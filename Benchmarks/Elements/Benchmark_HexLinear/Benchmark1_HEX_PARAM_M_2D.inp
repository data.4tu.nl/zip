*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\Benchmarks\Elements\Benchmark_HexLinear\Benchmark2_QUADSERENDIPITYHEX_PARAM_M_2D
*NODE
1, 0, 0, 0
2, 0.0014, 0, 0
3, 0.0014, 0.001524, 0
4, 0, 0.001524, 0
5, 0.000175, 0, 0
6, 0.00035, 0, 0
7, 0.000525, 0, 0
8, 0.0007, 0, 0
9, 0.000875, 0, 0
10, 0.00105, 0, 0
11, 0.001225, 0, 0
12, 0.0014, 0.0001905, 0
13, 0.0014, 0.000381, 0
14, 0.0014, 0.0005715, 0
15, 0.0014, 0.000762, 0
16, 0.0014, 0.0009525, 0
17, 0.0014, 0.001143, 0
18, 0.0014, 0.0013335, 0
19, 0.001225, 0.001524, 0
20, 0.00105, 0.001524, 0
21, 0.000875, 0.001524, 0
22, 0.0007, 0.001524, 0
23, 0.000525, 0.001524, 0
24, 0.00035, 0.001524, 0
25, 0.000175, 0.001524, 0
26, 0, 0.0013335, 0
27, 0, 0.001143, 0
28, 0, 0.0009525, 0
29, 0, 0.000762, 0
30, 0, 0.0005715, 0
31, 0, 0.000381, 0
32, 0, 0.0001905, 0
33, 0.000175, 0.0001905, 0
34, 0.000175, 0.000381, 0
35, 0.000175, 0.0005715, 0
36, 0.000175, 0.000762, 0
37, 0.000175, 0.0009525, 0
38, 0.000175, 0.001143, 0
39, 0.000175, 0.0013335, 0
40, 0.00035, 0.0001905, 0
41, 0.00035, 0.000381, 0
42, 0.00035, 0.0005715, 0
43, 0.00035, 0.000762, 0
44, 0.00035, 0.0009525, 0
45, 0.00035, 0.001143, 0
46, 0.00035, 0.0013335, 0
47, 0.000525, 0.0001905, 0
48, 0.000525, 0.000381, 0
49, 0.000525, 0.0005715, 0
50, 0.000525, 0.000762, 0
51, 0.000525, 0.0009525, 0
52, 0.000525, 0.001143, 0
53, 0.000525, 0.0013335, 0
54, 0.0007, 0.0001905, 0
55, 0.0007, 0.000381, 0
56, 0.0007, 0.0005715, 0
57, 0.0007, 0.000762, 0
58, 0.0007, 0.0009525, 0
59, 0.0007, 0.001143, 0
60, 0.0007, 0.0013335, 0
61, 0.000875, 0.0001905, 0
62, 0.000875, 0.000381, 0
63, 0.000875, 0.0005715, 0
64, 0.000875, 0.000762, 0
65, 0.000875, 0.0009525, 0
66, 0.000875, 0.001143, 0
67, 0.000875, 0.0013335, 0
68, 0.00105, 0.0001905, 0
69, 0.00105, 0.000381, 0
70, 0.00105, 0.0005715, 0
71, 0.00105, 0.000762, 0
72, 0.00105, 0.0009525, 0
73, 0.00105, 0.001143, 0
74, 0.00105, 0.0013335, 0
75, 0.001225, 0.0001905, 0
76, 0.001225, 0.000381, 0
77, 0.001225, 0.0005715, 0
78, 0.001225, 0.000762, 0
79, 0.001225, 0.0009525, 0
80, 0.001225, 0.001143, 0
81, 0.001225, 0.0013335, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
5, 1, 5
6, 5, 6
7, 6, 7
8, 7, 8
9, 8, 9
10, 9, 10
11, 10, 11
12, 11, 2
*ELEMENT, type=T3D2, ELSET=Line2
13, 2, 12
14, 12, 13
15, 13, 14
16, 14, 15
17, 15, 16
18, 16, 17
19, 17, 18
20, 18, 3
*ELEMENT, type=T3D2, ELSET=Line3
21, 3, 19
22, 19, 20
23, 20, 21
24, 21, 22
25, 22, 23
26, 23, 24
27, 24, 25
28, 25, 4
*ELEMENT, type=T3D2, ELSET=Line4
29, 4, 26
30, 26, 27
31, 27, 28
32, 28, 29
33, 29, 30
34, 30, 31
35, 31, 32
36, 32, 1
*ELEMENT, type=CPS4, ELSET=Surface1
37, 1, 5, 33, 32
38, 32, 33, 34, 31
39, 31, 34, 35, 30
40, 30, 35, 36, 29
41, 29, 36, 37, 28
42, 28, 37, 38, 27
43, 27, 38, 39, 26
44, 26, 39, 25, 4
45, 5, 6, 40, 33
46, 33, 40, 41, 34
47, 34, 41, 42, 35
48, 35, 42, 43, 36
49, 36, 43, 44, 37
50, 37, 44, 45, 38
51, 38, 45, 46, 39
52, 39, 46, 24, 25
53, 6, 7, 47, 40
54, 40, 47, 48, 41
55, 41, 48, 49, 42
56, 42, 49, 50, 43
57, 43, 50, 51, 44
58, 44, 51, 52, 45
59, 45, 52, 53, 46
60, 46, 53, 23, 24
61, 7, 8, 54, 47
62, 47, 54, 55, 48
63, 48, 55, 56, 49
64, 49, 56, 57, 50
65, 50, 57, 58, 51
66, 51, 58, 59, 52
67, 52, 59, 60, 53
68, 53, 60, 22, 23
69, 8, 9, 61, 54
70, 54, 61, 62, 55
71, 55, 62, 63, 56
72, 56, 63, 64, 57
73, 57, 64, 65, 58
74, 58, 65, 66, 59
75, 59, 66, 67, 60
76, 60, 67, 21, 22
77, 9, 10, 68, 61
78, 61, 68, 69, 62
79, 62, 69, 70, 63
80, 63, 70, 71, 64
81, 64, 71, 72, 65
82, 65, 72, 73, 66
83, 66, 73, 74, 67
84, 67, 74, 20, 21
85, 10, 11, 75, 68
86, 68, 75, 76, 69
87, 69, 76, 77, 70
88, 70, 77, 78, 71
89, 71, 78, 79, 72
90, 72, 79, 80, 73
91, 73, 80, 81, 74
92, 74, 81, 19, 20
93, 11, 2, 12, 75
94, 75, 12, 13, 76
95, 76, 13, 14, 77
96, 77, 14, 15, 78
97, 78, 15, 16, 79
98, 79, 16, 17, 80
99, 80, 17, 18, 81
100, 81, 18, 3, 19
*ELSET,ELSET=Ymin
5, 6, 7, 8, 9, 10, 11, 12, 
*ELSET,ELSET=Ymax
21, 22, 23, 24, 25, 26, 27, 28, 
*ELSET,ELSET=Xmin
29, 30, 31, 32, 33, 34, 35, 36, 
*ELSET,ELSET=Xmax
13, 14, 15, 16, 17, 18, 19, 20, 
*ELSET,ELSET=Surface
37, 38, 39, 40, 41, 42, 43, 44, 45, 46, 
47, 48, 49, 50, 51, 52, 53, 54, 55, 56, 
57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 
67, 68, 69, 70, 71, 72, 73, 74, 75, 76, 
77, 78, 79, 80, 81, 82, 83, 84, 85, 86, 
87, 88, 89, 90, 91, 92, 93, 94, 95, 96, 
97, 98, 99, 100, 
*NSET,NSET=Ymin
1, 2, 5, 6, 7, 8, 9, 10, 11, 
*NSET,NSET=Ymax
3, 4, 19, 20, 21, 22, 23, 24, 25, 
*NSET,NSET=Xmin
1, 4, 26, 27, 28, 29, 30, 31, 32, 
*NSET,NSET=Xmax
2, 3, 12, 13, 14, 15, 16, 17, 18, 
*NSET,NSET=Surface
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 
