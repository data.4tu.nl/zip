*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\Benchmarks\Elements\Benchmark_HexLinear\Benchmark1_LINEARHEX_PARAM.inp
*NODE
1, 0, 0, 0
2, 0.0014, 0, 0
3, 0.0014, 0.001524, 0
4, 0, 0.001524, 0
5, 0, 0, 0.0014
6, 0.0014, 0, 0.0014
7, 0.0014, 0.001524, 0.0014
8, 0, 0.001524, 0.0014
9, 0.00027999999999937, 0, 0
10, 0.0005599999999985, 0, 0
11, 0.00083999999999848, 0, 0
12, 0.0011199999999991, 0, 0
13, 0.0014, 0.00030479999999933, 0
14, 0.0014, 0.00060959999999842, 0
15, 0.0014, 0.00091439999999838, 0
16, 0.0014, 0.0012191999999992, 0
17, 0.0011200000000007, 0.001524, 0
18, 0.00084000000000158, 0.001524, 0
19, 0.00056000000000157, 0.001524, 0
20, 0.00028000000000088, 0.001524, 0
21, 0, 0.0012192000000008, 0
22, 0, 0.00091440000000162, 0
23, 0, 0.00060960000000165, 0
24, 0, 0.00030480000000085, 0
25, 0.00027999999999937, 0, 0.0014
26, 0.0005599999999985, 0, 0.0014
27, 0.00083999999999848, 0, 0.0014
28, 0.0011199999999991, 0, 0.0014
29, 0.0014, 0.00030479999999933, 0.0014
30, 0.0014, 0.00060959999999842, 0.0014
31, 0.0014, 0.00091439999999838, 0.0014
32, 0.0014, 0.0012191999999992, 0.0014
33, 0.0011200000000007, 0.001524, 0.0014
34, 0.00084000000000158, 0.001524, 0.0014
35, 0.00056000000000157, 0.001524, 0.0014
36, 0.00028000000000088, 0.001524, 0.0014
37, 0, 0.0012192000000008, 0.0014
38, 0, 0.00091440000000162, 0.0014
39, 0, 0.00060960000000165, 0.0014
40, 0, 0.00030480000000085, 0.0014
41, 0, 0, 0.00027999999999937
42, 0, 0, 0.0005599999999985
43, 0, 0, 0.00083999999999848
44, 0, 0, 0.0011199999999991
45, 0.0014, 0, 0.00027999999999937
46, 0.0014, 0, 0.0005599999999985
47, 0.0014, 0, 0.00083999999999848
48, 0.0014, 0, 0.0011199999999991
49, 0.0014, 0.001524, 0.00027999999999937
50, 0.0014, 0.001524, 0.0005599999999985
51, 0.0014, 0.001524, 0.00083999999999848
52, 0.0014, 0.001524, 0.0011199999999991
53, 0, 0.001524, 0.00027999999999937
54, 0, 0.001524, 0.0005599999999985
55, 0, 0.001524, 0.00083999999999848
56, 0, 0.001524, 0.0011199999999991
57, 0.00027999999999937, 0, 0.0011199999999991
58, 0.00027999999999937, 0, 0.00083999999999848
59, 0.00027999999999937, 0, 0.0005599999999985
60, 0.00027999999999937, 0, 0.00027999999999937
61, 0.0005599999999985, 0, 0.0011199999999991
62, 0.0005599999999985, 0, 0.00083999999999848
63, 0.0005599999999985, 0, 0.0005599999999985
64, 0.0005599999999985, 0, 0.00027999999999937
65, 0.00083999999999848, 0, 0.0011199999999991
66, 0.00083999999999848, 0, 0.00083999999999848
67, 0.00083999999999848, 0, 0.0005599999999985
68, 0.00083999999999848, 0, 0.00027999999999937
69, 0.0011199999999991, 0, 0.0011199999999991
70, 0.0011199999999991, 0, 0.00083999999999848
71, 0.0011199999999991, 0, 0.0005599999999985
72, 0.0011199999999991, 0, 0.00027999999999937
73, 0.00027999999999967, 0.00030480000000054, 0.0014
74, 0.00027999999999998, 0.000609600000001, 0.0014
75, 0.00028000000000028, 0.00091440000000098, 0.0014
76, 0.00028000000000058, 0.0012192000000004, 0.0014
77, 0.00055999999999912, 0.00030480000000024, 0.0014
78, 0.00055999999999973, 0.00060960000000036, 0.0014
79, 0.00056000000000035, 0.00091440000000033, 0.0014
80, 0.00056000000000096, 0.0012192000000001, 0.0014
81, 0.0008399999999991, 0.00030479999999994, 0.0014
82, 0.00083999999999972, 0.00060959999999971, 0.0014
83, 0.00084000000000034, 0.00091439999999968, 0.0014
84, 0.00084000000000096, 0.0012191999999998, 0.0014
85, 0.0011199999999995, 0.00030479999999964, 0.0014
86, 0.0011199999999998, 0.00060959999999907, 0.0014
87, 0.0011200000000001, 0.00091439999999903, 0.0014
88, 0.0011200000000004, 0.0012191999999995, 0.0014
89, 0, 0.0012192000000008, 0.0011199999999991
90, 0, 0.0012192000000008, 0.00083999999999848
91, 0, 0.0012192000000008, 0.0005599999999985
92, 0, 0.0012192000000008, 0.00027999999999937
93, 0, 0.00091440000000162, 0.0011199999999991
94, 0, 0.00091440000000162, 0.00083999999999848
95, 0, 0.00091440000000162, 0.0005599999999985
96, 0, 0.00091440000000162, 0.00027999999999937
97, 0, 0.00060960000000165, 0.0011199999999991
98, 0, 0.00060960000000165, 0.00083999999999848
99, 0, 0.00060960000000165, 0.0005599999999985
100, 0, 0.00060960000000165, 0.00027999999999937
101, 0, 0.00030480000000085, 0.0011199999999991
102, 0, 0.00030480000000085, 0.00083999999999848
103, 0, 0.00030480000000085, 0.0005599999999985
104, 0, 0.00030480000000085, 0.00027999999999937
105, 0.00027999999999967, 0.00030480000000054, 0
106, 0.00027999999999998, 0.000609600000001, 0
107, 0.00028000000000028, 0.00091440000000098, 0
108, 0.00028000000000058, 0.0012192000000004, 0
109, 0.00055999999999912, 0.00030480000000024, 0
110, 0.00055999999999973, 0.00060960000000036, 0
111, 0.00056000000000035, 0.00091440000000033, 0
112, 0.00056000000000096, 0.0012192000000001, 0
113, 0.0008399999999991, 0.00030479999999994, 0
114, 0.00083999999999972, 0.00060959999999971, 0
115, 0.00084000000000034, 0.00091439999999968, 0
116, 0.00084000000000096, 0.0012191999999998, 0
117, 0.0011199999999995, 0.00030479999999964, 0
118, 0.0011199999999998, 0.00060959999999907, 0
119, 0.0011200000000001, 0.00091439999999903, 0
120, 0.0011200000000004, 0.0012191999999995, 0
121, 0.00028000000000088, 0.001524, 0.00027999999999937
122, 0.00056000000000157, 0.001524, 0.00027999999999937
123, 0.00084000000000158, 0.001524, 0.00027999999999937
124, 0.0011200000000007, 0.001524, 0.00027999999999937
125, 0.00028000000000088, 0.001524, 0.0005599999999985
126, 0.00056000000000157, 0.001524, 0.0005599999999985
127, 0.00084000000000158, 0.001524, 0.0005599999999985
128, 0.0011200000000007, 0.001524, 0.0005599999999985
129, 0.00028000000000088, 0.001524, 0.00083999999999848
130, 0.00056000000000157, 0.001524, 0.00083999999999848
131, 0.00084000000000158, 0.001524, 0.00083999999999848
132, 0.0011200000000007, 0.001524, 0.00083999999999848
133, 0.00028000000000088, 0.001524, 0.0011199999999991
134, 0.00056000000000157, 0.001524, 0.0011199999999991
135, 0.00084000000000158, 0.001524, 0.0011199999999991
136, 0.0011200000000007, 0.001524, 0.0011199999999991
137, 0.0014, 0.00030479999999933, 0.0011199999999991
138, 0.0014, 0.00030479999999933, 0.00083999999999848
139, 0.0014, 0.00030479999999933, 0.0005599999999985
140, 0.0014, 0.00030479999999933, 0.00027999999999937
141, 0.0014, 0.00060959999999842, 0.0011199999999991
142, 0.0014, 0.00060959999999842, 0.00083999999999848
143, 0.0014, 0.00060959999999842, 0.0005599999999985
144, 0.0014, 0.00060959999999842, 0.00027999999999937
145, 0.0014, 0.00091439999999838, 0.0011199999999991
146, 0.0014, 0.00091439999999838, 0.00083999999999848
147, 0.0014, 0.00091439999999838, 0.0005599999999985
148, 0.0014, 0.00091439999999838, 0.00027999999999937
149, 0.0014, 0.0012191999999992, 0.0011199999999991
150, 0.0014, 0.0012191999999992, 0.00083999999999848
151, 0.0014, 0.0012191999999992, 0.0005599999999985
152, 0.0014, 0.0012191999999992, 0.00027999999999937
153, 0.00027999999999967, 0.00030480000000054, 0.0011199999999991
154, 0.00027999999999967, 0.00030480000000054, 0.00083999999999848
155, 0.00027999999999967, 0.00030480000000054, 0.0005599999999985
156, 0.00027999999999967, 0.00030480000000054, 0.00027999999999937
157, 0.00027999999999998, 0.000609600000001, 0.0011199999999991
158, 0.00027999999999998, 0.000609600000001, 0.00083999999999848
159, 0.00027999999999998, 0.000609600000001, 0.0005599999999985
160, 0.00027999999999998, 0.000609600000001, 0.00027999999999937
161, 0.00028000000000028, 0.00091440000000097, 0.0011199999999991
162, 0.00028000000000028, 0.00091440000000097, 0.00083999999999848
163, 0.00028000000000028, 0.00091440000000097, 0.0005599999999985
164, 0.00028000000000028, 0.00091440000000097, 0.00027999999999937
165, 0.00028000000000058, 0.0012192000000004, 0.0011199999999991
166, 0.00028000000000058, 0.0012192000000004, 0.00083999999999848
167, 0.00028000000000058, 0.0012192000000004, 0.0005599999999985
168, 0.00028000000000058, 0.0012192000000004, 0.00027999999999937
169, 0.00055999999999912, 0.00030480000000024, 0.0011199999999991
170, 0.00055999999999912, 0.00030480000000024, 0.00083999999999848
171, 0.00055999999999912, 0.00030480000000024, 0.0005599999999985
172, 0.00055999999999912, 0.00030480000000024, 0.00027999999999937
173, 0.00055999999999973, 0.00060960000000036, 0.0011199999999991
174, 0.00055999999999973, 0.00060960000000036, 0.00083999999999848
175, 0.00055999999999973, 0.00060960000000036, 0.0005599999999985
176, 0.00055999999999973, 0.00060960000000036, 0.00027999999999937
177, 0.00056000000000034, 0.00091440000000033, 0.0011199999999991
178, 0.00056000000000035, 0.00091440000000033, 0.00083999999999848
179, 0.00056000000000034, 0.00091440000000033, 0.0005599999999985
180, 0.00056000000000035, 0.00091440000000033, 0.00027999999999937
181, 0.00056000000000096, 0.0012192000000001, 0.0011199999999991
182, 0.00056000000000096, 0.0012192000000001, 0.00083999999999848
183, 0.00056000000000096, 0.0012192000000001, 0.0005599999999985
184, 0.00056000000000096, 0.0012192000000001, 0.00027999999999937
185, 0.0008399999999991, 0.00030479999999994, 0.0011199999999991
186, 0.0008399999999991, 0.00030479999999994, 0.00083999999999848
187, 0.0008399999999991, 0.00030479999999994, 0.0005599999999985
188, 0.0008399999999991, 0.00030479999999994, 0.00027999999999937
189, 0.00083999999999972, 0.00060959999999971, 0.0011199999999991
190, 0.00083999999999972, 0.00060959999999971, 0.00083999999999848
191, 0.00083999999999972, 0.00060959999999971, 0.0005599999999985
192, 0.00083999999999972, 0.00060959999999971, 0.00027999999999937
193, 0.00084000000000034, 0.00091439999999968, 0.0011199999999991
194, 0.00084000000000034, 0.00091439999999968, 0.00083999999999848
195, 0.00084000000000034, 0.00091439999999968, 0.0005599999999985
196, 0.00084000000000034, 0.00091439999999968, 0.00027999999999937
197, 0.00084000000000096, 0.0012191999999998, 0.0011199999999991
198, 0.00084000000000096, 0.0012191999999998, 0.00083999999999848
199, 0.00084000000000096, 0.0012191999999998, 0.0005599999999985
200, 0.00084000000000096, 0.0012191999999998, 0.00027999999999937
201, 0.0011199999999995, 0.00030479999999964, 0.0011199999999991
202, 0.0011199999999995, 0.00030479999999964, 0.00083999999999848
203, 0.0011199999999995, 0.00030479999999964, 0.0005599999999985
204, 0.0011199999999995, 0.00030479999999964, 0.00027999999999937
205, 0.0011199999999998, 0.00060959999999907, 0.0011199999999991
206, 0.0011199999999998, 0.00060959999999907, 0.00083999999999848
207, 0.0011199999999998, 0.00060959999999907, 0.0005599999999985
208, 0.0011199999999998, 0.00060959999999907, 0.00027999999999937
209, 0.0011200000000001, 0.00091439999999903, 0.0011199999999991
210, 0.0011200000000001, 0.00091439999999903, 0.00083999999999848
211, 0.0011200000000001, 0.00091439999999903, 0.0005599999999985
212, 0.0011200000000001, 0.00091439999999903, 0.00027999999999937
213, 0.0011200000000004, 0.0012191999999995, 0.0011199999999991
214, 0.0011200000000004, 0.0012191999999995, 0.00083999999999848
215, 0.0011200000000004, 0.0012191999999995, 0.0005599999999985
216, 0.0011200000000004, 0.0012191999999995, 0.00027999999999937
******* E L E M E N T S *************
*ELEMENT, type=T3D2, ELSET=Line1
9, 1, 9
10, 9, 10
11, 10, 11
12, 11, 12
13, 12, 2
*ELEMENT, type=T3D2, ELSET=Line2
14, 2, 13
15, 13, 14
16, 14, 15
17, 15, 16
18, 16, 3
*ELEMENT, type=T3D2, ELSET=Line3
19, 3, 17
20, 17, 18
21, 18, 19
22, 19, 20
23, 20, 4
*ELEMENT, type=T3D2, ELSET=Line4
24, 4, 21
25, 21, 22
26, 22, 23
27, 23, 24
28, 24, 1
*ELEMENT, type=T3D2, ELSET=Line5
29, 5, 25
30, 25, 26
31, 26, 27
32, 27, 28
33, 28, 6
*ELEMENT, type=T3D2, ELSET=Line6
34, 6, 29
35, 29, 30
36, 30, 31
37, 31, 32
38, 32, 7
*ELEMENT, type=T3D2, ELSET=Line7
39, 7, 33
40, 33, 34
41, 34, 35
42, 35, 36
43, 36, 8
*ELEMENT, type=T3D2, ELSET=Line8
44, 8, 37
45, 37, 38
46, 38, 39
47, 39, 40
48, 40, 5
*ELEMENT, type=T3D2, ELSET=Line9
49, 1, 41
50, 41, 42
51, 42, 43
52, 43, 44
53, 44, 5
*ELEMENT, type=T3D2, ELSET=Line10
54, 2, 45
55, 45, 46
56, 46, 47
57, 47, 48
58, 48, 6
*ELEMENT, type=T3D2, ELSET=Line11
59, 3, 49
60, 49, 50
61, 50, 51
62, 51, 52
63, 52, 7
*ELEMENT, type=T3D2, ELSET=Line12
64, 4, 53
65, 53, 54
66, 54, 55
67, 55, 56
68, 56, 8
*ELEMENT, type=CPS4, ELSET=Surface1
69, 5, 25, 57, 44
70, 44, 57, 58, 43
71, 43, 58, 59, 42
72, 42, 59, 60, 41
73, 41, 60, 9, 1
74, 25, 26, 61, 57
75, 57, 61, 62, 58
76, 58, 62, 63, 59
77, 59, 63, 64, 60
78, 60, 64, 10, 9
79, 26, 27, 65, 61
80, 61, 65, 66, 62
81, 62, 66, 67, 63
82, 63, 67, 68, 64
83, 64, 68, 11, 10
84, 27, 28, 69, 65
85, 65, 69, 70, 66
86, 66, 70, 71, 67
87, 67, 71, 72, 68
88, 68, 72, 12, 11
89, 28, 6, 48, 69
90, 69, 48, 47, 70
91, 70, 47, 46, 71
92, 71, 46, 45, 72
93, 72, 45, 2, 12
*ELEMENT, type=CPS4, ELSET=Surface2
94, 5, 25, 73, 40
95, 40, 73, 74, 39
96, 39, 74, 75, 38
97, 38, 75, 76, 37
98, 37, 76, 36, 8
99, 25, 26, 77, 73
100, 73, 77, 78, 74
101, 74, 78, 79, 75
102, 75, 79, 80, 76
103, 76, 80, 35, 36
104, 26, 27, 81, 77
105, 77, 81, 82, 78
106, 78, 82, 83, 79
107, 79, 83, 84, 80
108, 80, 84, 34, 35
109, 27, 28, 85, 81
110, 81, 85, 86, 82
111, 82, 86, 87, 83
112, 83, 87, 88, 84
113, 84, 88, 33, 34
114, 28, 6, 29, 85
115, 85, 29, 30, 86
116, 86, 30, 31, 87
117, 87, 31, 32, 88
118, 88, 32, 7, 33
*ELEMENT, type=CPS4, ELSET=Surface3
119, 8, 37, 89, 56
120, 56, 89, 90, 55
121, 55, 90, 91, 54
122, 54, 91, 92, 53
123, 53, 92, 21, 4
124, 37, 38, 93, 89
125, 89, 93, 94, 90
126, 90, 94, 95, 91
127, 91, 95, 96, 92
128, 92, 96, 22, 21
129, 38, 39, 97, 93
130, 93, 97, 98, 94
131, 94, 98, 99, 95
132, 95, 99, 100, 96
133, 96, 100, 23, 22
134, 39, 40, 101, 97
135, 97, 101, 102, 98
136, 98, 102, 103, 99
137, 99, 103, 104, 100
138, 100, 104, 24, 23
139, 40, 5, 44, 101
140, 101, 44, 43, 102
141, 102, 43, 42, 103
142, 103, 42, 41, 104
143, 104, 41, 1, 24
*ELEMENT, type=CPS4, ELSET=Surface4
144, 1, 9, 105, 24
145, 24, 105, 106, 23
146, 23, 106, 107, 22
147, 22, 107, 108, 21
148, 21, 108, 20, 4
149, 9, 10, 109, 105
150, 105, 109, 110, 106
151, 106, 110, 111, 107
152, 107, 111, 112, 108
153, 108, 112, 19, 20
154, 10, 11, 113, 109
155, 109, 113, 114, 110
156, 110, 114, 115, 111
157, 111, 115, 116, 112
158, 112, 116, 18, 19
159, 11, 12, 117, 113
160, 113, 117, 118, 114
161, 114, 118, 119, 115
162, 115, 119, 120, 116
163, 116, 120, 17, 18
164, 12, 2, 13, 117
165, 117, 13, 14, 118
166, 118, 14, 15, 119
167, 119, 15, 16, 120
168, 120, 16, 3, 17
*ELEMENT, type=CPS4, ELSET=Surface5
169, 4, 53, 121, 20
170, 20, 121, 122, 19
171, 19, 122, 123, 18
172, 18, 123, 124, 17
173, 17, 124, 49, 3
174, 53, 54, 125, 121
175, 121, 125, 126, 122
176, 122, 126, 127, 123
177, 123, 127, 128, 124
178, 124, 128, 50, 49
179, 54, 55, 129, 125
180, 125, 129, 130, 126
181, 126, 130, 131, 127
182, 127, 131, 132, 128
183, 128, 132, 51, 50
184, 55, 56, 133, 129
185, 129, 133, 134, 130
186, 130, 134, 135, 131
187, 131, 135, 136, 132
188, 132, 136, 52, 51
189, 56, 8, 36, 133
190, 133, 36, 35, 134
191, 134, 35, 34, 135
192, 135, 34, 33, 136
193, 136, 33, 7, 52
*ELEMENT, type=CPS4, ELSET=Surface6
194, 6, 29, 137, 48
195, 48, 137, 138, 47
196, 47, 138, 139, 46
197, 46, 139, 140, 45
198, 45, 140, 13, 2
199, 29, 30, 141, 137
200, 137, 141, 142, 138
201, 138, 142, 143, 139
202, 139, 143, 144, 140
203, 140, 144, 14, 13
204, 30, 31, 145, 141
205, 141, 145, 146, 142
206, 142, 146, 147, 143
207, 143, 147, 148, 144
208, 144, 148, 15, 14
209, 31, 32, 149, 145
210, 145, 149, 150, 146
211, 146, 150, 151, 147
212, 147, 151, 152, 148
213, 148, 152, 16, 15
214, 32, 7, 52, 149
215, 149, 52, 51, 150
216, 150, 51, 50, 151
217, 151, 50, 49, 152
218, 152, 49, 3, 16
*ELEMENT, type=C3D8, ELSET=Volume1
219, 73, 25, 5, 40, 153, 57, 44, 101
220, 153, 57, 44, 101, 154, 58, 43, 102
221, 154, 58, 43, 102, 155, 59, 42, 103
222, 155, 59, 42, 103, 156, 60, 41, 104
223, 156, 60, 41, 104, 105, 9, 1, 24
224, 74, 73, 40, 39, 157, 153, 101, 97
225, 157, 153, 101, 97, 158, 154, 102, 98
226, 158, 154, 102, 98, 159, 155, 103, 99
227, 159, 155, 103, 99, 160, 156, 104, 100
228, 160, 156, 104, 100, 106, 105, 24, 23
229, 75, 74, 39, 38, 161, 157, 97, 93
230, 161, 157, 97, 93, 162, 158, 98, 94
231, 162, 158, 98, 94, 163, 159, 99, 95
232, 163, 159, 99, 95, 164, 160, 100, 96
233, 164, 160, 100, 96, 107, 106, 23, 22
234, 76, 75, 38, 37, 165, 161, 93, 89
235, 165, 161, 93, 89, 166, 162, 94, 90
236, 166, 162, 94, 90, 167, 163, 95, 91
237, 167, 163, 95, 91, 168, 164, 96, 92
238, 168, 164, 96, 92, 108, 107, 22, 21
239, 36, 76, 37, 8, 133, 165, 89, 56
240, 133, 165, 89, 56, 129, 166, 90, 55
241, 129, 166, 90, 55, 125, 167, 91, 54
242, 125, 167, 91, 54, 121, 168, 92, 53
243, 121, 168, 92, 53, 20, 108, 21, 4
244, 77, 26, 25, 73, 169, 61, 57, 153
245, 169, 61, 57, 153, 170, 62, 58, 154
246, 170, 62, 58, 154, 171, 63, 59, 155
247, 171, 63, 59, 155, 172, 64, 60, 156
248, 172, 64, 60, 156, 109, 10, 9, 105
249, 78, 77, 73, 74, 173, 169, 153, 157
250, 173, 169, 153, 157, 174, 170, 154, 158
251, 174, 170, 154, 158, 175, 171, 155, 159
252, 175, 171, 155, 159, 176, 172, 156, 160
253, 176, 172, 156, 160, 110, 109, 105, 106
254, 79, 78, 74, 75, 177, 173, 157, 161
255, 177, 173, 157, 161, 178, 174, 158, 162
256, 178, 174, 158, 162, 179, 175, 159, 163
257, 179, 175, 159, 163, 180, 176, 160, 164
258, 180, 176, 160, 164, 111, 110, 106, 107
259, 80, 79, 75, 76, 181, 177, 161, 165
260, 181, 177, 161, 165, 182, 178, 162, 166
261, 182, 178, 162, 166, 183, 179, 163, 167
262, 183, 179, 163, 167, 184, 180, 164, 168
263, 184, 180, 164, 168, 112, 111, 107, 108
264, 35, 80, 76, 36, 134, 181, 165, 133
265, 134, 181, 165, 133, 130, 182, 166, 129
266, 130, 182, 166, 129, 126, 183, 167, 125
267, 126, 183, 167, 125, 122, 184, 168, 121
268, 122, 184, 168, 121, 19, 112, 108, 20
269, 81, 27, 26, 77, 185, 65, 61, 169
270, 185, 65, 61, 169, 186, 66, 62, 170
271, 186, 66, 62, 170, 187, 67, 63, 171
272, 187, 67, 63, 171, 188, 68, 64, 172
273, 188, 68, 64, 172, 113, 11, 10, 109
274, 82, 81, 77, 78, 189, 185, 169, 173
275, 189, 185, 169, 173, 190, 186, 170, 174
276, 190, 186, 170, 174, 191, 187, 171, 175
277, 191, 187, 171, 175, 192, 188, 172, 176
278, 192, 188, 172, 176, 114, 113, 109, 110
279, 83, 82, 78, 79, 193, 189, 173, 177
280, 193, 189, 173, 177, 194, 190, 174, 178
281, 194, 190, 174, 178, 195, 191, 175, 179
282, 195, 191, 175, 179, 196, 192, 176, 180
283, 196, 192, 176, 180, 115, 114, 110, 111
284, 84, 83, 79, 80, 197, 193, 177, 181
285, 197, 193, 177, 181, 198, 194, 178, 182
286, 198, 194, 178, 182, 199, 195, 179, 183
287, 199, 195, 179, 183, 200, 196, 180, 184
288, 200, 196, 180, 184, 116, 115, 111, 112
289, 34, 84, 80, 35, 135, 197, 181, 134
290, 135, 197, 181, 134, 131, 198, 182, 130
291, 131, 198, 182, 130, 127, 199, 183, 126
292, 127, 199, 183, 126, 123, 200, 184, 122
293, 123, 200, 184, 122, 18, 116, 112, 19
294, 85, 28, 27, 81, 201, 69, 65, 185
295, 201, 69, 65, 185, 202, 70, 66, 186
296, 202, 70, 66, 186, 203, 71, 67, 187
297, 203, 71, 67, 187, 204, 72, 68, 188
298, 204, 72, 68, 188, 117, 12, 11, 113
299, 86, 85, 81, 82, 205, 201, 185, 189
300, 205, 201, 185, 189, 206, 202, 186, 190
301, 206, 202, 186, 190, 207, 203, 187, 191
302, 207, 203, 187, 191, 208, 204, 188, 192
303, 208, 204, 188, 192, 118, 117, 113, 114
304, 87, 86, 82, 83, 209, 205, 189, 193
305, 209, 205, 189, 193, 210, 206, 190, 194
306, 210, 206, 190, 194, 211, 207, 191, 195
307, 211, 207, 191, 195, 212, 208, 192, 196
308, 212, 208, 192, 196, 119, 118, 114, 115
309, 88, 87, 83, 84, 213, 209, 193, 197
310, 213, 209, 193, 197, 214, 210, 194, 198
311, 214, 210, 194, 198, 215, 211, 195, 199
312, 215, 211, 195, 199, 216, 212, 196, 200
313, 216, 212, 196, 200, 120, 119, 115, 116
314, 33, 88, 84, 34, 136, 213, 197, 135
315, 136, 213, 197, 135, 132, 214, 198, 131
316, 132, 214, 198, 131, 128, 215, 199, 127
317, 128, 215, 199, 127, 124, 216, 200, 123
318, 124, 216, 200, 123, 17, 120, 116, 18
319, 29, 6, 28, 85, 137, 48, 69, 201
320, 137, 48, 69, 201, 138, 47, 70, 202
321, 138, 47, 70, 202, 139, 46, 71, 203
322, 139, 46, 71, 203, 140, 45, 72, 204
323, 140, 45, 72, 204, 13, 2, 12, 117
324, 30, 29, 85, 86, 141, 137, 201, 205
325, 141, 137, 201, 205, 142, 138, 202, 206
326, 142, 138, 202, 206, 143, 139, 203, 207
327, 143, 139, 203, 207, 144, 140, 204, 208
328, 144, 140, 204, 208, 14, 13, 117, 118
329, 31, 30, 86, 87, 145, 141, 205, 209
330, 145, 141, 205, 209, 146, 142, 206, 210
331, 146, 142, 206, 210, 147, 143, 207, 211
332, 147, 143, 207, 211, 148, 144, 208, 212
333, 148, 144, 208, 212, 15, 14, 118, 119
334, 32, 31, 87, 88, 149, 145, 209, 213
335, 149, 145, 209, 213, 150, 146, 210, 214
336, 150, 146, 210, 214, 151, 147, 211, 215
337, 151, 147, 211, 215, 152, 148, 212, 216
338, 152, 148, 212, 216, 16, 15, 119, 120
339, 7, 32, 88, 33, 52, 149, 213, 136
340, 52, 149, 213, 136, 51, 150, 214, 132
341, 51, 150, 214, 132, 50, 151, 215, 128
342, 50, 151, 215, 128, 49, 152, 216, 124
343, 49, 152, 216, 124, 3, 16, 120, 17
*ELSET,ELSET=Ymin_line
49, 50, 51, 52, 53, 
*ELSET,ELSET=Zmax_line
44, 45, 46, 47, 48, 
*ELSET,ELSET=Zmin_line
24, 25, 26, 27, 28, 
*ELSET,ELSET=Ymax_line
64, 65, 66, 67, 68, 
*ELSET,ELSET=Ymax
169, 170, 171, 172, 173, 174, 175, 176, 177, 178, 
179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 
189, 190, 191, 192, 193, 
*ELSET,ELSET=Ymin
69, 70, 71, 72, 73, 74, 75, 76, 77, 78, 
79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 90, 91, 92, 93, 
*ELSET,ELSET=Zmax
94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 
104, 105, 106, 107, 108, 109, 110, 111, 112, 113, 
114, 115, 116, 117, 118, 
*ELSET,ELSET=Zmin
144, 145, 146, 147, 148, 149, 150, 151, 152, 153, 
154, 155, 156, 157, 158, 159, 160, 161, 162, 163, 
164, 165, 166, 167, 168, 
*ELSET,ELSET=Xmin
119, 120, 121, 122, 123, 124, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 
139, 140, 141, 142, 143, 
*ELSET,ELSET=Xmax
194, 195, 196, 197, 198, 199, 200, 201, 202, 203, 
204, 205, 206, 207, 208, 209, 210, 211, 212, 213, 
214, 215, 216, 217, 218, 
*ELSET,ELSET=Surface
119, 120, 121, 122, 123, 124, 125, 126, 127, 128, 
129, 130, 131, 132, 133, 134, 135, 136, 137, 138, 
139, 140, 141, 142, 143, 
*ELSET,ELSET=Volume
219, 220, 221, 222, 223, 224, 225, 226, 227, 228, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 
259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
279, 280, 281, 282, 283, 284, 285, 286, 287, 288, 
289, 290, 291, 292, 293, 294, 295, 296, 297, 298, 
299, 300, 301, 302, 303, 304, 305, 306, 307, 308, 
309, 310, 311, 312, 313, 314, 315, 316, 317, 318, 
319, 320, 321, 322, 323, 324, 325, 326, 327, 328, 
329, 330, 331, 332, 333, 334, 335, 336, 337, 338, 
339, 340, 341, 342, 343, 
*NSET,NSET=Ymin_line
1, 5, 41, 42, 43, 44, 
*NSET,NSET=Zmax_line
5, 8, 37, 38, 39, 40, 
*NSET,NSET=Zmin_line
1, 4, 21, 22, 23, 24, 
*NSET,NSET=Ymax_line
4, 8, 53, 54, 55, 56, 
*NSET,NSET=Ymax
3, 4, 7, 8, 17, 18, 19, 20, 33, 34, 
35, 36, 49, 50, 51, 52, 53, 54, 55, 56, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 
*NSET,NSET=Ymin
1, 2, 5, 6, 9, 10, 11, 12, 25, 26, 
27, 28, 41, 42, 43, 44, 45, 46, 47, 48, 
57, 58, 59, 60, 61, 62, 63, 64, 65, 66, 
67, 68, 69, 70, 71, 72, 
*NSET,NSET=Zmax
5, 6, 7, 8, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
73, 74, 75, 76, 77, 78, 79, 80, 81, 82, 
83, 84, 85, 86, 87, 88, 
*NSET,NSET=Zmin
1, 2, 3, 4, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 
105, 106, 107, 108, 109, 110, 111, 112, 113, 114, 
115, 116, 117, 118, 119, 120, 
*NSET,NSET=Xmin
1, 4, 5, 8, 21, 22, 23, 24, 37, 38, 
39, 40, 41, 42, 43, 44, 53, 54, 55, 56, 
89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 
99, 100, 101, 102, 103, 104, 
*NSET,NSET=Xmax
2, 3, 6, 7, 13, 14, 15, 16, 29, 30, 
31, 32, 45, 46, 47, 48, 49, 50, 51, 52, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 
*NSET,NSET=Surface
1, 4, 5, 8, 21, 22, 23, 24, 37, 38, 
39, 40, 41, 42, 43, 44, 53, 54, 55, 56, 
89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 
99, 100, 101, 102, 103, 104, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 
