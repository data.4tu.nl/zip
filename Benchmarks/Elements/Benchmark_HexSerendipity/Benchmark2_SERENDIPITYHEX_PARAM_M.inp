*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\Benchmarks\Elements\Benchmark_HexSerendipity\Benchmark2_SERENDIPITYHEX_PARAM_M.inp
*NODE
1, 0, 0, 0
2, 0.0014, 0, 0
3, 0.0014, 0.001524, 0
4, 0, 0.001524, 0
5, 0, 0, 0.0014
6, 0.0014, 0, 0.0014
7, 0.0014, 0.001524, 0.0014
8, 0, 0.001524, 0.0014
9, 0.00027999999999937, 0, 0
10, 0.0005599999999985, 0, 0
11, 0.00083999999999848, 0, 0
12, 0.0011199999999991, 0, 0
13, 0.00013999999999975, 0, 0
14, 0.00041999999999895, 0, 0
15, 0.00069999999999819, 0, 0
16, 0.00097999999999893, 0, 0
17, 0.0012599999999994, 0, 0
18, 0.0014, 0.00030479999999933, 0
19, 0.0014, 0.00060959999999842, 0
20, 0.0014, 0.00091439999999838, 0
21, 0.0014, 0.0012191999999992, 0
22, 0.0014, 0.00015239999999977, 0
23, 0.0014, 0.00045719999999885, 0
24, 0.0014, 0.00076199999999799, 0
25, 0.0014, 0.0010667999999988, 0
26, 0.0014, 0.0013715999999996, 0
27, 0.0011200000000007, 0.001524, 0
28, 0.00084000000000158, 0.001524, 0
29, 0.00056000000000157, 0.001524, 0
30, 0.00028000000000088, 0.001524, 0
31, 0.0012600000000002, 0.001524, 0
32, 0.00098000000000121, 0.001524, 0
33, 0.00070000000000192, 0.001524, 0
34, 0.00042000000000123, 0.001524, 0
35, 0.00014000000000051, 0.001524, 0
36, 0, 0.0012192000000008, 0
37, 0, 0.00091440000000162, 0
38, 0, 0.00060960000000165, 0
39, 0, 0.00030480000000085, 0
40, 0, 0.0013716000000005, 0
41, 0, 0.0010668000000012, 0
42, 0, 0.0007620000000021, 0
43, 0, 0.00045720000000125, 0
44, 0, 0.00015240000000042, 0
45, 0.00027999999999937, 0, 0.0014
46, 0.0005599999999985, 0, 0.0014
47, 0.00083999999999848, 0, 0.0014
48, 0.0011199999999991, 0, 0.0014
49, 0.00013999999999975, 0, 0.0014
50, 0.00041999999999895, 0, 0.0014
51, 0.00069999999999819, 0, 0.0014
52, 0.00097999999999893, 0, 0.0014
53, 0.0012599999999994, 0, 0.0014
54, 0.0014, 0.00030479999999933, 0.0014
55, 0.0014, 0.00060959999999842, 0.0014
56, 0.0014, 0.00091439999999838, 0.0014
57, 0.0014, 0.0012191999999992, 0.0014
58, 0.0014, 0.00015239999999977, 0.0014
59, 0.0014, 0.00045719999999885, 0.0014
60, 0.0014, 0.00076199999999799, 0.0014
61, 0.0014, 0.0010667999999988, 0.0014
62, 0.0014, 0.0013715999999996, 0.0014
63, 0.0011200000000007, 0.001524, 0.0014
64, 0.00084000000000158, 0.001524, 0.0014
65, 0.00056000000000157, 0.001524, 0.0014
66, 0.00028000000000088, 0.001524, 0.0014
67, 0.0012600000000002, 0.001524, 0.0014
68, 0.00098000000000121, 0.001524, 0.0014
69, 0.00070000000000192, 0.001524, 0.0014
70, 0.00042000000000123, 0.001524, 0.0014
71, 0.00014000000000051, 0.001524, 0.0014
72, 0, 0.0012192000000008, 0.0014
73, 0, 0.00091440000000162, 0.0014
74, 0, 0.00060960000000165, 0.0014
75, 0, 0.00030480000000085, 0.0014
76, 0, 0.0013716000000005, 0.0014
77, 0, 0.0010668000000012, 0.0014
78, 0, 0.0007620000000021, 0.0014
79, 0, 0.00045720000000125, 0.0014
80, 0, 0.00015240000000042, 0.0014
81, 0, 0, 0.00027999999999937
82, 0, 0, 0.0005599999999985
83, 0, 0, 0.00083999999999848
84, 0, 0, 0.0011199999999991
85, 0, 0, 0.00013999999999975
86, 0, 0, 0.00041999999999895
87, 0, 0, 0.00069999999999819
88, 0, 0, 0.00097999999999893
89, 0, 0, 0.0012599999999994
90, 0.0014, 0, 0.00027999999999937
91, 0.0014, 0, 0.0005599999999985
92, 0.0014, 0, 0.00083999999999848
93, 0.0014, 0, 0.0011199999999991
94, 0.0014, 0, 0.00013999999999975
95, 0.0014, 0, 0.00041999999999895
96, 0.0014, 0, 0.00069999999999819
97, 0.0014, 0, 0.00097999999999893
98, 0.0014, 0, 0.0012599999999994
99, 0.0014, 0.001524, 0.00027999999999937
100, 0.0014, 0.001524, 0.0005599999999985
101, 0.0014, 0.001524, 0.00083999999999848
102, 0.0014, 0.001524, 0.0011199999999991
103, 0.0014, 0.001524, 0.00013999999999975
104, 0.0014, 0.001524, 0.00041999999999895
105, 0.0014, 0.001524, 0.00069999999999819
106, 0.0014, 0.001524, 0.00097999999999893
107, 0.0014, 0.001524, 0.0012599999999994
108, 0, 0.001524, 0.00027999999999937
109, 0, 0.001524, 0.0005599999999985
110, 0, 0.001524, 0.00083999999999848
111, 0, 0.001524, 0.0011199999999991
112, 0, 0.001524, 0.00013999999999975
113, 0, 0.001524, 0.00041999999999895
114, 0, 0.001524, 0.00069999999999819
115, 0, 0.001524, 0.00097999999999893
116, 0, 0.001524, 0.0012599999999994
117, 0.00027999999999937, 0, 0.0011199999999991
118, 0.00027999999999937, 0, 0.00083999999999848
119, 0.00027999999999937, 0, 0.0005599999999985
120, 0.00027999999999937, 0, 0.00027999999999937
121, 0.0005599999999985, 0, 0.0011199999999991
122, 0.0005599999999985, 0, 0.00083999999999848
123, 0.0005599999999985, 0, 0.0005599999999985
124, 0.0005599999999985, 0, 0.00027999999999937
125, 0.00083999999999848, 0, 0.0011199999999991
126, 0.00083999999999848, 0, 0.00083999999999848
127, 0.00083999999999848, 0, 0.0005599999999985
128, 0.00083999999999848, 0, 0.00027999999999937
129, 0.0011199999999991, 0, 0.0011199999999991
130, 0.0011199999999991, 0, 0.00083999999999848
131, 0.0011199999999991, 0, 0.0005599999999985
132, 0.0011199999999991, 0, 0.00027999999999937
133, 0.00027999999999937, 0, 0.0012599999999996
134, 0.00013999999999969, 0, 0.0011199999999991
135, 0.00027999999999937, 0, 0.00097999999999881
136, 0.00013999999999969, 0, 0.00083999999999848
137, 0.00027999999999937, 0, 0.00069999999999849
138, 0.00013999999999969, 0, 0.0005599999999985
139, 0.00027999999999937, 0, 0.00041999999999894
140, 0.00013999999999969, 0, 0.00027999999999937
141, 0.00027999999999937, 0, 0.00013999999999969
142, 0.0005599999999985, 0, 0.0012599999999996
143, 0.00041999999999894, 0, 0.0011199999999991
144, 0.0005599999999985, 0, 0.00097999999999881
145, 0.00041999999999894, 0, 0.00083999999999848
146, 0.0005599999999985, 0, 0.00069999999999849
147, 0.00041999999999894, 0, 0.0005599999999985
148, 0.0005599999999985, 0, 0.00041999999999894
149, 0.00041999999999894, 0, 0.00027999999999937
150, 0.0005599999999985, 0, 0.00013999999999969
151, 0.00083999999999848, 0, 0.0012599999999996
152, 0.00069999999999849, 0, 0.0011199999999991
153, 0.00083999999999848, 0, 0.00097999999999881
154, 0.00069999999999849, 0, 0.00083999999999848
155, 0.00083999999999848, 0, 0.00069999999999849
156, 0.00069999999999849, 0, 0.0005599999999985
157, 0.00083999999999848, 0, 0.00041999999999894
158, 0.00069999999999849, 0, 0.00027999999999937
159, 0.00083999999999848, 0, 0.00013999999999969
160, 0.0011199999999991, 0, 0.0012599999999996
161, 0.00097999999999881, 0, 0.0011199999999991
162, 0.0011199999999991, 0, 0.00097999999999881
163, 0.00097999999999881, 0, 0.00083999999999848
164, 0.0011199999999991, 0, 0.00069999999999849
165, 0.00097999999999881, 0, 0.0005599999999985
166, 0.0011199999999991, 0, 0.00041999999999894
167, 0.00097999999999881, 0, 0.00027999999999937
168, 0.0011199999999991, 0, 0.00013999999999969
169, 0.0012599999999996, 0, 0.0011199999999991
170, 0.0012599999999996, 0, 0.00083999999999848
171, 0.0012599999999996, 0, 0.0005599999999985
172, 0.0012599999999996, 0, 0.00027999999999937
173, 0.00027999999999967, 0.00030480000000054, 0.0014
174, 0.00027999999999998, 0.000609600000001, 0.0014
175, 0.00028000000000028, 0.00091440000000098, 0.0014
176, 0.00028000000000058, 0.0012192000000004, 0.0014
177, 0.00055999999999912, 0.00030480000000024, 0.0014
178, 0.00055999999999973, 0.00060960000000036, 0.0014
179, 0.00056000000000035, 0.00091440000000033, 0.0014
180, 0.00056000000000096, 0.0012192000000001, 0.0014
181, 0.0008399999999991, 0.00030479999999994, 0.0014
182, 0.00083999999999972, 0.00060959999999971, 0.0014
183, 0.00084000000000034, 0.00091439999999968, 0.0014
184, 0.00084000000000096, 0.0012191999999998, 0.0014
185, 0.0011199999999995, 0.00030479999999964, 0.0014
186, 0.0011199999999998, 0.00060959999999907, 0.0014
187, 0.0011200000000001, 0.00091439999999903, 0.0014
188, 0.0011200000000004, 0.0012191999999995, 0.0014
189, 0.00027999999999952, 0.00015240000000027, 0.0014
190, 0.00013999999999984, 0.00030480000000069, 0.0014
191, 0.00027999999999982, 0.00045720000000077, 0.0014
192, 0.00013999999999999, 0.00060960000000133, 0.0014
193, 0.00028000000000013, 0.00076200000000099, 0.0014
194, 0.00014000000000014, 0.0009144000000013, 0.0014
195, 0.00028000000000043, 0.0010668000000007, 0.0014
196, 0.00014000000000029, 0.0012192000000006, 0.0014
197, 0.00028000000000073, 0.0013716000000002, 0.0014
198, 0.00055999999999881, 0.00015240000000012, 0.0014
199, 0.0004199999999994, 0.00030480000000039, 0.0014
200, 0.00055999999999942, 0.0004572000000003, 0.0014
201, 0.00041999999999985, 0.00060960000000068, 0.0014
202, 0.00056000000000004, 0.00076200000000034, 0.0014
203, 0.00042000000000031, 0.00091440000000065, 0.0014
204, 0.00056000000000065, 0.0010668000000002, 0.0014
205, 0.00042000000000077, 0.0012192000000003, 0.0014
206, 0.00056000000000127, 0.0013716000000001, 0.0014
207, 0.00083999999999879, 0.00015239999999997, 0.0014
208, 0.00069999999999911, 0.00030480000000009, 0.0014
209, 0.00083999999999941, 0.00045719999999983, 0.0014
210, 0.00069999999999973, 0.00060960000000004, 0.0014
211, 0.00084000000000003, 0.00076199999999969, 0.0014
212, 0.00070000000000034, 0.0009144, 0.0014
213, 0.00084000000000065, 0.0010667999999997, 0.0014
214, 0.00070000000000096, 0.0012192, 0.0014
215, 0.00084000000000127, 0.0013715999999999, 0.0014
216, 0.0011199999999993, 0.00015239999999982, 0.0014
217, 0.00097999999999928, 0.00030479999999979, 0.0014
218, 0.0011199999999996, 0.00045719999999935, 0.0014
219, 0.00097999999999974, 0.00060959999999939, 0.0014
220, 0.0011199999999999, 0.00076199999999905, 0.0014
221, 0.00098000000000021, 0.00091439999999935, 0.0014
222, 0.0011200000000002, 0.0010667999999993, 0.0014
223, 0.00098000000000067, 0.0012191999999996, 0.0014
224, 0.0011200000000005, 0.0013715999999997, 0.0014
225, 0.0012599999999997, 0.00030479999999948, 0.0014
226, 0.0012599999999999, 0.00060959999999874, 0.0014
227, 0.00126, 0.0009143999999987, 0.0014
228, 0.0012600000000002, 0.0012191999999993, 0.0014
229, 0, 0.0012192000000008, 0.0011199999999991
230, 0, 0.0012192000000008, 0.00083999999999848
231, 0, 0.0012192000000008, 0.0005599999999985
232, 0, 0.0012192000000008, 0.00027999999999937
233, 0, 0.00091440000000162, 0.0011199999999991
234, 0, 0.00091440000000162, 0.00083999999999848
235, 0, 0.00091440000000162, 0.0005599999999985
236, 0, 0.00091440000000162, 0.00027999999999937
237, 0, 0.00060960000000165, 0.0011199999999991
238, 0, 0.00060960000000165, 0.00083999999999848
239, 0, 0.00060960000000165, 0.0005599999999985
240, 0, 0.00060960000000165, 0.00027999999999937
241, 0, 0.00030480000000085, 0.0011199999999991
242, 0, 0.00030480000000085, 0.00083999999999848
243, 0, 0.00030480000000085, 0.0005599999999985
244, 0, 0.00030480000000085, 0.00027999999999937
245, 0, 0.0012192000000008, 0.0012599999999996
246, 0, 0.0013716000000004, 0.0011199999999991
247, 0, 0.0012192000000008, 0.00097999999999881
248, 0, 0.0013716000000004, 0.00083999999999848
249, 0, 0.0012192000000008, 0.00069999999999849
250, 0, 0.0013716000000004, 0.0005599999999985
251, 0, 0.0012192000000008, 0.00041999999999894
252, 0, 0.0013716000000004, 0.00027999999999937
253, 0, 0.0012192000000008, 0.00013999999999969
254, 0, 0.00091440000000162, 0.0012599999999996
255, 0, 0.0010668000000012, 0.0011199999999991
256, 0, 0.00091440000000162, 0.00097999999999881
257, 0, 0.0010668000000012, 0.00083999999999848
258, 0, 0.00091440000000162, 0.00069999999999849
259, 0, 0.0010668000000012, 0.0005599999999985
260, 0, 0.00091440000000162, 0.00041999999999894
261, 0, 0.0010668000000012, 0.00027999999999937
262, 0, 0.00091440000000162, 0.00013999999999969
263, 0, 0.00060960000000165, 0.0012599999999996
264, 0, 0.00076200000000164, 0.0011199999999991
265, 0, 0.00060960000000165, 0.00097999999999881
266, 0, 0.00076200000000164, 0.00083999999999848
267, 0, 0.00060960000000165, 0.00069999999999849
268, 0, 0.00076200000000164, 0.0005599999999985
269, 0, 0.00060960000000165, 0.00041999999999894
270, 0, 0.00076200000000164, 0.00027999999999937
271, 0, 0.00060960000000165, 0.00013999999999969
272, 0, 0.00030480000000085, 0.0012599999999996
273, 0, 0.00045720000000125, 0.0011199999999991
274, 0, 0.00030480000000085, 0.00097999999999881
275, 0, 0.00045720000000125, 0.00083999999999848
276, 0, 0.00030480000000085, 0.00069999999999849
277, 0, 0.00045720000000125, 0.0005599999999985
278, 0, 0.00030480000000085, 0.00041999999999894
279, 0, 0.00045720000000125, 0.00027999999999937
280, 0, 0.00030480000000085, 0.00013999999999969
281, 0, 0.00015240000000042, 0.0011199999999991
282, 0, 0.00015240000000042, 0.00083999999999848
283, 0, 0.00015240000000042, 0.0005599999999985
284, 0, 0.00015240000000042, 0.00027999999999937
285, 0.00027999999999967, 0.00030480000000054, 0
286, 0.00027999999999998, 0.000609600000001, 0
287, 0.00028000000000028, 0.00091440000000098, 0
288, 0.00028000000000058, 0.0012192000000004, 0
289, 0.00055999999999912, 0.00030480000000024, 0
290, 0.00055999999999973, 0.00060960000000036, 0
291, 0.00056000000000035, 0.00091440000000033, 0
292, 0.00056000000000096, 0.0012192000000001, 0
293, 0.0008399999999991, 0.00030479999999994, 0
294, 0.00083999999999972, 0.00060959999999971, 0
295, 0.00084000000000034, 0.00091439999999968, 0
296, 0.00084000000000096, 0.0012191999999998, 0
297, 0.0011199999999995, 0.00030479999999964, 0
298, 0.0011199999999998, 0.00060959999999907, 0
299, 0.0011200000000001, 0.00091439999999903, 0
300, 0.0011200000000004, 0.0012191999999995, 0
301, 0.00027999999999952, 0.00015240000000027, 0
302, 0.00013999999999984, 0.00030480000000069, 0
303, 0.00027999999999982, 0.00045720000000077, 0
304, 0.00013999999999999, 0.00060960000000133, 0
305, 0.00028000000000013, 0.00076200000000099, 0
306, 0.00014000000000014, 0.0009144000000013, 0
307, 0.00028000000000043, 0.0010668000000007, 0
308, 0.00014000000000029, 0.0012192000000006, 0
309, 0.00028000000000073, 0.0013716000000002, 0
310, 0.00055999999999881, 0.00015240000000012, 0
311, 0.0004199999999994, 0.00030480000000039, 0
312, 0.00055999999999942, 0.0004572000000003, 0
313, 0.00041999999999985, 0.00060960000000068, 0
314, 0.00056000000000004, 0.00076200000000034, 0
315, 0.00042000000000031, 0.00091440000000065, 0
316, 0.00056000000000065, 0.0010668000000002, 0
317, 0.00042000000000077, 0.0012192000000003, 0
318, 0.00056000000000127, 0.0013716000000001, 0
319, 0.00083999999999879, 0.00015239999999997, 0
320, 0.00069999999999911, 0.00030480000000009, 0
321, 0.00083999999999941, 0.00045719999999983, 0
322, 0.00069999999999973, 0.00060960000000004, 0
323, 0.00084000000000003, 0.00076199999999969, 0
324, 0.00070000000000034, 0.0009144, 0
325, 0.00084000000000065, 0.0010667999999997, 0
326, 0.00070000000000096, 0.0012192, 0
327, 0.00084000000000127, 0.0013715999999999, 0
328, 0.0011199999999993, 0.00015239999999982, 0
329, 0.00097999999999928, 0.00030479999999979, 0
330, 0.0011199999999996, 0.00045719999999935, 0
331, 0.00097999999999974, 0.00060959999999939, 0
332, 0.0011199999999999, 0.00076199999999905, 0
333, 0.00098000000000021, 0.00091439999999935, 0
334, 0.0011200000000002, 0.0010667999999993, 0
335, 0.00098000000000067, 0.0012191999999996, 0
336, 0.0011200000000005, 0.0013715999999997, 0
337, 0.0012599999999997, 0.00030479999999948, 0
338, 0.0012599999999999, 0.00060959999999874, 0
339, 0.00126, 0.0009143999999987, 0
340, 0.0012600000000002, 0.0012191999999993, 0
341, 0.00028000000000088, 0.001524, 0.00027999999999937
342, 0.00056000000000157, 0.001524, 0.00027999999999937
343, 0.00084000000000158, 0.001524, 0.00027999999999937
344, 0.0011200000000007, 0.001524, 0.00027999999999937
345, 0.00028000000000088, 0.001524, 0.0005599999999985
346, 0.00056000000000157, 0.001524, 0.0005599999999985
347, 0.00084000000000158, 0.001524, 0.0005599999999985
348, 0.0011200000000007, 0.001524, 0.0005599999999985
349, 0.00028000000000088, 0.001524, 0.00083999999999848
350, 0.00056000000000157, 0.001524, 0.00083999999999848
351, 0.00084000000000158, 0.001524, 0.00083999999999848
352, 0.0011200000000007, 0.001524, 0.00083999999999848
353, 0.00028000000000088, 0.001524, 0.0011199999999991
354, 0.00056000000000157, 0.001524, 0.0011199999999991
355, 0.00084000000000158, 0.001524, 0.0011199999999991
356, 0.0011200000000007, 0.001524, 0.0011199999999991
357, 0.00014000000000044, 0.001524, 0.00027999999999937
358, 0.00028000000000088, 0.001524, 0.00013999999999969
359, 0.00042000000000123, 0.001524, 0.00027999999999937
360, 0.00056000000000157, 0.001524, 0.00013999999999969
361, 0.00070000000000157, 0.001524, 0.00027999999999937
362, 0.00084000000000158, 0.001524, 0.00013999999999969
363, 0.00098000000000114, 0.001524, 0.00027999999999937
364, 0.0011200000000007, 0.001524, 0.00013999999999969
365, 0.0012600000000003, 0.001524, 0.00027999999999937
366, 0.00014000000000044, 0.001524, 0.0005599999999985
367, 0.00028000000000088, 0.001524, 0.00041999999999894
368, 0.00042000000000123, 0.001524, 0.0005599999999985
369, 0.00056000000000157, 0.001524, 0.00041999999999894
370, 0.00070000000000157, 0.001524, 0.0005599999999985
371, 0.00084000000000158, 0.001524, 0.00041999999999894
372, 0.00098000000000114, 0.001524, 0.0005599999999985
373, 0.0011200000000007, 0.001524, 0.00041999999999894
374, 0.0012600000000003, 0.001524, 0.0005599999999985
375, 0.00014000000000044, 0.001524, 0.00083999999999848
376, 0.00028000000000088, 0.001524, 0.00069999999999849
377, 0.00042000000000123, 0.001524, 0.00083999999999848
378, 0.00056000000000157, 0.001524, 0.00069999999999849
379, 0.00070000000000157, 0.001524, 0.00083999999999848
380, 0.00084000000000158, 0.001524, 0.00069999999999849
381, 0.00098000000000114, 0.001524, 0.00083999999999848
382, 0.0011200000000007, 0.001524, 0.00069999999999849
383, 0.0012600000000003, 0.001524, 0.00083999999999848
384, 0.00014000000000044, 0.001524, 0.0011199999999991
385, 0.00028000000000088, 0.001524, 0.00097999999999881
386, 0.00042000000000123, 0.001524, 0.0011199999999991
387, 0.00056000000000157, 0.001524, 0.00097999999999881
388, 0.00070000000000157, 0.001524, 0.0011199999999991
389, 0.00084000000000158, 0.001524, 0.00097999999999881
390, 0.00098000000000114, 0.001524, 0.0011199999999991
391, 0.0011200000000007, 0.001524, 0.00097999999999881
392, 0.0012600000000003, 0.001524, 0.0011199999999991
393, 0.00028000000000088, 0.001524, 0.0012599999999996
394, 0.00056000000000157, 0.001524, 0.0012599999999996
395, 0.00084000000000158, 0.001524, 0.0012599999999996
396, 0.0011200000000007, 0.001524, 0.0012599999999996
397, 0.0014, 0.00030479999999933, 0.0011199999999991
398, 0.0014, 0.00030479999999933, 0.00083999999999848
399, 0.0014, 0.00030479999999933, 0.0005599999999985
400, 0.0014, 0.00030479999999933, 0.00027999999999937
401, 0.0014, 0.00060959999999842, 0.0011199999999991
402, 0.0014, 0.00060959999999842, 0.00083999999999848
403, 0.0014, 0.00060959999999842, 0.0005599999999985
404, 0.0014, 0.00060959999999842, 0.00027999999999937
405, 0.0014, 0.00091439999999838, 0.0011199999999991
406, 0.0014, 0.00091439999999838, 0.00083999999999848
407, 0.0014, 0.00091439999999838, 0.0005599999999985
408, 0.0014, 0.00091439999999838, 0.00027999999999937
409, 0.0014, 0.0012191999999992, 0.0011199999999991
410, 0.0014, 0.0012191999999992, 0.00083999999999848
411, 0.0014, 0.0012191999999992, 0.0005599999999985
412, 0.0014, 0.0012191999999992, 0.00027999999999937
413, 0.0014, 0.00030479999999933, 0.0012599999999996
414, 0.0014, 0.00015239999999967, 0.0011199999999991
415, 0.0014, 0.00030479999999933, 0.00097999999999881
416, 0.0014, 0.00015239999999967, 0.00083999999999848
417, 0.0014, 0.00030479999999933, 0.00069999999999849
418, 0.0014, 0.00015239999999967, 0.0005599999999985
419, 0.0014, 0.00030479999999933, 0.00041999999999894
420, 0.0014, 0.00015239999999967, 0.00027999999999937
421, 0.0014, 0.00030479999999933, 0.00013999999999969
422, 0.0014, 0.00060959999999842, 0.0012599999999996
423, 0.0014, 0.00045719999999888, 0.0011199999999991
424, 0.0014, 0.00060959999999842, 0.00097999999999881
425, 0.0014, 0.00045719999999888, 0.00083999999999848
426, 0.0014, 0.00060959999999842, 0.00069999999999849
427, 0.0014, 0.00045719999999888, 0.0005599999999985
428, 0.0014, 0.00060959999999842, 0.00041999999999894
429, 0.0014, 0.00045719999999888, 0.00027999999999937
430, 0.0014, 0.00060959999999842, 0.00013999999999969
431, 0.0014, 0.00091439999999838, 0.0012599999999996
432, 0.0014, 0.0007619999999984, 0.0011199999999991
433, 0.0014, 0.00091439999999838, 0.00097999999999881
434, 0.0014, 0.0007619999999984, 0.00083999999999848
435, 0.0014, 0.00091439999999838, 0.00069999999999849
436, 0.0014, 0.0007619999999984, 0.0005599999999985
437, 0.0014, 0.00091439999999838, 0.00041999999999894
438, 0.0014, 0.0007619999999984, 0.00027999999999937
439, 0.0014, 0.00091439999999838, 0.00013999999999969
440, 0.0014, 0.0012191999999992, 0.0012599999999996
441, 0.0014, 0.0010667999999988, 0.0011199999999991
442, 0.0014, 0.0012191999999992, 0.00097999999999881
443, 0.0014, 0.0010667999999988, 0.00083999999999848
444, 0.0014, 0.0012191999999992, 0.00069999999999849
445, 0.0014, 0.0010667999999988, 0.0005599999999985
446, 0.0014, 0.0012191999999992, 0.00041999999999894
447, 0.0014, 0.0010667999999988, 0.00027999999999937
448, 0.0014, 0.0012191999999992, 0.00013999999999969
449, 0.0014, 0.0013715999999996, 0.0011199999999991
450, 0.0014, 0.0013715999999996, 0.00083999999999848
451, 0.0014, 0.0013715999999996, 0.0005599999999985
452, 0.0014, 0.0013715999999996, 0.00027999999999937
453, 0.00027999999999967, 0.00030480000000054, 0.0011199999999991
454, 0.00027999999999967, 0.00030480000000054, 0.00083999999999848
455, 0.00027999999999967, 0.00030480000000054, 0.0005599999999985
456, 0.00027999999999967, 0.00030480000000054, 0.00027999999999937
457, 0.00027999999999998, 0.000609600000001, 0.0011199999999991
458, 0.00027999999999998, 0.000609600000001, 0.00083999999999848
459, 0.00027999999999998, 0.000609600000001, 0.0005599999999985
460, 0.00027999999999998, 0.000609600000001, 0.00027999999999937
461, 0.00028000000000028, 0.00091440000000097, 0.0011199999999991
462, 0.00028000000000028, 0.00091440000000097, 0.00083999999999848
463, 0.00028000000000028, 0.00091440000000097, 0.0005599999999985
464, 0.00028000000000028, 0.00091440000000097, 0.00027999999999937
465, 0.00028000000000058, 0.0012192000000004, 0.0011199999999991
466, 0.00028000000000058, 0.0012192000000004, 0.00083999999999848
467, 0.00028000000000058, 0.0012192000000004, 0.0005599999999985
468, 0.00028000000000058, 0.0012192000000004, 0.00027999999999937
469, 0.00055999999999912, 0.00030480000000024, 0.0011199999999991
470, 0.00055999999999912, 0.00030480000000024, 0.00083999999999848
471, 0.00055999999999912, 0.00030480000000024, 0.0005599999999985
472, 0.00055999999999912, 0.00030480000000024, 0.00027999999999937
473, 0.00055999999999973, 0.00060960000000036, 0.0011199999999991
474, 0.00055999999999973, 0.00060960000000036, 0.00083999999999848
475, 0.00055999999999973, 0.00060960000000036, 0.0005599999999985
476, 0.00055999999999973, 0.00060960000000036, 0.00027999999999937
477, 0.00056000000000034, 0.00091440000000033, 0.0011199999999991
478, 0.00056000000000035, 0.00091440000000033, 0.00083999999999848
479, 0.00056000000000034, 0.00091440000000033, 0.0005599999999985
480, 0.00056000000000035, 0.00091440000000033, 0.00027999999999937
481, 0.00056000000000096, 0.0012192000000001, 0.0011199999999991
482, 0.00056000000000096, 0.0012192000000001, 0.00083999999999848
483, 0.00056000000000096, 0.0012192000000001, 0.0005599999999985
484, 0.00056000000000096, 0.0012192000000001, 0.00027999999999937
485, 0.0008399999999991, 0.00030479999999994, 0.0011199999999991
486, 0.0008399999999991, 0.00030479999999994, 0.00083999999999848
487, 0.0008399999999991, 0.00030479999999994, 0.0005599999999985
488, 0.0008399999999991, 0.00030479999999994, 0.00027999999999937
489, 0.00083999999999972, 0.00060959999999971, 0.0011199999999991
490, 0.00083999999999972, 0.00060959999999971, 0.00083999999999848
491, 0.00083999999999972, 0.00060959999999971, 0.0005599999999985
492, 0.00083999999999972, 0.00060959999999971, 0.00027999999999937
493, 0.00084000000000034, 0.00091439999999968, 0.0011199999999991
494, 0.00084000000000034, 0.00091439999999968, 0.00083999999999848
495, 0.00084000000000034, 0.00091439999999968, 0.0005599999999985
496, 0.00084000000000034, 0.00091439999999968, 0.00027999999999937
497, 0.00084000000000096, 0.0012191999999998, 0.0011199999999991
498, 0.00084000000000096, 0.0012191999999998, 0.00083999999999848
499, 0.00084000000000096, 0.0012191999999998, 0.0005599999999985
500, 0.00084000000000096, 0.0012191999999998, 0.00027999999999937
501, 0.0011199999999995, 0.00030479999999964, 0.0011199999999991
502, 0.0011199999999995, 0.00030479999999964, 0.00083999999999848
503, 0.0011199999999995, 0.00030479999999964, 0.0005599999999985
504, 0.0011199999999995, 0.00030479999999964, 0.00027999999999937
505, 0.0011199999999998, 0.00060959999999907, 0.0011199999999991
506, 0.0011199999999998, 0.00060959999999907, 0.00083999999999848
507, 0.0011199999999998, 0.00060959999999907, 0.0005599999999985
508, 0.0011199999999998, 0.00060959999999907, 0.00027999999999937
509, 0.0011200000000001, 0.00091439999999903, 0.0011199999999991
510, 0.0011200000000001, 0.00091439999999903, 0.00083999999999848
511, 0.0011200000000001, 0.00091439999999903, 0.0005599999999985
512, 0.0011200000000001, 0.00091439999999903, 0.00027999999999937
513, 0.0011200000000004, 0.0012191999999995, 0.0011199999999991
514, 0.0011200000000004, 0.0012191999999995, 0.00083999999999848
515, 0.0011200000000004, 0.0012191999999995, 0.0005599999999985
516, 0.0011200000000004, 0.0012191999999995, 0.00027999999999937
517, 0.00027999999999967, 0.00030480000000054, 0.0012599999999996
518, 0.00027999999999952, 0.00015240000000027, 0.0011199999999991
519, 0.00013999999999984, 0.00030480000000069, 0.0011199999999991
520, 0.00027999999999967, 0.00030480000000054, 0.00097999999999881
521, 0.00027999999999952, 0.00015240000000027, 0.00083999999999848
522, 0.00013999999999984, 0.00030480000000069, 0.00083999999999848
523, 0.00027999999999967, 0.00030480000000054, 0.00069999999999849
524, 0.00027999999999952, 0.00015240000000027, 0.0005599999999985
525, 0.00013999999999984, 0.00030480000000069, 0.0005599999999985
526, 0.00027999999999967, 0.00030480000000054, 0.00041999999999894
527, 0.00027999999999952, 0.00015240000000027, 0.00027999999999937
528, 0.00013999999999984, 0.00030480000000069, 0.00027999999999937
529, 0.00027999999999967, 0.00030480000000054, 0.00013999999999969
530, 0.00027999999999998, 0.000609600000001, 0.0012599999999996
531, 0.00027999999999983, 0.00045720000000077, 0.0011199999999991
532, 0.00013999999999999, 0.00060960000000133, 0.0011199999999991
533, 0.00027999999999998, 0.000609600000001, 0.00097999999999881
534, 0.00027999999999982, 0.00045720000000077, 0.00083999999999848
535, 0.00013999999999999, 0.00060960000000133, 0.00083999999999848
536, 0.00027999999999998, 0.000609600000001, 0.00069999999999849
537, 0.00027999999999982, 0.00045720000000077, 0.0005599999999985
538, 0.00013999999999999, 0.00060960000000133, 0.0005599999999985
539, 0.00027999999999998, 0.000609600000001, 0.00041999999999894
540, 0.00027999999999982, 0.00045720000000077, 0.00027999999999937
541, 0.00013999999999999, 0.00060960000000133, 0.00027999999999937
542, 0.00027999999999998, 0.000609600000001, 0.00013999999999969
543, 0.00028000000000028, 0.00091440000000097, 0.0012599999999996
544, 0.00028000000000013, 0.00076200000000099, 0.0011199999999991
545, 0.00014000000000014, 0.0009144000000013, 0.0011199999999991
546, 0.00028000000000028, 0.00091440000000097, 0.00097999999999881
547, 0.00028000000000013, 0.00076200000000099, 0.00083999999999848
548, 0.00014000000000014, 0.0009144000000013, 0.00083999999999848
549, 0.00028000000000028, 0.00091440000000097, 0.00069999999999849
550, 0.00028000000000013, 0.00076200000000099, 0.0005599999999985
551, 0.00014000000000014, 0.0009144000000013, 0.0005599999999985
552, 0.00028000000000028, 0.00091440000000097, 0.00041999999999894
553, 0.00028000000000013, 0.00076200000000099, 0.00027999999999937
554, 0.00014000000000014, 0.0009144000000013, 0.00027999999999937
555, 0.00028000000000028, 0.00091440000000097, 0.00013999999999969
556, 0.00028000000000058, 0.0012192000000004, 0.0012599999999996
557, 0.00028000000000043, 0.0010668000000007, 0.0011199999999991
558, 0.00014000000000029, 0.0012192000000006, 0.0011199999999991
559, 0.00028000000000058, 0.0012192000000004, 0.00097999999999881
560, 0.00028000000000043, 0.0010668000000007, 0.00083999999999848
561, 0.00014000000000029, 0.0012192000000006, 0.00083999999999848
562, 0.00028000000000058, 0.0012192000000004, 0.00069999999999849
563, 0.00028000000000043, 0.0010668000000007, 0.0005599999999985
564, 0.00014000000000029, 0.0012192000000006, 0.0005599999999985
565, 0.00028000000000058, 0.0012192000000004, 0.00041999999999894
566, 0.00028000000000043, 0.0010668000000007, 0.00027999999999937
567, 0.00014000000000029, 0.0012192000000006, 0.00027999999999937
568, 0.00028000000000058, 0.0012192000000004, 0.00013999999999969
569, 0.00028000000000073, 0.0013716000000002, 0.0011199999999991
570, 0.00028000000000073, 0.0013716000000002, 0.00083999999999848
571, 0.00028000000000073, 0.0013716000000002, 0.0005599999999985
572, 0.00028000000000073, 0.0013716000000002, 0.00027999999999937
573, 0.00055999999999912, 0.00030480000000024, 0.0012599999999996
574, 0.00055999999999881, 0.00015240000000012, 0.0011199999999991
575, 0.0004199999999994, 0.00030480000000039, 0.0011199999999991
576, 0.00055999999999912, 0.00030480000000024, 0.00097999999999881
577, 0.00055999999999881, 0.00015240000000012, 0.00083999999999848
578, 0.0004199999999994, 0.00030480000000039, 0.00083999999999848
579, 0.00055999999999912, 0.00030480000000024, 0.00069999999999849
580, 0.00055999999999881, 0.00015240000000012, 0.0005599999999985
581, 0.0004199999999994, 0.00030480000000039, 0.0005599999999985
582, 0.00055999999999912, 0.00030480000000024, 0.00041999999999894
583, 0.00055999999999881, 0.00015240000000012, 0.00027999999999937
584, 0.0004199999999994, 0.00030480000000039, 0.00027999999999937
585, 0.00055999999999912, 0.00030480000000024, 0.00013999999999969
586, 0.00055999999999973, 0.00060960000000036, 0.0012599999999996
587, 0.00055999999999942, 0.0004572000000003, 0.0011199999999991
588, 0.00041999999999985, 0.00060960000000068, 0.0011199999999991
589, 0.00055999999999973, 0.00060960000000036, 0.00097999999999881
590, 0.00055999999999942, 0.0004572000000003, 0.00083999999999848
591, 0.00041999999999985, 0.00060960000000068, 0.00083999999999848
592, 0.00055999999999973, 0.00060960000000036, 0.00069999999999849
593, 0.00055999999999942, 0.0004572000000003, 0.0005599999999985
594, 0.00041999999999985, 0.00060960000000068, 0.0005599999999985
595, 0.00055999999999973, 0.00060960000000036, 0.00041999999999894
596, 0.00055999999999942, 0.0004572000000003, 0.00027999999999937
597, 0.00041999999999985, 0.00060960000000068, 0.00027999999999937
598, 0.00055999999999973, 0.00060960000000036, 0.00013999999999969
599, 0.00056000000000035, 0.00091440000000033, 0.0012599999999996
600, 0.00056000000000004, 0.00076200000000034, 0.0011199999999991
601, 0.00042000000000031, 0.00091440000000065, 0.0011199999999991
602, 0.00056000000000035, 0.00091440000000033, 0.00097999999999881
603, 0.00056000000000004, 0.00076200000000034, 0.00083999999999848
604, 0.00042000000000031, 0.00091440000000065, 0.00083999999999848
605, 0.00056000000000035, 0.00091440000000033, 0.00069999999999849
606, 0.00056000000000004, 0.00076200000000034, 0.0005599999999985
607, 0.00042000000000031, 0.00091440000000065, 0.0005599999999985
608, 0.00056000000000035, 0.00091440000000033, 0.00041999999999894
609, 0.00056000000000004, 0.00076200000000034, 0.00027999999999937
610, 0.00042000000000031, 0.00091440000000065, 0.00027999999999937
611, 0.00056000000000035, 0.00091440000000033, 0.00013999999999969
612, 0.00056000000000096, 0.0012192000000001, 0.0012599999999996
613, 0.00056000000000065, 0.0010668000000002, 0.0011199999999991
614, 0.00042000000000077, 0.0012192000000003, 0.0011199999999991
615, 0.00056000000000096, 0.0012192000000001, 0.00097999999999881
616, 0.00056000000000065, 0.0010668000000002, 0.00083999999999848
617, 0.00042000000000077, 0.0012192000000003, 0.00083999999999848
618, 0.00056000000000096, 0.0012192000000001, 0.00069999999999849
619, 0.00056000000000065, 0.0010668000000002, 0.0005599999999985
620, 0.00042000000000077, 0.0012192000000003, 0.0005599999999985
621, 0.00056000000000096, 0.0012192000000001, 0.00041999999999894
622, 0.00056000000000065, 0.0010668000000002, 0.00027999999999937
623, 0.00042000000000077, 0.0012192000000003, 0.00027999999999937
624, 0.00056000000000096, 0.0012192000000001, 0.00013999999999969
625, 0.00056000000000127, 0.0013716000000001, 0.0011199999999991
626, 0.00056000000000127, 0.0013716000000001, 0.00083999999999848
627, 0.00056000000000127, 0.0013716000000001, 0.0005599999999985
628, 0.00056000000000127, 0.0013716000000001, 0.00027999999999937
629, 0.0008399999999991, 0.00030479999999994, 0.0012599999999996
630, 0.00083999999999879, 0.00015239999999997, 0.0011199999999991
631, 0.00069999999999911, 0.00030480000000009, 0.0011199999999991
632, 0.0008399999999991, 0.00030479999999994, 0.00097999999999881
633, 0.00083999999999879, 0.00015239999999997, 0.00083999999999848
634, 0.00069999999999911, 0.00030480000000009, 0.00083999999999848
635, 0.0008399999999991, 0.00030479999999994, 0.00069999999999849
636, 0.00083999999999879, 0.00015239999999997, 0.0005599999999985
637, 0.00069999999999911, 0.00030480000000009, 0.0005599999999985
638, 0.0008399999999991, 0.00030479999999994, 0.00041999999999894
639, 0.00083999999999879, 0.00015239999999997, 0.00027999999999937
640, 0.00069999999999911, 0.00030480000000009, 0.00027999999999937
641, 0.0008399999999991, 0.00030479999999994, 0.00013999999999969
642, 0.00083999999999972, 0.00060959999999971, 0.0012599999999996
643, 0.00083999999999941, 0.00045719999999983, 0.0011199999999991
644, 0.00069999999999973, 0.00060960000000004, 0.0011199999999991
645, 0.00083999999999972, 0.00060959999999971, 0.00097999999999881
646, 0.00083999999999941, 0.00045719999999983, 0.00083999999999848
647, 0.00069999999999973, 0.00060960000000004, 0.00083999999999848
648, 0.00083999999999972, 0.00060959999999971, 0.00069999999999849
649, 0.00083999999999941, 0.00045719999999983, 0.0005599999999985
650, 0.00069999999999973, 0.00060960000000004, 0.0005599999999985
651, 0.00083999999999972, 0.00060959999999971, 0.00041999999999894
652, 0.00083999999999941, 0.00045719999999983, 0.00027999999999937
653, 0.00069999999999973, 0.00060960000000004, 0.00027999999999937
654, 0.00083999999999972, 0.00060959999999971, 0.00013999999999969
655, 0.00084000000000034, 0.00091439999999968, 0.0012599999999996
656, 0.00084000000000003, 0.00076199999999969, 0.0011199999999991
657, 0.00070000000000034, 0.0009144, 0.0011199999999991
658, 0.00084000000000034, 0.00091439999999968, 0.00097999999999881
659, 0.00084000000000003, 0.00076199999999969, 0.00083999999999848
660, 0.00070000000000034, 0.0009144, 0.00083999999999848
661, 0.00084000000000034, 0.00091439999999968, 0.00069999999999849
662, 0.00084000000000003, 0.0007619999999997, 0.0005599999999985
663, 0.00070000000000034, 0.0009144, 0.0005599999999985
664, 0.00084000000000034, 0.00091439999999968, 0.00041999999999894
665, 0.00084000000000003, 0.00076199999999969, 0.00027999999999937
666, 0.00070000000000034, 0.0009144, 0.00027999999999937
667, 0.00084000000000034, 0.00091439999999968, 0.00013999999999969
668, 0.00084000000000096, 0.0012191999999998, 0.0012599999999996
669, 0.00084000000000065, 0.0010667999999997, 0.0011199999999991
670, 0.00070000000000096, 0.0012192, 0.0011199999999991
671, 0.00084000000000096, 0.0012191999999998, 0.00097999999999881
672, 0.00084000000000065, 0.0010667999999997, 0.00083999999999848
673, 0.00070000000000096, 0.0012192, 0.00083999999999848
674, 0.00084000000000096, 0.0012191999999998, 0.00069999999999849
675, 0.00084000000000065, 0.0010667999999997, 0.0005599999999985
676, 0.00070000000000096, 0.0012192, 0.0005599999999985
677, 0.00084000000000096, 0.0012191999999998, 0.00041999999999894
678, 0.00084000000000065, 0.0010667999999997, 0.00027999999999937
679, 0.00070000000000096, 0.0012192, 0.00027999999999937
680, 0.00084000000000096, 0.0012191999999998, 0.00013999999999969
681, 0.00084000000000127, 0.0013715999999999, 0.0011199999999991
682, 0.00084000000000127, 0.0013715999999999, 0.00083999999999848
683, 0.00084000000000127, 0.0013715999999999, 0.0005599999999985
684, 0.00084000000000127, 0.0013715999999999, 0.00027999999999937
685, 0.0011199999999995, 0.00030479999999964, 0.0012599999999996
686, 0.0011199999999993, 0.00015239999999982, 0.0011199999999991
687, 0.00097999999999928, 0.00030479999999979, 0.0011199999999991
688, 0.0011199999999995, 0.00030479999999964, 0.00097999999999881
689, 0.0011199999999993, 0.00015239999999982, 0.00083999999999848
690, 0.00097999999999928, 0.00030479999999979, 0.00083999999999848
691, 0.0011199999999995, 0.00030479999999964, 0.00069999999999849
692, 0.0011199999999993, 0.00015239999999982, 0.0005599999999985
693, 0.00097999999999928, 0.00030479999999979, 0.0005599999999985
694, 0.0011199999999995, 0.00030479999999964, 0.00041999999999894
695, 0.0011199999999993, 0.00015239999999982, 0.00027999999999937
696, 0.00097999999999928, 0.00030479999999979, 0.00027999999999937
697, 0.0011199999999995, 0.00030479999999964, 0.00013999999999969
698, 0.0011199999999998, 0.00060959999999907, 0.0012599999999996
699, 0.0011199999999996, 0.00045719999999935, 0.0011199999999991
700, 0.00097999999999974, 0.00060959999999939, 0.0011199999999991
701, 0.0011199999999998, 0.00060959999999907, 0.00097999999999881
702, 0.0011199999999996, 0.00045719999999935, 0.00083999999999848
703, 0.00097999999999974, 0.00060959999999939, 0.00083999999999848
704, 0.0011199999999998, 0.00060959999999907, 0.00069999999999849
705, 0.0011199999999996, 0.00045719999999935, 0.0005599999999985
706, 0.00097999999999974, 0.00060959999999939, 0.0005599999999985
707, 0.0011199999999998, 0.00060959999999907, 0.00041999999999894
708, 0.0011199999999996, 0.00045719999999935, 0.00027999999999937
709, 0.00097999999999974, 0.00060959999999939, 0.00027999999999937
710, 0.0011199999999998, 0.00060959999999907, 0.00013999999999969
711, 0.0011200000000001, 0.00091439999999903, 0.0012599999999996
712, 0.0011199999999999, 0.00076199999999905, 0.0011199999999991
713, 0.00098000000000021, 0.00091439999999935, 0.0011199999999991
714, 0.0011200000000001, 0.00091439999999903, 0.00097999999999881
715, 0.0011199999999999, 0.00076199999999905, 0.00083999999999848
716, 0.00098000000000021, 0.00091439999999935, 0.00083999999999848
717, 0.0011200000000001, 0.00091439999999903, 0.00069999999999849
718, 0.0011199999999999, 0.00076199999999905, 0.0005599999999985
719, 0.00098000000000021, 0.00091439999999935, 0.0005599999999985
720, 0.0011200000000001, 0.00091439999999903, 0.00041999999999894
721, 0.0011199999999999, 0.00076199999999905, 0.00027999999999937
722, 0.00098000000000021, 0.00091439999999935, 0.00027999999999937
723, 0.0011200000000001, 0.00091439999999903, 0.00013999999999969
724, 0.0011200000000004, 0.0012191999999995, 0.0012599999999996
725, 0.0011200000000002, 0.0010667999999993, 0.0011199999999991
726, 0.00098000000000067, 0.0012191999999996, 0.0011199999999991
727, 0.0011200000000004, 0.0012191999999995, 0.00097999999999881
728, 0.0011200000000002, 0.0010667999999993, 0.00083999999999848
729, 0.00098000000000067, 0.0012191999999996, 0.00083999999999848
730, 0.0011200000000004, 0.0012191999999995, 0.00069999999999849
731, 0.0011200000000002, 0.0010667999999993, 0.0005599999999985
732, 0.00098000000000067, 0.0012191999999996, 0.0005599999999985
733, 0.0011200000000004, 0.0012191999999995, 0.00041999999999894
734, 0.0011200000000002, 0.0010667999999993, 0.00027999999999937
735, 0.00098000000000067, 0.0012191999999996, 0.00027999999999937
736, 0.0011200000000004, 0.0012191999999995, 0.00013999999999969
737, 0.0011200000000005, 0.0013715999999997, 0.0011199999999991
738, 0.0011200000000005, 0.0013715999999997, 0.00083999999999848
739, 0.0011200000000005, 0.0013715999999997, 0.0005599999999985
740, 0.0011200000000005, 0.0013715999999997, 0.00027999999999937
741, 0.0012599999999997, 0.00030479999999948, 0.0011199999999991
742, 0.0012599999999997, 0.00030479999999948, 0.00083999999999848
743, 0.0012599999999997, 0.00030479999999948, 0.0005599999999985
744, 0.0012599999999997, 0.00030479999999948, 0.00027999999999937
745, 0.0012599999999999, 0.00060959999999874, 0.0011199999999991
746, 0.0012599999999999, 0.00060959999999874, 0.00083999999999848
747, 0.0012599999999999, 0.00060959999999874, 0.0005599999999985
748, 0.0012599999999999, 0.00060959999999874, 0.00027999999999937
749, 0.00126, 0.0009143999999987, 0.0011199999999991
750, 0.00126, 0.0009143999999987, 0.00083999999999848
751, 0.00126, 0.0009143999999987, 0.0005599999999985
752, 0.00126, 0.0009143999999987, 0.00027999999999937
753, 0.0012600000000002, 0.0012191999999993, 0.0011199999999991
754, 0.0012600000000002, 0.0012191999999993, 0.00083999999999848
755, 0.0012600000000002, 0.0012191999999993, 0.0005599999999985
756, 0.0012600000000002, 0.0012191999999993, 0.00027999999999937
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
304, 1, 13, 9
305, 9, 14, 10
306, 10, 15, 11
307, 11, 16, 12
308, 12, 17, 2
*ELEMENT, type=T3D3, ELSET=Line2
309, 2, 22, 18
310, 18, 23, 19
311, 19, 24, 20
312, 20, 25, 21
313, 21, 26, 3
*ELEMENT, type=T3D3, ELSET=Line3
314, 3, 31, 27
315, 27, 32, 28
316, 28, 33, 29
317, 29, 34, 30
318, 30, 35, 4
*ELEMENT, type=T3D3, ELSET=Line4
1, 4, 40, 36
2, 36, 41, 37
3, 37, 42, 38
4, 38, 43, 39
5, 39, 44, 1
*ELEMENT, type=T3D3, ELSET=Line5
319, 5, 49, 45
320, 45, 50, 46
321, 46, 51, 47
322, 47, 52, 48
323, 48, 53, 6
*ELEMENT, type=T3D3, ELSET=Line6
324, 6, 58, 54
325, 54, 59, 55
326, 55, 60, 56
327, 56, 61, 57
328, 57, 62, 7
*ELEMENT, type=T3D3, ELSET=Line7
329, 7, 67, 63
330, 63, 68, 64
331, 64, 69, 65
332, 65, 70, 66
333, 66, 71, 8
*ELEMENT, type=T3D3, ELSET=Line8
6, 8, 76, 72
7, 72, 77, 73
8, 73, 78, 74
9, 74, 79, 75
10, 75, 80, 5
*ELEMENT, type=T3D3, ELSET=Line9
11, 1, 85, 81
12, 81, 86, 82
13, 82, 87, 83
14, 83, 88, 84
15, 84, 89, 5
*ELEMENT, type=T3D3, ELSET=Line10
334, 2, 94, 90
335, 90, 95, 91
336, 91, 96, 92
337, 92, 97, 93
338, 93, 98, 6
*ELEMENT, type=T3D3, ELSET=Line11
339, 3, 103, 99
340, 99, 104, 100
341, 100, 105, 101
342, 101, 106, 102
343, 102, 107, 7
*ELEMENT, type=T3D3, ELSET=Line12
16, 4, 112, 108
17, 108, 113, 109
18, 109, 114, 110
19, 110, 115, 111
20, 111, 116, 8
*ELEMENT, type=CPS8, ELSET=Surface1
21, 5, 45, 117, 84, 49, 133, 134, 89
22, 84, 117, 118, 83, 134, 135, 136, 88
23, 83, 118, 119, 82, 136, 137, 138, 87
24, 82, 119, 120, 81, 138, 139, 140, 86
25, 81, 120, 9, 1, 140, 141, 13, 85
26, 45, 46, 121, 117, 50, 142, 143, 133
27, 117, 121, 122, 118, 143, 144, 145, 135
28, 118, 122, 123, 119, 145, 146, 147, 137
29, 119, 123, 124, 120, 147, 148, 149, 139
30, 120, 124, 10, 9, 149, 150, 14, 141
31, 46, 47, 125, 121, 51, 151, 152, 142
32, 121, 125, 126, 122, 152, 153, 154, 144
33, 122, 126, 127, 123, 154, 155, 156, 146
34, 123, 127, 128, 124, 156, 157, 158, 148
35, 124, 128, 11, 10, 158, 159, 15, 150
36, 47, 48, 129, 125, 52, 160, 161, 151
37, 125, 129, 130, 126, 161, 162, 163, 153
38, 126, 130, 131, 127, 163, 164, 165, 155
39, 127, 131, 132, 128, 165, 166, 167, 157
40, 128, 132, 12, 11, 167, 168, 16, 159
41, 48, 6, 93, 129, 53, 98, 169, 160
42, 129, 93, 92, 130, 169, 97, 170, 162
43, 130, 92, 91, 131, 170, 96, 171, 164
44, 131, 91, 90, 132, 171, 95, 172, 166
45, 132, 90, 2, 12, 172, 94, 17, 168
*ELEMENT, type=CPS8, ELSET=Surface2
46, 5, 45, 173, 75, 49, 189, 190, 80
47, 75, 173, 174, 74, 190, 191, 192, 79
48, 74, 174, 175, 73, 192, 193, 194, 78
49, 73, 175, 176, 72, 194, 195, 196, 77
50, 72, 176, 66, 8, 196, 197, 71, 76
51, 45, 46, 177, 173, 50, 198, 199, 189
52, 173, 177, 178, 174, 199, 200, 201, 191
53, 174, 178, 179, 175, 201, 202, 203, 193
54, 175, 179, 180, 176, 203, 204, 205, 195
55, 176, 180, 65, 66, 205, 206, 70, 197
56, 46, 47, 181, 177, 51, 207, 208, 198
57, 177, 181, 182, 178, 208, 209, 210, 200
58, 178, 182, 183, 179, 210, 211, 212, 202
59, 179, 183, 184, 180, 212, 213, 214, 204
60, 180, 184, 64, 65, 214, 215, 69, 206
61, 47, 48, 185, 181, 52, 216, 217, 207
62, 181, 185, 186, 182, 217, 218, 219, 209
63, 182, 186, 187, 183, 219, 220, 221, 211
64, 183, 187, 188, 184, 221, 222, 223, 213
65, 184, 188, 63, 64, 223, 224, 68, 215
66, 48, 6, 54, 185, 53, 58, 225, 216
67, 185, 54, 55, 186, 225, 59, 226, 218
68, 186, 55, 56, 187, 226, 60, 227, 220
69, 187, 56, 57, 188, 227, 61, 228, 222
70, 188, 57, 7, 63, 228, 62, 67, 224
*ELEMENT, type=CPS8, ELSET=Surface3
71, 8, 72, 229, 111, 76, 245, 246, 116
72, 111, 229, 230, 110, 246, 247, 248, 115
73, 110, 230, 231, 109, 248, 249, 250, 114
74, 109, 231, 232, 108, 250, 251, 252, 113
75, 108, 232, 36, 4, 252, 253, 40, 112
76, 72, 73, 233, 229, 77, 254, 255, 245
77, 229, 233, 234, 230, 255, 256, 257, 247
78, 230, 234, 235, 231, 257, 258, 259, 249
79, 231, 235, 236, 232, 259, 260, 261, 251
80, 232, 236, 37, 36, 261, 262, 41, 253
81, 73, 74, 237, 233, 78, 263, 264, 254
82, 233, 237, 238, 234, 264, 265, 266, 256
83, 234, 238, 239, 235, 266, 267, 268, 258
84, 235, 239, 240, 236, 268, 269, 270, 260
85, 236, 240, 38, 37, 270, 271, 42, 262
86, 74, 75, 241, 237, 79, 272, 273, 263
87, 237, 241, 242, 238, 273, 274, 275, 265
88, 238, 242, 243, 239, 275, 276, 277, 267
89, 239, 243, 244, 240, 277, 278, 279, 269
90, 240, 244, 39, 38, 279, 280, 43, 271
91, 75, 5, 84, 241, 80, 89, 281, 272
92, 241, 84, 83, 242, 281, 88, 282, 274
93, 242, 83, 82, 243, 282, 87, 283, 276
94, 243, 82, 81, 244, 283, 86, 284, 278
95, 244, 81, 1, 39, 284, 85, 44, 280
*ELEMENT, type=CPS8, ELSET=Surface4
96, 1, 9, 285, 39, 13, 301, 302, 44
97, 39, 285, 286, 38, 302, 303, 304, 43
98, 38, 286, 287, 37, 304, 305, 306, 42
99, 37, 287, 288, 36, 306, 307, 308, 41
100, 36, 288, 30, 4, 308, 309, 35, 40
101, 9, 10, 289, 285, 14, 310, 311, 301
102, 285, 289, 290, 286, 311, 312, 313, 303
103, 286, 290, 291, 287, 313, 314, 315, 305
104, 287, 291, 292, 288, 315, 316, 317, 307
105, 288, 292, 29, 30, 317, 318, 34, 309
106, 10, 11, 293, 289, 15, 319, 320, 310
107, 289, 293, 294, 290, 320, 321, 322, 312
108, 290, 294, 295, 291, 322, 323, 324, 314
109, 291, 295, 296, 292, 324, 325, 326, 316
110, 292, 296, 28, 29, 326, 327, 33, 318
111, 11, 12, 297, 293, 16, 328, 329, 319
112, 293, 297, 298, 294, 329, 330, 331, 321
113, 294, 298, 299, 295, 331, 332, 333, 323
114, 295, 299, 300, 296, 333, 334, 335, 325
115, 296, 300, 27, 28, 335, 336, 32, 327
116, 12, 2, 18, 297, 17, 22, 337, 328
117, 297, 18, 19, 298, 337, 23, 338, 330
118, 298, 19, 20, 299, 338, 24, 339, 332
119, 299, 20, 21, 300, 339, 25, 340, 334
120, 300, 21, 3, 27, 340, 26, 31, 336
*ELEMENT, type=CPS8, ELSET=Surface5
121, 4, 108, 341, 30, 112, 357, 358, 35
122, 30, 341, 342, 29, 358, 359, 360, 34
123, 29, 342, 343, 28, 360, 361, 362, 33
124, 28, 343, 344, 27, 362, 363, 364, 32
125, 27, 344, 99, 3, 364, 365, 103, 31
126, 108, 109, 345, 341, 113, 366, 367, 357
127, 341, 345, 346, 342, 367, 368, 369, 359
128, 342, 346, 347, 343, 369, 370, 371, 361
129, 343, 347, 348, 344, 371, 372, 373, 363
130, 344, 348, 100, 99, 373, 374, 104, 365
131, 109, 110, 349, 345, 114, 375, 376, 366
132, 345, 349, 350, 346, 376, 377, 378, 368
133, 346, 350, 351, 347, 378, 379, 380, 370
134, 347, 351, 352, 348, 380, 381, 382, 372
135, 348, 352, 101, 100, 382, 383, 105, 374
136, 110, 111, 353, 349, 115, 384, 385, 375
137, 349, 353, 354, 350, 385, 386, 387, 377
138, 350, 354, 355, 351, 387, 388, 389, 379
139, 351, 355, 356, 352, 389, 390, 391, 381
140, 352, 356, 102, 101, 391, 392, 106, 383
141, 111, 8, 66, 353, 116, 71, 393, 384
142, 353, 66, 65, 354, 393, 70, 394, 386
143, 354, 65, 64, 355, 394, 69, 395, 388
144, 355, 64, 63, 356, 395, 68, 396, 390
145, 356, 63, 7, 102, 396, 67, 107, 392
*ELEMENT, type=CPS8, ELSET=Surface6
146, 6, 54, 397, 93, 58, 413, 414, 98
147, 93, 397, 398, 92, 414, 415, 416, 97
148, 92, 398, 399, 91, 416, 417, 418, 96
149, 91, 399, 400, 90, 418, 419, 420, 95
150, 90, 400, 18, 2, 420, 421, 22, 94
151, 54, 55, 401, 397, 59, 422, 423, 413
152, 397, 401, 402, 398, 423, 424, 425, 415
153, 398, 402, 403, 399, 425, 426, 427, 417
154, 399, 403, 404, 400, 427, 428, 429, 419
155, 400, 404, 19, 18, 429, 430, 23, 421
156, 55, 56, 405, 401, 60, 431, 432, 422
157, 401, 405, 406, 402, 432, 433, 434, 424
158, 402, 406, 407, 403, 434, 435, 436, 426
159, 403, 407, 408, 404, 436, 437, 438, 428
160, 404, 408, 20, 19, 438, 439, 24, 430
161, 56, 57, 409, 405, 61, 440, 441, 431
162, 405, 409, 410, 406, 441, 442, 443, 433
163, 406, 410, 411, 407, 443, 444, 445, 435
164, 407, 411, 412, 408, 445, 446, 447, 437
165, 408, 412, 21, 20, 447, 448, 25, 439
166, 57, 7, 102, 409, 62, 107, 449, 440
167, 409, 102, 101, 410, 449, 106, 450, 442
168, 410, 101, 100, 411, 450, 105, 451, 444
169, 411, 100, 99, 412, 451, 104, 452, 446
170, 412, 99, 3, 21, 452, 103, 26, 448
*ELEMENT, type=C3D20, ELSET=Volume1
171, 173, 45, 5, 75, 453, 117, 84, 241, 189, 49, 80, 190, 518, 134, 281, 
519, 517, 133, 89, 272
172, 453, 117, 84, 241, 454, 118, 83, 242, 518, 134, 281, 519, 521, 136, 282, 
522, 520, 135, 88, 274
173, 454, 118, 83, 242, 455, 119, 82, 243, 521, 136, 282, 522, 524, 138, 283, 
525, 523, 137, 87, 276
174, 455, 119, 82, 243, 456, 120, 81, 244, 524, 138, 283, 525, 527, 140, 284, 
528, 526, 139, 86, 278
175, 456, 120, 81, 244, 285, 9, 1, 39, 527, 140, 284, 528, 301, 13, 44, 
302, 529, 141, 85, 280
176, 174, 173, 75, 74, 457, 453, 241, 237, 191, 190, 79, 192, 531, 519, 273, 
532, 530, 517, 272, 263
177, 457, 453, 241, 237, 458, 454, 242, 238, 531, 519, 273, 532, 534, 522, 275, 
535, 533, 520, 274, 265
178, 458, 454, 242, 238, 459, 455, 243, 239, 534, 522, 275, 535, 537, 525, 277, 
538, 536, 523, 276, 267
179, 459, 455, 243, 239, 460, 456, 244, 240, 537, 525, 277, 538, 540, 528, 279, 
541, 539, 526, 278, 269
180, 460, 456, 244, 240, 286, 285, 39, 38, 540, 528, 279, 541, 303, 302, 43, 
304, 542, 529, 280, 271
181, 175, 174, 74, 73, 461, 457, 237, 233, 193, 192, 78, 194, 544, 532, 264, 
545, 543, 530, 263, 254
182, 461, 457, 237, 233, 462, 458, 238, 234, 544, 532, 264, 545, 547, 535, 266, 
548, 546, 533, 265, 256
183, 462, 458, 238, 234, 463, 459, 239, 235, 547, 535, 266, 548, 550, 538, 268, 
551, 549, 536, 267, 258
184, 463, 459, 239, 235, 464, 460, 240, 236, 550, 538, 268, 551, 553, 541, 270, 
554, 552, 539, 269, 260
185, 464, 460, 240, 236, 287, 286, 38, 37, 553, 541, 270, 554, 305, 304, 42, 
306, 555, 542, 271, 262
186, 176, 175, 73, 72, 465, 461, 233, 229, 195, 194, 77, 196, 557, 545, 255, 
558, 556, 543, 254, 245
187, 465, 461, 233, 229, 466, 462, 234, 230, 557, 545, 255, 558, 560, 548, 257, 
561, 559, 546, 256, 247
188, 466, 462, 234, 230, 467, 463, 235, 231, 560, 548, 257, 561, 563, 551, 259, 
564, 562, 549, 258, 249
189, 467, 463, 235, 231, 468, 464, 236, 232, 563, 551, 259, 564, 566, 554, 261, 
567, 565, 552, 260, 251
190, 468, 464, 236, 232, 288, 287, 37, 36, 566, 554, 261, 567, 307, 306, 41, 
308, 568, 555, 262, 253
191, 66, 176, 72, 8, 353, 465, 229, 111, 197, 196, 76, 71, 569, 558, 246, 
384, 393, 556, 245, 116
192, 353, 465, 229, 111, 349, 466, 230, 110, 569, 558, 246, 384, 570, 561, 248, 
375, 385, 559, 247, 115
193, 349, 466, 230, 110, 345, 467, 231, 109, 570, 561, 248, 375, 571, 564, 250, 
366, 376, 562, 249, 114
194, 345, 467, 231, 109, 341, 468, 232, 108, 571, 564, 250, 366, 572, 567, 252, 
357, 367, 565, 251, 113
195, 341, 468, 232, 108, 30, 288, 36, 4, 572, 567, 252, 357, 309, 308, 40, 
35, 358, 568, 253, 112
196, 177, 46, 45, 173, 469, 121, 117, 453, 198, 50, 189, 199, 574, 143, 518, 
575, 573, 142, 133, 517
197, 469, 121, 117, 453, 470, 122, 118, 454, 574, 143, 518, 575, 577, 145, 521, 
578, 576, 144, 135, 520
198, 470, 122, 118, 454, 471, 123, 119, 455, 577, 145, 521, 578, 580, 147, 524, 
581, 579, 146, 137, 523
199, 471, 123, 119, 455, 472, 124, 120, 456, 580, 147, 524, 581, 583, 149, 527, 
584, 582, 148, 139, 526
200, 472, 124, 120, 456, 289, 10, 9, 285, 583, 149, 527, 584, 310, 14, 301, 
311, 585, 150, 141, 529
201, 178, 177, 173, 174, 473, 469, 453, 457, 200, 199, 191, 201, 587, 575, 531, 
588, 586, 573, 517, 530
202, 473, 469, 453, 457, 474, 470, 454, 458, 587, 575, 531, 588, 590, 578, 534, 
591, 589, 576, 520, 533
203, 474, 470, 454, 458, 475, 471, 455, 459, 590, 578, 534, 591, 593, 581, 537, 
594, 592, 579, 523, 536
204, 475, 471, 455, 459, 476, 472, 456, 460, 593, 581, 537, 594, 596, 584, 540, 
597, 595, 582, 526, 539
205, 476, 472, 456, 460, 290, 289, 285, 286, 596, 584, 540, 597, 312, 311, 303, 
313, 598, 585, 529, 542
206, 179, 178, 174, 175, 477, 473, 457, 461, 202, 201, 193, 203, 600, 588, 544, 
601, 599, 586, 530, 543
207, 477, 473, 457, 461, 478, 474, 458, 462, 600, 588, 544, 601, 603, 591, 547, 
604, 602, 589, 533, 546
208, 478, 474, 458, 462, 479, 475, 459, 463, 603, 591, 547, 604, 606, 594, 550, 
607, 605, 592, 536, 549
209, 479, 475, 459, 463, 480, 476, 460, 464, 606, 594, 550, 607, 609, 597, 553, 
610, 608, 595, 539, 552
210, 480, 476, 460, 464, 291, 290, 286, 287, 609, 597, 553, 610, 314, 313, 305, 
315, 611, 598, 542, 555
211, 180, 179, 175, 176, 481, 477, 461, 465, 204, 203, 195, 205, 613, 601, 557, 
614, 612, 599, 543, 556
212, 481, 477, 461, 465, 482, 478, 462, 466, 613, 601, 557, 614, 616, 604, 560, 
617, 615, 602, 546, 559
213, 482, 478, 462, 466, 483, 479, 463, 467, 616, 604, 560, 617, 619, 607, 563, 
620, 618, 605, 549, 562
214, 483, 479, 463, 467, 484, 480, 464, 468, 619, 607, 563, 620, 622, 610, 566, 
623, 621, 608, 552, 565
215, 484, 480, 464, 468, 292, 291, 287, 288, 622, 610, 566, 623, 316, 315, 307, 
317, 624, 611, 555, 568
216, 65, 180, 176, 66, 354, 481, 465, 353, 206, 205, 197, 70, 625, 614, 569, 
386, 394, 612, 556, 393
217, 354, 481, 465, 353, 350, 482, 466, 349, 625, 614, 569, 386, 626, 617, 570, 
377, 387, 615, 559, 385
218, 350, 482, 466, 349, 346, 483, 467, 345, 626, 617, 570, 377, 627, 620, 571, 
368, 378, 618, 562, 376
219, 346, 483, 467, 345, 342, 484, 468, 341, 627, 620, 571, 368, 628, 623, 572, 
359, 369, 621, 565, 367
220, 342, 484, 468, 341, 29, 292, 288, 30, 628, 623, 572, 359, 318, 317, 309, 
34, 360, 624, 568, 358
221, 181, 47, 46, 177, 485, 125, 121, 469, 207, 51, 198, 208, 630, 152, 574, 
631, 629, 151, 142, 573
222, 485, 125, 121, 469, 486, 126, 122, 470, 630, 152, 574, 631, 633, 154, 577, 
634, 632, 153, 144, 576
223, 486, 126, 122, 470, 487, 127, 123, 471, 633, 154, 577, 634, 636, 156, 580, 
637, 635, 155, 146, 579
224, 487, 127, 123, 471, 488, 128, 124, 472, 636, 156, 580, 637, 639, 158, 583, 
640, 638, 157, 148, 582
225, 488, 128, 124, 472, 293, 11, 10, 289, 639, 158, 583, 640, 319, 15, 310, 
320, 641, 159, 150, 585
226, 182, 181, 177, 178, 489, 485, 469, 473, 209, 208, 200, 210, 643, 631, 587, 
644, 642, 629, 573, 586
227, 489, 485, 469, 473, 490, 486, 470, 474, 643, 631, 587, 644, 646, 634, 590, 
647, 645, 632, 576, 589
228, 490, 486, 470, 474, 491, 487, 471, 475, 646, 634, 590, 647, 649, 637, 593, 
650, 648, 635, 579, 592
229, 491, 487, 471, 475, 492, 488, 472, 476, 649, 637, 593, 650, 652, 640, 596, 
653, 651, 638, 582, 595
230, 492, 488, 472, 476, 294, 293, 289, 290, 652, 640, 596, 653, 321, 320, 312, 
322, 654, 641, 585, 598
231, 183, 182, 178, 179, 493, 489, 473, 477, 211, 210, 202, 212, 656, 644, 600, 
657, 655, 642, 586, 599
232, 493, 489, 473, 477, 494, 490, 474, 478, 656, 644, 600, 657, 659, 647, 603, 
660, 658, 645, 589, 602
233, 494, 490, 474, 478, 495, 491, 475, 479, 659, 647, 603, 660, 662, 650, 606, 
663, 661, 648, 592, 605
234, 495, 491, 475, 479, 496, 492, 476, 480, 662, 650, 606, 663, 665, 653, 609, 
666, 664, 651, 595, 608
235, 496, 492, 476, 480, 295, 294, 290, 291, 665, 653, 609, 666, 323, 322, 314, 
324, 667, 654, 598, 611
236, 184, 183, 179, 180, 497, 493, 477, 481, 213, 212, 204, 214, 669, 657, 613, 
670, 668, 655, 599, 612
237, 497, 493, 477, 481, 498, 494, 478, 482, 669, 657, 613, 670, 672, 660, 616, 
673, 671, 658, 602, 615
238, 498, 494, 478, 482, 499, 495, 479, 483, 672, 660, 616, 673, 675, 663, 619, 
676, 674, 661, 605, 618
239, 499, 495, 479, 483, 500, 496, 480, 484, 675, 663, 619, 676, 678, 666, 622, 
679, 677, 664, 608, 621
240, 500, 496, 480, 484, 296, 295, 291, 292, 678, 666, 622, 679, 325, 324, 316, 
326, 680, 667, 611, 624
241, 64, 184, 180, 65, 355, 497, 481, 354, 215, 214, 206, 69, 681, 670, 625, 
388, 395, 668, 612, 394
242, 355, 497, 481, 354, 351, 498, 482, 350, 681, 670, 625, 388, 682, 673, 626, 
379, 389, 671, 615, 387
243, 351, 498, 482, 350, 347, 499, 483, 346, 682, 673, 626, 379, 683, 676, 627, 
370, 380, 674, 618, 378
244, 347, 499, 483, 346, 343, 500, 484, 342, 683, 676, 627, 370, 684, 679, 628, 
361, 371, 677, 621, 369
245, 343, 500, 484, 342, 28, 296, 292, 29, 684, 679, 628, 361, 327, 326, 318, 
33, 362, 680, 624, 360
246, 185, 48, 47, 181, 501, 129, 125, 485, 216, 52, 207, 217, 686, 161, 630, 
687, 685, 160, 151, 629
247, 501, 129, 125, 485, 502, 130, 126, 486, 686, 161, 630, 687, 689, 163, 633, 
690, 688, 162, 153, 632
248, 502, 130, 126, 486, 503, 131, 127, 487, 689, 163, 633, 690, 692, 165, 636, 
693, 691, 164, 155, 635
249, 503, 131, 127, 487, 504, 132, 128, 488, 692, 165, 636, 693, 695, 167, 639, 
696, 694, 166, 157, 638
250, 504, 132, 128, 488, 297, 12, 11, 293, 695, 167, 639, 696, 328, 16, 319, 
329, 697, 168, 159, 641
251, 186, 185, 181, 182, 505, 501, 485, 489, 218, 217, 209, 219, 699, 687, 643, 
700, 698, 685, 629, 642
252, 505, 501, 485, 489, 506, 502, 486, 490, 699, 687, 643, 700, 702, 690, 646, 
703, 701, 688, 632, 645
253, 506, 502, 486, 490, 507, 503, 487, 491, 702, 690, 646, 703, 705, 693, 649, 
706, 704, 691, 635, 648
254, 507, 503, 487, 491, 508, 504, 488, 492, 705, 693, 649, 706, 708, 696, 652, 
709, 707, 694, 638, 651
255, 508, 504, 488, 492, 298, 297, 293, 294, 708, 696, 652, 709, 330, 329, 321, 
331, 710, 697, 641, 654
256, 187, 186, 182, 183, 509, 505, 489, 493, 220, 219, 211, 221, 712, 700, 656, 
713, 711, 698, 642, 655
257, 509, 505, 489, 493, 510, 506, 490, 494, 712, 700, 656, 713, 715, 703, 659, 
716, 714, 701, 645, 658
258, 510, 506, 490, 494, 511, 507, 491, 495, 715, 703, 659, 716, 718, 706, 662, 
719, 717, 704, 648, 661
259, 511, 507, 491, 495, 512, 508, 492, 496, 718, 706, 662, 719, 721, 709, 665, 
722, 720, 707, 651, 664
260, 512, 508, 492, 496, 299, 298, 294, 295, 721, 709, 665, 722, 332, 331, 323, 
333, 723, 710, 654, 667
261, 188, 187, 183, 184, 513, 509, 493, 497, 222, 221, 213, 223, 725, 713, 669, 
726, 724, 711, 655, 668
262, 513, 509, 493, 497, 514, 510, 494, 498, 725, 713, 669, 726, 728, 716, 672, 
729, 727, 714, 658, 671
263, 514, 510, 494, 498, 515, 511, 495, 499, 728, 716, 672, 729, 731, 719, 675, 
732, 730, 717, 661, 674
264, 515, 511, 495, 499, 516, 512, 496, 500, 731, 719, 675, 732, 734, 722, 678, 
735, 733, 720, 664, 677
265, 516, 512, 496, 500, 300, 299, 295, 296, 734, 722, 678, 735, 334, 333, 325, 
335, 736, 723, 667, 680
266, 63, 188, 184, 64, 356, 513, 497, 355, 224, 223, 215, 68, 737, 726, 681, 
390, 396, 724, 668, 395
267, 356, 513, 497, 355, 352, 514, 498, 351, 737, 726, 681, 390, 738, 729, 682, 
381, 391, 727, 671, 389
268, 352, 514, 498, 351, 348, 515, 499, 347, 738, 729, 682, 381, 739, 732, 683, 
372, 382, 730, 674, 380
269, 348, 515, 499, 347, 344, 516, 500, 343, 739, 732, 683, 372, 740, 735, 684, 
363, 373, 733, 677, 371
270, 344, 516, 500, 343, 27, 300, 296, 28, 740, 735, 684, 363, 336, 335, 327, 
32, 364, 736, 680, 362
271, 54, 6, 48, 185, 397, 93, 129, 501, 58, 53, 216, 225, 414, 169, 686, 
741, 413, 98, 160, 685
272, 397, 93, 129, 501, 398, 92, 130, 502, 414, 169, 686, 741, 416, 170, 689, 
742, 415, 97, 162, 688
273, 398, 92, 130, 502, 399, 91, 131, 503, 416, 170, 689, 742, 418, 171, 692, 
743, 417, 96, 164, 691
274, 399, 91, 131, 503, 400, 90, 132, 504, 418, 171, 692, 743, 420, 172, 695, 
744, 419, 95, 166, 694
275, 400, 90, 132, 504, 18, 2, 12, 297, 420, 172, 695, 744, 22, 17, 328, 
337, 421, 94, 168, 697
276, 55, 54, 185, 186, 401, 397, 501, 505, 59, 225, 218, 226, 423, 741, 699, 
745, 422, 413, 685, 698
277, 401, 397, 501, 505, 402, 398, 502, 506, 423, 741, 699, 745, 425, 742, 702, 
746, 424, 415, 688, 701
278, 402, 398, 502, 506, 403, 399, 503, 507, 425, 742, 702, 746, 427, 743, 705, 
747, 426, 417, 691, 704
279, 403, 399, 503, 507, 404, 400, 504, 508, 427, 743, 705, 747, 429, 744, 708, 
748, 428, 419, 694, 707
280, 404, 400, 504, 508, 19, 18, 297, 298, 429, 744, 708, 748, 23, 337, 330, 
338, 430, 421, 697, 710
281, 56, 55, 186, 187, 405, 401, 505, 509, 60, 226, 220, 227, 432, 745, 712, 
749, 431, 422, 698, 711
282, 405, 401, 505, 509, 406, 402, 506, 510, 432, 745, 712, 749, 434, 746, 715, 
750, 433, 424, 701, 714
283, 406, 402, 506, 510, 407, 403, 507, 511, 434, 746, 715, 750, 436, 747, 718, 
751, 435, 426, 704, 717
284, 407, 403, 507, 511, 408, 404, 508, 512, 436, 747, 718, 751, 438, 748, 721, 
752, 437, 428, 707, 720
285, 408, 404, 508, 512, 20, 19, 298, 299, 438, 748, 721, 752, 24, 338, 332, 
339, 439, 430, 710, 723
286, 57, 56, 187, 188, 409, 405, 509, 513, 61, 227, 222, 228, 441, 749, 725, 
753, 440, 431, 711, 724
287, 409, 405, 509, 513, 410, 406, 510, 514, 441, 749, 725, 753, 443, 750, 728, 
754, 442, 433, 714, 727
288, 410, 406, 510, 514, 411, 407, 511, 515, 443, 750, 728, 754, 445, 751, 731, 
755, 444, 435, 717, 730
289, 411, 407, 511, 515, 412, 408, 512, 516, 445, 751, 731, 755, 447, 752, 734, 
756, 446, 437, 720, 733
290, 412, 408, 512, 516, 21, 20, 299, 300, 447, 752, 734, 756, 25, 339, 334, 
340, 448, 439, 723, 736
291, 7, 57, 188, 63, 102, 409, 513, 356, 62, 228, 224, 67, 449, 753, 737, 
392, 107, 440, 724, 396
292, 102, 409, 513, 356, 101, 410, 514, 352, 449, 753, 737, 392, 450, 754, 738, 
383, 106, 442, 727, 391
293, 101, 410, 514, 352, 100, 411, 515, 348, 450, 754, 738, 383, 451, 755, 739, 
374, 105, 444, 730, 382
294, 100, 411, 515, 348, 99, 412, 516, 344, 451, 755, 739, 374, 452, 756, 740, 
365, 104, 446, 733, 373
295, 99, 412, 516, 344, 3, 21, 300, 27, 452, 756, 740, 365, 26, 340, 336, 
31, 103, 448, 736, 364
*ELSET,ELSET=Ymin_line
11, 12, 13, 14, 15, 
*ELSET,ELSET=Zmax_line
6, 7, 8, 9, 10, 
*ELSET,ELSET=Zmin_line
1, 2, 3, 4, 5, 
*ELSET,ELSET=Ymax_line
16, 17, 18, 19, 20, 
*ELSET,ELSET=Ymax
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 
*ELSET,ELSET=Ymin
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 
*ELSET,ELSET=Zmax
46, 47, 48, 49, 50, 51, 52, 53, 54, 55, 
56, 57, 58, 59, 60, 61, 62, 63, 64, 65, 
66, 67, 68, 69, 70, 
*ELSET,ELSET=Zmin
96, 97, 98, 99, 100, 101, 102, 103, 104, 105, 
106, 107, 108, 109, 110, 111, 112, 113, 114, 115, 
116, 117, 118, 119, 120, 
*ELSET,ELSET=Xmin
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 
*ELSET,ELSET=Xmax
146, 147, 148, 149, 150, 151, 152, 153, 154, 155, 
156, 157, 158, 159, 160, 161, 162, 163, 164, 165, 
166, 167, 168, 169, 170, 
*ELSET,ELSET=Surface
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 
*ELSET,ELSET=Volume
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 
*NSET,NSET=Ymin_line
1, 5, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 
*NSET,NSET=Zmax_line
5, 8, 72, 73, 74, 75, 76, 77, 78, 79, 
80, 
*NSET,NSET=Zmin_line
1, 4, 36, 37, 38, 39, 40, 41, 42, 43, 
44, 
*NSET,NSET=Ymax_line
4, 8, 108, 109, 110, 111, 112, 113, 114, 115, 
116, 
*NSET,NSET=Ymax
3, 4, 7, 8, 27, 28, 29, 30, 31, 32, 
33, 34, 35, 63, 64, 65, 66, 67, 68, 69, 
70, 71, 99, 100, 101, 102, 103, 104, 105, 106, 
107, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 
*NSET,NSET=Ymin
1, 2, 5, 6, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 45, 46, 47, 48, 49, 50, 51, 
52, 53, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 90, 91, 92, 93, 94, 95, 96, 97, 98, 
117, 118, 119, 120, 121, 122, 123, 124, 125, 126, 
127, 128, 129, 130, 131, 132, 133, 134, 135, 136, 
137, 138, 139, 140, 141, 142, 143, 144, 145, 146, 
147, 148, 149, 150, 151, 152, 153, 154, 155, 156, 
157, 158, 159, 160, 161, 162, 163, 164, 165, 166, 
167, 168, 169, 170, 171, 172, 
*NSET,NSET=Zmax
5, 6, 7, 8, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
173, 174, 175, 176, 177, 178, 179, 180, 181, 182, 
183, 184, 185, 186, 187, 188, 189, 190, 191, 192, 
193, 194, 195, 196, 197, 198, 199, 200, 201, 202, 
203, 204, 205, 206, 207, 208, 209, 210, 211, 212, 
213, 214, 215, 216, 217, 218, 219, 220, 221, 222, 
223, 224, 225, 226, 227, 228, 
*NSET,NSET=Zmin
1, 2, 3, 4, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 21, 22, 23, 24, 
25, 26, 27, 28, 29, 30, 31, 32, 33, 34, 
35, 36, 37, 38, 39, 40, 41, 42, 43, 44, 
285, 286, 287, 288, 289, 290, 291, 292, 293, 294, 
295, 296, 297, 298, 299, 300, 301, 302, 303, 304, 
305, 306, 307, 308, 309, 310, 311, 312, 313, 314, 
315, 316, 317, 318, 319, 320, 321, 322, 323, 324, 
325, 326, 327, 328, 329, 330, 331, 332, 333, 334, 
335, 336, 337, 338, 339, 340, 
*NSET,NSET=Xmin
1, 4, 5, 8, 36, 37, 38, 39, 40, 41, 
42, 43, 44, 72, 73, 74, 75, 76, 77, 78, 
79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 
259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
279, 280, 281, 282, 283, 284, 
*NSET,NSET=Xmax
2, 3, 6, 7, 18, 19, 20, 21, 22, 23, 
24, 25, 26, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 90, 91, 92, 93, 94, 95, 96, 97, 
98, 99, 100, 101, 102, 103, 104, 105, 106, 107, 
397, 398, 399, 400, 401, 402, 403, 404, 405, 406, 
407, 408, 409, 410, 411, 412, 413, 414, 415, 416, 
417, 418, 419, 420, 421, 422, 423, 424, 425, 426, 
427, 428, 429, 430, 431, 432, 433, 434, 435, 436, 
437, 438, 439, 440, 441, 442, 443, 444, 445, 446, 
447, 448, 449, 450, 451, 452, 
*NSET,NSET=Surface
1, 4, 5, 8, 36, 37, 38, 39, 40, 41, 
42, 43, 44, 72, 73, 74, 75, 76, 77, 78, 
79, 80, 81, 82, 83, 84, 85, 86, 87, 88, 
89, 108, 109, 110, 111, 112, 113, 114, 115, 116, 
229, 230, 231, 232, 233, 234, 235, 236, 237, 238, 
239, 240, 241, 242, 243, 244, 245, 246, 247, 248, 
249, 250, 251, 252, 253, 254, 255, 256, 257, 258, 
259, 260, 261, 262, 263, 264, 265, 266, 267, 268, 
269, 270, 271, 272, 273, 274, 275, 276, 277, 278, 
279, 280, 281, 282, 283, 284, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 82, 83, 84, 85, 86, 87, 88, 89, 90, 
91, 92, 93, 94, 95, 96, 97, 98, 99, 100, 
101, 102, 103, 104, 105, 106, 107, 108, 109, 110, 
111, 112, 113, 114, 115, 116, 117, 118, 119, 120, 
121, 122, 123, 124, 125, 126, 127, 128, 129, 130, 
131, 132, 133, 134, 135, 136, 137, 138, 139, 140, 
141, 142, 143, 144, 145, 146, 147, 148, 149, 150, 
151, 152, 153, 154, 155, 156, 157, 158, 159, 160, 
161, 162, 163, 164, 165, 166, 167, 168, 169, 170, 
171, 172, 173, 174, 175, 176, 177, 178, 179, 180, 
181, 182, 183, 184, 185, 186, 187, 188, 189, 190, 
191, 192, 193, 194, 195, 196, 197, 198, 199, 200, 
201, 202, 203, 204, 205, 206, 207, 208, 209, 210, 
211, 212, 213, 214, 215, 216, 217, 218, 219, 220, 
221, 222, 223, 224, 225, 226, 227, 228, 229, 230, 
231, 232, 233, 234, 235, 236, 237, 238, 239, 240, 
241, 242, 243, 244, 245, 246, 247, 248, 249, 250, 
251, 252, 253, 254, 255, 256, 257, 258, 259, 260, 
261, 262, 263, 264, 265, 266, 267, 268, 269, 270, 
271, 272, 273, 274, 275, 276, 277, 278, 279, 280, 
281, 282, 283, 284, 285, 286, 287, 288, 289, 290, 
291, 292, 293, 294, 295, 296, 297, 298, 299, 300, 
301, 302, 303, 304, 305, 306, 307, 308, 309, 310, 
311, 312, 313, 314, 315, 316, 317, 318, 319, 320, 
321, 322, 323, 324, 325, 326, 327, 328, 329, 330, 
331, 332, 333, 334, 335, 336, 337, 338, 339, 340, 
341, 342, 343, 344, 345, 346, 347, 348, 349, 350, 
351, 352, 353, 354, 355, 356, 357, 358, 359, 360, 
361, 362, 363, 364, 365, 366, 367, 368, 369, 370, 
371, 372, 373, 374, 375, 376, 377, 378, 379, 380, 
381, 382, 383, 384, 385, 386, 387, 388, 389, 390, 
391, 392, 393, 394, 395, 396, 397, 398, 399, 400, 
401, 402, 403, 404, 405, 406, 407, 408, 409, 410, 
411, 412, 413, 414, 415, 416, 417, 418, 419, 420, 
421, 422, 423, 424, 425, 426, 427, 428, 429, 430, 
431, 432, 433, 434, 435, 436, 437, 438, 439, 440, 
441, 442, 443, 444, 445, 446, 447, 448, 449, 450, 
451, 452, 453, 454, 455, 456, 457, 458, 459, 460, 
461, 462, 463, 464, 465, 466, 467, 468, 469, 470, 
471, 472, 473, 474, 475, 476, 477, 478, 479, 480, 
481, 482, 483, 484, 485, 486, 487, 488, 489, 490, 
491, 492, 493, 494, 495, 496, 497, 498, 499, 500, 
501, 502, 503, 504, 505, 506, 507, 508, 509, 510, 
511, 512, 513, 514, 515, 516, 517, 518, 519, 520, 
521, 522, 523, 524, 525, 526, 527, 528, 529, 530, 
531, 532, 533, 534, 535, 536, 537, 538, 539, 540, 
541, 542, 543, 544, 545, 546, 547, 548, 549, 550, 
551, 552, 553, 554, 555, 556, 557, 558, 559, 560, 
561, 562, 563, 564, 565, 566, 567, 568, 569, 570, 
571, 572, 573, 574, 575, 576, 577, 578, 579, 580, 
581, 582, 583, 584, 585, 586, 587, 588, 589, 590, 
591, 592, 593, 594, 595, 596, 597, 598, 599, 600, 
601, 602, 603, 604, 605, 606, 607, 608, 609, 610, 
611, 612, 613, 614, 615, 616, 617, 618, 619, 620, 
621, 622, 623, 624, 625, 626, 627, 628, 629, 630, 
631, 632, 633, 634, 635, 636, 637, 638, 639, 640, 
641, 642, 643, 644, 645, 646, 647, 648, 649, 650, 
651, 652, 653, 654, 655, 656, 657, 658, 659, 660, 
661, 662, 663, 664, 665, 666, 667, 668, 669, 670, 
671, 672, 673, 674, 675, 676, 677, 678, 679, 680, 
681, 682, 683, 684, 685, 686, 687, 688, 689, 690, 
691, 692, 693, 694, 695, 696, 697, 698, 699, 700, 
701, 702, 703, 704, 705, 706, 707, 708, 709, 710, 
711, 712, 713, 714, 715, 716, 717, 718, 719, 720, 
721, 722, 723, 724, 725, 726, 727, 728, 729, 730, 
731, 732, 733, 734, 735, 736, 737, 738, 739, 740, 
741, 742, 743, 744, 745, 746, 747, 748, 749, 750, 
751, 752, 753, 754, 755, 756, 
