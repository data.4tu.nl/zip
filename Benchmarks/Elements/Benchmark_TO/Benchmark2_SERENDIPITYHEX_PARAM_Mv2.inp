*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\Benchmarks\Elements\Benchmark_TO\Benchmark2_SERENDIPITYHEX_PARAM_Mv2.inp
*NODE
1, 0, 0, 0
2, 0.0014, 0, 0
3, 0.0014, 0.001524, 0
4, 0, 0.001524, 0
5, 0, 0, 0.0014
6, 0.0014, 0, 0.0014
7, 0.0014, 0.001524, 0.0014
8, 0, 0.001524, 0.0014
9, 0.00069999999999812, 0, 0
10, 0.00034999999999933, 0, 0
11, 0.0010499999999989, 0, 0
12, 0.0014, 0.00076199999999801, 0
13, 0.0014, 0.00038099999999921, 0
14, 0.0014, 0.001142999999999, 0
15, 0.00070000000000195, 0.001524, 0
16, 0.001050000000001, 0.001524, 0
17, 0.00035000000000095, 0.001524, 0
18, 0, 0.00076200000000203, 0
19, 0, 0.001143000000001, 0
20, 0, 0.00038100000000102, 0
21, 0.00069999999999812, 0, 0.0014
22, 0.00034999999999933, 0, 0.0014
23, 0.0010499999999989, 0, 0.0014
24, 0.0014, 0.00076199999999801, 0.0014
25, 0.0014, 0.00038099999999921, 0.0014
26, 0.0014, 0.001142999999999, 0.0014
27, 0.00070000000000195, 0.001524, 0.0014
28, 0.001050000000001, 0.001524, 0.0014
29, 0.00035000000000095, 0.001524, 0.0014
30, 0, 0.00076200000000203, 0.0014
31, 0, 0.001143000000001, 0.0014
32, 0, 0.00038100000000102, 0.0014
33, 0, 0, 0.00069999999999812
34, 0, 0, 0.00034999999999933
35, 0, 0, 0.0010499999999989
36, 0.0014, 0, 0.00069999999999812
37, 0.0014, 0, 0.00034999999999933
38, 0.0014, 0, 0.0010499999999989
39, 0.0014, 0.001524, 0.00069999999999812
40, 0.0014, 0.001524, 0.00034999999999933
41, 0.0014, 0.001524, 0.0010499999999989
42, 0, 0.001524, 0.00069999999999812
43, 0, 0.001524, 0.00034999999999933
44, 0, 0.001524, 0.0010499999999989
45, 0.00069999999999812, 0, 0.00069999999999812
46, 0.00069999999999812, 0, 0.0010499999999991
47, 0.00034999999999906, 0, 0.00069999999999812
48, 0.00069999999999812, 0, 0.00034999999999906
49, 0.0010499999999991, 0, 0.00069999999999812
50, 0.00070000000000003, 0.00076200000000002, 0.0014
51, 0.00069999999999908, 0.00038100000000001, 0.0014
52, 0.00035000000000002, 0.00076200000000102, 0.0014
53, 0.00070000000000099, 0.001143, 0.0014
54, 0.00105, 0.00076199999999901, 0.0014
55, 0, 0.00076200000000203, 0.00069999999999812
56, 0, 0.00076200000000203, 0.0010499999999991
57, 0, 0.001143000000001, 0.00069999999999812
58, 0, 0.00076200000000203, 0.00034999999999906
59, 0, 0.00038100000000102, 0.00069999999999812
60, 0.00070000000000003, 0.00076200000000002, 0
61, 0.00069999999999908, 0.00038100000000001, 0
62, 0.00035000000000002, 0.00076200000000102, 0
63, 0.00070000000000099, 0.001143, 0
64, 0.00105, 0.00076199999999901, 0
65, 0.00070000000000195, 0.001524, 0.00069999999999812
66, 0.00035000000000097, 0.001524, 0.00069999999999812
67, 0.00070000000000195, 0.001524, 0.00034999999999906
68, 0.001050000000001, 0.001524, 0.00069999999999812
69, 0.00070000000000195, 0.001524, 0.0010499999999991
70, 0.0014, 0.00076199999999801, 0.00069999999999812
71, 0.0014, 0.00076199999999801, 0.0010499999999991
72, 0.0014, 0.000380999999999, 0.00069999999999812
73, 0.0014, 0.00076199999999801, 0.00034999999999906
74, 0.0014, 0.001142999999999, 0.00069999999999812
75, 0.00070000000000003, 0.00076200000000002, 0.00069999999999812
76, 0.00070000000000003, 0.00076200000000002, 0.0010499999999991
77, 0.00069999999999908, 0.00038100000000001, 0.00069999999999812
78, 0.00035000000000002, 0.00076200000000102, 0.00069999999999812
79, 0.00070000000000003, 0.00076200000000002, 0.00034999999999906
80, 0.00070000000000099, 0.001143, 0.00069999999999812
81, 0.00105, 0.00076199999999901, 0.00069999999999812
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
41, 1, 10, 9
42, 9, 11, 2
*ELEMENT, type=T3D3, ELSET=Line2
43, 2, 13, 12
44, 12, 14, 3
*ELEMENT, type=T3D3, ELSET=Line3
45, 3, 16, 15
46, 15, 17, 4
*ELEMENT, type=T3D3, ELSET=Line4
47, 4, 19, 18
48, 18, 20, 1
*ELEMENT, type=T3D3, ELSET=Line5
49, 5, 22, 21
50, 21, 23, 6
*ELEMENT, type=T3D3, ELSET=Line6
51, 6, 25, 24
52, 24, 26, 7
*ELEMENT, type=T3D3, ELSET=Line7
53, 7, 28, 27
54, 27, 29, 8
*ELEMENT, type=T3D3, ELSET=Line8
55, 8, 31, 30
56, 30, 32, 5
*ELEMENT, type=T3D3, ELSET=Line9
57, 1, 34, 33
58, 33, 35, 5
*ELEMENT, type=T3D3, ELSET=Line10
59, 2, 37, 36
60, 36, 38, 6
*ELEMENT, type=T3D3, ELSET=Line11
61, 3, 40, 39
62, 39, 41, 7
*ELEMENT, type=T3D3, ELSET=Line12
63, 4, 43, 42
64, 42, 44, 8
*ELEMENT, type=CPS8, ELSET=Surface1
1, 5, 21, 45, 33, 22, 46, 47, 35
2, 33, 45, 9, 1, 47, 48, 10, 34
3, 21, 6, 36, 45, 23, 38, 49, 46
4, 45, 36, 2, 9, 49, 37, 11, 48
*ELEMENT, type=CPS8, ELSET=Surface2
5, 5, 21, 50, 30, 22, 51, 52, 32
6, 30, 50, 27, 8, 52, 53, 29, 31
7, 21, 6, 24, 50, 23, 25, 54, 51
8, 50, 24, 7, 27, 54, 26, 28, 53
*ELEMENT, type=CPS8, ELSET=Surface3
9, 8, 30, 55, 42, 31, 56, 57, 44
10, 42, 55, 18, 4, 57, 58, 19, 43
11, 30, 5, 33, 55, 32, 35, 59, 56
12, 55, 33, 1, 18, 59, 34, 20, 58
*ELEMENT, type=CPS8, ELSET=Surface4
13, 1, 9, 60, 18, 10, 61, 62, 20
14, 18, 60, 15, 4, 62, 63, 17, 19
15, 9, 2, 12, 60, 11, 13, 64, 61
16, 60, 12, 3, 15, 64, 14, 16, 63
*ELEMENT, type=CPS8, ELSET=Surface5
17, 4, 42, 65, 15, 43, 66, 67, 17
18, 15, 65, 39, 3, 67, 68, 40, 16
19, 42, 8, 27, 65, 44, 29, 69, 66
20, 65, 27, 7, 39, 69, 28, 41, 68
*ELEMENT, type=CPS8, ELSET=Surface6
21, 6, 24, 70, 36, 25, 71, 72, 38
22, 36, 70, 12, 2, 72, 73, 13, 37
23, 24, 7, 39, 70, 26, 41, 74, 71
24, 70, 39, 3, 12, 74, 40, 14, 73
*ELEMENT, type=C3D20, ELSET=Volume1
25, 50, 21, 5, 30, 75, 45, 33, 55, 51, 22, 32, 52, 77, 47, 59, 
78, 76, 46, 35, 56
26, 75, 45, 33, 55, 60, 9, 1, 18, 77, 47, 59, 78, 61, 10, 20, 
62, 79, 48, 34, 58
27, 27, 50, 30, 8, 65, 75, 55, 42, 53, 52, 31, 29, 80, 78, 57, 
66, 69, 76, 56, 44
28, 65, 75, 55, 42, 15, 60, 18, 4, 80, 78, 57, 66, 63, 62, 19, 
17, 67, 79, 58, 43
29, 24, 6, 21, 50, 70, 36, 45, 75, 25, 23, 51, 54, 72, 49, 77, 
81, 71, 38, 46, 76
30, 70, 36, 45, 75, 12, 2, 9, 60, 72, 49, 77, 81, 13, 11, 61, 
64, 73, 37, 48, 79
31, 7, 24, 50, 27, 39, 70, 75, 65, 26, 54, 53, 28, 74, 81, 80, 
68, 41, 71, 76, 69
32, 39, 70, 75, 65, 3, 12, 60, 15, 74, 81, 80, 68, 14, 64, 63, 
16, 40, 73, 79, 67
*ELSET,ELSET=Ymax
17, 18, 19, 20, 
*ELSET,ELSET=Ymin
1, 2, 3, 4, 
*ELSET,ELSET=Zmax
5, 6, 7, 8, 
*ELSET,ELSET=Zmin
13, 14, 15, 16, 
*ELSET,ELSET=Xmin
9, 10, 11, 12, 
*ELSET,ELSET=Xmax
21, 22, 23, 24, 
*ELSET,ELSET=Volume
25, 26, 27, 28, 29, 30, 31, 32, 
*NSET,NSET=Ymax
3, 4, 7, 8, 15, 16, 17, 27, 28, 29, 
39, 40, 41, 42, 43, 44, 65, 66, 67, 68, 
69, 
*NSET,NSET=Ymin
1, 2, 5, 6, 9, 10, 11, 21, 22, 23, 
33, 34, 35, 36, 37, 38, 45, 46, 47, 48, 
49, 
*NSET,NSET=Zmax
5, 6, 7, 8, 21, 22, 23, 24, 25, 26, 
27, 28, 29, 30, 31, 32, 50, 51, 52, 53, 
54, 
*NSET,NSET=Zmin
1, 2, 3, 4, 9, 10, 11, 12, 13, 14, 
15, 16, 17, 18, 19, 20, 60, 61, 62, 63, 
64, 
*NSET,NSET=Xmin
1, 4, 5, 8, 18, 19, 20, 30, 31, 32, 
33, 34, 35, 42, 43, 44, 55, 56, 57, 58, 
59, 
*NSET,NSET=Xmax
2, 3, 6, 7, 12, 13, 14, 24, 25, 26, 
36, 37, 38, 39, 40, 41, 70, 71, 72, 73, 
74, 
*NSET,NSET=Volume
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 33, 34, 35, 36, 37, 38, 39, 40, 
41, 42, 43, 44, 45, 46, 47, 48, 49, 50, 
51, 52, 53, 54, 55, 56, 57, 58, 59, 60, 
61, 62, 63, 64, 65, 66, 67, 68, 69, 70, 
71, 72, 73, 74, 75, 76, 77, 78, 79, 80, 
81, 
