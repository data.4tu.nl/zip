22138, 0.43478260869565, 0.56739130434783, 0.5
22139, 0.39130434782609, 0.56739130434783, 0.5
22140, 0.34782608695652, 0.56739130434783, 0.5
22141, 0.30434782608696, 0.56739130434783, 0.5
22142, 0.26086956521739, 0.56739130434783, 0.5
22143, 0.21739130434783, 0.56739130434783, 0.5
22144, 0.17391304347826, 0.56739130434783, 0.5
22145, 0.1304347826087, 0.56739130434783, 0.5
22146, 0.08695652173913, 0.56739130434783, 0.5
22147, 0.043478260869565, 0.56739130434783, 0.5
22148, 0.95652173913043, 0.6195652173913, 0.5
22149, 0.91304347826087, 0.6195652173913, 0.5
22150, 0.8695652173913, 0.6195652173913, 0.5
22151, 0.82608695652174, 0.6195652173913, 0.5
22152, 0.78260869565217, 0.6195652173913, 0.5
22153, 0.73913043478261, 0.6195652173913, 0.5
22154, 0.69565217391304, 0.6195652173913, 0.5
22155, 0.65217391304348, 0.6195652173913, 0.5
22156, 0.60869565217391, 0.6195652173913, 0.5
22157, 0.56521739130435, 0.6195652173913, 0.5
22158, 0.52173913043478, 0.6195652173913, 0.5
22159, 0.47826086956522, 0.6195652173913, 0.5
22160, 0.43478260869565, 0.6195652173913, 0.5
22161, 0.39130434782609, 0.6195652173913, 0.5
22162, 0.34782608695652, 0.6195652173913, 0.5
22163, 0.30434782608696, 0.6195652173913, 0.5
22164, 0.26086956521739, 0.6195652173913, 0.5
22165, 0.21739130434783, 0.6195652173913, 0.5
22166, 0.17391304347826, 0.6195652173913, 0.5
22167, 0.1304347826087, 0.6195652173913, 0.5
22168, 0.08695652173913, 0.6195652173913, 0.5
22169, 0.043478260869565, 0.6195652173913, 0.5
22170, 0.95652173913043, 0.67173913043478, 0.5
22171, 0.91304347826087, 0.67173913043478, 0.5
22172, 0.8695652173913, 0.67173913043478, 0.5
22173, 0.82608695652174, 0.67173913043478, 0.5
22174, 0.78260869565217, 0.67173913043478, 0.5
22175, 0.73913043478261, 0.67173913043478, 0.5
22176, 0.69565217391304, 0.67173913043478, 0.5
22177, 0.65217391304348, 0.67173913043478, 0.5
22178, 0.60869565217391, 0.67173913043478, 0.5
22179, 0.56521739130435, 0.67173913043478, 0.5
22180, 0.52173913043478, 0.67173913043478, 0.5
22181, 0.47826086956522, 0.67173913043478, 0.5
22182, 0.43478260869565, 0.67173913043478, 0.5
22183, 0.39130434782609, 0.67173913043478, 0.5
22184, 0.34782608695652, 0.67173913043478, 0.5
22185, 0.30434782608696, 0.67173913043478, 0.5
22186, 0.26086956521739, 0.67173913043478, 0.5
22187, 0.21739130434783, 0.67173913043478, 0.5
22188, 0.17391304347826, 0.67173913043478, 0.5
22189, 0.1304347826087, 0.67173913043478, 0.5
22190, 0.08695652173913, 0.67173913043478, 0.5
22191, 0.043478260869565, 0.67173913043478, 0.5
22192, 0.95652173913043, 0.72391304347826, 0.5
22193, 0.91304347826087, 0.72391304347826, 0.5
22194, 0.8695652173913, 0.72391304347826, 0.5
22195, 0.82608695652174, 0.72391304347826, 0.5
22196, 0.78260869565217, 0.72391304347826, 0.5
22197, 0.73913043478261, 0.72391304347826, 0.5
22198, 0.69565217391304, 0.72391304347826, 0.5
22199, 0.65217391304348, 0.72391304347826, 0.5
22200, 0.60869565217391, 0.72391304347826, 0.5
22201, 0.56521739130435, 0.72391304347826, 0.5
22202, 0.52173913043478, 0.72391304347826, 0.5
22203, 0.47826086956522, 0.72391304347826, 0.5
22204, 0.43478260869565, 0.72391304347826, 0.5
22205, 0.39130434782609, 0.72391304347826, 0.5
22206, 0.34782608695652, 0.72391304347826, 0.5
22207, 0.30434782608696, 0.72391304347826, 0.5
22208, 0.26086956521739, 0.72391304347826, 0.5
22209, 0.21739130434783, 0.72391304347826, 0.5
22210, 0.17391304347826, 0.72391304347826, 0.5
22211, 0.1304347826087, 0.72391304347826, 0.5
22212, 0.08695652173913, 0.72391304347826, 0.5
22213, 0.043478260869565, 0.72391304347826, 0.5
22214, 0.95652173913043, 0.77608695652174, 0.5
22215, 0.91304347826087, 0.77608695652174, 0.5
22216, 0.8695652173913, 0.77608695652174, 0.5
22217, 0.82608695652174, 0.77608695652174, 0.5
22218, 0.78260869565217, 0.77608695652174, 0.5
22219, 0.73913043478261, 0.77608695652174, 0.5
22220, 0.69565217391304, 0.77608695652174, 0.5
22221, 0.65217391304348, 0.77608695652174, 0.5
22222, 0.60869565217391, 0.77608695652174, 0.5
22223, 0.56521739130435, 0.77608695652174, 0.5
22224, 0.52173913043478, 0.77608695652174, 0.5
22225, 0.47826086956522, 0.77608695652174, 0.5
22226, 0.43478260869565, 0.77608695652174, 0.5
22227, 0.39130434782609, 0.77608695652174, 0.5
22228, 0.34782608695652, 0.77608695652174, 0.5
22229, 0.30434782608696, 0.77608695652174, 0.5
22230, 0.26086956521739, 0.77608695652174, 0.5
22231, 0.21739130434783, 0.77608695652174, 0.5
22232, 0.17391304347826, 0.77608695652174, 0.5
22233, 0.1304347826087, 0.77608695652174, 0.5
22234, 0.08695652173913, 0.77608695652174, 0.5
22235, 0.043478260869565, 0.77608695652174, 0.5
22236, 0.95652173913043, 0.82826086956522, 0.5
22237, 0.91304347826087, 0.82826086956522, 0.5
22238, 0.8695652173913, 0.82826086956522, 0.5
22239, 0.82608695652174, 0.82826086956522, 0.5
22240, 0.78260869565217, 0.82826086956522, 0.5
22241, 0.73913043478261, 0.82826086956522, 0.5
22242, 0.69565217391304, 0.82826086956522, 0.5
22243, 0.65217391304348, 0.82826086956522, 0.5
22244, 0.60869565217391, 0.82826086956522, 0.5
22245, 0.56521739130435, 0.82826086956522, 0.5
22246, 0.52173913043478, 0.82826086956522, 0.5
22247, 0.47826086956522, 0.82826086956522, 0.5
22248, 0.43478260869565, 0.82826086956522, 0.5
22249, 0.39130434782609, 0.82826086956522, 0.5
22250, 0.34782608695652, 0.82826086956522, 0.5
22251, 0.30434782608696, 0.82826086956522, 0.5
22252, 0.26086956521739, 0.82826086956522, 0.5
22253, 0.21739130434783, 0.82826086956522, 0.5
22254, 0.17391304347826, 0.82826086956522, 0.5
22255, 0.1304347826087, 0.82826086956522, 0.5
22256, 0.08695652173913, 0.82826086956522, 0.5
22257, 0.043478260869565, 0.82826086956522, 0.5
22258, 0.95652173913043, 0.8804347826087, 0.5
22259, 0.91304347826087, 0.8804347826087, 0.5
22260, 0.8695652173913, 0.88043478260869, 0.5
22261, 0.82608695652174, 0.8804347826087, 0.5
22262, 0.78260869565217, 0.8804347826087, 0.5
22263, 0.73913043478261, 0.8804347826087, 0.5
22264, 0.69565217391304, 0.8804347826087, 0.5
22265, 0.65217391304348, 0.8804347826087, 0.5
22266, 0.60869565217391, 0.8804347826087, 0.5
22267, 0.56521739130435, 0.8804347826087, 0.5
22268, 0.52173913043478, 0.88043478260869, 0.5
22269, 0.47826086956522, 0.8804347826087, 0.5
22270, 0.43478260869565, 0.8804347826087, 0.5
22271, 0.39130434782609, 0.88043478260869, 0.5
22272, 0.34782608695652, 0.8804347826087, 0.5
22273, 0.30434782608696, 0.8804347826087, 0.5
22274, 0.26086956521739, 0.8804347826087, 0.5
22275, 0.21739130434783, 0.8804347826087, 0.5
22276, 0.17391304347826, 0.8804347826087, 0.5
22277, 0.1304347826087, 0.8804347826087, 0.5
22278, 0.08695652173913, 0.8804347826087, 0.5
22279, 0.043478260869565, 0.8804347826087, 0.5
22280, 0.95652173913043, 0.93260869565217, 0.5
22281, 0.91304347826087, 0.93260869565217, 0.5
22282, 0.8695652173913, 0.93260869565217, 0.5
22283, 0.82608695652174, 0.93260869565217, 0.5
22284, 0.78260869565217, 0.93260869565217, 0.5
22285, 0.73913043478261, 0.93260869565217, 0.5
22286, 0.69565217391304, 0.93260869565217, 0.5
22287, 0.65217391304348, 0.93260869565217, 0.5
22288, 0.60869565217391, 0.93260869565217, 0.5
22289, 0.56521739130435, 0.93260869565217, 0.5
22290, 0.52173913043478, 0.93260869565217, 0.5
22291, 0.47826086956522, 0.93260869565217, 0.5
22292, 0.43478260869565, 0.93260869565217, 0.5
22293, 0.39130434782609, 0.93260869565217, 0.5
22294, 0.34782608695652, 0.93260869565217, 0.5
22295, 0.30434782608696, 0.93260869565217, 0.5
22296, 0.26086956521739, 0.93260869565217, 0.5
22297, 0.21739130434783, 0.93260869565217, 0.5
22298, 0.17391304347826, 0.93260869565217, 0.5
22299, 0.1304347826087, 0.93260869565217, 0.5
22300, 0.08695652173913, 0.93260869565217, 0.5
22301, 0.043478260869565, 0.93260869565217, 0.5
22302, 0.95652173913043, 0.98478260869565, 0.5
22303, 0.91304347826087, 0.98478260869565, 0.5
22304, 0.8695652173913, 0.98478260869565, 0.5
22305, 0.82608695652174, 0.98478260869565, 0.5
22306, 0.78260869565217, 0.98478260869565, 0.5
22307, 0.73913043478261, 0.98478260869565, 0.5
22308, 0.69565217391304, 0.98478260869565, 0.5
22309, 0.65217391304348, 0.98478260869565, 0.5
22310, 0.60869565217391, 0.98478260869565, 0.5
22311, 0.56521739130435, 0.98478260869565, 0.5
22312, 0.52173913043478, 0.98478260869565, 0.5
22313, 0.47826086956522, 0.98478260869565, 0.5
22314, 0.43478260869565, 0.98478260869565, 0.5
22315, 0.39130434782609, 0.98478260869565, 0.5
22316, 0.34782608695652, 0.98478260869565, 0.5
22317, 0.30434782608696, 0.98478260869565, 0.5
22318, 0.26086956521739, 0.98478260869565, 0.5
22319, 0.21739130434783, 0.98478260869565, 0.5
22320, 0.17391304347826, 0.98478260869565, 0.5
22321, 0.1304347826087, 0.98478260869565, 0.5
22322, 0.08695652173913, 0.98478260869565, 0.5
22323, 0.043478260869565, 0.98478260869565, 0.5
22324, 0.95652173913043, 1.0369565217391, 0.5
22325, 0.91304347826087, 1.0369565217391, 0.5
22326, 0.8695652173913, 1.0369565217391, 0.5
22327, 0.82608695652174, 1.0369565217391, 0.5
22328, 0.78260869565217, 1.0369565217391, 0.5
22329, 0.73913043478261, 1.0369565217391, 0.5
22330, 0.69565217391304, 1.0369565217391, 0.5
22331, 0.65217391304348, 1.0369565217391, 0.5
22332, 0.60869565217391, 1.0369565217391, 0.5
22333, 0.56521739130435, 1.0369565217391, 0.5
22334, 0.52173913043478, 1.0369565217391, 0.5
22335, 0.47826086956522, 1.0369565217391, 0.5
22336, 0.43478260869565, 1.0369565217391, 0.5
22337, 0.39130434782609, 1.0369565217391, 0.5
22338, 0.34782608695652, 1.0369565217391, 0.5
22339, 0.30434782608696, 1.0369565217391, 0.5
22340, 0.26086956521739, 1.0369565217391, 0.5
22341, 0.21739130434783, 1.0369565217391, 0.5
22342, 0.17391304347826, 1.0369565217391, 0.5
22343, 0.1304347826087, 1.0369565217391, 0.5
22344, 0.08695652173913, 1.0369565217391, 0.5
22345, 0.043478260869565, 1.0369565217391, 0.5
22346, 0.95652173913043, 1.0891304347826, 0.5
22347, 0.91304347826087, 1.0891304347826, 0.5
22348, 0.8695652173913, 1.0891304347826, 0.5
22349, 0.82608695652174, 1.0891304347826, 0.5
22350, 0.78260869565217, 1.0891304347826, 0.5
22351, 0.73913043478261, 1.0891304347826, 0.5
22352, 0.69565217391304, 1.0891304347826, 0.5
22353, 0.65217391304348, 1.0891304347826, 0.5
22354, 0.60869565217391, 1.0891304347826, 0.5
22355, 0.56521739130435, 1.0891304347826, 0.5
22356, 0.52173913043478, 1.0891304347826, 0.5
22357, 0.47826086956522, 1.0891304347826, 0.5
22358, 0.43478260869565, 1.0891304347826, 0.5
22359, 0.39130434782609, 1.0891304347826, 0.5
22360, 0.34782608695652, 1.0891304347826, 0.5
22361, 0.30434782608696, 1.0891304347826, 0.5
22362, 0.26086956521739, 1.0891304347826, 0.5
22363, 0.21739130434783, 1.0891304347826, 0.5
22364, 0.17391304347826, 1.0891304347826, 0.5
22365, 0.1304347826087, 1.0891304347826, 0.5
22366, 0.08695652173913, 1.0891304347826, 0.5
22367, 0.043478260869565, 1.0891304347826, 0.5
22368, 0.95652173913043, 1.1413043478261, 0.5
22369, 0.91304347826087, 1.1413043478261, 0.5
22370, 0.8695652173913, 1.1413043478261, 0.5
22371, 0.82608695652174, 1.1413043478261, 0.5
22372, 0.78260869565217, 1.1413043478261, 0.5
22373, 0.73913043478261, 1.1413043478261, 0.5
22374, 0.69565217391304, 1.1413043478261, 0.5
22375, 0.65217391304348, 1.1413043478261, 0.5
22376, 0.60869565217391, 1.1413043478261, 0.5
22377, 0.56521739130435, 1.1413043478261, 0.5
22378, 0.52173913043478, 1.1413043478261, 0.5
22379, 0.47826086956522, 1.1413043478261, 0.5
22380, 0.43478260869565, 1.1413043478261, 0.5
22381, 0.39130434782609, 1.1413043478261, 0.5
22382, 0.34782608695652, 1.1413043478261, 0.5
22383, 0.30434782608696, 1.1413043478261, 0.5
22384, 0.26086956521739, 1.1413043478261, 0.5
22385, 0.21739130434783, 1.1413043478261, 0.5
22386, 0.17391304347826, 1.1413043478261, 0.5
22387, 0.1304347826087, 1.1413043478261, 0.5
22388, 0.08695652173913, 1.1413043478261, 0.5
22389, 0.043478260869565, 1.1413043478261, 0.5
22390, 0.95652173913043, 1.1934782608696, 0.5
22391, 0.91304347826087, 1.1934782608696, 0.5
22392, 0.8695652173913, 1.1934782608696, 0.5
22393, 0.82608695652174, 1.1934782608696, 0.5
22394, 0.78260869565217, 1.1934782608696, 0.5
22395, 0.73913043478261, 1.1934782608696, 0.5
22396, 0.69565217391304, 1.1934782608696, 0.5
22397, 0.65217391304348, 1.1934782608696, 0.5
22398, 0.60869565217391, 1.1934782608696, 0.5
22399, 0.56521739130435, 1.1934782608696, 0.5
22400, 0.52173913043478, 1.1934782608696, 0.5
22401, 0.47826086956522, 1.1934782608696, 0.5
22402, 0.43478260869565, 1.1934782608696, 0.5
22403, 0.39130434782609, 1.1934782608696, 0.5
22404, 0.34782608695652, 1.1934782608696, 0.5
22405, 0.30434782608696, 1.1934782608696, 0.5
22406, 0.26086956521739, 1.1934782608696, 0.5
22407, 0.21739130434783, 1.1934782608696, 0.5
22408, 0.17391304347826, 1.1934782608696, 0.5
22409, 0.1304347826087, 1.1934782608696, 0.5
22410, 0.08695652173913, 1.1934782608696, 0.5
22411, 0.043478260869565, 1.1934782608696, 0.5
22412, 0.95652173913043, 1.245652173913, 0.5
22413, 0.91304347826087, 1.245652173913, 0.5
22414, 0.8695652173913, 1.245652173913, 0.5
22415, 0.82608695652174, 1.245652173913, 0.5
22416, 0.78260869565217, 1.245652173913, 0.5
22417, 0.73913043478261, 1.245652173913, 0.5
22418, 0.69565217391304, 1.245652173913, 0.5
22419, 0.65217391304348, 1.245652173913, 0.5
22420, 0.60869565217391, 1.245652173913, 0.5
22421, 0.56521739130435, 1.245652173913, 0.5
22422, 0.52173913043478, 1.245652173913, 0.5
22423, 0.47826086956522, 1.245652173913, 0.5
22424, 0.43478260869565, 1.245652173913, 0.5
22425, 0.39130434782609, 1.245652173913, 0.5
22426, 0.34782608695652, 1.245652173913, 0.5
22427, 0.30434782608696, 1.245652173913, 0.5
22428, 0.26086956521739, 1.245652173913, 0.5
22429, 0.21739130434783, 1.245652173913, 0.5
22430, 0.17391304347826, 1.245652173913, 0.5
22431, 0.1304347826087, 1.245652173913, 0.5
22432, 0.08695652173913, 1.245652173913, 0.5
22433, 0.043478260869565, 1.245652173913, 0.5
22434, 0.95652173913043, 1.2978260869565, 0.5
22435, 0.91304347826087, 1.2978260869565, 0.5
22436, 0.8695652173913, 1.2978260869565, 0.5
22437, 0.82608695652174, 1.2978260869565, 0.5
22438, 0.78260869565217, 1.2978260869565, 0.5
22439, 0.73913043478261, 1.2978260869565, 0.5
22440, 0.69565217391304, 1.2978260869565, 0.5
22441, 0.65217391304348, 1.2978260869565, 0.5
22442, 0.60869565217391, 1.2978260869565, 0.5
22443, 0.56521739130435, 1.2978260869565, 0.5
22444, 0.52173913043478, 1.2978260869565, 0.5
22445, 0.47826086956522, 1.2978260869565, 0.5
22446, 0.43478260869565, 1.2978260869565, 0.5
22447, 0.39130434782609, 1.2978260869565, 0.5
22448, 0.34782608695652, 1.2978260869565, 0.5
22449, 0.30434782608696, 1.2978260869565, 0.5
22450, 0.26086956521739, 1.2978260869565, 0.5
22451, 0.21739130434783, 1.2978260869565, 0.5
22452, 0.17391304347826, 1.2978260869565, 0.5
22453, 0.1304347826087, 1.2978260869565, 0.5
22454, 0.08695652173913, 1.2978260869565, 0.5
22455, 0.043478260869565, 1.2978260869565, 0.5
22456, 0.97826086956522, 0.20217391304348, 0.5
22457, 0.95652173913043, 0.17608695652174, 0.5
22458, 0.93478260869565, 0.20217391304348, 0.5
22459, 0.91304347826087, 0.17608695652174, 0.5
22460, 0.89130434782609, 0.20217391304348, 0.5
22461, 0.8695652173913, 0.17608695652174, 0.5
22462, 0.84782608695652, 0.20217391304348, 0.5
22463, 0.82608695652174, 0.17608695652174, 0.5
22464, 0.80434782608696, 0.20217391304348, 0.5
22465, 0.78260869565217, 0.17608695652174, 0.5
22466, 0.76086956521739, 0.20217391304348, 0.5
22467, 0.73913043478261, 0.17608695652174, 0.5
22468, 0.71739130434783, 0.20217391304348, 0.5
22469, 0.69565217391304, 0.17608695652174, 0.5
22470, 0.67391304347826, 0.20217391304348, 0.5
22471, 0.65217391304348, 0.17608695652174, 0.5
22472, 0.6304347826087, 0.20217391304348, 0.5
22473, 0.60869565217391, 0.17608695652174, 0.5
22474, 0.58695652173913, 0.20217391304348, 0.5
22475, 0.56521739130435, 0.17608695652174, 0.5
22476, 0.54347826086957, 0.20217391304348, 0.5
22477, 0.52173913043478, 0.17608695652174, 0.5
22478, 0.5, 0.20217391304348, 0.5
22479, 0.47826086956522, 0.17608695652174, 0.5
22480, 0.45652173913043, 0.20217391304348, 0.5
22481, 0.43478260869565, 0.17608695652174, 0.5
22482, 0.41304347826087, 0.20217391304348, 0.5
22483, 0.39130434782609, 0.17608695652174, 0.5
22484, 0.3695652173913, 0.20217391304348, 0.5
22485, 0.34782608695652, 0.17608695652174, 0.5
22486, 0.32608695652174, 0.20217391304348, 0.5
22487, 0.30434782608696, 0.17608695652174, 0.5
22488, 0.28260869565217, 0.20217391304348, 0.5
22489, 0.26086956521739, 0.17608695652174, 0.5
22490, 0.23913043478261, 0.20217391304348, 0.5
22491, 0.21739130434783, 0.17608695652174, 0.5
22492, 0.19565217391304, 0.20217391304348, 0.5
22493, 0.17391304347826, 0.17608695652174, 0.5
22494, 0.15217391304348, 0.20217391304348, 0.5
22495, 0.1304347826087, 0.17608695652174, 0.5
22496, 0.10869565217391, 0.20217391304348, 0.5
22497, 0.08695652173913, 0.17608695652174, 0.5
22498, 0.065217391304348, 0.20217391304348, 0.5
22499, 0.043478260869565, 0.17608695652174, 0.5
22500, 0.021739130434783, 0.20217391304348, 0.5
22501, 0.97826086956522, 0.25434782608696, 0.5
22502, 0.95652173913043, 0.22826086956522, 0.5
22503, 0.93478260869565, 0.25434782608696, 0.5
22504, 0.91304347826087, 0.22826086956522, 0.5
22505, 0.89130434782609, 0.25434782608696, 0.5
22506, 0.8695652173913, 0.22826086956522, 0.5
22507, 0.84782608695652, 0.25434782608696, 0.5
22508, 0.82608695652174, 0.22826086956522, 0.5
22509, 0.80434782608696, 0.25434782608696, 0.5
22510, 0.78260869565217, 0.22826086956522, 0.5
22511, 0.76086956521739, 0.25434782608696, 0.5
22512, 0.73913043478261, 0.22826086956522, 0.5
22513, 0.71739130434783, 0.25434782608696, 0.5
22514, 0.69565217391304, 0.22826086956522, 0.5
22515, 0.67391304347826, 0.25434782608696, 0.5
22516, 0.65217391304348, 0.22826086956522, 0.5
22517, 0.6304347826087, 0.25434782608696, 0.5
22518, 0.60869565217391, 0.22826086956522, 0.5
22519, 0.58695652173913, 0.25434782608696, 0.5
22520, 0.56521739130435, 0.22826086956522, 0.5
22521, 0.54347826086957, 0.25434782608696, 0.5
22522, 0.52173913043478, 0.22826086956522, 0.5
22523, 0.5, 0.25434782608696, 0.5
22524, 0.47826086956522, 0.22826086956522, 0.5
22525, 0.45652173913043, 0.25434782608696, 0.5
22526, 0.43478260869565, 0.22826086956522, 0.5
22527, 0.41304347826087, 0.25434782608696, 0.5
22528, 0.39130434782609, 0.22826086956522, 0.5
22529, 0.3695652173913, 0.25434782608696, 0.5
22530, 0.34782608695652, 0.22826086956522, 0.5
22531, 0.32608695652174, 0.25434782608696, 0.5
22532, 0.30434782608696, 0.22826086956522, 0.5
22533, 0.28260869565217, 0.25434782608696, 0.5
22534, 0.26086956521739, 0.22826086956522, 0.5
22535, 0.23913043478261, 0.25434782608696, 0.5
22536, 0.21739130434783, 0.22826086956522, 0.5
22537, 0.19565217391304, 0.25434782608696, 0.5
22538, 0.17391304347826, 0.22826086956522, 0.5
22539, 0.15217391304348, 0.25434782608696, 0.5
22540, 0.1304347826087, 0.22826086956522, 0.5
22541, 0.10869565217391, 0.25434782608696, 0.5
22542, 0.08695652173913, 0.22826086956522, 0.5
22543, 0.065217391304348, 0.25434782608696, 0.5
22544, 0.043478260869565, 0.22826086956522, 0.5
22545, 0.021739130434783, 0.25434782608696, 0.5
22546, 0.97826086956522, 0.30652173913043, 0.5
22547, 0.95652173913043, 0.2804347826087, 0.5
22548, 0.93478260869565, 0.30652173913043, 0.5
22549, 0.91304347826087, 0.2804347826087, 0.5
22550, 0.89130434782609, 0.30652173913043, 0.5
22551, 0.8695652173913, 0.2804347826087, 0.5
22552, 0.84782608695652, 0.30652173913043, 0.5
22553, 0.82608695652174, 0.2804347826087, 0.5
22554, 0.80434782608696, 0.30652173913043, 0.5
22555, 0.78260869565217, 0.2804347826087, 0.5
22556, 0.76086956521739, 0.30652173913043, 0.5
22557, 0.73913043478261, 0.2804347826087, 0.5
22558, 0.71739130434783, 0.30652173913043, 0.5
22559, 0.69565217391304, 0.2804347826087, 0.5
22560, 0.67391304347826, 0.30652173913043, 0.5
22561, 0.65217391304348, 0.2804347826087, 0.5
22562, 0.6304347826087, 0.30652173913043, 0.5
22563, 0.60869565217391, 0.2804347826087, 0.5
22564, 0.58695652173913, 0.30652173913043, 0.5
22565, 0.56521739130435, 0.2804347826087, 0.5
22566, 0.54347826086957, 0.30652173913043, 0.5
22567, 0.52173913043478, 0.2804347826087, 0.5
22568, 0.5, 0.30652173913043, 0.5
22569, 0.47826086956522, 0.2804347826087, 0.5
22570, 0.45652173913043, 0.30652173913043, 0.5
22571, 0.43478260869565, 0.2804347826087, 0.5
22572, 0.41304347826087, 0.30652173913043, 0.5
22573, 0.39130434782609, 0.2804347826087, 0.5
22574, 0.3695652173913, 0.30652173913043, 0.5
22575, 0.34782608695652, 0.2804347826087, 0.5
22576, 0.32608695652174, 0.30652173913043, 0.5
22577, 0.30434782608696, 0.2804347826087, 0.5
22578, 0.28260869565217, 0.30652173913043, 0.5
22579, 0.26086956521739, 0.2804347826087, 0.5
22580, 0.23913043478261, 0.30652173913043, 0.5
22581, 0.21739130434783, 0.2804347826087, 0.5
22582, 0.19565217391304, 0.30652173913043, 0.5
22583, 0.17391304347826, 0.2804347826087, 0.5
22584, 0.15217391304348, 0.30652173913043, 0.5
22585, 0.1304347826087, 0.2804347826087, 0.5
22586, 0.10869565217391, 0.30652173913043, 0.5
22587, 0.08695652173913, 0.2804347826087, 0.5
22588, 0.065217391304348, 0.30652173913043, 0.5
22589, 0.043478260869565, 0.2804347826087, 0.5
22590, 0.021739130434783, 0.30652173913043, 0.5
22591, 0.97826086956522, 0.35869565217391, 0.5
22592, 0.95652173913043, 0.33260869565217, 0.5
22593, 0.93478260869565, 0.35869565217391, 0.5
22594, 0.91304347826087, 0.33260869565217, 0.5
22595, 0.89130434782609, 0.35869565217391, 0.5
22596, 0.8695652173913, 0.33260869565217, 0.5
22597, 0.84782608695652, 0.35869565217391, 0.5
22598, 0.82608695652174, 0.33260869565217, 0.5
22599, 0.80434782608696, 0.35869565217391, 0.5
22600, 0.78260869565217, 0.33260869565217, 0.5
22601, 0.76086956521739, 0.35869565217391, 0.5
22602, 0.73913043478261, 0.33260869565217, 0.5
22603, 0.71739130434783, 0.35869565217391, 0.5
22604, 0.69565217391304, 0.33260869565217, 0.5
22605, 0.67391304347826, 0.35869565217391, 0.5
22606, 0.65217391304348, 0.33260869565217, 0.5
22607, 0.6304347826087, 0.35869565217391, 0.5
22608, 0.60869565217391, 0.33260869565217, 0.5
22609, 0.58695652173913, 0.35869565217391, 0.5
22610, 0.56521739130435, 0.33260869565217, 0.5
22611, 0.54347826086957, 0.35869565217391, 0.5
22612, 0.52173913043478, 0.33260869565217, 0.5
22613, 0.5, 0.35869565217391, 0.5
22614, 0.47826086956522, 0.33260869565217, 0.5
22615, 0.45652173913043, 0.35869565217391, 0.5
22616, 0.43478260869565, 0.33260869565217, 0.5
22617, 0.41304347826087, 0.35869565217391, 0.5
22618, 0.39130434782609, 0.33260869565217, 0.5
22619, 0.3695652173913, 0.35869565217391, 0.5
22620, 0.34782608695652, 0.33260869565217, 0.5
22621, 0.32608695652174, 0.35869565217391, 0.5
22622, 0.30434782608696, 0.33260869565217, 0.5
22623, 0.28260869565217, 0.35869565217391, 0.5
22624, 0.26086956521739, 0.33260869565217, 0.5
22625, 0.23913043478261, 0.35869565217391, 0.5
22626, 0.21739130434783, 0.33260869565217, 0.5
22627, 0.19565217391304, 0.35869565217391, 0.5
22628, 0.17391304347826, 0.33260869565217, 0.5
22629, 0.15217391304348, 0.35869565217391, 0.5
22630, 0.1304347826087, 0.33260869565217, 0.5
22631, 0.10869565217391, 0.35869565217391, 0.5
22632, 0.08695652173913, 0.33260869565217, 0.5
22633, 0.065217391304348, 0.35869565217391, 0.5
22634, 0.043478260869565, 0.33260869565217, 0.5
22635, 0.021739130434783, 0.35869565217391, 0.5
22636, 0.97826086956522, 0.41086956521739, 0.5
22637, 0.95652173913043, 0.38478260869565, 0.5
22638, 0.93478260869565, 0.41086956521739, 0.5
22639, 0.91304347826087, 0.38478260869565, 0.5
22640, 0.89130434782609, 0.41086956521739, 0.5
22641, 0.8695652173913, 0.38478260869565, 0.5
22642, 0.84782608695652, 0.41086956521739, 0.5
22643, 0.82608695652174, 0.38478260869565, 0.5
22644, 0.80434782608696, 0.41086956521739, 0.5
22645, 0.78260869565217, 0.38478260869565, 0.5
22646, 0.76086956521739, 0.41086956521739, 0.5
22647, 0.73913043478261, 0.38478260869565, 0.5
22648, 0.71739130434783, 0.41086956521739, 0.5
22649, 0.69565217391304, 0.38478260869565, 0.5
22650, 0.67391304347826, 0.41086956521739, 0.5
22651, 0.65217391304348, 0.38478260869565, 0.5
22652, 0.6304347826087, 0.41086956521739, 0.5
22653, 0.60869565217391, 0.38478260869565, 0.5
22654, 0.58695652173913, 0.41086956521739, 0.5
22655, 0.56521739130435, 0.38478260869565, 0.5
22656, 0.54347826086957, 0.41086956521739, 0.5
22657, 0.52173913043478, 0.38478260869565, 0.5
22658, 0.5, 0.41086956521739, 0.5
22659, 0.47826086956522, 0.38478260869565, 0.5
22660, 0.45652173913043, 0.41086956521739, 0.5
22661, 0.43478260869565, 0.38478260869565, 0.5
22662, 0.41304347826087, 0.41086956521739, 0.5
22663, 0.39130434782609, 0.38478260869565, 0.5
22664, 0.3695652173913, 0.41086956521739, 0.5
22665, 0.34782608695652, 0.38478260869565, 0.5
22666, 0.32608695652174, 0.41086956521739, 0.5
22667, 0.30434782608696, 0.38478260869565, 0.5
22668, 0.28260869565217, 0.41086956521739, 0.5
22669, 0.26086956521739, 0.38478260869565, 0.5
22670, 0.23913043478261, 0.41086956521739, 0.5
22671, 0.21739130434783, 0.38478260869565, 0.5
22672, 0.19565217391304, 0.41086956521739, 0.5
22673, 0.17391304347826, 0.38478260869565, 0.5
22674, 0.15217391304348, 0.41086956521739, 0.5
22675, 0.1304347826087, 0.38478260869565, 0.5
22676, 0.10869565217391, 0.41086956521739, 0.5
22677, 0.08695652173913, 0.38478260869565, 0.5
22678, 0.065217391304348, 0.41086956521739, 0.5
22679, 0.043478260869565, 0.38478260869565, 0.5
22680, 0.021739130434783, 0.41086956521739, 0.5
22681, 0.97826086956522, 0.46304347826087, 0.5
22682, 0.95652173913043, 0.43695652173913, 0.5
22683, 0.93478260869565, 0.46304347826087, 0.5
22684, 0.91304347826087, 0.43695652173913, 0.5
22685, 0.89130434782609, 0.46304347826087, 0.5
22686, 0.8695652173913, 0.43695652173913, 0.5
22687, 0.84782608695652, 0.46304347826087, 0.5
22688, 0.82608695652174, 0.43695652173913, 0.5
22689, 0.80434782608696, 0.46304347826087, 0.5
22690, 0.78260869565217, 0.43695652173913, 0.5
22691, 0.76086956521739, 0.46304347826087, 0.5
22692, 0.73913043478261, 0.43695652173913, 0.5
22693, 0.71739130434783, 0.46304347826087, 0.5
22694, 0.69565217391304, 0.43695652173913, 0.5
22695, 0.67391304347826, 0.46304347826087, 0.5
22696, 0.65217391304348, 0.43695652173913, 0.5
22697, 0.6304347826087, 0.46304347826087, 0.5
22698, 0.60869565217391, 0.43695652173913, 0.5
22699, 0.58695652173913, 0.46304347826087, 0.5
22700, 0.56521739130435, 0.43695652173913, 0.5
22701, 0.54347826086957, 0.46304347826087, 0.5
22702, 0.52173913043478, 0.43695652173913, 0.5
22703, 0.5, 0.46304347826087, 0.5
22704, 0.47826086956522, 0.43695652173913, 0.5
22705, 0.45652173913043, 0.46304347826087, 0.5
22706, 0.43478260869565, 0.43695652173913, 0.5
22707, 0.41304347826087, 0.46304347826087, 0.5
22708, 0.39130434782609, 0.43695652173913, 0.5
22709, 0.3695652173913, 0.46304347826087, 0.5
22710, 0.34782608695652, 0.43695652173913, 0.5
22711, 0.32608695652174, 0.46304347826087, 0.5
22712, 0.30434782608696, 0.43695652173913, 0.5
22713, 0.28260869565217, 0.46304347826087, 0.5
22714, 0.26086956521739, 0.43695652173913, 0.5
22715, 0.23913043478261, 0.46304347826087, 0.5
22716, 0.21739130434783, 0.43695652173913, 0.5
22717, 0.19565217391304, 0.46304347826087, 0.5
22718, 0.17391304347826, 0.43695652173913, 0.5
22719, 0.15217391304348, 0.46304347826087, 0.5
22720, 0.1304347826087, 0.43695652173913, 0.5
22721, 0.10869565217391, 0.46304347826087, 0.5
22722, 0.08695652173913, 0.43695652173913, 0.5
22723, 0.065217391304348, 0.46304347826087, 0.5
22724, 0.043478260869565, 0.43695652173913, 0.5
22725, 0.021739130434783, 0.46304347826087, 0.5
22726, 0.97826086956522, 0.51521739130435, 0.5
22727, 0.95652173913043, 0.48913043478261, 0.5
22728, 0.93478260869565, 0.51521739130435, 0.5
22729, 0.91304347826087, 0.48913043478261, 0.5
22730, 0.89130434782609, 0.51521739130435, 0.5
22731, 0.8695652173913, 0.48913043478261, 0.5
22732, 0.84782608695652, 0.51521739130435, 0.5
22733, 0.82608695652174, 0.48913043478261, 0.5
22734, 0.80434782608696, 0.51521739130435, 0.5
22735, 0.78260869565217, 0.48913043478261, 0.5
22736, 0.76086956521739, 0.51521739130435, 0.5
22737, 0.73913043478261, 0.48913043478261, 0.5
22738, 0.71739130434783, 0.51521739130435, 0.5
22739, 0.69565217391304, 0.48913043478261, 0.5
22740, 0.67391304347826, 0.51521739130435, 0.5
22741, 0.65217391304348, 0.48913043478261, 0.5
22742, 0.6304347826087, 0.51521739130435, 0.5
22743, 0.60869565217391, 0.48913043478261, 0.5
22744, 0.58695652173913, 0.51521739130435, 0.5
22745, 0.56521739130435, 0.48913043478261, 0.5
22746, 0.54347826086957, 0.51521739130435, 0.5
22747, 0.52173913043478, 0.48913043478261, 0.5
22748, 0.5, 0.51521739130435, 0.5
22749, 0.47826086956522, 0.48913043478261, 0.5
22750, 0.45652173913043, 0.51521739130435, 0.5
22751, 0.43478260869565, 0.48913043478261, 0.5
22752, 0.41304347826087, 0.51521739130435, 0.5
22753, 0.39130434782609, 0.48913043478261, 0.5
22754, 0.3695652173913, 0.51521739130435, 0.5
22755, 0.34782608695652, 0.48913043478261, 0.5
22756, 0.32608695652174, 0.51521739130435, 0.5
22757, 0.30434782608696, 0.48913043478261, 0.5
22758, 0.28260869565217, 0.51521739130435, 0.5
22759, 0.26086956521739, 0.48913043478261, 0.5
22760, 0.23913043478261, 0.51521739130435, 0.5
22761, 0.21739130434783, 0.48913043478261, 0.5
22762, 0.19565217391304, 0.51521739130435, 0.5
22763, 0.17391304347826, 0.48913043478261, 0.5
22764, 0.15217391304348, 0.51521739130435, 0.5
22765, 0.1304347826087, 0.48913043478261, 0.5
22766, 0.10869565217391, 0.51521739130435, 0.5
22767, 0.08695652173913, 0.48913043478261, 0.5
22768, 0.065217391304348, 0.51521739130435, 0.5
22769, 0.043478260869565, 0.48913043478261, 0.5
22770, 0.021739130434783, 0.51521739130435, 0.5
22771, 0.97826086956522, 0.56739130434783, 0.5
22772, 0.95652173913043, 0.54130434782609, 0.5
22773, 0.93478260869565, 0.56739130434783, 0.5
22774, 0.91304347826087, 0.54130434782609, 0.5
22775, 0.89130434782609, 0.56739130434783, 0.5
22776, 0.8695652173913, 0.54130434782609, 0.5
22777, 0.84782608695652, 0.56739130434783, 0.5
22778, 0.82608695652174, 0.54130434782609, 0.5
22779, 0.80434782608696, 0.56739130434783, 0.5
22780, 0.78260869565217, 0.54130434782609, 0.5
22781, 0.76086956521739, 0.56739130434783, 0.5
22782, 0.73913043478261, 0.54130434782609, 0.5
22783, 0.71739130434783, 0.56739130434783, 0.5
22784, 0.69565217391304, 0.54130434782609, 0.5
22785, 0.67391304347826, 0.56739130434783, 0.5
22786, 0.65217391304348, 0.54130434782609, 0.5
22787, 0.6304347826087, 0.56739130434783, 0.5
22788, 0.60869565217391, 0.54130434782609, 0.5
22789, 0.58695652173913, 0.56739130434783, 0.5
22790, 0.56521739130435, 0.54130434782609, 0.5
22791, 0.54347826086957, 0.56739130434783, 0.5
22792, 0.52173913043478, 0.54130434782609, 0.5
22793, 0.5, 0.56739130434783, 0.5
22794, 0.47826086956522, 0.54130434782609, 0.5
22795, 0.45652173913043, 0.56739130434783, 0.5
22796, 0.43478260869565, 0.54130434782609, 0.5
22797, 0.41304347826087, 0.56739130434783, 0.5
22798, 0.39130434782609, 0.54130434782609, 0.5
22799, 0.3695652173913, 0.56739130434783, 0.5
22800, 0.34782608695652, 0.54130434782609, 0.5
22801, 0.32608695652174, 0.56739130434783, 0.5
22802, 0.30434782608696, 0.54130434782609, 0.5
22803, 0.28260869565217, 0.56739130434783, 0.5
22804, 0.26086956521739, 0.54130434782609, 0.5
22805, 0.23913043478261, 0.56739130434783, 0.5
22806, 0.21739130434783, 0.54130434782609, 0.5
22807, 0.19565217391304, 0.56739130434783, 0.5
22808, 0.17391304347826, 0.54130434782609, 0.5
22809, 0.15217391304348, 0.56739130434783, 0.5
22810, 0.1304347826087, 0.54130434782609, 0.5
22811, 0.10869565217391, 0.56739130434783, 0.5
22812, 0.08695652173913, 0.54130434782609, 0.5
22813, 0.065217391304348, 0.56739130434783, 0.5
22814, 0.043478260869565, 0.54130434782609, 0.5
22815, 0.021739130434783, 0.56739130434783, 0.5
22816, 0.97826086956522, 0.6195652173913, 0.5
22817, 0.95652173913043, 0.59347826086956, 0.5
22818, 0.93478260869565, 0.6195652173913, 0.5
22819, 0.91304347826087, 0.59347826086956, 0.5
22820, 0.89130434782609, 0.6195652173913, 0.5
22821, 0.8695652173913, 0.59347826086956, 0.5
22822, 0.84782608695652, 0.6195652173913, 0.5
22823, 0.82608695652174, 0.59347826086956, 0.5
22824, 0.80434782608696, 0.6195652173913, 0.5
22825, 0.78260869565217, 0.59347826086956, 0.5
22826, 0.76086956521739, 0.6195652173913, 0.5
22827, 0.73913043478261, 0.59347826086956, 0.5
22828, 0.71739130434783, 0.6195652173913, 0.5
22829, 0.69565217391304, 0.59347826086956, 0.5
22830, 0.67391304347826, 0.6195652173913, 0.5
22831, 0.65217391304348, 0.59347826086956, 0.5
22832, 0.6304347826087, 0.6195652173913, 0.5
22833, 0.60869565217391, 0.59347826086956, 0.5
22834, 0.58695652173913, 0.6195652173913, 0.5
22835, 0.56521739130435, 0.59347826086956, 0.5
22836, 0.54347826086957, 0.6195652173913, 0.5
22837, 0.52173913043478, 0.59347826086956, 0.5
22838, 0.5, 0.6195652173913, 0.5
22839, 0.47826086956522, 0.59347826086956, 0.5
22840, 0.45652173913043, 0.6195652173913, 0.5
22841, 0.43478260869565, 0.59347826086956, 0.5
22842, 0.41304347826087, 0.6195652173913, 0.5
22843, 0.39130434782609, 0.59347826086956, 0.5
22844, 0.3695652173913, 0.6195652173913, 0.5
22845, 0.34782608695652, 0.59347826086956, 0.5
22846, 0.32608695652174, 0.6195652173913, 0.5
22847, 0.30434782608696, 0.59347826086956, 0.5
22848, 0.28260869565217, 0.6195652173913, 0.5
22849, 0.26086956521739, 0.59347826086956, 0.5
22850, 0.23913043478261, 0.6195652173913, 0.5
22851, 0.21739130434783, 0.59347826086956, 0.5
22852, 0.19565217391304, 0.6195652173913, 0.5
22853, 0.17391304347826, 0.59347826086956, 0.5
22854, 0.15217391304348, 0.6195652173913, 0.5
22855, 0.1304347826087, 0.59347826086956, 0.5
22856, 0.10869565217391, 0.6195652173913, 0.5
22857, 0.08695652173913, 0.59347826086956, 0.5
22858, 0.065217391304348, 0.6195652173913, 0.5
22859, 0.043478260869565, 0.59347826086956, 0.5
22860, 0.021739130434783, 0.6195652173913, 0.5
22861, 0.97826086956522, 0.67173913043478, 0.5
22862, 0.95652173913043, 0.64565217391304, 0.5
22863, 0.93478260869565, 0.67173913043478, 0.5
22864, 0.91304347826087, 0.64565217391304, 0.5
22865, 0.89130434782609, 0.67173913043478, 0.5
22866, 0.8695652173913, 0.64565217391304, 0.5
22867, 0.84782608695652, 0.67173913043478, 0.5
22868, 0.82608695652174, 0.64565217391304, 0.5
22869, 0.80434782608696, 0.67173913043478, 0.5
22870, 0.78260869565217, 0.64565217391304, 0.5
22871, 0.76086956521739, 0.67173913043478, 0.5
22872, 0.73913043478261, 0.64565217391304, 0.5
22873, 0.71739130434783, 0.67173913043478, 0.5
22874, 0.69565217391304, 0.64565217391304, 0.5
22875, 0.67391304347826, 0.67173913043478, 0.5
22876, 0.65217391304348, 0.64565217391304, 0.5
22877, 0.6304347826087, 0.67173913043478, 0.5
22878, 0.60869565217391, 0.64565217391304, 0.5
22879, 0.58695652173913, 0.67173913043478, 0.5
22880, 0.56521739130435, 0.64565217391304, 0.5
22881, 0.54347826086957, 0.67173913043478, 0.5
22882, 0.52173913043478, 0.64565217391304, 0.5
22883, 0.5, 0.67173913043478, 0.5
22884, 0.47826086956522, 0.64565217391304, 0.5
22885, 0.45652173913043, 0.67173913043478, 0.5
22886, 0.43478260869565, 0.64565217391304, 0.5
22887, 0.41304347826087, 0.67173913043478, 0.5
22888, 0.39130434782609, 0.64565217391304, 0.5
22889, 0.3695652173913, 0.67173913043478, 0.5
22890, 0.34782608695652, 0.64565217391304, 0.5
22891, 0.32608695652174, 0.67173913043478, 0.5
22892, 0.30434782608696, 0.64565217391304, 0.5
22893, 0.28260869565217, 0.67173913043478, 0.5
22894, 0.26086956521739, 0.64565217391304, 0.5
22895, 0.23913043478261, 0.67173913043478, 0.5
22896, 0.21739130434783, 0.64565217391304, 0.5
22897, 0.19565217391304, 0.67173913043478, 0.5
22898, 0.17391304347826, 0.64565217391304, 0.5
22899, 0.15217391304348, 0.67173913043478, 0.5
22900, 0.1304347826087, 0.64565217391304, 0.5
22901, 0.10869565217391, 0.67173913043478, 0.5
22902, 0.08695652173913, 0.64565217391304, 0.5
22903, 0.065217391304348, 0.67173913043478, 0.5
22904, 0.043478260869565, 0.64565217391304, 0.5
22905, 0.021739130434783, 0.67173913043478, 0.5
22906, 0.97826086956522, 0.72391304347826, 0.5
22907, 0.95652173913043, 0.69782608695652, 0.5
22908, 0.93478260869565, 0.72391304347826, 0.5
22909, 0.91304347826087, 0.69782608695652, 0.5
22910, 0.89130434782609, 0.72391304347826, 0.5
22911, 0.8695652173913, 0.69782608695652, 0.5
22912, 0.84782608695652, 0.72391304347826, 0.5
22913, 0.82608695652174, 0.69782608695652, 0.5
22914, 0.80434782608696, 0.72391304347826, 0.5
22915, 0.78260869565217, 0.69782608695652, 0.5
22916, 0.76086956521739, 0.72391304347826, 0.5
22917, 0.73913043478261, 0.69782608695652, 0.5
22918, 0.71739130434783, 0.72391304347826, 0.5
22919, 0.69565217391304, 0.69782608695652, 0.5
22920, 0.67391304347826, 0.72391304347826, 0.5
22921, 0.65217391304348, 0.69782608695652, 0.5
22922, 0.6304347826087, 0.72391304347826, 0.5
22923, 0.60869565217391, 0.69782608695652, 0.5
22924, 0.58695652173913, 0.72391304347826, 0.5
22925, 0.56521739130435, 0.69782608695652, 0.5
22926, 0.54347826086957, 0.72391304347826, 0.5
22927, 0.52173913043478, 0.69782608695652, 0.5
22928, 0.5, 0.72391304347826, 0.5
22929, 0.47826086956522, 0.69782608695652, 0.5
22930, 0.45652173913043, 0.72391304347826, 0.5
22931, 0.43478260869565, 0.69782608695652, 0.5
22932, 0.41304347826087, 0.72391304347826, 0.5
22933, 0.39130434782609, 0.69782608695652, 0.5
22934, 0.3695652173913, 0.72391304347826, 0.5
22935, 0.34782608695652, 0.69782608695652, 0.5
22936, 0.32608695652174, 0.72391304347826, 0.5
22937, 0.30434782608696, 0.69782608695652, 0.5
22938, 0.28260869565217, 0.72391304347826, 0.5
22939, 0.26086956521739, 0.69782608695652, 0.5
22940, 0.23913043478261, 0.72391304347826, 0.5
22941, 0.21739130434783, 0.69782608695652, 0.5
22942, 0.19565217391304, 0.72391304347826, 0.5
22943, 0.17391304347826, 0.69782608695652, 0.5
22944, 0.15217391304348, 0.72391304347826, 0.5
22945, 0.1304347826087, 0.69782608695652, 0.5
22946, 0.10869565217391, 0.72391304347826, 0.5
22947, 0.08695652173913, 0.69782608695652, 0.5
22948, 0.065217391304348, 0.72391304347826, 0.5
22949, 0.043478260869565, 0.69782608695652, 0.5
22950, 0.021739130434783, 0.72391304347826, 0.5
22951, 0.97826086956522, 0.77608695652174, 0.5
22952, 0.95652173913043, 0.75, 0.5
22953, 0.93478260869565, 0.77608695652174, 0.5
22954, 0.91304347826087, 0.75, 0.5
22955, 0.89130434782609, 0.77608695652174, 0.5
22956, 0.8695652173913, 0.75, 0.5
22957, 0.84782608695652, 0.77608695652174, 0.5
22958, 0.82608695652174, 0.75, 0.5
22959, 0.80434782608696, 0.77608695652174, 0.5
22960, 0.78260869565217, 0.75, 0.5
22961, 0.76086956521739, 0.77608695652174, 0.5
22962, 0.73913043478261, 0.75, 0.5
22963, 0.71739130434783, 0.77608695652174, 0.5
22964, 0.69565217391304, 0.75, 0.5
22965, 0.67391304347826, 0.77608695652174, 0.5
22966, 0.65217391304348, 0.75, 0.5
22967, 0.6304347826087, 0.77608695652174, 0.5
22968, 0.60869565217391, 0.75, 0.5
22969, 0.58695652173913, 0.77608695652174, 0.5
22970, 0.56521739130435, 0.75, 0.5
22971, 0.54347826086957, 0.77608695652174, 0.5
22972, 0.52173913043478, 0.75, 0.5
22973, 0.5, 0.77608695652174, 0.5
22974, 0.47826086956522, 0.75, 0.5
22975, 0.45652173913043, 0.77608695652174, 0.5
22976, 0.43478260869565, 0.75, 0.5
22977, 0.41304347826087, 0.77608695652174, 0.5
22978, 0.39130434782609, 0.75, 0.5
22979, 0.3695652173913, 0.77608695652174, 0.5
22980, 0.34782608695652, 0.75, 0.5
22981, 0.32608695652174, 0.77608695652174, 0.5
22982, 0.30434782608696, 0.75, 0.5
22983, 0.28260869565217, 0.77608695652174, 0.5
22984, 0.26086956521739, 0.75, 0.5
22985, 0.23913043478261, 0.77608695652174, 0.5
22986, 0.21739130434783, 0.75, 0.5
22987, 0.19565217391304, 0.77608695652174, 0.5
22988, 0.17391304347826, 0.75, 0.5
22989, 0.15217391304348, 0.77608695652174, 0.5
22990, 0.1304347826087, 0.75, 0.5
22991, 0.10869565217391, 0.77608695652174, 0.5
22992, 0.08695652173913, 0.75, 0.5
22993, 0.065217391304348, 0.77608695652174, 0.5
22994, 0.043478260869565, 0.75, 0.5
22995, 0.021739130434783, 0.77608695652174, 0.5
22996, 0.97826086956522, 0.82826086956522, 0.5
22997, 0.95652173913043, 0.80217391304348, 0.5
22998, 0.93478260869565, 0.82826086956522, 0.5
22999, 0.91304347826087, 0.80217391304348, 0.5
23000, 0.89130434782609, 0.82826086956522, 0.5
23001, 0.8695652173913, 0.80217391304348, 0.5
23002, 0.84782608695652, 0.82826086956522, 0.5
23003, 0.82608695652174, 0.80217391304348, 0.5
23004, 0.80434782608696, 0.82826086956522, 0.5
23005, 0.78260869565217, 0.80217391304348, 0.5
23006, 0.76086956521739, 0.82826086956522, 0.5
23007, 0.73913043478261, 0.80217391304348, 0.5
23008, 0.71739130434783, 0.82826086956522, 0.5
23009, 0.69565217391304, 0.80217391304348, 0.5
23010, 0.67391304347826, 0.82826086956522, 0.5
23011, 0.65217391304348, 0.80217391304348, 0.5
23012, 0.6304347826087, 0.82826086956522, 0.5
23013, 0.60869565217391, 0.80217391304348, 0.5
23014, 0.58695652173913, 0.82826086956522, 0.5
23015, 0.56521739130435, 0.80217391304348, 0.5
23016, 0.54347826086957, 0.82826086956522, 0.5
23017, 0.52173913043478, 0.80217391304348, 0.5
23018, 0.5, 0.82826086956522, 0.5
23019, 0.47826086956522, 0.80217391304348, 0.5
23020, 0.45652173913043, 0.82826086956522, 0.5
23021, 0.43478260869565, 0.80217391304348, 0.5
23022, 0.41304347826087, 0.82826086956522, 0.5
23023, 0.39130434782609, 0.80217391304348, 0.5
23024, 0.3695652173913, 0.82826086956522, 0.5
23025, 0.34782608695652, 0.80217391304348, 0.5
23026, 0.32608695652174, 0.82826086956522, 0.5
23027, 0.30434782608696, 0.80217391304348, 0.5
23028, 0.28260869565217, 0.82826086956522, 0.5
23029, 0.26086956521739, 0.80217391304348, 0.5
23030, 0.23913043478261, 0.82826086956522, 0.5
23031, 0.21739130434783, 0.80217391304348, 0.5
23032, 0.19565217391304, 0.82826086956522, 0.5
23033, 0.17391304347826, 0.80217391304348, 0.5
23034, 0.15217391304348, 0.82826086956522, 0.5
23035, 0.1304347826087, 0.80217391304348, 0.5
23036, 0.10869565217391, 0.82826086956522, 0.5
23037, 0.08695652173913, 0.80217391304348, 0.5
23038, 0.065217391304348, 0.82826086956522, 0.5
23039, 0.043478260869565, 0.80217391304348, 0.5
23040, 0.021739130434783, 0.82826086956522, 0.5
23041, 0.97826086956522, 0.8804347826087, 0.5
23042, 0.95652173913043, 0.85434782608696, 0.5
23043, 0.93478260869565, 0.8804347826087, 0.5
23044, 0.91304347826087, 0.85434782608696, 0.5
23045, 0.89130434782609, 0.8804347826087, 0.5
23046, 0.8695652173913, 0.85434782608696, 0.5
23047, 0.84782608695652, 0.8804347826087, 0.5
23048, 0.82608695652174, 0.85434782608696, 0.5
23049, 0.80434782608696, 0.8804347826087, 0.5
23050, 0.78260869565217, 0.85434782608696, 0.5
23051, 0.76086956521739, 0.8804347826087, 0.5
23052, 0.73913043478261, 0.85434782608696, 0.5
23053, 0.71739130434783, 0.8804347826087, 0.5
23054, 0.69565217391304, 0.85434782608696, 0.5
23055, 0.67391304347826, 0.8804347826087, 0.5
23056, 0.65217391304348, 0.85434782608696, 0.5
23057, 0.6304347826087, 0.8804347826087, 0.5
23058, 0.60869565217391, 0.85434782608696, 0.5
23059, 0.58695652173913, 0.8804347826087, 0.5
23060, 0.56521739130435, 0.85434782608696, 0.5
23061, 0.54347826086957, 0.88043478260869, 0.5
23062, 0.52173913043478, 0.85434782608696, 0.5
23063, 0.5, 0.88043478260869, 0.5
23064, 0.47826086956522, 0.85434782608696, 0.5
23065, 0.45652173913043, 0.8804347826087, 0.5
23066, 0.43478260869565, 0.85434782608696, 0.5
23067, 0.41304347826087, 0.88043478260869, 0.5
23068, 0.39130434782609, 0.85434782608696, 0.5
23069, 0.3695652173913, 0.8804347826087, 0.5
23070, 0.34782608695652, 0.85434782608696, 0.5
23071, 0.32608695652174, 0.8804347826087, 0.5
23072, 0.30434782608696, 0.85434782608696, 0.5
23073, 0.28260869565217, 0.8804347826087, 0.5
23074, 0.26086956521739, 0.85434782608696, 0.5
23075, 0.23913043478261, 0.8804347826087, 0.5
23076, 0.21739130434783, 0.85434782608696, 0.5
23077, 0.19565217391304, 0.8804347826087, 0.5
23078, 0.17391304347826, 0.85434782608696, 0.5
23079, 0.15217391304348, 0.8804347826087, 0.5
23080, 0.1304347826087, 0.85434782608696, 0.5
23081, 0.10869565217391, 0.8804347826087, 0.5
23082, 0.08695652173913, 0.85434782608696, 0.5
23083, 0.065217391304348, 0.8804347826087, 0.5
23084, 0.043478260869565, 0.85434782608696, 0.5
23085, 0.021739130434783, 0.8804347826087, 0.5
23086, 0.97826086956522, 0.93260869565217, 0.5
23087, 0.95652173913043, 0.90652173913043, 0.5
23088, 0.93478260869565, 0.93260869565217, 0.5
23089, 0.91304347826087, 0.90652173913043, 0.5
23090, 0.89130434782609, 0.93260869565217, 0.5
23091, 0.8695652173913, 0.90652173913043, 0.5
23092, 0.84782608695652, 0.93260869565217, 0.5
23093, 0.82608695652174, 0.90652173913043, 0.5
23094, 0.80434782608696, 0.93260869565217, 0.5
23095, 0.78260869565217, 0.90652173913043, 0.5
23096, 0.76086956521739, 0.93260869565217, 0.5
23097, 0.73913043478261, 0.90652173913043, 0.5
23098, 0.71739130434783, 0.93260869565217, 0.5
23099, 0.69565217391304, 0.90652173913043, 0.5
23100, 0.67391304347826, 0.93260869565217, 0.5
23101, 0.65217391304348, 0.90652173913043, 0.5
23102, 0.6304347826087, 0.93260869565217, 0.5
23103, 0.60869565217391, 0.90652173913043, 0.5
23104, 0.58695652173913, 0.93260869565217, 0.5
23105, 0.56521739130435, 0.90652173913043, 0.5
23106, 0.54347826086957, 0.93260869565217, 0.5
23107, 0.52173913043478, 0.90652173913043, 0.5
23108, 0.5, 0.93260869565217, 0.5
23109, 0.47826086956522, 0.90652173913043, 0.5
23110, 0.45652173913043, 0.93260869565217, 0.5
23111, 0.43478260869565, 0.90652173913043, 0.5
23112, 0.41304347826087, 0.93260869565217, 0.5
23113, 0.39130434782609, 0.90652173913043, 0.5
23114, 0.3695652173913, 0.93260869565217, 0.5
23115, 0.34782608695652, 0.90652173913043, 0.5
23116, 0.32608695652174, 0.93260869565217, 0.5
23117, 0.30434782608696, 0.90652173913043, 0.5
23118, 0.28260869565217, 0.93260869565217, 0.5
23119, 0.26086956521739, 0.90652173913043, 0.5
23120, 0.23913043478261, 0.93260869565217, 0.5
23121, 0.21739130434783, 0.90652173913043, 0.5
23122, 0.19565217391304, 0.93260869565217, 0.5
23123, 0.17391304347826, 0.90652173913043, 0.5
23124, 0.15217391304348, 0.93260869565217, 0.5
23125, 0.1304347826087, 0.90652173913043, 0.5
23126, 0.10869565217391, 0.93260869565217, 0.5
23127, 0.08695652173913, 0.90652173913043, 0.5
23128, 0.065217391304348, 0.93260869565217, 0.5
23129, 0.043478260869565, 0.90652173913043, 0.5
23130, 0.021739130434783, 0.93260869565217, 0.5
23131, 0.97826086956522, 0.98478260869565, 0.5
23132, 0.95652173913043, 0.95869565217391, 0.5
23133, 0.93478260869565, 0.98478260869565, 0.5
23134, 0.91304347826087, 0.95869565217391, 0.5
23135, 0.89130434782609, 0.98478260869565, 0.5
23136, 0.8695652173913, 0.95869565217391, 0.5
23137, 0.84782608695652, 0.98478260869565, 0.5
23138, 0.82608695652174, 0.95869565217391, 0.5
23139, 0.80434782608696, 0.98478260869565, 0.5
23140, 0.78260869565217, 0.95869565217391, 0.5
23141, 0.76086956521739, 0.98478260869565, 0.5
23142, 0.73913043478261, 0.95869565217391, 0.5
23143, 0.71739130434783, 0.98478260869565, 0.5
23144, 0.69565217391304, 0.95869565217391, 0.5
23145, 0.67391304347826, 0.98478260869565, 0.5
23146, 0.65217391304348, 0.95869565217391, 0.5
23147, 0.6304347826087, 0.98478260869565, 0.5
23148, 0.60869565217391, 0.95869565217391, 0.5
23149, 0.58695652173913, 0.98478260869565, 0.5
23150, 0.56521739130435, 0.95869565217391, 0.5
23151, 0.54347826086957, 0.98478260869565, 0.5
23152, 0.52173913043478, 0.95869565217391, 0.5
23153, 0.5, 0.98478260869565, 0.5
23154, 0.47826086956522, 0.95869565217391, 0.5
23155, 0.45652173913043, 0.98478260869565, 0.5
23156, 0.43478260869565, 0.95869565217391, 0.5
23157, 0.41304347826087, 0.98478260869565, 0.5
23158, 0.39130434782609, 0.95869565217391, 0.5
23159, 0.3695652173913, 0.98478260869565, 0.5
23160, 0.34782608695652, 0.95869565217391, 0.5
23161, 0.32608695652174, 0.98478260869565, 0.5
23162, 0.30434782608696, 0.95869565217391, 0.5
23163, 0.28260869565217, 0.98478260869565, 0.5
23164, 0.26086956521739, 0.95869565217391, 0.5
23165, 0.23913043478261, 0.98478260869565, 0.5
23166, 0.21739130434783, 0.95869565217391, 0.5
23167, 0.19565217391304, 0.98478260869565, 0.5
23168, 0.17391304347826, 0.95869565217391, 0.5
23169, 0.15217391304348, 0.98478260869565, 0.5
23170, 0.1304347826087, 0.95869565217391, 0.5
23171, 0.10869565217391, 0.98478260869565, 0.5
23172, 0.08695652173913, 0.95869565217391, 0.5
23173, 0.065217391304348, 0.98478260869565, 0.5
23174, 0.043478260869565, 0.95869565217391, 0.5
23175, 0.021739130434783, 0.98478260869565, 0.5
23176, 0.97826086956522, 1.0369565217391, 0.5
23177, 0.95652173913043, 1.0108695652174, 0.5
23178, 0.93478260869565, 1.0369565217391, 0.5
23179, 0.91304347826087, 1.0108695652174, 0.5
23180, 0.89130434782609, 1.0369565217391, 0.5
23181, 0.8695652173913, 1.0108695652174, 0.5
23182, 0.84782608695652, 1.0369565217391, 0.5
23183, 0.82608695652174, 1.0108695652174, 0.5
23184, 0.80434782608696, 1.0369565217391, 0.5
23185, 0.78260869565217, 1.0108695652174, 0.5
23186, 0.76086956521739, 1.0369565217391, 0.5
23187, 0.73913043478261, 1.0108695652174, 0.5
23188, 0.71739130434783, 1.0369565217391, 0.5
23189, 0.69565217391304, 1.0108695652174, 0.5
23190, 0.67391304347826, 1.0369565217391, 0.5
23191, 0.65217391304348, 1.0108695652174, 0.5
23192, 0.6304347826087, 1.0369565217391, 0.5
23193, 0.60869565217391, 1.0108695652174, 0.5
23194, 0.58695652173913, 1.0369565217391, 0.5
23195, 0.56521739130435, 1.0108695652174, 0.5
23196, 0.54347826086957, 1.0369565217391, 0.5
23197, 0.52173913043478, 1.0108695652174, 0.5
23198, 0.5, 1.0369565217391, 0.5
23199, 0.47826086956522, 1.0108695652174, 0.5
23200, 0.45652173913043, 1.0369565217391, 0.5
23201, 0.43478260869565, 1.0108695652174, 0.5
23202, 0.41304347826087, 1.0369565217391, 0.5
23203, 0.39130434782609, 1.0108695652174, 0.5
23204, 0.3695652173913, 1.0369565217391, 0.5
23205, 0.34782608695652, 1.0108695652174, 0.5
23206, 0.32608695652174, 1.0369565217391, 0.5
23207, 0.30434782608696, 1.0108695652174, 0.5
23208, 0.28260869565217, 1.0369565217391, 0.5
23209, 0.26086956521739, 1.0108695652174, 0.5
23210, 0.23913043478261, 1.0369565217391, 0.5
23211, 0.21739130434783, 1.0108695652174, 0.5
23212, 0.19565217391304, 1.0369565217391, 0.5
23213, 0.17391304347826, 1.0108695652174, 0.5
23214, 0.15217391304348, 1.0369565217391, 0.5
23215, 0.1304347826087, 1.0108695652174, 0.5
23216, 0.10869565217391, 1.0369565217391, 0.5
23217, 0.08695652173913, 1.0108695652174, 0.5
23218, 0.065217391304348, 1.0369565217391, 0.5
23219, 0.043478260869565, 1.0108695652174, 0.5
23220, 0.021739130434783, 1.0369565217391, 0.5
23221, 0.97826086956522, 1.0891304347826, 0.5
23222, 0.95652173913043, 1.0630434782609, 0.5
23223, 0.93478260869565, 1.0891304347826, 0.5
23224, 0.91304347826087, 1.0630434782609, 0.5
23225, 0.89130434782609, 1.0891304347826, 0.5
23226, 0.8695652173913, 1.0630434782609, 0.5
23227, 0.84782608695652, 1.0891304347826, 0.5
23228, 0.82608695652174, 1.0630434782609, 0.5
23229, 0.80434782608696, 1.0891304347826, 0.5
23230, 0.78260869565217, 1.0630434782609, 0.5
23231, 0.76086956521739, 1.0891304347826, 0.5
23232, 0.73913043478261, 1.0630434782609, 0.5
23233, 0.71739130434783, 1.0891304347826, 0.5
23234, 0.69565217391304, 1.0630434782609, 0.5
23235, 0.67391304347826, 1.0891304347826, 0.5
23236, 0.65217391304348, 1.0630434782609, 0.5
23237, 0.6304347826087, 1.0891304347826, 0.5
23238, 0.60869565217391, 1.0630434782609, 0.5
23239, 0.58695652173913, 1.0891304347826, 0.5
23240, 0.56521739130435, 1.0630434782609, 0.5
23241, 0.54347826086957, 1.0891304347826, 0.5
23242, 0.52173913043478, 1.0630434782609, 0.5
23243, 0.5, 1.0891304347826, 0.5
23244, 0.47826086956522, 1.0630434782609, 0.5
23245, 0.45652173913043, 1.0891304347826, 0.5
23246, 0.43478260869565, 1.0630434782609, 0.5
23247, 0.41304347826087, 1.0891304347826, 0.5
23248, 0.39130434782609, 1.0630434782609, 0.5
23249, 0.3695652173913, 1.0891304347826, 0.5
23250, 0.34782608695652, 1.0630434782609, 0.5
23251, 0.32608695652174, 1.0891304347826, 0.5
23252, 0.30434782608696, 1.0630434782609, 0.5
23253, 0.28260869565217, 1.0891304347826, 0.5
23254, 0.26086956521739, 1.0630434782609, 0.5
23255, 0.23913043478261, 1.0891304347826, 0.5
23256, 0.21739130434783, 1.0630434782609, 0.5
23257, 0.19565217391304, 1.0891304347826, 0.5
23258, 0.17391304347826, 1.0630434782609, 0.5
23259, 0.15217391304348, 1.0891304347826, 0.5
23260, 0.1304347826087, 1.0630434782609, 0.5
23261, 0.10869565217391, 1.0891304347826, 0.5
23262, 0.08695652173913, 1.0630434782609, 0.5
23263, 0.065217391304348, 1.0891304347826, 0.5
23264, 0.043478260869565, 1.0630434782609, 0.5
23265, 0.021739130434783, 1.0891304347826, 0.5
23266, 0.97826086956522, 1.1413043478261, 0.5
23267, 0.95652173913043, 1.1152173913043, 0.5
23268, 0.93478260869565, 1.1413043478261, 0.5
23269, 0.91304347826087, 1.1152173913043, 0.5
23270, 0.89130434782609, 1.1413043478261, 0.5
23271, 0.8695652173913, 1.1152173913043, 0.5
23272, 0.84782608695652, 1.1413043478261, 0.5
23273, 0.82608695652174, 1.1152173913043, 0.5
23274, 0.80434782608696, 1.1413043478261, 0.5
23275, 0.78260869565217, 1.1152173913043, 0.5
23276, 0.76086956521739, 1.1413043478261, 0.5
23277, 0.73913043478261, 1.1152173913043, 0.5
23278, 0.71739130434783, 1.1413043478261, 0.5
23279, 0.69565217391304, 1.1152173913043, 0.5
23280, 0.67391304347826, 1.1413043478261, 0.5
23281, 0.65217391304348, 1.1152173913043, 0.5
23282, 0.6304347826087, 1.1413043478261, 0.5
23283, 0.60869565217391, 1.1152173913043, 0.5
23284, 0.58695652173913, 1.1413043478261, 0.5
23285, 0.56521739130435, 1.1152173913043, 0.5
23286, 0.54347826086957, 1.1413043478261, 0.5
23287, 0.52173913043478, 1.1152173913043, 0.5
23288, 0.5, 1.1413043478261, 0.5
23289, 0.47826086956522, 1.1152173913043, 0.5
23290, 0.45652173913043, 1.1413043478261, 0.5
23291, 0.43478260869565, 1.1152173913043, 0.5
23292, 0.41304347826087, 1.1413043478261, 0.5
23293, 0.39130434782609, 1.1152173913043, 0.5
23294, 0.3695652173913, 1.1413043478261, 0.5
23295, 0.34782608695652, 1.1152173913043, 0.5
23296, 0.32608695652174, 1.1413043478261, 0.5
23297, 0.30434782608696, 1.1152173913043, 0.5
23298, 0.28260869565217, 1.1413043478261, 0.5
23299, 0.26086956521739, 1.1152173913043, 0.5
23300, 0.23913043478261, 1.1413043478261, 0.5
23301, 0.21739130434783, 1.1152173913043, 0.5
23302, 0.19565217391304, 1.1413043478261, 0.5
23303, 0.17391304347826, 1.1152173913043, 0.5
23304, 0.15217391304348, 1.1413043478261, 0.5
23305, 0.1304347826087, 1.1152173913043, 0.5
23306, 0.10869565217391, 1.1413043478261, 0.5
23307, 0.08695652173913, 1.1152173913043, 0.5
23308, 0.065217391304348, 1.1413043478261, 0.5
23309, 0.043478260869565, 1.1152173913043, 0.5
23310, 0.021739130434783, 1.1413043478261, 0.5
23311, 0.97826086956522, 1.1934782608696, 0.5
23312, 0.95652173913043, 1.1673913043478, 0.5
23313, 0.93478260869565, 1.1934782608696, 0.5
23314, 0.91304347826087, 1.1673913043478, 0.5
23315, 0.89130434782609, 1.1934782608696, 0.5
23316, 0.8695652173913, 1.1673913043478, 0.5
23317, 0.84782608695652, 1.1934782608696, 0.5
23318, 0.82608695652174, 1.1673913043478, 0.5
23319, 0.80434782608696, 1.1934782608696, 0.5
23320, 0.78260869565217, 1.1673913043478, 0.5
23321, 0.76086956521739, 1.1934782608696, 0.5
23322, 0.73913043478261, 1.1673913043478, 0.5
23323, 0.71739130434783, 1.1934782608696, 0.5
23324, 0.69565217391304, 1.1673913043478, 0.5
23325, 0.67391304347826, 1.1934782608696, 0.5
23326, 0.65217391304348, 1.1673913043478, 0.5
23327, 0.6304347826087, 1.1934782608696, 0.5
23328, 0.60869565217391, 1.1673913043478, 0.5
23329, 0.58695652173913, 1.1934782608696, 0.5
23330, 0.56521739130435, 1.1673913043478, 0.5
23331, 0.54347826086957, 1.1934782608696, 0.5
23332, 0.52173913043478, 1.1673913043478, 0.5
23333, 0.5, 1.1934782608696, 0.5
23334, 0.47826086956522, 1.1673913043478, 0.5
23335, 0.45652173913043, 1.1934782608696, 0.5
23336, 0.43478260869565, 1.1673913043478, 0.5
23337, 0.41304347826087, 1.1934782608696, 0.5
23338, 0.39130434782609, 1.1673913043478, 0.5
23339, 0.3695652173913, 1.1934782608696, 0.5
23340, 0.34782608695652, 1.1673913043478, 0.5
23341, 0.32608695652174, 1.1934782608696, 0.5
23342, 0.30434782608696, 1.1673913043478, 0.5
23343, 0.28260869565217, 1.1934782608696, 0.5
23344, 0.26086956521739, 1.1673913043478, 0.5
23345, 0.23913043478261, 1.1934782608696, 0.5
23346, 0.21739130434783, 1.1673913043478, 0.5
23347, 0.19565217391304, 1.1934782608696, 0.5
23348, 0.17391304347826, 1.1673913043478, 0.5
23349, 0.15217391304348, 1.1934782608696, 0.5
23350, 0.1304347826087, 1.1673913043478, 0.5
23351, 0.10869565217391, 1.1934782608696, 0.5
23352, 0.08695652173913, 1.1673913043478, 0.5
23353, 0.065217391304348, 1.1934782608696, 0.5
23354, 0.043478260869565, 1.1673913043478, 0.5
23355, 0.021739130434783, 1.1934782608696, 0.5
23356, 0.97826086956522, 1.245652173913, 0.5
23357, 0.95652173913043, 1.2195652173913, 0.5
23358, 0.93478260869565, 1.245652173913, 0.5
23359, 0.91304347826087, 1.2195652173913, 0.5
23360, 0.89130434782609, 1.245652173913, 0.5
23361, 0.8695652173913, 1.2195652173913, 0.5
23362, 0.84782608695652, 1.245652173913, 0.5
23363, 0.82608695652174, 1.2195652173913, 0.5
23364, 0.80434782608696, 1.245652173913, 0.5
23365, 0.78260869565217, 1.2195652173913, 0.5
23366, 0.76086956521739, 1.245652173913, 0.5
23367, 0.73913043478261, 1.2195652173913, 0.5
23368, 0.71739130434783, 1.245652173913, 0.5
23369, 0.69565217391304, 1.2195652173913, 0.5
23370, 0.67391304347826, 1.245652173913, 0.5
23371, 0.65217391304348, 1.2195652173913, 0.5
23372, 0.6304347826087, 1.245652173913, 0.5
23373, 0.60869565217391, 1.2195652173913, 0.5
23374, 0.58695652173913, 1.245652173913, 0.5
23375, 0.56521739130435, 1.2195652173913, 0.5
23376, 0.54347826086957, 1.245652173913, 0.5
23377, 0.52173913043478, 1.2195652173913, 0.5
23378, 0.5, 1.245652173913, 0.5
23379, 0.47826086956522, 1.2195652173913, 0.5
23380, 0.45652173913043, 1.245652173913, 0.5
23381, 0.43478260869565, 1.2195652173913, 0.5
23382, 0.41304347826087, 1.245652173913, 0.5
23383, 0.39130434782609, 1.2195652173913, 0.5
23384, 0.3695652173913, 1.245652173913, 0.5
23385, 0.34782608695652, 1.2195652173913, 0.5
23386, 0.32608695652174, 1.245652173913, 0.5
23387, 0.30434782608696, 1.2195652173913, 0.5
23388, 0.28260869565217, 1.245652173913, 0.5
23389, 0.26086956521739, 1.2195652173913, 0.5
23390, 0.23913043478261, 1.245652173913, 0.5
23391, 0.21739130434783, 1.2195652173913, 0.5
23392, 0.19565217391304, 1.245652173913, 0.5
23393, 0.17391304347826, 1.2195652173913, 0.5
23394, 0.15217391304348, 1.245652173913, 0.5
23395, 0.1304347826087, 1.2195652173913, 0.5
23396, 0.10869565217391, 1.245652173913, 0.5
23397, 0.08695652173913, 1.2195652173913, 0.5
23398, 0.065217391304348, 1.245652173913, 0.5
23399, 0.043478260869565, 1.2195652173913, 0.5
23400, 0.021739130434783, 1.245652173913, 0.5
23401, 0.97826086956522, 1.2978260869565, 0.5
23402, 0.95652173913043, 1.2717391304348, 0.5
23403, 0.93478260869565, 1.2978260869565, 0.5
23404, 0.91304347826087, 1.2717391304348, 0.5
23405, 0.89130434782609, 1.2978260869565, 0.5
23406, 0.8695652173913, 1.2717391304348, 0.5
23407, 0.84782608695652, 1.2978260869565, 0.5
23408, 0.82608695652174, 1.2717391304348, 0.5
23409, 0.80434782608696, 1.2978260869565, 0.5
23410, 0.78260869565217, 1.2717391304348, 0.5
23411, 0.76086956521739, 1.2978260869565, 0.5
23412, 0.73913043478261, 1.2717391304348, 0.5
23413, 0.71739130434783, 1.2978260869565, 0.5
23414, 0.69565217391304, 1.2717391304348, 0.5
23415, 0.67391304347826, 1.2978260869565, 0.5
23416, 0.65217391304348, 1.2717391304348, 0.5
23417, 0.6304347826087, 1.2978260869565, 0.5
23418, 0.60869565217391, 1.2717391304348, 0.5
23419, 0.58695652173913, 1.2978260869565, 0.5
23420, 0.56521739130435, 1.2717391304348, 0.5
23421, 0.54347826086957, 1.2978260869565, 0.5
23422, 0.52173913043478, 1.2717391304348, 0.5
23423, 0.5, 1.2978260869565, 0.5
23424, 0.47826086956522, 1.2717391304348, 0.5
23425, 0.45652173913043, 1.2978260869565, 0.5
23426, 0.43478260869565, 1.2717391304348, 0.5
23427, 0.41304347826087, 1.2978260869565, 0.5
23428, 0.39130434782609, 1.2717391304348, 0.5
23429, 0.3695652173913, 1.2978260869565, 0.5
23430, 0.34782608695652, 1.2717391304348, 0.5
23431, 0.32608695652174, 1.2978260869565, 0.5
23432, 0.30434782608696, 1.2717391304348, 0.5
23433, 0.28260869565217, 1.2978260869565, 0.5
23434, 0.26086956521739, 1.2717391304348, 0.5
23435, 0.23913043478261, 1.2978260869565, 0.5
23436, 0.21739130434783, 1.2717391304348, 0.5
23437, 0.19565217391304, 1.2978260869565, 0.5
23438, 0.17391304347826, 1.2717391304348, 0.5
23439, 0.15217391304348, 1.2978260869565, 0.5
23440, 0.1304347826087, 1.2717391304348, 0.5
23441, 0.10869565217391, 1.2978260869565, 0.5
23442, 0.08695652173913, 1.2717391304348, 0.5
23443, 0.065217391304348, 1.2978260869565, 0.5
23444, 0.043478260869565, 1.2717391304348, 0.5
23445, 0.021739130434783, 1.2978260869565, 0.5
23446, 0.95652173913043, 1.3239130434783, 0.5
23447, 0.91304347826087, 1.3239130434783, 0.5
23448, 0.8695652173913, 1.3239130434783, 0.5
23449, 0.82608695652174, 1.3239130434783, 0.5
23450, 0.78260869565217, 1.3239130434783, 0.5
23451, 0.73913043478261, 1.3239130434783, 0.5
23452, 0.69565217391304, 1.3239130434783, 0.5
23453, 0.65217391304348, 1.3239130434783, 0.5
23454, 0.60869565217391, 1.3239130434783, 0.5
23455, 0.56521739130435, 1.3239130434783, 0.5
23456, 0.52173913043478, 1.3239130434783, 0.5
23457, 0.47826086956522, 1.3239130434783, 0.5
23458, 0.43478260869565, 1.3239130434783, 0.5
23459, 0.39130434782609, 1.3239130434783, 0.5
23460, 0.34782608695652, 1.3239130434783, 0.5
23461, 0.30434782608696, 1.3239130434783, 0.5
23462, 0.26086956521739, 1.3239130434783, 0.5
23463, 0.21739130434783, 1.3239130434783, 0.5
23464, 0.17391304347826, 1.3239130434783, 0.5
23465, 0.1304347826087, 1.3239130434783, 0.5
23466, 0.08695652173913, 1.3239130434783, 0.5
23467, 0.043478260869565, 1.3239130434783, 0.5
23468, 0, 0.20217391304348, 0.44444444444444
23469, 0, 0.20217391304348, 0.38888888888889
23470, 0, 0.20217391304348, 0.33333333333333
23471, 0, 0.20217391304348, 0.27777777777778
23472, 0, 0.20217391304348, 0.22222222222222
23473, 0, 0.20217391304348, 0.16666666666667
23474, 0, 0.20217391304348, 0.11111111111111
23475, 0, 0.20217391304348, 0.055555555555556
23476, 0, 0.25434782608696, 0.44444444444444
23477, 0, 0.25434782608696, 0.38888888888889
23478, 0, 0.25434782608696, 0.33333333333333
23479, 0, 0.25434782608696, 0.27777777777778
23480, 0, 0.25434782608696, 0.22222222222222
23481, 0, 0.25434782608696, 0.16666666666667
23482, 0, 0.25434782608696, 0.11111111111111
23483, 0, 0.25434782608696, 0.055555555555556
23484, 0, 0.30652173913043, 0.44444444444444
23485, 0, 0.30652173913043, 0.38888888888889
23486, 0, 0.30652173913043, 0.33333333333333
23487, 0, 0.30652173913043, 0.27777777777778
23488, 0, 0.30652173913043, 0.22222222222222
23489, 0, 0.30652173913043, 0.16666666666667
23490, 0, 0.30652173913043, 0.11111111111111
23491, 0, 0.30652173913043, 0.055555555555556
23492, 0, 0.35869565217391, 0.44444444444444
23493, 0, 0.35869565217391, 0.38888888888889
23494, 0, 0.35869565217391, 0.33333333333333
23495, 0, 0.35869565217391, 0.27777777777778
23496, 0, 0.35869565217391, 0.22222222222222
23497, 0, 0.35869565217391, 0.16666666666667
23498, 0, 0.35869565217391, 0.11111111111111
23499, 0, 0.35869565217391, 0.055555555555556
23500, 0, 0.41086956521739, 0.44444444444444
23501, 0, 0.41086956521739, 0.38888888888889
23502, 0, 0.41086956521739, 0.33333333333333
23503, 0, 0.41086956521739, 0.27777777777778
23504, 0, 0.41086956521739, 0.22222222222222
23505, 0, 0.41086956521739, 0.16666666666667
23506, 0, 0.41086956521739, 0.11111111111111
23507, 0, 0.41086956521739, 0.055555555555556
23508, 0, 0.46304347826087, 0.44444444444444
23509, 0, 0.46304347826087, 0.38888888888889
23510, 0, 0.46304347826087, 0.33333333333333
23511, 0, 0.46304347826087, 0.27777777777778
23512, 0, 0.46304347826087, 0.22222222222222
23513, 0, 0.46304347826087, 0.16666666666667
23514, 0, 0.46304347826087, 0.11111111111111
23515, 0, 0.46304347826087, 0.055555555555556
23516, 0, 0.51521739130435, 0.44444444444444
23517, 0, 0.51521739130435, 0.38888888888889
23518, 0, 0.51521739130435, 0.33333333333333
23519, 0, 0.51521739130435, 0.27777777777778
23520, 0, 0.51521739130435, 0.22222222222222
23521, 0, 0.51521739130435, 0.16666666666667
23522, 0, 0.51521739130435, 0.11111111111111
23523, 0, 0.51521739130435, 0.055555555555556
23524, 0, 0.56739130434783, 0.44444444444444
23525, 0, 0.56739130434783, 0.38888888888889
23526, 0, 0.56739130434783, 0.33333333333333
23527, 0, 0.56739130434783, 0.27777777777778
23528, 0, 0.56739130434783, 0.22222222222222
23529, 0, 0.56739130434783, 0.16666666666667
23530, 0, 0.56739130434783, 0.11111111111111
23531, 0, 0.56739130434783, 0.055555555555556
23532, 0, 0.6195652173913, 0.44444444444444
23533, 0, 0.6195652173913, 0.38888888888889
23534, 0, 0.6195652173913, 0.33333333333333
23535, 0, 0.6195652173913, 0.27777777777778
23536, 0, 0.6195652173913, 0.22222222222222
23537, 0, 0.6195652173913, 0.16666666666667
23538, 0, 0.6195652173913, 0.11111111111111
23539, 0, 0.6195652173913, 0.055555555555556
23540, 0, 0.67173913043478, 0.44444444444444
23541, 0, 0.67173913043478, 0.38888888888889
23542, 0, 0.67173913043478, 0.33333333333333
23543, 0, 0.67173913043478, 0.27777777777778
23544, 0, 0.67173913043478, 0.22222222222222
23545, 0, 0.67173913043478, 0.16666666666667
23546, 0, 0.67173913043478, 0.11111111111111
23547, 0, 0.67173913043478, 0.055555555555556
23548, 0, 0.72391304347826, 0.44444444444444
23549, 0, 0.72391304347826, 0.38888888888889
23550, 0, 0.72391304347826, 0.33333333333333
23551, 0, 0.72391304347826, 0.27777777777778
23552, 0, 0.72391304347826, 0.22222222222222
23553, 0, 0.72391304347826, 0.16666666666667
23554, 0, 0.72391304347826, 0.11111111111111
23555, 0, 0.72391304347826, 0.055555555555556
23556, 0, 0.77608695652174, 0.44444444444444
23557, 0, 0.77608695652174, 0.38888888888889
23558, 0, 0.77608695652174, 0.33333333333333
23559, 0, 0.77608695652174, 0.27777777777778
23560, 0, 0.77608695652174, 0.22222222222222
23561, 0, 0.77608695652174, 0.16666666666667
23562, 0, 0.77608695652174, 0.11111111111111
23563, 0, 0.77608695652174, 0.055555555555556
23564, 0, 0.82826086956522, 0.44444444444444
23565, 0, 0.82826086956522, 0.38888888888889
23566, 0, 0.82826086956522, 0.33333333333333
23567, 0, 0.82826086956522, 0.27777777777778
23568, 0, 0.82826086956522, 0.22222222222222
23569, 0, 0.82826086956522, 0.16666666666667
23570, 0, 0.82826086956522, 0.11111111111111
23571, 0, 0.82826086956522, 0.055555555555556
23572, 0, 0.88043478260869, 0.44444444444444
23573, 0, 0.8804347826087, 0.38888888888889
23574, 0, 0.8804347826087, 0.33333333333333
23575, 0, 0.8804347826087, 0.27777777777778
23576, 0, 0.8804347826087, 0.22222222222222
23577, 0, 0.8804347826087, 0.16666666666667
23578, 0, 0.8804347826087, 0.11111111111111
23579, 0, 0.8804347826087, 0.055555555555556
23580, 0, 0.93260869565217, 0.44444444444444
23581, 0, 0.93260869565217, 0.38888888888889
23582, 0, 0.93260869565217, 0.33333333333333
23583, 0, 0.93260869565217, 0.27777777777778
23584, 0, 0.93260869565217, 0.22222222222222
23585, 0, 0.93260869565217, 0.16666666666667
23586, 0, 0.93260869565217, 0.11111111111111
23587, 0, 0.93260869565217, 0.055555555555556
23588, 0, 0.98478260869565, 0.44444444444444
23589, 0, 0.98478260869565, 0.38888888888889
23590, 0, 0.98478260869565, 0.33333333333333
23591, 0, 0.98478260869565, 0.27777777777778
23592, 0, 0.98478260869565, 0.22222222222222
23593, 0, 0.98478260869565, 0.16666666666667
23594, 0, 0.98478260869565, 0.11111111111111
23595, 0, 0.98478260869565, 0.055555555555556
23596, 0, 1.0369565217391, 0.44444444444444
23597, 0, 1.0369565217391, 0.38888888888889
23598, 0, 1.0369565217391, 0.33333333333333
23599, 0, 1.0369565217391, 0.27777777777778
23600, 0, 1.0369565217391, 0.22222222222222
23601, 0, 1.0369565217391, 0.16666666666667
23602, 0, 1.0369565217391, 0.11111111111111
23603, 0, 1.0369565217391, 0.055555555555556
23604, 0, 1.0891304347826, 0.44444444444444
23605, 0, 1.0891304347826, 0.38888888888889
23606, 0, 1.0891304347826, 0.33333333333333
23607, 0, 1.0891304347826, 0.27777777777778
23608, 0, 1.0891304347826, 0.22222222222222
23609, 0, 1.0891304347826, 0.16666666666667
23610, 0, 1.0891304347826, 0.11111111111111
23611, 0, 1.0891304347826, 0.055555555555556
23612, 0, 1.1413043478261, 0.44444444444444
23613, 0, 1.1413043478261, 0.38888888888889
23614, 0, 1.1413043478261, 0.33333333333333
23615, 0, 1.1413043478261, 0.27777777777778
23616, 0, 1.1413043478261, 0.22222222222222
23617, 0, 1.1413043478261, 0.16666666666667
23618, 0, 1.1413043478261, 0.11111111111111
23619, 0, 1.1413043478261, 0.055555555555556
23620, 0, 1.1934782608696, 0.44444444444444
23621, 0, 1.1934782608696, 0.38888888888889
23622, 0, 1.1934782608696, 0.33333333333333
23623, 0, 1.1934782608696, 0.27777777777778
23624, 0, 1.1934782608696, 0.22222222222222
23625, 0, 1.1934782608696, 0.16666666666667
23626, 0, 1.1934782608696, 0.11111111111111
23627, 0, 1.1934782608696, 0.055555555555556
23628, 0, 1.245652173913, 0.44444444444444
23629, 0, 1.245652173913, 0.38888888888889
23630, 0, 1.245652173913, 0.33333333333333
23631, 0, 1.245652173913, 0.27777777777778
23632, 0, 1.245652173913, 0.22222222222222
23633, 0, 1.245652173913, 0.16666666666667
23634, 0, 1.245652173913, 0.11111111111111
23635, 0, 1.245652173913, 0.055555555555556
23636, 0, 1.2978260869565, 0.44444444444444
23637, 0, 1.2978260869565, 0.38888888888889
23638, 0, 1.2978260869565, 0.33333333333333
23639, 0, 1.2978260869565, 0.27777777777778
23640, 0, 1.2978260869565, 0.22222222222222
23641, 0, 1.2978260869565, 0.16666666666667
23642, 0, 1.2978260869565, 0.11111111111111
23643, 0, 1.2978260869565, 0.055555555555556
23644, 0, 0.20217391304348, 0.47222222222222
23645, 0, 0.17608695652174, 0.44444444444444
23646, 0, 0.20217391304348, 0.41666666666667
23647, 0, 0.17608695652174, 0.38888888888889
23648, 0, 0.20217391304348, 0.36111111111111
23649, 0, 0.17608695652174, 0.33333333333333
23650, 0, 0.20217391304348, 0.30555555555556
23651, 0, 0.17608695652174, 0.27777777777778
23652, 0, 0.20217391304348, 0.25
23653, 0, 0.17608695652174, 0.22222222222222
23654, 0, 0.20217391304348, 0.19444444444444
23655, 0, 0.17608695652174, 0.16666666666667
23656, 0, 0.20217391304348, 0.13888888888889
23657, 0, 0.17608695652174, 0.11111111111111
23658, 0, 0.20217391304348, 0.083333333333333
23659, 0, 0.17608695652174, 0.055555555555556
23660, 0, 0.20217391304348, 0.027777777777778
23661, 0, 0.25434782608696, 0.47222222222222
23662, 0, 0.22826086956522, 0.44444444444444
23663, 0, 0.25434782608696, 0.41666666666667
23664, 0, 0.22826086956522, 0.38888888888889
23665, 0, 0.25434782608696, 0.36111111111111
23666, 0, 0.22826086956522, 0.33333333333333
23667, 0, 0.25434782608696, 0.30555555555556
23668, 0, 0.22826086956522, 0.27777777777778
23669, 0, 0.25434782608696, 0.25
23670, 0, 0.22826086956522, 0.22222222222222
23671, 0, 0.25434782608696, 0.19444444444444
23672, 0, 0.22826086956522, 0.16666666666667
23673, 0, 0.25434782608696, 0.13888888888889
23674, 0, 0.22826086956522, 0.11111111111111
23675, 0, 0.25434782608696, 0.083333333333333
23676, 0, 0.22826086956522, 0.055555555555556
23677, 0, 0.25434782608696, 0.027777777777778
23678, 0, 0.30652173913043, 0.47222222222222
23679, 0, 0.2804347826087, 0.44444444444444
23680, 0, 0.30652173913043, 0.41666666666667
23681, 0, 0.2804347826087, 0.38888888888889
23682, 0, 0.30652173913043, 0.36111111111111
23683, 0, 0.2804347826087, 0.33333333333333
23684, 0, 0.30652173913043, 0.30555555555556
23685, 0, 0.2804347826087, 0.27777777777778
23686, 0, 0.30652173913043, 0.25
23687, 0, 0.2804347826087, 0.22222222222222
23688, 0, 0.30652173913043, 0.19444444444444
23689, 0, 0.2804347826087, 0.16666666666667
23690, 0, 0.30652173913043, 0.13888888888889
23691, 0, 0.2804347826087, 0.11111111111111
23692, 0, 0.30652173913043, 0.083333333333333
23693, 0, 0.2804347826087, 0.055555555555556
23694, 0, 0.30652173913043, 0.027777777777778
23695, 0, 0.35869565217391, 0.47222222222222
23696, 0, 0.33260869565217, 0.44444444444444
23697, 0, 0.35869565217391, 0.41666666666667
23698, 0, 0.33260869565217, 0.38888888888889
23699, 0, 0.35869565217391, 0.36111111111111
23700, 0, 0.33260869565217, 0.33333333333333
23701, 0, 0.35869565217391, 0.30555555555556
23702, 0, 0.33260869565217, 0.27777777777778
23703, 0, 0.35869565217391, 0.25
23704, 0, 0.33260869565217, 0.22222222222222
23705, 0, 0.35869565217391, 0.19444444444444
23706, 0, 0.33260869565217, 0.16666666666667
23707, 0, 0.35869565217391, 0.13888888888889
23708, 0, 0.33260869565217, 0.11111111111111
23709, 0, 0.35869565217391, 0.083333333333333
23710, 0, 0.33260869565217, 0.055555555555556
23711, 0, 0.35869565217391, 0.027777777777778
23712, 0, 0.41086956521739, 0.47222222222222
23713, 0, 0.38478260869565, 0.44444444444444
23714, 0, 0.41086956521739, 0.41666666666667
23715, 0, 0.38478260869565, 0.38888888888889
23716, 0, 0.41086956521739, 0.36111111111111
23717, 0, 0.38478260869565, 0.33333333333333
23718, 0, 0.41086956521739, 0.30555555555556
23719, 0, 0.38478260869565, 0.27777777777778
23720, 0, 0.41086956521739, 0.25
23721, 0, 0.38478260869565, 0.22222222222222
23722, 0, 0.41086956521739, 0.19444444444444
23723, 0, 0.38478260869565, 0.16666666666667
23724, 0, 0.41086956521739, 0.13888888888889
23725, 0, 0.38478260869565, 0.11111111111111
23726, 0, 0.41086956521739, 0.083333333333333
23727, 0, 0.38478260869565, 0.055555555555556
23728, 0, 0.41086956521739, 0.027777777777778
23729, 0, 0.46304347826087, 0.47222222222222
23730, 0, 0.43695652173913, 0.44444444444444
23731, 0, 0.46304347826087, 0.41666666666667
23732, 0, 0.43695652173913, 0.38888888888889
23733, 0, 0.46304347826087, 0.36111111111111
23734, 0, 0.43695652173913, 0.33333333333333
23735, 0, 0.46304347826087, 0.30555555555556
23736, 0, 0.43695652173913, 0.27777777777778
23737, 0, 0.46304347826087, 0.25
23738, 0, 0.43695652173913, 0.22222222222222
23739, 0, 0.46304347826087, 0.19444444444444
23740, 0, 0.43695652173913, 0.16666666666667
23741, 0, 0.46304347826087, 0.13888888888889
23742, 0, 0.43695652173913, 0.11111111111111
23743, 0, 0.46304347826087, 0.083333333333333
23744, 0, 0.43695652173913, 0.055555555555556
23745, 0, 0.46304347826087, 0.027777777777778
23746, 0, 0.51521739130435, 0.47222222222222
23747, 0, 0.48913043478261, 0.44444444444444
23748, 0, 0.51521739130435, 0.41666666666667
23749, 0, 0.48913043478261, 0.38888888888889
23750, 0, 0.51521739130435, 0.36111111111111
23751, 0, 0.48913043478261, 0.33333333333333
23752, 0, 0.51521739130435, 0.30555555555556
23753, 0, 0.48913043478261, 0.27777777777778
23754, 0, 0.51521739130435, 0.25
23755, 0, 0.48913043478261, 0.22222222222222
23756, 0, 0.51521739130435, 0.19444444444444
23757, 0, 0.48913043478261, 0.16666666666667
23758, 0, 0.51521739130435, 0.13888888888889
23759, 0, 0.48913043478261, 0.11111111111111
23760, 0, 0.51521739130435, 0.083333333333333
23761, 0, 0.48913043478261, 0.055555555555556
23762, 0, 0.51521739130435, 0.027777777777778
23763, 0, 0.56739130434783, 0.47222222222222
23764, 0, 0.54130434782609, 0.44444444444444
23765, 0, 0.56739130434783, 0.41666666666667
23766, 0, 0.54130434782609, 0.38888888888889
23767, 0, 0.56739130434783, 0.36111111111111
23768, 0, 0.54130434782609, 0.33333333333333
23769, 0, 0.56739130434783, 0.30555555555556
23770, 0, 0.54130434782609, 0.27777777777778
23771, 0, 0.56739130434783, 0.25
23772, 0, 0.54130434782609, 0.22222222222222
23773, 0, 0.56739130434783, 0.19444444444444
23774, 0, 0.54130434782609, 0.16666666666667
23775, 0, 0.56739130434783, 0.13888888888889
23776, 0, 0.54130434782609, 0.11111111111111
23777, 0, 0.56739130434783, 0.083333333333333
23778, 0, 0.54130434782609, 0.055555555555556
23779, 0, 0.56739130434783, 0.027777777777778
23780, 0, 0.6195652173913, 0.47222222222222
23781, 0, 0.59347826086956, 0.44444444444444
23782, 0, 0.6195652173913, 0.41666666666667
23783, 0, 0.59347826086956, 0.38888888888889
23784, 0, 0.6195652173913, 0.36111111111111
23785, 0, 0.59347826086956, 0.33333333333333
23786, 0, 0.6195652173913, 0.30555555555556
23787, 0, 0.59347826086956, 0.27777777777778
23788, 0, 0.6195652173913, 0.25
23789, 0, 0.59347826086956, 0.22222222222222
23790, 0, 0.6195652173913, 0.19444444444444
23791, 0, 0.59347826086956, 0.16666666666667
23792, 0, 0.6195652173913, 0.13888888888889
23793, 0, 0.59347826086956, 0.11111111111111
23794, 0, 0.6195652173913, 0.083333333333333
23795, 0, 0.59347826086956, 0.055555555555556
23796, 0, 0.6195652173913, 0.027777777777778
23797, 0, 0.67173913043478, 0.47222222222222
23798, 0, 0.64565217391304, 0.44444444444444
23799, 0, 0.67173913043478, 0.41666666666667
23800, 0, 0.64565217391304, 0.38888888888889
23801, 0, 0.67173913043478, 0.36111111111111
23802, 0, 0.64565217391304, 0.33333333333333
23803, 0, 0.67173913043478, 0.30555555555556
23804, 0, 0.64565217391304, 0.27777777777778
23805, 0, 0.67173913043478, 0.25
23806, 0, 0.64565217391304, 0.22222222222222
23807, 0, 0.67173913043478, 0.19444444444444
23808, 0, 0.64565217391304, 0.16666666666667
23809, 0, 0.67173913043478, 0.13888888888889
23810, 0, 0.64565217391304, 0.11111111111111
23811, 0, 0.67173913043478, 0.083333333333333
23812, 0, 0.64565217391304, 0.055555555555556
23813, 0, 0.67173913043478, 0.027777777777778
23814, 0, 0.72391304347826, 0.47222222222222
23815, 0, 0.69782608695652, 0.44444444444444
23816, 0, 0.72391304347826, 0.41666666666667
23817, 0, 0.69782608695652, 0.38888888888889
23818, 0, 0.72391304347826, 0.36111111111111
23819, 0, 0.69782608695652, 0.33333333333333
23820, 0, 0.72391304347826, 0.30555555555556
23821, 0, 0.69782608695652, 0.27777777777778
23822, 0, 0.72391304347826, 0.25
23823, 0, 0.69782608695652, 0.22222222222222
23824, 0, 0.72391304347826, 0.19444444444444
23825, 0, 0.69782608695652, 0.16666666666667
23826, 0, 0.72391304347826, 0.13888888888889
23827, 0, 0.69782608695652, 0.11111111111111
23828, 0, 0.72391304347826, 0.083333333333333
23829, 0, 0.69782608695652, 0.055555555555556
23830, 0, 0.72391304347826, 0.027777777777778
23831, 0, 0.77608695652174, 0.47222222222222
23832, 0, 0.75, 0.44444444444444
23833, 0, 0.77608695652174, 0.41666666666667
23834, 0, 0.75, 0.38888888888889
23835, 0, 0.77608695652174, 0.36111111111111
23836, 0, 0.75, 0.33333333333333
23837, 0, 0.77608695652174, 0.30555555555556
23838, 0, 0.75, 0.27777777777778
23839, 0, 0.77608695652174, 0.25
23840, 0, 0.75, 0.22222222222222
23841, 0, 0.77608695652174, 0.19444444444444
23842, 0, 0.75, 0.16666666666667
23843, 0, 0.77608695652174, 0.13888888888889
23844, 0, 0.75, 0.11111111111111
23845, 0, 0.77608695652174, 0.083333333333333
23846, 0, 0.75, 0.055555555555556
23847, 0, 0.77608695652174, 0.027777777777778
23848, 0, 0.82826086956522, 0.47222222222222
23849, 0, 0.80217391304348, 0.44444444444444
23850, 0, 0.82826086956522, 0.41666666666667
23851, 0, 0.80217391304348, 0.38888888888889
23852, 0, 0.82826086956522, 0.36111111111111
23853, 0, 0.80217391304348, 0.33333333333333
23854, 0, 0.82826086956522, 0.30555555555556
23855, 0, 0.80217391304348, 0.27777777777778
23856, 0, 0.82826086956522, 0.25
23857, 0, 0.80217391304348, 0.22222222222222
23858, 0, 0.82826086956522, 0.19444444444444
23859, 0, 0.80217391304348, 0.16666666666667
23860, 0, 0.82826086956522, 0.13888888888889
23861, 0, 0.80217391304348, 0.11111111111111
23862, 0, 0.82826086956522, 0.083333333333333
23863, 0, 0.80217391304348, 0.055555555555556
23864, 0, 0.82826086956522, 0.027777777777778
23865, 0, 0.88043478260869, 0.47222222222222
23866, 0, 0.85434782608696, 0.44444444444444
23867, 0, 0.88043478260869, 0.41666666666667
23868, 0, 0.85434782608696, 0.38888888888889
23869, 0, 0.8804347826087, 0.36111111111111
23870, 0, 0.85434782608696, 0.33333333333333
23871, 0, 0.8804347826087, 0.30555555555556
23872, 0, 0.85434782608696, 0.27777777777778
23873, 0, 0.8804347826087, 0.25
23874, 0, 0.85434782608696, 0.22222222222222
23875, 0, 0.8804347826087, 0.19444444444444
23876, 0, 0.85434782608696, 0.16666666666667
23877, 0, 0.8804347826087, 0.13888888888889
23878, 0, 0.85434782608696, 0.11111111111111
23879, 0, 0.8804347826087, 0.083333333333333
23880, 0, 0.85434782608696, 0.055555555555556
23881, 0, 0.8804347826087, 0.027777777777778
23882, 0, 0.93260869565217, 0.47222222222222
23883, 0, 0.90652173913043, 0.44444444444444
23884, 0, 0.93260869565217, 0.41666666666667
23885, 0, 0.90652173913043, 0.38888888888889
23886, 0, 0.93260869565217, 0.36111111111111
23887, 0, 0.90652173913043, 0.33333333333333
23888, 0, 0.93260869565217, 0.30555555555556
23889, 0, 0.90652173913043, 0.27777777777778
23890, 0, 0.93260869565217, 0.25
23891, 0, 0.90652173913043, 0.22222222222222
23892, 0, 0.93260869565217, 0.19444444444444
23893, 0, 0.90652173913043, 0.16666666666667
23894, 0, 0.93260869565217, 0.13888888888889
23895, 0, 0.90652173913043, 0.11111111111111
23896, 0, 0.93260869565217, 0.083333333333333
23897, 0, 0.90652173913043, 0.055555555555556
23898, 0, 0.93260869565217, 0.027777777777778
23899, 0, 0.98478260869565, 0.47222222222222
23900, 0, 0.95869565217391, 0.44444444444444
23901, 0, 0.98478260869565, 0.41666666666667
23902, 0, 0.95869565217391, 0.38888888888889
23903, 0, 0.98478260869565, 0.36111111111111
23904, 0, 0.95869565217391, 0.33333333333333
23905, 0, 0.98478260869565, 0.30555555555556
23906, 0, 0.95869565217391, 0.27777777777778
23907, 0, 0.98478260869565, 0.25
23908, 0, 0.95869565217391, 0.22222222222222
23909, 0, 0.98478260869565, 0.19444444444444
23910, 0, 0.95869565217391, 0.16666666666667
23911, 0, 0.98478260869565, 0.13888888888889
23912, 0, 0.95869565217391, 0.11111111111111
23913, 0, 0.98478260869565, 0.083333333333333
23914, 0, 0.95869565217391, 0.055555555555556
23915, 0, 0.98478260869565, 0.027777777777778
23916, 0, 1.0369565217391, 0.47222222222222
23917, 0, 1.0108695652174, 0.44444444444444
23918, 0, 1.0369565217391, 0.41666666666667
23919, 0, 1.0108695652174, 0.38888888888889
23920, 0, 1.0369565217391, 0.36111111111111
23921, 0, 1.0108695652174, 0.33333333333333
23922, 0, 1.0369565217391, 0.30555555555556
23923, 0, 1.0108695652174, 0.27777777777778
23924, 0, 1.0369565217391, 0.25
23925, 0, 1.0108695652174, 0.22222222222222
23926, 0, 1.0369565217391, 0.19444444444444
23927, 0, 1.0108695652174, 0.16666666666667
23928, 0, 1.0369565217391, 0.13888888888889
23929, 0, 1.0108695652174, 0.11111111111111
23930, 0, 1.0369565217391, 0.083333333333333
23931, 0, 1.0108695652174, 0.055555555555556
23932, 0, 1.0369565217391, 0.027777777777778
23933, 0, 1.0891304347826, 0.47222222222222
23934, 0, 1.0630434782609, 0.44444444444444
23935, 0, 1.0891304347826, 0.41666666666667
23936, 0, 1.0630434782609, 0.38888888888889
23937, 0, 1.0891304347826, 0.36111111111111
23938, 0, 1.0630434782609, 0.33333333333333
23939, 0, 1.0891304347826, 0.30555555555556
23940, 0, 1.0630434782609, 0.27777777777778
23941, 0, 1.0891304347826, 0.25
23942, 0, 1.0630434782609, 0.22222222222222
23943, 0, 1.0891304347826, 0.19444444444444
23944, 0, 1.0630434782609, 0.16666666666667
23945, 0, 1.0891304347826, 0.13888888888889
23946, 0, 1.0630434782609, 0.11111111111111
23947, 0, 1.0891304347826, 0.083333333333333
23948, 0, 1.0630434782609, 0.055555555555556
23949, 0, 1.0891304347826, 0.027777777777778
23950, 0, 1.1413043478261, 0.47222222222222
23951, 0, 1.1152173913043, 0.44444444444444
23952, 0, 1.1413043478261, 0.41666666666667
23953, 0, 1.1152173913043, 0.38888888888889
23954, 0, 1.1413043478261, 0.36111111111111
23955, 0, 1.1152173913043, 0.33333333333333
23956, 0, 1.1413043478261, 0.30555555555556
23957, 0, 1.1152173913043, 0.27777777777778
23958, 0, 1.1413043478261, 0.25
23959, 0, 1.1152173913043, 0.22222222222222
23960, 0, 1.1413043478261, 0.19444444444444
23961, 0, 1.1152173913043, 0.16666666666667
23962, 0, 1.1413043478261, 0.13888888888889
23963, 0, 1.1152173913043, 0.11111111111111
23964, 0, 1.1413043478261, 0.083333333333333
23965, 0, 1.1152173913043, 0.055555555555556
23966, 0, 1.1413043478261, 0.027777777777778
23967, 0, 1.1934782608696, 0.47222222222222
23968, 0, 1.1673913043478, 0.44444444444444
23969, 0, 1.1934782608696, 0.41666666666667
23970, 0, 1.1673913043478, 0.38888888888889
23971, 0, 1.1934782608696, 0.36111111111111
23972, 0, 1.1673913043478, 0.33333333333333
23973, 0, 1.1934782608696, 0.30555555555556
23974, 0, 1.1673913043478, 0.27777777777778
23975, 0, 1.1934782608696, 0.25
23976, 0, 1.1673913043478, 0.22222222222222
23977, 0, 1.1934782608696, 0.19444444444444
23978, 0, 1.1673913043478, 0.16666666666667
23979, 0, 1.1934782608696, 0.13888888888889
23980, 0, 1.1673913043478, 0.11111111111111
23981, 0, 1.1934782608696, 0.083333333333333
23982, 0, 1.1673913043478, 0.055555555555556
23983, 0, 1.1934782608696, 0.027777777777778
23984, 0, 1.245652173913, 0.47222222222222
23985, 0, 1.2195652173913, 0.44444444444444
23986, 0, 1.245652173913, 0.41666666666667
23987, 0, 1.2195652173913, 0.38888888888889
23988, 0, 1.245652173913, 0.36111111111111
23989, 0, 1.2195652173913, 0.33333333333333
23990, 0, 1.245652173913, 0.30555555555556
23991, 0, 1.2195652173913, 0.27777777777778
23992, 0, 1.245652173913, 0.25
23993, 0, 1.2195652173913, 0.22222222222222
23994, 0, 1.245652173913, 0.19444444444444
23995, 0, 1.2195652173913, 0.16666666666667
23996, 0, 1.245652173913, 0.13888888888889
23997, 0, 1.2195652173913, 0.11111111111111
23998, 0, 1.245652173913, 0.083333333333333
23999, 0, 1.2195652173913, 0.055555555555556
24000, 0, 1.245652173913, 0.027777777777778
24001, 0, 1.2978260869565, 0.47222222222222
24002, 0, 1.2717391304348, 0.44444444444444
24003, 0, 1.2978260869565, 0.41666666666667
24004, 0, 1.2717391304348, 0.38888888888889
24005, 0, 1.2978260869565, 0.36111111111111
24006, 0, 1.2717391304348, 0.33333333333333
24007, 0, 1.2978260869565, 0.30555555555556
24008, 0, 1.2717391304348, 0.27777777777778
24009, 0, 1.2978260869565, 0.25
24010, 0, 1.2717391304348, 0.22222222222222
24011, 0, 1.2978260869565, 0.19444444444444
24012, 0, 1.2717391304348, 0.16666666666667
24013, 0, 1.2978260869565, 0.13888888888889
24014, 0, 1.2717391304348, 0.11111111111111
24015, 0, 1.2978260869565, 0.083333333333333
24016, 0, 1.2717391304348, 0.055555555555556
24017, 0, 1.2978260869565, 0.027777777777778
24018, 0, 1.3239130434783, 0.44444444444444
24019, 0, 1.3239130434783, 0.38888888888889
24020, 0, 1.3239130434783, 0.33333333333333
24021, 0, 1.3239130434783, 0.27777777777778
24022, 0, 1.3239130434783, 0.22222222222222
24023, 0, 1.3239130434783, 0.16666666666667
24024, 0, 1.3239130434783, 0.11111111111111
24025, 0, 1.3239130434783, 0.055555555555556
24026, 0.043478260869565, 1.35, 0.055555555555556
24027, 0.043478260869565, 1.35, 0.11111111111111
24028, 0.043478260869565, 1.35, 0.16666666666667
24029, 0.043478260869565, 1.35, 0.22222222222222
24030, 0.043478260869565, 1.35, 0.27777777777778
24031, 0.043478260869565, 1.35, 0.33333333333333
24032, 0.043478260869565, 1.35, 0.38888888888889
24033, 0.043478260869565, 1.35, 0.44444444444444
24034, 0.08695652173913, 1.35, 0.055555555555556
24035, 0.08695652173913, 1.35, 0.11111111111111
24036, 0.08695652173913, 1.35, 0.16666666666667
24037, 0.08695652173913, 1.35, 0.22222222222222
24038, 0.08695652173913, 1.35, 0.27777777777778
24039, 0.08695652173913, 1.35, 0.33333333333333
24040, 0.08695652173913, 1.35, 0.38888888888889
24041, 0.08695652173913, 1.35, 0.44444444444444
24042, 0.1304347826087, 1.35, 0.055555555555556
24043, 0.1304347826087, 1.35, 0.11111111111111
24044, 0.1304347826087, 1.35, 0.16666666666667
24045, 0.1304347826087, 1.35, 0.22222222222222
24046, 0.1304347826087, 1.35, 0.27777777777778
24047, 0.1304347826087, 1.35, 0.33333333333333
24048, 0.1304347826087, 1.35, 0.38888888888889
24049, 0.1304347826087, 1.35, 0.44444444444444
24050, 0.17391304347826, 1.35, 0.055555555555556
24051, 0.17391304347826, 1.35, 0.11111111111111
24052, 0.17391304347826, 1.35, 0.16666666666667
24053, 0.17391304347826, 1.35, 0.22222222222222
24054, 0.17391304347826, 1.35, 0.27777777777778
24055, 0.17391304347826, 1.35, 0.33333333333333
24056, 0.17391304347826, 1.35, 0.38888888888889
24057, 0.17391304347826, 1.35, 0.44444444444444
24058, 0.21739130434783, 1.35, 0.055555555555556
24059, 0.21739130434783, 1.35, 0.11111111111111
24060, 0.21739130434783, 1.35, 0.16666666666667
24061, 0.21739130434783, 1.35, 0.22222222222222
24062, 0.21739130434783, 1.35, 0.27777777777778
24063, 0.21739130434783, 1.35, 0.33333333333333
24064, 0.21739130434783, 1.35, 0.38888888888889
24065, 0.21739130434783, 1.35, 0.44444444444444
24066, 0.26086956521739, 1.35, 0.055555555555556
24067, 0.26086956521739, 1.35, 0.11111111111111
24068, 0.26086956521739, 1.35, 0.16666666666667
24069, 0.26086956521739, 1.35, 0.22222222222222
24070, 0.26086956521739, 1.35, 0.27777777777778
24071, 0.26086956521739, 1.35, 0.33333333333333
24072, 0.26086956521739, 1.35, 0.38888888888889
24073, 0.26086956521739, 1.35, 0.44444444444444
24074, 0.30434782608696, 1.35, 0.055555555555556
24075, 0.30434782608696, 1.35, 0.11111111111111
24076, 0.30434782608696, 1.35, 0.16666666666667
24077, 0.30434782608696, 1.35, 0.22222222222222
24078, 0.30434782608696, 1.35, 0.27777777777778
24079, 0.30434782608696, 1.35, 0.33333333333333
24080, 0.30434782608696, 1.35, 0.38888888888889
24081, 0.30434782608696, 1.35, 0.44444444444444
24082, 0.34782608695652, 1.35, 0.055555555555556
24083, 0.34782608695652, 1.35, 0.11111111111111
24084, 0.34782608695652, 1.35, 0.16666666666667
24085, 0.34782608695652, 1.35, 0.22222222222222
24086, 0.34782608695652, 1.35, 0.27777777777778
24087, 0.34782608695652, 1.35, 0.33333333333333
24088, 0.34782608695652, 1.35, 0.38888888888889
24089, 0.34782608695652, 1.35, 0.44444444444444
24090, 0.39130434782609, 1.35, 0.055555555555556
24091, 0.39130434782609, 1.35, 0.11111111111111
24092, 0.39130434782609, 1.35, 0.16666666666667
24093, 0.39130434782609, 1.35, 0.22222222222222
24094, 0.39130434782609, 1.35, 0.27777777777778
24095, 0.39130434782609, 1.35, 0.33333333333333
24096, 0.39130434782609, 1.35, 0.38888888888889
24097, 0.39130434782609, 1.35, 0.44444444444444
24098, 0.43478260869565, 1.35, 0.055555555555556
24099, 0.43478260869565, 1.35, 0.11111111111111
24100, 0.43478260869565, 1.35, 0.16666666666667
24101, 0.43478260869565, 1.35, 0.22222222222222
24102, 0.43478260869565, 1.35, 0.27777777777778
24103, 0.43478260869565, 1.35, 0.33333333333333
24104, 0.43478260869565, 1.35, 0.38888888888889
24105, 0.43478260869565, 1.35, 0.44444444444444
24106, 0.47826086956522, 1.35, 0.055555555555556
24107, 0.47826086956522, 1.35, 0.11111111111111
24108, 0.47826086956522, 1.35, 0.16666666666667
24109, 0.47826086956522, 1.35, 0.22222222222222
24110, 0.47826086956522, 1.35, 0.27777777777778
24111, 0.47826086956522, 1.35, 0.33333333333333
24112, 0.47826086956522, 1.35, 0.38888888888889
24113, 0.47826086956522, 1.35, 0.44444444444444
24114, 0.52173913043478, 1.35, 0.055555555555556
24115, 0.52173913043478, 1.35, 0.11111111111111
24116, 0.52173913043478, 1.35, 0.16666666666667
24117, 0.52173913043478, 1.35, 0.22222222222222
24118, 0.52173913043478, 1.35, 0.27777777777778
24119, 0.52173913043478, 1.35, 0.33333333333333
24120, 0.52173913043478, 1.35, 0.38888888888889
24121, 0.52173913043478, 1.35, 0.44444444444444
24122, 0.56521739130435, 1.35, 0.055555555555556
24123, 0.56521739130435, 1.35, 0.11111111111111
24124, 0.56521739130435, 1.35, 0.16666666666667
24125, 0.56521739130435, 1.35, 0.22222222222222
24126, 0.56521739130435, 1.35, 0.27777777777778
24127, 0.56521739130435, 1.35, 0.33333333333333
24128, 0.56521739130435, 1.35, 0.38888888888889
24129, 0.56521739130435, 1.35, 0.44444444444444
24130, 0.60869565217391, 1.35, 0.055555555555556
24131, 0.60869565217391, 1.35, 0.11111111111111
24132, 0.60869565217391, 1.35, 0.16666666666667
24133, 0.60869565217391, 1.35, 0.22222222222222
24134, 0.60869565217391, 1.35, 0.27777777777778
24135, 0.60869565217391, 1.35, 0.33333333333333
24136, 0.60869565217391, 1.35, 0.38888888888889
24137, 0.60869565217391, 1.35, 0.44444444444444
24138, 0.65217391304348, 1.35, 0.055555555555556
24139, 0.65217391304348, 1.35, 0.11111111111111
24140, 0.65217391304348, 1.35, 0.16666666666667
24141, 0.65217391304348, 1.35, 0.22222222222222
24142, 0.65217391304348, 1.35, 0.27777777777778
24143, 0.65217391304348, 1.35, 0.33333333333333
24144, 0.65217391304348, 1.35, 0.38888888888889
24145, 0.65217391304348, 1.35, 0.44444444444444
24146, 0.69565217391304, 1.35, 0.055555555555556
24147, 0.69565217391304, 1.35, 0.11111111111111
24148, 0.69565217391304, 1.35, 0.16666666666667
24149, 0.69565217391304, 1.35, 0.22222222222222
24150, 0.69565217391304, 1.35, 0.27777777777778
24151, 0.69565217391304, 1.35, 0.33333333333333
24152, 0.69565217391304, 1.35, 0.38888888888889
24153, 0.69565217391304, 1.35, 0.44444444444444
24154, 0.73913043478261, 1.35, 0.055555555555556
24155, 0.73913043478261, 1.35, 0.11111111111111
24156, 0.73913043478261, 1.35, 0.16666666666667
24157, 0.73913043478261, 1.35, 0.22222222222222
24158, 0.73913043478261, 1.35, 0.27777777777778
24159, 0.73913043478261, 1.35, 0.33333333333333
24160, 0.73913043478261, 1.35, 0.38888888888889
24161, 0.73913043478261, 1.35, 0.44444444444444
24162, 0.78260869565217, 1.35, 0.055555555555556
24163, 0.78260869565217, 1.35, 0.11111111111111
24164, 0.78260869565217, 1.35, 0.16666666666667
24165, 0.78260869565217, 1.35, 0.22222222222222
24166, 0.78260869565217, 1.35, 0.27777777777778
24167, 0.78260869565217, 1.35, 0.33333333333333
24168, 0.78260869565217, 1.35, 0.38888888888889
24169, 0.78260869565217, 1.35, 0.44444444444444
24170, 0.82608695652174, 1.35, 0.055555555555556
24171, 0.82608695652174, 1.35, 0.11111111111111
24172, 0.82608695652174, 1.35, 0.16666666666667
24173, 0.82608695652174, 1.35, 0.22222222222222
24174, 0.82608695652174, 1.35, 0.27777777777778
24175, 0.82608695652174, 1.35, 0.33333333333333
24176, 0.82608695652174, 1.35, 0.38888888888889
24177, 0.82608695652174, 1.35, 0.44444444444444
24178, 0.8695652173913, 1.35, 0.055555555555556
24179, 0.8695652173913, 1.35, 0.11111111111111
24180, 0.8695652173913, 1.35, 0.16666666666667
24181, 0.8695652173913, 1.35, 0.22222222222222
24182, 0.8695652173913, 1.35, 0.27777777777778
24183, 0.8695652173913, 1.35, 0.33333333333333
24184, 0.8695652173913, 1.35, 0.38888888888889
24185, 0.8695652173913, 1.35, 0.44444444444444
24186, 0.91304347826087, 1.35, 0.055555555555556
24187, 0.91304347826087, 1.35, 0.11111111111111
24188, 0.91304347826087, 1.35, 0.16666666666667
24189, 0.91304347826087, 1.35, 0.22222222222222
24190, 0.91304347826087, 1.35, 0.27777777777778
24191, 0.91304347826087, 1.35, 0.33333333333333
24192, 0.91304347826087, 1.35, 0.38888888888889
24193, 0.91304347826087, 1.35, 0.44444444444444
24194, 0.95652173913043, 1.35, 0.055555555555556
24195, 0.95652173913043, 1.35, 0.11111111111111
24196, 0.95652173913043, 1.35, 0.16666666666667
24197, 0.95652173913043, 1.35, 0.22222222222222
24198, 0.95652173913043, 1.35, 0.27777777777778
24199, 0.95652173913043, 1.35, 0.33333333333333
24200, 0.95652173913043, 1.35, 0.38888888888889
24201, 0.95652173913043, 1.35, 0.44444444444444
24202, 0.021739130434783, 1.35, 0.055555555555556
24203, 0.043478260869565, 1.35, 0.027777777777778
24204, 0.021739130434783, 1.35, 0.11111111111111
24205, 0.043478260869565, 1.35, 0.083333333333333
24206, 0.021739130434783, 1.35, 0.16666666666667
24207, 0.043478260869565, 1.35, 0.13888888888889
24208, 0.021739130434783, 1.35, 0.22222222222222
24209, 0.043478260869565, 1.35, 0.19444444444444
24210, 0.021739130434783, 1.35, 0.27777777777778
24211, 0.043478260869565, 1.35, 0.25
24212, 0.021739130434783, 1.35, 0.33333333333333
24213, 0.043478260869565, 1.35, 0.30555555555556
24214, 0.021739130434783, 1.35, 0.38888888888889
24215, 0.043478260869565, 1.35, 0.36111111111111
24216, 0.021739130434783, 1.35, 0.44444444444444
24217, 0.043478260869565, 1.35, 0.41666666666667
24218, 0.043478260869565, 1.35, 0.47222222222222
24219, 0.065217391304348, 1.35, 0.055555555555556
24220, 0.08695652173913, 1.35, 0.027777777777778
24221, 0.065217391304348, 1.35, 0.11111111111111
24222, 0.08695652173913, 1.35, 0.083333333333333
24223, 0.065217391304348, 1.35, 0.16666666666667
24224, 0.08695652173913, 1.35, 0.13888888888889
24225, 0.065217391304348, 1.35, 0.22222222222222
24226, 0.08695652173913, 1.35, 0.19444444444444
24227, 0.065217391304348, 1.35, 0.27777777777778
24228, 0.08695652173913, 1.35, 0.25
24229, 0.065217391304348, 1.35, 0.33333333333333
24230, 0.08695652173913, 1.35, 0.30555555555556
24231, 0.065217391304348, 1.35, 0.38888888888889
24232, 0.08695652173913, 1.35, 0.36111111111111
24233, 0.065217391304348, 1.35, 0.44444444444444
24234, 0.08695652173913, 1.35, 0.41666666666667
24235, 0.08695652173913, 1.35, 0.47222222222222
24236, 0.10869565217391, 1.35, 0.055555555555556
24237, 0.1304347826087, 1.35, 0.027777777777778
24238, 0.10869565217391, 1.35, 0.11111111111111
24239, 0.1304347826087, 1.35, 0.083333333333333
24240, 0.10869565217391, 1.35, 0.16666666666667
24241, 0.1304347826087, 1.35, 0.13888888888889
24242, 0.10869565217391, 1.35, 0.22222222222222
24243, 0.1304347826087, 1.35, 0.19444444444444
24244, 0.10869565217391, 1.35, 0.27777777777778
24245, 0.1304347826087, 1.35, 0.25
24246, 0.10869565217391, 1.35, 0.33333333333333
24247, 0.1304347826087, 1.35, 0.30555555555556
24248, 0.10869565217391, 1.35, 0.38888888888889
24249, 0.1304347826087, 1.35, 0.36111111111111
24250, 0.10869565217391, 1.35, 0.44444444444444
24251, 0.1304347826087, 1.35, 0.41666666666667
24252, 0.1304347826087, 1.35, 0.47222222222222
24253, 0.15217391304348, 1.35, 0.055555555555556
24254, 0.17391304347826, 1.35, 0.027777777777778
24255, 0.15217391304348, 1.35, 0.11111111111111
24256, 0.17391304347826, 1.35, 0.083333333333333
24257, 0.15217391304348, 1.35, 0.16666666666667
24258, 0.17391304347826, 1.35, 0.13888888888889
24259, 0.15217391304348, 1.35, 0.22222222222222
24260, 0.17391304347826, 1.35, 0.19444444444444
24261, 0.15217391304348, 1.35, 0.27777777777778
24262, 0.17391304347826, 1.35, 0.25
24263, 0.15217391304348, 1.35, 0.33333333333333
24264, 0.17391304347826, 1.35, 0.30555555555556
24265, 0.15217391304348, 1.35, 0.38888888888889
24266, 0.17391304347826, 1.35, 0.36111111111111
24267, 0.15217391304348, 1.35, 0.44444444444444
24268, 0.17391304347826, 1.35, 0.41666666666667
24269, 0.17391304347826, 1.35, 0.47222222222222
24270, 0.19565217391304, 1.35, 0.055555555555556
24271, 0.21739130434783, 1.35, 0.027777777777778
24272, 0.19565217391304, 1.35, 0.11111111111111
24273, 0.21739130434783, 1.35, 0.083333333333333
24274, 0.19565217391304, 1.35, 0.16666666666667
24275, 0.21739130434783, 1.35, 0.13888888888889
24276, 0.19565217391304, 1.35, 0.22222222222222
24277, 0.21739130434783, 1.35, 0.19444444444444
24278, 0.19565217391304, 1.35, 0.27777777777778
24279, 0.21739130434783, 1.35, 0.25
24280, 0.19565217391304, 1.35, 0.33333333333333
24281, 0.21739130434783, 1.35, 0.30555555555556
24282, 0.19565217391304, 1.35, 0.38888888888889
24283, 0.21739130434783, 1.35, 0.36111111111111
24284, 0.19565217391304, 1.35, 0.44444444444444
24285, 0.21739130434783, 1.35, 0.41666666666667
24286, 0.21739130434783, 1.35, 0.47222222222222
24287, 0.23913043478261, 1.35, 0.055555555555556
24288, 0.26086956521739, 1.35, 0.027777777777778
24289, 0.23913043478261, 1.35, 0.11111111111111
24290, 0.26086956521739, 1.35, 0.083333333333333
24291, 0.23913043478261, 1.35, 0.16666666666667
24292, 0.26086956521739, 1.35, 0.13888888888889
24293, 0.23913043478261, 1.35, 0.22222222222222
24294, 0.26086956521739, 1.35, 0.19444444444444
24295, 0.23913043478261, 1.35, 0.27777777777778
24296, 0.26086956521739, 1.35, 0.25
24297, 0.23913043478261, 1.35, 0.33333333333333
24298, 0.26086956521739, 1.35, 0.30555555555556
24299, 0.23913043478261, 1.35, 0.38888888888889
24300, 0.26086956521739, 1.35, 0.36111111111111
24301, 0.23913043478261, 1.35, 0.44444444444444
24302, 0.26086956521739, 1.35, 0.41666666666667
24303, 0.26086956521739, 1.35, 0.47222222222222
24304, 0.28260869565217, 1.35, 0.055555555555556
24305, 0.30434782608696, 1.35, 0.027777777777778
24306, 0.28260869565217, 1.35, 0.11111111111111
24307, 0.30434782608696, 1.35, 0.083333333333333
24308, 0.28260869565217, 1.35, 0.16666666666667
24309, 0.30434782608696, 1.35, 0.13888888888889
24310, 0.28260869565217, 1.35, 0.22222222222222
24311, 0.30434782608696, 1.35, 0.19444444444444
24312, 0.28260869565217, 1.35, 0.27777777777778
24313, 0.30434782608696, 1.35, 0.25
24314, 0.28260869565217, 1.35, 0.33333333333333
24315, 0.30434782608696, 1.35, 0.30555555555556
24316, 0.28260869565217, 1.35, 0.38888888888889
24317, 0.30434782608696, 1.35, 0.36111111111111
