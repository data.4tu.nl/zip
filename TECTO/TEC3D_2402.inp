102472, 1.2869565217391, 0.41086956521739, -0.025
102473, 1.3086956521739, 0.41086956521739, -0.05
102474, 1.3304347826087, 0.43695652173913, -0.05
102475, 1.3304347826087, 0.41086956521739, -0.025
102476, 1.3521739130435, 0.41086956521739, -0.05
102477, 1.3739130434783, 0.43695652173913, -0.05
102478, 1.3739130434783, 0.41086956521739, -0.025
102479, 1.395652173913, 0.41086956521739, -0.05
102480, 1.4173913043478, 0.43695652173913, -0.05
102481, 1.4173913043478, 0.41086956521739, -0.025
102482, 1.4391304347826, 0.41086956521739, -0.05
102483, 1.4608695652174, 0.43695652173913, -0.05
102484, 1.4608695652174, 0.41086956521739, -0.025
102485, 1.4826086956522, 0.41086956521739, -0.05
102486, 1.504347826087, 0.43695652173913, -0.05
102487, 1.504347826087, 0.41086956521739, -0.025
102488, 1.5260869565217, 0.41086956521739, -0.05
102489, 1.5478260869565, 0.43695652173913, -0.05
102490, 1.5478260869565, 0.41086956521739, -0.025
102491, 1.5695652173913, 0.41086956521739, -0.05
102492, 1.5913043478261, 0.43695652173913, -0.05
102493, 1.5913043478261, 0.41086956521739, -0.025
102494, 1.6130434782609, 0.41086956521739, -0.05
102495, 1.6347826086957, 0.43695652173913, -0.05
102496, 1.6347826086957, 0.41086956521739, -0.025
102497, 1.6565217391304, 0.41086956521739, -0.05
102498, 1.6782608695652, 0.43695652173913, -0.05
102499, 1.6782608695652, 0.41086956521739, -0.025
102500, 1.7, 0.41086956521739, -0.05
102501, 1.7217391304348, 0.43695652173913, -0.05
102502, 1.7217391304348, 0.41086956521739, -0.025
102503, 1.7434782608696, 0.41086956521739, -0.05
102504, 1.7652173913043, 0.43695652173913, -0.05
102505, 1.7652173913043, 0.41086956521739, -0.025
102506, 1.7869565217391, 0.41086956521739, -0.05
102507, 1.8086956521739, 0.43695652173913, -0.05
102508, 1.8086956521739, 0.41086956521739, -0.025
102509, 1.8304347826087, 0.41086956521739, -0.05
102510, 1.8521739130435, 0.43695652173913, -0.05
102511, 1.8521739130435, 0.41086956521739, -0.025
102512, 1.8739130434783, 0.41086956521739, -0.05
102513, 1.895652173913, 0.43695652173913, -0.05
102514, 1.895652173913, 0.41086956521739, -0.025
102515, 1.9173913043478, 0.41086956521739, -0.05
102516, 1.9391304347826, 0.43695652173913, -0.05
102517, 1.9391304347826, 0.41086956521739, -0.025
102518, 1.9608695652174, 0.41086956521739, -0.05
102519, 1.9826086956522, 0.43695652173913, -0.05
102520, 1.9826086956522, 0.41086956521739, -0.025
102521, 2.004347826087, 0.41086956521739, -0.05
102522, 2.0260869565217, 0.43695652173913, -0.05
102523, 2.0260869565217, 0.41086956521739, -0.025
102524, 2.0478260869565, 0.41086956521739, -0.05
102525, 2.0695652173913, 0.43695652173913, -0.05
102526, 2.0695652173913, 0.41086956521739, -0.025
102527, 2.0913043478261, 0.41086956521739, -0.05
102528, 2.1130434782609, 0.43695652173913, -0.05
102529, 2.1130434782609, 0.41086956521739, -0.025
102530, 2.1347826086957, 0.41086956521739, -0.05
102531, 2.1565217391304, 0.43695652173913, -0.05
102532, 2.1565217391304, 0.41086956521739, -0.025
102533, 2.1782608695652, 0.41086956521739, -0.05
102534, 1.2217391304348, 0.35869565217391, -0.05
102535, 1.2434782608696, 0.38478260869565, -0.05
102536, 1.2434782608696, 0.35869565217391, -0.025
102537, 1.2652173913043, 0.35869565217391, -0.05
102538, 1.2869565217391, 0.38478260869565, -0.05
102539, 1.2869565217391, 0.35869565217391, -0.025
102540, 1.3086956521739, 0.35869565217391, -0.05
102541, 1.3304347826087, 0.38478260869565, -0.05
102542, 1.3304347826087, 0.35869565217391, -0.025
102543, 1.3521739130435, 0.35869565217391, -0.05
102544, 1.3739130434783, 0.38478260869565, -0.05
102545, 1.3739130434783, 0.35869565217391, -0.025
102546, 1.395652173913, 0.35869565217391, -0.05
102547, 1.4173913043478, 0.38478260869565, -0.05
102548, 1.4173913043478, 0.35869565217391, -0.025
102549, 1.4391304347826, 0.35869565217391, -0.05
102550, 1.4608695652174, 0.38478260869565, -0.05
102551, 1.4608695652174, 0.35869565217391, -0.025
102552, 1.4826086956522, 0.35869565217391, -0.05
102553, 1.504347826087, 0.38478260869565, -0.05
102554, 1.504347826087, 0.35869565217391, -0.025
102555, 1.5260869565217, 0.35869565217391, -0.05
102556, 1.5478260869565, 0.38478260869565, -0.05
102557, 1.5478260869565, 0.35869565217391, -0.025
102558, 1.5695652173913, 0.35869565217391, -0.05
102559, 1.5913043478261, 0.38478260869565, -0.05
102560, 1.5913043478261, 0.35869565217391, -0.025
102561, 1.6130434782609, 0.35869565217391, -0.05
102562, 1.6347826086957, 0.38478260869565, -0.05
102563, 1.6347826086957, 0.35869565217391, -0.025
102564, 1.6565217391304, 0.35869565217391, -0.05
102565, 1.6782608695652, 0.38478260869565, -0.05
102566, 1.6782608695652, 0.35869565217391, -0.025
102567, 1.7, 0.35869565217391, -0.05
102568, 1.7217391304348, 0.38478260869565, -0.05
102569, 1.7217391304348, 0.35869565217391, -0.025
102570, 1.7434782608696, 0.35869565217391, -0.05
102571, 1.7652173913043, 0.38478260869565, -0.05
102572, 1.7652173913043, 0.35869565217391, -0.025
102573, 1.7869565217391, 0.35869565217391, -0.05
102574, 1.8086956521739, 0.38478260869565, -0.05
102575, 1.8086956521739, 0.35869565217391, -0.025
102576, 1.8304347826087, 0.35869565217391, -0.05
102577, 1.8521739130435, 0.38478260869565, -0.05
102578, 1.8521739130435, 0.35869565217391, -0.025
102579, 1.8739130434783, 0.35869565217391, -0.05
102580, 1.895652173913, 0.38478260869565, -0.05
102581, 1.895652173913, 0.35869565217391, -0.025
102582, 1.9173913043478, 0.35869565217391, -0.05
102583, 1.9391304347826, 0.38478260869565, -0.05
102584, 1.9391304347826, 0.35869565217391, -0.025
102585, 1.9608695652174, 0.35869565217391, -0.05
102586, 1.9826086956522, 0.38478260869565, -0.05
102587, 1.9826086956522, 0.35869565217391, -0.025
102588, 2.004347826087, 0.35869565217391, -0.05
102589, 2.0260869565217, 0.38478260869565, -0.05
102590, 2.0260869565217, 0.35869565217391, -0.025
102591, 2.0478260869565, 0.35869565217391, -0.05
102592, 2.0695652173913, 0.38478260869565, -0.05
102593, 2.0695652173913, 0.35869565217391, -0.025
102594, 2.0913043478261, 0.35869565217391, -0.05
102595, 2.1130434782609, 0.38478260869565, -0.05
102596, 2.1130434782609, 0.35869565217391, -0.025
102597, 2.1347826086957, 0.35869565217391, -0.05
102598, 2.1565217391304, 0.38478260869565, -0.05
102599, 2.1565217391304, 0.35869565217391, -0.025
102600, 2.1782608695652, 0.35869565217391, -0.05
102601, 1.2217391304348, 0.30652173913044, -0.05
102602, 1.2434782608696, 0.33260869565217, -0.05
102603, 1.2434782608696, 0.30652173913044, -0.025
102604, 1.2652173913043, 0.30652173913043, -0.05
102605, 1.2869565217391, 0.33260869565217, -0.05
102606, 1.2869565217391, 0.30652173913043, -0.025
102607, 1.3086956521739, 0.30652173913043, -0.05
102608, 1.3304347826087, 0.33260869565217, -0.05
102609, 1.3304347826087, 0.30652173913043, -0.025
102610, 1.3521739130435, 0.30652173913043, -0.05
102611, 1.3739130434783, 0.33260869565217, -0.05
102612, 1.3739130434783, 0.30652173913044, -0.025
102613, 1.395652173913, 0.30652173913044, -0.05
102614, 1.4173913043478, 0.33260869565217, -0.05
102615, 1.4173913043478, 0.30652173913044, -0.025
102616, 1.4391304347826, 0.30652173913043, -0.05
102617, 1.4608695652174, 0.33260869565217, -0.05
102618, 1.4608695652174, 0.30652173913043, -0.025
102619, 1.4826086956522, 0.30652173913043, -0.05
102620, 1.504347826087, 0.33260869565217, -0.05
102621, 1.504347826087, 0.30652173913044, -0.025
102622, 1.5260869565217, 0.30652173913044, -0.05
102623, 1.5478260869565, 0.33260869565217, -0.05
102624, 1.5478260869565, 0.30652173913044, -0.025
102625, 1.5695652173913, 0.30652173913044, -0.05
102626, 1.5913043478261, 0.33260869565217, -0.05
102627, 1.5913043478261, 0.30652173913044, -0.025
102628, 1.6130434782609, 0.30652173913043, -0.05
102629, 1.6347826086957, 0.33260869565217, -0.05
102630, 1.6347826086957, 0.30652173913043, -0.025
102631, 1.6565217391304, 0.30652173913043, -0.05
102632, 1.6782608695652, 0.33260869565217, -0.05
102633, 1.6782608695652, 0.30652173913043, -0.025
102634, 1.7, 0.30652173913043, -0.05
102635, 1.7217391304348, 0.33260869565217, -0.05
102636, 1.7217391304348, 0.30652173913043, -0.025
102637, 1.7434782608696, 0.30652173913043, -0.05
102638, 1.7652173913043, 0.33260869565217, -0.05
102639, 1.7652173913043, 0.30652173913043, -0.025
102640, 1.7869565217391, 0.30652173913043, -0.05
102641, 1.8086956521739, 0.33260869565217, -0.05
102642, 1.8086956521739, 0.30652173913044, -0.025
102643, 1.8304347826087, 0.30652173913043, -0.05
102644, 1.8521739130435, 0.33260869565217, -0.05
102645, 1.8521739130435, 0.30652173913043, -0.025
102646, 1.8739130434783, 0.30652173913043, -0.05
102647, 1.895652173913, 0.33260869565217, -0.05
102648, 1.895652173913, 0.30652173913044, -0.025
102649, 1.9173913043478, 0.30652173913043, -0.05
102650, 1.9391304347826, 0.33260869565217, -0.05
102651, 1.9391304347826, 0.30652173913043, -0.025
102652, 1.9608695652174, 0.30652173913043, -0.05
102653, 1.9826086956522, 0.33260869565217, -0.05
102654, 1.9826086956522, 0.30652173913044, -0.025
102655, 2.004347826087, 0.30652173913044, -0.05
102656, 2.0260869565217, 0.33260869565217, -0.05
102657, 2.0260869565217, 0.30652173913044, -0.025
102658, 2.0478260869565, 0.30652173913043, -0.05
102659, 2.0695652173913, 0.33260869565217, -0.05
102660, 2.0695652173913, 0.30652173913043, -0.025
102661, 2.0913043478261, 0.30652173913043, -0.05
102662, 2.1130434782609, 0.33260869565217, -0.05
102663, 2.1130434782609, 0.30652173913043, -0.025
102664, 2.1347826086957, 0.30652173913043, -0.05
102665, 2.1565217391304, 0.33260869565217, -0.05
102666, 2.1565217391304, 0.30652173913043, -0.025
102667, 2.1782608695652, 0.30652173913043, -0.05
102668, 1.2217391304348, 0.25434782608696, -0.05
102669, 1.2434782608696, 0.2804347826087, -0.05
102670, 1.2434782608696, 0.25434782608696, -0.025
102671, 1.2652173913043, 0.25434782608696, -0.05
102672, 1.2869565217391, 0.2804347826087, -0.05
102673, 1.2869565217391, 0.25434782608696, -0.025
102674, 1.3086956521739, 0.25434782608696, -0.05
102675, 1.3304347826087, 0.2804347826087, -0.05
102676, 1.3304347826087, 0.25434782608696, -0.025
102677, 1.3521739130435, 0.25434782608696, -0.05
102678, 1.3739130434783, 0.2804347826087, -0.05
102679, 1.3739130434783, 0.25434782608696, -0.025
102680, 1.395652173913, 0.25434782608696, -0.05
102681, 1.4173913043478, 0.2804347826087, -0.05
102682, 1.4173913043478, 0.25434782608696, -0.025
102683, 1.4391304347826, 0.25434782608696, -0.05
102684, 1.4608695652174, 0.2804347826087, -0.05
102685, 1.4608695652174, 0.25434782608696, -0.025
102686, 1.4826086956522, 0.25434782608696, -0.05
102687, 1.504347826087, 0.2804347826087, -0.05
102688, 1.504347826087, 0.25434782608696, -0.025
102689, 1.5260869565217, 0.25434782608696, -0.05
102690, 1.5478260869565, 0.2804347826087, -0.05
102691, 1.5478260869565, 0.25434782608696, -0.025
102692, 1.5695652173913, 0.25434782608696, -0.05
102693, 1.5913043478261, 0.2804347826087, -0.05
102694, 1.5913043478261, 0.25434782608696, -0.025
102695, 1.6130434782609, 0.25434782608696, -0.05
102696, 1.6347826086957, 0.2804347826087, -0.05
102697, 1.6347826086957, 0.25434782608696, -0.025
102698, 1.6565217391304, 0.25434782608696, -0.05
102699, 1.6782608695652, 0.2804347826087, -0.05
102700, 1.6782608695652, 0.25434782608696, -0.025
102701, 1.7, 0.25434782608696, -0.05
102702, 1.7217391304348, 0.2804347826087, -0.05
102703, 1.7217391304348, 0.25434782608696, -0.025
102704, 1.7434782608696, 0.25434782608696, -0.05
102705, 1.7652173913043, 0.2804347826087, -0.05
102706, 1.7652173913043, 0.25434782608696, -0.025
102707, 1.7869565217391, 0.25434782608696, -0.05
102708, 1.8086956521739, 0.2804347826087, -0.05
102709, 1.8086956521739, 0.25434782608696, -0.025
102710, 1.8304347826087, 0.25434782608696, -0.05
102711, 1.8521739130435, 0.2804347826087, -0.05
102712, 1.8521739130435, 0.25434782608696, -0.025
102713, 1.8739130434783, 0.25434782608696, -0.05
102714, 1.895652173913, 0.2804347826087, -0.05
102715, 1.895652173913, 0.25434782608696, -0.025
102716, 1.9173913043478, 0.25434782608696, -0.05
102717, 1.9391304347826, 0.2804347826087, -0.05
102718, 1.9391304347826, 0.25434782608696, -0.025
102719, 1.9608695652174, 0.25434782608696, -0.05
102720, 1.9826086956522, 0.2804347826087, -0.05
102721, 1.9826086956522, 0.25434782608696, -0.025
102722, 2.004347826087, 0.25434782608696, -0.05
102723, 2.0260869565217, 0.2804347826087, -0.05
102724, 2.0260869565217, 0.25434782608696, -0.025
102725, 2.0478260869565, 0.25434782608696, -0.05
102726, 2.0695652173913, 0.2804347826087, -0.05
102727, 2.0695652173913, 0.25434782608696, -0.025
102728, 2.0913043478261, 0.25434782608696, -0.05
102729, 2.1130434782609, 0.2804347826087, -0.05
102730, 2.1130434782609, 0.25434782608696, -0.025
102731, 2.1347826086957, 0.25434782608696, -0.05
102732, 2.1565217391304, 0.2804347826087, -0.05
102733, 2.1565217391304, 0.25434782608696, -0.025
102734, 2.1782608695652, 0.25434782608696, -0.05
102735, 1.2217391304348, 0.20217391304348, -0.05
102736, 1.2434782608696, 0.22826086956522, -0.05
102737, 1.2434782608696, 0.20217391304348, -0.025
102738, 1.2652173913043, 0.20217391304348, -0.05
102739, 1.2869565217391, 0.22826086956522, -0.05
102740, 1.2869565217391, 0.20217391304348, -0.025
102741, 1.3086956521739, 0.20217391304348, -0.05
102742, 1.3304347826087, 0.22826086956522, -0.05
102743, 1.3304347826087, 0.20217391304348, -0.025
102744, 1.3521739130435, 0.20217391304348, -0.05
102745, 1.3739130434783, 0.22826086956522, -0.05
102746, 1.3739130434783, 0.20217391304348, -0.025
102747, 1.395652173913, 0.20217391304348, -0.05
102748, 1.4173913043478, 0.22826086956522, -0.05
102749, 1.4173913043478, 0.20217391304348, -0.025
102750, 1.4391304347826, 0.20217391304348, -0.05
102751, 1.4608695652174, 0.22826086956522, -0.05
102752, 1.4608695652174, 0.20217391304348, -0.025
102753, 1.4826086956522, 0.20217391304348, -0.05
102754, 1.504347826087, 0.22826086956522, -0.05
102755, 1.504347826087, 0.20217391304348, -0.025
102756, 1.5260869565217, 0.20217391304348, -0.05
102757, 1.5478260869565, 0.22826086956522, -0.05
102758, 1.5478260869565, 0.20217391304348, -0.025
102759, 1.5695652173913, 0.20217391304348, -0.05
102760, 1.5913043478261, 0.22826086956522, -0.05
102761, 1.5913043478261, 0.20217391304348, -0.025
102762, 1.6130434782609, 0.20217391304348, -0.05
102763, 1.6347826086957, 0.22826086956522, -0.05
102764, 1.6347826086957, 0.20217391304348, -0.025
102765, 1.6565217391304, 0.20217391304348, -0.05
102766, 1.6782608695652, 0.22826086956522, -0.05
102767, 1.6782608695652, 0.20217391304348, -0.025
102768, 1.7, 0.20217391304348, -0.05
102769, 1.7217391304348, 0.22826086956522, -0.05
102770, 1.7217391304348, 0.20217391304348, -0.025
102771, 1.7434782608696, 0.20217391304348, -0.05
102772, 1.7652173913043, 0.22826086956522, -0.05
102773, 1.7652173913043, 0.20217391304348, -0.025
102774, 1.7869565217391, 0.20217391304348, -0.05
102775, 1.8086956521739, 0.22826086956522, -0.05
102776, 1.8086956521739, 0.20217391304348, -0.025
102777, 1.8304347826087, 0.20217391304348, -0.05
102778, 1.8521739130435, 0.22826086956522, -0.05
102779, 1.8521739130435, 0.20217391304348, -0.025
102780, 1.8739130434783, 0.20217391304348, -0.05
102781, 1.895652173913, 0.22826086956522, -0.05
102782, 1.895652173913, 0.20217391304348, -0.025
102783, 1.9173913043478, 0.20217391304348, -0.05
102784, 1.9391304347826, 0.22826086956522, -0.05
102785, 1.9391304347826, 0.20217391304348, -0.025
102786, 1.9608695652174, 0.20217391304348, -0.05
102787, 1.9826086956522, 0.22826086956522, -0.05
102788, 1.9826086956522, 0.20217391304348, -0.025
102789, 2.004347826087, 0.20217391304348, -0.05
102790, 2.0260869565217, 0.22826086956522, -0.05
102791, 2.0260869565217, 0.20217391304348, -0.025
102792, 2.0478260869565, 0.20217391304348, -0.05
102793, 2.0695652173913, 0.22826086956522, -0.05
102794, 2.0695652173913, 0.20217391304348, -0.025
102795, 2.0913043478261, 0.20217391304348, -0.05
102796, 2.1130434782609, 0.22826086956522, -0.05
102797, 2.1130434782609, 0.20217391304348, -0.025
102798, 2.1347826086957, 0.20217391304348, -0.05
102799, 2.1565217391304, 0.22826086956522, -0.05
102800, 2.1565217391304, 0.20217391304348, -0.025
102801, 2.1782608695652, 0.20217391304348, -0.05
102802, 1.2434782608696, 0.17608695652174, -0.05
102803, 1.2869565217391, 0.17608695652174, -0.05
102804, 1.3304347826087, 0.17608695652174, -0.05
102805, 1.3739130434783, 0.17608695652174, -0.05
102806, 1.4173913043478, 0.17608695652174, -0.05
102807, 1.4608695652174, 0.17608695652174, -0.05
102808, 1.504347826087, 0.17608695652174, -0.05
102809, 1.5478260869565, 0.17608695652174, -0.05
102810, 1.5913043478261, 0.17608695652174, -0.05
102811, 1.6347826086957, 0.17608695652174, -0.05
102812, 1.6782608695652, 0.17608695652174, -0.05
102813, 1.7217391304348, 0.17608695652174, -0.05
102814, 1.7652173913043, 0.17608695652174, -0.05
102815, 1.8086956521739, 0.17608695652174, -0.05
102816, 1.8521739130435, 0.17608695652174, -0.05
102817, 1.895652173913, 0.17608695652174, -0.05
102818, 1.9391304347826, 0.17608695652174, -0.05
102819, 1.9826086956522, 0.17608695652174, -0.05
102820, 2.0260869565217, 0.17608695652174, -0.05
102821, 2.0695652173913, 0.17608695652174, -0.05
102822, 2.1130434782609, 0.17608695652174, -0.05
102823, 2.1565217391304, 0.17608695652174, -0.05
102824, 1.2217391304348, 1.2978260869565, -0.1
102825, 1.2434782608696, 1.3239130434783, -0.1
102826, 1.2434782608696, 1.2978260869565, -0.075
102827, 1.2652173913043, 1.2978260869565, -0.1
102828, 1.2869565217391, 1.3239130434783, -0.1
102829, 1.2869565217391, 1.2978260869565, -0.075
102830, 1.3086956521739, 1.2978260869565, -0.1
102831, 1.3304347826087, 1.3239130434783, -0.1
102832, 1.3304347826087, 1.2978260869565, -0.075
102833, 1.3521739130435, 1.2978260869565, -0.1
102834, 1.3739130434783, 1.3239130434783, -0.1
102835, 1.3739130434783, 1.2978260869565, -0.075
102836, 1.395652173913, 1.2978260869565, -0.1
102837, 1.4173913043478, 1.3239130434783, -0.1
102838, 1.4173913043478, 1.2978260869565, -0.075
102839, 1.4391304347826, 1.2978260869565, -0.1
102840, 1.4608695652174, 1.3239130434783, -0.1
102841, 1.4608695652174, 1.2978260869565, -0.075
102842, 1.4826086956522, 1.2978260869565, -0.1
102843, 1.504347826087, 1.3239130434783, -0.1
102844, 1.504347826087, 1.2978260869565, -0.075
102845, 1.5260869565217, 1.2978260869565, -0.1
102846, 1.5478260869565, 1.3239130434783, -0.1
102847, 1.5478260869565, 1.2978260869565, -0.075
102848, 1.5695652173913, 1.2978260869565, -0.1
102849, 1.5913043478261, 1.3239130434783, -0.1
102850, 1.5913043478261, 1.2978260869565, -0.075
102851, 1.6130434782609, 1.2978260869565, -0.1
102852, 1.6347826086957, 1.3239130434783, -0.1
102853, 1.6347826086957, 1.2978260869565, -0.075
102854, 1.6565217391304, 1.2978260869565, -0.1
102855, 1.6782608695652, 1.3239130434783, -0.1
102856, 1.6782608695652, 1.2978260869565, -0.075
102857, 1.7, 1.2978260869565, -0.1
102858, 1.7217391304348, 1.3239130434783, -0.1
102859, 1.7217391304348, 1.2978260869565, -0.075
102860, 1.7434782608696, 1.2978260869565, -0.1
102861, 1.7652173913043, 1.3239130434783, -0.1
102862, 1.7652173913043, 1.2978260869565, -0.075
102863, 1.7869565217391, 1.2978260869565, -0.1
102864, 1.8086956521739, 1.3239130434783, -0.1
102865, 1.8086956521739, 1.2978260869565, -0.075
102866, 1.8304347826087, 1.2978260869565, -0.1
102867, 1.8521739130435, 1.3239130434783, -0.1
102868, 1.8521739130435, 1.2978260869565, -0.075
102869, 1.8739130434783, 1.2978260869565, -0.1
102870, 1.895652173913, 1.3239130434783, -0.1
102871, 1.895652173913, 1.2978260869565, -0.075
102872, 1.9173913043478, 1.2978260869565, -0.1
102873, 1.9391304347826, 1.3239130434783, -0.1
102874, 1.9391304347826, 1.2978260869565, -0.075
102875, 1.9608695652174, 1.2978260869565, -0.1
102876, 1.9826086956522, 1.3239130434783, -0.1
102877, 1.9826086956522, 1.2978260869565, -0.075
102878, 2.004347826087, 1.2978260869565, -0.1
102879, 2.0260869565217, 1.3239130434783, -0.1
102880, 2.0260869565217, 1.2978260869565, -0.075
102881, 2.0478260869565, 1.2978260869565, -0.1
102882, 2.0695652173913, 1.3239130434783, -0.1
102883, 2.0695652173913, 1.2978260869565, -0.075
102884, 2.0913043478261, 1.2978260869565, -0.1
102885, 2.1130434782609, 1.3239130434783, -0.1
102886, 2.1130434782609, 1.2978260869565, -0.075
102887, 2.1347826086957, 1.2978260869565, -0.1
102888, 2.1565217391304, 1.3239130434783, -0.1
102889, 2.1565217391304, 1.2978260869565, -0.075
102890, 2.1782608695652, 1.2978260869565, -0.1
102891, 1.2217391304348, 1.245652173913, -0.1
102892, 1.2434782608696, 1.2717391304348, -0.1
102893, 1.2434782608696, 1.245652173913, -0.075
102894, 1.2652173913043, 1.245652173913, -0.1
102895, 1.2869565217391, 1.2717391304348, -0.1
102896, 1.2869565217391, 1.245652173913, -0.075
102897, 1.3086956521739, 1.245652173913, -0.1
102898, 1.3304347826087, 1.2717391304348, -0.1
102899, 1.3304347826087, 1.245652173913, -0.075
102900, 1.3521739130435, 1.245652173913, -0.1
102901, 1.3739130434783, 1.2717391304348, -0.1
102902, 1.3739130434783, 1.245652173913, -0.075
102903, 1.395652173913, 1.245652173913, -0.1
102904, 1.4173913043478, 1.2717391304348, -0.1
102905, 1.4173913043478, 1.245652173913, -0.075
102906, 1.4391304347826, 1.245652173913, -0.1
102907, 1.4608695652174, 1.2717391304348, -0.1
102908, 1.4608695652174, 1.245652173913, -0.075
102909, 1.4826086956522, 1.245652173913, -0.1
102910, 1.504347826087, 1.2717391304348, -0.1
102911, 1.504347826087, 1.245652173913, -0.075
102912, 1.5260869565217, 1.245652173913, -0.1
102913, 1.5478260869565, 1.2717391304348, -0.1
102914, 1.5478260869565, 1.245652173913, -0.075
102915, 1.5695652173913, 1.245652173913, -0.1
102916, 1.5913043478261, 1.2717391304348, -0.1
102917, 1.5913043478261, 1.245652173913, -0.075
102918, 1.6130434782609, 1.245652173913, -0.1
102919, 1.6347826086957, 1.2717391304348, -0.1
102920, 1.6347826086957, 1.245652173913, -0.075
102921, 1.6565217391304, 1.245652173913, -0.1
102922, 1.6782608695652, 1.2717391304348, -0.1
102923, 1.6782608695652, 1.245652173913, -0.075
102924, 1.7, 1.245652173913, -0.1
102925, 1.7217391304348, 1.2717391304348, -0.1
102926, 1.7217391304348, 1.245652173913, -0.075
102927, 1.7434782608696, 1.245652173913, -0.1
102928, 1.7652173913043, 1.2717391304348, -0.1
102929, 1.7652173913043, 1.245652173913, -0.075
102930, 1.7869565217391, 1.245652173913, -0.1
102931, 1.8086956521739, 1.2717391304348, -0.1
102932, 1.8086956521739, 1.245652173913, -0.075
102933, 1.8304347826087, 1.245652173913, -0.1
102934, 1.8521739130435, 1.2717391304348, -0.1
102935, 1.8521739130435, 1.245652173913, -0.075
102936, 1.8739130434783, 1.245652173913, -0.1
102937, 1.895652173913, 1.2717391304348, -0.1
102938, 1.895652173913, 1.245652173913, -0.075
102939, 1.9173913043478, 1.245652173913, -0.1
102940, 1.9391304347826, 1.2717391304348, -0.1
102941, 1.9391304347826, 1.245652173913, -0.075
102942, 1.9608695652174, 1.245652173913, -0.1
102943, 1.9826086956522, 1.2717391304348, -0.1
102944, 1.9826086956522, 1.245652173913, -0.075
102945, 2.004347826087, 1.245652173913, -0.1
102946, 2.0260869565217, 1.2717391304348, -0.1
102947, 2.0260869565217, 1.245652173913, -0.075
102948, 2.0478260869565, 1.245652173913, -0.1
102949, 2.0695652173913, 1.2717391304348, -0.1
102950, 2.0695652173913, 1.245652173913, -0.075
102951, 2.0913043478261, 1.245652173913, -0.1
102952, 2.1130434782609, 1.2717391304348, -0.1
102953, 2.1130434782609, 1.245652173913, -0.075
102954, 2.1347826086957, 1.245652173913, -0.1
102955, 2.1565217391304, 1.2717391304348, -0.1
102956, 2.1565217391304, 1.245652173913, -0.075
102957, 2.1782608695652, 1.245652173913, -0.1
102958, 1.2217391304348, 1.1934782608696, -0.1
102959, 1.2434782608696, 1.2195652173913, -0.1
102960, 1.2434782608696, 1.1934782608696, -0.075
102961, 1.2652173913043, 1.1934782608696, -0.1
102962, 1.2869565217391, 1.2195652173913, -0.1
102963, 1.2869565217391, 1.1934782608696, -0.075
102964, 1.3086956521739, 1.1934782608696, -0.1
102965, 1.3304347826087, 1.2195652173913, -0.1
102966, 1.3304347826087, 1.1934782608696, -0.075
102967, 1.3521739130435, 1.1934782608696, -0.1
102968, 1.3739130434783, 1.2195652173913, -0.1
102969, 1.3739130434783, 1.1934782608696, -0.075
102970, 1.395652173913, 1.1934782608696, -0.1
102971, 1.4173913043478, 1.2195652173913, -0.1
102972, 1.4173913043478, 1.1934782608696, -0.075
102973, 1.4391304347826, 1.1934782608696, -0.1
102974, 1.4608695652174, 1.2195652173913, -0.1
102975, 1.4608695652174, 1.1934782608696, -0.075
102976, 1.4826086956522, 1.1934782608696, -0.1
102977, 1.504347826087, 1.2195652173913, -0.1
102978, 1.504347826087, 1.1934782608696, -0.075
102979, 1.5260869565217, 1.1934782608696, -0.1
102980, 1.5478260869565, 1.2195652173913, -0.1
102981, 1.5478260869565, 1.1934782608696, -0.075
102982, 1.5695652173913, 1.1934782608696, -0.1
102983, 1.5913043478261, 1.2195652173913, -0.1
102984, 1.5913043478261, 1.1934782608696, -0.075
102985, 1.6130434782609, 1.1934782608696, -0.1
102986, 1.6347826086957, 1.2195652173913, -0.1
102987, 1.6347826086957, 1.1934782608696, -0.075
102988, 1.6565217391304, 1.1934782608696, -0.1
102989, 1.6782608695652, 1.2195652173913, -0.1
102990, 1.6782608695652, 1.1934782608696, -0.075
102991, 1.7, 1.1934782608696, -0.1
102992, 1.7217391304348, 1.2195652173913, -0.1
102993, 1.7217391304348, 1.1934782608696, -0.075
102994, 1.7434782608696, 1.1934782608696, -0.1
102995, 1.7652173913043, 1.2195652173913, -0.1
102996, 1.7652173913043, 1.1934782608696, -0.075
102997, 1.7869565217391, 1.1934782608696, -0.1
102998, 1.8086956521739, 1.2195652173913, -0.1
102999, 1.8086956521739, 1.1934782608696, -0.075
103000, 1.8304347826087, 1.1934782608696, -0.1
103001, 1.8521739130435, 1.2195652173913, -0.1
103002, 1.8521739130435, 1.1934782608696, -0.075
103003, 1.8739130434783, 1.1934782608696, -0.1
103004, 1.895652173913, 1.2195652173913, -0.1
103005, 1.895652173913, 1.1934782608696, -0.075
103006, 1.9173913043478, 1.1934782608696, -0.1
103007, 1.9391304347826, 1.2195652173913, -0.1
103008, 1.9391304347826, 1.1934782608696, -0.075
103009, 1.9608695652174, 1.1934782608696, -0.1
103010, 1.9826086956522, 1.2195652173913, -0.1
103011, 1.9826086956522, 1.1934782608696, -0.075
103012, 2.004347826087, 1.1934782608696, -0.1
103013, 2.0260869565217, 1.2195652173913, -0.1
103014, 2.0260869565217, 1.1934782608696, -0.075
103015, 2.0478260869565, 1.1934782608696, -0.1
103016, 2.0695652173913, 1.2195652173913, -0.1
103017, 2.0695652173913, 1.1934782608696, -0.075
103018, 2.0913043478261, 1.1934782608696, -0.1
103019, 2.1130434782609, 1.2195652173913, -0.1
103020, 2.1130434782609, 1.1934782608696, -0.075
103021, 2.1347826086957, 1.1934782608696, -0.1
103022, 2.1565217391304, 1.2195652173913, -0.1
103023, 2.1565217391304, 1.1934782608696, -0.075
103024, 2.1782608695652, 1.1934782608696, -0.1
103025, 1.2217391304348, 1.1413043478261, -0.1
103026, 1.2434782608696, 1.1673913043478, -0.1
103027, 1.2434782608696, 1.1413043478261, -0.075
103028, 1.2652173913043, 1.1413043478261, -0.1
103029, 1.2869565217391, 1.1673913043478, -0.1
103030, 1.2869565217391, 1.1413043478261, -0.075
103031, 1.3086956521739, 1.1413043478261, -0.1
103032, 1.3304347826087, 1.1673913043478, -0.1
103033, 1.3304347826087, 1.1413043478261, -0.075
103034, 1.3521739130435, 1.1413043478261, -0.1
103035, 1.3739130434783, 1.1673913043478, -0.1
103036, 1.3739130434783, 1.1413043478261, -0.075
103037, 1.395652173913, 1.1413043478261, -0.1
103038, 1.4173913043478, 1.1673913043478, -0.1
103039, 1.4173913043478, 1.1413043478261, -0.075
103040, 1.4391304347826, 1.1413043478261, -0.1
103041, 1.4608695652174, 1.1673913043478, -0.1
103042, 1.4608695652174, 1.1413043478261, -0.075
103043, 1.4826086956522, 1.1413043478261, -0.1
103044, 1.504347826087, 1.1673913043478, -0.1
103045, 1.504347826087, 1.1413043478261, -0.075
103046, 1.5260869565217, 1.1413043478261, -0.1
103047, 1.5478260869565, 1.1673913043478, -0.1
103048, 1.5478260869565, 1.1413043478261, -0.075
103049, 1.5695652173913, 1.1413043478261, -0.1
103050, 1.5913043478261, 1.1673913043478, -0.1
103051, 1.5913043478261, 1.1413043478261, -0.075
103052, 1.6130434782609, 1.1413043478261, -0.1
103053, 1.6347826086957, 1.1673913043478, -0.1
103054, 1.6347826086957, 1.1413043478261, -0.075
103055, 1.6565217391304, 1.1413043478261, -0.1
103056, 1.6782608695652, 1.1673913043478, -0.1
103057, 1.6782608695652, 1.1413043478261, -0.075
103058, 1.7, 1.1413043478261, -0.1
103059, 1.7217391304348, 1.1673913043478, -0.1
103060, 1.7217391304348, 1.1413043478261, -0.075
103061, 1.7434782608696, 1.1413043478261, -0.1
103062, 1.7652173913043, 1.1673913043478, -0.1
103063, 1.7652173913043, 1.1413043478261, -0.075
103064, 1.7869565217391, 1.1413043478261, -0.1
103065, 1.8086956521739, 1.1673913043478, -0.1
103066, 1.8086956521739, 1.1413043478261, -0.075
103067, 1.8304347826087, 1.1413043478261, -0.1
103068, 1.8521739130435, 1.1673913043478, -0.1
103069, 1.8521739130435, 1.1413043478261, -0.075
103070, 1.8739130434783, 1.1413043478261, -0.1
103071, 1.895652173913, 1.1673913043478, -0.1
103072, 1.895652173913, 1.1413043478261, -0.075
103073, 1.9173913043478, 1.1413043478261, -0.1
103074, 1.9391304347826, 1.1673913043478, -0.1
103075, 1.9391304347826, 1.1413043478261, -0.075
103076, 1.9608695652174, 1.1413043478261, -0.1
103077, 1.9826086956522, 1.1673913043478, -0.1
103078, 1.9826086956522, 1.1413043478261, -0.075
103079, 2.004347826087, 1.1413043478261, -0.1
103080, 2.0260869565217, 1.1673913043478, -0.1
103081, 2.0260869565217, 1.1413043478261, -0.075
103082, 2.0478260869565, 1.1413043478261, -0.1
103083, 2.0695652173913, 1.1673913043478, -0.1
103084, 2.0695652173913, 1.1413043478261, -0.075
103085, 2.0913043478261, 1.1413043478261, -0.1
103086, 2.1130434782609, 1.1673913043478, -0.1
103087, 2.1130434782609, 1.1413043478261, -0.075
103088, 2.1347826086957, 1.1413043478261, -0.1
103089, 2.1565217391304, 1.1673913043478, -0.1
103090, 2.1565217391304, 1.1413043478261, -0.075
103091, 2.1782608695652, 1.1413043478261, -0.1
103092, 1.2217391304348, 1.0891304347826, -0.1
103093, 1.2434782608696, 1.1152173913043, -0.1
103094, 1.2434782608696, 1.0891304347826, -0.075
103095, 1.2652173913043, 1.0891304347826, -0.1
103096, 1.2869565217391, 1.1152173913043, -0.1
103097, 1.2869565217391, 1.0891304347826, -0.075
103098, 1.3086956521739, 1.0891304347826, -0.1
103099, 1.3304347826087, 1.1152173913043, -0.1
103100, 1.3304347826087, 1.0891304347826, -0.075
103101, 1.3521739130435, 1.0891304347826, -0.1
103102, 1.3739130434783, 1.1152173913043, -0.1
103103, 1.3739130434783, 1.0891304347826, -0.075
103104, 1.395652173913, 1.0891304347826, -0.1
103105, 1.4173913043478, 1.1152173913043, -0.1
103106, 1.4173913043478, 1.0891304347826, -0.075
103107, 1.4391304347826, 1.0891304347826, -0.1
103108, 1.4608695652174, 1.1152173913043, -0.1
103109, 1.4608695652174, 1.0891304347826, -0.075
103110, 1.4826086956522, 1.0891304347826, -0.1
103111, 1.504347826087, 1.1152173913043, -0.1
103112, 1.504347826087, 1.0891304347826, -0.075
103113, 1.5260869565217, 1.0891304347826, -0.1
103114, 1.5478260869565, 1.1152173913043, -0.1
103115, 1.5478260869565, 1.0891304347826, -0.075
103116, 1.5695652173913, 1.0891304347826, -0.1
103117, 1.5913043478261, 1.1152173913043, -0.1
103118, 1.5913043478261, 1.0891304347826, -0.075
103119, 1.6130434782609, 1.0891304347826, -0.1
103120, 1.6347826086957, 1.1152173913043, -0.1
103121, 1.6347826086957, 1.0891304347826, -0.075
103122, 1.6565217391304, 1.0891304347826, -0.1
103123, 1.6782608695652, 1.1152173913043, -0.1
103124, 1.6782608695652, 1.0891304347826, -0.075
103125, 1.7, 1.0891304347826, -0.1
103126, 1.7217391304348, 1.1152173913043, -0.1
103127, 1.7217391304348, 1.0891304347826, -0.075
103128, 1.7434782608696, 1.0891304347826, -0.1
103129, 1.7652173913043, 1.1152173913043, -0.1
103130, 1.7652173913043, 1.0891304347826, -0.075
103131, 1.7869565217391, 1.0891304347826, -0.1
103132, 1.8086956521739, 1.1152173913043, -0.1
103133, 1.8086956521739, 1.0891304347826, -0.075
103134, 1.8304347826087, 1.0891304347826, -0.1
103135, 1.8521739130435, 1.1152173913043, -0.1
103136, 1.8521739130435, 1.0891304347826, -0.075
103137, 1.8739130434783, 1.0891304347826, -0.1
103138, 1.895652173913, 1.1152173913043, -0.1
103139, 1.895652173913, 1.0891304347826, -0.075
103140, 1.9173913043478, 1.0891304347826, -0.1
103141, 1.9391304347826, 1.1152173913043, -0.1
103142, 1.9391304347826, 1.0891304347826, -0.075
103143, 1.9608695652174, 1.0891304347826, -0.1
103144, 1.9826086956522, 1.1152173913043, -0.1
103145, 1.9826086956522, 1.0891304347826, -0.075
103146, 2.004347826087, 1.0891304347826, -0.1
103147, 2.0260869565217, 1.1152173913043, -0.1
103148, 2.0260869565217, 1.0891304347826, -0.075
103149, 2.0478260869565, 1.0891304347826, -0.1
103150, 2.0695652173913, 1.1152173913043, -0.1
103151, 2.0695652173913, 1.0891304347826, -0.075
103152, 2.0913043478261, 1.0891304347826, -0.1
103153, 2.1130434782609, 1.1152173913043, -0.1
103154, 2.1130434782609, 1.0891304347826, -0.075
103155, 2.1347826086957, 1.0891304347826, -0.1
103156, 2.1565217391304, 1.1152173913043, -0.1
103157, 2.1565217391304, 1.0891304347826, -0.075
103158, 2.1782608695652, 1.0891304347826, -0.1
103159, 1.2217391304348, 1.0369565217391, -0.1
103160, 1.2434782608696, 1.0630434782609, -0.1
103161, 1.2434782608696, 1.0369565217391, -0.075
103162, 1.2652173913043, 1.0369565217391, -0.1
103163, 1.2869565217391, 1.0630434782609, -0.1
103164, 1.2869565217391, 1.0369565217391, -0.075
103165, 1.3086956521739, 1.0369565217391, -0.1
103166, 1.3304347826087, 1.0630434782609, -0.1
103167, 1.3304347826087, 1.0369565217391, -0.075
103168, 1.3521739130435, 1.0369565217391, -0.1
103169, 1.3739130434783, 1.0630434782609, -0.1
103170, 1.3739130434783, 1.0369565217391, -0.075
103171, 1.395652173913, 1.0369565217391, -0.1
103172, 1.4173913043478, 1.0630434782609, -0.1
103173, 1.4173913043478, 1.0369565217391, -0.075
103174, 1.4391304347826, 1.0369565217391, -0.1
103175, 1.4608695652174, 1.0630434782609, -0.1
103176, 1.4608695652174, 1.0369565217391, -0.075
103177, 1.4826086956522, 1.0369565217391, -0.1
103178, 1.504347826087, 1.0630434782609, -0.1
103179, 1.504347826087, 1.0369565217391, -0.075
103180, 1.5260869565217, 1.0369565217391, -0.1
103181, 1.5478260869565, 1.0630434782609, -0.1
103182, 1.5478260869565, 1.0369565217391, -0.075
103183, 1.5695652173913, 1.0369565217391, -0.1
103184, 1.5913043478261, 1.0630434782609, -0.1
103185, 1.5913043478261, 1.0369565217391, -0.075
103186, 1.6130434782609, 1.0369565217391, -0.1
103187, 1.6347826086957, 1.0630434782609, -0.1
103188, 1.6347826086957, 1.0369565217391, -0.075
103189, 1.6565217391304, 1.0369565217391, -0.1
103190, 1.6782608695652, 1.0630434782609, -0.1
103191, 1.6782608695652, 1.0369565217391, -0.075
103192, 1.7, 1.0369565217391, -0.1
103193, 1.7217391304348, 1.0630434782609, -0.1
103194, 1.7217391304348, 1.0369565217391, -0.075
103195, 1.7434782608696, 1.0369565217391, -0.1
103196, 1.7652173913043, 1.0630434782609, -0.1
103197, 1.7652173913043, 1.0369565217391, -0.075
103198, 1.7869565217391, 1.0369565217391, -0.1
103199, 1.8086956521739, 1.0630434782609, -0.1
103200, 1.8086956521739, 1.0369565217391, -0.075
103201, 1.8304347826087, 1.0369565217391, -0.1
103202, 1.8521739130435, 1.0630434782609, -0.1
103203, 1.8521739130435, 1.0369565217391, -0.075
103204, 1.8739130434783, 1.0369565217391, -0.1
103205, 1.895652173913, 1.0630434782609, -0.1
103206, 1.895652173913, 1.0369565217391, -0.075
103207, 1.9173913043478, 1.0369565217391, -0.1
103208, 1.9391304347826, 1.0630434782609, -0.1
103209, 1.9391304347826, 1.0369565217391, -0.075
103210, 1.9608695652174, 1.0369565217391, -0.1
103211, 1.9826086956522, 1.0630434782609, -0.1
103212, 1.9826086956522, 1.0369565217391, -0.075
103213, 2.004347826087, 1.0369565217391, -0.1
103214, 2.0260869565217, 1.0630434782609, -0.1
103215, 2.0260869565217, 1.0369565217391, -0.075
103216, 2.0478260869565, 1.0369565217391, -0.1
103217, 2.0695652173913, 1.0630434782609, -0.1
103218, 2.0695652173913, 1.0369565217391, -0.075
103219, 2.0913043478261, 1.0369565217391, -0.1
103220, 2.1130434782609, 1.0630434782609, -0.1
103221, 2.1130434782609, 1.0369565217391, -0.075
103222, 2.1347826086957, 1.0369565217391, -0.1
103223, 2.1565217391304, 1.0630434782609, -0.1
103224, 2.1565217391304, 1.0369565217391, -0.075
103225, 2.1782608695652, 1.0369565217391, -0.1
103226, 1.2217391304348, 0.98478260869565, -0.1
103227, 1.2434782608696, 1.0108695652174, -0.1
103228, 1.2434782608696, 0.98478260869565, -0.075
103229, 1.2652173913043, 0.98478260869565, -0.1
103230, 1.2869565217391, 1.0108695652174, -0.1
103231, 1.2869565217391, 0.98478260869565, -0.075
103232, 1.3086956521739, 0.98478260869565, -0.1
103233, 1.3304347826087, 1.0108695652174, -0.1
103234, 1.3304347826087, 0.98478260869565, -0.075
103235, 1.3521739130435, 0.98478260869565, -0.1
103236, 1.3739130434783, 1.0108695652174, -0.1
103237, 1.3739130434783, 0.98478260869565, -0.075
103238, 1.395652173913, 0.98478260869565, -0.1
103239, 1.4173913043478, 1.0108695652174, -0.1
103240, 1.4173913043478, 0.98478260869565, -0.075
103241, 1.4391304347826, 0.98478260869565, -0.1
103242, 1.4608695652174, 1.0108695652174, -0.1
103243, 1.4608695652174, 0.98478260869565, -0.075
103244, 1.4826086956522, 0.98478260869565, -0.1
103245, 1.504347826087, 1.0108695652174, -0.1
103246, 1.504347826087, 0.98478260869565, -0.075
103247, 1.5260869565217, 0.98478260869565, -0.1
103248, 1.5478260869565, 1.0108695652174, -0.1
103249, 1.5478260869565, 0.98478260869565, -0.075
103250, 1.5695652173913, 0.98478260869565, -0.1
103251, 1.5913043478261, 1.0108695652174, -0.1
103252, 1.5913043478261, 0.98478260869565, -0.075
103253, 1.6130434782609, 0.98478260869565, -0.1
103254, 1.6347826086957, 1.0108695652174, -0.1
103255, 1.6347826086957, 0.98478260869565, -0.075
103256, 1.6565217391304, 0.98478260869565, -0.1
103257, 1.6782608695652, 1.0108695652174, -0.1
103258, 1.6782608695652, 0.98478260869565, -0.075
103259, 1.7, 0.98478260869565, -0.1
103260, 1.7217391304348, 1.0108695652174, -0.1
103261, 1.7217391304348, 0.98478260869565, -0.075
103262, 1.7434782608696, 0.98478260869565, -0.1
103263, 1.7652173913043, 1.0108695652174, -0.1
103264, 1.7652173913043, 0.98478260869565, -0.075
103265, 1.7869565217391, 0.98478260869565, -0.1
103266, 1.8086956521739, 1.0108695652174, -0.1
103267, 1.8086956521739, 0.98478260869565, -0.075
103268, 1.8304347826087, 0.98478260869565, -0.1
103269, 1.8521739130435, 1.0108695652174, -0.1
103270, 1.8521739130435, 0.98478260869565, -0.075
103271, 1.8739130434783, 0.98478260869565, -0.1
103272, 1.895652173913, 1.0108695652174, -0.1
103273, 1.895652173913, 0.98478260869565, -0.075
103274, 1.9173913043478, 0.98478260869565, -0.1
103275, 1.9391304347826, 1.0108695652174, -0.1
103276, 1.9391304347826, 0.98478260869565, -0.075
103277, 1.9608695652174, 0.98478260869565, -0.1
103278, 1.9826086956522, 1.0108695652174, -0.1
103279, 1.9826086956522, 0.98478260869565, -0.075
103280, 2.004347826087, 0.98478260869565, -0.1
103281, 2.0260869565217, 1.0108695652174, -0.1
103282, 2.0260869565217, 0.98478260869565, -0.075
103283, 2.0478260869565, 0.98478260869565, -0.1
103284, 2.0695652173913, 1.0108695652174, -0.1
103285, 2.0695652173913, 0.98478260869565, -0.075
103286, 2.0913043478261, 0.98478260869565, -0.1
103287, 2.1130434782609, 1.0108695652174, -0.1
103288, 2.1130434782609, 0.98478260869565, -0.075
103289, 2.1347826086957, 0.98478260869565, -0.1
103290, 2.1565217391304, 1.0108695652174, -0.1
103291, 2.1565217391304, 0.98478260869565, -0.075
103292, 2.1782608695652, 0.98478260869565, -0.1
103293, 1.2217391304348, 0.93260869565217, -0.1
103294, 1.2434782608696, 0.95869565217391, -0.1
103295, 1.2434782608696, 0.93260869565217, -0.075
103296, 1.2652173913043, 0.93260869565217, -0.1
103297, 1.2869565217391, 0.95869565217391, -0.1
103298, 1.2869565217391, 0.93260869565217, -0.075
103299, 1.3086956521739, 0.93260869565217, -0.1
103300, 1.3304347826087, 0.95869565217391, -0.1
103301, 1.3304347826087, 0.93260869565217, -0.075
103302, 1.3521739130435, 0.93260869565217, -0.1
103303, 1.3739130434783, 0.95869565217391, -0.1
103304, 1.3739130434783, 0.93260869565217, -0.075
103305, 1.395652173913, 0.93260869565217, -0.1
103306, 1.4173913043478, 0.95869565217391, -0.1
103307, 1.4173913043478, 0.93260869565217, -0.075
103308, 1.4391304347826, 0.93260869565217, -0.1
103309, 1.4608695652174, 0.95869565217391, -0.1
103310, 1.4608695652174, 0.93260869565217, -0.075
103311, 1.4826086956522, 0.93260869565217, -0.1
103312, 1.504347826087, 0.95869565217391, -0.1
103313, 1.504347826087, 0.93260869565217, -0.075
103314, 1.5260869565217, 0.93260869565217, -0.1
103315, 1.5478260869565, 0.95869565217391, -0.1
103316, 1.5478260869565, 0.93260869565217, -0.075
103317, 1.5695652173913, 0.93260869565217, -0.1
103318, 1.5913043478261, 0.95869565217391, -0.1
103319, 1.5913043478261, 0.93260869565217, -0.075
103320, 1.6130434782609, 0.93260869565217, -0.1
103321, 1.6347826086957, 0.95869565217391, -0.1
103322, 1.6347826086957, 0.93260869565217, -0.075
103323, 1.6565217391304, 0.93260869565217, -0.1
103324, 1.6782608695652, 0.95869565217391, -0.1
103325, 1.6782608695652, 0.93260869565217, -0.075
103326, 1.7, 0.93260869565217, -0.1
103327, 1.7217391304348, 0.95869565217391, -0.1
103328, 1.7217391304348, 0.93260869565217, -0.075
103329, 1.7434782608696, 0.93260869565217, -0.1
103330, 1.7652173913043, 0.95869565217391, -0.1
103331, 1.7652173913043, 0.93260869565217, -0.075
103332, 1.7869565217391, 0.93260869565217, -0.1
103333, 1.8086956521739, 0.95869565217391, -0.1
103334, 1.8086956521739, 0.93260869565217, -0.075
103335, 1.8304347826087, 0.93260869565217, -0.1
103336, 1.8521739130435, 0.95869565217391, -0.1
103337, 1.8521739130435, 0.93260869565218, -0.075
103338, 1.8739130434783, 0.93260869565217, -0.1
103339, 1.895652173913, 0.95869565217391, -0.1
103340, 1.895652173913, 0.93260869565217, -0.075
103341, 1.9173913043478, 0.93260869565217, -0.1
103342, 1.9391304347826, 0.95869565217391, -0.1
103343, 1.9391304347826, 0.93260869565218, -0.075
103344, 1.9608695652174, 0.93260869565217, -0.1
103345, 1.9826086956522, 0.95869565217391, -0.1
103346, 1.9826086956522, 0.93260869565217, -0.075
103347, 2.004347826087, 0.93260869565217, -0.1
103348, 2.0260869565217, 0.95869565217391, -0.1
103349, 2.0260869565217, 0.93260869565217, -0.075
103350, 2.0478260869565, 0.93260869565217, -0.1
103351, 2.0695652173913, 0.95869565217391, -0.1
103352, 2.0695652173913, 0.93260869565217, -0.075
103353, 2.0913043478261, 0.93260869565217, -0.1
103354, 2.1130434782609, 0.95869565217391, -0.1
103355, 2.1130434782609, 0.93260869565217, -0.075
103356, 2.1347826086957, 0.93260869565217, -0.1
103357, 2.1565217391304, 0.95869565217391, -0.1
103358, 2.1565217391304, 0.93260869565217, -0.075
103359, 2.1782608695652, 0.93260869565217, -0.1
103360, 1.2217391304348, 0.8804347826087, -0.1
103361, 1.2434782608696, 0.90652173913044, -0.1
103362, 1.2434782608696, 0.8804347826087, -0.075
103363, 1.2652173913043, 0.8804347826087, -0.1
103364, 1.2869565217391, 0.90652173913044, -0.1
103365, 1.2869565217391, 0.8804347826087, -0.075
103366, 1.3086956521739, 0.8804347826087, -0.1
103367, 1.3304347826087, 0.90652173913044, -0.1
103368, 1.3304347826087, 0.8804347826087, -0.075
103369, 1.3521739130435, 0.8804347826087, -0.1
103370, 1.3739130434783, 0.90652173913044, -0.1
103371, 1.3739130434783, 0.8804347826087, -0.075
103372, 1.395652173913, 0.8804347826087, -0.1
103373, 1.4173913043478, 0.90652173913044, -0.1
103374, 1.4173913043478, 0.8804347826087, -0.075
103375, 1.4391304347826, 0.8804347826087, -0.1
103376, 1.4608695652174, 0.90652173913044, -0.1
103377, 1.4608695652174, 0.8804347826087, -0.075
103378, 1.4826086956522, 0.8804347826087, -0.1
103379, 1.504347826087, 0.90652173913044, -0.1
103380, 1.504347826087, 0.8804347826087, -0.075
103381, 1.5260869565217, 0.8804347826087, -0.1
103382, 1.5478260869565, 0.90652173913044, -0.1
103383, 1.5478260869565, 0.8804347826087, -0.075
103384, 1.5695652173913, 0.8804347826087, -0.1
103385, 1.5913043478261, 0.90652173913044, -0.1
103386, 1.5913043478261, 0.8804347826087, -0.075
103387, 1.6130434782609, 0.8804347826087, -0.1
103388, 1.6347826086957, 0.90652173913044, -0.1
103389, 1.6347826086957, 0.8804347826087, -0.075
103390, 1.6565217391304, 0.8804347826087, -0.1
103391, 1.6782608695652, 0.90652173913044, -0.1
103392, 1.6782608695652, 0.8804347826087, -0.075
103393, 1.7, 0.8804347826087, -0.1
103394, 1.7217391304348, 0.90652173913044, -0.1
103395, 1.7217391304348, 0.8804347826087, -0.075
103396, 1.7434782608696, 0.8804347826087, -0.1
103397, 1.7652173913043, 0.90652173913044, -0.1
103398, 1.7652173913043, 0.8804347826087, -0.075
103399, 1.7869565217391, 0.8804347826087, -0.1
103400, 1.8086956521739, 0.90652173913044, -0.1
103401, 1.8086956521739, 0.8804347826087, -0.075
103402, 1.8304347826087, 0.8804347826087, -0.1
103403, 1.8521739130435, 0.90652173913044, -0.1
103404, 1.8521739130435, 0.8804347826087, -0.075
103405, 1.8739130434783, 0.8804347826087, -0.1
103406, 1.895652173913, 0.90652173913044, -0.1
103407, 1.895652173913, 0.8804347826087, -0.075
103408, 1.9173913043478, 0.8804347826087, -0.1
103409, 1.9391304347826, 0.90652173913044, -0.1
103410, 1.9391304347826, 0.8804347826087, -0.075
103411, 1.9608695652174, 0.8804347826087, -0.1
103412, 1.9826086956522, 0.90652173913044, -0.1
103413, 1.9826086956522, 0.8804347826087, -0.075
103414, 2.004347826087, 0.8804347826087, -0.1
103415, 2.0260869565217, 0.90652173913044, -0.1
103416, 2.0260869565217, 0.8804347826087, -0.075
103417, 2.0478260869565, 0.8804347826087, -0.1
103418, 2.0695652173913, 0.90652173913044, -0.1
103419, 2.0695652173913, 0.8804347826087, -0.075
103420, 2.0913043478261, 0.8804347826087, -0.1
103421, 2.1130434782609, 0.90652173913044, -0.1
103422, 2.1130434782609, 0.8804347826087, -0.075
103423, 2.1347826086957, 0.8804347826087, -0.1
103424, 2.1565217391304, 0.90652173913044, -0.1
103425, 2.1565217391304, 0.8804347826087, -0.075
103426, 2.1782608695652, 0.8804347826087, -0.1
103427, 1.2217391304348, 0.82826086956522, -0.1
103428, 1.2434782608696, 0.85434782608696, -0.1
103429, 1.2434782608696, 0.82826086956522, -0.075
103430, 1.2652173913043, 0.82826086956522, -0.1
103431, 1.2869565217391, 0.85434782608696, -0.1
103432, 1.2869565217391, 0.82826086956522, -0.075
103433, 1.3086956521739, 0.82826086956522, -0.1
103434, 1.3304347826087, 0.85434782608696, -0.1
103435, 1.3304347826087, 0.82826086956522, -0.075
103436, 1.3521739130435, 0.82826086956522, -0.1
103437, 1.3739130434783, 0.85434782608696, -0.1
103438, 1.3739130434783, 0.82826086956522, -0.075
103439, 1.395652173913, 0.82826086956522, -0.1
103440, 1.4173913043478, 0.85434782608696, -0.1
103441, 1.4173913043478, 0.82826086956522, -0.075
103442, 1.4391304347826, 0.82826086956522, -0.1
103443, 1.4608695652174, 0.85434782608696, -0.1
103444, 1.4608695652174, 0.82826086956522, -0.075
103445, 1.4826086956522, 0.82826086956522, -0.1
103446, 1.504347826087, 0.85434782608696, -0.1
103447, 1.504347826087, 0.82826086956522, -0.075
103448, 1.5260869565217, 0.82826086956522, -0.1
103449, 1.5478260869565, 0.85434782608696, -0.1
103450, 1.5478260869565, 0.82826086956522, -0.075
103451, 1.5695652173913, 0.82826086956522, -0.1
103452, 1.5913043478261, 0.85434782608696, -0.1
103453, 1.5913043478261, 0.82826086956522, -0.075
103454, 1.6130434782609, 0.82826086956522, -0.1
103455, 1.6347826086957, 0.85434782608696, -0.1
103456, 1.6347826086957, 0.82826086956522, -0.075
103457, 1.6565217391304, 0.82826086956522, -0.1
103458, 1.6782608695652, 0.85434782608696, -0.1
103459, 1.6782608695652, 0.82826086956522, -0.075
103460, 1.7, 0.82826086956522, -0.1
103461, 1.7217391304348, 0.85434782608696, -0.1
103462, 1.7217391304348, 0.82826086956522, -0.075
103463, 1.7434782608696, 0.82826086956522, -0.1
103464, 1.7652173913043, 0.85434782608696, -0.1
103465, 1.7652173913043, 0.82826086956522, -0.075
103466, 1.7869565217391, 0.82826086956522, -0.1
103467, 1.8086956521739, 0.85434782608696, -0.1
103468, 1.8086956521739, 0.82826086956522, -0.075
103469, 1.8304347826087, 0.82826086956522, -0.1
103470, 1.8521739130435, 0.85434782608696, -0.1
103471, 1.8521739130435, 0.82826086956522, -0.075
103472, 1.8739130434783, 0.82826086956522, -0.1
103473, 1.895652173913, 0.85434782608696, -0.1
103474, 1.895652173913, 0.82826086956522, -0.075
103475, 1.9173913043478, 0.82826086956522, -0.1
103476, 1.9391304347826, 0.85434782608696, -0.1
103477, 1.9391304347826, 0.82826086956522, -0.075
103478, 1.9608695652174, 0.82826086956522, -0.1
103479, 1.9826086956522, 0.85434782608696, -0.1
103480, 1.9826086956522, 0.82826086956522, -0.075
103481, 2.004347826087, 0.82826086956522, -0.1
103482, 2.0260869565217, 0.85434782608696, -0.1
103483, 2.0260869565217, 0.82826086956522, -0.075
103484, 2.0478260869565, 0.82826086956522, -0.1
103485, 2.0695652173913, 0.85434782608696, -0.1
103486, 2.0695652173913, 0.82826086956522, -0.075
103487, 2.0913043478261, 0.82826086956522, -0.1
103488, 2.1130434782609, 0.85434782608696, -0.1
103489, 2.1130434782609, 0.82826086956522, -0.075
103490, 2.1347826086957, 0.82826086956522, -0.1
103491, 2.1565217391304, 0.85434782608696, -0.1
103492, 2.1565217391304, 0.82826086956522, -0.075
103493, 2.1782608695652, 0.82826086956522, -0.1
103494, 1.2217391304348, 0.77608695652174, -0.1
103495, 1.2434782608696, 0.80217391304348, -0.1
103496, 1.2434782608696, 0.77608695652174, -0.075
103497, 1.2652173913043, 0.77608695652174, -0.1
103498, 1.2869565217391, 0.80217391304348, -0.1
103499, 1.2869565217391, 0.77608695652174, -0.075
103500, 1.3086956521739, 0.77608695652174, -0.1
103501, 1.3304347826087, 0.80217391304348, -0.1
103502, 1.3304347826087, 0.77608695652174, -0.075
103503, 1.3521739130435, 0.77608695652174, -0.1
103504, 1.3739130434783, 0.80217391304348, -0.1
103505, 1.3739130434783, 0.77608695652174, -0.075
103506, 1.395652173913, 0.77608695652174, -0.1
103507, 1.4173913043478, 0.80217391304348, -0.1
103508, 1.4173913043478, 0.77608695652174, -0.075
103509, 1.4391304347826, 0.77608695652174, -0.1
103510, 1.4608695652174, 0.80217391304348, -0.1
103511, 1.4608695652174, 0.77608695652174, -0.075
103512, 1.4826086956522, 0.77608695652174, -0.1
103513, 1.504347826087, 0.80217391304348, -0.1
103514, 1.504347826087, 0.77608695652174, -0.075
103515, 1.5260869565217, 0.77608695652174, -0.1
103516, 1.5478260869565, 0.80217391304348, -0.1
103517, 1.5478260869565, 0.77608695652174, -0.075
103518, 1.5695652173913, 0.77608695652174, -0.1
103519, 1.5913043478261, 0.80217391304348, -0.1
103520, 1.5913043478261, 0.77608695652174, -0.075
103521, 1.6130434782609, 0.77608695652174, -0.1
103522, 1.6347826086957, 0.80217391304348, -0.1
103523, 1.6347826086957, 0.77608695652174, -0.075
103524, 1.6565217391304, 0.77608695652174, -0.1
103525, 1.6782608695652, 0.80217391304348, -0.1
103526, 1.6782608695652, 0.77608695652174, -0.075
103527, 1.7, 0.77608695652174, -0.1
103528, 1.7217391304348, 0.80217391304348, -0.1
103529, 1.7217391304348, 0.77608695652174, -0.075
103530, 1.7434782608696, 0.77608695652174, -0.1
103531, 1.7652173913043, 0.80217391304348, -0.1
103532, 1.7652173913043, 0.77608695652174, -0.075
103533, 1.7869565217391, 0.77608695652174, -0.1
103534, 1.8086956521739, 0.80217391304348, -0.1
103535, 1.8086956521739, 0.77608695652174, -0.075
103536, 1.8304347826087, 0.77608695652174, -0.1
103537, 1.8521739130435, 0.80217391304348, -0.1
103538, 1.8521739130435, 0.77608695652174, -0.075
103539, 1.8739130434783, 0.77608695652174, -0.1
103540, 1.895652173913, 0.80217391304348, -0.1
103541, 1.895652173913, 0.77608695652174, -0.075
103542, 1.9173913043478, 0.77608695652174, -0.1
103543, 1.9391304347826, 0.80217391304348, -0.1
103544, 1.9391304347826, 0.77608695652174, -0.075
103545, 1.9608695652174, 0.77608695652174, -0.1
103546, 1.9826086956522, 0.80217391304348, -0.1
103547, 1.9826086956522, 0.77608695652174, -0.075
103548, 2.004347826087, 0.77608695652174, -0.1
103549, 2.0260869565217, 0.80217391304348, -0.1
103550, 2.0260869565217, 0.77608695652174, -0.075
103551, 2.0478260869565, 0.77608695652174, -0.1
103552, 2.0695652173913, 0.80217391304348, -0.1
103553, 2.0695652173913, 0.77608695652174, -0.075
103554, 2.0913043478261, 0.77608695652174, -0.1
103555, 2.1130434782609, 0.80217391304348, -0.1
103556, 2.1130434782609, 0.77608695652174, -0.075
103557, 2.1347826086957, 0.77608695652174, -0.1
103558, 2.1565217391304, 0.80217391304348, -0.1
103559, 2.1565217391304, 0.77608695652174, -0.075
103560, 2.1782608695652, 0.77608695652174, -0.1
103561, 1.2217391304348, 0.72391304347826, -0.1
103562, 1.2434782608696, 0.75, -0.1
103563, 1.2434782608696, 0.72391304347826, -0.075
103564, 1.2652173913043, 0.72391304347826, -0.1
103565, 1.2869565217391, 0.75, -0.1
103566, 1.2869565217391, 0.72391304347826, -0.075
103567, 1.3086956521739, 0.72391304347826, -0.1
103568, 1.3304347826087, 0.75, -0.1
103569, 1.3304347826087, 0.72391304347826, -0.075
103570, 1.3521739130435, 0.72391304347826, -0.1
103571, 1.3739130434783, 0.75, -0.1
103572, 1.3739130434783, 0.72391304347826, -0.075
103573, 1.395652173913, 0.72391304347826, -0.1
103574, 1.4173913043478, 0.75, -0.1
103575, 1.4173913043478, 0.72391304347826, -0.075
103576, 1.4391304347826, 0.72391304347826, -0.1
103577, 1.4608695652174, 0.75, -0.1
103578, 1.4608695652174, 0.72391304347826, -0.075
103579, 1.4826086956522, 0.72391304347826, -0.1
103580, 1.504347826087, 0.75, -0.1
103581, 1.504347826087, 0.72391304347826, -0.075
103582, 1.5260869565217, 0.72391304347826, -0.1
103583, 1.5478260869565, 0.75, -0.1
103584, 1.5478260869565, 0.72391304347826, -0.075
103585, 1.5695652173913, 0.72391304347826, -0.1
103586, 1.5913043478261, 0.75, -0.1
103587, 1.5913043478261, 0.72391304347826, -0.075
103588, 1.6130434782609, 0.72391304347826, -0.1
103589, 1.6347826086957, 0.75, -0.1
103590, 1.6347826086957, 0.72391304347826, -0.075
103591, 1.6565217391304, 0.72391304347826, -0.1
103592, 1.6782608695652, 0.75, -0.1
103593, 1.6782608695652, 0.72391304347826, -0.075
103594, 1.7, 0.72391304347826, -0.1
103595, 1.7217391304348, 0.75, -0.1
103596, 1.7217391304348, 0.72391304347826, -0.075
103597, 1.7434782608696, 0.72391304347826, -0.1
103598, 1.7652173913043, 0.75, -0.1
103599, 1.7652173913043, 0.72391304347826, -0.075
103600, 1.7869565217391, 0.72391304347826, -0.1
103601, 1.8086956521739, 0.75, -0.1
103602, 1.8086956521739, 0.72391304347826, -0.075
103603, 1.8304347826087, 0.72391304347826, -0.1
103604, 1.8521739130435, 0.75, -0.1
103605, 1.8521739130435, 0.72391304347826, -0.075
103606, 1.8739130434783, 0.72391304347826, -0.1
103607, 1.895652173913, 0.75, -0.1
103608, 1.895652173913, 0.72391304347826, -0.075
103609, 1.9173913043478, 0.72391304347826, -0.1
103610, 1.9391304347826, 0.75, -0.1
103611, 1.9391304347826, 0.72391304347826, -0.075
103612, 1.9608695652174, 0.72391304347826, -0.1
103613, 1.9826086956522, 0.75, -0.1
103614, 1.9826086956522, 0.72391304347826, -0.075
103615, 2.004347826087, 0.72391304347826, -0.1
103616, 2.0260869565217, 0.75, -0.1
103617, 2.0260869565217, 0.72391304347826, -0.075
103618, 2.0478260869565, 0.72391304347826, -0.1
103619, 2.0695652173913, 0.75, -0.1
103620, 2.0695652173913, 0.72391304347826, -0.075
103621, 2.0913043478261, 0.72391304347826, -0.1
103622, 2.1130434782609, 0.75, -0.1
103623, 2.1130434782609, 0.72391304347826, -0.075
103624, 2.1347826086957, 0.72391304347826, -0.1
103625, 2.1565217391304, 0.75, -0.1
103626, 2.1565217391304, 0.72391304347826, -0.075
103627, 2.1782608695652, 0.72391304347826, -0.1
103628, 1.2217391304348, 0.67173913043478, -0.1
103629, 1.2434782608696, 0.69782608695652, -0.1
103630, 1.2434782608696, 0.67173913043478, -0.075
103631, 1.2652173913043, 0.67173913043478, -0.1
103632, 1.2869565217391, 0.69782608695652, -0.1
103633, 1.2869565217391, 0.67173913043478, -0.075
103634, 1.3086956521739, 0.67173913043478, -0.1
103635, 1.3304347826087, 0.69782608695652, -0.1
103636, 1.3304347826087, 0.67173913043478, -0.075
103637, 1.3521739130435, 0.67173913043478, -0.1
103638, 1.3739130434783, 0.69782608695652, -0.1
103639, 1.3739130434783, 0.67173913043478, -0.075
103640, 1.395652173913, 0.67173913043478, -0.1
103641, 1.4173913043478, 0.69782608695652, -0.1
103642, 1.4173913043478, 0.67173913043478, -0.075
103643, 1.4391304347826, 0.67173913043478, -0.1
103644, 1.4608695652174, 0.69782608695652, -0.1
103645, 1.4608695652174, 0.67173913043478, -0.075
103646, 1.4826086956522, 0.67173913043478, -0.1
103647, 1.504347826087, 0.69782608695652, -0.1
103648, 1.504347826087, 0.67173913043478, -0.075
103649, 1.5260869565217, 0.67173913043478, -0.1
103650, 1.5478260869565, 0.69782608695652, -0.1
103651, 1.5478260869565, 0.67173913043478, -0.075
103652, 1.5695652173913, 0.67173913043478, -0.1
103653, 1.5913043478261, 0.69782608695652, -0.1
103654, 1.5913043478261, 0.67173913043478, -0.075
103655, 1.6130434782609, 0.67173913043478, -0.1
103656, 1.6347826086957, 0.69782608695652, -0.1
103657, 1.6347826086957, 0.67173913043478, -0.075
103658, 1.6565217391304, 0.67173913043478, -0.1
103659, 1.6782608695652, 0.69782608695652, -0.1
103660, 1.6782608695652, 0.67173913043478, -0.075
103661, 1.7, 0.67173913043478, -0.1
103662, 1.7217391304348, 0.69782608695652, -0.1
103663, 1.7217391304348, 0.67173913043478, -0.075
103664, 1.7434782608696, 0.67173913043478, -0.1
103665, 1.7652173913043, 0.69782608695652, -0.1
103666, 1.7652173913043, 0.67173913043478, -0.075
103667, 1.7869565217391, 0.67173913043478, -0.1
103668, 1.8086956521739, 0.69782608695652, -0.1
103669, 1.8086956521739, 0.67173913043478, -0.075
103670, 1.8304347826087, 0.67173913043478, -0.1
103671, 1.8521739130435, 0.69782608695652, -0.1
103672, 1.8521739130435, 0.67173913043478, -0.075
103673, 1.8739130434783, 0.67173913043478, -0.1
103674, 1.895652173913, 0.69782608695652, -0.1
103675, 1.895652173913, 0.67173913043478, -0.075
103676, 1.9173913043478, 0.67173913043478, -0.1
103677, 1.9391304347826, 0.69782608695652, -0.1
103678, 1.9391304347826, 0.67173913043478, -0.075
103679, 1.9608695652174, 0.67173913043478, -0.1
103680, 1.9826086956522, 0.69782608695652, -0.1
103681, 1.9826086956522, 0.67173913043478, -0.075
103682, 2.004347826087, 0.67173913043478, -0.1
103683, 2.0260869565217, 0.69782608695652, -0.1
103684, 2.0260869565217, 0.67173913043478, -0.075
103685, 2.0478260869565, 0.67173913043478, -0.1
103686, 2.0695652173913, 0.69782608695652, -0.1
103687, 2.0695652173913, 0.67173913043478, -0.075
103688, 2.0913043478261, 0.67173913043478, -0.1
103689, 2.1130434782609, 0.69782608695652, -0.1
103690, 2.1130434782609, 0.67173913043478, -0.075
103691, 2.1347826086957, 0.67173913043478, -0.1
103692, 2.1565217391304, 0.69782608695652, -0.1
103693, 2.1565217391304, 0.67173913043478, -0.075
103694, 2.1782608695652, 0.67173913043478, -0.1
103695, 1.2217391304348, 0.61956521739131, -0.1
103696, 1.2434782608696, 0.64565217391304, -0.1
103697, 1.2434782608696, 0.61956521739131, -0.075
103698, 1.2652173913043, 0.61956521739131, -0.1
103699, 1.2869565217391, 0.64565217391304, -0.1
103700, 1.2869565217391, 0.61956521739131, -0.075
103701, 1.3086956521739, 0.61956521739131, -0.1
103702, 1.3304347826087, 0.64565217391304, -0.1
103703, 1.3304347826087, 0.61956521739131, -0.075
103704, 1.3521739130435, 0.61956521739131, -0.1
103705, 1.3739130434783, 0.64565217391304, -0.1
103706, 1.3739130434783, 0.61956521739131, -0.075
103707, 1.395652173913, 0.61956521739131, -0.1
103708, 1.4173913043478, 0.64565217391304, -0.1
103709, 1.4173913043478, 0.61956521739131, -0.075
103710, 1.4391304347826, 0.61956521739131, -0.1
103711, 1.4608695652174, 0.64565217391304, -0.1
103712, 1.4608695652174, 0.6195652173913, -0.075
103713, 1.4826086956522, 0.6195652173913, -0.1
103714, 1.504347826087, 0.64565217391304, -0.1
103715, 1.504347826087, 0.6195652173913, -0.075
103716, 1.5260869565217, 0.6195652173913, -0.1
103717, 1.5478260869565, 0.64565217391304, -0.1
103718, 1.5478260869565, 0.61956521739131, -0.075
103719, 1.5695652173913, 0.6195652173913, -0.1
103720, 1.5913043478261, 0.64565217391304, -0.1
103721, 1.5913043478261, 0.6195652173913, -0.075
103722, 1.6130434782609, 0.6195652173913, -0.1
103723, 1.6347826086957, 0.64565217391304, -0.1
103724, 1.6347826086957, 0.61956521739131, -0.075
103725, 1.6565217391304, 0.61956521739131, -0.1
103726, 1.6782608695652, 0.64565217391304, -0.1
103727, 1.6782608695652, 0.61956521739131, -0.075
103728, 1.7, 0.61956521739131, -0.1
103729, 1.7217391304348, 0.64565217391304, -0.1
103730, 1.7217391304348, 0.61956521739131, -0.075
103731, 1.7434782608696, 0.61956521739131, -0.1
103732, 1.7652173913043, 0.64565217391304, -0.1
103733, 1.7652173913043, 0.61956521739131, -0.075
103734, 1.7869565217391, 0.61956521739131, -0.1
103735, 1.8086956521739, 0.64565217391304, -0.1
103736, 1.8086956521739, 0.61956521739131, -0.075
103737, 1.8304347826087, 0.61956521739131, -0.1
103738, 1.8521739130435, 0.64565217391304, -0.1
103739, 1.8521739130435, 0.61956521739131, -0.075
103740, 1.8739130434783, 0.61956521739131, -0.1
103741, 1.895652173913, 0.64565217391304, -0.1
103742, 1.895652173913, 0.61956521739131, -0.075
103743, 1.9173913043478, 0.61956521739131, -0.1
103744, 1.9391304347826, 0.64565217391304, -0.1
103745, 1.9391304347826, 0.61956521739131, -0.075
103746, 1.9608695652174, 0.61956521739131, -0.1
103747, 1.9826086956522, 0.64565217391304, -0.1
103748, 1.9826086956522, 0.61956521739131, -0.075
103749, 2.004347826087, 0.6195652173913, -0.1
103750, 2.0260869565217, 0.64565217391304, -0.1
103751, 2.0260869565217, 0.6195652173913, -0.075
103752, 2.0478260869565, 0.6195652173913, -0.1
103753, 2.0695652173913, 0.64565217391304, -0.1
103754, 2.0695652173913, 0.61956521739131, -0.075
103755, 2.0913043478261, 0.61956521739131, -0.1
103756, 2.1130434782609, 0.64565217391304, -0.1
103757, 2.1130434782609, 0.61956521739131, -0.075
103758, 2.1347826086957, 0.61956521739131, -0.1
103759, 2.1565217391304, 0.64565217391304, -0.1
103760, 2.1565217391304, 0.61956521739131, -0.075
103761, 2.1782608695652, 0.61956521739131, -0.1
103762, 1.2217391304348, 0.56739130434783, -0.1
103763, 1.2434782608696, 0.59347826086957, -0.1
103764, 1.2434782608696, 0.56739130434783, -0.075
103765, 1.2652173913043, 0.56739130434783, -0.1
103766, 1.2869565217391, 0.59347826086957, -0.1
103767, 1.2869565217391, 0.56739130434783, -0.075
103768, 1.3086956521739, 0.56739130434783, -0.1
103769, 1.3304347826087, 0.59347826086957, -0.1
103770, 1.3304347826087, 0.56739130434783, -0.075
103771, 1.3521739130435, 0.56739130434783, -0.1
103772, 1.3739130434783, 0.59347826086957, -0.1
103773, 1.3739130434783, 0.56739130434783, -0.075
103774, 1.395652173913, 0.56739130434783, -0.1
103775, 1.4173913043478, 0.59347826086957, -0.1
103776, 1.4173913043478, 0.56739130434783, -0.075
103777, 1.4391304347826, 0.56739130434783, -0.1
103778, 1.4608695652174, 0.59347826086957, -0.1
103779, 1.4608695652174, 0.56739130434783, -0.075
103780, 1.4826086956522, 0.56739130434783, -0.1
103781, 1.504347826087, 0.59347826086957, -0.1
103782, 1.504347826087, 0.56739130434783, -0.075
103783, 1.5260869565217, 0.56739130434783, -0.1
103784, 1.5478260869565, 0.59347826086957, -0.1
103785, 1.5478260869565, 0.56739130434783, -0.075
103786, 1.5695652173913, 0.56739130434783, -0.1
103787, 1.5913043478261, 0.59347826086957, -0.1
103788, 1.5913043478261, 0.56739130434783, -0.075
103789, 1.6130434782609, 0.56739130434783, -0.1
103790, 1.6347826086957, 0.59347826086957, -0.1
103791, 1.6347826086957, 0.56739130434783, -0.075
103792, 1.6565217391304, 0.56739130434783, -0.1
103793, 1.6782608695652, 0.59347826086957, -0.1
103794, 1.6782608695652, 0.56739130434783, -0.075
103795, 1.7, 0.56739130434783, -0.1
103796, 1.7217391304348, 0.59347826086957, -0.1
103797, 1.7217391304348, 0.56739130434783, -0.075
103798, 1.7434782608696, 0.56739130434783, -0.1
103799, 1.7652173913043, 0.59347826086957, -0.1
103800, 1.7652173913043, 0.56739130434783, -0.075
103801, 1.7869565217391, 0.56739130434783, -0.1
103802, 1.8086956521739, 0.59347826086957, -0.1
103803, 1.8086956521739, 0.56739130434783, -0.075
103804, 1.8304347826087, 0.56739130434783, -0.1
103805, 1.8521739130435, 0.59347826086957, -0.1
103806, 1.8521739130435, 0.56739130434783, -0.075
103807, 1.8739130434783, 0.56739130434783, -0.1
103808, 1.895652173913, 0.59347826086957, -0.1
103809, 1.895652173913, 0.56739130434783, -0.075
103810, 1.9173913043478, 0.56739130434783, -0.1
103811, 1.9391304347826, 0.59347826086957, -0.1
103812, 1.9391304347826, 0.56739130434783, -0.075
103813, 1.9608695652174, 0.56739130434783, -0.1
103814, 1.9826086956522, 0.59347826086957, -0.1
103815, 1.9826086956522, 0.56739130434783, -0.075
103816, 2.004347826087, 0.56739130434783, -0.1
103817, 2.0260869565217, 0.59347826086957, -0.1
103818, 2.0260869565217, 0.56739130434783, -0.075
103819, 2.0478260869565, 0.56739130434783, -0.1
103820, 2.0695652173913, 0.59347826086957, -0.1
103821, 2.0695652173913, 0.56739130434783, -0.075
103822, 2.0913043478261, 0.56739130434783, -0.1
103823, 2.1130434782609, 0.59347826086957, -0.1
103824, 2.1130434782609, 0.56739130434783, -0.075
103825, 2.1347826086957, 0.56739130434783, -0.1
103826, 2.1565217391304, 0.59347826086957, -0.1
103827, 2.1565217391304, 0.56739130434783, -0.075
103828, 2.1782608695652, 0.56739130434783, -0.1
103829, 1.2217391304348, 0.51521739130435, -0.1
103830, 1.2434782608696, 0.54130434782609, -0.1
103831, 1.2434782608696, 0.51521739130435, -0.075
103832, 1.2652173913043, 0.51521739130435, -0.1
103833, 1.2869565217391, 0.54130434782609, -0.1
103834, 1.2869565217391, 0.51521739130435, -0.075
103835, 1.3086956521739, 0.51521739130435, -0.1
103836, 1.3304347826087, 0.54130434782609, -0.1
103837, 1.3304347826087, 0.51521739130435, -0.075
103838, 1.3521739130435, 0.51521739130435, -0.1
103839, 1.3739130434783, 0.54130434782609, -0.1
103840, 1.3739130434783, 0.51521739130435, -0.075
103841, 1.395652173913, 0.51521739130435, -0.1
103842, 1.4173913043478, 0.54130434782609, -0.1
103843, 1.4173913043478, 0.51521739130435, -0.075
103844, 1.4391304347826, 0.51521739130435, -0.1
103845, 1.4608695652174, 0.54130434782609, -0.1
103846, 1.4608695652174, 0.51521739130435, -0.075
103847, 1.4826086956522, 0.51521739130435, -0.1
103848, 1.504347826087, 0.54130434782609, -0.1
103849, 1.504347826087, 0.51521739130435, -0.075
103850, 1.5260869565217, 0.51521739130435, -0.1
103851, 1.5478260869565, 0.54130434782609, -0.1
103852, 1.5478260869565, 0.51521739130435, -0.075
103853, 1.5695652173913, 0.51521739130435, -0.1
103854, 1.5913043478261, 0.54130434782609, -0.1
103855, 1.5913043478261, 0.51521739130435, -0.075
103856, 1.6130434782609, 0.51521739130435, -0.1
103857, 1.6347826086957, 0.54130434782609, -0.1
103858, 1.6347826086957, 0.51521739130435, -0.075
103859, 1.6565217391304, 0.51521739130435, -0.1
103860, 1.6782608695652, 0.54130434782609, -0.1
103861, 1.6782608695652, 0.51521739130435, -0.075
103862, 1.7, 0.51521739130435, -0.1
103863, 1.7217391304348, 0.54130434782609, -0.1
103864, 1.7217391304348, 0.51521739130435, -0.075
103865, 1.7434782608696, 0.51521739130435, -0.1
103866, 1.7652173913043, 0.54130434782609, -0.1
103867, 1.7652173913043, 0.51521739130435, -0.075
103868, 1.7869565217391, 0.51521739130435, -0.1
103869, 1.8086956521739, 0.54130434782609, -0.1
103870, 1.8086956521739, 0.51521739130435, -0.075
103871, 1.8304347826087, 0.51521739130435, -0.1
103872, 1.8521739130435, 0.54130434782609, -0.1
103873, 1.8521739130435, 0.51521739130435, -0.075
103874, 1.8739130434783, 0.51521739130435, -0.1
103875, 1.895652173913, 0.54130434782609, -0.1
103876, 1.895652173913, 0.51521739130435, -0.075
103877, 1.9173913043478, 0.51521739130435, -0.1
103878, 1.9391304347826, 0.54130434782609, -0.1
103879, 1.9391304347826, 0.51521739130435, -0.075
103880, 1.9608695652174, 0.51521739130435, -0.1
103881, 1.9826086956522, 0.54130434782609, -0.1
103882, 1.9826086956522, 0.51521739130435, -0.075
103883, 2.004347826087, 0.51521739130435, -0.1
103884, 2.0260869565217, 0.54130434782609, -0.1
103885, 2.0260869565217, 0.51521739130435, -0.075
103886, 2.0478260869565, 0.51521739130435, -0.1
103887, 2.0695652173913, 0.54130434782609, -0.1
103888, 2.0695652173913, 0.51521739130435, -0.075
103889, 2.0913043478261, 0.51521739130435, -0.1
103890, 2.1130434782609, 0.54130434782609, -0.1
103891, 2.1130434782609, 0.51521739130435, -0.075
103892, 2.1347826086957, 0.51521739130435, -0.1
103893, 2.1565217391304, 0.54130434782609, -0.1
103894, 2.1565217391304, 0.51521739130435, -0.075
103895, 2.1782608695652, 0.51521739130435, -0.1
103896, 1.2217391304348, 0.46304347826087, -0.1
103897, 1.2434782608696, 0.48913043478261, -0.1
103898, 1.2434782608696, 0.46304347826087, -0.075
103899, 1.2652173913043, 0.46304347826087, -0.1
103900, 1.2869565217391, 0.48913043478261, -0.1
103901, 1.2869565217391, 0.46304347826087, -0.075
103902, 1.3086956521739, 0.46304347826087, -0.1
103903, 1.3304347826087, 0.48913043478261, -0.1
103904, 1.3304347826087, 0.46304347826087, -0.075
103905, 1.3521739130435, 0.46304347826087, -0.1
103906, 1.3739130434783, 0.48913043478261, -0.1
103907, 1.3739130434783, 0.46304347826087, -0.075
103908, 1.395652173913, 0.46304347826087, -0.1
103909, 1.4173913043478, 0.48913043478261, -0.1
103910, 1.4173913043478, 0.46304347826087, -0.075
103911, 1.4391304347826, 0.46304347826087, -0.1
103912, 1.4608695652174, 0.48913043478261, -0.1
103913, 1.4608695652174, 0.46304347826087, -0.075
103914, 1.4826086956522, 0.46304347826087, -0.1
103915, 1.504347826087, 0.48913043478261, -0.1
103916, 1.504347826087, 0.46304347826087, -0.075
103917, 1.5260869565217, 0.46304347826087, -0.1
103918, 1.5478260869565, 0.48913043478261, -0.1
103919, 1.5478260869565, 0.46304347826087, -0.075
103920, 1.5695652173913, 0.46304347826087, -0.1
103921, 1.5913043478261, 0.48913043478261, -0.1
103922, 1.5913043478261, 0.46304347826087, -0.075
103923, 1.6130434782609, 0.46304347826087, -0.1
103924, 1.6347826086957, 0.48913043478261, -0.1
103925, 1.6347826086957, 0.46304347826087, -0.075
103926, 1.6565217391304, 0.46304347826087, -0.1
103927, 1.6782608695652, 0.48913043478261, -0.1
103928, 1.6782608695652, 0.46304347826087, -0.075
103929, 1.7, 0.46304347826087, -0.1
103930, 1.7217391304348, 0.48913043478261, -0.1
103931, 1.7217391304348, 0.46304347826087, -0.075
103932, 1.7434782608696, 0.46304347826087, -0.1
103933, 1.7652173913043, 0.48913043478261, -0.1
103934, 1.7652173913043, 0.46304347826087, -0.075
103935, 1.7869565217391, 0.46304347826087, -0.1
103936, 1.8086956521739, 0.48913043478261, -0.1
103937, 1.8086956521739, 0.46304347826087, -0.075
103938, 1.8304347826087, 0.46304347826087, -0.1
103939, 1.8521739130435, 0.48913043478261, -0.1
103940, 1.8521739130435, 0.46304347826087, -0.075
103941, 1.8739130434783, 0.46304347826087, -0.1
103942, 1.895652173913, 0.48913043478261, -0.1
103943, 1.895652173913, 0.46304347826087, -0.075
103944, 1.9173913043478, 0.46304347826087, -0.1
103945, 1.9391304347826, 0.48913043478261, -0.1
103946, 1.9391304347826, 0.46304347826087, -0.075
103947, 1.9608695652174, 0.46304347826087, -0.1
103948, 1.9826086956522, 0.48913043478261, -0.1
103949, 1.9826086956522, 0.46304347826087, -0.075
103950, 2.004347826087, 0.46304347826087, -0.1
103951, 2.0260869565217, 0.48913043478261, -0.1
103952, 2.0260869565217, 0.46304347826087, -0.075
103953, 2.0478260869565, 0.46304347826087, -0.1
103954, 2.0695652173913, 0.48913043478261, -0.1
103955, 2.0695652173913, 0.46304347826087, -0.075
103956, 2.0913043478261, 0.46304347826087, -0.1
103957, 2.1130434782609, 0.48913043478261, -0.1
103958, 2.1130434782609, 0.46304347826087, -0.075
103959, 2.1347826086957, 0.46304347826087, -0.1
103960, 2.1565217391304, 0.48913043478261, -0.1
103961, 2.1565217391304, 0.46304347826087, -0.075
103962, 2.1782608695652, 0.46304347826087, -0.1
103963, 1.2217391304348, 0.41086956521739, -0.1
103964, 1.2434782608696, 0.43695652173913, -0.1
103965, 1.2434782608696, 0.41086956521739, -0.075
103966, 1.2652173913043, 0.41086956521739, -0.1
103967, 1.2869565217391, 0.43695652173913, -0.1
103968, 1.2869565217391, 0.41086956521739, -0.075
103969, 1.3086956521739, 0.41086956521739, -0.1
103970, 1.3304347826087, 0.43695652173913, -0.1
103971, 1.3304347826087, 0.41086956521739, -0.075
103972, 1.3521739130435, 0.41086956521739, -0.1
103973, 1.3739130434783, 0.43695652173913, -0.1
103974, 1.3739130434783, 0.41086956521739, -0.075
103975, 1.395652173913, 0.41086956521739, -0.1
103976, 1.4173913043478, 0.43695652173913, -0.1
103977, 1.4173913043478, 0.41086956521739, -0.075
103978, 1.4391304347826, 0.41086956521739, -0.1
103979, 1.4608695652174, 0.43695652173913, -0.1
103980, 1.4608695652174, 0.41086956521739, -0.075
103981, 1.4826086956522, 0.41086956521739, -0.1
103982, 1.504347826087, 0.43695652173913, -0.1
103983, 1.504347826087, 0.41086956521739, -0.075
103984, 1.5260869565217, 0.41086956521739, -0.1
103985, 1.5478260869565, 0.43695652173913, -0.1
103986, 1.5478260869565, 0.41086956521739, -0.075
103987, 1.5695652173913, 0.41086956521739, -0.1
103988, 1.5913043478261, 0.43695652173913, -0.1
103989, 1.5913043478261, 0.41086956521739, -0.075
103990, 1.6130434782609, 0.41086956521739, -0.1
103991, 1.6347826086957, 0.43695652173913, -0.1
103992, 1.6347826086957, 0.41086956521739, -0.075
103993, 1.6565217391304, 0.41086956521739, -0.1
103994, 1.6782608695652, 0.43695652173913, -0.1
103995, 1.6782608695652, 0.41086956521739, -0.075
103996, 1.7, 0.41086956521739, -0.1
103997, 1.7217391304348, 0.43695652173913, -0.1
103998, 1.7217391304348, 0.41086956521739, -0.075
103999, 1.7434782608696, 0.41086956521739, -0.1
104000, 1.7652173913043, 0.43695652173913, -0.1
104001, 1.7652173913043, 0.41086956521739, -0.075
104002, 1.7869565217391, 0.41086956521739, -0.1
104003, 1.8086956521739, 0.43695652173913, -0.1
104004, 1.8086956521739, 0.41086956521739, -0.075
104005, 1.8304347826087, 0.41086956521739, -0.1
104006, 1.8521739130435, 0.43695652173913, -0.1
104007, 1.8521739130435, 0.41086956521739, -0.075
104008, 1.8739130434783, 0.41086956521739, -0.1
104009, 1.895652173913, 0.43695652173913, -0.1
104010, 1.895652173913, 0.41086956521739, -0.075
104011, 1.9173913043478, 0.41086956521739, -0.1
104012, 1.9391304347826, 0.43695652173913, -0.1
104013, 1.9391304347826, 0.41086956521739, -0.075
104014, 1.9608695652174, 0.41086956521739, -0.1
104015, 1.9826086956522, 0.43695652173913, -0.1
104016, 1.9826086956522, 0.41086956521739, -0.075
104017, 2.004347826087, 0.41086956521739, -0.1
104018, 2.0260869565217, 0.43695652173913, -0.1
104019, 2.0260869565217, 0.41086956521739, -0.075
104020, 2.0478260869565, 0.41086956521739, -0.1
104021, 2.0695652173913, 0.43695652173913, -0.1
104022, 2.0695652173913, 0.41086956521739, -0.075
104023, 2.0913043478261, 0.41086956521739, -0.1
104024, 2.1130434782609, 0.43695652173913, -0.1
104025, 2.1130434782609, 0.41086956521739, -0.075
104026, 2.1347826086957, 0.41086956521739, -0.1
104027, 2.1565217391304, 0.43695652173913, -0.1
104028, 2.1565217391304, 0.41086956521739, -0.075
104029, 2.1782608695652, 0.41086956521739, -0.1
104030, 1.2217391304348, 0.35869565217391, -0.1
104031, 1.2434782608696, 0.38478260869565, -0.1
104032, 1.2434782608696, 0.35869565217391, -0.075
104033, 1.2652173913043, 0.35869565217391, -0.1
104034, 1.2869565217391, 0.38478260869565, -0.1
104035, 1.2869565217391, 0.35869565217391, -0.075
104036, 1.3086956521739, 0.35869565217391, -0.1
104037, 1.3304347826087, 0.38478260869565, -0.1
104038, 1.3304347826087, 0.35869565217391, -0.075
104039, 1.3521739130435, 0.35869565217391, -0.1
104040, 1.3739130434783, 0.38478260869565, -0.1
104041, 1.3739130434783, 0.35869565217391, -0.075
104042, 1.395652173913, 0.35869565217391, -0.1
104043, 1.4173913043478, 0.38478260869565, -0.1
104044, 1.4173913043478, 0.35869565217391, -0.075
104045, 1.4391304347826, 0.35869565217391, -0.1
104046, 1.4608695652174, 0.38478260869565, -0.1
104047, 1.4608695652174, 0.35869565217391, -0.075
104048, 1.4826086956522, 0.35869565217391, -0.1
104049, 1.504347826087, 0.38478260869565, -0.1
104050, 1.504347826087, 0.35869565217391, -0.075
104051, 1.5260869565217, 0.35869565217391, -0.1
104052, 1.5478260869565, 0.38478260869565, -0.1
104053, 1.5478260869565, 0.35869565217391, -0.075
104054, 1.5695652173913, 0.35869565217391, -0.1
104055, 1.5913043478261, 0.38478260869565, -0.1
104056, 1.5913043478261, 0.35869565217391, -0.075
104057, 1.6130434782609, 0.35869565217391, -0.1
104058, 1.6347826086957, 0.38478260869565, -0.1
104059, 1.6347826086957, 0.35869565217391, -0.075
104060, 1.6565217391304, 0.35869565217391, -0.1
104061, 1.6782608695652, 0.38478260869565, -0.1
104062, 1.6782608695652, 0.35869565217391, -0.075
104063, 1.7, 0.35869565217391, -0.1
104064, 1.7217391304348, 0.38478260869565, -0.1
104065, 1.7217391304348, 0.35869565217391, -0.075
104066, 1.7434782608696, 0.35869565217391, -0.1
104067, 1.7652173913043, 0.38478260869565, -0.1
104068, 1.7652173913043, 0.35869565217391, -0.075
104069, 1.7869565217391, 0.35869565217391, -0.1
104070, 1.8086956521739, 0.38478260869565, -0.1
104071, 1.8086956521739, 0.35869565217391, -0.075
104072, 1.8304347826087, 0.35869565217391, -0.1
104073, 1.8521739130435, 0.38478260869565, -0.1
104074, 1.8521739130435, 0.35869565217391, -0.075
104075, 1.8739130434783, 0.35869565217391, -0.1
104076, 1.895652173913, 0.38478260869565, -0.1
104077, 1.895652173913, 0.35869565217391, -0.075
104078, 1.9173913043478, 0.35869565217391, -0.1
104079, 1.9391304347826, 0.38478260869565, -0.1
104080, 1.9391304347826, 0.35869565217391, -0.075
104081, 1.9608695652174, 0.35869565217391, -0.1
104082, 1.9826086956522, 0.38478260869565, -0.1
104083, 1.9826086956522, 0.35869565217391, -0.075
104084, 2.004347826087, 0.35869565217391, -0.1
104085, 2.0260869565217, 0.38478260869565, -0.1
104086, 2.0260869565217, 0.35869565217391, -0.075
104087, 2.0478260869565, 0.35869565217391, -0.1
104088, 2.0695652173913, 0.38478260869565, -0.1
104089, 2.0695652173913, 0.35869565217391, -0.075
104090, 2.0913043478261, 0.35869565217391, -0.1
104091, 2.1130434782609, 0.38478260869565, -0.1
104092, 2.1130434782609, 0.35869565217391, -0.075
104093, 2.1347826086957, 0.35869565217391, -0.1
104094, 2.1565217391304, 0.38478260869565, -0.1
104095, 2.1565217391304, 0.35869565217391, -0.075
104096, 2.1782608695652, 0.35869565217391, -0.1
104097, 1.2217391304348, 0.30652173913044, -0.1
104098, 1.2434782608696, 0.33260869565217, -0.1
104099, 1.2434782608696, 0.30652173913044, -0.075
104100, 1.2652173913043, 0.30652173913044, -0.1
104101, 1.2869565217391, 0.33260869565217, -0.1
104102, 1.2869565217391, 0.30652173913043, -0.075
104103, 1.3086956521739, 0.30652173913043, -0.1
104104, 1.3304347826087, 0.33260869565217, -0.1
104105, 1.3304347826087, 0.30652173913043, -0.075
104106, 1.3521739130435, 0.30652173913044, -0.1
104107, 1.3739130434783, 0.33260869565217, -0.1
104108, 1.3739130434783, 0.30652173913044, -0.075
104109, 1.395652173913, 0.30652173913044, -0.1
104110, 1.4173913043478, 0.33260869565217, -0.1
104111, 1.4173913043478, 0.30652173913044, -0.075
104112, 1.4391304347826, 0.30652173913044, -0.1
104113, 1.4608695652174, 0.33260869565217, -0.1
104114, 1.4608695652174, 0.30652173913043, -0.075
104115, 1.4826086956522, 0.30652173913044, -0.1
104116, 1.504347826087, 0.33260869565217, -0.1
104117, 1.504347826087, 0.30652173913044, -0.075
104118, 1.5260869565217, 0.30652173913044, -0.1
104119, 1.5478260869565, 0.33260869565217, -0.1
104120, 1.5478260869565, 0.30652173913044, -0.075
104121, 1.5695652173913, 0.30652173913044, -0.1
104122, 1.5913043478261, 0.33260869565217, -0.1
104123, 1.5913043478261, 0.30652173913044, -0.075
104124, 1.6130434782609, 0.30652173913044, -0.1
104125, 1.6347826086957, 0.33260869565217, -0.1
104126, 1.6347826086957, 0.30652173913043, -0.075
104127, 1.6565217391304, 0.30652173913043, -0.1
104128, 1.6782608695652, 0.33260869565217, -0.1
104129, 1.6782608695652, 0.30652173913043, -0.075
104130, 1.7, 0.30652173913043, -0.1
104131, 1.7217391304348, 0.33260869565217, -0.1
104132, 1.7217391304348, 0.30652173913043, -0.075
104133, 1.7434782608696, 0.30652173913043, -0.1
104134, 1.7652173913043, 0.33260869565217, -0.1
104135, 1.7652173913043, 0.30652173913043, -0.075
104136, 1.7869565217391, 0.30652173913044, -0.1
104137, 1.8086956521739, 0.33260869565217, -0.1
104138, 1.8086956521739, 0.30652173913044, -0.075
104139, 1.8304347826087, 0.30652173913044, -0.1
104140, 1.8521739130435, 0.33260869565217, -0.1
104141, 1.8521739130435, 0.30652173913043, -0.075
104142, 1.8739130434783, 0.30652173913043, -0.1
104143, 1.895652173913, 0.33260869565217, -0.1
104144, 1.895652173913, 0.30652173913044, -0.075
104145, 1.9173913043478, 0.30652173913044, -0.1
104146, 1.9391304347826, 0.33260869565217, -0.1
104147, 1.9391304347826, 0.30652173913043, -0.075
104148, 1.9608695652174, 0.30652173913044, -0.1
104149, 1.9826086956522, 0.33260869565217, -0.1
104150, 1.9826086956522, 0.30652173913044, -0.075
104151, 2.004347826087, 0.30652173913044, -0.1
104152, 2.0260869565217, 0.33260869565217, -0.1
104153, 2.0260869565217, 0.30652173913044, -0.075
104154, 2.0478260869565, 0.30652173913044, -0.1
104155, 2.0695652173913, 0.33260869565217, -0.1
104156, 2.0695652173913, 0.30652173913043, -0.075
104157, 2.0913043478261, 0.30652173913043, -0.1
104158, 2.1130434782609, 0.33260869565217, -0.1
104159, 2.1130434782609, 0.30652173913043, -0.075
104160, 2.1347826086957, 0.30652173913043, -0.1
104161, 2.1565217391304, 0.33260869565217, -0.1
104162, 2.1565217391304, 0.30652173913043, -0.075
104163, 2.1782608695652, 0.30652173913044, -0.1
104164, 1.2217391304348, 0.25434782608696, -0.1
104165, 1.2434782608696, 0.2804347826087, -0.1
104166, 1.2434782608696, 0.25434782608696, -0.075
104167, 1.2652173913043, 0.25434782608696, -0.1
104168, 1.2869565217391, 0.2804347826087, -0.1
104169, 1.2869565217391, 0.25434782608696, -0.075
104170, 1.3086956521739, 0.25434782608696, -0.1
104171, 1.3304347826087, 0.2804347826087, -0.1
104172, 1.3304347826087, 0.25434782608696, -0.075
104173, 1.3521739130435, 0.25434782608696, -0.1
104174, 1.3739130434783, 0.2804347826087, -0.1
104175, 1.3739130434783, 0.25434782608696, -0.075
104176, 1.395652173913, 0.25434782608696, -0.1
104177, 1.4173913043478, 0.2804347826087, -0.1
104178, 1.4173913043478, 0.25434782608696, -0.075
104179, 1.4391304347826, 0.25434782608696, -0.1
104180, 1.4608695652174, 0.2804347826087, -0.1
104181, 1.4608695652174, 0.25434782608696, -0.075
104182, 1.4826086956522, 0.25434782608696, -0.1
104183, 1.504347826087, 0.2804347826087, -0.1
104184, 1.504347826087, 0.25434782608696, -0.075
104185, 1.5260869565217, 0.25434782608696, -0.1
104186, 1.5478260869565, 0.2804347826087, -0.1
104187, 1.5478260869565, 0.25434782608696, -0.075
104188, 1.5695652173913, 0.25434782608696, -0.1
104189, 1.5913043478261, 0.2804347826087, -0.1
104190, 1.5913043478261, 0.25434782608696, -0.075
104191, 1.6130434782609, 0.25434782608696, -0.1
104192, 1.6347826086957, 0.2804347826087, -0.1
104193, 1.6347826086957, 0.25434782608696, -0.075
104194, 1.6565217391304, 0.25434782608696, -0.1
104195, 1.6782608695652, 0.2804347826087, -0.1
104196, 1.6782608695652, 0.25434782608696, -0.075
104197, 1.7, 0.25434782608696, -0.1
104198, 1.7217391304348, 0.2804347826087, -0.1
104199, 1.7217391304348, 0.25434782608696, -0.075
104200, 1.7434782608696, 0.25434782608696, -0.1
104201, 1.7652173913043, 0.2804347826087, -0.1
104202, 1.7652173913043, 0.25434782608696, -0.075
104203, 1.7869565217391, 0.25434782608696, -0.1
104204, 1.8086956521739, 0.2804347826087, -0.1
104205, 1.8086956521739, 0.25434782608696, -0.075
104206, 1.8304347826087, 0.25434782608696, -0.1
104207, 1.8521739130435, 0.2804347826087, -0.1
104208, 1.8521739130435, 0.25434782608696, -0.075
104209, 1.8739130434783, 0.25434782608696, -0.1
104210, 1.895652173913, 0.2804347826087, -0.1
104211, 1.895652173913, 0.25434782608696, -0.075
104212, 1.9173913043478, 0.25434782608696, -0.1
104213, 1.9391304347826, 0.2804347826087, -0.1
104214, 1.9391304347826, 0.25434782608696, -0.075
104215, 1.9608695652174, 0.25434782608696, -0.1
104216, 1.9826086956522, 0.2804347826087, -0.1
104217, 1.9826086956522, 0.25434782608696, -0.075
104218, 2.004347826087, 0.25434782608696, -0.1
104219, 2.0260869565217, 0.2804347826087, -0.1
104220, 2.0260869565217, 0.25434782608696, -0.075
104221, 2.0478260869565, 0.25434782608696, -0.1
104222, 2.0695652173913, 0.2804347826087, -0.1
104223, 2.0695652173913, 0.25434782608696, -0.075
104224, 2.0913043478261, 0.25434782608696, -0.1
104225, 2.1130434782609, 0.2804347826087, -0.1
104226, 2.1130434782609, 0.25434782608696, -0.075
104227, 2.1347826086957, 0.25434782608696, -0.1
104228, 2.1565217391304, 0.2804347826087, -0.1
104229, 2.1565217391304, 0.25434782608696, -0.075
104230, 2.1782608695652, 0.25434782608696, -0.1
104231, 1.2217391304348, 0.20217391304348, -0.1
104232, 1.2434782608696, 0.22826086956522, -0.1
104233, 1.2434782608696, 0.20217391304348, -0.075
104234, 1.2652173913043, 0.20217391304348, -0.1
104235, 1.2869565217391, 0.22826086956522, -0.1
104236, 1.2869565217391, 0.20217391304348, -0.075
104237, 1.3086956521739, 0.20217391304348, -0.1
104238, 1.3304347826087, 0.22826086956522, -0.1
104239, 1.3304347826087, 0.20217391304348, -0.075
104240, 1.3521739130435, 0.20217391304348, -0.1
104241, 1.3739130434783, 0.22826086956522, -0.1
104242, 1.3739130434783, 0.20217391304348, -0.075
104243, 1.395652173913, 0.20217391304348, -0.1
104244, 1.4173913043478, 0.22826086956522, -0.1
104245, 1.4173913043478, 0.20217391304348, -0.075
104246, 1.4391304347826, 0.20217391304348, -0.1
104247, 1.4608695652174, 0.22826086956522, -0.1
104248, 1.4608695652174, 0.20217391304348, -0.075
104249, 1.4826086956522, 0.20217391304348, -0.1
104250, 1.504347826087, 0.22826086956522, -0.1
104251, 1.504347826087, 0.20217391304348, -0.075
104252, 1.5260869565217, 0.20217391304348, -0.1
104253, 1.5478260869565, 0.22826086956522, -0.1
104254, 1.5478260869565, 0.20217391304348, -0.075
104255, 1.5695652173913, 0.20217391304348, -0.1
104256, 1.5913043478261, 0.22826086956522, -0.1
104257, 1.5913043478261, 0.20217391304348, -0.075
104258, 1.6130434782609, 0.20217391304348, -0.1
104259, 1.6347826086957, 0.22826086956522, -0.1
104260, 1.6347826086957, 0.20217391304348, -0.075
104261, 1.6565217391304, 0.20217391304348, -0.1
104262, 1.6782608695652, 0.22826086956522, -0.1
104263, 1.6782608695652, 0.20217391304348, -0.075
104264, 1.7, 0.20217391304348, -0.1
104265, 1.7217391304348, 0.22826086956522, -0.1
104266, 1.7217391304348, 0.20217391304348, -0.075
104267, 1.7434782608696, 0.20217391304348, -0.1
104268, 1.7652173913043, 0.22826086956522, -0.1
104269, 1.7652173913043, 0.20217391304348, -0.075
104270, 1.7869565217391, 0.20217391304348, -0.1
104271, 1.8086956521739, 0.22826086956522, -0.1
104272, 1.8086956521739, 0.20217391304348, -0.075
104273, 1.8304347826087, 0.20217391304348, -0.1
104274, 1.8521739130435, 0.22826086956522, -0.1
104275, 1.8521739130435, 0.20217391304348, -0.075
104276, 1.8739130434783, 0.20217391304348, -0.1
104277, 1.895652173913, 0.22826086956522, -0.1
104278, 1.895652173913, 0.20217391304348, -0.075
104279, 1.9173913043478, 0.20217391304348, -0.1
104280, 1.9391304347826, 0.22826086956522, -0.1
104281, 1.9391304347826, 0.20217391304348, -0.075
104282, 1.9608695652174, 0.20217391304348, -0.1
104283, 1.9826086956522, 0.22826086956522, -0.1
104284, 1.9826086956522, 0.20217391304348, -0.075
104285, 2.004347826087, 0.20217391304348, -0.1
104286, 2.0260869565217, 0.22826086956522, -0.1
104287, 2.0260869565217, 0.20217391304348, -0.075
104288, 2.0478260869565, 0.20217391304348, -0.1
104289, 2.0695652173913, 0.22826086956522, -0.1
104290, 2.0695652173913, 0.20217391304348, -0.075
104291, 2.0913043478261, 0.20217391304348, -0.1
104292, 2.1130434782609, 0.22826086956522, -0.1
104293, 2.1130434782609, 0.20217391304348, -0.075
104294, 2.1347826086957, 0.20217391304348, -0.1
104295, 2.1565217391304, 0.22826086956522, -0.1
104296, 2.1565217391304, 0.20217391304348, -0.075
104297, 2.1782608695652, 0.20217391304348, -0.1
104298, 1.2434782608696, 0.17608695652174, -0.1
104299, 1.2869565217391, 0.17608695652174, -0.1
104300, 1.3304347826087, 0.17608695652174, -0.1
104301, 1.3739130434783, 0.17608695652174, -0.1
104302, 1.4173913043478, 0.17608695652174, -0.1
104303, 1.4608695652174, 0.17608695652174, -0.1
104304, 1.504347826087, 0.17608695652174, -0.1
104305, 1.5478260869565, 0.17608695652174, -0.1
104306, 1.5913043478261, 0.17608695652174, -0.1
104307, 1.6347826086957, 0.17608695652174, -0.1
104308, 1.6782608695652, 0.17608695652174, -0.1
104309, 1.7217391304348, 0.17608695652174, -0.1
104310, 1.7652173913043, 0.17608695652174, -0.1
104311, 1.8086956521739, 0.17608695652174, -0.1
104312, 1.8521739130435, 0.17608695652174, -0.1
104313, 1.895652173913, 0.17608695652174, -0.1
104314, 1.9391304347826, 0.17608695652174, -0.1
104315, 1.9826086956522, 0.17608695652174, -0.1
104316, 2.0260869565217, 0.17608695652174, -0.1
104317, 2.0695652173913, 0.17608695652174, -0.1
104318, 2.1130434782609, 0.17608695652174, -0.1
104319, 2.1565217391304, 0.17608695652174, -0.1
104320, 1.2217391304348, 1.2978260869565, -0.15
104321, 1.2434782608696, 1.3239130434783, -0.15
104322, 1.2434782608696, 1.2978260869565, -0.125
104323, 1.2652173913043, 1.2978260869565, -0.15
104324, 1.2869565217391, 1.3239130434783, -0.15
104325, 1.2869565217391, 1.2978260869565, -0.125
104326, 1.3086956521739, 1.2978260869565, -0.15
104327, 1.3304347826087, 1.3239130434783, -0.15
104328, 1.3304347826087, 1.2978260869565, -0.125
104329, 1.3521739130435, 1.2978260869565, -0.15
104330, 1.3739130434783, 1.3239130434783, -0.15
104331, 1.3739130434783, 1.2978260869565, -0.125
104332, 1.395652173913, 1.2978260869565, -0.15
104333, 1.4173913043478, 1.3239130434783, -0.15
104334, 1.4173913043478, 1.2978260869565, -0.125
104335, 1.4391304347826, 1.2978260869565, -0.15
104336, 1.4608695652174, 1.3239130434783, -0.15
104337, 1.4608695652174, 1.2978260869565, -0.125
104338, 1.4826086956522, 1.2978260869565, -0.15
104339, 1.504347826087, 1.3239130434783, -0.15
104340, 1.504347826087, 1.2978260869565, -0.125
104341, 1.5260869565217, 1.2978260869565, -0.15
104342, 1.5478260869565, 1.3239130434783, -0.15
104343, 1.5478260869565, 1.2978260869565, -0.125
104344, 1.5695652173913, 1.2978260869565, -0.15
104345, 1.5913043478261, 1.3239130434783, -0.15
104346, 1.5913043478261, 1.2978260869565, -0.125
104347, 1.6130434782609, 1.2978260869565, -0.15
104348, 1.6347826086957, 1.3239130434783, -0.15
104349, 1.6347826086957, 1.2978260869565, -0.125
104350, 1.6565217391304, 1.2978260869565, -0.15
104351, 1.6782608695652, 1.3239130434783, -0.15
104352, 1.6782608695652, 1.2978260869565, -0.125
104353, 1.7, 1.2978260869565, -0.15
104354, 1.7217391304348, 1.3239130434783, -0.15
104355, 1.7217391304348, 1.2978260869565, -0.125
104356, 1.7434782608696, 1.2978260869565, -0.15
104357, 1.7652173913043, 1.3239130434783, -0.15
104358, 1.7652173913043, 1.2978260869565, -0.125
104359, 1.7869565217391, 1.2978260869565, -0.15
104360, 1.8086956521739, 1.3239130434783, -0.15
104361, 1.8086956521739, 1.2978260869565, -0.125
104362, 1.8304347826087, 1.2978260869565, -0.15
104363, 1.8521739130435, 1.3239130434783, -0.15
104364, 1.8521739130435, 1.2978260869565, -0.125
104365, 1.8739130434783, 1.2978260869565, -0.15
104366, 1.895652173913, 1.3239130434783, -0.15
104367, 1.895652173913, 1.2978260869565, -0.125
104368, 1.9173913043478, 1.2978260869565, -0.15
104369, 1.9391304347826, 1.3239130434783, -0.15
104370, 1.9391304347826, 1.2978260869565, -0.125
104371, 1.9608695652174, 1.2978260869565, -0.15
104372, 1.9826086956522, 1.3239130434783, -0.15
104373, 1.9826086956522, 1.2978260869565, -0.125
104374, 2.004347826087, 1.2978260869565, -0.15
104375, 2.0260869565217, 1.3239130434783, -0.15
104376, 2.0260869565217, 1.2978260869565, -0.125
104377, 2.0478260869565, 1.2978260869565, -0.15
104378, 2.0695652173913, 1.3239130434783, -0.15
104379, 2.0695652173913, 1.2978260869565, -0.125
104380, 2.0913043478261, 1.2978260869565, -0.15
104381, 2.1130434782609, 1.3239130434783, -0.15
104382, 2.1130434782609, 1.2978260869565, -0.125
104383, 2.1347826086957, 1.2978260869565, -0.15
104384, 2.1565217391304, 1.3239130434783, -0.15
104385, 2.1565217391304, 1.2978260869565, -0.125
104386, 2.1782608695652, 1.2978260869565, -0.15
104387, 1.2217391304348, 1.245652173913, -0.15
104388, 1.2434782608696, 1.2717391304348, -0.15
104389, 1.2434782608696, 1.245652173913, -0.125
104390, 1.2652173913043, 1.245652173913, -0.15
104391, 1.2869565217391, 1.2717391304348, -0.15
104392, 1.2869565217391, 1.245652173913, -0.125
104393, 1.3086956521739, 1.245652173913, -0.15
104394, 1.3304347826087, 1.2717391304348, -0.15
104395, 1.3304347826087, 1.245652173913, -0.125
104396, 1.3521739130435, 1.245652173913, -0.15
104397, 1.3739130434783, 1.2717391304348, -0.15
104398, 1.3739130434783, 1.245652173913, -0.125
104399, 1.395652173913, 1.245652173913, -0.15
104400, 1.4173913043478, 1.2717391304348, -0.15
104401, 1.4173913043478, 1.245652173913, -0.125
104402, 1.4391304347826, 1.245652173913, -0.15
104403, 1.4608695652174, 1.2717391304348, -0.15
104404, 1.4608695652174, 1.245652173913, -0.125
104405, 1.4826086956522, 1.245652173913, -0.15
104406, 1.504347826087, 1.2717391304348, -0.15
104407, 1.504347826087, 1.245652173913, -0.125
104408, 1.5260869565217, 1.245652173913, -0.15
104409, 1.5478260869565, 1.2717391304348, -0.15
104410, 1.5478260869565, 1.245652173913, -0.125
104411, 1.5695652173913, 1.245652173913, -0.15
104412, 1.5913043478261, 1.2717391304348, -0.15
104413, 1.5913043478261, 1.245652173913, -0.125
104414, 1.6130434782609, 1.245652173913, -0.15
104415, 1.6347826086957, 1.2717391304348, -0.15
104416, 1.6347826086957, 1.245652173913, -0.125
104417, 1.6565217391304, 1.245652173913, -0.15
104418, 1.6782608695652, 1.2717391304348, -0.15
104419, 1.6782608695652, 1.245652173913, -0.125
104420, 1.7, 1.245652173913, -0.15
104421, 1.7217391304348, 1.2717391304348, -0.15
104422, 1.7217391304348, 1.245652173913, -0.125
104423, 1.7434782608696, 1.245652173913, -0.15
104424, 1.7652173913043, 1.2717391304348, -0.15
104425, 1.7652173913043, 1.245652173913, -0.125
104426, 1.7869565217391, 1.245652173913, -0.15
104427, 1.8086956521739, 1.2717391304348, -0.15
104428, 1.8086956521739, 1.245652173913, -0.125
104429, 1.8304347826087, 1.245652173913, -0.15
104430, 1.8521739130435, 1.2717391304348, -0.15
104431, 1.8521739130435, 1.245652173913, -0.125
104432, 1.8739130434783, 1.245652173913, -0.15
104433, 1.895652173913, 1.2717391304348, -0.15
104434, 1.895652173913, 1.245652173913, -0.125
104435, 1.9173913043478, 1.245652173913, -0.15
104436, 1.9391304347826, 1.2717391304348, -0.15
104437, 1.9391304347826, 1.245652173913, -0.125
104438, 1.9608695652174, 1.245652173913, -0.15
104439, 1.9826086956522, 1.2717391304348, -0.15
104440, 1.9826086956522, 1.245652173913, -0.125
104441, 2.004347826087, 1.245652173913, -0.15
104442, 2.0260869565217, 1.2717391304348, -0.15
104443, 2.0260869565217, 1.245652173913, -0.125
104444, 2.0478260869565, 1.245652173913, -0.15
104445, 2.0695652173913, 1.2717391304348, -0.15
104446, 2.0695652173913, 1.245652173913, -0.125
104447, 2.0913043478261, 1.245652173913, -0.15
104448, 2.1130434782609, 1.2717391304348, -0.15
104449, 2.1130434782609, 1.245652173913, -0.125
104450, 2.1347826086957, 1.245652173913, -0.15
104451, 2.1565217391304, 1.2717391304348, -0.15
104452, 2.1565217391304, 1.245652173913, -0.125
104453, 2.1782608695652, 1.245652173913, -0.15
104454, 1.2217391304348, 1.1934782608696, -0.15
104455, 1.2434782608696, 1.2195652173913, -0.15
104456, 1.2434782608696, 1.1934782608696, -0.125
104457, 1.2652173913043, 1.1934782608696, -0.15
104458, 1.2869565217391, 1.2195652173913, -0.15
104459, 1.2869565217391, 1.1934782608696, -0.125
104460, 1.3086956521739, 1.1934782608696, -0.15
104461, 1.3304347826087, 1.2195652173913, -0.15
104462, 1.3304347826087, 1.1934782608696, -0.125
104463, 1.3521739130435, 1.1934782608696, -0.15
104464, 1.3739130434783, 1.2195652173913, -0.15
104465, 1.3739130434783, 1.1934782608696, -0.125
104466, 1.395652173913, 1.1934782608696, -0.15
104467, 1.4173913043478, 1.2195652173913, -0.15
104468, 1.4173913043478, 1.1934782608696, -0.125
104469, 1.4391304347826, 1.1934782608696, -0.15
104470, 1.4608695652174, 1.2195652173913, -0.15
104471, 1.4608695652174, 1.1934782608696, -0.125
104472, 1.4826086956522, 1.1934782608696, -0.15
104473, 1.504347826087, 1.2195652173913, -0.15
104474, 1.504347826087, 1.1934782608696, -0.125
104475, 1.5260869565217, 1.1934782608696, -0.15
104476, 1.5478260869565, 1.2195652173913, -0.15
104477, 1.5478260869565, 1.1934782608696, -0.125
104478, 1.5695652173913, 1.1934782608696, -0.15
104479, 1.5913043478261, 1.2195652173913, -0.15
104480, 1.5913043478261, 1.1934782608696, -0.125
104481, 1.6130434782609, 1.1934782608696, -0.15
104482, 1.6347826086957, 1.2195652173913, -0.15
104483, 1.6347826086957, 1.1934782608696, -0.125
104484, 1.6565217391304, 1.1934782608696, -0.15
104485, 1.6782608695652, 1.2195652173913, -0.15
104486, 1.6782608695652, 1.1934782608696, -0.125
104487, 1.7, 1.1934782608696, -0.15
104488, 1.7217391304348, 1.2195652173913, -0.15
104489, 1.7217391304348, 1.1934782608696, -0.125
104490, 1.7434782608696, 1.1934782608696, -0.15
104491, 1.7652173913043, 1.2195652173913, -0.15
104492, 1.7652173913043, 1.1934782608696, -0.125
104493, 1.7869565217391, 1.1934782608696, -0.15
104494, 1.8086956521739, 1.2195652173913, -0.15
104495, 1.8086956521739, 1.1934782608696, -0.125
104496, 1.8304347826087, 1.1934782608696, -0.15
104497, 1.8521739130435, 1.2195652173913, -0.15
104498, 1.8521739130435, 1.1934782608696, -0.125
104499, 1.8739130434783, 1.1934782608696, -0.15
104500, 1.895652173913, 1.2195652173913, -0.15
104501, 1.895652173913, 1.1934782608696, -0.125
104502, 1.9173913043478, 1.1934782608696, -0.15
104503, 1.9391304347826, 1.2195652173913, -0.15
104504, 1.9391304347826, 1.1934782608696, -0.125
104505, 1.9608695652174, 1.1934782608696, -0.15
104506, 1.9826086956522, 1.2195652173913, -0.15
104507, 1.9826086956522, 1.1934782608696, -0.125
104508, 2.004347826087, 1.1934782608696, -0.15
104509, 2.0260869565217, 1.2195652173913, -0.15
104510, 2.0260869565217, 1.1934782608696, -0.125
104511, 2.0478260869565, 1.1934782608696, -0.15
104512, 2.0695652173913, 1.2195652173913, -0.15
104513, 2.0695652173913, 1.1934782608696, -0.125
104514, 2.0913043478261, 1.1934782608696, -0.15
104515, 2.1130434782609, 1.2195652173913, -0.15
104516, 2.1130434782609, 1.1934782608696, -0.125
104517, 2.1347826086957, 1.1934782608696, -0.15
104518, 2.1565217391304, 1.2195652173913, -0.15
104519, 2.1565217391304, 1.1934782608696, -0.125
104520, 2.1782608695652, 1.1934782608696, -0.15
104521, 1.2217391304348, 1.1413043478261, -0.15
104522, 1.2434782608696, 1.1673913043478, -0.15
104523, 1.2434782608696, 1.1413043478261, -0.125
104524, 1.2652173913043, 1.1413043478261, -0.15
104525, 1.2869565217391, 1.1673913043478, -0.15
104526, 1.2869565217391, 1.1413043478261, -0.125
104527, 1.3086956521739, 1.1413043478261, -0.15
104528, 1.3304347826087, 1.1673913043478, -0.15
104529, 1.3304347826087, 1.1413043478261, -0.125
104530, 1.3521739130435, 1.1413043478261, -0.15
104531, 1.3739130434783, 1.1673913043478, -0.15
104532, 1.3739130434783, 1.1413043478261, -0.125
104533, 1.395652173913, 1.1413043478261, -0.15
104534, 1.4173913043478, 1.1673913043478, -0.15
104535, 1.4173913043478, 1.1413043478261, -0.125
104536, 1.4391304347826, 1.1413043478261, -0.15
104537, 1.4608695652174, 1.1673913043478, -0.15
104538, 1.4608695652174, 1.1413043478261, -0.125
104539, 1.4826086956522, 1.1413043478261, -0.15
104540, 1.504347826087, 1.1673913043478, -0.15
104541, 1.504347826087, 1.1413043478261, -0.125
104542, 1.5260869565217, 1.1413043478261, -0.15
104543, 1.5478260869565, 1.1673913043478, -0.15
104544, 1.5478260869565, 1.1413043478261, -0.125
104545, 1.5695652173913, 1.1413043478261, -0.15
104546, 1.5913043478261, 1.1673913043478, -0.15
104547, 1.5913043478261, 1.1413043478261, -0.125
104548, 1.6130434782609, 1.1413043478261, -0.15
104549, 1.6347826086957, 1.1673913043478, -0.15
104550, 1.6347826086957, 1.1413043478261, -0.125
104551, 1.6565217391304, 1.1413043478261, -0.15
104552, 1.6782608695652, 1.1673913043478, -0.15
