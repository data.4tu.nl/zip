92137, 0.41304347826087, 1.375, 0.11111111111111
92138, 0.39130434782609, 1.3875, 0.11111111111111
92139, 0.39130434782609, 1.375, 0.13888888888889
92140, 0.41304347826087, 1.375, 0.16666666666667
92141, 0.39130434782609, 1.3875, 0.16666666666667
92142, 0.39130434782609, 1.375, 0.19444444444444
92143, 0.41304347826087, 1.375, 0.22222222222222
92144, 0.39130434782609, 1.3875, 0.22222222222222
92145, 0.39130434782609, 1.375, 0.25
92146, 0.41304347826087, 1.375, 0.27777777777778
92147, 0.39130434782609, 1.3875, 0.27777777777778
92148, 0.39130434782609, 1.375, 0.30555555555556
92149, 0.41304347826087, 1.375, 0.33333333333333
92150, 0.39130434782609, 1.3875, 0.33333333333333
92151, 0.39130434782609, 1.375, 0.36111111111111
92152, 0.41304347826087, 1.375, 0.38888888888889
92153, 0.39130434782609, 1.3875, 0.38888888888889
92154, 0.39130434782609, 1.375, 0.41666666666667
92155, 0.41304347826087, 1.375, 0.44444444444444
92156, 0.39130434782609, 1.3875, 0.44444444444444
92157, 0.39130434782609, 1.375, 0.47222222222222
92158, 0.34782608695652, 1.375, 0.027777777777778
92159, 0.3695652173913, 1.375, 0.055555555555556
92160, 0.34782608695652, 1.3875, 0.055555555555556
92161, 0.34782608695652, 1.375, 0.083333333333333
92162, 0.3695652173913, 1.375, 0.11111111111111
92163, 0.34782608695652, 1.3875, 0.11111111111111
92164, 0.34782608695652, 1.375, 0.13888888888889
92165, 0.3695652173913, 1.375, 0.16666666666667
92166, 0.34782608695652, 1.3875, 0.16666666666667
92167, 0.34782608695652, 1.375, 0.19444444444444
92168, 0.3695652173913, 1.375, 0.22222222222222
92169, 0.34782608695652, 1.3875, 0.22222222222222
92170, 0.34782608695652, 1.375, 0.25
92171, 0.3695652173913, 1.375, 0.27777777777778
92172, 0.34782608695652, 1.3875, 0.27777777777778
92173, 0.34782608695652, 1.375, 0.30555555555556
92174, 0.3695652173913, 1.375, 0.33333333333333
92175, 0.34782608695652, 1.3875, 0.33333333333333
92176, 0.34782608695652, 1.375, 0.36111111111111
92177, 0.3695652173913, 1.375, 0.38888888888889
92178, 0.34782608695652, 1.3875, 0.38888888888889
92179, 0.34782608695652, 1.375, 0.41666666666667
92180, 0.3695652173913, 1.375, 0.44444444444444
92181, 0.34782608695652, 1.3875, 0.44444444444444
92182, 0.34782608695652, 1.375, 0.47222222222222
92183, 0.30434782608696, 1.375, 0.027777777777778
92184, 0.32608695652174, 1.375, 0.055555555555556
92185, 0.30434782608696, 1.3875, 0.055555555555556
92186, 0.30434782608696, 1.375, 0.083333333333333
92187, 0.32608695652174, 1.375, 0.11111111111111
92188, 0.30434782608696, 1.3875, 0.11111111111111
92189, 0.30434782608696, 1.375, 0.13888888888889
92190, 0.32608695652174, 1.375, 0.16666666666667
92191, 0.30434782608696, 1.3875, 0.16666666666667
92192, 0.30434782608696, 1.375, 0.19444444444444
92193, 0.32608695652174, 1.375, 0.22222222222222
92194, 0.30434782608696, 1.3875, 0.22222222222222
92195, 0.30434782608696, 1.375, 0.25
92196, 0.32608695652174, 1.375, 0.27777777777778
92197, 0.30434782608696, 1.3875, 0.27777777777778
92198, 0.30434782608696, 1.375, 0.30555555555556
92199, 0.32608695652174, 1.375, 0.33333333333333
92200, 0.30434782608696, 1.3875, 0.33333333333333
92201, 0.30434782608696, 1.375, 0.36111111111111
92202, 0.32608695652174, 1.375, 0.38888888888889
92203, 0.30434782608696, 1.3875, 0.38888888888889
92204, 0.30434782608696, 1.375, 0.41666666666667
92205, 0.32608695652174, 1.375, 0.44444444444444
92206, 0.30434782608696, 1.3875, 0.44444444444444
92207, 0.30434782608696, 1.375, 0.47222222222222
92208, 0.26086956521739, 1.375, 0.027777777777778
92209, 0.28260869565217, 1.375, 0.055555555555556
92210, 0.26086956521739, 1.3875, 0.055555555555556
92211, 0.26086956521739, 1.375, 0.083333333333333
92212, 0.28260869565217, 1.375, 0.11111111111111
92213, 0.26086956521739, 1.3875, 0.11111111111111
92214, 0.26086956521739, 1.375, 0.13888888888889
92215, 0.28260869565217, 1.375, 0.16666666666667
92216, 0.26086956521739, 1.3875, 0.16666666666667
92217, 0.26086956521739, 1.375, 0.19444444444444
92218, 0.28260869565217, 1.375, 0.22222222222222
92219, 0.26086956521739, 1.3875, 0.22222222222222
92220, 0.26086956521739, 1.375, 0.25
92221, 0.28260869565217, 1.375, 0.27777777777778
92222, 0.26086956521739, 1.3875, 0.27777777777778
92223, 0.26086956521739, 1.375, 0.30555555555556
92224, 0.28260869565217, 1.375, 0.33333333333333
92225, 0.26086956521739, 1.3875, 0.33333333333333
92226, 0.26086956521739, 1.375, 0.36111111111111
92227, 0.28260869565217, 1.375, 0.38888888888889
92228, 0.26086956521739, 1.3875, 0.38888888888889
92229, 0.26086956521739, 1.375, 0.41666666666667
92230, 0.28260869565217, 1.375, 0.44444444444444
92231, 0.26086956521739, 1.3875, 0.44444444444444
92232, 0.26086956521739, 1.375, 0.47222222222222
92233, 0.21739130434783, 1.375, 0.027777777777778
92234, 0.23913043478261, 1.375, 0.055555555555556
92235, 0.21739130434783, 1.3875, 0.055555555555556
92236, 0.21739130434783, 1.375, 0.083333333333333
92237, 0.23913043478261, 1.375, 0.11111111111111
92238, 0.21739130434783, 1.3875, 0.11111111111111
92239, 0.21739130434783, 1.375, 0.13888888888889
92240, 0.23913043478261, 1.375, 0.16666666666667
92241, 0.21739130434783, 1.3875, 0.16666666666667
92242, 0.21739130434783, 1.375, 0.19444444444444
92243, 0.23913043478261, 1.375, 0.22222222222222
92244, 0.21739130434783, 1.3875, 0.22222222222222
92245, 0.21739130434783, 1.375, 0.25
92246, 0.23913043478261, 1.375, 0.27777777777778
92247, 0.21739130434783, 1.3875, 0.27777777777778
92248, 0.21739130434783, 1.375, 0.30555555555556
92249, 0.23913043478261, 1.375, 0.33333333333333
92250, 0.21739130434783, 1.3875, 0.33333333333333
92251, 0.21739130434783, 1.375, 0.36111111111111
92252, 0.23913043478261, 1.375, 0.38888888888889
92253, 0.21739130434783, 1.3875, 0.38888888888889
92254, 0.21739130434783, 1.375, 0.41666666666667
92255, 0.23913043478261, 1.375, 0.44444444444444
92256, 0.21739130434783, 1.3875, 0.44444444444444
92257, 0.21739130434783, 1.375, 0.47222222222222
92258, 0.17391304347826, 1.375, 0.027777777777778
92259, 0.19565217391304, 1.375, 0.055555555555556
92260, 0.17391304347826, 1.3875, 0.055555555555556
92261, 0.17391304347826, 1.375, 0.083333333333333
92262, 0.19565217391304, 1.375, 0.11111111111111
92263, 0.17391304347826, 1.3875, 0.11111111111111
92264, 0.17391304347826, 1.375, 0.13888888888889
92265, 0.19565217391304, 1.375, 0.16666666666667
92266, 0.17391304347826, 1.3875, 0.16666666666667
92267, 0.17391304347826, 1.375, 0.19444444444444
92268, 0.19565217391304, 1.375, 0.22222222222222
92269, 0.17391304347826, 1.3875, 0.22222222222222
92270, 0.17391304347826, 1.375, 0.25
92271, 0.19565217391304, 1.375, 0.27777777777778
92272, 0.17391304347826, 1.3875, 0.27777777777778
92273, 0.17391304347826, 1.375, 0.30555555555556
92274, 0.19565217391304, 1.375, 0.33333333333333
92275, 0.17391304347826, 1.3875, 0.33333333333333
92276, 0.17391304347826, 1.375, 0.36111111111111
92277, 0.19565217391304, 1.375, 0.38888888888889
92278, 0.17391304347826, 1.3875, 0.38888888888889
92279, 0.17391304347826, 1.375, 0.41666666666667
92280, 0.19565217391304, 1.375, 0.44444444444444
92281, 0.17391304347826, 1.3875, 0.44444444444444
92282, 0.17391304347826, 1.375, 0.47222222222222
92283, 0.1304347826087, 1.375, 0.027777777777778
92284, 0.15217391304348, 1.375, 0.055555555555556
92285, 0.1304347826087, 1.3875, 0.055555555555556
92286, 0.1304347826087, 1.375, 0.083333333333333
92287, 0.15217391304348, 1.375, 0.11111111111111
92288, 0.1304347826087, 1.3875, 0.11111111111111
92289, 0.1304347826087, 1.375, 0.13888888888889
92290, 0.15217391304348, 1.375, 0.16666666666667
92291, 0.1304347826087, 1.3875, 0.16666666666667
92292, 0.1304347826087, 1.375, 0.19444444444444
92293, 0.15217391304348, 1.375, 0.22222222222222
92294, 0.1304347826087, 1.3875, 0.22222222222222
92295, 0.1304347826087, 1.375, 0.25
92296, 0.15217391304348, 1.375, 0.27777777777778
92297, 0.1304347826087, 1.3875, 0.27777777777778
92298, 0.1304347826087, 1.375, 0.30555555555556
92299, 0.15217391304348, 1.375, 0.33333333333333
92300, 0.1304347826087, 1.3875, 0.33333333333333
92301, 0.1304347826087, 1.375, 0.36111111111111
92302, 0.15217391304348, 1.375, 0.38888888888889
92303, 0.1304347826087, 1.3875, 0.38888888888889
92304, 0.1304347826087, 1.375, 0.41666666666667
92305, 0.15217391304348, 1.375, 0.44444444444444
92306, 0.1304347826087, 1.3875, 0.44444444444444
92307, 0.1304347826087, 1.375, 0.47222222222222
92308, 0.08695652173913, 1.375, 0.027777777777778
92309, 0.10869565217391, 1.375, 0.055555555555556
92310, 0.08695652173913, 1.3875, 0.055555555555556
92311, 0.08695652173913, 1.375, 0.083333333333333
92312, 0.10869565217391, 1.375, 0.11111111111111
92313, 0.08695652173913, 1.3875, 0.11111111111111
92314, 0.08695652173913, 1.375, 0.13888888888889
92315, 0.10869565217391, 1.375, 0.16666666666667
92316, 0.08695652173913, 1.3875, 0.16666666666667
92317, 0.08695652173913, 1.375, 0.19444444444444
92318, 0.10869565217391, 1.375, 0.22222222222222
92319, 0.08695652173913, 1.3875, 0.22222222222222
92320, 0.08695652173913, 1.375, 0.25
92321, 0.10869565217391, 1.375, 0.27777777777778
92322, 0.08695652173913, 1.3875, 0.27777777777778
92323, 0.08695652173913, 1.375, 0.30555555555556
92324, 0.10869565217391, 1.375, 0.33333333333333
92325, 0.08695652173913, 1.3875, 0.33333333333333
92326, 0.08695652173913, 1.375, 0.36111111111111
92327, 0.10869565217391, 1.375, 0.38888888888889
92328, 0.08695652173913, 1.3875, 0.38888888888889
92329, 0.08695652173913, 1.375, 0.41666666666667
92330, 0.10869565217391, 1.375, 0.44444444444444
92331, 0.08695652173913, 1.3875, 0.44444444444444
92332, 0.08695652173913, 1.375, 0.47222222222222
92333, 0.043478260869565, 1.375, 0.027777777777778
92334, 0.065217391304348, 1.375, 0.055555555555556
92335, 0.043478260869565, 1.3875, 0.055555555555556
92336, 0.043478260869565, 1.375, 0.083333333333333
92337, 0.065217391304348, 1.375, 0.11111111111111
92338, 0.043478260869565, 1.3875, 0.11111111111111
92339, 0.043478260869565, 1.375, 0.13888888888889
92340, 0.065217391304348, 1.375, 0.16666666666667
92341, 0.043478260869565, 1.3875, 0.16666666666667
92342, 0.043478260869565, 1.375, 0.19444444444444
92343, 0.065217391304348, 1.375, 0.22222222222222
92344, 0.043478260869565, 1.3875, 0.22222222222222
92345, 0.043478260869565, 1.375, 0.25
92346, 0.065217391304348, 1.375, 0.27777777777778
92347, 0.043478260869565, 1.3875, 0.27777777777778
92348, 0.043478260869565, 1.375, 0.30555555555556
92349, 0.065217391304348, 1.375, 0.33333333333333
92350, 0.043478260869565, 1.3875, 0.33333333333333
92351, 0.043478260869565, 1.375, 0.36111111111111
92352, 0.065217391304348, 1.375, 0.38888888888889
92353, 0.043478260869565, 1.3875, 0.38888888888889
92354, 0.043478260869565, 1.375, 0.41666666666667
92355, 0.065217391304348, 1.375, 0.44444444444444
92356, 0.043478260869565, 1.3875, 0.44444444444444
92357, 0.043478260869565, 1.375, 0.47222222222222
92358, 0.021739130434783, 1.375, 0.055555555555556
92359, 0.021739130434783, 1.375, 0.11111111111111
92360, 0.021739130434783, 1.375, 0.16666666666667
92361, 0.021739130434783, 1.375, 0.22222222222222
92362, 0.021739130434783, 1.375, 0.27777777777778
92363, 0.021739130434783, 1.375, 0.33333333333333
92364, 0.021739130434783, 1.375, 0.38888888888889
92365, 0.021739130434783, 1.375, 0.44444444444444
92366, 0.95652173913043, 1.3625, 0.055555555555556
92367, 0.95652173913044, 1.3625, 0.11111111111111
92368, 0.95652173913044, 1.3625, 0.16666666666667
92369, 0.95652173913043, 1.3625, 0.22222222222222
92370, 0.95652173913043, 1.3625, 0.27777777777778
92371, 0.95652173913043, 1.3625, 0.33333333333333
92372, 0.95652173913043, 1.3625, 0.38888888888889
92373, 0.95652173913043, 1.3625, 0.44444444444444
92374, 0.91304347826087, 1.3625, 0.055555555555556
92375, 0.91304347826087, 1.3625, 0.11111111111111
92376, 0.91304347826087, 1.3625, 0.16666666666667
92377, 0.91304347826087, 1.3625, 0.22222222222222
92378, 0.91304347826087, 1.3625, 0.27777777777778
92379, 0.91304347826087, 1.3625, 0.33333333333333
92380, 0.91304347826087, 1.3625, 0.38888888888889
92381, 0.91304347826087, 1.3625, 0.44444444444444
92382, 0.8695652173913, 1.3625, 0.055555555555556
92383, 0.8695652173913, 1.3625, 0.11111111111111
92384, 0.8695652173913, 1.3625, 0.16666666666667
92385, 0.8695652173913, 1.3625, 0.22222222222222
92386, 0.8695652173913, 1.3625, 0.27777777777778
92387, 0.8695652173913, 1.3625, 0.33333333333333
92388, 0.8695652173913, 1.3625, 0.38888888888889
92389, 0.8695652173913, 1.3625, 0.44444444444444
92390, 0.82608695652174, 1.3625, 0.055555555555556
92391, 0.82608695652174, 1.3625, 0.11111111111111
92392, 0.82608695652174, 1.3625, 0.16666666666667
92393, 0.82608695652174, 1.3625, 0.22222222222222
92394, 0.82608695652174, 1.3625, 0.27777777777778
92395, 0.82608695652174, 1.3625, 0.33333333333333
92396, 0.82608695652174, 1.3625, 0.38888888888889
92397, 0.82608695652174, 1.3625, 0.44444444444444
92398, 0.78260869565217, 1.3625, 0.055555555555556
92399, 0.78260869565217, 1.3625, 0.11111111111111
92400, 0.78260869565217, 1.3625, 0.16666666666667
92401, 0.78260869565217, 1.3625, 0.22222222222222
92402, 0.78260869565217, 1.3625, 0.27777777777778
92403, 0.78260869565217, 1.3625, 0.33333333333333
92404, 0.78260869565217, 1.3625, 0.38888888888889
92405, 0.78260869565217, 1.3625, 0.44444444444444
92406, 0.73913043478261, 1.3625, 0.055555555555556
92407, 0.73913043478261, 1.3625, 0.11111111111111
92408, 0.73913043478261, 1.3625, 0.16666666666667
92409, 0.73913043478261, 1.3625, 0.22222222222222
92410, 0.73913043478261, 1.3625, 0.27777777777778
92411, 0.73913043478261, 1.3625, 0.33333333333333
92412, 0.73913043478261, 1.3625, 0.38888888888889
92413, 0.73913043478261, 1.3625, 0.44444444444444
92414, 0.69565217391304, 1.3625, 0.055555555555556
92415, 0.69565217391304, 1.3625, 0.11111111111111
92416, 0.69565217391304, 1.3625, 0.16666666666667
92417, 0.69565217391304, 1.3625, 0.22222222222222
92418, 0.69565217391304, 1.3625, 0.27777777777778
92419, 0.69565217391304, 1.3625, 0.33333333333333
92420, 0.69565217391304, 1.3625, 0.38888888888889
92421, 0.69565217391304, 1.3625, 0.44444444444444
92422, 0.65217391304348, 1.3625, 0.055555555555556
92423, 0.65217391304348, 1.3625, 0.11111111111111
92424, 0.65217391304348, 1.3625, 0.16666666666667
92425, 0.65217391304348, 1.3625, 0.22222222222222
92426, 0.65217391304348, 1.3625, 0.27777777777778
92427, 0.65217391304348, 1.3625, 0.33333333333333
92428, 0.65217391304348, 1.3625, 0.38888888888889
92429, 0.65217391304348, 1.3625, 0.44444444444444
92430, 0.60869565217391, 1.3625, 0.055555555555556
92431, 0.60869565217391, 1.3625, 0.11111111111111
92432, 0.60869565217391, 1.3625, 0.16666666666667
92433, 0.60869565217391, 1.3625, 0.22222222222222
92434, 0.60869565217391, 1.3625, 0.27777777777778
92435, 0.60869565217391, 1.3625, 0.33333333333333
92436, 0.60869565217391, 1.3625, 0.38888888888889
92437, 0.60869565217391, 1.3625, 0.44444444444444
92438, 0.56521739130435, 1.3625, 0.055555555555556
92439, 0.56521739130435, 1.3625, 0.11111111111111
92440, 0.56521739130435, 1.3625, 0.16666666666667
92441, 0.56521739130435, 1.3625, 0.22222222222222
92442, 0.56521739130435, 1.3625, 0.27777777777778
92443, 0.56521739130435, 1.3625, 0.33333333333333
92444, 0.56521739130435, 1.3625, 0.38888888888889
92445, 0.56521739130435, 1.3625, 0.44444444444444
92446, 0.52173913043478, 1.3625, 0.055555555555556
92447, 0.52173913043478, 1.3625, 0.11111111111111
92448, 0.52173913043478, 1.3625, 0.16666666666667
92449, 0.52173913043478, 1.3625, 0.22222222222222
92450, 0.52173913043478, 1.3625, 0.27777777777778
92451, 0.52173913043478, 1.3625, 0.33333333333333
92452, 0.52173913043478, 1.3625, 0.38888888888889
92453, 0.52173913043478, 1.3625, 0.44444444444444
92454, 0.47826086956522, 1.3625, 0.055555555555556
92455, 0.47826086956522, 1.3625, 0.11111111111111
92456, 0.47826086956522, 1.3625, 0.16666666666667
92457, 0.47826086956522, 1.3625, 0.22222222222222
92458, 0.47826086956522, 1.3625, 0.27777777777778
92459, 0.47826086956522, 1.3625, 0.33333333333333
92460, 0.47826086956522, 1.3625, 0.38888888888889
92461, 0.47826086956522, 1.3625, 0.44444444444444
92462, 0.43478260869565, 1.3625, 0.055555555555556
92463, 0.43478260869565, 1.3625, 0.11111111111111
92464, 0.43478260869565, 1.3625, 0.16666666666667
92465, 0.43478260869565, 1.3625, 0.22222222222222
92466, 0.43478260869565, 1.3625, 0.27777777777778
92467, 0.43478260869565, 1.3625, 0.33333333333333
92468, 0.43478260869565, 1.3625, 0.38888888888889
92469, 0.43478260869565, 1.3625, 0.44444444444444
92470, 0.39130434782609, 1.3625, 0.055555555555556
92471, 0.39130434782609, 1.3625, 0.11111111111111
92472, 0.39130434782609, 1.3625, 0.16666666666667
92473, 0.39130434782609, 1.3625, 0.22222222222222
92474, 0.39130434782609, 1.3625, 0.27777777777778
92475, 0.39130434782609, 1.3625, 0.33333333333333
92476, 0.39130434782609, 1.3625, 0.38888888888889
92477, 0.39130434782609, 1.3625, 0.44444444444444
92478, 0.34782608695652, 1.3625, 0.055555555555556
92479, 0.34782608695652, 1.3625, 0.11111111111111
92480, 0.34782608695652, 1.3625, 0.16666666666667
92481, 0.34782608695652, 1.3625, 0.22222222222222
92482, 0.34782608695652, 1.3625, 0.27777777777778
92483, 0.34782608695652, 1.3625, 0.33333333333333
92484, 0.34782608695652, 1.3625, 0.38888888888889
92485, 0.34782608695652, 1.3625, 0.44444444444444
92486, 0.30434782608696, 1.3625, 0.055555555555556
92487, 0.30434782608696, 1.3625, 0.11111111111111
92488, 0.30434782608696, 1.3625, 0.16666666666667
92489, 0.30434782608696, 1.3625, 0.22222222222222
92490, 0.30434782608696, 1.3625, 0.27777777777778
92491, 0.30434782608696, 1.3625, 0.33333333333333
92492, 0.30434782608696, 1.3625, 0.38888888888889
92493, 0.30434782608696, 1.3625, 0.44444444444444
92494, 0.26086956521739, 1.3625, 0.055555555555556
92495, 0.26086956521739, 1.3625, 0.11111111111111
92496, 0.26086956521739, 1.3625, 0.16666666666667
92497, 0.26086956521739, 1.3625, 0.22222222222222
92498, 0.26086956521739, 1.3625, 0.27777777777778
92499, 0.26086956521739, 1.3625, 0.33333333333333
92500, 0.26086956521739, 1.3625, 0.38888888888889
92501, 0.26086956521739, 1.3625, 0.44444444444444
92502, 0.21739130434783, 1.3625, 0.055555555555556
92503, 0.21739130434783, 1.3625, 0.11111111111111
92504, 0.21739130434783, 1.3625, 0.16666666666667
92505, 0.21739130434783, 1.3625, 0.22222222222222
92506, 0.21739130434783, 1.3625, 0.27777777777778
92507, 0.21739130434783, 1.3625, 0.33333333333333
92508, 0.21739130434783, 1.3625, 0.38888888888889
92509, 0.21739130434783, 1.3625, 0.44444444444444
92510, 0.17391304347826, 1.3625, 0.055555555555556
92511, 0.17391304347826, 1.3625, 0.11111111111111
92512, 0.17391304347826, 1.3625, 0.16666666666667
92513, 0.17391304347826, 1.3625, 0.22222222222222
92514, 0.17391304347826, 1.3625, 0.27777777777778
92515, 0.17391304347826, 1.3625, 0.33333333333333
92516, 0.17391304347826, 1.3625, 0.38888888888889
92517, 0.17391304347826, 1.3625, 0.44444444444444
92518, 0.1304347826087, 1.3625, 0.055555555555556
92519, 0.1304347826087, 1.3625, 0.11111111111111
92520, 0.1304347826087, 1.3625, 0.16666666666667
92521, 0.1304347826087, 1.3625, 0.22222222222222
92522, 0.1304347826087, 1.3625, 0.27777777777778
92523, 0.1304347826087, 1.3625, 0.33333333333333
92524, 0.1304347826087, 1.3625, 0.38888888888889
92525, 0.1304347826087, 1.3625, 0.44444444444444
92526, 0.08695652173913, 1.3625, 0.055555555555556
92527, 0.08695652173913, 1.3625, 0.11111111111111
92528, 0.08695652173913, 1.3625, 0.16666666666667
92529, 0.08695652173913, 1.3625, 0.22222222222222
92530, 0.08695652173913, 1.3625, 0.27777777777778
92531, 0.08695652173913, 1.3625, 0.33333333333333
92532, 0.08695652173913, 1.3625, 0.38888888888889
92533, 0.08695652173913, 1.3625, 0.44444444444444
92534, 0.043478260869565, 1.3625, 0.055555555555556
92535, 0.043478260869565, 1.3625, 0.11111111111111
92536, 0.043478260869565, 1.3625, 0.16666666666667
92537, 0.043478260869565, 1.3625, 0.22222222222222
92538, 0.043478260869565, 1.3625, 0.27777777777778
92539, 0.043478260869565, 1.3625, 0.33333333333333
92540, 0.043478260869565, 1.3625, 0.38888888888889
92541, 0.043478260869565, 1.3625, 0.44444444444444
92542, 1.2434782608696, 1.375, 0.44444444444444
92543, 1.2434782608696, 1.375, 0.38888888888889
92544, 1.2434782608696, 1.375, 0.33333333333333
92545, 1.2434782608696, 1.375, 0.27777777777778
92546, 1.2434782608696, 1.375, 0.22222222222222
92547, 1.2434782608696, 1.375, 0.16666666666667
92548, 1.2434782608696, 1.375, 0.11111111111111
92549, 1.2434782608696, 1.375, 0.055555555555556
92550, 1.2869565217391, 1.375, 0.44444444444444
92551, 1.2869565217391, 1.375, 0.38888888888889
92552, 1.2869565217391, 1.375, 0.33333333333333
92553, 1.2869565217391, 1.375, 0.27777777777778
92554, 1.2869565217391, 1.375, 0.22222222222222
92555, 1.2869565217391, 1.375, 0.16666666666667
92556, 1.2869565217391, 1.375, 0.11111111111111
92557, 1.2869565217391, 1.375, 0.055555555555556
92558, 1.3304347826087, 1.375, 0.44444444444444
92559, 1.3304347826087, 1.375, 0.38888888888889
92560, 1.3304347826087, 1.375, 0.33333333333333
92561, 1.3304347826087, 1.375, 0.27777777777778
92562, 1.3304347826087, 1.375, 0.22222222222222
92563, 1.3304347826087, 1.375, 0.16666666666667
92564, 1.3304347826087, 1.375, 0.11111111111111
92565, 1.3304347826087, 1.375, 0.055555555555556
92566, 1.3739130434783, 1.375, 0.44444444444444
92567, 1.3739130434783, 1.375, 0.38888888888889
92568, 1.3739130434783, 1.375, 0.33333333333333
92569, 1.3739130434783, 1.375, 0.27777777777778
92570, 1.3739130434783, 1.375, 0.22222222222222
92571, 1.3739130434783, 1.375, 0.16666666666667
92572, 1.3739130434783, 1.375, 0.11111111111111
92573, 1.3739130434783, 1.375, 0.055555555555556
92574, 1.4173913043478, 1.375, 0.44444444444444
92575, 1.4173913043478, 1.375, 0.38888888888889
92576, 1.4173913043478, 1.375, 0.33333333333333
92577, 1.4173913043478, 1.375, 0.27777777777778
92578, 1.4173913043478, 1.375, 0.22222222222222
92579, 1.4173913043478, 1.375, 0.16666666666667
92580, 1.4173913043478, 1.375, 0.11111111111111
92581, 1.4173913043478, 1.375, 0.055555555555556
92582, 1.4608695652174, 1.375, 0.44444444444444
92583, 1.4608695652174, 1.375, 0.38888888888889
92584, 1.4608695652174, 1.375, 0.33333333333333
92585, 1.4608695652174, 1.375, 0.27777777777778
92586, 1.4608695652174, 1.375, 0.22222222222222
92587, 1.4608695652174, 1.375, 0.16666666666667
92588, 1.4608695652174, 1.375, 0.11111111111111
92589, 1.4608695652174, 1.375, 0.055555555555556
92590, 1.504347826087, 1.375, 0.44444444444444
92591, 1.504347826087, 1.375, 0.38888888888889
92592, 1.504347826087, 1.375, 0.33333333333333
92593, 1.504347826087, 1.375, 0.27777777777778
92594, 1.504347826087, 1.375, 0.22222222222222
92595, 1.504347826087, 1.375, 0.16666666666667
92596, 1.504347826087, 1.375, 0.11111111111111
92597, 1.504347826087, 1.375, 0.055555555555556
92598, 1.5478260869565, 1.375, 0.44444444444444
92599, 1.5478260869565, 1.375, 0.38888888888889
92600, 1.5478260869565, 1.375, 0.33333333333333
92601, 1.5478260869565, 1.375, 0.27777777777778
92602, 1.5478260869565, 1.375, 0.22222222222222
92603, 1.5478260869565, 1.375, 0.16666666666667
92604, 1.5478260869565, 1.375, 0.11111111111111
92605, 1.5478260869565, 1.375, 0.055555555555556
92606, 1.5913043478261, 1.375, 0.44444444444444
92607, 1.5913043478261, 1.375, 0.38888888888889
92608, 1.5913043478261, 1.375, 0.33333333333333
92609, 1.5913043478261, 1.375, 0.27777777777778
92610, 1.5913043478261, 1.375, 0.22222222222222
92611, 1.5913043478261, 1.375, 0.16666666666667
92612, 1.5913043478261, 1.375, 0.11111111111111
92613, 1.5913043478261, 1.375, 0.055555555555556
92614, 1.6347826086957, 1.375, 0.44444444444444
92615, 1.6347826086957, 1.375, 0.38888888888889
92616, 1.6347826086957, 1.375, 0.33333333333333
92617, 1.6347826086957, 1.375, 0.27777777777778
92618, 1.6347826086957, 1.375, 0.22222222222222
92619, 1.6347826086957, 1.375, 0.16666666666667
92620, 1.6347826086957, 1.375, 0.11111111111111
92621, 1.6347826086957, 1.375, 0.055555555555556
92622, 1.6782608695652, 1.375, 0.44444444444444
92623, 1.6782608695652, 1.375, 0.38888888888889
92624, 1.6782608695652, 1.375, 0.33333333333333
92625, 1.6782608695652, 1.375, 0.27777777777778
92626, 1.6782608695652, 1.375, 0.22222222222222
92627, 1.6782608695652, 1.375, 0.16666666666667
92628, 1.6782608695652, 1.375, 0.11111111111111
92629, 1.6782608695652, 1.375, 0.055555555555556
92630, 1.7217391304348, 1.375, 0.44444444444444
92631, 1.7217391304348, 1.375, 0.38888888888889
92632, 1.7217391304348, 1.375, 0.33333333333333
92633, 1.7217391304348, 1.375, 0.27777777777778
92634, 1.7217391304348, 1.375, 0.22222222222222
92635, 1.7217391304348, 1.375, 0.16666666666667
92636, 1.7217391304348, 1.375, 0.11111111111111
92637, 1.7217391304348, 1.375, 0.055555555555556
92638, 1.7652173913043, 1.375, 0.44444444444444
92639, 1.7652173913043, 1.375, 0.38888888888889
92640, 1.7652173913043, 1.375, 0.33333333333333
92641, 1.7652173913043, 1.375, 0.27777777777778
92642, 1.7652173913043, 1.375, 0.22222222222222
92643, 1.7652173913043, 1.375, 0.16666666666667
92644, 1.7652173913043, 1.375, 0.11111111111111
92645, 1.7652173913043, 1.375, 0.055555555555556
92646, 1.8086956521739, 1.375, 0.44444444444444
92647, 1.8086956521739, 1.375, 0.38888888888889
92648, 1.8086956521739, 1.375, 0.33333333333333
92649, 1.8086956521739, 1.375, 0.27777777777778
92650, 1.8086956521739, 1.375, 0.22222222222222
92651, 1.8086956521739, 1.375, 0.16666666666667
92652, 1.8086956521739, 1.375, 0.11111111111111
92653, 1.8086956521739, 1.375, 0.055555555555556
92654, 1.8521739130435, 1.375, 0.44444444444444
92655, 1.8521739130435, 1.375, 0.38888888888889
92656, 1.8521739130435, 1.375, 0.33333333333333
92657, 1.8521739130435, 1.375, 0.27777777777778
92658, 1.8521739130435, 1.375, 0.22222222222222
92659, 1.8521739130435, 1.375, 0.16666666666667
92660, 1.8521739130435, 1.375, 0.11111111111111
92661, 1.8521739130435, 1.375, 0.055555555555556
92662, 1.895652173913, 1.375, 0.44444444444444
92663, 1.895652173913, 1.375, 0.38888888888889
92664, 1.895652173913, 1.375, 0.33333333333333
92665, 1.895652173913, 1.375, 0.27777777777778
92666, 1.895652173913, 1.375, 0.22222222222222
92667, 1.895652173913, 1.375, 0.16666666666667
92668, 1.895652173913, 1.375, 0.11111111111111
92669, 1.895652173913, 1.375, 0.055555555555556
92670, 1.9391304347826, 1.375, 0.44444444444444
92671, 1.9391304347826, 1.375, 0.38888888888889
92672, 1.9391304347826, 1.375, 0.33333333333333
92673, 1.9391304347826, 1.375, 0.27777777777778
92674, 1.9391304347826, 1.375, 0.22222222222222
92675, 1.9391304347826, 1.375, 0.16666666666667
92676, 1.9391304347826, 1.375, 0.11111111111111
92677, 1.9391304347826, 1.375, 0.055555555555556
92678, 1.9826086956522, 1.375, 0.44444444444444
92679, 1.9826086956522, 1.375, 0.38888888888889
92680, 1.9826086956522, 1.375, 0.33333333333333
92681, 1.9826086956522, 1.375, 0.27777777777778
92682, 1.9826086956522, 1.375, 0.22222222222222
92683, 1.9826086956522, 1.375, 0.16666666666667
92684, 1.9826086956522, 1.375, 0.11111111111111
92685, 1.9826086956522, 1.375, 0.055555555555556
92686, 2.0260869565217, 1.375, 0.44444444444444
92687, 2.0260869565217, 1.375, 0.38888888888889
92688, 2.0260869565217, 1.375, 0.33333333333333
92689, 2.0260869565217, 1.375, 0.27777777777778
92690, 2.0260869565217, 1.375, 0.22222222222222
92691, 2.0260869565217, 1.375, 0.16666666666667
92692, 2.0260869565217, 1.375, 0.11111111111111
92693, 2.0260869565217, 1.375, 0.055555555555556
92694, 2.0695652173913, 1.375, 0.44444444444444
92695, 2.0695652173913, 1.375, 0.38888888888889
92696, 2.0695652173913, 1.375, 0.33333333333333
92697, 2.0695652173913, 1.375, 0.27777777777778
92698, 2.0695652173913, 1.375, 0.22222222222222
92699, 2.0695652173913, 1.375, 0.16666666666667
92700, 2.0695652173913, 1.375, 0.11111111111111
92701, 2.0695652173913, 1.375, 0.055555555555556
92702, 2.1130434782609, 1.375, 0.44444444444444
92703, 2.1130434782609, 1.375, 0.38888888888889
92704, 2.1130434782609, 1.375, 0.33333333333333
92705, 2.1130434782609, 1.375, 0.27777777777778
92706, 2.1130434782609, 1.375, 0.22222222222222
92707, 2.1130434782609, 1.375, 0.16666666666667
92708, 2.1130434782609, 1.375, 0.11111111111111
92709, 2.1130434782609, 1.375, 0.055555555555556
92710, 2.1565217391304, 1.375, 0.44444444444444
92711, 2.1565217391304, 1.375, 0.38888888888889
92712, 2.1565217391304, 1.375, 0.33333333333333
92713, 2.1565217391304, 1.375, 0.27777777777778
92714, 2.1565217391304, 1.375, 0.22222222222222
92715, 2.1565217391304, 1.375, 0.16666666666667
92716, 2.1565217391304, 1.375, 0.11111111111111
92717, 2.1565217391304, 1.375, 0.055555555555556
92718, 1.2434782608696, 1.375, 0.47222222222222
92719, 1.2217391304348, 1.375, 0.44444444444444
92720, 1.2434782608696, 1.3875, 0.44444444444444
92721, 1.2434782608696, 1.375, 0.41666666666667
92722, 1.2217391304348, 1.375, 0.38888888888889
92723, 1.2434782608696, 1.3875, 0.38888888888889
92724, 1.2434782608696, 1.375, 0.36111111111111
92725, 1.2217391304348, 1.375, 0.33333333333333
92726, 1.2434782608696, 1.3875, 0.33333333333333
92727, 1.2434782608696, 1.375, 0.30555555555556
92728, 1.2217391304348, 1.375, 0.27777777777778
92729, 1.2434782608696, 1.3875, 0.27777777777778
92730, 1.2434782608696, 1.375, 0.25
92731, 1.2217391304348, 1.375, 0.22222222222222
92732, 1.2434782608696, 1.3875, 0.22222222222222
92733, 1.2434782608696, 1.375, 0.19444444444444
92734, 1.2217391304348, 1.375, 0.16666666666667
92735, 1.2434782608696, 1.3875, 0.16666666666667
92736, 1.2434782608696, 1.375, 0.13888888888889
92737, 1.2217391304348, 1.375, 0.11111111111111
92738, 1.2434782608696, 1.3875, 0.11111111111111
92739, 1.2434782608696, 1.375, 0.083333333333333
92740, 1.2217391304348, 1.375, 0.055555555555556
92741, 1.2434782608696, 1.3875, 0.055555555555556
92742, 1.2434782608696, 1.375, 0.027777777777778
92743, 1.2869565217391, 1.375, 0.47222222222222
92744, 1.2652173913043, 1.375, 0.44444444444444
92745, 1.2869565217391, 1.3875, 0.44444444444444
92746, 1.2869565217391, 1.375, 0.41666666666667
92747, 1.2652173913043, 1.375, 0.38888888888889
92748, 1.2869565217391, 1.3875, 0.38888888888889
92749, 1.2869565217391, 1.375, 0.36111111111111
92750, 1.2652173913043, 1.375, 0.33333333333333
92751, 1.2869565217391, 1.3875, 0.33333333333333
92752, 1.2869565217391, 1.375, 0.30555555555556
92753, 1.2652173913043, 1.375, 0.27777777777778
92754, 1.2869565217391, 1.3875, 0.27777777777778
92755, 1.2869565217391, 1.375, 0.25
92756, 1.2652173913043, 1.375, 0.22222222222222
92757, 1.2869565217391, 1.3875, 0.22222222222222
92758, 1.2869565217391, 1.375, 0.19444444444444
92759, 1.2652173913043, 1.375, 0.16666666666667
92760, 1.2869565217391, 1.3875, 0.16666666666667
92761, 1.2869565217391, 1.375, 0.13888888888889
92762, 1.2652173913043, 1.375, 0.11111111111111
92763, 1.2869565217391, 1.3875, 0.11111111111111
92764, 1.2869565217391, 1.375, 0.083333333333333
92765, 1.2652173913043, 1.375, 0.055555555555556
92766, 1.2869565217391, 1.3875, 0.055555555555556
92767, 1.2869565217391, 1.375, 0.027777777777778
92768, 1.3304347826087, 1.375, 0.47222222222222
92769, 1.3086956521739, 1.375, 0.44444444444444
92770, 1.3304347826087, 1.3875, 0.44444444444444
92771, 1.3304347826087, 1.375, 0.41666666666667
92772, 1.3086956521739, 1.375, 0.38888888888889
92773, 1.3304347826087, 1.3875, 0.38888888888889
92774, 1.3304347826087, 1.375, 0.36111111111111
92775, 1.3086956521739, 1.375, 0.33333333333333
92776, 1.3304347826087, 1.3875, 0.33333333333333
92777, 1.3304347826087, 1.375, 0.30555555555556
92778, 1.3086956521739, 1.375, 0.27777777777778
92779, 1.3304347826087, 1.3875, 0.27777777777778
92780, 1.3304347826087, 1.375, 0.25
92781, 1.3086956521739, 1.375, 0.22222222222222
92782, 1.3304347826087, 1.3875, 0.22222222222222
92783, 1.3304347826087, 1.375, 0.19444444444444
92784, 1.3086956521739, 1.375, 0.16666666666667
92785, 1.3304347826087, 1.3875, 0.16666666666667
92786, 1.3304347826087, 1.375, 0.13888888888889
92787, 1.3086956521739, 1.375, 0.11111111111111
92788, 1.3304347826087, 1.3875, 0.11111111111111
92789, 1.3304347826087, 1.375, 0.083333333333333
92790, 1.3086956521739, 1.375, 0.055555555555556
92791, 1.3304347826087, 1.3875, 0.055555555555556
92792, 1.3304347826087, 1.375, 0.027777777777778
92793, 1.3739130434783, 1.375, 0.47222222222222
92794, 1.3521739130435, 1.375, 0.44444444444444
92795, 1.3739130434783, 1.3875, 0.44444444444444
92796, 1.3739130434783, 1.375, 0.41666666666667
92797, 1.3521739130435, 1.375, 0.38888888888889
92798, 1.3739130434783, 1.3875, 0.38888888888889
92799, 1.3739130434783, 1.375, 0.36111111111111
92800, 1.3521739130435, 1.375, 0.33333333333333
92801, 1.3739130434783, 1.3875, 0.33333333333333
92802, 1.3739130434783, 1.375, 0.30555555555556
92803, 1.3521739130435, 1.375, 0.27777777777778
92804, 1.3739130434783, 1.3875, 0.27777777777778
92805, 1.3739130434783, 1.375, 0.25
92806, 1.3521739130435, 1.375, 0.22222222222222
92807, 1.3739130434783, 1.3875, 0.22222222222222
92808, 1.3739130434783, 1.375, 0.19444444444444
92809, 1.3521739130435, 1.375, 0.16666666666667
92810, 1.3739130434783, 1.3875, 0.16666666666667
92811, 1.3739130434783, 1.375, 0.13888888888889
92812, 1.3521739130435, 1.375, 0.11111111111111
92813, 1.3739130434783, 1.3875, 0.11111111111111
92814, 1.3739130434783, 1.375, 0.083333333333333
92815, 1.3521739130435, 1.375, 0.055555555555556
92816, 1.3739130434783, 1.3875, 0.055555555555556
92817, 1.3739130434783, 1.375, 0.027777777777778
92818, 1.4173913043478, 1.375, 0.47222222222222
92819, 1.395652173913, 1.375, 0.44444444444444
92820, 1.4173913043478, 1.3875, 0.44444444444444
92821, 1.4173913043478, 1.375, 0.41666666666667
92822, 1.395652173913, 1.375, 0.38888888888889
92823, 1.4173913043478, 1.3875, 0.38888888888889
92824, 1.4173913043478, 1.375, 0.36111111111111
92825, 1.395652173913, 1.375, 0.33333333333333
92826, 1.4173913043478, 1.3875, 0.33333333333333
92827, 1.4173913043478, 1.375, 0.30555555555556
92828, 1.395652173913, 1.375, 0.27777777777778
92829, 1.4173913043478, 1.3875, 0.27777777777778
92830, 1.4173913043478, 1.375, 0.25
92831, 1.395652173913, 1.375, 0.22222222222222
92832, 1.4173913043478, 1.3875, 0.22222222222222
92833, 1.4173913043478, 1.375, 0.19444444444444
92834, 1.395652173913, 1.375, 0.16666666666667
92835, 1.4173913043478, 1.3875, 0.16666666666667
92836, 1.4173913043478, 1.375, 0.13888888888889
92837, 1.395652173913, 1.375, 0.11111111111111
92838, 1.4173913043478, 1.3875, 0.11111111111111
92839, 1.4173913043478, 1.375, 0.083333333333333
92840, 1.395652173913, 1.375, 0.055555555555556
92841, 1.4173913043478, 1.3875, 0.055555555555556
92842, 1.4173913043478, 1.375, 0.027777777777778
92843, 1.4608695652174, 1.375, 0.47222222222222
92844, 1.4391304347826, 1.375, 0.44444444444444
92845, 1.4608695652174, 1.3875, 0.44444444444444
92846, 1.4608695652174, 1.375, 0.41666666666667
92847, 1.4391304347826, 1.375, 0.38888888888889
92848, 1.4608695652174, 1.3875, 0.38888888888889
92849, 1.4608695652174, 1.375, 0.36111111111111
92850, 1.4391304347826, 1.375, 0.33333333333333
92851, 1.4608695652174, 1.3875, 0.33333333333333
92852, 1.4608695652174, 1.375, 0.30555555555556
92853, 1.4391304347826, 1.375, 0.27777777777778
92854, 1.4608695652174, 1.3875, 0.27777777777778
92855, 1.4608695652174, 1.375, 0.25
92856, 1.4391304347826, 1.375, 0.22222222222222
92857, 1.4608695652174, 1.3875, 0.22222222222222
92858, 1.4608695652174, 1.375, 0.19444444444444
92859, 1.4391304347826, 1.375, 0.16666666666667
92860, 1.4608695652174, 1.3875, 0.16666666666667
92861, 1.4608695652174, 1.375, 0.13888888888889
92862, 1.4391304347826, 1.375, 0.11111111111111
92863, 1.4608695652174, 1.3875, 0.11111111111111
92864, 1.4608695652174, 1.375, 0.083333333333333
92865, 1.4391304347826, 1.375, 0.055555555555556
92866, 1.4608695652174, 1.3875, 0.055555555555556
92867, 1.4608695652174, 1.375, 0.027777777777778
92868, 1.504347826087, 1.375, 0.47222222222222
92869, 1.4826086956522, 1.375, 0.44444444444444
92870, 1.504347826087, 1.3875, 0.44444444444444
92871, 1.504347826087, 1.375, 0.41666666666667
92872, 1.4826086956522, 1.375, 0.38888888888889
92873, 1.504347826087, 1.3875, 0.38888888888889
92874, 1.504347826087, 1.375, 0.36111111111111
92875, 1.4826086956522, 1.375, 0.33333333333333
92876, 1.504347826087, 1.3875, 0.33333333333333
92877, 1.504347826087, 1.375, 0.30555555555556
92878, 1.4826086956522, 1.375, 0.27777777777778
92879, 1.504347826087, 1.3875, 0.27777777777778
92880, 1.504347826087, 1.375, 0.25
92881, 1.4826086956522, 1.375, 0.22222222222222
92882, 1.504347826087, 1.3875, 0.22222222222222
92883, 1.504347826087, 1.375, 0.19444444444444
92884, 1.4826086956522, 1.375, 0.16666666666667
92885, 1.504347826087, 1.3875, 0.16666666666667
92886, 1.504347826087, 1.375, 0.13888888888889
92887, 1.4826086956522, 1.375, 0.11111111111111
92888, 1.504347826087, 1.3875, 0.11111111111111
92889, 1.504347826087, 1.375, 0.083333333333333
92890, 1.4826086956522, 1.375, 0.055555555555556
92891, 1.504347826087, 1.3875, 0.055555555555556
92892, 1.504347826087, 1.375, 0.027777777777778
92893, 1.5478260869565, 1.375, 0.47222222222222
92894, 1.5260869565217, 1.375, 0.44444444444444
92895, 1.5478260869565, 1.3875, 0.44444444444444
92896, 1.5478260869565, 1.375, 0.41666666666667
92897, 1.5260869565217, 1.375, 0.38888888888889
92898, 1.5478260869565, 1.3875, 0.38888888888889
92899, 1.5478260869565, 1.375, 0.36111111111111
92900, 1.5260869565217, 1.375, 0.33333333333333
92901, 1.5478260869565, 1.3875, 0.33333333333333
92902, 1.5478260869565, 1.375, 0.30555555555556
92903, 1.5260869565217, 1.375, 0.27777777777778
92904, 1.5478260869565, 1.3875, 0.27777777777778
92905, 1.5478260869565, 1.375, 0.25
92906, 1.5260869565217, 1.375, 0.22222222222222
92907, 1.5478260869565, 1.3875, 0.22222222222222
92908, 1.5478260869565, 1.375, 0.19444444444444
92909, 1.5260869565217, 1.375, 0.16666666666667
92910, 1.5478260869565, 1.3875, 0.16666666666667
92911, 1.5478260869565, 1.375, 0.13888888888889
92912, 1.5260869565217, 1.375, 0.11111111111111
92913, 1.5478260869565, 1.3875, 0.11111111111111
92914, 1.5478260869565, 1.375, 0.083333333333333
92915, 1.5260869565217, 1.375, 0.055555555555556
92916, 1.5478260869565, 1.3875, 0.055555555555556
92917, 1.5478260869565, 1.375, 0.027777777777778
92918, 1.5913043478261, 1.375, 0.47222222222222
92919, 1.5695652173913, 1.375, 0.44444444444444
92920, 1.5913043478261, 1.3875, 0.44444444444444
92921, 1.5913043478261, 1.375, 0.41666666666667
92922, 1.5695652173913, 1.375, 0.38888888888889
92923, 1.5913043478261, 1.3875, 0.38888888888889
92924, 1.5913043478261, 1.375, 0.36111111111111
92925, 1.5695652173913, 1.375, 0.33333333333333
92926, 1.5913043478261, 1.3875, 0.33333333333333
92927, 1.5913043478261, 1.375, 0.30555555555556
92928, 1.5695652173913, 1.375, 0.27777777777778
92929, 1.5913043478261, 1.3875, 0.27777777777778
92930, 1.5913043478261, 1.375, 0.25
92931, 1.5695652173913, 1.375, 0.22222222222222
92932, 1.5913043478261, 1.3875, 0.22222222222222
92933, 1.5913043478261, 1.375, 0.19444444444444
92934, 1.5695652173913, 1.375, 0.16666666666667
92935, 1.5913043478261, 1.3875, 0.16666666666667
92936, 1.5913043478261, 1.375, 0.13888888888889
92937, 1.5695652173913, 1.375, 0.11111111111111
92938, 1.5913043478261, 1.3875, 0.11111111111111
92939, 1.5913043478261, 1.375, 0.083333333333333
92940, 1.5695652173913, 1.375, 0.055555555555556
92941, 1.5913043478261, 1.3875, 0.055555555555556
92942, 1.5913043478261, 1.375, 0.027777777777778
92943, 1.6347826086957, 1.375, 0.47222222222222
92944, 1.6130434782609, 1.375, 0.44444444444444
92945, 1.6347826086957, 1.3875, 0.44444444444444
92946, 1.6347826086957, 1.375, 0.41666666666667
92947, 1.6130434782609, 1.375, 0.38888888888889
92948, 1.6347826086957, 1.3875, 0.38888888888889
92949, 1.6347826086957, 1.375, 0.36111111111111
92950, 1.6130434782609, 1.375, 0.33333333333333
92951, 1.6347826086957, 1.3875, 0.33333333333333
92952, 1.6347826086957, 1.375, 0.30555555555556
92953, 1.6130434782609, 1.375, 0.27777777777778
92954, 1.6347826086957, 1.3875, 0.27777777777778
92955, 1.6347826086957, 1.375, 0.25
92956, 1.6130434782609, 1.375, 0.22222222222222
92957, 1.6347826086957, 1.3875, 0.22222222222222
92958, 1.6347826086957, 1.375, 0.19444444444444
92959, 1.6130434782609, 1.375, 0.16666666666667
92960, 1.6347826086957, 1.3875, 0.16666666666667
92961, 1.6347826086957, 1.375, 0.13888888888889
92962, 1.6130434782609, 1.375, 0.11111111111111
92963, 1.6347826086957, 1.3875, 0.11111111111111
92964, 1.6347826086957, 1.375, 0.083333333333333
92965, 1.6130434782609, 1.375, 0.055555555555556
92966, 1.6347826086957, 1.3875, 0.055555555555556
92967, 1.6347826086957, 1.375, 0.027777777777778
92968, 1.6782608695652, 1.375, 0.47222222222222
92969, 1.6565217391304, 1.375, 0.44444444444444
92970, 1.6782608695652, 1.3875, 0.44444444444444
92971, 1.6782608695652, 1.375, 0.41666666666667
92972, 1.6565217391304, 1.375, 0.38888888888889
92973, 1.6782608695652, 1.3875, 0.38888888888889
92974, 1.6782608695652, 1.375, 0.36111111111111
92975, 1.6565217391304, 1.375, 0.33333333333333
92976, 1.6782608695652, 1.3875, 0.33333333333333
92977, 1.6782608695652, 1.375, 0.30555555555556
92978, 1.6565217391304, 1.375, 0.27777777777778
92979, 1.6782608695652, 1.3875, 0.27777777777778
92980, 1.6782608695652, 1.375, 0.25
92981, 1.6565217391304, 1.375, 0.22222222222222
92982, 1.6782608695652, 1.3875, 0.22222222222222
92983, 1.6782608695652, 1.375, 0.19444444444444
92984, 1.6565217391304, 1.375, 0.16666666666667
92985, 1.6782608695652, 1.3875, 0.16666666666667
92986, 1.6782608695652, 1.375, 0.13888888888889
92987, 1.6565217391304, 1.375, 0.11111111111111
92988, 1.6782608695652, 1.3875, 0.11111111111111
92989, 1.6782608695652, 1.375, 0.083333333333333
92990, 1.6565217391304, 1.375, 0.055555555555556
92991, 1.6782608695652, 1.3875, 0.055555555555556
92992, 1.6782608695652, 1.375, 0.027777777777778
92993, 1.7217391304348, 1.375, 0.47222222222222
92994, 1.7, 1.375, 0.44444444444444
92995, 1.7217391304348, 1.3875, 0.44444444444444
92996, 1.7217391304348, 1.375, 0.41666666666667
92997, 1.7, 1.375, 0.38888888888889
92998, 1.7217391304348, 1.3875, 0.38888888888889
92999, 1.7217391304348, 1.375, 0.36111111111111
93000, 1.7, 1.375, 0.33333333333333
93001, 1.7217391304348, 1.3875, 0.33333333333333
93002, 1.7217391304348, 1.375, 0.30555555555556
93003, 1.7, 1.375, 0.27777777777778
93004, 1.7217391304348, 1.3875, 0.27777777777778
93005, 1.7217391304348, 1.375, 0.25
93006, 1.7, 1.375, 0.22222222222222
93007, 1.7217391304348, 1.3875, 0.22222222222222
93008, 1.7217391304348, 1.375, 0.19444444444444
93009, 1.7, 1.375, 0.16666666666667
93010, 1.7217391304348, 1.3875, 0.16666666666667
93011, 1.7217391304348, 1.375, 0.13888888888889
93012, 1.7, 1.375, 0.11111111111111
93013, 1.7217391304348, 1.3875, 0.11111111111111
93014, 1.7217391304348, 1.375, 0.083333333333333
93015, 1.7, 1.375, 0.055555555555556
93016, 1.7217391304348, 1.3875, 0.055555555555556
93017, 1.7217391304348, 1.375, 0.027777777777778
93018, 1.7652173913043, 1.375, 0.47222222222222
93019, 1.7434782608696, 1.375, 0.44444444444444
93020, 1.7652173913043, 1.3875, 0.44444444444444
93021, 1.7652173913043, 1.375, 0.41666666666667
93022, 1.7434782608696, 1.375, 0.38888888888889
93023, 1.7652173913043, 1.3875, 0.38888888888889
93024, 1.7652173913043, 1.375, 0.36111111111111
93025, 1.7434782608696, 1.375, 0.33333333333333
93026, 1.7652173913043, 1.3875, 0.33333333333333
93027, 1.7652173913043, 1.375, 0.30555555555556
93028, 1.7434782608696, 1.375, 0.27777777777778
93029, 1.7652173913043, 1.3875, 0.27777777777778
93030, 1.7652173913043, 1.375, 0.25
93031, 1.7434782608696, 1.375, 0.22222222222222
93032, 1.7652173913043, 1.3875, 0.22222222222222
93033, 1.7652173913043, 1.375, 0.19444444444444
93034, 1.7434782608696, 1.375, 0.16666666666667
93035, 1.7652173913043, 1.3875, 0.16666666666667
93036, 1.7652173913043, 1.375, 0.13888888888889
93037, 1.7434782608696, 1.375, 0.11111111111111
93038, 1.7652173913043, 1.3875, 0.11111111111111
93039, 1.7652173913043, 1.375, 0.083333333333333
93040, 1.7434782608696, 1.375, 0.055555555555556
93041, 1.7652173913043, 1.3875, 0.055555555555556
93042, 1.7652173913043, 1.375, 0.027777777777778
93043, 1.8086956521739, 1.375, 0.47222222222222
93044, 1.7869565217391, 1.375, 0.44444444444444
93045, 1.8086956521739, 1.3875, 0.44444444444444
93046, 1.8086956521739, 1.375, 0.41666666666667
93047, 1.7869565217391, 1.375, 0.38888888888889
93048, 1.8086956521739, 1.3875, 0.38888888888889
93049, 1.8086956521739, 1.375, 0.36111111111111
93050, 1.7869565217391, 1.375, 0.33333333333333
93051, 1.8086956521739, 1.3875, 0.33333333333333
93052, 1.8086956521739, 1.375, 0.30555555555556
93053, 1.7869565217391, 1.375, 0.27777777777778
93054, 1.8086956521739, 1.3875, 0.27777777777778
93055, 1.8086956521739, 1.375, 0.25
93056, 1.7869565217391, 1.375, 0.22222222222222
93057, 1.8086956521739, 1.3875, 0.22222222222222
93058, 1.8086956521739, 1.375, 0.19444444444444
93059, 1.7869565217391, 1.375, 0.16666666666667
93060, 1.8086956521739, 1.3875, 0.16666666666667
93061, 1.8086956521739, 1.375, 0.13888888888889
93062, 1.7869565217391, 1.375, 0.11111111111111
93063, 1.8086956521739, 1.3875, 0.11111111111111
93064, 1.8086956521739, 1.375, 0.083333333333333
93065, 1.7869565217391, 1.375, 0.055555555555556
93066, 1.8086956521739, 1.3875, 0.055555555555556
93067, 1.8086956521739, 1.375, 0.027777777777778
93068, 1.8521739130435, 1.375, 0.47222222222222
93069, 1.8304347826087, 1.375, 0.44444444444444
93070, 1.8521739130435, 1.3875, 0.44444444444444
93071, 1.8521739130435, 1.375, 0.41666666666667
93072, 1.8304347826087, 1.375, 0.38888888888889
93073, 1.8521739130435, 1.3875, 0.38888888888889
93074, 1.8521739130435, 1.375, 0.36111111111111
93075, 1.8304347826087, 1.375, 0.33333333333333
93076, 1.8521739130435, 1.3875, 0.33333333333333
93077, 1.8521739130435, 1.375, 0.30555555555556
93078, 1.8304347826087, 1.375, 0.27777777777778
93079, 1.8521739130435, 1.3875, 0.27777777777778
93080, 1.8521739130435, 1.375, 0.25
93081, 1.8304347826087, 1.375, 0.22222222222222
93082, 1.8521739130435, 1.3875, 0.22222222222222
93083, 1.8521739130435, 1.375, 0.19444444444444
93084, 1.8304347826087, 1.375, 0.16666666666667
93085, 1.8521739130435, 1.3875, 0.16666666666667
93086, 1.8521739130435, 1.375, 0.13888888888889
93087, 1.8304347826087, 1.375, 0.11111111111111
93088, 1.8521739130435, 1.3875, 0.11111111111111
93089, 1.8521739130435, 1.375, 0.083333333333333
93090, 1.8304347826087, 1.375, 0.055555555555556
93091, 1.8521739130435, 1.3875, 0.055555555555556
93092, 1.8521739130435, 1.375, 0.027777777777778
93093, 1.895652173913, 1.375, 0.47222222222222
93094, 1.8739130434783, 1.375, 0.44444444444444
93095, 1.895652173913, 1.3875, 0.44444444444444
93096, 1.895652173913, 1.375, 0.41666666666667
93097, 1.8739130434783, 1.375, 0.38888888888889
93098, 1.895652173913, 1.3875, 0.38888888888889
93099, 1.895652173913, 1.375, 0.36111111111111
93100, 1.8739130434783, 1.375, 0.33333333333333
93101, 1.895652173913, 1.3875, 0.33333333333333
93102, 1.895652173913, 1.375, 0.30555555555556
93103, 1.8739130434783, 1.375, 0.27777777777778
93104, 1.895652173913, 1.3875, 0.27777777777778
93105, 1.895652173913, 1.375, 0.25
93106, 1.8739130434783, 1.375, 0.22222222222222
93107, 1.895652173913, 1.3875, 0.22222222222222
93108, 1.895652173913, 1.375, 0.19444444444444
93109, 1.8739130434783, 1.375, 0.16666666666667
93110, 1.895652173913, 1.3875, 0.16666666666667
93111, 1.895652173913, 1.375, 0.13888888888889
93112, 1.8739130434783, 1.375, 0.11111111111111
93113, 1.895652173913, 1.3875, 0.11111111111111
93114, 1.895652173913, 1.375, 0.083333333333333
93115, 1.8739130434783, 1.375, 0.055555555555556
93116, 1.895652173913, 1.3875, 0.055555555555556
93117, 1.895652173913, 1.375, 0.027777777777778
93118, 1.9391304347826, 1.375, 0.47222222222222
93119, 1.9173913043478, 1.375, 0.44444444444444
93120, 1.9391304347826, 1.3875, 0.44444444444444
93121, 1.9391304347826, 1.375, 0.41666666666667
93122, 1.9173913043478, 1.375, 0.38888888888889
93123, 1.9391304347826, 1.3875, 0.38888888888889
93124, 1.9391304347826, 1.375, 0.36111111111111
93125, 1.9173913043478, 1.375, 0.33333333333333
93126, 1.9391304347826, 1.3875, 0.33333333333333
93127, 1.9391304347826, 1.375, 0.30555555555556
93128, 1.9173913043478, 1.375, 0.27777777777778
93129, 1.9391304347826, 1.3875, 0.27777777777778
93130, 1.9391304347826, 1.375, 0.25
93131, 1.9173913043478, 1.375, 0.22222222222222
93132, 1.9391304347826, 1.3875, 0.22222222222222
93133, 1.9391304347826, 1.375, 0.19444444444444
93134, 1.9173913043478, 1.375, 0.16666666666667
93135, 1.9391304347826, 1.3875, 0.16666666666667
93136, 1.9391304347826, 1.375, 0.13888888888889
93137, 1.9173913043478, 1.375, 0.11111111111111
93138, 1.9391304347826, 1.3875, 0.11111111111111
93139, 1.9391304347826, 1.375, 0.083333333333333
93140, 1.9173913043478, 1.375, 0.055555555555556
93141, 1.9391304347826, 1.3875, 0.055555555555556
93142, 1.9391304347826, 1.375, 0.027777777777778
93143, 1.9826086956522, 1.375, 0.47222222222222
93144, 1.9608695652174, 1.375, 0.44444444444444
93145, 1.9826086956522, 1.3875, 0.44444444444444
93146, 1.9826086956522, 1.375, 0.41666666666667
93147, 1.9608695652174, 1.375, 0.38888888888889
93148, 1.9826086956522, 1.3875, 0.38888888888889
93149, 1.9826086956522, 1.375, 0.36111111111111
93150, 1.9608695652174, 1.375, 0.33333333333333
93151, 1.9826086956522, 1.3875, 0.33333333333333
93152, 1.9826086956522, 1.375, 0.30555555555556
93153, 1.9608695652174, 1.375, 0.27777777777778
93154, 1.9826086956522, 1.3875, 0.27777777777778
93155, 1.9826086956522, 1.375, 0.25
93156, 1.9608695652174, 1.375, 0.22222222222222
93157, 1.9826086956522, 1.3875, 0.22222222222222
93158, 1.9826086956522, 1.375, 0.19444444444444
93159, 1.9608695652174, 1.375, 0.16666666666667
93160, 1.9826086956522, 1.3875, 0.16666666666667
93161, 1.9826086956522, 1.375, 0.13888888888889
93162, 1.9608695652174, 1.375, 0.11111111111111
93163, 1.9826086956522, 1.3875, 0.11111111111111
93164, 1.9826086956522, 1.375, 0.083333333333333
93165, 1.9608695652174, 1.375, 0.055555555555556
93166, 1.9826086956522, 1.3875, 0.055555555555556
93167, 1.9826086956522, 1.375, 0.027777777777778
93168, 2.0260869565217, 1.375, 0.47222222222222
93169, 2.004347826087, 1.375, 0.44444444444444
93170, 2.0260869565217, 1.3875, 0.44444444444444
93171, 2.0260869565217, 1.375, 0.41666666666667
93172, 2.004347826087, 1.375, 0.38888888888889
93173, 2.0260869565217, 1.3875, 0.38888888888889
93174, 2.0260869565217, 1.375, 0.36111111111111
93175, 2.004347826087, 1.375, 0.33333333333333
93176, 2.0260869565217, 1.3875, 0.33333333333333
93177, 2.0260869565217, 1.375, 0.30555555555556
93178, 2.004347826087, 1.375, 0.27777777777778
93179, 2.0260869565217, 1.3875, 0.27777777777778
93180, 2.0260869565217, 1.375, 0.25
93181, 2.004347826087, 1.375, 0.22222222222222
93182, 2.0260869565217, 1.3875, 0.22222222222222
93183, 2.0260869565217, 1.375, 0.19444444444444
93184, 2.004347826087, 1.375, 0.16666666666667
93185, 2.0260869565217, 1.3875, 0.16666666666667
93186, 2.0260869565217, 1.375, 0.13888888888889
93187, 2.004347826087, 1.375, 0.11111111111111
93188, 2.0260869565217, 1.3875, 0.11111111111111
93189, 2.0260869565217, 1.375, 0.083333333333333
93190, 2.004347826087, 1.375, 0.055555555555556
93191, 2.0260869565217, 1.3875, 0.055555555555556
93192, 2.0260869565217, 1.375, 0.027777777777778
93193, 2.0695652173913, 1.375, 0.47222222222222
93194, 2.0478260869565, 1.375, 0.44444444444444
93195, 2.0695652173913, 1.3875, 0.44444444444444
93196, 2.0695652173913, 1.375, 0.41666666666667
93197, 2.0478260869565, 1.375, 0.38888888888889
93198, 2.0695652173913, 1.3875, 0.38888888888889
93199, 2.0695652173913, 1.375, 0.36111111111111
93200, 2.0478260869565, 1.375, 0.33333333333333
93201, 2.0695652173913, 1.3875, 0.33333333333333
93202, 2.0695652173913, 1.375, 0.30555555555556
93203, 2.0478260869565, 1.375, 0.27777777777778
93204, 2.0695652173913, 1.3875, 0.27777777777778
93205, 2.0695652173913, 1.375, 0.25
93206, 2.0478260869565, 1.375, 0.22222222222222
93207, 2.0695652173913, 1.3875, 0.22222222222222
93208, 2.0695652173913, 1.375, 0.19444444444444
93209, 2.0478260869565, 1.375, 0.16666666666667
93210, 2.0695652173913, 1.3875, 0.16666666666667
93211, 2.0695652173913, 1.375, 0.13888888888889
93212, 2.0478260869565, 1.375, 0.11111111111111
93213, 2.0695652173913, 1.3875, 0.11111111111111
93214, 2.0695652173913, 1.375, 0.083333333333333
93215, 2.0478260869565, 1.375, 0.055555555555556
93216, 2.0695652173913, 1.3875, 0.055555555555556
93217, 2.0695652173913, 1.375, 0.027777777777778
93218, 2.1130434782609, 1.375, 0.47222222222222
93219, 2.0913043478261, 1.375, 0.44444444444444
93220, 2.1130434782609, 1.3875, 0.44444444444444
93221, 2.1130434782609, 1.375, 0.41666666666667
93222, 2.0913043478261, 1.375, 0.38888888888889
93223, 2.1130434782609, 1.3875, 0.38888888888889
93224, 2.1130434782609, 1.375, 0.36111111111111
93225, 2.0913043478261, 1.375, 0.33333333333333
93226, 2.1130434782609, 1.3875, 0.33333333333333
93227, 2.1130434782609, 1.375, 0.30555555555556
93228, 2.0913043478261, 1.375, 0.27777777777778
93229, 2.1130434782609, 1.3875, 0.27777777777778
93230, 2.1130434782609, 1.375, 0.25
93231, 2.0913043478261, 1.375, 0.22222222222222
93232, 2.1130434782609, 1.3875, 0.22222222222222
93233, 2.1130434782609, 1.375, 0.19444444444444
93234, 2.0913043478261, 1.375, 0.16666666666667
93235, 2.1130434782609, 1.3875, 0.16666666666667
93236, 2.1130434782609, 1.375, 0.13888888888889
93237, 2.0913043478261, 1.375, 0.11111111111111
93238, 2.1130434782609, 1.3875, 0.11111111111111
93239, 2.1130434782609, 1.375, 0.083333333333333
93240, 2.0913043478261, 1.375, 0.055555555555556
93241, 2.1130434782609, 1.3875, 0.055555555555556
93242, 2.1130434782609, 1.375, 0.027777777777778
93243, 2.1565217391304, 1.375, 0.47222222222222
93244, 2.1347826086957, 1.375, 0.44444444444444
93245, 2.1565217391304, 1.3875, 0.44444444444444
93246, 2.1565217391304, 1.375, 0.41666666666667
93247, 2.1347826086957, 1.375, 0.38888888888889
93248, 2.1565217391304, 1.3875, 0.38888888888889
93249, 2.1565217391304, 1.375, 0.36111111111111
93250, 2.1347826086957, 1.375, 0.33333333333333
93251, 2.1565217391304, 1.3875, 0.33333333333333
93252, 2.1565217391304, 1.375, 0.30555555555556
93253, 2.1347826086957, 1.375, 0.27777777777778
93254, 2.1565217391304, 1.3875, 0.27777777777778
93255, 2.1565217391304, 1.375, 0.25
93256, 2.1347826086957, 1.375, 0.22222222222222
93257, 2.1565217391304, 1.3875, 0.22222222222222
93258, 2.1565217391304, 1.375, 0.19444444444444
93259, 2.1347826086957, 1.375, 0.16666666666667
93260, 2.1565217391304, 1.3875, 0.16666666666667
93261, 2.1565217391304, 1.375, 0.13888888888889
93262, 2.1347826086957, 1.375, 0.11111111111111
93263, 2.1565217391304, 1.3875, 0.11111111111111
93264, 2.1565217391304, 1.375, 0.083333333333333
93265, 2.1347826086957, 1.375, 0.055555555555556
93266, 2.1565217391304, 1.3875, 0.055555555555556
93267, 2.1565217391304, 1.375, 0.027777777777778
93268, 2.1782608695652, 1.375, 0.44444444444444
93269, 2.1782608695652, 1.375, 0.38888888888889
93270, 2.1782608695652, 1.375, 0.33333333333333
93271, 2.1782608695652, 1.375, 0.27777777777778
93272, 2.1782608695652, 1.375, 0.22222222222222
93273, 2.1782608695652, 1.375, 0.16666666666667
93274, 2.1782608695652, 1.375, 0.11111111111111
93275, 2.1782608695652, 1.375, 0.055555555555556
93276, 1.2434782608696, 1.3625, 0.44444444444444
93277, 1.2434782608696, 1.3625, 0.38888888888889
93278, 1.2434782608696, 1.3625, 0.33333333333333
93279, 1.2434782608696, 1.3625, 0.27777777777778
93280, 1.2434782608696, 1.3625, 0.22222222222222
93281, 1.2434782608696, 1.3625, 0.16666666666667
93282, 1.2434782608696, 1.3625, 0.11111111111111
93283, 1.2434782608696, 1.3625, 0.055555555555556
93284, 1.2869565217391, 1.3625, 0.44444444444444
93285, 1.2869565217391, 1.3625, 0.38888888888889
93286, 1.2869565217391, 1.3625, 0.33333333333333
93287, 1.2869565217391, 1.3625, 0.27777777777778
93288, 1.2869565217391, 1.3625, 0.22222222222222
93289, 1.2869565217391, 1.3625, 0.16666666666667
93290, 1.2869565217391, 1.3625, 0.11111111111111
93291, 1.2869565217391, 1.3625, 0.055555555555556
93292, 1.3304347826087, 1.3625, 0.44444444444444
93293, 1.3304347826087, 1.3625, 0.38888888888889
93294, 1.3304347826087, 1.3625, 0.33333333333333
93295, 1.3304347826087, 1.3625, 0.27777777777778
93296, 1.3304347826087, 1.3625, 0.22222222222222
93297, 1.3304347826087, 1.3625, 0.16666666666667
93298, 1.3304347826087, 1.3625, 0.11111111111111
93299, 1.3304347826087, 1.3625, 0.055555555555556
93300, 1.3739130434783, 1.3625, 0.44444444444444
93301, 1.3739130434783, 1.3625, 0.38888888888889
93302, 1.3739130434783, 1.3625, 0.33333333333333
93303, 1.3739130434783, 1.3625, 0.27777777777778
93304, 1.3739130434783, 1.3625, 0.22222222222222
93305, 1.3739130434783, 1.3625, 0.16666666666667
93306, 1.3739130434783, 1.3625, 0.11111111111111
93307, 1.3739130434783, 1.3625, 0.055555555555556
93308, 1.4173913043478, 1.3625, 0.44444444444444
93309, 1.4173913043478, 1.3625, 0.38888888888889
93310, 1.4173913043478, 1.3625, 0.33333333333333
93311, 1.4173913043478, 1.3625, 0.27777777777778
93312, 1.4173913043478, 1.3625, 0.22222222222222
93313, 1.4173913043478, 1.3625, 0.16666666666667
93314, 1.4173913043478, 1.3625, 0.11111111111111
93315, 1.4173913043478, 1.3625, 0.055555555555556
93316, 1.4608695652174, 1.3625, 0.44444444444444
93317, 1.4608695652174, 1.3625, 0.38888888888889
93318, 1.4608695652174, 1.3625, 0.33333333333333
93319, 1.4608695652174, 1.3625, 0.27777777777778
93320, 1.4608695652174, 1.3625, 0.22222222222222
93321, 1.4608695652174, 1.3625, 0.16666666666667
93322, 1.4608695652174, 1.3625, 0.11111111111111
93323, 1.4608695652174, 1.3625, 0.055555555555556
93324, 1.504347826087, 1.3625, 0.44444444444444
93325, 1.504347826087, 1.3625, 0.38888888888889
93326, 1.504347826087, 1.3625, 0.33333333333333
93327, 1.504347826087, 1.3625, 0.27777777777778
93328, 1.504347826087, 1.3625, 0.22222222222222
93329, 1.504347826087, 1.3625, 0.16666666666667
93330, 1.504347826087, 1.3625, 0.11111111111111
93331, 1.504347826087, 1.3625, 0.055555555555556
93332, 1.5478260869565, 1.3625, 0.44444444444444
93333, 1.5478260869565, 1.3625, 0.38888888888889
93334, 1.5478260869565, 1.3625, 0.33333333333333
93335, 1.5478260869565, 1.3625, 0.27777777777778
93336, 1.5478260869565, 1.3625, 0.22222222222222
93337, 1.5478260869565, 1.3625, 0.16666666666667
93338, 1.5478260869565, 1.3625, 0.11111111111111
93339, 1.5478260869565, 1.3625, 0.055555555555556
93340, 1.5913043478261, 1.3625, 0.44444444444444
93341, 1.5913043478261, 1.3625, 0.38888888888889
93342, 1.5913043478261, 1.3625, 0.33333333333333
93343, 1.5913043478261, 1.3625, 0.27777777777778
93344, 1.5913043478261, 1.3625, 0.22222222222222
93345, 1.5913043478261, 1.3625, 0.16666666666667
93346, 1.5913043478261, 1.3625, 0.11111111111111
93347, 1.5913043478261, 1.3625, 0.055555555555556
93348, 1.6347826086957, 1.3625, 0.44444444444444
93349, 1.6347826086957, 1.3625, 0.38888888888889
93350, 1.6347826086957, 1.3625, 0.33333333333333
93351, 1.6347826086957, 1.3625, 0.27777777777778
93352, 1.6347826086957, 1.3625, 0.22222222222222
93353, 1.6347826086957, 1.3625, 0.16666666666667
93354, 1.6347826086957, 1.3625, 0.11111111111111
93355, 1.6347826086957, 1.3625, 0.055555555555556
93356, 1.6782608695652, 1.3625, 0.44444444444444
93357, 1.6782608695652, 1.3625, 0.38888888888889
93358, 1.6782608695652, 1.3625, 0.33333333333333
93359, 1.6782608695652, 1.3625, 0.27777777777778
93360, 1.6782608695652, 1.3625, 0.22222222222222
93361, 1.6782608695652, 1.3625, 0.16666666666667
93362, 1.6782608695652, 1.3625, 0.11111111111111
93363, 1.6782608695652, 1.3625, 0.055555555555556
93364, 1.7217391304348, 1.3625, 0.44444444444444
93365, 1.7217391304348, 1.3625, 0.38888888888889
93366, 1.7217391304348, 1.3625, 0.33333333333333
93367, 1.7217391304348, 1.3625, 0.27777777777778
93368, 1.7217391304348, 1.3625, 0.22222222222222
93369, 1.7217391304348, 1.3625, 0.16666666666667
93370, 1.7217391304348, 1.3625, 0.11111111111111
93371, 1.7217391304348, 1.3625, 0.055555555555556
93372, 1.7652173913043, 1.3625, 0.44444444444444
93373, 1.7652173913043, 1.3625, 0.38888888888889
93374, 1.7652173913043, 1.3625, 0.33333333333333
93375, 1.7652173913043, 1.3625, 0.27777777777778
93376, 1.7652173913043, 1.3625, 0.22222222222222
93377, 1.7652173913043, 1.3625, 0.16666666666667
93378, 1.7652173913043, 1.3625, 0.11111111111111
93379, 1.7652173913043, 1.3625, 0.055555555555556
93380, 1.8086956521739, 1.3625, 0.44444444444444
93381, 1.8086956521739, 1.3625, 0.38888888888889
93382, 1.8086956521739, 1.3625, 0.33333333333333
93383, 1.8086956521739, 1.3625, 0.27777777777778
93384, 1.8086956521739, 1.3625, 0.22222222222222
93385, 1.8086956521739, 1.3625, 0.16666666666667
93386, 1.8086956521739, 1.3625, 0.11111111111111
93387, 1.8086956521739, 1.3625, 0.055555555555556
93388, 1.8521739130435, 1.3625, 0.44444444444444
93389, 1.8521739130435, 1.3625, 0.38888888888889
93390, 1.8521739130435, 1.3625, 0.33333333333333
93391, 1.8521739130435, 1.3625, 0.27777777777778
93392, 1.8521739130435, 1.3625, 0.22222222222222
93393, 1.8521739130435, 1.3625, 0.16666666666667
93394, 1.8521739130435, 1.3625, 0.11111111111111
93395, 1.8521739130435, 1.3625, 0.055555555555556
93396, 1.895652173913, 1.3625, 0.44444444444444
93397, 1.895652173913, 1.3625, 0.38888888888889
93398, 1.895652173913, 1.3625, 0.33333333333333
93399, 1.895652173913, 1.3625, 0.27777777777778
93400, 1.895652173913, 1.3625, 0.22222222222222
93401, 1.895652173913, 1.3625, 0.16666666666667
93402, 1.895652173913, 1.3625, 0.11111111111111
93403, 1.895652173913, 1.3625, 0.055555555555556
93404, 1.9391304347826, 1.3625, 0.44444444444444
93405, 1.9391304347826, 1.3625, 0.38888888888889
93406, 1.9391304347826, 1.3625, 0.33333333333333
93407, 1.9391304347826, 1.3625, 0.27777777777778
93408, 1.9391304347826, 1.3625, 0.22222222222222
93409, 1.9391304347826, 1.3625, 0.16666666666667
93410, 1.9391304347826, 1.3625, 0.11111111111111
93411, 1.9391304347826, 1.3625, 0.055555555555556
93412, 1.9826086956522, 1.3625, 0.44444444444444
93413, 1.9826086956522, 1.3625, 0.38888888888889
93414, 1.9826086956522, 1.3625, 0.33333333333333
93415, 1.9826086956522, 1.3625, 0.27777777777778
93416, 1.9826086956522, 1.3625, 0.22222222222222
93417, 1.9826086956522, 1.3625, 0.16666666666667
93418, 1.9826086956522, 1.3625, 0.11111111111111
93419, 1.9826086956522, 1.3625, 0.055555555555556
93420, 2.0260869565217, 1.3625, 0.44444444444444
93421, 2.0260869565217, 1.3625, 0.38888888888889
93422, 2.0260869565217, 1.3625, 0.33333333333333
93423, 2.0260869565217, 1.3625, 0.27777777777778
93424, 2.0260869565217, 1.3625, 0.22222222222222
93425, 2.0260869565217, 1.3625, 0.16666666666667
93426, 2.0260869565217, 1.3625, 0.11111111111111
93427, 2.0260869565217, 1.3625, 0.055555555555556
93428, 2.0695652173913, 1.3625, 0.44444444444444
93429, 2.0695652173913, 1.3625, 0.38888888888889
93430, 2.0695652173913, 1.3625, 0.33333333333333
93431, 2.0695652173913, 1.3625, 0.27777777777778
93432, 2.0695652173913, 1.3625, 0.22222222222222
93433, 2.0695652173913, 1.3625, 0.16666666666667
93434, 2.0695652173913, 1.3625, 0.11111111111111
93435, 2.0695652173913, 1.3625, 0.055555555555556
93436, 2.1130434782609, 1.3625, 0.44444444444444
93437, 2.1130434782609, 1.3625, 0.38888888888889
93438, 2.1130434782609, 1.3625, 0.33333333333333
93439, 2.1130434782609, 1.3625, 0.27777777777778
93440, 2.1130434782609, 1.3625, 0.22222222222222
93441, 2.1130434782609, 1.3625, 0.16666666666667
93442, 2.1130434782609, 1.3625, 0.11111111111111
93443, 2.1130434782609, 1.3625, 0.055555555555556
93444, 2.1565217391304, 1.3625, 0.44444444444444
93445, 2.1565217391304, 1.3625, 0.38888888888889
93446, 2.1565217391304, 1.3625, 0.33333333333333
93447, 2.1565217391304, 1.3625, 0.27777777777778
93448, 2.1565217391304, 1.3625, 0.22222222222222
93449, 2.1565217391304, 1.3625, 0.16666666666667
93450, 2.1565217391304, 1.3625, 0.11111111111111
93451, 2.1565217391304, 1.3625, 0.055555555555556
93452, 0.95652173913044, 0.20217391304348, -0.05
93453, 0.91304347826087, 0.20217391304348, -0.05
93454, 0.8695652173913, 0.20217391304348, -0.05
93455, 0.82608695652174, 0.20217391304348, -0.05
93456, 0.78260869565217, 0.20217391304348, -0.05
93457, 0.73913043478261, 0.20217391304348, -0.05
93458, 0.69565217391304, 0.20217391304348, -0.05
93459, 0.65217391304348, 0.20217391304348, -0.05
93460, 0.60869565217391, 0.20217391304348, -0.05
93461, 0.56521739130435, 0.20217391304348, -0.05
93462, 0.52173913043478, 0.20217391304348, -0.05
93463, 0.47826086956522, 0.20217391304348, -0.05
93464, 0.43478260869565, 0.20217391304348, -0.05
93465, 0.39130434782609, 0.20217391304348, -0.05
93466, 0.34782608695652, 0.20217391304348, -0.05
93467, 0.30434782608696, 0.20217391304348, -0.05
93468, 0.26086956521739, 0.20217391304348, -0.05
93469, 0.21739130434783, 0.20217391304348, -0.05
93470, 0.17391304347826, 0.20217391304348, -0.05
93471, 0.1304347826087, 0.20217391304348, -0.05
93472, 0.08695652173913, 0.20217391304348, -0.05
93473, 0.043478260869565, 0.20217391304348, -0.05
93474, 0.95652173913043, 0.25434782608696, -0.05
93475, 0.91304347826087, 0.25434782608696, -0.05
93476, 0.8695652173913, 0.25434782608696, -0.05
93477, 0.82608695652174, 0.25434782608696, -0.05
93478, 0.78260869565217, 0.25434782608696, -0.05
93479, 0.73913043478261, 0.25434782608696, -0.05
93480, 0.69565217391304, 0.25434782608696, -0.05
93481, 0.65217391304348, 0.25434782608696, -0.05
93482, 0.60869565217391, 0.25434782608696, -0.05
93483, 0.56521739130435, 0.25434782608696, -0.05
93484, 0.52173913043478, 0.25434782608696, -0.05
93485, 0.47826086956522, 0.25434782608696, -0.05
93486, 0.43478260869565, 0.25434782608696, -0.05
93487, 0.39130434782609, 0.25434782608696, -0.05
93488, 0.34782608695652, 0.25434782608696, -0.05
93489, 0.30434782608696, 0.25434782608696, -0.05
93490, 0.26086956521739, 0.25434782608696, -0.05
93491, 0.21739130434783, 0.25434782608696, -0.05
93492, 0.17391304347826, 0.25434782608696, -0.05
93493, 0.1304347826087, 0.25434782608696, -0.05
93494, 0.08695652173913, 0.25434782608696, -0.05
93495, 0.043478260869565, 0.25434782608696, -0.05
93496, 0.95652173913044, 0.30652173913043, -0.05
93497, 0.91304347826087, 0.30652173913043, -0.05
93498, 0.8695652173913, 0.30652173913043, -0.05
93499, 0.82608695652174, 0.30652173913043, -0.05
93500, 0.78260869565217, 0.30652173913043, -0.05
93501, 0.73913043478261, 0.30652173913043, -0.05
93502, 0.69565217391304, 0.30652173913043, -0.05
93503, 0.65217391304348, 0.30652173913043, -0.05
93504, 0.60869565217391, 0.30652173913043, -0.05
93505, 0.56521739130435, 0.30652173913043, -0.05
93506, 0.52173913043478, 0.30652173913043, -0.05
93507, 0.47826086956522, 0.30652173913043, -0.05
93508, 0.43478260869565, 0.30652173913043, -0.05
93509, 0.39130434782609, 0.30652173913043, -0.05
93510, 0.34782608695652, 0.30652173913043, -0.05
93511, 0.30434782608696, 0.30652173913043, -0.05
93512, 0.26086956521739, 0.30652173913043, -0.05
93513, 0.21739130434783, 0.30652173913043, -0.05
93514, 0.17391304347826, 0.30652173913043, -0.05
93515, 0.1304347826087, 0.30652173913043, -0.05
93516, 0.08695652173913, 0.30652173913043, -0.05
93517, 0.043478260869565, 0.30652173913043, -0.05
93518, 0.95652173913043, 0.35869565217391, -0.05
93519, 0.91304347826087, 0.35869565217391, -0.05
93520, 0.8695652173913, 0.35869565217391, -0.05
93521, 0.82608695652174, 0.35869565217391, -0.05
93522, 0.78260869565217, 0.35869565217391, -0.05
93523, 0.73913043478261, 0.35869565217391, -0.05
93524, 0.69565217391304, 0.35869565217391, -0.05
93525, 0.65217391304348, 0.35869565217391, -0.05
93526, 0.60869565217391, 0.35869565217391, -0.05
93527, 0.56521739130435, 0.35869565217391, -0.05
93528, 0.52173913043478, 0.35869565217391, -0.05
93529, 0.47826086956522, 0.35869565217391, -0.05
93530, 0.43478260869565, 0.35869565217391, -0.05
93531, 0.39130434782609, 0.35869565217391, -0.05
93532, 0.34782608695652, 0.35869565217391, -0.05
93533, 0.30434782608696, 0.35869565217391, -0.05
93534, 0.26086956521739, 0.35869565217391, -0.05
93535, 0.21739130434783, 0.35869565217391, -0.05
93536, 0.17391304347826, 0.35869565217391, -0.05
93537, 0.1304347826087, 0.35869565217391, -0.05
93538, 0.08695652173913, 0.35869565217391, -0.05
93539, 0.043478260869565, 0.35869565217391, -0.05
93540, 0.95652173913043, 0.41086956521739, -0.05
93541, 0.91304347826087, 0.41086956521739, -0.05
93542, 0.8695652173913, 0.41086956521739, -0.05
93543, 0.82608695652174, 0.41086956521739, -0.05
93544, 0.78260869565217, 0.41086956521739, -0.05
93545, 0.73913043478261, 0.41086956521739, -0.05
93546, 0.69565217391304, 0.41086956521739, -0.05
93547, 0.65217391304348, 0.41086956521739, -0.05
93548, 0.60869565217391, 0.41086956521739, -0.05
93549, 0.56521739130435, 0.41086956521739, -0.05
93550, 0.52173913043478, 0.41086956521739, -0.05
93551, 0.47826086956522, 0.41086956521739, -0.05
93552, 0.43478260869565, 0.41086956521739, -0.05
93553, 0.39130434782609, 0.41086956521739, -0.05
93554, 0.34782608695652, 0.41086956521739, -0.05
93555, 0.30434782608696, 0.41086956521739, -0.05
93556, 0.26086956521739, 0.41086956521739, -0.05
93557, 0.21739130434783, 0.41086956521739, -0.05
93558, 0.17391304347826, 0.41086956521739, -0.05
93559, 0.1304347826087, 0.41086956521739, -0.05
93560, 0.08695652173913, 0.41086956521739, -0.05
93561, 0.043478260869565, 0.41086956521739, -0.05
93562, 0.95652173913043, 0.46304347826087, -0.05
93563, 0.91304347826087, 0.46304347826087, -0.05
93564, 0.8695652173913, 0.46304347826087, -0.05
93565, 0.82608695652174, 0.46304347826087, -0.05
93566, 0.78260869565217, 0.46304347826087, -0.05
93567, 0.73913043478261, 0.46304347826087, -0.05
93568, 0.69565217391304, 0.46304347826087, -0.05
93569, 0.65217391304348, 0.46304347826087, -0.05
93570, 0.60869565217391, 0.46304347826087, -0.05
93571, 0.56521739130435, 0.46304347826087, -0.05
93572, 0.52173913043478, 0.46304347826087, -0.05
93573, 0.47826086956522, 0.46304347826087, -0.05
93574, 0.43478260869565, 0.46304347826087, -0.05
93575, 0.39130434782609, 0.46304347826087, -0.05
93576, 0.34782608695652, 0.46304347826087, -0.05
93577, 0.30434782608696, 0.46304347826087, -0.05
93578, 0.26086956521739, 0.46304347826087, -0.05
93579, 0.21739130434783, 0.46304347826087, -0.05
93580, 0.17391304347826, 0.46304347826087, -0.05
93581, 0.1304347826087, 0.46304347826087, -0.05
93582, 0.08695652173913, 0.46304347826087, -0.05
93583, 0.043478260869565, 0.46304347826087, -0.05
93584, 0.95652173913043, 0.51521739130435, -0.05
93585, 0.91304347826087, 0.51521739130435, -0.05
93586, 0.8695652173913, 0.51521739130435, -0.05
93587, 0.82608695652174, 0.51521739130435, -0.05
93588, 0.78260869565217, 0.51521739130435, -0.05
93589, 0.73913043478261, 0.51521739130435, -0.05
93590, 0.69565217391304, 0.51521739130435, -0.05
93591, 0.65217391304348, 0.51521739130435, -0.05
93592, 0.60869565217391, 0.51521739130435, -0.05
93593, 0.56521739130435, 0.51521739130435, -0.05
93594, 0.52173913043478, 0.51521739130435, -0.05
93595, 0.47826086956522, 0.51521739130435, -0.05
93596, 0.43478260869565, 0.51521739130435, -0.05
93597, 0.39130434782609, 0.51521739130435, -0.05
93598, 0.34782608695652, 0.51521739130435, -0.05
93599, 0.30434782608696, 0.51521739130435, -0.05
93600, 0.26086956521739, 0.51521739130435, -0.05
93601, 0.21739130434783, 0.51521739130435, -0.05
93602, 0.17391304347826, 0.51521739130435, -0.05
93603, 0.1304347826087, 0.51521739130435, -0.05
93604, 0.08695652173913, 0.51521739130435, -0.05
93605, 0.043478260869565, 0.51521739130435, -0.05
93606, 0.95652173913043, 0.56739130434783, -0.05
93607, 0.91304347826087, 0.56739130434783, -0.05
93608, 0.8695652173913, 0.56739130434783, -0.05
93609, 0.82608695652174, 0.56739130434783, -0.05
93610, 0.78260869565217, 0.56739130434783, -0.05
93611, 0.73913043478261, 0.56739130434783, -0.05
93612, 0.69565217391304, 0.56739130434783, -0.05
93613, 0.65217391304348, 0.56739130434783, -0.05
93614, 0.60869565217391, 0.56739130434783, -0.05
93615, 0.56521739130435, 0.56739130434783, -0.05
93616, 0.52173913043478, 0.56739130434783, -0.05
93617, 0.47826086956522, 0.56739130434783, -0.05
93618, 0.43478260869565, 0.56739130434783, -0.05
93619, 0.39130434782609, 0.56739130434783, -0.05
93620, 0.34782608695652, 0.56739130434783, -0.05
93621, 0.30434782608696, 0.56739130434783, -0.05
93622, 0.26086956521739, 0.56739130434783, -0.05
93623, 0.21739130434783, 0.56739130434783, -0.05
93624, 0.17391304347826, 0.56739130434783, -0.05
93625, 0.1304347826087, 0.56739130434783, -0.05
93626, 0.08695652173913, 0.56739130434783, -0.05
93627, 0.043478260869565, 0.56739130434783, -0.05
93628, 0.95652173913043, 0.6195652173913, -0.05
93629, 0.91304347826087, 0.6195652173913, -0.05
93630, 0.8695652173913, 0.6195652173913, -0.05
93631, 0.82608695652174, 0.6195652173913, -0.05
93632, 0.78260869565217, 0.6195652173913, -0.05
93633, 0.73913043478261, 0.6195652173913, -0.05
93634, 0.69565217391304, 0.6195652173913, -0.05
93635, 0.65217391304348, 0.6195652173913, -0.05
93636, 0.60869565217391, 0.6195652173913, -0.05
93637, 0.56521739130435, 0.6195652173913, -0.05
93638, 0.52173913043478, 0.6195652173913, -0.05
93639, 0.47826086956522, 0.6195652173913, -0.05
93640, 0.43478260869565, 0.6195652173913, -0.05
93641, 0.39130434782609, 0.6195652173913, -0.05
93642, 0.34782608695652, 0.6195652173913, -0.05
93643, 0.30434782608696, 0.6195652173913, -0.05
93644, 0.26086956521739, 0.6195652173913, -0.05
93645, 0.21739130434783, 0.6195652173913, -0.05
93646, 0.17391304347826, 0.6195652173913, -0.05
93647, 0.1304347826087, 0.6195652173913, -0.05
93648, 0.08695652173913, 0.6195652173913, -0.05
93649, 0.043478260869565, 0.6195652173913, -0.05
93650, 0.95652173913044, 0.67173913043478, -0.05
93651, 0.91304347826087, 0.67173913043478, -0.05
93652, 0.8695652173913, 0.67173913043478, -0.05
93653, 0.82608695652174, 0.67173913043478, -0.05
93654, 0.78260869565217, 0.67173913043478, -0.05
93655, 0.73913043478261, 0.67173913043478, -0.05
93656, 0.69565217391304, 0.67173913043478, -0.05
93657, 0.65217391304348, 0.67173913043478, -0.05
93658, 0.60869565217391, 0.67173913043478, -0.05
93659, 0.56521739130435, 0.67173913043478, -0.05
93660, 0.52173913043478, 0.67173913043478, -0.05
93661, 0.47826086956522, 0.67173913043478, -0.05
93662, 0.43478260869565, 0.67173913043478, -0.05
93663, 0.39130434782609, 0.67173913043478, -0.05
93664, 0.34782608695652, 0.67173913043478, -0.05
93665, 0.30434782608696, 0.67173913043478, -0.05
93666, 0.26086956521739, 0.67173913043478, -0.05
93667, 0.21739130434783, 0.67173913043478, -0.05
93668, 0.17391304347826, 0.67173913043478, -0.05
93669, 0.1304347826087, 0.67173913043478, -0.05
93670, 0.08695652173913, 0.67173913043478, -0.05
93671, 0.043478260869565, 0.67173913043478, -0.05
93672, 0.95652173913043, 0.72391304347826, -0.05
93673, 0.91304347826087, 0.72391304347826, -0.05
93674, 0.8695652173913, 0.72391304347826, -0.05
93675, 0.82608695652174, 0.72391304347826, -0.05
93676, 0.78260869565217, 0.72391304347826, -0.05
93677, 0.73913043478261, 0.72391304347826, -0.05
93678, 0.69565217391304, 0.72391304347826, -0.05
93679, 0.65217391304348, 0.72391304347826, -0.05
93680, 0.60869565217391, 0.72391304347826, -0.05
93681, 0.56521739130435, 0.72391304347826, -0.05
93682, 0.52173913043478, 0.72391304347826, -0.05
93683, 0.47826086956522, 0.72391304347826, -0.05
93684, 0.43478260869565, 0.72391304347826, -0.05
93685, 0.39130434782609, 0.72391304347826, -0.05
93686, 0.34782608695652, 0.72391304347826, -0.05
93687, 0.30434782608696, 0.72391304347826, -0.05
93688, 0.26086956521739, 0.72391304347826, -0.05
93689, 0.21739130434783, 0.72391304347826, -0.05
93690, 0.17391304347826, 0.72391304347826, -0.05
93691, 0.1304347826087, 0.72391304347826, -0.05
93692, 0.08695652173913, 0.72391304347826, -0.05
93693, 0.043478260869565, 0.72391304347826, -0.05
93694, 0.95652173913043, 0.77608695652174, -0.05
93695, 0.91304347826087, 0.77608695652174, -0.05
93696, 0.8695652173913, 0.77608695652174, -0.05
93697, 0.82608695652174, 0.77608695652174, -0.05
93698, 0.78260869565217, 0.77608695652174, -0.05
93699, 0.73913043478261, 0.77608695652174, -0.05
93700, 0.69565217391304, 0.77608695652174, -0.05
93701, 0.65217391304348, 0.77608695652174, -0.05
93702, 0.60869565217391, 0.77608695652174, -0.05
93703, 0.56521739130435, 0.77608695652174, -0.05
93704, 0.52173913043478, 0.77608695652174, -0.05
93705, 0.47826086956522, 0.77608695652174, -0.05
93706, 0.43478260869565, 0.77608695652174, -0.05
93707, 0.39130434782609, 0.77608695652174, -0.05
93708, 0.34782608695652, 0.77608695652174, -0.05
93709, 0.30434782608696, 0.77608695652174, -0.05
93710, 0.26086956521739, 0.77608695652174, -0.05
93711, 0.21739130434783, 0.77608695652174, -0.05
93712, 0.17391304347826, 0.77608695652174, -0.05
93713, 0.1304347826087, 0.77608695652174, -0.05
93714, 0.08695652173913, 0.77608695652174, -0.05
93715, 0.043478260869565, 0.77608695652174, -0.05
93716, 0.95652173913044, 0.82826086956522, -0.05
93717, 0.91304347826087, 0.82826086956522, -0.05
93718, 0.8695652173913, 0.82826086956522, -0.05
93719, 0.82608695652174, 0.82826086956522, -0.05
93720, 0.78260869565217, 0.82826086956522, -0.05
93721, 0.73913043478261, 0.82826086956522, -0.05
93722, 0.69565217391304, 0.82826086956522, -0.05
93723, 0.65217391304348, 0.82826086956522, -0.05
93724, 0.60869565217391, 0.82826086956522, -0.05
93725, 0.56521739130435, 0.82826086956522, -0.05
93726, 0.52173913043478, 0.82826086956522, -0.05
93727, 0.47826086956522, 0.82826086956522, -0.05
93728, 0.43478260869565, 0.82826086956522, -0.05
93729, 0.39130434782609, 0.82826086956522, -0.05
93730, 0.34782608695652, 0.82826086956522, -0.05
93731, 0.30434782608696, 0.82826086956522, -0.05
93732, 0.26086956521739, 0.82826086956522, -0.05
93733, 0.21739130434783, 0.82826086956522, -0.05
93734, 0.17391304347826, 0.82826086956522, -0.05
93735, 0.1304347826087, 0.82826086956522, -0.05
93736, 0.08695652173913, 0.82826086956522, -0.05
93737, 0.043478260869565, 0.82826086956522, -0.05
93738, 0.95652173913044, 0.88043478260869, -0.05
93739, 0.91304347826087, 0.8804347826087, -0.05
93740, 0.8695652173913, 0.8804347826087, -0.05
93741, 0.82608695652174, 0.8804347826087, -0.05
93742, 0.78260869565217, 0.88043478260869, -0.05
93743, 0.73913043478261, 0.88043478260869, -0.05
93744, 0.69565217391304, 0.8804347826087, -0.05
93745, 0.65217391304348, 0.8804347826087, -0.05
93746, 0.60869565217391, 0.88043478260869, -0.05
93747, 0.56521739130435, 0.88043478260869, -0.05
93748, 0.52173913043478, 0.8804347826087, -0.05
93749, 0.47826086956522, 0.8804347826087, -0.05
93750, 0.43478260869565, 0.88043478260869, -0.05
93751, 0.39130434782609, 0.8804347826087, -0.05
93752, 0.34782608695652, 0.8804347826087, -0.05
93753, 0.30434782608696, 0.88043478260869, -0.05
93754, 0.26086956521739, 0.8804347826087, -0.05
93755, 0.21739130434783, 0.88043478260869, -0.05
93756, 0.17391304347826, 0.88043478260869, -0.05
93757, 0.1304347826087, 0.88043478260869, -0.05
93758, 0.08695652173913, 0.8804347826087, -0.05
93759, 0.043478260869565, 0.88043478260869, -0.05
93760, 0.95652173913043, 0.93260869565217, -0.05
93761, 0.91304347826087, 0.93260869565217, -0.05
93762, 0.8695652173913, 0.93260869565217, -0.05
93763, 0.82608695652174, 0.93260869565217, -0.05
93764, 0.78260869565217, 0.93260869565217, -0.05
93765, 0.73913043478261, 0.93260869565217, -0.05
93766, 0.69565217391304, 0.93260869565217, -0.05
93767, 0.65217391304348, 0.93260869565217, -0.05
93768, 0.60869565217391, 0.93260869565217, -0.05
93769, 0.56521739130435, 0.93260869565217, -0.05
93770, 0.52173913043478, 0.93260869565217, -0.05
93771, 0.47826086956522, 0.93260869565217, -0.05
93772, 0.43478260869565, 0.93260869565217, -0.05
93773, 0.39130434782609, 0.93260869565217, -0.05
93774, 0.34782608695652, 0.93260869565217, -0.05
93775, 0.30434782608696, 0.93260869565217, -0.05
93776, 0.26086956521739, 0.93260869565217, -0.05
93777, 0.21739130434783, 0.93260869565217, -0.05
93778, 0.17391304347826, 0.93260869565217, -0.05
93779, 0.1304347826087, 0.93260869565217, -0.05
93780, 0.08695652173913, 0.93260869565217, -0.05
93781, 0.043478260869565, 0.93260869565217, -0.05
93782, 0.95652173913043, 0.98478260869565, -0.05
93783, 0.91304347826087, 0.98478260869565, -0.05
93784, 0.8695652173913, 0.98478260869565, -0.05
93785, 0.82608695652174, 0.98478260869565, -0.05
93786, 0.78260869565217, 0.98478260869565, -0.05
93787, 0.73913043478261, 0.98478260869565, -0.05
93788, 0.69565217391304, 0.98478260869565, -0.05
93789, 0.65217391304348, 0.98478260869565, -0.05
93790, 0.60869565217391, 0.98478260869565, -0.05
93791, 0.56521739130435, 0.98478260869565, -0.05
93792, 0.52173913043478, 0.98478260869565, -0.05
93793, 0.47826086956522, 0.98478260869565, -0.05
93794, 0.43478260869565, 0.98478260869565, -0.05
93795, 0.39130434782609, 0.98478260869565, -0.05
93796, 0.34782608695652, 0.98478260869565, -0.05
93797, 0.30434782608696, 0.98478260869565, -0.05
93798, 0.26086956521739, 0.98478260869565, -0.05
93799, 0.21739130434783, 0.98478260869565, -0.05
93800, 0.17391304347826, 0.98478260869565, -0.05
93801, 0.1304347826087, 0.98478260869565, -0.05
93802, 0.08695652173913, 0.98478260869565, -0.05
93803, 0.043478260869565, 0.98478260869565, -0.05
93804, 0.95652173913043, 1.0369565217391, -0.05
93805, 0.91304347826087, 1.0369565217391, -0.05
93806, 0.8695652173913, 1.0369565217391, -0.05
93807, 0.82608695652174, 1.0369565217391, -0.05
93808, 0.78260869565217, 1.0369565217391, -0.05
93809, 0.73913043478261, 1.0369565217391, -0.05
93810, 0.69565217391304, 1.0369565217391, -0.05
93811, 0.65217391304348, 1.0369565217391, -0.05
93812, 0.60869565217391, 1.0369565217391, -0.05
93813, 0.56521739130435, 1.0369565217391, -0.05
93814, 0.52173913043478, 1.0369565217391, -0.05
93815, 0.47826086956522, 1.0369565217391, -0.05
93816, 0.43478260869565, 1.0369565217391, -0.05
93817, 0.39130434782609, 1.0369565217391, -0.05
93818, 0.34782608695652, 1.0369565217391, -0.05
93819, 0.30434782608696, 1.0369565217391, -0.05
93820, 0.26086956521739, 1.0369565217391, -0.05
93821, 0.21739130434783, 1.0369565217391, -0.05
93822, 0.17391304347826, 1.0369565217391, -0.05
93823, 0.1304347826087, 1.0369565217391, -0.05
93824, 0.08695652173913, 1.0369565217391, -0.05
93825, 0.043478260869565, 1.0369565217391, -0.05
93826, 0.95652173913043, 1.0891304347826, -0.05
93827, 0.91304347826087, 1.0891304347826, -0.05
93828, 0.8695652173913, 1.0891304347826, -0.05
93829, 0.82608695652174, 1.0891304347826, -0.05
93830, 0.78260869565217, 1.0891304347826, -0.05
93831, 0.73913043478261, 1.0891304347826, -0.05
93832, 0.69565217391304, 1.0891304347826, -0.05
93833, 0.65217391304348, 1.0891304347826, -0.05
93834, 0.60869565217391, 1.0891304347826, -0.05
93835, 0.56521739130435, 1.0891304347826, -0.05
93836, 0.52173913043478, 1.0891304347826, -0.05
93837, 0.47826086956522, 1.0891304347826, -0.05
93838, 0.43478260869565, 1.0891304347826, -0.05
93839, 0.39130434782609, 1.0891304347826, -0.05
93840, 0.34782608695652, 1.0891304347826, -0.05
93841, 0.30434782608696, 1.0891304347826, -0.05
93842, 0.26086956521739, 1.0891304347826, -0.05
93843, 0.21739130434783, 1.0891304347826, -0.05
93844, 0.17391304347826, 1.0891304347826, -0.05
93845, 0.1304347826087, 1.0891304347826, -0.05
93846, 0.08695652173913, 1.0891304347826, -0.05
93847, 0.043478260869565, 1.0891304347826, -0.05
93848, 0.95652173913043, 1.1413043478261, -0.05
93849, 0.91304347826087, 1.1413043478261, -0.05
93850, 0.8695652173913, 1.1413043478261, -0.05
93851, 0.82608695652174, 1.1413043478261, -0.05
93852, 0.78260869565217, 1.1413043478261, -0.05
93853, 0.73913043478261, 1.1413043478261, -0.05
93854, 0.69565217391304, 1.1413043478261, -0.05
93855, 0.65217391304348, 1.1413043478261, -0.05
93856, 0.60869565217391, 1.1413043478261, -0.05
93857, 0.56521739130435, 1.1413043478261, -0.05
93858, 0.52173913043478, 1.1413043478261, -0.05
93859, 0.47826086956522, 1.1413043478261, -0.05
93860, 0.43478260869565, 1.1413043478261, -0.05
93861, 0.39130434782609, 1.1413043478261, -0.05
93862, 0.34782608695652, 1.1413043478261, -0.05
93863, 0.30434782608696, 1.1413043478261, -0.05
93864, 0.26086956521739, 1.1413043478261, -0.05
93865, 0.21739130434783, 1.1413043478261, -0.05
93866, 0.17391304347826, 1.1413043478261, -0.05
93867, 0.1304347826087, 1.1413043478261, -0.05
93868, 0.08695652173913, 1.1413043478261, -0.05
93869, 0.043478260869565, 1.1413043478261, -0.05
93870, 0.95652173913043, 1.1934782608696, -0.05
93871, 0.91304347826087, 1.1934782608696, -0.05
93872, 0.8695652173913, 1.1934782608696, -0.05
93873, 0.82608695652174, 1.1934782608696, -0.05
93874, 0.78260869565217, 1.1934782608696, -0.05
93875, 0.73913043478261, 1.1934782608696, -0.05
93876, 0.69565217391304, 1.1934782608696, -0.05
93877, 0.65217391304348, 1.1934782608696, -0.05
93878, 0.60869565217391, 1.1934782608696, -0.05
93879, 0.56521739130435, 1.1934782608696, -0.05
93880, 0.52173913043478, 1.1934782608696, -0.05
93881, 0.47826086956522, 1.1934782608696, -0.05
93882, 0.43478260869565, 1.1934782608696, -0.05
93883, 0.39130434782609, 1.1934782608696, -0.05
93884, 0.34782608695652, 1.1934782608696, -0.05
93885, 0.30434782608696, 1.1934782608696, -0.05
93886, 0.26086956521739, 1.1934782608696, -0.05
93887, 0.21739130434783, 1.1934782608696, -0.05
93888, 0.17391304347826, 1.1934782608696, -0.05
93889, 0.1304347826087, 1.1934782608696, -0.05
93890, 0.08695652173913, 1.1934782608696, -0.05
93891, 0.043478260869565, 1.1934782608696, -0.05
93892, 0.95652173913043, 1.245652173913, -0.05
93893, 0.91304347826087, 1.245652173913, -0.05
93894, 0.8695652173913, 1.245652173913, -0.05
93895, 0.82608695652174, 1.245652173913, -0.05
93896, 0.78260869565217, 1.245652173913, -0.05
93897, 0.73913043478261, 1.245652173913, -0.05
93898, 0.69565217391304, 1.245652173913, -0.05
93899, 0.65217391304348, 1.245652173913, -0.05
93900, 0.60869565217391, 1.245652173913, -0.05
93901, 0.56521739130435, 1.245652173913, -0.05
93902, 0.52173913043478, 1.245652173913, -0.05
93903, 0.47826086956522, 1.245652173913, -0.05
93904, 0.43478260869565, 1.245652173913, -0.05
93905, 0.39130434782609, 1.245652173913, -0.05
93906, 0.34782608695652, 1.245652173913, -0.05
93907, 0.30434782608696, 1.245652173913, -0.05
93908, 0.26086956521739, 1.245652173913, -0.05
93909, 0.21739130434783, 1.245652173913, -0.05
93910, 0.17391304347826, 1.245652173913, -0.05
93911, 0.1304347826087, 1.245652173913, -0.05
93912, 0.08695652173913, 1.245652173913, -0.05
93913, 0.043478260869565, 1.245652173913, -0.05
93914, 0.95652173913044, 1.2978260869565, -0.05
93915, 0.91304347826087, 1.2978260869565, -0.05
93916, 0.8695652173913, 1.2978260869565, -0.05
93917, 0.82608695652174, 1.2978260869565, -0.05
93918, 0.78260869565217, 1.2978260869565, -0.05
93919, 0.73913043478261, 1.2978260869565, -0.05
93920, 0.69565217391304, 1.2978260869565, -0.05
93921, 0.65217391304348, 1.2978260869565, -0.05
93922, 0.60869565217391, 1.2978260869565, -0.05
93923, 0.56521739130435, 1.2978260869565, -0.05
93924, 0.52173913043478, 1.2978260869565, -0.05
93925, 0.47826086956522, 1.2978260869565, -0.05
93926, 0.43478260869565, 1.2978260869565, -0.05
93927, 0.39130434782609, 1.2978260869565, -0.05
93928, 0.34782608695652, 1.2978260869565, -0.05
93929, 0.30434782608696, 1.2978260869565, -0.05
93930, 0.26086956521739, 1.2978260869565, -0.05
93931, 0.21739130434783, 1.2978260869565, -0.05
93932, 0.17391304347826, 1.2978260869565, -0.05
93933, 0.1304347826087, 1.2978260869565, -0.05
93934, 0.08695652173913, 1.2978260869565, -0.05
93935, 0.043478260869565, 1.2978260869565, -0.05
93936, 0.95652173913044, 0.20217391304348, -0.1
93937, 0.91304347826087, 0.20217391304348, -0.1
93938, 0.8695652173913, 0.20217391304348, -0.1
93939, 0.82608695652174, 0.20217391304348, -0.1
93940, 0.78260869565217, 0.20217391304348, -0.1
93941, 0.73913043478261, 0.20217391304348, -0.1
93942, 0.69565217391304, 0.20217391304348, -0.1
93943, 0.65217391304348, 0.20217391304348, -0.1
93944, 0.60869565217391, 0.20217391304348, -0.1
93945, 0.56521739130435, 0.20217391304348, -0.1
93946, 0.52173913043478, 0.20217391304348, -0.1
93947, 0.47826086956522, 0.20217391304348, -0.1
93948, 0.43478260869565, 0.20217391304348, -0.1
93949, 0.39130434782609, 0.20217391304348, -0.1
93950, 0.34782608695652, 0.20217391304348, -0.1
93951, 0.30434782608696, 0.20217391304348, -0.1
93952, 0.26086956521739, 0.20217391304348, -0.1
93953, 0.21739130434783, 0.20217391304348, -0.1
93954, 0.17391304347826, 0.20217391304348, -0.1
93955, 0.1304347826087, 0.20217391304348, -0.1
93956, 0.08695652173913, 0.20217391304348, -0.1
93957, 0.043478260869565, 0.20217391304348, -0.1
93958, 0.95652173913044, 0.25434782608696, -0.1
93959, 0.91304347826087, 0.25434782608696, -0.1
93960, 0.8695652173913, 0.25434782608696, -0.1
93961, 0.82608695652174, 0.25434782608696, -0.1
93962, 0.78260869565217, 0.25434782608696, -0.1
93963, 0.73913043478261, 0.25434782608696, -0.1
93964, 0.69565217391304, 0.25434782608696, -0.1
93965, 0.65217391304348, 0.25434782608696, -0.1
93966, 0.60869565217391, 0.25434782608696, -0.1
93967, 0.56521739130435, 0.25434782608696, -0.1
93968, 0.52173913043478, 0.25434782608696, -0.1
93969, 0.47826086956522, 0.25434782608696, -0.1
93970, 0.43478260869565, 0.25434782608696, -0.1
93971, 0.39130434782609, 0.25434782608696, -0.1
93972, 0.34782608695652, 0.25434782608696, -0.1
93973, 0.30434782608696, 0.25434782608696, -0.1
93974, 0.26086956521739, 0.25434782608696, -0.1
93975, 0.21739130434783, 0.25434782608696, -0.1
93976, 0.17391304347826, 0.25434782608696, -0.1
93977, 0.1304347826087, 0.25434782608696, -0.1
93978, 0.08695652173913, 0.25434782608696, -0.1
93979, 0.043478260869565, 0.25434782608696, -0.1
93980, 0.95652173913044, 0.30652173913043, -0.1
93981, 0.91304347826087, 0.30652173913043, -0.1
93982, 0.8695652173913, 0.30652173913043, -0.1
93983, 0.82608695652174, 0.30652173913043, -0.1
93984, 0.78260869565217, 0.30652173913043, -0.1
93985, 0.73913043478261, 0.30652173913043, -0.1
93986, 0.69565217391304, 0.30652173913043, -0.1
93987, 0.65217391304348, 0.30652173913043, -0.1
93988, 0.60869565217391, 0.30652173913043, -0.1
93989, 0.56521739130435, 0.30652173913043, -0.1
93990, 0.52173913043478, 0.30652173913043, -0.1
93991, 0.47826086956522, 0.30652173913043, -0.1
93992, 0.43478260869565, 0.30652173913043, -0.1
93993, 0.39130434782609, 0.30652173913043, -0.1
93994, 0.34782608695652, 0.30652173913043, -0.1
93995, 0.30434782608696, 0.30652173913043, -0.1
93996, 0.26086956521739, 0.30652173913043, -0.1
93997, 0.21739130434783, 0.30652173913043, -0.1
93998, 0.17391304347826, 0.30652173913043, -0.1
93999, 0.1304347826087, 0.30652173913043, -0.1
94000, 0.08695652173913, 0.30652173913043, -0.1
94001, 0.043478260869565, 0.30652173913043, -0.1
94002, 0.95652173913044, 0.35869565217391, -0.1
94003, 0.91304347826087, 0.35869565217391, -0.1
94004, 0.8695652173913, 0.35869565217391, -0.1
94005, 0.82608695652174, 0.35869565217391, -0.1
94006, 0.78260869565217, 0.35869565217391, -0.1
94007, 0.73913043478261, 0.35869565217391, -0.1
94008, 0.69565217391304, 0.35869565217391, -0.1
94009, 0.65217391304348, 0.35869565217391, -0.1
94010, 0.60869565217391, 0.35869565217391, -0.1
94011, 0.56521739130435, 0.35869565217391, -0.1
94012, 0.52173913043478, 0.35869565217391, -0.1
94013, 0.47826086956522, 0.35869565217391, -0.1
94014, 0.43478260869565, 0.35869565217391, -0.1
94015, 0.39130434782609, 0.35869565217391, -0.1
94016, 0.34782608695652, 0.35869565217391, -0.1
94017, 0.30434782608696, 0.35869565217391, -0.1
94018, 0.26086956521739, 0.35869565217391, -0.1
94019, 0.21739130434783, 0.35869565217391, -0.1
94020, 0.17391304347826, 0.35869565217391, -0.1
94021, 0.1304347826087, 0.35869565217391, -0.1
94022, 0.08695652173913, 0.35869565217391, -0.1
94023, 0.043478260869565, 0.35869565217391, -0.1
94024, 0.95652173913044, 0.41086956521739, -0.1
94025, 0.91304347826087, 0.41086956521739, -0.1
94026, 0.8695652173913, 0.41086956521739, -0.1
94027, 0.82608695652174, 0.41086956521739, -0.1
94028, 0.78260869565217, 0.41086956521739, -0.1
94029, 0.73913043478261, 0.41086956521739, -0.1
94030, 0.69565217391304, 0.41086956521739, -0.1
94031, 0.65217391304348, 0.41086956521739, -0.1
94032, 0.60869565217391, 0.41086956521739, -0.1
94033, 0.56521739130435, 0.41086956521739, -0.1
94034, 0.52173913043478, 0.41086956521739, -0.1
94035, 0.47826086956522, 0.41086956521739, -0.1
94036, 0.43478260869565, 0.41086956521739, -0.1
94037, 0.39130434782609, 0.41086956521739, -0.1
94038, 0.34782608695652, 0.41086956521739, -0.1
94039, 0.30434782608696, 0.41086956521739, -0.1
94040, 0.26086956521739, 0.41086956521739, -0.1
94041, 0.21739130434783, 0.41086956521739, -0.1
94042, 0.17391304347826, 0.41086956521739, -0.1
94043, 0.1304347826087, 0.41086956521739, -0.1
94044, 0.08695652173913, 0.41086956521739, -0.1
94045, 0.043478260869565, 0.41086956521739, -0.1
94046, 0.95652173913044, 0.46304347826087, -0.1
94047, 0.91304347826087, 0.46304347826087, -0.1
94048, 0.8695652173913, 0.46304347826087, -0.1
94049, 0.82608695652174, 0.46304347826087, -0.1
94050, 0.78260869565217, 0.46304347826087, -0.1
94051, 0.73913043478261, 0.46304347826087, -0.1
94052, 0.69565217391304, 0.46304347826087, -0.1
94053, 0.65217391304348, 0.46304347826087, -0.1
94054, 0.60869565217391, 0.46304347826087, -0.1
94055, 0.56521739130435, 0.46304347826087, -0.1
94056, 0.52173913043478, 0.46304347826087, -0.1
94057, 0.47826086956522, 0.46304347826087, -0.1
94058, 0.43478260869565, 0.46304347826087, -0.1
94059, 0.39130434782609, 0.46304347826087, -0.1
94060, 0.34782608695652, 0.46304347826087, -0.1
94061, 0.30434782608696, 0.46304347826087, -0.1
94062, 0.26086956521739, 0.46304347826087, -0.1
94063, 0.21739130434783, 0.46304347826087, -0.1
94064, 0.17391304347826, 0.46304347826087, -0.1
94065, 0.1304347826087, 0.46304347826087, -0.1
94066, 0.08695652173913, 0.46304347826087, -0.1
94067, 0.043478260869565, 0.46304347826087, -0.1
94068, 0.95652173913044, 0.51521739130435, -0.1
94069, 0.91304347826087, 0.51521739130435, -0.1
94070, 0.8695652173913, 0.51521739130435, -0.1
94071, 0.82608695652174, 0.51521739130435, -0.1
94072, 0.78260869565217, 0.51521739130435, -0.1
94073, 0.73913043478261, 0.51521739130435, -0.1
94074, 0.69565217391304, 0.51521739130435, -0.1
94075, 0.65217391304348, 0.51521739130435, -0.1
94076, 0.60869565217391, 0.51521739130435, -0.1
94077, 0.56521739130435, 0.51521739130435, -0.1
94078, 0.52173913043478, 0.51521739130435, -0.1
94079, 0.47826086956522, 0.51521739130435, -0.1
94080, 0.43478260869565, 0.51521739130435, -0.1
94081, 0.39130434782609, 0.51521739130435, -0.1
94082, 0.34782608695652, 0.51521739130435, -0.1
94083, 0.30434782608696, 0.51521739130435, -0.1
94084, 0.26086956521739, 0.51521739130435, -0.1
94085, 0.21739130434783, 0.51521739130435, -0.1
94086, 0.17391304347826, 0.51521739130435, -0.1
94087, 0.1304347826087, 0.51521739130435, -0.1
94088, 0.08695652173913, 0.51521739130435, -0.1
94089, 0.043478260869565, 0.51521739130435, -0.1
94090, 0.95652173913044, 0.56739130434783, -0.1
94091, 0.91304347826087, 0.56739130434783, -0.1
94092, 0.8695652173913, 0.56739130434783, -0.1
94093, 0.82608695652174, 0.56739130434783, -0.1
94094, 0.78260869565217, 0.56739130434783, -0.1
94095, 0.73913043478261, 0.56739130434783, -0.1
94096, 0.69565217391304, 0.56739130434783, -0.1
94097, 0.65217391304348, 0.56739130434783, -0.1
94098, 0.60869565217391, 0.56739130434783, -0.1
94099, 0.56521739130435, 0.56739130434783, -0.1
94100, 0.52173913043478, 0.56739130434783, -0.1
94101, 0.47826086956522, 0.56739130434783, -0.1
94102, 0.43478260869565, 0.56739130434783, -0.1
94103, 0.39130434782609, 0.56739130434783, -0.1
94104, 0.34782608695652, 0.56739130434783, -0.1
94105, 0.30434782608696, 0.56739130434783, -0.1
94106, 0.26086956521739, 0.56739130434783, -0.1
94107, 0.21739130434783, 0.56739130434783, -0.1
94108, 0.17391304347826, 0.56739130434783, -0.1
94109, 0.1304347826087, 0.56739130434783, -0.1
94110, 0.08695652173913, 0.56739130434783, -0.1
94111, 0.043478260869565, 0.56739130434783, -0.1
94112, 0.95652173913044, 0.6195652173913, -0.1
94113, 0.91304347826087, 0.6195652173913, -0.1
94114, 0.8695652173913, 0.6195652173913, -0.1
94115, 0.82608695652174, 0.6195652173913, -0.1
94116, 0.78260869565217, 0.6195652173913, -0.1
94117, 0.73913043478261, 0.6195652173913, -0.1
94118, 0.69565217391304, 0.6195652173913, -0.1
94119, 0.65217391304348, 0.6195652173913, -0.1
94120, 0.60869565217391, 0.6195652173913, -0.1
94121, 0.56521739130435, 0.6195652173913, -0.1
94122, 0.52173913043478, 0.6195652173913, -0.1
94123, 0.47826086956522, 0.6195652173913, -0.1
94124, 0.43478260869565, 0.6195652173913, -0.1
94125, 0.39130434782609, 0.6195652173913, -0.1
94126, 0.34782608695652, 0.6195652173913, -0.1
94127, 0.30434782608696, 0.6195652173913, -0.1
94128, 0.26086956521739, 0.6195652173913, -0.1
94129, 0.21739130434783, 0.6195652173913, -0.1
94130, 0.17391304347826, 0.6195652173913, -0.1
94131, 0.1304347826087, 0.6195652173913, -0.1
94132, 0.08695652173913, 0.6195652173913, -0.1
94133, 0.043478260869565, 0.6195652173913, -0.1
94134, 0.95652173913044, 0.67173913043478, -0.1
94135, 0.91304347826087, 0.67173913043478, -0.1
94136, 0.8695652173913, 0.67173913043478, -0.1
94137, 0.82608695652174, 0.67173913043478, -0.1
94138, 0.78260869565217, 0.67173913043478, -0.1
94139, 0.73913043478261, 0.67173913043478, -0.1
94140, 0.69565217391304, 0.67173913043478, -0.1
94141, 0.65217391304348, 0.67173913043478, -0.1
94142, 0.60869565217391, 0.67173913043478, -0.1
94143, 0.56521739130435, 0.67173913043478, -0.1
94144, 0.52173913043478, 0.67173913043478, -0.1
94145, 0.47826086956522, 0.67173913043478, -0.1
94146, 0.43478260869565, 0.67173913043478, -0.1
94147, 0.39130434782609, 0.67173913043478, -0.1
94148, 0.34782608695652, 0.67173913043478, -0.1
94149, 0.30434782608696, 0.67173913043478, -0.1
94150, 0.26086956521739, 0.67173913043478, -0.1
94151, 0.21739130434783, 0.67173913043478, -0.1
94152, 0.17391304347826, 0.67173913043478, -0.1
94153, 0.1304347826087, 0.67173913043478, -0.1
94154, 0.08695652173913, 0.67173913043478, -0.1
94155, 0.043478260869565, 0.67173913043478, -0.1
94156, 0.95652173913044, 0.72391304347826, -0.1
94157, 0.91304347826087, 0.72391304347826, -0.1
94158, 0.8695652173913, 0.72391304347826, -0.1
94159, 0.82608695652174, 0.72391304347826, -0.1
94160, 0.78260869565217, 0.72391304347826, -0.1
94161, 0.73913043478261, 0.72391304347826, -0.1
94162, 0.69565217391304, 0.72391304347826, -0.1
94163, 0.65217391304348, 0.72391304347826, -0.1
94164, 0.60869565217391, 0.72391304347826, -0.1
94165, 0.56521739130435, 0.72391304347826, -0.1
94166, 0.52173913043478, 0.72391304347826, -0.1
94167, 0.47826086956522, 0.72391304347826, -0.1
94168, 0.43478260869565, 0.72391304347826, -0.1
94169, 0.39130434782609, 0.72391304347826, -0.1
94170, 0.34782608695652, 0.72391304347826, -0.1
94171, 0.30434782608696, 0.72391304347826, -0.1
94172, 0.26086956521739, 0.72391304347826, -0.1
94173, 0.21739130434783, 0.72391304347826, -0.1
94174, 0.17391304347826, 0.72391304347826, -0.1
94175, 0.1304347826087, 0.72391304347826, -0.1
94176, 0.08695652173913, 0.72391304347826, -0.1
94177, 0.043478260869565, 0.72391304347826, -0.1
94178, 0.95652173913044, 0.77608695652174, -0.1
94179, 0.91304347826087, 0.77608695652174, -0.1
94180, 0.8695652173913, 0.77608695652174, -0.1
94181, 0.82608695652174, 0.77608695652174, -0.1
94182, 0.78260869565217, 0.77608695652174, -0.1
94183, 0.73913043478261, 0.77608695652174, -0.1
94184, 0.69565217391304, 0.77608695652174, -0.1
94185, 0.65217391304348, 0.77608695652174, -0.1
94186, 0.60869565217391, 0.77608695652174, -0.1
94187, 0.56521739130435, 0.77608695652174, -0.1
94188, 0.52173913043478, 0.77608695652174, -0.1
94189, 0.47826086956522, 0.77608695652174, -0.1
94190, 0.43478260869565, 0.77608695652174, -0.1
94191, 0.39130434782609, 0.77608695652174, -0.1
94192, 0.34782608695652, 0.77608695652174, -0.1
94193, 0.30434782608696, 0.77608695652174, -0.1
94194, 0.26086956521739, 0.77608695652174, -0.1
94195, 0.21739130434783, 0.77608695652174, -0.1
94196, 0.17391304347826, 0.77608695652174, -0.1
94197, 0.1304347826087, 0.77608695652174, -0.1
94198, 0.08695652173913, 0.77608695652174, -0.1
94199, 0.043478260869565, 0.77608695652174, -0.1
94200, 0.95652173913044, 0.82826086956522, -0.1
