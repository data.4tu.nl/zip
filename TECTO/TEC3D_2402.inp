44416, 0.08695652173913, 0.35869565217391, 0.25
44417, 0.10869565217391, 0.35869565217391, 0.27777777777778
44418, 0.08695652173913, 0.33260869565217, 0.27777777777778
44419, 0.08695652173913, 0.35869565217391, 0.30555555555556
44420, 0.10869565217391, 0.35869565217391, 0.33333333333333
44421, 0.08695652173913, 0.33260869565217, 0.33333333333333
44422, 0.08695652173913, 0.35869565217391, 0.36111111111111
44423, 0.10869565217391, 0.35869565217391, 0.38888888888889
44424, 0.08695652173913, 0.33260869565217, 0.38888888888889
44425, 0.08695652173913, 0.35869565217391, 0.41666666666667
44426, 0.10869565217391, 0.35869565217391, 0.44444444444444
44427, 0.08695652173913, 0.33260869565217, 0.44444444444444
44428, 0.08695652173913, 0.35869565217391, 0.47222222222222
44429, 0.043478260869565, 0.35869565217391, 0.027777777777778
44430, 0.065217391304348, 0.35869565217391, 0.055555555555556
44431, 0.043478260869565, 0.33260869565217, 0.055555555555556
44432, 0.043478260869565, 0.35869565217391, 0.083333333333333
44433, 0.065217391304348, 0.35869565217391, 0.11111111111111
44434, 0.043478260869565, 0.33260869565217, 0.11111111111111
44435, 0.043478260869565, 0.35869565217391, 0.13888888888889
44436, 0.065217391304348, 0.35869565217391, 0.16666666666667
44437, 0.043478260869565, 0.33260869565217, 0.16666666666667
44438, 0.043478260869565, 0.35869565217391, 0.19444444444444
44439, 0.065217391304348, 0.35869565217391, 0.22222222222222
44440, 0.043478260869565, 0.33260869565217, 0.22222222222222
44441, 0.043478260869565, 0.35869565217391, 0.25
44442, 0.065217391304348, 0.35869565217391, 0.27777777777778
44443, 0.043478260869565, 0.33260869565217, 0.27777777777778
44444, 0.043478260869565, 0.35869565217391, 0.30555555555556
44445, 0.065217391304348, 0.35869565217391, 0.33333333333333
44446, 0.043478260869565, 0.33260869565217, 0.33333333333333
44447, 0.043478260869565, 0.35869565217391, 0.36111111111111
44448, 0.065217391304348, 0.35869565217391, 0.38888888888889
44449, 0.043478260869565, 0.33260869565217, 0.38888888888889
44450, 0.043478260869565, 0.35869565217391, 0.41666666666667
44451, 0.065217391304348, 0.35869565217391, 0.44444444444444
44452, 0.043478260869565, 0.33260869565217, 0.44444444444444
44453, 0.043478260869565, 0.35869565217391, 0.47222222222222
44454, 0.021739130434783, 0.35869565217391, 0.055555555555556
44455, 0.021739130434783, 0.35869565217391, 0.11111111111111
44456, 0.021739130434783, 0.35869565217391, 0.16666666666667
44457, 0.021739130434783, 0.35869565217391, 0.22222222222222
44458, 0.021739130434783, 0.35869565217391, 0.27777777777778
44459, 0.021739130434783, 0.35869565217391, 0.33333333333333
44460, 0.021739130434783, 0.35869565217391, 0.38888888888889
44461, 0.021739130434783, 0.35869565217391, 0.44444444444444
44462, 0.95652173913043, 0.41086956521739, 0.027777777777778
44463, 0.97826086956522, 0.41086956521739, 0.055555555555556
44464, 0.95652173913043, 0.38478260869565, 0.055555555555556
44465, 0.95652173913043, 0.41086956521739, 0.083333333333333
44466, 0.97826086956522, 0.41086956521739, 0.11111111111111
44467, 0.95652173913044, 0.38478260869565, 0.11111111111111
44468, 0.95652173913044, 0.41086956521739, 0.13888888888889
44469, 0.97826086956522, 0.41086956521739, 0.16666666666667
44470, 0.95652173913044, 0.38478260869565, 0.16666666666667
44471, 0.95652173913044, 0.41086956521739, 0.19444444444444
44472, 0.97826086956522, 0.41086956521739, 0.22222222222222
44473, 0.95652173913044, 0.38478260869565, 0.22222222222222
44474, 0.95652173913044, 0.41086956521739, 0.25
44475, 0.97826086956522, 0.41086956521739, 0.27777777777778
44476, 0.95652173913044, 0.38478260869565, 0.27777777777778
44477, 0.95652173913044, 0.41086956521739, 0.30555555555556
44478, 0.97826086956522, 0.41086956521739, 0.33333333333333
44479, 0.95652173913044, 0.38478260869565, 0.33333333333333
44480, 0.95652173913044, 0.41086956521739, 0.36111111111111
44481, 0.97826086956522, 0.41086956521739, 0.38888888888889
44482, 0.95652173913043, 0.38478260869565, 0.38888888888889
44483, 0.95652173913044, 0.41086956521739, 0.41666666666667
44484, 0.97826086956522, 0.41086956521739, 0.44444444444444
44485, 0.95652173913044, 0.38478260869565, 0.44444444444444
44486, 0.95652173913043, 0.41086956521739, 0.47222222222222
44487, 0.91304347826087, 0.41086956521739, 0.027777777777778
44488, 0.93478260869565, 0.41086956521739, 0.055555555555556
44489, 0.91304347826087, 0.38478260869565, 0.055555555555556
44490, 0.91304347826087, 0.41086956521739, 0.083333333333333
44491, 0.93478260869565, 0.41086956521739, 0.11111111111111
44492, 0.91304347826087, 0.38478260869565, 0.11111111111111
44493, 0.91304347826087, 0.41086956521739, 0.13888888888889
44494, 0.93478260869565, 0.41086956521739, 0.16666666666667
44495, 0.91304347826087, 0.38478260869565, 0.16666666666667
44496, 0.91304347826087, 0.41086956521739, 0.19444444444444
44497, 0.93478260869565, 0.41086956521739, 0.22222222222222
44498, 0.91304347826087, 0.38478260869565, 0.22222222222222
44499, 0.91304347826087, 0.41086956521739, 0.25
44500, 0.93478260869565, 0.41086956521739, 0.27777777777778
44501, 0.91304347826087, 0.38478260869565, 0.27777777777778
44502, 0.91304347826087, 0.41086956521739, 0.30555555555556
44503, 0.93478260869565, 0.41086956521739, 0.33333333333333
44504, 0.91304347826087, 0.38478260869565, 0.33333333333333
44505, 0.91304347826087, 0.41086956521739, 0.36111111111111
44506, 0.93478260869565, 0.41086956521739, 0.38888888888889
44507, 0.91304347826087, 0.38478260869565, 0.38888888888889
44508, 0.91304347826087, 0.41086956521739, 0.41666666666667
44509, 0.93478260869565, 0.41086956521739, 0.44444444444444
44510, 0.91304347826087, 0.38478260869565, 0.44444444444444
44511, 0.91304347826087, 0.41086956521739, 0.47222222222222
44512, 0.8695652173913, 0.41086956521739, 0.027777777777778
44513, 0.89130434782609, 0.41086956521739, 0.055555555555556
44514, 0.8695652173913, 0.38478260869565, 0.055555555555556
44515, 0.8695652173913, 0.41086956521739, 0.083333333333333
44516, 0.89130434782609, 0.41086956521739, 0.11111111111111
44517, 0.8695652173913, 0.38478260869565, 0.11111111111111
44518, 0.8695652173913, 0.41086956521739, 0.13888888888889
44519, 0.89130434782609, 0.41086956521739, 0.16666666666667
44520, 0.8695652173913, 0.38478260869565, 0.16666666666667
44521, 0.8695652173913, 0.41086956521739, 0.19444444444444
44522, 0.89130434782609, 0.41086956521739, 0.22222222222222
44523, 0.8695652173913, 0.38478260869565, 0.22222222222222
44524, 0.8695652173913, 0.41086956521739, 0.25
44525, 0.89130434782609, 0.41086956521739, 0.27777777777778
44526, 0.8695652173913, 0.38478260869565, 0.27777777777778
44527, 0.8695652173913, 0.41086956521739, 0.30555555555556
44528, 0.89130434782609, 0.41086956521739, 0.33333333333333
44529, 0.8695652173913, 0.38478260869565, 0.33333333333333
44530, 0.8695652173913, 0.41086956521739, 0.36111111111111
44531, 0.89130434782609, 0.41086956521739, 0.38888888888889
44532, 0.8695652173913, 0.38478260869565, 0.38888888888889
44533, 0.8695652173913, 0.41086956521739, 0.41666666666667
44534, 0.89130434782609, 0.41086956521739, 0.44444444444444
44535, 0.8695652173913, 0.38478260869565, 0.44444444444444
44536, 0.8695652173913, 0.41086956521739, 0.47222222222222
44537, 0.82608695652174, 0.41086956521739, 0.027777777777778
44538, 0.84782608695652, 0.41086956521739, 0.055555555555556
44539, 0.82608695652174, 0.38478260869565, 0.055555555555556
44540, 0.82608695652174, 0.41086956521739, 0.083333333333333
44541, 0.84782608695652, 0.41086956521739, 0.11111111111111
44542, 0.82608695652174, 0.38478260869565, 0.11111111111111
44543, 0.82608695652174, 0.41086956521739, 0.13888888888889
44544, 0.84782608695652, 0.41086956521739, 0.16666666666667
44545, 0.82608695652174, 0.38478260869565, 0.16666666666667
44546, 0.82608695652174, 0.41086956521739, 0.19444444444444
44547, 0.84782608695652, 0.41086956521739, 0.22222222222222
44548, 0.82608695652174, 0.38478260869565, 0.22222222222222
44549, 0.82608695652174, 0.41086956521739, 0.25
44550, 0.84782608695652, 0.41086956521739, 0.27777777777778
44551, 0.82608695652174, 0.38478260869565, 0.27777777777778
44552, 0.82608695652174, 0.41086956521739, 0.30555555555556
44553, 0.84782608695652, 0.41086956521739, 0.33333333333333
44554, 0.82608695652174, 0.38478260869565, 0.33333333333333
44555, 0.82608695652174, 0.41086956521739, 0.36111111111111
44556, 0.84782608695652, 0.41086956521739, 0.38888888888889
44557, 0.82608695652174, 0.38478260869565, 0.38888888888889
44558, 0.82608695652174, 0.41086956521739, 0.41666666666667
44559, 0.84782608695652, 0.41086956521739, 0.44444444444444
44560, 0.82608695652174, 0.38478260869565, 0.44444444444444
44561, 0.82608695652174, 0.41086956521739, 0.47222222222222
44562, 0.78260869565217, 0.41086956521739, 0.027777777777778
44563, 0.80434782608696, 0.41086956521739, 0.055555555555556
44564, 0.78260869565217, 0.38478260869565, 0.055555555555556
44565, 0.78260869565217, 0.41086956521739, 0.083333333333333
44566, 0.80434782608696, 0.41086956521739, 0.11111111111111
44567, 0.78260869565217, 0.38478260869565, 0.11111111111111
44568, 0.78260869565217, 0.41086956521739, 0.13888888888889
44569, 0.80434782608696, 0.41086956521739, 0.16666666666667
44570, 0.78260869565217, 0.38478260869565, 0.16666666666667
44571, 0.78260869565217, 0.41086956521739, 0.19444444444444
44572, 0.80434782608696, 0.41086956521739, 0.22222222222222
44573, 0.78260869565217, 0.38478260869565, 0.22222222222222
44574, 0.78260869565217, 0.41086956521739, 0.25
44575, 0.80434782608696, 0.41086956521739, 0.27777777777778
44576, 0.78260869565217, 0.38478260869565, 0.27777777777778
44577, 0.78260869565217, 0.41086956521739, 0.30555555555556
44578, 0.80434782608696, 0.41086956521739, 0.33333333333333
44579, 0.78260869565217, 0.38478260869565, 0.33333333333333
44580, 0.78260869565217, 0.41086956521739, 0.36111111111111
44581, 0.80434782608696, 0.41086956521739, 0.38888888888889
44582, 0.78260869565217, 0.38478260869565, 0.38888888888889
44583, 0.78260869565217, 0.41086956521739, 0.41666666666667
44584, 0.80434782608696, 0.41086956521739, 0.44444444444444
44585, 0.78260869565217, 0.38478260869565, 0.44444444444444
44586, 0.78260869565217, 0.41086956521739, 0.47222222222222
44587, 0.73913043478261, 0.41086956521739, 0.027777777777778
44588, 0.76086956521739, 0.41086956521739, 0.055555555555556
44589, 0.73913043478261, 0.38478260869565, 0.055555555555556
44590, 0.73913043478261, 0.41086956521739, 0.083333333333333
44591, 0.76086956521739, 0.41086956521739, 0.11111111111111
44592, 0.73913043478261, 0.38478260869565, 0.11111111111111
44593, 0.73913043478261, 0.41086956521739, 0.13888888888889
44594, 0.76086956521739, 0.41086956521739, 0.16666666666667
44595, 0.73913043478261, 0.38478260869565, 0.16666666666667
44596, 0.73913043478261, 0.41086956521739, 0.19444444444444
44597, 0.76086956521739, 0.41086956521739, 0.22222222222222
44598, 0.73913043478261, 0.38478260869565, 0.22222222222222
44599, 0.73913043478261, 0.41086956521739, 0.25
44600, 0.76086956521739, 0.41086956521739, 0.27777777777778
44601, 0.73913043478261, 0.38478260869565, 0.27777777777778
44602, 0.73913043478261, 0.41086956521739, 0.30555555555556
44603, 0.76086956521739, 0.41086956521739, 0.33333333333333
44604, 0.73913043478261, 0.38478260869565, 0.33333333333333
44605, 0.73913043478261, 0.41086956521739, 0.36111111111111
44606, 0.76086956521739, 0.41086956521739, 0.38888888888889
44607, 0.73913043478261, 0.38478260869565, 0.38888888888889
44608, 0.73913043478261, 0.41086956521739, 0.41666666666667
44609, 0.76086956521739, 0.41086956521739, 0.44444444444444
44610, 0.73913043478261, 0.38478260869565, 0.44444444444444
44611, 0.73913043478261, 0.41086956521739, 0.47222222222222
44612, 0.69565217391304, 0.41086956521739, 0.027777777777778
44613, 0.71739130434783, 0.41086956521739, 0.055555555555556
44614, 0.69565217391304, 0.38478260869565, 0.055555555555556
44615, 0.69565217391304, 0.41086956521739, 0.083333333333333
44616, 0.71739130434783, 0.41086956521739, 0.11111111111111
44617, 0.69565217391304, 0.38478260869565, 0.11111111111111
44618, 0.69565217391304, 0.41086956521739, 0.13888888888889
44619, 0.71739130434783, 0.41086956521739, 0.16666666666667
44620, 0.69565217391304, 0.38478260869565, 0.16666666666667
44621, 0.69565217391304, 0.41086956521739, 0.19444444444444
44622, 0.71739130434783, 0.41086956521739, 0.22222222222222
44623, 0.69565217391304, 0.38478260869565, 0.22222222222222
44624, 0.69565217391304, 0.41086956521739, 0.25
44625, 0.71739130434783, 0.41086956521739, 0.27777777777778
44626, 0.69565217391304, 0.38478260869565, 0.27777777777778
44627, 0.69565217391304, 0.41086956521739, 0.30555555555556
44628, 0.71739130434783, 0.41086956521739, 0.33333333333333
44629, 0.69565217391304, 0.38478260869565, 0.33333333333333
44630, 0.69565217391304, 0.41086956521739, 0.36111111111111
44631, 0.71739130434783, 0.41086956521739, 0.38888888888889
44632, 0.69565217391304, 0.38478260869565, 0.38888888888889
44633, 0.69565217391304, 0.41086956521739, 0.41666666666667
44634, 0.71739130434783, 0.41086956521739, 0.44444444444444
44635, 0.69565217391304, 0.38478260869565, 0.44444444444444
44636, 0.69565217391304, 0.41086956521739, 0.47222222222222
44637, 0.65217391304348, 0.41086956521739, 0.027777777777778
44638, 0.67391304347826, 0.41086956521739, 0.055555555555556
44639, 0.65217391304348, 0.38478260869565, 0.055555555555556
44640, 0.65217391304348, 0.41086956521739, 0.083333333333333
44641, 0.67391304347826, 0.41086956521739, 0.11111111111111
44642, 0.65217391304348, 0.38478260869565, 0.11111111111111
44643, 0.65217391304348, 0.41086956521739, 0.13888888888889
44644, 0.67391304347826, 0.41086956521739, 0.16666666666667
44645, 0.65217391304348, 0.38478260869565, 0.16666666666667
44646, 0.65217391304348, 0.41086956521739, 0.19444444444444
44647, 0.67391304347826, 0.41086956521739, 0.22222222222222
44648, 0.65217391304348, 0.38478260869565, 0.22222222222222
44649, 0.65217391304348, 0.41086956521739, 0.25
44650, 0.67391304347826, 0.41086956521739, 0.27777777777778
44651, 0.65217391304348, 0.38478260869565, 0.27777777777778
44652, 0.65217391304348, 0.41086956521739, 0.30555555555556
44653, 0.67391304347826, 0.41086956521739, 0.33333333333333
44654, 0.65217391304348, 0.38478260869565, 0.33333333333333
44655, 0.65217391304348, 0.41086956521739, 0.36111111111111
44656, 0.67391304347826, 0.41086956521739, 0.38888888888889
44657, 0.65217391304348, 0.38478260869565, 0.38888888888889
44658, 0.65217391304348, 0.41086956521739, 0.41666666666667
44659, 0.67391304347826, 0.41086956521739, 0.44444444444444
44660, 0.65217391304348, 0.38478260869565, 0.44444444444444
44661, 0.65217391304348, 0.41086956521739, 0.47222222222222
44662, 0.60869565217391, 0.41086956521739, 0.027777777777778
44663, 0.6304347826087, 0.41086956521739, 0.055555555555556
44664, 0.60869565217391, 0.38478260869565, 0.055555555555556
44665, 0.60869565217391, 0.41086956521739, 0.083333333333333
44666, 0.6304347826087, 0.41086956521739, 0.11111111111111
44667, 0.60869565217391, 0.38478260869565, 0.11111111111111
44668, 0.60869565217391, 0.41086956521739, 0.13888888888889
44669, 0.6304347826087, 0.41086956521739, 0.16666666666667
44670, 0.60869565217391, 0.38478260869565, 0.16666666666667
44671, 0.60869565217391, 0.41086956521739, 0.19444444444444
44672, 0.6304347826087, 0.41086956521739, 0.22222222222222
44673, 0.60869565217391, 0.38478260869565, 0.22222222222222
44674, 0.60869565217391, 0.41086956521739, 0.25
44675, 0.6304347826087, 0.41086956521739, 0.27777777777778
44676, 0.60869565217391, 0.38478260869565, 0.27777777777778
44677, 0.60869565217391, 0.41086956521739, 0.30555555555556
44678, 0.6304347826087, 0.41086956521739, 0.33333333333333
44679, 0.60869565217391, 0.38478260869565, 0.33333333333333
44680, 0.60869565217391, 0.41086956521739, 0.36111111111111
44681, 0.6304347826087, 0.41086956521739, 0.38888888888889
44682, 0.60869565217391, 0.38478260869565, 0.38888888888889
44683, 0.60869565217391, 0.41086956521739, 0.41666666666667
44684, 0.6304347826087, 0.41086956521739, 0.44444444444444
44685, 0.60869565217391, 0.38478260869565, 0.44444444444444
44686, 0.60869565217391, 0.41086956521739, 0.47222222222222
44687, 0.56521739130435, 0.41086956521739, 0.027777777777778
44688, 0.58695652173913, 0.41086956521739, 0.055555555555556
44689, 0.56521739130435, 0.38478260869565, 0.055555555555556
44690, 0.56521739130435, 0.41086956521739, 0.083333333333333
44691, 0.58695652173913, 0.41086956521739, 0.11111111111111
44692, 0.56521739130435, 0.38478260869565, 0.11111111111111
44693, 0.56521739130435, 0.41086956521739, 0.13888888888889
44694, 0.58695652173913, 0.41086956521739, 0.16666666666667
44695, 0.56521739130435, 0.38478260869565, 0.16666666666667
44696, 0.56521739130435, 0.41086956521739, 0.19444444444444
44697, 0.58695652173913, 0.41086956521739, 0.22222222222222
44698, 0.56521739130435, 0.38478260869565, 0.22222222222222
44699, 0.56521739130435, 0.41086956521739, 0.25
44700, 0.58695652173913, 0.41086956521739, 0.27777777777778
44701, 0.56521739130435, 0.38478260869565, 0.27777777777778
44702, 0.56521739130435, 0.41086956521739, 0.30555555555556
44703, 0.58695652173913, 0.41086956521739, 0.33333333333333
44704, 0.56521739130435, 0.38478260869565, 0.33333333333333
44705, 0.56521739130435, 0.41086956521739, 0.36111111111111
44706, 0.58695652173913, 0.41086956521739, 0.38888888888889
44707, 0.56521739130435, 0.38478260869565, 0.38888888888889
44708, 0.56521739130435, 0.41086956521739, 0.41666666666667
44709, 0.58695652173913, 0.41086956521739, 0.44444444444444
44710, 0.56521739130435, 0.38478260869565, 0.44444444444444
44711, 0.56521739130435, 0.41086956521739, 0.47222222222222
44712, 0.52173913043478, 0.41086956521739, 0.027777777777778
44713, 0.54347826086957, 0.41086956521739, 0.055555555555556
44714, 0.52173913043478, 0.38478260869565, 0.055555555555556
44715, 0.52173913043478, 0.41086956521739, 0.083333333333333
44716, 0.54347826086957, 0.41086956521739, 0.11111111111111
44717, 0.52173913043478, 0.38478260869565, 0.11111111111111
44718, 0.52173913043478, 0.41086956521739, 0.13888888888889
44719, 0.54347826086957, 0.41086956521739, 0.16666666666667
44720, 0.52173913043478, 0.38478260869565, 0.16666666666667
44721, 0.52173913043478, 0.41086956521739, 0.19444444444444
44722, 0.54347826086956, 0.41086956521739, 0.22222222222222
44723, 0.52173913043478, 0.38478260869565, 0.22222222222222
44724, 0.52173913043478, 0.41086956521739, 0.25
44725, 0.54347826086956, 0.41086956521739, 0.27777777777778
44726, 0.52173913043478, 0.38478260869565, 0.27777777777778
44727, 0.52173913043478, 0.41086956521739, 0.30555555555556
44728, 0.54347826086956, 0.41086956521739, 0.33333333333333
44729, 0.52173913043478, 0.38478260869565, 0.33333333333333
44730, 0.52173913043478, 0.41086956521739, 0.36111111111111
44731, 0.54347826086956, 0.41086956521739, 0.38888888888889
44732, 0.52173913043478, 0.38478260869565, 0.38888888888889
44733, 0.52173913043478, 0.41086956521739, 0.41666666666667
44734, 0.54347826086956, 0.41086956521739, 0.44444444444444
44735, 0.52173913043478, 0.38478260869565, 0.44444444444444
44736, 0.52173913043478, 0.41086956521739, 0.47222222222222
44737, 0.47826086956522, 0.41086956521739, 0.027777777777778
44738, 0.5, 0.41086956521739, 0.055555555555556
44739, 0.47826086956522, 0.38478260869565, 0.055555555555556
44740, 0.47826086956522, 0.41086956521739, 0.083333333333333
44741, 0.5, 0.41086956521739, 0.11111111111111
44742, 0.47826086956522, 0.38478260869565, 0.11111111111111
44743, 0.47826086956522, 0.41086956521739, 0.13888888888889
44744, 0.5, 0.41086956521739, 0.16666666666667
44745, 0.47826086956522, 0.38478260869565, 0.16666666666667
44746, 0.47826086956522, 0.41086956521739, 0.19444444444444
44747, 0.5, 0.41086956521739, 0.22222222222222
44748, 0.47826086956522, 0.38478260869565, 0.22222222222222
44749, 0.47826086956522, 0.41086956521739, 0.25
44750, 0.5, 0.41086956521739, 0.27777777777778
44751, 0.47826086956522, 0.38478260869565, 0.27777777777778
44752, 0.47826086956522, 0.41086956521739, 0.30555555555556
44753, 0.5, 0.41086956521739, 0.33333333333333
44754, 0.47826086956522, 0.38478260869565, 0.33333333333333
44755, 0.47826086956522, 0.41086956521739, 0.36111111111111
44756, 0.5, 0.41086956521739, 0.38888888888889
44757, 0.47826086956522, 0.38478260869565, 0.38888888888889
44758, 0.47826086956522, 0.41086956521739, 0.41666666666667
44759, 0.5, 0.41086956521739, 0.44444444444444
44760, 0.47826086956522, 0.38478260869565, 0.44444444444444
44761, 0.47826086956522, 0.41086956521739, 0.47222222222222
44762, 0.43478260869565, 0.41086956521739, 0.027777777777778
44763, 0.45652173913043, 0.41086956521739, 0.055555555555556
44764, 0.43478260869565, 0.38478260869565, 0.055555555555556
44765, 0.43478260869565, 0.41086956521739, 0.083333333333333
44766, 0.45652173913043, 0.41086956521739, 0.11111111111111
44767, 0.43478260869565, 0.38478260869565, 0.11111111111111
44768, 0.43478260869565, 0.41086956521739, 0.13888888888889
44769, 0.45652173913043, 0.41086956521739, 0.16666666666667
44770, 0.43478260869565, 0.38478260869565, 0.16666666666667
44771, 0.43478260869565, 0.41086956521739, 0.19444444444444
44772, 0.45652173913043, 0.41086956521739, 0.22222222222222
44773, 0.43478260869565, 0.38478260869565, 0.22222222222222
44774, 0.43478260869565, 0.41086956521739, 0.25
44775, 0.45652173913043, 0.41086956521739, 0.27777777777778
44776, 0.43478260869565, 0.38478260869565, 0.27777777777778
44777, 0.43478260869565, 0.41086956521739, 0.30555555555556
44778, 0.45652173913043, 0.41086956521739, 0.33333333333333
44779, 0.43478260869565, 0.38478260869565, 0.33333333333333
44780, 0.43478260869565, 0.41086956521739, 0.36111111111111
44781, 0.45652173913044, 0.41086956521739, 0.38888888888889
44782, 0.43478260869565, 0.38478260869565, 0.38888888888889
44783, 0.43478260869565, 0.41086956521739, 0.41666666666667
44784, 0.45652173913043, 0.41086956521739, 0.44444444444444
44785, 0.43478260869565, 0.38478260869565, 0.44444444444444
44786, 0.43478260869565, 0.41086956521739, 0.47222222222222
44787, 0.39130434782609, 0.41086956521739, 0.027777777777778
44788, 0.41304347826087, 0.41086956521739, 0.055555555555556
44789, 0.39130434782609, 0.38478260869565, 0.055555555555556
44790, 0.39130434782609, 0.41086956521739, 0.083333333333333
44791, 0.41304347826087, 0.41086956521739, 0.11111111111111
44792, 0.39130434782609, 0.38478260869565, 0.11111111111111
44793, 0.39130434782609, 0.41086956521739, 0.13888888888889
44794, 0.41304347826087, 0.41086956521739, 0.16666666666667
44795, 0.39130434782609, 0.38478260869565, 0.16666666666667
44796, 0.39130434782609, 0.41086956521739, 0.19444444444444
44797, 0.41304347826087, 0.41086956521739, 0.22222222222222
44798, 0.39130434782609, 0.38478260869565, 0.22222222222222
44799, 0.39130434782609, 0.41086956521739, 0.25
44800, 0.41304347826087, 0.41086956521739, 0.27777777777778
44801, 0.39130434782609, 0.38478260869565, 0.27777777777778
44802, 0.39130434782609, 0.41086956521739, 0.30555555555556
44803, 0.41304347826087, 0.41086956521739, 0.33333333333333
44804, 0.39130434782609, 0.38478260869565, 0.33333333333333
44805, 0.39130434782609, 0.41086956521739, 0.36111111111111
44806, 0.41304347826087, 0.41086956521739, 0.38888888888889
44807, 0.39130434782609, 0.38478260869565, 0.38888888888889
44808, 0.39130434782609, 0.41086956521739, 0.41666666666667
44809, 0.41304347826087, 0.41086956521739, 0.44444444444444
44810, 0.39130434782609, 0.38478260869565, 0.44444444444444
44811, 0.39130434782609, 0.41086956521739, 0.47222222222222
44812, 0.34782608695652, 0.41086956521739, 0.027777777777778
44813, 0.3695652173913, 0.41086956521739, 0.055555555555556
44814, 0.34782608695652, 0.38478260869565, 0.055555555555556
44815, 0.34782608695652, 0.41086956521739, 0.083333333333333
44816, 0.3695652173913, 0.41086956521739, 0.11111111111111
44817, 0.34782608695652, 0.38478260869565, 0.11111111111111
44818, 0.34782608695652, 0.41086956521739, 0.13888888888889
44819, 0.3695652173913, 0.41086956521739, 0.16666666666667
44820, 0.34782608695652, 0.38478260869565, 0.16666666666667
44821, 0.34782608695652, 0.41086956521739, 0.19444444444444
44822, 0.3695652173913, 0.41086956521739, 0.22222222222222
44823, 0.34782608695652, 0.38478260869565, 0.22222222222222
44824, 0.34782608695652, 0.41086956521739, 0.25
44825, 0.3695652173913, 0.41086956521739, 0.27777777777778
44826, 0.34782608695652, 0.38478260869565, 0.27777777777778
44827, 0.34782608695652, 0.41086956521739, 0.30555555555556
44828, 0.3695652173913, 0.41086956521739, 0.33333333333333
44829, 0.34782608695652, 0.38478260869565, 0.33333333333333
44830, 0.34782608695652, 0.41086956521739, 0.36111111111111
44831, 0.3695652173913, 0.41086956521739, 0.38888888888889
44832, 0.34782608695652, 0.38478260869565, 0.38888888888889
44833, 0.34782608695652, 0.41086956521739, 0.41666666666667
44834, 0.3695652173913, 0.41086956521739, 0.44444444444444
44835, 0.34782608695652, 0.38478260869565, 0.44444444444444
44836, 0.34782608695652, 0.41086956521739, 0.47222222222222
44837, 0.30434782608696, 0.41086956521739, 0.027777777777778
44838, 0.32608695652174, 0.41086956521739, 0.055555555555556
44839, 0.30434782608696, 0.38478260869565, 0.055555555555556
44840, 0.30434782608696, 0.41086956521739, 0.083333333333333
44841, 0.32608695652174, 0.41086956521739, 0.11111111111111
44842, 0.30434782608696, 0.38478260869565, 0.11111111111111
44843, 0.30434782608696, 0.41086956521739, 0.13888888888889
44844, 0.32608695652174, 0.41086956521739, 0.16666666666667
44845, 0.30434782608696, 0.38478260869565, 0.16666666666667
44846, 0.30434782608696, 0.41086956521739, 0.19444444444444
44847, 0.32608695652174, 0.41086956521739, 0.22222222222222
44848, 0.30434782608696, 0.38478260869565, 0.22222222222222
44849, 0.30434782608696, 0.41086956521739, 0.25
44850, 0.32608695652174, 0.41086956521739, 0.27777777777778
44851, 0.30434782608696, 0.38478260869565, 0.27777777777778
44852, 0.30434782608696, 0.41086956521739, 0.30555555555556
44853, 0.32608695652174, 0.41086956521739, 0.33333333333333
44854, 0.30434782608696, 0.38478260869565, 0.33333333333333
44855, 0.30434782608696, 0.41086956521739, 0.36111111111111
44856, 0.32608695652174, 0.41086956521739, 0.38888888888889
44857, 0.30434782608696, 0.38478260869565, 0.38888888888889
44858, 0.30434782608696, 0.41086956521739, 0.41666666666667
44859, 0.32608695652174, 0.41086956521739, 0.44444444444444
44860, 0.30434782608696, 0.38478260869565, 0.44444444444444
44861, 0.30434782608696, 0.41086956521739, 0.47222222222222
44862, 0.26086956521739, 0.41086956521739, 0.027777777777778
44863, 0.28260869565217, 0.41086956521739, 0.055555555555556
44864, 0.26086956521739, 0.38478260869565, 0.055555555555556
44865, 0.26086956521739, 0.41086956521739, 0.083333333333333
44866, 0.28260869565217, 0.41086956521739, 0.11111111111111
44867, 0.26086956521739, 0.38478260869565, 0.11111111111111
44868, 0.26086956521739, 0.41086956521739, 0.13888888888889
44869, 0.28260869565217, 0.41086956521739, 0.16666666666667
44870, 0.26086956521739, 0.38478260869565, 0.16666666666667
44871, 0.26086956521739, 0.41086956521739, 0.19444444444444
44872, 0.28260869565217, 0.41086956521739, 0.22222222222222
44873, 0.26086956521739, 0.38478260869565, 0.22222222222222
44874, 0.26086956521739, 0.41086956521739, 0.25
44875, 0.28260869565217, 0.41086956521739, 0.27777777777778
44876, 0.26086956521739, 0.38478260869565, 0.27777777777778
44877, 0.26086956521739, 0.41086956521739, 0.30555555555556
44878, 0.28260869565217, 0.41086956521739, 0.33333333333333
44879, 0.26086956521739, 0.38478260869565, 0.33333333333333
44880, 0.26086956521739, 0.41086956521739, 0.36111111111111
44881, 0.28260869565217, 0.41086956521739, 0.38888888888889
44882, 0.26086956521739, 0.38478260869565, 0.38888888888889
44883, 0.26086956521739, 0.41086956521739, 0.41666666666667
44884, 0.28260869565217, 0.41086956521739, 0.44444444444444
44885, 0.26086956521739, 0.38478260869565, 0.44444444444444
44886, 0.26086956521739, 0.41086956521739, 0.47222222222222
44887, 0.21739130434783, 0.41086956521739, 0.027777777777778
44888, 0.23913043478261, 0.41086956521739, 0.055555555555556
44889, 0.21739130434783, 0.38478260869565, 0.055555555555556
44890, 0.21739130434783, 0.41086956521739, 0.083333333333333
44891, 0.23913043478261, 0.41086956521739, 0.11111111111111
44892, 0.21739130434783, 0.38478260869565, 0.11111111111111
44893, 0.21739130434783, 0.41086956521739, 0.13888888888889
44894, 0.23913043478261, 0.41086956521739, 0.16666666666667
44895, 0.21739130434783, 0.38478260869565, 0.16666666666667
44896, 0.21739130434783, 0.41086956521739, 0.19444444444444
44897, 0.23913043478261, 0.41086956521739, 0.22222222222222
44898, 0.21739130434783, 0.38478260869565, 0.22222222222222
44899, 0.21739130434783, 0.41086956521739, 0.25
44900, 0.23913043478261, 0.41086956521739, 0.27777777777778
44901, 0.21739130434783, 0.38478260869565, 0.27777777777778
44902, 0.21739130434783, 0.41086956521739, 0.30555555555556
44903, 0.23913043478261, 0.41086956521739, 0.33333333333333
44904, 0.21739130434783, 0.38478260869565, 0.33333333333333
44905, 0.21739130434783, 0.41086956521739, 0.36111111111111
44906, 0.23913043478261, 0.41086956521739, 0.38888888888889
44907, 0.21739130434783, 0.38478260869565, 0.38888888888889
44908, 0.21739130434783, 0.41086956521739, 0.41666666666667
44909, 0.23913043478261, 0.41086956521739, 0.44444444444444
44910, 0.21739130434783, 0.38478260869565, 0.44444444444444
44911, 0.21739130434783, 0.41086956521739, 0.47222222222222
44912, 0.17391304347826, 0.41086956521739, 0.027777777777778
44913, 0.19565217391304, 0.41086956521739, 0.055555555555556
44914, 0.17391304347826, 0.38478260869565, 0.055555555555556
44915, 0.17391304347826, 0.41086956521739, 0.083333333333333
44916, 0.19565217391304, 0.41086956521739, 0.11111111111111
44917, 0.17391304347826, 0.38478260869565, 0.11111111111111
44918, 0.17391304347826, 0.41086956521739, 0.13888888888889
44919, 0.19565217391304, 0.41086956521739, 0.16666666666667
44920, 0.17391304347826, 0.38478260869565, 0.16666666666667
44921, 0.17391304347826, 0.41086956521739, 0.19444444444444
44922, 0.19565217391304, 0.41086956521739, 0.22222222222222
44923, 0.17391304347826, 0.38478260869565, 0.22222222222222
44924, 0.17391304347826, 0.41086956521739, 0.25
44925, 0.19565217391304, 0.41086956521739, 0.27777777777778
44926, 0.17391304347826, 0.38478260869565, 0.27777777777778
44927, 0.17391304347826, 0.41086956521739, 0.30555555555556
44928, 0.19565217391304, 0.41086956521739, 0.33333333333333
44929, 0.17391304347826, 0.38478260869565, 0.33333333333333
44930, 0.17391304347826, 0.41086956521739, 0.36111111111111
44931, 0.19565217391304, 0.41086956521739, 0.38888888888889
44932, 0.17391304347826, 0.38478260869565, 0.38888888888889
44933, 0.17391304347826, 0.41086956521739, 0.41666666666667
44934, 0.19565217391304, 0.41086956521739, 0.44444444444444
44935, 0.17391304347826, 0.38478260869565, 0.44444444444444
44936, 0.17391304347826, 0.41086956521739, 0.47222222222222
44937, 0.1304347826087, 0.41086956521739, 0.027777777777778
44938, 0.15217391304348, 0.41086956521739, 0.055555555555556
44939, 0.1304347826087, 0.38478260869565, 0.055555555555556
44940, 0.1304347826087, 0.41086956521739, 0.083333333333333
44941, 0.15217391304348, 0.41086956521739, 0.11111111111111
44942, 0.1304347826087, 0.38478260869565, 0.11111111111111
44943, 0.1304347826087, 0.41086956521739, 0.13888888888889
44944, 0.15217391304348, 0.41086956521739, 0.16666666666667
44945, 0.1304347826087, 0.38478260869565, 0.16666666666667
44946, 0.1304347826087, 0.41086956521739, 0.19444444444444
44947, 0.15217391304348, 0.41086956521739, 0.22222222222222
44948, 0.1304347826087, 0.38478260869565, 0.22222222222222
44949, 0.1304347826087, 0.41086956521739, 0.25
44950, 0.15217391304348, 0.41086956521739, 0.27777777777778
44951, 0.1304347826087, 0.38478260869565, 0.27777777777778
44952, 0.1304347826087, 0.41086956521739, 0.30555555555556
44953, 0.15217391304348, 0.41086956521739, 0.33333333333333
44954, 0.1304347826087, 0.38478260869565, 0.33333333333333
44955, 0.1304347826087, 0.41086956521739, 0.36111111111111
44956, 0.15217391304348, 0.41086956521739, 0.38888888888889
44957, 0.1304347826087, 0.38478260869565, 0.38888888888889
44958, 0.1304347826087, 0.41086956521739, 0.41666666666667
44959, 0.15217391304348, 0.41086956521739, 0.44444444444444
44960, 0.1304347826087, 0.38478260869565, 0.44444444444444
44961, 0.1304347826087, 0.41086956521739, 0.47222222222222
44962, 0.08695652173913, 0.41086956521739, 0.027777777777778
44963, 0.10869565217391, 0.41086956521739, 0.055555555555556
44964, 0.08695652173913, 0.38478260869565, 0.055555555555556
44965, 0.08695652173913, 0.41086956521739, 0.083333333333333
44966, 0.10869565217391, 0.41086956521739, 0.11111111111111
44967, 0.08695652173913, 0.38478260869565, 0.11111111111111
44968, 0.08695652173913, 0.41086956521739, 0.13888888888889
44969, 0.10869565217391, 0.41086956521739, 0.16666666666667
44970, 0.08695652173913, 0.38478260869565, 0.16666666666667
44971, 0.08695652173913, 0.41086956521739, 0.19444444444444
44972, 0.10869565217391, 0.41086956521739, 0.22222222222222
44973, 0.08695652173913, 0.38478260869565, 0.22222222222222
44974, 0.08695652173913, 0.41086956521739, 0.25
44975, 0.10869565217391, 0.41086956521739, 0.27777777777778
44976, 0.08695652173913, 0.38478260869565, 0.27777777777778
44977, 0.08695652173913, 0.41086956521739, 0.30555555555556
44978, 0.10869565217391, 0.41086956521739, 0.33333333333333
44979, 0.08695652173913, 0.38478260869565, 0.33333333333333
44980, 0.08695652173913, 0.41086956521739, 0.36111111111111
44981, 0.10869565217391, 0.41086956521739, 0.38888888888889
44982, 0.08695652173913, 0.38478260869565, 0.38888888888889
44983, 0.08695652173913, 0.41086956521739, 0.41666666666667
44984, 0.10869565217391, 0.41086956521739, 0.44444444444444
44985, 0.08695652173913, 0.38478260869565, 0.44444444444444
44986, 0.08695652173913, 0.41086956521739, 0.47222222222222
44987, 0.043478260869565, 0.41086956521739, 0.027777777777778
44988, 0.065217391304348, 0.41086956521739, 0.055555555555556
44989, 0.043478260869565, 0.38478260869565, 0.055555555555556
44990, 0.043478260869565, 0.41086956521739, 0.083333333333333
44991, 0.065217391304348, 0.41086956521739, 0.11111111111111
44992, 0.043478260869565, 0.38478260869565, 0.11111111111111
44993, 0.043478260869565, 0.41086956521739, 0.13888888888889
44994, 0.065217391304348, 0.41086956521739, 0.16666666666667
44995, 0.043478260869565, 0.38478260869565, 0.16666666666667
44996, 0.043478260869565, 0.41086956521739, 0.19444444444444
44997, 0.065217391304348, 0.41086956521739, 0.22222222222222
44998, 0.043478260869565, 0.38478260869565, 0.22222222222222
44999, 0.043478260869565, 0.41086956521739, 0.25
45000, 0.065217391304348, 0.41086956521739, 0.27777777777778
45001, 0.043478260869565, 0.38478260869565, 0.27777777777778
45002, 0.043478260869565, 0.41086956521739, 0.30555555555556
45003, 0.065217391304348, 0.41086956521739, 0.33333333333333
45004, 0.043478260869565, 0.38478260869565, 0.33333333333333
45005, 0.043478260869565, 0.41086956521739, 0.36111111111111
45006, 0.065217391304348, 0.41086956521739, 0.38888888888889
45007, 0.043478260869565, 0.38478260869565, 0.38888888888889
45008, 0.043478260869565, 0.41086956521739, 0.41666666666667
45009, 0.065217391304348, 0.41086956521739, 0.44444444444444
45010, 0.043478260869565, 0.38478260869565, 0.44444444444444
45011, 0.043478260869565, 0.41086956521739, 0.47222222222222
45012, 0.021739130434783, 0.41086956521739, 0.055555555555556
45013, 0.021739130434783, 0.41086956521739, 0.11111111111111
45014, 0.021739130434783, 0.41086956521739, 0.16666666666667
45015, 0.021739130434783, 0.41086956521739, 0.22222222222222
45016, 0.021739130434783, 0.41086956521739, 0.27777777777778
45017, 0.021739130434783, 0.41086956521739, 0.33333333333333
45018, 0.021739130434783, 0.41086956521739, 0.38888888888889
45019, 0.021739130434783, 0.41086956521739, 0.44444444444444
45020, 0.95652173913043, 0.46304347826087, 0.027777777777778
45021, 0.97826086956522, 0.46304347826087, 0.055555555555556
45022, 0.95652173913043, 0.43695652173913, 0.055555555555556
45023, 0.95652173913043, 0.46304347826087, 0.083333333333333
45024, 0.97826086956522, 0.46304347826087, 0.11111111111111
45025, 0.95652173913044, 0.43695652173913, 0.11111111111111
45026, 0.95652173913044, 0.46304347826087, 0.13888888888889
45027, 0.97826086956522, 0.46304347826087, 0.16666666666667
45028, 0.95652173913044, 0.43695652173913, 0.16666666666667
45029, 0.95652173913044, 0.46304347826087, 0.19444444444444
45030, 0.97826086956522, 0.46304347826087, 0.22222222222222
45031, 0.95652173913044, 0.43695652173913, 0.22222222222222
45032, 0.95652173913044, 0.46304347826087, 0.25
45033, 0.97826086956522, 0.46304347826087, 0.27777777777778
45034, 0.95652173913044, 0.43695652173913, 0.27777777777778
45035, 0.95652173913044, 0.46304347826087, 0.30555555555556
45036, 0.97826086956522, 0.46304347826087, 0.33333333333333
45037, 0.95652173913044, 0.43695652173913, 0.33333333333333
45038, 0.95652173913044, 0.46304347826087, 0.36111111111111
45039, 0.97826086956522, 0.46304347826087, 0.38888888888889
45040, 0.95652173913044, 0.43695652173913, 0.38888888888889
45041, 0.95652173913044, 0.46304347826087, 0.41666666666667
45042, 0.97826086956522, 0.46304347826087, 0.44444444444444
45043, 0.95652173913044, 0.43695652173913, 0.44444444444444
45044, 0.95652173913044, 0.46304347826087, 0.47222222222222
45045, 0.91304347826087, 0.46304347826087, 0.027777777777778
45046, 0.93478260869565, 0.46304347826087, 0.055555555555556
45047, 0.91304347826087, 0.43695652173913, 0.055555555555556
45048, 0.91304347826087, 0.46304347826087, 0.083333333333333
45049, 0.93478260869565, 0.46304347826087, 0.11111111111111
45050, 0.91304347826087, 0.43695652173913, 0.11111111111111
45051, 0.91304347826087, 0.46304347826087, 0.13888888888889
45052, 0.93478260869565, 0.46304347826087, 0.16666666666667
45053, 0.91304347826087, 0.43695652173913, 0.16666666666667
45054, 0.91304347826087, 0.46304347826087, 0.19444444444444
45055, 0.93478260869565, 0.46304347826087, 0.22222222222222
45056, 0.91304347826087, 0.43695652173913, 0.22222222222222
45057, 0.91304347826087, 0.46304347826087, 0.25
45058, 0.93478260869565, 0.46304347826087, 0.27777777777778
45059, 0.91304347826087, 0.43695652173913, 0.27777777777778
45060, 0.91304347826087, 0.46304347826087, 0.30555555555556
45061, 0.93478260869565, 0.46304347826087, 0.33333333333333
45062, 0.91304347826087, 0.43695652173913, 0.33333333333333
45063, 0.91304347826087, 0.46304347826087, 0.36111111111111
45064, 0.93478260869565, 0.46304347826087, 0.38888888888889
45065, 0.91304347826087, 0.43695652173913, 0.38888888888889
45066, 0.91304347826087, 0.46304347826087, 0.41666666666667
45067, 0.93478260869565, 0.46304347826087, 0.44444444444444
45068, 0.91304347826087, 0.43695652173913, 0.44444444444444
45069, 0.91304347826087, 0.46304347826087, 0.47222222222222
45070, 0.8695652173913, 0.46304347826087, 0.027777777777778
45071, 0.89130434782609, 0.46304347826087, 0.055555555555556
45072, 0.8695652173913, 0.43695652173913, 0.055555555555556
45073, 0.8695652173913, 0.46304347826087, 0.083333333333333
45074, 0.89130434782609, 0.46304347826087, 0.11111111111111
45075, 0.8695652173913, 0.43695652173913, 0.11111111111111
45076, 0.8695652173913, 0.46304347826087, 0.13888888888889
45077, 0.89130434782609, 0.46304347826087, 0.16666666666667
45078, 0.8695652173913, 0.43695652173913, 0.16666666666667
45079, 0.8695652173913, 0.46304347826087, 0.19444444444444
45080, 0.89130434782609, 0.46304347826087, 0.22222222222222
45081, 0.8695652173913, 0.43695652173913, 0.22222222222222
45082, 0.8695652173913, 0.46304347826087, 0.25
45083, 0.89130434782609, 0.46304347826087, 0.27777777777778
45084, 0.8695652173913, 0.43695652173913, 0.27777777777778
45085, 0.8695652173913, 0.46304347826087, 0.30555555555556
45086, 0.89130434782609, 0.46304347826087, 0.33333333333333
45087, 0.8695652173913, 0.43695652173913, 0.33333333333333
45088, 0.8695652173913, 0.46304347826087, 0.36111111111111
45089, 0.89130434782609, 0.46304347826087, 0.38888888888889
45090, 0.8695652173913, 0.43695652173913, 0.38888888888889
45091, 0.8695652173913, 0.46304347826087, 0.41666666666667
45092, 0.89130434782609, 0.46304347826087, 0.44444444444444
45093, 0.8695652173913, 0.43695652173913, 0.44444444444444
45094, 0.8695652173913, 0.46304347826087, 0.47222222222222
45095, 0.82608695652174, 0.46304347826087, 0.027777777777778
45096, 0.84782608695652, 0.46304347826087, 0.055555555555556
45097, 0.82608695652174, 0.43695652173913, 0.055555555555556
45098, 0.82608695652174, 0.46304347826087, 0.083333333333333
45099, 0.84782608695652, 0.46304347826087, 0.11111111111111
45100, 0.82608695652174, 0.43695652173913, 0.11111111111111
45101, 0.82608695652174, 0.46304347826087, 0.13888888888889
45102, 0.84782608695652, 0.46304347826087, 0.16666666666667
45103, 0.82608695652174, 0.43695652173913, 0.16666666666667
45104, 0.82608695652174, 0.46304347826087, 0.19444444444444
45105, 0.84782608695652, 0.46304347826087, 0.22222222222222
45106, 0.82608695652174, 0.43695652173913, 0.22222222222222
45107, 0.82608695652174, 0.46304347826087, 0.25
45108, 0.84782608695652, 0.46304347826087, 0.27777777777778
45109, 0.82608695652174, 0.43695652173913, 0.27777777777778
45110, 0.82608695652174, 0.46304347826087, 0.30555555555556
45111, 0.84782608695652, 0.46304347826087, 0.33333333333333
45112, 0.82608695652174, 0.43695652173913, 0.33333333333333
45113, 0.82608695652174, 0.46304347826087, 0.36111111111111
45114, 0.84782608695652, 0.46304347826087, 0.38888888888889
45115, 0.82608695652174, 0.43695652173913, 0.38888888888889
45116, 0.82608695652174, 0.46304347826087, 0.41666666666667
45117, 0.84782608695652, 0.46304347826087, 0.44444444444444
45118, 0.82608695652174, 0.43695652173913, 0.44444444444444
45119, 0.82608695652174, 0.46304347826087, 0.47222222222222
45120, 0.78260869565217, 0.46304347826087, 0.027777777777778
45121, 0.80434782608696, 0.46304347826087, 0.055555555555556
45122, 0.78260869565217, 0.43695652173913, 0.055555555555556
45123, 0.78260869565217, 0.46304347826087, 0.083333333333333
45124, 0.80434782608696, 0.46304347826087, 0.11111111111111
45125, 0.78260869565217, 0.43695652173913, 0.11111111111111
45126, 0.78260869565217, 0.46304347826087, 0.13888888888889
45127, 0.80434782608696, 0.46304347826087, 0.16666666666667
45128, 0.78260869565217, 0.43695652173913, 0.16666666666667
45129, 0.78260869565217, 0.46304347826087, 0.19444444444444
45130, 0.80434782608696, 0.46304347826087, 0.22222222222222
45131, 0.78260869565217, 0.43695652173913, 0.22222222222222
45132, 0.78260869565217, 0.46304347826087, 0.25
45133, 0.80434782608696, 0.46304347826087, 0.27777777777778
45134, 0.78260869565217, 0.43695652173913, 0.27777777777778
45135, 0.78260869565217, 0.46304347826087, 0.30555555555556
45136, 0.80434782608696, 0.46304347826087, 0.33333333333333
45137, 0.78260869565217, 0.43695652173913, 0.33333333333333
45138, 0.78260869565217, 0.46304347826087, 0.36111111111111
45139, 0.80434782608696, 0.46304347826087, 0.38888888888889
45140, 0.78260869565217, 0.43695652173913, 0.38888888888889
45141, 0.78260869565217, 0.46304347826087, 0.41666666666667
45142, 0.80434782608696, 0.46304347826087, 0.44444444444444
45143, 0.78260869565217, 0.43695652173913, 0.44444444444444
45144, 0.78260869565217, 0.46304347826087, 0.47222222222222
45145, 0.73913043478261, 0.46304347826087, 0.027777777777778
45146, 0.76086956521739, 0.46304347826087, 0.055555555555556
45147, 0.73913043478261, 0.43695652173913, 0.055555555555556
45148, 0.73913043478261, 0.46304347826087, 0.083333333333333
45149, 0.76086956521739, 0.46304347826087, 0.11111111111111
45150, 0.73913043478261, 0.43695652173913, 0.11111111111111
45151, 0.73913043478261, 0.46304347826087, 0.13888888888889
45152, 0.76086956521739, 0.46304347826087, 0.16666666666667
45153, 0.73913043478261, 0.43695652173913, 0.16666666666667
45154, 0.73913043478261, 0.46304347826087, 0.19444444444444
45155, 0.76086956521739, 0.46304347826087, 0.22222222222222
45156, 0.73913043478261, 0.43695652173913, 0.22222222222222
45157, 0.73913043478261, 0.46304347826087, 0.25
45158, 0.76086956521739, 0.46304347826087, 0.27777777777778
45159, 0.73913043478261, 0.43695652173913, 0.27777777777778
45160, 0.73913043478261, 0.46304347826087, 0.30555555555556
45161, 0.76086956521739, 0.46304347826087, 0.33333333333333
45162, 0.73913043478261, 0.43695652173913, 0.33333333333333
45163, 0.73913043478261, 0.46304347826087, 0.36111111111111
45164, 0.76086956521739, 0.46304347826087, 0.38888888888889
45165, 0.73913043478261, 0.43695652173913, 0.38888888888889
45166, 0.73913043478261, 0.46304347826087, 0.41666666666667
45167, 0.76086956521739, 0.46304347826087, 0.44444444444444
45168, 0.73913043478261, 0.43695652173913, 0.44444444444444
45169, 0.73913043478261, 0.46304347826087, 0.47222222222222
45170, 0.69565217391304, 0.46304347826087, 0.027777777777778
45171, 0.71739130434783, 0.46304347826087, 0.055555555555556
45172, 0.69565217391304, 0.43695652173913, 0.055555555555556
45173, 0.69565217391304, 0.46304347826087, 0.083333333333333
45174, 0.71739130434783, 0.46304347826087, 0.11111111111111
45175, 0.69565217391304, 0.43695652173913, 0.11111111111111
45176, 0.69565217391304, 0.46304347826087, 0.13888888888889
45177, 0.71739130434783, 0.46304347826087, 0.16666666666667
45178, 0.69565217391304, 0.43695652173913, 0.16666666666667
45179, 0.69565217391304, 0.46304347826087, 0.19444444444444
45180, 0.71739130434783, 0.46304347826087, 0.22222222222222
45181, 0.69565217391304, 0.43695652173913, 0.22222222222222
45182, 0.69565217391304, 0.46304347826087, 0.25
45183, 0.71739130434783, 0.46304347826087, 0.27777777777778
45184, 0.69565217391304, 0.43695652173913, 0.27777777777778
45185, 0.69565217391304, 0.46304347826087, 0.30555555555556
45186, 0.71739130434783, 0.46304347826087, 0.33333333333333
45187, 0.69565217391304, 0.43695652173913, 0.33333333333333
45188, 0.69565217391304, 0.46304347826087, 0.36111111111111
45189, 0.71739130434783, 0.46304347826087, 0.38888888888889
45190, 0.69565217391304, 0.43695652173913, 0.38888888888889
45191, 0.69565217391304, 0.46304347826087, 0.41666666666667
45192, 0.71739130434783, 0.46304347826087, 0.44444444444444
45193, 0.69565217391304, 0.43695652173913, 0.44444444444444
45194, 0.69565217391304, 0.46304347826087, 0.47222222222222
45195, 0.65217391304348, 0.46304347826087, 0.027777777777778
45196, 0.67391304347826, 0.46304347826087, 0.055555555555556
45197, 0.65217391304348, 0.43695652173913, 0.055555555555556
45198, 0.65217391304348, 0.46304347826087, 0.083333333333333
45199, 0.67391304347826, 0.46304347826087, 0.11111111111111
45200, 0.65217391304348, 0.43695652173913, 0.11111111111111
45201, 0.65217391304348, 0.46304347826087, 0.13888888888889
45202, 0.67391304347826, 0.46304347826087, 0.16666666666667
45203, 0.65217391304348, 0.43695652173913, 0.16666666666667
45204, 0.65217391304348, 0.46304347826087, 0.19444444444444
45205, 0.67391304347826, 0.46304347826087, 0.22222222222222
45206, 0.65217391304348, 0.43695652173913, 0.22222222222222
45207, 0.65217391304348, 0.46304347826087, 0.25
45208, 0.67391304347826, 0.46304347826087, 0.27777777777778
45209, 0.65217391304348, 0.43695652173913, 0.27777777777778
45210, 0.65217391304348, 0.46304347826087, 0.30555555555556
45211, 0.67391304347826, 0.46304347826087, 0.33333333333333
45212, 0.65217391304348, 0.43695652173913, 0.33333333333333
45213, 0.65217391304348, 0.46304347826087, 0.36111111111111
45214, 0.67391304347826, 0.46304347826087, 0.38888888888889
45215, 0.65217391304348, 0.43695652173913, 0.38888888888889
45216, 0.65217391304348, 0.46304347826087, 0.41666666666667
45217, 0.67391304347826, 0.46304347826087, 0.44444444444444
45218, 0.65217391304348, 0.43695652173913, 0.44444444444444
45219, 0.65217391304348, 0.46304347826087, 0.47222222222222
45220, 0.60869565217391, 0.46304347826087, 0.027777777777778
45221, 0.6304347826087, 0.46304347826087, 0.055555555555556
45222, 0.60869565217391, 0.43695652173913, 0.055555555555556
45223, 0.60869565217391, 0.46304347826087, 0.083333333333333
45224, 0.6304347826087, 0.46304347826087, 0.11111111111111
45225, 0.60869565217391, 0.43695652173913, 0.11111111111111
45226, 0.60869565217391, 0.46304347826087, 0.13888888888889
45227, 0.6304347826087, 0.46304347826087, 0.16666666666667
45228, 0.60869565217391, 0.43695652173913, 0.16666666666667
45229, 0.60869565217391, 0.46304347826087, 0.19444444444444
45230, 0.6304347826087, 0.46304347826087, 0.22222222222222
45231, 0.60869565217391, 0.43695652173913, 0.22222222222222
45232, 0.60869565217391, 0.46304347826087, 0.25
45233, 0.6304347826087, 0.46304347826087, 0.27777777777778
45234, 0.60869565217391, 0.43695652173913, 0.27777777777778
45235, 0.60869565217391, 0.46304347826087, 0.30555555555556
45236, 0.6304347826087, 0.46304347826087, 0.33333333333333
45237, 0.60869565217391, 0.43695652173913, 0.33333333333333
45238, 0.60869565217391, 0.46304347826087, 0.36111111111111
45239, 0.6304347826087, 0.46304347826087, 0.38888888888889
45240, 0.60869565217391, 0.43695652173913, 0.38888888888889
45241, 0.60869565217391, 0.46304347826087, 0.41666666666667
45242, 0.6304347826087, 0.46304347826087, 0.44444444444444
45243, 0.60869565217391, 0.43695652173913, 0.44444444444444
45244, 0.60869565217391, 0.46304347826087, 0.47222222222222
45245, 0.56521739130435, 0.46304347826087, 0.027777777777778
45246, 0.58695652173913, 0.46304347826087, 0.055555555555556
45247, 0.56521739130435, 0.43695652173913, 0.055555555555556
45248, 0.56521739130435, 0.46304347826087, 0.083333333333333
45249, 0.58695652173913, 0.46304347826087, 0.11111111111111
45250, 0.56521739130435, 0.43695652173913, 0.11111111111111
45251, 0.56521739130435, 0.46304347826087, 0.13888888888889
45252, 0.58695652173913, 0.46304347826087, 0.16666666666667
45253, 0.56521739130435, 0.43695652173913, 0.16666666666667
45254, 0.56521739130435, 0.46304347826087, 0.19444444444444
45255, 0.58695652173913, 0.46304347826087, 0.22222222222222
45256, 0.56521739130435, 0.43695652173913, 0.22222222222222
45257, 0.56521739130435, 0.46304347826087, 0.25
45258, 0.58695652173913, 0.46304347826087, 0.27777777777778
45259, 0.56521739130435, 0.43695652173913, 0.27777777777778
45260, 0.56521739130435, 0.46304347826087, 0.30555555555556
45261, 0.58695652173913, 0.46304347826087, 0.33333333333333
45262, 0.56521739130435, 0.43695652173913, 0.33333333333333
45263, 0.56521739130435, 0.46304347826087, 0.36111111111111
45264, 0.58695652173913, 0.46304347826087, 0.38888888888889
45265, 0.56521739130435, 0.43695652173913, 0.38888888888889
45266, 0.56521739130435, 0.46304347826087, 0.41666666666667
45267, 0.58695652173913, 0.46304347826087, 0.44444444444444
45268, 0.56521739130435, 0.43695652173913, 0.44444444444444
45269, 0.56521739130435, 0.46304347826087, 0.47222222222222
45270, 0.52173913043478, 0.46304347826087, 0.027777777777778
45271, 0.54347826086957, 0.46304347826087, 0.055555555555556
45272, 0.52173913043478, 0.43695652173913, 0.055555555555556
45273, 0.52173913043478, 0.46304347826087, 0.083333333333333
45274, 0.54347826086957, 0.46304347826087, 0.11111111111111
45275, 0.52173913043478, 0.43695652173913, 0.11111111111111
45276, 0.52173913043478, 0.46304347826087, 0.13888888888889
45277, 0.54347826086956, 0.46304347826087, 0.16666666666667
45278, 0.52173913043478, 0.43695652173913, 0.16666666666667
45279, 0.52173913043478, 0.46304347826087, 0.19444444444444
45280, 0.54347826086956, 0.46304347826087, 0.22222222222222
45281, 0.52173913043478, 0.43695652173913, 0.22222222222222
45282, 0.52173913043478, 0.46304347826087, 0.25
45283, 0.54347826086956, 0.46304347826087, 0.27777777777778
45284, 0.52173913043478, 0.43695652173913, 0.27777777777778
45285, 0.52173913043478, 0.46304347826087, 0.30555555555556
45286, 0.54347826086956, 0.46304347826087, 0.33333333333333
45287, 0.52173913043478, 0.43695652173913, 0.33333333333333
45288, 0.52173913043478, 0.46304347826087, 0.36111111111111
45289, 0.54347826086956, 0.46304347826087, 0.38888888888889
45290, 0.52173913043478, 0.43695652173913, 0.38888888888889
45291, 0.52173913043478, 0.46304347826087, 0.41666666666667
45292, 0.54347826086956, 0.46304347826087, 0.44444444444444
45293, 0.52173913043478, 0.43695652173913, 0.44444444444444
45294, 0.52173913043478, 0.46304347826087, 0.47222222222222
45295, 0.47826086956522, 0.46304347826087, 0.027777777777778
45296, 0.5, 0.46304347826087, 0.055555555555556
45297, 0.47826086956522, 0.43695652173913, 0.055555555555556
45298, 0.47826086956522, 0.46304347826087, 0.083333333333333
45299, 0.5, 0.46304347826087, 0.11111111111111
45300, 0.47826086956522, 0.43695652173913, 0.11111111111111
45301, 0.47826086956522, 0.46304347826087, 0.13888888888889
45302, 0.5, 0.46304347826087, 0.16666666666667
45303, 0.47826086956522, 0.43695652173913, 0.16666666666667
45304, 0.47826086956522, 0.46304347826087, 0.19444444444444
45305, 0.5, 0.46304347826087, 0.22222222222222
45306, 0.47826086956522, 0.43695652173913, 0.22222222222222
45307, 0.47826086956522, 0.46304347826087, 0.25
45308, 0.5, 0.46304347826087, 0.27777777777778
45309, 0.47826086956522, 0.43695652173913, 0.27777777777778
45310, 0.47826086956522, 0.46304347826087, 0.30555555555556
45311, 0.5, 0.46304347826087, 0.33333333333333
45312, 0.47826086956522, 0.43695652173913, 0.33333333333333
45313, 0.47826086956522, 0.46304347826087, 0.36111111111111
45314, 0.5, 0.46304347826087, 0.38888888888889
45315, 0.47826086956522, 0.43695652173913, 0.38888888888889
45316, 0.47826086956522, 0.46304347826087, 0.41666666666667
45317, 0.5, 0.46304347826087, 0.44444444444444
45318, 0.47826086956522, 0.43695652173913, 0.44444444444444
45319, 0.47826086956522, 0.46304347826087, 0.47222222222222
45320, 0.43478260869565, 0.46304347826087, 0.027777777777778
45321, 0.45652173913043, 0.46304347826087, 0.055555555555556
45322, 0.43478260869565, 0.43695652173913, 0.055555555555556
45323, 0.43478260869565, 0.46304347826087, 0.083333333333333
45324, 0.45652173913043, 0.46304347826087, 0.11111111111111
45325, 0.43478260869565, 0.43695652173913, 0.11111111111111
45326, 0.43478260869565, 0.46304347826087, 0.13888888888889
45327, 0.45652173913043, 0.46304347826087, 0.16666666666667
45328, 0.43478260869565, 0.43695652173913, 0.16666666666667
45329, 0.43478260869565, 0.46304347826087, 0.19444444444444
45330, 0.45652173913043, 0.46304347826087, 0.22222222222222
45331, 0.43478260869565, 0.43695652173913, 0.22222222222222
45332, 0.43478260869565, 0.46304347826087, 0.25
45333, 0.45652173913043, 0.46304347826087, 0.27777777777778
45334, 0.43478260869565, 0.43695652173913, 0.27777777777778
45335, 0.43478260869565, 0.46304347826087, 0.30555555555556
45336, 0.45652173913043, 0.46304347826087, 0.33333333333333
45337, 0.43478260869565, 0.43695652173913, 0.33333333333333
45338, 0.43478260869565, 0.46304347826087, 0.36111111111111
45339, 0.45652173913044, 0.46304347826087, 0.38888888888889
45340, 0.43478260869565, 0.43695652173913, 0.38888888888889
45341, 0.43478260869565, 0.46304347826087, 0.41666666666667
45342, 0.45652173913043, 0.46304347826087, 0.44444444444444
45343, 0.43478260869565, 0.43695652173913, 0.44444444444444
45344, 0.43478260869565, 0.46304347826087, 0.47222222222222
45345, 0.39130434782609, 0.46304347826087, 0.027777777777778
45346, 0.41304347826087, 0.46304347826087, 0.055555555555556
45347, 0.39130434782609, 0.43695652173913, 0.055555555555556
45348, 0.39130434782609, 0.46304347826087, 0.083333333333333
45349, 0.41304347826087, 0.46304347826087, 0.11111111111111
45350, 0.39130434782609, 0.43695652173913, 0.11111111111111
45351, 0.39130434782609, 0.46304347826087, 0.13888888888889
45352, 0.41304347826087, 0.46304347826087, 0.16666666666667
45353, 0.39130434782609, 0.43695652173913, 0.16666666666667
45354, 0.39130434782609, 0.46304347826087, 0.19444444444444
45355, 0.41304347826087, 0.46304347826087, 0.22222222222222
45356, 0.39130434782609, 0.43695652173913, 0.22222222222222
45357, 0.39130434782609, 0.46304347826087, 0.25
45358, 0.41304347826087, 0.46304347826087, 0.27777777777778
45359, 0.39130434782609, 0.43695652173913, 0.27777777777778
45360, 0.39130434782609, 0.46304347826087, 0.30555555555556
45361, 0.41304347826087, 0.46304347826087, 0.33333333333333
45362, 0.39130434782609, 0.43695652173913, 0.33333333333333
45363, 0.39130434782609, 0.46304347826087, 0.36111111111111
45364, 0.41304347826087, 0.46304347826087, 0.38888888888889
45365, 0.39130434782609, 0.43695652173913, 0.38888888888889
45366, 0.39130434782609, 0.46304347826087, 0.41666666666667
45367, 0.41304347826087, 0.46304347826087, 0.44444444444444
45368, 0.39130434782609, 0.43695652173913, 0.44444444444444
45369, 0.39130434782609, 0.46304347826087, 0.47222222222222
45370, 0.34782608695652, 0.46304347826087, 0.027777777777778
45371, 0.3695652173913, 0.46304347826087, 0.055555555555556
45372, 0.34782608695652, 0.43695652173913, 0.055555555555556
45373, 0.34782608695652, 0.46304347826087, 0.083333333333333
45374, 0.3695652173913, 0.46304347826087, 0.11111111111111
45375, 0.34782608695652, 0.43695652173913, 0.11111111111111
45376, 0.34782608695652, 0.46304347826087, 0.13888888888889
45377, 0.3695652173913, 0.46304347826087, 0.16666666666667
45378, 0.34782608695652, 0.43695652173913, 0.16666666666667
45379, 0.34782608695652, 0.46304347826087, 0.19444444444444
45380, 0.3695652173913, 0.46304347826087, 0.22222222222222
45381, 0.34782608695652, 0.43695652173913, 0.22222222222222
45382, 0.34782608695652, 0.46304347826087, 0.25
45383, 0.3695652173913, 0.46304347826087, 0.27777777777778
45384, 0.34782608695652, 0.43695652173913, 0.27777777777778
45385, 0.34782608695652, 0.46304347826087, 0.30555555555556
45386, 0.3695652173913, 0.46304347826087, 0.33333333333333
45387, 0.34782608695652, 0.43695652173913, 0.33333333333333
45388, 0.34782608695652, 0.46304347826087, 0.36111111111111
45389, 0.3695652173913, 0.46304347826087, 0.38888888888889
45390, 0.34782608695652, 0.43695652173913, 0.38888888888889
45391, 0.34782608695652, 0.46304347826087, 0.41666666666667
45392, 0.3695652173913, 0.46304347826087, 0.44444444444444
45393, 0.34782608695652, 0.43695652173913, 0.44444444444444
45394, 0.34782608695652, 0.46304347826087, 0.47222222222222
45395, 0.30434782608696, 0.46304347826087, 0.027777777777778
45396, 0.32608695652174, 0.46304347826087, 0.055555555555556
45397, 0.30434782608696, 0.43695652173913, 0.055555555555556
45398, 0.30434782608696, 0.46304347826087, 0.083333333333333
45399, 0.32608695652174, 0.46304347826087, 0.11111111111111
45400, 0.30434782608696, 0.43695652173913, 0.11111111111111
45401, 0.30434782608696, 0.46304347826087, 0.13888888888889
45402, 0.32608695652174, 0.46304347826087, 0.16666666666667
45403, 0.30434782608696, 0.43695652173913, 0.16666666666667
45404, 0.30434782608696, 0.46304347826087, 0.19444444444444
45405, 0.32608695652174, 0.46304347826087, 0.22222222222222
45406, 0.30434782608696, 0.43695652173913, 0.22222222222222
45407, 0.30434782608696, 0.46304347826087, 0.25
45408, 0.32608695652174, 0.46304347826087, 0.27777777777778
45409, 0.30434782608696, 0.43695652173913, 0.27777777777778
45410, 0.30434782608696, 0.46304347826087, 0.30555555555556
45411, 0.32608695652174, 0.46304347826087, 0.33333333333333
45412, 0.30434782608696, 0.43695652173913, 0.33333333333333
45413, 0.30434782608696, 0.46304347826087, 0.36111111111111
45414, 0.32608695652174, 0.46304347826087, 0.38888888888889
45415, 0.30434782608696, 0.43695652173913, 0.38888888888889
45416, 0.30434782608696, 0.46304347826087, 0.41666666666667
45417, 0.32608695652174, 0.46304347826087, 0.44444444444444
45418, 0.30434782608696, 0.43695652173913, 0.44444444444444
45419, 0.30434782608696, 0.46304347826087, 0.47222222222222
45420, 0.26086956521739, 0.46304347826087, 0.027777777777778
45421, 0.28260869565217, 0.46304347826087, 0.055555555555556
45422, 0.26086956521739, 0.43695652173913, 0.055555555555556
45423, 0.26086956521739, 0.46304347826087, 0.083333333333333
45424, 0.28260869565217, 0.46304347826087, 0.11111111111111
45425, 0.26086956521739, 0.43695652173913, 0.11111111111111
45426, 0.26086956521739, 0.46304347826087, 0.13888888888889
45427, 0.28260869565217, 0.46304347826087, 0.16666666666667
45428, 0.26086956521739, 0.43695652173913, 0.16666666666667
45429, 0.26086956521739, 0.46304347826087, 0.19444444444444
45430, 0.28260869565217, 0.46304347826087, 0.22222222222222
45431, 0.26086956521739, 0.43695652173913, 0.22222222222222
45432, 0.26086956521739, 0.46304347826087, 0.25
45433, 0.28260869565217, 0.46304347826087, 0.27777777777778
45434, 0.26086956521739, 0.43695652173913, 0.27777777777778
45435, 0.26086956521739, 0.46304347826087, 0.30555555555556
45436, 0.28260869565217, 0.46304347826087, 0.33333333333333
45437, 0.26086956521739, 0.43695652173913, 0.33333333333333
45438, 0.26086956521739, 0.46304347826087, 0.36111111111111
45439, 0.28260869565217, 0.46304347826087, 0.38888888888889
45440, 0.26086956521739, 0.43695652173913, 0.38888888888889
45441, 0.26086956521739, 0.46304347826087, 0.41666666666667
45442, 0.28260869565217, 0.46304347826087, 0.44444444444444
45443, 0.26086956521739, 0.43695652173913, 0.44444444444444
45444, 0.26086956521739, 0.46304347826087, 0.47222222222222
45445, 0.21739130434783, 0.46304347826087, 0.027777777777778
45446, 0.23913043478261, 0.46304347826087, 0.055555555555556
45447, 0.21739130434783, 0.43695652173913, 0.055555555555556
45448, 0.21739130434783, 0.46304347826087, 0.083333333333333
45449, 0.23913043478261, 0.46304347826087, 0.11111111111111
45450, 0.21739130434783, 0.43695652173913, 0.11111111111111
45451, 0.21739130434783, 0.46304347826087, 0.13888888888889
45452, 0.23913043478261, 0.46304347826087, 0.16666666666667
45453, 0.21739130434783, 0.43695652173913, 0.16666666666667
45454, 0.21739130434783, 0.46304347826087, 0.19444444444444
45455, 0.23913043478261, 0.46304347826087, 0.22222222222222
45456, 0.21739130434783, 0.43695652173913, 0.22222222222222
45457, 0.21739130434783, 0.46304347826087, 0.25
45458, 0.23913043478261, 0.46304347826087, 0.27777777777778
45459, 0.21739130434783, 0.43695652173913, 0.27777777777778
45460, 0.21739130434783, 0.46304347826087, 0.30555555555556
45461, 0.23913043478261, 0.46304347826087, 0.33333333333333
45462, 0.21739130434783, 0.43695652173913, 0.33333333333333
45463, 0.21739130434783, 0.46304347826087, 0.36111111111111
45464, 0.23913043478261, 0.46304347826087, 0.38888888888889
45465, 0.21739130434783, 0.43695652173913, 0.38888888888889
45466, 0.21739130434783, 0.46304347826087, 0.41666666666667
45467, 0.23913043478261, 0.46304347826087, 0.44444444444444
45468, 0.21739130434783, 0.43695652173913, 0.44444444444444
45469, 0.21739130434783, 0.46304347826087, 0.47222222222222
45470, 0.17391304347826, 0.46304347826087, 0.027777777777778
45471, 0.19565217391304, 0.46304347826087, 0.055555555555556
45472, 0.17391304347826, 0.43695652173913, 0.055555555555556
45473, 0.17391304347826, 0.46304347826087, 0.083333333333333
45474, 0.19565217391304, 0.46304347826087, 0.11111111111111
45475, 0.17391304347826, 0.43695652173913, 0.11111111111111
45476, 0.17391304347826, 0.46304347826087, 0.13888888888889
45477, 0.19565217391304, 0.46304347826087, 0.16666666666667
45478, 0.17391304347826, 0.43695652173913, 0.16666666666667
45479, 0.17391304347826, 0.46304347826087, 0.19444444444444
45480, 0.19565217391304, 0.46304347826087, 0.22222222222222
45481, 0.17391304347826, 0.43695652173913, 0.22222222222222
45482, 0.17391304347826, 0.46304347826087, 0.25
45483, 0.19565217391304, 0.46304347826087, 0.27777777777778
45484, 0.17391304347826, 0.43695652173913, 0.27777777777778
45485, 0.17391304347826, 0.46304347826087, 0.30555555555556
45486, 0.19565217391304, 0.46304347826087, 0.33333333333333
45487, 0.17391304347826, 0.43695652173913, 0.33333333333333
45488, 0.17391304347826, 0.46304347826087, 0.36111111111111
45489, 0.19565217391304, 0.46304347826087, 0.38888888888889
45490, 0.17391304347826, 0.43695652173913, 0.38888888888889
45491, 0.17391304347826, 0.46304347826087, 0.41666666666667
45492, 0.19565217391304, 0.46304347826087, 0.44444444444444
45493, 0.17391304347826, 0.43695652173913, 0.44444444444444
45494, 0.17391304347826, 0.46304347826087, 0.47222222222222
45495, 0.1304347826087, 0.46304347826087, 0.027777777777778
45496, 0.15217391304348, 0.46304347826087, 0.055555555555556
45497, 0.1304347826087, 0.43695652173913, 0.055555555555556
45498, 0.1304347826087, 0.46304347826087, 0.083333333333333
45499, 0.15217391304348, 0.46304347826087, 0.11111111111111
45500, 0.1304347826087, 0.43695652173913, 0.11111111111111
45501, 0.1304347826087, 0.46304347826087, 0.13888888888889
45502, 0.15217391304348, 0.46304347826087, 0.16666666666667
45503, 0.1304347826087, 0.43695652173913, 0.16666666666667
45504, 0.1304347826087, 0.46304347826087, 0.19444444444444
45505, 0.15217391304348, 0.46304347826087, 0.22222222222222
45506, 0.1304347826087, 0.43695652173913, 0.22222222222222
45507, 0.1304347826087, 0.46304347826087, 0.25
45508, 0.15217391304348, 0.46304347826087, 0.27777777777778
45509, 0.1304347826087, 0.43695652173913, 0.27777777777778
45510, 0.1304347826087, 0.46304347826087, 0.30555555555556
45511, 0.15217391304348, 0.46304347826087, 0.33333333333333
45512, 0.1304347826087, 0.43695652173913, 0.33333333333333
45513, 0.1304347826087, 0.46304347826087, 0.36111111111111
45514, 0.15217391304348, 0.46304347826087, 0.38888888888889
45515, 0.1304347826087, 0.43695652173913, 0.38888888888889
45516, 0.1304347826087, 0.46304347826087, 0.41666666666667
45517, 0.15217391304348, 0.46304347826087, 0.44444444444444
45518, 0.1304347826087, 0.43695652173913, 0.44444444444444
45519, 0.1304347826087, 0.46304347826087, 0.47222222222222
45520, 0.08695652173913, 0.46304347826087, 0.027777777777778
45521, 0.10869565217391, 0.46304347826087, 0.055555555555556
45522, 0.08695652173913, 0.43695652173913, 0.055555555555556
45523, 0.08695652173913, 0.46304347826087, 0.083333333333333
45524, 0.10869565217391, 0.46304347826087, 0.11111111111111
45525, 0.08695652173913, 0.43695652173913, 0.11111111111111
45526, 0.08695652173913, 0.46304347826087, 0.13888888888889
45527, 0.10869565217391, 0.46304347826087, 0.16666666666667
45528, 0.08695652173913, 0.43695652173913, 0.16666666666667
45529, 0.08695652173913, 0.46304347826087, 0.19444444444444
45530, 0.10869565217391, 0.46304347826087, 0.22222222222222
45531, 0.08695652173913, 0.43695652173913, 0.22222222222222
45532, 0.08695652173913, 0.46304347826087, 0.25
45533, 0.10869565217391, 0.46304347826087, 0.27777777777778
45534, 0.08695652173913, 0.43695652173913, 0.27777777777778
45535, 0.08695652173913, 0.46304347826087, 0.30555555555556
45536, 0.10869565217391, 0.46304347826087, 0.33333333333333
45537, 0.08695652173913, 0.43695652173913, 0.33333333333333
45538, 0.08695652173913, 0.46304347826087, 0.36111111111111
45539, 0.10869565217391, 0.46304347826087, 0.38888888888889
45540, 0.08695652173913, 0.43695652173913, 0.38888888888889
45541, 0.08695652173913, 0.46304347826087, 0.41666666666667
45542, 0.10869565217391, 0.46304347826087, 0.44444444444444
45543, 0.08695652173913, 0.43695652173913, 0.44444444444444
45544, 0.08695652173913, 0.46304347826087, 0.47222222222222
45545, 0.043478260869565, 0.46304347826087, 0.027777777777778
45546, 0.065217391304348, 0.46304347826087, 0.055555555555556
45547, 0.043478260869565, 0.43695652173913, 0.055555555555556
45548, 0.043478260869565, 0.46304347826087, 0.083333333333333
45549, 0.065217391304348, 0.46304347826087, 0.11111111111111
45550, 0.043478260869565, 0.43695652173913, 0.11111111111111
45551, 0.043478260869565, 0.46304347826087, 0.13888888888889
45552, 0.065217391304348, 0.46304347826087, 0.16666666666667
45553, 0.043478260869565, 0.43695652173913, 0.16666666666667
45554, 0.043478260869565, 0.46304347826087, 0.19444444444444
45555, 0.065217391304348, 0.46304347826087, 0.22222222222222
45556, 0.043478260869565, 0.43695652173913, 0.22222222222222
45557, 0.043478260869565, 0.46304347826087, 0.25
45558, 0.065217391304348, 0.46304347826087, 0.27777777777778
45559, 0.043478260869565, 0.43695652173913, 0.27777777777778
45560, 0.043478260869565, 0.46304347826087, 0.30555555555556
45561, 0.065217391304348, 0.46304347826087, 0.33333333333333
45562, 0.043478260869565, 0.43695652173913, 0.33333333333333
45563, 0.043478260869565, 0.46304347826087, 0.36111111111111
45564, 0.065217391304348, 0.46304347826087, 0.38888888888889
45565, 0.043478260869565, 0.43695652173913, 0.38888888888889
45566, 0.043478260869565, 0.46304347826087, 0.41666666666667
45567, 0.065217391304348, 0.46304347826087, 0.44444444444444
45568, 0.043478260869565, 0.43695652173913, 0.44444444444444
45569, 0.043478260869565, 0.46304347826087, 0.47222222222222
45570, 0.021739130434783, 0.46304347826087, 0.055555555555556
45571, 0.021739130434783, 0.46304347826087, 0.11111111111111
45572, 0.021739130434783, 0.46304347826087, 0.16666666666667
45573, 0.021739130434783, 0.46304347826087, 0.22222222222222
45574, 0.021739130434783, 0.46304347826087, 0.27777777777778
45575, 0.021739130434783, 0.46304347826087, 0.33333333333333
45576, 0.021739130434783, 0.46304347826087, 0.38888888888889
45577, 0.021739130434783, 0.46304347826087, 0.44444444444444
45578, 0.95652173913043, 0.51521739130435, 0.027777777777778
45579, 0.97826086956522, 0.51521739130435, 0.055555555555556
45580, 0.95652173913043, 0.48913043478261, 0.055555555555556
45581, 0.95652173913043, 0.51521739130435, 0.083333333333333
45582, 0.97826086956522, 0.51521739130435, 0.11111111111111
45583, 0.95652173913044, 0.48913043478261, 0.11111111111111
45584, 0.95652173913043, 0.51521739130435, 0.13888888888889
45585, 0.97826086956522, 0.51521739130435, 0.16666666666667
45586, 0.95652173913043, 0.48913043478261, 0.16666666666667
45587, 0.95652173913043, 0.51521739130435, 0.19444444444444
45588, 0.97826086956522, 0.51521739130435, 0.22222222222222
45589, 0.95652173913044, 0.48913043478261, 0.22222222222222
45590, 0.95652173913044, 0.51521739130435, 0.25
45591, 0.97826086956522, 0.51521739130435, 0.27777777777778
45592, 0.95652173913044, 0.48913043478261, 0.27777777777778
45593, 0.95652173913043, 0.51521739130435, 0.30555555555556
45594, 0.97826086956522, 0.51521739130435, 0.33333333333333
45595, 0.95652173913043, 0.48913043478261, 0.33333333333333
45596, 0.95652173913043, 0.51521739130435, 0.36111111111111
45597, 0.97826086956522, 0.51521739130435, 0.38888888888889
45598, 0.95652173913043, 0.48913043478261, 0.38888888888889
45599, 0.95652173913043, 0.51521739130435, 0.41666666666667
45600, 0.97826086956522, 0.51521739130435, 0.44444444444444
45601, 0.95652173913043, 0.48913043478261, 0.44444444444444
45602, 0.95652173913043, 0.51521739130435, 0.47222222222222
45603, 0.91304347826087, 0.51521739130435, 0.027777777777778
45604, 0.93478260869565, 0.51521739130435, 0.055555555555556
45605, 0.91304347826087, 0.48913043478261, 0.055555555555556
45606, 0.91304347826087, 0.51521739130435, 0.083333333333333
45607, 0.93478260869565, 0.51521739130435, 0.11111111111111
45608, 0.91304347826087, 0.48913043478261, 0.11111111111111
45609, 0.91304347826087, 0.51521739130435, 0.13888888888889
45610, 0.93478260869565, 0.51521739130435, 0.16666666666667
45611, 0.91304347826087, 0.48913043478261, 0.16666666666667
45612, 0.91304347826087, 0.51521739130435, 0.19444444444444
45613, 0.93478260869565, 0.51521739130435, 0.22222222222222
45614, 0.91304347826087, 0.48913043478261, 0.22222222222222
45615, 0.91304347826087, 0.51521739130435, 0.25
45616, 0.93478260869565, 0.51521739130435, 0.27777777777778
45617, 0.91304347826087, 0.48913043478261, 0.27777777777778
45618, 0.91304347826087, 0.51521739130435, 0.30555555555556
45619, 0.93478260869565, 0.51521739130435, 0.33333333333333
45620, 0.91304347826087, 0.48913043478261, 0.33333333333333
45621, 0.91304347826087, 0.51521739130435, 0.36111111111111
45622, 0.93478260869565, 0.51521739130435, 0.38888888888889
45623, 0.91304347826087, 0.48913043478261, 0.38888888888889
45624, 0.91304347826087, 0.51521739130435, 0.41666666666667
45625, 0.93478260869565, 0.51521739130435, 0.44444444444444
45626, 0.91304347826087, 0.48913043478261, 0.44444444444444
45627, 0.91304347826087, 0.51521739130435, 0.47222222222222
45628, 0.8695652173913, 0.51521739130435, 0.027777777777778
45629, 0.89130434782609, 0.51521739130435, 0.055555555555556
45630, 0.8695652173913, 0.48913043478261, 0.055555555555556
45631, 0.8695652173913, 0.51521739130435, 0.083333333333333
45632, 0.89130434782609, 0.51521739130435, 0.11111111111111
45633, 0.8695652173913, 0.48913043478261, 0.11111111111111
45634, 0.8695652173913, 0.51521739130435, 0.13888888888889
45635, 0.89130434782609, 0.51521739130435, 0.16666666666667
45636, 0.8695652173913, 0.48913043478261, 0.16666666666667
45637, 0.8695652173913, 0.51521739130435, 0.19444444444444
45638, 0.89130434782609, 0.51521739130435, 0.22222222222222
45639, 0.8695652173913, 0.48913043478261, 0.22222222222222
45640, 0.8695652173913, 0.51521739130435, 0.25
45641, 0.89130434782609, 0.51521739130435, 0.27777777777778
45642, 0.8695652173913, 0.48913043478261, 0.27777777777778
45643, 0.8695652173913, 0.51521739130435, 0.30555555555556
45644, 0.89130434782609, 0.51521739130435, 0.33333333333333
45645, 0.8695652173913, 0.48913043478261, 0.33333333333333
45646, 0.8695652173913, 0.51521739130435, 0.36111111111111
45647, 0.89130434782609, 0.51521739130435, 0.38888888888889
45648, 0.8695652173913, 0.48913043478261, 0.38888888888889
45649, 0.8695652173913, 0.51521739130435, 0.41666666666667
45650, 0.89130434782609, 0.51521739130435, 0.44444444444444
45651, 0.8695652173913, 0.48913043478261, 0.44444444444444
45652, 0.8695652173913, 0.51521739130435, 0.47222222222222
45653, 0.82608695652174, 0.51521739130435, 0.027777777777778
45654, 0.84782608695652, 0.51521739130435, 0.055555555555556
45655, 0.82608695652174, 0.48913043478261, 0.055555555555556
45656, 0.82608695652174, 0.51521739130435, 0.083333333333333
45657, 0.84782608695652, 0.51521739130435, 0.11111111111111
45658, 0.82608695652174, 0.48913043478261, 0.11111111111111
45659, 0.82608695652174, 0.51521739130435, 0.13888888888889
45660, 0.84782608695652, 0.51521739130435, 0.16666666666667
45661, 0.82608695652174, 0.48913043478261, 0.16666666666667
45662, 0.82608695652174, 0.51521739130435, 0.19444444444444
45663, 0.84782608695652, 0.51521739130435, 0.22222222222222
45664, 0.82608695652174, 0.48913043478261, 0.22222222222222
45665, 0.82608695652174, 0.51521739130435, 0.25
45666, 0.84782608695652, 0.51521739130435, 0.27777777777778
45667, 0.82608695652174, 0.48913043478261, 0.27777777777778
45668, 0.82608695652174, 0.51521739130435, 0.30555555555556
45669, 0.84782608695652, 0.51521739130435, 0.33333333333333
45670, 0.82608695652174, 0.48913043478261, 0.33333333333333
45671, 0.82608695652174, 0.51521739130435, 0.36111111111111
45672, 0.84782608695652, 0.51521739130435, 0.38888888888889
45673, 0.82608695652174, 0.48913043478261, 0.38888888888889
45674, 0.82608695652174, 0.51521739130435, 0.41666666666667
45675, 0.84782608695652, 0.51521739130435, 0.44444444444444
45676, 0.82608695652174, 0.48913043478261, 0.44444444444444
45677, 0.82608695652174, 0.51521739130435, 0.47222222222222
45678, 0.78260869565217, 0.51521739130435, 0.027777777777778
45679, 0.80434782608696, 0.51521739130435, 0.055555555555556
45680, 0.78260869565217, 0.48913043478261, 0.055555555555556
45681, 0.78260869565217, 0.51521739130435, 0.083333333333333
45682, 0.80434782608696, 0.51521739130435, 0.11111111111111
45683, 0.78260869565217, 0.48913043478261, 0.11111111111111
45684, 0.78260869565217, 0.51521739130435, 0.13888888888889
45685, 0.80434782608696, 0.51521739130435, 0.16666666666667
45686, 0.78260869565217, 0.48913043478261, 0.16666666666667
45687, 0.78260869565217, 0.51521739130435, 0.19444444444444
45688, 0.80434782608696, 0.51521739130435, 0.22222222222222
45689, 0.78260869565217, 0.48913043478261, 0.22222222222222
45690, 0.78260869565217, 0.51521739130435, 0.25
45691, 0.80434782608696, 0.51521739130435, 0.27777777777778
45692, 0.78260869565217, 0.48913043478261, 0.27777777777778
45693, 0.78260869565217, 0.51521739130435, 0.30555555555556
45694, 0.80434782608696, 0.51521739130435, 0.33333333333333
45695, 0.78260869565217, 0.48913043478261, 0.33333333333333
45696, 0.78260869565217, 0.51521739130435, 0.36111111111111
45697, 0.80434782608696, 0.51521739130435, 0.38888888888889
45698, 0.78260869565217, 0.48913043478261, 0.38888888888889
45699, 0.78260869565217, 0.51521739130435, 0.41666666666667
45700, 0.80434782608696, 0.51521739130435, 0.44444444444444
45701, 0.78260869565217, 0.48913043478261, 0.44444444444444
45702, 0.78260869565217, 0.51521739130435, 0.47222222222222
45703, 0.73913043478261, 0.51521739130435, 0.027777777777778
45704, 0.76086956521739, 0.51521739130435, 0.055555555555556
45705, 0.73913043478261, 0.48913043478261, 0.055555555555556
45706, 0.73913043478261, 0.51521739130435, 0.083333333333333
45707, 0.76086956521739, 0.51521739130435, 0.11111111111111
45708, 0.73913043478261, 0.48913043478261, 0.11111111111111
45709, 0.73913043478261, 0.51521739130435, 0.13888888888889
45710, 0.76086956521739, 0.51521739130435, 0.16666666666667
45711, 0.73913043478261, 0.48913043478261, 0.16666666666667
45712, 0.73913043478261, 0.51521739130435, 0.19444444444444
45713, 0.76086956521739, 0.51521739130435, 0.22222222222222
45714, 0.73913043478261, 0.48913043478261, 0.22222222222222
45715, 0.73913043478261, 0.51521739130435, 0.25
45716, 0.76086956521739, 0.51521739130435, 0.27777777777778
45717, 0.73913043478261, 0.48913043478261, 0.27777777777778
45718, 0.73913043478261, 0.51521739130435, 0.30555555555556
45719, 0.76086956521739, 0.51521739130435, 0.33333333333333
45720, 0.73913043478261, 0.48913043478261, 0.33333333333333
45721, 0.73913043478261, 0.51521739130435, 0.36111111111111
45722, 0.76086956521739, 0.51521739130435, 0.38888888888889
45723, 0.73913043478261, 0.48913043478261, 0.38888888888889
45724, 0.73913043478261, 0.51521739130435, 0.41666666666667
45725, 0.76086956521739, 0.51521739130435, 0.44444444444444
45726, 0.73913043478261, 0.48913043478261, 0.44444444444444
45727, 0.73913043478261, 0.51521739130435, 0.47222222222222
45728, 0.69565217391304, 0.51521739130435, 0.027777777777778
45729, 0.71739130434783, 0.51521739130435, 0.055555555555556
45730, 0.69565217391304, 0.48913043478261, 0.055555555555556
45731, 0.69565217391304, 0.51521739130435, 0.083333333333333
45732, 0.71739130434783, 0.51521739130435, 0.11111111111111
45733, 0.69565217391304, 0.48913043478261, 0.11111111111111
45734, 0.69565217391304, 0.51521739130435, 0.13888888888889
45735, 0.71739130434783, 0.51521739130435, 0.16666666666667
45736, 0.69565217391304, 0.48913043478261, 0.16666666666667
45737, 0.69565217391304, 0.51521739130435, 0.19444444444444
45738, 0.71739130434783, 0.51521739130435, 0.22222222222222
45739, 0.69565217391304, 0.48913043478261, 0.22222222222222
45740, 0.69565217391304, 0.51521739130435, 0.25
45741, 0.71739130434783, 0.51521739130435, 0.27777777777778
45742, 0.69565217391304, 0.48913043478261, 0.27777777777778
45743, 0.69565217391304, 0.51521739130435, 0.30555555555556
45744, 0.71739130434783, 0.51521739130435, 0.33333333333333
45745, 0.69565217391304, 0.48913043478261, 0.33333333333333
45746, 0.69565217391304, 0.51521739130435, 0.36111111111111
45747, 0.71739130434783, 0.51521739130435, 0.38888888888889
45748, 0.69565217391304, 0.48913043478261, 0.38888888888889
45749, 0.69565217391304, 0.51521739130435, 0.41666666666667
45750, 0.71739130434783, 0.51521739130435, 0.44444444444444
45751, 0.69565217391304, 0.48913043478261, 0.44444444444444
45752, 0.69565217391304, 0.51521739130435, 0.47222222222222
45753, 0.65217391304348, 0.51521739130435, 0.027777777777778
45754, 0.67391304347826, 0.51521739130435, 0.055555555555556
45755, 0.65217391304348, 0.48913043478261, 0.055555555555556
45756, 0.65217391304348, 0.51521739130435, 0.083333333333333
45757, 0.67391304347826, 0.51521739130435, 0.11111111111111
45758, 0.65217391304348, 0.48913043478261, 0.11111111111111
45759, 0.65217391304348, 0.51521739130435, 0.13888888888889
45760, 0.67391304347826, 0.51521739130435, 0.16666666666667
45761, 0.65217391304348, 0.48913043478261, 0.16666666666667
45762, 0.65217391304348, 0.51521739130435, 0.19444444444444
45763, 0.67391304347826, 0.51521739130435, 0.22222222222222
45764, 0.65217391304348, 0.48913043478261, 0.22222222222222
45765, 0.65217391304348, 0.51521739130435, 0.25
45766, 0.67391304347826, 0.51521739130435, 0.27777777777778
45767, 0.65217391304348, 0.48913043478261, 0.27777777777778
45768, 0.65217391304348, 0.51521739130435, 0.30555555555556
45769, 0.67391304347826, 0.51521739130435, 0.33333333333333
45770, 0.65217391304348, 0.48913043478261, 0.33333333333333
45771, 0.65217391304348, 0.51521739130435, 0.36111111111111
45772, 0.67391304347826, 0.51521739130435, 0.38888888888889
45773, 0.65217391304348, 0.48913043478261, 0.38888888888889
45774, 0.65217391304348, 0.51521739130435, 0.41666666666667
45775, 0.67391304347826, 0.51521739130435, 0.44444444444444
45776, 0.65217391304348, 0.48913043478261, 0.44444444444444
45777, 0.65217391304348, 0.51521739130435, 0.47222222222222
45778, 0.60869565217391, 0.51521739130435, 0.027777777777778
45779, 0.6304347826087, 0.51521739130435, 0.055555555555556
45780, 0.60869565217391, 0.48913043478261, 0.055555555555556
45781, 0.60869565217391, 0.51521739130435, 0.083333333333333
45782, 0.6304347826087, 0.51521739130435, 0.11111111111111
45783, 0.60869565217391, 0.48913043478261, 0.11111111111111
45784, 0.60869565217391, 0.51521739130435, 0.13888888888889
45785, 0.6304347826087, 0.51521739130435, 0.16666666666667
45786, 0.60869565217391, 0.48913043478261, 0.16666666666667
45787, 0.60869565217391, 0.51521739130435, 0.19444444444444
45788, 0.6304347826087, 0.51521739130435, 0.22222222222222
45789, 0.60869565217391, 0.48913043478261, 0.22222222222222
45790, 0.60869565217391, 0.51521739130435, 0.25
45791, 0.6304347826087, 0.51521739130435, 0.27777777777778
45792, 0.60869565217391, 0.48913043478261, 0.27777777777778
45793, 0.60869565217391, 0.51521739130435, 0.30555555555556
45794, 0.6304347826087, 0.51521739130435, 0.33333333333333
45795, 0.60869565217391, 0.48913043478261, 0.33333333333333
45796, 0.60869565217391, 0.51521739130435, 0.36111111111111
45797, 0.6304347826087, 0.51521739130435, 0.38888888888889
45798, 0.60869565217391, 0.48913043478261, 0.38888888888889
45799, 0.60869565217391, 0.51521739130435, 0.41666666666667
45800, 0.6304347826087, 0.51521739130435, 0.44444444444444
45801, 0.60869565217391, 0.48913043478261, 0.44444444444444
45802, 0.60869565217391, 0.51521739130435, 0.47222222222222
45803, 0.56521739130435, 0.51521739130435, 0.027777777777778
45804, 0.58695652173913, 0.51521739130435, 0.055555555555556
45805, 0.56521739130435, 0.48913043478261, 0.055555555555556
45806, 0.56521739130435, 0.51521739130435, 0.083333333333333
45807, 0.58695652173913, 0.51521739130435, 0.11111111111111
45808, 0.56521739130435, 0.48913043478261, 0.11111111111111
45809, 0.56521739130435, 0.51521739130435, 0.13888888888889
45810, 0.58695652173913, 0.51521739130435, 0.16666666666667
45811, 0.56521739130435, 0.48913043478261, 0.16666666666667
45812, 0.56521739130435, 0.51521739130435, 0.19444444444444
45813, 0.58695652173913, 0.51521739130435, 0.22222222222222
45814, 0.56521739130435, 0.48913043478261, 0.22222222222222
45815, 0.56521739130435, 0.51521739130435, 0.25
45816, 0.58695652173913, 0.51521739130435, 0.27777777777778
45817, 0.56521739130435, 0.48913043478261, 0.27777777777778
45818, 0.56521739130435, 0.51521739130435, 0.30555555555556
45819, 0.58695652173913, 0.51521739130435, 0.33333333333333
45820, 0.56521739130435, 0.48913043478261, 0.33333333333333
45821, 0.56521739130435, 0.51521739130435, 0.36111111111111
45822, 0.58695652173913, 0.51521739130435, 0.38888888888889
45823, 0.56521739130435, 0.48913043478261, 0.38888888888889
45824, 0.56521739130435, 0.51521739130435, 0.41666666666667
45825, 0.58695652173913, 0.51521739130435, 0.44444444444444
45826, 0.56521739130435, 0.48913043478261, 0.44444444444444
45827, 0.56521739130435, 0.51521739130435, 0.47222222222222
45828, 0.52173913043478, 0.51521739130435, 0.027777777777778
45829, 0.54347826086956, 0.51521739130435, 0.055555555555556
45830, 0.52173913043478, 0.48913043478261, 0.055555555555556
45831, 0.52173913043478, 0.51521739130435, 0.083333333333333
45832, 0.54347826086956, 0.51521739130435, 0.11111111111111
45833, 0.52173913043478, 0.48913043478261, 0.11111111111111
45834, 0.52173913043478, 0.51521739130435, 0.13888888888889
45835, 0.54347826086956, 0.51521739130435, 0.16666666666667
45836, 0.52173913043478, 0.48913043478261, 0.16666666666667
45837, 0.52173913043478, 0.51521739130435, 0.19444444444444
45838, 0.54347826086956, 0.51521739130435, 0.22222222222222
45839, 0.52173913043478, 0.48913043478261, 0.22222222222222
45840, 0.52173913043478, 0.51521739130435, 0.25
45841, 0.54347826086956, 0.51521739130435, 0.27777777777778
45842, 0.52173913043478, 0.48913043478261, 0.27777777777778
45843, 0.52173913043478, 0.51521739130435, 0.30555555555556
45844, 0.54347826086956, 0.51521739130435, 0.33333333333333
45845, 0.52173913043478, 0.48913043478261, 0.33333333333333
45846, 0.52173913043478, 0.51521739130435, 0.36111111111111
45847, 0.54347826086956, 0.51521739130435, 0.38888888888889
45848, 0.52173913043478, 0.48913043478261, 0.38888888888889
45849, 0.52173913043478, 0.51521739130435, 0.41666666666667
45850, 0.54347826086956, 0.51521739130435, 0.44444444444444
45851, 0.52173913043478, 0.48913043478261, 0.44444444444444
45852, 0.52173913043478, 0.51521739130435, 0.47222222222222
45853, 0.47826086956522, 0.51521739130435, 0.027777777777778
45854, 0.5, 0.51521739130435, 0.055555555555556
45855, 0.47826086956522, 0.48913043478261, 0.055555555555556
45856, 0.47826086956522, 0.51521739130435, 0.083333333333333
45857, 0.5, 0.51521739130435, 0.11111111111111
45858, 0.47826086956522, 0.48913043478261, 0.11111111111111
45859, 0.47826086956522, 0.51521739130435, 0.13888888888889
45860, 0.5, 0.51521739130435, 0.16666666666667
45861, 0.47826086956522, 0.48913043478261, 0.16666666666667
45862, 0.47826086956522, 0.51521739130435, 0.19444444444444
45863, 0.5, 0.51521739130435, 0.22222222222222
45864, 0.47826086956522, 0.48913043478261, 0.22222222222222
45865, 0.47826086956522, 0.51521739130435, 0.25
45866, 0.5, 0.51521739130435, 0.27777777777778
45867, 0.47826086956522, 0.48913043478261, 0.27777777777778
45868, 0.47826086956522, 0.51521739130435, 0.30555555555556
45869, 0.5, 0.51521739130435, 0.33333333333333
45870, 0.47826086956522, 0.48913043478261, 0.33333333333333
45871, 0.47826086956522, 0.51521739130435, 0.36111111111111
45872, 0.5, 0.51521739130435, 0.38888888888889
45873, 0.47826086956522, 0.48913043478261, 0.38888888888889
45874, 0.47826086956522, 0.51521739130435, 0.41666666666667
45875, 0.5, 0.51521739130435, 0.44444444444444
45876, 0.47826086956522, 0.48913043478261, 0.44444444444444
45877, 0.47826086956522, 0.51521739130435, 0.47222222222222
45878, 0.43478260869565, 0.51521739130435, 0.027777777777778
45879, 0.45652173913043, 0.51521739130435, 0.055555555555556
45880, 0.43478260869565, 0.48913043478261, 0.055555555555556
45881, 0.43478260869565, 0.51521739130435, 0.083333333333333
45882, 0.45652173913044, 0.51521739130435, 0.11111111111111
45883, 0.43478260869565, 0.48913043478261, 0.11111111111111
45884, 0.43478260869565, 0.51521739130435, 0.13888888888889
45885, 0.45652173913043, 0.51521739130435, 0.16666666666667
45886, 0.43478260869565, 0.48913043478261, 0.16666666666667
45887, 0.43478260869565, 0.51521739130435, 0.19444444444444
45888, 0.45652173913043, 0.51521739130435, 0.22222222222222
45889, 0.43478260869565, 0.48913043478261, 0.22222222222222
45890, 0.43478260869565, 0.51521739130435, 0.25
45891, 0.45652173913043, 0.51521739130435, 0.27777777777778
45892, 0.43478260869565, 0.48913043478261, 0.27777777777778
45893, 0.43478260869565, 0.51521739130435, 0.30555555555556
45894, 0.45652173913043, 0.51521739130435, 0.33333333333333
45895, 0.43478260869565, 0.48913043478261, 0.33333333333333
45896, 0.43478260869565, 0.51521739130435, 0.36111111111111
45897, 0.45652173913044, 0.51521739130435, 0.38888888888889
45898, 0.43478260869565, 0.48913043478261, 0.38888888888889
45899, 0.43478260869565, 0.51521739130435, 0.41666666666667
45900, 0.45652173913043, 0.51521739130435, 0.44444444444444
45901, 0.43478260869565, 0.48913043478261, 0.44444444444444
45902, 0.43478260869565, 0.51521739130435, 0.47222222222222
45903, 0.39130434782609, 0.51521739130435, 0.027777777777778
45904, 0.41304347826087, 0.51521739130435, 0.055555555555556
45905, 0.39130434782609, 0.48913043478261, 0.055555555555556
45906, 0.39130434782609, 0.51521739130435, 0.083333333333333
45907, 0.41304347826087, 0.51521739130435, 0.11111111111111
45908, 0.39130434782609, 0.48913043478261, 0.11111111111111
45909, 0.39130434782609, 0.51521739130435, 0.13888888888889
45910, 0.41304347826087, 0.51521739130435, 0.16666666666667
45911, 0.39130434782609, 0.48913043478261, 0.16666666666667
45912, 0.39130434782609, 0.51521739130435, 0.19444444444444
45913, 0.41304347826087, 0.51521739130435, 0.22222222222222
45914, 0.39130434782609, 0.48913043478261, 0.22222222222222
45915, 0.39130434782609, 0.51521739130435, 0.25
45916, 0.41304347826087, 0.51521739130435, 0.27777777777778
45917, 0.39130434782609, 0.48913043478261, 0.27777777777778
45918, 0.39130434782609, 0.51521739130435, 0.30555555555556
45919, 0.41304347826087, 0.51521739130435, 0.33333333333333
45920, 0.39130434782609, 0.48913043478261, 0.33333333333333
45921, 0.39130434782609, 0.51521739130435, 0.36111111111111
45922, 0.41304347826087, 0.51521739130435, 0.38888888888889
45923, 0.39130434782609, 0.48913043478261, 0.38888888888889
45924, 0.39130434782609, 0.51521739130435, 0.41666666666667
45925, 0.41304347826087, 0.51521739130435, 0.44444444444444
45926, 0.39130434782609, 0.48913043478261, 0.44444444444444
45927, 0.39130434782609, 0.51521739130435, 0.47222222222222
45928, 0.34782608695652, 0.51521739130435, 0.027777777777778
45929, 0.3695652173913, 0.51521739130435, 0.055555555555556
45930, 0.34782608695652, 0.48913043478261, 0.055555555555556
45931, 0.34782608695652, 0.51521739130435, 0.083333333333333
45932, 0.3695652173913, 0.51521739130435, 0.11111111111111
45933, 0.34782608695652, 0.48913043478261, 0.11111111111111
45934, 0.34782608695652, 0.51521739130435, 0.13888888888889
45935, 0.3695652173913, 0.51521739130435, 0.16666666666667
45936, 0.34782608695652, 0.48913043478261, 0.16666666666667
45937, 0.34782608695652, 0.51521739130435, 0.19444444444444
45938, 0.3695652173913, 0.51521739130435, 0.22222222222222
45939, 0.34782608695652, 0.48913043478261, 0.22222222222222
45940, 0.34782608695652, 0.51521739130435, 0.25
45941, 0.3695652173913, 0.51521739130435, 0.27777777777778
45942, 0.34782608695652, 0.48913043478261, 0.27777777777778
45943, 0.34782608695652, 0.51521739130435, 0.30555555555556
45944, 0.3695652173913, 0.51521739130435, 0.33333333333333
45945, 0.34782608695652, 0.48913043478261, 0.33333333333333
45946, 0.34782608695652, 0.51521739130435, 0.36111111111111
45947, 0.3695652173913, 0.51521739130435, 0.38888888888889
45948, 0.34782608695652, 0.48913043478261, 0.38888888888889
45949, 0.34782608695652, 0.51521739130435, 0.41666666666667
45950, 0.3695652173913, 0.51521739130435, 0.44444444444444
45951, 0.34782608695652, 0.48913043478261, 0.44444444444444
45952, 0.34782608695652, 0.51521739130435, 0.47222222222222
45953, 0.30434782608696, 0.51521739130435, 0.027777777777778
45954, 0.32608695652174, 0.51521739130435, 0.055555555555556
45955, 0.30434782608696, 0.48913043478261, 0.055555555555556
45956, 0.30434782608696, 0.51521739130435, 0.083333333333333
45957, 0.32608695652174, 0.51521739130435, 0.11111111111111
45958, 0.30434782608696, 0.48913043478261, 0.11111111111111
45959, 0.30434782608696, 0.51521739130435, 0.13888888888889
45960, 0.32608695652174, 0.51521739130435, 0.16666666666667
45961, 0.30434782608696, 0.48913043478261, 0.16666666666667
45962, 0.30434782608696, 0.51521739130435, 0.19444444444444
45963, 0.32608695652174, 0.51521739130435, 0.22222222222222
45964, 0.30434782608696, 0.48913043478261, 0.22222222222222
45965, 0.30434782608696, 0.51521739130435, 0.25
45966, 0.32608695652174, 0.51521739130435, 0.27777777777778
45967, 0.30434782608696, 0.48913043478261, 0.27777777777778
45968, 0.30434782608696, 0.51521739130435, 0.30555555555556
45969, 0.32608695652174, 0.51521739130435, 0.33333333333333
45970, 0.30434782608696, 0.48913043478261, 0.33333333333333
45971, 0.30434782608696, 0.51521739130435, 0.36111111111111
45972, 0.32608695652174, 0.51521739130435, 0.38888888888889
45973, 0.30434782608696, 0.48913043478261, 0.38888888888889
45974, 0.30434782608696, 0.51521739130435, 0.41666666666667
45975, 0.32608695652174, 0.51521739130435, 0.44444444444444
45976, 0.30434782608696, 0.48913043478261, 0.44444444444444
45977, 0.30434782608696, 0.51521739130435, 0.47222222222222
45978, 0.26086956521739, 0.51521739130435, 0.027777777777778
45979, 0.28260869565217, 0.51521739130435, 0.055555555555556
45980, 0.26086956521739, 0.48913043478261, 0.055555555555556
45981, 0.26086956521739, 0.51521739130435, 0.083333333333333
45982, 0.28260869565217, 0.51521739130435, 0.11111111111111
45983, 0.26086956521739, 0.48913043478261, 0.11111111111111
45984, 0.26086956521739, 0.51521739130435, 0.13888888888889
45985, 0.28260869565217, 0.51521739130435, 0.16666666666667
45986, 0.26086956521739, 0.48913043478261, 0.16666666666667
45987, 0.26086956521739, 0.51521739130435, 0.19444444444444
45988, 0.28260869565217, 0.51521739130435, 0.22222222222222
45989, 0.26086956521739, 0.48913043478261, 0.22222222222222
45990, 0.26086956521739, 0.51521739130435, 0.25
45991, 0.28260869565217, 0.51521739130435, 0.27777777777778
45992, 0.26086956521739, 0.48913043478261, 0.27777777777778
45993, 0.26086956521739, 0.51521739130435, 0.30555555555556
45994, 0.28260869565217, 0.51521739130435, 0.33333333333333
45995, 0.26086956521739, 0.48913043478261, 0.33333333333333
45996, 0.26086956521739, 0.51521739130435, 0.36111111111111
45997, 0.28260869565217, 0.51521739130435, 0.38888888888889
45998, 0.26086956521739, 0.48913043478261, 0.38888888888889
45999, 0.26086956521739, 0.51521739130435, 0.41666666666667
46000, 0.28260869565217, 0.51521739130435, 0.44444444444444
46001, 0.26086956521739, 0.48913043478261, 0.44444444444444
46002, 0.26086956521739, 0.51521739130435, 0.47222222222222
46003, 0.21739130434783, 0.51521739130435, 0.027777777777778
46004, 0.23913043478261, 0.51521739130435, 0.055555555555556
46005, 0.21739130434783, 0.48913043478261, 0.055555555555556
46006, 0.21739130434783, 0.51521739130435, 0.083333333333333
46007, 0.23913043478261, 0.51521739130435, 0.11111111111111
46008, 0.21739130434783, 0.48913043478261, 0.11111111111111
46009, 0.21739130434783, 0.51521739130435, 0.13888888888889
46010, 0.23913043478261, 0.51521739130435, 0.16666666666667
46011, 0.21739130434783, 0.48913043478261, 0.16666666666667
46012, 0.21739130434783, 0.51521739130435, 0.19444444444444
46013, 0.23913043478261, 0.51521739130435, 0.22222222222222
46014, 0.21739130434783, 0.48913043478261, 0.22222222222222
46015, 0.21739130434783, 0.51521739130435, 0.25
46016, 0.23913043478261, 0.51521739130435, 0.27777777777778
46017, 0.21739130434783, 0.48913043478261, 0.27777777777778
46018, 0.21739130434783, 0.51521739130435, 0.30555555555556
46019, 0.23913043478261, 0.51521739130435, 0.33333333333333
46020, 0.21739130434783, 0.48913043478261, 0.33333333333333
46021, 0.21739130434783, 0.51521739130435, 0.36111111111111
46022, 0.23913043478261, 0.51521739130435, 0.38888888888889
46023, 0.21739130434783, 0.48913043478261, 0.38888888888889
46024, 0.21739130434783, 0.51521739130435, 0.41666666666667
46025, 0.23913043478261, 0.51521739130435, 0.44444444444444
46026, 0.21739130434783, 0.48913043478261, 0.44444444444444
46027, 0.21739130434783, 0.51521739130435, 0.47222222222222
46028, 0.17391304347826, 0.51521739130435, 0.027777777777778
46029, 0.19565217391304, 0.51521739130435, 0.055555555555556
46030, 0.17391304347826, 0.48913043478261, 0.055555555555556
46031, 0.17391304347826, 0.51521739130435, 0.083333333333333
46032, 0.19565217391304, 0.51521739130435, 0.11111111111111
46033, 0.17391304347826, 0.48913043478261, 0.11111111111111
46034, 0.17391304347826, 0.51521739130435, 0.13888888888889
46035, 0.19565217391304, 0.51521739130435, 0.16666666666667
46036, 0.17391304347826, 0.48913043478261, 0.16666666666667
46037, 0.17391304347826, 0.51521739130435, 0.19444444444444
46038, 0.19565217391304, 0.51521739130435, 0.22222222222222
46039, 0.17391304347826, 0.48913043478261, 0.22222222222222
46040, 0.17391304347826, 0.51521739130435, 0.25
46041, 0.19565217391304, 0.51521739130435, 0.27777777777778
46042, 0.17391304347826, 0.48913043478261, 0.27777777777778
46043, 0.17391304347826, 0.51521739130435, 0.30555555555556
46044, 0.19565217391304, 0.51521739130435, 0.33333333333333
46045, 0.17391304347826, 0.48913043478261, 0.33333333333333
46046, 0.17391304347826, 0.51521739130435, 0.36111111111111
46047, 0.19565217391304, 0.51521739130435, 0.38888888888889
46048, 0.17391304347826, 0.48913043478261, 0.38888888888889
46049, 0.17391304347826, 0.51521739130435, 0.41666666666667
46050, 0.19565217391304, 0.51521739130435, 0.44444444444444
46051, 0.17391304347826, 0.48913043478261, 0.44444444444444
46052, 0.17391304347826, 0.51521739130435, 0.47222222222222
46053, 0.1304347826087, 0.51521739130435, 0.027777777777778
46054, 0.15217391304348, 0.51521739130435, 0.055555555555556
46055, 0.1304347826087, 0.48913043478261, 0.055555555555556
46056, 0.1304347826087, 0.51521739130435, 0.083333333333333
46057, 0.15217391304348, 0.51521739130435, 0.11111111111111
46058, 0.1304347826087, 0.48913043478261, 0.11111111111111
46059, 0.1304347826087, 0.51521739130435, 0.13888888888889
46060, 0.15217391304348, 0.51521739130435, 0.16666666666667
46061, 0.1304347826087, 0.48913043478261, 0.16666666666667
46062, 0.1304347826087, 0.51521739130435, 0.19444444444444
46063, 0.15217391304348, 0.51521739130435, 0.22222222222222
46064, 0.1304347826087, 0.48913043478261, 0.22222222222222
46065, 0.1304347826087, 0.51521739130435, 0.25
46066, 0.15217391304348, 0.51521739130435, 0.27777777777778
46067, 0.1304347826087, 0.48913043478261, 0.27777777777778
46068, 0.1304347826087, 0.51521739130435, 0.30555555555556
46069, 0.15217391304348, 0.51521739130435, 0.33333333333333
46070, 0.1304347826087, 0.48913043478261, 0.33333333333333
46071, 0.1304347826087, 0.51521739130435, 0.36111111111111
46072, 0.15217391304348, 0.51521739130435, 0.38888888888889
46073, 0.1304347826087, 0.48913043478261, 0.38888888888889
46074, 0.1304347826087, 0.51521739130435, 0.41666666666667
46075, 0.15217391304348, 0.51521739130435, 0.44444444444444
46076, 0.1304347826087, 0.48913043478261, 0.44444444444444
46077, 0.1304347826087, 0.51521739130435, 0.47222222222222
46078, 0.08695652173913, 0.51521739130435, 0.027777777777778
46079, 0.10869565217391, 0.51521739130435, 0.055555555555556
46080, 0.08695652173913, 0.48913043478261, 0.055555555555556
46081, 0.08695652173913, 0.51521739130435, 0.083333333333333
46082, 0.10869565217391, 0.51521739130435, 0.11111111111111
46083, 0.08695652173913, 0.48913043478261, 0.11111111111111
46084, 0.08695652173913, 0.51521739130435, 0.13888888888889
46085, 0.10869565217391, 0.51521739130435, 0.16666666666667
46086, 0.08695652173913, 0.48913043478261, 0.16666666666667
46087, 0.08695652173913, 0.51521739130435, 0.19444444444444
46088, 0.10869565217391, 0.51521739130435, 0.22222222222222
46089, 0.08695652173913, 0.48913043478261, 0.22222222222222
46090, 0.08695652173913, 0.51521739130435, 0.25
46091, 0.10869565217391, 0.51521739130435, 0.27777777777778
46092, 0.08695652173913, 0.48913043478261, 0.27777777777778
46093, 0.08695652173913, 0.51521739130435, 0.30555555555556
46094, 0.10869565217391, 0.51521739130435, 0.33333333333333
46095, 0.08695652173913, 0.48913043478261, 0.33333333333333
46096, 0.08695652173913, 0.51521739130435, 0.36111111111111
