68801, 1.9826086956522, 0.8804347826087, 0.25
68802, 1.9608695652174, 0.8804347826087, 0.22222222222222
68803, 1.9826086956522, 0.90652173913044, 0.22222222222222
68804, 1.9826086956522, 0.8804347826087, 0.19444444444444
68805, 1.9608695652174, 0.8804347826087, 0.16666666666667
68806, 1.9826086956522, 0.90652173913044, 0.16666666666667
68807, 1.9826086956522, 0.8804347826087, 0.13888888888889
68808, 1.9608695652174, 0.8804347826087, 0.11111111111111
68809, 1.9826086956522, 0.90652173913044, 0.11111111111111
68810, 1.9826086956522, 0.8804347826087, 0.083333333333333
68811, 1.9608695652174, 0.8804347826087, 0.055555555555556
68812, 1.9826086956522, 0.90652173913044, 0.055555555555556
68813, 1.9826086956522, 0.8804347826087, 0.027777777777778
68814, 2.0260869565217, 0.8804347826087, 0.47222222222222
68815, 2.004347826087, 0.8804347826087, 0.44444444444444
68816, 2.0260869565217, 0.90652173913044, 0.44444444444444
68817, 2.0260869565217, 0.8804347826087, 0.41666666666667
68818, 2.004347826087, 0.8804347826087, 0.38888888888889
68819, 2.0260869565217, 0.90652173913044, 0.38888888888889
68820, 2.0260869565217, 0.8804347826087, 0.36111111111111
68821, 2.004347826087, 0.8804347826087, 0.33333333333333
68822, 2.0260869565217, 0.90652173913044, 0.33333333333333
68823, 2.0260869565217, 0.8804347826087, 0.30555555555556
68824, 2.004347826087, 0.8804347826087, 0.27777777777778
68825, 2.0260869565217, 0.90652173913044, 0.27777777777778
68826, 2.0260869565217, 0.8804347826087, 0.25
68827, 2.004347826087, 0.8804347826087, 0.22222222222222
68828, 2.0260869565217, 0.90652173913044, 0.22222222222222
68829, 2.0260869565217, 0.8804347826087, 0.19444444444444
68830, 2.004347826087, 0.8804347826087, 0.16666666666667
68831, 2.0260869565217, 0.90652173913044, 0.16666666666667
68832, 2.0260869565217, 0.8804347826087, 0.13888888888889
68833, 2.004347826087, 0.8804347826087, 0.11111111111111
68834, 2.0260869565217, 0.90652173913044, 0.11111111111111
68835, 2.0260869565217, 0.8804347826087, 0.083333333333333
68836, 2.004347826087, 0.8804347826087, 0.055555555555556
68837, 2.0260869565217, 0.90652173913044, 0.055555555555556
68838, 2.0260869565217, 0.8804347826087, 0.027777777777778
68839, 2.0695652173913, 0.8804347826087, 0.47222222222222
68840, 2.0478260869565, 0.8804347826087, 0.44444444444444
68841, 2.0695652173913, 0.90652173913044, 0.44444444444444
68842, 2.0695652173913, 0.8804347826087, 0.41666666666667
68843, 2.0478260869565, 0.8804347826087, 0.38888888888889
68844, 2.0695652173913, 0.90652173913044, 0.38888888888889
68845, 2.0695652173913, 0.8804347826087, 0.36111111111111
68846, 2.0478260869565, 0.8804347826087, 0.33333333333333
68847, 2.0695652173913, 0.90652173913044, 0.33333333333333
68848, 2.0695652173913, 0.8804347826087, 0.30555555555556
68849, 2.0478260869565, 0.8804347826087, 0.27777777777778
68850, 2.0695652173913, 0.90652173913044, 0.27777777777778
68851, 2.0695652173913, 0.8804347826087, 0.25
68852, 2.0478260869565, 0.8804347826087, 0.22222222222222
68853, 2.0695652173913, 0.90652173913044, 0.22222222222222
68854, 2.0695652173913, 0.8804347826087, 0.19444444444444
68855, 2.0478260869565, 0.8804347826087, 0.16666666666667
68856, 2.0695652173913, 0.90652173913044, 0.16666666666667
68857, 2.0695652173913, 0.8804347826087, 0.13888888888889
68858, 2.0478260869565, 0.8804347826087, 0.11111111111111
68859, 2.0695652173913, 0.90652173913044, 0.11111111111111
68860, 2.0695652173913, 0.8804347826087, 0.083333333333333
68861, 2.0478260869565, 0.8804347826087, 0.055555555555556
68862, 2.0695652173913, 0.90652173913044, 0.055555555555556
68863, 2.0695652173913, 0.8804347826087, 0.027777777777778
68864, 2.1130434782609, 0.8804347826087, 0.47222222222222
68865, 2.0913043478261, 0.8804347826087, 0.44444444444444
68866, 2.1130434782609, 0.90652173913044, 0.44444444444444
68867, 2.1130434782609, 0.8804347826087, 0.41666666666667
68868, 2.0913043478261, 0.8804347826087, 0.38888888888889
68869, 2.1130434782609, 0.90652173913044, 0.38888888888889
68870, 2.1130434782609, 0.8804347826087, 0.36111111111111
68871, 2.0913043478261, 0.8804347826087, 0.33333333333333
68872, 2.1130434782609, 0.90652173913044, 0.33333333333333
68873, 2.1130434782609, 0.8804347826087, 0.30555555555556
68874, 2.0913043478261, 0.8804347826087, 0.27777777777778
68875, 2.1130434782609, 0.90652173913044, 0.27777777777778
68876, 2.1130434782609, 0.8804347826087, 0.25
68877, 2.0913043478261, 0.8804347826087, 0.22222222222222
68878, 2.1130434782609, 0.90652173913044, 0.22222222222222
68879, 2.1130434782609, 0.8804347826087, 0.19444444444444
68880, 2.0913043478261, 0.8804347826087, 0.16666666666667
68881, 2.1130434782609, 0.90652173913044, 0.16666666666667
68882, 2.1130434782609, 0.8804347826087, 0.13888888888889
68883, 2.0913043478261, 0.8804347826087, 0.11111111111111
68884, 2.1130434782609, 0.90652173913044, 0.11111111111111
68885, 2.1130434782609, 0.8804347826087, 0.083333333333333
68886, 2.0913043478261, 0.8804347826087, 0.055555555555556
68887, 2.1130434782609, 0.90652173913044, 0.055555555555556
68888, 2.1130434782609, 0.8804347826087, 0.027777777777778
68889, 2.1565217391304, 0.8804347826087, 0.47222222222222
68890, 2.1347826086957, 0.8804347826087, 0.44444444444444
68891, 2.1565217391304, 0.90652173913044, 0.44444444444444
68892, 2.1565217391304, 0.8804347826087, 0.41666666666667
68893, 2.1347826086957, 0.8804347826087, 0.38888888888889
68894, 2.1565217391304, 0.90652173913044, 0.38888888888889
68895, 2.1565217391304, 0.8804347826087, 0.36111111111111
68896, 2.1347826086957, 0.8804347826087, 0.33333333333333
68897, 2.1565217391304, 0.90652173913044, 0.33333333333333
68898, 2.1565217391304, 0.8804347826087, 0.30555555555556
68899, 2.1347826086957, 0.8804347826087, 0.27777777777778
68900, 2.1565217391304, 0.90652173913044, 0.27777777777778
68901, 2.1565217391304, 0.8804347826087, 0.25
68902, 2.1347826086957, 0.8804347826087, 0.22222222222222
68903, 2.1565217391304, 0.90652173913044, 0.22222222222222
68904, 2.1565217391304, 0.8804347826087, 0.19444444444444
68905, 2.1347826086957, 0.8804347826087, 0.16666666666667
68906, 2.1565217391304, 0.90652173913044, 0.16666666666667
68907, 2.1565217391304, 0.8804347826087, 0.13888888888889
68908, 2.1347826086957, 0.8804347826087, 0.11111111111111
68909, 2.1565217391304, 0.90652173913044, 0.11111111111111
68910, 2.1565217391304, 0.8804347826087, 0.083333333333333
68911, 2.1347826086957, 0.8804347826087, 0.055555555555556
68912, 2.1565217391304, 0.90652173913044, 0.055555555555556
68913, 2.1565217391304, 0.8804347826087, 0.027777777777778
68914, 2.1782608695652, 0.8804347826087, 0.44444444444444
68915, 2.1782608695652, 0.8804347826087, 0.38888888888889
68916, 2.1782608695652, 0.8804347826087, 0.33333333333333
68917, 2.1782608695652, 0.8804347826087, 0.27777777777778
68918, 2.1782608695652, 0.8804347826087, 0.22222222222222
68919, 2.1782608695652, 0.8804347826087, 0.16666666666667
68920, 2.1782608695652, 0.8804347826087, 0.11111111111111
68921, 2.1782608695652, 0.8804347826087, 0.055555555555556
68922, 1.2434782608696, 0.82826086956522, 0.47222222222222
68923, 1.2217391304348, 0.82826086956522, 0.44444444444444
68924, 1.2434782608696, 0.85434782608696, 0.44444444444444
68925, 1.2434782608696, 0.82826086956522, 0.41666666666667
68926, 1.2217391304348, 0.82826086956522, 0.38888888888889
68927, 1.2434782608696, 0.85434782608696, 0.38888888888889
68928, 1.2434782608696, 0.82826086956522, 0.36111111111111
68929, 1.2217391304348, 0.82826086956522, 0.33333333333333
68930, 1.2434782608696, 0.85434782608696, 0.33333333333333
68931, 1.2434782608696, 0.82826086956522, 0.30555555555556
68932, 1.2217391304348, 0.82826086956522, 0.27777777777778
68933, 1.2434782608696, 0.85434782608696, 0.27777777777778
68934, 1.2434782608696, 0.82826086956522, 0.25
68935, 1.2217391304348, 0.82826086956522, 0.22222222222222
68936, 1.2434782608696, 0.85434782608696, 0.22222222222222
68937, 1.2434782608696, 0.82826086956522, 0.19444444444444
68938, 1.2217391304348, 0.82826086956522, 0.16666666666667
68939, 1.2434782608696, 0.85434782608696, 0.16666666666667
68940, 1.2434782608696, 0.82826086956522, 0.13888888888889
68941, 1.2217391304348, 0.82826086956522, 0.11111111111111
68942, 1.2434782608696, 0.85434782608696, 0.11111111111111
68943, 1.2434782608696, 0.82826086956522, 0.083333333333333
68944, 1.2217391304348, 0.82826086956522, 0.055555555555556
68945, 1.2434782608696, 0.85434782608696, 0.055555555555556
68946, 1.2434782608696, 0.82826086956522, 0.027777777777778
68947, 1.2869565217391, 0.82826086956522, 0.47222222222222
68948, 1.2652173913043, 0.82826086956522, 0.44444444444444
68949, 1.2869565217391, 0.85434782608696, 0.44444444444444
68950, 1.2869565217391, 0.82826086956522, 0.41666666666667
68951, 1.2652173913043, 0.82826086956522, 0.38888888888889
68952, 1.2869565217391, 0.85434782608696, 0.38888888888889
68953, 1.2869565217391, 0.82826086956522, 0.36111111111111
68954, 1.2652173913043, 0.82826086956522, 0.33333333333333
68955, 1.2869565217391, 0.85434782608696, 0.33333333333333
68956, 1.2869565217391, 0.82826086956522, 0.30555555555556
68957, 1.2652173913043, 0.82826086956522, 0.27777777777778
68958, 1.2869565217391, 0.85434782608696, 0.27777777777778
68959, 1.2869565217391, 0.82826086956522, 0.25
68960, 1.2652173913043, 0.82826086956522, 0.22222222222222
68961, 1.2869565217391, 0.85434782608696, 0.22222222222222
68962, 1.2869565217391, 0.82826086956522, 0.19444444444444
68963, 1.2652173913043, 0.82826086956522, 0.16666666666667
68964, 1.2869565217391, 0.85434782608696, 0.16666666666667
68965, 1.2869565217391, 0.82826086956522, 0.13888888888889
68966, 1.2652173913043, 0.82826086956522, 0.11111111111111
68967, 1.2869565217391, 0.85434782608696, 0.11111111111111
68968, 1.2869565217391, 0.82826086956522, 0.083333333333333
68969, 1.2652173913043, 0.82826086956522, 0.055555555555556
68970, 1.2869565217391, 0.85434782608696, 0.055555555555556
68971, 1.2869565217391, 0.82826086956522, 0.027777777777778
68972, 1.3304347826087, 0.82826086956522, 0.47222222222222
68973, 1.3086956521739, 0.82826086956522, 0.44444444444444
68974, 1.3304347826087, 0.85434782608696, 0.44444444444444
68975, 1.3304347826087, 0.82826086956522, 0.41666666666667
68976, 1.3086956521739, 0.82826086956522, 0.38888888888889
68977, 1.3304347826087, 0.85434782608696, 0.38888888888889
68978, 1.3304347826087, 0.82826086956522, 0.36111111111111
68979, 1.3086956521739, 0.82826086956522, 0.33333333333333
68980, 1.3304347826087, 0.85434782608696, 0.33333333333333
68981, 1.3304347826087, 0.82826086956522, 0.30555555555556
68982, 1.3086956521739, 0.82826086956522, 0.27777777777778
68983, 1.3304347826087, 0.85434782608696, 0.27777777777778
68984, 1.3304347826087, 0.82826086956522, 0.25
68985, 1.3086956521739, 0.82826086956522, 0.22222222222222
68986, 1.3304347826087, 0.85434782608696, 0.22222222222222
68987, 1.3304347826087, 0.82826086956522, 0.19444444444444
68988, 1.3086956521739, 0.82826086956522, 0.16666666666667
68989, 1.3304347826087, 0.85434782608696, 0.16666666666667
68990, 1.3304347826087, 0.82826086956522, 0.13888888888889
68991, 1.3086956521739, 0.82826086956522, 0.11111111111111
68992, 1.3304347826087, 0.85434782608696, 0.11111111111111
68993, 1.3304347826087, 0.82826086956522, 0.083333333333333
68994, 1.3086956521739, 0.82826086956522, 0.055555555555556
68995, 1.3304347826087, 0.85434782608696, 0.055555555555556
68996, 1.3304347826087, 0.82826086956522, 0.027777777777778
68997, 1.3739130434783, 0.82826086956522, 0.47222222222222
68998, 1.3521739130435, 0.82826086956522, 0.44444444444444
68999, 1.3739130434783, 0.85434782608696, 0.44444444444444
69000, 1.3739130434783, 0.82826086956522, 0.41666666666667
69001, 1.3521739130435, 0.82826086956522, 0.38888888888889
69002, 1.3739130434783, 0.85434782608696, 0.38888888888889
69003, 1.3739130434783, 0.82826086956522, 0.36111111111111
69004, 1.3521739130435, 0.82826086956522, 0.33333333333333
69005, 1.3739130434783, 0.85434782608696, 0.33333333333333
69006, 1.3739130434783, 0.82826086956522, 0.30555555555556
69007, 1.3521739130435, 0.82826086956522, 0.27777777777778
69008, 1.3739130434783, 0.85434782608696, 0.27777777777778
69009, 1.3739130434783, 0.82826086956522, 0.25
69010, 1.3521739130435, 0.82826086956522, 0.22222222222222
69011, 1.3739130434783, 0.85434782608696, 0.22222222222222
69012, 1.3739130434783, 0.82826086956522, 0.19444444444444
69013, 1.3521739130435, 0.82826086956522, 0.16666666666667
69014, 1.3739130434783, 0.85434782608696, 0.16666666666667
69015, 1.3739130434783, 0.82826086956522, 0.13888888888889
69016, 1.3521739130435, 0.82826086956522, 0.11111111111111
69017, 1.3739130434783, 0.85434782608696, 0.11111111111111
69018, 1.3739130434783, 0.82826086956522, 0.083333333333333
69019, 1.3521739130435, 0.82826086956522, 0.055555555555556
69020, 1.3739130434783, 0.85434782608696, 0.055555555555556
69021, 1.3739130434783, 0.82826086956522, 0.027777777777778
69022, 1.4173913043478, 0.82826086956522, 0.47222222222222
69023, 1.395652173913, 0.82826086956522, 0.44444444444444
69024, 1.4173913043478, 0.85434782608696, 0.44444444444444
69025, 1.4173913043478, 0.82826086956522, 0.41666666666667
69026, 1.395652173913, 0.82826086956522, 0.38888888888889
69027, 1.4173913043478, 0.85434782608696, 0.38888888888889
69028, 1.4173913043478, 0.82826086956522, 0.36111111111111
69029, 1.395652173913, 0.82826086956522, 0.33333333333333
69030, 1.4173913043478, 0.85434782608696, 0.33333333333333
69031, 1.4173913043478, 0.82826086956522, 0.30555555555556
69032, 1.395652173913, 0.82826086956522, 0.27777777777778
69033, 1.4173913043478, 0.85434782608696, 0.27777777777778
69034, 1.4173913043478, 0.82826086956522, 0.25
69035, 1.395652173913, 0.82826086956522, 0.22222222222222
69036, 1.4173913043478, 0.85434782608696, 0.22222222222222
69037, 1.4173913043478, 0.82826086956522, 0.19444444444444
69038, 1.395652173913, 0.82826086956522, 0.16666666666667
69039, 1.4173913043478, 0.85434782608696, 0.16666666666667
69040, 1.4173913043478, 0.82826086956522, 0.13888888888889
69041, 1.395652173913, 0.82826086956522, 0.11111111111111
69042, 1.4173913043478, 0.85434782608696, 0.11111111111111
69043, 1.4173913043478, 0.82826086956522, 0.083333333333333
69044, 1.395652173913, 0.82826086956522, 0.055555555555556
69045, 1.4173913043478, 0.85434782608696, 0.055555555555556
69046, 1.4173913043478, 0.82826086956522, 0.027777777777778
69047, 1.4608695652174, 0.82826086956522, 0.47222222222222
69048, 1.4391304347826, 0.82826086956522, 0.44444444444444
69049, 1.4608695652174, 0.85434782608696, 0.44444444444444
69050, 1.4608695652174, 0.82826086956522, 0.41666666666667
69051, 1.4391304347826, 0.82826086956522, 0.38888888888889
69052, 1.4608695652174, 0.85434782608696, 0.38888888888889
69053, 1.4608695652174, 0.82826086956522, 0.36111111111111
69054, 1.4391304347826, 0.82826086956522, 0.33333333333333
69055, 1.4608695652174, 0.85434782608696, 0.33333333333333
69056, 1.4608695652174, 0.82826086956522, 0.30555555555556
69057, 1.4391304347826, 0.82826086956522, 0.27777777777778
69058, 1.4608695652174, 0.85434782608696, 0.27777777777778
69059, 1.4608695652174, 0.82826086956522, 0.25
69060, 1.4391304347826, 0.82826086956522, 0.22222222222222
69061, 1.4608695652174, 0.85434782608696, 0.22222222222222
69062, 1.4608695652174, 0.82826086956522, 0.19444444444444
69063, 1.4391304347826, 0.82826086956522, 0.16666666666667
69064, 1.4608695652174, 0.85434782608696, 0.16666666666667
69065, 1.4608695652174, 0.82826086956522, 0.13888888888889
69066, 1.4391304347826, 0.82826086956522, 0.11111111111111
69067, 1.4608695652174, 0.85434782608696, 0.11111111111111
69068, 1.4608695652174, 0.82826086956522, 0.083333333333333
69069, 1.4391304347826, 0.82826086956522, 0.055555555555556
69070, 1.4608695652174, 0.85434782608696, 0.055555555555556
69071, 1.4608695652174, 0.82826086956522, 0.027777777777778
69072, 1.504347826087, 0.82826086956522, 0.47222222222222
69073, 1.4826086956522, 0.82826086956522, 0.44444444444444
69074, 1.504347826087, 0.85434782608696, 0.44444444444444
69075, 1.504347826087, 0.82826086956522, 0.41666666666667
69076, 1.4826086956522, 0.82826086956522, 0.38888888888889
69077, 1.504347826087, 0.85434782608696, 0.38888888888889
69078, 1.504347826087, 0.82826086956522, 0.36111111111111
69079, 1.4826086956522, 0.82826086956522, 0.33333333333333
69080, 1.504347826087, 0.85434782608696, 0.33333333333333
69081, 1.504347826087, 0.82826086956522, 0.30555555555556
69082, 1.4826086956522, 0.82826086956522, 0.27777777777778
69083, 1.504347826087, 0.85434782608696, 0.27777777777778
69084, 1.504347826087, 0.82826086956522, 0.25
69085, 1.4826086956522, 0.82826086956522, 0.22222222222222
69086, 1.504347826087, 0.85434782608696, 0.22222222222222
69087, 1.504347826087, 0.82826086956522, 0.19444444444444
69088, 1.4826086956522, 0.82826086956522, 0.16666666666667
69089, 1.504347826087, 0.85434782608696, 0.16666666666667
69090, 1.504347826087, 0.82826086956522, 0.13888888888889
69091, 1.4826086956522, 0.82826086956522, 0.11111111111111
69092, 1.504347826087, 0.85434782608696, 0.11111111111111
69093, 1.504347826087, 0.82826086956522, 0.083333333333333
69094, 1.4826086956522, 0.82826086956522, 0.055555555555556
69095, 1.504347826087, 0.85434782608696, 0.055555555555556
69096, 1.504347826087, 0.82826086956522, 0.027777777777778
69097, 1.5478260869565, 0.82826086956522, 0.47222222222222
69098, 1.5260869565217, 0.82826086956522, 0.44444444444444
69099, 1.5478260869565, 0.85434782608696, 0.44444444444444
69100, 1.5478260869565, 0.82826086956522, 0.41666666666667
69101, 1.5260869565217, 0.82826086956522, 0.38888888888889
69102, 1.5478260869565, 0.85434782608696, 0.38888888888889
69103, 1.5478260869565, 0.82826086956522, 0.36111111111111
69104, 1.5260869565217, 0.82826086956522, 0.33333333333333
69105, 1.5478260869565, 0.85434782608696, 0.33333333333333
69106, 1.5478260869565, 0.82826086956522, 0.30555555555556
69107, 1.5260869565217, 0.82826086956522, 0.27777777777778
69108, 1.5478260869565, 0.85434782608696, 0.27777777777778
69109, 1.5478260869565, 0.82826086956522, 0.25
69110, 1.5260869565217, 0.82826086956522, 0.22222222222222
69111, 1.5478260869565, 0.85434782608696, 0.22222222222222
69112, 1.5478260869565, 0.82826086956522, 0.19444444444444
69113, 1.5260869565217, 0.82826086956522, 0.16666666666667
69114, 1.5478260869565, 0.85434782608696, 0.16666666666667
69115, 1.5478260869565, 0.82826086956522, 0.13888888888889
69116, 1.5260869565217, 0.82826086956522, 0.11111111111111
69117, 1.5478260869565, 0.85434782608696, 0.11111111111111
69118, 1.5478260869565, 0.82826086956522, 0.083333333333333
69119, 1.5260869565217, 0.82826086956522, 0.055555555555556
69120, 1.5478260869565, 0.85434782608696, 0.055555555555556
69121, 1.5478260869565, 0.82826086956522, 0.027777777777778
69122, 1.5913043478261, 0.82826086956522, 0.47222222222222
69123, 1.5695652173913, 0.82826086956522, 0.44444444444444
69124, 1.5913043478261, 0.85434782608696, 0.44444444444444
69125, 1.5913043478261, 0.82826086956522, 0.41666666666667
69126, 1.5695652173913, 0.82826086956522, 0.38888888888889
69127, 1.5913043478261, 0.85434782608696, 0.38888888888889
69128, 1.5913043478261, 0.82826086956522, 0.36111111111111
69129, 1.5695652173913, 0.82826086956522, 0.33333333333333
69130, 1.5913043478261, 0.85434782608696, 0.33333333333333
69131, 1.5913043478261, 0.82826086956522, 0.30555555555556
69132, 1.5695652173913, 0.82826086956522, 0.27777777777778
69133, 1.5913043478261, 0.85434782608696, 0.27777777777778
69134, 1.5913043478261, 0.82826086956522, 0.25
69135, 1.5695652173913, 0.82826086956522, 0.22222222222222
69136, 1.5913043478261, 0.85434782608696, 0.22222222222222
69137, 1.5913043478261, 0.82826086956522, 0.19444444444444
69138, 1.5695652173913, 0.82826086956522, 0.16666666666667
69139, 1.5913043478261, 0.85434782608696, 0.16666666666667
69140, 1.5913043478261, 0.82826086956522, 0.13888888888889
69141, 1.5695652173913, 0.82826086956522, 0.11111111111111
69142, 1.5913043478261, 0.85434782608696, 0.11111111111111
69143, 1.5913043478261, 0.82826086956522, 0.083333333333333
69144, 1.5695652173913, 0.82826086956522, 0.055555555555556
69145, 1.5913043478261, 0.85434782608696, 0.055555555555556
69146, 1.5913043478261, 0.82826086956522, 0.027777777777778
69147, 1.6347826086957, 0.82826086956522, 0.47222222222222
69148, 1.6130434782609, 0.82826086956522, 0.44444444444444
69149, 1.6347826086957, 0.85434782608696, 0.44444444444444
69150, 1.6347826086957, 0.82826086956522, 0.41666666666667
69151, 1.6130434782609, 0.82826086956522, 0.38888888888889
69152, 1.6347826086957, 0.85434782608696, 0.38888888888889
69153, 1.6347826086957, 0.82826086956522, 0.36111111111111
69154, 1.6130434782609, 0.82826086956522, 0.33333333333333
69155, 1.6347826086957, 0.85434782608696, 0.33333333333333
69156, 1.6347826086957, 0.82826086956522, 0.30555555555556
69157, 1.6130434782609, 0.82826086956522, 0.27777777777778
69158, 1.6347826086957, 0.85434782608696, 0.27777777777778
69159, 1.6347826086957, 0.82826086956522, 0.25
69160, 1.6130434782609, 0.82826086956522, 0.22222222222222
69161, 1.6347826086957, 0.85434782608696, 0.22222222222222
69162, 1.6347826086957, 0.82826086956522, 0.19444444444444
69163, 1.6130434782609, 0.82826086956522, 0.16666666666667
69164, 1.6347826086957, 0.85434782608696, 0.16666666666667
69165, 1.6347826086957, 0.82826086956522, 0.13888888888889
69166, 1.6130434782609, 0.82826086956522, 0.11111111111111
69167, 1.6347826086957, 0.85434782608696, 0.11111111111111
69168, 1.6347826086957, 0.82826086956522, 0.083333333333333
69169, 1.6130434782609, 0.82826086956522, 0.055555555555556
69170, 1.6347826086957, 0.85434782608696, 0.055555555555556
69171, 1.6347826086957, 0.82826086956522, 0.027777777777778
69172, 1.6782608695652, 0.82826086956522, 0.47222222222222
69173, 1.6565217391304, 0.82826086956522, 0.44444444444444
69174, 1.6782608695652, 0.85434782608696, 0.44444444444444
69175, 1.6782608695652, 0.82826086956522, 0.41666666666667
69176, 1.6565217391304, 0.82826086956522, 0.38888888888889
69177, 1.6782608695652, 0.85434782608696, 0.38888888888889
69178, 1.6782608695652, 0.82826086956522, 0.36111111111111
69179, 1.6565217391304, 0.82826086956522, 0.33333333333333
69180, 1.6782608695652, 0.85434782608696, 0.33333333333333
69181, 1.6782608695652, 0.82826086956522, 0.30555555555556
69182, 1.6565217391304, 0.82826086956522, 0.27777777777778
69183, 1.6782608695652, 0.85434782608696, 0.27777777777778
69184, 1.6782608695652, 0.82826086956522, 0.25
69185, 1.6565217391304, 0.82826086956522, 0.22222222222222
69186, 1.6782608695652, 0.85434782608696, 0.22222222222222
69187, 1.6782608695652, 0.82826086956522, 0.19444444444444
69188, 1.6565217391304, 0.82826086956522, 0.16666666666667
69189, 1.6782608695652, 0.85434782608696, 0.16666666666667
69190, 1.6782608695652, 0.82826086956522, 0.13888888888889
69191, 1.6565217391304, 0.82826086956522, 0.11111111111111
69192, 1.6782608695652, 0.85434782608696, 0.11111111111111
69193, 1.6782608695652, 0.82826086956522, 0.083333333333333
69194, 1.6565217391304, 0.82826086956522, 0.055555555555556
69195, 1.6782608695652, 0.85434782608696, 0.055555555555556
69196, 1.6782608695652, 0.82826086956522, 0.027777777777778
69197, 1.7217391304348, 0.82826086956522, 0.47222222222222
69198, 1.7, 0.82826086956522, 0.44444444444444
69199, 1.7217391304348, 0.85434782608696, 0.44444444444444
69200, 1.7217391304348, 0.82826086956522, 0.41666666666667
69201, 1.7, 0.82826086956522, 0.38888888888889
69202, 1.7217391304348, 0.85434782608696, 0.38888888888889
69203, 1.7217391304348, 0.82826086956522, 0.36111111111111
69204, 1.7, 0.82826086956522, 0.33333333333333
69205, 1.7217391304348, 0.85434782608696, 0.33333333333333
69206, 1.7217391304348, 0.82826086956522, 0.30555555555556
69207, 1.7, 0.82826086956522, 0.27777777777778
69208, 1.7217391304348, 0.85434782608696, 0.27777777777778
69209, 1.7217391304348, 0.82826086956522, 0.25
69210, 1.7, 0.82826086956522, 0.22222222222222
69211, 1.7217391304348, 0.85434782608696, 0.22222222222222
69212, 1.7217391304348, 0.82826086956522, 0.19444444444444
69213, 1.7, 0.82826086956522, 0.16666666666667
69214, 1.7217391304348, 0.85434782608696, 0.16666666666667
69215, 1.7217391304348, 0.82826086956522, 0.13888888888889
69216, 1.7, 0.82826086956522, 0.11111111111111
69217, 1.7217391304348, 0.85434782608696, 0.11111111111111
69218, 1.7217391304348, 0.82826086956522, 0.083333333333333
69219, 1.7, 0.82826086956522, 0.055555555555556
69220, 1.7217391304348, 0.85434782608696, 0.055555555555556
69221, 1.7217391304348, 0.82826086956522, 0.027777777777778
69222, 1.7652173913043, 0.82826086956522, 0.47222222222222
69223, 1.7434782608696, 0.82826086956522, 0.44444444444444
69224, 1.7652173913043, 0.85434782608696, 0.44444444444444
69225, 1.7652173913043, 0.82826086956522, 0.41666666666667
69226, 1.7434782608696, 0.82826086956522, 0.38888888888889
69227, 1.7652173913043, 0.85434782608696, 0.38888888888889
69228, 1.7652173913043, 0.82826086956522, 0.36111111111111
69229, 1.7434782608696, 0.82826086956522, 0.33333333333333
69230, 1.7652173913043, 0.85434782608696, 0.33333333333333
69231, 1.7652173913043, 0.82826086956522, 0.30555555555556
69232, 1.7434782608696, 0.82826086956522, 0.27777777777778
69233, 1.7652173913043, 0.85434782608696, 0.27777777777778
69234, 1.7652173913043, 0.82826086956522, 0.25
69235, 1.7434782608696, 0.82826086956522, 0.22222222222222
69236, 1.7652173913043, 0.85434782608696, 0.22222222222222
69237, 1.7652173913043, 0.82826086956522, 0.19444444444444
69238, 1.7434782608696, 0.82826086956522, 0.16666666666667
69239, 1.7652173913043, 0.85434782608696, 0.16666666666667
69240, 1.7652173913043, 0.82826086956522, 0.13888888888889
69241, 1.7434782608696, 0.82826086956522, 0.11111111111111
69242, 1.7652173913043, 0.85434782608696, 0.11111111111111
69243, 1.7652173913043, 0.82826086956522, 0.083333333333333
69244, 1.7434782608696, 0.82826086956522, 0.055555555555556
69245, 1.7652173913043, 0.85434782608696, 0.055555555555556
69246, 1.7652173913043, 0.82826086956522, 0.027777777777778
69247, 1.8086956521739, 0.82826086956522, 0.47222222222222
69248, 1.7869565217391, 0.82826086956522, 0.44444444444444
69249, 1.8086956521739, 0.85434782608696, 0.44444444444444
69250, 1.8086956521739, 0.82826086956522, 0.41666666666667
69251, 1.7869565217391, 0.82826086956522, 0.38888888888889
69252, 1.8086956521739, 0.85434782608696, 0.38888888888889
69253, 1.8086956521739, 0.82826086956522, 0.36111111111111
69254, 1.7869565217391, 0.82826086956522, 0.33333333333333
69255, 1.8086956521739, 0.85434782608696, 0.33333333333333
69256, 1.8086956521739, 0.82826086956522, 0.30555555555556
69257, 1.7869565217391, 0.82826086956522, 0.27777777777778
69258, 1.8086956521739, 0.85434782608696, 0.27777777777778
69259, 1.8086956521739, 0.82826086956522, 0.25
69260, 1.7869565217391, 0.82826086956522, 0.22222222222222
69261, 1.8086956521739, 0.85434782608696, 0.22222222222222
69262, 1.8086956521739, 0.82826086956522, 0.19444444444444
69263, 1.7869565217391, 0.82826086956522, 0.16666666666667
69264, 1.8086956521739, 0.85434782608696, 0.16666666666667
69265, 1.8086956521739, 0.82826086956522, 0.13888888888889
69266, 1.7869565217391, 0.82826086956522, 0.11111111111111
69267, 1.8086956521739, 0.85434782608696, 0.11111111111111
69268, 1.8086956521739, 0.82826086956522, 0.083333333333333
69269, 1.7869565217391, 0.82826086956522, 0.055555555555556
69270, 1.8086956521739, 0.85434782608696, 0.055555555555556
69271, 1.8086956521739, 0.82826086956522, 0.027777777777778
69272, 1.8521739130435, 0.82826086956522, 0.47222222222222
69273, 1.8304347826087, 0.82826086956522, 0.44444444444444
69274, 1.8521739130435, 0.85434782608696, 0.44444444444444
69275, 1.8521739130435, 0.82826086956522, 0.41666666666667
69276, 1.8304347826087, 0.82826086956522, 0.38888888888889
69277, 1.8521739130435, 0.85434782608696, 0.38888888888889
69278, 1.8521739130435, 0.82826086956522, 0.36111111111111
69279, 1.8304347826087, 0.82826086956522, 0.33333333333333
69280, 1.8521739130435, 0.85434782608696, 0.33333333333333
69281, 1.8521739130435, 0.82826086956522, 0.30555555555556
69282, 1.8304347826087, 0.82826086956522, 0.27777777777778
69283, 1.8521739130435, 0.85434782608696, 0.27777777777778
69284, 1.8521739130435, 0.82826086956522, 0.25
69285, 1.8304347826087, 0.82826086956522, 0.22222222222222
69286, 1.8521739130435, 0.85434782608696, 0.22222222222222
69287, 1.8521739130435, 0.82826086956522, 0.19444444444444
69288, 1.8304347826087, 0.82826086956522, 0.16666666666667
69289, 1.8521739130435, 0.85434782608696, 0.16666666666667
69290, 1.8521739130435, 0.82826086956522, 0.13888888888889
69291, 1.8304347826087, 0.82826086956522, 0.11111111111111
69292, 1.8521739130435, 0.85434782608696, 0.11111111111111
69293, 1.8521739130435, 0.82826086956522, 0.083333333333333
69294, 1.8304347826087, 0.82826086956522, 0.055555555555556
69295, 1.8521739130435, 0.85434782608696, 0.055555555555556
69296, 1.8521739130435, 0.82826086956522, 0.027777777777778
69297, 1.895652173913, 0.82826086956522, 0.47222222222222
69298, 1.8739130434783, 0.82826086956522, 0.44444444444444
69299, 1.895652173913, 0.85434782608696, 0.44444444444444
69300, 1.895652173913, 0.82826086956522, 0.41666666666667
69301, 1.8739130434783, 0.82826086956522, 0.38888888888889
69302, 1.895652173913, 0.85434782608696, 0.38888888888889
69303, 1.895652173913, 0.82826086956522, 0.36111111111111
69304, 1.8739130434783, 0.82826086956522, 0.33333333333333
69305, 1.895652173913, 0.85434782608696, 0.33333333333333
69306, 1.895652173913, 0.82826086956522, 0.30555555555556
69307, 1.8739130434783, 0.82826086956522, 0.27777777777778
69308, 1.895652173913, 0.85434782608696, 0.27777777777778
69309, 1.895652173913, 0.82826086956522, 0.25
69310, 1.8739130434783, 0.82826086956522, 0.22222222222222
69311, 1.895652173913, 0.85434782608696, 0.22222222222222
69312, 1.895652173913, 0.82826086956522, 0.19444444444444
69313, 1.8739130434783, 0.82826086956522, 0.16666666666667
69314, 1.895652173913, 0.85434782608696, 0.16666666666667
69315, 1.895652173913, 0.82826086956522, 0.13888888888889
69316, 1.8739130434783, 0.82826086956522, 0.11111111111111
69317, 1.895652173913, 0.85434782608696, 0.11111111111111
69318, 1.895652173913, 0.82826086956522, 0.083333333333333
69319, 1.8739130434783, 0.82826086956522, 0.055555555555556
69320, 1.895652173913, 0.85434782608696, 0.055555555555556
69321, 1.895652173913, 0.82826086956522, 0.027777777777778
69322, 1.9391304347826, 0.82826086956522, 0.47222222222222
69323, 1.9173913043478, 0.82826086956522, 0.44444444444444
69324, 1.9391304347826, 0.85434782608696, 0.44444444444444
69325, 1.9391304347826, 0.82826086956522, 0.41666666666667
69326, 1.9173913043478, 0.82826086956522, 0.38888888888889
69327, 1.9391304347826, 0.85434782608696, 0.38888888888889
69328, 1.9391304347826, 0.82826086956522, 0.36111111111111
69329, 1.9173913043478, 0.82826086956522, 0.33333333333333
69330, 1.9391304347826, 0.85434782608696, 0.33333333333333
69331, 1.9391304347826, 0.82826086956522, 0.30555555555556
69332, 1.9173913043478, 0.82826086956522, 0.27777777777778
69333, 1.9391304347826, 0.85434782608696, 0.27777777777778
69334, 1.9391304347826, 0.82826086956522, 0.25
69335, 1.9173913043478, 0.82826086956522, 0.22222222222222
69336, 1.9391304347826, 0.85434782608696, 0.22222222222222
69337, 1.9391304347826, 0.82826086956522, 0.19444444444444
69338, 1.9173913043478, 0.82826086956522, 0.16666666666667
69339, 1.9391304347826, 0.85434782608696, 0.16666666666667
69340, 1.9391304347826, 0.82826086956522, 0.13888888888889
69341, 1.9173913043478, 0.82826086956522, 0.11111111111111
69342, 1.9391304347826, 0.85434782608696, 0.11111111111111
69343, 1.9391304347826, 0.82826086956522, 0.083333333333333
69344, 1.9173913043478, 0.82826086956522, 0.055555555555556
69345, 1.9391304347826, 0.85434782608696, 0.055555555555556
69346, 1.9391304347826, 0.82826086956522, 0.027777777777778
69347, 1.9826086956522, 0.82826086956522, 0.47222222222222
69348, 1.9608695652174, 0.82826086956522, 0.44444444444444
69349, 1.9826086956522, 0.85434782608696, 0.44444444444444
69350, 1.9826086956522, 0.82826086956522, 0.41666666666667
69351, 1.9608695652174, 0.82826086956522, 0.38888888888889
69352, 1.9826086956522, 0.85434782608696, 0.38888888888889
69353, 1.9826086956522, 0.82826086956522, 0.36111111111111
69354, 1.9608695652174, 0.82826086956522, 0.33333333333333
69355, 1.9826086956522, 0.85434782608696, 0.33333333333333
69356, 1.9826086956522, 0.82826086956522, 0.30555555555556
69357, 1.9608695652174, 0.82826086956522, 0.27777777777778
69358, 1.9826086956522, 0.85434782608696, 0.27777777777778
69359, 1.9826086956522, 0.82826086956522, 0.25
69360, 1.9608695652174, 0.82826086956522, 0.22222222222222
69361, 1.9826086956522, 0.85434782608696, 0.22222222222222
69362, 1.9826086956522, 0.82826086956522, 0.19444444444444
69363, 1.9608695652174, 0.82826086956522, 0.16666666666667
69364, 1.9826086956522, 0.85434782608696, 0.16666666666667
69365, 1.9826086956522, 0.82826086956522, 0.13888888888889
69366, 1.9608695652174, 0.82826086956522, 0.11111111111111
69367, 1.9826086956522, 0.85434782608696, 0.11111111111111
69368, 1.9826086956522, 0.82826086956522, 0.083333333333333
69369, 1.9608695652174, 0.82826086956522, 0.055555555555556
69370, 1.9826086956522, 0.85434782608696, 0.055555555555556
69371, 1.9826086956522, 0.82826086956522, 0.027777777777778
69372, 2.0260869565217, 0.82826086956522, 0.47222222222222
69373, 2.004347826087, 0.82826086956522, 0.44444444444444
69374, 2.0260869565217, 0.85434782608696, 0.44444444444444
69375, 2.0260869565217, 0.82826086956522, 0.41666666666667
69376, 2.004347826087, 0.82826086956522, 0.38888888888889
69377, 2.0260869565217, 0.85434782608696, 0.38888888888889
69378, 2.0260869565217, 0.82826086956522, 0.36111111111111
69379, 2.004347826087, 0.82826086956522, 0.33333333333333
69380, 2.0260869565217, 0.85434782608696, 0.33333333333333
69381, 2.0260869565217, 0.82826086956522, 0.30555555555556
69382, 2.004347826087, 0.82826086956522, 0.27777777777778
69383, 2.0260869565217, 0.85434782608696, 0.27777777777778
69384, 2.0260869565217, 0.82826086956522, 0.25
69385, 2.004347826087, 0.82826086956522, 0.22222222222222
69386, 2.0260869565217, 0.85434782608696, 0.22222222222222
69387, 2.0260869565217, 0.82826086956522, 0.19444444444444
69388, 2.004347826087, 0.82826086956522, 0.16666666666667
69389, 2.0260869565217, 0.85434782608696, 0.16666666666667
69390, 2.0260869565217, 0.82826086956522, 0.13888888888889
69391, 2.004347826087, 0.82826086956522, 0.11111111111111
69392, 2.0260869565217, 0.85434782608696, 0.11111111111111
69393, 2.0260869565217, 0.82826086956522, 0.083333333333333
69394, 2.004347826087, 0.82826086956522, 0.055555555555556
69395, 2.0260869565217, 0.85434782608696, 0.055555555555556
69396, 2.0260869565217, 0.82826086956522, 0.027777777777778
69397, 2.0695652173913, 0.82826086956522, 0.47222222222222
69398, 2.0478260869565, 0.82826086956522, 0.44444444444444
69399, 2.0695652173913, 0.85434782608696, 0.44444444444444
69400, 2.0695652173913, 0.82826086956522, 0.41666666666667
69401, 2.0478260869565, 0.82826086956522, 0.38888888888889
69402, 2.0695652173913, 0.85434782608696, 0.38888888888889
69403, 2.0695652173913, 0.82826086956522, 0.36111111111111
69404, 2.0478260869565, 0.82826086956522, 0.33333333333333
69405, 2.0695652173913, 0.85434782608696, 0.33333333333333
69406, 2.0695652173913, 0.82826086956522, 0.30555555555556
69407, 2.0478260869565, 0.82826086956522, 0.27777777777778
69408, 2.0695652173913, 0.85434782608696, 0.27777777777778
69409, 2.0695652173913, 0.82826086956522, 0.25
69410, 2.0478260869565, 0.82826086956522, 0.22222222222222
69411, 2.0695652173913, 0.85434782608696, 0.22222222222222
69412, 2.0695652173913, 0.82826086956522, 0.19444444444444
69413, 2.0478260869565, 0.82826086956522, 0.16666666666667
69414, 2.0695652173913, 0.85434782608696, 0.16666666666667
69415, 2.0695652173913, 0.82826086956522, 0.13888888888889
69416, 2.0478260869565, 0.82826086956522, 0.11111111111111
69417, 2.0695652173913, 0.85434782608696, 0.11111111111111
69418, 2.0695652173913, 0.82826086956522, 0.083333333333333
69419, 2.0478260869565, 0.82826086956522, 0.055555555555556
69420, 2.0695652173913, 0.85434782608696, 0.055555555555556
69421, 2.0695652173913, 0.82826086956522, 0.027777777777778
69422, 2.1130434782609, 0.82826086956522, 0.47222222222222
69423, 2.0913043478261, 0.82826086956522, 0.44444444444444
69424, 2.1130434782609, 0.85434782608696, 0.44444444444444
69425, 2.1130434782609, 0.82826086956522, 0.41666666666667
69426, 2.0913043478261, 0.82826086956522, 0.38888888888889
69427, 2.1130434782609, 0.85434782608696, 0.38888888888889
69428, 2.1130434782609, 0.82826086956522, 0.36111111111111
69429, 2.0913043478261, 0.82826086956522, 0.33333333333333
69430, 2.1130434782609, 0.85434782608696, 0.33333333333333
69431, 2.1130434782609, 0.82826086956522, 0.30555555555556
69432, 2.0913043478261, 0.82826086956522, 0.27777777777778
69433, 2.1130434782609, 0.85434782608696, 0.27777777777778
69434, 2.1130434782609, 0.82826086956522, 0.25
69435, 2.0913043478261, 0.82826086956522, 0.22222222222222
69436, 2.1130434782609, 0.85434782608696, 0.22222222222222
69437, 2.1130434782609, 0.82826086956522, 0.19444444444444
69438, 2.0913043478261, 0.82826086956522, 0.16666666666667
69439, 2.1130434782609, 0.85434782608696, 0.16666666666667
69440, 2.1130434782609, 0.82826086956522, 0.13888888888889
69441, 2.0913043478261, 0.82826086956522, 0.11111111111111
69442, 2.1130434782609, 0.85434782608696, 0.11111111111111
69443, 2.1130434782609, 0.82826086956522, 0.083333333333333
69444, 2.0913043478261, 0.82826086956522, 0.055555555555556
69445, 2.1130434782609, 0.85434782608696, 0.055555555555556
69446, 2.1130434782609, 0.82826086956522, 0.027777777777778
69447, 2.1565217391304, 0.82826086956522, 0.47222222222222
69448, 2.1347826086957, 0.82826086956522, 0.44444444444444
69449, 2.1565217391304, 0.85434782608696, 0.44444444444444
69450, 2.1565217391304, 0.82826086956522, 0.41666666666667
69451, 2.1347826086957, 0.82826086956522, 0.38888888888889
69452, 2.1565217391304, 0.85434782608696, 0.38888888888889
69453, 2.1565217391304, 0.82826086956522, 0.36111111111111
69454, 2.1347826086957, 0.82826086956522, 0.33333333333333
69455, 2.1565217391304, 0.85434782608696, 0.33333333333333
69456, 2.1565217391304, 0.82826086956522, 0.30555555555556
69457, 2.1347826086957, 0.82826086956522, 0.27777777777778
69458, 2.1565217391304, 0.85434782608696, 0.27777777777778
69459, 2.1565217391304, 0.82826086956522, 0.25
69460, 2.1347826086957, 0.82826086956522, 0.22222222222222
69461, 2.1565217391304, 0.85434782608696, 0.22222222222222
69462, 2.1565217391304, 0.82826086956522, 0.19444444444444
69463, 2.1347826086957, 0.82826086956522, 0.16666666666667
69464, 2.1565217391304, 0.85434782608696, 0.16666666666667
69465, 2.1565217391304, 0.82826086956522, 0.13888888888889
69466, 2.1347826086957, 0.82826086956522, 0.11111111111111
69467, 2.1565217391304, 0.85434782608696, 0.11111111111111
69468, 2.1565217391304, 0.82826086956522, 0.083333333333333
69469, 2.1347826086957, 0.82826086956522, 0.055555555555556
69470, 2.1565217391304, 0.85434782608696, 0.055555555555556
69471, 2.1565217391304, 0.82826086956522, 0.027777777777778
69472, 2.1782608695652, 0.82826086956522, 0.44444444444444
69473, 2.1782608695652, 0.82826086956522, 0.38888888888889
69474, 2.1782608695652, 0.82826086956522, 0.33333333333333
69475, 2.1782608695652, 0.82826086956522, 0.27777777777778
69476, 2.1782608695652, 0.82826086956522, 0.22222222222222
69477, 2.1782608695652, 0.82826086956522, 0.16666666666667
69478, 2.1782608695652, 0.82826086956522, 0.11111111111111
69479, 2.1782608695652, 0.82826086956522, 0.055555555555556
69480, 1.2434782608696, 0.77608695652174, 0.47222222222222
69481, 1.2217391304348, 0.77608695652174, 0.44444444444444
69482, 1.2434782608696, 0.80217391304348, 0.44444444444444
69483, 1.2434782608696, 0.77608695652174, 0.41666666666667
69484, 1.2217391304348, 0.77608695652174, 0.38888888888889
69485, 1.2434782608696, 0.80217391304348, 0.38888888888889
69486, 1.2434782608696, 0.77608695652174, 0.36111111111111
69487, 1.2217391304348, 0.77608695652174, 0.33333333333333
69488, 1.2434782608696, 0.80217391304348, 0.33333333333333
69489, 1.2434782608696, 0.77608695652174, 0.30555555555556
69490, 1.2217391304348, 0.77608695652174, 0.27777777777778
69491, 1.2434782608696, 0.80217391304348, 0.27777777777778
69492, 1.2434782608696, 0.77608695652174, 0.25
69493, 1.2217391304348, 0.77608695652174, 0.22222222222222
69494, 1.2434782608696, 0.80217391304348, 0.22222222222222
69495, 1.2434782608696, 0.77608695652174, 0.19444444444444
69496, 1.2217391304348, 0.77608695652174, 0.16666666666667
69497, 1.2434782608696, 0.80217391304348, 0.16666666666667
69498, 1.2434782608696, 0.77608695652174, 0.13888888888889
69499, 1.2217391304348, 0.77608695652174, 0.11111111111111
69500, 1.2434782608696, 0.80217391304348, 0.11111111111111
69501, 1.2434782608696, 0.77608695652174, 0.083333333333333
69502, 1.2217391304348, 0.77608695652174, 0.055555555555556
69503, 1.2434782608696, 0.80217391304348, 0.055555555555556
69504, 1.2434782608696, 0.77608695652174, 0.027777777777778
69505, 1.2869565217391, 0.77608695652174, 0.47222222222222
69506, 1.2652173913043, 0.77608695652174, 0.44444444444444
69507, 1.2869565217391, 0.80217391304348, 0.44444444444444
69508, 1.2869565217391, 0.77608695652174, 0.41666666666667
69509, 1.2652173913043, 0.77608695652174, 0.38888888888889
69510, 1.2869565217391, 0.80217391304348, 0.38888888888889
69511, 1.2869565217391, 0.77608695652174, 0.36111111111111
69512, 1.2652173913043, 0.77608695652174, 0.33333333333333
69513, 1.2869565217391, 0.80217391304348, 0.33333333333333
69514, 1.2869565217391, 0.77608695652174, 0.30555555555556
69515, 1.2652173913043, 0.77608695652174, 0.27777777777778
69516, 1.2869565217391, 0.80217391304348, 0.27777777777778
69517, 1.2869565217391, 0.77608695652174, 0.25
69518, 1.2652173913043, 0.77608695652174, 0.22222222222222
69519, 1.2869565217391, 0.80217391304348, 0.22222222222222
69520, 1.2869565217391, 0.77608695652174, 0.19444444444444
69521, 1.2652173913043, 0.77608695652174, 0.16666666666667
69522, 1.2869565217391, 0.80217391304348, 0.16666666666667
69523, 1.2869565217391, 0.77608695652174, 0.13888888888889
69524, 1.2652173913043, 0.77608695652174, 0.11111111111111
69525, 1.2869565217391, 0.80217391304348, 0.11111111111111
69526, 1.2869565217391, 0.77608695652174, 0.083333333333333
69527, 1.2652173913043, 0.77608695652174, 0.055555555555556
69528, 1.2869565217391, 0.80217391304348, 0.055555555555556
69529, 1.2869565217391, 0.77608695652174, 0.027777777777778
69530, 1.3304347826087, 0.77608695652174, 0.47222222222222
69531, 1.3086956521739, 0.77608695652174, 0.44444444444444
69532, 1.3304347826087, 0.80217391304348, 0.44444444444444
69533, 1.3304347826087, 0.77608695652174, 0.41666666666667
69534, 1.3086956521739, 0.77608695652174, 0.38888888888889
69535, 1.3304347826087, 0.80217391304348, 0.38888888888889
69536, 1.3304347826087, 0.77608695652174, 0.36111111111111
69537, 1.3086956521739, 0.77608695652174, 0.33333333333333
69538, 1.3304347826087, 0.80217391304348, 0.33333333333333
69539, 1.3304347826087, 0.77608695652174, 0.30555555555556
69540, 1.3086956521739, 0.77608695652174, 0.27777777777778
69541, 1.3304347826087, 0.80217391304348, 0.27777777777778
69542, 1.3304347826087, 0.77608695652174, 0.25
69543, 1.3086956521739, 0.77608695652174, 0.22222222222222
69544, 1.3304347826087, 0.80217391304348, 0.22222222222222
69545, 1.3304347826087, 0.77608695652174, 0.19444444444444
69546, 1.3086956521739, 0.77608695652174, 0.16666666666667
69547, 1.3304347826087, 0.80217391304348, 0.16666666666667
69548, 1.3304347826087, 0.77608695652174, 0.13888888888889
69549, 1.3086956521739, 0.77608695652174, 0.11111111111111
69550, 1.3304347826087, 0.80217391304348, 0.11111111111111
69551, 1.3304347826087, 0.77608695652174, 0.083333333333333
69552, 1.3086956521739, 0.77608695652174, 0.055555555555556
69553, 1.3304347826087, 0.80217391304348, 0.055555555555556
69554, 1.3304347826087, 0.77608695652174, 0.027777777777778
69555, 1.3739130434783, 0.77608695652174, 0.47222222222222
69556, 1.3521739130435, 0.77608695652174, 0.44444444444444
69557, 1.3739130434783, 0.80217391304348, 0.44444444444444
69558, 1.3739130434783, 0.77608695652174, 0.41666666666667
69559, 1.3521739130435, 0.77608695652174, 0.38888888888889
69560, 1.3739130434783, 0.80217391304348, 0.38888888888889
69561, 1.3739130434783, 0.77608695652174, 0.36111111111111
69562, 1.3521739130435, 0.77608695652174, 0.33333333333333
69563, 1.3739130434783, 0.80217391304348, 0.33333333333333
69564, 1.3739130434783, 0.77608695652174, 0.30555555555556
69565, 1.3521739130435, 0.77608695652174, 0.27777777777778
69566, 1.3739130434783, 0.80217391304348, 0.27777777777778
69567, 1.3739130434783, 0.77608695652174, 0.25
69568, 1.3521739130435, 0.77608695652174, 0.22222222222222
69569, 1.3739130434783, 0.80217391304348, 0.22222222222222
69570, 1.3739130434783, 0.77608695652174, 0.19444444444444
69571, 1.3521739130435, 0.77608695652174, 0.16666666666667
69572, 1.3739130434783, 0.80217391304348, 0.16666666666667
69573, 1.3739130434783, 0.77608695652174, 0.13888888888889
69574, 1.3521739130435, 0.77608695652174, 0.11111111111111
69575, 1.3739130434783, 0.80217391304348, 0.11111111111111
69576, 1.3739130434783, 0.77608695652174, 0.083333333333333
69577, 1.3521739130435, 0.77608695652174, 0.055555555555556
69578, 1.3739130434783, 0.80217391304348, 0.055555555555556
69579, 1.3739130434783, 0.77608695652174, 0.027777777777778
69580, 1.4173913043478, 0.77608695652174, 0.47222222222222
69581, 1.395652173913, 0.77608695652174, 0.44444444444444
69582, 1.4173913043478, 0.80217391304348, 0.44444444444444
69583, 1.4173913043478, 0.77608695652174, 0.41666666666667
69584, 1.395652173913, 0.77608695652174, 0.38888888888889
69585, 1.4173913043478, 0.80217391304348, 0.38888888888889
69586, 1.4173913043478, 0.77608695652174, 0.36111111111111
69587, 1.395652173913, 0.77608695652174, 0.33333333333333
69588, 1.4173913043478, 0.80217391304348, 0.33333333333333
69589, 1.4173913043478, 0.77608695652174, 0.30555555555556
69590, 1.395652173913, 0.77608695652174, 0.27777777777778
69591, 1.4173913043478, 0.80217391304348, 0.27777777777778
69592, 1.4173913043478, 0.77608695652174, 0.25
69593, 1.395652173913, 0.77608695652174, 0.22222222222222
69594, 1.4173913043478, 0.80217391304348, 0.22222222222222
69595, 1.4173913043478, 0.77608695652174, 0.19444444444444
69596, 1.395652173913, 0.77608695652174, 0.16666666666667
69597, 1.4173913043478, 0.80217391304348, 0.16666666666667
69598, 1.4173913043478, 0.77608695652174, 0.13888888888889
69599, 1.395652173913, 0.77608695652174, 0.11111111111111
69600, 1.4173913043478, 0.80217391304348, 0.11111111111111
69601, 1.4173913043478, 0.77608695652174, 0.083333333333333
69602, 1.395652173913, 0.77608695652174, 0.055555555555556
69603, 1.4173913043478, 0.80217391304348, 0.055555555555556
69604, 1.4173913043478, 0.77608695652174, 0.027777777777778
69605, 1.4608695652174, 0.77608695652174, 0.47222222222222
69606, 1.4391304347826, 0.77608695652174, 0.44444444444444
69607, 1.4608695652174, 0.80217391304348, 0.44444444444444
69608, 1.4608695652174, 0.77608695652174, 0.41666666666667
69609, 1.4391304347826, 0.77608695652174, 0.38888888888889
69610, 1.4608695652174, 0.80217391304348, 0.38888888888889
69611, 1.4608695652174, 0.77608695652174, 0.36111111111111
69612, 1.4391304347826, 0.77608695652174, 0.33333333333333
69613, 1.4608695652174, 0.80217391304348, 0.33333333333333
69614, 1.4608695652174, 0.77608695652174, 0.30555555555556
69615, 1.4391304347826, 0.77608695652174, 0.27777777777778
69616, 1.4608695652174, 0.80217391304348, 0.27777777777778
69617, 1.4608695652174, 0.77608695652174, 0.25
69618, 1.4391304347826, 0.77608695652174, 0.22222222222222
69619, 1.4608695652174, 0.80217391304348, 0.22222222222222
69620, 1.4608695652174, 0.77608695652174, 0.19444444444444
69621, 1.4391304347826, 0.77608695652174, 0.16666666666667
69622, 1.4608695652174, 0.80217391304348, 0.16666666666667
69623, 1.4608695652174, 0.77608695652174, 0.13888888888889
69624, 1.4391304347826, 0.77608695652174, 0.11111111111111
69625, 1.4608695652174, 0.80217391304348, 0.11111111111111
69626, 1.4608695652174, 0.77608695652174, 0.083333333333333
69627, 1.4391304347826, 0.77608695652174, 0.055555555555556
69628, 1.4608695652174, 0.80217391304348, 0.055555555555556
69629, 1.4608695652174, 0.77608695652174, 0.027777777777778
69630, 1.504347826087, 0.77608695652174, 0.47222222222222
69631, 1.4826086956522, 0.77608695652174, 0.44444444444444
69632, 1.504347826087, 0.80217391304348, 0.44444444444444
69633, 1.504347826087, 0.77608695652174, 0.41666666666667
69634, 1.4826086956522, 0.77608695652174, 0.38888888888889
69635, 1.504347826087, 0.80217391304348, 0.38888888888889
69636, 1.504347826087, 0.77608695652174, 0.36111111111111
69637, 1.4826086956522, 0.77608695652174, 0.33333333333333
69638, 1.504347826087, 0.80217391304348, 0.33333333333333
69639, 1.504347826087, 0.77608695652174, 0.30555555555556
69640, 1.4826086956522, 0.77608695652174, 0.27777777777778
69641, 1.504347826087, 0.80217391304348, 0.27777777777778
69642, 1.504347826087, 0.77608695652174, 0.25
69643, 1.4826086956522, 0.77608695652174, 0.22222222222222
69644, 1.504347826087, 0.80217391304348, 0.22222222222222
69645, 1.504347826087, 0.77608695652174, 0.19444444444444
69646, 1.4826086956522, 0.77608695652174, 0.16666666666667
69647, 1.504347826087, 0.80217391304348, 0.16666666666667
69648, 1.504347826087, 0.77608695652174, 0.13888888888889
69649, 1.4826086956522, 0.77608695652174, 0.11111111111111
69650, 1.504347826087, 0.80217391304348, 0.11111111111111
69651, 1.504347826087, 0.77608695652174, 0.083333333333333
69652, 1.4826086956522, 0.77608695652174, 0.055555555555556
69653, 1.504347826087, 0.80217391304348, 0.055555555555556
69654, 1.504347826087, 0.77608695652174, 0.027777777777778
69655, 1.5478260869565, 0.77608695652174, 0.47222222222222
69656, 1.5260869565217, 0.77608695652174, 0.44444444444444
69657, 1.5478260869565, 0.80217391304348, 0.44444444444444
69658, 1.5478260869565, 0.77608695652174, 0.41666666666667
69659, 1.5260869565217, 0.77608695652174, 0.38888888888889
69660, 1.5478260869565, 0.80217391304348, 0.38888888888889
69661, 1.5478260869565, 0.77608695652174, 0.36111111111111
69662, 1.5260869565217, 0.77608695652174, 0.33333333333333
69663, 1.5478260869565, 0.80217391304348, 0.33333333333333
69664, 1.5478260869565, 0.77608695652174, 0.30555555555556
69665, 1.5260869565217, 0.77608695652174, 0.27777777777778
69666, 1.5478260869565, 0.80217391304348, 0.27777777777778
69667, 1.5478260869565, 0.77608695652174, 0.25
69668, 1.5260869565217, 0.77608695652174, 0.22222222222222
69669, 1.5478260869565, 0.80217391304348, 0.22222222222222
69670, 1.5478260869565, 0.77608695652174, 0.19444444444444
69671, 1.5260869565217, 0.77608695652174, 0.16666666666667
69672, 1.5478260869565, 0.80217391304348, 0.16666666666667
69673, 1.5478260869565, 0.77608695652174, 0.13888888888889
69674, 1.5260869565217, 0.77608695652174, 0.11111111111111
69675, 1.5478260869565, 0.80217391304348, 0.11111111111111
69676, 1.5478260869565, 0.77608695652174, 0.083333333333333
69677, 1.5260869565217, 0.77608695652174, 0.055555555555556
69678, 1.5478260869565, 0.80217391304348, 0.055555555555556
69679, 1.5478260869565, 0.77608695652174, 0.027777777777778
69680, 1.5913043478261, 0.77608695652174, 0.47222222222222
69681, 1.5695652173913, 0.77608695652174, 0.44444444444444
69682, 1.5913043478261, 0.80217391304348, 0.44444444444444
69683, 1.5913043478261, 0.77608695652174, 0.41666666666667
69684, 1.5695652173913, 0.77608695652174, 0.38888888888889
69685, 1.5913043478261, 0.80217391304348, 0.38888888888889
69686, 1.5913043478261, 0.77608695652174, 0.36111111111111
69687, 1.5695652173913, 0.77608695652174, 0.33333333333333
69688, 1.5913043478261, 0.80217391304348, 0.33333333333333
69689, 1.5913043478261, 0.77608695652174, 0.30555555555556
69690, 1.5695652173913, 0.77608695652174, 0.27777777777778
69691, 1.5913043478261, 0.80217391304348, 0.27777777777778
69692, 1.5913043478261, 0.77608695652174, 0.25
69693, 1.5695652173913, 0.77608695652174, 0.22222222222222
69694, 1.5913043478261, 0.80217391304348, 0.22222222222222
69695, 1.5913043478261, 0.77608695652174, 0.19444444444444
69696, 1.5695652173913, 0.77608695652174, 0.16666666666667
69697, 1.5913043478261, 0.80217391304348, 0.16666666666667
69698, 1.5913043478261, 0.77608695652174, 0.13888888888889
69699, 1.5695652173913, 0.77608695652174, 0.11111111111111
69700, 1.5913043478261, 0.80217391304348, 0.11111111111111
69701, 1.5913043478261, 0.77608695652174, 0.083333333333333
69702, 1.5695652173913, 0.77608695652174, 0.055555555555556
69703, 1.5913043478261, 0.80217391304348, 0.055555555555556
69704, 1.5913043478261, 0.77608695652174, 0.027777777777778
69705, 1.6347826086957, 0.77608695652174, 0.47222222222222
69706, 1.6130434782609, 0.77608695652174, 0.44444444444444
69707, 1.6347826086957, 0.80217391304348, 0.44444444444444
69708, 1.6347826086957, 0.77608695652174, 0.41666666666667
69709, 1.6130434782609, 0.77608695652174, 0.38888888888889
69710, 1.6347826086957, 0.80217391304348, 0.38888888888889
69711, 1.6347826086957, 0.77608695652174, 0.36111111111111
69712, 1.6130434782609, 0.77608695652174, 0.33333333333333
69713, 1.6347826086957, 0.80217391304348, 0.33333333333333
69714, 1.6347826086957, 0.77608695652174, 0.30555555555556
69715, 1.6130434782609, 0.77608695652174, 0.27777777777778
69716, 1.6347826086957, 0.80217391304348, 0.27777777777778
69717, 1.6347826086957, 0.77608695652174, 0.25
69718, 1.6130434782609, 0.77608695652174, 0.22222222222222
69719, 1.6347826086957, 0.80217391304348, 0.22222222222222
69720, 1.6347826086957, 0.77608695652174, 0.19444444444444
69721, 1.6130434782609, 0.77608695652174, 0.16666666666667
69722, 1.6347826086957, 0.80217391304348, 0.16666666666667
69723, 1.6347826086957, 0.77608695652174, 0.13888888888889
69724, 1.6130434782609, 0.77608695652174, 0.11111111111111
69725, 1.6347826086957, 0.80217391304348, 0.11111111111111
69726, 1.6347826086957, 0.77608695652174, 0.083333333333333
69727, 1.6130434782609, 0.77608695652174, 0.055555555555556
69728, 1.6347826086957, 0.80217391304348, 0.055555555555556
69729, 1.6347826086957, 0.77608695652174, 0.027777777777778
69730, 1.6782608695652, 0.77608695652174, 0.47222222222222
69731, 1.6565217391304, 0.77608695652174, 0.44444444444444
69732, 1.6782608695652, 0.80217391304348, 0.44444444444444
69733, 1.6782608695652, 0.77608695652174, 0.41666666666667
69734, 1.6565217391304, 0.77608695652174, 0.38888888888889
69735, 1.6782608695652, 0.80217391304348, 0.38888888888889
69736, 1.6782608695652, 0.77608695652174, 0.36111111111111
69737, 1.6565217391304, 0.77608695652174, 0.33333333333333
69738, 1.6782608695652, 0.80217391304348, 0.33333333333333
69739, 1.6782608695652, 0.77608695652174, 0.30555555555556
69740, 1.6565217391304, 0.77608695652174, 0.27777777777778
69741, 1.6782608695652, 0.80217391304348, 0.27777777777778
69742, 1.6782608695652, 0.77608695652174, 0.25
69743, 1.6565217391304, 0.77608695652174, 0.22222222222222
69744, 1.6782608695652, 0.80217391304348, 0.22222222222222
69745, 1.6782608695652, 0.77608695652174, 0.19444444444444
69746, 1.6565217391304, 0.77608695652174, 0.16666666666667
69747, 1.6782608695652, 0.80217391304348, 0.16666666666667
69748, 1.6782608695652, 0.77608695652174, 0.13888888888889
69749, 1.6565217391304, 0.77608695652174, 0.11111111111111
69750, 1.6782608695652, 0.80217391304348, 0.11111111111111
69751, 1.6782608695652, 0.77608695652174, 0.083333333333333
69752, 1.6565217391304, 0.77608695652174, 0.055555555555556
69753, 1.6782608695652, 0.80217391304348, 0.055555555555556
69754, 1.6782608695652, 0.77608695652174, 0.027777777777778
69755, 1.7217391304348, 0.77608695652174, 0.47222222222222
69756, 1.7, 0.77608695652174, 0.44444444444444
69757, 1.7217391304348, 0.80217391304348, 0.44444444444444
69758, 1.7217391304348, 0.77608695652174, 0.41666666666667
69759, 1.7, 0.77608695652174, 0.38888888888889
69760, 1.7217391304348, 0.80217391304348, 0.38888888888889
69761, 1.7217391304348, 0.77608695652174, 0.36111111111111
69762, 1.7, 0.77608695652174, 0.33333333333333
69763, 1.7217391304348, 0.80217391304348, 0.33333333333333
69764, 1.7217391304348, 0.77608695652174, 0.30555555555556
69765, 1.7, 0.77608695652174, 0.27777777777778
69766, 1.7217391304348, 0.80217391304348, 0.27777777777778
69767, 1.7217391304348, 0.77608695652174, 0.25
69768, 1.7, 0.77608695652174, 0.22222222222222
69769, 1.7217391304348, 0.80217391304348, 0.22222222222222
69770, 1.7217391304348, 0.77608695652174, 0.19444444444444
69771, 1.7, 0.77608695652174, 0.16666666666667
69772, 1.7217391304348, 0.80217391304348, 0.16666666666667
69773, 1.7217391304348, 0.77608695652174, 0.13888888888889
69774, 1.7, 0.77608695652174, 0.11111111111111
69775, 1.7217391304348, 0.80217391304348, 0.11111111111111
69776, 1.7217391304348, 0.77608695652174, 0.083333333333333
69777, 1.7, 0.77608695652174, 0.055555555555556
69778, 1.7217391304348, 0.80217391304348, 0.055555555555556
69779, 1.7217391304348, 0.77608695652174, 0.027777777777778
69780, 1.7652173913043, 0.77608695652174, 0.47222222222222
69781, 1.7434782608696, 0.77608695652174, 0.44444444444444
69782, 1.7652173913043, 0.80217391304348, 0.44444444444444
69783, 1.7652173913043, 0.77608695652174, 0.41666666666667
69784, 1.7434782608696, 0.77608695652174, 0.38888888888889
69785, 1.7652173913043, 0.80217391304348, 0.38888888888889
69786, 1.7652173913043, 0.77608695652174, 0.36111111111111
69787, 1.7434782608696, 0.77608695652174, 0.33333333333333
69788, 1.7652173913043, 0.80217391304348, 0.33333333333333
69789, 1.7652173913043, 0.77608695652174, 0.30555555555556
69790, 1.7434782608696, 0.77608695652174, 0.27777777777778
69791, 1.7652173913043, 0.80217391304348, 0.27777777777778
69792, 1.7652173913043, 0.77608695652174, 0.25
69793, 1.7434782608696, 0.77608695652174, 0.22222222222222
69794, 1.7652173913043, 0.80217391304348, 0.22222222222222
69795, 1.7652173913043, 0.77608695652174, 0.19444444444444
69796, 1.7434782608696, 0.77608695652174, 0.16666666666667
69797, 1.7652173913043, 0.80217391304348, 0.16666666666667
69798, 1.7652173913043, 0.77608695652174, 0.13888888888889
69799, 1.7434782608696, 0.77608695652174, 0.11111111111111
69800, 1.7652173913043, 0.80217391304348, 0.11111111111111
69801, 1.7652173913043, 0.77608695652174, 0.083333333333333
69802, 1.7434782608696, 0.77608695652174, 0.055555555555556
69803, 1.7652173913043, 0.80217391304348, 0.055555555555556
69804, 1.7652173913043, 0.77608695652174, 0.027777777777778
69805, 1.8086956521739, 0.77608695652174, 0.47222222222222
69806, 1.7869565217391, 0.77608695652174, 0.44444444444444
69807, 1.8086956521739, 0.80217391304348, 0.44444444444444
69808, 1.8086956521739, 0.77608695652174, 0.41666666666667
69809, 1.7869565217391, 0.77608695652174, 0.38888888888889
69810, 1.8086956521739, 0.80217391304348, 0.38888888888889
69811, 1.8086956521739, 0.77608695652174, 0.36111111111111
69812, 1.7869565217391, 0.77608695652174, 0.33333333333333
69813, 1.8086956521739, 0.80217391304348, 0.33333333333333
69814, 1.8086956521739, 0.77608695652174, 0.30555555555556
69815, 1.7869565217391, 0.77608695652174, 0.27777777777778
69816, 1.8086956521739, 0.80217391304348, 0.27777777777778
69817, 1.8086956521739, 0.77608695652174, 0.25
69818, 1.7869565217391, 0.77608695652174, 0.22222222222222
69819, 1.8086956521739, 0.80217391304348, 0.22222222222222
69820, 1.8086956521739, 0.77608695652174, 0.19444444444444
69821, 1.7869565217391, 0.77608695652174, 0.16666666666667
69822, 1.8086956521739, 0.80217391304348, 0.16666666666667
69823, 1.8086956521739, 0.77608695652174, 0.13888888888889
69824, 1.7869565217391, 0.77608695652174, 0.11111111111111
69825, 1.8086956521739, 0.80217391304348, 0.11111111111111
69826, 1.8086956521739, 0.77608695652174, 0.083333333333333
69827, 1.7869565217391, 0.77608695652174, 0.055555555555556
69828, 1.8086956521739, 0.80217391304348, 0.055555555555556
69829, 1.8086956521739, 0.77608695652174, 0.027777777777778
69830, 1.8521739130435, 0.77608695652174, 0.47222222222222
69831, 1.8304347826087, 0.77608695652174, 0.44444444444444
69832, 1.8521739130435, 0.80217391304348, 0.44444444444444
69833, 1.8521739130435, 0.77608695652174, 0.41666666666667
69834, 1.8304347826087, 0.77608695652174, 0.38888888888889
69835, 1.8521739130435, 0.80217391304348, 0.38888888888889
69836, 1.8521739130435, 0.77608695652174, 0.36111111111111
69837, 1.8304347826087, 0.77608695652174, 0.33333333333333
69838, 1.8521739130435, 0.80217391304348, 0.33333333333333
69839, 1.8521739130435, 0.77608695652174, 0.30555555555556
69840, 1.8304347826087, 0.77608695652174, 0.27777777777778
69841, 1.8521739130435, 0.80217391304348, 0.27777777777778
69842, 1.8521739130435, 0.77608695652174, 0.25
69843, 1.8304347826087, 0.77608695652174, 0.22222222222222
69844, 1.8521739130435, 0.80217391304348, 0.22222222222222
69845, 1.8521739130435, 0.77608695652174, 0.19444444444444
69846, 1.8304347826087, 0.77608695652174, 0.16666666666667
69847, 1.8521739130435, 0.80217391304348, 0.16666666666667
69848, 1.8521739130435, 0.77608695652174, 0.13888888888889
69849, 1.8304347826087, 0.77608695652174, 0.11111111111111
69850, 1.8521739130435, 0.80217391304348, 0.11111111111111
69851, 1.8521739130435, 0.77608695652174, 0.083333333333333
69852, 1.8304347826087, 0.77608695652174, 0.055555555555556
69853, 1.8521739130435, 0.80217391304348, 0.055555555555556
69854, 1.8521739130435, 0.77608695652174, 0.027777777777778
69855, 1.895652173913, 0.77608695652174, 0.47222222222222
69856, 1.8739130434783, 0.77608695652174, 0.44444444444444
69857, 1.895652173913, 0.80217391304348, 0.44444444444444
69858, 1.895652173913, 0.77608695652174, 0.41666666666667
69859, 1.8739130434783, 0.77608695652174, 0.38888888888889
69860, 1.895652173913, 0.80217391304348, 0.38888888888889
69861, 1.895652173913, 0.77608695652174, 0.36111111111111
69862, 1.8739130434783, 0.77608695652174, 0.33333333333333
69863, 1.895652173913, 0.80217391304348, 0.33333333333333
69864, 1.895652173913, 0.77608695652174, 0.30555555555556
69865, 1.8739130434783, 0.77608695652174, 0.27777777777778
69866, 1.895652173913, 0.80217391304348, 0.27777777777778
69867, 1.895652173913, 0.77608695652174, 0.25
69868, 1.8739130434783, 0.77608695652174, 0.22222222222222
69869, 1.895652173913, 0.80217391304348, 0.22222222222222
69870, 1.895652173913, 0.77608695652174, 0.19444444444444
69871, 1.8739130434783, 0.77608695652174, 0.16666666666667
69872, 1.895652173913, 0.80217391304348, 0.16666666666667
69873, 1.895652173913, 0.77608695652174, 0.13888888888889
69874, 1.8739130434783, 0.77608695652174, 0.11111111111111
69875, 1.895652173913, 0.80217391304348, 0.11111111111111
69876, 1.895652173913, 0.77608695652174, 0.083333333333333
69877, 1.8739130434783, 0.77608695652174, 0.055555555555556
69878, 1.895652173913, 0.80217391304348, 0.055555555555556
69879, 1.895652173913, 0.77608695652174, 0.027777777777778
69880, 1.9391304347826, 0.77608695652174, 0.47222222222222
69881, 1.9173913043478, 0.77608695652174, 0.44444444444444
69882, 1.9391304347826, 0.80217391304348, 0.44444444444444
69883, 1.9391304347826, 0.77608695652174, 0.41666666666667
69884, 1.9173913043478, 0.77608695652174, 0.38888888888889
69885, 1.9391304347826, 0.80217391304348, 0.38888888888889
69886, 1.9391304347826, 0.77608695652174, 0.36111111111111
69887, 1.9173913043478, 0.77608695652174, 0.33333333333333
69888, 1.9391304347826, 0.80217391304348, 0.33333333333333
69889, 1.9391304347826, 0.77608695652174, 0.30555555555556
69890, 1.9173913043478, 0.77608695652174, 0.27777777777778
69891, 1.9391304347826, 0.80217391304348, 0.27777777777778
69892, 1.9391304347826, 0.77608695652174, 0.25
69893, 1.9173913043478, 0.77608695652174, 0.22222222222222
69894, 1.9391304347826, 0.80217391304348, 0.22222222222222
69895, 1.9391304347826, 0.77608695652174, 0.19444444444444
69896, 1.9173913043478, 0.77608695652174, 0.16666666666667
69897, 1.9391304347826, 0.80217391304348, 0.16666666666667
69898, 1.9391304347826, 0.77608695652174, 0.13888888888889
69899, 1.9173913043478, 0.77608695652174, 0.11111111111111
69900, 1.9391304347826, 0.80217391304348, 0.11111111111111
69901, 1.9391304347826, 0.77608695652174, 0.083333333333333
69902, 1.9173913043478, 0.77608695652174, 0.055555555555556
69903, 1.9391304347826, 0.80217391304348, 0.055555555555556
69904, 1.9391304347826, 0.77608695652174, 0.027777777777778
69905, 1.9826086956522, 0.77608695652174, 0.47222222222222
69906, 1.9608695652174, 0.77608695652174, 0.44444444444444
69907, 1.9826086956522, 0.80217391304348, 0.44444444444444
69908, 1.9826086956522, 0.77608695652174, 0.41666666666667
69909, 1.9608695652174, 0.77608695652174, 0.38888888888889
69910, 1.9826086956522, 0.80217391304348, 0.38888888888889
69911, 1.9826086956522, 0.77608695652174, 0.36111111111111
69912, 1.9608695652174, 0.77608695652174, 0.33333333333333
69913, 1.9826086956522, 0.80217391304348, 0.33333333333333
69914, 1.9826086956522, 0.77608695652174, 0.30555555555556
69915, 1.9608695652174, 0.77608695652174, 0.27777777777778
69916, 1.9826086956522, 0.80217391304348, 0.27777777777778
69917, 1.9826086956522, 0.77608695652174, 0.25
69918, 1.9608695652174, 0.77608695652174, 0.22222222222222
69919, 1.9826086956522, 0.80217391304348, 0.22222222222222
69920, 1.9826086956522, 0.77608695652174, 0.19444444444444
69921, 1.9608695652174, 0.77608695652174, 0.16666666666667
69922, 1.9826086956522, 0.80217391304348, 0.16666666666667
69923, 1.9826086956522, 0.77608695652174, 0.13888888888889
69924, 1.9608695652174, 0.77608695652174, 0.11111111111111
69925, 1.9826086956522, 0.80217391304348, 0.11111111111111
69926, 1.9826086956522, 0.77608695652174, 0.083333333333333
69927, 1.9608695652174, 0.77608695652174, 0.055555555555556
69928, 1.9826086956522, 0.80217391304348, 0.055555555555556
69929, 1.9826086956522, 0.77608695652174, 0.027777777777778
69930, 2.0260869565217, 0.77608695652174, 0.47222222222222
69931, 2.004347826087, 0.77608695652174, 0.44444444444444
69932, 2.0260869565217, 0.80217391304348, 0.44444444444444
69933, 2.0260869565217, 0.77608695652174, 0.41666666666667
69934, 2.004347826087, 0.77608695652174, 0.38888888888889
69935, 2.0260869565217, 0.80217391304348, 0.38888888888889
69936, 2.0260869565217, 0.77608695652174, 0.36111111111111
69937, 2.004347826087, 0.77608695652174, 0.33333333333333
69938, 2.0260869565217, 0.80217391304348, 0.33333333333333
69939, 2.0260869565217, 0.77608695652174, 0.30555555555556
69940, 2.004347826087, 0.77608695652174, 0.27777777777778
69941, 2.0260869565217, 0.80217391304348, 0.27777777777778
69942, 2.0260869565217, 0.77608695652174, 0.25
69943, 2.004347826087, 0.77608695652174, 0.22222222222222
69944, 2.0260869565217, 0.80217391304348, 0.22222222222222
69945, 2.0260869565217, 0.77608695652174, 0.19444444444444
69946, 2.004347826087, 0.77608695652174, 0.16666666666667
69947, 2.0260869565217, 0.80217391304348, 0.16666666666667
69948, 2.0260869565217, 0.77608695652174, 0.13888888888889
69949, 2.004347826087, 0.77608695652174, 0.11111111111111
69950, 2.0260869565217, 0.80217391304348, 0.11111111111111
69951, 2.0260869565217, 0.77608695652174, 0.083333333333333
69952, 2.004347826087, 0.77608695652174, 0.055555555555556
69953, 2.0260869565217, 0.80217391304348, 0.055555555555556
69954, 2.0260869565217, 0.77608695652174, 0.027777777777778
69955, 2.0695652173913, 0.77608695652174, 0.47222222222222
69956, 2.0478260869565, 0.77608695652174, 0.44444444444444
69957, 2.0695652173913, 0.80217391304348, 0.44444444444444
69958, 2.0695652173913, 0.77608695652174, 0.41666666666667
69959, 2.0478260869565, 0.77608695652174, 0.38888888888889
69960, 2.0695652173913, 0.80217391304348, 0.38888888888889
69961, 2.0695652173913, 0.77608695652174, 0.36111111111111
69962, 2.0478260869565, 0.77608695652174, 0.33333333333333
69963, 2.0695652173913, 0.80217391304348, 0.33333333333333
69964, 2.0695652173913, 0.77608695652174, 0.30555555555556
69965, 2.0478260869565, 0.77608695652174, 0.27777777777778
69966, 2.0695652173913, 0.80217391304348, 0.27777777777778
69967, 2.0695652173913, 0.77608695652174, 0.25
69968, 2.0478260869565, 0.77608695652174, 0.22222222222222
69969, 2.0695652173913, 0.80217391304348, 0.22222222222222
69970, 2.0695652173913, 0.77608695652174, 0.19444444444444
69971, 2.0478260869565, 0.77608695652174, 0.16666666666667
69972, 2.0695652173913, 0.80217391304348, 0.16666666666667
69973, 2.0695652173913, 0.77608695652174, 0.13888888888889
69974, 2.0478260869565, 0.77608695652174, 0.11111111111111
69975, 2.0695652173913, 0.80217391304348, 0.11111111111111
69976, 2.0695652173913, 0.77608695652174, 0.083333333333333
69977, 2.0478260869565, 0.77608695652174, 0.055555555555556
69978, 2.0695652173913, 0.80217391304348, 0.055555555555556
69979, 2.0695652173913, 0.77608695652174, 0.027777777777778
69980, 2.1130434782609, 0.77608695652174, 0.47222222222222
69981, 2.0913043478261, 0.77608695652174, 0.44444444444444
69982, 2.1130434782609, 0.80217391304348, 0.44444444444444
69983, 2.1130434782609, 0.77608695652174, 0.41666666666667
69984, 2.0913043478261, 0.77608695652174, 0.38888888888889
69985, 2.1130434782609, 0.80217391304348, 0.38888888888889
69986, 2.1130434782609, 0.77608695652174, 0.36111111111111
69987, 2.0913043478261, 0.77608695652174, 0.33333333333333
69988, 2.1130434782609, 0.80217391304348, 0.33333333333333
69989, 2.1130434782609, 0.77608695652174, 0.30555555555556
69990, 2.0913043478261, 0.77608695652174, 0.27777777777778
69991, 2.1130434782609, 0.80217391304348, 0.27777777777778
69992, 2.1130434782609, 0.77608695652174, 0.25
69993, 2.0913043478261, 0.77608695652174, 0.22222222222222
69994, 2.1130434782609, 0.80217391304348, 0.22222222222222
69995, 2.1130434782609, 0.77608695652174, 0.19444444444444
69996, 2.0913043478261, 0.77608695652174, 0.16666666666667
69997, 2.1130434782609, 0.80217391304348, 0.16666666666667
69998, 2.1130434782609, 0.77608695652174, 0.13888888888889
69999, 2.0913043478261, 0.77608695652174, 0.11111111111111
70000, 2.1130434782609, 0.80217391304348, 0.11111111111111
70001, 2.1130434782609, 0.77608695652174, 0.083333333333333
70002, 2.0913043478261, 0.77608695652174, 0.055555555555556
70003, 2.1130434782609, 0.80217391304348, 0.055555555555556
70004, 2.1130434782609, 0.77608695652174, 0.027777777777778
70005, 2.1565217391304, 0.77608695652174, 0.47222222222222
70006, 2.1347826086957, 0.77608695652174, 0.44444444444444
70007, 2.1565217391304, 0.80217391304348, 0.44444444444444
70008, 2.1565217391304, 0.77608695652174, 0.41666666666667
70009, 2.1347826086957, 0.77608695652174, 0.38888888888889
70010, 2.1565217391304, 0.80217391304348, 0.38888888888889
70011, 2.1565217391304, 0.77608695652174, 0.36111111111111
70012, 2.1347826086957, 0.77608695652174, 0.33333333333333
70013, 2.1565217391304, 0.80217391304348, 0.33333333333333
70014, 2.1565217391304, 0.77608695652174, 0.30555555555556
70015, 2.1347826086957, 0.77608695652174, 0.27777777777778
70016, 2.1565217391304, 0.80217391304348, 0.27777777777778
70017, 2.1565217391304, 0.77608695652174, 0.25
70018, 2.1347826086957, 0.77608695652174, 0.22222222222222
70019, 2.1565217391304, 0.80217391304348, 0.22222222222222
70020, 2.1565217391304, 0.77608695652174, 0.19444444444444
70021, 2.1347826086957, 0.77608695652174, 0.16666666666667
70022, 2.1565217391304, 0.80217391304348, 0.16666666666667
70023, 2.1565217391304, 0.77608695652174, 0.13888888888889
70024, 2.1347826086957, 0.77608695652174, 0.11111111111111
70025, 2.1565217391304, 0.80217391304348, 0.11111111111111
70026, 2.1565217391304, 0.77608695652174, 0.083333333333333
70027, 2.1347826086957, 0.77608695652174, 0.055555555555556
70028, 2.1565217391304, 0.80217391304348, 0.055555555555556
70029, 2.1565217391304, 0.77608695652174, 0.027777777777778
70030, 2.1782608695652, 0.77608695652174, 0.44444444444444
70031, 2.1782608695652, 0.77608695652174, 0.38888888888889
70032, 2.1782608695652, 0.77608695652174, 0.33333333333333
70033, 2.1782608695652, 0.77608695652174, 0.27777777777778
70034, 2.1782608695652, 0.77608695652174, 0.22222222222222
70035, 2.1782608695652, 0.77608695652174, 0.16666666666667
70036, 2.1782608695652, 0.77608695652174, 0.11111111111111
70037, 2.1782608695652, 0.77608695652174, 0.055555555555556
70038, 1.2434782608696, 0.72391304347826, 0.47222222222222
70039, 1.2217391304348, 0.72391304347826, 0.44444444444444
70040, 1.2434782608696, 0.75, 0.44444444444444
70041, 1.2434782608696, 0.72391304347826, 0.41666666666667
70042, 1.2217391304348, 0.72391304347826, 0.38888888888889
70043, 1.2434782608696, 0.75, 0.38888888888889
70044, 1.2434782608696, 0.72391304347826, 0.36111111111111
70045, 1.2217391304348, 0.72391304347826, 0.33333333333333
70046, 1.2434782608696, 0.75, 0.33333333333333
70047, 1.2434782608696, 0.72391304347826, 0.30555555555556
70048, 1.2217391304348, 0.72391304347826, 0.27777777777778
70049, 1.2434782608696, 0.75, 0.27777777777778
70050, 1.2434782608696, 0.72391304347826, 0.25
70051, 1.2217391304348, 0.72391304347826, 0.22222222222222
70052, 1.2434782608696, 0.75, 0.22222222222222
70053, 1.2434782608696, 0.72391304347826, 0.19444444444444
70054, 1.2217391304348, 0.72391304347826, 0.16666666666667
70055, 1.2434782608696, 0.75, 0.16666666666667
70056, 1.2434782608696, 0.72391304347826, 0.13888888888889
70057, 1.2217391304348, 0.72391304347826, 0.11111111111111
70058, 1.2434782608696, 0.75, 0.11111111111111
70059, 1.2434782608696, 0.72391304347826, 0.083333333333333
70060, 1.2217391304348, 0.72391304347826, 0.055555555555556
70061, 1.2434782608696, 0.75, 0.055555555555556
70062, 1.2434782608696, 0.72391304347826, 0.027777777777778
70063, 1.2869565217391, 0.72391304347826, 0.47222222222222
70064, 1.2652173913043, 0.72391304347826, 0.44444444444444
70065, 1.2869565217391, 0.75, 0.44444444444444
70066, 1.2869565217391, 0.72391304347826, 0.41666666666667
70067, 1.2652173913043, 0.72391304347826, 0.38888888888889
70068, 1.2869565217391, 0.75, 0.38888888888889
70069, 1.2869565217391, 0.72391304347826, 0.36111111111111
70070, 1.2652173913043, 0.72391304347826, 0.33333333333333
70071, 1.2869565217391, 0.75, 0.33333333333333
70072, 1.2869565217391, 0.72391304347826, 0.30555555555556
70073, 1.2652173913043, 0.72391304347826, 0.27777777777778
70074, 1.2869565217391, 0.75, 0.27777777777778
70075, 1.2869565217391, 0.72391304347826, 0.25
70076, 1.2652173913043, 0.72391304347826, 0.22222222222222
70077, 1.2869565217391, 0.75, 0.22222222222222
70078, 1.2869565217391, 0.72391304347826, 0.19444444444444
70079, 1.2652173913043, 0.72391304347826, 0.16666666666667
70080, 1.2869565217391, 0.75, 0.16666666666667
70081, 1.2869565217391, 0.72391304347826, 0.13888888888889
70082, 1.2652173913043, 0.72391304347826, 0.11111111111111
70083, 1.2869565217391, 0.75, 0.11111111111111
70084, 1.2869565217391, 0.72391304347826, 0.083333333333333
70085, 1.2652173913043, 0.72391304347826, 0.055555555555556
70086, 1.2869565217391, 0.75, 0.055555555555556
70087, 1.2869565217391, 0.72391304347826, 0.027777777777778
70088, 1.3304347826087, 0.72391304347826, 0.47222222222222
70089, 1.3086956521739, 0.72391304347826, 0.44444444444444
70090, 1.3304347826087, 0.75, 0.44444444444444
70091, 1.3304347826087, 0.72391304347826, 0.41666666666667
70092, 1.3086956521739, 0.72391304347826, 0.38888888888889
70093, 1.3304347826087, 0.75, 0.38888888888889
70094, 1.3304347826087, 0.72391304347826, 0.36111111111111
70095, 1.3086956521739, 0.72391304347826, 0.33333333333333
70096, 1.3304347826087, 0.75, 0.33333333333333
70097, 1.3304347826087, 0.72391304347826, 0.30555555555556
70098, 1.3086956521739, 0.72391304347826, 0.27777777777778
70099, 1.3304347826087, 0.75, 0.27777777777778
70100, 1.3304347826087, 0.72391304347826, 0.25
70101, 1.3086956521739, 0.72391304347826, 0.22222222222222
70102, 1.3304347826087, 0.75, 0.22222222222222
70103, 1.3304347826087, 0.72391304347826, 0.19444444444444
70104, 1.3086956521739, 0.72391304347826, 0.16666666666667
70105, 1.3304347826087, 0.75, 0.16666666666667
70106, 1.3304347826087, 0.72391304347826, 0.13888888888889
70107, 1.3086956521739, 0.72391304347826, 0.11111111111111
70108, 1.3304347826087, 0.75, 0.11111111111111
70109, 1.3304347826087, 0.72391304347826, 0.083333333333333
70110, 1.3086956521739, 0.72391304347826, 0.055555555555556
70111, 1.3304347826087, 0.75, 0.055555555555556
70112, 1.3304347826087, 0.72391304347826, 0.027777777777778
70113, 1.3739130434783, 0.72391304347826, 0.47222222222222
70114, 1.3521739130435, 0.72391304347826, 0.44444444444444
70115, 1.3739130434783, 0.75, 0.44444444444444
70116, 1.3739130434783, 0.72391304347826, 0.41666666666667
70117, 1.3521739130435, 0.72391304347826, 0.38888888888889
70118, 1.3739130434783, 0.75, 0.38888888888889
70119, 1.3739130434783, 0.72391304347826, 0.36111111111111
70120, 1.3521739130435, 0.72391304347826, 0.33333333333333
70121, 1.3739130434783, 0.75, 0.33333333333333
70122, 1.3739130434783, 0.72391304347826, 0.30555555555556
70123, 1.3521739130435, 0.72391304347826, 0.27777777777778
70124, 1.3739130434783, 0.75, 0.27777777777778
70125, 1.3739130434783, 0.72391304347826, 0.25
70126, 1.3521739130435, 0.72391304347826, 0.22222222222222
70127, 1.3739130434783, 0.75, 0.22222222222222
70128, 1.3739130434783, 0.72391304347826, 0.19444444444444
70129, 1.3521739130435, 0.72391304347826, 0.16666666666667
70130, 1.3739130434783, 0.75, 0.16666666666667
70131, 1.3739130434783, 0.72391304347826, 0.13888888888889
70132, 1.3521739130435, 0.72391304347826, 0.11111111111111
70133, 1.3739130434783, 0.75, 0.11111111111111
70134, 1.3739130434783, 0.72391304347826, 0.083333333333333
70135, 1.3521739130435, 0.72391304347826, 0.055555555555556
70136, 1.3739130434783, 0.75, 0.055555555555556
70137, 1.3739130434783, 0.72391304347826, 0.027777777777778
70138, 1.4173913043478, 0.72391304347826, 0.47222222222222
70139, 1.395652173913, 0.72391304347826, 0.44444444444444
70140, 1.4173913043478, 0.75, 0.44444444444444
70141, 1.4173913043478, 0.72391304347826, 0.41666666666667
70142, 1.395652173913, 0.72391304347826, 0.38888888888889
70143, 1.4173913043478, 0.75, 0.38888888888889
70144, 1.4173913043478, 0.72391304347826, 0.36111111111111
70145, 1.395652173913, 0.72391304347826, 0.33333333333333
70146, 1.4173913043478, 0.75, 0.33333333333333
70147, 1.4173913043478, 0.72391304347826, 0.30555555555556
70148, 1.395652173913, 0.72391304347826, 0.27777777777778
70149, 1.4173913043478, 0.75, 0.27777777777778
70150, 1.4173913043478, 0.72391304347826, 0.25
70151, 1.395652173913, 0.72391304347826, 0.22222222222222
70152, 1.4173913043478, 0.75, 0.22222222222222
70153, 1.4173913043478, 0.72391304347826, 0.19444444444444
70154, 1.395652173913, 0.72391304347826, 0.16666666666667
70155, 1.4173913043478, 0.75, 0.16666666666667
70156, 1.4173913043478, 0.72391304347826, 0.13888888888889
70157, 1.395652173913, 0.72391304347826, 0.11111111111111
70158, 1.4173913043478, 0.75, 0.11111111111111
70159, 1.4173913043478, 0.72391304347826, 0.083333333333333
70160, 1.395652173913, 0.72391304347826, 0.055555555555556
70161, 1.4173913043478, 0.75, 0.055555555555556
70162, 1.4173913043478, 0.72391304347826, 0.027777777777778
70163, 1.4608695652174, 0.72391304347826, 0.47222222222222
70164, 1.4391304347826, 0.72391304347826, 0.44444444444444
70165, 1.4608695652174, 0.75, 0.44444444444444
70166, 1.4608695652174, 0.72391304347826, 0.41666666666667
70167, 1.4391304347826, 0.72391304347826, 0.38888888888889
70168, 1.4608695652174, 0.75, 0.38888888888889
70169, 1.4608695652174, 0.72391304347826, 0.36111111111111
70170, 1.4391304347826, 0.72391304347826, 0.33333333333333
70171, 1.4608695652174, 0.75, 0.33333333333333
70172, 1.4608695652174, 0.72391304347826, 0.30555555555556
70173, 1.4391304347826, 0.72391304347826, 0.27777777777778
70174, 1.4608695652174, 0.75, 0.27777777777778
70175, 1.4608695652174, 0.72391304347826, 0.25
70176, 1.4391304347826, 0.72391304347826, 0.22222222222222
70177, 1.4608695652174, 0.75, 0.22222222222222
70178, 1.4608695652174, 0.72391304347826, 0.19444444444444
70179, 1.4391304347826, 0.72391304347826, 0.16666666666667
70180, 1.4608695652174, 0.75, 0.16666666666667
70181, 1.4608695652174, 0.72391304347826, 0.13888888888889
70182, 1.4391304347826, 0.72391304347826, 0.11111111111111
70183, 1.4608695652174, 0.75, 0.11111111111111
70184, 1.4608695652174, 0.72391304347826, 0.083333333333333
70185, 1.4391304347826, 0.72391304347826, 0.055555555555556
70186, 1.4608695652174, 0.75, 0.055555555555556
70187, 1.4608695652174, 0.72391304347826, 0.027777777777778
70188, 1.504347826087, 0.72391304347826, 0.47222222222222
70189, 1.4826086956522, 0.72391304347826, 0.44444444444444
70190, 1.504347826087, 0.75, 0.44444444444444
70191, 1.504347826087, 0.72391304347826, 0.41666666666667
70192, 1.4826086956522, 0.72391304347826, 0.38888888888889
70193, 1.504347826087, 0.75, 0.38888888888889
70194, 1.504347826087, 0.72391304347826, 0.36111111111111
70195, 1.4826086956522, 0.72391304347826, 0.33333333333333
70196, 1.504347826087, 0.75, 0.33333333333333
70197, 1.504347826087, 0.72391304347826, 0.30555555555556
70198, 1.4826086956522, 0.72391304347826, 0.27777777777778
70199, 1.504347826087, 0.75, 0.27777777777778
70200, 1.504347826087, 0.72391304347826, 0.25
70201, 1.4826086956522, 0.72391304347826, 0.22222222222222
70202, 1.504347826087, 0.75, 0.22222222222222
70203, 1.504347826087, 0.72391304347826, 0.19444444444444
70204, 1.4826086956522, 0.72391304347826, 0.16666666666667
70205, 1.504347826087, 0.75, 0.16666666666667
70206, 1.504347826087, 0.72391304347826, 0.13888888888889
70207, 1.4826086956522, 0.72391304347826, 0.11111111111111
70208, 1.504347826087, 0.75, 0.11111111111111
70209, 1.504347826087, 0.72391304347826, 0.083333333333333
70210, 1.4826086956522, 0.72391304347826, 0.055555555555556
70211, 1.504347826087, 0.75, 0.055555555555556
70212, 1.504347826087, 0.72391304347826, 0.027777777777778
70213, 1.5478260869565, 0.72391304347826, 0.47222222222222
70214, 1.5260869565217, 0.72391304347826, 0.44444444444444
70215, 1.5478260869565, 0.75, 0.44444444444444
70216, 1.5478260869565, 0.72391304347826, 0.41666666666667
70217, 1.5260869565217, 0.72391304347826, 0.38888888888889
70218, 1.5478260869565, 0.75, 0.38888888888889
70219, 1.5478260869565, 0.72391304347826, 0.36111111111111
70220, 1.5260869565217, 0.72391304347826, 0.33333333333333
70221, 1.5478260869565, 0.75, 0.33333333333333
70222, 1.5478260869565, 0.72391304347826, 0.30555555555556
70223, 1.5260869565217, 0.72391304347826, 0.27777777777778
70224, 1.5478260869565, 0.75, 0.27777777777778
70225, 1.5478260869565, 0.72391304347826, 0.25
70226, 1.5260869565217, 0.72391304347826, 0.22222222222222
70227, 1.5478260869565, 0.75, 0.22222222222222
70228, 1.5478260869565, 0.72391304347826, 0.19444444444444
70229, 1.5260869565217, 0.72391304347826, 0.16666666666667
70230, 1.5478260869565, 0.75, 0.16666666666667
70231, 1.5478260869565, 0.72391304347826, 0.13888888888889
70232, 1.5260869565217, 0.72391304347826, 0.11111111111111
70233, 1.5478260869565, 0.75, 0.11111111111111
70234, 1.5478260869565, 0.72391304347826, 0.083333333333333
70235, 1.5260869565217, 0.72391304347826, 0.055555555555556
70236, 1.5478260869565, 0.75, 0.055555555555556
70237, 1.5478260869565, 0.72391304347826, 0.027777777777778
70238, 1.5913043478261, 0.72391304347826, 0.47222222222222
70239, 1.5695652173913, 0.72391304347826, 0.44444444444444
70240, 1.5913043478261, 0.75, 0.44444444444444
70241, 1.5913043478261, 0.72391304347826, 0.41666666666667
70242, 1.5695652173913, 0.72391304347826, 0.38888888888889
70243, 1.5913043478261, 0.75, 0.38888888888889
70244, 1.5913043478261, 0.72391304347826, 0.36111111111111
70245, 1.5695652173913, 0.72391304347826, 0.33333333333333
70246, 1.5913043478261, 0.75, 0.33333333333333
70247, 1.5913043478261, 0.72391304347826, 0.30555555555556
70248, 1.5695652173913, 0.72391304347826, 0.27777777777778
70249, 1.5913043478261, 0.75, 0.27777777777778
70250, 1.5913043478261, 0.72391304347826, 0.25
70251, 1.5695652173913, 0.72391304347826, 0.22222222222222
70252, 1.5913043478261, 0.75, 0.22222222222222
70253, 1.5913043478261, 0.72391304347826, 0.19444444444444
70254, 1.5695652173913, 0.72391304347826, 0.16666666666667
70255, 1.5913043478261, 0.75, 0.16666666666667
70256, 1.5913043478261, 0.72391304347826, 0.13888888888889
70257, 1.5695652173913, 0.72391304347826, 0.11111111111111
70258, 1.5913043478261, 0.75, 0.11111111111111
70259, 1.5913043478261, 0.72391304347826, 0.083333333333333
70260, 1.5695652173913, 0.72391304347826, 0.055555555555556
70261, 1.5913043478261, 0.75, 0.055555555555556
70262, 1.5913043478261, 0.72391304347826, 0.027777777777778
70263, 1.6347826086957, 0.72391304347826, 0.47222222222222
70264, 1.6130434782609, 0.72391304347826, 0.44444444444444
70265, 1.6347826086957, 0.75, 0.44444444444444
70266, 1.6347826086957, 0.72391304347826, 0.41666666666667
70267, 1.6130434782609, 0.72391304347826, 0.38888888888889
70268, 1.6347826086957, 0.75, 0.38888888888889
70269, 1.6347826086957, 0.72391304347826, 0.36111111111111
70270, 1.6130434782609, 0.72391304347826, 0.33333333333333
70271, 1.6347826086957, 0.75, 0.33333333333333
70272, 1.6347826086957, 0.72391304347826, 0.30555555555556
70273, 1.6130434782609, 0.72391304347826, 0.27777777777778
70274, 1.6347826086957, 0.75, 0.27777777777778
70275, 1.6347826086957, 0.72391304347826, 0.25
70276, 1.6130434782609, 0.72391304347826, 0.22222222222222
70277, 1.6347826086957, 0.75, 0.22222222222222
70278, 1.6347826086957, 0.72391304347826, 0.19444444444444
70279, 1.6130434782609, 0.72391304347826, 0.16666666666667
70280, 1.6347826086957, 0.75, 0.16666666666667
70281, 1.6347826086957, 0.72391304347826, 0.13888888888889
70282, 1.6130434782609, 0.72391304347826, 0.11111111111111
70283, 1.6347826086957, 0.75, 0.11111111111111
70284, 1.6347826086957, 0.72391304347826, 0.083333333333333
70285, 1.6130434782609, 0.72391304347826, 0.055555555555556
70286, 1.6347826086957, 0.75, 0.055555555555556
70287, 1.6347826086957, 0.72391304347826, 0.027777777777778
70288, 1.6782608695652, 0.72391304347826, 0.47222222222222
70289, 1.6565217391304, 0.72391304347826, 0.44444444444444
70290, 1.6782608695652, 0.75, 0.44444444444444
70291, 1.6782608695652, 0.72391304347826, 0.41666666666667
70292, 1.6565217391304, 0.72391304347826, 0.38888888888889
70293, 1.6782608695652, 0.75, 0.38888888888889
70294, 1.6782608695652, 0.72391304347826, 0.36111111111111
70295, 1.6565217391304, 0.72391304347826, 0.33333333333333
70296, 1.6782608695652, 0.75, 0.33333333333333
70297, 1.6782608695652, 0.72391304347826, 0.30555555555556
70298, 1.6565217391304, 0.72391304347826, 0.27777777777778
70299, 1.6782608695652, 0.75, 0.27777777777778
70300, 1.6782608695652, 0.72391304347826, 0.25
70301, 1.6565217391304, 0.72391304347826, 0.22222222222222
70302, 1.6782608695652, 0.75, 0.22222222222222
70303, 1.6782608695652, 0.72391304347826, 0.19444444444444
70304, 1.6565217391304, 0.72391304347826, 0.16666666666667
70305, 1.6782608695652, 0.75, 0.16666666666667
70306, 1.6782608695652, 0.72391304347826, 0.13888888888889
70307, 1.6565217391304, 0.72391304347826, 0.11111111111111
70308, 1.6782608695652, 0.75, 0.11111111111111
70309, 1.6782608695652, 0.72391304347826, 0.083333333333333
70310, 1.6565217391304, 0.72391304347826, 0.055555555555556
70311, 1.6782608695652, 0.75, 0.055555555555556
70312, 1.6782608695652, 0.72391304347826, 0.027777777777778
70313, 1.7217391304348, 0.72391304347826, 0.47222222222222
70314, 1.7, 0.72391304347826, 0.44444444444444
70315, 1.7217391304348, 0.75, 0.44444444444444
70316, 1.7217391304348, 0.72391304347826, 0.41666666666667
70317, 1.7, 0.72391304347826, 0.38888888888889
70318, 1.7217391304348, 0.75, 0.38888888888889
70319, 1.7217391304348, 0.72391304347826, 0.36111111111111
70320, 1.7, 0.72391304347826, 0.33333333333333
70321, 1.7217391304348, 0.75, 0.33333333333333
70322, 1.7217391304348, 0.72391304347826, 0.30555555555556
70323, 1.7, 0.72391304347826, 0.27777777777778
70324, 1.7217391304348, 0.75, 0.27777777777778
70325, 1.7217391304348, 0.72391304347826, 0.25
70326, 1.7, 0.72391304347826, 0.22222222222222
70327, 1.7217391304348, 0.75, 0.22222222222222
70328, 1.7217391304348, 0.72391304347826, 0.19444444444444
70329, 1.7, 0.72391304347826, 0.16666666666667
70330, 1.7217391304348, 0.75, 0.16666666666667
70331, 1.7217391304348, 0.72391304347826, 0.13888888888889
70332, 1.7, 0.72391304347826, 0.11111111111111
70333, 1.7217391304348, 0.75, 0.11111111111111
70334, 1.7217391304348, 0.72391304347826, 0.083333333333333
70335, 1.7, 0.72391304347826, 0.055555555555556
70336, 1.7217391304348, 0.75, 0.055555555555556
70337, 1.7217391304348, 0.72391304347826, 0.027777777777778
70338, 1.7652173913043, 0.72391304347826, 0.47222222222222
70339, 1.7434782608696, 0.72391304347826, 0.44444444444444
70340, 1.7652173913043, 0.75, 0.44444444444444
70341, 1.7652173913043, 0.72391304347826, 0.41666666666667
70342, 1.7434782608696, 0.72391304347826, 0.38888888888889
70343, 1.7652173913043, 0.75, 0.38888888888889
70344, 1.7652173913043, 0.72391304347826, 0.36111111111111
70345, 1.7434782608696, 0.72391304347826, 0.33333333333333
70346, 1.7652173913043, 0.75, 0.33333333333333
70347, 1.7652173913043, 0.72391304347826, 0.30555555555556
70348, 1.7434782608696, 0.72391304347826, 0.27777777777778
70349, 1.7652173913043, 0.75, 0.27777777777778
70350, 1.7652173913043, 0.72391304347826, 0.25
70351, 1.7434782608696, 0.72391304347826, 0.22222222222222
70352, 1.7652173913043, 0.75, 0.22222222222222
70353, 1.7652173913043, 0.72391304347826, 0.19444444444444
70354, 1.7434782608696, 0.72391304347826, 0.16666666666667
70355, 1.7652173913043, 0.75, 0.16666666666667
70356, 1.7652173913043, 0.72391304347826, 0.13888888888889
70357, 1.7434782608696, 0.72391304347826, 0.11111111111111
70358, 1.7652173913043, 0.75, 0.11111111111111
70359, 1.7652173913043, 0.72391304347826, 0.083333333333333
70360, 1.7434782608696, 0.72391304347826, 0.055555555555556
70361, 1.7652173913043, 0.75, 0.055555555555556
70362, 1.7652173913043, 0.72391304347826, 0.027777777777778
70363, 1.8086956521739, 0.72391304347826, 0.47222222222222
70364, 1.7869565217391, 0.72391304347826, 0.44444444444444
70365, 1.8086956521739, 0.75, 0.44444444444444
70366, 1.8086956521739, 0.72391304347826, 0.41666666666667
70367, 1.7869565217391, 0.72391304347826, 0.38888888888889
70368, 1.8086956521739, 0.75, 0.38888888888889
70369, 1.8086956521739, 0.72391304347826, 0.36111111111111
70370, 1.7869565217391, 0.72391304347826, 0.33333333333333
70371, 1.8086956521739, 0.75, 0.33333333333333
70372, 1.8086956521739, 0.72391304347826, 0.30555555555556
70373, 1.7869565217391, 0.72391304347826, 0.27777777777778
70374, 1.8086956521739, 0.75, 0.27777777777778
70375, 1.8086956521739, 0.72391304347826, 0.25
70376, 1.7869565217391, 0.72391304347826, 0.22222222222222
70377, 1.8086956521739, 0.75, 0.22222222222222
70378, 1.8086956521739, 0.72391304347826, 0.19444444444444
70379, 1.7869565217391, 0.72391304347826, 0.16666666666667
70380, 1.8086956521739, 0.75, 0.16666666666667
70381, 1.8086956521739, 0.72391304347826, 0.13888888888889
70382, 1.7869565217391, 0.72391304347826, 0.11111111111111
70383, 1.8086956521739, 0.75, 0.11111111111111
70384, 1.8086956521739, 0.72391304347826, 0.083333333333333
70385, 1.7869565217391, 0.72391304347826, 0.055555555555556
70386, 1.8086956521739, 0.75, 0.055555555555556
70387, 1.8086956521739, 0.72391304347826, 0.027777777777778
70388, 1.8521739130435, 0.72391304347826, 0.47222222222222
70389, 1.8304347826087, 0.72391304347826, 0.44444444444444
70390, 1.8521739130435, 0.75, 0.44444444444444
70391, 1.8521739130435, 0.72391304347826, 0.41666666666667
70392, 1.8304347826087, 0.72391304347826, 0.38888888888889
70393, 1.8521739130435, 0.75, 0.38888888888889
70394, 1.8521739130435, 0.72391304347826, 0.36111111111111
70395, 1.8304347826087, 0.72391304347826, 0.33333333333333
70396, 1.8521739130435, 0.75, 0.33333333333333
70397, 1.8521739130435, 0.72391304347826, 0.30555555555556
70398, 1.8304347826087, 0.72391304347826, 0.27777777777778
70399, 1.8521739130435, 0.75, 0.27777777777778
70400, 1.8521739130435, 0.72391304347826, 0.25
70401, 1.8304347826087, 0.72391304347826, 0.22222222222222
70402, 1.8521739130435, 0.75, 0.22222222222222
70403, 1.8521739130435, 0.72391304347826, 0.19444444444444
70404, 1.8304347826087, 0.72391304347826, 0.16666666666667
70405, 1.8521739130435, 0.75, 0.16666666666667
70406, 1.8521739130435, 0.72391304347826, 0.13888888888889
70407, 1.8304347826087, 0.72391304347826, 0.11111111111111
70408, 1.8521739130435, 0.75, 0.11111111111111
70409, 1.8521739130435, 0.72391304347826, 0.083333333333333
70410, 1.8304347826087, 0.72391304347826, 0.055555555555556
70411, 1.8521739130435, 0.75, 0.055555555555556
70412, 1.8521739130435, 0.72391304347826, 0.027777777777778
70413, 1.895652173913, 0.72391304347826, 0.47222222222222
70414, 1.8739130434783, 0.72391304347826, 0.44444444444444
70415, 1.895652173913, 0.75, 0.44444444444444
70416, 1.895652173913, 0.72391304347826, 0.41666666666667
70417, 1.8739130434783, 0.72391304347826, 0.38888888888889
70418, 1.895652173913, 0.75, 0.38888888888889
70419, 1.895652173913, 0.72391304347826, 0.36111111111111
70420, 1.8739130434783, 0.72391304347826, 0.33333333333333
70421, 1.895652173913, 0.75, 0.33333333333333
70422, 1.895652173913, 0.72391304347826, 0.30555555555556
70423, 1.8739130434783, 0.72391304347826, 0.27777777777778
70424, 1.895652173913, 0.75, 0.27777777777778
70425, 1.895652173913, 0.72391304347826, 0.25
70426, 1.8739130434783, 0.72391304347826, 0.22222222222222
70427, 1.895652173913, 0.75, 0.22222222222222
70428, 1.895652173913, 0.72391304347826, 0.19444444444444
70429, 1.8739130434783, 0.72391304347826, 0.16666666666667
70430, 1.895652173913, 0.75, 0.16666666666667
70431, 1.895652173913, 0.72391304347826, 0.13888888888889
70432, 1.8739130434783, 0.72391304347826, 0.11111111111111
70433, 1.895652173913, 0.75, 0.11111111111111
70434, 1.895652173913, 0.72391304347826, 0.083333333333333
70435, 1.8739130434783, 0.72391304347826, 0.055555555555556
70436, 1.895652173913, 0.75, 0.055555555555556
70437, 1.895652173913, 0.72391304347826, 0.027777777777778
70438, 1.9391304347826, 0.72391304347826, 0.47222222222222
70439, 1.9173913043478, 0.72391304347826, 0.44444444444444
70440, 1.9391304347826, 0.75, 0.44444444444444
70441, 1.9391304347826, 0.72391304347826, 0.41666666666667
70442, 1.9173913043478, 0.72391304347826, 0.38888888888889
70443, 1.9391304347826, 0.75, 0.38888888888889
70444, 1.9391304347826, 0.72391304347826, 0.36111111111111
70445, 1.9173913043478, 0.72391304347826, 0.33333333333333
70446, 1.9391304347826, 0.75, 0.33333333333333
70447, 1.9391304347826, 0.72391304347826, 0.30555555555556
70448, 1.9173913043478, 0.72391304347826, 0.27777777777778
70449, 1.9391304347826, 0.75, 0.27777777777778
70450, 1.9391304347826, 0.72391304347826, 0.25
70451, 1.9173913043478, 0.72391304347826, 0.22222222222222
70452, 1.9391304347826, 0.75, 0.22222222222222
70453, 1.9391304347826, 0.72391304347826, 0.19444444444444
70454, 1.9173913043478, 0.72391304347826, 0.16666666666667
70455, 1.9391304347826, 0.75, 0.16666666666667
70456, 1.9391304347826, 0.72391304347826, 0.13888888888889
70457, 1.9173913043478, 0.72391304347826, 0.11111111111111
70458, 1.9391304347826, 0.75, 0.11111111111111
70459, 1.9391304347826, 0.72391304347826, 0.083333333333333
70460, 1.9173913043478, 0.72391304347826, 0.055555555555556
70461, 1.9391304347826, 0.75, 0.055555555555556
70462, 1.9391304347826, 0.72391304347826, 0.027777777777778
70463, 1.9826086956522, 0.72391304347826, 0.47222222222222
70464, 1.9608695652174, 0.72391304347826, 0.44444444444444
70465, 1.9826086956522, 0.75, 0.44444444444444
70466, 1.9826086956522, 0.72391304347826, 0.41666666666667
70467, 1.9608695652174, 0.72391304347826, 0.38888888888889
70468, 1.9826086956522, 0.75, 0.38888888888889
70469, 1.9826086956522, 0.72391304347826, 0.36111111111111
70470, 1.9608695652174, 0.72391304347826, 0.33333333333333
70471, 1.9826086956522, 0.75, 0.33333333333333
70472, 1.9826086956522, 0.72391304347826, 0.30555555555556
70473, 1.9608695652174, 0.72391304347826, 0.27777777777778
70474, 1.9826086956522, 0.75, 0.27777777777778
70475, 1.9826086956522, 0.72391304347826, 0.25
70476, 1.9608695652174, 0.72391304347826, 0.22222222222222
70477, 1.9826086956522, 0.75, 0.22222222222222
70478, 1.9826086956522, 0.72391304347826, 0.19444444444444
70479, 1.9608695652174, 0.72391304347826, 0.16666666666667
70480, 1.9826086956522, 0.75, 0.16666666666667
70481, 1.9826086956522, 0.72391304347826, 0.13888888888889
70482, 1.9608695652174, 0.72391304347826, 0.11111111111111
70483, 1.9826086956522, 0.75, 0.11111111111111
70484, 1.9826086956522, 0.72391304347826, 0.083333333333333
70485, 1.9608695652174, 0.72391304347826, 0.055555555555556
70486, 1.9826086956522, 0.75, 0.055555555555556
70487, 1.9826086956522, 0.72391304347826, 0.027777777777778
70488, 2.0260869565217, 0.72391304347826, 0.47222222222222
70489, 2.004347826087, 0.72391304347826, 0.44444444444444
70490, 2.0260869565217, 0.75, 0.44444444444444
70491, 2.0260869565217, 0.72391304347826, 0.41666666666667
70492, 2.004347826087, 0.72391304347826, 0.38888888888889
70493, 2.0260869565217, 0.75, 0.38888888888889
70494, 2.0260869565217, 0.72391304347826, 0.36111111111111
70495, 2.004347826087, 0.72391304347826, 0.33333333333333
70496, 2.0260869565217, 0.75, 0.33333333333333
70497, 2.0260869565217, 0.72391304347826, 0.30555555555556
70498, 2.004347826087, 0.72391304347826, 0.27777777777778
70499, 2.0260869565217, 0.75, 0.27777777777778
70500, 2.0260869565217, 0.72391304347826, 0.25
70501, 2.004347826087, 0.72391304347826, 0.22222222222222
70502, 2.0260869565217, 0.75, 0.22222222222222
70503, 2.0260869565217, 0.72391304347826, 0.19444444444444
70504, 2.004347826087, 0.72391304347826, 0.16666666666667
70505, 2.0260869565217, 0.75, 0.16666666666667
70506, 2.0260869565217, 0.72391304347826, 0.13888888888889
70507, 2.004347826087, 0.72391304347826, 0.11111111111111
70508, 2.0260869565217, 0.75, 0.11111111111111
70509, 2.0260869565217, 0.72391304347826, 0.083333333333333
70510, 2.004347826087, 0.72391304347826, 0.055555555555556
70511, 2.0260869565217, 0.75, 0.055555555555556
70512, 2.0260869565217, 0.72391304347826, 0.027777777777778
70513, 2.0695652173913, 0.72391304347826, 0.47222222222222
70514, 2.0478260869565, 0.72391304347826, 0.44444444444444
70515, 2.0695652173913, 0.75, 0.44444444444444
70516, 2.0695652173913, 0.72391304347826, 0.41666666666667
70517, 2.0478260869565, 0.72391304347826, 0.38888888888889
70518, 2.0695652173913, 0.75, 0.38888888888889
70519, 2.0695652173913, 0.72391304347826, 0.36111111111111
70520, 2.0478260869565, 0.72391304347826, 0.33333333333333
70521, 2.0695652173913, 0.75, 0.33333333333333
70522, 2.0695652173913, 0.72391304347826, 0.30555555555556
70523, 2.0478260869565, 0.72391304347826, 0.27777777777778
70524, 2.0695652173913, 0.75, 0.27777777777778
70525, 2.0695652173913, 0.72391304347826, 0.25
70526, 2.0478260869565, 0.72391304347826, 0.22222222222222
70527, 2.0695652173913, 0.75, 0.22222222222222
70528, 2.0695652173913, 0.72391304347826, 0.19444444444444
70529, 2.0478260869565, 0.72391304347826, 0.16666666666667
70530, 2.0695652173913, 0.75, 0.16666666666667
70531, 2.0695652173913, 0.72391304347826, 0.13888888888889
70532, 2.0478260869565, 0.72391304347826, 0.11111111111111
70533, 2.0695652173913, 0.75, 0.11111111111111
70534, 2.0695652173913, 0.72391304347826, 0.083333333333333
70535, 2.0478260869565, 0.72391304347826, 0.055555555555556
70536, 2.0695652173913, 0.75, 0.055555555555556
70537, 2.0695652173913, 0.72391304347826, 0.027777777777778
70538, 2.1130434782609, 0.72391304347826, 0.47222222222222
70539, 2.0913043478261, 0.72391304347826, 0.44444444444444
70540, 2.1130434782609, 0.75, 0.44444444444444
70541, 2.1130434782609, 0.72391304347826, 0.41666666666667
70542, 2.0913043478261, 0.72391304347826, 0.38888888888889
70543, 2.1130434782609, 0.75, 0.38888888888889
70544, 2.1130434782609, 0.72391304347826, 0.36111111111111
70545, 2.0913043478261, 0.72391304347826, 0.33333333333333
70546, 2.1130434782609, 0.75, 0.33333333333333
