63598, 1.504347826087, 0.25434782608696, 0.33333333333333
63599, 1.504347826087, 0.25434782608696, 0.27777777777778
63600, 1.504347826087, 0.25434782608696, 0.22222222222222
63601, 1.504347826087, 0.25434782608696, 0.16666666666667
63602, 1.504347826087, 0.25434782608696, 0.11111111111111
63603, 1.504347826087, 0.25434782608696, 0.055555555555556
63604, 1.5478260869565, 0.25434782608696, 0.44444444444444
63605, 1.5478260869565, 0.25434782608696, 0.38888888888889
63606, 1.5478260869565, 0.25434782608696, 0.33333333333333
63607, 1.5478260869565, 0.25434782608696, 0.27777777777778
63608, 1.5478260869565, 0.25434782608696, 0.22222222222222
63609, 1.5478260869565, 0.25434782608696, 0.16666666666667
63610, 1.5478260869565, 0.25434782608696, 0.11111111111111
63611, 1.5478260869565, 0.25434782608696, 0.055555555555556
63612, 1.5913043478261, 0.25434782608696, 0.44444444444444
63613, 1.5913043478261, 0.25434782608696, 0.38888888888889
63614, 1.5913043478261, 0.25434782608696, 0.33333333333333
63615, 1.5913043478261, 0.25434782608696, 0.27777777777778
63616, 1.5913043478261, 0.25434782608696, 0.22222222222222
63617, 1.5913043478261, 0.25434782608696, 0.16666666666667
63618, 1.5913043478261, 0.25434782608696, 0.11111111111111
63619, 1.5913043478261, 0.25434782608696, 0.055555555555556
63620, 1.6347826086957, 0.25434782608696, 0.44444444444444
63621, 1.6347826086957, 0.25434782608696, 0.38888888888889
63622, 1.6347826086957, 0.25434782608696, 0.33333333333333
63623, 1.6347826086957, 0.25434782608696, 0.27777777777778
63624, 1.6347826086957, 0.25434782608696, 0.22222222222222
63625, 1.6347826086957, 0.25434782608696, 0.16666666666667
63626, 1.6347826086957, 0.25434782608696, 0.11111111111111
63627, 1.6347826086957, 0.25434782608696, 0.055555555555556
63628, 1.6782608695652, 0.25434782608696, 0.44444444444444
63629, 1.6782608695652, 0.25434782608696, 0.38888888888889
63630, 1.6782608695652, 0.25434782608696, 0.33333333333333
63631, 1.6782608695652, 0.25434782608696, 0.27777777777778
63632, 1.6782608695652, 0.25434782608696, 0.22222222222222
63633, 1.6782608695652, 0.25434782608696, 0.16666666666667
63634, 1.6782608695652, 0.25434782608696, 0.11111111111111
63635, 1.6782608695652, 0.25434782608696, 0.055555555555556
63636, 1.7217391304348, 0.25434782608696, 0.44444444444444
63637, 1.7217391304348, 0.25434782608696, 0.38888888888889
63638, 1.7217391304348, 0.25434782608696, 0.33333333333333
63639, 1.7217391304348, 0.25434782608696, 0.27777777777778
63640, 1.7217391304348, 0.25434782608696, 0.22222222222222
63641, 1.7217391304348, 0.25434782608696, 0.16666666666667
63642, 1.7217391304348, 0.25434782608696, 0.11111111111111
63643, 1.7217391304348, 0.25434782608696, 0.055555555555556
63644, 1.7652173913043, 0.25434782608696, 0.44444444444444
63645, 1.7652173913043, 0.25434782608696, 0.38888888888889
63646, 1.7652173913043, 0.25434782608696, 0.33333333333333
63647, 1.7652173913043, 0.25434782608696, 0.27777777777778
63648, 1.7652173913043, 0.25434782608696, 0.22222222222222
63649, 1.7652173913043, 0.25434782608696, 0.16666666666667
63650, 1.7652173913043, 0.25434782608696, 0.11111111111111
63651, 1.7652173913043, 0.25434782608696, 0.055555555555556
63652, 1.8086956521739, 0.25434782608696, 0.44444444444444
63653, 1.8086956521739, 0.25434782608696, 0.38888888888889
63654, 1.8086956521739, 0.25434782608696, 0.33333333333333
63655, 1.8086956521739, 0.25434782608696, 0.27777777777778
63656, 1.8086956521739, 0.25434782608696, 0.22222222222222
63657, 1.8086956521739, 0.25434782608696, 0.16666666666667
63658, 1.8086956521739, 0.25434782608696, 0.11111111111111
63659, 1.8086956521739, 0.25434782608696, 0.055555555555556
63660, 1.8521739130435, 0.25434782608696, 0.44444444444444
63661, 1.8521739130435, 0.25434782608696, 0.38888888888889
63662, 1.8521739130435, 0.25434782608696, 0.33333333333333
63663, 1.8521739130435, 0.25434782608696, 0.27777777777778
63664, 1.8521739130435, 0.25434782608696, 0.22222222222222
63665, 1.8521739130435, 0.25434782608696, 0.16666666666667
63666, 1.8521739130435, 0.25434782608696, 0.11111111111111
63667, 1.8521739130435, 0.25434782608696, 0.055555555555556
63668, 1.895652173913, 0.25434782608696, 0.44444444444444
63669, 1.895652173913, 0.25434782608696, 0.38888888888889
63670, 1.895652173913, 0.25434782608696, 0.33333333333333
63671, 1.895652173913, 0.25434782608696, 0.27777777777778
63672, 1.895652173913, 0.25434782608696, 0.22222222222222
63673, 1.895652173913, 0.25434782608696, 0.16666666666667
63674, 1.895652173913, 0.25434782608696, 0.11111111111111
63675, 1.895652173913, 0.25434782608696, 0.055555555555556
63676, 1.9391304347826, 0.25434782608696, 0.44444444444444
63677, 1.9391304347826, 0.25434782608696, 0.38888888888889
63678, 1.9391304347826, 0.25434782608696, 0.33333333333333
63679, 1.9391304347826, 0.25434782608696, 0.27777777777778
63680, 1.9391304347826, 0.25434782608696, 0.22222222222222
63681, 1.9391304347826, 0.25434782608696, 0.16666666666667
63682, 1.9391304347826, 0.25434782608696, 0.11111111111111
63683, 1.9391304347826, 0.25434782608696, 0.055555555555556
63684, 1.9826086956522, 0.25434782608696, 0.44444444444444
63685, 1.9826086956522, 0.25434782608696, 0.38888888888889
63686, 1.9826086956522, 0.25434782608696, 0.33333333333333
63687, 1.9826086956522, 0.25434782608696, 0.27777777777778
63688, 1.9826086956522, 0.25434782608696, 0.22222222222222
63689, 1.9826086956522, 0.25434782608696, 0.16666666666667
63690, 1.9826086956522, 0.25434782608696, 0.11111111111111
63691, 1.9826086956522, 0.25434782608696, 0.055555555555556
63692, 2.0260869565217, 0.25434782608696, 0.44444444444444
63693, 2.0260869565217, 0.25434782608696, 0.38888888888889
63694, 2.0260869565217, 0.25434782608696, 0.33333333333333
63695, 2.0260869565217, 0.25434782608696, 0.27777777777778
63696, 2.0260869565217, 0.25434782608696, 0.22222222222222
63697, 2.0260869565217, 0.25434782608696, 0.16666666666667
63698, 2.0260869565217, 0.25434782608696, 0.11111111111111
63699, 2.0260869565217, 0.25434782608696, 0.055555555555556
63700, 2.0695652173913, 0.25434782608696, 0.44444444444444
63701, 2.0695652173913, 0.25434782608696, 0.38888888888889
63702, 2.0695652173913, 0.25434782608696, 0.33333333333333
63703, 2.0695652173913, 0.25434782608696, 0.27777777777778
63704, 2.0695652173913, 0.25434782608696, 0.22222222222222
63705, 2.0695652173913, 0.25434782608696, 0.16666666666667
63706, 2.0695652173913, 0.25434782608696, 0.11111111111111
63707, 2.0695652173913, 0.25434782608696, 0.055555555555556
63708, 2.1130434782609, 0.25434782608696, 0.44444444444444
63709, 2.1130434782609, 0.25434782608696, 0.38888888888889
63710, 2.1130434782609, 0.25434782608696, 0.33333333333333
63711, 2.1130434782609, 0.25434782608696, 0.27777777777778
63712, 2.1130434782609, 0.25434782608696, 0.22222222222222
63713, 2.1130434782609, 0.25434782608696, 0.16666666666667
63714, 2.1130434782609, 0.25434782608696, 0.11111111111111
63715, 2.1130434782609, 0.25434782608696, 0.055555555555556
63716, 2.1565217391304, 0.25434782608696, 0.44444444444444
63717, 2.1565217391304, 0.25434782608696, 0.38888888888889
63718, 2.1565217391304, 0.25434782608696, 0.33333333333333
63719, 2.1565217391304, 0.25434782608696, 0.27777777777778
63720, 2.1565217391304, 0.25434782608696, 0.22222222222222
63721, 2.1565217391304, 0.25434782608696, 0.16666666666667
63722, 2.1565217391304, 0.25434782608696, 0.11111111111111
63723, 2.1565217391304, 0.25434782608696, 0.055555555555556
63724, 1.2434782608696, 0.20217391304348, 0.44444444444444
63725, 1.2434782608696, 0.20217391304348, 0.38888888888889
63726, 1.2434782608696, 0.20217391304348, 0.33333333333333
63727, 1.2434782608696, 0.20217391304348, 0.27777777777778
63728, 1.2434782608696, 0.20217391304348, 0.22222222222222
63729, 1.2434782608696, 0.20217391304348, 0.16666666666667
63730, 1.2434782608696, 0.20217391304348, 0.11111111111111
63731, 1.2434782608696, 0.20217391304348, 0.055555555555556
63732, 1.2869565217391, 0.20217391304348, 0.44444444444444
63733, 1.2869565217391, 0.20217391304348, 0.38888888888889
63734, 1.2869565217391, 0.20217391304348, 0.33333333333333
63735, 1.2869565217391, 0.20217391304348, 0.27777777777778
63736, 1.2869565217391, 0.20217391304348, 0.22222222222222
63737, 1.2869565217391, 0.20217391304348, 0.16666666666667
63738, 1.2869565217391, 0.20217391304348, 0.11111111111111
63739, 1.2869565217391, 0.20217391304348, 0.055555555555556
63740, 1.3304347826087, 0.20217391304348, 0.44444444444444
63741, 1.3304347826087, 0.20217391304348, 0.38888888888889
63742, 1.3304347826087, 0.20217391304348, 0.33333333333333
63743, 1.3304347826087, 0.20217391304348, 0.27777777777778
63744, 1.3304347826087, 0.20217391304348, 0.22222222222222
63745, 1.3304347826087, 0.20217391304348, 0.16666666666667
63746, 1.3304347826087, 0.20217391304348, 0.11111111111111
63747, 1.3304347826087, 0.20217391304348, 0.055555555555556
63748, 1.3739130434783, 0.20217391304348, 0.44444444444444
63749, 1.3739130434783, 0.20217391304348, 0.38888888888889
63750, 1.3739130434783, 0.20217391304348, 0.33333333333333
63751, 1.3739130434783, 0.20217391304348, 0.27777777777778
63752, 1.3739130434783, 0.20217391304348, 0.22222222222222
63753, 1.3739130434783, 0.20217391304348, 0.16666666666667
63754, 1.3739130434783, 0.20217391304348, 0.11111111111111
63755, 1.3739130434783, 0.20217391304348, 0.055555555555556
63756, 1.4173913043478, 0.20217391304348, 0.44444444444444
63757, 1.4173913043478, 0.20217391304348, 0.38888888888889
63758, 1.4173913043478, 0.20217391304348, 0.33333333333333
63759, 1.4173913043478, 0.20217391304348, 0.27777777777778
63760, 1.4173913043478, 0.20217391304348, 0.22222222222222
63761, 1.4173913043478, 0.20217391304348, 0.16666666666667
63762, 1.4173913043478, 0.20217391304348, 0.11111111111111
63763, 1.4173913043478, 0.20217391304348, 0.055555555555556
63764, 1.4608695652174, 0.20217391304348, 0.44444444444444
63765, 1.4608695652174, 0.20217391304348, 0.38888888888889
63766, 1.4608695652174, 0.20217391304348, 0.33333333333333
63767, 1.4608695652174, 0.20217391304348, 0.27777777777778
63768, 1.4608695652174, 0.20217391304348, 0.22222222222222
63769, 1.4608695652174, 0.20217391304348, 0.16666666666667
63770, 1.4608695652174, 0.20217391304348, 0.11111111111111
63771, 1.4608695652174, 0.20217391304348, 0.055555555555556
63772, 1.504347826087, 0.20217391304348, 0.44444444444444
63773, 1.504347826087, 0.20217391304348, 0.38888888888889
63774, 1.504347826087, 0.20217391304348, 0.33333333333333
63775, 1.504347826087, 0.20217391304348, 0.27777777777778
63776, 1.504347826087, 0.20217391304348, 0.22222222222222
63777, 1.504347826087, 0.20217391304348, 0.16666666666667
63778, 1.504347826087, 0.20217391304348, 0.11111111111111
63779, 1.504347826087, 0.20217391304348, 0.055555555555556
63780, 1.5478260869565, 0.20217391304348, 0.44444444444444
63781, 1.5478260869565, 0.20217391304348, 0.38888888888889
63782, 1.5478260869565, 0.20217391304348, 0.33333333333333
63783, 1.5478260869565, 0.20217391304348, 0.27777777777778
63784, 1.5478260869565, 0.20217391304348, 0.22222222222222
63785, 1.5478260869565, 0.20217391304348, 0.16666666666667
63786, 1.5478260869565, 0.20217391304348, 0.11111111111111
63787, 1.5478260869565, 0.20217391304348, 0.055555555555556
63788, 1.5913043478261, 0.20217391304348, 0.44444444444444
63789, 1.5913043478261, 0.20217391304348, 0.38888888888889
63790, 1.5913043478261, 0.20217391304348, 0.33333333333333
63791, 1.5913043478261, 0.20217391304348, 0.27777777777778
63792, 1.5913043478261, 0.20217391304348, 0.22222222222222
63793, 1.5913043478261, 0.20217391304348, 0.16666666666667
63794, 1.5913043478261, 0.20217391304348, 0.11111111111111
63795, 1.5913043478261, 0.20217391304348, 0.055555555555556
63796, 1.6347826086957, 0.20217391304348, 0.44444444444444
63797, 1.6347826086957, 0.20217391304348, 0.38888888888889
63798, 1.6347826086957, 0.20217391304348, 0.33333333333333
63799, 1.6347826086957, 0.20217391304348, 0.27777777777778
63800, 1.6347826086957, 0.20217391304348, 0.22222222222222
63801, 1.6347826086957, 0.20217391304348, 0.16666666666667
63802, 1.6347826086957, 0.20217391304348, 0.11111111111111
63803, 1.6347826086957, 0.20217391304348, 0.055555555555556
63804, 1.6782608695652, 0.20217391304348, 0.44444444444444
63805, 1.6782608695652, 0.20217391304348, 0.38888888888889
63806, 1.6782608695652, 0.20217391304348, 0.33333333333333
63807, 1.6782608695652, 0.20217391304348, 0.27777777777778
63808, 1.6782608695652, 0.20217391304348, 0.22222222222222
63809, 1.6782608695652, 0.20217391304348, 0.16666666666667
63810, 1.6782608695652, 0.20217391304348, 0.11111111111111
63811, 1.6782608695652, 0.20217391304348, 0.055555555555556
63812, 1.7217391304348, 0.20217391304348, 0.44444444444444
63813, 1.7217391304348, 0.20217391304348, 0.38888888888889
63814, 1.7217391304348, 0.20217391304348, 0.33333333333333
63815, 1.7217391304348, 0.20217391304348, 0.27777777777778
63816, 1.7217391304348, 0.20217391304348, 0.22222222222222
63817, 1.7217391304348, 0.20217391304348, 0.16666666666667
63818, 1.7217391304348, 0.20217391304348, 0.11111111111111
63819, 1.7217391304348, 0.20217391304348, 0.055555555555556
63820, 1.7652173913043, 0.20217391304348, 0.44444444444444
63821, 1.7652173913043, 0.20217391304348, 0.38888888888889
63822, 1.7652173913043, 0.20217391304348, 0.33333333333333
63823, 1.7652173913043, 0.20217391304348, 0.27777777777778
63824, 1.7652173913043, 0.20217391304348, 0.22222222222222
63825, 1.7652173913043, 0.20217391304348, 0.16666666666667
63826, 1.7652173913043, 0.20217391304348, 0.11111111111111
63827, 1.7652173913043, 0.20217391304348, 0.055555555555556
63828, 1.8086956521739, 0.20217391304348, 0.44444444444444
63829, 1.8086956521739, 0.20217391304348, 0.38888888888889
63830, 1.8086956521739, 0.20217391304348, 0.33333333333333
63831, 1.8086956521739, 0.20217391304348, 0.27777777777778
63832, 1.8086956521739, 0.20217391304348, 0.22222222222222
63833, 1.8086956521739, 0.20217391304348, 0.16666666666667
63834, 1.8086956521739, 0.20217391304348, 0.11111111111111
63835, 1.8086956521739, 0.20217391304348, 0.055555555555556
63836, 1.8521739130435, 0.20217391304348, 0.44444444444444
63837, 1.8521739130435, 0.20217391304348, 0.38888888888889
63838, 1.8521739130435, 0.20217391304348, 0.33333333333333
63839, 1.8521739130435, 0.20217391304348, 0.27777777777778
63840, 1.8521739130435, 0.20217391304348, 0.22222222222222
63841, 1.8521739130435, 0.20217391304348, 0.16666666666667
63842, 1.8521739130435, 0.20217391304348, 0.11111111111111
63843, 1.8521739130435, 0.20217391304348, 0.055555555555556
63844, 1.895652173913, 0.20217391304348, 0.44444444444444
63845, 1.895652173913, 0.20217391304348, 0.38888888888889
63846, 1.895652173913, 0.20217391304348, 0.33333333333333
63847, 1.895652173913, 0.20217391304348, 0.27777777777778
63848, 1.895652173913, 0.20217391304348, 0.22222222222222
63849, 1.895652173913, 0.20217391304348, 0.16666666666667
63850, 1.895652173913, 0.20217391304348, 0.11111111111111
63851, 1.895652173913, 0.20217391304348, 0.055555555555556
63852, 1.9391304347826, 0.20217391304348, 0.44444444444444
63853, 1.9391304347826, 0.20217391304348, 0.38888888888889
63854, 1.9391304347826, 0.20217391304348, 0.33333333333333
63855, 1.9391304347826, 0.20217391304348, 0.27777777777778
63856, 1.9391304347826, 0.20217391304348, 0.22222222222222
63857, 1.9391304347826, 0.20217391304348, 0.16666666666667
63858, 1.9391304347826, 0.20217391304348, 0.11111111111111
63859, 1.9391304347826, 0.20217391304348, 0.055555555555556
63860, 1.9826086956522, 0.20217391304348, 0.44444444444444
63861, 1.9826086956522, 0.20217391304348, 0.38888888888889
63862, 1.9826086956522, 0.20217391304348, 0.33333333333333
63863, 1.9826086956522, 0.20217391304348, 0.27777777777778
63864, 1.9826086956522, 0.20217391304348, 0.22222222222222
63865, 1.9826086956522, 0.20217391304348, 0.16666666666667
63866, 1.9826086956522, 0.20217391304348, 0.11111111111111
63867, 1.9826086956522, 0.20217391304348, 0.055555555555556
63868, 2.0260869565217, 0.20217391304348, 0.44444444444444
63869, 2.0260869565217, 0.20217391304348, 0.38888888888889
63870, 2.0260869565217, 0.20217391304348, 0.33333333333333
63871, 2.0260869565217, 0.20217391304348, 0.27777777777778
63872, 2.0260869565217, 0.20217391304348, 0.22222222222222
63873, 2.0260869565217, 0.20217391304348, 0.16666666666667
63874, 2.0260869565217, 0.20217391304348, 0.11111111111111
63875, 2.0260869565217, 0.20217391304348, 0.055555555555556
63876, 2.0695652173913, 0.20217391304348, 0.44444444444444
63877, 2.0695652173913, 0.20217391304348, 0.38888888888889
63878, 2.0695652173913, 0.20217391304348, 0.33333333333333
63879, 2.0695652173913, 0.20217391304348, 0.27777777777778
63880, 2.0695652173913, 0.20217391304348, 0.22222222222222
63881, 2.0695652173913, 0.20217391304348, 0.16666666666667
63882, 2.0695652173913, 0.20217391304348, 0.11111111111111
63883, 2.0695652173913, 0.20217391304348, 0.055555555555556
63884, 2.1130434782609, 0.20217391304348, 0.44444444444444
63885, 2.1130434782609, 0.20217391304348, 0.38888888888889
63886, 2.1130434782609, 0.20217391304348, 0.33333333333333
63887, 2.1130434782609, 0.20217391304348, 0.27777777777778
63888, 2.1130434782609, 0.20217391304348, 0.22222222222222
63889, 2.1130434782609, 0.20217391304348, 0.16666666666667
63890, 2.1130434782609, 0.20217391304348, 0.11111111111111
63891, 2.1130434782609, 0.20217391304348, 0.055555555555556
63892, 2.1565217391304, 0.20217391304348, 0.44444444444444
63893, 2.1565217391304, 0.20217391304348, 0.38888888888889
63894, 2.1565217391304, 0.20217391304348, 0.33333333333333
63895, 2.1565217391304, 0.20217391304348, 0.27777777777778
63896, 2.1565217391304, 0.20217391304348, 0.22222222222222
63897, 2.1565217391304, 0.20217391304348, 0.16666666666667
63898, 2.1565217391304, 0.20217391304348, 0.11111111111111
63899, 2.1565217391304, 0.20217391304348, 0.055555555555556
63900, 1.2434782608696, 1.2978260869565, 0.47222222222222
63901, 1.2217391304348, 1.2978260869565, 0.44444444444444
63902, 1.2434782608696, 1.3239130434783, 0.44444444444444
63903, 1.2434782608696, 1.2978260869565, 0.41666666666667
63904, 1.2217391304348, 1.2978260869565, 0.38888888888889
63905, 1.2434782608696, 1.3239130434783, 0.38888888888889
63906, 1.2434782608696, 1.2978260869565, 0.36111111111111
63907, 1.2217391304348, 1.2978260869565, 0.33333333333333
63908, 1.2434782608696, 1.3239130434783, 0.33333333333333
63909, 1.2434782608696, 1.2978260869565, 0.30555555555556
63910, 1.2217391304348, 1.2978260869565, 0.27777777777778
63911, 1.2434782608696, 1.3239130434783, 0.27777777777778
63912, 1.2434782608696, 1.2978260869565, 0.25
63913, 1.2217391304348, 1.2978260869565, 0.22222222222222
63914, 1.2434782608696, 1.3239130434783, 0.22222222222222
63915, 1.2434782608696, 1.2978260869565, 0.19444444444444
63916, 1.2217391304348, 1.2978260869565, 0.16666666666667
63917, 1.2434782608696, 1.3239130434783, 0.16666666666667
63918, 1.2434782608696, 1.2978260869565, 0.13888888888889
63919, 1.2217391304348, 1.2978260869565, 0.11111111111111
63920, 1.2434782608696, 1.3239130434783, 0.11111111111111
63921, 1.2434782608696, 1.2978260869565, 0.083333333333333
63922, 1.2217391304348, 1.2978260869565, 0.055555555555556
63923, 1.2434782608696, 1.3239130434783, 0.055555555555556
63924, 1.2434782608696, 1.2978260869565, 0.027777777777778
63925, 1.2869565217391, 1.2978260869565, 0.47222222222222
63926, 1.2652173913043, 1.2978260869565, 0.44444444444444
63927, 1.2869565217391, 1.3239130434783, 0.44444444444444
63928, 1.2869565217391, 1.2978260869565, 0.41666666666667
63929, 1.2652173913043, 1.2978260869565, 0.38888888888889
63930, 1.2869565217391, 1.3239130434783, 0.38888888888889
63931, 1.2869565217391, 1.2978260869565, 0.36111111111111
63932, 1.2652173913043, 1.2978260869565, 0.33333333333333
63933, 1.2869565217391, 1.3239130434783, 0.33333333333333
63934, 1.2869565217391, 1.2978260869565, 0.30555555555556
63935, 1.2652173913043, 1.2978260869565, 0.27777777777778
63936, 1.2869565217391, 1.3239130434783, 0.27777777777778
63937, 1.2869565217391, 1.2978260869565, 0.25
63938, 1.2652173913043, 1.2978260869565, 0.22222222222222
63939, 1.2869565217391, 1.3239130434783, 0.22222222222222
63940, 1.2869565217391, 1.2978260869565, 0.19444444444444
63941, 1.2652173913043, 1.2978260869565, 0.16666666666667
63942, 1.2869565217391, 1.3239130434783, 0.16666666666667
63943, 1.2869565217391, 1.2978260869565, 0.13888888888889
63944, 1.2652173913043, 1.2978260869565, 0.11111111111111
63945, 1.2869565217391, 1.3239130434783, 0.11111111111111
63946, 1.2869565217391, 1.2978260869565, 0.083333333333333
63947, 1.2652173913043, 1.2978260869565, 0.055555555555556
63948, 1.2869565217391, 1.3239130434783, 0.055555555555556
63949, 1.2869565217391, 1.2978260869565, 0.027777777777778
63950, 1.3304347826087, 1.2978260869565, 0.47222222222222
63951, 1.3086956521739, 1.2978260869565, 0.44444444444444
63952, 1.3304347826087, 1.3239130434783, 0.44444444444444
63953, 1.3304347826087, 1.2978260869565, 0.41666666666667
63954, 1.3086956521739, 1.2978260869565, 0.38888888888889
63955, 1.3304347826087, 1.3239130434783, 0.38888888888889
63956, 1.3304347826087, 1.2978260869565, 0.36111111111111
63957, 1.3086956521739, 1.2978260869565, 0.33333333333333
63958, 1.3304347826087, 1.3239130434783, 0.33333333333333
63959, 1.3304347826087, 1.2978260869565, 0.30555555555556
63960, 1.3086956521739, 1.2978260869565, 0.27777777777778
63961, 1.3304347826087, 1.3239130434783, 0.27777777777778
63962, 1.3304347826087, 1.2978260869565, 0.25
63963, 1.3086956521739, 1.2978260869565, 0.22222222222222
63964, 1.3304347826087, 1.3239130434783, 0.22222222222222
63965, 1.3304347826087, 1.2978260869565, 0.19444444444444
63966, 1.3086956521739, 1.2978260869565, 0.16666666666667
63967, 1.3304347826087, 1.3239130434783, 0.16666666666667
63968, 1.3304347826087, 1.2978260869565, 0.13888888888889
63969, 1.3086956521739, 1.2978260869565, 0.11111111111111
63970, 1.3304347826087, 1.3239130434783, 0.11111111111111
63971, 1.3304347826087, 1.2978260869565, 0.083333333333333
63972, 1.3086956521739, 1.2978260869565, 0.055555555555556
63973, 1.3304347826087, 1.3239130434783, 0.055555555555556
63974, 1.3304347826087, 1.2978260869565, 0.027777777777778
63975, 1.3739130434783, 1.2978260869565, 0.47222222222222
63976, 1.3521739130435, 1.2978260869565, 0.44444444444444
63977, 1.3739130434783, 1.3239130434783, 0.44444444444444
63978, 1.3739130434783, 1.2978260869565, 0.41666666666667
63979, 1.3521739130435, 1.2978260869565, 0.38888888888889
63980, 1.3739130434783, 1.3239130434783, 0.38888888888889
63981, 1.3739130434783, 1.2978260869565, 0.36111111111111
63982, 1.3521739130435, 1.2978260869565, 0.33333333333333
63983, 1.3739130434783, 1.3239130434783, 0.33333333333333
63984, 1.3739130434783, 1.2978260869565, 0.30555555555556
63985, 1.3521739130435, 1.2978260869565, 0.27777777777778
63986, 1.3739130434783, 1.3239130434783, 0.27777777777778
63987, 1.3739130434783, 1.2978260869565, 0.25
63988, 1.3521739130435, 1.2978260869565, 0.22222222222222
63989, 1.3739130434783, 1.3239130434783, 0.22222222222222
63990, 1.3739130434783, 1.2978260869565, 0.19444444444444
63991, 1.3521739130435, 1.2978260869565, 0.16666666666667
63992, 1.3739130434783, 1.3239130434783, 0.16666666666667
63993, 1.3739130434783, 1.2978260869565, 0.13888888888889
63994, 1.3521739130435, 1.2978260869565, 0.11111111111111
63995, 1.3739130434783, 1.3239130434783, 0.11111111111111
63996, 1.3739130434783, 1.2978260869565, 0.083333333333333
63997, 1.3521739130435, 1.2978260869565, 0.055555555555556
63998, 1.3739130434783, 1.3239130434783, 0.055555555555556
63999, 1.3739130434783, 1.2978260869565, 0.027777777777778
64000, 1.4173913043478, 1.2978260869565, 0.47222222222222
64001, 1.395652173913, 1.2978260869565, 0.44444444444444
64002, 1.4173913043478, 1.3239130434783, 0.44444444444444
64003, 1.4173913043478, 1.2978260869565, 0.41666666666667
64004, 1.395652173913, 1.2978260869565, 0.38888888888889
64005, 1.4173913043478, 1.3239130434783, 0.38888888888889
64006, 1.4173913043478, 1.2978260869565, 0.36111111111111
64007, 1.395652173913, 1.2978260869565, 0.33333333333333
64008, 1.4173913043478, 1.3239130434783, 0.33333333333333
64009, 1.4173913043478, 1.2978260869565, 0.30555555555556
64010, 1.395652173913, 1.2978260869565, 0.27777777777778
64011, 1.4173913043478, 1.3239130434783, 0.27777777777778
64012, 1.4173913043478, 1.2978260869565, 0.25
64013, 1.395652173913, 1.2978260869565, 0.22222222222222
64014, 1.4173913043478, 1.3239130434783, 0.22222222222222
64015, 1.4173913043478, 1.2978260869565, 0.19444444444444
64016, 1.395652173913, 1.2978260869565, 0.16666666666667
64017, 1.4173913043478, 1.3239130434783, 0.16666666666667
64018, 1.4173913043478, 1.2978260869565, 0.13888888888889
64019, 1.395652173913, 1.2978260869565, 0.11111111111111
64020, 1.4173913043478, 1.3239130434783, 0.11111111111111
64021, 1.4173913043478, 1.2978260869565, 0.083333333333333
64022, 1.395652173913, 1.2978260869565, 0.055555555555556
64023, 1.4173913043478, 1.3239130434783, 0.055555555555556
64024, 1.4173913043478, 1.2978260869565, 0.027777777777778
64025, 1.4608695652174, 1.2978260869565, 0.47222222222222
64026, 1.4391304347826, 1.2978260869565, 0.44444444444444
64027, 1.4608695652174, 1.3239130434783, 0.44444444444444
64028, 1.4608695652174, 1.2978260869565, 0.41666666666667
64029, 1.4391304347826, 1.2978260869565, 0.38888888888889
64030, 1.4608695652174, 1.3239130434783, 0.38888888888889
64031, 1.4608695652174, 1.2978260869565, 0.36111111111111
64032, 1.4391304347826, 1.2978260869565, 0.33333333333333
64033, 1.4608695652174, 1.3239130434783, 0.33333333333333
64034, 1.4608695652174, 1.2978260869565, 0.30555555555556
64035, 1.4391304347826, 1.2978260869565, 0.27777777777778
64036, 1.4608695652174, 1.3239130434783, 0.27777777777778
64037, 1.4608695652174, 1.2978260869565, 0.25
64038, 1.4391304347826, 1.2978260869565, 0.22222222222222
64039, 1.4608695652174, 1.3239130434783, 0.22222222222222
64040, 1.4608695652174, 1.2978260869565, 0.19444444444444
64041, 1.4391304347826, 1.2978260869565, 0.16666666666667
64042, 1.4608695652174, 1.3239130434783, 0.16666666666667
64043, 1.4608695652174, 1.2978260869565, 0.13888888888889
64044, 1.4391304347826, 1.2978260869565, 0.11111111111111
64045, 1.4608695652174, 1.3239130434783, 0.11111111111111
64046, 1.4608695652174, 1.2978260869565, 0.083333333333333
64047, 1.4391304347826, 1.2978260869565, 0.055555555555556
64048, 1.4608695652174, 1.3239130434783, 0.055555555555556
64049, 1.4608695652174, 1.2978260869565, 0.027777777777778
64050, 1.504347826087, 1.2978260869565, 0.47222222222222
64051, 1.4826086956522, 1.2978260869565, 0.44444444444444
64052, 1.504347826087, 1.3239130434783, 0.44444444444444
64053, 1.504347826087, 1.2978260869565, 0.41666666666667
64054, 1.4826086956522, 1.2978260869565, 0.38888888888889
64055, 1.504347826087, 1.3239130434783, 0.38888888888889
64056, 1.504347826087, 1.2978260869565, 0.36111111111111
64057, 1.4826086956522, 1.2978260869565, 0.33333333333333
64058, 1.504347826087, 1.3239130434783, 0.33333333333333
64059, 1.504347826087, 1.2978260869565, 0.30555555555556
64060, 1.4826086956522, 1.2978260869565, 0.27777777777778
64061, 1.504347826087, 1.3239130434783, 0.27777777777778
64062, 1.504347826087, 1.2978260869565, 0.25
64063, 1.4826086956522, 1.2978260869565, 0.22222222222222
64064, 1.504347826087, 1.3239130434783, 0.22222222222222
64065, 1.504347826087, 1.2978260869565, 0.19444444444444
64066, 1.4826086956522, 1.2978260869565, 0.16666666666667
64067, 1.504347826087, 1.3239130434783, 0.16666666666667
64068, 1.504347826087, 1.2978260869565, 0.13888888888889
64069, 1.4826086956522, 1.2978260869565, 0.11111111111111
64070, 1.504347826087, 1.3239130434783, 0.11111111111111
64071, 1.504347826087, 1.2978260869565, 0.083333333333333
64072, 1.4826086956522, 1.2978260869565, 0.055555555555556
64073, 1.504347826087, 1.3239130434783, 0.055555555555556
64074, 1.504347826087, 1.2978260869565, 0.027777777777778
64075, 1.5478260869565, 1.2978260869565, 0.47222222222222
64076, 1.5260869565217, 1.2978260869565, 0.44444444444444
64077, 1.5478260869565, 1.3239130434783, 0.44444444444444
64078, 1.5478260869565, 1.2978260869565, 0.41666666666667
64079, 1.5260869565217, 1.2978260869565, 0.38888888888889
64080, 1.5478260869565, 1.3239130434783, 0.38888888888889
64081, 1.5478260869565, 1.2978260869565, 0.36111111111111
64082, 1.5260869565217, 1.2978260869565, 0.33333333333333
64083, 1.5478260869565, 1.3239130434783, 0.33333333333333
64084, 1.5478260869565, 1.2978260869565, 0.30555555555556
64085, 1.5260869565217, 1.2978260869565, 0.27777777777778
64086, 1.5478260869565, 1.3239130434783, 0.27777777777778
64087, 1.5478260869565, 1.2978260869565, 0.25
64088, 1.5260869565217, 1.2978260869565, 0.22222222222222
64089, 1.5478260869565, 1.3239130434783, 0.22222222222222
64090, 1.5478260869565, 1.2978260869565, 0.19444444444444
64091, 1.5260869565217, 1.2978260869565, 0.16666666666667
64092, 1.5478260869565, 1.3239130434783, 0.16666666666667
64093, 1.5478260869565, 1.2978260869565, 0.13888888888889
64094, 1.5260869565217, 1.2978260869565, 0.11111111111111
64095, 1.5478260869565, 1.3239130434783, 0.11111111111111
64096, 1.5478260869565, 1.2978260869565, 0.083333333333333
64097, 1.5260869565217, 1.2978260869565, 0.055555555555556
64098, 1.5478260869565, 1.3239130434783, 0.055555555555556
64099, 1.5478260869565, 1.2978260869565, 0.027777777777778
64100, 1.5913043478261, 1.2978260869565, 0.47222222222222
64101, 1.5695652173913, 1.2978260869565, 0.44444444444444
64102, 1.5913043478261, 1.3239130434783, 0.44444444444444
64103, 1.5913043478261, 1.2978260869565, 0.41666666666667
64104, 1.5695652173913, 1.2978260869565, 0.38888888888889
64105, 1.5913043478261, 1.3239130434783, 0.38888888888889
64106, 1.5913043478261, 1.2978260869565, 0.36111111111111
64107, 1.5695652173913, 1.2978260869565, 0.33333333333333
64108, 1.5913043478261, 1.3239130434783, 0.33333333333333
64109, 1.5913043478261, 1.2978260869565, 0.30555555555556
64110, 1.5695652173913, 1.2978260869565, 0.27777777777778
64111, 1.5913043478261, 1.3239130434783, 0.27777777777778
64112, 1.5913043478261, 1.2978260869565, 0.25
64113, 1.5695652173913, 1.2978260869565, 0.22222222222222
64114, 1.5913043478261, 1.3239130434783, 0.22222222222222
64115, 1.5913043478261, 1.2978260869565, 0.19444444444444
64116, 1.5695652173913, 1.2978260869565, 0.16666666666667
64117, 1.5913043478261, 1.3239130434783, 0.16666666666667
64118, 1.5913043478261, 1.2978260869565, 0.13888888888889
64119, 1.5695652173913, 1.2978260869565, 0.11111111111111
64120, 1.5913043478261, 1.3239130434783, 0.11111111111111
64121, 1.5913043478261, 1.2978260869565, 0.083333333333333
64122, 1.5695652173913, 1.2978260869565, 0.055555555555556
64123, 1.5913043478261, 1.3239130434783, 0.055555555555556
64124, 1.5913043478261, 1.2978260869565, 0.027777777777778
64125, 1.6347826086957, 1.2978260869565, 0.47222222222222
64126, 1.6130434782609, 1.2978260869565, 0.44444444444444
64127, 1.6347826086957, 1.3239130434783, 0.44444444444444
64128, 1.6347826086957, 1.2978260869565, 0.41666666666667
64129, 1.6130434782609, 1.2978260869565, 0.38888888888889
64130, 1.6347826086957, 1.3239130434783, 0.38888888888889
64131, 1.6347826086957, 1.2978260869565, 0.36111111111111
64132, 1.6130434782609, 1.2978260869565, 0.33333333333333
64133, 1.6347826086957, 1.3239130434783, 0.33333333333333
64134, 1.6347826086957, 1.2978260869565, 0.30555555555556
64135, 1.6130434782609, 1.2978260869565, 0.27777777777778
64136, 1.6347826086957, 1.3239130434783, 0.27777777777778
64137, 1.6347826086957, 1.2978260869565, 0.25
64138, 1.6130434782609, 1.2978260869565, 0.22222222222222
64139, 1.6347826086957, 1.3239130434783, 0.22222222222222
64140, 1.6347826086957, 1.2978260869565, 0.19444444444444
64141, 1.6130434782609, 1.2978260869565, 0.16666666666667
64142, 1.6347826086957, 1.3239130434783, 0.16666666666667
64143, 1.6347826086957, 1.2978260869565, 0.13888888888889
64144, 1.6130434782609, 1.2978260869565, 0.11111111111111
64145, 1.6347826086957, 1.3239130434783, 0.11111111111111
64146, 1.6347826086957, 1.2978260869565, 0.083333333333333
64147, 1.6130434782609, 1.2978260869565, 0.055555555555556
64148, 1.6347826086957, 1.3239130434783, 0.055555555555556
64149, 1.6347826086957, 1.2978260869565, 0.027777777777778
64150, 1.6782608695652, 1.2978260869565, 0.47222222222222
64151, 1.6565217391304, 1.2978260869565, 0.44444444444444
64152, 1.6782608695652, 1.3239130434783, 0.44444444444444
64153, 1.6782608695652, 1.2978260869565, 0.41666666666667
64154, 1.6565217391304, 1.2978260869565, 0.38888888888889
64155, 1.6782608695652, 1.3239130434783, 0.38888888888889
64156, 1.6782608695652, 1.2978260869565, 0.36111111111111
64157, 1.6565217391304, 1.2978260869565, 0.33333333333333
64158, 1.6782608695652, 1.3239130434783, 0.33333333333333
64159, 1.6782608695652, 1.2978260869565, 0.30555555555556
64160, 1.6565217391304, 1.2978260869565, 0.27777777777778
64161, 1.6782608695652, 1.3239130434783, 0.27777777777778
64162, 1.6782608695652, 1.2978260869565, 0.25
64163, 1.6565217391304, 1.2978260869565, 0.22222222222222
64164, 1.6782608695652, 1.3239130434783, 0.22222222222222
64165, 1.6782608695652, 1.2978260869565, 0.19444444444444
64166, 1.6565217391304, 1.2978260869565, 0.16666666666667
64167, 1.6782608695652, 1.3239130434783, 0.16666666666667
64168, 1.6782608695652, 1.2978260869565, 0.13888888888889
64169, 1.6565217391304, 1.2978260869565, 0.11111111111111
64170, 1.6782608695652, 1.3239130434783, 0.11111111111111
64171, 1.6782608695652, 1.2978260869565, 0.083333333333333
64172, 1.6565217391304, 1.2978260869565, 0.055555555555556
64173, 1.6782608695652, 1.3239130434783, 0.055555555555556
64174, 1.6782608695652, 1.2978260869565, 0.027777777777778
64175, 1.7217391304348, 1.2978260869565, 0.47222222222222
64176, 1.7, 1.2978260869565, 0.44444444444444
64177, 1.7217391304348, 1.3239130434783, 0.44444444444444
64178, 1.7217391304348, 1.2978260869565, 0.41666666666667
64179, 1.7, 1.2978260869565, 0.38888888888889
64180, 1.7217391304348, 1.3239130434783, 0.38888888888889
64181, 1.7217391304348, 1.2978260869565, 0.36111111111111
64182, 1.7, 1.2978260869565, 0.33333333333333
64183, 1.7217391304348, 1.3239130434783, 0.33333333333333
64184, 1.7217391304348, 1.2978260869565, 0.30555555555556
64185, 1.7, 1.2978260869565, 0.27777777777778
64186, 1.7217391304348, 1.3239130434783, 0.27777777777778
64187, 1.7217391304348, 1.2978260869565, 0.25
64188, 1.7, 1.2978260869565, 0.22222222222222
64189, 1.7217391304348, 1.3239130434783, 0.22222222222222
64190, 1.7217391304348, 1.2978260869565, 0.19444444444444
64191, 1.7, 1.2978260869565, 0.16666666666667
64192, 1.7217391304348, 1.3239130434783, 0.16666666666667
64193, 1.7217391304348, 1.2978260869565, 0.13888888888889
64194, 1.7, 1.2978260869565, 0.11111111111111
64195, 1.7217391304348, 1.3239130434783, 0.11111111111111
64196, 1.7217391304348, 1.2978260869565, 0.083333333333333
64197, 1.7, 1.2978260869565, 0.055555555555556
64198, 1.7217391304348, 1.3239130434783, 0.055555555555556
64199, 1.7217391304348, 1.2978260869565, 0.027777777777778
64200, 1.7652173913043, 1.2978260869565, 0.47222222222222
64201, 1.7434782608696, 1.2978260869565, 0.44444444444444
64202, 1.7652173913043, 1.3239130434783, 0.44444444444444
64203, 1.7652173913043, 1.2978260869565, 0.41666666666667
64204, 1.7434782608696, 1.2978260869565, 0.38888888888889
64205, 1.7652173913043, 1.3239130434783, 0.38888888888889
64206, 1.7652173913043, 1.2978260869565, 0.36111111111111
64207, 1.7434782608696, 1.2978260869565, 0.33333333333333
64208, 1.7652173913043, 1.3239130434783, 0.33333333333333
64209, 1.7652173913043, 1.2978260869565, 0.30555555555556
64210, 1.7434782608696, 1.2978260869565, 0.27777777777778
64211, 1.7652173913043, 1.3239130434783, 0.27777777777778
64212, 1.7652173913043, 1.2978260869565, 0.25
64213, 1.7434782608696, 1.2978260869565, 0.22222222222222
64214, 1.7652173913043, 1.3239130434783, 0.22222222222222
64215, 1.7652173913043, 1.2978260869565, 0.19444444444444
64216, 1.7434782608696, 1.2978260869565, 0.16666666666667
64217, 1.7652173913043, 1.3239130434783, 0.16666666666667
64218, 1.7652173913043, 1.2978260869565, 0.13888888888889
64219, 1.7434782608696, 1.2978260869565, 0.11111111111111
64220, 1.7652173913043, 1.3239130434783, 0.11111111111111
64221, 1.7652173913043, 1.2978260869565, 0.083333333333333
64222, 1.7434782608696, 1.2978260869565, 0.055555555555556
64223, 1.7652173913043, 1.3239130434783, 0.055555555555556
64224, 1.7652173913043, 1.2978260869565, 0.027777777777778
64225, 1.8086956521739, 1.2978260869565, 0.47222222222222
64226, 1.7869565217391, 1.2978260869565, 0.44444444444444
64227, 1.8086956521739, 1.3239130434783, 0.44444444444444
64228, 1.8086956521739, 1.2978260869565, 0.41666666666667
64229, 1.7869565217391, 1.2978260869565, 0.38888888888889
64230, 1.8086956521739, 1.3239130434783, 0.38888888888889
64231, 1.8086956521739, 1.2978260869565, 0.36111111111111
64232, 1.7869565217391, 1.2978260869565, 0.33333333333333
64233, 1.8086956521739, 1.3239130434783, 0.33333333333333
64234, 1.8086956521739, 1.2978260869565, 0.30555555555556
64235, 1.7869565217391, 1.2978260869565, 0.27777777777778
64236, 1.8086956521739, 1.3239130434783, 0.27777777777778
64237, 1.8086956521739, 1.2978260869565, 0.25
64238, 1.7869565217391, 1.2978260869565, 0.22222222222222
64239, 1.8086956521739, 1.3239130434783, 0.22222222222222
64240, 1.8086956521739, 1.2978260869565, 0.19444444444444
64241, 1.7869565217391, 1.2978260869565, 0.16666666666667
64242, 1.8086956521739, 1.3239130434783, 0.16666666666667
64243, 1.8086956521739, 1.2978260869565, 0.13888888888889
64244, 1.7869565217391, 1.2978260869565, 0.11111111111111
64245, 1.8086956521739, 1.3239130434783, 0.11111111111111
64246, 1.8086956521739, 1.2978260869565, 0.083333333333333
64247, 1.7869565217391, 1.2978260869565, 0.055555555555556
64248, 1.8086956521739, 1.3239130434783, 0.055555555555556
64249, 1.8086956521739, 1.2978260869565, 0.027777777777778
64250, 1.8521739130435, 1.2978260869565, 0.47222222222222
64251, 1.8304347826087, 1.2978260869565, 0.44444444444444
64252, 1.8521739130435, 1.3239130434783, 0.44444444444444
64253, 1.8521739130435, 1.2978260869565, 0.41666666666667
64254, 1.8304347826087, 1.2978260869565, 0.38888888888889
64255, 1.8521739130435, 1.3239130434783, 0.38888888888889
64256, 1.8521739130435, 1.2978260869565, 0.36111111111111
64257, 1.8304347826087, 1.2978260869565, 0.33333333333333
64258, 1.8521739130435, 1.3239130434783, 0.33333333333333
64259, 1.8521739130435, 1.2978260869565, 0.30555555555556
64260, 1.8304347826087, 1.2978260869565, 0.27777777777778
64261, 1.8521739130435, 1.3239130434783, 0.27777777777778
64262, 1.8521739130435, 1.2978260869565, 0.25
64263, 1.8304347826087, 1.2978260869565, 0.22222222222222
64264, 1.8521739130435, 1.3239130434783, 0.22222222222222
64265, 1.8521739130435, 1.2978260869565, 0.19444444444444
64266, 1.8304347826087, 1.2978260869565, 0.16666666666667
64267, 1.8521739130435, 1.3239130434783, 0.16666666666667
64268, 1.8521739130435, 1.2978260869565, 0.13888888888889
64269, 1.8304347826087, 1.2978260869565, 0.11111111111111
64270, 1.8521739130435, 1.3239130434783, 0.11111111111111
64271, 1.8521739130435, 1.2978260869565, 0.083333333333333
64272, 1.8304347826087, 1.2978260869565, 0.055555555555556
64273, 1.8521739130435, 1.3239130434783, 0.055555555555556
64274, 1.8521739130435, 1.2978260869565, 0.027777777777778
64275, 1.895652173913, 1.2978260869565, 0.47222222222222
64276, 1.8739130434783, 1.2978260869565, 0.44444444444444
64277, 1.895652173913, 1.3239130434783, 0.44444444444444
64278, 1.895652173913, 1.2978260869565, 0.41666666666667
64279, 1.8739130434783, 1.2978260869565, 0.38888888888889
64280, 1.895652173913, 1.3239130434783, 0.38888888888889
64281, 1.895652173913, 1.2978260869565, 0.36111111111111
64282, 1.8739130434783, 1.2978260869565, 0.33333333333333
64283, 1.895652173913, 1.3239130434783, 0.33333333333333
64284, 1.895652173913, 1.2978260869565, 0.30555555555556
64285, 1.8739130434783, 1.2978260869565, 0.27777777777778
64286, 1.895652173913, 1.3239130434783, 0.27777777777778
64287, 1.895652173913, 1.2978260869565, 0.25
64288, 1.8739130434783, 1.2978260869565, 0.22222222222222
64289, 1.895652173913, 1.3239130434783, 0.22222222222222
64290, 1.895652173913, 1.2978260869565, 0.19444444444444
64291, 1.8739130434783, 1.2978260869565, 0.16666666666667
64292, 1.895652173913, 1.3239130434783, 0.16666666666667
64293, 1.895652173913, 1.2978260869565, 0.13888888888889
64294, 1.8739130434783, 1.2978260869565, 0.11111111111111
64295, 1.895652173913, 1.3239130434783, 0.11111111111111
64296, 1.895652173913, 1.2978260869565, 0.083333333333333
64297, 1.8739130434783, 1.2978260869565, 0.055555555555556
64298, 1.895652173913, 1.3239130434783, 0.055555555555556
64299, 1.895652173913, 1.2978260869565, 0.027777777777778
64300, 1.9391304347826, 1.2978260869565, 0.47222222222222
64301, 1.9173913043478, 1.2978260869565, 0.44444444444444
64302, 1.9391304347826, 1.3239130434783, 0.44444444444444
64303, 1.9391304347826, 1.2978260869565, 0.41666666666667
64304, 1.9173913043478, 1.2978260869565, 0.38888888888889
64305, 1.9391304347826, 1.3239130434783, 0.38888888888889
64306, 1.9391304347826, 1.2978260869565, 0.36111111111111
64307, 1.9173913043478, 1.2978260869565, 0.33333333333333
64308, 1.9391304347826, 1.3239130434783, 0.33333333333333
64309, 1.9391304347826, 1.2978260869565, 0.30555555555556
64310, 1.9173913043478, 1.2978260869565, 0.27777777777778
64311, 1.9391304347826, 1.3239130434783, 0.27777777777778
64312, 1.9391304347826, 1.2978260869565, 0.25
64313, 1.9173913043478, 1.2978260869565, 0.22222222222222
64314, 1.9391304347826, 1.3239130434783, 0.22222222222222
64315, 1.9391304347826, 1.2978260869565, 0.19444444444444
64316, 1.9173913043478, 1.2978260869565, 0.16666666666667
64317, 1.9391304347826, 1.3239130434783, 0.16666666666667
64318, 1.9391304347826, 1.2978260869565, 0.13888888888889
64319, 1.9173913043478, 1.2978260869565, 0.11111111111111
64320, 1.9391304347826, 1.3239130434783, 0.11111111111111
64321, 1.9391304347826, 1.2978260869565, 0.083333333333333
64322, 1.9173913043478, 1.2978260869565, 0.055555555555556
64323, 1.9391304347826, 1.3239130434783, 0.055555555555556
64324, 1.9391304347826, 1.2978260869565, 0.027777777777778
64325, 1.9826086956522, 1.2978260869565, 0.47222222222222
64326, 1.9608695652174, 1.2978260869565, 0.44444444444444
64327, 1.9826086956522, 1.3239130434783, 0.44444444444444
64328, 1.9826086956522, 1.2978260869565, 0.41666666666667
64329, 1.9608695652174, 1.2978260869565, 0.38888888888889
64330, 1.9826086956522, 1.3239130434783, 0.38888888888889
64331, 1.9826086956522, 1.2978260869565, 0.36111111111111
64332, 1.9608695652174, 1.2978260869565, 0.33333333333333
64333, 1.9826086956522, 1.3239130434783, 0.33333333333333
64334, 1.9826086956522, 1.2978260869565, 0.30555555555556
64335, 1.9608695652174, 1.2978260869565, 0.27777777777778
64336, 1.9826086956522, 1.3239130434783, 0.27777777777778
64337, 1.9826086956522, 1.2978260869565, 0.25
64338, 1.9608695652174, 1.2978260869565, 0.22222222222222
64339, 1.9826086956522, 1.3239130434783, 0.22222222222222
64340, 1.9826086956522, 1.2978260869565, 0.19444444444444
64341, 1.9608695652174, 1.2978260869565, 0.16666666666667
64342, 1.9826086956522, 1.3239130434783, 0.16666666666667
64343, 1.9826086956522, 1.2978260869565, 0.13888888888889
64344, 1.9608695652174, 1.2978260869565, 0.11111111111111
64345, 1.9826086956522, 1.3239130434783, 0.11111111111111
64346, 1.9826086956522, 1.2978260869565, 0.083333333333333
64347, 1.9608695652174, 1.2978260869565, 0.055555555555556
64348, 1.9826086956522, 1.3239130434783, 0.055555555555556
64349, 1.9826086956522, 1.2978260869565, 0.027777777777778
64350, 2.0260869565217, 1.2978260869565, 0.47222222222222
64351, 2.004347826087, 1.2978260869565, 0.44444444444444
64352, 2.0260869565217, 1.3239130434783, 0.44444444444444
64353, 2.0260869565217, 1.2978260869565, 0.41666666666667
64354, 2.004347826087, 1.2978260869565, 0.38888888888889
64355, 2.0260869565217, 1.3239130434783, 0.38888888888889
64356, 2.0260869565217, 1.2978260869565, 0.36111111111111
64357, 2.004347826087, 1.2978260869565, 0.33333333333333
64358, 2.0260869565217, 1.3239130434783, 0.33333333333333
64359, 2.0260869565217, 1.2978260869565, 0.30555555555556
64360, 2.004347826087, 1.2978260869565, 0.27777777777778
64361, 2.0260869565217, 1.3239130434783, 0.27777777777778
64362, 2.0260869565217, 1.2978260869565, 0.25
64363, 2.004347826087, 1.2978260869565, 0.22222222222222
64364, 2.0260869565217, 1.3239130434783, 0.22222222222222
64365, 2.0260869565217, 1.2978260869565, 0.19444444444444
64366, 2.004347826087, 1.2978260869565, 0.16666666666667
64367, 2.0260869565217, 1.3239130434783, 0.16666666666667
64368, 2.0260869565217, 1.2978260869565, 0.13888888888889
64369, 2.004347826087, 1.2978260869565, 0.11111111111111
64370, 2.0260869565217, 1.3239130434783, 0.11111111111111
64371, 2.0260869565217, 1.2978260869565, 0.083333333333333
64372, 2.004347826087, 1.2978260869565, 0.055555555555556
64373, 2.0260869565217, 1.3239130434783, 0.055555555555556
64374, 2.0260869565217, 1.2978260869565, 0.027777777777778
64375, 2.0695652173913, 1.2978260869565, 0.47222222222222
64376, 2.0478260869565, 1.2978260869565, 0.44444444444444
64377, 2.0695652173913, 1.3239130434783, 0.44444444444444
64378, 2.0695652173913, 1.2978260869565, 0.41666666666667
64379, 2.0478260869565, 1.2978260869565, 0.38888888888889
64380, 2.0695652173913, 1.3239130434783, 0.38888888888889
64381, 2.0695652173913, 1.2978260869565, 0.36111111111111
64382, 2.0478260869565, 1.2978260869565, 0.33333333333333
64383, 2.0695652173913, 1.3239130434783, 0.33333333333333
64384, 2.0695652173913, 1.2978260869565, 0.30555555555556
64385, 2.0478260869565, 1.2978260869565, 0.27777777777778
64386, 2.0695652173913, 1.3239130434783, 0.27777777777778
64387, 2.0695652173913, 1.2978260869565, 0.25
64388, 2.0478260869565, 1.2978260869565, 0.22222222222222
64389, 2.0695652173913, 1.3239130434783, 0.22222222222222
64390, 2.0695652173913, 1.2978260869565, 0.19444444444444
64391, 2.0478260869565, 1.2978260869565, 0.16666666666667
64392, 2.0695652173913, 1.3239130434783, 0.16666666666667
64393, 2.0695652173913, 1.2978260869565, 0.13888888888889
64394, 2.0478260869565, 1.2978260869565, 0.11111111111111
64395, 2.0695652173913, 1.3239130434783, 0.11111111111111
64396, 2.0695652173913, 1.2978260869565, 0.083333333333333
64397, 2.0478260869565, 1.2978260869565, 0.055555555555556
64398, 2.0695652173913, 1.3239130434783, 0.055555555555556
64399, 2.0695652173913, 1.2978260869565, 0.027777777777778
64400, 2.1130434782609, 1.2978260869565, 0.47222222222222
64401, 2.0913043478261, 1.2978260869565, 0.44444444444444
64402, 2.1130434782609, 1.3239130434783, 0.44444444444444
64403, 2.1130434782609, 1.2978260869565, 0.41666666666667
64404, 2.0913043478261, 1.2978260869565, 0.38888888888889
64405, 2.1130434782609, 1.3239130434783, 0.38888888888889
64406, 2.1130434782609, 1.2978260869565, 0.36111111111111
64407, 2.0913043478261, 1.2978260869565, 0.33333333333333
64408, 2.1130434782609, 1.3239130434783, 0.33333333333333
64409, 2.1130434782609, 1.2978260869565, 0.30555555555556
64410, 2.0913043478261, 1.2978260869565, 0.27777777777778
64411, 2.1130434782609, 1.3239130434783, 0.27777777777778
64412, 2.1130434782609, 1.2978260869565, 0.25
64413, 2.0913043478261, 1.2978260869565, 0.22222222222222
64414, 2.1130434782609, 1.3239130434783, 0.22222222222222
64415, 2.1130434782609, 1.2978260869565, 0.19444444444444
64416, 2.0913043478261, 1.2978260869565, 0.16666666666667
64417, 2.1130434782609, 1.3239130434783, 0.16666666666667
64418, 2.1130434782609, 1.2978260869565, 0.13888888888889
64419, 2.0913043478261, 1.2978260869565, 0.11111111111111
64420, 2.1130434782609, 1.3239130434783, 0.11111111111111
64421, 2.1130434782609, 1.2978260869565, 0.083333333333333
64422, 2.0913043478261, 1.2978260869565, 0.055555555555556
64423, 2.1130434782609, 1.3239130434783, 0.055555555555556
64424, 2.1130434782609, 1.2978260869565, 0.027777777777778
64425, 2.1565217391304, 1.2978260869565, 0.47222222222222
64426, 2.1347826086957, 1.2978260869565, 0.44444444444444
64427, 2.1565217391304, 1.3239130434783, 0.44444444444444
64428, 2.1565217391304, 1.2978260869565, 0.41666666666667
64429, 2.1347826086957, 1.2978260869565, 0.38888888888889
64430, 2.1565217391304, 1.3239130434783, 0.38888888888889
64431, 2.1565217391304, 1.2978260869565, 0.36111111111111
64432, 2.1347826086957, 1.2978260869565, 0.33333333333333
64433, 2.1565217391304, 1.3239130434783, 0.33333333333333
64434, 2.1565217391304, 1.2978260869565, 0.30555555555556
64435, 2.1347826086957, 1.2978260869565, 0.27777777777778
64436, 2.1565217391304, 1.3239130434783, 0.27777777777778
64437, 2.1565217391304, 1.2978260869565, 0.25
64438, 2.1347826086957, 1.2978260869565, 0.22222222222222
64439, 2.1565217391304, 1.3239130434783, 0.22222222222222
64440, 2.1565217391304, 1.2978260869565, 0.19444444444444
64441, 2.1347826086957, 1.2978260869565, 0.16666666666667
64442, 2.1565217391304, 1.3239130434783, 0.16666666666667
64443, 2.1565217391304, 1.2978260869565, 0.13888888888889
64444, 2.1347826086957, 1.2978260869565, 0.11111111111111
64445, 2.1565217391304, 1.3239130434783, 0.11111111111111
64446, 2.1565217391304, 1.2978260869565, 0.083333333333333
64447, 2.1347826086957, 1.2978260869565, 0.055555555555556
64448, 2.1565217391304, 1.3239130434783, 0.055555555555556
64449, 2.1565217391304, 1.2978260869565, 0.027777777777778
64450, 2.1782608695652, 1.2978260869565, 0.44444444444444
64451, 2.1782608695652, 1.2978260869565, 0.38888888888889
64452, 2.1782608695652, 1.2978260869565, 0.33333333333333
64453, 2.1782608695652, 1.2978260869565, 0.27777777777778
64454, 2.1782608695652, 1.2978260869565, 0.22222222222222
64455, 2.1782608695652, 1.2978260869565, 0.16666666666667
64456, 2.1782608695652, 1.2978260869565, 0.11111111111111
64457, 2.1782608695652, 1.2978260869565, 0.055555555555556
64458, 1.2434782608696, 1.245652173913, 0.47222222222222
64459, 1.2217391304348, 1.245652173913, 0.44444444444444
64460, 1.2434782608696, 1.2717391304348, 0.44444444444444
64461, 1.2434782608696, 1.245652173913, 0.41666666666667
64462, 1.2217391304348, 1.245652173913, 0.38888888888889
64463, 1.2434782608696, 1.2717391304348, 0.38888888888889
64464, 1.2434782608696, 1.245652173913, 0.36111111111111
64465, 1.2217391304348, 1.245652173913, 0.33333333333333
64466, 1.2434782608696, 1.2717391304348, 0.33333333333333
64467, 1.2434782608696, 1.245652173913, 0.30555555555556
64468, 1.2217391304348, 1.245652173913, 0.27777777777778
64469, 1.2434782608696, 1.2717391304348, 0.27777777777778
64470, 1.2434782608696, 1.245652173913, 0.25
64471, 1.2217391304348, 1.245652173913, 0.22222222222222
64472, 1.2434782608696, 1.2717391304348, 0.22222222222222
64473, 1.2434782608696, 1.245652173913, 0.19444444444444
64474, 1.2217391304348, 1.245652173913, 0.16666666666667
64475, 1.2434782608696, 1.2717391304348, 0.16666666666667
64476, 1.2434782608696, 1.245652173913, 0.13888888888889
64477, 1.2217391304348, 1.245652173913, 0.11111111111111
64478, 1.2434782608696, 1.2717391304348, 0.11111111111111
64479, 1.2434782608696, 1.245652173913, 0.083333333333333
64480, 1.2217391304348, 1.245652173913, 0.055555555555556
64481, 1.2434782608696, 1.2717391304348, 0.055555555555556
64482, 1.2434782608696, 1.245652173913, 0.027777777777778
64483, 1.2869565217391, 1.245652173913, 0.47222222222222
64484, 1.2652173913043, 1.245652173913, 0.44444444444444
64485, 1.2869565217391, 1.2717391304348, 0.44444444444444
64486, 1.2869565217391, 1.245652173913, 0.41666666666667
64487, 1.2652173913043, 1.245652173913, 0.38888888888889
64488, 1.2869565217391, 1.2717391304348, 0.38888888888889
64489, 1.2869565217391, 1.245652173913, 0.36111111111111
64490, 1.2652173913043, 1.245652173913, 0.33333333333333
64491, 1.2869565217391, 1.2717391304348, 0.33333333333333
64492, 1.2869565217391, 1.245652173913, 0.30555555555556
64493, 1.2652173913043, 1.245652173913, 0.27777777777778
64494, 1.2869565217391, 1.2717391304348, 0.27777777777778
64495, 1.2869565217391, 1.245652173913, 0.25
64496, 1.2652173913043, 1.245652173913, 0.22222222222222
64497, 1.2869565217391, 1.2717391304348, 0.22222222222222
64498, 1.2869565217391, 1.245652173913, 0.19444444444444
64499, 1.2652173913043, 1.245652173913, 0.16666666666667
64500, 1.2869565217391, 1.2717391304348, 0.16666666666667
64501, 1.2869565217391, 1.245652173913, 0.13888888888889
64502, 1.2652173913043, 1.245652173913, 0.11111111111111
64503, 1.2869565217391, 1.2717391304348, 0.11111111111111
64504, 1.2869565217391, 1.245652173913, 0.083333333333333
64505, 1.2652173913043, 1.245652173913, 0.055555555555556
64506, 1.2869565217391, 1.2717391304348, 0.055555555555556
64507, 1.2869565217391, 1.245652173913, 0.027777777777778
64508, 1.3304347826087, 1.245652173913, 0.47222222222222
64509, 1.3086956521739, 1.245652173913, 0.44444444444444
64510, 1.3304347826087, 1.2717391304348, 0.44444444444444
64511, 1.3304347826087, 1.245652173913, 0.41666666666667
64512, 1.3086956521739, 1.245652173913, 0.38888888888889
64513, 1.3304347826087, 1.2717391304348, 0.38888888888889
64514, 1.3304347826087, 1.245652173913, 0.36111111111111
64515, 1.3086956521739, 1.245652173913, 0.33333333333333
64516, 1.3304347826087, 1.2717391304348, 0.33333333333333
64517, 1.3304347826087, 1.245652173913, 0.30555555555556
64518, 1.3086956521739, 1.245652173913, 0.27777777777778
64519, 1.3304347826087, 1.2717391304348, 0.27777777777778
64520, 1.3304347826087, 1.245652173913, 0.25
64521, 1.3086956521739, 1.245652173913, 0.22222222222222
64522, 1.3304347826087, 1.2717391304348, 0.22222222222222
64523, 1.3304347826087, 1.245652173913, 0.19444444444444
64524, 1.3086956521739, 1.245652173913, 0.16666666666667
64525, 1.3304347826087, 1.2717391304348, 0.16666666666667
64526, 1.3304347826087, 1.245652173913, 0.13888888888889
64527, 1.3086956521739, 1.245652173913, 0.11111111111111
64528, 1.3304347826087, 1.2717391304348, 0.11111111111111
64529, 1.3304347826087, 1.245652173913, 0.083333333333333
64530, 1.3086956521739, 1.245652173913, 0.055555555555556
64531, 1.3304347826087, 1.2717391304348, 0.055555555555556
64532, 1.3304347826087, 1.245652173913, 0.027777777777778
64533, 1.3739130434783, 1.245652173913, 0.47222222222222
64534, 1.3521739130435, 1.245652173913, 0.44444444444444
64535, 1.3739130434783, 1.2717391304348, 0.44444444444444
64536, 1.3739130434783, 1.245652173913, 0.41666666666667
64537, 1.3521739130435, 1.245652173913, 0.38888888888889
64538, 1.3739130434783, 1.2717391304348, 0.38888888888889
64539, 1.3739130434783, 1.245652173913, 0.36111111111111
64540, 1.3521739130435, 1.245652173913, 0.33333333333333
64541, 1.3739130434783, 1.2717391304348, 0.33333333333333
64542, 1.3739130434783, 1.245652173913, 0.30555555555556
64543, 1.3521739130435, 1.245652173913, 0.27777777777778
64544, 1.3739130434783, 1.2717391304348, 0.27777777777778
64545, 1.3739130434783, 1.245652173913, 0.25
64546, 1.3521739130435, 1.245652173913, 0.22222222222222
64547, 1.3739130434783, 1.2717391304348, 0.22222222222222
64548, 1.3739130434783, 1.245652173913, 0.19444444444444
64549, 1.3521739130435, 1.245652173913, 0.16666666666667
64550, 1.3739130434783, 1.2717391304348, 0.16666666666667
64551, 1.3739130434783, 1.245652173913, 0.13888888888889
64552, 1.3521739130435, 1.245652173913, 0.11111111111111
64553, 1.3739130434783, 1.2717391304348, 0.11111111111111
64554, 1.3739130434783, 1.245652173913, 0.083333333333333
64555, 1.3521739130435, 1.245652173913, 0.055555555555556
64556, 1.3739130434783, 1.2717391304348, 0.055555555555556
64557, 1.3739130434783, 1.245652173913, 0.027777777777778
64558, 1.4173913043478, 1.245652173913, 0.47222222222222
64559, 1.395652173913, 1.245652173913, 0.44444444444444
64560, 1.4173913043478, 1.2717391304348, 0.44444444444444
64561, 1.4173913043478, 1.245652173913, 0.41666666666667
64562, 1.395652173913, 1.245652173913, 0.38888888888889
64563, 1.4173913043478, 1.2717391304348, 0.38888888888889
64564, 1.4173913043478, 1.245652173913, 0.36111111111111
64565, 1.395652173913, 1.245652173913, 0.33333333333333
64566, 1.4173913043478, 1.2717391304348, 0.33333333333333
64567, 1.4173913043478, 1.245652173913, 0.30555555555556
64568, 1.395652173913, 1.245652173913, 0.27777777777778
64569, 1.4173913043478, 1.2717391304348, 0.27777777777778
64570, 1.4173913043478, 1.245652173913, 0.25
64571, 1.395652173913, 1.245652173913, 0.22222222222222
64572, 1.4173913043478, 1.2717391304348, 0.22222222222222
64573, 1.4173913043478, 1.245652173913, 0.19444444444444
64574, 1.395652173913, 1.245652173913, 0.16666666666667
64575, 1.4173913043478, 1.2717391304348, 0.16666666666667
64576, 1.4173913043478, 1.245652173913, 0.13888888888889
64577, 1.395652173913, 1.245652173913, 0.11111111111111
64578, 1.4173913043478, 1.2717391304348, 0.11111111111111
64579, 1.4173913043478, 1.245652173913, 0.083333333333333
64580, 1.395652173913, 1.245652173913, 0.055555555555556
64581, 1.4173913043478, 1.2717391304348, 0.055555555555556
64582, 1.4173913043478, 1.245652173913, 0.027777777777778
64583, 1.4608695652174, 1.245652173913, 0.47222222222222
64584, 1.4391304347826, 1.245652173913, 0.44444444444444
64585, 1.4608695652174, 1.2717391304348, 0.44444444444444
64586, 1.4608695652174, 1.245652173913, 0.41666666666667
64587, 1.4391304347826, 1.245652173913, 0.38888888888889
64588, 1.4608695652174, 1.2717391304348, 0.38888888888889
64589, 1.4608695652174, 1.245652173913, 0.36111111111111
64590, 1.4391304347826, 1.245652173913, 0.33333333333333
64591, 1.4608695652174, 1.2717391304348, 0.33333333333333
64592, 1.4608695652174, 1.245652173913, 0.30555555555556
64593, 1.4391304347826, 1.245652173913, 0.27777777777778
64594, 1.4608695652174, 1.2717391304348, 0.27777777777778
64595, 1.4608695652174, 1.245652173913, 0.25
64596, 1.4391304347826, 1.245652173913, 0.22222222222222
64597, 1.4608695652174, 1.2717391304348, 0.22222222222222
64598, 1.4608695652174, 1.245652173913, 0.19444444444444
64599, 1.4391304347826, 1.245652173913, 0.16666666666667
64600, 1.4608695652174, 1.2717391304348, 0.16666666666667
64601, 1.4608695652174, 1.245652173913, 0.13888888888889
64602, 1.4391304347826, 1.245652173913, 0.11111111111111
64603, 1.4608695652174, 1.2717391304348, 0.11111111111111
64604, 1.4608695652174, 1.245652173913, 0.083333333333333
64605, 1.4391304347826, 1.245652173913, 0.055555555555556
64606, 1.4608695652174, 1.2717391304348, 0.055555555555556
64607, 1.4608695652174, 1.245652173913, 0.027777777777778
64608, 1.504347826087, 1.245652173913, 0.47222222222222
64609, 1.4826086956522, 1.245652173913, 0.44444444444444
64610, 1.504347826087, 1.2717391304348, 0.44444444444444
64611, 1.504347826087, 1.245652173913, 0.41666666666667
64612, 1.4826086956522, 1.245652173913, 0.38888888888889
64613, 1.504347826087, 1.2717391304348, 0.38888888888889
64614, 1.504347826087, 1.245652173913, 0.36111111111111
64615, 1.4826086956522, 1.245652173913, 0.33333333333333
64616, 1.504347826087, 1.2717391304348, 0.33333333333333
64617, 1.504347826087, 1.245652173913, 0.30555555555556
64618, 1.4826086956522, 1.245652173913, 0.27777777777778
64619, 1.504347826087, 1.2717391304348, 0.27777777777778
64620, 1.504347826087, 1.245652173913, 0.25
64621, 1.4826086956522, 1.245652173913, 0.22222222222222
64622, 1.504347826087, 1.2717391304348, 0.22222222222222
64623, 1.504347826087, 1.245652173913, 0.19444444444444
64624, 1.4826086956522, 1.245652173913, 0.16666666666667
64625, 1.504347826087, 1.2717391304348, 0.16666666666667
64626, 1.504347826087, 1.245652173913, 0.13888888888889
64627, 1.4826086956522, 1.245652173913, 0.11111111111111
64628, 1.504347826087, 1.2717391304348, 0.11111111111111
64629, 1.504347826087, 1.245652173913, 0.083333333333333
64630, 1.4826086956522, 1.245652173913, 0.055555555555556
64631, 1.504347826087, 1.2717391304348, 0.055555555555556
64632, 1.504347826087, 1.245652173913, 0.027777777777778
64633, 1.5478260869565, 1.245652173913, 0.47222222222222
64634, 1.5260869565217, 1.245652173913, 0.44444444444444
64635, 1.5478260869565, 1.2717391304348, 0.44444444444444
64636, 1.5478260869565, 1.245652173913, 0.41666666666667
64637, 1.5260869565217, 1.245652173913, 0.38888888888889
64638, 1.5478260869565, 1.2717391304348, 0.38888888888889
64639, 1.5478260869565, 1.245652173913, 0.36111111111111
64640, 1.5260869565217, 1.245652173913, 0.33333333333333
64641, 1.5478260869565, 1.2717391304348, 0.33333333333333
64642, 1.5478260869565, 1.245652173913, 0.30555555555556
64643, 1.5260869565217, 1.245652173913, 0.27777777777778
64644, 1.5478260869565, 1.2717391304348, 0.27777777777778
64645, 1.5478260869565, 1.245652173913, 0.25
64646, 1.5260869565217, 1.245652173913, 0.22222222222222
64647, 1.5478260869565, 1.2717391304348, 0.22222222222222
64648, 1.5478260869565, 1.245652173913, 0.19444444444444
64649, 1.5260869565217, 1.245652173913, 0.16666666666667
64650, 1.5478260869565, 1.2717391304348, 0.16666666666667
64651, 1.5478260869565, 1.245652173913, 0.13888888888889
64652, 1.5260869565217, 1.245652173913, 0.11111111111111
64653, 1.5478260869565, 1.2717391304348, 0.11111111111111
64654, 1.5478260869565, 1.245652173913, 0.083333333333333
64655, 1.5260869565217, 1.245652173913, 0.055555555555556
64656, 1.5478260869565, 1.2717391304348, 0.055555555555556
64657, 1.5478260869565, 1.245652173913, 0.027777777777778
64658, 1.5913043478261, 1.245652173913, 0.47222222222222
64659, 1.5695652173913, 1.245652173913, 0.44444444444444
64660, 1.5913043478261, 1.2717391304348, 0.44444444444444
64661, 1.5913043478261, 1.245652173913, 0.41666666666667
64662, 1.5695652173913, 1.245652173913, 0.38888888888889
64663, 1.5913043478261, 1.2717391304348, 0.38888888888889
64664, 1.5913043478261, 1.245652173913, 0.36111111111111
64665, 1.5695652173913, 1.245652173913, 0.33333333333333
64666, 1.5913043478261, 1.2717391304348, 0.33333333333333
64667, 1.5913043478261, 1.245652173913, 0.30555555555556
64668, 1.5695652173913, 1.245652173913, 0.27777777777778
64669, 1.5913043478261, 1.2717391304348, 0.27777777777778
64670, 1.5913043478261, 1.245652173913, 0.25
64671, 1.5695652173913, 1.245652173913, 0.22222222222222
64672, 1.5913043478261, 1.2717391304348, 0.22222222222222
64673, 1.5913043478261, 1.245652173913, 0.19444444444444
64674, 1.5695652173913, 1.245652173913, 0.16666666666667
64675, 1.5913043478261, 1.2717391304348, 0.16666666666667
64676, 1.5913043478261, 1.245652173913, 0.13888888888889
64677, 1.5695652173913, 1.245652173913, 0.11111111111111
64678, 1.5913043478261, 1.2717391304348, 0.11111111111111
64679, 1.5913043478261, 1.245652173913, 0.083333333333333
64680, 1.5695652173913, 1.245652173913, 0.055555555555556
64681, 1.5913043478261, 1.2717391304348, 0.055555555555556
64682, 1.5913043478261, 1.245652173913, 0.027777777777778
64683, 1.6347826086957, 1.245652173913, 0.47222222222222
64684, 1.6130434782609, 1.245652173913, 0.44444444444444
64685, 1.6347826086957, 1.2717391304348, 0.44444444444444
64686, 1.6347826086957, 1.245652173913, 0.41666666666667
64687, 1.6130434782609, 1.245652173913, 0.38888888888889
64688, 1.6347826086957, 1.2717391304348, 0.38888888888889
64689, 1.6347826086957, 1.245652173913, 0.36111111111111
64690, 1.6130434782609, 1.245652173913, 0.33333333333333
64691, 1.6347826086957, 1.2717391304348, 0.33333333333333
64692, 1.6347826086957, 1.245652173913, 0.30555555555556
64693, 1.6130434782609, 1.245652173913, 0.27777777777778
64694, 1.6347826086957, 1.2717391304348, 0.27777777777778
64695, 1.6347826086957, 1.245652173913, 0.25
64696, 1.6130434782609, 1.245652173913, 0.22222222222222
64697, 1.6347826086957, 1.2717391304348, 0.22222222222222
64698, 1.6347826086957, 1.245652173913, 0.19444444444444
64699, 1.6130434782609, 1.245652173913, 0.16666666666667
64700, 1.6347826086957, 1.2717391304348, 0.16666666666667
64701, 1.6347826086957, 1.245652173913, 0.13888888888889
64702, 1.6130434782609, 1.245652173913, 0.11111111111111
64703, 1.6347826086957, 1.2717391304348, 0.11111111111111
64704, 1.6347826086957, 1.245652173913, 0.083333333333333
64705, 1.6130434782609, 1.245652173913, 0.055555555555556
64706, 1.6347826086957, 1.2717391304348, 0.055555555555556
64707, 1.6347826086957, 1.245652173913, 0.027777777777778
64708, 1.6782608695652, 1.245652173913, 0.47222222222222
64709, 1.6565217391304, 1.245652173913, 0.44444444444444
64710, 1.6782608695652, 1.2717391304348, 0.44444444444444
64711, 1.6782608695652, 1.245652173913, 0.41666666666667
64712, 1.6565217391304, 1.245652173913, 0.38888888888889
64713, 1.6782608695652, 1.2717391304348, 0.38888888888889
64714, 1.6782608695652, 1.245652173913, 0.36111111111111
64715, 1.6565217391304, 1.245652173913, 0.33333333333333
64716, 1.6782608695652, 1.2717391304348, 0.33333333333333
64717, 1.6782608695652, 1.245652173913, 0.30555555555556
64718, 1.6565217391304, 1.245652173913, 0.27777777777778
64719, 1.6782608695652, 1.2717391304348, 0.27777777777778
64720, 1.6782608695652, 1.245652173913, 0.25
64721, 1.6565217391304, 1.245652173913, 0.22222222222222
64722, 1.6782608695652, 1.2717391304348, 0.22222222222222
64723, 1.6782608695652, 1.245652173913, 0.19444444444444
64724, 1.6565217391304, 1.245652173913, 0.16666666666667
64725, 1.6782608695652, 1.2717391304348, 0.16666666666667
64726, 1.6782608695652, 1.245652173913, 0.13888888888889
64727, 1.6565217391304, 1.245652173913, 0.11111111111111
64728, 1.6782608695652, 1.2717391304348, 0.11111111111111
64729, 1.6782608695652, 1.245652173913, 0.083333333333333
64730, 1.6565217391304, 1.245652173913, 0.055555555555556
64731, 1.6782608695652, 1.2717391304348, 0.055555555555556
64732, 1.6782608695652, 1.245652173913, 0.027777777777778
64733, 1.7217391304348, 1.245652173913, 0.47222222222222
64734, 1.7, 1.245652173913, 0.44444444444444
64735, 1.7217391304348, 1.2717391304348, 0.44444444444444
64736, 1.7217391304348, 1.245652173913, 0.41666666666667
64737, 1.7, 1.245652173913, 0.38888888888889
64738, 1.7217391304348, 1.2717391304348, 0.38888888888889
64739, 1.7217391304348, 1.245652173913, 0.36111111111111
64740, 1.7, 1.245652173913, 0.33333333333333
64741, 1.7217391304348, 1.2717391304348, 0.33333333333333
64742, 1.7217391304348, 1.245652173913, 0.30555555555556
64743, 1.7, 1.245652173913, 0.27777777777778
64744, 1.7217391304348, 1.2717391304348, 0.27777777777778
64745, 1.7217391304348, 1.245652173913, 0.25
64746, 1.7, 1.245652173913, 0.22222222222222
64747, 1.7217391304348, 1.2717391304348, 0.22222222222222
64748, 1.7217391304348, 1.245652173913, 0.19444444444444
64749, 1.7, 1.245652173913, 0.16666666666667
64750, 1.7217391304348, 1.2717391304348, 0.16666666666667
64751, 1.7217391304348, 1.245652173913, 0.13888888888889
64752, 1.7, 1.245652173913, 0.11111111111111
64753, 1.7217391304348, 1.2717391304348, 0.11111111111111
64754, 1.7217391304348, 1.245652173913, 0.083333333333333
64755, 1.7, 1.245652173913, 0.055555555555556
64756, 1.7217391304348, 1.2717391304348, 0.055555555555556
64757, 1.7217391304348, 1.245652173913, 0.027777777777778
64758, 1.7652173913043, 1.245652173913, 0.47222222222222
64759, 1.7434782608696, 1.245652173913, 0.44444444444444
64760, 1.7652173913043, 1.2717391304348, 0.44444444444444
64761, 1.7652173913043, 1.245652173913, 0.41666666666667
64762, 1.7434782608696, 1.245652173913, 0.38888888888889
64763, 1.7652173913043, 1.2717391304348, 0.38888888888889
64764, 1.7652173913043, 1.245652173913, 0.36111111111111
64765, 1.7434782608696, 1.245652173913, 0.33333333333333
64766, 1.7652173913043, 1.2717391304348, 0.33333333333333
64767, 1.7652173913043, 1.245652173913, 0.30555555555556
64768, 1.7434782608696, 1.245652173913, 0.27777777777778
64769, 1.7652173913043, 1.2717391304348, 0.27777777777778
64770, 1.7652173913043, 1.245652173913, 0.25
64771, 1.7434782608696, 1.245652173913, 0.22222222222222
64772, 1.7652173913043, 1.2717391304348, 0.22222222222222
64773, 1.7652173913043, 1.245652173913, 0.19444444444444
64774, 1.7434782608696, 1.245652173913, 0.16666666666667
64775, 1.7652173913043, 1.2717391304348, 0.16666666666667
64776, 1.7652173913043, 1.245652173913, 0.13888888888889
64777, 1.7434782608696, 1.245652173913, 0.11111111111111
64778, 1.7652173913043, 1.2717391304348, 0.11111111111111
64779, 1.7652173913043, 1.245652173913, 0.083333333333333
64780, 1.7434782608696, 1.245652173913, 0.055555555555556
64781, 1.7652173913043, 1.2717391304348, 0.055555555555556
64782, 1.7652173913043, 1.245652173913, 0.027777777777778
64783, 1.8086956521739, 1.245652173913, 0.47222222222222
64784, 1.7869565217391, 1.245652173913, 0.44444444444444
64785, 1.8086956521739, 1.2717391304348, 0.44444444444444
64786, 1.8086956521739, 1.245652173913, 0.41666666666667
64787, 1.7869565217391, 1.245652173913, 0.38888888888889
64788, 1.8086956521739, 1.2717391304348, 0.38888888888889
64789, 1.8086956521739, 1.245652173913, 0.36111111111111
64790, 1.7869565217391, 1.245652173913, 0.33333333333333
64791, 1.8086956521739, 1.2717391304348, 0.33333333333333
64792, 1.8086956521739, 1.245652173913, 0.30555555555556
64793, 1.7869565217391, 1.245652173913, 0.27777777777778
64794, 1.8086956521739, 1.2717391304348, 0.27777777777778
64795, 1.8086956521739, 1.245652173913, 0.25
64796, 1.7869565217391, 1.245652173913, 0.22222222222222
64797, 1.8086956521739, 1.2717391304348, 0.22222222222222
64798, 1.8086956521739, 1.245652173913, 0.19444444444444
64799, 1.7869565217391, 1.245652173913, 0.16666666666667
64800, 1.8086956521739, 1.2717391304348, 0.16666666666667
64801, 1.8086956521739, 1.245652173913, 0.13888888888889
64802, 1.7869565217391, 1.245652173913, 0.11111111111111
64803, 1.8086956521739, 1.2717391304348, 0.11111111111111
64804, 1.8086956521739, 1.245652173913, 0.083333333333333
64805, 1.7869565217391, 1.245652173913, 0.055555555555556
64806, 1.8086956521739, 1.2717391304348, 0.055555555555556
64807, 1.8086956521739, 1.245652173913, 0.027777777777778
64808, 1.8521739130435, 1.245652173913, 0.47222222222222
64809, 1.8304347826087, 1.245652173913, 0.44444444444444
64810, 1.8521739130435, 1.2717391304348, 0.44444444444444
64811, 1.8521739130435, 1.245652173913, 0.41666666666667
64812, 1.8304347826087, 1.245652173913, 0.38888888888889
64813, 1.8521739130435, 1.2717391304348, 0.38888888888889
64814, 1.8521739130435, 1.245652173913, 0.36111111111111
64815, 1.8304347826087, 1.245652173913, 0.33333333333333
64816, 1.8521739130435, 1.2717391304348, 0.33333333333333
64817, 1.8521739130435, 1.245652173913, 0.30555555555556
64818, 1.8304347826087, 1.245652173913, 0.27777777777778
64819, 1.8521739130435, 1.2717391304348, 0.27777777777778
64820, 1.8521739130435, 1.245652173913, 0.25
64821, 1.8304347826087, 1.245652173913, 0.22222222222222
64822, 1.8521739130435, 1.2717391304348, 0.22222222222222
64823, 1.8521739130435, 1.245652173913, 0.19444444444444
64824, 1.8304347826087, 1.245652173913, 0.16666666666667
64825, 1.8521739130435, 1.2717391304348, 0.16666666666667
64826, 1.8521739130435, 1.245652173913, 0.13888888888889
64827, 1.8304347826087, 1.245652173913, 0.11111111111111
64828, 1.8521739130435, 1.2717391304348, 0.11111111111111
64829, 1.8521739130435, 1.245652173913, 0.083333333333333
64830, 1.8304347826087, 1.245652173913, 0.055555555555556
64831, 1.8521739130435, 1.2717391304348, 0.055555555555556
64832, 1.8521739130435, 1.245652173913, 0.027777777777778
64833, 1.895652173913, 1.245652173913, 0.47222222222222
64834, 1.8739130434783, 1.245652173913, 0.44444444444444
64835, 1.895652173913, 1.2717391304348, 0.44444444444444
64836, 1.895652173913, 1.245652173913, 0.41666666666667
64837, 1.8739130434783, 1.245652173913, 0.38888888888889
64838, 1.895652173913, 1.2717391304348, 0.38888888888889
64839, 1.895652173913, 1.245652173913, 0.36111111111111
64840, 1.8739130434783, 1.245652173913, 0.33333333333333
64841, 1.895652173913, 1.2717391304348, 0.33333333333333
64842, 1.895652173913, 1.245652173913, 0.30555555555556
64843, 1.8739130434783, 1.245652173913, 0.27777777777778
64844, 1.895652173913, 1.2717391304348, 0.27777777777778
64845, 1.895652173913, 1.245652173913, 0.25
64846, 1.8739130434783, 1.245652173913, 0.22222222222222
64847, 1.895652173913, 1.2717391304348, 0.22222222222222
64848, 1.895652173913, 1.245652173913, 0.19444444444444
64849, 1.8739130434783, 1.245652173913, 0.16666666666667
64850, 1.895652173913, 1.2717391304348, 0.16666666666667
64851, 1.895652173913, 1.245652173913, 0.13888888888889
64852, 1.8739130434783, 1.245652173913, 0.11111111111111
64853, 1.895652173913, 1.2717391304348, 0.11111111111111
64854, 1.895652173913, 1.245652173913, 0.083333333333333
64855, 1.8739130434783, 1.245652173913, 0.055555555555556
64856, 1.895652173913, 1.2717391304348, 0.055555555555556
64857, 1.895652173913, 1.245652173913, 0.027777777777778
64858, 1.9391304347826, 1.245652173913, 0.47222222222222
64859, 1.9173913043478, 1.245652173913, 0.44444444444444
64860, 1.9391304347826, 1.2717391304348, 0.44444444444444
64861, 1.9391304347826, 1.245652173913, 0.41666666666667
64862, 1.9173913043478, 1.245652173913, 0.38888888888889
64863, 1.9391304347826, 1.2717391304348, 0.38888888888889
64864, 1.9391304347826, 1.245652173913, 0.36111111111111
64865, 1.9173913043478, 1.245652173913, 0.33333333333333
64866, 1.9391304347826, 1.2717391304348, 0.33333333333333
64867, 1.9391304347826, 1.245652173913, 0.30555555555556
64868, 1.9173913043478, 1.245652173913, 0.27777777777778
64869, 1.9391304347826, 1.2717391304348, 0.27777777777778
64870, 1.9391304347826, 1.245652173913, 0.25
64871, 1.9173913043478, 1.245652173913, 0.22222222222222
64872, 1.9391304347826, 1.2717391304348, 0.22222222222222
64873, 1.9391304347826, 1.245652173913, 0.19444444444444
64874, 1.9173913043478, 1.245652173913, 0.16666666666667
64875, 1.9391304347826, 1.2717391304348, 0.16666666666667
64876, 1.9391304347826, 1.245652173913, 0.13888888888889
64877, 1.9173913043478, 1.245652173913, 0.11111111111111
64878, 1.9391304347826, 1.2717391304348, 0.11111111111111
64879, 1.9391304347826, 1.245652173913, 0.083333333333333
64880, 1.9173913043478, 1.245652173913, 0.055555555555556
64881, 1.9391304347826, 1.2717391304348, 0.055555555555556
64882, 1.9391304347826, 1.245652173913, 0.027777777777778
64883, 1.9826086956522, 1.245652173913, 0.47222222222222
64884, 1.9608695652174, 1.245652173913, 0.44444444444444
64885, 1.9826086956522, 1.2717391304348, 0.44444444444444
64886, 1.9826086956522, 1.245652173913, 0.41666666666667
64887, 1.9608695652174, 1.245652173913, 0.38888888888889
64888, 1.9826086956522, 1.2717391304348, 0.38888888888889
64889, 1.9826086956522, 1.245652173913, 0.36111111111111
64890, 1.9608695652174, 1.245652173913, 0.33333333333333
64891, 1.9826086956522, 1.2717391304348, 0.33333333333333
64892, 1.9826086956522, 1.245652173913, 0.30555555555556
64893, 1.9608695652174, 1.245652173913, 0.27777777777778
64894, 1.9826086956522, 1.2717391304348, 0.27777777777778
64895, 1.9826086956522, 1.245652173913, 0.25
64896, 1.9608695652174, 1.245652173913, 0.22222222222222
64897, 1.9826086956522, 1.2717391304348, 0.22222222222222
64898, 1.9826086956522, 1.245652173913, 0.19444444444444
64899, 1.9608695652174, 1.245652173913, 0.16666666666667
64900, 1.9826086956522, 1.2717391304348, 0.16666666666667
64901, 1.9826086956522, 1.245652173913, 0.13888888888889
64902, 1.9608695652174, 1.245652173913, 0.11111111111111
64903, 1.9826086956522, 1.2717391304348, 0.11111111111111
64904, 1.9826086956522, 1.245652173913, 0.083333333333333
64905, 1.9608695652174, 1.245652173913, 0.055555555555556
64906, 1.9826086956522, 1.2717391304348, 0.055555555555556
64907, 1.9826086956522, 1.245652173913, 0.027777777777778
64908, 2.0260869565217, 1.245652173913, 0.47222222222222
64909, 2.004347826087, 1.245652173913, 0.44444444444444
64910, 2.0260869565217, 1.2717391304348, 0.44444444444444
64911, 2.0260869565217, 1.245652173913, 0.41666666666667
64912, 2.004347826087, 1.245652173913, 0.38888888888889
64913, 2.0260869565217, 1.2717391304348, 0.38888888888889
64914, 2.0260869565217, 1.245652173913, 0.36111111111111
64915, 2.004347826087, 1.245652173913, 0.33333333333333
64916, 2.0260869565217, 1.2717391304348, 0.33333333333333
64917, 2.0260869565217, 1.245652173913, 0.30555555555556
64918, 2.004347826087, 1.245652173913, 0.27777777777778
64919, 2.0260869565217, 1.2717391304348, 0.27777777777778
64920, 2.0260869565217, 1.245652173913, 0.25
64921, 2.004347826087, 1.245652173913, 0.22222222222222
64922, 2.0260869565217, 1.2717391304348, 0.22222222222222
64923, 2.0260869565217, 1.245652173913, 0.19444444444444
64924, 2.004347826087, 1.245652173913, 0.16666666666667
64925, 2.0260869565217, 1.2717391304348, 0.16666666666667
64926, 2.0260869565217, 1.245652173913, 0.13888888888889
64927, 2.004347826087, 1.245652173913, 0.11111111111111
64928, 2.0260869565217, 1.2717391304348, 0.11111111111111
64929, 2.0260869565217, 1.245652173913, 0.083333333333333
64930, 2.004347826087, 1.245652173913, 0.055555555555556
64931, 2.0260869565217, 1.2717391304348, 0.055555555555556
64932, 2.0260869565217, 1.245652173913, 0.027777777777778
64933, 2.0695652173913, 1.245652173913, 0.47222222222222
64934, 2.0478260869565, 1.245652173913, 0.44444444444444
64935, 2.0695652173913, 1.2717391304348, 0.44444444444444
64936, 2.0695652173913, 1.245652173913, 0.41666666666667
64937, 2.0478260869565, 1.245652173913, 0.38888888888889
64938, 2.0695652173913, 1.2717391304348, 0.38888888888889
64939, 2.0695652173913, 1.245652173913, 0.36111111111111
64940, 2.0478260869565, 1.245652173913, 0.33333333333333
64941, 2.0695652173913, 1.2717391304348, 0.33333333333333
64942, 2.0695652173913, 1.245652173913, 0.30555555555556
64943, 2.0478260869565, 1.245652173913, 0.27777777777778
64944, 2.0695652173913, 1.2717391304348, 0.27777777777778
64945, 2.0695652173913, 1.245652173913, 0.25
64946, 2.0478260869565, 1.245652173913, 0.22222222222222
64947, 2.0695652173913, 1.2717391304348, 0.22222222222222
64948, 2.0695652173913, 1.245652173913, 0.19444444444444
64949, 2.0478260869565, 1.245652173913, 0.16666666666667
64950, 2.0695652173913, 1.2717391304348, 0.16666666666667
64951, 2.0695652173913, 1.245652173913, 0.13888888888889
64952, 2.0478260869565, 1.245652173913, 0.11111111111111
64953, 2.0695652173913, 1.2717391304348, 0.11111111111111
64954, 2.0695652173913, 1.245652173913, 0.083333333333333
64955, 2.0478260869565, 1.245652173913, 0.055555555555556
64956, 2.0695652173913, 1.2717391304348, 0.055555555555556
64957, 2.0695652173913, 1.245652173913, 0.027777777777778
64958, 2.1130434782609, 1.245652173913, 0.47222222222222
64959, 2.0913043478261, 1.245652173913, 0.44444444444444
64960, 2.1130434782609, 1.2717391304348, 0.44444444444444
64961, 2.1130434782609, 1.245652173913, 0.41666666666667
64962, 2.0913043478261, 1.245652173913, 0.38888888888889
64963, 2.1130434782609, 1.2717391304348, 0.38888888888889
64964, 2.1130434782609, 1.245652173913, 0.36111111111111
64965, 2.0913043478261, 1.245652173913, 0.33333333333333
64966, 2.1130434782609, 1.2717391304348, 0.33333333333333
64967, 2.1130434782609, 1.245652173913, 0.30555555555556
64968, 2.0913043478261, 1.245652173913, 0.27777777777778
64969, 2.1130434782609, 1.2717391304348, 0.27777777777778
64970, 2.1130434782609, 1.245652173913, 0.25
64971, 2.0913043478261, 1.245652173913, 0.22222222222222
64972, 2.1130434782609, 1.2717391304348, 0.22222222222222
64973, 2.1130434782609, 1.245652173913, 0.19444444444444
64974, 2.0913043478261, 1.245652173913, 0.16666666666667
64975, 2.1130434782609, 1.2717391304348, 0.16666666666667
64976, 2.1130434782609, 1.245652173913, 0.13888888888889
64977, 2.0913043478261, 1.245652173913, 0.11111111111111
64978, 2.1130434782609, 1.2717391304348, 0.11111111111111
64979, 2.1130434782609, 1.245652173913, 0.083333333333333
64980, 2.0913043478261, 1.245652173913, 0.055555555555556
64981, 2.1130434782609, 1.2717391304348, 0.055555555555556
64982, 2.1130434782609, 1.245652173913, 0.027777777777778
64983, 2.1565217391304, 1.245652173913, 0.47222222222222
64984, 2.1347826086957, 1.245652173913, 0.44444444444444
64985, 2.1565217391304, 1.2717391304348, 0.44444444444444
64986, 2.1565217391304, 1.245652173913, 0.41666666666667
64987, 2.1347826086957, 1.245652173913, 0.38888888888889
64988, 2.1565217391304, 1.2717391304348, 0.38888888888889
64989, 2.1565217391304, 1.245652173913, 0.36111111111111
64990, 2.1347826086957, 1.245652173913, 0.33333333333333
64991, 2.1565217391304, 1.2717391304348, 0.33333333333333
64992, 2.1565217391304, 1.245652173913, 0.30555555555556
64993, 2.1347826086957, 1.245652173913, 0.27777777777778
64994, 2.1565217391304, 1.2717391304348, 0.27777777777778
64995, 2.1565217391304, 1.245652173913, 0.25
64996, 2.1347826086957, 1.245652173913, 0.22222222222222
64997, 2.1565217391304, 1.2717391304348, 0.22222222222222
64998, 2.1565217391304, 1.245652173913, 0.19444444444444
64999, 2.1347826086957, 1.245652173913, 0.16666666666667
65000, 2.1565217391304, 1.2717391304348, 0.16666666666667
65001, 2.1565217391304, 1.245652173913, 0.13888888888889
65002, 2.1347826086957, 1.245652173913, 0.11111111111111
65003, 2.1565217391304, 1.2717391304348, 0.11111111111111
65004, 2.1565217391304, 1.245652173913, 0.083333333333333
65005, 2.1347826086957, 1.245652173913, 0.055555555555556
65006, 2.1565217391304, 1.2717391304348, 0.055555555555556
65007, 2.1565217391304, 1.245652173913, 0.027777777777778
65008, 2.1782608695652, 1.245652173913, 0.44444444444444
65009, 2.1782608695652, 1.245652173913, 0.38888888888889
65010, 2.1782608695652, 1.245652173913, 0.33333333333333
65011, 2.1782608695652, 1.245652173913, 0.27777777777778
65012, 2.1782608695652, 1.245652173913, 0.22222222222222
65013, 2.1782608695652, 1.245652173913, 0.16666666666667
65014, 2.1782608695652, 1.245652173913, 0.11111111111111
65015, 2.1782608695652, 1.245652173913, 0.055555555555556
65016, 1.2434782608696, 1.1934782608696, 0.47222222222222
65017, 1.2217391304348, 1.1934782608696, 0.44444444444444
65018, 1.2434782608696, 1.2195652173913, 0.44444444444444
65019, 1.2434782608696, 1.1934782608696, 0.41666666666667
65020, 1.2217391304348, 1.1934782608696, 0.38888888888889
65021, 1.2434782608696, 1.2195652173913, 0.38888888888889
65022, 1.2434782608696, 1.1934782608696, 0.36111111111111
65023, 1.2217391304348, 1.1934782608696, 0.33333333333333
65024, 1.2434782608696, 1.2195652173913, 0.33333333333333
65025, 1.2434782608696, 1.1934782608696, 0.30555555555556
65026, 1.2217391304348, 1.1934782608696, 0.27777777777778
65027, 1.2434782608696, 1.2195652173913, 0.27777777777778
65028, 1.2434782608696, 1.1934782608696, 0.25
65029, 1.2217391304348, 1.1934782608696, 0.22222222222222
65030, 1.2434782608696, 1.2195652173913, 0.22222222222222
65031, 1.2434782608696, 1.1934782608696, 0.19444444444444
65032, 1.2217391304348, 1.1934782608696, 0.16666666666667
65033, 1.2434782608696, 1.2195652173913, 0.16666666666667
65034, 1.2434782608696, 1.1934782608696, 0.13888888888889
65035, 1.2217391304348, 1.1934782608696, 0.11111111111111
65036, 1.2434782608696, 1.2195652173913, 0.11111111111111
65037, 1.2434782608696, 1.1934782608696, 0.083333333333333
65038, 1.2217391304348, 1.1934782608696, 0.055555555555556
65039, 1.2434782608696, 1.2195652173913, 0.055555555555556
65040, 1.2434782608696, 1.1934782608696, 0.027777777777778
65041, 1.2869565217391, 1.1934782608696, 0.47222222222222
65042, 1.2652173913043, 1.1934782608696, 0.44444444444444
65043, 1.2869565217391, 1.2195652173913, 0.44444444444444
65044, 1.2869565217391, 1.1934782608696, 0.41666666666667
65045, 1.2652173913043, 1.1934782608696, 0.38888888888889
65046, 1.2869565217391, 1.2195652173913, 0.38888888888889
65047, 1.2869565217391, 1.1934782608696, 0.36111111111111
65048, 1.2652173913043, 1.1934782608696, 0.33333333333333
65049, 1.2869565217391, 1.2195652173913, 0.33333333333333
65050, 1.2869565217391, 1.1934782608696, 0.30555555555556
65051, 1.2652173913043, 1.1934782608696, 0.27777777777778
65052, 1.2869565217391, 1.2195652173913, 0.27777777777778
65053, 1.2869565217391, 1.1934782608696, 0.25
65054, 1.2652173913043, 1.1934782608696, 0.22222222222222
65055, 1.2869565217391, 1.2195652173913, 0.22222222222222
65056, 1.2869565217391, 1.1934782608696, 0.19444444444444
65057, 1.2652173913043, 1.1934782608696, 0.16666666666667
65058, 1.2869565217391, 1.2195652173913, 0.16666666666667
65059, 1.2869565217391, 1.1934782608696, 0.13888888888889
65060, 1.2652173913043, 1.1934782608696, 0.11111111111111
65061, 1.2869565217391, 1.2195652173913, 0.11111111111111
65062, 1.2869565217391, 1.1934782608696, 0.083333333333333
65063, 1.2652173913043, 1.1934782608696, 0.055555555555556
65064, 1.2869565217391, 1.2195652173913, 0.055555555555556
65065, 1.2869565217391, 1.1934782608696, 0.027777777777778
65066, 1.3304347826087, 1.1934782608696, 0.47222222222222
65067, 1.3086956521739, 1.1934782608696, 0.44444444444444
65068, 1.3304347826087, 1.2195652173913, 0.44444444444444
65069, 1.3304347826087, 1.1934782608696, 0.41666666666667
65070, 1.3086956521739, 1.1934782608696, 0.38888888888889
65071, 1.3304347826087, 1.2195652173913, 0.38888888888889
65072, 1.3304347826087, 1.1934782608696, 0.36111111111111
65073, 1.3086956521739, 1.1934782608696, 0.33333333333333
65074, 1.3304347826087, 1.2195652173913, 0.33333333333333
65075, 1.3304347826087, 1.1934782608696, 0.30555555555556
65076, 1.3086956521739, 1.1934782608696, 0.27777777777778
65077, 1.3304347826087, 1.2195652173913, 0.27777777777778
65078, 1.3304347826087, 1.1934782608696, 0.25
65079, 1.3086956521739, 1.1934782608696, 0.22222222222222
65080, 1.3304347826087, 1.2195652173913, 0.22222222222222
65081, 1.3304347826087, 1.1934782608696, 0.19444444444444
65082, 1.3086956521739, 1.1934782608696, 0.16666666666667
65083, 1.3304347826087, 1.2195652173913, 0.16666666666667
65084, 1.3304347826087, 1.1934782608696, 0.13888888888889
65085, 1.3086956521739, 1.1934782608696, 0.11111111111111
65086, 1.3304347826087, 1.2195652173913, 0.11111111111111
65087, 1.3304347826087, 1.1934782608696, 0.083333333333333
65088, 1.3086956521739, 1.1934782608696, 0.055555555555556
65089, 1.3304347826087, 1.2195652173913, 0.055555555555556
65090, 1.3304347826087, 1.1934782608696, 0.027777777777778
65091, 1.3739130434783, 1.1934782608696, 0.47222222222222
65092, 1.3521739130435, 1.1934782608696, 0.44444444444444
65093, 1.3739130434783, 1.2195652173913, 0.44444444444444
65094, 1.3739130434783, 1.1934782608696, 0.41666666666667
65095, 1.3521739130435, 1.1934782608696, 0.38888888888889
65096, 1.3739130434783, 1.2195652173913, 0.38888888888889
65097, 1.3739130434783, 1.1934782608696, 0.36111111111111
65098, 1.3521739130435, 1.1934782608696, 0.33333333333333
65099, 1.3739130434783, 1.2195652173913, 0.33333333333333
65100, 1.3739130434783, 1.1934782608696, 0.30555555555556
65101, 1.3521739130435, 1.1934782608696, 0.27777777777778
65102, 1.3739130434783, 1.2195652173913, 0.27777777777778
65103, 1.3739130434783, 1.1934782608696, 0.25
65104, 1.3521739130435, 1.1934782608696, 0.22222222222222
65105, 1.3739130434783, 1.2195652173913, 0.22222222222222
65106, 1.3739130434783, 1.1934782608696, 0.19444444444444
65107, 1.3521739130435, 1.1934782608696, 0.16666666666667
65108, 1.3739130434783, 1.2195652173913, 0.16666666666667
65109, 1.3739130434783, 1.1934782608696, 0.13888888888889
65110, 1.3521739130435, 1.1934782608696, 0.11111111111111
65111, 1.3739130434783, 1.2195652173913, 0.11111111111111
65112, 1.3739130434783, 1.1934782608696, 0.083333333333333
65113, 1.3521739130435, 1.1934782608696, 0.055555555555556
65114, 1.3739130434783, 1.2195652173913, 0.055555555555556
65115, 1.3739130434783, 1.1934782608696, 0.027777777777778
65116, 1.4173913043478, 1.1934782608696, 0.47222222222222
65117, 1.395652173913, 1.1934782608696, 0.44444444444444
65118, 1.4173913043478, 1.2195652173913, 0.44444444444444
65119, 1.4173913043478, 1.1934782608696, 0.41666666666667
65120, 1.395652173913, 1.1934782608696, 0.38888888888889
65121, 1.4173913043478, 1.2195652173913, 0.38888888888889
65122, 1.4173913043478, 1.1934782608696, 0.36111111111111
65123, 1.395652173913, 1.1934782608696, 0.33333333333333
65124, 1.4173913043478, 1.2195652173913, 0.33333333333333
65125, 1.4173913043478, 1.1934782608696, 0.30555555555556
65126, 1.395652173913, 1.1934782608696, 0.27777777777778
65127, 1.4173913043478, 1.2195652173913, 0.27777777777778
65128, 1.4173913043478, 1.1934782608696, 0.25
65129, 1.395652173913, 1.1934782608696, 0.22222222222222
65130, 1.4173913043478, 1.2195652173913, 0.22222222222222
65131, 1.4173913043478, 1.1934782608696, 0.19444444444444
65132, 1.395652173913, 1.1934782608696, 0.16666666666667
65133, 1.4173913043478, 1.2195652173913, 0.16666666666667
65134, 1.4173913043478, 1.1934782608696, 0.13888888888889
65135, 1.395652173913, 1.1934782608696, 0.11111111111111
65136, 1.4173913043478, 1.2195652173913, 0.11111111111111
65137, 1.4173913043478, 1.1934782608696, 0.083333333333333
65138, 1.395652173913, 1.1934782608696, 0.055555555555556
65139, 1.4173913043478, 1.2195652173913, 0.055555555555556
65140, 1.4173913043478, 1.1934782608696, 0.027777777777778
65141, 1.4608695652174, 1.1934782608696, 0.47222222222222
65142, 1.4391304347826, 1.1934782608696, 0.44444444444444
65143, 1.4608695652174, 1.2195652173913, 0.44444444444444
65144, 1.4608695652174, 1.1934782608696, 0.41666666666667
65145, 1.4391304347826, 1.1934782608696, 0.38888888888889
65146, 1.4608695652174, 1.2195652173913, 0.38888888888889
65147, 1.4608695652174, 1.1934782608696, 0.36111111111111
65148, 1.4391304347826, 1.1934782608696, 0.33333333333333
65149, 1.4608695652174, 1.2195652173913, 0.33333333333333
65150, 1.4608695652174, 1.1934782608696, 0.30555555555556
65151, 1.4391304347826, 1.1934782608696, 0.27777777777778
65152, 1.4608695652174, 1.2195652173913, 0.27777777777778
65153, 1.4608695652174, 1.1934782608696, 0.25
65154, 1.4391304347826, 1.1934782608696, 0.22222222222222
65155, 1.4608695652174, 1.2195652173913, 0.22222222222222
65156, 1.4608695652174, 1.1934782608696, 0.19444444444444
65157, 1.4391304347826, 1.1934782608696, 0.16666666666667
65158, 1.4608695652174, 1.2195652173913, 0.16666666666667
65159, 1.4608695652174, 1.1934782608696, 0.13888888888889
65160, 1.4391304347826, 1.1934782608696, 0.11111111111111
65161, 1.4608695652174, 1.2195652173913, 0.11111111111111
65162, 1.4608695652174, 1.1934782608696, 0.083333333333333
65163, 1.4391304347826, 1.1934782608696, 0.055555555555556
65164, 1.4608695652174, 1.2195652173913, 0.055555555555556
65165, 1.4608695652174, 1.1934782608696, 0.027777777777778
65166, 1.504347826087, 1.1934782608696, 0.47222222222222
65167, 1.4826086956522, 1.1934782608696, 0.44444444444444
65168, 1.504347826087, 1.2195652173913, 0.44444444444444
65169, 1.504347826087, 1.1934782608696, 0.41666666666667
65170, 1.4826086956522, 1.1934782608696, 0.38888888888889
65171, 1.504347826087, 1.2195652173913, 0.38888888888889
65172, 1.504347826087, 1.1934782608696, 0.36111111111111
65173, 1.4826086956522, 1.1934782608696, 0.33333333333333
65174, 1.504347826087, 1.2195652173913, 0.33333333333333
65175, 1.504347826087, 1.1934782608696, 0.30555555555556
65176, 1.4826086956522, 1.1934782608696, 0.27777777777778
65177, 1.504347826087, 1.2195652173913, 0.27777777777778
65178, 1.504347826087, 1.1934782608696, 0.25
65179, 1.4826086956522, 1.1934782608696, 0.22222222222222
65180, 1.504347826087, 1.2195652173913, 0.22222222222222
65181, 1.504347826087, 1.1934782608696, 0.19444444444444
65182, 1.4826086956522, 1.1934782608696, 0.16666666666667
65183, 1.504347826087, 1.2195652173913, 0.16666666666667
65184, 1.504347826087, 1.1934782608696, 0.13888888888889
65185, 1.4826086956522, 1.1934782608696, 0.11111111111111
65186, 1.504347826087, 1.2195652173913, 0.11111111111111
65187, 1.504347826087, 1.1934782608696, 0.083333333333333
65188, 1.4826086956522, 1.1934782608696, 0.055555555555556
65189, 1.504347826087, 1.2195652173913, 0.055555555555556
65190, 1.504347826087, 1.1934782608696, 0.027777777777778
65191, 1.5478260869565, 1.1934782608696, 0.47222222222222
65192, 1.5260869565217, 1.1934782608696, 0.44444444444444
65193, 1.5478260869565, 1.2195652173913, 0.44444444444444
65194, 1.5478260869565, 1.1934782608696, 0.41666666666667
65195, 1.5260869565217, 1.1934782608696, 0.38888888888889
65196, 1.5478260869565, 1.2195652173913, 0.38888888888889
65197, 1.5478260869565, 1.1934782608696, 0.36111111111111
65198, 1.5260869565217, 1.1934782608696, 0.33333333333333
65199, 1.5478260869565, 1.2195652173913, 0.33333333333333
65200, 1.5478260869565, 1.1934782608696, 0.30555555555556
65201, 1.5260869565217, 1.1934782608696, 0.27777777777778
65202, 1.5478260869565, 1.2195652173913, 0.27777777777778
65203, 1.5478260869565, 1.1934782608696, 0.25
65204, 1.5260869565217, 1.1934782608696, 0.22222222222222
65205, 1.5478260869565, 1.2195652173913, 0.22222222222222
65206, 1.5478260869565, 1.1934782608696, 0.19444444444444
65207, 1.5260869565217, 1.1934782608696, 0.16666666666667
65208, 1.5478260869565, 1.2195652173913, 0.16666666666667
65209, 1.5478260869565, 1.1934782608696, 0.13888888888889
65210, 1.5260869565217, 1.1934782608696, 0.11111111111111
65211, 1.5478260869565, 1.2195652173913, 0.11111111111111
65212, 1.5478260869565, 1.1934782608696, 0.083333333333333
65213, 1.5260869565217, 1.1934782608696, 0.055555555555556
65214, 1.5478260869565, 1.2195652173913, 0.055555555555556
65215, 1.5478260869565, 1.1934782608696, 0.027777777777778
65216, 1.5913043478261, 1.1934782608696, 0.47222222222222
65217, 1.5695652173913, 1.1934782608696, 0.44444444444444
65218, 1.5913043478261, 1.2195652173913, 0.44444444444444
65219, 1.5913043478261, 1.1934782608696, 0.41666666666667
65220, 1.5695652173913, 1.1934782608696, 0.38888888888889
65221, 1.5913043478261, 1.2195652173913, 0.38888888888889
65222, 1.5913043478261, 1.1934782608696, 0.36111111111111
65223, 1.5695652173913, 1.1934782608696, 0.33333333333333
65224, 1.5913043478261, 1.2195652173913, 0.33333333333333
65225, 1.5913043478261, 1.1934782608696, 0.30555555555556
65226, 1.5695652173913, 1.1934782608696, 0.27777777777778
65227, 1.5913043478261, 1.2195652173913, 0.27777777777778
65228, 1.5913043478261, 1.1934782608696, 0.25
65229, 1.5695652173913, 1.1934782608696, 0.22222222222222
65230, 1.5913043478261, 1.2195652173913, 0.22222222222222
65231, 1.5913043478261, 1.1934782608696, 0.19444444444444
65232, 1.5695652173913, 1.1934782608696, 0.16666666666667
65233, 1.5913043478261, 1.2195652173913, 0.16666666666667
65234, 1.5913043478261, 1.1934782608696, 0.13888888888889
65235, 1.5695652173913, 1.1934782608696, 0.11111111111111
65236, 1.5913043478261, 1.2195652173913, 0.11111111111111
65237, 1.5913043478261, 1.1934782608696, 0.083333333333333
65238, 1.5695652173913, 1.1934782608696, 0.055555555555556
65239, 1.5913043478261, 1.2195652173913, 0.055555555555556
65240, 1.5913043478261, 1.1934782608696, 0.027777777777778
65241, 1.6347826086957, 1.1934782608696, 0.47222222222222
65242, 1.6130434782609, 1.1934782608696, 0.44444444444444
65243, 1.6347826086957, 1.2195652173913, 0.44444444444444
65244, 1.6347826086957, 1.1934782608696, 0.41666666666667
65245, 1.6130434782609, 1.1934782608696, 0.38888888888889
65246, 1.6347826086957, 1.2195652173913, 0.38888888888889
65247, 1.6347826086957, 1.1934782608696, 0.36111111111111
65248, 1.6130434782609, 1.1934782608696, 0.33333333333333
65249, 1.6347826086957, 1.2195652173913, 0.33333333333333
65250, 1.6347826086957, 1.1934782608696, 0.30555555555556
65251, 1.6130434782609, 1.1934782608696, 0.27777777777778
65252, 1.6347826086957, 1.2195652173913, 0.27777777777778
65253, 1.6347826086957, 1.1934782608696, 0.25
65254, 1.6130434782609, 1.1934782608696, 0.22222222222222
65255, 1.6347826086957, 1.2195652173913, 0.22222222222222
65256, 1.6347826086957, 1.1934782608696, 0.19444444444444
65257, 1.6130434782609, 1.1934782608696, 0.16666666666667
65258, 1.6347826086957, 1.2195652173913, 0.16666666666667
65259, 1.6347826086957, 1.1934782608696, 0.13888888888889
65260, 1.6130434782609, 1.1934782608696, 0.11111111111111
65261, 1.6347826086957, 1.2195652173913, 0.11111111111111
65262, 1.6347826086957, 1.1934782608696, 0.083333333333333
65263, 1.6130434782609, 1.1934782608696, 0.055555555555556
65264, 1.6347826086957, 1.2195652173913, 0.055555555555556
65265, 1.6347826086957, 1.1934782608696, 0.027777777777778
65266, 1.6782608695652, 1.1934782608696, 0.47222222222222
65267, 1.6565217391304, 1.1934782608696, 0.44444444444444
65268, 1.6782608695652, 1.2195652173913, 0.44444444444444
65269, 1.6782608695652, 1.1934782608696, 0.41666666666667
65270, 1.6565217391304, 1.1934782608696, 0.38888888888889
65271, 1.6782608695652, 1.2195652173913, 0.38888888888889
65272, 1.6782608695652, 1.1934782608696, 0.36111111111111
65273, 1.6565217391304, 1.1934782608696, 0.33333333333333
65274, 1.6782608695652, 1.2195652173913, 0.33333333333333
65275, 1.6782608695652, 1.1934782608696, 0.30555555555556
65276, 1.6565217391304, 1.1934782608696, 0.27777777777778
65277, 1.6782608695652, 1.2195652173913, 0.27777777777778
65278, 1.6782608695652, 1.1934782608696, 0.25
65279, 1.6565217391304, 1.1934782608696, 0.22222222222222
65280, 1.6782608695652, 1.2195652173913, 0.22222222222222
65281, 1.6782608695652, 1.1934782608696, 0.19444444444444
65282, 1.6565217391304, 1.1934782608696, 0.16666666666667
65283, 1.6782608695652, 1.2195652173913, 0.16666666666667
65284, 1.6782608695652, 1.1934782608696, 0.13888888888889
65285, 1.6565217391304, 1.1934782608696, 0.11111111111111
65286, 1.6782608695652, 1.2195652173913, 0.11111111111111
65287, 1.6782608695652, 1.1934782608696, 0.083333333333333
65288, 1.6565217391304, 1.1934782608696, 0.055555555555556
65289, 1.6782608695652, 1.2195652173913, 0.055555555555556
65290, 1.6782608695652, 1.1934782608696, 0.027777777777778
65291, 1.7217391304348, 1.1934782608696, 0.47222222222222
65292, 1.7, 1.1934782608696, 0.44444444444444
65293, 1.7217391304348, 1.2195652173913, 0.44444444444444
65294, 1.7217391304348, 1.1934782608696, 0.41666666666667
65295, 1.7, 1.1934782608696, 0.38888888888889
65296, 1.7217391304348, 1.2195652173913, 0.38888888888889
65297, 1.7217391304348, 1.1934782608696, 0.36111111111111
65298, 1.7, 1.1934782608696, 0.33333333333333
65299, 1.7217391304348, 1.2195652173913, 0.33333333333333
65300, 1.7217391304348, 1.1934782608696, 0.30555555555556
65301, 1.7, 1.1934782608696, 0.27777777777778
65302, 1.7217391304348, 1.2195652173913, 0.27777777777778
65303, 1.7217391304348, 1.1934782608696, 0.25
65304, 1.7, 1.1934782608696, 0.22222222222222
65305, 1.7217391304348, 1.2195652173913, 0.22222222222222
65306, 1.7217391304348, 1.1934782608696, 0.19444444444444
65307, 1.7, 1.1934782608696, 0.16666666666667
65308, 1.7217391304348, 1.2195652173913, 0.16666666666667
65309, 1.7217391304348, 1.1934782608696, 0.13888888888889
65310, 1.7, 1.1934782608696, 0.11111111111111
65311, 1.7217391304348, 1.2195652173913, 0.11111111111111
65312, 1.7217391304348, 1.1934782608696, 0.083333333333333
65313, 1.7, 1.1934782608696, 0.055555555555556
65314, 1.7217391304348, 1.2195652173913, 0.055555555555556
65315, 1.7217391304348, 1.1934782608696, 0.027777777777778
65316, 1.7652173913043, 1.1934782608696, 0.47222222222222
65317, 1.7434782608696, 1.1934782608696, 0.44444444444444
65318, 1.7652173913043, 1.2195652173913, 0.44444444444444
65319, 1.7652173913043, 1.1934782608696, 0.41666666666667
65320, 1.7434782608696, 1.1934782608696, 0.38888888888889
65321, 1.7652173913043, 1.2195652173913, 0.38888888888889
65322, 1.7652173913043, 1.1934782608696, 0.36111111111111
65323, 1.7434782608696, 1.1934782608696, 0.33333333333333
65324, 1.7652173913043, 1.2195652173913, 0.33333333333333
65325, 1.7652173913043, 1.1934782608696, 0.30555555555556
65326, 1.7434782608696, 1.1934782608696, 0.27777777777778
65327, 1.7652173913043, 1.2195652173913, 0.27777777777778
65328, 1.7652173913043, 1.1934782608696, 0.25
65329, 1.7434782608696, 1.1934782608696, 0.22222222222222
65330, 1.7652173913043, 1.2195652173913, 0.22222222222222
65331, 1.7652173913043, 1.1934782608696, 0.19444444444444
65332, 1.7434782608696, 1.1934782608696, 0.16666666666667
65333, 1.7652173913043, 1.2195652173913, 0.16666666666667
65334, 1.7652173913043, 1.1934782608696, 0.13888888888889
65335, 1.7434782608696, 1.1934782608696, 0.11111111111111
65336, 1.7652173913043, 1.2195652173913, 0.11111111111111
65337, 1.7652173913043, 1.1934782608696, 0.083333333333333
