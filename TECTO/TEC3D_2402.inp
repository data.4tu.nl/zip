13480, 3639, 32184, 32206, 3640, 32945, 32989, 32990, 3662
13481, 32184, 32185, 32207, 32206, 32947, 32991, 32992, 32989
13482, 32185, 32186, 32208, 32207, 32949, 32993, 32994, 32991
13483, 32186, 32187, 32209, 32208, 32951, 32995, 32996, 32993
13484, 32187, 32188, 32210, 32209, 32953, 32997, 32998, 32995
13485, 32188, 32189, 32211, 32210, 32955, 32999, 33000, 32997
13486, 32189, 32190, 32212, 32211, 32957, 33001, 33002, 32999
13487, 32190, 32191, 32213, 32212, 32959, 33003, 33004, 33001
13488, 32191, 32192, 32214, 32213, 32961, 33005, 33006, 33003
13489, 32192, 32193, 32215, 32214, 32963, 33007, 33008, 33005
13490, 32193, 32194, 32216, 32215, 32965, 33009, 33010, 33007
13491, 32194, 32195, 32217, 32216, 32967, 33011, 33012, 33009
13492, 32195, 32196, 32218, 32217, 32969, 33013, 33014, 33011
13493, 32196, 32197, 32219, 32218, 32971, 33015, 33016, 33013
13494, 32197, 32198, 32220, 32219, 32973, 33017, 33018, 33015
13495, 32198, 32199, 32221, 32220, 32975, 33019, 33020, 33017
13496, 32199, 32200, 32222, 32221, 32977, 33021, 33022, 33019
13497, 32200, 32201, 32223, 32222, 32979, 33023, 33024, 33021
13498, 32201, 32202, 32224, 32223, 32981, 33025, 33026, 33023
13499, 32202, 32203, 32225, 32224, 32983, 33027, 33028, 33025
13500, 32203, 32204, 32226, 32225, 32985, 33029, 33030, 33027
13501, 32204, 32205, 32227, 32226, 32987, 33031, 33032, 33029
13502, 32205, 3698, 3699, 32227, 32988, 3721, 33033, 33031
13503, 3640, 32206, 32228, 3641, 32990, 33034, 33035, 3663
13504, 32206, 32207, 32229, 32228, 32992, 33036, 33037, 33034
13505, 32207, 32208, 32230, 32229, 32994, 33038, 33039, 33036
13506, 32208, 32209, 32231, 32230, 32996, 33040, 33041, 33038
13507, 32209, 32210, 32232, 32231, 32998, 33042, 33043, 33040
13508, 32210, 32211, 32233, 32232, 33000, 33044, 33045, 33042
13509, 32211, 32212, 32234, 32233, 33002, 33046, 33047, 33044
13510, 32212, 32213, 32235, 32234, 33004, 33048, 33049, 33046
13511, 32213, 32214, 32236, 32235, 33006, 33050, 33051, 33048
13512, 32214, 32215, 32237, 32236, 33008, 33052, 33053, 33050
13513, 32215, 32216, 32238, 32237, 33010, 33054, 33055, 33052
13514, 32216, 32217, 32239, 32238, 33012, 33056, 33057, 33054
13515, 32217, 32218, 32240, 32239, 33014, 33058, 33059, 33056
13516, 32218, 32219, 32241, 32240, 33016, 33060, 33061, 33058
13517, 32219, 32220, 32242, 32241, 33018, 33062, 33063, 33060
13518, 32220, 32221, 32243, 32242, 33020, 33064, 33065, 33062
13519, 32221, 32222, 32244, 32243, 33022, 33066, 33067, 33064
13520, 32222, 32223, 32245, 32244, 33024, 33068, 33069, 33066
13521, 32223, 32224, 32246, 32245, 33026, 33070, 33071, 33068
13522, 32224, 32225, 32247, 32246, 33028, 33072, 33073, 33070
13523, 32225, 32226, 32248, 32247, 33030, 33074, 33075, 33072
13524, 32226, 32227, 32249, 32248, 33032, 33076, 33077, 33074
13525, 32227, 3699, 3700, 32249, 33033, 3722, 33078, 33076
13526, 3641, 32228, 32250, 3642, 33035, 33079, 33080, 3664
13527, 32228, 32229, 32251, 32250, 33037, 33081, 33082, 33079
13528, 32229, 32230, 32252, 32251, 33039, 33083, 33084, 33081
13529, 32230, 32231, 32253, 32252, 33041, 33085, 33086, 33083
13530, 32231, 32232, 32254, 32253, 33043, 33087, 33088, 33085
13531, 32232, 32233, 32255, 32254, 33045, 33089, 33090, 33087
13532, 32233, 32234, 32256, 32255, 33047, 33091, 33092, 33089
13533, 32234, 32235, 32257, 32256, 33049, 33093, 33094, 33091
13534, 32235, 32236, 32258, 32257, 33051, 33095, 33096, 33093
13535, 32236, 32237, 32259, 32258, 33053, 33097, 33098, 33095
13536, 32237, 32238, 32260, 32259, 33055, 33099, 33100, 33097
13537, 32238, 32239, 32261, 32260, 33057, 33101, 33102, 33099
13538, 32239, 32240, 32262, 32261, 33059, 33103, 33104, 33101
13539, 32240, 32241, 32263, 32262, 33061, 33105, 33106, 33103
13540, 32241, 32242, 32264, 32263, 33063, 33107, 33108, 33105
13541, 32242, 32243, 32265, 32264, 33065, 33109, 33110, 33107
13542, 32243, 32244, 32266, 32265, 33067, 33111, 33112, 33109
13543, 32244, 32245, 32267, 32266, 33069, 33113, 33114, 33111
13544, 32245, 32246, 32268, 32267, 33071, 33115, 33116, 33113
13545, 32246, 32247, 32269, 32268, 33073, 33117, 33118, 33115
13546, 32247, 32248, 32270, 32269, 33075, 33119, 33120, 33117
13547, 32248, 32249, 32271, 32270, 33077, 33121, 33122, 33119
13548, 32249, 3700, 3701, 32271, 33078, 3723, 33123, 33121
13549, 3642, 32250, 32272, 3643, 33080, 33124, 33125, 3665
13550, 32250, 32251, 32273, 32272, 33082, 33126, 33127, 33124
13551, 32251, 32252, 32274, 32273, 33084, 33128, 33129, 33126
13552, 32252, 32253, 32275, 32274, 33086, 33130, 33131, 33128
13553, 32253, 32254, 32276, 32275, 33088, 33132, 33133, 33130
13554, 32254, 32255, 32277, 32276, 33090, 33134, 33135, 33132
13555, 32255, 32256, 32278, 32277, 33092, 33136, 33137, 33134
13556, 32256, 32257, 32279, 32278, 33094, 33138, 33139, 33136
13557, 32257, 32258, 32280, 32279, 33096, 33140, 33141, 33138
13558, 32258, 32259, 32281, 32280, 33098, 33142, 33143, 33140
13559, 32259, 32260, 32282, 32281, 33100, 33144, 33145, 33142
13560, 32260, 32261, 32283, 32282, 33102, 33146, 33147, 33144
13561, 32261, 32262, 32284, 32283, 33104, 33148, 33149, 33146
13562, 32262, 32263, 32285, 32284, 33106, 33150, 33151, 33148
13563, 32263, 32264, 32286, 32285, 33108, 33152, 33153, 33150
13564, 32264, 32265, 32287, 32286, 33110, 33154, 33155, 33152
13565, 32265, 32266, 32288, 32287, 33112, 33156, 33157, 33154
13566, 32266, 32267, 32289, 32288, 33114, 33158, 33159, 33156
13567, 32267, 32268, 32290, 32289, 33116, 33160, 33161, 33158
13568, 32268, 32269, 32291, 32290, 33118, 33162, 33163, 33160
13569, 32269, 32270, 32292, 32291, 33120, 33164, 33165, 33162
13570, 32270, 32271, 32293, 32292, 33122, 33166, 33167, 33164
13571, 32271, 3701, 3702, 32293, 33123, 3724, 33168, 33166
13572, 3643, 32272, 32294, 3644, 33125, 33169, 33170, 3666
13573, 32272, 32273, 32295, 32294, 33127, 33171, 33172, 33169
13574, 32273, 32274, 32296, 32295, 33129, 33173, 33174, 33171
13575, 32274, 32275, 32297, 32296, 33131, 33175, 33176, 33173
13576, 32275, 32276, 32298, 32297, 33133, 33177, 33178, 33175
13577, 32276, 32277, 32299, 32298, 33135, 33179, 33180, 33177
13578, 32277, 32278, 32300, 32299, 33137, 33181, 33182, 33179
13579, 32278, 32279, 32301, 32300, 33139, 33183, 33184, 33181
13580, 32279, 32280, 32302, 32301, 33141, 33185, 33186, 33183
13581, 32280, 32281, 32303, 32302, 33143, 33187, 33188, 33185
13582, 32281, 32282, 32304, 32303, 33145, 33189, 33190, 33187
13583, 32282, 32283, 32305, 32304, 33147, 33191, 33192, 33189
13584, 32283, 32284, 32306, 32305, 33149, 33193, 33194, 33191
13585, 32284, 32285, 32307, 32306, 33151, 33195, 33196, 33193
13586, 32285, 32286, 32308, 32307, 33153, 33197, 33198, 33195
13587, 32286, 32287, 32309, 32308, 33155, 33199, 33200, 33197
13588, 32287, 32288, 32310, 32309, 33157, 33201, 33202, 33199
13589, 32288, 32289, 32311, 32310, 33159, 33203, 33204, 33201
13590, 32289, 32290, 32312, 32311, 33161, 33205, 33206, 33203
13591, 32290, 32291, 32313, 32312, 33163, 33207, 33208, 33205
13592, 32291, 32292, 32314, 32313, 33165, 33209, 33210, 33207
13593, 32292, 32293, 32315, 32314, 33167, 33211, 33212, 33209
13594, 32293, 3702, 3703, 32315, 33168, 3725, 33213, 33211
13595, 3644, 32294, 32316, 3645, 33170, 33214, 33215, 3667
13596, 32294, 32295, 32317, 32316, 33172, 33216, 33217, 33214
13597, 32295, 32296, 32318, 32317, 33174, 33218, 33219, 33216
13598, 32296, 32297, 32319, 32318, 33176, 33220, 33221, 33218
13599, 32297, 32298, 32320, 32319, 33178, 33222, 33223, 33220
13600, 32298, 32299, 32321, 32320, 33180, 33224, 33225, 33222
13601, 32299, 32300, 32322, 32321, 33182, 33226, 33227, 33224
13602, 32300, 32301, 32323, 32322, 33184, 33228, 33229, 33226
13603, 32301, 32302, 32324, 32323, 33186, 33230, 33231, 33228
13604, 32302, 32303, 32325, 32324, 33188, 33232, 33233, 33230
13605, 32303, 32304, 32326, 32325, 33190, 33234, 33235, 33232
13606, 32304, 32305, 32327, 32326, 33192, 33236, 33237, 33234
13607, 32305, 32306, 32328, 32327, 33194, 33238, 33239, 33236
13608, 32306, 32307, 32329, 32328, 33196, 33240, 33241, 33238
13609, 32307, 32308, 32330, 32329, 33198, 33242, 33243, 33240
13610, 32308, 32309, 32331, 32330, 33200, 33244, 33245, 33242
13611, 32309, 32310, 32332, 32331, 33202, 33246, 33247, 33244
13612, 32310, 32311, 32333, 32332, 33204, 33248, 33249, 33246
13613, 32311, 32312, 32334, 32333, 33206, 33250, 33251, 33248
13614, 32312, 32313, 32335, 32334, 33208, 33252, 33253, 33250
13615, 32313, 32314, 32336, 32335, 33210, 33254, 33255, 33252
13616, 32314, 32315, 32337, 32336, 33212, 33256, 33257, 33254
13617, 32315, 3703, 3704, 32337, 33213, 3726, 33258, 33256
13618, 3645, 32316, 32338, 3646, 33215, 33259, 33260, 3668
13619, 32316, 32317, 32339, 32338, 33217, 33261, 33262, 33259
13620, 32317, 32318, 32340, 32339, 33219, 33263, 33264, 33261
13621, 32318, 32319, 32341, 32340, 33221, 33265, 33266, 33263
13622, 32319, 32320, 32342, 32341, 33223, 33267, 33268, 33265
13623, 32320, 32321, 32343, 32342, 33225, 33269, 33270, 33267
13624, 32321, 32322, 32344, 32343, 33227, 33271, 33272, 33269
13625, 32322, 32323, 32345, 32344, 33229, 33273, 33274, 33271
13626, 32323, 32324, 32346, 32345, 33231, 33275, 33276, 33273
13627, 32324, 32325, 32347, 32346, 33233, 33277, 33278, 33275
13628, 32325, 32326, 32348, 32347, 33235, 33279, 33280, 33277
13629, 32326, 32327, 32349, 32348, 33237, 33281, 33282, 33279
13630, 32327, 32328, 32350, 32349, 33239, 33283, 33284, 33281
13631, 32328, 32329, 32351, 32350, 33241, 33285, 33286, 33283
13632, 32329, 32330, 32352, 32351, 33243, 33287, 33288, 33285
13633, 32330, 32331, 32353, 32352, 33245, 33289, 33290, 33287
13634, 32331, 32332, 32354, 32353, 33247, 33291, 33292, 33289
13635, 32332, 32333, 32355, 32354, 33249, 33293, 33294, 33291
13636, 32333, 32334, 32356, 32355, 33251, 33295, 33296, 33293
13637, 32334, 32335, 32357, 32356, 33253, 33297, 33298, 33295
13638, 32335, 32336, 32358, 32357, 33255, 33299, 33300, 33297
13639, 32336, 32337, 32359, 32358, 33257, 33301, 33302, 33299
13640, 32337, 3704, 3705, 32359, 33258, 3727, 33303, 33301
13641, 3646, 32338, 32360, 3647, 33260, 33304, 33305, 3669
13642, 32338, 32339, 32361, 32360, 33262, 33306, 33307, 33304
13643, 32339, 32340, 32362, 32361, 33264, 33308, 33309, 33306
13644, 32340, 32341, 32363, 32362, 33266, 33310, 33311, 33308
13645, 32341, 32342, 32364, 32363, 33268, 33312, 33313, 33310
13646, 32342, 32343, 32365, 32364, 33270, 33314, 33315, 33312
13647, 32343, 32344, 32366, 32365, 33272, 33316, 33317, 33314
13648, 32344, 32345, 32367, 32366, 33274, 33318, 33319, 33316
13649, 32345, 32346, 32368, 32367, 33276, 33320, 33321, 33318
13650, 32346, 32347, 32369, 32368, 33278, 33322, 33323, 33320
13651, 32347, 32348, 32370, 32369, 33280, 33324, 33325, 33322
13652, 32348, 32349, 32371, 32370, 33282, 33326, 33327, 33324
13653, 32349, 32350, 32372, 32371, 33284, 33328, 33329, 33326
13654, 32350, 32351, 32373, 32372, 33286, 33330, 33331, 33328
13655, 32351, 32352, 32374, 32373, 33288, 33332, 33333, 33330
13656, 32352, 32353, 32375, 32374, 33290, 33334, 33335, 33332
13657, 32353, 32354, 32376, 32375, 33292, 33336, 33337, 33334
13658, 32354, 32355, 32377, 32376, 33294, 33338, 33339, 33336
13659, 32355, 32356, 32378, 32377, 33296, 33340, 33341, 33338
13660, 32356, 32357, 32379, 32378, 33298, 33342, 33343, 33340
13661, 32357, 32358, 32380, 32379, 33300, 33344, 33345, 33342
13662, 32358, 32359, 32381, 32380, 33302, 33346, 33347, 33344
13663, 32359, 3705, 3706, 32381, 33303, 3728, 33348, 33346
13664, 3647, 32360, 32382, 3648, 33305, 33349, 33350, 3670
13665, 32360, 32361, 32383, 32382, 33307, 33351, 33352, 33349
13666, 32361, 32362, 32384, 32383, 33309, 33353, 33354, 33351
13667, 32362, 32363, 32385, 32384, 33311, 33355, 33356, 33353
13668, 32363, 32364, 32386, 32385, 33313, 33357, 33358, 33355
13669, 32364, 32365, 32387, 32386, 33315, 33359, 33360, 33357
13670, 32365, 32366, 32388, 32387, 33317, 33361, 33362, 33359
13671, 32366, 32367, 32389, 32388, 33319, 33363, 33364, 33361
13672, 32367, 32368, 32390, 32389, 33321, 33365, 33366, 33363
13673, 32368, 32369, 32391, 32390, 33323, 33367, 33368, 33365
13674, 32369, 32370, 32392, 32391, 33325, 33369, 33370, 33367
13675, 32370, 32371, 32393, 32392, 33327, 33371, 33372, 33369
13676, 32371, 32372, 32394, 32393, 33329, 33373, 33374, 33371
13677, 32372, 32373, 32395, 32394, 33331, 33375, 33376, 33373
13678, 32373, 32374, 32396, 32395, 33333, 33377, 33378, 33375
13679, 32374, 32375, 32397, 32396, 33335, 33379, 33380, 33377
13680, 32375, 32376, 32398, 32397, 33337, 33381, 33382, 33379
13681, 32376, 32377, 32399, 32398, 33339, 33383, 33384, 33381
13682, 32377, 32378, 32400, 32399, 33341, 33385, 33386, 33383
13683, 32378, 32379, 32401, 32400, 33343, 33387, 33388, 33385
13684, 32379, 32380, 32402, 32401, 33345, 33389, 33390, 33387
13685, 32380, 32381, 32403, 32402, 33347, 33391, 33392, 33389
13686, 32381, 3706, 3707, 32403, 33348, 3729, 33393, 33391
13687, 3648, 32382, 3797, 102, 33350, 33394, 3820, 3671
13688, 32382, 32383, 3796, 3797, 33352, 33395, 3819, 33394
13689, 32383, 32384, 3795, 3796, 33354, 33396, 3818, 33395
13690, 32384, 32385, 3794, 3795, 33356, 33397, 3817, 33396
13691, 32385, 32386, 3793, 3794, 33358, 33398, 3816, 33397
13692, 32386, 32387, 3792, 3793, 33360, 33399, 3815, 33398
13693, 32387, 32388, 3791, 3792, 33362, 33400, 3814, 33399
13694, 32388, 32389, 3790, 3791, 33364, 33401, 3813, 33400
13695, 32389, 32390, 3789, 3790, 33366, 33402, 3812, 33401
13696, 32390, 32391, 3788, 3789, 33368, 33403, 3811, 33402
13697, 32391, 32392, 3787, 3788, 33370, 33404, 3810, 33403
13698, 32392, 32393, 3786, 3787, 33372, 33405, 3809, 33404
13699, 32393, 32394, 3785, 3786, 33374, 33406, 3808, 33405
13700, 32394, 32395, 3784, 3785, 33376, 33407, 3807, 33406
13701, 32395, 32396, 3783, 3784, 33378, 33408, 3806, 33407
13702, 32396, 32397, 3782, 3783, 33380, 33409, 3805, 33408
13703, 32397, 32398, 3781, 3782, 33382, 33410, 3804, 33409
13704, 32398, 32399, 3780, 3781, 33384, 33411, 3803, 33410
13705, 32399, 32400, 3779, 3780, 33386, 33412, 3802, 33411
13706, 32400, 32401, 3778, 3779, 33388, 33413, 3801, 33412
13707, 32401, 32402, 3777, 3778, 33390, 33414, 3800, 33413
13708, 32402, 32403, 3776, 3777, 33392, 33415, 3799, 33414
13709, 32403, 3707, 104, 3776, 33393, 3730, 3798, 33415
*ELEMENT, type=CPS8, ELSET=Surface312
13710, 95, 3260, 33416, 3821, 3282, 33482, 33483, 3824
13711, 3260, 3261, 33417, 33416, 3283, 33484, 33485, 33482
13712, 3261, 3262, 33418, 33417, 3284, 33486, 33487, 33484
13713, 3262, 3263, 33419, 33418, 3285, 33488, 33489, 33486
13714, 3263, 3264, 33420, 33419, 3286, 33490, 33491, 33488
13715, 3264, 3265, 33421, 33420, 3287, 33492, 33493, 33490
13716, 3265, 3266, 33422, 33421, 3288, 33494, 33495, 33492
13717, 3266, 3267, 33423, 33422, 3289, 33496, 33497, 33494
13718, 3267, 3268, 33424, 33423, 3290, 33498, 33499, 33496
13719, 3268, 3269, 33425, 33424, 3291, 33500, 33501, 33498
13720, 3269, 3270, 33426, 33425, 3292, 33502, 33503, 33500
13721, 3270, 3271, 33427, 33426, 3293, 33504, 33505, 33502
13722, 3271, 3272, 33428, 33427, 3294, 33506, 33507, 33504
13723, 3272, 3273, 33429, 33428, 3295, 33508, 33509, 33506
13724, 3273, 3274, 33430, 33429, 3296, 33510, 33511, 33508
13725, 3274, 3275, 33431, 33430, 3297, 33512, 33513, 33510
13726, 3275, 3276, 33432, 33431, 3298, 33514, 33515, 33512
13727, 3276, 3277, 33433, 33432, 3299, 33516, 33517, 33514
13728, 3277, 3278, 33434, 33433, 3300, 33518, 33519, 33516
13729, 3278, 3279, 33435, 33434, 3301, 33520, 33521, 33518
13730, 3279, 3280, 33436, 33435, 3302, 33522, 33523, 33520
13731, 3280, 3281, 33437, 33436, 3303, 33524, 33525, 33522
13732, 3281, 7, 3828, 33437, 3304, 3831, 33526, 33524
13733, 3821, 33416, 33438, 3822, 33483, 33527, 33528, 3825
13734, 33416, 33417, 33439, 33438, 33485, 33529, 33530, 33527
13735, 33417, 33418, 33440, 33439, 33487, 33531, 33532, 33529
13736, 33418, 33419, 33441, 33440, 33489, 33533, 33534, 33531
13737, 33419, 33420, 33442, 33441, 33491, 33535, 33536, 33533
13738, 33420, 33421, 33443, 33442, 33493, 33537, 33538, 33535
13739, 33421, 33422, 33444, 33443, 33495, 33539, 33540, 33537
13740, 33422, 33423, 33445, 33444, 33497, 33541, 33542, 33539
13741, 33423, 33424, 33446, 33445, 33499, 33543, 33544, 33541
13742, 33424, 33425, 33447, 33446, 33501, 33545, 33546, 33543
13743, 33425, 33426, 33448, 33447, 33503, 33547, 33548, 33545
13744, 33426, 33427, 33449, 33448, 33505, 33549, 33550, 33547
13745, 33427, 33428, 33450, 33449, 33507, 33551, 33552, 33549
13746, 33428, 33429, 33451, 33450, 33509, 33553, 33554, 33551
13747, 33429, 33430, 33452, 33451, 33511, 33555, 33556, 33553
13748, 33430, 33431, 33453, 33452, 33513, 33557, 33558, 33555
13749, 33431, 33432, 33454, 33453, 33515, 33559, 33560, 33557
13750, 33432, 33433, 33455, 33454, 33517, 33561, 33562, 33559
13751, 33433, 33434, 33456, 33455, 33519, 33563, 33564, 33561
13752, 33434, 33435, 33457, 33456, 33521, 33565, 33566, 33563
13753, 33435, 33436, 33458, 33457, 33523, 33567, 33568, 33565
13754, 33436, 33437, 33459, 33458, 33525, 33569, 33570, 33567
13755, 33437, 3828, 3829, 33459, 33526, 3832, 33571, 33569
13756, 3822, 33438, 33460, 3823, 33528, 33572, 33573, 3826
13757, 33438, 33439, 33461, 33460, 33530, 33574, 33575, 33572
13758, 33439, 33440, 33462, 33461, 33532, 33576, 33577, 33574
13759, 33440, 33441, 33463, 33462, 33534, 33578, 33579, 33576
13760, 33441, 33442, 33464, 33463, 33536, 33580, 33581, 33578
13761, 33442, 33443, 33465, 33464, 33538, 33582, 33583, 33580
13762, 33443, 33444, 33466, 33465, 33540, 33584, 33585, 33582
13763, 33444, 33445, 33467, 33466, 33542, 33586, 33587, 33584
13764, 33445, 33446, 33468, 33467, 33544, 33588, 33589, 33586
13765, 33446, 33447, 33469, 33468, 33546, 33590, 33591, 33588
13766, 33447, 33448, 33470, 33469, 33548, 33592, 33593, 33590
13767, 33448, 33449, 33471, 33470, 33550, 33594, 33595, 33592
13768, 33449, 33450, 33472, 33471, 33552, 33596, 33597, 33594
13769, 33450, 33451, 33473, 33472, 33554, 33598, 33599, 33596
13770, 33451, 33452, 33474, 33473, 33556, 33600, 33601, 33598
13771, 33452, 33453, 33475, 33474, 33558, 33602, 33603, 33600
13772, 33453, 33454, 33476, 33475, 33560, 33604, 33605, 33602
13773, 33454, 33455, 33477, 33476, 33562, 33606, 33607, 33604
13774, 33455, 33456, 33478, 33477, 33564, 33608, 33609, 33606
13775, 33456, 33457, 33479, 33478, 33566, 33610, 33611, 33608
13776, 33457, 33458, 33480, 33479, 33568, 33612, 33613, 33610
13777, 33458, 33459, 33481, 33480, 33570, 33614, 33615, 33612
13778, 33459, 3829, 3830, 33481, 33571, 3833, 33616, 33614
13779, 3823, 33460, 3835, 105, 33573, 33617, 3857, 3827
13780, 33460, 33461, 3836, 3835, 33575, 33618, 3858, 33617
13781, 33461, 33462, 3837, 3836, 33577, 33619, 3859, 33618
13782, 33462, 33463, 3838, 3837, 33579, 33620, 3860, 33619
13783, 33463, 33464, 3839, 3838, 33581, 33621, 3861, 33620
13784, 33464, 33465, 3840, 3839, 33583, 33622, 3862, 33621
13785, 33465, 33466, 3841, 3840, 33585, 33623, 3863, 33622
13786, 33466, 33467, 3842, 3841, 33587, 33624, 3864, 33623
13787, 33467, 33468, 3843, 3842, 33589, 33625, 3865, 33624
13788, 33468, 33469, 3844, 3843, 33591, 33626, 3866, 33625
13789, 33469, 33470, 3845, 3844, 33593, 33627, 3867, 33626
13790, 33470, 33471, 3846, 3845, 33595, 33628, 3868, 33627
13791, 33471, 33472, 3847, 3846, 33597, 33629, 3869, 33628
13792, 33472, 33473, 3848, 3847, 33599, 33630, 3870, 33629
13793, 33473, 33474, 3849, 3848, 33601, 33631, 3871, 33630
13794, 33474, 33475, 3850, 3849, 33603, 33632, 3872, 33631
13795, 33475, 33476, 3851, 3850, 33605, 33633, 3873, 33632
13796, 33476, 33477, 3852, 3851, 33607, 33634, 3874, 33633
13797, 33477, 33478, 3853, 3852, 33609, 33635, 3875, 33634
13798, 33478, 33479, 3854, 3853, 33611, 33636, 3876, 33635
13799, 33479, 33480, 3855, 3854, 33613, 33637, 3877, 33636
13800, 33480, 33481, 3856, 3855, 33615, 33638, 3878, 33637
13801, 33481, 3830, 106, 3856, 33616, 3834, 3879, 33638
*ELEMENT, type=CPS8, ELSET=Surface315
13802, 96, 3305, 33639, 3880, 3327, 33705, 33706, 3883
13803, 3305, 3306, 33640, 33639, 3328, 33707, 33708, 33705
13804, 3306, 3307, 33641, 33640, 3329, 33709, 33710, 33707
13805, 3307, 3308, 33642, 33641, 3330, 33711, 33712, 33709
13806, 3308, 3309, 33643, 33642, 3331, 33713, 33714, 33711
13807, 3309, 3310, 33644, 33643, 3332, 33715, 33716, 33713
13808, 3310, 3311, 33645, 33644, 3333, 33717, 33718, 33715
13809, 3311, 3312, 33646, 33645, 3334, 33719, 33720, 33717
13810, 3312, 3313, 33647, 33646, 3335, 33721, 33722, 33719
13811, 3313, 3314, 33648, 33647, 3336, 33723, 33724, 33721
13812, 3314, 3315, 33649, 33648, 3337, 33725, 33726, 33723
13813, 3315, 3316, 33650, 33649, 3338, 33727, 33728, 33725
13814, 3316, 3317, 33651, 33650, 3339, 33729, 33730, 33727
13815, 3317, 3318, 33652, 33651, 3340, 33731, 33732, 33729
13816, 3318, 3319, 33653, 33652, 3341, 33733, 33734, 33731
13817, 3319, 3320, 33654, 33653, 3342, 33735, 33736, 33733
13818, 3320, 3321, 33655, 33654, 3343, 33737, 33738, 33735
13819, 3321, 3322, 33656, 33655, 3344, 33739, 33740, 33737
13820, 3322, 3323, 33657, 33656, 3345, 33741, 33742, 33739
13821, 3323, 3324, 33658, 33657, 3346, 33743, 33744, 33741
13822, 3324, 3325, 33659, 33658, 3347, 33745, 33746, 33743
13823, 3325, 3326, 33660, 33659, 3348, 33747, 33748, 33745
13824, 3326, 8, 3887, 33660, 3349, 3890, 33749, 33747
13825, 3880, 33639, 33661, 3881, 33706, 33750, 33751, 3884
13826, 33639, 33640, 33662, 33661, 33708, 33752, 33753, 33750
13827, 33640, 33641, 33663, 33662, 33710, 33754, 33755, 33752
13828, 33641, 33642, 33664, 33663, 33712, 33756, 33757, 33754
13829, 33642, 33643, 33665, 33664, 33714, 33758, 33759, 33756
13830, 33643, 33644, 33666, 33665, 33716, 33760, 33761, 33758
13831, 33644, 33645, 33667, 33666, 33718, 33762, 33763, 33760
13832, 33645, 33646, 33668, 33667, 33720, 33764, 33765, 33762
13833, 33646, 33647, 33669, 33668, 33722, 33766, 33767, 33764
13834, 33647, 33648, 33670, 33669, 33724, 33768, 33769, 33766
13835, 33648, 33649, 33671, 33670, 33726, 33770, 33771, 33768
13836, 33649, 33650, 33672, 33671, 33728, 33772, 33773, 33770
13837, 33650, 33651, 33673, 33672, 33730, 33774, 33775, 33772
13838, 33651, 33652, 33674, 33673, 33732, 33776, 33777, 33774
13839, 33652, 33653, 33675, 33674, 33734, 33778, 33779, 33776
13840, 33653, 33654, 33676, 33675, 33736, 33780, 33781, 33778
13841, 33654, 33655, 33677, 33676, 33738, 33782, 33783, 33780
13842, 33655, 33656, 33678, 33677, 33740, 33784, 33785, 33782
13843, 33656, 33657, 33679, 33678, 33742, 33786, 33787, 33784
13844, 33657, 33658, 33680, 33679, 33744, 33788, 33789, 33786
13845, 33658, 33659, 33681, 33680, 33746, 33790, 33791, 33788
13846, 33659, 33660, 33682, 33681, 33748, 33792, 33793, 33790
13847, 33660, 3887, 3888, 33682, 33749, 3891, 33794, 33792
13848, 3881, 33661, 33683, 3882, 33751, 33795, 33796, 3885
13849, 33661, 33662, 33684, 33683, 33753, 33797, 33798, 33795
13850, 33662, 33663, 33685, 33684, 33755, 33799, 33800, 33797
13851, 33663, 33664, 33686, 33685, 33757, 33801, 33802, 33799
13852, 33664, 33665, 33687, 33686, 33759, 33803, 33804, 33801
13853, 33665, 33666, 33688, 33687, 33761, 33805, 33806, 33803
13854, 33666, 33667, 33689, 33688, 33763, 33807, 33808, 33805
13855, 33667, 33668, 33690, 33689, 33765, 33809, 33810, 33807
13856, 33668, 33669, 33691, 33690, 33767, 33811, 33812, 33809
13857, 33669, 33670, 33692, 33691, 33769, 33813, 33814, 33811
13858, 33670, 33671, 33693, 33692, 33771, 33815, 33816, 33813
13859, 33671, 33672, 33694, 33693, 33773, 33817, 33818, 33815
13860, 33672, 33673, 33695, 33694, 33775, 33819, 33820, 33817
13861, 33673, 33674, 33696, 33695, 33777, 33821, 33822, 33819
13862, 33674, 33675, 33697, 33696, 33779, 33823, 33824, 33821
13863, 33675, 33676, 33698, 33697, 33781, 33825, 33826, 33823
13864, 33676, 33677, 33699, 33698, 33783, 33827, 33828, 33825
13865, 33677, 33678, 33700, 33699, 33785, 33829, 33830, 33827
13866, 33678, 33679, 33701, 33700, 33787, 33831, 33832, 33829
13867, 33679, 33680, 33702, 33701, 33789, 33833, 33834, 33831
13868, 33680, 33681, 33703, 33702, 33791, 33835, 33836, 33833
13869, 33681, 33682, 33704, 33703, 33793, 33837, 33838, 33835
13870, 33682, 3888, 3889, 33704, 33794, 3892, 33839, 33837
13871, 3882, 33683, 3894, 107, 33796, 33840, 3916, 3886
13872, 33683, 33684, 3895, 3894, 33798, 33841, 3917, 33840
13873, 33684, 33685, 3896, 3895, 33800, 33842, 3918, 33841
13874, 33685, 33686, 3897, 3896, 33802, 33843, 3919, 33842
13875, 33686, 33687, 3898, 3897, 33804, 33844, 3920, 33843
13876, 33687, 33688, 3899, 3898, 33806, 33845, 3921, 33844
13877, 33688, 33689, 3900, 3899, 33808, 33846, 3922, 33845
13878, 33689, 33690, 3901, 3900, 33810, 33847, 3923, 33846
13879, 33690, 33691, 3902, 3901, 33812, 33848, 3924, 33847
13880, 33691, 33692, 3903, 3902, 33814, 33849, 3925, 33848
13881, 33692, 33693, 3904, 3903, 33816, 33850, 3926, 33849
13882, 33693, 33694, 3905, 3904, 33818, 33851, 3927, 33850
13883, 33694, 33695, 3906, 3905, 33820, 33852, 3928, 33851
13884, 33695, 33696, 3907, 3906, 33822, 33853, 3929, 33852
13885, 33696, 33697, 3908, 3907, 33824, 33854, 3930, 33853
13886, 33697, 33698, 3909, 3908, 33826, 33855, 3931, 33854
13887, 33698, 33699, 3910, 3909, 33828, 33856, 3932, 33855
13888, 33699, 33700, 3911, 3910, 33830, 33857, 3933, 33856
13889, 33700, 33701, 3912, 3911, 33832, 33858, 3934, 33857
13890, 33701, 33702, 3913, 3912, 33834, 33859, 3935, 33858
13891, 33702, 33703, 3914, 3913, 33836, 33860, 3936, 33859
13892, 33703, 33704, 3915, 3914, 33838, 33861, 3937, 33860
13893, 33704, 3889, 108, 3915, 33839, 3893, 3938, 33861
*ELEMENT, type=CPS8, ELSET=Surface316
13894, 95, 3350, 33862, 3821, 3372, 33928, 33929, 3824
13895, 3350, 3351, 33863, 33862, 3373, 33930, 33931, 33928
13896, 3351, 3352, 33864, 33863, 3374, 33932, 33933, 33930
13897, 3352, 3353, 33865, 33864, 3375, 33934, 33935, 33932
13898, 3353, 3354, 33866, 33865, 3376, 33936, 33937, 33934
13899, 3354, 3355, 33867, 33866, 3377, 33938, 33939, 33936
13900, 3355, 3356, 33868, 33867, 3378, 33940, 33941, 33938
13901, 3356, 3357, 33869, 33868, 3379, 33942, 33943, 33940
13902, 3357, 3358, 33870, 33869, 3380, 33944, 33945, 33942
13903, 3358, 3359, 33871, 33870, 3381, 33946, 33947, 33944
13904, 3359, 3360, 33872, 33871, 3382, 33948, 33949, 33946
13905, 3360, 3361, 33873, 33872, 3383, 33950, 33951, 33948
13906, 3361, 3362, 33874, 33873, 3384, 33952, 33953, 33950
13907, 3362, 3363, 33875, 33874, 3385, 33954, 33955, 33952
13908, 3363, 3364, 33876, 33875, 3386, 33956, 33957, 33954
13909, 3364, 3365, 33877, 33876, 3387, 33958, 33959, 33956
13910, 3365, 3366, 33878, 33877, 3388, 33960, 33961, 33958
13911, 3366, 3367, 33879, 33878, 3389, 33962, 33963, 33960
13912, 3367, 3368, 33880, 33879, 3390, 33964, 33965, 33962
13913, 3368, 3369, 33881, 33880, 3391, 33966, 33967, 33964
13914, 3369, 3370, 33882, 33881, 3392, 33968, 33969, 33966
13915, 3370, 3371, 33883, 33882, 3393, 33970, 33971, 33968
13916, 3371, 96, 3880, 33883, 3394, 3883, 33972, 33970
13917, 3821, 33862, 33884, 3822, 33929, 33973, 33974, 3825
13918, 33862, 33863, 33885, 33884, 33931, 33975, 33976, 33973
13919, 33863, 33864, 33886, 33885, 33933, 33977, 33978, 33975
13920, 33864, 33865, 33887, 33886, 33935, 33979, 33980, 33977
13921, 33865, 33866, 33888, 33887, 33937, 33981, 33982, 33979
13922, 33866, 33867, 33889, 33888, 33939, 33983, 33984, 33981
13923, 33867, 33868, 33890, 33889, 33941, 33985, 33986, 33983
13924, 33868, 33869, 33891, 33890, 33943, 33987, 33988, 33985
13925, 33869, 33870, 33892, 33891, 33945, 33989, 33990, 33987
13926, 33870, 33871, 33893, 33892, 33947, 33991, 33992, 33989
13927, 33871, 33872, 33894, 33893, 33949, 33993, 33994, 33991
13928, 33872, 33873, 33895, 33894, 33951, 33995, 33996, 33993
13929, 33873, 33874, 33896, 33895, 33953, 33997, 33998, 33995
13930, 33874, 33875, 33897, 33896, 33955, 33999, 34000, 33997
13931, 33875, 33876, 33898, 33897, 33957, 34001, 34002, 33999
13932, 33876, 33877, 33899, 33898, 33959, 34003, 34004, 34001
13933, 33877, 33878, 33900, 33899, 33961, 34005, 34006, 34003
13934, 33878, 33879, 33901, 33900, 33963, 34007, 34008, 34005
13935, 33879, 33880, 33902, 33901, 33965, 34009, 34010, 34007
13936, 33880, 33881, 33903, 33902, 33967, 34011, 34012, 34009
13937, 33881, 33882, 33904, 33903, 33969, 34013, 34014, 34011
13938, 33882, 33883, 33905, 33904, 33971, 34015, 34016, 34013
13939, 33883, 3880, 3881, 33905, 33972, 3884, 34017, 34015
13940, 3822, 33884, 33906, 3823, 33974, 34018, 34019, 3826
13941, 33884, 33885, 33907, 33906, 33976, 34020, 34021, 34018
13942, 33885, 33886, 33908, 33907, 33978, 34022, 34023, 34020
13943, 33886, 33887, 33909, 33908, 33980, 34024, 34025, 34022
13944, 33887, 33888, 33910, 33909, 33982, 34026, 34027, 34024
13945, 33888, 33889, 33911, 33910, 33984, 34028, 34029, 34026
13946, 33889, 33890, 33912, 33911, 33986, 34030, 34031, 34028
13947, 33890, 33891, 33913, 33912, 33988, 34032, 34033, 34030
13948, 33891, 33892, 33914, 33913, 33990, 34034, 34035, 34032
13949, 33892, 33893, 33915, 33914, 33992, 34036, 34037, 34034
13950, 33893, 33894, 33916, 33915, 33994, 34038, 34039, 34036
13951, 33894, 33895, 33917, 33916, 33996, 34040, 34041, 34038
13952, 33895, 33896, 33918, 33917, 33998, 34042, 34043, 34040
13953, 33896, 33897, 33919, 33918, 34000, 34044, 34045, 34042
13954, 33897, 33898, 33920, 33919, 34002, 34046, 34047, 34044
13955, 33898, 33899, 33921, 33920, 34004, 34048, 34049, 34046
13956, 33899, 33900, 33922, 33921, 34006, 34050, 34051, 34048
13957, 33900, 33901, 33923, 33922, 34008, 34052, 34053, 34050
13958, 33901, 33902, 33924, 33923, 34010, 34054, 34055, 34052
13959, 33902, 33903, 33925, 33924, 34012, 34056, 34057, 34054
13960, 33903, 33904, 33926, 33925, 34014, 34058, 34059, 34056
13961, 33904, 33905, 33927, 33926, 34016, 34060, 34061, 34058
13962, 33905, 3881, 3882, 33927, 34017, 3885, 34062, 34060
13963, 3823, 33906, 3939, 105, 34019, 34063, 3961, 3827
13964, 33906, 33907, 3940, 3939, 34021, 34064, 3962, 34063
13965, 33907, 33908, 3941, 3940, 34023, 34065, 3963, 34064
13966, 33908, 33909, 3942, 3941, 34025, 34066, 3964, 34065
13967, 33909, 33910, 3943, 3942, 34027, 34067, 3965, 34066
13968, 33910, 33911, 3944, 3943, 34029, 34068, 3966, 34067
13969, 33911, 33912, 3945, 3944, 34031, 34069, 3967, 34068
13970, 33912, 33913, 3946, 3945, 34033, 34070, 3968, 34069
13971, 33913, 33914, 3947, 3946, 34035, 34071, 3969, 34070
13972, 33914, 33915, 3948, 3947, 34037, 34072, 3970, 34071
13973, 33915, 33916, 3949, 3948, 34039, 34073, 3971, 34072
13974, 33916, 33917, 3950, 3949, 34041, 34074, 3972, 34073
13975, 33917, 33918, 3951, 3950, 34043, 34075, 3973, 34074
13976, 33918, 33919, 3952, 3951, 34045, 34076, 3974, 34075
13977, 33919, 33920, 3953, 3952, 34047, 34077, 3975, 34076
13978, 33920, 33921, 3954, 3953, 34049, 34078, 3976, 34077
13979, 33921, 33922, 3955, 3954, 34051, 34079, 3977, 34078
13980, 33922, 33923, 3956, 3955, 34053, 34080, 3978, 34079
13981, 33923, 33924, 3957, 3956, 34055, 34081, 3979, 34080
13982, 33924, 33925, 3958, 3957, 34057, 34082, 3980, 34081
13983, 33925, 33926, 3959, 3958, 34059, 34083, 3981, 34082
13984, 33926, 33927, 3960, 3959, 34061, 34084, 3982, 34083
13985, 33927, 3882, 107, 3960, 34062, 3886, 3983, 34084
*ELEMENT, type=CPS8, ELSET=Surface317
13986, 7, 3828, 34085, 278, 3831, 34151, 34152, 300
13987, 278, 34085, 34086, 279, 34152, 34153, 34154, 301
13988, 279, 34086, 34087, 280, 34154, 34155, 34156, 302
13989, 280, 34087, 34088, 281, 34156, 34157, 34158, 303
13990, 281, 34088, 34089, 282, 34158, 34159, 34160, 304
13991, 282, 34089, 34090, 283, 34160, 34161, 34162, 305
13992, 283, 34090, 34091, 284, 34162, 34163, 34164, 306
13993, 284, 34091, 34092, 285, 34164, 34165, 34166, 307
13994, 285, 34092, 34093, 286, 34166, 34167, 34168, 308
13995, 286, 34093, 34094, 287, 34168, 34169, 34170, 309
13996, 287, 34094, 34095, 288, 34170, 34171, 34172, 310
13997, 288, 34095, 34096, 289, 34172, 34173, 34174, 311
13998, 289, 34096, 34097, 290, 34174, 34175, 34176, 312
13999, 290, 34097, 34098, 291, 34176, 34177, 34178, 313
14000, 291, 34098, 34099, 292, 34178, 34179, 34180, 314
14001, 292, 34099, 34100, 293, 34180, 34181, 34182, 315
14002, 293, 34100, 34101, 294, 34182, 34183, 34184, 316
14003, 294, 34101, 34102, 295, 34184, 34185, 34186, 317
14004, 295, 34102, 34103, 296, 34186, 34187, 34188, 318
14005, 296, 34103, 34104, 297, 34188, 34189, 34190, 319
14006, 297, 34104, 34105, 298, 34190, 34191, 34192, 320
14007, 298, 34105, 34106, 299, 34192, 34193, 34194, 321
14008, 299, 34106, 3887, 8, 34194, 34195, 3890, 322
14009, 3828, 3829, 34107, 34085, 3832, 34196, 34197, 34151
14010, 34085, 34107, 34108, 34086, 34197, 34198, 34199, 34153
14011, 34086, 34108, 34109, 34087, 34199, 34200, 34201, 34155
14012, 34087, 34109, 34110, 34088, 34201, 34202, 34203, 34157
14013, 34088, 34110, 34111, 34089, 34203, 34204, 34205, 34159
14014, 34089, 34111, 34112, 34090, 34205, 34206, 34207, 34161
14015, 34090, 34112, 34113, 34091, 34207, 34208, 34209, 34163
14016, 34091, 34113, 34114, 34092, 34209, 34210, 34211, 34165
14017, 34092, 34114, 34115, 34093, 34211, 34212, 34213, 34167
14018, 34093, 34115, 34116, 34094, 34213, 34214, 34215, 34169
14019, 34094, 34116, 34117, 34095, 34215, 34216, 34217, 34171
14020, 34095, 34117, 34118, 34096, 34217, 34218, 34219, 34173
14021, 34096, 34118, 34119, 34097, 34219, 34220, 34221, 34175
14022, 34097, 34119, 34120, 34098, 34221, 34222, 34223, 34177
14023, 34098, 34120, 34121, 34099, 34223, 34224, 34225, 34179
14024, 34099, 34121, 34122, 34100, 34225, 34226, 34227, 34181
14025, 34100, 34122, 34123, 34101, 34227, 34228, 34229, 34183
14026, 34101, 34123, 34124, 34102, 34229, 34230, 34231, 34185
14027, 34102, 34124, 34125, 34103, 34231, 34232, 34233, 34187
14028, 34103, 34125, 34126, 34104, 34233, 34234, 34235, 34189
14029, 34104, 34126, 34127, 34105, 34235, 34236, 34237, 34191
14030, 34105, 34127, 34128, 34106, 34237, 34238, 34239, 34193
14031, 34106, 34128, 3888, 3887, 34239, 34240, 3891, 34195
14032, 3829, 3830, 34129, 34107, 3833, 34241, 34242, 34196
14033, 34107, 34129, 34130, 34108, 34242, 34243, 34244, 34198
14034, 34108, 34130, 34131, 34109, 34244, 34245, 34246, 34200
14035, 34109, 34131, 34132, 34110, 34246, 34247, 34248, 34202
14036, 34110, 34132, 34133, 34111, 34248, 34249, 34250, 34204
14037, 34111, 34133, 34134, 34112, 34250, 34251, 34252, 34206
14038, 34112, 34134, 34135, 34113, 34252, 34253, 34254, 34208
14039, 34113, 34135, 34136, 34114, 34254, 34255, 34256, 34210
14040, 34114, 34136, 34137, 34115, 34256, 34257, 34258, 34212
14041, 34115, 34137, 34138, 34116, 34258, 34259, 34260, 34214
14042, 34116, 34138, 34139, 34117, 34260, 34261, 34262, 34216
14043, 34117, 34139, 34140, 34118, 34262, 34263, 34264, 34218
14044, 34118, 34140, 34141, 34119, 34264, 34265, 34266, 34220
14045, 34119, 34141, 34142, 34120, 34266, 34267, 34268, 34222
14046, 34120, 34142, 34143, 34121, 34268, 34269, 34270, 34224
14047, 34121, 34143, 34144, 34122, 34270, 34271, 34272, 34226
14048, 34122, 34144, 34145, 34123, 34272, 34273, 34274, 34228
14049, 34123, 34145, 34146, 34124, 34274, 34275, 34276, 34230
14050, 34124, 34146, 34147, 34125, 34276, 34277, 34278, 34232
14051, 34125, 34147, 34148, 34126, 34278, 34279, 34280, 34234
14052, 34126, 34148, 34149, 34127, 34280, 34281, 34282, 34236
14053, 34127, 34149, 34150, 34128, 34282, 34283, 34284, 34238
14054, 34128, 34150, 3889, 3888, 34284, 34285, 3892, 34240
14055, 3830, 106, 3984, 34129, 3834, 4006, 34286, 34241
14056, 34129, 3984, 3985, 34130, 34286, 4007, 34287, 34243
14057, 34130, 3985, 3986, 34131, 34287, 4008, 34288, 34245
14058, 34131, 3986, 3987, 34132, 34288, 4009, 34289, 34247
14059, 34132, 3987, 3988, 34133, 34289, 4010, 34290, 34249
14060, 34133, 3988, 3989, 34134, 34290, 4011, 34291, 34251
14061, 34134, 3989, 3990, 34135, 34291, 4012, 34292, 34253
14062, 34135, 3990, 3991, 34136, 34292, 4013, 34293, 34255
14063, 34136, 3991, 3992, 34137, 34293, 4014, 34294, 34257
14064, 34137, 3992, 3993, 34138, 34294, 4015, 34295, 34259
14065, 34138, 3993, 3994, 34139, 34295, 4016, 34296, 34261
14066, 34139, 3994, 3995, 34140, 34296, 4017, 34297, 34263
14067, 34140, 3995, 3996, 34141, 34297, 4018, 34298, 34265
14068, 34141, 3996, 3997, 34142, 34298, 4019, 34299, 34267
14069, 34142, 3997, 3998, 34143, 34299, 4020, 34300, 34269
14070, 34143, 3998, 3999, 34144, 34300, 4021, 34301, 34271
14071, 34144, 3999, 4000, 34145, 34301, 4022, 34302, 34273
14072, 34145, 4000, 4001, 34146, 34302, 4023, 34303, 34275
14073, 34146, 4001, 4002, 34147, 34303, 4024, 34304, 34277
14074, 34147, 4002, 4003, 34148, 34304, 4025, 34305, 34279
14075, 34148, 4003, 4004, 34149, 34305, 4026, 34306, 34281
14076, 34149, 4004, 4005, 34150, 34306, 4027, 34307, 34283
14077, 34150, 4005, 108, 3889, 34307, 4028, 3893, 34285
*ELEMENT, type=CPS8, ELSET=Surface318
14078, 105, 3939, 34308, 3835, 3961, 34792, 34793, 3857
14079, 3939, 3940, 34309, 34308, 3962, 34794, 34795, 34792
14080, 3940, 3941, 34310, 34309, 3963, 34796, 34797, 34794
14081, 3941, 3942, 34311, 34310, 3964, 34798, 34799, 34796
14082, 3942, 3943, 34312, 34311, 3965, 34800, 34801, 34798
14083, 3943, 3944, 34313, 34312, 3966, 34802, 34803, 34800
14084, 3944, 3945, 34314, 34313, 3967, 34804, 34805, 34802
14085, 3945, 3946, 34315, 34314, 3968, 34806, 34807, 34804
14086, 3946, 3947, 34316, 34315, 3969, 34808, 34809, 34806
14087, 3947, 3948, 34317, 34316, 3970, 34810, 34811, 34808
14088, 3948, 3949, 34318, 34317, 3971, 34812, 34813, 34810
14089, 3949, 3950, 34319, 34318, 3972, 34814, 34815, 34812
14090, 3950, 3951, 34320, 34319, 3973, 34816, 34817, 34814
14091, 3951, 3952, 34321, 34320, 3974, 34818, 34819, 34816
14092, 3952, 3953, 34322, 34321, 3975, 34820, 34821, 34818
14093, 3953, 3954, 34323, 34322, 3976, 34822, 34823, 34820
14094, 3954, 3955, 34324, 34323, 3977, 34824, 34825, 34822
14095, 3955, 3956, 34325, 34324, 3978, 34826, 34827, 34824
14096, 3956, 3957, 34326, 34325, 3979, 34828, 34829, 34826
14097, 3957, 3958, 34327, 34326, 3980, 34830, 34831, 34828
14098, 3958, 3959, 34328, 34327, 3981, 34832, 34833, 34830
14099, 3959, 3960, 34329, 34328, 3982, 34834, 34835, 34832
14100, 3960, 107, 3894, 34329, 3983, 3916, 34836, 34834
14101, 3835, 34308, 34330, 3836, 34793, 34837, 34838, 3858
14102, 34308, 34309, 34331, 34330, 34795, 34839, 34840, 34837
14103, 34309, 34310, 34332, 34331, 34797, 34841, 34842, 34839
14104, 34310, 34311, 34333, 34332, 34799, 34843, 34844, 34841
14105, 34311, 34312, 34334, 34333, 34801, 34845, 34846, 34843
14106, 34312, 34313, 34335, 34334, 34803, 34847, 34848, 34845
14107, 34313, 34314, 34336, 34335, 34805, 34849, 34850, 34847
14108, 34314, 34315, 34337, 34336, 34807, 34851, 34852, 34849
14109, 34315, 34316, 34338, 34337, 34809, 34853, 34854, 34851
14110, 34316, 34317, 34339, 34338, 34811, 34855, 34856, 34853
14111, 34317, 34318, 34340, 34339, 34813, 34857, 34858, 34855
14112, 34318, 34319, 34341, 34340, 34815, 34859, 34860, 34857
14113, 34319, 34320, 34342, 34341, 34817, 34861, 34862, 34859
14114, 34320, 34321, 34343, 34342, 34819, 34863, 34864, 34861
14115, 34321, 34322, 34344, 34343, 34821, 34865, 34866, 34863
14116, 34322, 34323, 34345, 34344, 34823, 34867, 34868, 34865
14117, 34323, 34324, 34346, 34345, 34825, 34869, 34870, 34867
14118, 34324, 34325, 34347, 34346, 34827, 34871, 34872, 34869
14119, 34325, 34326, 34348, 34347, 34829, 34873, 34874, 34871
14120, 34326, 34327, 34349, 34348, 34831, 34875, 34876, 34873
14121, 34327, 34328, 34350, 34349, 34833, 34877, 34878, 34875
14122, 34328, 34329, 34351, 34350, 34835, 34879, 34880, 34877
14123, 34329, 3894, 3895, 34351, 34836, 3917, 34881, 34879
14124, 3836, 34330, 34352, 3837, 34838, 34882, 34883, 3859
14125, 34330, 34331, 34353, 34352, 34840, 34884, 34885, 34882
14126, 34331, 34332, 34354, 34353, 34842, 34886, 34887, 34884
14127, 34332, 34333, 34355, 34354, 34844, 34888, 34889, 34886
14128, 34333, 34334, 34356, 34355, 34846, 34890, 34891, 34888
14129, 34334, 34335, 34357, 34356, 34848, 34892, 34893, 34890
14130, 34335, 34336, 34358, 34357, 34850, 34894, 34895, 34892
14131, 34336, 34337, 34359, 34358, 34852, 34896, 34897, 34894
14132, 34337, 34338, 34360, 34359, 34854, 34898, 34899, 34896
14133, 34338, 34339, 34361, 34360, 34856, 34900, 34901, 34898
14134, 34339, 34340, 34362, 34361, 34858, 34902, 34903, 34900
14135, 34340, 34341, 34363, 34362, 34860, 34904, 34905, 34902
14136, 34341, 34342, 34364, 34363, 34862, 34906, 34907, 34904
14137, 34342, 34343, 34365, 34364, 34864, 34908, 34909, 34906
14138, 34343, 34344, 34366, 34365, 34866, 34910, 34911, 34908
14139, 34344, 34345, 34367, 34366, 34868, 34912, 34913, 34910
14140, 34345, 34346, 34368, 34367, 34870, 34914, 34915, 34912
14141, 34346, 34347, 34369, 34368, 34872, 34916, 34917, 34914
14142, 34347, 34348, 34370, 34369, 34874, 34918, 34919, 34916
14143, 34348, 34349, 34371, 34370, 34876, 34920, 34921, 34918
14144, 34349, 34350, 34372, 34371, 34878, 34922, 34923, 34920
14145, 34350, 34351, 34373, 34372, 34880, 34924, 34925, 34922
14146, 34351, 3895, 3896, 34373, 34881, 3918, 34926, 34924
14147, 3837, 34352, 34374, 3838, 34883, 34927, 34928, 3860
14148, 34352, 34353, 34375, 34374, 34885, 34929, 34930, 34927
14149, 34353, 34354, 34376, 34375, 34887, 34931, 34932, 34929
14150, 34354, 34355, 34377, 34376, 34889, 34933, 34934, 34931
14151, 34355, 34356, 34378, 34377, 34891, 34935, 34936, 34933
14152, 34356, 34357, 34379, 34378, 34893, 34937, 34938, 34935
14153, 34357, 34358, 34380, 34379, 34895, 34939, 34940, 34937
14154, 34358, 34359, 34381, 34380, 34897, 34941, 34942, 34939
14155, 34359, 34360, 34382, 34381, 34899, 34943, 34944, 34941
14156, 34360, 34361, 34383, 34382, 34901, 34945, 34946, 34943
14157, 34361, 34362, 34384, 34383, 34903, 34947, 34948, 34945
14158, 34362, 34363, 34385, 34384, 34905, 34949, 34950, 34947
14159, 34363, 34364, 34386, 34385, 34907, 34951, 34952, 34949
14160, 34364, 34365, 34387, 34386, 34909, 34953, 34954, 34951
14161, 34365, 34366, 34388, 34387, 34911, 34955, 34956, 34953
14162, 34366, 34367, 34389, 34388, 34913, 34957, 34958, 34955
14163, 34367, 34368, 34390, 34389, 34915, 34959, 34960, 34957
14164, 34368, 34369, 34391, 34390, 34917, 34961, 34962, 34959
14165, 34369, 34370, 34392, 34391, 34919, 34963, 34964, 34961
14166, 34370, 34371, 34393, 34392, 34921, 34965, 34966, 34963
14167, 34371, 34372, 34394, 34393, 34923, 34967, 34968, 34965
14168, 34372, 34373, 34395, 34394, 34925, 34969, 34970, 34967
14169, 34373, 3896, 3897, 34395, 34926, 3919, 34971, 34969
14170, 3838, 34374, 34396, 3839, 34928, 34972, 34973, 3861
14171, 34374, 34375, 34397, 34396, 34930, 34974, 34975, 34972
14172, 34375, 34376, 34398, 34397, 34932, 34976, 34977, 34974
14173, 34376, 34377, 34399, 34398, 34934, 34978, 34979, 34976
14174, 34377, 34378, 34400, 34399, 34936, 34980, 34981, 34978
14175, 34378, 34379, 34401, 34400, 34938, 34982, 34983, 34980
14176, 34379, 34380, 34402, 34401, 34940, 34984, 34985, 34982
14177, 34380, 34381, 34403, 34402, 34942, 34986, 34987, 34984
14178, 34381, 34382, 34404, 34403, 34944, 34988, 34989, 34986
14179, 34382, 34383, 34405, 34404, 34946, 34990, 34991, 34988
14180, 34383, 34384, 34406, 34405, 34948, 34992, 34993, 34990
14181, 34384, 34385, 34407, 34406, 34950, 34994, 34995, 34992
14182, 34385, 34386, 34408, 34407, 34952, 34996, 34997, 34994
14183, 34386, 34387, 34409, 34408, 34954, 34998, 34999, 34996
14184, 34387, 34388, 34410, 34409, 34956, 35000, 35001, 34998
14185, 34388, 34389, 34411, 34410, 34958, 35002, 35003, 35000
14186, 34389, 34390, 34412, 34411, 34960, 35004, 35005, 35002
14187, 34390, 34391, 34413, 34412, 34962, 35006, 35007, 35004
14188, 34391, 34392, 34414, 34413, 34964, 35008, 35009, 35006
14189, 34392, 34393, 34415, 34414, 34966, 35010, 35011, 35008
14190, 34393, 34394, 34416, 34415, 34968, 35012, 35013, 35010
14191, 34394, 34395, 34417, 34416, 34970, 35014, 35015, 35012
14192, 34395, 3897, 3898, 34417, 34971, 3920, 35016, 35014
14193, 3839, 34396, 34418, 3840, 34973, 35017, 35018, 3862
14194, 34396, 34397, 34419, 34418, 34975, 35019, 35020, 35017
14195, 34397, 34398, 34420, 34419, 34977, 35021, 35022, 35019
14196, 34398, 34399, 34421, 34420, 34979, 35023, 35024, 35021
14197, 34399, 34400, 34422, 34421, 34981, 35025, 35026, 35023
14198, 34400, 34401, 34423, 34422, 34983, 35027, 35028, 35025
14199, 34401, 34402, 34424, 34423, 34985, 35029, 35030, 35027
14200, 34402, 34403, 34425, 34424, 34987, 35031, 35032, 35029
14201, 34403, 34404, 34426, 34425, 34989, 35033, 35034, 35031
14202, 34404, 34405, 34427, 34426, 34991, 35035, 35036, 35033
14203, 34405, 34406, 34428, 34427, 34993, 35037, 35038, 35035
14204, 34406, 34407, 34429, 34428, 34995, 35039, 35040, 35037
14205, 34407, 34408, 34430, 34429, 34997, 35041, 35042, 35039
14206, 34408, 34409, 34431, 34430, 34999, 35043, 35044, 35041
14207, 34409, 34410, 34432, 34431, 35001, 35045, 35046, 35043
14208, 34410, 34411, 34433, 34432, 35003, 35047, 35048, 35045
14209, 34411, 34412, 34434, 34433, 35005, 35049, 35050, 35047
14210, 34412, 34413, 34435, 34434, 35007, 35051, 35052, 35049
14211, 34413, 34414, 34436, 34435, 35009, 35053, 35054, 35051
14212, 34414, 34415, 34437, 34436, 35011, 35055, 35056, 35053
14213, 34415, 34416, 34438, 34437, 35013, 35057, 35058, 35055
14214, 34416, 34417, 34439, 34438, 35015, 35059, 35060, 35057
14215, 34417, 3898, 3899, 34439, 35016, 3921, 35061, 35059
14216, 3840, 34418, 34440, 3841, 35018, 35062, 35063, 3863
14217, 34418, 34419, 34441, 34440, 35020, 35064, 35065, 35062
14218, 34419, 34420, 34442, 34441, 35022, 35066, 35067, 35064
14219, 34420, 34421, 34443, 34442, 35024, 35068, 35069, 35066
14220, 34421, 34422, 34444, 34443, 35026, 35070, 35071, 35068
14221, 34422, 34423, 34445, 34444, 35028, 35072, 35073, 35070
14222, 34423, 34424, 34446, 34445, 35030, 35074, 35075, 35072
14223, 34424, 34425, 34447, 34446, 35032, 35076, 35077, 35074
14224, 34425, 34426, 34448, 34447, 35034, 35078, 35079, 35076
14225, 34426, 34427, 34449, 34448, 35036, 35080, 35081, 35078
14226, 34427, 34428, 34450, 34449, 35038, 35082, 35083, 35080
14227, 34428, 34429, 34451, 34450, 35040, 35084, 35085, 35082
14228, 34429, 34430, 34452, 34451, 35042, 35086, 35087, 35084
14229, 34430, 34431, 34453, 34452, 35044, 35088, 35089, 35086
14230, 34431, 34432, 34454, 34453, 35046, 35090, 35091, 35088
14231, 34432, 34433, 34455, 34454, 35048, 35092, 35093, 35090
14232, 34433, 34434, 34456, 34455, 35050, 35094, 35095, 35092
14233, 34434, 34435, 34457, 34456, 35052, 35096, 35097, 35094
14234, 34435, 34436, 34458, 34457, 35054, 35098, 35099, 35096
14235, 34436, 34437, 34459, 34458, 35056, 35100, 35101, 35098
14236, 34437, 34438, 34460, 34459, 35058, 35102, 35103, 35100
14237, 34438, 34439, 34461, 34460, 35060, 35104, 35105, 35102
14238, 34439, 3899, 3900, 34461, 35061, 3922, 35106, 35104
14239, 3841, 34440, 34462, 3842, 35063, 35107, 35108, 3864
14240, 34440, 34441, 34463, 34462, 35065, 35109, 35110, 35107
14241, 34441, 34442, 34464, 34463, 35067, 35111, 35112, 35109
14242, 34442, 34443, 34465, 34464, 35069, 35113, 35114, 35111
14243, 34443, 34444, 34466, 34465, 35071, 35115, 35116, 35113
14244, 34444, 34445, 34467, 34466, 35073, 35117, 35118, 35115
14245, 34445, 34446, 34468, 34467, 35075, 35119, 35120, 35117
14246, 34446, 34447, 34469, 34468, 35077, 35121, 35122, 35119
14247, 34447, 34448, 34470, 34469, 35079, 35123, 35124, 35121
14248, 34448, 34449, 34471, 34470, 35081, 35125, 35126, 35123
14249, 34449, 34450, 34472, 34471, 35083, 35127, 35128, 35125
14250, 34450, 34451, 34473, 34472, 35085, 35129, 35130, 35127
14251, 34451, 34452, 34474, 34473, 35087, 35131, 35132, 35129
14252, 34452, 34453, 34475, 34474, 35089, 35133, 35134, 35131
14253, 34453, 34454, 34476, 34475, 35091, 35135, 35136, 35133
14254, 34454, 34455, 34477, 34476, 35093, 35137, 35138, 35135
14255, 34455, 34456, 34478, 34477, 35095, 35139, 35140, 35137
14256, 34456, 34457, 34479, 34478, 35097, 35141, 35142, 35139
14257, 34457, 34458, 34480, 34479, 35099, 35143, 35144, 35141
14258, 34458, 34459, 34481, 34480, 35101, 35145, 35146, 35143
14259, 34459, 34460, 34482, 34481, 35103, 35147, 35148, 35145
14260, 34460, 34461, 34483, 34482, 35105, 35149, 35150, 35147
14261, 34461, 3900, 3901, 34483, 35106, 3923, 35151, 35149
14262, 3842, 34462, 34484, 3843, 35108, 35152, 35153, 3865
14263, 34462, 34463, 34485, 34484, 35110, 35154, 35155, 35152
14264, 34463, 34464, 34486, 34485, 35112, 35156, 35157, 35154
14265, 34464, 34465, 34487, 34486, 35114, 35158, 35159, 35156
14266, 34465, 34466, 34488, 34487, 35116, 35160, 35161, 35158
14267, 34466, 34467, 34489, 34488, 35118, 35162, 35163, 35160
14268, 34467, 34468, 34490, 34489, 35120, 35164, 35165, 35162
14269, 34468, 34469, 34491, 34490, 35122, 35166, 35167, 35164
14270, 34469, 34470, 34492, 34491, 35124, 35168, 35169, 35166
14271, 34470, 34471, 34493, 34492, 35126, 35170, 35171, 35168
14272, 34471, 34472, 34494, 34493, 35128, 35172, 35173, 35170
14273, 34472, 34473, 34495, 34494, 35130, 35174, 35175, 35172
14274, 34473, 34474, 34496, 34495, 35132, 35176, 35177, 35174
14275, 34474, 34475, 34497, 34496, 35134, 35178, 35179, 35176
14276, 34475, 34476, 34498, 34497, 35136, 35180, 35181, 35178
14277, 34476, 34477, 34499, 34498, 35138, 35182, 35183, 35180
14278, 34477, 34478, 34500, 34499, 35140, 35184, 35185, 35182
14279, 34478, 34479, 34501, 34500, 35142, 35186, 35187, 35184
14280, 34479, 34480, 34502, 34501, 35144, 35188, 35189, 35186
14281, 34480, 34481, 34503, 34502, 35146, 35190, 35191, 35188
14282, 34481, 34482, 34504, 34503, 35148, 35192, 35193, 35190
14283, 34482, 34483, 34505, 34504, 35150, 35194, 35195, 35192
14284, 34483, 3901, 3902, 34505, 35151, 3924, 35196, 35194
14285, 3843, 34484, 34506, 3844, 35153, 35197, 35198, 3866
14286, 34484, 34485, 34507, 34506, 35155, 35199, 35200, 35197
14287, 34485, 34486, 34508, 34507, 35157, 35201, 35202, 35199
14288, 34486, 34487, 34509, 34508, 35159, 35203, 35204, 35201
14289, 34487, 34488, 34510, 34509, 35161, 35205, 35206, 35203
14290, 34488, 34489, 34511, 34510, 35163, 35207, 35208, 35205
14291, 34489, 34490, 34512, 34511, 35165, 35209, 35210, 35207
14292, 34490, 34491, 34513, 34512, 35167, 35211, 35212, 35209
14293, 34491, 34492, 34514, 34513, 35169, 35213, 35214, 35211
14294, 34492, 34493, 34515, 34514, 35171, 35215, 35216, 35213
14295, 34493, 34494, 34516, 34515, 35173, 35217, 35218, 35215
14296, 34494, 34495, 34517, 34516, 35175, 35219, 35220, 35217
14297, 34495, 34496, 34518, 34517, 35177, 35221, 35222, 35219
14298, 34496, 34497, 34519, 34518, 35179, 35223, 35224, 35221
14299, 34497, 34498, 34520, 34519, 35181, 35225, 35226, 35223
14300, 34498, 34499, 34521, 34520, 35183, 35227, 35228, 35225
14301, 34499, 34500, 34522, 34521, 35185, 35229, 35230, 35227
14302, 34500, 34501, 34523, 34522, 35187, 35231, 35232, 35229
14303, 34501, 34502, 34524, 34523, 35189, 35233, 35234, 35231
14304, 34502, 34503, 34525, 34524, 35191, 35235, 35236, 35233
14305, 34503, 34504, 34526, 34525, 35193, 35237, 35238, 35235
14306, 34504, 34505, 34527, 34526, 35195, 35239, 35240, 35237
14307, 34505, 3902, 3903, 34527, 35196, 3925, 35241, 35239
14308, 3844, 34506, 34528, 3845, 35198, 35242, 35243, 3867
14309, 34506, 34507, 34529, 34528, 35200, 35244, 35245, 35242
14310, 34507, 34508, 34530, 34529, 35202, 35246, 35247, 35244
14311, 34508, 34509, 34531, 34530, 35204, 35248, 35249, 35246
14312, 34509, 34510, 34532, 34531, 35206, 35250, 35251, 35248
14313, 34510, 34511, 34533, 34532, 35208, 35252, 35253, 35250
14314, 34511, 34512, 34534, 34533, 35210, 35254, 35255, 35252
14315, 34512, 34513, 34535, 34534, 35212, 35256, 35257, 35254
14316, 34513, 34514, 34536, 34535, 35214, 35258, 35259, 35256
14317, 34514, 34515, 34537, 34536, 35216, 35260, 35261, 35258
14318, 34515, 34516, 34538, 34537, 35218, 35262, 35263, 35260
14319, 34516, 34517, 34539, 34538, 35220, 35264, 35265, 35262
14320, 34517, 34518, 34540, 34539, 35222, 35266, 35267, 35264
14321, 34518, 34519, 34541, 34540, 35224, 35268, 35269, 35266
14322, 34519, 34520, 34542, 34541, 35226, 35270, 35271, 35268
14323, 34520, 34521, 34543, 34542, 35228, 35272, 35273, 35270
14324, 34521, 34522, 34544, 34543, 35230, 35274, 35275, 35272
14325, 34522, 34523, 34545, 34544, 35232, 35276, 35277, 35274
14326, 34523, 34524, 34546, 34545, 35234, 35278, 35279, 35276
14327, 34524, 34525, 34547, 34546, 35236, 35280, 35281, 35278
14328, 34525, 34526, 34548, 34547, 35238, 35282, 35283, 35280
14329, 34526, 34527, 34549, 34548, 35240, 35284, 35285, 35282
14330, 34527, 3903, 3904, 34549, 35241, 3926, 35286, 35284
14331, 3845, 34528, 34550, 3846, 35243, 35287, 35288, 3868
14332, 34528, 34529, 34551, 34550, 35245, 35289, 35290, 35287
14333, 34529, 34530, 34552, 34551, 35247, 35291, 35292, 35289
14334, 34530, 34531, 34553, 34552, 35249, 35293, 35294, 35291
14335, 34531, 34532, 34554, 34553, 35251, 35295, 35296, 35293
14336, 34532, 34533, 34555, 34554, 35253, 35297, 35298, 35295
14337, 34533, 34534, 34556, 34555, 35255, 35299, 35300, 35297
14338, 34534, 34535, 34557, 34556, 35257, 35301, 35302, 35299
14339, 34535, 34536, 34558, 34557, 35259, 35303, 35304, 35301
14340, 34536, 34537, 34559, 34558, 35261, 35305, 35306, 35303
14341, 34537, 34538, 34560, 34559, 35263, 35307, 35308, 35305
14342, 34538, 34539, 34561, 34560, 35265, 35309, 35310, 35307
14343, 34539, 34540, 34562, 34561, 35267, 35311, 35312, 35309
14344, 34540, 34541, 34563, 34562, 35269, 35313, 35314, 35311
14345, 34541, 34542, 34564, 34563, 35271, 35315, 35316, 35313
14346, 34542, 34543, 34565, 34564, 35273, 35317, 35318, 35315
14347, 34543, 34544, 34566, 34565, 35275, 35319, 35320, 35317
14348, 34544, 34545, 34567, 34566, 35277, 35321, 35322, 35319
14349, 34545, 34546, 34568, 34567, 35279, 35323, 35324, 35321
14350, 34546, 34547, 34569, 34568, 35281, 35325, 35326, 35323
14351, 34547, 34548, 34570, 34569, 35283, 35327, 35328, 35325
14352, 34548, 34549, 34571, 34570, 35285, 35329, 35330, 35327
14353, 34549, 3904, 3905, 34571, 35286, 3927, 35331, 35329
14354, 3846, 34550, 34572, 3847, 35288, 35332, 35333, 3869
14355, 34550, 34551, 34573, 34572, 35290, 35334, 35335, 35332
14356, 34551, 34552, 34574, 34573, 35292, 35336, 35337, 35334
14357, 34552, 34553, 34575, 34574, 35294, 35338, 35339, 35336
14358, 34553, 34554, 34576, 34575, 35296, 35340, 35341, 35338
14359, 34554, 34555, 34577, 34576, 35298, 35342, 35343, 35340
14360, 34555, 34556, 34578, 34577, 35300, 35344, 35345, 35342
14361, 34556, 34557, 34579, 34578, 35302, 35346, 35347, 35344
14362, 34557, 34558, 34580, 34579, 35304, 35348, 35349, 35346
14363, 34558, 34559, 34581, 34580, 35306, 35350, 35351, 35348
14364, 34559, 34560, 34582, 34581, 35308, 35352, 35353, 35350
14365, 34560, 34561, 34583, 34582, 35310, 35354, 35355, 35352
14366, 34561, 34562, 34584, 34583, 35312, 35356, 35357, 35354
14367, 34562, 34563, 34585, 34584, 35314, 35358, 35359, 35356
14368, 34563, 34564, 34586, 34585, 35316, 35360, 35361, 35358
14369, 34564, 34565, 34587, 34586, 35318, 35362, 35363, 35360
14370, 34565, 34566, 34588, 34587, 35320, 35364, 35365, 35362
14371, 34566, 34567, 34589, 34588, 35322, 35366, 35367, 35364
14372, 34567, 34568, 34590, 34589, 35324, 35368, 35369, 35366
14373, 34568, 34569, 34591, 34590, 35326, 35370, 35371, 35368
14374, 34569, 34570, 34592, 34591, 35328, 35372, 35373, 35370
14375, 34570, 34571, 34593, 34592, 35330, 35374, 35375, 35372
14376, 34571, 3905, 3906, 34593, 35331, 3928, 35376, 35374
14377, 3847, 34572, 34594, 3848, 35333, 35377, 35378, 3870
14378, 34572, 34573, 34595, 34594, 35335, 35379, 35380, 35377
14379, 34573, 34574, 34596, 34595, 35337, 35381, 35382, 35379
14380, 34574, 34575, 34597, 34596, 35339, 35383, 35384, 35381
14381, 34575, 34576, 34598, 34597, 35341, 35385, 35386, 35383
14382, 34576, 34577, 34599, 34598, 35343, 35387, 35388, 35385
14383, 34577, 34578, 34600, 34599, 35345, 35389, 35390, 35387
14384, 34578, 34579, 34601, 34600, 35347, 35391, 35392, 35389
14385, 34579, 34580, 34602, 34601, 35349, 35393, 35394, 35391
14386, 34580, 34581, 34603, 34602, 35351, 35395, 35396, 35393
14387, 34581, 34582, 34604, 34603, 35353, 35397, 35398, 35395
14388, 34582, 34583, 34605, 34604, 35355, 35399, 35400, 35397
14389, 34583, 34584, 34606, 34605, 35357, 35401, 35402, 35399
14390, 34584, 34585, 34607, 34606, 35359, 35403, 35404, 35401
14391, 34585, 34586, 34608, 34607, 35361, 35405, 35406, 35403
14392, 34586, 34587, 34609, 34608, 35363, 35407, 35408, 35405
14393, 34587, 34588, 34610, 34609, 35365, 35409, 35410, 35407
14394, 34588, 34589, 34611, 34610, 35367, 35411, 35412, 35409
14395, 34589, 34590, 34612, 34611, 35369, 35413, 35414, 35411
14396, 34590, 34591, 34613, 34612, 35371, 35415, 35416, 35413
14397, 34591, 34592, 34614, 34613, 35373, 35417, 35418, 35415
14398, 34592, 34593, 34615, 34614, 35375, 35419, 35420, 35417
14399, 34593, 3906, 3907, 34615, 35376, 3929, 35421, 35419
14400, 3848, 34594, 34616, 3849, 35378, 35422, 35423, 3871
14401, 34594, 34595, 34617, 34616, 35380, 35424, 35425, 35422
14402, 34595, 34596, 34618, 34617, 35382, 35426, 35427, 35424
14403, 34596, 34597, 34619, 34618, 35384, 35428, 35429, 35426
14404, 34597, 34598, 34620, 34619, 35386, 35430, 35431, 35428
14405, 34598, 34599, 34621, 34620, 35388, 35432, 35433, 35430
14406, 34599, 34600, 34622, 34621, 35390, 35434, 35435, 35432
14407, 34600, 34601, 34623, 34622, 35392, 35436, 35437, 35434
14408, 34601, 34602, 34624, 34623, 35394, 35438, 35439, 35436
14409, 34602, 34603, 34625, 34624, 35396, 35440, 35441, 35438
14410, 34603, 34604, 34626, 34625, 35398, 35442, 35443, 35440
14411, 34604, 34605, 34627, 34626, 35400, 35444, 35445, 35442
14412, 34605, 34606, 34628, 34627, 35402, 35446, 35447, 35444
14413, 34606, 34607, 34629, 34628, 35404, 35448, 35449, 35446
14414, 34607, 34608, 34630, 34629, 35406, 35450, 35451, 35448
14415, 34608, 34609, 34631, 34630, 35408, 35452, 35453, 35450
14416, 34609, 34610, 34632, 34631, 35410, 35454, 35455, 35452
14417, 34610, 34611, 34633, 34632, 35412, 35456, 35457, 35454
14418, 34611, 34612, 34634, 34633, 35414, 35458, 35459, 35456
14419, 34612, 34613, 34635, 34634, 35416, 35460, 35461, 35458
14420, 34613, 34614, 34636, 34635, 35418, 35462, 35463, 35460
14421, 34614, 34615, 34637, 34636, 35420, 35464, 35465, 35462
14422, 34615, 3907, 3908, 34637, 35421, 3930, 35466, 35464
14423, 3849, 34616, 34638, 3850, 35423, 35467, 35468, 3872
14424, 34616, 34617, 34639, 34638, 35425, 35469, 35470, 35467
14425, 34617, 34618, 34640, 34639, 35427, 35471, 35472, 35469
14426, 34618, 34619, 34641, 34640, 35429, 35473, 35474, 35471
14427, 34619, 34620, 34642, 34641, 35431, 35475, 35476, 35473
14428, 34620, 34621, 34643, 34642, 35433, 35477, 35478, 35475
14429, 34621, 34622, 34644, 34643, 35435, 35479, 35480, 35477
14430, 34622, 34623, 34645, 34644, 35437, 35481, 35482, 35479
14431, 34623, 34624, 34646, 34645, 35439, 35483, 35484, 35481
14432, 34624, 34625, 34647, 34646, 35441, 35485, 35486, 35483
14433, 34625, 34626, 34648, 34647, 35443, 35487, 35488, 35485
14434, 34626, 34627, 34649, 34648, 35445, 35489, 35490, 35487
14435, 34627, 34628, 34650, 34649, 35447, 35491, 35492, 35489
14436, 34628, 34629, 34651, 34650, 35449, 35493, 35494, 35491
14437, 34629, 34630, 34652, 34651, 35451, 35495, 35496, 35493
14438, 34630, 34631, 34653, 34652, 35453, 35497, 35498, 35495
14439, 34631, 34632, 34654, 34653, 35455, 35499, 35500, 35497
14440, 34632, 34633, 34655, 34654, 35457, 35501, 35502, 35499
14441, 34633, 34634, 34656, 34655, 35459, 35503, 35504, 35501
14442, 34634, 34635, 34657, 34656, 35461, 35505, 35506, 35503
14443, 34635, 34636, 34658, 34657, 35463, 35507, 35508, 35505
14444, 34636, 34637, 34659, 34658, 35465, 35509, 35510, 35507
14445, 34637, 3908, 3909, 34659, 35466, 3931, 35511, 35509
14446, 3850, 34638, 34660, 3851, 35468, 35512, 35513, 3873
14447, 34638, 34639, 34661, 34660, 35470, 35514, 35515, 35512
14448, 34639, 34640, 34662, 34661, 35472, 35516, 35517, 35514
14449, 34640, 34641, 34663, 34662, 35474, 35518, 35519, 35516
14450, 34641, 34642, 34664, 34663, 35476, 35520, 35521, 35518
14451, 34642, 34643, 34665, 34664, 35478, 35522, 35523, 35520
14452, 34643, 34644, 34666, 34665, 35480, 35524, 35525, 35522
14453, 34644, 34645, 34667, 34666, 35482, 35526, 35527, 35524
14454, 34645, 34646, 34668, 34667, 35484, 35528, 35529, 35526
14455, 34646, 34647, 34669, 34668, 35486, 35530, 35531, 35528
14456, 34647, 34648, 34670, 34669, 35488, 35532, 35533, 35530
14457, 34648, 34649, 34671, 34670, 35490, 35534, 35535, 35532
14458, 34649, 34650, 34672, 34671, 35492, 35536, 35537, 35534
14459, 34650, 34651, 34673, 34672, 35494, 35538, 35539, 35536
14460, 34651, 34652, 34674, 34673, 35496, 35540, 35541, 35538
14461, 34652, 34653, 34675, 34674, 35498, 35542, 35543, 35540
14462, 34653, 34654, 34676, 34675, 35500, 35544, 35545, 35542
14463, 34654, 34655, 34677, 34676, 35502, 35546, 35547, 35544
14464, 34655, 34656, 34678, 34677, 35504, 35548, 35549, 35546
14465, 34656, 34657, 34679, 34678, 35506, 35550, 35551, 35548
14466, 34657, 34658, 34680, 34679, 35508, 35552, 35553, 35550
14467, 34658, 34659, 34681, 34680, 35510, 35554, 35555, 35552
14468, 34659, 3909, 3910, 34681, 35511, 3932, 35556, 35554
14469, 3851, 34660, 34682, 3852, 35513, 35557, 35558, 3874
14470, 34660, 34661, 34683, 34682, 35515, 35559, 35560, 35557
14471, 34661, 34662, 34684, 34683, 35517, 35561, 35562, 35559
14472, 34662, 34663, 34685, 34684, 35519, 35563, 35564, 35561
14473, 34663, 34664, 34686, 34685, 35521, 35565, 35566, 35563
14474, 34664, 34665, 34687, 34686, 35523, 35567, 35568, 35565
14475, 34665, 34666, 34688, 34687, 35525, 35569, 35570, 35567
14476, 34666, 34667, 34689, 34688, 35527, 35571, 35572, 35569
14477, 34667, 34668, 34690, 34689, 35529, 35573, 35574, 35571
14478, 34668, 34669, 34691, 34690, 35531, 35575, 35576, 35573
14479, 34669, 34670, 34692, 34691, 35533, 35577, 35578, 35575
14480, 34670, 34671, 34693, 34692, 35535, 35579, 35580, 35577
14481, 34671, 34672, 34694, 34693, 35537, 35581, 35582, 35579
14482, 34672, 34673, 34695, 34694, 35539, 35583, 35584, 35581
14483, 34673, 34674, 34696, 34695, 35541, 35585, 35586, 35583
14484, 34674, 34675, 34697, 34696, 35543, 35587, 35588, 35585
14485, 34675, 34676, 34698, 34697, 35545, 35589, 35590, 35587
14486, 34676, 34677, 34699, 34698, 35547, 35591, 35592, 35589
14487, 34677, 34678, 34700, 34699, 35549, 35593, 35594, 35591
14488, 34678, 34679, 34701, 34700, 35551, 35595, 35596, 35593
14489, 34679, 34680, 34702, 34701, 35553, 35597, 35598, 35595
14490, 34680, 34681, 34703, 34702, 35555, 35599, 35600, 35597
14491, 34681, 3910, 3911, 34703, 35556, 3933, 35601, 35599
14492, 3852, 34682, 34704, 3853, 35558, 35602, 35603, 3875
14493, 34682, 34683, 34705, 34704, 35560, 35604, 35605, 35602
14494, 34683, 34684, 34706, 34705, 35562, 35606, 35607, 35604
14495, 34684, 34685, 34707, 34706, 35564, 35608, 35609, 35606
14496, 34685, 34686, 34708, 34707, 35566, 35610, 35611, 35608
14497, 34686, 34687, 34709, 34708, 35568, 35612, 35613, 35610
14498, 34687, 34688, 34710, 34709, 35570, 35614, 35615, 35612
14499, 34688, 34689, 34711, 34710, 35572, 35616, 35617, 35614
14500, 34689, 34690, 34712, 34711, 35574, 35618, 35619, 35616
14501, 34690, 34691, 34713, 34712, 35576, 35620, 35621, 35618
14502, 34691, 34692, 34714, 34713, 35578, 35622, 35623, 35620
14503, 34692, 34693, 34715, 34714, 35580, 35624, 35625, 35622
14504, 34693, 34694, 34716, 34715, 35582, 35626, 35627, 35624
14505, 34694, 34695, 34717, 34716, 35584, 35628, 35629, 35626
14506, 34695, 34696, 34718, 34717, 35586, 35630, 35631, 35628
14507, 34696, 34697, 34719, 34718, 35588, 35632, 35633, 35630
14508, 34697, 34698, 34720, 34719, 35590, 35634, 35635, 35632
14509, 34698, 34699, 34721, 34720, 35592, 35636, 35637, 35634
14510, 34699, 34700, 34722, 34721, 35594, 35638, 35639, 35636
14511, 34700, 34701, 34723, 34722, 35596, 35640, 35641, 35638
14512, 34701, 34702, 34724, 34723, 35598, 35642, 35643, 35640
14513, 34702, 34703, 34725, 34724, 35600, 35644, 35645, 35642
14514, 34703, 3911, 3912, 34725, 35601, 3934, 35646, 35644
14515, 3853, 34704, 34726, 3854, 35603, 35647, 35648, 3876
14516, 34704, 34705, 34727, 34726, 35605, 35649, 35650, 35647
14517, 34705, 34706, 34728, 34727, 35607, 35651, 35652, 35649
14518, 34706, 34707, 34729, 34728, 35609, 35653, 35654, 35651
14519, 34707, 34708, 34730, 34729, 35611, 35655, 35656, 35653
14520, 34708, 34709, 34731, 34730, 35613, 35657, 35658, 35655
14521, 34709, 34710, 34732, 34731, 35615, 35659, 35660, 35657
14522, 34710, 34711, 34733, 34732, 35617, 35661, 35662, 35659
14523, 34711, 34712, 34734, 34733, 35619, 35663, 35664, 35661
14524, 34712, 34713, 34735, 34734, 35621, 35665, 35666, 35663
14525, 34713, 34714, 34736, 34735, 35623, 35667, 35668, 35665
14526, 34714, 34715, 34737, 34736, 35625, 35669, 35670, 35667
14527, 34715, 34716, 34738, 34737, 35627, 35671, 35672, 35669
14528, 34716, 34717, 34739, 34738, 35629, 35673, 35674, 35671
14529, 34717, 34718, 34740, 34739, 35631, 35675, 35676, 35673
14530, 34718, 34719, 34741, 34740, 35633, 35677, 35678, 35675
14531, 34719, 34720, 34742, 34741, 35635, 35679, 35680, 35677
14532, 34720, 34721, 34743, 34742, 35637, 35681, 35682, 35679
14533, 34721, 34722, 34744, 34743, 35639, 35683, 35684, 35681
14534, 34722, 34723, 34745, 34744, 35641, 35685, 35686, 35683
14535, 34723, 34724, 34746, 34745, 35643, 35687, 35688, 35685
14536, 34724, 34725, 34747, 34746, 35645, 35689, 35690, 35687
14537, 34725, 3912, 3913, 34747, 35646, 3935, 35691, 35689
14538, 3854, 34726, 34748, 3855, 35648, 35692, 35693, 3877
14539, 34726, 34727, 34749, 34748, 35650, 35694, 35695, 35692
14540, 34727, 34728, 34750, 34749, 35652, 35696, 35697, 35694
14541, 34728, 34729, 34751, 34750, 35654, 35698, 35699, 35696
14542, 34729, 34730, 34752, 34751, 35656, 35700, 35701, 35698
14543, 34730, 34731, 34753, 34752, 35658, 35702, 35703, 35700
14544, 34731, 34732, 34754, 34753, 35660, 35704, 35705, 35702
14545, 34732, 34733, 34755, 34754, 35662, 35706, 35707, 35704
14546, 34733, 34734, 34756, 34755, 35664, 35708, 35709, 35706
14547, 34734, 34735, 34757, 34756, 35666, 35710, 35711, 35708
14548, 34735, 34736, 34758, 34757, 35668, 35712, 35713, 35710
14549, 34736, 34737, 34759, 34758, 35670, 35714, 35715, 35712
14550, 34737, 34738, 34760, 34759, 35672, 35716, 35717, 35714
14551, 34738, 34739, 34761, 34760, 35674, 35718, 35719, 35716
14552, 34739, 34740, 34762, 34761, 35676, 35720, 35721, 35718
14553, 34740, 34741, 34763, 34762, 35678, 35722, 35723, 35720
14554, 34741, 34742, 34764, 34763, 35680, 35724, 35725, 35722
14555, 34742, 34743, 34765, 34764, 35682, 35726, 35727, 35724
14556, 34743, 34744, 34766, 34765, 35684, 35728, 35729, 35726
14557, 34744, 34745, 34767, 34766, 35686, 35730, 35731, 35728
14558, 34745, 34746, 34768, 34767, 35688, 35732, 35733, 35730
14559, 34746, 34747, 34769, 34768, 35690, 35734, 35735, 35732
14560, 34747, 3913, 3914, 34769, 35691, 3936, 35736, 35734
14561, 3855, 34748, 34770, 3856, 35693, 35737, 35738, 3878
14562, 34748, 34749, 34771, 34770, 35695, 35739, 35740, 35737
14563, 34749, 34750, 34772, 34771, 35697, 35741, 35742, 35739
14564, 34750, 34751, 34773, 34772, 35699, 35743, 35744, 35741
14565, 34751, 34752, 34774, 34773, 35701, 35745, 35746, 35743
14566, 34752, 34753, 34775, 34774, 35703, 35747, 35748, 35745
14567, 34753, 34754, 34776, 34775, 35705, 35749, 35750, 35747
14568, 34754, 34755, 34777, 34776, 35707, 35751, 35752, 35749
14569, 34755, 34756, 34778, 34777, 35709, 35753, 35754, 35751
14570, 34756, 34757, 34779, 34778, 35711, 35755, 35756, 35753
14571, 34757, 34758, 34780, 34779, 35713, 35757, 35758, 35755
14572, 34758, 34759, 34781, 34780, 35715, 35759, 35760, 35757
14573, 34759, 34760, 34782, 34781, 35717, 35761, 35762, 35759
14574, 34760, 34761, 34783, 34782, 35719, 35763, 35764, 35761
14575, 34761, 34762, 34784, 34783, 35721, 35765, 35766, 35763
14576, 34762, 34763, 34785, 34784, 35723, 35767, 35768, 35765
14577, 34763, 34764, 34786, 34785, 35725, 35769, 35770, 35767
14578, 34764, 34765, 34787, 34786, 35727, 35771, 35772, 35769
14579, 34765, 34766, 34788, 34787, 35729, 35773, 35774, 35771
14580, 34766, 34767, 34789, 34788, 35731, 35775, 35776, 35773
14581, 34767, 34768, 34790, 34789, 35733, 35777, 35778, 35775
14582, 34768, 34769, 34791, 34790, 35735, 35779, 35780, 35777
14583, 34769, 3914, 3915, 34791, 35736, 3937, 35781, 35779
14584, 3856, 34770, 3984, 106, 35738, 35782, 4006, 3879
14585, 34770, 34771, 3985, 3984, 35740, 35783, 4007, 35782
14586, 34771, 34772, 3986, 3985, 35742, 35784, 4008, 35783
14587, 34772, 34773, 3987, 3986, 35744, 35785, 4009, 35784
14588, 34773, 34774, 3988, 3987, 35746, 35786, 4010, 35785
14589, 34774, 34775, 3989, 3988, 35748, 35787, 4011, 35786
14590, 34775, 34776, 3990, 3989, 35750, 35788, 4012, 35787
14591, 34776, 34777, 3991, 3990, 35752, 35789, 4013, 35788
14592, 34777, 34778, 3992, 3991, 35754, 35790, 4014, 35789
14593, 34778, 34779, 3993, 3992, 35756, 35791, 4015, 35790
14594, 34779, 34780, 3994, 3993, 35758, 35792, 4016, 35791
14595, 34780, 34781, 3995, 3994, 35760, 35793, 4017, 35792
14596, 34781, 34782, 3996, 3995, 35762, 35794, 4018, 35793
14597, 34782, 34783, 3997, 3996, 35764, 35795, 4019, 35794
14598, 34783, 34784, 3998, 3997, 35766, 35796, 4020, 35795
14599, 34784, 34785, 3999, 3998, 35768, 35797, 4021, 35796
14600, 34785, 34786, 4000, 3999, 35770, 35798, 4022, 35797
14601, 34786, 34787, 4001, 4000, 35772, 35799, 4023, 35798
14602, 34787, 34788, 4002, 4001, 35774, 35800, 4024, 35799
14603, 34788, 34789, 4003, 4002, 35776, 35801, 4025, 35800
14604, 34789, 34790, 4004, 4003, 35778, 35802, 4026, 35801
14605, 34790, 34791, 4005, 4004, 35780, 35803, 4027, 35802
14606, 34791, 3915, 108, 4005, 35781, 3938, 4028, 35803
*ELEMENT, type=C3D20, ELSET=Volume1
14607, 5229, 376, 13, 447, 35804, 5628, 569, 6744, 5246, 384, 449, 5245, 36157, 5804, 6789, 
36158, 36156, 5805, 591, 6788
14608, 35804, 5628, 569, 6744, 35805, 5636, 570, 6745, 36157, 5804, 6789, 36158, 36160, 5821, 6791, 
36161, 36159, 5822, 592, 6790
14609, 35805, 5636, 570, 6745, 35806, 5644, 571, 6746, 36160, 5821, 6791, 36161, 36163, 5838, 6793, 
36164, 36162, 5839, 593, 6792
14610, 35806, 5644, 571, 6746, 35807, 5652, 572, 6747, 36163, 5838, 6793, 36164, 36166, 5855, 6795, 
36167, 36165, 5856, 594, 6794
14611, 35807, 5652, 572, 6747, 35808, 5660, 573, 6748, 36166, 5855, 6795, 36167, 36169, 5872, 6797, 
36170, 36168, 5873, 595, 6796
14612, 35808, 5660, 573, 6748, 35809, 5668, 574, 6749, 36169, 5872, 6797, 36170, 36172, 5889, 6799, 
36173, 36171, 5890, 596, 6798
14613, 35809, 5668, 574, 6749, 35810, 5676, 575, 6750, 36172, 5889, 6799, 36173, 36175, 5906, 6801, 
36176, 36174, 5907, 597, 6800
14614, 35810, 5676, 575, 6750, 35811, 5684, 576, 6751, 36175, 5906, 6801, 36176, 36178, 5923, 6803, 
36179, 36177, 5924, 598, 6802
14615, 35811, 5684, 576, 6751, 35812, 5692, 577, 6752, 36178, 5923, 6803, 36179, 36181, 5940, 6805, 
36182, 36180, 5941, 599, 6804
14616, 35812, 5692, 577, 6752, 35813, 5700, 578, 6753, 36181, 5940, 6805, 36182, 36184, 5957, 6807, 
36185, 36183, 5958, 600, 6806
14617, 35813, 5700, 578, 6753, 35814, 5708, 579, 6754, 36184, 5957, 6807, 36185, 36187, 5974, 6809, 
36188, 36186, 5975, 601, 6808
14618, 35814, 5708, 579, 6754, 35815, 5716, 580, 6755, 36187, 5974, 6809, 36188, 36190, 5991, 6811, 
36191, 36189, 5992, 602, 6810
14619, 35815, 5716, 580, 6755, 35816, 5724, 581, 6756, 36190, 5991, 6811, 36191, 36193, 6008, 6813, 
36194, 36192, 6009, 603, 6812
14620, 35816, 5724, 581, 6756, 35817, 5732, 582, 6757, 36193, 6008, 6813, 36194, 36196, 6025, 6815, 
36197, 36195, 6026, 604, 6814
14621, 35817, 5732, 582, 6757, 35818, 5740, 583, 6758, 36196, 6025, 6815, 36197, 36199, 6042, 6817, 
36200, 36198, 6043, 605, 6816
14622, 35818, 5740, 583, 6758, 35819, 5748, 584, 6759, 36199, 6042, 6817, 36200, 36202, 6059, 6819, 
36203, 36201, 6060, 606, 6818
14623, 35819, 5748, 584, 6759, 35820, 5756, 585, 6760, 36202, 6059, 6819, 36203, 36205, 6076, 6821, 
36206, 36204, 6077, 607, 6820
14624, 35820, 5756, 585, 6760, 35821, 5764, 586, 6761, 36205, 6076, 6821, 36206, 36208, 6093, 6823, 
36209, 36207, 6094, 608, 6822
14625, 35821, 5764, 586, 6761, 35822, 5772, 587, 6762, 36208, 6093, 6823, 36209, 36211, 6110, 6825, 
36212, 36210, 6111, 609, 6824
14626, 35822, 5772, 587, 6762, 35823, 5780, 588, 6763, 36211, 6110, 6825, 36212, 36214, 6127, 6827, 
36215, 36213, 6128, 610, 6826
14627, 35823, 5780, 588, 6763, 35824, 5788, 589, 6764, 36214, 6127, 6827, 36215, 36217, 6144, 6829, 
36218, 36216, 6145, 611, 6828
14628, 35824, 5788, 589, 6764, 35825, 5796, 590, 6765, 36217, 6144, 6829, 36218, 36220, 6161, 6831, 
36221, 36219, 6162, 612, 6830
14629, 35825, 5796, 590, 6765, 5570, 525, 22, 564, 36220, 6161, 6831, 36221, 5587, 533, 566, 
5586, 36222, 6178, 613, 6832
14630, 5230, 5229, 447, 448, 35826, 35804, 6744, 6766, 5248, 5245, 450, 5247, 36224, 36158, 6834, 
36225, 36223, 36156, 6788, 6833
14631, 35826, 35804, 6744, 6766, 35827, 35805, 6745, 6767, 36224, 36158, 6834, 36225, 36227, 36161, 6836, 
36228, 36226, 36159, 6790, 6835
14632, 35827, 35805, 6745, 6767, 35828, 35806, 6746, 6768, 36227, 36161, 6836, 36228, 36230, 36164, 6838, 
36231, 36229, 36162, 6792, 6837
14633, 35828, 35806, 6746, 6768, 35829, 35807, 6747, 6769, 36230, 36164, 6838, 36231, 36233, 36167, 6840, 
36234, 36232, 36165, 6794, 6839
14634, 35829, 35807, 6747, 6769, 35830, 35808, 6748, 6770, 36233, 36167, 6840, 36234, 36236, 36170, 6842, 
36237, 36235, 36168, 6796, 6841
14635, 35830, 35808, 6748, 6770, 35831, 35809, 6749, 6771, 36236, 36170, 6842, 36237, 36239, 36173, 6844, 
36240, 36238, 36171, 6798, 6843
14636, 35831, 35809, 6749, 6771, 35832, 35810, 6750, 6772, 36239, 36173, 6844, 36240, 36242, 36176, 6846, 
36243, 36241, 36174, 6800, 6845
14637, 35832, 35810, 6750, 6772, 35833, 35811, 6751, 6773, 36242, 36176, 6846, 36243, 36245, 36179, 6848, 
36246, 36244, 36177, 6802, 6847
14638, 35833, 35811, 6751, 6773, 35834, 35812, 6752, 6774, 36245, 36179, 6848, 36246, 36248, 36182, 6850, 
36249, 36247, 36180, 6804, 6849
14639, 35834, 35812, 6752, 6774, 35835, 35813, 6753, 6775, 36248, 36182, 6850, 36249, 36251, 36185, 6852, 
36252, 36250, 36183, 6806, 6851
14640, 35835, 35813, 6753, 6775, 35836, 35814, 6754, 6776, 36251, 36185, 6852, 36252, 36254, 36188, 6854, 
36255, 36253, 36186, 6808, 6853
14641, 35836, 35814, 6754, 6776, 35837, 35815, 6755, 6777, 36254, 36188, 6854, 36255, 36257, 36191, 6856, 
36258, 36256, 36189, 6810, 6855
14642, 35837, 35815, 6755, 6777, 35838, 35816, 6756, 6778, 36257, 36191, 6856, 36258, 36260, 36194, 6858, 
36261, 36259, 36192, 6812, 6857
14643, 35838, 35816, 6756, 6778, 35839, 35817, 6757, 6779, 36260, 36194, 6858, 36261, 36263, 36197, 6860, 
36264, 36262, 36195, 6814, 6859
14644, 35839, 35817, 6757, 6779, 35840, 35818, 6758, 6780, 36263, 36197, 6860, 36264, 36266, 36200, 6862, 
36267, 36265, 36198, 6816, 6861
14645, 35840, 35818, 6758, 6780, 35841, 35819, 6759, 6781, 36266, 36200, 6862, 36267, 36269, 36203, 6864, 
36270, 36268, 36201, 6818, 6863
14646, 35841, 35819, 6759, 6781, 35842, 35820, 6760, 6782, 36269, 36203, 6864, 36270, 36272, 36206, 6866, 
36273, 36271, 36204, 6820, 6865
14647, 35842, 35820, 6760, 6782, 35843, 35821, 6761, 6783, 36272, 36206, 6866, 36273, 36275, 36209, 6868, 
36276, 36274, 36207, 6822, 6867
14648, 35843, 35821, 6761, 6783, 35844, 35822, 6762, 6784, 36275, 36209, 6868, 36276, 36278, 36212, 6870, 
36279, 36277, 36210, 6824, 6869
14649, 35844, 35822, 6762, 6784, 35845, 35823, 6763, 6785, 36278, 36212, 6870, 36279, 36281, 36215, 6872, 
36282, 36280, 36213, 6826, 6871
14650, 35845, 35823, 6763, 6785, 35846, 35824, 6764, 6786, 36281, 36215, 6872, 36282, 36284, 36218, 6874, 
36285, 36283, 36216, 6828, 6873
14651, 35846, 35824, 6764, 6786, 35847, 35825, 6765, 6787, 36284, 36218, 6874, 36285, 36287, 36221, 6876, 
36288, 36286, 36219, 6830, 6875
14652, 35847, 35825, 6765, 6787, 5571, 5570, 564, 565, 36287, 36221, 6876, 36288, 5589, 5586, 567, 
5588, 36289, 36222, 6832, 6877
14653, 413, 5230, 448, 15, 6186, 35826, 6766, 659, 5249, 5247, 451, 421, 36290, 36225, 6878, 
6363, 6362, 36223, 6833, 681
14654, 6186, 35826, 6766, 659, 6194, 35827, 6767, 660, 36290, 36225, 6878, 6363, 36291, 36228, 6879, 
6380, 6379, 36226, 6835, 682
14655, 6194, 35827, 6767, 660, 6202, 35828, 6768, 661, 36291, 36228, 6879, 6380, 36292, 36231, 6880, 
6397, 6396, 36229, 6837, 683
14656, 6202, 35828, 6768, 661, 6210, 35829, 6769, 662, 36292, 36231, 6880, 6397, 36293, 36234, 6881, 
6414, 6413, 36232, 6839, 684
14657, 6210, 35829, 6769, 662, 6218, 35830, 6770, 663, 36293, 36234, 6881, 6414, 36294, 36237, 6882, 
6431, 6430, 36235, 6841, 685
14658, 6218, 35830, 6770, 663, 6226, 35831, 6771, 664, 36294, 36237, 6882, 6431, 36295, 36240, 6883, 
6448, 6447, 36238, 6843, 686
14659, 6226, 35831, 6771, 664, 6234, 35832, 6772, 665, 36295, 36240, 6883, 6448, 36296, 36243, 6884, 
6465, 6464, 36241, 6845, 687
14660, 6234, 35832, 6772, 665, 6242, 35833, 6773, 666, 36296, 36243, 6884, 6465, 36297, 36246, 6885, 
6482, 6481, 36244, 6847, 688
14661, 6242, 35833, 6773, 666, 6250, 35834, 6774, 667, 36297, 36246, 6885, 6482, 36298, 36249, 6886, 
6499, 6498, 36247, 6849, 689
14662, 6250, 35834, 6774, 667, 6258, 35835, 6775, 668, 36298, 36249, 6886, 6499, 36299, 36252, 6887, 
6516, 6515, 36250, 6851, 690
14663, 6258, 35835, 6775, 668, 6266, 35836, 6776, 669, 36299, 36252, 6887, 6516, 36300, 36255, 6888, 
6533, 6532, 36253, 6853, 691
14664, 6266, 35836, 6776, 669, 6274, 35837, 6777, 670, 36300, 36255, 6888, 6533, 36301, 36258, 6889, 
6550, 6549, 36256, 6855, 692
14665, 6274, 35837, 6777, 670, 6282, 35838, 6778, 671, 36301, 36258, 6889, 6550, 36302, 36261, 6890, 
6567, 6566, 36259, 6857, 693
14666, 6282, 35838, 6778, 671, 6290, 35839, 6779, 672, 36302, 36261, 6890, 6567, 36303, 36264, 6891, 
6584, 6583, 36262, 6859, 694
14667, 6290, 35839, 6779, 672, 6298, 35840, 6780, 673, 36303, 36264, 6891, 6584, 36304, 36267, 6892, 
6601, 6600, 36265, 6861, 695
14668, 6298, 35840, 6780, 673, 6306, 35841, 6781, 674, 36304, 36267, 6892, 6601, 36305, 36270, 6893, 
6618, 6617, 36268, 6863, 696
14669, 6306, 35841, 6781, 674, 6314, 35842, 6782, 675, 36305, 36270, 6893, 6618, 36306, 36273, 6894, 
6635, 6634, 36271, 6865, 697
14670, 6314, 35842, 6782, 675, 6322, 35843, 6783, 676, 36306, 36273, 6894, 6635, 36307, 36276, 6895, 
6652, 6651, 36274, 6867, 698
14671, 6322, 35843, 6783, 676, 6330, 35844, 6784, 677, 36307, 36276, 6895, 6652, 36308, 36279, 6896, 
6669, 6668, 36277, 6869, 699
14672, 6330, 35844, 6784, 677, 6338, 35845, 6785, 678, 36308, 36279, 6896, 6669, 36309, 36282, 6897, 
6686, 6685, 36280, 6871, 700
14673, 6338, 35845, 6785, 678, 6346, 35846, 6786, 679, 36309, 36282, 6897, 6686, 36310, 36285, 6898, 
6703, 6702, 36283, 6873, 701
14674, 6346, 35846, 6786, 679, 6354, 35847, 6787, 680, 36310, 36285, 6898, 6703, 36311, 36288, 6899, 
6720, 6719, 36286, 6875, 702
14675, 6354, 35847, 6787, 680, 547, 5571, 565, 24, 36311, 36288, 6899, 6720, 5590, 5588, 568, 
555, 6736, 36289, 6877, 703
14676, 5231, 377, 376, 5229, 35848, 5629, 5628, 35804, 5251, 385, 5246, 5250, 36313, 5806, 36157, 
36314, 36312, 5807, 5805, 36156
14677, 35848, 5629, 5628, 35804, 35849, 5637, 5636, 35805, 36313, 5806, 36157, 36314, 36316, 5823, 36160, 
36317, 36315, 5824, 5822, 36159
14678, 35849, 5637, 5636, 35805, 35850, 5645, 5644, 35806, 36316, 5823, 36160, 36317, 36319, 5840, 36163, 
36320, 36318, 5841, 5839, 36162
14679, 35850, 5645, 5644, 35806, 35851, 5653, 5652, 35807, 36319, 5840, 36163, 36320, 36322, 5857, 36166, 
36323, 36321, 5858, 5856, 36165
14680, 35851, 5653, 5652, 35807, 35852, 5661, 5660, 35808, 36322, 5857, 36166, 36323, 36325, 5874, 36169, 
36326, 36324, 5875, 5873, 36168
14681, 35852, 5661, 5660, 35808, 35853, 5669, 5668, 35809, 36325, 5874, 36169, 36326, 36328, 5891, 36172, 
36329, 36327, 5892, 5890, 36171
14682, 35853, 5669, 5668, 35809, 35854, 5677, 5676, 35810, 36328, 5891, 36172, 36329, 36331, 5908, 36175, 
36332, 36330, 5909, 5907, 36174
14683, 35854, 5677, 5676, 35810, 35855, 5685, 5684, 35811, 36331, 5908, 36175, 36332, 36334, 5925, 36178, 
36335, 36333, 5926, 5924, 36177
14684, 35855, 5685, 5684, 35811, 35856, 5693, 5692, 35812, 36334, 5925, 36178, 36335, 36337, 5942, 36181, 
36338, 36336, 5943, 5941, 36180
14685, 35856, 5693, 5692, 35812, 35857, 5701, 5700, 35813, 36337, 5942, 36181, 36338, 36340, 5959, 36184, 
36341, 36339, 5960, 5958, 36183
14686, 35857, 5701, 5700, 35813, 35858, 5709, 5708, 35814, 36340, 5959, 36184, 36341, 36343, 5976, 36187, 
36344, 36342, 5977, 5975, 36186
14687, 35858, 5709, 5708, 35814, 35859, 5717, 5716, 35815, 36343, 5976, 36187, 36344, 36346, 5993, 36190, 
36347, 36345, 5994, 5992, 36189
14688, 35859, 5717, 5716, 35815, 35860, 5725, 5724, 35816, 36346, 5993, 36190, 36347, 36349, 6010, 36193, 
36350, 36348, 6011, 6009, 36192
14689, 35860, 5725, 5724, 35816, 35861, 5733, 5732, 35817, 36349, 6010, 36193, 36350, 36352, 6027, 36196, 
36353, 36351, 6028, 6026, 36195
14690, 35861, 5733, 5732, 35817, 35862, 5741, 5740, 35818, 36352, 6027, 36196, 36353, 36355, 6044, 36199, 
36356, 36354, 6045, 6043, 36198
14691, 35862, 5741, 5740, 35818, 35863, 5749, 5748, 35819, 36355, 6044, 36199, 36356, 36358, 6061, 36202, 
36359, 36357, 6062, 6060, 36201
14692, 35863, 5749, 5748, 35819, 35864, 5757, 5756, 35820, 36358, 6061, 36202, 36359, 36361, 6078, 36205, 
36362, 36360, 6079, 6077, 36204
14693, 35864, 5757, 5756, 35820, 35865, 5765, 5764, 35821, 36361, 6078, 36205, 36362, 36364, 6095, 36208, 
36365, 36363, 6096, 6094, 36207
14694, 35865, 5765, 5764, 35821, 35866, 5773, 5772, 35822, 36364, 6095, 36208, 36365, 36367, 6112, 36211, 
36368, 36366, 6113, 6111, 36210
14695, 35866, 5773, 5772, 35822, 35867, 5781, 5780, 35823, 36367, 6112, 36211, 36368, 36370, 6129, 36214, 
36371, 36369, 6130, 6128, 36213
14696, 35867, 5781, 5780, 35823, 35868, 5789, 5788, 35824, 36370, 6129, 36214, 36371, 36373, 6146, 36217, 
36374, 36372, 6147, 6145, 36216
14697, 35868, 5789, 5788, 35824, 35869, 5797, 5796, 35825, 36373, 6146, 36217, 36374, 36376, 6163, 36220, 
36377, 36375, 6164, 6162, 36219
14698, 35869, 5797, 5796, 35825, 5572, 526, 525, 5570, 36376, 6163, 36220, 36377, 5592, 534, 5587, 
5591, 36378, 6179, 6178, 36222
14699, 5232, 5231, 5229, 5230, 35870, 35848, 35804, 35826, 5253, 5250, 5248, 5252, 36380, 36314, 36224, 
36381, 36379, 36312, 36156, 36223
14700, 35870, 35848, 35804, 35826, 35871, 35849, 35805, 35827, 36380, 36314, 36224, 36381, 36383, 36317, 36227, 
36384, 36382, 36315, 36159, 36226
14701, 35871, 35849, 35805, 35827, 35872, 35850, 35806, 35828, 36383, 36317, 36227, 36384, 36386, 36320, 36230, 
36387, 36385, 36318, 36162, 36229
14702, 35872, 35850, 35806, 35828, 35873, 35851, 35807, 35829, 36386, 36320, 36230, 36387, 36389, 36323, 36233, 
36390, 36388, 36321, 36165, 36232
14703, 35873, 35851, 35807, 35829, 35874, 35852, 35808, 35830, 36389, 36323, 36233, 36390, 36392, 36326, 36236, 
36393, 36391, 36324, 36168, 36235
14704, 35874, 35852, 35808, 35830, 35875, 35853, 35809, 35831, 36392, 36326, 36236, 36393, 36395, 36329, 36239, 
36396, 36394, 36327, 36171, 36238
14705, 35875, 35853, 35809, 35831, 35876, 35854, 35810, 35832, 36395, 36329, 36239, 36396, 36398, 36332, 36242, 
36399, 36397, 36330, 36174, 36241
14706, 35876, 35854, 35810, 35832, 35877, 35855, 35811, 35833, 36398, 36332, 36242, 36399, 36401, 36335, 36245, 
36402, 36400, 36333, 36177, 36244
14707, 35877, 35855, 35811, 35833, 35878, 35856, 35812, 35834, 36401, 36335, 36245, 36402, 36404, 36338, 36248, 
36405, 36403, 36336, 36180, 36247
14708, 35878, 35856, 35812, 35834, 35879, 35857, 35813, 35835, 36404, 36338, 36248, 36405, 36407, 36341, 36251, 
36408, 36406, 36339, 36183, 36250
14709, 35879, 35857, 35813, 35835, 35880, 35858, 35814, 35836, 36407, 36341, 36251, 36408, 36410, 36344, 36254, 
36411, 36409, 36342, 36186, 36253
14710, 35880, 35858, 35814, 35836, 35881, 35859, 35815, 35837, 36410, 36344, 36254, 36411, 36413, 36347, 36257, 
36414, 36412, 36345, 36189, 36256
14711, 35881, 35859, 35815, 35837, 35882, 35860, 35816, 35838, 36413, 36347, 36257, 36414, 36416, 36350, 36260, 
36417, 36415, 36348, 36192, 36259
14712, 35882, 35860, 35816, 35838, 35883, 35861, 35817, 35839, 36416, 36350, 36260, 36417, 36419, 36353, 36263, 
36420, 36418, 36351, 36195, 36262
14713, 35883, 35861, 35817, 35839, 35884, 35862, 35818, 35840, 36419, 36353, 36263, 36420, 36422, 36356, 36266, 
36423, 36421, 36354, 36198, 36265
14714, 35884, 35862, 35818, 35840, 35885, 35863, 35819, 35841, 36422, 36356, 36266, 36423, 36425, 36359, 36269, 
36426, 36424, 36357, 36201, 36268
14715, 35885, 35863, 35819, 35841, 35886, 35864, 35820, 35842, 36425, 36359, 36269, 36426, 36428, 36362, 36272, 
36429, 36427, 36360, 36204, 36271
14716, 35886, 35864, 35820, 35842, 35887, 35865, 35821, 35843, 36428, 36362, 36272, 36429, 36431, 36365, 36275, 
36432, 36430, 36363, 36207, 36274
14717, 35887, 35865, 35821, 35843, 35888, 35866, 35822, 35844, 36431, 36365, 36275, 36432, 36434, 36368, 36278, 
36435, 36433, 36366, 36210, 36277
14718, 35888, 35866, 35822, 35844, 35889, 35867, 35823, 35845, 36434, 36368, 36278, 36435, 36437, 36371, 36281, 
36438, 36436, 36369, 36213, 36280
14719, 35889, 35867, 35823, 35845, 35890, 35868, 35824, 35846, 36437, 36371, 36281, 36438, 36440, 36374, 36284, 
36441, 36439, 36372, 36216, 36283
14720, 35890, 35868, 35824, 35846, 35891, 35869, 35825, 35847, 36440, 36374, 36284, 36441, 36443, 36377, 36287, 
36444, 36442, 36375, 36219, 36286
14721, 35891, 35869, 35825, 35847, 5573, 5572, 5570, 5571, 36443, 36377, 36287, 36444, 5594, 5591, 5589, 
5593, 36445, 36378, 36222, 36289
14722, 414, 5232, 5230, 413, 6187, 35870, 35826, 6186, 5254, 5252, 5249, 422, 36446, 36381, 36290, 
6365, 6364, 36379, 36223, 6362
14723, 6187, 35870, 35826, 6186, 6195, 35871, 35827, 6194, 36446, 36381, 36290, 6365, 36447, 36384, 36291, 
6382, 6381, 36382, 36226, 6379
14724, 6195, 35871, 35827, 6194, 6203, 35872, 35828, 6202, 36447, 36384, 36291, 6382, 36448, 36387, 36292, 
6399, 6398, 36385, 36229, 6396
14725, 6203, 35872, 35828, 6202, 6211, 35873, 35829, 6210, 36448, 36387, 36292, 6399, 36449, 36390, 36293, 
6416, 6415, 36388, 36232, 6413
14726, 6211, 35873, 35829, 6210, 6219, 35874, 35830, 6218, 36449, 36390, 36293, 6416, 36450, 36393, 36294, 
6433, 6432, 36391, 36235, 6430
14727, 6219, 35874, 35830, 6218, 6227, 35875, 35831, 6226, 36450, 36393, 36294, 6433, 36451, 36396, 36295, 
6450, 6449, 36394, 36238, 6447
14728, 6227, 35875, 35831, 6226, 6235, 35876, 35832, 6234, 36451, 36396, 36295, 6450, 36452, 36399, 36296, 
6467, 6466, 36397, 36241, 6464
14729, 6235, 35876, 35832, 6234, 6243, 35877, 35833, 6242, 36452, 36399, 36296, 6467, 36453, 36402, 36297, 
6484, 6483, 36400, 36244, 6481
14730, 6243, 35877, 35833, 6242, 6251, 35878, 35834, 6250, 36453, 36402, 36297, 6484, 36454, 36405, 36298, 
6501, 6500, 36403, 36247, 6498
14731, 6251, 35878, 35834, 6250, 6259, 35879, 35835, 6258, 36454, 36405, 36298, 6501, 36455, 36408, 36299, 
6518, 6517, 36406, 36250, 6515
14732, 6259, 35879, 35835, 6258, 6267, 35880, 35836, 6266, 36455, 36408, 36299, 6518, 36456, 36411, 36300, 
6535, 6534, 36409, 36253, 6532
14733, 6267, 35880, 35836, 6266, 6275, 35881, 35837, 6274, 36456, 36411, 36300, 6535, 36457, 36414, 36301, 
6552, 6551, 36412, 36256, 6549
14734, 6275, 35881, 35837, 6274, 6283, 35882, 35838, 6282, 36457, 36414, 36301, 6552, 36458, 36417, 36302, 
6569, 6568, 36415, 36259, 6566
14735, 6283, 35882, 35838, 6282, 6291, 35883, 35839, 6290, 36458, 36417, 36302, 6569, 36459, 36420, 36303, 
6586, 6585, 36418, 36262, 6583
14736, 6291, 35883, 35839, 6290, 6299, 35884, 35840, 6298, 36459, 36420, 36303, 6586, 36460, 36423, 36304, 
6603, 6602, 36421, 36265, 6600
14737, 6299, 35884, 35840, 6298, 6307, 35885, 35841, 6306, 36460, 36423, 36304, 6603, 36461, 36426, 36305, 
6620, 6619, 36424, 36268, 6617
14738, 6307, 35885, 35841, 6306, 6315, 35886, 35842, 6314, 36461, 36426, 36305, 6620, 36462, 36429, 36306, 
6637, 6636, 36427, 36271, 6634
14739, 6315, 35886, 35842, 6314, 6323, 35887, 35843, 6322, 36462, 36429, 36306, 6637, 36463, 36432, 36307, 
6654, 6653, 36430, 36274, 6651
14740, 6323, 35887, 35843, 6322, 6331, 35888, 35844, 6330, 36463, 36432, 36307, 6654, 36464, 36435, 36308, 
6671, 6670, 36433, 36277, 6668
14741, 6331, 35888, 35844, 6330, 6339, 35889, 35845, 6338, 36464, 36435, 36308, 6671, 36465, 36438, 36309, 
6688, 6687, 36436, 36280, 6685
14742, 6339, 35889, 35845, 6338, 6347, 35890, 35846, 6346, 36465, 36438, 36309, 6688, 36466, 36441, 36310, 
6705, 6704, 36439, 36283, 6702
14743, 6347, 35890, 35846, 6346, 6355, 35891, 35847, 6354, 36466, 36441, 36310, 6705, 36467, 36444, 36311, 
6722, 6721, 36442, 36286, 6719
14744, 6355, 35891, 35847, 6354, 548, 5573, 5571, 547, 36467, 36444, 36311, 6722, 5595, 5593, 5590, 
556, 6737, 36445, 36289, 6736
14745, 5233, 378, 377, 5231, 35892, 5630, 5629, 35848, 5256, 386, 5251, 5255, 36469, 5808, 36313, 
36470, 36468, 5809, 5807, 36312
14746, 35892, 5630, 5629, 35848, 35893, 5638, 5637, 35849, 36469, 5808, 36313, 36470, 36472, 5825, 36316, 
36473, 36471, 5826, 5824, 36315
14747, 35893, 5638, 5637, 35849, 35894, 5646, 5645, 35850, 36472, 5825, 36316, 36473, 36475, 5842, 36319, 
36476, 36474, 5843, 5841, 36318
14748, 35894, 5646, 5645, 35850, 35895, 5654, 5653, 35851, 36475, 5842, 36319, 36476, 36478, 5859, 36322, 
36479, 36477, 5860, 5858, 36321
14749, 35895, 5654, 5653, 35851, 35896, 5662, 5661, 35852, 36478, 5859, 36322, 36479, 36481, 5876, 36325, 
36482, 36480, 5877, 5875, 36324
14750, 35896, 5662, 5661, 35852, 35897, 5670, 5669, 35853, 36481, 5876, 36325, 36482, 36484, 5893, 36328, 
36485, 36483, 5894, 5892, 36327
14751, 35897, 5670, 5669, 35853, 35898, 5678, 5677, 35854, 36484, 5893, 36328, 36485, 36487, 5910, 36331, 
36488, 36486, 5911, 5909, 36330
14752, 35898, 5678, 5677, 35854, 35899, 5686, 5685, 35855, 36487, 5910, 36331, 36488, 36490, 5927, 36334, 
36491, 36489, 5928, 5926, 36333
14753, 35899, 5686, 5685, 35855, 35900, 5694, 5693, 35856, 36490, 5927, 36334, 36491, 36493, 5944, 36337, 
36494, 36492, 5945, 5943, 36336
14754, 35900, 5694, 5693, 35856, 35901, 5702, 5701, 35857, 36493, 5944, 36337, 36494, 36496, 5961, 36340, 
36497, 36495, 5962, 5960, 36339
14755, 35901, 5702, 5701, 35857, 35902, 5710, 5709, 35858, 36496, 5961, 36340, 36497, 36499, 5978, 36343, 
36500, 36498, 5979, 5977, 36342
14756, 35902, 5710, 5709, 35858, 35903, 5718, 5717, 35859, 36499, 5978, 36343, 36500, 36502, 5995, 36346, 
36503, 36501, 5996, 5994, 36345
14757, 35903, 5718, 5717, 35859, 35904, 5726, 5725, 35860, 36502, 5995, 36346, 36503, 36505, 6012, 36349, 
36506, 36504, 6013, 6011, 36348
14758, 35904, 5726, 5725, 35860, 35905, 5734, 5733, 35861, 36505, 6012, 36349, 36506, 36508, 6029, 36352, 
36509, 36507, 6030, 6028, 36351
14759, 35905, 5734, 5733, 35861, 35906, 5742, 5741, 35862, 36508, 6029, 36352, 36509, 36511, 6046, 36355, 
36512, 36510, 6047, 6045, 36354
14760, 35906, 5742, 5741, 35862, 35907, 5750, 5749, 35863, 36511, 6046, 36355, 36512, 36514, 6063, 36358, 
36515, 36513, 6064, 6062, 36357
14761, 35907, 5750, 5749, 35863, 35908, 5758, 5757, 35864, 36514, 6063, 36358, 36515, 36517, 6080, 36361, 
36518, 36516, 6081, 6079, 36360
14762, 35908, 5758, 5757, 35864, 35909, 5766, 5765, 35865, 36517, 6080, 36361, 36518, 36520, 6097, 36364, 
36521, 36519, 6098, 6096, 36363
14763, 35909, 5766, 5765, 35865, 35910, 5774, 5773, 35866, 36520, 6097, 36364, 36521, 36523, 6114, 36367, 
36524, 36522, 6115, 6113, 36366
14764, 35910, 5774, 5773, 35866, 35911, 5782, 5781, 35867, 36523, 6114, 36367, 36524, 36526, 6131, 36370, 
36527, 36525, 6132, 6130, 36369
14765, 35911, 5782, 5781, 35867, 35912, 5790, 5789, 35868, 36526, 6131, 36370, 36527, 36529, 6148, 36373, 
36530, 36528, 6149, 6147, 36372
14766, 35912, 5790, 5789, 35868, 35913, 5798, 5797, 35869, 36529, 6148, 36373, 36530, 36532, 6165, 36376, 
36533, 36531, 6166, 6164, 36375
14767, 35913, 5798, 5797, 35869, 5574, 527, 526, 5572, 36532, 6165, 36376, 36533, 5597, 535, 5592, 
5596, 36534, 6180, 6179, 36378
14768, 5234, 5233, 5231, 5232, 35914, 35892, 35848, 35870, 5258, 5255, 5253, 5257, 36536, 36470, 36380, 
36537, 36535, 36468, 36312, 36379
14769, 35914, 35892, 35848, 35870, 35915, 35893, 35849, 35871, 36536, 36470, 36380, 36537, 36539, 36473, 36383, 
36540, 36538, 36471, 36315, 36382
14770, 35915, 35893, 35849, 35871, 35916, 35894, 35850, 35872, 36539, 36473, 36383, 36540, 36542, 36476, 36386, 
36543, 36541, 36474, 36318, 36385
14771, 35916, 35894, 35850, 35872, 35917, 35895, 35851, 35873, 36542, 36476, 36386, 36543, 36545, 36479, 36389, 
36546, 36544, 36477, 36321, 36388
14772, 35917, 35895, 35851, 35873, 35918, 35896, 35852, 35874, 36545, 36479, 36389, 36546, 36548, 36482, 36392, 
36549, 36547, 36480, 36324, 36391
14773, 35918, 35896, 35852, 35874, 35919, 35897, 35853, 35875, 36548, 36482, 36392, 36549, 36551, 36485, 36395, 
36552, 36550, 36483, 36327, 36394
14774, 35919, 35897, 35853, 35875, 35920, 35898, 35854, 35876, 36551, 36485, 36395, 36552, 36554, 36488, 36398, 
36555, 36553, 36486, 36330, 36397
14775, 35920, 35898, 35854, 35876, 35921, 35899, 35855, 35877, 36554, 36488, 36398, 36555, 36557, 36491, 36401, 
36558, 36556, 36489, 36333, 36400
14776, 35921, 35899, 35855, 35877, 35922, 35900, 35856, 35878, 36557, 36491, 36401, 36558, 36560, 36494, 36404, 
36561, 36559, 36492, 36336, 36403
14777, 35922, 35900, 35856, 35878, 35923, 35901, 35857, 35879, 36560, 36494, 36404, 36561, 36563, 36497, 36407, 
36564, 36562, 36495, 36339, 36406
14778, 35923, 35901, 35857, 35879, 35924, 35902, 35858, 35880, 36563, 36497, 36407, 36564, 36566, 36500, 36410, 
36567, 36565, 36498, 36342, 36409
14779, 35924, 35902, 35858, 35880, 35925, 35903, 35859, 35881, 36566, 36500, 36410, 36567, 36569, 36503, 36413, 
36570, 36568, 36501, 36345, 36412
14780, 35925, 35903, 35859, 35881, 35926, 35904, 35860, 35882, 36569, 36503, 36413, 36570, 36572, 36506, 36416, 
36573, 36571, 36504, 36348, 36415
14781, 35926, 35904, 35860, 35882, 35927, 35905, 35861, 35883, 36572, 36506, 36416, 36573, 36575, 36509, 36419, 
36576, 36574, 36507, 36351, 36418
14782, 35927, 35905, 35861, 35883, 35928, 35906, 35862, 35884, 36575, 36509, 36419, 36576, 36578, 36512, 36422, 
36579, 36577, 36510, 36354, 36421
14783, 35928, 35906, 35862, 35884, 35929, 35907, 35863, 35885, 36578, 36512, 36422, 36579, 36581, 36515, 36425, 
36582, 36580, 36513, 36357, 36424
14784, 35929, 35907, 35863, 35885, 35930, 35908, 35864, 35886, 36581, 36515, 36425, 36582, 36584, 36518, 36428, 
36585, 36583, 36516, 36360, 36427
14785, 35930, 35908, 35864, 35886, 35931, 35909, 35865, 35887, 36584, 36518, 36428, 36585, 36587, 36521, 36431, 
36588, 36586, 36519, 36363, 36430
14786, 35931, 35909, 35865, 35887, 35932, 35910, 35866, 35888, 36587, 36521, 36431, 36588, 36590, 36524, 36434, 
36591, 36589, 36522, 36366, 36433
14787, 35932, 35910, 35866, 35888, 35933, 35911, 35867, 35889, 36590, 36524, 36434, 36591, 36593, 36527, 36437, 
36594, 36592, 36525, 36369, 36436
14788, 35933, 35911, 35867, 35889, 35934, 35912, 35868, 35890, 36593, 36527, 36437, 36594, 36596, 36530, 36440, 
36597, 36595, 36528, 36372, 36439
14789, 35934, 35912, 35868, 35890, 35935, 35913, 35869, 35891, 36596, 36530, 36440, 36597, 36599, 36533, 36443, 
36600, 36598, 36531, 36375, 36442
14790, 35935, 35913, 35869, 35891, 5575, 5574, 5572, 5573, 36599, 36533, 36443, 36600, 5599, 5596, 5594, 
5598, 36601, 36534, 36378, 36445
14791, 415, 5234, 5232, 414, 6188, 35914, 35870, 6187, 5259, 5257, 5254, 423, 36602, 36537, 36446, 
6367, 6366, 36535, 36379, 6364
14792, 6188, 35914, 35870, 6187, 6196, 35915, 35871, 6195, 36602, 36537, 36446, 6367, 36603, 36540, 36447, 
6384, 6383, 36538, 36382, 6381
14793, 6196, 35915, 35871, 6195, 6204, 35916, 35872, 6203, 36603, 36540, 36447, 6384, 36604, 36543, 36448, 
6401, 6400, 36541, 36385, 6398
14794, 6204, 35916, 35872, 6203, 6212, 35917, 35873, 6211, 36604, 36543, 36448, 6401, 36605, 36546, 36449, 
6418, 6417, 36544, 36388, 6415
14795, 6212, 35917, 35873, 6211, 6220, 35918, 35874, 6219, 36605, 36546, 36449, 6418, 36606, 36549, 36450, 
6435, 6434, 36547, 36391, 6432
14796, 6220, 35918, 35874, 6219, 6228, 35919, 35875, 6227, 36606, 36549, 36450, 6435, 36607, 36552, 36451, 
6452, 6451, 36550, 36394, 6449
14797, 6228, 35919, 35875, 6227, 6236, 35920, 35876, 6235, 36607, 36552, 36451, 6452, 36608, 36555, 36452, 
6469, 6468, 36553, 36397, 6466
14798, 6236, 35920, 35876, 6235, 6244, 35921, 35877, 6243, 36608, 36555, 36452, 6469, 36609, 36558, 36453, 
6486, 6485, 36556, 36400, 6483
14799, 6244, 35921, 35877, 6243, 6252, 35922, 35878, 6251, 36609, 36558, 36453, 6486, 36610, 36561, 36454, 
6503, 6502, 36559, 36403, 6500
14800, 6252, 35922, 35878, 6251, 6260, 35923, 35879, 6259, 36610, 36561, 36454, 6503, 36611, 36564, 36455, 
6520, 6519, 36562, 36406, 6517
14801, 6260, 35923, 35879, 6259, 6268, 35924, 35880, 6267, 36611, 36564, 36455, 6520, 36612, 36567, 36456, 
6537, 6536, 36565, 36409, 6534
14802, 6268, 35924, 35880, 6267, 6276, 35925, 35881, 6275, 36612, 36567, 36456, 6537, 36613, 36570, 36457, 
6554, 6553, 36568, 36412, 6551
14803, 6276, 35925, 35881, 6275, 6284, 35926, 35882, 6283, 36613, 36570, 36457, 6554, 36614, 36573, 36458, 
6571, 6570, 36571, 36415, 6568
14804, 6284, 35926, 35882, 6283, 6292, 35927, 35883, 6291, 36614, 36573, 36458, 6571, 36615, 36576, 36459, 
6588, 6587, 36574, 36418, 6585
14805, 6292, 35927, 35883, 6291, 6300, 35928, 35884, 6299, 36615, 36576, 36459, 6588, 36616, 36579, 36460, 
6605, 6604, 36577, 36421, 6602
14806, 6300, 35928, 35884, 6299, 6308, 35929, 35885, 6307, 36616, 36579, 36460, 6605, 36617, 36582, 36461, 
6622, 6621, 36580, 36424, 6619
14807, 6308, 35929, 35885, 6307, 6316, 35930, 35886, 6315, 36617, 36582, 36461, 6622, 36618, 36585, 36462, 
6639, 6638, 36583, 36427, 6636
14808, 6316, 35930, 35886, 6315, 6324, 35931, 35887, 6323, 36618, 36585, 36462, 6639, 36619, 36588, 36463, 
6656, 6655, 36586, 36430, 6653
14809, 6324, 35931, 35887, 6323, 6332, 35932, 35888, 6331, 36619, 36588, 36463, 6656, 36620, 36591, 36464, 
6673, 6672, 36589, 36433, 6670
14810, 6332, 35932, 35888, 6331, 6340, 35933, 35889, 6339, 36620, 36591, 36464, 6673, 36621, 36594, 36465, 
6690, 6689, 36592, 36436, 6687
14811, 6340, 35933, 35889, 6339, 6348, 35934, 35890, 6347, 36621, 36594, 36465, 6690, 36622, 36597, 36466, 
6707, 6706, 36595, 36439, 6704
14812, 6348, 35934, 35890, 6347, 6356, 35935, 35891, 6355, 36622, 36597, 36466, 6707, 36623, 36600, 36467, 
6724, 6723, 36598, 36442, 6721
14813, 6356, 35935, 35891, 6355, 549, 5575, 5573, 548, 36623, 36600, 36467, 6724, 5600, 5598, 5595, 
557, 6738, 36601, 36445, 6737
14814, 5235, 379, 378, 5233, 35936, 5631, 5630, 35892, 5261, 387, 5256, 5260, 36625, 5810, 36469, 
36626, 36624, 5811, 5809, 36468
14815, 35936, 5631, 5630, 35892, 35937, 5639, 5638, 35893, 36625, 5810, 36469, 36626, 36628, 5827, 36472, 
36629, 36627, 5828, 5826, 36471
14816, 35937, 5639, 5638, 35893, 35938, 5647, 5646, 35894, 36628, 5827, 36472, 36629, 36631, 5844, 36475, 
36632, 36630, 5845, 5843, 36474
14817, 35938, 5647, 5646, 35894, 35939, 5655, 5654, 35895, 36631, 5844, 36475, 36632, 36634, 5861, 36478, 
36635, 36633, 5862, 5860, 36477
14818, 35939, 5655, 5654, 35895, 35940, 5663, 5662, 35896, 36634, 5861, 36478, 36635, 36637, 5878, 36481, 
36638, 36636, 5879, 5877, 36480
14819, 35940, 5663, 5662, 35896, 35941, 5671, 5670, 35897, 36637, 5878, 36481, 36638, 36640, 5895, 36484, 
36641, 36639, 5896, 5894, 36483
14820, 35941, 5671, 5670, 35897, 35942, 5679, 5678, 35898, 36640, 5895, 36484, 36641, 36643, 5912, 36487, 
36644, 36642, 5913, 5911, 36486
14821, 35942, 5679, 5678, 35898, 35943, 5687, 5686, 35899, 36643, 5912, 36487, 36644, 36646, 5929, 36490, 
36647, 36645, 5930, 5928, 36489
14822, 35943, 5687, 5686, 35899, 35944, 5695, 5694, 35900, 36646, 5929, 36490, 36647, 36649, 5946, 36493, 
36650, 36648, 5947, 5945, 36492
14823, 35944, 5695, 5694, 35900, 35945, 5703, 5702, 35901, 36649, 5946, 36493, 36650, 36652, 5963, 36496, 
36653, 36651, 5964, 5962, 36495
14824, 35945, 5703, 5702, 35901, 35946, 5711, 5710, 35902, 36652, 5963, 36496, 36653, 36655, 5980, 36499, 
36656, 36654, 5981, 5979, 36498
14825, 35946, 5711, 5710, 35902, 35947, 5719, 5718, 35903, 36655, 5980, 36499, 36656, 36658, 5997, 36502, 
36659, 36657, 5998, 5996, 36501
14826, 35947, 5719, 5718, 35903, 35948, 5727, 5726, 35904, 36658, 5997, 36502, 36659, 36661, 6014, 36505, 
36662, 36660, 6015, 6013, 36504
14827, 35948, 5727, 5726, 35904, 35949, 5735, 5734, 35905, 36661, 6014, 36505, 36662, 36664, 6031, 36508, 
36665, 36663, 6032, 6030, 36507
14828, 35949, 5735, 5734, 35905, 35950, 5743, 5742, 35906, 36664, 6031, 36508, 36665, 36667, 6048, 36511, 
36668, 36666, 6049, 6047, 36510
14829, 35950, 5743, 5742, 35906, 35951, 5751, 5750, 35907, 36667, 6048, 36511, 36668, 36670, 6065, 36514, 
36671, 36669, 6066, 6064, 36513
14830, 35951, 5751, 5750, 35907, 35952, 5759, 5758, 35908, 36670, 6065, 36514, 36671, 36673, 6082, 36517, 
36674, 36672, 6083, 6081, 36516
