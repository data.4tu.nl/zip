73972, 1.2869565217391, 0.35869565217391, 0.41666666666667
73973, 1.2652173913043, 0.35869565217391, 0.38888888888889
73974, 1.2869565217391, 0.38478260869565, 0.38888888888889
73975, 1.2869565217391, 0.35869565217391, 0.36111111111111
73976, 1.2652173913043, 0.35869565217391, 0.33333333333333
73977, 1.2869565217391, 0.38478260869565, 0.33333333333333
73978, 1.2869565217391, 0.35869565217391, 0.30555555555556
73979, 1.2652173913043, 0.35869565217391, 0.27777777777778
73980, 1.2869565217391, 0.38478260869565, 0.27777777777778
73981, 1.2869565217391, 0.35869565217391, 0.25
73982, 1.2652173913043, 0.35869565217391, 0.22222222222222
73983, 1.2869565217391, 0.38478260869565, 0.22222222222222
73984, 1.2869565217391, 0.35869565217391, 0.19444444444444
73985, 1.2652173913043, 0.35869565217391, 0.16666666666667
73986, 1.2869565217391, 0.38478260869565, 0.16666666666667
73987, 1.2869565217391, 0.35869565217391, 0.13888888888889
73988, 1.2652173913043, 0.35869565217391, 0.11111111111111
73989, 1.2869565217391, 0.38478260869565, 0.11111111111111
73990, 1.2869565217391, 0.35869565217391, 0.083333333333333
73991, 1.2652173913043, 0.35869565217391, 0.055555555555556
73992, 1.2869565217391, 0.38478260869565, 0.055555555555556
73993, 1.2869565217391, 0.35869565217391, 0.027777777777778
73994, 1.3304347826087, 0.35869565217391, 0.47222222222222
73995, 1.3086956521739, 0.35869565217391, 0.44444444444444
73996, 1.3304347826087, 0.38478260869565, 0.44444444444444
73997, 1.3304347826087, 0.35869565217391, 0.41666666666667
73998, 1.3086956521739, 0.35869565217391, 0.38888888888889
73999, 1.3304347826087, 0.38478260869565, 0.38888888888889
74000, 1.3304347826087, 0.35869565217391, 0.36111111111111
74001, 1.3086956521739, 0.35869565217391, 0.33333333333333
74002, 1.3304347826087, 0.38478260869565, 0.33333333333333
74003, 1.3304347826087, 0.35869565217391, 0.30555555555556
74004, 1.3086956521739, 0.35869565217391, 0.27777777777778
74005, 1.3304347826087, 0.38478260869565, 0.27777777777778
74006, 1.3304347826087, 0.35869565217391, 0.25
74007, 1.3086956521739, 0.35869565217391, 0.22222222222222
74008, 1.3304347826087, 0.38478260869565, 0.22222222222222
74009, 1.3304347826087, 0.35869565217391, 0.19444444444444
74010, 1.3086956521739, 0.35869565217391, 0.16666666666667
74011, 1.3304347826087, 0.38478260869565, 0.16666666666667
74012, 1.3304347826087, 0.35869565217391, 0.13888888888889
74013, 1.3086956521739, 0.35869565217391, 0.11111111111111
74014, 1.3304347826087, 0.38478260869565, 0.11111111111111
74015, 1.3304347826087, 0.35869565217391, 0.083333333333333
74016, 1.3086956521739, 0.35869565217391, 0.055555555555556
74017, 1.3304347826087, 0.38478260869565, 0.055555555555556
74018, 1.3304347826087, 0.35869565217391, 0.027777777777778
74019, 1.3739130434783, 0.35869565217391, 0.47222222222222
74020, 1.3521739130435, 0.35869565217391, 0.44444444444444
74021, 1.3739130434783, 0.38478260869565, 0.44444444444444
74022, 1.3739130434783, 0.35869565217391, 0.41666666666667
74023, 1.3521739130435, 0.35869565217391, 0.38888888888889
74024, 1.3739130434783, 0.38478260869565, 0.38888888888889
74025, 1.3739130434783, 0.35869565217391, 0.36111111111111
74026, 1.3521739130435, 0.35869565217391, 0.33333333333333
74027, 1.3739130434783, 0.38478260869565, 0.33333333333333
74028, 1.3739130434783, 0.35869565217391, 0.30555555555556
74029, 1.3521739130435, 0.35869565217391, 0.27777777777778
74030, 1.3739130434783, 0.38478260869565, 0.27777777777778
74031, 1.3739130434783, 0.35869565217391, 0.25
74032, 1.3521739130435, 0.35869565217391, 0.22222222222222
74033, 1.3739130434783, 0.38478260869565, 0.22222222222222
74034, 1.3739130434783, 0.35869565217391, 0.19444444444444
74035, 1.3521739130435, 0.35869565217391, 0.16666666666667
74036, 1.3739130434783, 0.38478260869565, 0.16666666666667
74037, 1.3739130434783, 0.35869565217391, 0.13888888888889
74038, 1.3521739130435, 0.35869565217391, 0.11111111111111
74039, 1.3739130434783, 0.38478260869565, 0.11111111111111
74040, 1.3739130434783, 0.35869565217391, 0.083333333333333
74041, 1.3521739130435, 0.35869565217391, 0.055555555555556
74042, 1.3739130434783, 0.38478260869565, 0.055555555555556
74043, 1.3739130434783, 0.35869565217391, 0.027777777777778
74044, 1.4173913043478, 0.35869565217391, 0.47222222222222
74045, 1.395652173913, 0.35869565217391, 0.44444444444444
74046, 1.4173913043478, 0.38478260869565, 0.44444444444444
74047, 1.4173913043478, 0.35869565217391, 0.41666666666667
74048, 1.395652173913, 0.35869565217391, 0.38888888888889
74049, 1.4173913043478, 0.38478260869565, 0.38888888888889
74050, 1.4173913043478, 0.35869565217391, 0.36111111111111
74051, 1.395652173913, 0.35869565217391, 0.33333333333333
74052, 1.4173913043478, 0.38478260869565, 0.33333333333333
74053, 1.4173913043478, 0.35869565217391, 0.30555555555556
74054, 1.395652173913, 0.35869565217391, 0.27777777777778
74055, 1.4173913043478, 0.38478260869565, 0.27777777777778
74056, 1.4173913043478, 0.35869565217391, 0.25
74057, 1.395652173913, 0.35869565217391, 0.22222222222222
74058, 1.4173913043478, 0.38478260869565, 0.22222222222222
74059, 1.4173913043478, 0.35869565217391, 0.19444444444444
74060, 1.395652173913, 0.35869565217391, 0.16666666666667
74061, 1.4173913043478, 0.38478260869565, 0.16666666666667
74062, 1.4173913043478, 0.35869565217391, 0.13888888888889
74063, 1.395652173913, 0.35869565217391, 0.11111111111111
74064, 1.4173913043478, 0.38478260869565, 0.11111111111111
74065, 1.4173913043478, 0.35869565217391, 0.083333333333333
74066, 1.395652173913, 0.35869565217391, 0.055555555555556
74067, 1.4173913043478, 0.38478260869565, 0.055555555555556
74068, 1.4173913043478, 0.35869565217391, 0.027777777777778
74069, 1.4608695652174, 0.35869565217391, 0.47222222222222
74070, 1.4391304347826, 0.35869565217391, 0.44444444444444
74071, 1.4608695652174, 0.38478260869565, 0.44444444444444
74072, 1.4608695652174, 0.35869565217391, 0.41666666666667
74073, 1.4391304347826, 0.35869565217391, 0.38888888888889
74074, 1.4608695652174, 0.38478260869565, 0.38888888888889
74075, 1.4608695652174, 0.35869565217391, 0.36111111111111
74076, 1.4391304347826, 0.35869565217391, 0.33333333333333
74077, 1.4608695652174, 0.38478260869565, 0.33333333333333
74078, 1.4608695652174, 0.35869565217391, 0.30555555555556
74079, 1.4391304347826, 0.35869565217391, 0.27777777777778
74080, 1.4608695652174, 0.38478260869565, 0.27777777777778
74081, 1.4608695652174, 0.35869565217391, 0.25
74082, 1.4391304347826, 0.35869565217391, 0.22222222222222
74083, 1.4608695652174, 0.38478260869565, 0.22222222222222
74084, 1.4608695652174, 0.35869565217391, 0.19444444444444
74085, 1.4391304347826, 0.35869565217391, 0.16666666666667
74086, 1.4608695652174, 0.38478260869565, 0.16666666666667
74087, 1.4608695652174, 0.35869565217391, 0.13888888888889
74088, 1.4391304347826, 0.35869565217391, 0.11111111111111
74089, 1.4608695652174, 0.38478260869565, 0.11111111111111
74090, 1.4608695652174, 0.35869565217391, 0.083333333333333
74091, 1.4391304347826, 0.35869565217391, 0.055555555555556
74092, 1.4608695652174, 0.38478260869565, 0.055555555555556
74093, 1.4608695652174, 0.35869565217391, 0.027777777777778
74094, 1.504347826087, 0.35869565217391, 0.47222222222222
74095, 1.4826086956522, 0.35869565217391, 0.44444444444444
74096, 1.504347826087, 0.38478260869565, 0.44444444444444
74097, 1.504347826087, 0.35869565217391, 0.41666666666667
74098, 1.4826086956522, 0.35869565217391, 0.38888888888889
74099, 1.504347826087, 0.38478260869565, 0.38888888888889
74100, 1.504347826087, 0.35869565217391, 0.36111111111111
74101, 1.4826086956522, 0.35869565217391, 0.33333333333333
74102, 1.504347826087, 0.38478260869565, 0.33333333333333
74103, 1.504347826087, 0.35869565217391, 0.30555555555556
74104, 1.4826086956522, 0.35869565217391, 0.27777777777778
74105, 1.504347826087, 0.38478260869565, 0.27777777777778
74106, 1.504347826087, 0.35869565217391, 0.25
74107, 1.4826086956522, 0.35869565217391, 0.22222222222222
74108, 1.504347826087, 0.38478260869565, 0.22222222222222
74109, 1.504347826087, 0.35869565217391, 0.19444444444444
74110, 1.4826086956522, 0.35869565217391, 0.16666666666667
74111, 1.504347826087, 0.38478260869565, 0.16666666666667
74112, 1.504347826087, 0.35869565217391, 0.13888888888889
74113, 1.4826086956522, 0.35869565217391, 0.11111111111111
74114, 1.504347826087, 0.38478260869565, 0.11111111111111
74115, 1.504347826087, 0.35869565217391, 0.083333333333333
74116, 1.4826086956522, 0.35869565217391, 0.055555555555556
74117, 1.504347826087, 0.38478260869565, 0.055555555555556
74118, 1.504347826087, 0.35869565217391, 0.027777777777778
74119, 1.5478260869565, 0.35869565217391, 0.47222222222222
74120, 1.5260869565217, 0.35869565217391, 0.44444444444444
74121, 1.5478260869565, 0.38478260869565, 0.44444444444444
74122, 1.5478260869565, 0.35869565217391, 0.41666666666667
74123, 1.5260869565217, 0.35869565217391, 0.38888888888889
74124, 1.5478260869565, 0.38478260869565, 0.38888888888889
74125, 1.5478260869565, 0.35869565217391, 0.36111111111111
74126, 1.5260869565217, 0.35869565217391, 0.33333333333333
74127, 1.5478260869565, 0.38478260869565, 0.33333333333333
74128, 1.5478260869565, 0.35869565217391, 0.30555555555556
74129, 1.5260869565217, 0.35869565217391, 0.27777777777778
74130, 1.5478260869565, 0.38478260869565, 0.27777777777778
74131, 1.5478260869565, 0.35869565217391, 0.25
74132, 1.5260869565217, 0.35869565217391, 0.22222222222222
74133, 1.5478260869565, 0.38478260869565, 0.22222222222222
74134, 1.5478260869565, 0.35869565217391, 0.19444444444444
74135, 1.5260869565217, 0.35869565217391, 0.16666666666667
74136, 1.5478260869565, 0.38478260869565, 0.16666666666667
74137, 1.5478260869565, 0.35869565217391, 0.13888888888889
74138, 1.5260869565217, 0.35869565217391, 0.11111111111111
74139, 1.5478260869565, 0.38478260869565, 0.11111111111111
74140, 1.5478260869565, 0.35869565217391, 0.083333333333333
74141, 1.5260869565217, 0.35869565217391, 0.055555555555556
74142, 1.5478260869565, 0.38478260869565, 0.055555555555556
74143, 1.5478260869565, 0.35869565217391, 0.027777777777778
74144, 1.5913043478261, 0.35869565217391, 0.47222222222222
74145, 1.5695652173913, 0.35869565217391, 0.44444444444444
74146, 1.5913043478261, 0.38478260869565, 0.44444444444444
74147, 1.5913043478261, 0.35869565217391, 0.41666666666667
74148, 1.5695652173913, 0.35869565217391, 0.38888888888889
74149, 1.5913043478261, 0.38478260869565, 0.38888888888889
74150, 1.5913043478261, 0.35869565217391, 0.36111111111111
74151, 1.5695652173913, 0.35869565217391, 0.33333333333333
74152, 1.5913043478261, 0.38478260869565, 0.33333333333333
74153, 1.5913043478261, 0.35869565217391, 0.30555555555556
74154, 1.5695652173913, 0.35869565217391, 0.27777777777778
74155, 1.5913043478261, 0.38478260869565, 0.27777777777778
74156, 1.5913043478261, 0.35869565217391, 0.25
74157, 1.5695652173913, 0.35869565217391, 0.22222222222222
74158, 1.5913043478261, 0.38478260869565, 0.22222222222222
74159, 1.5913043478261, 0.35869565217391, 0.19444444444444
74160, 1.5695652173913, 0.35869565217391, 0.16666666666667
74161, 1.5913043478261, 0.38478260869565, 0.16666666666667
74162, 1.5913043478261, 0.35869565217391, 0.13888888888889
74163, 1.5695652173913, 0.35869565217391, 0.11111111111111
74164, 1.5913043478261, 0.38478260869565, 0.11111111111111
74165, 1.5913043478261, 0.35869565217391, 0.083333333333333
74166, 1.5695652173913, 0.35869565217391, 0.055555555555556
74167, 1.5913043478261, 0.38478260869565, 0.055555555555556
74168, 1.5913043478261, 0.35869565217391, 0.027777777777778
74169, 1.6347826086957, 0.35869565217391, 0.47222222222222
74170, 1.6130434782609, 0.35869565217391, 0.44444444444444
74171, 1.6347826086957, 0.38478260869565, 0.44444444444444
74172, 1.6347826086957, 0.35869565217391, 0.41666666666667
74173, 1.6130434782609, 0.35869565217391, 0.38888888888889
74174, 1.6347826086957, 0.38478260869565, 0.38888888888889
74175, 1.6347826086957, 0.35869565217391, 0.36111111111111
74176, 1.6130434782609, 0.35869565217391, 0.33333333333333
74177, 1.6347826086957, 0.38478260869565, 0.33333333333333
74178, 1.6347826086957, 0.35869565217391, 0.30555555555556
74179, 1.6130434782609, 0.35869565217391, 0.27777777777778
74180, 1.6347826086957, 0.38478260869565, 0.27777777777778
74181, 1.6347826086957, 0.35869565217391, 0.25
74182, 1.6130434782609, 0.35869565217391, 0.22222222222222
74183, 1.6347826086957, 0.38478260869565, 0.22222222222222
74184, 1.6347826086957, 0.35869565217391, 0.19444444444444
74185, 1.6130434782609, 0.35869565217391, 0.16666666666667
74186, 1.6347826086957, 0.38478260869565, 0.16666666666667
74187, 1.6347826086957, 0.35869565217391, 0.13888888888889
74188, 1.6130434782609, 0.35869565217391, 0.11111111111111
74189, 1.6347826086957, 0.38478260869565, 0.11111111111111
74190, 1.6347826086957, 0.35869565217391, 0.083333333333333
74191, 1.6130434782609, 0.35869565217391, 0.055555555555556
74192, 1.6347826086957, 0.38478260869565, 0.055555555555556
74193, 1.6347826086957, 0.35869565217391, 0.027777777777778
74194, 1.6782608695652, 0.35869565217391, 0.47222222222222
74195, 1.6565217391304, 0.35869565217391, 0.44444444444444
74196, 1.6782608695652, 0.38478260869565, 0.44444444444444
74197, 1.6782608695652, 0.35869565217391, 0.41666666666667
74198, 1.6565217391304, 0.35869565217391, 0.38888888888889
74199, 1.6782608695652, 0.38478260869565, 0.38888888888889
74200, 1.6782608695652, 0.35869565217391, 0.36111111111111
74201, 1.6565217391304, 0.35869565217391, 0.33333333333333
74202, 1.6782608695652, 0.38478260869565, 0.33333333333333
74203, 1.6782608695652, 0.35869565217391, 0.30555555555556
74204, 1.6565217391304, 0.35869565217391, 0.27777777777778
74205, 1.6782608695652, 0.38478260869565, 0.27777777777778
74206, 1.6782608695652, 0.35869565217391, 0.25
74207, 1.6565217391304, 0.35869565217391, 0.22222222222222
74208, 1.6782608695652, 0.38478260869565, 0.22222222222222
74209, 1.6782608695652, 0.35869565217391, 0.19444444444444
74210, 1.6565217391304, 0.35869565217391, 0.16666666666667
74211, 1.6782608695652, 0.38478260869565, 0.16666666666667
74212, 1.6782608695652, 0.35869565217391, 0.13888888888889
74213, 1.6565217391304, 0.35869565217391, 0.11111111111111
74214, 1.6782608695652, 0.38478260869565, 0.11111111111111
74215, 1.6782608695652, 0.35869565217391, 0.083333333333333
74216, 1.6565217391304, 0.35869565217391, 0.055555555555556
74217, 1.6782608695652, 0.38478260869565, 0.055555555555556
74218, 1.6782608695652, 0.35869565217391, 0.027777777777778
74219, 1.7217391304348, 0.35869565217391, 0.47222222222222
74220, 1.7, 0.35869565217391, 0.44444444444444
74221, 1.7217391304348, 0.38478260869565, 0.44444444444444
74222, 1.7217391304348, 0.35869565217391, 0.41666666666667
74223, 1.7, 0.35869565217391, 0.38888888888889
74224, 1.7217391304348, 0.38478260869565, 0.38888888888889
74225, 1.7217391304348, 0.35869565217391, 0.36111111111111
74226, 1.7, 0.35869565217391, 0.33333333333333
74227, 1.7217391304348, 0.38478260869565, 0.33333333333333
74228, 1.7217391304348, 0.35869565217391, 0.30555555555556
74229, 1.7, 0.35869565217391, 0.27777777777778
74230, 1.7217391304348, 0.38478260869565, 0.27777777777778
74231, 1.7217391304348, 0.35869565217391, 0.25
74232, 1.7, 0.35869565217391, 0.22222222222222
74233, 1.7217391304348, 0.38478260869565, 0.22222222222222
74234, 1.7217391304348, 0.35869565217391, 0.19444444444444
74235, 1.7, 0.35869565217391, 0.16666666666667
74236, 1.7217391304348, 0.38478260869565, 0.16666666666667
74237, 1.7217391304348, 0.35869565217391, 0.13888888888889
74238, 1.7, 0.35869565217391, 0.11111111111111
74239, 1.7217391304348, 0.38478260869565, 0.11111111111111
74240, 1.7217391304348, 0.35869565217391, 0.083333333333333
74241, 1.7, 0.35869565217391, 0.055555555555556
74242, 1.7217391304348, 0.38478260869565, 0.055555555555556
74243, 1.7217391304348, 0.35869565217391, 0.027777777777778
74244, 1.7652173913043, 0.35869565217391, 0.47222222222222
74245, 1.7434782608696, 0.35869565217391, 0.44444444444444
74246, 1.7652173913043, 0.38478260869565, 0.44444444444444
74247, 1.7652173913043, 0.35869565217391, 0.41666666666667
74248, 1.7434782608696, 0.35869565217391, 0.38888888888889
74249, 1.7652173913043, 0.38478260869565, 0.38888888888889
74250, 1.7652173913043, 0.35869565217391, 0.36111111111111
74251, 1.7434782608696, 0.35869565217391, 0.33333333333333
74252, 1.7652173913043, 0.38478260869565, 0.33333333333333
74253, 1.7652173913043, 0.35869565217391, 0.30555555555556
74254, 1.7434782608696, 0.35869565217391, 0.27777777777778
74255, 1.7652173913043, 0.38478260869565, 0.27777777777778
74256, 1.7652173913043, 0.35869565217391, 0.25
74257, 1.7434782608696, 0.35869565217391, 0.22222222222222
74258, 1.7652173913043, 0.38478260869565, 0.22222222222222
74259, 1.7652173913043, 0.35869565217391, 0.19444444444444
74260, 1.7434782608696, 0.35869565217391, 0.16666666666667
74261, 1.7652173913043, 0.38478260869565, 0.16666666666667
74262, 1.7652173913043, 0.35869565217391, 0.13888888888889
74263, 1.7434782608696, 0.35869565217391, 0.11111111111111
74264, 1.7652173913043, 0.38478260869565, 0.11111111111111
74265, 1.7652173913043, 0.35869565217391, 0.083333333333333
74266, 1.7434782608696, 0.35869565217391, 0.055555555555556
74267, 1.7652173913043, 0.38478260869565, 0.055555555555556
74268, 1.7652173913043, 0.35869565217391, 0.027777777777778
74269, 1.8086956521739, 0.35869565217391, 0.47222222222222
74270, 1.7869565217391, 0.35869565217391, 0.44444444444444
74271, 1.8086956521739, 0.38478260869565, 0.44444444444444
74272, 1.8086956521739, 0.35869565217391, 0.41666666666667
74273, 1.7869565217391, 0.35869565217391, 0.38888888888889
74274, 1.8086956521739, 0.38478260869565, 0.38888888888889
74275, 1.8086956521739, 0.35869565217391, 0.36111111111111
74276, 1.7869565217391, 0.35869565217391, 0.33333333333333
74277, 1.8086956521739, 0.38478260869565, 0.33333333333333
74278, 1.8086956521739, 0.35869565217391, 0.30555555555556
74279, 1.7869565217391, 0.35869565217391, 0.27777777777778
74280, 1.8086956521739, 0.38478260869565, 0.27777777777778
74281, 1.8086956521739, 0.35869565217391, 0.25
74282, 1.7869565217391, 0.35869565217391, 0.22222222222222
74283, 1.8086956521739, 0.38478260869565, 0.22222222222222
74284, 1.8086956521739, 0.35869565217391, 0.19444444444444
74285, 1.7869565217391, 0.35869565217391, 0.16666666666667
74286, 1.8086956521739, 0.38478260869565, 0.16666666666667
74287, 1.8086956521739, 0.35869565217391, 0.13888888888889
74288, 1.7869565217391, 0.35869565217391, 0.11111111111111
74289, 1.8086956521739, 0.38478260869565, 0.11111111111111
74290, 1.8086956521739, 0.35869565217391, 0.083333333333333
74291, 1.7869565217391, 0.35869565217391, 0.055555555555556
74292, 1.8086956521739, 0.38478260869565, 0.055555555555556
74293, 1.8086956521739, 0.35869565217391, 0.027777777777778
74294, 1.8521739130435, 0.35869565217391, 0.47222222222222
74295, 1.8304347826087, 0.35869565217391, 0.44444444444444
74296, 1.8521739130435, 0.38478260869565, 0.44444444444444
74297, 1.8521739130435, 0.35869565217391, 0.41666666666667
74298, 1.8304347826087, 0.35869565217391, 0.38888888888889
74299, 1.8521739130435, 0.38478260869565, 0.38888888888889
74300, 1.8521739130435, 0.35869565217391, 0.36111111111111
74301, 1.8304347826087, 0.35869565217391, 0.33333333333333
74302, 1.8521739130435, 0.38478260869565, 0.33333333333333
74303, 1.8521739130435, 0.35869565217391, 0.30555555555556
74304, 1.8304347826087, 0.35869565217391, 0.27777777777778
74305, 1.8521739130435, 0.38478260869565, 0.27777777777778
74306, 1.8521739130435, 0.35869565217391, 0.25
74307, 1.8304347826087, 0.35869565217391, 0.22222222222222
74308, 1.8521739130435, 0.38478260869565, 0.22222222222222
74309, 1.8521739130435, 0.35869565217391, 0.19444444444444
74310, 1.8304347826087, 0.35869565217391, 0.16666666666667
74311, 1.8521739130435, 0.38478260869565, 0.16666666666667
74312, 1.8521739130435, 0.35869565217391, 0.13888888888889
74313, 1.8304347826087, 0.35869565217391, 0.11111111111111
74314, 1.8521739130435, 0.38478260869565, 0.11111111111111
74315, 1.8521739130435, 0.35869565217391, 0.083333333333333
74316, 1.8304347826087, 0.35869565217391, 0.055555555555556
74317, 1.8521739130435, 0.38478260869565, 0.055555555555556
74318, 1.8521739130435, 0.35869565217391, 0.027777777777778
74319, 1.895652173913, 0.35869565217391, 0.47222222222222
74320, 1.8739130434783, 0.35869565217391, 0.44444444444444
74321, 1.895652173913, 0.38478260869565, 0.44444444444444
74322, 1.895652173913, 0.35869565217391, 0.41666666666667
74323, 1.8739130434783, 0.35869565217391, 0.38888888888889
74324, 1.895652173913, 0.38478260869565, 0.38888888888889
74325, 1.895652173913, 0.35869565217391, 0.36111111111111
74326, 1.8739130434783, 0.35869565217391, 0.33333333333333
74327, 1.895652173913, 0.38478260869565, 0.33333333333333
74328, 1.895652173913, 0.35869565217391, 0.30555555555556
74329, 1.8739130434783, 0.35869565217391, 0.27777777777778
74330, 1.895652173913, 0.38478260869565, 0.27777777777778
74331, 1.895652173913, 0.35869565217391, 0.25
74332, 1.8739130434783, 0.35869565217391, 0.22222222222222
74333, 1.895652173913, 0.38478260869565, 0.22222222222222
74334, 1.895652173913, 0.35869565217391, 0.19444444444444
74335, 1.8739130434783, 0.35869565217391, 0.16666666666667
74336, 1.895652173913, 0.38478260869565, 0.16666666666667
74337, 1.895652173913, 0.35869565217391, 0.13888888888889
74338, 1.8739130434783, 0.35869565217391, 0.11111111111111
74339, 1.895652173913, 0.38478260869565, 0.11111111111111
74340, 1.895652173913, 0.35869565217391, 0.083333333333333
74341, 1.8739130434783, 0.35869565217391, 0.055555555555556
74342, 1.895652173913, 0.38478260869565, 0.055555555555556
74343, 1.895652173913, 0.35869565217391, 0.027777777777778
74344, 1.9391304347826, 0.35869565217391, 0.47222222222222
74345, 1.9173913043478, 0.35869565217391, 0.44444444444444
74346, 1.9391304347826, 0.38478260869565, 0.44444444444444
74347, 1.9391304347826, 0.35869565217391, 0.41666666666667
74348, 1.9173913043478, 0.35869565217391, 0.38888888888889
74349, 1.9391304347826, 0.38478260869565, 0.38888888888889
74350, 1.9391304347826, 0.35869565217391, 0.36111111111111
74351, 1.9173913043478, 0.35869565217391, 0.33333333333333
74352, 1.9391304347826, 0.38478260869565, 0.33333333333333
74353, 1.9391304347826, 0.35869565217391, 0.30555555555556
74354, 1.9173913043478, 0.35869565217391, 0.27777777777778
74355, 1.9391304347826, 0.38478260869565, 0.27777777777778
74356, 1.9391304347826, 0.35869565217391, 0.25
74357, 1.9173913043478, 0.35869565217391, 0.22222222222222
74358, 1.9391304347826, 0.38478260869565, 0.22222222222222
74359, 1.9391304347826, 0.35869565217391, 0.19444444444444
74360, 1.9173913043478, 0.35869565217391, 0.16666666666667
74361, 1.9391304347826, 0.38478260869565, 0.16666666666667
74362, 1.9391304347826, 0.35869565217391, 0.13888888888889
74363, 1.9173913043478, 0.35869565217391, 0.11111111111111
74364, 1.9391304347826, 0.38478260869565, 0.11111111111111
74365, 1.9391304347826, 0.35869565217391, 0.083333333333333
74366, 1.9173913043478, 0.35869565217391, 0.055555555555556
74367, 1.9391304347826, 0.38478260869565, 0.055555555555556
74368, 1.9391304347826, 0.35869565217391, 0.027777777777778
74369, 1.9826086956522, 0.35869565217391, 0.47222222222222
74370, 1.9608695652174, 0.35869565217391, 0.44444444444444
74371, 1.9826086956522, 0.38478260869565, 0.44444444444444
74372, 1.9826086956522, 0.35869565217391, 0.41666666666667
74373, 1.9608695652174, 0.35869565217391, 0.38888888888889
74374, 1.9826086956522, 0.38478260869565, 0.38888888888889
74375, 1.9826086956522, 0.35869565217391, 0.36111111111111
74376, 1.9608695652174, 0.35869565217391, 0.33333333333333
74377, 1.9826086956522, 0.38478260869565, 0.33333333333333
74378, 1.9826086956522, 0.35869565217391, 0.30555555555556
74379, 1.9608695652174, 0.35869565217391, 0.27777777777778
74380, 1.9826086956522, 0.38478260869565, 0.27777777777778
74381, 1.9826086956522, 0.35869565217391, 0.25
74382, 1.9608695652174, 0.35869565217391, 0.22222222222222
74383, 1.9826086956522, 0.38478260869565, 0.22222222222222
74384, 1.9826086956522, 0.35869565217391, 0.19444444444444
74385, 1.9608695652174, 0.35869565217391, 0.16666666666667
74386, 1.9826086956522, 0.38478260869565, 0.16666666666667
74387, 1.9826086956522, 0.35869565217391, 0.13888888888889
74388, 1.9608695652174, 0.35869565217391, 0.11111111111111
74389, 1.9826086956522, 0.38478260869565, 0.11111111111111
74390, 1.9826086956522, 0.35869565217391, 0.083333333333333
74391, 1.9608695652174, 0.35869565217391, 0.055555555555556
74392, 1.9826086956522, 0.38478260869565, 0.055555555555556
74393, 1.9826086956522, 0.35869565217391, 0.027777777777778
74394, 2.0260869565217, 0.35869565217391, 0.47222222222222
74395, 2.004347826087, 0.35869565217391, 0.44444444444444
74396, 2.0260869565217, 0.38478260869565, 0.44444444444444
74397, 2.0260869565217, 0.35869565217391, 0.41666666666667
74398, 2.004347826087, 0.35869565217391, 0.38888888888889
74399, 2.0260869565217, 0.38478260869565, 0.38888888888889
74400, 2.0260869565217, 0.35869565217391, 0.36111111111111
74401, 2.004347826087, 0.35869565217391, 0.33333333333333
74402, 2.0260869565217, 0.38478260869565, 0.33333333333333
74403, 2.0260869565217, 0.35869565217391, 0.30555555555556
74404, 2.004347826087, 0.35869565217391, 0.27777777777778
74405, 2.0260869565217, 0.38478260869565, 0.27777777777778
74406, 2.0260869565217, 0.35869565217391, 0.25
74407, 2.004347826087, 0.35869565217391, 0.22222222222222
74408, 2.0260869565217, 0.38478260869565, 0.22222222222222
74409, 2.0260869565217, 0.35869565217391, 0.19444444444444
74410, 2.004347826087, 0.35869565217391, 0.16666666666667
74411, 2.0260869565217, 0.38478260869565, 0.16666666666667
74412, 2.0260869565217, 0.35869565217391, 0.13888888888889
74413, 2.004347826087, 0.35869565217391, 0.11111111111111
74414, 2.0260869565217, 0.38478260869565, 0.11111111111111
74415, 2.0260869565217, 0.35869565217391, 0.083333333333333
74416, 2.004347826087, 0.35869565217391, 0.055555555555556
74417, 2.0260869565217, 0.38478260869565, 0.055555555555556
74418, 2.0260869565217, 0.35869565217391, 0.027777777777778
74419, 2.0695652173913, 0.35869565217391, 0.47222222222222
74420, 2.0478260869565, 0.35869565217391, 0.44444444444444
74421, 2.0695652173913, 0.38478260869565, 0.44444444444444
74422, 2.0695652173913, 0.35869565217391, 0.41666666666667
74423, 2.0478260869565, 0.35869565217391, 0.38888888888889
74424, 2.0695652173913, 0.38478260869565, 0.38888888888889
74425, 2.0695652173913, 0.35869565217391, 0.36111111111111
74426, 2.0478260869565, 0.35869565217391, 0.33333333333333
74427, 2.0695652173913, 0.38478260869565, 0.33333333333333
74428, 2.0695652173913, 0.35869565217391, 0.30555555555556
74429, 2.0478260869565, 0.35869565217391, 0.27777777777778
74430, 2.0695652173913, 0.38478260869565, 0.27777777777778
74431, 2.0695652173913, 0.35869565217391, 0.25
74432, 2.0478260869565, 0.35869565217391, 0.22222222222222
74433, 2.0695652173913, 0.38478260869565, 0.22222222222222
74434, 2.0695652173913, 0.35869565217391, 0.19444444444444
74435, 2.0478260869565, 0.35869565217391, 0.16666666666667
74436, 2.0695652173913, 0.38478260869565, 0.16666666666667
74437, 2.0695652173913, 0.35869565217391, 0.13888888888889
74438, 2.0478260869565, 0.35869565217391, 0.11111111111111
74439, 2.0695652173913, 0.38478260869565, 0.11111111111111
74440, 2.0695652173913, 0.35869565217391, 0.083333333333333
74441, 2.0478260869565, 0.35869565217391, 0.055555555555556
74442, 2.0695652173913, 0.38478260869565, 0.055555555555556
74443, 2.0695652173913, 0.35869565217391, 0.027777777777778
74444, 2.1130434782609, 0.35869565217391, 0.47222222222222
74445, 2.0913043478261, 0.35869565217391, 0.44444444444444
74446, 2.1130434782609, 0.38478260869565, 0.44444444444444
74447, 2.1130434782609, 0.35869565217391, 0.41666666666667
74448, 2.0913043478261, 0.35869565217391, 0.38888888888889
74449, 2.1130434782609, 0.38478260869565, 0.38888888888889
74450, 2.1130434782609, 0.35869565217391, 0.36111111111111
74451, 2.0913043478261, 0.35869565217391, 0.33333333333333
74452, 2.1130434782609, 0.38478260869565, 0.33333333333333
74453, 2.1130434782609, 0.35869565217391, 0.30555555555556
74454, 2.0913043478261, 0.35869565217391, 0.27777777777778
74455, 2.1130434782609, 0.38478260869565, 0.27777777777778
74456, 2.1130434782609, 0.35869565217391, 0.25
74457, 2.0913043478261, 0.35869565217391, 0.22222222222222
74458, 2.1130434782609, 0.38478260869565, 0.22222222222222
74459, 2.1130434782609, 0.35869565217391, 0.19444444444444
74460, 2.0913043478261, 0.35869565217391, 0.16666666666667
74461, 2.1130434782609, 0.38478260869565, 0.16666666666667
74462, 2.1130434782609, 0.35869565217391, 0.13888888888889
74463, 2.0913043478261, 0.35869565217391, 0.11111111111111
74464, 2.1130434782609, 0.38478260869565, 0.11111111111111
74465, 2.1130434782609, 0.35869565217391, 0.083333333333333
74466, 2.0913043478261, 0.35869565217391, 0.055555555555556
74467, 2.1130434782609, 0.38478260869565, 0.055555555555556
74468, 2.1130434782609, 0.35869565217391, 0.027777777777778
74469, 2.1565217391304, 0.35869565217391, 0.47222222222222
74470, 2.1347826086957, 0.35869565217391, 0.44444444444444
74471, 2.1565217391304, 0.38478260869565, 0.44444444444444
74472, 2.1565217391304, 0.35869565217391, 0.41666666666667
74473, 2.1347826086957, 0.35869565217391, 0.38888888888889
74474, 2.1565217391304, 0.38478260869565, 0.38888888888889
74475, 2.1565217391304, 0.35869565217391, 0.36111111111111
74476, 2.1347826086957, 0.35869565217391, 0.33333333333333
74477, 2.1565217391304, 0.38478260869565, 0.33333333333333
74478, 2.1565217391304, 0.35869565217391, 0.30555555555556
74479, 2.1347826086957, 0.35869565217391, 0.27777777777778
74480, 2.1565217391304, 0.38478260869565, 0.27777777777778
74481, 2.1565217391304, 0.35869565217391, 0.25
74482, 2.1347826086957, 0.35869565217391, 0.22222222222222
74483, 2.1565217391304, 0.38478260869565, 0.22222222222222
74484, 2.1565217391304, 0.35869565217391, 0.19444444444444
74485, 2.1347826086957, 0.35869565217391, 0.16666666666667
74486, 2.1565217391304, 0.38478260869565, 0.16666666666667
74487, 2.1565217391304, 0.35869565217391, 0.13888888888889
74488, 2.1347826086957, 0.35869565217391, 0.11111111111111
74489, 2.1565217391304, 0.38478260869565, 0.11111111111111
74490, 2.1565217391304, 0.35869565217391, 0.083333333333333
74491, 2.1347826086957, 0.35869565217391, 0.055555555555556
74492, 2.1565217391304, 0.38478260869565, 0.055555555555556
74493, 2.1565217391304, 0.35869565217391, 0.027777777777778
74494, 2.1782608695652, 0.35869565217391, 0.44444444444444
74495, 2.1782608695652, 0.35869565217391, 0.38888888888889
74496, 2.1782608695652, 0.35869565217391, 0.33333333333333
74497, 2.1782608695652, 0.35869565217391, 0.27777777777778
74498, 2.1782608695652, 0.35869565217391, 0.22222222222222
74499, 2.1782608695652, 0.35869565217391, 0.16666666666667
74500, 2.1782608695652, 0.35869565217391, 0.11111111111111
74501, 2.1782608695652, 0.35869565217391, 0.055555555555556
74502, 1.2434782608696, 0.30652173913044, 0.47222222222222
74503, 1.2217391304348, 0.30652173913044, 0.44444444444444
74504, 1.2434782608696, 0.33260869565217, 0.44444444444444
74505, 1.2434782608696, 0.30652173913044, 0.41666666666667
74506, 1.2217391304348, 0.30652173913044, 0.38888888888889
74507, 1.2434782608696, 0.33260869565217, 0.38888888888889
74508, 1.2434782608696, 0.30652173913044, 0.36111111111111
74509, 1.2217391304348, 0.30652173913044, 0.33333333333333
74510, 1.2434782608696, 0.33260869565217, 0.33333333333333
74511, 1.2434782608696, 0.30652173913044, 0.30555555555556
74512, 1.2217391304348, 0.30652173913044, 0.27777777777778
74513, 1.2434782608696, 0.33260869565217, 0.27777777777778
74514, 1.2434782608696, 0.30652173913044, 0.25
74515, 1.2217391304348, 0.30652173913044, 0.22222222222222
74516, 1.2434782608696, 0.33260869565217, 0.22222222222222
74517, 1.2434782608696, 0.30652173913044, 0.19444444444444
74518, 1.2217391304348, 0.30652173913044, 0.16666666666667
74519, 1.2434782608696, 0.33260869565217, 0.16666666666667
74520, 1.2434782608696, 0.30652173913044, 0.13888888888889
74521, 1.2217391304348, 0.30652173913044, 0.11111111111111
74522, 1.2434782608696, 0.33260869565217, 0.11111111111111
74523, 1.2434782608696, 0.30652173913044, 0.083333333333333
74524, 1.2217391304348, 0.30652173913044, 0.055555555555556
74525, 1.2434782608696, 0.33260869565217, 0.055555555555556
74526, 1.2434782608696, 0.30652173913044, 0.027777777777778
74527, 1.2869565217391, 0.30652173913043, 0.47222222222222
74528, 1.2652173913043, 0.30652173913044, 0.44444444444444
74529, 1.2869565217391, 0.33260869565217, 0.44444444444444
74530, 1.2869565217391, 0.30652173913043, 0.41666666666667
74531, 1.2652173913043, 0.30652173913044, 0.38888888888889
74532, 1.2869565217391, 0.33260869565217, 0.38888888888889
74533, 1.2869565217391, 0.30652173913043, 0.36111111111111
74534, 1.2652173913043, 0.30652173913044, 0.33333333333333
74535, 1.2869565217391, 0.33260869565217, 0.33333333333333
74536, 1.2869565217391, 0.30652173913043, 0.30555555555556
74537, 1.2652173913043, 0.30652173913044, 0.27777777777778
74538, 1.2869565217391, 0.33260869565217, 0.27777777777778
74539, 1.2869565217391, 0.30652173913043, 0.25
74540, 1.2652173913043, 0.30652173913044, 0.22222222222222
74541, 1.2869565217391, 0.33260869565217, 0.22222222222222
74542, 1.2869565217391, 0.30652173913043, 0.19444444444444
74543, 1.2652173913043, 0.30652173913044, 0.16666666666667
74544, 1.2869565217391, 0.33260869565217, 0.16666666666667
74545, 1.2869565217391, 0.30652173913043, 0.13888888888889
74546, 1.2652173913043, 0.30652173913044, 0.11111111111111
74547, 1.2869565217391, 0.33260869565217, 0.11111111111111
74548, 1.2869565217391, 0.30652173913043, 0.083333333333333
74549, 1.2652173913043, 0.30652173913044, 0.055555555555556
74550, 1.2869565217391, 0.33260869565217, 0.055555555555556
74551, 1.2869565217391, 0.30652173913043, 0.027777777777778
74552, 1.3304347826087, 0.30652173913043, 0.47222222222222
74553, 1.3086956521739, 0.30652173913043, 0.44444444444444
74554, 1.3304347826087, 0.33260869565217, 0.44444444444444
74555, 1.3304347826087, 0.30652173913043, 0.41666666666667
74556, 1.3086956521739, 0.30652173913043, 0.38888888888889
74557, 1.3304347826087, 0.33260869565217, 0.38888888888889
74558, 1.3304347826087, 0.30652173913043, 0.36111111111111
74559, 1.3086956521739, 0.30652173913043, 0.33333333333333
74560, 1.3304347826087, 0.33260869565217, 0.33333333333333
74561, 1.3304347826087, 0.30652173913043, 0.30555555555556
74562, 1.3086956521739, 0.30652173913043, 0.27777777777778
74563, 1.3304347826087, 0.33260869565217, 0.27777777777778
74564, 1.3304347826087, 0.30652173913043, 0.25
74565, 1.3086956521739, 0.30652173913043, 0.22222222222222
74566, 1.3304347826087, 0.33260869565217, 0.22222222222222
74567, 1.3304347826087, 0.30652173913043, 0.19444444444444
74568, 1.3086956521739, 0.30652173913043, 0.16666666666667
74569, 1.3304347826087, 0.33260869565217, 0.16666666666667
74570, 1.3304347826087, 0.30652173913043, 0.13888888888889
74571, 1.3086956521739, 0.30652173913043, 0.11111111111111
74572, 1.3304347826087, 0.33260869565217, 0.11111111111111
74573, 1.3304347826087, 0.30652173913043, 0.083333333333333
74574, 1.3086956521739, 0.30652173913043, 0.055555555555556
74575, 1.3304347826087, 0.33260869565217, 0.055555555555556
74576, 1.3304347826087, 0.30652173913043, 0.027777777777778
74577, 1.3739130434783, 0.30652173913044, 0.47222222222222
74578, 1.3521739130435, 0.30652173913044, 0.44444444444444
74579, 1.3739130434783, 0.33260869565217, 0.44444444444444
74580, 1.3739130434783, 0.30652173913044, 0.41666666666667
74581, 1.3521739130435, 0.30652173913044, 0.38888888888889
74582, 1.3739130434783, 0.33260869565217, 0.38888888888889
74583, 1.3739130434783, 0.30652173913044, 0.36111111111111
74584, 1.3521739130435, 0.30652173913044, 0.33333333333333
74585, 1.3739130434783, 0.33260869565217, 0.33333333333333
74586, 1.3739130434783, 0.30652173913044, 0.30555555555556
74587, 1.3521739130435, 0.30652173913044, 0.27777777777778
74588, 1.3739130434783, 0.33260869565217, 0.27777777777778
74589, 1.3739130434783, 0.30652173913044, 0.25
74590, 1.3521739130435, 0.30652173913044, 0.22222222222222
74591, 1.3739130434783, 0.33260869565217, 0.22222222222222
74592, 1.3739130434783, 0.30652173913044, 0.19444444444444
74593, 1.3521739130435, 0.30652173913044, 0.16666666666667
74594, 1.3739130434783, 0.33260869565217, 0.16666666666667
74595, 1.3739130434783, 0.30652173913044, 0.13888888888889
74596, 1.3521739130435, 0.30652173913044, 0.11111111111111
74597, 1.3739130434783, 0.33260869565217, 0.11111111111111
74598, 1.3739130434783, 0.30652173913044, 0.083333333333333
74599, 1.3521739130435, 0.30652173913044, 0.055555555555556
74600, 1.3739130434783, 0.33260869565217, 0.055555555555556
74601, 1.3739130434783, 0.30652173913044, 0.027777777777778
74602, 1.4173913043478, 0.30652173913044, 0.47222222222222
74603, 1.395652173913, 0.30652173913044, 0.44444444444444
74604, 1.4173913043478, 0.33260869565217, 0.44444444444444
74605, 1.4173913043478, 0.30652173913044, 0.41666666666667
74606, 1.395652173913, 0.30652173913044, 0.38888888888889
74607, 1.4173913043478, 0.33260869565217, 0.38888888888889
74608, 1.4173913043478, 0.30652173913044, 0.36111111111111
74609, 1.395652173913, 0.30652173913044, 0.33333333333333
74610, 1.4173913043478, 0.33260869565217, 0.33333333333333
74611, 1.4173913043478, 0.30652173913044, 0.30555555555556
74612, 1.395652173913, 0.30652173913044, 0.27777777777778
74613, 1.4173913043478, 0.33260869565217, 0.27777777777778
74614, 1.4173913043478, 0.30652173913044, 0.25
74615, 1.395652173913, 0.30652173913044, 0.22222222222222
74616, 1.4173913043478, 0.33260869565217, 0.22222222222222
74617, 1.4173913043478, 0.30652173913044, 0.19444444444444
74618, 1.395652173913, 0.30652173913044, 0.16666666666667
74619, 1.4173913043478, 0.33260869565217, 0.16666666666667
74620, 1.4173913043478, 0.30652173913044, 0.13888888888889
74621, 1.395652173913, 0.30652173913044, 0.11111111111111
74622, 1.4173913043478, 0.33260869565217, 0.11111111111111
74623, 1.4173913043478, 0.30652173913044, 0.083333333333333
74624, 1.395652173913, 0.30652173913044, 0.055555555555556
74625, 1.4173913043478, 0.33260869565217, 0.055555555555556
74626, 1.4173913043478, 0.30652173913044, 0.027777777777778
74627, 1.4608695652174, 0.30652173913043, 0.47222222222222
74628, 1.4391304347826, 0.30652173913044, 0.44444444444444
74629, 1.4608695652174, 0.33260869565217, 0.44444444444444
74630, 1.4608695652174, 0.30652173913043, 0.41666666666667
74631, 1.4391304347826, 0.30652173913043, 0.38888888888889
74632, 1.4608695652174, 0.33260869565217, 0.38888888888889
74633, 1.4608695652174, 0.30652173913043, 0.36111111111111
74634, 1.4391304347826, 0.30652173913044, 0.33333333333333
74635, 1.4608695652174, 0.33260869565217, 0.33333333333333
74636, 1.4608695652174, 0.30652173913043, 0.30555555555556
74637, 1.4391304347826, 0.30652173913044, 0.27777777777778
74638, 1.4608695652174, 0.33260869565217, 0.27777777777778
74639, 1.4608695652174, 0.30652173913043, 0.25
74640, 1.4391304347826, 0.30652173913044, 0.22222222222222
74641, 1.4608695652174, 0.33260869565217, 0.22222222222222
74642, 1.4608695652174, 0.30652173913043, 0.19444444444444
74643, 1.4391304347826, 0.30652173913044, 0.16666666666667
74644, 1.4608695652174, 0.33260869565217, 0.16666666666667
74645, 1.4608695652174, 0.30652173913043, 0.13888888888889
74646, 1.4391304347826, 0.30652173913044, 0.11111111111111
74647, 1.4608695652174, 0.33260869565217, 0.11111111111111
74648, 1.4608695652174, 0.30652173913043, 0.083333333333333
74649, 1.4391304347826, 0.30652173913044, 0.055555555555556
74650, 1.4608695652174, 0.33260869565217, 0.055555555555556
74651, 1.4608695652174, 0.30652173913043, 0.027777777777778
74652, 1.504347826087, 0.30652173913044, 0.47222222222222
74653, 1.4826086956522, 0.30652173913044, 0.44444444444444
74654, 1.504347826087, 0.33260869565217, 0.44444444444444
74655, 1.504347826087, 0.30652173913044, 0.41666666666667
74656, 1.4826086956522, 0.30652173913044, 0.38888888888889
74657, 1.504347826087, 0.33260869565217, 0.38888888888889
74658, 1.504347826087, 0.30652173913044, 0.36111111111111
74659, 1.4826086956522, 0.30652173913044, 0.33333333333333
74660, 1.504347826087, 0.33260869565217, 0.33333333333333
74661, 1.504347826087, 0.30652173913044, 0.30555555555556
74662, 1.4826086956522, 0.30652173913044, 0.27777777777778
74663, 1.504347826087, 0.33260869565217, 0.27777777777778
74664, 1.504347826087, 0.30652173913044, 0.25
74665, 1.4826086956522, 0.30652173913044, 0.22222222222222
74666, 1.504347826087, 0.33260869565217, 0.22222222222222
74667, 1.504347826087, 0.30652173913044, 0.19444444444444
74668, 1.4826086956522, 0.30652173913044, 0.16666666666667
74669, 1.504347826087, 0.33260869565217, 0.16666666666667
74670, 1.504347826087, 0.30652173913044, 0.13888888888889
74671, 1.4826086956522, 0.30652173913044, 0.11111111111111
74672, 1.504347826087, 0.33260869565217, 0.11111111111111
74673, 1.504347826087, 0.30652173913044, 0.083333333333333
74674, 1.4826086956522, 0.30652173913044, 0.055555555555556
74675, 1.504347826087, 0.33260869565217, 0.055555555555556
74676, 1.504347826087, 0.30652173913044, 0.027777777777778
74677, 1.5478260869565, 0.30652173913044, 0.47222222222222
74678, 1.5260869565217, 0.30652173913044, 0.44444444444444
74679, 1.5478260869565, 0.33260869565217, 0.44444444444444
74680, 1.5478260869565, 0.30652173913044, 0.41666666666667
74681, 1.5260869565217, 0.30652173913044, 0.38888888888889
74682, 1.5478260869565, 0.33260869565217, 0.38888888888889
74683, 1.5478260869565, 0.30652173913044, 0.36111111111111
74684, 1.5260869565217, 0.30652173913044, 0.33333333333333
74685, 1.5478260869565, 0.33260869565217, 0.33333333333333
74686, 1.5478260869565, 0.30652173913044, 0.30555555555556
74687, 1.5260869565217, 0.30652173913044, 0.27777777777778
74688, 1.5478260869565, 0.33260869565217, 0.27777777777778
74689, 1.5478260869565, 0.30652173913044, 0.25
74690, 1.5260869565217, 0.30652173913044, 0.22222222222222
74691, 1.5478260869565, 0.33260869565217, 0.22222222222222
74692, 1.5478260869565, 0.30652173913044, 0.19444444444444
74693, 1.5260869565217, 0.30652173913044, 0.16666666666667
74694, 1.5478260869565, 0.33260869565217, 0.16666666666667
74695, 1.5478260869565, 0.30652173913044, 0.13888888888889
74696, 1.5260869565217, 0.30652173913044, 0.11111111111111
74697, 1.5478260869565, 0.33260869565217, 0.11111111111111
74698, 1.5478260869565, 0.30652173913044, 0.083333333333333
74699, 1.5260869565217, 0.30652173913044, 0.055555555555556
74700, 1.5478260869565, 0.33260869565217, 0.055555555555556
74701, 1.5478260869565, 0.30652173913044, 0.027777777777778
74702, 1.5913043478261, 0.30652173913044, 0.47222222222222
74703, 1.5695652173913, 0.30652173913044, 0.44444444444444
74704, 1.5913043478261, 0.33260869565217, 0.44444444444444
74705, 1.5913043478261, 0.30652173913044, 0.41666666666667
74706, 1.5695652173913, 0.30652173913044, 0.38888888888889
74707, 1.5913043478261, 0.33260869565217, 0.38888888888889
74708, 1.5913043478261, 0.30652173913044, 0.36111111111111
74709, 1.5695652173913, 0.30652173913044, 0.33333333333333
74710, 1.5913043478261, 0.33260869565217, 0.33333333333333
74711, 1.5913043478261, 0.30652173913044, 0.30555555555556
74712, 1.5695652173913, 0.30652173913044, 0.27777777777778
74713, 1.5913043478261, 0.33260869565217, 0.27777777777778
74714, 1.5913043478261, 0.30652173913044, 0.25
74715, 1.5695652173913, 0.30652173913044, 0.22222222222222
74716, 1.5913043478261, 0.33260869565217, 0.22222222222222
74717, 1.5913043478261, 0.30652173913044, 0.19444444444444
74718, 1.5695652173913, 0.30652173913044, 0.16666666666667
74719, 1.5913043478261, 0.33260869565217, 0.16666666666667
74720, 1.5913043478261, 0.30652173913044, 0.13888888888889
74721, 1.5695652173913, 0.30652173913044, 0.11111111111111
74722, 1.5913043478261, 0.33260869565217, 0.11111111111111
74723, 1.5913043478261, 0.30652173913044, 0.083333333333333
74724, 1.5695652173913, 0.30652173913044, 0.055555555555556
74725, 1.5913043478261, 0.33260869565217, 0.055555555555556
74726, 1.5913043478261, 0.30652173913044, 0.027777777777778
74727, 1.6347826086957, 0.30652173913043, 0.47222222222222
74728, 1.6130434782609, 0.30652173913044, 0.44444444444444
74729, 1.6347826086957, 0.33260869565217, 0.44444444444444
74730, 1.6347826086957, 0.30652173913043, 0.41666666666667
74731, 1.6130434782609, 0.30652173913043, 0.38888888888889
74732, 1.6347826086957, 0.33260869565217, 0.38888888888889
74733, 1.6347826086957, 0.30652173913043, 0.36111111111111
74734, 1.6130434782609, 0.30652173913044, 0.33333333333333
74735, 1.6347826086957, 0.33260869565217, 0.33333333333333
74736, 1.6347826086957, 0.30652173913044, 0.30555555555556
74737, 1.6130434782609, 0.30652173913044, 0.27777777777778
74738, 1.6347826086957, 0.33260869565217, 0.27777777777778
74739, 1.6347826086957, 0.30652173913043, 0.25
74740, 1.6130434782609, 0.30652173913043, 0.22222222222222
74741, 1.6347826086957, 0.33260869565217, 0.22222222222222
74742, 1.6347826086957, 0.30652173913043, 0.19444444444444
74743, 1.6130434782609, 0.30652173913043, 0.16666666666667
74744, 1.6347826086957, 0.33260869565217, 0.16666666666667
74745, 1.6347826086957, 0.30652173913043, 0.13888888888889
74746, 1.6130434782609, 0.30652173913043, 0.11111111111111
74747, 1.6347826086957, 0.33260869565217, 0.11111111111111
74748, 1.6347826086957, 0.30652173913043, 0.083333333333333
74749, 1.6130434782609, 0.30652173913043, 0.055555555555556
74750, 1.6347826086957, 0.33260869565217, 0.055555555555556
74751, 1.6347826086957, 0.30652173913043, 0.027777777777778
74752, 1.6782608695652, 0.30652173913043, 0.47222222222222
74753, 1.6565217391304, 0.30652173913043, 0.44444444444444
74754, 1.6782608695652, 0.33260869565217, 0.44444444444444
74755, 1.6782608695652, 0.30652173913043, 0.41666666666667
74756, 1.6565217391304, 0.30652173913043, 0.38888888888889
74757, 1.6782608695652, 0.33260869565217, 0.38888888888889
74758, 1.6782608695652, 0.30652173913043, 0.36111111111111
74759, 1.6565217391304, 0.30652173913044, 0.33333333333333
74760, 1.6782608695652, 0.33260869565217, 0.33333333333333
74761, 1.6782608695652, 0.30652173913043, 0.30555555555556
74762, 1.6565217391304, 0.30652173913043, 0.27777777777778
74763, 1.6782608695652, 0.33260869565217, 0.27777777777778
74764, 1.6782608695652, 0.30652173913043, 0.25
74765, 1.6565217391304, 0.30652173913043, 0.22222222222222
74766, 1.6782608695652, 0.33260869565217, 0.22222222222222
74767, 1.6782608695652, 0.30652173913043, 0.19444444444444
74768, 1.6565217391304, 0.30652173913043, 0.16666666666667
74769, 1.6782608695652, 0.33260869565217, 0.16666666666667
74770, 1.6782608695652, 0.30652173913043, 0.13888888888889
74771, 1.6565217391304, 0.30652173913043, 0.11111111111111
74772, 1.6782608695652, 0.33260869565217, 0.11111111111111
74773, 1.6782608695652, 0.30652173913043, 0.083333333333333
74774, 1.6565217391304, 0.30652173913043, 0.055555555555556
74775, 1.6782608695652, 0.33260869565217, 0.055555555555556
74776, 1.6782608695652, 0.30652173913043, 0.027777777777778
74777, 1.7217391304348, 0.30652173913043, 0.47222222222222
74778, 1.7, 0.30652173913043, 0.44444444444444
74779, 1.7217391304348, 0.33260869565217, 0.44444444444444
74780, 1.7217391304348, 0.30652173913043, 0.41666666666667
74781, 1.7, 0.30652173913043, 0.38888888888889
74782, 1.7217391304348, 0.33260869565217, 0.38888888888889
74783, 1.7217391304348, 0.30652173913043, 0.36111111111111
74784, 1.7, 0.30652173913044, 0.33333333333333
74785, 1.7217391304348, 0.33260869565217, 0.33333333333333
74786, 1.7217391304348, 0.30652173913044, 0.30555555555556
74787, 1.7, 0.30652173913043, 0.27777777777778
74788, 1.7217391304348, 0.33260869565217, 0.27777777777778
74789, 1.7217391304348, 0.30652173913043, 0.25
74790, 1.7, 0.30652173913043, 0.22222222222222
74791, 1.7217391304348, 0.33260869565217, 0.22222222222222
74792, 1.7217391304348, 0.30652173913043, 0.19444444444444
74793, 1.7, 0.30652173913043, 0.16666666666667
74794, 1.7217391304348, 0.33260869565217, 0.16666666666667
74795, 1.7217391304348, 0.30652173913043, 0.13888888888889
74796, 1.7, 0.30652173913043, 0.11111111111111
74797, 1.7217391304348, 0.33260869565217, 0.11111111111111
74798, 1.7217391304348, 0.30652173913043, 0.083333333333333
74799, 1.7, 0.30652173913043, 0.055555555555556
74800, 1.7217391304348, 0.33260869565217, 0.055555555555556
74801, 1.7217391304348, 0.30652173913043, 0.027777777777778
74802, 1.7652173913043, 0.30652173913043, 0.47222222222222
74803, 1.7434782608696, 0.30652173913043, 0.44444444444444
74804, 1.7652173913043, 0.33260869565217, 0.44444444444444
74805, 1.7652173913043, 0.30652173913043, 0.41666666666667
74806, 1.7434782608696, 0.30652173913043, 0.38888888888889
74807, 1.7652173913043, 0.33260869565217, 0.38888888888889
74808, 1.7652173913043, 0.30652173913043, 0.36111111111111
74809, 1.7434782608696, 0.30652173913044, 0.33333333333333
74810, 1.7652173913043, 0.33260869565217, 0.33333333333333
74811, 1.7652173913043, 0.30652173913043, 0.30555555555556
74812, 1.7434782608696, 0.30652173913043, 0.27777777777778
74813, 1.7652173913043, 0.33260869565217, 0.27777777777778
74814, 1.7652173913043, 0.30652173913043, 0.25
74815, 1.7434782608696, 0.30652173913043, 0.22222222222222
74816, 1.7652173913043, 0.33260869565217, 0.22222222222222
74817, 1.7652173913043, 0.30652173913043, 0.19444444444444
74818, 1.7434782608696, 0.30652173913043, 0.16666666666667
74819, 1.7652173913043, 0.33260869565217, 0.16666666666667
74820, 1.7652173913043, 0.30652173913043, 0.13888888888889
74821, 1.7434782608696, 0.30652173913043, 0.11111111111111
74822, 1.7652173913043, 0.33260869565217, 0.11111111111111
74823, 1.7652173913043, 0.30652173913043, 0.083333333333333
74824, 1.7434782608696, 0.30652173913043, 0.055555555555556
74825, 1.7652173913043, 0.33260869565217, 0.055555555555556
74826, 1.7652173913043, 0.30652173913043, 0.027777777777778
74827, 1.8086956521739, 0.30652173913044, 0.47222222222222
74828, 1.7869565217391, 0.30652173913044, 0.44444444444444
74829, 1.8086956521739, 0.33260869565217, 0.44444444444444
74830, 1.8086956521739, 0.30652173913044, 0.41666666666667
74831, 1.7869565217391, 0.30652173913044, 0.38888888888889
74832, 1.8086956521739, 0.33260869565217, 0.38888888888889
74833, 1.8086956521739, 0.30652173913044, 0.36111111111111
74834, 1.7869565217391, 0.30652173913044, 0.33333333333333
74835, 1.8086956521739, 0.33260869565217, 0.33333333333333
74836, 1.8086956521739, 0.30652173913044, 0.30555555555556
74837, 1.7869565217391, 0.30652173913044, 0.27777777777778
74838, 1.8086956521739, 0.33260869565217, 0.27777777777778
74839, 1.8086956521739, 0.30652173913044, 0.25
74840, 1.7869565217391, 0.30652173913044, 0.22222222222222
74841, 1.8086956521739, 0.33260869565217, 0.22222222222222
74842, 1.8086956521739, 0.30652173913044, 0.19444444444444
74843, 1.7869565217391, 0.30652173913044, 0.16666666666667
74844, 1.8086956521739, 0.33260869565217, 0.16666666666667
74845, 1.8086956521739, 0.30652173913044, 0.13888888888889
74846, 1.7869565217391, 0.30652173913044, 0.11111111111111
74847, 1.8086956521739, 0.33260869565217, 0.11111111111111
74848, 1.8086956521739, 0.30652173913044, 0.083333333333333
74849, 1.7869565217391, 0.30652173913044, 0.055555555555556
74850, 1.8086956521739, 0.33260869565217, 0.055555555555556
74851, 1.8086956521739, 0.30652173913044, 0.027777777777778
74852, 1.8521739130435, 0.30652173913043, 0.47222222222222
74853, 1.8304347826087, 0.30652173913043, 0.44444444444444
74854, 1.8521739130435, 0.33260869565217, 0.44444444444444
74855, 1.8521739130435, 0.30652173913043, 0.41666666666667
74856, 1.8304347826087, 0.30652173913044, 0.38888888888889
74857, 1.8521739130435, 0.33260869565217, 0.38888888888889
74858, 1.8521739130435, 0.30652173913043, 0.36111111111111
74859, 1.8304347826087, 0.30652173913044, 0.33333333333333
74860, 1.8521739130435, 0.33260869565217, 0.33333333333333
74861, 1.8521739130435, 0.30652173913043, 0.30555555555556
74862, 1.8304347826087, 0.30652173913044, 0.27777777777778
74863, 1.8521739130435, 0.33260869565217, 0.27777777777778
74864, 1.8521739130435, 0.30652173913043, 0.25
74865, 1.8304347826087, 0.30652173913044, 0.22222222222222
74866, 1.8521739130435, 0.33260869565217, 0.22222222222222
74867, 1.8521739130435, 0.30652173913043, 0.19444444444444
74868, 1.8304347826087, 0.30652173913044, 0.16666666666667
74869, 1.8521739130435, 0.33260869565217, 0.16666666666667
74870, 1.8521739130435, 0.30652173913043, 0.13888888888889
74871, 1.8304347826087, 0.30652173913044, 0.11111111111111
74872, 1.8521739130435, 0.33260869565217, 0.11111111111111
74873, 1.8521739130435, 0.30652173913043, 0.083333333333333
74874, 1.8304347826087, 0.30652173913044, 0.055555555555556
74875, 1.8521739130435, 0.33260869565217, 0.055555555555556
74876, 1.8521739130435, 0.30652173913043, 0.027777777777778
74877, 1.895652173913, 0.30652173913044, 0.47222222222222
74878, 1.8739130434783, 0.30652173913043, 0.44444444444444
74879, 1.895652173913, 0.33260869565217, 0.44444444444444
74880, 1.895652173913, 0.30652173913044, 0.41666666666667
74881, 1.8739130434783, 0.30652173913043, 0.38888888888889
74882, 1.895652173913, 0.33260869565217, 0.38888888888889
74883, 1.895652173913, 0.30652173913044, 0.36111111111111
74884, 1.8739130434783, 0.30652173913043, 0.33333333333333
74885, 1.895652173913, 0.33260869565217, 0.33333333333333
74886, 1.895652173913, 0.30652173913044, 0.30555555555556
74887, 1.8739130434783, 0.30652173913043, 0.27777777777778
74888, 1.895652173913, 0.33260869565217, 0.27777777777778
74889, 1.895652173913, 0.30652173913044, 0.25
74890, 1.8739130434783, 0.30652173913043, 0.22222222222222
74891, 1.895652173913, 0.33260869565217, 0.22222222222222
74892, 1.895652173913, 0.30652173913044, 0.19444444444444
74893, 1.8739130434783, 0.30652173913043, 0.16666666666667
74894, 1.895652173913, 0.33260869565217, 0.16666666666667
74895, 1.895652173913, 0.30652173913044, 0.13888888888889
74896, 1.8739130434783, 0.30652173913043, 0.11111111111111
74897, 1.895652173913, 0.33260869565217, 0.11111111111111
74898, 1.895652173913, 0.30652173913044, 0.083333333333333
74899, 1.8739130434783, 0.30652173913043, 0.055555555555556
74900, 1.895652173913, 0.33260869565217, 0.055555555555556
74901, 1.895652173913, 0.30652173913044, 0.027777777777778
74902, 1.9391304347826, 0.30652173913043, 0.47222222222222
74903, 1.9173913043478, 0.30652173913044, 0.44444444444444
74904, 1.9391304347826, 0.33260869565217, 0.44444444444444
74905, 1.9391304347826, 0.30652173913043, 0.41666666666667
74906, 1.9173913043478, 0.30652173913044, 0.38888888888889
74907, 1.9391304347826, 0.33260869565217, 0.38888888888889
74908, 1.9391304347826, 0.30652173913043, 0.36111111111111
74909, 1.9173913043478, 0.30652173913044, 0.33333333333333
74910, 1.9391304347826, 0.33260869565217, 0.33333333333333
74911, 1.9391304347826, 0.30652173913044, 0.30555555555556
74912, 1.9173913043478, 0.30652173913044, 0.27777777777778
74913, 1.9391304347826, 0.33260869565217, 0.27777777777778
74914, 1.9391304347826, 0.30652173913043, 0.25
74915, 1.9173913043478, 0.30652173913044, 0.22222222222222
74916, 1.9391304347826, 0.33260869565217, 0.22222222222222
74917, 1.9391304347826, 0.30652173913043, 0.19444444444444
74918, 1.9173913043478, 0.30652173913044, 0.16666666666667
74919, 1.9391304347826, 0.33260869565217, 0.16666666666667
74920, 1.9391304347826, 0.30652173913043, 0.13888888888889
74921, 1.9173913043478, 0.30652173913044, 0.11111111111111
74922, 1.9391304347826, 0.33260869565217, 0.11111111111111
74923, 1.9391304347826, 0.30652173913043, 0.083333333333333
74924, 1.9173913043478, 0.30652173913044, 0.055555555555556
74925, 1.9391304347826, 0.33260869565217, 0.055555555555556
74926, 1.9391304347826, 0.30652173913043, 0.027777777777778
74927, 1.9826086956522, 0.30652173913044, 0.47222222222222
74928, 1.9608695652174, 0.30652173913044, 0.44444444444444
74929, 1.9826086956522, 0.33260869565217, 0.44444444444444
74930, 1.9826086956522, 0.30652173913044, 0.41666666666667
74931, 1.9608695652174, 0.30652173913044, 0.38888888888889
74932, 1.9826086956522, 0.33260869565217, 0.38888888888889
74933, 1.9826086956522, 0.30652173913044, 0.36111111111111
74934, 1.9608695652174, 0.30652173913044, 0.33333333333333
74935, 1.9826086956522, 0.33260869565217, 0.33333333333333
74936, 1.9826086956522, 0.30652173913044, 0.30555555555556
74937, 1.9608695652174, 0.30652173913044, 0.27777777777778
74938, 1.9826086956522, 0.33260869565217, 0.27777777777778
74939, 1.9826086956522, 0.30652173913044, 0.25
74940, 1.9608695652174, 0.30652173913044, 0.22222222222222
74941, 1.9826086956522, 0.33260869565217, 0.22222222222222
74942, 1.9826086956522, 0.30652173913044, 0.19444444444444
74943, 1.9608695652174, 0.30652173913044, 0.16666666666667
74944, 1.9826086956522, 0.33260869565217, 0.16666666666667
74945, 1.9826086956522, 0.30652173913044, 0.13888888888889
74946, 1.9608695652174, 0.30652173913044, 0.11111111111111
74947, 1.9826086956522, 0.33260869565217, 0.11111111111111
74948, 1.9826086956522, 0.30652173913044, 0.083333333333333
74949, 1.9608695652174, 0.30652173913044, 0.055555555555556
74950, 1.9826086956522, 0.33260869565217, 0.055555555555556
74951, 1.9826086956522, 0.30652173913044, 0.027777777777778
74952, 2.0260869565217, 0.30652173913044, 0.47222222222222
74953, 2.004347826087, 0.30652173913044, 0.44444444444444
74954, 2.0260869565217, 0.33260869565217, 0.44444444444444
74955, 2.0260869565217, 0.30652173913044, 0.41666666666667
74956, 2.004347826087, 0.30652173913044, 0.38888888888889
74957, 2.0260869565217, 0.33260869565217, 0.38888888888889
74958, 2.0260869565217, 0.30652173913044, 0.36111111111111
74959, 2.004347826087, 0.30652173913044, 0.33333333333333
74960, 2.0260869565217, 0.33260869565217, 0.33333333333333
74961, 2.0260869565217, 0.30652173913044, 0.30555555555556
74962, 2.004347826087, 0.30652173913044, 0.27777777777778
74963, 2.0260869565217, 0.33260869565217, 0.27777777777778
74964, 2.0260869565217, 0.30652173913044, 0.25
74965, 2.004347826087, 0.30652173913044, 0.22222222222222
74966, 2.0260869565217, 0.33260869565217, 0.22222222222222
74967, 2.0260869565217, 0.30652173913044, 0.19444444444444
74968, 2.004347826087, 0.30652173913044, 0.16666666666667
74969, 2.0260869565217, 0.33260869565217, 0.16666666666667
74970, 2.0260869565217, 0.30652173913044, 0.13888888888889
74971, 2.004347826087, 0.30652173913044, 0.11111111111111
74972, 2.0260869565217, 0.33260869565217, 0.11111111111111
74973, 2.0260869565217, 0.30652173913044, 0.083333333333333
74974, 2.004347826087, 0.30652173913044, 0.055555555555556
74975, 2.0260869565217, 0.33260869565217, 0.055555555555556
74976, 2.0260869565217, 0.30652173913044, 0.027777777777778
74977, 2.0695652173913, 0.30652173913043, 0.47222222222222
74978, 2.0478260869565, 0.30652173913044, 0.44444444444444
74979, 2.0695652173913, 0.33260869565217, 0.44444444444444
74980, 2.0695652173913, 0.30652173913043, 0.41666666666667
74981, 2.0478260869565, 0.30652173913044, 0.38888888888889
74982, 2.0695652173913, 0.33260869565217, 0.38888888888889
74983, 2.0695652173913, 0.30652173913043, 0.36111111111111
74984, 2.0478260869565, 0.30652173913044, 0.33333333333333
74985, 2.0695652173913, 0.33260869565217, 0.33333333333333
74986, 2.0695652173913, 0.30652173913044, 0.30555555555556
74987, 2.0478260869565, 0.30652173913044, 0.27777777777778
74988, 2.0695652173913, 0.33260869565217, 0.27777777777778
74989, 2.0695652173913, 0.30652173913043, 0.25
74990, 2.0478260869565, 0.30652173913044, 0.22222222222222
74991, 2.0695652173913, 0.33260869565217, 0.22222222222222
74992, 2.0695652173913, 0.30652173913043, 0.19444444444444
74993, 2.0478260869565, 0.30652173913044, 0.16666666666667
74994, 2.0695652173913, 0.33260869565217, 0.16666666666667
74995, 2.0695652173913, 0.30652173913043, 0.13888888888889
74996, 2.0478260869565, 0.30652173913044, 0.11111111111111
74997, 2.0695652173913, 0.33260869565217, 0.11111111111111
74998, 2.0695652173913, 0.30652173913043, 0.083333333333333
74999, 2.0478260869565, 0.30652173913044, 0.055555555555556
75000, 2.0695652173913, 0.33260869565217, 0.055555555555556
75001, 2.0695652173913, 0.30652173913043, 0.027777777777778
75002, 2.1130434782609, 0.30652173913043, 0.47222222222222
75003, 2.0913043478261, 0.30652173913043, 0.44444444444444
75004, 2.1130434782609, 0.33260869565217, 0.44444444444444
75005, 2.1130434782609, 0.30652173913043, 0.41666666666667
75006, 2.0913043478261, 0.30652173913043, 0.38888888888889
75007, 2.1130434782609, 0.33260869565217, 0.38888888888889
75008, 2.1130434782609, 0.30652173913043, 0.36111111111111
75009, 2.0913043478261, 0.30652173913044, 0.33333333333333
75010, 2.1130434782609, 0.33260869565217, 0.33333333333333
75011, 2.1130434782609, 0.30652173913044, 0.30555555555556
75012, 2.0913043478261, 0.30652173913043, 0.27777777777778
75013, 2.1130434782609, 0.33260869565217, 0.27777777777778
75014, 2.1130434782609, 0.30652173913043, 0.25
75015, 2.0913043478261, 0.30652173913043, 0.22222222222222
75016, 2.1130434782609, 0.33260869565217, 0.22222222222222
75017, 2.1130434782609, 0.30652173913043, 0.19444444444444
75018, 2.0913043478261, 0.30652173913043, 0.16666666666667
75019, 2.1130434782609, 0.33260869565217, 0.16666666666667
75020, 2.1130434782609, 0.30652173913043, 0.13888888888889
75021, 2.0913043478261, 0.30652173913043, 0.11111111111111
75022, 2.1130434782609, 0.33260869565217, 0.11111111111111
75023, 2.1130434782609, 0.30652173913043, 0.083333333333333
75024, 2.0913043478261, 0.30652173913043, 0.055555555555556
75025, 2.1130434782609, 0.33260869565217, 0.055555555555556
75026, 2.1130434782609, 0.30652173913043, 0.027777777777778
75027, 2.1565217391304, 0.30652173913043, 0.47222222222222
75028, 2.1347826086957, 0.30652173913044, 0.44444444444444
75029, 2.1565217391304, 0.33260869565217, 0.44444444444444
75030, 2.1565217391304, 0.30652173913043, 0.41666666666667
75031, 2.1347826086957, 0.30652173913043, 0.38888888888889
75032, 2.1565217391304, 0.33260869565217, 0.38888888888889
75033, 2.1565217391304, 0.30652173913043, 0.36111111111111
75034, 2.1347826086957, 0.30652173913044, 0.33333333333333
75035, 2.1565217391304, 0.33260869565217, 0.33333333333333
75036, 2.1565217391304, 0.30652173913044, 0.30555555555556
75037, 2.1347826086957, 0.30652173913043, 0.27777777777778
75038, 2.1565217391304, 0.33260869565217, 0.27777777777778
75039, 2.1565217391304, 0.30652173913043, 0.25
75040, 2.1347826086957, 0.30652173913043, 0.22222222222222
75041, 2.1565217391304, 0.33260869565217, 0.22222222222222
75042, 2.1565217391304, 0.30652173913043, 0.19444444444444
75043, 2.1347826086957, 0.30652173913043, 0.16666666666667
75044, 2.1565217391304, 0.33260869565217, 0.16666666666667
75045, 2.1565217391304, 0.30652173913043, 0.13888888888889
75046, 2.1347826086957, 0.30652173913043, 0.11111111111111
75047, 2.1565217391304, 0.33260869565217, 0.11111111111111
75048, 2.1565217391304, 0.30652173913043, 0.083333333333333
75049, 2.1347826086957, 0.30652173913043, 0.055555555555556
75050, 2.1565217391304, 0.33260869565217, 0.055555555555556
75051, 2.1565217391304, 0.30652173913043, 0.027777777777778
75052, 2.1782608695652, 0.30652173913044, 0.44444444444444
75053, 2.1782608695652, 0.30652173913043, 0.38888888888889
75054, 2.1782608695652, 0.30652173913044, 0.33333333333333
75055, 2.1782608695652, 0.30652173913044, 0.27777777777778
75056, 2.1782608695652, 0.30652173913044, 0.22222222222222
75057, 2.1782608695652, 0.30652173913044, 0.16666666666667
75058, 2.1782608695652, 0.30652173913044, 0.11111111111111
75059, 2.1782608695652, 0.30652173913044, 0.055555555555556
75060, 1.2434782608696, 0.25434782608696, 0.47222222222222
75061, 1.2217391304348, 0.25434782608696, 0.44444444444444
75062, 1.2434782608696, 0.2804347826087, 0.44444444444444
75063, 1.2434782608696, 0.25434782608696, 0.41666666666667
75064, 1.2217391304348, 0.25434782608696, 0.38888888888889
75065, 1.2434782608696, 0.2804347826087, 0.38888888888889
75066, 1.2434782608696, 0.25434782608696, 0.36111111111111
75067, 1.2217391304348, 0.25434782608696, 0.33333333333333
75068, 1.2434782608696, 0.2804347826087, 0.33333333333333
75069, 1.2434782608696, 0.25434782608696, 0.30555555555556
75070, 1.2217391304348, 0.25434782608696, 0.27777777777778
75071, 1.2434782608696, 0.2804347826087, 0.27777777777778
75072, 1.2434782608696, 0.25434782608696, 0.25
75073, 1.2217391304348, 0.25434782608696, 0.22222222222222
75074, 1.2434782608696, 0.2804347826087, 0.22222222222222
75075, 1.2434782608696, 0.25434782608696, 0.19444444444444
75076, 1.2217391304348, 0.25434782608696, 0.16666666666667
75077, 1.2434782608696, 0.2804347826087, 0.16666666666667
75078, 1.2434782608696, 0.25434782608696, 0.13888888888889
75079, 1.2217391304348, 0.25434782608696, 0.11111111111111
75080, 1.2434782608696, 0.2804347826087, 0.11111111111111
75081, 1.2434782608696, 0.25434782608696, 0.083333333333333
75082, 1.2217391304348, 0.25434782608696, 0.055555555555556
75083, 1.2434782608696, 0.2804347826087, 0.055555555555556
75084, 1.2434782608696, 0.25434782608696, 0.027777777777778
75085, 1.2869565217391, 0.25434782608696, 0.47222222222222
75086, 1.2652173913043, 0.25434782608696, 0.44444444444444
75087, 1.2869565217391, 0.2804347826087, 0.44444444444444
75088, 1.2869565217391, 0.25434782608696, 0.41666666666667
75089, 1.2652173913043, 0.25434782608696, 0.38888888888889
75090, 1.2869565217391, 0.2804347826087, 0.38888888888889
75091, 1.2869565217391, 0.25434782608696, 0.36111111111111
75092, 1.2652173913043, 0.25434782608696, 0.33333333333333
75093, 1.2869565217391, 0.2804347826087, 0.33333333333333
75094, 1.2869565217391, 0.25434782608696, 0.30555555555556
75095, 1.2652173913043, 0.25434782608696, 0.27777777777778
75096, 1.2869565217391, 0.2804347826087, 0.27777777777778
75097, 1.2869565217391, 0.25434782608696, 0.25
75098, 1.2652173913043, 0.25434782608696, 0.22222222222222
75099, 1.2869565217391, 0.2804347826087, 0.22222222222222
75100, 1.2869565217391, 0.25434782608696, 0.19444444444444
75101, 1.2652173913043, 0.25434782608696, 0.16666666666667
75102, 1.2869565217391, 0.2804347826087, 0.16666666666667
75103, 1.2869565217391, 0.25434782608696, 0.13888888888889
75104, 1.2652173913043, 0.25434782608696, 0.11111111111111
75105, 1.2869565217391, 0.2804347826087, 0.11111111111111
75106, 1.2869565217391, 0.25434782608696, 0.083333333333333
75107, 1.2652173913043, 0.25434782608696, 0.055555555555556
75108, 1.2869565217391, 0.2804347826087, 0.055555555555556
75109, 1.2869565217391, 0.25434782608696, 0.027777777777778
75110, 1.3304347826087, 0.25434782608696, 0.47222222222222
75111, 1.3086956521739, 0.25434782608696, 0.44444444444444
75112, 1.3304347826087, 0.2804347826087, 0.44444444444444
75113, 1.3304347826087, 0.25434782608696, 0.41666666666667
75114, 1.3086956521739, 0.25434782608696, 0.38888888888889
75115, 1.3304347826087, 0.2804347826087, 0.38888888888889
75116, 1.3304347826087, 0.25434782608696, 0.36111111111111
75117, 1.3086956521739, 0.25434782608696, 0.33333333333333
75118, 1.3304347826087, 0.2804347826087, 0.33333333333333
75119, 1.3304347826087, 0.25434782608696, 0.30555555555556
75120, 1.3086956521739, 0.25434782608696, 0.27777777777778
75121, 1.3304347826087, 0.2804347826087, 0.27777777777778
75122, 1.3304347826087, 0.25434782608696, 0.25
75123, 1.3086956521739, 0.25434782608696, 0.22222222222222
75124, 1.3304347826087, 0.2804347826087, 0.22222222222222
75125, 1.3304347826087, 0.25434782608696, 0.19444444444444
75126, 1.3086956521739, 0.25434782608696, 0.16666666666667
75127, 1.3304347826087, 0.2804347826087, 0.16666666666667
75128, 1.3304347826087, 0.25434782608696, 0.13888888888889
75129, 1.3086956521739, 0.25434782608696, 0.11111111111111
75130, 1.3304347826087, 0.2804347826087, 0.11111111111111
75131, 1.3304347826087, 0.25434782608696, 0.083333333333333
75132, 1.3086956521739, 0.25434782608696, 0.055555555555556
75133, 1.3304347826087, 0.2804347826087, 0.055555555555556
75134, 1.3304347826087, 0.25434782608696, 0.027777777777778
75135, 1.3739130434783, 0.25434782608696, 0.47222222222222
75136, 1.3521739130435, 0.25434782608696, 0.44444444444444
75137, 1.3739130434783, 0.2804347826087, 0.44444444444444
75138, 1.3739130434783, 0.25434782608696, 0.41666666666667
75139, 1.3521739130435, 0.25434782608696, 0.38888888888889
75140, 1.3739130434783, 0.2804347826087, 0.38888888888889
75141, 1.3739130434783, 0.25434782608696, 0.36111111111111
75142, 1.3521739130435, 0.25434782608696, 0.33333333333333
75143, 1.3739130434783, 0.2804347826087, 0.33333333333333
75144, 1.3739130434783, 0.25434782608696, 0.30555555555556
75145, 1.3521739130435, 0.25434782608696, 0.27777777777778
75146, 1.3739130434783, 0.2804347826087, 0.27777777777778
75147, 1.3739130434783, 0.25434782608696, 0.25
75148, 1.3521739130435, 0.25434782608696, 0.22222222222222
75149, 1.3739130434783, 0.2804347826087, 0.22222222222222
75150, 1.3739130434783, 0.25434782608696, 0.19444444444444
75151, 1.3521739130435, 0.25434782608696, 0.16666666666667
75152, 1.3739130434783, 0.2804347826087, 0.16666666666667
75153, 1.3739130434783, 0.25434782608696, 0.13888888888889
75154, 1.3521739130435, 0.25434782608696, 0.11111111111111
75155, 1.3739130434783, 0.2804347826087, 0.11111111111111
75156, 1.3739130434783, 0.25434782608696, 0.083333333333333
75157, 1.3521739130435, 0.25434782608696, 0.055555555555556
75158, 1.3739130434783, 0.2804347826087, 0.055555555555556
75159, 1.3739130434783, 0.25434782608696, 0.027777777777778
75160, 1.4173913043478, 0.25434782608696, 0.47222222222222
75161, 1.395652173913, 0.25434782608696, 0.44444444444444
75162, 1.4173913043478, 0.2804347826087, 0.44444444444444
75163, 1.4173913043478, 0.25434782608696, 0.41666666666667
75164, 1.395652173913, 0.25434782608696, 0.38888888888889
75165, 1.4173913043478, 0.2804347826087, 0.38888888888889
75166, 1.4173913043478, 0.25434782608696, 0.36111111111111
75167, 1.395652173913, 0.25434782608696, 0.33333333333333
75168, 1.4173913043478, 0.2804347826087, 0.33333333333333
75169, 1.4173913043478, 0.25434782608696, 0.30555555555556
75170, 1.395652173913, 0.25434782608696, 0.27777777777778
75171, 1.4173913043478, 0.2804347826087, 0.27777777777778
75172, 1.4173913043478, 0.25434782608696, 0.25
75173, 1.395652173913, 0.25434782608696, 0.22222222222222
75174, 1.4173913043478, 0.2804347826087, 0.22222222222222
75175, 1.4173913043478, 0.25434782608696, 0.19444444444444
75176, 1.395652173913, 0.25434782608696, 0.16666666666667
75177, 1.4173913043478, 0.2804347826087, 0.16666666666667
75178, 1.4173913043478, 0.25434782608696, 0.13888888888889
75179, 1.395652173913, 0.25434782608696, 0.11111111111111
75180, 1.4173913043478, 0.2804347826087, 0.11111111111111
75181, 1.4173913043478, 0.25434782608696, 0.083333333333333
75182, 1.395652173913, 0.25434782608696, 0.055555555555556
75183, 1.4173913043478, 0.2804347826087, 0.055555555555556
75184, 1.4173913043478, 0.25434782608696, 0.027777777777778
75185, 1.4608695652174, 0.25434782608696, 0.47222222222222
75186, 1.4391304347826, 0.25434782608696, 0.44444444444444
75187, 1.4608695652174, 0.2804347826087, 0.44444444444444
75188, 1.4608695652174, 0.25434782608696, 0.41666666666667
75189, 1.4391304347826, 0.25434782608696, 0.38888888888889
75190, 1.4608695652174, 0.2804347826087, 0.38888888888889
75191, 1.4608695652174, 0.25434782608696, 0.36111111111111
75192, 1.4391304347826, 0.25434782608696, 0.33333333333333
75193, 1.4608695652174, 0.2804347826087, 0.33333333333333
75194, 1.4608695652174, 0.25434782608696, 0.30555555555556
75195, 1.4391304347826, 0.25434782608696, 0.27777777777778
75196, 1.4608695652174, 0.2804347826087, 0.27777777777778
75197, 1.4608695652174, 0.25434782608696, 0.25
75198, 1.4391304347826, 0.25434782608696, 0.22222222222222
75199, 1.4608695652174, 0.2804347826087, 0.22222222222222
75200, 1.4608695652174, 0.25434782608696, 0.19444444444444
75201, 1.4391304347826, 0.25434782608696, 0.16666666666667
75202, 1.4608695652174, 0.2804347826087, 0.16666666666667
75203, 1.4608695652174, 0.25434782608696, 0.13888888888889
75204, 1.4391304347826, 0.25434782608696, 0.11111111111111
75205, 1.4608695652174, 0.2804347826087, 0.11111111111111
75206, 1.4608695652174, 0.25434782608696, 0.083333333333333
75207, 1.4391304347826, 0.25434782608696, 0.055555555555556
75208, 1.4608695652174, 0.2804347826087, 0.055555555555556
75209, 1.4608695652174, 0.25434782608696, 0.027777777777778
75210, 1.504347826087, 0.25434782608696, 0.47222222222222
75211, 1.4826086956522, 0.25434782608696, 0.44444444444444
75212, 1.504347826087, 0.2804347826087, 0.44444444444444
75213, 1.504347826087, 0.25434782608696, 0.41666666666667
75214, 1.4826086956522, 0.25434782608696, 0.38888888888889
75215, 1.504347826087, 0.2804347826087, 0.38888888888889
75216, 1.504347826087, 0.25434782608696, 0.36111111111111
75217, 1.4826086956522, 0.25434782608696, 0.33333333333333
75218, 1.504347826087, 0.2804347826087, 0.33333333333333
75219, 1.504347826087, 0.25434782608696, 0.30555555555556
75220, 1.4826086956522, 0.25434782608696, 0.27777777777778
75221, 1.504347826087, 0.2804347826087, 0.27777777777778
75222, 1.504347826087, 0.25434782608696, 0.25
75223, 1.4826086956522, 0.25434782608696, 0.22222222222222
75224, 1.504347826087, 0.2804347826087, 0.22222222222222
75225, 1.504347826087, 0.25434782608696, 0.19444444444444
75226, 1.4826086956522, 0.25434782608696, 0.16666666666667
75227, 1.504347826087, 0.2804347826087, 0.16666666666667
75228, 1.504347826087, 0.25434782608696, 0.13888888888889
75229, 1.4826086956522, 0.25434782608696, 0.11111111111111
75230, 1.504347826087, 0.2804347826087, 0.11111111111111
75231, 1.504347826087, 0.25434782608696, 0.083333333333333
75232, 1.4826086956522, 0.25434782608696, 0.055555555555556
75233, 1.504347826087, 0.2804347826087, 0.055555555555556
75234, 1.504347826087, 0.25434782608696, 0.027777777777778
75235, 1.5478260869565, 0.25434782608696, 0.47222222222222
75236, 1.5260869565217, 0.25434782608696, 0.44444444444444
75237, 1.5478260869565, 0.2804347826087, 0.44444444444444
75238, 1.5478260869565, 0.25434782608696, 0.41666666666667
75239, 1.5260869565217, 0.25434782608696, 0.38888888888889
75240, 1.5478260869565, 0.2804347826087, 0.38888888888889
75241, 1.5478260869565, 0.25434782608696, 0.36111111111111
75242, 1.5260869565217, 0.25434782608696, 0.33333333333333
75243, 1.5478260869565, 0.2804347826087, 0.33333333333333
75244, 1.5478260869565, 0.25434782608696, 0.30555555555556
75245, 1.5260869565217, 0.25434782608696, 0.27777777777778
75246, 1.5478260869565, 0.2804347826087, 0.27777777777778
75247, 1.5478260869565, 0.25434782608696, 0.25
75248, 1.5260869565217, 0.25434782608696, 0.22222222222222
75249, 1.5478260869565, 0.2804347826087, 0.22222222222222
75250, 1.5478260869565, 0.25434782608696, 0.19444444444444
75251, 1.5260869565217, 0.25434782608696, 0.16666666666667
75252, 1.5478260869565, 0.2804347826087, 0.16666666666667
75253, 1.5478260869565, 0.25434782608696, 0.13888888888889
75254, 1.5260869565217, 0.25434782608696, 0.11111111111111
75255, 1.5478260869565, 0.2804347826087, 0.11111111111111
75256, 1.5478260869565, 0.25434782608696, 0.083333333333333
75257, 1.5260869565217, 0.25434782608696, 0.055555555555556
75258, 1.5478260869565, 0.2804347826087, 0.055555555555556
75259, 1.5478260869565, 0.25434782608696, 0.027777777777778
75260, 1.5913043478261, 0.25434782608696, 0.47222222222222
75261, 1.5695652173913, 0.25434782608696, 0.44444444444444
75262, 1.5913043478261, 0.2804347826087, 0.44444444444444
75263, 1.5913043478261, 0.25434782608696, 0.41666666666667
75264, 1.5695652173913, 0.25434782608696, 0.38888888888889
75265, 1.5913043478261, 0.2804347826087, 0.38888888888889
75266, 1.5913043478261, 0.25434782608696, 0.36111111111111
75267, 1.5695652173913, 0.25434782608696, 0.33333333333333
75268, 1.5913043478261, 0.2804347826087, 0.33333333333333
75269, 1.5913043478261, 0.25434782608696, 0.30555555555556
75270, 1.5695652173913, 0.25434782608696, 0.27777777777778
75271, 1.5913043478261, 0.2804347826087, 0.27777777777778
75272, 1.5913043478261, 0.25434782608696, 0.25
75273, 1.5695652173913, 0.25434782608696, 0.22222222222222
75274, 1.5913043478261, 0.2804347826087, 0.22222222222222
75275, 1.5913043478261, 0.25434782608696, 0.19444444444444
75276, 1.5695652173913, 0.25434782608696, 0.16666666666667
75277, 1.5913043478261, 0.2804347826087, 0.16666666666667
75278, 1.5913043478261, 0.25434782608696, 0.13888888888889
75279, 1.5695652173913, 0.25434782608696, 0.11111111111111
75280, 1.5913043478261, 0.2804347826087, 0.11111111111111
75281, 1.5913043478261, 0.25434782608696, 0.083333333333333
75282, 1.5695652173913, 0.25434782608696, 0.055555555555556
75283, 1.5913043478261, 0.2804347826087, 0.055555555555556
75284, 1.5913043478261, 0.25434782608696, 0.027777777777778
75285, 1.6347826086957, 0.25434782608696, 0.47222222222222
75286, 1.6130434782609, 0.25434782608696, 0.44444444444444
75287, 1.6347826086957, 0.2804347826087, 0.44444444444444
75288, 1.6347826086957, 0.25434782608696, 0.41666666666667
75289, 1.6130434782609, 0.25434782608696, 0.38888888888889
75290, 1.6347826086957, 0.2804347826087, 0.38888888888889
75291, 1.6347826086957, 0.25434782608696, 0.36111111111111
75292, 1.6130434782609, 0.25434782608696, 0.33333333333333
75293, 1.6347826086957, 0.2804347826087, 0.33333333333333
75294, 1.6347826086957, 0.25434782608696, 0.30555555555556
75295, 1.6130434782609, 0.25434782608696, 0.27777777777778
75296, 1.6347826086957, 0.2804347826087, 0.27777777777778
75297, 1.6347826086957, 0.25434782608696, 0.25
75298, 1.6130434782609, 0.25434782608696, 0.22222222222222
75299, 1.6347826086957, 0.2804347826087, 0.22222222222222
75300, 1.6347826086957, 0.25434782608696, 0.19444444444444
75301, 1.6130434782609, 0.25434782608696, 0.16666666666667
75302, 1.6347826086957, 0.2804347826087, 0.16666666666667
75303, 1.6347826086957, 0.25434782608696, 0.13888888888889
75304, 1.6130434782609, 0.25434782608696, 0.11111111111111
75305, 1.6347826086957, 0.2804347826087, 0.11111111111111
75306, 1.6347826086957, 0.25434782608696, 0.083333333333333
75307, 1.6130434782609, 0.25434782608696, 0.055555555555556
75308, 1.6347826086957, 0.2804347826087, 0.055555555555556
75309, 1.6347826086957, 0.25434782608696, 0.027777777777778
75310, 1.6782608695652, 0.25434782608696, 0.47222222222222
75311, 1.6565217391304, 0.25434782608696, 0.44444444444444
75312, 1.6782608695652, 0.2804347826087, 0.44444444444444
75313, 1.6782608695652, 0.25434782608696, 0.41666666666667
75314, 1.6565217391304, 0.25434782608696, 0.38888888888889
75315, 1.6782608695652, 0.2804347826087, 0.38888888888889
75316, 1.6782608695652, 0.25434782608696, 0.36111111111111
75317, 1.6565217391304, 0.25434782608696, 0.33333333333333
75318, 1.6782608695652, 0.2804347826087, 0.33333333333333
75319, 1.6782608695652, 0.25434782608696, 0.30555555555556
75320, 1.6565217391304, 0.25434782608696, 0.27777777777778
75321, 1.6782608695652, 0.2804347826087, 0.27777777777778
75322, 1.6782608695652, 0.25434782608696, 0.25
75323, 1.6565217391304, 0.25434782608696, 0.22222222222222
75324, 1.6782608695652, 0.2804347826087, 0.22222222222222
75325, 1.6782608695652, 0.25434782608696, 0.19444444444444
75326, 1.6565217391304, 0.25434782608696, 0.16666666666667
75327, 1.6782608695652, 0.2804347826087, 0.16666666666667
75328, 1.6782608695652, 0.25434782608696, 0.13888888888889
75329, 1.6565217391304, 0.25434782608696, 0.11111111111111
75330, 1.6782608695652, 0.2804347826087, 0.11111111111111
75331, 1.6782608695652, 0.25434782608696, 0.083333333333333
75332, 1.6565217391304, 0.25434782608696, 0.055555555555556
75333, 1.6782608695652, 0.2804347826087, 0.055555555555556
75334, 1.6782608695652, 0.25434782608696, 0.027777777777778
75335, 1.7217391304348, 0.25434782608696, 0.47222222222222
75336, 1.7, 0.25434782608696, 0.44444444444444
75337, 1.7217391304348, 0.2804347826087, 0.44444444444444
75338, 1.7217391304348, 0.25434782608696, 0.41666666666667
75339, 1.7, 0.25434782608696, 0.38888888888889
75340, 1.7217391304348, 0.2804347826087, 0.38888888888889
75341, 1.7217391304348, 0.25434782608696, 0.36111111111111
75342, 1.7, 0.25434782608696, 0.33333333333333
75343, 1.7217391304348, 0.2804347826087, 0.33333333333333
75344, 1.7217391304348, 0.25434782608696, 0.30555555555556
75345, 1.7, 0.25434782608696, 0.27777777777778
75346, 1.7217391304348, 0.2804347826087, 0.27777777777778
75347, 1.7217391304348, 0.25434782608696, 0.25
75348, 1.7, 0.25434782608696, 0.22222222222222
75349, 1.7217391304348, 0.2804347826087, 0.22222222222222
75350, 1.7217391304348, 0.25434782608696, 0.19444444444444
75351, 1.7, 0.25434782608696, 0.16666666666667
75352, 1.7217391304348, 0.2804347826087, 0.16666666666667
75353, 1.7217391304348, 0.25434782608696, 0.13888888888889
75354, 1.7, 0.25434782608696, 0.11111111111111
75355, 1.7217391304348, 0.2804347826087, 0.11111111111111
75356, 1.7217391304348, 0.25434782608696, 0.083333333333333
75357, 1.7, 0.25434782608696, 0.055555555555556
75358, 1.7217391304348, 0.2804347826087, 0.055555555555556
75359, 1.7217391304348, 0.25434782608696, 0.027777777777778
75360, 1.7652173913043, 0.25434782608696, 0.47222222222222
75361, 1.7434782608696, 0.25434782608696, 0.44444444444444
75362, 1.7652173913043, 0.2804347826087, 0.44444444444444
75363, 1.7652173913043, 0.25434782608696, 0.41666666666667
75364, 1.7434782608696, 0.25434782608696, 0.38888888888889
75365, 1.7652173913043, 0.2804347826087, 0.38888888888889
75366, 1.7652173913043, 0.25434782608696, 0.36111111111111
75367, 1.7434782608696, 0.25434782608696, 0.33333333333333
75368, 1.7652173913043, 0.2804347826087, 0.33333333333333
75369, 1.7652173913043, 0.25434782608696, 0.30555555555556
75370, 1.7434782608696, 0.25434782608696, 0.27777777777778
75371, 1.7652173913043, 0.2804347826087, 0.27777777777778
75372, 1.7652173913043, 0.25434782608696, 0.25
75373, 1.7434782608696, 0.25434782608696, 0.22222222222222
75374, 1.7652173913043, 0.2804347826087, 0.22222222222222
75375, 1.7652173913043, 0.25434782608696, 0.19444444444444
75376, 1.7434782608696, 0.25434782608696, 0.16666666666667
75377, 1.7652173913043, 0.2804347826087, 0.16666666666667
75378, 1.7652173913043, 0.25434782608696, 0.13888888888889
75379, 1.7434782608696, 0.25434782608696, 0.11111111111111
75380, 1.7652173913043, 0.2804347826087, 0.11111111111111
75381, 1.7652173913043, 0.25434782608696, 0.083333333333333
75382, 1.7434782608696, 0.25434782608696, 0.055555555555556
75383, 1.7652173913043, 0.2804347826087, 0.055555555555556
75384, 1.7652173913043, 0.25434782608696, 0.027777777777778
75385, 1.8086956521739, 0.25434782608696, 0.47222222222222
75386, 1.7869565217391, 0.25434782608696, 0.44444444444444
75387, 1.8086956521739, 0.2804347826087, 0.44444444444444
75388, 1.8086956521739, 0.25434782608696, 0.41666666666667
75389, 1.7869565217391, 0.25434782608696, 0.38888888888889
75390, 1.8086956521739, 0.2804347826087, 0.38888888888889
75391, 1.8086956521739, 0.25434782608696, 0.36111111111111
75392, 1.7869565217391, 0.25434782608696, 0.33333333333333
75393, 1.8086956521739, 0.2804347826087, 0.33333333333333
75394, 1.8086956521739, 0.25434782608696, 0.30555555555556
75395, 1.7869565217391, 0.25434782608696, 0.27777777777778
75396, 1.8086956521739, 0.2804347826087, 0.27777777777778
75397, 1.8086956521739, 0.25434782608696, 0.25
75398, 1.7869565217391, 0.25434782608696, 0.22222222222222
75399, 1.8086956521739, 0.2804347826087, 0.22222222222222
75400, 1.8086956521739, 0.25434782608696, 0.19444444444444
75401, 1.7869565217391, 0.25434782608696, 0.16666666666667
75402, 1.8086956521739, 0.2804347826087, 0.16666666666667
75403, 1.8086956521739, 0.25434782608696, 0.13888888888889
75404, 1.7869565217391, 0.25434782608696, 0.11111111111111
75405, 1.8086956521739, 0.2804347826087, 0.11111111111111
75406, 1.8086956521739, 0.25434782608696, 0.083333333333333
75407, 1.7869565217391, 0.25434782608696, 0.055555555555556
75408, 1.8086956521739, 0.2804347826087, 0.055555555555556
75409, 1.8086956521739, 0.25434782608696, 0.027777777777778
75410, 1.8521739130435, 0.25434782608696, 0.47222222222222
75411, 1.8304347826087, 0.25434782608696, 0.44444444444444
75412, 1.8521739130435, 0.2804347826087, 0.44444444444444
75413, 1.8521739130435, 0.25434782608696, 0.41666666666667
75414, 1.8304347826087, 0.25434782608696, 0.38888888888889
75415, 1.8521739130435, 0.2804347826087, 0.38888888888889
75416, 1.8521739130435, 0.25434782608696, 0.36111111111111
75417, 1.8304347826087, 0.25434782608696, 0.33333333333333
75418, 1.8521739130435, 0.2804347826087, 0.33333333333333
75419, 1.8521739130435, 0.25434782608696, 0.30555555555556
75420, 1.8304347826087, 0.25434782608696, 0.27777777777778
75421, 1.8521739130435, 0.2804347826087, 0.27777777777778
75422, 1.8521739130435, 0.25434782608696, 0.25
75423, 1.8304347826087, 0.25434782608696, 0.22222222222222
75424, 1.8521739130435, 0.2804347826087, 0.22222222222222
75425, 1.8521739130435, 0.25434782608696, 0.19444444444444
75426, 1.8304347826087, 0.25434782608696, 0.16666666666667
75427, 1.8521739130435, 0.2804347826087, 0.16666666666667
75428, 1.8521739130435, 0.25434782608696, 0.13888888888889
75429, 1.8304347826087, 0.25434782608696, 0.11111111111111
75430, 1.8521739130435, 0.2804347826087, 0.11111111111111
75431, 1.8521739130435, 0.25434782608696, 0.083333333333333
75432, 1.8304347826087, 0.25434782608696, 0.055555555555556
75433, 1.8521739130435, 0.2804347826087, 0.055555555555556
75434, 1.8521739130435, 0.25434782608696, 0.027777777777778
75435, 1.895652173913, 0.25434782608696, 0.47222222222222
75436, 1.8739130434783, 0.25434782608696, 0.44444444444444
75437, 1.895652173913, 0.2804347826087, 0.44444444444444
75438, 1.895652173913, 0.25434782608696, 0.41666666666667
75439, 1.8739130434783, 0.25434782608696, 0.38888888888889
75440, 1.895652173913, 0.2804347826087, 0.38888888888889
75441, 1.895652173913, 0.25434782608696, 0.36111111111111
75442, 1.8739130434783, 0.25434782608696, 0.33333333333333
75443, 1.895652173913, 0.2804347826087, 0.33333333333333
75444, 1.895652173913, 0.25434782608696, 0.30555555555556
75445, 1.8739130434783, 0.25434782608696, 0.27777777777778
75446, 1.895652173913, 0.2804347826087, 0.27777777777778
75447, 1.895652173913, 0.25434782608696, 0.25
75448, 1.8739130434783, 0.25434782608696, 0.22222222222222
75449, 1.895652173913, 0.2804347826087, 0.22222222222222
75450, 1.895652173913, 0.25434782608696, 0.19444444444444
75451, 1.8739130434783, 0.25434782608696, 0.16666666666667
75452, 1.895652173913, 0.2804347826087, 0.16666666666667
75453, 1.895652173913, 0.25434782608696, 0.13888888888889
75454, 1.8739130434783, 0.25434782608696, 0.11111111111111
75455, 1.895652173913, 0.2804347826087, 0.11111111111111
75456, 1.895652173913, 0.25434782608696, 0.083333333333333
75457, 1.8739130434783, 0.25434782608696, 0.055555555555556
75458, 1.895652173913, 0.2804347826087, 0.055555555555556
75459, 1.895652173913, 0.25434782608696, 0.027777777777778
75460, 1.9391304347826, 0.25434782608696, 0.47222222222222
75461, 1.9173913043478, 0.25434782608696, 0.44444444444444
75462, 1.9391304347826, 0.2804347826087, 0.44444444444444
75463, 1.9391304347826, 0.25434782608696, 0.41666666666667
75464, 1.9173913043478, 0.25434782608696, 0.38888888888889
75465, 1.9391304347826, 0.2804347826087, 0.38888888888889
75466, 1.9391304347826, 0.25434782608696, 0.36111111111111
75467, 1.9173913043478, 0.25434782608696, 0.33333333333333
75468, 1.9391304347826, 0.2804347826087, 0.33333333333333
75469, 1.9391304347826, 0.25434782608696, 0.30555555555556
75470, 1.9173913043478, 0.25434782608696, 0.27777777777778
75471, 1.9391304347826, 0.2804347826087, 0.27777777777778
75472, 1.9391304347826, 0.25434782608696, 0.25
75473, 1.9173913043478, 0.25434782608696, 0.22222222222222
75474, 1.9391304347826, 0.2804347826087, 0.22222222222222
75475, 1.9391304347826, 0.25434782608696, 0.19444444444444
75476, 1.9173913043478, 0.25434782608696, 0.16666666666667
75477, 1.9391304347826, 0.2804347826087, 0.16666666666667
75478, 1.9391304347826, 0.25434782608696, 0.13888888888889
75479, 1.9173913043478, 0.25434782608696, 0.11111111111111
75480, 1.9391304347826, 0.2804347826087, 0.11111111111111
75481, 1.9391304347826, 0.25434782608696, 0.083333333333333
75482, 1.9173913043478, 0.25434782608696, 0.055555555555556
75483, 1.9391304347826, 0.2804347826087, 0.055555555555556
75484, 1.9391304347826, 0.25434782608696, 0.027777777777778
75485, 1.9826086956522, 0.25434782608696, 0.47222222222222
75486, 1.9608695652174, 0.25434782608696, 0.44444444444444
75487, 1.9826086956522, 0.2804347826087, 0.44444444444444
75488, 1.9826086956522, 0.25434782608696, 0.41666666666667
75489, 1.9608695652174, 0.25434782608696, 0.38888888888889
75490, 1.9826086956522, 0.2804347826087, 0.38888888888889
75491, 1.9826086956522, 0.25434782608696, 0.36111111111111
75492, 1.9608695652174, 0.25434782608696, 0.33333333333333
75493, 1.9826086956522, 0.2804347826087, 0.33333333333333
75494, 1.9826086956522, 0.25434782608696, 0.30555555555556
75495, 1.9608695652174, 0.25434782608696, 0.27777777777778
75496, 1.9826086956522, 0.2804347826087, 0.27777777777778
75497, 1.9826086956522, 0.25434782608696, 0.25
75498, 1.9608695652174, 0.25434782608696, 0.22222222222222
75499, 1.9826086956522, 0.2804347826087, 0.22222222222222
75500, 1.9826086956522, 0.25434782608696, 0.19444444444444
75501, 1.9608695652174, 0.25434782608696, 0.16666666666667
75502, 1.9826086956522, 0.2804347826087, 0.16666666666667
75503, 1.9826086956522, 0.25434782608696, 0.13888888888889
75504, 1.9608695652174, 0.25434782608696, 0.11111111111111
75505, 1.9826086956522, 0.2804347826087, 0.11111111111111
75506, 1.9826086956522, 0.25434782608696, 0.083333333333333
75507, 1.9608695652174, 0.25434782608696, 0.055555555555556
75508, 1.9826086956522, 0.2804347826087, 0.055555555555556
75509, 1.9826086956522, 0.25434782608696, 0.027777777777778
75510, 2.0260869565217, 0.25434782608696, 0.47222222222222
75511, 2.004347826087, 0.25434782608696, 0.44444444444444
75512, 2.0260869565217, 0.2804347826087, 0.44444444444444
75513, 2.0260869565217, 0.25434782608696, 0.41666666666667
75514, 2.004347826087, 0.25434782608696, 0.38888888888889
75515, 2.0260869565217, 0.2804347826087, 0.38888888888889
75516, 2.0260869565217, 0.25434782608696, 0.36111111111111
75517, 2.004347826087, 0.25434782608696, 0.33333333333333
75518, 2.0260869565217, 0.2804347826087, 0.33333333333333
75519, 2.0260869565217, 0.25434782608696, 0.30555555555556
75520, 2.004347826087, 0.25434782608696, 0.27777777777778
75521, 2.0260869565217, 0.2804347826087, 0.27777777777778
75522, 2.0260869565217, 0.25434782608696, 0.25
75523, 2.004347826087, 0.25434782608696, 0.22222222222222
75524, 2.0260869565217, 0.2804347826087, 0.22222222222222
75525, 2.0260869565217, 0.25434782608696, 0.19444444444444
75526, 2.004347826087, 0.25434782608696, 0.16666666666667
75527, 2.0260869565217, 0.2804347826087, 0.16666666666667
75528, 2.0260869565217, 0.25434782608696, 0.13888888888889
75529, 2.004347826087, 0.25434782608696, 0.11111111111111
75530, 2.0260869565217, 0.2804347826087, 0.11111111111111
75531, 2.0260869565217, 0.25434782608696, 0.083333333333333
75532, 2.004347826087, 0.25434782608696, 0.055555555555556
75533, 2.0260869565217, 0.2804347826087, 0.055555555555556
75534, 2.0260869565217, 0.25434782608696, 0.027777777777778
75535, 2.0695652173913, 0.25434782608696, 0.47222222222222
75536, 2.0478260869565, 0.25434782608696, 0.44444444444444
75537, 2.0695652173913, 0.2804347826087, 0.44444444444444
75538, 2.0695652173913, 0.25434782608696, 0.41666666666667
75539, 2.0478260869565, 0.25434782608696, 0.38888888888889
75540, 2.0695652173913, 0.2804347826087, 0.38888888888889
75541, 2.0695652173913, 0.25434782608696, 0.36111111111111
75542, 2.0478260869565, 0.25434782608696, 0.33333333333333
75543, 2.0695652173913, 0.2804347826087, 0.33333333333333
75544, 2.0695652173913, 0.25434782608696, 0.30555555555556
75545, 2.0478260869565, 0.25434782608696, 0.27777777777778
75546, 2.0695652173913, 0.2804347826087, 0.27777777777778
75547, 2.0695652173913, 0.25434782608696, 0.25
75548, 2.0478260869565, 0.25434782608696, 0.22222222222222
75549, 2.0695652173913, 0.2804347826087, 0.22222222222222
75550, 2.0695652173913, 0.25434782608696, 0.19444444444444
75551, 2.0478260869565, 0.25434782608696, 0.16666666666667
75552, 2.0695652173913, 0.2804347826087, 0.16666666666667
75553, 2.0695652173913, 0.25434782608696, 0.13888888888889
75554, 2.0478260869565, 0.25434782608696, 0.11111111111111
75555, 2.0695652173913, 0.2804347826087, 0.11111111111111
75556, 2.0695652173913, 0.25434782608696, 0.083333333333333
75557, 2.0478260869565, 0.25434782608696, 0.055555555555556
75558, 2.0695652173913, 0.2804347826087, 0.055555555555556
75559, 2.0695652173913, 0.25434782608696, 0.027777777777778
75560, 2.1130434782609, 0.25434782608696, 0.47222222222222
75561, 2.0913043478261, 0.25434782608696, 0.44444444444444
75562, 2.1130434782609, 0.2804347826087, 0.44444444444444
75563, 2.1130434782609, 0.25434782608696, 0.41666666666667
75564, 2.0913043478261, 0.25434782608696, 0.38888888888889
75565, 2.1130434782609, 0.2804347826087, 0.38888888888889
75566, 2.1130434782609, 0.25434782608696, 0.36111111111111
75567, 2.0913043478261, 0.25434782608696, 0.33333333333333
75568, 2.1130434782609, 0.2804347826087, 0.33333333333333
75569, 2.1130434782609, 0.25434782608696, 0.30555555555556
75570, 2.0913043478261, 0.25434782608696, 0.27777777777778
75571, 2.1130434782609, 0.2804347826087, 0.27777777777778
75572, 2.1130434782609, 0.25434782608696, 0.25
75573, 2.0913043478261, 0.25434782608696, 0.22222222222222
75574, 2.1130434782609, 0.2804347826087, 0.22222222222222
75575, 2.1130434782609, 0.25434782608696, 0.19444444444444
75576, 2.0913043478261, 0.25434782608696, 0.16666666666667
75577, 2.1130434782609, 0.2804347826087, 0.16666666666667
75578, 2.1130434782609, 0.25434782608696, 0.13888888888889
75579, 2.0913043478261, 0.25434782608696, 0.11111111111111
75580, 2.1130434782609, 0.2804347826087, 0.11111111111111
75581, 2.1130434782609, 0.25434782608696, 0.083333333333333
75582, 2.0913043478261, 0.25434782608696, 0.055555555555556
75583, 2.1130434782609, 0.2804347826087, 0.055555555555556
75584, 2.1130434782609, 0.25434782608696, 0.027777777777778
75585, 2.1565217391304, 0.25434782608696, 0.47222222222222
75586, 2.1347826086957, 0.25434782608696, 0.44444444444444
75587, 2.1565217391304, 0.2804347826087, 0.44444444444444
75588, 2.1565217391304, 0.25434782608696, 0.41666666666667
75589, 2.1347826086957, 0.25434782608696, 0.38888888888889
75590, 2.1565217391304, 0.2804347826087, 0.38888888888889
75591, 2.1565217391304, 0.25434782608696, 0.36111111111111
75592, 2.1347826086957, 0.25434782608696, 0.33333333333333
75593, 2.1565217391304, 0.2804347826087, 0.33333333333333
75594, 2.1565217391304, 0.25434782608696, 0.30555555555556
75595, 2.1347826086957, 0.25434782608696, 0.27777777777778
75596, 2.1565217391304, 0.2804347826087, 0.27777777777778
75597, 2.1565217391304, 0.25434782608696, 0.25
75598, 2.1347826086957, 0.25434782608696, 0.22222222222222
75599, 2.1565217391304, 0.2804347826087, 0.22222222222222
75600, 2.1565217391304, 0.25434782608696, 0.19444444444444
75601, 2.1347826086957, 0.25434782608696, 0.16666666666667
75602, 2.1565217391304, 0.2804347826087, 0.16666666666667
75603, 2.1565217391304, 0.25434782608696, 0.13888888888889
75604, 2.1347826086957, 0.25434782608696, 0.11111111111111
75605, 2.1565217391304, 0.2804347826087, 0.11111111111111
75606, 2.1565217391304, 0.25434782608696, 0.083333333333333
75607, 2.1347826086957, 0.25434782608696, 0.055555555555556
75608, 2.1565217391304, 0.2804347826087, 0.055555555555556
75609, 2.1565217391304, 0.25434782608696, 0.027777777777778
75610, 2.1782608695652, 0.25434782608696, 0.44444444444444
75611, 2.1782608695652, 0.25434782608696, 0.38888888888889
75612, 2.1782608695652, 0.25434782608696, 0.33333333333333
75613, 2.1782608695652, 0.25434782608696, 0.27777777777778
75614, 2.1782608695652, 0.25434782608696, 0.22222222222222
75615, 2.1782608695652, 0.25434782608696, 0.16666666666667
75616, 2.1782608695652, 0.25434782608696, 0.11111111111111
75617, 2.1782608695652, 0.25434782608696, 0.055555555555556
75618, 1.2434782608696, 0.20217391304348, 0.47222222222222
75619, 1.2217391304348, 0.20217391304348, 0.44444444444444
75620, 1.2434782608696, 0.22826086956522, 0.44444444444444
75621, 1.2434782608696, 0.20217391304348, 0.41666666666667
75622, 1.2217391304348, 0.20217391304348, 0.38888888888889
75623, 1.2434782608696, 0.22826086956522, 0.38888888888889
75624, 1.2434782608696, 0.20217391304348, 0.36111111111111
75625, 1.2217391304348, 0.20217391304348, 0.33333333333333
75626, 1.2434782608696, 0.22826086956522, 0.33333333333333
75627, 1.2434782608696, 0.20217391304348, 0.30555555555556
75628, 1.2217391304348, 0.20217391304348, 0.27777777777778
75629, 1.2434782608696, 0.22826086956522, 0.27777777777778
75630, 1.2434782608696, 0.20217391304348, 0.25
75631, 1.2217391304348, 0.20217391304348, 0.22222222222222
75632, 1.2434782608696, 0.22826086956522, 0.22222222222222
75633, 1.2434782608696, 0.20217391304348, 0.19444444444444
75634, 1.2217391304348, 0.20217391304348, 0.16666666666667
75635, 1.2434782608696, 0.22826086956522, 0.16666666666667
75636, 1.2434782608696, 0.20217391304348, 0.13888888888889
75637, 1.2217391304348, 0.20217391304348, 0.11111111111111
75638, 1.2434782608696, 0.22826086956522, 0.11111111111111
75639, 1.2434782608696, 0.20217391304348, 0.083333333333333
75640, 1.2217391304348, 0.20217391304348, 0.055555555555556
75641, 1.2434782608696, 0.22826086956522, 0.055555555555556
75642, 1.2434782608696, 0.20217391304348, 0.027777777777778
75643, 1.2869565217391, 0.20217391304348, 0.47222222222222
75644, 1.2652173913043, 0.20217391304348, 0.44444444444444
75645, 1.2869565217391, 0.22826086956522, 0.44444444444444
75646, 1.2869565217391, 0.20217391304348, 0.41666666666667
75647, 1.2652173913043, 0.20217391304348, 0.38888888888889
75648, 1.2869565217391, 0.22826086956522, 0.38888888888889
75649, 1.2869565217391, 0.20217391304348, 0.36111111111111
75650, 1.2652173913043, 0.20217391304348, 0.33333333333333
75651, 1.2869565217391, 0.22826086956522, 0.33333333333333
75652, 1.2869565217391, 0.20217391304348, 0.30555555555556
75653, 1.2652173913043, 0.20217391304348, 0.27777777777778
75654, 1.2869565217391, 0.22826086956522, 0.27777777777778
75655, 1.2869565217391, 0.20217391304348, 0.25
75656, 1.2652173913043, 0.20217391304348, 0.22222222222222
75657, 1.2869565217391, 0.22826086956522, 0.22222222222222
75658, 1.2869565217391, 0.20217391304348, 0.19444444444444
75659, 1.2652173913043, 0.20217391304348, 0.16666666666667
75660, 1.2869565217391, 0.22826086956522, 0.16666666666667
75661, 1.2869565217391, 0.20217391304348, 0.13888888888889
75662, 1.2652173913043, 0.20217391304348, 0.11111111111111
75663, 1.2869565217391, 0.22826086956522, 0.11111111111111
75664, 1.2869565217391, 0.20217391304348, 0.083333333333333
75665, 1.2652173913043, 0.20217391304348, 0.055555555555556
75666, 1.2869565217391, 0.22826086956522, 0.055555555555556
75667, 1.2869565217391, 0.20217391304348, 0.027777777777778
75668, 1.3304347826087, 0.20217391304348, 0.47222222222222
75669, 1.3086956521739, 0.20217391304348, 0.44444444444444
75670, 1.3304347826087, 0.22826086956522, 0.44444444444444
75671, 1.3304347826087, 0.20217391304348, 0.41666666666667
75672, 1.3086956521739, 0.20217391304348, 0.38888888888889
75673, 1.3304347826087, 0.22826086956522, 0.38888888888889
75674, 1.3304347826087, 0.20217391304348, 0.36111111111111
75675, 1.3086956521739, 0.20217391304348, 0.33333333333333
75676, 1.3304347826087, 0.22826086956522, 0.33333333333333
75677, 1.3304347826087, 0.20217391304348, 0.30555555555556
75678, 1.3086956521739, 0.20217391304348, 0.27777777777778
75679, 1.3304347826087, 0.22826086956522, 0.27777777777778
75680, 1.3304347826087, 0.20217391304348, 0.25
75681, 1.3086956521739, 0.20217391304348, 0.22222222222222
75682, 1.3304347826087, 0.22826086956522, 0.22222222222222
75683, 1.3304347826087, 0.20217391304348, 0.19444444444444
75684, 1.3086956521739, 0.20217391304348, 0.16666666666667
75685, 1.3304347826087, 0.22826086956522, 0.16666666666667
