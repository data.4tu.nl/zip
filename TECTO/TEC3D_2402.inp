92369, 24566, 3012, 30647, 91817
33412, 24197, 3004, 30633, 91635, 24198, 3005, 30632, 91636, 24579, 30658, 91818, 92369, 24580, 30657, 91821, 
92370, 24568, 3013, 30645, 91820
33413, 24198, 3005, 30632, 91636, 24199, 3006, 30631, 91637, 24580, 30657, 91821, 92370, 24581, 30656, 91824, 
92371, 24570, 3014, 30643, 91823
33414, 24199, 3006, 30631, 91637, 24200, 3007, 30630, 91638, 24581, 30656, 91824, 92371, 24582, 30655, 91827, 
92372, 24572, 3015, 30641, 91826
33415, 24200, 3007, 30630, 91638, 24201, 3008, 30629, 91639, 24582, 30655, 91827, 92372, 24583, 30654, 91830, 
92373, 24574, 3016, 30639, 91829
33416, 24201, 3008, 30629, 91639, 3084, 91, 3595, 30662, 24583, 30654, 91830, 92373, 3107, 3597, 30685, 
30729, 24575, 3017, 30637, 91832
33417, 2931, 2932, 30540, 30541, 24186, 24194, 91632, 91640, 2954, 30607, 30564, 30608, 24559, 92366, 91834, 
92374, 24543, 24560, 91808, 91833
33418, 24186, 24194, 91632, 91640, 24187, 24195, 91633, 91641, 24559, 92366, 91834, 92374, 24561, 92367, 91837, 
92375, 24545, 24562, 91811, 91836
33419, 24187, 24195, 91633, 91641, 24188, 24196, 91634, 91642, 24561, 92367, 91837, 92375, 24563, 92368, 91840, 
92376, 24547, 24564, 91814, 91839
33420, 24188, 24196, 91634, 91642, 24189, 24197, 91635, 91643, 24563, 92368, 91840, 92376, 24565, 92369, 91843, 
92377, 24549, 24566, 91817, 91842
33421, 24189, 24197, 91635, 91643, 24190, 24198, 91636, 91644, 24565, 92369, 91843, 92377, 24567, 92370, 91846, 
92378, 24551, 24568, 91820, 91845
33422, 24190, 24198, 91636, 91644, 24191, 24199, 91637, 91645, 24567, 92370, 91846, 92378, 24569, 92371, 91849, 
92379, 24553, 24570, 91823, 91848
33423, 24191, 24199, 91637, 91645, 24192, 24200, 91638, 91646, 24569, 92371, 91849, 92379, 24571, 92372, 91852, 
92380, 24555, 24572, 91826, 91851
33424, 24192, 24200, 91638, 91646, 24193, 24201, 91639, 91647, 24571, 92372, 91852, 92380, 24573, 92373, 91855, 
92381, 24557, 24574, 91829, 91854
33425, 24193, 24201, 91639, 91647, 3083, 3084, 30662, 30663, 24573, 92373, 91855, 92381, 3106, 30729, 30687, 
30730, 24558, 24575, 91832, 91857
33426, 2930, 2931, 30541, 30542, 24178, 24186, 91640, 91648, 2953, 30608, 30566, 30609, 24542, 92374, 91859, 
92382, 24526, 24543, 91833, 91858
33427, 24178, 24186, 91640, 91648, 24179, 24187, 91641, 91649, 24542, 92374, 91859, 92382, 24544, 92375, 91862, 
92383, 24528, 24545, 91836, 91861
33428, 24179, 24187, 91641, 91649, 24180, 24188, 91642, 91650, 24544, 92375, 91862, 92383, 24546, 92376, 91865, 
92384, 24530, 24547, 91839, 91864
33429, 24180, 24188, 91642, 91650, 24181, 24189, 91643, 91651, 24546, 92376, 91865, 92384, 24548, 92377, 91868, 
92385, 24532, 24549, 91842, 91867
33430, 24181, 24189, 91643, 91651, 24182, 24190, 91644, 91652, 24548, 92377, 91868, 92385, 24550, 92378, 91871, 
92386, 24534, 24551, 91845, 91870
33431, 24182, 24190, 91644, 91652, 24183, 24191, 91645, 91653, 24550, 92378, 91871, 92386, 24552, 92379, 91874, 
92387, 24536, 24553, 91848, 91873
33432, 24183, 24191, 91645, 91653, 24184, 24192, 91646, 91654, 24552, 92379, 91874, 92387, 24554, 92380, 91877, 
92388, 24538, 24555, 91851, 91876
33433, 24184, 24192, 91646, 91654, 24185, 24193, 91647, 91655, 24554, 92380, 91877, 92388, 24556, 92381, 91880, 
92389, 24540, 24557, 91854, 91879
33434, 24185, 24193, 91647, 91655, 3082, 3083, 30663, 30664, 24556, 92381, 91880, 92389, 3105, 30730, 30689, 
30731, 24541, 24558, 91857, 91882
33435, 2929, 2930, 30542, 30543, 24170, 24178, 91648, 91656, 2952, 30609, 30568, 30610, 24525, 92382, 91884, 
92390, 24509, 24526, 91858, 91883
33436, 24170, 24178, 91648, 91656, 24171, 24179, 91649, 91657, 24525, 92382, 91884, 92390, 24527, 92383, 91887, 
92391, 24511, 24528, 91861, 91886
33437, 24171, 24179, 91649, 91657, 24172, 24180, 91650, 91658, 24527, 92383, 91887, 92391, 24529, 92384, 91890, 
92392, 24513, 24530, 91864, 91889
33438, 24172, 24180, 91650, 91658, 24173, 24181, 91651, 91659, 24529, 92384, 91890, 92392, 24531, 92385, 91893, 
92393, 24515, 24532, 91867, 91892
33439, 24173, 24181, 91651, 91659, 24174, 24182, 91652, 91660, 24531, 92385, 91893, 92393, 24533, 92386, 91896, 
92394, 24517, 24534, 91870, 91895
33440, 24174, 24182, 91652, 91660, 24175, 24183, 91653, 91661, 24533, 92386, 91896, 92394, 24535, 92387, 91899, 
92395, 24519, 24536, 91873, 91898
33441, 24175, 24183, 91653, 91661, 24176, 24184, 91654, 91662, 24535, 92387, 91899, 92395, 24537, 92388, 91902, 
92396, 24521, 24538, 91876, 91901
33442, 24176, 24184, 91654, 91662, 24177, 24185, 91655, 91663, 24537, 92388, 91902, 92396, 24539, 92389, 91905, 
92397, 24523, 24540, 91879, 91904
33443, 24177, 24185, 91655, 91663, 3081, 3082, 30664, 30665, 24539, 92389, 91905, 92397, 3104, 30731, 30691, 
30732, 24524, 24541, 91882, 91907
33444, 2928, 2929, 30543, 30544, 24162, 24170, 91656, 91664, 2951, 30610, 30570, 30611, 24508, 92390, 91909, 
92398, 24492, 24509, 91883, 91908
33445, 24162, 24170, 91656, 91664, 24163, 24171, 91657, 91665, 24508, 92390, 91909, 92398, 24510, 92391, 91912, 
92399, 24494, 24511, 91886, 91911
33446, 24163, 24171, 91657, 91665, 24164, 24172, 91658, 91666, 24510, 92391, 91912, 92399, 24512, 92392, 91915, 
92400, 24496, 24513, 91889, 91914
33447, 24164, 24172, 91658, 91666, 24165, 24173, 91659, 91667, 24512, 92392, 91915, 92400, 24514, 92393, 91918, 
92401, 24498, 24515, 91892, 91917
33448, 24165, 24173, 91659, 91667, 24166, 24174, 91660, 91668, 24514, 92393, 91918, 92401, 24516, 92394, 91921, 
92402, 24500, 24517, 91895, 91920
33449, 24166, 24174, 91660, 91668, 24167, 24175, 91661, 91669, 24516, 92394, 91921, 92402, 24518, 92395, 91924, 
92403, 24502, 24519, 91898, 91923
33450, 24167, 24175, 91661, 91669, 24168, 24176, 91662, 91670, 24518, 92395, 91924, 92403, 24520, 92396, 91927, 
92404, 24504, 24521, 91901, 91926
33451, 24168, 24176, 91662, 91670, 24169, 24177, 91663, 91671, 24520, 92396, 91927, 92404, 24522, 92397, 91930, 
92405, 24506, 24523, 91904, 91929
33452, 24169, 24177, 91663, 91671, 3080, 3081, 30665, 30666, 24522, 92397, 91930, 92405, 3103, 30732, 30693, 
30733, 24507, 24524, 91907, 91932
33453, 2927, 2928, 30544, 30545, 24154, 24162, 91664, 91672, 2950, 30611, 30572, 30612, 24491, 92398, 91934, 
92406, 24475, 24492, 91908, 91933
33454, 24154, 24162, 91664, 91672, 24155, 24163, 91665, 91673, 24491, 92398, 91934, 92406, 24493, 92399, 91937, 
92407, 24477, 24494, 91911, 91936
33455, 24155, 24163, 91665, 91673, 24156, 24164, 91666, 91674, 24493, 92399, 91937, 92407, 24495, 92400, 91940, 
92408, 24479, 24496, 91914, 91939
33456, 24156, 24164, 91666, 91674, 24157, 24165, 91667, 91675, 24495, 92400, 91940, 92408, 24497, 92401, 91943, 
92409, 24481, 24498, 91917, 91942
33457, 24157, 24165, 91667, 91675, 24158, 24166, 91668, 91676, 24497, 92401, 91943, 92409, 24499, 92402, 91946, 
92410, 24483, 24500, 91920, 91945
33458, 24158, 24166, 91668, 91676, 24159, 24167, 91669, 91677, 24499, 92402, 91946, 92410, 24501, 92403, 91949, 
92411, 24485, 24502, 91923, 91948
33459, 24159, 24167, 91669, 91677, 24160, 24168, 91670, 91678, 24501, 92403, 91949, 92411, 24503, 92404, 91952, 
92412, 24487, 24504, 91926, 91951
33460, 24160, 24168, 91670, 91678, 24161, 24169, 91671, 91679, 24503, 92404, 91952, 92412, 24505, 92405, 91955, 
92413, 24489, 24506, 91929, 91954
33461, 24161, 24169, 91671, 91679, 3079, 3080, 30666, 30667, 24505, 92405, 91955, 92413, 3102, 30733, 30695, 
30734, 24490, 24507, 91932, 91957
33462, 2926, 2927, 30545, 30546, 24146, 24154, 91672, 91680, 2949, 30612, 30574, 30613, 24474, 92406, 91959, 
92414, 24458, 24475, 91933, 91958
33463, 24146, 24154, 91672, 91680, 24147, 24155, 91673, 91681, 24474, 92406, 91959, 92414, 24476, 92407, 91962, 
92415, 24460, 24477, 91936, 91961
33464, 24147, 24155, 91673, 91681, 24148, 24156, 91674, 91682, 24476, 92407, 91962, 92415, 24478, 92408, 91965, 
92416, 24462, 24479, 91939, 91964
33465, 24148, 24156, 91674, 91682, 24149, 24157, 91675, 91683, 24478, 92408, 91965, 92416, 24480, 92409, 91968, 
92417, 24464, 24481, 91942, 91967
33466, 24149, 24157, 91675, 91683, 24150, 24158, 91676, 91684, 24480, 92409, 91968, 92417, 24482, 92410, 91971, 
92418, 24466, 24483, 91945, 91970
33467, 24150, 24158, 91676, 91684, 24151, 24159, 91677, 91685, 24482, 92410, 91971, 92418, 24484, 92411, 91974, 
92419, 24468, 24485, 91948, 91973
33468, 24151, 24159, 91677, 91685, 24152, 24160, 91678, 91686, 24484, 92411, 91974, 92419, 24486, 92412, 91977, 
92420, 24470, 24487, 91951, 91976
33469, 24152, 24160, 91678, 91686, 24153, 24161, 91679, 91687, 24486, 92412, 91977, 92420, 24488, 92413, 91980, 
92421, 24472, 24489, 91954, 91979
33470, 24153, 24161, 91679, 91687, 3078, 3079, 30667, 30668, 24488, 92413, 91980, 92421, 3101, 30734, 30697, 
30735, 24473, 24490, 91957, 91982
33471, 2925, 2926, 30546, 30547, 24138, 24146, 91680, 91688, 2948, 30613, 30576, 30614, 24457, 92414, 91984, 
92422, 24441, 24458, 91958, 91983
33472, 24138, 24146, 91680, 91688, 24139, 24147, 91681, 91689, 24457, 92414, 91984, 92422, 24459, 92415, 91987, 
92423, 24443, 24460, 91961, 91986
33473, 24139, 24147, 91681, 91689, 24140, 24148, 91682, 91690, 24459, 92415, 91987, 92423, 24461, 92416, 91990, 
92424, 24445, 24462, 91964, 91989
33474, 24140, 24148, 91682, 91690, 24141, 24149, 91683, 91691, 24461, 92416, 91990, 92424, 24463, 92417, 91993, 
92425, 24447, 24464, 91967, 91992
33475, 24141, 24149, 91683, 91691, 24142, 24150, 91684, 91692, 24463, 92417, 91993, 92425, 24465, 92418, 91996, 
92426, 24449, 24466, 91970, 91995
33476, 24142, 24150, 91684, 91692, 24143, 24151, 91685, 91693, 24465, 92418, 91996, 92426, 24467, 92419, 91999, 
92427, 24451, 24468, 91973, 91998
33477, 24143, 24151, 91685, 91693, 24144, 24152, 91686, 91694, 24467, 92419, 91999, 92427, 24469, 92420, 92002, 
92428, 24453, 24470, 91976, 92001
33478, 24144, 24152, 91686, 91694, 24145, 24153, 91687, 91695, 24469, 92420, 92002, 92428, 24471, 92421, 92005, 
92429, 24455, 24472, 91979, 92004
33479, 24145, 24153, 91687, 91695, 3077, 3078, 30668, 30669, 24471, 92421, 92005, 92429, 3100, 30735, 30699, 
30736, 24456, 24473, 91982, 92007
33480, 2924, 2925, 30547, 30548, 24130, 24138, 91688, 91696, 2947, 30614, 30578, 30615, 24440, 92422, 92009, 
92430, 24424, 24441, 91983, 92008
33481, 24130, 24138, 91688, 91696, 24131, 24139, 91689, 91697, 24440, 92422, 92009, 92430, 24442, 92423, 92012, 
92431, 24426, 24443, 91986, 92011
33482, 24131, 24139, 91689, 91697, 24132, 24140, 91690, 91698, 24442, 92423, 92012, 92431, 24444, 92424, 92015, 
92432, 24428, 24445, 91989, 92014
33483, 24132, 24140, 91690, 91698, 24133, 24141, 91691, 91699, 24444, 92424, 92015, 92432, 24446, 92425, 92018, 
92433, 24430, 24447, 91992, 92017
33484, 24133, 24141, 91691, 91699, 24134, 24142, 91692, 91700, 24446, 92425, 92018, 92433, 24448, 92426, 92021, 
92434, 24432, 24449, 91995, 92020
33485, 24134, 24142, 91692, 91700, 24135, 24143, 91693, 91701, 24448, 92426, 92021, 92434, 24450, 92427, 92024, 
92435, 24434, 24451, 91998, 92023
33486, 24135, 24143, 91693, 91701, 24136, 24144, 91694, 91702, 24450, 92427, 92024, 92435, 24452, 92428, 92027, 
92436, 24436, 24453, 92001, 92026
33487, 24136, 24144, 91694, 91702, 24137, 24145, 91695, 91703, 24452, 92428, 92027, 92436, 24454, 92429, 92030, 
92437, 24438, 24455, 92004, 92029
33488, 24137, 24145, 91695, 91703, 3076, 3077, 30669, 30670, 24454, 92429, 92030, 92437, 3099, 30736, 30701, 
30737, 24439, 24456, 92007, 92032
33489, 2923, 2924, 30548, 30549, 24122, 24130, 91696, 91704, 2946, 30615, 30580, 30616, 24423, 92430, 92034, 
92438, 24407, 24424, 92008, 92033
33490, 24122, 24130, 91696, 91704, 24123, 24131, 91697, 91705, 24423, 92430, 92034, 92438, 24425, 92431, 92037, 
92439, 24409, 24426, 92011, 92036
33491, 24123, 24131, 91697, 91705, 24124, 24132, 91698, 91706, 24425, 92431, 92037, 92439, 24427, 92432, 92040, 
92440, 24411, 24428, 92014, 92039
33492, 24124, 24132, 91698, 91706, 24125, 24133, 91699, 91707, 24427, 92432, 92040, 92440, 24429, 92433, 92043, 
92441, 24413, 24430, 92017, 92042
33493, 24125, 24133, 91699, 91707, 24126, 24134, 91700, 91708, 24429, 92433, 92043, 92441, 24431, 92434, 92046, 
92442, 24415, 24432, 92020, 92045
33494, 24126, 24134, 91700, 91708, 24127, 24135, 91701, 91709, 24431, 92434, 92046, 92442, 24433, 92435, 92049, 
92443, 24417, 24434, 92023, 92048
33495, 24127, 24135, 91701, 91709, 24128, 24136, 91702, 91710, 24433, 92435, 92049, 92443, 24435, 92436, 92052, 
92444, 24419, 24436, 92026, 92051
33496, 24128, 24136, 91702, 91710, 24129, 24137, 91703, 91711, 24435, 92436, 92052, 92444, 24437, 92437, 92055, 
92445, 24421, 24438, 92029, 92054
33497, 24129, 24137, 91703, 91711, 3075, 3076, 30670, 30671, 24437, 92437, 92055, 92445, 3098, 30737, 30703, 
30738, 24422, 24439, 92032, 92057
33498, 2922, 2923, 30549, 30550, 24114, 24122, 91704, 91712, 2945, 30616, 30582, 30617, 24406, 92438, 92059, 
92446, 24390, 24407, 92033, 92058
33499, 24114, 24122, 91704, 91712, 24115, 24123, 91705, 91713, 24406, 92438, 92059, 92446, 24408, 92439, 92062, 
92447, 24392, 24409, 92036, 92061
33500, 24115, 24123, 91705, 91713, 24116, 24124, 91706, 91714, 24408, 92439, 92062, 92447, 24410, 92440, 92065, 
92448, 24394, 24411, 92039, 92064
33501, 24116, 24124, 91706, 91714, 24117, 24125, 91707, 91715, 24410, 92440, 92065, 92448, 24412, 92441, 92068, 
92449, 24396, 24413, 92042, 92067
33502, 24117, 24125, 91707, 91715, 24118, 24126, 91708, 91716, 24412, 92441, 92068, 92449, 24414, 92442, 92071, 
92450, 24398, 24415, 92045, 92070
33503, 24118, 24126, 91708, 91716, 24119, 24127, 91709, 91717, 24414, 92442, 92071, 92450, 24416, 92443, 92074, 
92451, 24400, 24417, 92048, 92073
33504, 24119, 24127, 91709, 91717, 24120, 24128, 91710, 91718, 24416, 92443, 92074, 92451, 24418, 92444, 92077, 
92452, 24402, 24419, 92051, 92076
33505, 24120, 24128, 91710, 91718, 24121, 24129, 91711, 91719, 24418, 92444, 92077, 92452, 24420, 92445, 92080, 
92453, 24404, 24421, 92054, 92079
33506, 24121, 24129, 91711, 91719, 3074, 3075, 30671, 30672, 24420, 92445, 92080, 92453, 3097, 30738, 30705, 
30739, 24405, 24422, 92057, 92082
33507, 2921, 2922, 30550, 30551, 24106, 24114, 91712, 91720, 2944, 30617, 30584, 30618, 24389, 92446, 92084, 
92454, 24373, 24390, 92058, 92083
33508, 24106, 24114, 91712, 91720, 24107, 24115, 91713, 91721, 24389, 92446, 92084, 92454, 24391, 92447, 92087, 
92455, 24375, 24392, 92061, 92086
33509, 24107, 24115, 91713, 91721, 24108, 24116, 91714, 91722, 24391, 92447, 92087, 92455, 24393, 92448, 92090, 
92456, 24377, 24394, 92064, 92089
33510, 24108, 24116, 91714, 91722, 24109, 24117, 91715, 91723, 24393, 92448, 92090, 92456, 24395, 92449, 92093, 
92457, 24379, 24396, 92067, 92092
33511, 24109, 24117, 91715, 91723, 24110, 24118, 91716, 91724, 24395, 92449, 92093, 92457, 24397, 92450, 92096, 
92458, 24381, 24398, 92070, 92095
33512, 24110, 24118, 91716, 91724, 24111, 24119, 91717, 91725, 24397, 92450, 92096, 92458, 24399, 92451, 92099, 
92459, 24383, 24400, 92073, 92098
33513, 24111, 24119, 91717, 91725, 24112, 24120, 91718, 91726, 24399, 92451, 92099, 92459, 24401, 92452, 92102, 
92460, 24385, 24402, 92076, 92101
33514, 24112, 24120, 91718, 91726, 24113, 24121, 91719, 91727, 24401, 92452, 92102, 92460, 24403, 92453, 92105, 
92461, 24387, 24404, 92079, 92104
33515, 24113, 24121, 91719, 91727, 3073, 3074, 30672, 30673, 24403, 92453, 92105, 92461, 3096, 30739, 30707, 
30740, 24388, 24405, 92082, 92107
33516, 2920, 2921, 30551, 30552, 24098, 24106, 91720, 91728, 2943, 30618, 30586, 30619, 24372, 92454, 92109, 
92462, 24356, 24373, 92083, 92108
33517, 24098, 24106, 91720, 91728, 24099, 24107, 91721, 91729, 24372, 92454, 92109, 92462, 24374, 92455, 92112, 
92463, 24358, 24375, 92086, 92111
33518, 24099, 24107, 91721, 91729, 24100, 24108, 91722, 91730, 24374, 92455, 92112, 92463, 24376, 92456, 92115, 
92464, 24360, 24377, 92089, 92114
33519, 24100, 24108, 91722, 91730, 24101, 24109, 91723, 91731, 24376, 92456, 92115, 92464, 24378, 92457, 92118, 
92465, 24362, 24379, 92092, 92117
33520, 24101, 24109, 91723, 91731, 24102, 24110, 91724, 91732, 24378, 92457, 92118, 92465, 24380, 92458, 92121, 
92466, 24364, 24381, 92095, 92120
33521, 24102, 24110, 91724, 91732, 24103, 24111, 91725, 91733, 24380, 92458, 92121, 92466, 24382, 92459, 92124, 
92467, 24366, 24383, 92098, 92123
33522, 24103, 24111, 91725, 91733, 24104, 24112, 91726, 91734, 24382, 92459, 92124, 92467, 24384, 92460, 92127, 
92468, 24368, 24385, 92101, 92126
33523, 24104, 24112, 91726, 91734, 24105, 24113, 91727, 91735, 24384, 92460, 92127, 92468, 24386, 92461, 92130, 
92469, 24370, 24387, 92104, 92129
33524, 24105, 24113, 91727, 91735, 3072, 3073, 30673, 30674, 24386, 92461, 92130, 92469, 3095, 30740, 30709, 
30741, 24371, 24388, 92107, 92132
33525, 2919, 2920, 30552, 30553, 24090, 24098, 91728, 91736, 2942, 30619, 30588, 30620, 24355, 92462, 92134, 
92470, 24339, 24356, 92108, 92133
33526, 24090, 24098, 91728, 91736, 24091, 24099, 91729, 91737, 24355, 92462, 92134, 92470, 24357, 92463, 92137, 
92471, 24341, 24358, 92111, 92136
33527, 24091, 24099, 91729, 91737, 24092, 24100, 91730, 91738, 24357, 92463, 92137, 92471, 24359, 92464, 92140, 
92472, 24343, 24360, 92114, 92139
33528, 24092, 24100, 91730, 91738, 24093, 24101, 91731, 91739, 24359, 92464, 92140, 92472, 24361, 92465, 92143, 
92473, 24345, 24362, 92117, 92142
33529, 24093, 24101, 91731, 91739, 24094, 24102, 91732, 91740, 24361, 92465, 92143, 92473, 24363, 92466, 92146, 
92474, 24347, 24364, 92120, 92145
33530, 24094, 24102, 91732, 91740, 24095, 24103, 91733, 91741, 24363, 92466, 92146, 92474, 24365, 92467, 92149, 
92475, 24349, 24366, 92123, 92148
33531, 24095, 24103, 91733, 91741, 24096, 24104, 91734, 91742, 24365, 92467, 92149, 92475, 24367, 92468, 92152, 
92476, 24351, 24368, 92126, 92151
33532, 24096, 24104, 91734, 91742, 24097, 24105, 91735, 91743, 24367, 92468, 92152, 92476, 24369, 92469, 92155, 
92477, 24353, 24370, 92129, 92154
33533, 24097, 24105, 91735, 91743, 3071, 3072, 30674, 30675, 24369, 92469, 92155, 92477, 3094, 30741, 30711, 
30742, 24354, 24371, 92132, 92157
33534, 2918, 2919, 30553, 30554, 24082, 24090, 91736, 91744, 2941, 30620, 30590, 30621, 24338, 92470, 92159, 
92478, 24322, 24339, 92133, 92158
33535, 24082, 24090, 91736, 91744, 24083, 24091, 91737, 91745, 24338, 92470, 92159, 92478, 24340, 92471, 92162, 
92479, 24324, 24341, 92136, 92161
33536, 24083, 24091, 91737, 91745, 24084, 24092, 91738, 91746, 24340, 92471, 92162, 92479, 24342, 92472, 92165, 
92480, 24326, 24343, 92139, 92164
33537, 24084, 24092, 91738, 91746, 24085, 24093, 91739, 91747, 24342, 92472, 92165, 92480, 24344, 92473, 92168, 
92481, 24328, 24345, 92142, 92167
33538, 24085, 24093, 91739, 91747, 24086, 24094, 91740, 91748, 24344, 92473, 92168, 92481, 24346, 92474, 92171, 
92482, 24330, 24347, 92145, 92170
33539, 24086, 24094, 91740, 91748, 24087, 24095, 91741, 91749, 24346, 92474, 92171, 92482, 24348, 92475, 92174, 
92483, 24332, 24349, 92148, 92173
33540, 24087, 24095, 91741, 91749, 24088, 24096, 91742, 91750, 24348, 92475, 92174, 92483, 24350, 92476, 92177, 
92484, 24334, 24351, 92151, 92176
33541, 24088, 24096, 91742, 91750, 24089, 24097, 91743, 91751, 24350, 92476, 92177, 92484, 24352, 92477, 92180, 
92485, 24336, 24353, 92154, 92179
33542, 24089, 24097, 91743, 91751, 3070, 3071, 30675, 30676, 24352, 92477, 92180, 92485, 3093, 30742, 30713, 
30743, 24337, 24354, 92157, 92182
33543, 2917, 2918, 30554, 30555, 24074, 24082, 91744, 91752, 2940, 30621, 30592, 30622, 24321, 92478, 92184, 
92486, 24305, 24322, 92158, 92183
33544, 24074, 24082, 91744, 91752, 24075, 24083, 91745, 91753, 24321, 92478, 92184, 92486, 24323, 92479, 92187, 
92487, 24307, 24324, 92161, 92186
33545, 24075, 24083, 91745, 91753, 24076, 24084, 91746, 91754, 24323, 92479, 92187, 92487, 24325, 92480, 92190, 
92488, 24309, 24326, 92164, 92189
33546, 24076, 24084, 91746, 91754, 24077, 24085, 91747, 91755, 24325, 92480, 92190, 92488, 24327, 92481, 92193, 
92489, 24311, 24328, 92167, 92192
33547, 24077, 24085, 91747, 91755, 24078, 24086, 91748, 91756, 24327, 92481, 92193, 92489, 24329, 92482, 92196, 
92490, 24313, 24330, 92170, 92195
33548, 24078, 24086, 91748, 91756, 24079, 24087, 91749, 91757, 24329, 92482, 92196, 92490, 24331, 92483, 92199, 
92491, 24315, 24332, 92173, 92198
33549, 24079, 24087, 91749, 91757, 24080, 24088, 91750, 91758, 24331, 92483, 92199, 92491, 24333, 92484, 92202, 
92492, 24317, 24334, 92176, 92201
33550, 24080, 24088, 91750, 91758, 24081, 24089, 91751, 91759, 24333, 92484, 92202, 92492, 24335, 92485, 92205, 
92493, 24319, 24336, 92179, 92204
33551, 24081, 24089, 91751, 91759, 3069, 3070, 30676, 30677, 24335, 92485, 92205, 92493, 3092, 30743, 30715, 
30744, 24320, 24337, 92182, 92207
33552, 2916, 2917, 30555, 30556, 24066, 24074, 91752, 91760, 2939, 30622, 30594, 30623, 24304, 92486, 92209, 
92494, 24288, 24305, 92183, 92208
33553, 24066, 24074, 91752, 91760, 24067, 24075, 91753, 91761, 24304, 92486, 92209, 92494, 24306, 92487, 92212, 
92495, 24290, 24307, 92186, 92211
33554, 24067, 24075, 91753, 91761, 24068, 24076, 91754, 91762, 24306, 92487, 92212, 92495, 24308, 92488, 92215, 
92496, 24292, 24309, 92189, 92214
33555, 24068, 24076, 91754, 91762, 24069, 24077, 91755, 91763, 24308, 92488, 92215, 92496, 24310, 92489, 92218, 
92497, 24294, 24311, 92192, 92217
33556, 24069, 24077, 91755, 91763, 24070, 24078, 91756, 91764, 24310, 92489, 92218, 92497, 24312, 92490, 92221, 
92498, 24296, 24313, 92195, 92220
33557, 24070, 24078, 91756, 91764, 24071, 24079, 91757, 91765, 24312, 92490, 92221, 92498, 24314, 92491, 92224, 
92499, 24298, 24315, 92198, 92223
33558, 24071, 24079, 91757, 91765, 24072, 24080, 91758, 91766, 24314, 92491, 92224, 92499, 24316, 92492, 92227, 
92500, 24300, 24317, 92201, 92226
33559, 24072, 24080, 91758, 91766, 24073, 24081, 91759, 91767, 24316, 92492, 92227, 92500, 24318, 92493, 92230, 
92501, 24302, 24319, 92204, 92229
33560, 24073, 24081, 91759, 91767, 3068, 3069, 30677, 30678, 24318, 92493, 92230, 92501, 3091, 30744, 30717, 
30745, 24303, 24320, 92207, 92232
33561, 2915, 2916, 30556, 30557, 24058, 24066, 91760, 91768, 2938, 30623, 30596, 30624, 24287, 92494, 92234, 
92502, 24271, 24288, 92208, 92233
33562, 24058, 24066, 91760, 91768, 24059, 24067, 91761, 91769, 24287, 92494, 92234, 92502, 24289, 92495, 92237, 
92503, 24273, 24290, 92211, 92236
33563, 24059, 24067, 91761, 91769, 24060, 24068, 91762, 91770, 24289, 92495, 92237, 92503, 24291, 92496, 92240, 
92504, 24275, 24292, 92214, 92239
33564, 24060, 24068, 91762, 91770, 24061, 24069, 91763, 91771, 24291, 92496, 92240, 92504, 24293, 92497, 92243, 
92505, 24277, 24294, 92217, 92242
33565, 24061, 24069, 91763, 91771, 24062, 24070, 91764, 91772, 24293, 92497, 92243, 92505, 24295, 92498, 92246, 
92506, 24279, 24296, 92220, 92245
33566, 24062, 24070, 91764, 91772, 24063, 24071, 91765, 91773, 24295, 92498, 92246, 92506, 24297, 92499, 92249, 
92507, 24281, 24298, 92223, 92248
33567, 24063, 24071, 91765, 91773, 24064, 24072, 91766, 91774, 24297, 92499, 92249, 92507, 24299, 92500, 92252, 
92508, 24283, 24300, 92226, 92251
33568, 24064, 24072, 91766, 91774, 24065, 24073, 91767, 91775, 24299, 92500, 92252, 92508, 24301, 92501, 92255, 
92509, 24285, 24302, 92229, 92254
33569, 24065, 24073, 91767, 91775, 3067, 3068, 30678, 30679, 24301, 92501, 92255, 92509, 3090, 30745, 30719, 
30746, 24286, 24303, 92232, 92257
33570, 2914, 2915, 30557, 30558, 24050, 24058, 91768, 91776, 2937, 30624, 30598, 30625, 24270, 92502, 92259, 
92510, 24254, 24271, 92233, 92258
33571, 24050, 24058, 91768, 91776, 24051, 24059, 91769, 91777, 24270, 92502, 92259, 92510, 24272, 92503, 92262, 
92511, 24256, 24273, 92236, 92261
33572, 24051, 24059, 91769, 91777, 24052, 24060, 91770, 91778, 24272, 92503, 92262, 92511, 24274, 92504, 92265, 
92512, 24258, 24275, 92239, 92264
33573, 24052, 24060, 91770, 91778, 24053, 24061, 91771, 91779, 24274, 92504, 92265, 92512, 24276, 92505, 92268, 
92513, 24260, 24277, 92242, 92267
33574, 24053, 24061, 91771, 91779, 24054, 24062, 91772, 91780, 24276, 92505, 92268, 92513, 24278, 92506, 92271, 
92514, 24262, 24279, 92245, 92270
33575, 24054, 24062, 91772, 91780, 24055, 24063, 91773, 91781, 24278, 92506, 92271, 92514, 24280, 92507, 92274, 
92515, 24264, 24281, 92248, 92273
33576, 24055, 24063, 91773, 91781, 24056, 24064, 91774, 91782, 24280, 92507, 92274, 92515, 24282, 92508, 92277, 
92516, 24266, 24283, 92251, 92276
33577, 24056, 24064, 91774, 91782, 24057, 24065, 91775, 91783, 24282, 92508, 92277, 92516, 24284, 92509, 92280, 
92517, 24268, 24285, 92254, 92279
33578, 24057, 24065, 91775, 91783, 3066, 3067, 30679, 30680, 24284, 92509, 92280, 92517, 3089, 30746, 30721, 
30747, 24269, 24286, 92257, 92282
33579, 2913, 2914, 30558, 30559, 24042, 24050, 91776, 91784, 2936, 30625, 30600, 30626, 24253, 92510, 92284, 
92518, 24237, 24254, 92258, 92283
33580, 24042, 24050, 91776, 91784, 24043, 24051, 91777, 91785, 24253, 92510, 92284, 92518, 24255, 92511, 92287, 
92519, 24239, 24256, 92261, 92286
33581, 24043, 24051, 91777, 91785, 24044, 24052, 91778, 91786, 24255, 92511, 92287, 92519, 24257, 92512, 92290, 
92520, 24241, 24258, 92264, 92289
33582, 24044, 24052, 91778, 91786, 24045, 24053, 91779, 91787, 24257, 92512, 92290, 92520, 24259, 92513, 92293, 
92521, 24243, 24260, 92267, 92292
33583, 24045, 24053, 91779, 91787, 24046, 24054, 91780, 91788, 24259, 92513, 92293, 92521, 24261, 92514, 92296, 
92522, 24245, 24262, 92270, 92295
33584, 24046, 24054, 91780, 91788, 24047, 24055, 91781, 91789, 24261, 92514, 92296, 92522, 24263, 92515, 92299, 
92523, 24247, 24264, 92273, 92298
33585, 24047, 24055, 91781, 91789, 24048, 24056, 91782, 91790, 24263, 92515, 92299, 92523, 24265, 92516, 92302, 
92524, 24249, 24266, 92276, 92301
33586, 24048, 24056, 91782, 91790, 24049, 24057, 91783, 91791, 24265, 92516, 92302, 92524, 24267, 92517, 92305, 
92525, 24251, 24268, 92279, 92304
33587, 24049, 24057, 91783, 91791, 3065, 3066, 30680, 30681, 24267, 92517, 92305, 92525, 3088, 30747, 30723, 
30748, 24252, 24269, 92282, 92307
33588, 2912, 2913, 30559, 30560, 24034, 24042, 91784, 91792, 2935, 30626, 30602, 30627, 24236, 92518, 92309, 
92526, 24220, 24237, 92283, 92308
33589, 24034, 24042, 91784, 91792, 24035, 24043, 91785, 91793, 24236, 92518, 92309, 92526, 24238, 92519, 92312, 
92527, 24222, 24239, 92286, 92311
33590, 24035, 24043, 91785, 91793, 24036, 24044, 91786, 91794, 24238, 92519, 92312, 92527, 24240, 92520, 92315, 
92528, 24224, 24241, 92289, 92314
33591, 24036, 24044, 91786, 91794, 24037, 24045, 91787, 91795, 24240, 92520, 92315, 92528, 24242, 92521, 92318, 
92529, 24226, 24243, 92292, 92317
33592, 24037, 24045, 91787, 91795, 24038, 24046, 91788, 91796, 24242, 92521, 92318, 92529, 24244, 92522, 92321, 
92530, 24228, 24245, 92295, 92320
33593, 24038, 24046, 91788, 91796, 24039, 24047, 91789, 91797, 24244, 92522, 92321, 92530, 24246, 92523, 92324, 
92531, 24230, 24247, 92298, 92323
33594, 24039, 24047, 91789, 91797, 24040, 24048, 91790, 91798, 24246, 92523, 92324, 92531, 24248, 92524, 92327, 
92532, 24232, 24249, 92301, 92326
33595, 24040, 24048, 91790, 91798, 24041, 24049, 91791, 91799, 24248, 92524, 92327, 92532, 24250, 92525, 92330, 
92533, 24234, 24251, 92304, 92329
33596, 24041, 24049, 91791, 91799, 3064, 3065, 30681, 30682, 24250, 92525, 92330, 92533, 3087, 30748, 30725, 
30749, 24235, 24252, 92307, 92332
33597, 2911, 2912, 30560, 30561, 24026, 24034, 91792, 91800, 2934, 30627, 30604, 30628, 24219, 92526, 92334, 
92534, 24203, 24220, 92308, 92333
33598, 24026, 24034, 91792, 91800, 24027, 24035, 91793, 91801, 24219, 92526, 92334, 92534, 24221, 92527, 92337, 
92535, 24205, 24222, 92311, 92336
33599, 24027, 24035, 91793, 91801, 24028, 24036, 91794, 91802, 24221, 92527, 92337, 92535, 24223, 92528, 92340, 
92536, 24207, 24224, 92314, 92339
33600, 24028, 24036, 91794, 91802, 24029, 24037, 91795, 91803, 24223, 92528, 92340, 92536, 24225, 92529, 92343, 
92537, 24209, 24226, 92317, 92342
33601, 24029, 24037, 91795, 91803, 24030, 24038, 91796, 91804, 24225, 92529, 92343, 92537, 24227, 92530, 92346, 
92538, 24211, 24228, 92320, 92345
33602, 24030, 24038, 91796, 91804, 24031, 24039, 91797, 91805, 24227, 92530, 92346, 92538, 24229, 92531, 92349, 
92539, 24213, 24230, 92323, 92348
33603, 24031, 24039, 91797, 91805, 24032, 24040, 91798, 91806, 24229, 92531, 92349, 92539, 24231, 92532, 92352, 
92540, 24215, 24232, 92326, 92351
33604, 24032, 24040, 91798, 91806, 24033, 24041, 91799, 91807, 24231, 92532, 92352, 92540, 24233, 92533, 92355, 
92541, 24217, 24234, 92329, 92354
33605, 24033, 24041, 91799, 91807, 3063, 3064, 30682, 30683, 24233, 92533, 92355, 92541, 3086, 30749, 30727, 
30750, 24218, 24235, 92332, 92357
33606, 90, 2911, 30561, 3592, 3108, 24026, 91800, 30758, 2933, 30628, 30606, 3594, 24202, 92534, 92358, 
30783, 3116, 24203, 92333, 30775
33607, 3108, 24026, 91800, 30758, 3109, 24027, 91801, 30757, 24202, 92534, 92358, 30783, 24204, 92535, 92359, 
30782, 3117, 24205, 92336, 30774
33608, 3109, 24027, 91801, 30757, 3110, 24028, 91802, 30756, 24204, 92535, 92359, 30782, 24206, 92536, 92360, 
30781, 3118, 24207, 92339, 30772
33609, 3110, 24028, 91802, 30756, 3111, 24029, 91803, 30755, 24206, 92536, 92360, 30781, 24208, 92537, 92361, 
30780, 3119, 24209, 92342, 30770
33610, 3111, 24029, 91803, 30755, 3112, 24030, 91804, 30754, 24208, 92537, 92361, 30780, 24210, 92538, 92362, 
30779, 3120, 24211, 92345, 30768
33611, 3112, 24030, 91804, 30754, 3113, 24031, 91805, 30753, 24210, 92538, 92362, 30779, 24212, 92539, 92363, 
30778, 3121, 24213, 92348, 30766
33612, 3113, 24031, 91805, 30753, 3114, 24032, 91806, 30752, 24212, 92539, 92363, 30778, 24214, 92540, 92364, 
30777, 3122, 24215, 92351, 30764
33613, 3114, 24032, 91806, 30752, 3115, 24033, 91807, 30751, 24214, 92540, 92364, 30777, 24216, 92541, 92365, 
30776, 3123, 24217, 92354, 30762
33614, 3115, 24033, 91807, 30751, 92, 3063, 30683, 3598, 24216, 92541, 92365, 30776, 3085, 30750, 30728, 
3600, 3124, 24218, 92357, 30760
*ELEMENT, type=C3D20, ELSET=Volume35
33615, 30784, 3601, 71, 2195, 92542, 30962, 2343, 16368, 30806, 3602, 2217, 30807, 92719, 30970, 16544, 
92720, 92718, 30971, 2352, 16545
33616, 92542, 30962, 2343, 16368, 92543, 30963, 2342, 16369, 92719, 30970, 16544, 92720, 92722, 30972, 16546, 
92723, 92721, 30973, 2351, 16547
33617, 92543, 30963, 2342, 16369, 92544, 30964, 2341, 16370, 92722, 30972, 16546, 92723, 92725, 30974, 16548, 
92726, 92724, 30975, 2350, 16549
33618, 92544, 30964, 2341, 16370, 92545, 30965, 2340, 16371, 92725, 30974, 16548, 92726, 92728, 30976, 16550, 
92729, 92727, 30977, 2349, 16551
33619, 92545, 30965, 2340, 16371, 92546, 30966, 2339, 16372, 92728, 30976, 16550, 92729, 92731, 30978, 16552, 
92732, 92730, 30979, 2348, 16553
33620, 92546, 30966, 2339, 16372, 92547, 30967, 2338, 16373, 92731, 30978, 16552, 92732, 92734, 30980, 16554, 
92735, 92733, 30981, 2347, 16555
33621, 92547, 30967, 2338, 16373, 92548, 30968, 2337, 16374, 92734, 30980, 16554, 92735, 92737, 30982, 16556, 
92738, 92736, 30983, 2346, 16557
33622, 92548, 30968, 2337, 16374, 92549, 30969, 2336, 16375, 92737, 30982, 16556, 92738, 92740, 30984, 16558, 
92741, 92739, 30985, 2345, 16559
33623, 92549, 30969, 2336, 16375, 30873, 3607, 74, 2291, 92740, 30984, 16558, 92741, 30896, 3608, 2313, 
30895, 92742, 30986, 2344, 16560
33624, 30785, 30784, 2195, 2196, 92550, 92542, 16368, 16376, 30808, 30807, 2218, 30809, 92744, 92720, 16561, 
92745, 92743, 92718, 16545, 16562
33625, 92550, 92542, 16368, 16376, 92551, 92543, 16369, 16377, 92744, 92720, 16561, 92745, 92747, 92723, 16563, 
92748, 92746, 92721, 16547, 16564
33626, 92551, 92543, 16369, 16377, 92552, 92544, 16370, 16378, 92747, 92723, 16563, 92748, 92750, 92726, 16565, 
92751, 92749, 92724, 16549, 16566
33627, 92552, 92544, 16370, 16378, 92553, 92545, 16371, 16379, 92750, 92726, 16565, 92751, 92753, 92729, 16567, 
92754, 92752, 92727, 16551, 16568
33628, 92553, 92545, 16371, 16379, 92554, 92546, 16372, 16380, 92753, 92729, 16567, 92754, 92756, 92732, 16569, 
92757, 92755, 92730, 16553, 16570
33629, 92554, 92546, 16372, 16380, 92555, 92547, 16373, 16381, 92756, 92732, 16569, 92757, 92759, 92735, 16571, 
92760, 92758, 92733, 16555, 16572
33630, 92555, 92547, 16373, 16381, 92556, 92548, 16374, 16382, 92759, 92735, 16571, 92760, 92762, 92738, 16573, 
92763, 92761, 92736, 16557, 16574
33631, 92556, 92548, 16374, 16382, 92557, 92549, 16375, 16383, 92762, 92738, 16573, 92763, 92765, 92741, 16575, 
92766, 92764, 92739, 16559, 16576
33632, 92557, 92549, 16375, 16383, 30874, 30873, 2291, 2292, 92765, 92741, 16575, 92766, 30898, 30895, 2314, 
30897, 92767, 92742, 16560, 16577
33633, 30786, 30785, 2196, 2197, 92558, 92550, 16376, 16384, 30810, 30809, 2219, 30811, 92769, 92745, 16578, 
92770, 92768, 92743, 16562, 16579
33634, 92558, 92550, 16376, 16384, 92559, 92551, 16377, 16385, 92769, 92745, 16578, 92770, 92772, 92748, 16580, 
92773, 92771, 92746, 16564, 16581
33635, 92559, 92551, 16377, 16385, 92560, 92552, 16378, 16386, 92772, 92748, 16580, 92773, 92775, 92751, 16582, 
92776, 92774, 92749, 16566, 16583
33636, 92560, 92552, 16378, 16386, 92561, 92553, 16379, 16387, 92775, 92751, 16582, 92776, 92778, 92754, 16584, 
92779, 92777, 92752, 16568, 16585
33637, 92561, 92553, 16379, 16387, 92562, 92554, 16380, 16388, 92778, 92754, 16584, 92779, 92781, 92757, 16586, 
92782, 92780, 92755, 16570, 16587
33638, 92562, 92554, 16380, 16388, 92563, 92555, 16381, 16389, 92781, 92757, 16586, 92782, 92784, 92760, 16588, 
92785, 92783, 92758, 16572, 16589
33639, 92563, 92555, 16381, 16389, 92564, 92556, 16382, 16390, 92784, 92760, 16588, 92785, 92787, 92763, 16590, 
92788, 92786, 92761, 16574, 16591
33640, 92564, 92556, 16382, 16390, 92565, 92557, 16383, 16391, 92787, 92763, 16590, 92788, 92790, 92766, 16592, 
92791, 92789, 92764, 16576, 16593
33641, 92565, 92557, 16383, 16391, 30875, 30874, 2292, 2293, 92790, 92766, 16592, 92791, 30900, 30897, 2315, 
30899, 92792, 92767, 16577, 16594
33642, 30787, 30786, 2197, 2198, 92566, 92558, 16384, 16392, 30812, 30811, 2220, 30813, 92794, 92770, 16595, 
92795, 92793, 92768, 16579, 16596
33643, 92566, 92558, 16384, 16392, 92567, 92559, 16385, 16393, 92794, 92770, 16595, 92795, 92797, 92773, 16597, 
92798, 92796, 92771, 16581, 16598
33644, 92567, 92559, 16385, 16393, 92568, 92560, 16386, 16394, 92797, 92773, 16597, 92798, 92800, 92776, 16599, 
92801, 92799, 92774, 16583, 16600
33645, 92568, 92560, 16386, 16394, 92569, 92561, 16387, 16395, 92800, 92776, 16599, 92801, 92803, 92779, 16601, 
92804, 92802, 92777, 16585, 16602
33646, 92569, 92561, 16387, 16395, 92570, 92562, 16388, 16396, 92803, 92779, 16601, 92804, 92806, 92782, 16603, 
92807, 92805, 92780, 16587, 16604
33647, 92570, 92562, 16388, 16396, 92571, 92563, 16389, 16397, 92806, 92782, 16603, 92807, 92809, 92785, 16605, 
92810, 92808, 92783, 16589, 16606
33648, 92571, 92563, 16389, 16397, 92572, 92564, 16390, 16398, 92809, 92785, 16605, 92810, 92812, 92788, 16607, 
92813, 92811, 92786, 16591, 16608
33649, 92572, 92564, 16390, 16398, 92573, 92565, 16391, 16399, 92812, 92788, 16607, 92813, 92815, 92791, 16609, 
92816, 92814, 92789, 16593, 16610
33650, 92573, 92565, 16391, 16399, 30876, 30875, 2293, 2294, 92815, 92791, 16609, 92816, 30902, 30899, 2316, 
30901, 92817, 92792, 16594, 16611
33651, 30788, 30787, 2198, 2199, 92574, 92566, 16392, 16400, 30814, 30813, 2221, 30815, 92819, 92795, 16612, 
92820, 92818, 92793, 16596, 16613
33652, 92574, 92566, 16392, 16400, 92575, 92567, 16393, 16401, 92819, 92795, 16612, 92820, 92822, 92798, 16614, 
92823, 92821, 92796, 16598, 16615
33653, 92575, 92567, 16393, 16401, 92576, 92568, 16394, 16402, 92822, 92798, 16614, 92823, 92825, 92801, 16616, 
92826, 92824, 92799, 16600, 16617
33654, 92576, 92568, 16394, 16402, 92577, 92569, 16395, 16403, 92825, 92801, 16616, 92826, 92828, 92804, 16618, 
92829, 92827, 92802, 16602, 16619
33655, 92577, 92569, 16395, 16403, 92578, 92570, 16396, 16404, 92828, 92804, 16618, 92829, 92831, 92807, 16620, 
92832, 92830, 92805, 16604, 16621
33656, 92578, 92570, 16396, 16404, 92579, 92571, 16397, 16405, 92831, 92807, 16620, 92832, 92834, 92810, 16622, 
92835, 92833, 92808, 16606, 16623
33657, 92579, 92571, 16397, 16405, 92580, 92572, 16398, 16406, 92834, 92810, 16622, 92835, 92837, 92813, 16624, 
92838, 92836, 92811, 16608, 16625
33658, 92580, 92572, 16398, 16406, 92581, 92573, 16399, 16407, 92837, 92813, 16624, 92838, 92840, 92816, 16626, 
92841, 92839, 92814, 16610, 16627
33659, 92581, 92573, 16399, 16407, 30877, 30876, 2294, 2295, 92840, 92816, 16626, 92841, 30904, 30901, 2317, 
30903, 92842, 92817, 16611, 16628
33660, 30789, 30788, 2199, 2200, 92582, 92574, 16400, 16408, 30816, 30815, 2222, 30817, 92844, 92820, 16629, 
92845, 92843, 92818, 16613, 16630
33661, 92582, 92574, 16400, 16408, 92583, 92575, 16401, 16409, 92844, 92820, 16629, 92845, 92847, 92823, 16631, 
92848, 92846, 92821, 16615, 16632
33662, 92583, 92575, 16401, 16409, 92584, 92576, 16402, 16410, 92847, 92823, 16631, 92848, 92850, 92826, 16633, 
92851, 92849, 92824, 16617, 16634
33663, 92584, 92576, 16402, 16410, 92585, 92577, 16403, 16411, 92850, 92826, 16633, 92851, 92853, 92829, 16635, 
92854, 92852, 92827, 16619, 16636
33664, 92585, 92577, 16403, 16411, 92586, 92578, 16404, 16412, 92853, 92829, 16635, 92854, 92856, 92832, 16637, 
92857, 92855, 92830, 16621, 16638
33665, 92586, 92578, 16404, 16412, 92587, 92579, 16405, 16413, 92856, 92832, 16637, 92857, 92859, 92835, 16639, 
92860, 92858, 92833, 16623, 16640
33666, 92587, 92579, 16405, 16413, 92588, 92580, 16406, 16414, 92859, 92835, 16639, 92860, 92862, 92838, 16641, 
92863, 92861, 92836, 16625, 16642
33667, 92588, 92580, 16406, 16414, 92589, 92581, 16407, 16415, 92862, 92838, 16641, 92863, 92865, 92841, 16643, 
92866, 92864, 92839, 16627, 16644
33668, 92589, 92581, 16407, 16415, 30878, 30877, 2295, 2296, 92865, 92841, 16643, 92866, 30906, 30903, 2318, 
30905, 92867, 92842, 16628, 16645
33669, 30790, 30789, 2200, 2201, 92590, 92582, 16408, 16416, 30818, 30817, 2223, 30819, 92869, 92845, 16646, 
92870, 92868, 92843, 16630, 16647
33670, 92590, 92582, 16408, 16416, 92591, 92583, 16409, 16417, 92869, 92845, 16646, 92870, 92872, 92848, 16648, 
92873, 92871, 92846, 16632, 16649
33671, 92591, 92583, 16409, 16417, 92592, 92584, 16410, 16418, 92872, 92848, 16648, 92873, 92875, 92851, 16650, 
92876, 92874, 92849, 16634, 16651
33672, 92592, 92584, 16410, 16418, 92593, 92585, 16411, 16419, 92875, 92851, 16650, 92876, 92878, 92854, 16652, 
92879, 92877, 92852, 16636, 16653
33673, 92593, 92585, 16411, 16419, 92594, 92586, 16412, 16420, 92878, 92854, 16652, 92879, 92881, 92857, 16654, 
92882, 92880, 92855, 16638, 16655
33674, 92594, 92586, 16412, 16420, 92595, 92587, 16413, 16421, 92881, 92857, 16654, 92882, 92884, 92860, 16656, 
92885, 92883, 92858, 16640, 16657
33675, 92595, 92587, 16413, 16421, 92596, 92588, 16414, 16422, 92884, 92860, 16656, 92885, 92887, 92863, 16658, 
92888, 92886, 92861, 16642, 16659
33676, 92596, 92588, 16414, 16422, 92597, 92589, 16415, 16423, 92887, 92863, 16658, 92888, 92890, 92866, 16660, 
92891, 92889, 92864, 16644, 16661
33677, 92597, 92589, 16415, 16423, 30879, 30878, 2296, 2297, 92890, 92866, 16660, 92891, 30908, 30905, 2319, 
30907, 92892, 92867, 16645, 16662
33678, 30791, 30790, 2201, 2202, 92598, 92590, 16416, 16424, 30820, 30819, 2224, 30821, 92894, 92870, 16663, 
92895, 92893, 92868, 16647, 16664
33679, 92598, 92590, 16416, 16424, 92599, 92591, 16417, 16425, 92894, 92870, 16663, 92895, 92897, 92873, 16665, 
92898, 92896, 92871, 16649, 16666
33680, 92599, 92591, 16417, 16425, 92600, 92592, 16418, 16426, 92897, 92873, 16665, 92898, 92900, 92876, 16667, 
92901, 92899, 92874, 16651, 16668
33681, 92600, 92592, 16418, 16426, 92601, 92593, 16419, 16427, 92900, 92876, 16667, 92901, 92903, 92879, 16669, 
92904, 92902, 92877, 16653, 16670
33682, 92601, 92593, 16419, 16427, 92602, 92594, 16420, 16428, 92903, 92879, 16669, 92904, 92906, 92882, 16671, 
92907, 92905, 92880, 16655, 16672
33683, 92602, 92594, 16420, 16428, 92603, 92595, 16421, 16429, 92906, 92882, 16671, 92907, 92909, 92885, 16673, 
92910, 92908, 92883, 16657, 16674
33684, 92603, 92595, 16421, 16429, 92604, 92596, 16422, 16430, 92909, 92885, 16673, 92910, 92912, 92888, 16675, 
92913, 92911, 92886, 16659, 16676
33685, 92604, 92596, 16422, 16430, 92605, 92597, 16423, 16431, 92912, 92888, 16675, 92913, 92915, 92891, 16677, 
92916, 92914, 92889, 16661, 16678
33686, 92605, 92597, 16423, 16431, 30880, 30879, 2297, 2298, 92915, 92891, 16677, 92916, 30910, 30907, 2320, 
30909, 92917, 92892, 16662, 16679
33687, 30792, 30791, 2202, 2203, 92606, 92598, 16424, 16432, 30822, 30821, 2225, 30823, 92919, 92895, 16680, 
92920, 92918, 92893, 16664, 16681
33688, 92606, 92598, 16424, 16432, 92607, 92599, 16425, 16433, 92919, 92895, 16680, 92920, 92922, 92898, 16682, 
92923, 92921, 92896, 16666, 16683
33689, 92607, 92599, 16425, 16433, 92608, 92600, 16426, 16434, 92922, 92898, 16682, 92923, 92925, 92901, 16684, 
92926, 92924, 92899, 16668, 16685
33690, 92608, 92600, 16426, 16434, 92609, 92601, 16427, 16435, 92925, 92901, 16684, 92926, 92928, 92904, 16686, 
92929, 92927, 92902, 16670, 16687
33691, 92609, 92601, 16427, 16435, 92610, 92602, 16428, 16436, 92928, 92904, 16686, 92929, 92931, 92907, 16688, 
92932, 92930, 92905, 16672, 16689
33692, 92610, 92602, 16428, 16436, 92611, 92603, 16429, 16437, 92931, 92907, 16688, 92932, 92934, 92910, 16690, 
92935, 92933, 92908, 16674, 16691
33693, 92611, 92603, 16429, 16437, 92612, 92604, 16430, 16438, 92934, 92910, 16690, 92935, 92937, 92913, 16692, 
92938, 92936, 92911, 16676, 16693
33694, 92612, 92604, 16430, 16438, 92613, 92605, 16431, 16439, 92937, 92913, 16692, 92938, 92940, 92916, 16694, 
92941, 92939, 92914, 16678, 16695
33695, 92613, 92605, 16431, 16439, 30881, 30880, 2298, 2299, 92940, 92916, 16694, 92941, 30912, 30909, 2321, 
30911, 92942, 92917, 16679, 16696
33696, 30793, 30792, 2203, 2204, 92614, 92606, 16432, 16440, 30824, 30823, 2226, 30825, 92944, 92920, 16697, 
92945, 92943, 92918, 16681, 16698
33697, 92614, 92606, 16432, 16440, 92615, 92607, 16433, 16441, 92944, 92920, 16697, 92945, 92947, 92923, 16699, 
92948, 92946, 92921, 16683, 16700
33698, 92615, 92607, 16433, 16441, 92616, 92608, 16434, 16442, 92947, 92923, 16699, 92948, 92950, 92926, 16701, 
92951, 92949, 92924, 16685, 16702
33699, 92616, 92608, 16434, 16442, 92617, 92609, 16435, 16443, 92950, 92926, 16701, 92951, 92953, 92929, 16703, 
92954, 92952, 92927, 16687, 16704
33700, 92617, 92609, 16435, 16443, 92618, 92610, 16436, 16444, 92953, 92929, 16703, 92954, 92956, 92932, 16705, 
92957, 92955, 92930, 16689, 16706
33701, 92618, 92610, 16436, 16444, 92619, 92611, 16437, 16445, 92956, 92932, 16705, 92957, 92959, 92935, 16707, 
92960, 92958, 92933, 16691, 16708
33702, 92619, 92611, 16437, 16445, 92620, 92612, 16438, 16446, 92959, 92935, 16707, 92960, 92962, 92938, 16709, 
92963, 92961, 92936, 16693, 16710
33703, 92620, 92612, 16438, 16446, 92621, 92613, 16439, 16447, 92962, 92938, 16709, 92963, 92965, 92941, 16711, 
92966, 92964, 92939, 16695, 16712
33704, 92621, 92613, 16439, 16447, 30882, 30881, 2299, 2300, 92965, 92941, 16711, 92966, 30914, 30911, 2322, 
30913, 92967, 92942, 16696, 16713
33705, 30794, 30793, 2204, 2205, 92622, 92614, 16440, 16448, 30826, 30825, 2227, 30827, 92969, 92945, 16714, 
92970, 92968, 92943, 16698, 16715
33706, 92622, 92614, 16440, 16448, 92623, 92615, 16441, 16449, 92969, 92945, 16714, 92970, 92972, 92948, 16716, 
92973, 92971, 92946, 16700, 16717
33707, 92623, 92615, 16441, 16449, 92624, 92616, 16442, 16450, 92972, 92948, 16716, 92973, 92975, 92951, 16718, 
92976, 92974, 92949, 16702, 16719
33708, 92624, 92616, 16442, 16450, 92625, 92617, 16443, 16451, 92975, 92951, 16718, 92976, 92978, 92954, 16720, 
92979, 92977, 92952, 16704, 16721
33709, 92625, 92617, 16443, 16451, 92626, 92618, 16444, 16452, 92978, 92954, 16720, 92979, 92981, 92957, 16722, 
92982, 92980, 92955, 16706, 16723
33710, 92626, 92618, 16444, 16452, 92627, 92619, 16445, 16453, 92981, 92957, 16722, 92982, 92984, 92960, 16724, 
92985, 92983, 92958, 16708, 16725
33711, 92627, 92619, 16445, 16453, 92628, 92620, 16446, 16454, 92984, 92960, 16724, 92985, 92987, 92963, 16726, 
92988, 92986, 92961, 16710, 16727
33712, 92628, 92620, 16446, 16454, 92629, 92621, 16447, 16455, 92987, 92963, 16726, 92988, 92990, 92966, 16728, 
92991, 92989, 92964, 16712, 16729
33713, 92629, 92621, 16447, 16455, 30883, 30882, 2300, 2301, 92990, 92966, 16728, 92991, 30916, 30913, 2323, 
30915, 92992, 92967, 16713, 16730
33714, 30795, 30794, 2205, 2206, 92630, 92622, 16448, 16456, 30828, 30827, 2228, 30829, 92994, 92970, 16731, 
92995, 92993, 92968, 16715, 16732
33715, 92630, 92622, 16448, 16456, 92631, 92623, 16449, 16457, 92994, 92970, 16731, 92995, 92997, 92973, 16733, 
92998, 92996, 92971, 16717, 16734
33716, 92631, 92623, 16449, 16457, 92632, 92624, 16450, 16458, 92997, 92973, 16733, 92998, 93000, 92976, 16735, 
93001, 92999, 92974, 16719, 16736
33717, 92632, 92624, 16450, 16458, 92633, 92625, 16451, 16459, 93000, 92976, 16735, 93001, 93003, 92979, 16737, 
93004, 93002, 92977, 16721, 16738
33718, 92633, 92625, 16451, 16459, 92634, 92626, 16452, 16460, 93003, 92979, 16737, 93004, 93006, 92982, 16739, 
93007, 93005, 92980, 16723, 16740
33719, 92634, 92626, 16452, 16460, 92635, 92627, 16453, 16461, 93006, 92982, 16739, 93007, 93009, 92985, 16741, 
93010, 93008, 92983, 16725, 16742
33720, 92635, 92627, 16453, 16461, 92636, 92628, 16454, 16462, 93009, 92985, 16741, 93010, 93012, 92988, 16743, 
93013, 93011, 92986, 16727, 16744
33721, 92636, 92628, 16454, 16462, 92637, 92629, 16455, 16463, 93012, 92988, 16743, 93013, 93015, 92991, 16745, 
93016, 93014, 92989, 16729, 16746
33722, 92637, 92629, 16455, 16463, 30884, 30883, 2301, 2302, 93015, 92991, 16745, 93016, 30918, 30915, 2324, 
30917, 93017, 92992, 16730, 16747
33723, 30796, 30795, 2206, 2207, 92638, 92630, 16456, 16464, 30830, 30829, 2229, 30831, 93019, 92995, 16748, 
93020, 93018, 92993, 16732, 16749
33724, 92638, 92630, 16456, 16464, 92639, 92631, 16457, 16465, 93019, 92995, 16748, 93020, 93022, 92998, 16750, 
93023, 93021, 92996, 16734, 16751
33725, 92639, 92631, 16457, 16465, 92640, 92632, 16458, 16466, 93022, 92998, 16750, 93023, 93025, 93001, 16752, 
93026, 93024, 92999, 16736, 16753
33726, 92640, 92632, 16458, 16466, 92641, 92633, 16459, 16467, 93025, 93001, 16752, 93026, 93028, 93004, 16754, 
93029, 93027, 93002, 16738, 16755
33727, 92641, 92633, 16459, 16467, 92642, 92634, 16460, 16468, 93028, 93004, 16754, 93029, 93031, 93007, 16756, 
93032, 93030, 93005, 16740, 16757
33728, 92642, 92634, 16460, 16468, 92643, 92635, 16461, 16469, 93031, 93007, 16756, 93032, 93034, 93010, 16758, 
93035, 93033, 93008, 16742, 16759
33729, 92643, 92635, 16461, 16469, 92644, 92636, 16462, 16470, 93034, 93010, 16758, 93035, 93037, 93013, 16760, 
93038, 93036, 93011, 16744, 16761
33730, 92644, 92636, 16462, 16470, 92645, 92637, 16463, 16471, 93037, 93013, 16760, 93038, 93040, 93016, 16762, 
93041, 93039, 93014, 16746, 16763
33731, 92645, 92637, 16463, 16471, 30885, 30884, 2302, 2303, 93040, 93016, 16762, 93041, 30920, 30917, 2325, 
30919, 93042, 93017, 16747, 16764
33732, 30797, 30796, 2207, 2208, 92646, 92638, 16464, 16472, 30832, 30831, 2230, 30833, 93044, 93020, 16765, 
93045, 93043, 93018, 16749, 16766
33733, 92646, 92638, 16464, 16472, 92647, 92639, 16465, 16473, 93044, 93020, 16765, 93045, 93047, 93023, 16767, 
93048, 93046, 93021, 16751, 16768
33734, 92647, 92639, 16465, 16473, 92648, 92640, 16466, 16474, 93047, 93023, 16767, 93048, 93050, 93026, 16769, 
93051, 93049, 93024, 16753, 16770
33735, 92648, 92640, 16466, 16474, 92649, 92641, 16467, 16475, 93050, 93026, 16769, 93051, 93053, 93029, 16771, 
93054, 93052, 93027, 16755, 16772
33736, 92649, 92641, 16467, 16475, 92650, 92642, 16468, 16476, 93053, 93029, 16771, 93054, 93056, 93032, 16773, 
93057, 93055, 93030, 16757, 16774
33737, 92650, 92642, 16468, 16476, 92651, 92643, 16469, 16477, 93056, 93032, 16773, 93057, 93059, 93035, 16775, 
93060, 93058, 93033, 16759, 16776
33738, 92651, 92643, 16469, 16477, 92652, 92644, 16470, 16478, 93059, 93035, 16775, 93060, 93062, 93038, 16777, 
93063, 93061, 93036, 16761, 16778
33739, 92652, 92644, 16470, 16478, 92653, 92645, 16471, 16479, 93062, 93038, 16777, 93063, 93065, 93041, 16779, 
93066, 93064, 93039, 16763, 16780
33740, 92653, 92645, 16471, 16479, 30886, 30885, 2303, 2304, 93065, 93041, 16779, 93066, 30922, 30919, 2326, 
30921, 93067, 93042, 16764, 16781
33741, 30798, 30797, 2208, 2209, 92654, 92646, 16472, 16480, 30834, 30833, 2231, 30835, 93069, 93045, 16782, 
93070, 93068, 93043, 16766, 16783
33742, 92654, 92646, 16472, 16480, 92655, 92647, 16473, 16481, 93069, 93045, 16782, 93070, 93072, 93048, 16784, 
93073, 93071, 93046, 16768, 16785
33743, 92655, 92647, 16473, 16481, 92656, 92648, 16474, 16482, 93072, 93048, 16784, 93073, 93075, 93051, 16786, 
93076, 93074, 93049, 16770, 16787
33744, 92656, 92648, 16474, 16482, 92657, 92649, 16475, 16483, 93075, 93051, 16786, 93076, 93078, 93054, 16788, 
93079, 93077, 93052, 16772, 16789
33745, 92657, 92649, 16475, 16483, 92658, 92650, 16476, 16484, 93078, 93054, 16788, 93079, 93081, 93057, 16790, 
93082, 93080, 93055, 16774, 16791
33746, 92658, 92650, 16476, 16484, 92659, 92651, 16477, 16485, 93081, 93057, 16790, 93082, 93084, 93060, 16792, 
93085, 93083, 93058, 16776, 16793
33747, 92659, 92651, 16477, 16485, 92660, 92652, 16478, 16486, 93084, 93060, 16792, 93085, 93087, 93063, 16794, 
93088, 93086, 93061, 16778, 16795
33748, 92660, 92652, 16478, 16486, 92661, 92653, 16479, 16487, 93087, 93063, 16794, 93088, 93090, 93066, 16796, 
93091, 93089, 93064, 16780, 16797
33749, 92661, 92653, 16479, 16487, 30887, 30886, 2304, 2305, 93090, 93066, 16796, 93091, 30924, 30921, 2327, 
30923, 93092, 93067, 16781, 16798
33750, 30799, 30798, 2209, 2210, 92662, 92654, 16480, 16488, 30836, 30835, 2232, 30837, 93094, 93070, 16799, 
93095, 93093, 93068, 16783, 16800
33751, 92662, 92654, 16480, 16488, 92663, 92655, 16481, 16489, 93094, 93070, 16799, 93095, 93097, 93073, 16801, 
93098, 93096, 93071, 16785, 16802
33752, 92663, 92655, 16481, 16489, 92664, 92656, 16482, 16490, 93097, 93073, 16801, 93098, 93100, 93076, 16803, 
93101, 93099, 93074, 16787, 16804
33753, 92664, 92656, 16482, 16490, 92665, 92657, 16483, 16491, 93100, 93076, 16803, 93101, 93103, 93079, 16805, 
93104, 93102, 93077, 16789, 16806
33754, 92665, 92657, 16483, 16491, 92666, 92658, 16484, 16492, 93103, 93079, 16805, 93104, 93106, 93082, 16807, 
93107, 93105, 93080, 16791, 16808
33755, 92666, 92658, 16484, 16492, 92667, 92659, 16485, 16493, 93106, 93082, 16807, 93107, 93109, 93085, 16809, 
93110, 93108, 93083, 16793, 16810
33756, 92667, 92659, 16485, 16493, 92668, 92660, 16486, 16494, 93109, 93085, 16809, 93110, 93112, 93088, 16811, 
93113, 93111, 93086, 16795, 16812
33757, 92668, 92660, 16486, 16494, 92669, 92661, 16487, 16495, 93112, 93088, 16811, 93113, 93115, 93091, 16813, 
93116, 93114, 93089, 16797, 16814
33758, 92669, 92661, 16487, 16495, 30888, 30887, 2305, 2306, 93115, 93091, 16813, 93116, 30926, 30923, 2328, 
30925, 93117, 93092, 16798, 16815
33759, 30800, 30799, 2210, 2211, 92670, 92662, 16488, 16496, 30838, 30837, 2233, 30839, 93119, 93095, 16816, 
93120, 93118, 93093, 16800, 16817
33760, 92670, 92662, 16488, 16496, 92671, 92663, 16489, 16497, 93119, 93095, 16816, 93120, 93122, 93098, 16818, 
93123, 93121, 93096, 16802, 16819
33761, 92671, 92663, 16489, 16497, 92672, 92664, 16490, 16498, 93122, 93098, 16818, 93123, 93125, 93101, 16820, 
93126, 93124, 93099, 16804, 16821
33762, 92672, 92664, 16490, 16498, 92673, 92665, 16491, 16499, 93125, 93101, 16820, 93126, 93128, 93104, 16822, 
93129, 93127, 93102, 16806, 16823
33763, 92673, 92665, 16491, 16499, 92674, 92666, 16492, 16500, 93128, 93104, 16822, 93129, 93131, 93107, 16824, 
93132, 93130, 93105, 16808, 16825
33764, 92674, 92666, 16492, 16500, 92675, 92667, 16493, 16501, 93131, 93107, 16824, 93132, 93134, 93110, 16826, 
93135, 93133, 93108, 16810, 16827
33765, 92675, 92667, 16493, 16501, 92676, 92668, 16494, 16502, 93134, 93110, 16826, 93135, 93137, 93113, 16828, 
93138, 93136, 93111, 16812, 16829
33766, 92676, 92668, 16494, 16502, 92677, 92669, 16495, 16503, 93137, 93113, 16828, 93138, 93140, 93116, 16830, 
93141, 93139, 93114, 16814, 16831
33767, 92677, 92669, 16495, 16503, 30889, 30888, 2306, 2307, 93140, 93116, 16830, 93141, 30928, 30925, 2329, 
30927, 93142, 93117, 16815, 16832
33768, 30801, 30800, 2211, 2212, 92678, 92670, 16496, 16504, 30840, 30839, 2234, 30841, 93144, 93120, 16833, 
93145, 93143, 93118, 16817, 16834
33769, 92678, 92670, 16496, 16504, 92679, 92671, 16497, 16505, 93144, 93120, 16833, 93145, 93147, 93123, 16835, 
93148, 93146, 93121, 16819, 16836
33770, 92679, 92671, 16497, 16505, 92680, 92672, 16498, 16506, 93147, 93123, 16835, 93148, 93150, 93126, 16837, 
93151, 93149, 93124, 16821, 16838
33771, 92680, 92672, 16498, 16506, 92681, 92673, 16499, 16507, 93150, 93126, 16837, 93151, 93153, 93129, 16839, 
93154, 93152, 93127, 16823, 16840
33772, 92681, 92673, 16499, 16507, 92682, 92674, 16500, 16508, 93153, 93129, 16839, 93154, 93156, 93132, 16841, 
93157, 93155, 93130, 16825, 16842
33773, 92682, 92674, 16500, 16508, 92683, 92675, 16501, 16509, 93156, 93132, 16841, 93157, 93159, 93135, 16843, 
93160, 93158, 93133, 16827, 16844
33774, 92683, 92675, 16501, 16509, 92684, 92676, 16502, 16510, 93159, 93135, 16843, 93160, 93162, 93138, 16845, 
93163, 93161, 93136, 16829, 16846
33775, 92684, 92676, 16502, 16510, 92685, 92677, 16503, 16511, 93162, 93138, 16845, 93163, 93165, 93141, 16847, 
93166, 93164, 93139, 16831, 16848
33776, 92685, 92677, 16503, 16511, 30890, 30889, 2307, 2308, 93165, 93141, 16847, 93166, 30930, 30927, 2330, 
30929, 93167, 93142, 16832, 16849
33777, 30802, 30801, 2212, 2213, 92686, 92678, 16504, 16512, 30842, 30841, 2235, 30843, 93169, 93145, 16850, 
93170, 93168, 93143, 16834, 16851
33778, 92686, 92678, 16504, 16512, 92687, 92679, 16505, 16513, 93169, 93145, 16850, 93170, 93172, 93148, 16852, 
93173, 93171, 93146, 16836, 16853
33779, 92687, 92679, 16505, 16513, 92688, 92680, 16506, 16514, 93172, 93148, 16852, 93173, 93175, 93151, 16854, 
93176, 93174, 93149, 16838, 16855
33780, 92688, 92680, 16506, 16514, 92689, 92681, 16507, 16515, 93175, 93151, 16854, 93176, 93178, 93154, 16856, 
93179, 93177, 93152, 16840, 16857
33781, 92689, 92681, 16507, 16515, 92690, 92682, 16508, 16516, 93178, 93154, 16856, 93179, 93181, 93157, 16858, 
93182, 93180, 93155, 16842, 16859
33782, 92690, 92682, 16508, 16516, 92691, 92683, 16509, 16517, 93181, 93157, 16858, 93182, 93184, 93160, 16860, 
93185, 93183, 93158, 16844, 16861
33783, 92691, 92683, 16509, 16517, 92692, 92684, 16510, 16518, 93184, 93160, 16860, 93185, 93187, 93163, 16862, 
93188, 93186, 93161, 16846, 16863
33784, 92692, 92684, 16510, 16518, 92693, 92685, 16511, 16519, 93187, 93163, 16862, 93188, 93190, 93166, 16864, 
93191, 93189, 93164, 16848, 16865
33785, 92693, 92685, 16511, 16519, 30891, 30890, 2308, 2309, 93190, 93166, 16864, 93191, 30932, 30929, 2331, 
30931, 93192, 93167, 16849, 16866
33786, 30803, 30802, 2213, 2214, 92694, 92686, 16512, 16520, 30844, 30843, 2236, 30845, 93194, 93170, 16867, 
93195, 93193, 93168, 16851, 16868
33787, 92694, 92686, 16512, 16520, 92695, 92687, 16513, 16521, 93194, 93170, 16867, 93195, 93197, 93173, 16869, 
93198, 93196, 93171, 16853, 16870
33788, 92695, 92687, 16513, 16521, 92696, 92688, 16514, 16522, 93197, 93173, 16869, 93198, 93200, 93176, 16871, 
93201, 93199, 93174, 16855, 16872
33789, 92696, 92688, 16514, 16522, 92697, 92689, 16515, 16523, 93200, 93176, 16871, 93201, 93203, 93179, 16873, 
93204, 93202, 93177, 16857, 16874
33790, 92697, 92689, 16515, 16523, 92698, 92690, 16516, 16524, 93203, 93179, 16873, 93204, 93206, 93182, 16875, 
93207, 93205, 93180, 16859, 16876
33791, 92698, 92690, 16516, 16524, 92699, 92691, 16517, 16525, 93206, 93182, 16875, 93207, 93209, 93185, 16877, 
93210, 93208, 93183, 16861, 16878
33792, 92699, 92691, 16517, 16525, 92700, 92692, 16518, 16526, 93209, 93185, 16877, 93210, 93212, 93188, 16879, 
93213, 93211, 93186, 16863, 16880
33793, 92700, 92692, 16518, 16526, 92701, 92693, 16519, 16527, 93212, 93188, 16879, 93213, 93215, 93191, 16881, 
93216, 93214, 93189, 16865, 16882
33794, 92701, 92693, 16519, 16527, 30892, 30891, 2309, 2310, 93215, 93191, 16881, 93216, 30934, 30931, 2332, 
30933, 93217, 93192, 16866, 16883
33795, 30804, 30803, 2214, 2215, 92702, 92694, 16520, 16528, 30846, 30845, 2237, 30847, 93219, 93195, 16884, 
93220, 93218, 93193, 16868, 16885
33796, 92702, 92694, 16520, 16528, 92703, 92695, 16521, 16529, 93219, 93195, 16884, 93220, 93222, 93198, 16886, 
93223, 93221, 93196, 16870, 16887
33797, 92703, 92695, 16521, 16529, 92704, 92696, 16522, 16530, 93222, 93198, 16886, 93223, 93225, 93201, 16888, 
93226, 93224, 93199, 16872, 16889
33798, 92704, 92696, 16522, 16530, 92705, 92697, 16523, 16531, 93225, 93201, 16888, 93226, 93228, 93204, 16890, 
93229, 93227, 93202, 16874, 16891
33799, 92705, 92697, 16523, 16531, 92706, 92698, 16524, 16532, 93228, 93204, 16890, 93229, 93231, 93207, 16892, 
93232, 93230, 93205, 16876, 16893
33800, 92706, 92698, 16524, 16532, 92707, 92699, 16525, 16533, 93231, 93207, 16892, 93232, 93234, 93210, 16894, 
93235, 93233, 93208, 16878, 16895
33801, 92707, 92699, 16525, 16533, 92708, 92700, 16526, 16534, 93234, 93210, 16894, 93235, 93237, 93213, 16896, 
93238, 93236, 93211, 16880, 16897
33802, 92708, 92700, 16526, 16534, 92709, 92701, 16527, 16535, 93237, 93213, 16896, 93238, 93240, 93216, 16898, 
93241, 93239, 93214, 16882, 16899
33803, 92709, 92701, 16527, 16535, 30893, 30892, 2310, 2311, 93240, 93216, 16898, 93241, 30936, 30933, 2333, 
30935, 93242, 93217, 16883, 16900
33804, 30805, 30804, 2215, 2216, 92710, 92702, 16528, 16536, 30848, 30847, 2238, 30849, 93244, 93220, 16901, 
93245, 93243, 93218, 16885, 16902
33805, 92710, 92702, 16528, 16536, 92711, 92703, 16529, 16537, 93244, 93220, 16901, 93245, 93247, 93223, 16903, 
93248, 93246, 93221, 16887, 16904
33806, 92711, 92703, 16529, 16537, 92712, 92704, 16530, 16538, 93247, 93223, 16903, 93248, 93250, 93226, 16905, 
93251, 93249, 93224, 16889, 16906
33807, 92712, 92704, 16530, 16538, 92713, 92705, 16531, 16539, 93250, 93226, 16905, 93251, 93253, 93229, 16907, 
93254, 93252, 93227, 16891, 16908
33808, 92713, 92705, 16531, 16539, 92714, 92706, 16532, 16540, 93253, 93229, 16907, 93254, 93256, 93232, 16909, 
93257, 93255, 93230, 16893, 16910
33809, 92714, 92706, 16532, 16540, 92715, 92707, 16533, 16541, 93256, 93232, 16909, 93257, 93259, 93235, 16911, 
93260, 93258, 93233, 16895, 16912
33810, 92715, 92707, 16533, 16541, 92716, 92708, 16534, 16542, 93259, 93235, 16911, 93260, 93262, 93238, 16913, 
93263, 93261, 93236, 16897, 16914
33811, 92716, 92708, 16534, 16542, 92717, 92709, 16535, 16543, 93262, 93238, 16913, 93263, 93265, 93241, 16915, 
93266, 93264, 93239, 16899, 16916
33812, 92717, 92709, 16535, 16543, 30894, 30893, 2311, 2312, 93265, 93241, 16915, 93266, 30938, 30935, 2334, 
30937, 93267, 93242, 16900, 16917
33813, 3604, 30805, 2216, 73, 30995, 92710, 16536, 2377, 30850, 30849, 2239, 3605, 93268, 93245, 16918, 
31004, 31003, 93243, 16902, 2386
33814, 30995, 92710, 16536, 2377, 30996, 92711, 16537, 2376, 93268, 93245, 16918, 31004, 93269, 93248, 16919, 
31006, 31005, 93246, 16904, 2385
33815, 30996, 92711, 16537, 2376, 30997, 92712, 16538, 2375, 93269, 93248, 16919, 31006, 93270, 93251, 16920, 
31008, 31007, 93249, 16906, 2384
33816, 30997, 92712, 16538, 2375, 30998, 92713, 16539, 2374, 93270, 93251, 16920, 31008, 93271, 93254, 16921, 
31010, 31009, 93252, 16908, 2383
33817, 30998, 92713, 16539, 2374, 30999, 92714, 16540, 2373, 93271, 93254, 16921, 31010, 93272, 93257, 16922, 
31012, 31011, 93255, 16910, 2382
33818, 30999, 92714, 16540, 2373, 31000, 92715, 16541, 2372, 93272, 93257, 16922, 31012, 93273, 93260, 16923, 
31014, 31013, 93258, 16912, 2381
33819, 31000, 92715, 16541, 2372, 31001, 92716, 16542, 2371, 93273, 93260, 16923, 31014, 93274, 93263, 16924, 
31016, 31015, 93261, 16914, 2380
33820, 31001, 92716, 16542, 2371, 31002, 92717, 16543, 2370, 93274, 93263, 16924, 31016, 93275, 93266, 16925, 
31018, 31017, 93264, 16916, 2379
33821, 31002, 92717, 16543, 2370, 3610, 30894, 2312, 76, 93275, 93266, 16925, 31018, 30939, 30937, 2335, 
3611, 31019, 93267, 16917, 2378
33822, 3215, 93, 3601, 30784, 28692, 3402, 30962, 92542, 3237, 3603, 30806, 30851, 28869, 30987, 92719, 
93276, 28868, 3411, 30971, 92718
33823, 28692, 3402, 30962, 92542, 28693, 3401, 30963, 92543, 28869, 30987, 92719, 93276, 28871, 30988, 92722, 
93277, 28870, 3410, 30973, 92721
33824, 28693, 3401, 30963, 92543, 28694, 3400, 30964, 92544, 28871, 30988, 92722, 93277, 28873, 30989, 92725, 
93278, 28872, 3409, 30975, 92724
33825, 28694, 3400, 30964, 92544, 28695, 3399, 30965, 92545, 28873, 30989, 92725, 93278, 28875, 30990, 92728, 
93279, 28874, 3408, 30977, 92727
33826, 28695, 3399, 30965, 92545, 28696, 3398, 30966, 92546, 28875, 30990, 92728, 93279, 28877, 30991, 92731, 
93280, 28876, 3407, 30979, 92730
33827, 28696, 3398, 30966, 92546, 28697, 3397, 30967, 92547, 28877, 30991, 92731, 93280, 28879, 30992, 92734, 
93281, 28878, 3406, 30981, 92733
33828, 28697, 3397, 30967, 92547, 28698, 3396, 30968, 92548, 28879, 30992, 92734, 93281, 28881, 30993, 92737, 
93282, 28880, 3405, 30983, 92736
33829, 28698, 3396, 30968, 92548, 28699, 3395, 30969, 92549, 28881, 30993, 92737, 93282, 28883, 30994, 92740, 
93283, 28882, 3404, 30985, 92739
33830, 28699, 3395, 30969, 92549, 3350, 95, 3607, 30873, 28883, 30994, 92740, 93283, 3372, 3609, 30896, 
30940, 28884, 3403, 30986, 92742
33831, 3216, 3215, 30784, 30785, 28700, 28692, 92542, 92550, 3238, 30851, 30808, 30852, 28886, 93276, 92744, 
93284, 28885, 28868, 92718, 92743
33832, 28700, 28692, 92542, 92550, 28701, 28693, 92543, 92551, 28886, 93276, 92744, 93284, 28888, 93277, 92747, 
93285, 28887, 28870, 92721, 92746
33833, 28701, 28693, 92543, 92551, 28702, 28694, 92544, 92552, 28888, 93277, 92747, 93285, 28890, 93278, 92750, 
93286, 28889, 28872, 92724, 92749
33834, 28702, 28694, 92544, 92552, 28703, 28695, 92545, 92553, 28890, 93278, 92750, 93286, 28892, 93279, 92753, 
93287, 28891, 28874, 92727, 92752
33835, 28703, 28695, 92545, 92553, 28704, 28696, 92546, 92554, 28892, 93279, 92753, 93287, 28894, 93280, 92756, 
93288, 28893, 28876, 92730, 92755
33836, 28704, 28696, 92546, 92554, 28705, 28697, 92547, 92555, 28894, 93280, 92756, 93288, 28896, 93281, 92759, 
93289, 28895, 28878, 92733, 92758
33837, 28705, 28697, 92547, 92555, 28706, 28698, 92548, 92556, 28896, 93281, 92759, 93289, 28898, 93282, 92762, 
93290, 28897, 28880, 92736, 92761
33838, 28706, 28698, 92548, 92556, 28707, 28699, 92549, 92557, 28898, 93282, 92762, 93290, 28900, 93283, 92765, 
93291, 28899, 28882, 92739, 92764
33839, 28707, 28699, 92549, 92557, 3351, 3350, 30873, 30874, 28900, 93283, 92765, 93291, 3373, 30940, 30898, 
30941, 28901, 28884, 92742, 92767
33840, 3217, 3216, 30785, 30786, 28708, 28700, 92550, 92558, 3239, 30852, 30810, 30853, 28903, 93284, 92769, 
93292, 28902, 28885, 92743, 92768
33841, 28708, 28700, 92550, 92558, 28709, 28701, 92551, 92559, 28903, 93284, 92769, 93292, 28905, 93285, 92772, 
93293, 28904, 28887, 92746, 92771
33842, 28709, 28701, 92551, 92559, 28710, 28702, 92552, 92560, 28905, 93285, 92772, 93293, 28907, 93286, 92775, 
93294, 28906, 28889, 92749, 92774
33843, 28710, 28702, 92552, 92560, 28711, 28703, 92553, 92561, 28907, 93286, 92775, 93294, 28909, 93287, 92778, 
93295, 28908, 28891, 92752, 92777
33844, 28711, 28703, 92553, 92561, 28712, 28704, 92554, 92562, 28909, 93287, 92778, 93295, 28911, 93288, 92781, 
93296, 28910, 28893, 92755, 92780
33845, 28712, 28704, 92554, 92562, 28713, 28705, 92555, 92563, 28911, 93288, 92781, 93296, 28913, 93289, 92784, 
93297, 28912, 28895, 92758, 92783
33846, 28713, 28705, 92555, 92563, 28714, 28706, 92556, 92564, 28913, 93289, 92784, 93297, 28915, 93290, 92787, 
93298, 28914, 28897, 92761, 92786
33847, 28714, 28706, 92556, 92564, 28715, 28707, 92557, 92565, 28915, 93290, 92787, 93298, 28917, 93291, 92790, 
93299, 28916, 28899, 92764, 92789
33848, 28715, 28707, 92557, 92565, 3352, 3351, 30874, 30875, 28917, 93291, 92790, 93299, 3374, 30941, 30900, 
30942, 28918, 28901, 92767, 92792
33849, 3218, 3217, 30786, 30787, 28716, 28708, 92558, 92566, 3240, 30853, 30812, 30854, 28920, 93292, 92794, 
93300, 28919, 28902, 92768, 92793
33850, 28716, 28708, 92558, 92566, 28717, 28709, 92559, 92567, 28920, 93292, 92794, 93300, 28922, 93293, 92797, 
93301, 28921, 28904, 92771, 92796
33851, 28717, 28709, 92559, 92567, 28718, 28710, 92560, 92568, 28922, 93293, 92797, 93301, 28924, 93294, 92800, 
93302, 28923, 28906, 92774, 92799
33852, 28718, 28710, 92560, 92568, 28719, 28711, 92561, 92569, 28924, 93294, 92800, 93302, 28926, 93295, 92803, 
93303, 28925, 28908, 92777, 92802
33853, 28719, 28711, 92561, 92569, 28720, 28712, 92562, 92570, 28926, 93295, 92803, 93303, 28928, 93296, 92806, 
93304, 28927, 28910, 92780, 92805
33854, 28720, 28712, 92562, 92570, 28721, 28713, 92563, 92571, 28928, 93296, 92806, 93304, 28930, 93297, 92809, 
93305, 28929, 28912, 92783, 92808
33855, 28721, 28713, 92563, 92571, 28722, 28714, 92564, 92572, 28930, 93297, 92809, 93305, 28932, 93298, 92812, 
93306, 28931, 28914, 92786, 92811
33856, 28722, 28714, 92564, 92572, 28723, 28715, 92565, 92573, 28932, 93298, 92812, 93306, 28934, 93299, 92815, 
93307, 28933, 28916, 92789, 92814
33857, 28723, 28715, 92565, 92573, 3353, 3352, 30875, 30876, 28934, 93299, 92815, 93307, 3375, 30942, 30902, 
30943, 28935, 28918, 92792, 92817
33858, 3219, 3218, 30787, 30788, 28724, 28716, 92566, 92574, 3241, 30854, 30814, 30855, 28937, 93300, 92819, 
93308, 28936, 28919, 92793, 92818
33859, 28724, 28716, 92566, 92574, 28725, 28717, 92567, 92575, 28937, 93300, 92819, 93308, 28939, 93301, 92822, 
93309, 28938, 28921, 92796, 92821
33860, 28725, 28717, 92567, 92575, 28726, 28718, 92568, 92576, 28939, 93301, 92822, 93309, 28941, 93302, 92825, 
93310, 28940, 28923, 92799, 92824
33861, 28726, 28718, 92568, 92576, 28727, 28719, 92569, 92577, 28941, 93302, 92825, 93310, 28943, 93303, 92828, 
93311, 28942, 28925, 92802, 92827
33862, 28727, 28719, 92569, 92577, 28728, 28720, 92570, 92578, 28943, 93303, 92828, 93311, 28945, 93304, 92831, 
93312, 28944, 28927, 92805, 92830
33863, 28728, 28720, 92570, 92578, 28729, 28721, 92571, 92579, 28945, 93304, 92831, 93312, 28947, 93305, 92834, 
93313, 28946, 28929, 92808, 92833
33864, 28729, 28721, 92571, 92579, 28730, 28722, 92572, 92580, 28947, 93305, 92834, 93313, 28949, 93306, 92837, 
93314, 28948, 28931, 92811, 92836
33865, 28730, 28722, 92572, 92580, 28731, 28723, 92573, 92581, 28949, 93306, 92837, 93314, 28951, 93307, 92840, 
93315, 28950, 28933, 92814, 92839
33866, 28731, 28723, 92573, 92581, 3354, 3353, 30876, 30877, 28951, 93307, 92840, 93315, 3376, 30943, 30904, 
30944, 28952, 28935, 92817, 92842
33867, 3220, 3219, 30788, 30789, 28732, 28724, 92574, 92582, 3242, 30855, 30816, 30856, 28954, 93308, 92844, 
93316, 28953, 28936, 92818, 92843
33868, 28732, 28724, 92574, 92582, 28733, 28725, 92575, 92583, 28954, 93308, 92844, 93316, 28956, 93309, 92847, 
93317, 28955, 28938, 92821, 92846
33869, 28733, 28725, 92575, 92583, 28734, 28726, 92576, 92584, 28956, 93309, 92847, 93317, 28958, 93310, 92850, 
93318, 28957, 28940, 92824, 92849
33870, 28734, 28726, 92576, 92584, 28735, 28727, 92577, 92585, 28958, 93310, 92850, 93318, 28960, 93311, 92853, 
93319, 28959, 28942, 92827, 92852
33871, 28735, 28727, 92577, 92585, 28736, 28728, 92578, 92586, 28960, 93311, 92853, 93319, 28962, 93312, 92856, 
93320, 28961, 28944, 92830, 92855
33872, 28736, 28728, 92578, 92586, 28737, 28729, 92579, 92587, 28962, 93312, 92856, 93320, 28964, 93313, 92859, 
93321, 28963, 28946, 92833, 92858
33873, 28737, 28729, 92579, 92587, 28738, 28730, 92580, 92588, 28964, 93313, 92859, 93321, 28966, 93314, 92862, 
93322, 28965, 28948, 92836, 92861
33874, 28738, 28730, 92580, 92588, 28739, 28731, 92581, 92589, 28966, 93314, 92862, 93322, 28968, 93315, 92865, 
93323, 28967, 28950, 92839, 92864
33875, 28739, 28731, 92581, 92589, 3355, 3354, 30877, 30878, 28968, 93315, 92865, 93323, 3377, 30944, 30906, 
30945, 28969, 28952, 92842, 92867
33876, 3221, 3220, 30789, 30790, 28740, 28732, 92582, 92590, 3243, 30856, 30818, 30857, 28971, 93316, 92869, 
93324, 28970, 28953, 92843, 92868
33877, 28740, 28732, 92582, 92590, 28741, 28733, 92583, 92591, 28971, 93316, 92869, 93324, 28973, 93317, 92872, 
93325, 28972, 28955, 92846, 92871
33878, 28741, 28733, 92583, 92591, 28742, 28734, 92584, 92592, 28973, 93317, 92872, 93325, 28975, 93318, 92875, 
93326, 28974, 28957, 92849, 92874
33879, 28742, 28734, 92584, 92592, 28743, 28735, 92585, 92593, 28975, 93318, 92875, 93326, 28977, 93319, 92878, 
93327, 28976, 28959, 92852, 92877
33880, 28743, 28735, 92585, 92593, 28744, 28736, 92586, 92594, 28977, 93319, 92878, 93327, 28979, 93320, 92881, 
93328, 28978, 28961, 92855, 92880
33881, 28744, 28736, 92586, 92594, 28745, 28737, 92587, 92595, 28979, 93320, 92881, 93328, 28981, 93321, 92884, 
93329, 28980, 28963, 92858, 92883
33882, 28745, 28737, 92587, 92595, 28746, 28738, 92588, 92596, 28981, 93321, 92884, 93329, 28983, 93322, 92887, 
93330, 28982, 28965, 92861, 92886
33883, 28746, 28738, 92588, 92596, 28747, 28739, 92589, 92597, 28983, 93322, 92887, 93330, 28985, 93323, 92890, 
93331, 28984, 28967, 92864, 92889
33884, 28747, 28739, 92589, 92597, 3356, 3355, 30878, 30879, 28985, 93323, 92890, 93331, 3378, 30945, 30908, 
30946, 28986, 28969, 92867, 92892
33885, 3222, 3221, 30790, 30791, 28748, 28740, 92590, 92598, 3244, 30857, 30820, 30858, 28988, 93324, 92894, 
93332, 28987, 28970, 92868, 92893
33886, 28748, 28740, 92590, 92598, 28749, 28741, 92591, 92599, 28988, 93324, 92894, 93332, 28990, 93325, 92897, 
93333, 28989, 28972, 92871, 92896
33887, 28749, 28741, 92591, 92599, 28750, 28742, 92592, 92600, 28990, 93325, 92897, 93333, 28992, 93326, 92900, 
93334, 28991, 28974, 92874, 92899
33888, 28750, 28742, 92592, 92600, 28751, 28743, 92593, 92601, 28992, 93326, 92900, 93334, 28994, 93327, 92903, 
93335, 28993, 28976, 92877, 92902
33889, 28751, 28743, 92593, 92601, 28752, 28744, 92594, 92602, 28994, 93327, 92903, 93335, 28996, 93328, 92906, 
93336, 28995, 28978, 92880, 92905
33890, 28752, 28744, 92594, 92602, 28753, 28745, 92595, 92603, 28996, 93328, 92906, 93336, 28998, 93329, 92909, 
93337, 28997, 28980, 92883, 92908
33891, 28753, 28745, 92595, 92603, 28754, 28746, 92596, 92604, 28998, 93329, 92909, 93337, 29000, 93330, 92912, 
93338, 28999, 28982, 92886, 92911
33892, 28754, 28746, 92596, 92604, 28755, 28747, 92597, 92605, 29000, 93330, 92912, 93338, 29002, 93331, 92915, 
93339, 29001, 28984, 92889, 92914
33893, 28755, 28747, 92597, 92605, 3357, 3356, 30879, 30880, 29002, 93331, 92915, 93339, 3379, 30946, 30910, 
30947, 29003, 28986, 92892, 92917
33894, 3223, 3222, 30791, 30792, 28756, 28748, 92598, 92606, 3245, 30858, 30822, 30859, 29005, 93332, 92919, 
93340, 29004, 28987, 92893, 92918
33895, 28756, 28748, 92598, 92606, 28757, 28749, 92599, 92607, 29005, 93332, 92919, 93340, 29007, 93333, 92922, 
93341, 29006, 28989, 92896, 92921
33896, 28757, 28749, 92599, 92607, 28758, 28750, 92600, 92608, 29007, 93333, 92922, 93341, 29009, 93334, 92925, 
93342, 29008, 28991, 92899, 92924
33897, 28758, 28750, 92600, 92608, 28759, 28751, 92601, 92609, 29009, 93334, 92925, 93342, 29011, 93335, 92928, 
93343, 29010, 28993, 92902, 92927
33898, 28759, 28751, 92601, 92609, 28760, 28752, 92602, 92610, 29011, 93335, 92928, 93343, 29013, 93336, 92931, 
93344, 29012, 28995, 92905, 92930
33899, 28760, 28752, 92602, 92610, 28761, 28753, 92603, 92611, 29013, 93336, 92931, 93344, 29015, 93337, 92934, 
93345, 29014, 28997, 92908, 92933
33900, 28761, 28753, 92603, 92611, 28762, 28754, 92604, 92612, 29015, 93337, 92934, 93345, 29017, 93338, 92937, 
93346, 29016, 28999, 92911, 92936
33901, 28762, 28754, 92604, 92612, 28763, 28755, 92605, 92613, 29017, 93338, 92937, 93346, 29019, 93339, 92940, 
93347, 29018, 29001, 92914, 92939
33902, 28763, 28755, 92605, 92613, 3358, 3357, 30880, 30881, 29019, 93339, 92940, 93347, 3380, 30947, 30912, 
30948, 29020, 29003, 92917, 92942
33903, 3224, 3223, 30792, 30793, 28764, 28756, 92606, 92614, 3246, 30859, 30824, 30860, 29022, 93340, 92944, 
93348, 29021, 29004, 92918, 92943
33904, 28764, 28756, 92606, 92614, 28765, 28757, 92607, 92615, 29022, 93340, 92944, 93348, 29024, 93341, 92947, 
93349, 29023, 29006, 92921, 92946
33905, 28765, 28757, 92607, 92615, 28766, 28758, 92608, 92616, 29024, 93341, 92947, 93349, 29026, 93342, 92950, 
93350, 29025, 29008, 92924, 92949
33906, 28766, 28758, 92608, 92616, 28767, 28759, 92609, 92617, 29026, 93342, 92950, 93350, 29028, 93343, 92953, 
93351, 29027, 29010, 92927, 92952
33907, 28767, 28759, 92609, 92617, 28768, 28760, 92610, 92618, 29028, 93343, 92953, 93351, 29030, 93344, 92956, 
93352, 29029, 29012, 92930, 92955
33908, 28768, 28760, 92610, 92618, 28769, 28761, 92611, 92619, 29030, 93344, 92956, 93352, 29032, 93345, 92959, 
93353, 29031, 29014, 92933, 92958
33909, 28769, 28761, 92611, 92619, 28770, 28762, 92612, 92620, 29032, 93345, 92959, 93353, 29034, 93346, 92962, 
93354, 29033, 29016, 92936, 92961
33910, 28770, 28762, 92612, 92620, 28771, 28763, 92613, 92621, 29034, 93346, 92962, 93354, 29036, 93347, 92965, 
93355, 29035, 29018, 92939, 92964
33911, 28771, 28763, 92613, 92621, 3359, 3358, 30881, 30882, 29036, 93347, 92965, 93355, 3381, 30948, 30914, 
30949, 29037, 29020, 92942, 92967
33912, 3225, 3224, 30793, 30794, 28772, 28764, 92614, 92622, 3247, 30860, 30826, 30861, 29039, 93348, 92969, 
93356, 29038, 29021, 92943, 92968
33913, 28772, 28764, 92614, 92622, 28773, 28765, 92615, 92623, 29039, 93348, 92969, 93356, 29041, 93349, 92972, 
93357, 29040, 29023, 92946, 92971
33914, 28773, 28765, 92615, 92623, 28774, 28766, 92616, 92624, 29041, 93349, 92972, 93357, 29043, 93350, 92975, 
93358, 29042, 29025, 92949, 92974
33915, 28774, 28766, 92616, 92624, 28775, 28767, 92617, 92625, 29043, 93350, 92975, 93358, 29045, 93351, 92978, 
93359, 29044, 29027, 92952, 92977
33916, 28775, 28767, 92617, 92625, 28776, 28768, 92618, 92626, 29045, 93351, 92978, 93359, 29047, 93352, 92981, 
93360, 29046, 29029, 92955, 92980
33917, 28776, 28768, 92618, 92626, 28777, 28769, 92619, 92627, 29047, 93352, 92981, 93360, 29049, 93353, 92984, 
93361, 29048, 29031, 92958, 92983
33918, 28777, 28769, 92619, 92627, 28778, 28770, 92620, 92628, 29049, 93353, 92984, 93361, 29051, 93354, 92987, 
93362, 29050, 29033, 92961, 92986
33919, 28778, 28770, 92620, 92628, 28779, 28771, 92621, 92629, 29051, 93354, 92987, 93362, 29053, 93355, 92990, 
93363, 29052, 29035, 92964, 92989
33920, 28779, 28771, 92621, 92629, 3360, 3359, 30882, 30883, 29053, 93355, 92990, 93363, 3382, 30949, 30916, 
30950, 29054, 29037, 92967, 92992
33921, 3226, 3225, 30794, 30795, 28780, 28772, 92622, 92630, 3248, 30861, 30828, 30862, 29056, 93356, 92994, 
93364, 29055, 29038, 92968, 92993
33922, 28780, 28772, 92622, 92630, 28781, 28773, 92623, 92631, 29056, 93356, 92994, 93364, 29058, 93357, 92997, 
93365, 29057, 29040, 92971, 92996
33923, 28781, 28773, 92623, 92631, 28782, 28774, 92624, 92632, 29058, 93357, 92997, 93365, 29060, 93358, 93000, 
93366, 29059, 29042, 92974, 92999
33924, 28782, 28774, 92624, 92632, 28783, 28775, 92625, 92633, 29060, 93358, 93000, 93366, 29062, 93359, 93003, 
93367, 29061, 29044, 92977, 93002
33925, 28783, 28775, 92625, 92633, 28784, 28776, 92626, 92634, 29062, 93359, 93003, 93367, 29064, 93360, 93006, 
93368, 29063, 29046, 92980, 93005
33926, 28784, 28776, 92626, 92634, 28785, 28777, 92627, 92635, 29064, 93360, 93006, 93368, 29066, 93361, 93009, 
93369, 29065, 29048, 92983, 93008
33927, 28785, 28777, 92627, 92635, 28786, 28778, 92628, 92636, 29066, 93361, 93009, 93369, 29068, 93362, 93012, 
93370, 29067, 29050, 92986, 93011
33928, 28786, 28778, 92628, 92636, 28787, 28779, 92629, 92637, 29068, 93362, 93012, 93370, 29070, 93363, 93015, 
93371, 29069, 29052, 92989, 93014
33929, 28787, 28779, 92629, 92637, 3361, 3360, 30883, 30884, 29070, 93363, 93015, 93371, 3383, 30950, 30918, 
30951, 29071, 29054, 92992, 93017
33930, 3227, 3226, 30795, 30796, 28788, 28780, 92630, 92638, 3249, 30862, 30830, 30863, 29073, 93364, 93019, 
93372, 29072, 29055, 92993, 93018
33931, 28788, 28780, 92630, 92638, 28789, 28781, 92631, 92639, 29073, 93364, 93019, 93372, 29075, 93365, 93022, 
93373, 29074, 29057, 92996, 93021
33932, 28789, 28781, 92631, 92639, 28790, 28782, 92632, 92640, 29075, 93365, 93022, 93373, 29077, 93366, 93025, 
93374, 29076, 29059, 92999, 93024
33933, 28790, 28782, 92632, 92640, 28791, 28783, 92633, 92641, 29077, 93366, 93025, 93374, 29079, 93367, 93028, 
93375, 29078, 29061, 93002, 93027
33934, 28791, 28783, 92633, 92641, 28792, 28784, 92634, 92642, 29079, 93367, 93028, 93375, 29081, 93368, 93031, 
93376, 29080, 29063, 93005, 93030
33935, 28792, 28784, 92634, 92642, 28793, 28785, 92635, 92643, 29081, 93368, 93031, 93376, 29083, 93369, 93034, 
93377, 29082, 29065, 93008, 93033
33936, 28793, 28785, 92635, 92643, 28794, 28786, 92636, 92644, 29083, 93369, 93034, 93377, 29085, 93370, 93037, 
93378, 29084, 29067, 93011, 93036
33937, 28794, 28786, 92636, 92644, 28795, 28787, 92637, 92645, 29085, 93370, 93037, 93378, 29087, 93371, 93040, 
93379, 29086, 29069, 93014, 93039
33938, 28795, 28787, 92637, 92645, 3362, 3361, 30884, 30885, 29087, 93371, 93040, 93379, 3384, 30951, 30920, 
30952, 29088, 29071, 93017, 93042
33939, 3228, 3227, 30796, 30797, 28796, 28788, 92638, 92646, 3250, 30863, 30832, 30864, 29090, 93372, 93044, 
93380, 29089, 29072, 93018, 93043
33940, 28796, 28788, 92638, 92646, 28797, 28789, 92639, 92647, 29090, 93372, 93044, 93380, 29092, 93373, 93047, 
93381, 29091, 29074, 93021, 93046
33941, 28797, 28789, 92639, 92647, 28798, 28790, 92640, 92648, 29092, 93373, 93047, 93381, 29094, 93374, 93050, 
93382, 29093, 29076, 93024, 93049
33942, 28798, 28790, 92640, 92648, 28799, 28791, 92641, 92649, 29094, 93374, 93050, 93382, 29096, 93375, 93053, 
93383, 29095, 29078, 93027, 93052
33943, 28799, 28791, 92641, 92649, 28800, 28792, 92642, 92650, 29096, 93375, 93053, 93383, 29098, 93376, 93056, 
93384, 29097, 29080, 93030, 93055
33944, 28800, 28792, 92642, 92650, 28801, 28793, 92643, 92651, 29098, 93376, 93056, 93384, 29100, 93377, 93059, 
93385, 29099, 29082, 93033, 93058
33945, 28801, 28793, 92643, 92651, 28802, 28794, 92644, 92652, 29100, 93377, 93059, 93385, 29102, 93378, 93062, 
93386, 29101, 29084, 93036, 93061
33946, 28802, 28794, 92644, 92652, 28803, 28795, 92645, 92653, 29102, 93378, 93062, 93386, 29104, 93379, 93065, 
93387, 29103, 29086, 93039, 93064
33947, 28803, 28795, 92645, 92653, 3363, 3362, 30885, 30886, 29104, 93379, 93065, 93387, 3385, 30952, 30922, 
30953, 29105, 29088, 93042, 93067
33948, 3229, 3228, 30797, 30798, 28804, 28796, 92646, 92654, 3251, 30864, 30834, 30865, 29107, 93380, 93069, 
93388, 29106, 29089, 93043, 93068
33949, 28804, 28796, 92646, 92654, 28805, 28797, 92647, 92655, 29107, 93380, 93069, 93388, 29109, 93381, 93072, 
93389, 29108, 29091, 93046, 93071
33950, 28805, 28797, 92647, 92655, 28806, 28798, 92648, 92656, 29109, 93381, 93072, 93389, 29111, 93382, 93075, 
93390, 29110, 29093, 93049, 93074
33951, 28806, 28798, 92648, 92656, 28807, 28799, 92649, 92657, 29111, 93382, 93075, 93390, 29113, 93383, 93078, 
93391, 29112, 29095, 93052, 93077
33952, 28807, 28799, 92649, 92657, 28808, 28800, 92650, 92658, 29113, 93383, 93078, 93391, 29115, 93384, 93081, 
93392, 29114, 29097, 93055, 93080
33953, 28808, 28800, 92650, 92658, 28809, 28801, 92651, 92659, 29115, 93384, 93081, 93392, 29117, 93385, 93084, 
93393, 29116, 29099, 93058, 93083
33954, 28809, 28801, 92651, 92659, 28810, 28802, 92652, 92660, 29117, 93385, 93084, 93393, 29119, 93386, 93087, 
93394, 29118, 29101, 93061, 93086
33955, 28810, 28802, 92652, 92660, 28811, 28803, 92653, 92661, 29119, 93386, 93087, 93394, 29121, 93387, 93090, 
93395, 29120, 29103, 93064, 93089
33956, 28811, 28803, 92653, 92661, 3364, 3363, 30886, 30887, 29121, 93387, 93090, 93395, 3386, 30953, 30924, 
30954, 29122, 29105, 93067, 93092
33957, 3230, 3229, 30798, 30799, 28812, 28804, 92654, 92662, 3252, 30865, 30836, 30866, 29124, 93388, 93094, 
93396, 29123, 29106, 93068, 93093
33958, 28812, 28804, 92654, 92662, 28813, 28805, 92655, 92663, 29124, 93388, 93094, 93396, 29126, 93389, 93097, 
93397, 29125, 29108, 93071, 93096
33959, 28813, 28805, 92655, 92663, 28814, 28806, 92656, 92664, 29126, 93389, 93097, 93397, 29128, 93390, 93100, 
93398, 29127, 29110, 93074, 93099
33960, 28814, 28806, 92656, 92664, 28815, 28807, 92657, 92665, 29128, 93390, 93100, 93398, 29130, 93391, 93103, 
93399, 29129, 29112, 93077, 93102
33961, 28815, 28807, 92657, 92665, 28816, 28808, 92658, 92666, 29130, 93391, 93103, 93399, 29132, 93392, 93106, 
93400, 29131, 29114, 93080, 93105
33962, 28816, 28808, 92658, 92666, 28817, 28809, 92659, 92667, 29132, 93392, 93106, 93400, 29134, 93393, 93109, 
93401, 29133, 29116, 93083, 93108
33963, 28817, 28809, 92659, 92667, 28818, 28810, 92660, 92668, 29134, 93393, 93109, 93401, 29136, 93394, 93112, 
93402, 29135, 29118, 93086, 93111
33964, 28818, 28810, 92660, 92668, 28819, 28811, 92661, 92669, 29136, 93394, 93112, 93402, 29138, 93395, 93115, 
93403, 29137, 29120, 93089, 93114
33965, 28819, 28811, 92661, 92669, 3365, 3364, 30887, 30888, 29138, 93395, 93115, 93403, 3387, 30954, 30926, 
30955, 29139, 29122, 93092, 93117
33966, 3231, 3230, 30799, 30800, 28820, 28812, 92662, 92670, 3253, 30866, 30838, 30867, 29141, 93396, 93119, 
93404, 29140, 29123, 93093, 93118
33967, 28820, 28812, 92662, 92670, 28821, 28813, 92663, 92671, 29141, 93396, 93119, 93404, 29143, 93397, 93122, 
93405, 29142, 29125, 93096, 93121
33968, 28821, 28813, 92663, 92671, 28822, 28814, 92664, 92672, 29143, 93397, 93122, 93405, 29145, 93398, 93125, 
93406, 29144, 29127, 93099, 93124
33969, 28822, 28814, 92664, 92672, 28823, 28815, 92665, 92673, 29145, 93398, 93125, 93406, 29147, 93399, 93128, 
93407, 29146, 29129, 93102, 93127
33970, 28823, 28815, 92665, 92673, 28824, 28816, 92666, 92674, 29147, 93399, 93128, 93407, 29149, 93400, 93131, 
93408, 29148, 29131, 93105, 93130
33971, 28824, 28816, 92666, 92674, 28825, 28817, 92667, 92675, 29149, 93400, 93131, 93408, 29151, 93401, 93134, 
93409, 29150, 29133, 93108, 93133
33972, 28825, 28817, 92667, 92675, 28826, 28818, 92668, 92676, 29151, 93401, 93134, 93409, 29153, 93402, 93137, 
93410, 29152, 29135, 93111, 93136
33973, 28826, 28818, 92668, 92676, 28827, 28819, 92669, 92677, 29153, 93402, 93137, 93410, 29155, 93403, 93140, 
93411, 29154, 29137, 93114, 93139
33974, 28827, 28819, 92669, 92677, 3366, 3365, 30888, 30889, 29155, 93403, 93140, 93411, 3388, 30955, 30928, 
30956, 29156, 29139, 93117, 93142
33975, 3232, 3231, 30800, 30801, 28828, 28820, 92670, 92678, 3254, 30867, 30840, 30868, 29158, 93404, 93144, 
93412, 29157, 29140, 93118, 93143
33976, 28828, 28820, 92670, 92678, 28829, 28821, 92671, 92679, 29158, 93404, 93144, 93412, 29160, 93405, 93147, 
93413, 29159, 29142, 93121, 93146
33977, 28829, 28821, 92671, 92679, 28830, 28822, 92672, 92680, 29160, 93405, 93147, 93413, 29162, 93406, 93150, 
93414, 29161, 29144, 93124, 93149
33978, 28830, 28822, 92672, 92680, 28831, 28823, 92673, 92681, 29162, 93406, 93150, 93414, 29164, 93407, 93153, 
93415, 29163, 29146, 93127, 93152
33979, 28831, 28823, 92673, 92681, 28832, 28824, 92674, 92682, 29164, 93407, 93153, 93415, 29166, 93408, 93156, 
93416, 29165, 29148, 93130, 93155
33980, 28832, 28824, 92674, 92682, 28833, 28825, 92675, 92683, 29166, 93408, 93156, 93416, 29168, 93409, 93159, 
93417, 29167, 29150, 93133, 93158
33981, 28833, 28825, 92675, 92683, 28834, 28826, 92676, 92684, 29168, 93409, 93159, 93417, 29170, 93410, 93162, 
93418, 29169, 29152, 93136, 93161
33982, 28834, 28826, 92676, 92684, 28835, 28827, 92677, 92685, 29170, 93410, 93162, 93418, 29172, 93411, 93165, 
93419, 29171, 29154, 93139, 93164
33983, 28835, 28827, 92677, 92685, 3367, 3366, 30889, 30890, 29172, 93411, 93165, 93419, 3389, 30956, 30930, 
30957, 29173, 29156, 93142, 93167
33984, 3233, 3232, 30801, 30802, 28836, 28828, 92678, 92686, 3255, 30868, 30842, 30869, 29175, 93412, 93169, 
93420, 29174, 29157, 93143, 93168
33985, 28836, 28828, 92678, 92686, 28837, 28829, 92679, 92687, 29175, 93412, 93169, 93420, 29177, 93413, 93172, 
93421, 29176, 29159, 93146, 93171
33986, 28837, 28829, 92679, 92687, 28838, 28830, 92680, 92688, 29177, 93413, 93172, 93421, 29179, 93414, 93175, 
93422, 29178, 29161, 93149, 93174
33987, 28838, 28830, 92680, 92688, 28839, 28831, 92681, 92689, 29179, 93414, 93175, 93422, 29181, 93415, 93178, 
93423, 29180, 29163, 93152, 93177
33988, 28839, 28831, 92681, 92689, 28840, 28832, 92682, 92690, 29181, 93415, 93178, 93423, 29183, 93416, 93181, 
93424, 29182, 29165, 93155, 93180
33989, 28840, 28832, 92682, 92690, 28841, 28833, 92683, 92691, 29183, 93416, 93181, 93424, 29185, 93417, 93184, 
93425, 29184, 29167, 93158, 93183
33990, 28841, 28833, 92683, 92691, 28842, 28834, 92684, 92692, 29185, 93417, 93184, 93425, 29187, 93418, 93187, 
93426, 29186, 29169, 93161, 93186
33991, 28842, 28834, 92684, 92692, 28843, 28835, 92685, 92693, 29187, 93418, 93187, 93426, 29189, 93419, 93190, 
93427, 29188, 29171, 93164, 93189
33992, 28843, 28835, 92685, 92693, 3368, 3367, 30890, 30891, 29189, 93419, 93190, 93427, 3390, 30957, 30932, 
30958, 29190, 29173, 93167, 93192
33993, 3234, 3233, 30802, 30803, 28844, 28836, 92686, 92694, 3256, 30869, 30844, 30870, 29192, 93420, 93194, 
93428, 29191, 29174, 93168, 93193
33994, 28844, 28836, 92686, 92694, 28845, 28837, 92687, 92695, 29192, 93420, 93194, 93428, 29194, 93421, 93197, 
93429, 29193, 29176, 93171, 93196
33995, 28845, 28837, 92687, 92695, 28846, 28838, 92688, 92696, 29194, 93421, 93197, 93429, 29196, 93422, 93200, 
93430, 29195, 29178, 93174, 93199
33996, 28846, 28838, 92688, 92696, 28847, 28839, 92689, 92697, 29196, 93422, 93200, 93430, 29198, 93423, 93203, 
93431, 29197, 29180, 93177, 93202
33997, 28847, 28839, 92689, 92697, 28848, 28840, 92690, 92698, 29198, 93423, 93203, 93431, 29200, 93424, 93206, 
93432, 29199, 29182, 93180, 93205
33998, 28848, 28840, 92690, 92698, 28849, 28841, 92691, 92699, 29200, 93424, 93206, 93432, 29202, 93425, 93209, 
93433, 29201, 29184, 93183, 93208
33999, 28849, 28841, 92691, 92699, 28850, 28842, 92692, 92700, 29202, 93425, 93209, 93433, 29204, 93426, 93212, 
93434, 29203, 29186, 93186, 93211
34000, 28850, 28842, 92692, 92700, 28851, 28843, 92693, 92701, 29204, 93426, 93212, 93434, 29206, 93427, 93215, 
93435, 29205, 29188, 93189, 93214
34001, 28851, 28843, 92693, 92701, 3369, 3368, 30891, 30892, 29206, 93427, 93215, 93435, 3391, 30958, 30934, 
30959, 29207, 29190, 93192, 93217
34002, 3235, 3234, 30803, 30804, 28852, 28844, 92694, 92702, 3257, 30870, 30846, 30871, 29209, 93428, 93219, 
93436, 29208, 29191, 93193, 93218
34003, 28852, 28844, 92694, 92702, 28853, 28845, 92695, 92703, 29209, 93428, 93219, 93436, 29211, 93429, 93222, 
93437, 29210, 29193, 93196, 93221
34004, 28853, 28845, 92695, 92703, 28854, 28846, 92696, 92704, 29211, 93429, 93222, 93437, 29213, 93430, 93225, 
93438, 29212, 29195, 93199, 93224
34005, 28854, 28846, 92696, 92704, 28855, 28847, 92697, 92705, 29213, 93430, 93225, 93438, 29215, 93431, 93228, 
93439, 29214, 29197, 93202, 93227
34006, 28855, 28847, 92697, 92705, 28856, 28848, 92698, 92706, 29215, 93431, 93228, 93439, 29217, 93432, 93231, 
93440, 29216, 29199, 93205, 93230
34007, 28856, 28848, 92698, 92706, 28857, 28849, 92699, 92707, 29217, 93432, 93231, 93440, 29219, 93433, 93234, 
93441, 29218, 29201, 93208, 93233
34008, 28857, 28849, 92699, 92707, 28858, 28850, 92700, 92708, 29219, 93433, 93234, 93441, 29221, 93434, 93237, 
93442, 29220, 29203, 93211, 93236
34009, 28858, 28850, 92700, 92708, 28859, 28851, 92701, 92709, 29221, 93434, 93237, 93442, 29223, 93435, 93240, 
93443, 29222, 29205, 93214, 93239
34010, 28859, 28851, 92701, 92709, 3370, 3369, 30892, 30893, 29223, 93435, 93240, 93443, 3392, 30959, 30936, 
30960, 29224, 29207, 93217, 93242
34011, 3236, 3235, 30804, 30805, 28860, 28852, 92702, 92710, 3258, 30871, 30848, 30872, 29226, 93436, 93244, 
93444, 29225, 29208, 93218, 93243
34012, 28860, 28852, 92702, 92710, 28861, 28853, 92703, 92711, 29226, 93436, 93244, 93444, 29228, 93437, 93247, 
93445, 29227, 29210, 93221, 93246
34013, 28861, 28853, 92703, 92711, 28862, 28854, 92704, 92712, 29228, 93437, 93247, 93445, 29230, 93438, 93250, 
93446, 29229, 29212, 93224, 93249
34014, 28862, 28854, 92704, 92712, 28863, 28855, 92705, 92713, 29230, 93438, 93250, 93446, 29232, 93439, 93253, 
93447, 29231, 29214, 93227, 93252
34015, 28863, 28855, 92705, 92713, 28864, 28856, 92706, 92714, 29232, 93439, 93253, 93447, 29234, 93440, 93256, 
93448, 29233, 29216, 93230, 93255
34016, 28864, 28856, 92706, 92714, 28865, 28857, 92707, 92715, 29234, 93440, 93256, 93448, 29236, 93441, 93259, 
93449, 29235, 29218, 93233, 93258
34017, 28865, 28857, 92707, 92715, 28866, 28858, 92708, 92716, 29236, 93441, 93259, 93449, 29238, 93442, 93262, 
93450, 29237, 29220, 93236, 93261
34018, 28866, 28858, 92708, 92716, 28867, 28859, 92709, 92717, 29238, 93442, 93262, 93450, 29240, 93443, 93265, 
93451, 29239, 29222, 93239, 93264
34019, 28867, 28859, 92709, 92717, 3371, 3370, 30893, 30894, 29240, 93443, 93265, 93451, 3393, 30960, 30938, 
30961, 29241, 29224, 93242, 93267
34020, 94, 3236, 30805, 3604, 3419, 28860, 92710, 30995, 3259, 30872, 30850, 3606, 29242, 93444, 93268, 
31020, 3428, 29225, 93243, 31003
34021, 3419, 28860, 92710, 30995, 3418, 28861, 92711, 30996, 29242, 93444, 93268, 31020, 29243, 93445, 93269, 
31021, 3427, 29227, 93246, 31005
34022, 3418, 28861, 92711, 30996, 3417, 28862, 92712, 30997, 29243, 93445, 93269, 31021, 29244, 93446, 93270, 
31022, 3426, 29229, 93249, 31007
34023, 3417, 28862, 92712, 30997, 3416, 28863, 92713, 30998, 29244, 93446, 93270, 31022, 29245, 93447, 93271, 
31023, 3425, 29231, 93252, 31009
34024, 3416, 28863, 92713, 30998, 3415, 28864, 92714, 30999, 29245, 93447, 93271, 31023, 29246, 93448, 93272, 
31024, 3424, 29233, 93255, 31011
34025, 3415, 28864, 92714, 30999, 3414, 28865, 92715, 31000, 29246, 93448, 93272, 31024, 29247, 93449, 93273, 
31025, 3423, 29235, 93258, 31013
34026, 3414, 28865, 92715, 31000, 3413, 28866, 92716, 31001, 29247, 93449, 93273, 31025, 29248, 93450, 93274, 
31026, 3422, 29237, 93261, 31015
34027, 3413, 28866, 92716, 31001, 3412, 28867, 92717, 31002, 29248, 93450, 93274, 31026, 29249, 93451, 93275, 
31027, 3421, 29239, 93264, 31017
34028, 3412, 28867, 92717, 31002, 96, 3371, 30894, 3610, 29249, 93451, 93275, 31027, 3394, 30961, 30939, 
3612, 3420, 29241, 93267, 31019
*ELEMENT, type=C3D20, ELSET=Volume36
34029, 31028, 3613, 1, 2821, 93452, 31474, 130, 19918, 31094, 3616, 2843, 31095, 94905, 31540, 20402, 
94906, 94904, 31541, 153, 20403
34030, 93452, 31474, 130, 19918, 93453, 31475, 129, 19919, 94905, 31540, 20402, 94906, 94908, 31542, 20404, 
94909, 94907, 31543, 152, 20405
34031, 93453, 31475, 129, 19919, 93454, 31476, 128, 19920, 94908, 31542, 20404, 94909, 94911, 31544, 20406, 
94912, 94910, 31545, 151, 20407
34032, 93454, 31476, 128, 19920, 93455, 31477, 127, 19921, 94911, 31544, 20406, 94912, 94914, 31546, 20408, 
94915, 94913, 31547, 150, 20409
34033, 93455, 31477, 127, 19921, 93456, 31478, 126, 19922, 94914, 31546, 20408, 94915, 94917, 31548, 20410, 
94918, 94916, 31549, 149, 20411
34034, 93456, 31478, 126, 19922, 93457, 31479, 125, 19923, 94917, 31548, 20410, 94918, 94920, 31550, 20412, 
94921, 94919, 31551, 148, 20413
34035, 93457, 31479, 125, 19923, 93458, 31480, 124, 19924, 94920, 31550, 20412, 94921, 94923, 31552, 20414, 
94924, 94922, 31553, 147, 20415
34036, 93458, 31480, 124, 19924, 93459, 31481, 123, 19925, 94923, 31552, 20414, 94924, 94926, 31554, 20416, 
94927, 94925, 31555, 146, 20417
34037, 93459, 31481, 123, 19925, 93460, 31482, 122, 19926, 94926, 31554, 20416, 94927, 94929, 31556, 20418, 
94930, 94928, 31557, 145, 20419
34038, 93460, 31482, 122, 19926, 93461, 31483, 121, 19927, 94929, 31556, 20418, 94930, 94932, 31558, 20420, 
94933, 94931, 31559, 144, 20421
34039, 93461, 31483, 121, 19927, 93462, 31484, 120, 19928, 94932, 31558, 20420, 94933, 94935, 31560, 20422, 
94936, 94934, 31561, 143, 20423
34040, 93462, 31484, 120, 19928, 93463, 31485, 119, 19929, 94935, 31560, 20422, 94936, 94938, 31562, 20424, 
94939, 94937, 31563, 142, 20425
34041, 93463, 31485, 119, 19929, 93464, 31486, 118, 19930, 94938, 31562, 20424, 94939, 94941, 31564, 20426, 
94942, 94940, 31565, 141, 20427
34042, 93464, 31486, 118, 19930, 93465, 31487, 117, 19931, 94941, 31564, 20426, 94942, 94944, 31566, 20428, 
94945, 94943, 31567, 140, 20429
34043, 93465, 31487, 117, 19931, 93466, 31488, 116, 19932, 94944, 31566, 20428, 94945, 94947, 31568, 20430, 
94948, 94946, 31569, 139, 20431
34044, 93466, 31488, 116, 19932, 93467, 31489, 115, 19933, 94947, 31568, 20430, 94948, 94950, 31570, 20432, 
94951, 94949, 31571, 138, 20433
34045, 93467, 31489, 115, 19933, 93468, 31490, 114, 19934, 94950, 31570, 20432, 94951, 94953, 31572, 20434, 
94954, 94952, 31573, 137, 20435
34046, 93468, 31490, 114, 19934, 93469, 31491, 113, 19935, 94953, 31572, 20434, 94954, 94956, 31574, 20436, 
94957, 94955, 31575, 136, 20437
34047, 93469, 31491, 113, 19935, 93470, 31492, 112, 19936, 94956, 31574, 20436, 94957, 94959, 31576, 20438, 
94960, 94958, 31577, 135, 20439
34048, 93470, 31492, 112, 19936, 93471, 31493, 111, 19937, 94959, 31576, 20438, 94960, 94962, 31578, 20440, 
94963, 94961, 31579, 134, 20441
34049, 93471, 31493, 111, 19937, 93472, 31494, 110, 19938, 94962, 31578, 20440, 94963, 94965, 31580, 20442, 
94966, 94964, 31581, 133, 20443
34050, 93472, 31494, 110, 19938, 93473, 31495, 109, 19939, 94965, 31580, 20442, 94966, 94968, 31582, 20444, 
94969, 94967, 31583, 132, 20445
34051, 93473, 31495, 109, 19939, 31251, 3672, 2, 2866, 94968, 31582, 20444, 94969, 31318, 3675, 2888, 
31317, 94970, 31584, 131, 20446
34052, 31029, 31028, 2821, 2822, 93474, 93452, 19918, 19940, 31096, 31095, 2844, 31097, 94972, 94906, 20447, 
94973, 94971, 94904, 20403, 20448
34053, 93474, 93452, 19918, 19940, 93475, 93453, 19919, 19941, 94972, 94906, 20447, 94973, 94975, 94909, 20449, 
94976, 94974, 94907, 20405, 20450
34054, 93475, 93453, 19919, 19941, 93476, 93454, 19920, 19942, 94975, 94909, 20449, 94976, 94978, 94912, 20451, 
94979, 94977, 94910, 20407, 20452
34055, 93476, 93454, 19920, 19942, 93477, 93455, 19921, 19943, 94978, 94912, 20451, 94979, 94981, 94915, 20453, 
94982, 94980, 94913, 20409, 20454
34056, 93477, 93455, 19921, 19943, 93478, 93456, 19922, 19944, 94981, 94915, 20453, 94982, 94984, 94918, 20455, 
94985, 94983, 94916, 20411, 20456
34057, 93478, 93456, 19922, 19944, 93479, 93457, 19923, 19945, 94984, 94918, 20455, 94985, 94987, 94921, 20457, 
94988, 94986, 94919, 20413, 20458
34058, 93479, 93457, 19923, 19945, 93480, 93458, 19924, 19946, 94987, 94921, 20457, 94988, 94990, 94924, 20459, 
94991, 94989, 94922, 20415, 20460
34059, 93480, 93458, 19924, 19946, 93481, 93459, 19925, 19947, 94990, 94924, 20459, 94991, 94993, 94927, 20461, 
94994, 94992, 94925, 20417, 20462
34060, 93481, 93459, 19925, 19947, 93482, 93460, 19926, 19948, 94993, 94927, 20461, 94994, 94996, 94930, 20463, 
94997, 94995, 94928, 20419, 20464
34061, 93482, 93460, 19926, 19948, 93483, 93461, 19927, 19949, 94996, 94930, 20463, 94997, 94999, 94933, 20465, 
95000, 94998, 94931, 20421, 20466
34062, 93483, 93461, 19927, 19949, 93484, 93462, 19928, 19950, 94999, 94933, 20465, 95000, 95002, 94936, 20467, 
95003, 95001, 94934, 20423, 20468
34063, 93484, 93462, 19928, 19950, 93485, 93463, 19929, 19951, 95002, 94936, 20467, 95003, 95005, 94939, 20469, 
95006, 95004, 94937, 20425, 20470
34064, 93485, 93463, 19929, 19951, 93486, 93464, 19930, 19952, 95005, 94939, 20469, 95006, 95008, 94942, 20471, 
95009, 95007, 94940, 20427, 20472
34065, 93486, 93464, 19930, 19952, 93487, 93465, 19931, 19953, 95008, 94942, 20471, 95009, 95011, 94945, 20473, 
95012, 95010, 94943, 20429, 20474
34066, 93487, 93465, 19931, 19953, 93488, 93466, 19932, 19954, 95011, 94945, 20473, 95012, 95014, 94948, 20475, 
95015, 95013, 94946, 20431, 20476
34067, 93488, 93466, 19932, 19954, 93489, 93467, 19933, 19955, 95014, 94948, 20475, 95015, 95017, 94951, 20477, 
95018, 95016, 94949, 20433, 20478
34068, 93489, 93467, 19933, 19955, 93490, 93468, 19934, 19956, 95017, 94951, 20477, 95018, 95020, 94954, 20479, 
95021, 95019, 94952, 20435, 20480
34069, 93490, 93468, 19934, 19956, 93491, 93469, 19935, 19957, 95020, 94954, 20479, 95021, 95023, 94957, 20481, 
95024, 95022, 94955, 20437, 20482
34070, 93491, 93469, 19935, 19957, 93492, 93470, 19936, 19958, 95023, 94957, 20481, 95024, 95026, 94960, 20483, 
95027, 95025, 94958, 20439, 20484
34071, 93492, 93470, 19936, 19958, 93493, 93471, 19937, 19959, 95026, 94960, 20483, 95027, 95029, 94963, 20485, 
95030, 95028, 94961, 20441, 20486
34072, 93493, 93471, 19937, 19959, 93494, 93472, 19938, 19960, 95029, 94963, 20485, 95030, 95032, 94966, 20487, 
95033, 95031, 94964, 20443, 20488
34073, 93494, 93472, 19938, 19960, 93495, 93473, 19939, 19961, 95032, 94966, 20487, 95033, 95035, 94969, 20489, 
95036, 95034, 94967, 20445, 20490
34074, 93495, 93473, 19939, 19961, 31252, 31251, 2866, 2867, 95035, 94969, 20489, 95036, 31320, 31317, 2889, 
31319, 95037, 94970, 20446, 20491
34075, 31030, 31029, 2822, 2823, 93496, 93474, 19940, 19962, 31098, 31097, 2845, 31099, 95039, 94973, 20492, 
95040, 95038, 94971, 20448, 20493
34076, 93496, 93474, 19940, 19962, 93497, 93475, 19941, 19963, 95039, 94973, 20492, 95040, 95042, 94976, 20494, 
95043, 95041, 94974, 20450, 20495
34077, 93497, 93475, 19941, 19963, 93498, 93476, 19942, 19964, 95042, 94976, 20494, 95043, 95045, 94979, 20496, 
95046, 95044, 94977, 20452, 20497
34078, 93498, 93476, 19942, 19964, 93499, 93477, 19943, 19965, 95045, 94979, 20496, 95046, 95048, 94982, 20498, 
95049, 95047, 94980, 20454, 20499
34079, 93499, 93477, 19943, 19965, 93500, 93478, 19944, 19966, 95048, 94982, 20498, 95049, 95051, 94985, 20500, 
95052, 95050, 94983, 20456, 20501
34080, 93500, 93478, 19944, 19966, 93501, 93479, 19945, 19967, 95051, 94985, 20500, 95052, 95054, 94988, 20502, 
95055, 95053, 94986, 20458, 20503
34081, 93501, 93479, 19945, 19967, 93502, 93480, 19946, 19968, 95054, 94988, 20502, 95055, 95057, 94991, 20504, 
95058, 95056, 94989, 20460, 20505
34082, 93502, 93480, 19946, 19968, 93503, 93481, 19947, 19969, 95057, 94991, 20504, 95058, 95060, 94994, 20506, 
95061, 95059, 94992, 20462, 20507
34083, 93503, 93481, 19947, 19969, 93504, 93482, 19948, 19970, 95060, 94994, 20506, 95061, 95063, 94997, 20508, 
95064, 95062, 94995, 20464, 20509
34084, 93504, 93482, 19948, 19970, 93505, 93483, 19949, 19971, 95063, 94997, 20508, 95064, 95066, 95000, 20510, 
95067, 95065, 94998, 20466, 20511
34085, 93505, 93483, 19949, 19971, 93506, 93484, 19950, 19972, 95066, 95000, 20510, 95067, 95069, 95003, 20512, 
95070, 95068, 95001, 20468, 20513
34086, 93506, 93484, 19950, 19972, 93507, 93485, 19951, 19973, 95069, 95003, 20512, 95070, 95072, 95006, 20514, 
95073, 95071, 95004, 20470, 20515
34087, 93507, 93485, 19951, 19973, 93508, 93486, 19952, 19974, 95072, 95006, 20514, 95073, 95075, 95009, 20516, 
95076, 95074, 95007, 20472, 20517
34088, 93508, 93486, 19952, 19974, 93509, 93487, 19953, 19975, 95075, 95009, 20516, 95076, 95078, 95012, 20518, 
95079, 95077, 95010, 20474, 20519
34089, 93509, 93487, 19953, 19975, 93510, 93488, 19954, 19976, 95078, 95012, 20518, 95079, 95081, 95015, 20520, 
95082, 95080, 95013, 20476, 20521
34090, 93510, 93488, 19954, 19976, 93511, 93489, 19955, 19977, 95081, 95015, 20520, 95082, 95084, 95018, 20522, 
95085, 95083, 95016, 20478, 20523
34091, 93511, 93489, 19955, 19977, 93512, 93490, 19956, 19978, 95084, 95018, 20522, 95085, 95087, 95021, 20524, 
95088, 95086, 95019, 20480, 20525
34092, 93512, 93490, 19956, 19978, 93513, 93491, 19957, 19979, 95087, 95021, 20524, 95088, 95090, 95024, 20526, 
95091, 95089, 95022, 20482, 20527
34093, 93513, 93491, 19957, 19979, 93514, 93492, 19958, 19980, 95090, 95024, 20526, 95091, 95093, 95027, 20528, 
95094, 95092, 95025, 20484, 20529
34094, 93514, 93492, 19958, 19980, 93515, 93493, 19959, 19981, 95093, 95027, 20528, 95094, 95096, 95030, 20530, 
95097, 95095, 95028, 20486, 20531
34095, 93515, 93493, 19959, 19981, 93516, 93494, 19960, 19982, 95096, 95030, 20530, 95097, 95099, 95033, 20532, 
95100, 95098, 95031, 20488, 20533
