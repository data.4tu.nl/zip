17468, 1.3521739130435, 1.55, 0.38888888888889
17469, 1.3739130434783, 1.55, 0.36111111111111
17470, 1.3521739130435, 1.55, 0.33333333333333
17471, 1.3739130434783, 1.55, 0.30555555555556
17472, 1.3521739130435, 1.55, 0.27777777777778
17473, 1.3739130434783, 1.55, 0.25
17474, 1.3521739130435, 1.55, 0.22222222222222
17475, 1.3739130434783, 1.55, 0.19444444444444
17476, 1.3521739130435, 1.55, 0.16666666666667
17477, 1.3739130434783, 1.55, 0.13888888888889
17478, 1.3521739130435, 1.55, 0.11111111111111
17479, 1.3739130434783, 1.55, 0.083333333333333
17480, 1.3521739130435, 1.55, 0.055555555555556
17481, 1.3739130434783, 1.55, 0.027777777777778
17482, 1.4173913043478, 1.55, 0.47222222222222
17483, 1.395652173913, 1.55, 0.44444444444444
17484, 1.4173913043478, 1.55, 0.41666666666667
17485, 1.395652173913, 1.55, 0.38888888888889
17486, 1.4173913043478, 1.55, 0.36111111111111
17487, 1.395652173913, 1.55, 0.33333333333333
17488, 1.4173913043478, 1.55, 0.30555555555556
17489, 1.395652173913, 1.55, 0.27777777777778
17490, 1.4173913043478, 1.55, 0.25
17491, 1.395652173913, 1.55, 0.22222222222222
17492, 1.4173913043478, 1.55, 0.19444444444444
17493, 1.395652173913, 1.55, 0.16666666666667
17494, 1.4173913043478, 1.55, 0.13888888888889
17495, 1.395652173913, 1.55, 0.11111111111111
17496, 1.4173913043478, 1.55, 0.083333333333333
17497, 1.395652173913, 1.55, 0.055555555555556
17498, 1.4173913043478, 1.55, 0.027777777777778
17499, 1.4608695652174, 1.55, 0.47222222222222
17500, 1.4391304347826, 1.55, 0.44444444444444
17501, 1.4608695652174, 1.55, 0.41666666666667
17502, 1.4391304347826, 1.55, 0.38888888888889
17503, 1.4608695652174, 1.55, 0.36111111111111
17504, 1.4391304347826, 1.55, 0.33333333333333
17505, 1.4608695652174, 1.55, 0.30555555555556
17506, 1.4391304347826, 1.55, 0.27777777777778
17507, 1.4608695652174, 1.55, 0.25
17508, 1.4391304347826, 1.55, 0.22222222222222
17509, 1.4608695652174, 1.55, 0.19444444444444
17510, 1.4391304347826, 1.55, 0.16666666666667
17511, 1.4608695652174, 1.55, 0.13888888888889
17512, 1.4391304347826, 1.55, 0.11111111111111
17513, 1.4608695652174, 1.55, 0.083333333333333
17514, 1.4391304347826, 1.55, 0.055555555555556
17515, 1.4608695652174, 1.55, 0.027777777777778
17516, 1.504347826087, 1.55, 0.47222222222222
17517, 1.4826086956522, 1.55, 0.44444444444444
17518, 1.504347826087, 1.55, 0.41666666666667
17519, 1.4826086956522, 1.55, 0.38888888888889
17520, 1.504347826087, 1.55, 0.36111111111111
17521, 1.4826086956522, 1.55, 0.33333333333333
17522, 1.504347826087, 1.55, 0.30555555555556
17523, 1.4826086956522, 1.55, 0.27777777777778
17524, 1.504347826087, 1.55, 0.25
17525, 1.4826086956522, 1.55, 0.22222222222222
17526, 1.504347826087, 1.55, 0.19444444444444
17527, 1.4826086956522, 1.55, 0.16666666666667
17528, 1.504347826087, 1.55, 0.13888888888889
17529, 1.4826086956522, 1.55, 0.11111111111111
17530, 1.504347826087, 1.55, 0.083333333333333
17531, 1.4826086956522, 1.55, 0.055555555555556
17532, 1.504347826087, 1.55, 0.027777777777778
17533, 1.5478260869565, 1.55, 0.47222222222222
17534, 1.5260869565217, 1.55, 0.44444444444444
17535, 1.5478260869565, 1.55, 0.41666666666667
17536, 1.5260869565217, 1.55, 0.38888888888889
17537, 1.5478260869565, 1.55, 0.36111111111111
17538, 1.5260869565217, 1.55, 0.33333333333333
17539, 1.5478260869565, 1.55, 0.30555555555556
17540, 1.5260869565217, 1.55, 0.27777777777778
17541, 1.5478260869565, 1.55, 0.25
17542, 1.5260869565217, 1.55, 0.22222222222222
17543, 1.5478260869565, 1.55, 0.19444444444444
17544, 1.5260869565217, 1.55, 0.16666666666667
17545, 1.5478260869565, 1.55, 0.13888888888889
17546, 1.5260869565217, 1.55, 0.11111111111111
17547, 1.5478260869565, 1.55, 0.083333333333333
17548, 1.5260869565217, 1.55, 0.055555555555556
17549, 1.5478260869565, 1.55, 0.027777777777778
17550, 1.5913043478261, 1.55, 0.47222222222222
17551, 1.5695652173913, 1.55, 0.44444444444444
17552, 1.5913043478261, 1.55, 0.41666666666667
17553, 1.5695652173913, 1.55, 0.38888888888889
17554, 1.5913043478261, 1.55, 0.36111111111111
17555, 1.5695652173913, 1.55, 0.33333333333333
17556, 1.5913043478261, 1.55, 0.30555555555556
17557, 1.5695652173913, 1.55, 0.27777777777778
17558, 1.5913043478261, 1.55, 0.25
17559, 1.5695652173913, 1.55, 0.22222222222222
17560, 1.5913043478261, 1.55, 0.19444444444444
17561, 1.5695652173913, 1.55, 0.16666666666667
17562, 1.5913043478261, 1.55, 0.13888888888889
17563, 1.5695652173913, 1.55, 0.11111111111111
17564, 1.5913043478261, 1.55, 0.083333333333333
17565, 1.5695652173913, 1.55, 0.055555555555556
17566, 1.5913043478261, 1.55, 0.027777777777778
17567, 1.6347826086957, 1.55, 0.47222222222222
17568, 1.6130434782609, 1.55, 0.44444444444444
17569, 1.6347826086957, 1.55, 0.41666666666667
17570, 1.6130434782609, 1.55, 0.38888888888889
17571, 1.6347826086957, 1.55, 0.36111111111111
17572, 1.6130434782609, 1.55, 0.33333333333333
17573, 1.6347826086957, 1.55, 0.30555555555556
17574, 1.6130434782609, 1.55, 0.27777777777778
17575, 1.6347826086957, 1.55, 0.25
17576, 1.6130434782609, 1.55, 0.22222222222222
17577, 1.6347826086957, 1.55, 0.19444444444444
17578, 1.6130434782609, 1.55, 0.16666666666667
17579, 1.6347826086957, 1.55, 0.13888888888889
17580, 1.6130434782609, 1.55, 0.11111111111111
17581, 1.6347826086957, 1.55, 0.083333333333333
17582, 1.6130434782609, 1.55, 0.055555555555556
17583, 1.6347826086957, 1.55, 0.027777777777778
17584, 1.6782608695652, 1.55, 0.47222222222222
17585, 1.6565217391304, 1.55, 0.44444444444444
17586, 1.6782608695652, 1.55, 0.41666666666667
17587, 1.6565217391304, 1.55, 0.38888888888889
17588, 1.6782608695652, 1.55, 0.36111111111111
17589, 1.6565217391304, 1.55, 0.33333333333333
17590, 1.6782608695652, 1.55, 0.30555555555556
17591, 1.6565217391304, 1.55, 0.27777777777778
17592, 1.6782608695652, 1.55, 0.25
17593, 1.6565217391304, 1.55, 0.22222222222222
17594, 1.6782608695652, 1.55, 0.19444444444444
17595, 1.6565217391304, 1.55, 0.16666666666667
17596, 1.6782608695652, 1.55, 0.13888888888889
17597, 1.6565217391304, 1.55, 0.11111111111111
17598, 1.6782608695652, 1.55, 0.083333333333333
17599, 1.6565217391304, 1.55, 0.055555555555556
17600, 1.6782608695652, 1.55, 0.027777777777778
17601, 1.7217391304348, 1.55, 0.47222222222222
17602, 1.7, 1.55, 0.44444444444444
17603, 1.7217391304348, 1.55, 0.41666666666667
17604, 1.7, 1.55, 0.38888888888889
17605, 1.7217391304348, 1.55, 0.36111111111111
17606, 1.7, 1.55, 0.33333333333333
17607, 1.7217391304348, 1.55, 0.30555555555556
17608, 1.7, 1.55, 0.27777777777778
17609, 1.7217391304348, 1.55, 0.25
17610, 1.7, 1.55, 0.22222222222222
17611, 1.7217391304348, 1.55, 0.19444444444444
17612, 1.7, 1.55, 0.16666666666667
17613, 1.7217391304348, 1.55, 0.13888888888889
17614, 1.7, 1.55, 0.11111111111111
17615, 1.7217391304348, 1.55, 0.083333333333333
17616, 1.7, 1.55, 0.055555555555556
17617, 1.7217391304348, 1.55, 0.027777777777778
17618, 1.7652173913043, 1.55, 0.47222222222222
17619, 1.7434782608696, 1.55, 0.44444444444444
17620, 1.7652173913043, 1.55, 0.41666666666667
17621, 1.7434782608696, 1.55, 0.38888888888889
17622, 1.7652173913043, 1.55, 0.36111111111111
17623, 1.7434782608696, 1.55, 0.33333333333333
17624, 1.7652173913043, 1.55, 0.30555555555556
17625, 1.7434782608696, 1.55, 0.27777777777778
17626, 1.7652173913043, 1.55, 0.25
17627, 1.7434782608696, 1.55, 0.22222222222222
17628, 1.7652173913043, 1.55, 0.19444444444444
17629, 1.7434782608696, 1.55, 0.16666666666667
17630, 1.7652173913043, 1.55, 0.13888888888889
17631, 1.7434782608696, 1.55, 0.11111111111111
17632, 1.7652173913043, 1.55, 0.083333333333333
17633, 1.7434782608696, 1.55, 0.055555555555556
17634, 1.7652173913043, 1.55, 0.027777777777778
17635, 1.8086956521739, 1.55, 0.47222222222222
17636, 1.7869565217391, 1.55, 0.44444444444444
17637, 1.8086956521739, 1.55, 0.41666666666667
17638, 1.7869565217391, 1.55, 0.38888888888889
17639, 1.8086956521739, 1.55, 0.36111111111111
17640, 1.7869565217391, 1.55, 0.33333333333333
17641, 1.8086956521739, 1.55, 0.30555555555556
17642, 1.7869565217391, 1.55, 0.27777777777778
17643, 1.8086956521739, 1.55, 0.25
17644, 1.7869565217391, 1.55, 0.22222222222222
17645, 1.8086956521739, 1.55, 0.19444444444444
17646, 1.7869565217391, 1.55, 0.16666666666667
17647, 1.8086956521739, 1.55, 0.13888888888889
17648, 1.7869565217391, 1.55, 0.11111111111111
17649, 1.8086956521739, 1.55, 0.083333333333333
17650, 1.7869565217391, 1.55, 0.055555555555556
17651, 1.8086956521739, 1.55, 0.027777777777778
17652, 1.8521739130435, 1.55, 0.47222222222222
17653, 1.8304347826087, 1.55, 0.44444444444444
17654, 1.8521739130435, 1.55, 0.41666666666667
17655, 1.8304347826087, 1.55, 0.38888888888889
17656, 1.8521739130435, 1.55, 0.36111111111111
17657, 1.8304347826087, 1.55, 0.33333333333333
17658, 1.8521739130435, 1.55, 0.30555555555556
17659, 1.8304347826087, 1.55, 0.27777777777778
17660, 1.8521739130435, 1.55, 0.25
17661, 1.8304347826087, 1.55, 0.22222222222222
17662, 1.8521739130435, 1.55, 0.19444444444444
17663, 1.8304347826087, 1.55, 0.16666666666667
17664, 1.8521739130435, 1.55, 0.13888888888889
17665, 1.8304347826087, 1.55, 0.11111111111111
17666, 1.8521739130435, 1.55, 0.083333333333333
17667, 1.8304347826087, 1.55, 0.055555555555556
17668, 1.8521739130435, 1.55, 0.027777777777778
17669, 1.895652173913, 1.55, 0.47222222222222
17670, 1.8739130434783, 1.55, 0.44444444444444
17671, 1.895652173913, 1.55, 0.41666666666667
17672, 1.8739130434783, 1.55, 0.38888888888889
17673, 1.895652173913, 1.55, 0.36111111111111
17674, 1.8739130434783, 1.55, 0.33333333333333
17675, 1.895652173913, 1.55, 0.30555555555556
17676, 1.8739130434783, 1.55, 0.27777777777778
17677, 1.895652173913, 1.55, 0.25
17678, 1.8739130434783, 1.55, 0.22222222222222
17679, 1.895652173913, 1.55, 0.19444444444444
17680, 1.8739130434783, 1.55, 0.16666666666667
17681, 1.895652173913, 1.55, 0.13888888888889
17682, 1.8739130434783, 1.55, 0.11111111111111
17683, 1.895652173913, 1.55, 0.083333333333333
17684, 1.8739130434783, 1.55, 0.055555555555556
17685, 1.895652173913, 1.55, 0.027777777777778
17686, 1.9391304347826, 1.55, 0.47222222222222
17687, 1.9173913043478, 1.55, 0.44444444444444
17688, 1.9391304347826, 1.55, 0.41666666666667
17689, 1.9173913043478, 1.55, 0.38888888888889
17690, 1.9391304347826, 1.55, 0.36111111111111
17691, 1.9173913043478, 1.55, 0.33333333333333
17692, 1.9391304347826, 1.55, 0.30555555555556
17693, 1.9173913043478, 1.55, 0.27777777777778
17694, 1.9391304347826, 1.55, 0.25
17695, 1.9173913043478, 1.55, 0.22222222222222
17696, 1.9391304347826, 1.55, 0.19444444444444
17697, 1.9173913043478, 1.55, 0.16666666666667
17698, 1.9391304347826, 1.55, 0.13888888888889
17699, 1.9173913043478, 1.55, 0.11111111111111
17700, 1.9391304347826, 1.55, 0.083333333333333
17701, 1.9173913043478, 1.55, 0.055555555555556
17702, 1.9391304347826, 1.55, 0.027777777777778
17703, 1.9826086956522, 1.55, 0.47222222222222
17704, 1.9608695652174, 1.55, 0.44444444444444
17705, 1.9826086956522, 1.55, 0.41666666666667
17706, 1.9608695652174, 1.55, 0.38888888888889
17707, 1.9826086956522, 1.55, 0.36111111111111
17708, 1.9608695652174, 1.55, 0.33333333333333
17709, 1.9826086956522, 1.55, 0.30555555555556
17710, 1.9608695652174, 1.55, 0.27777777777778
17711, 1.9826086956522, 1.55, 0.25
17712, 1.9608695652174, 1.55, 0.22222222222222
17713, 1.9826086956522, 1.55, 0.19444444444444
17714, 1.9608695652174, 1.55, 0.16666666666667
17715, 1.9826086956522, 1.55, 0.13888888888889
17716, 1.9608695652174, 1.55, 0.11111111111111
17717, 1.9826086956522, 1.55, 0.083333333333333
17718, 1.9608695652174, 1.55, 0.055555555555556
17719, 1.9826086956522, 1.55, 0.027777777777778
17720, 2.0260869565217, 1.55, 0.47222222222222
17721, 2.004347826087, 1.55, 0.44444444444444
17722, 2.0260869565217, 1.55, 0.41666666666667
17723, 2.004347826087, 1.55, 0.38888888888889
17724, 2.0260869565217, 1.55, 0.36111111111111
17725, 2.004347826087, 1.55, 0.33333333333333
17726, 2.0260869565217, 1.55, 0.30555555555556
17727, 2.004347826087, 1.55, 0.27777777777778
17728, 2.0260869565217, 1.55, 0.25
17729, 2.004347826087, 1.55, 0.22222222222222
17730, 2.0260869565217, 1.55, 0.19444444444444
17731, 2.004347826087, 1.55, 0.16666666666667
17732, 2.0260869565217, 1.55, 0.13888888888889
17733, 2.004347826087, 1.55, 0.11111111111111
17734, 2.0260869565217, 1.55, 0.083333333333333
17735, 2.004347826087, 1.55, 0.055555555555556
17736, 2.0260869565217, 1.55, 0.027777777777778
17737, 2.0695652173913, 1.55, 0.47222222222222
17738, 2.0478260869565, 1.55, 0.44444444444444
17739, 2.0695652173913, 1.55, 0.41666666666667
17740, 2.0478260869565, 1.55, 0.38888888888889
17741, 2.0695652173913, 1.55, 0.36111111111111
17742, 2.0478260869565, 1.55, 0.33333333333333
17743, 2.0695652173913, 1.55, 0.30555555555556
17744, 2.0478260869565, 1.55, 0.27777777777778
17745, 2.0695652173913, 1.55, 0.25
17746, 2.0478260869565, 1.55, 0.22222222222222
17747, 2.0695652173913, 1.55, 0.19444444444444
17748, 2.0478260869565, 1.55, 0.16666666666667
17749, 2.0695652173913, 1.55, 0.13888888888889
17750, 2.0478260869565, 1.55, 0.11111111111111
17751, 2.0695652173913, 1.55, 0.083333333333333
17752, 2.0478260869565, 1.55, 0.055555555555556
17753, 2.0695652173913, 1.55, 0.027777777777778
17754, 2.1130434782609, 1.55, 0.47222222222222
17755, 2.0913043478261, 1.55, 0.44444444444444
17756, 2.1130434782609, 1.55, 0.41666666666667
17757, 2.0913043478261, 1.55, 0.38888888888889
17758, 2.1130434782609, 1.55, 0.36111111111111
17759, 2.0913043478261, 1.55, 0.33333333333333
17760, 2.1130434782609, 1.55, 0.30555555555556
17761, 2.0913043478261, 1.55, 0.27777777777778
17762, 2.1130434782609, 1.55, 0.25
17763, 2.0913043478261, 1.55, 0.22222222222222
17764, 2.1130434782609, 1.55, 0.19444444444444
17765, 2.0913043478261, 1.55, 0.16666666666667
17766, 2.1130434782609, 1.55, 0.13888888888889
17767, 2.0913043478261, 1.55, 0.11111111111111
17768, 2.1130434782609, 1.55, 0.083333333333333
17769, 2.0913043478261, 1.55, 0.055555555555556
17770, 2.1130434782609, 1.55, 0.027777777777778
17771, 2.1565217391304, 1.55, 0.47222222222222
17772, 2.1347826086957, 1.55, 0.44444444444444
17773, 2.1565217391304, 1.55, 0.41666666666667
17774, 2.1347826086957, 1.55, 0.38888888888889
17775, 2.1565217391304, 1.55, 0.36111111111111
17776, 2.1347826086957, 1.55, 0.33333333333333
17777, 2.1565217391304, 1.55, 0.30555555555556
17778, 2.1347826086957, 1.55, 0.27777777777778
17779, 2.1565217391304, 1.55, 0.25
17780, 2.1347826086957, 1.55, 0.22222222222222
17781, 2.1565217391304, 1.55, 0.19444444444444
17782, 2.1347826086957, 1.55, 0.16666666666667
17783, 2.1565217391304, 1.55, 0.13888888888889
17784, 2.1347826086957, 1.55, 0.11111111111111
17785, 2.1565217391304, 1.55, 0.083333333333333
17786, 2.1347826086957, 1.55, 0.055555555555556
17787, 2.1565217391304, 1.55, 0.027777777777778
17788, 2.1782608695652, 1.55, 0.44444444444444
17789, 2.1782608695652, 1.55, 0.38888888888889
17790, 2.1782608695652, 1.55, 0.33333333333333
17791, 2.1782608695652, 1.55, 0.27777777777778
17792, 2.1782608695652, 1.55, 0.22222222222222
17793, 2.1782608695652, 1.55, 0.16666666666667
17794, 2.1782608695652, 1.55, 0.11111111111111
17795, 2.1782608695652, 1.55, 0.055555555555556
17796, 2.2, 1.4833333333333, 0.44444444444444
17797, 2.2, 1.4833333333333, 0.38888888888889
17798, 2.2, 1.4833333333333, 0.33333333333333
17799, 2.2, 1.4833333333333, 0.27777777777778
17800, 2.2, 1.4833333333333, 0.22222222222222
17801, 2.2, 1.4833333333333, 0.16666666666667
17802, 2.2, 1.4833333333333, 0.11111111111111
17803, 2.2, 1.4833333333333, 0.055555555555556
17804, 2.2, 1.5166666666667, 0.44444444444444
17805, 2.2, 1.5166666666667, 0.38888888888889
17806, 2.2, 1.5166666666667, 0.33333333333333
17807, 2.2, 1.5166666666667, 0.27777777777778
17808, 2.2, 1.5166666666667, 0.22222222222222
17809, 2.2, 1.5166666666667, 0.16666666666667
17810, 2.2, 1.5166666666667, 0.11111111111111
17811, 2.2, 1.5166666666667, 0.055555555555556
17812, 2.2, 1.4666666666667, 0.44444444444444
17813, 2.2, 1.4833333333333, 0.47222222222222
17814, 2.2, 1.4666666666667, 0.38888888888889
17815, 2.2, 1.4833333333333, 0.41666666666667
17816, 2.2, 1.4666666666667, 0.33333333333333
17817, 2.2, 1.4833333333333, 0.36111111111111
17818, 2.2, 1.4666666666667, 0.27777777777778
17819, 2.2, 1.4833333333333, 0.30555555555556
17820, 2.2, 1.4666666666667, 0.22222222222222
17821, 2.2, 1.4833333333333, 0.25
17822, 2.2, 1.4666666666667, 0.16666666666667
17823, 2.2, 1.4833333333333, 0.19444444444444
17824, 2.2, 1.4666666666667, 0.11111111111111
17825, 2.2, 1.4833333333333, 0.13888888888889
17826, 2.2, 1.4666666666667, 0.055555555555556
17827, 2.2, 1.4833333333333, 0.083333333333333
17828, 2.2, 1.4833333333333, 0.027777777777778
17829, 2.2, 1.5, 0.44444444444444
17830, 2.2, 1.5166666666667, 0.47222222222222
17831, 2.2, 1.5, 0.38888888888889
17832, 2.2, 1.5166666666667, 0.41666666666667
17833, 2.2, 1.5, 0.33333333333333
17834, 2.2, 1.5166666666667, 0.36111111111111
17835, 2.2, 1.5, 0.27777777777778
17836, 2.2, 1.5166666666667, 0.30555555555556
17837, 2.2, 1.5, 0.22222222222222
17838, 2.2, 1.5166666666667, 0.25
17839, 2.2, 1.5, 0.16666666666667
17840, 2.2, 1.5166666666667, 0.19444444444444
17841, 2.2, 1.5, 0.11111111111111
17842, 2.2, 1.5166666666667, 0.13888888888889
17843, 2.2, 1.5, 0.055555555555556
17844, 2.2, 1.5166666666667, 0.083333333333333
17845, 2.2, 1.5166666666667, 0.027777777777778
17846, 2.2, 1.5333333333333, 0.44444444444444
17847, 2.2, 1.5333333333333, 0.38888888888889
17848, 2.2, 1.5333333333333, 0.33333333333333
17849, 2.2, 1.5333333333333, 0.27777777777778
17850, 2.2, 1.5333333333333, 0.22222222222222
17851, 2.2, 1.5333333333333, 0.16666666666667
17852, 2.2, 1.5333333333333, 0.11111111111111
17853, 2.2, 1.5333333333333, 0.055555555555556
17854, 1.2434782608696, 1.6, 0.5
17855, 1.2869565217391, 1.6, 0.5
17856, 1.3304347826087, 1.6, 0.5
17857, 1.3739130434783, 1.6, 0.5
17858, 1.4173913043478, 1.6, 0.5
17859, 1.4608695652174, 1.6, 0.5
17860, 1.504347826087, 1.6, 0.5
17861, 1.5478260869565, 1.6, 0.5
17862, 1.5913043478261, 1.6, 0.5
17863, 1.6347826086957, 1.6, 0.5
17864, 1.6782608695652, 1.6, 0.5
17865, 1.7217391304348, 1.6, 0.5
17866, 1.7652173913043, 1.6, 0.5
17867, 1.8086956521739, 1.6, 0.5
17868, 1.8521739130435, 1.6, 0.5
17869, 1.895652173913, 1.6, 0.5
17870, 1.9391304347826, 1.6, 0.5
17871, 1.9826086956522, 1.6, 0.5
17872, 2.0260869565217, 1.6, 0.5
17873, 2.0695652173913, 1.6, 0.5
17874, 2.1130434782609, 1.6, 0.5
17875, 2.1565217391304, 1.6, 0.5
17876, 1.2434782608696, 1.65, 0.5
17877, 1.2869565217391, 1.65, 0.5
17878, 1.3304347826087, 1.65, 0.5
17879, 1.3739130434783, 1.65, 0.5
17880, 1.4173913043478, 1.65, 0.5
17881, 1.4608695652174, 1.65, 0.5
17882, 1.504347826087, 1.65, 0.5
17883, 1.5478260869565, 1.65, 0.5
17884, 1.5913043478261, 1.65, 0.5
17885, 1.6347826086957, 1.65, 0.5
17886, 1.6782608695652, 1.65, 0.5
17887, 1.7217391304348, 1.65, 0.5
17888, 1.7652173913043, 1.65, 0.5
17889, 1.8086956521739, 1.65, 0.5
17890, 1.8521739130435, 1.65, 0.5
17891, 1.895652173913, 1.65, 0.5
17892, 1.9391304347826, 1.65, 0.5
17893, 1.9826086956522, 1.65, 0.5
17894, 2.0260869565217, 1.65, 0.5
17895, 2.0695652173913, 1.65, 0.5
17896, 2.1130434782609, 1.65, 0.5
17897, 2.1565217391304, 1.65, 0.5
17898, 1.2434782608696, 1.7, 0.5
17899, 1.2869565217391, 1.7, 0.5
17900, 1.3304347826087, 1.7, 0.5
17901, 1.3739130434783, 1.7, 0.5
17902, 1.4173913043478, 1.7, 0.5
17903, 1.4608695652174, 1.7, 0.5
17904, 1.504347826087, 1.7, 0.5
17905, 1.5478260869565, 1.7, 0.5
17906, 1.5913043478261, 1.7, 0.5
17907, 1.6347826086957, 1.7, 0.5
17908, 1.6782608695652, 1.7, 0.5
17909, 1.7217391304348, 1.7, 0.5
17910, 1.7652173913043, 1.7, 0.5
17911, 1.8086956521739, 1.7, 0.5
17912, 1.8521739130435, 1.7, 0.5
17913, 1.895652173913, 1.7, 0.5
17914, 1.9391304347826, 1.7, 0.5
17915, 1.9826086956522, 1.7, 0.5
17916, 2.0260869565217, 1.7, 0.5
17917, 2.0695652173913, 1.7, 0.5
17918, 2.1130434782609, 1.7, 0.5
17919, 2.1565217391304, 1.7, 0.5
17920, 1.2434782608696, 1.575, 0.5
17921, 1.2217391304348, 1.6, 0.5
17922, 1.2869565217391, 1.575, 0.5
17923, 1.2652173913043, 1.6, 0.5
17924, 1.3304347826087, 1.575, 0.5
17925, 1.3086956521739, 1.6, 0.5
17926, 1.3739130434783, 1.575, 0.5
17927, 1.3521739130435, 1.6, 0.5
17928, 1.4173913043478, 1.575, 0.5
17929, 1.395652173913, 1.6, 0.5
17930, 1.4608695652174, 1.575, 0.5
17931, 1.4391304347826, 1.6, 0.5
17932, 1.504347826087, 1.575, 0.5
17933, 1.4826086956522, 1.6, 0.5
17934, 1.5478260869565, 1.575, 0.5
17935, 1.5260869565217, 1.6, 0.5
17936, 1.5913043478261, 1.575, 0.5
17937, 1.5695652173913, 1.6, 0.5
17938, 1.6347826086957, 1.575, 0.5
17939, 1.6130434782609, 1.6, 0.5
17940, 1.6782608695652, 1.575, 0.5
17941, 1.6565217391304, 1.6, 0.5
17942, 1.7217391304348, 1.575, 0.5
17943, 1.7, 1.6, 0.5
17944, 1.7652173913043, 1.575, 0.5
17945, 1.7434782608696, 1.6, 0.5
17946, 1.8086956521739, 1.575, 0.5
17947, 1.7869565217391, 1.6, 0.5
17948, 1.8521739130435, 1.575, 0.5
17949, 1.8304347826087, 1.6, 0.5
17950, 1.895652173913, 1.575, 0.5
17951, 1.8739130434783, 1.6, 0.5
17952, 1.9391304347826, 1.575, 0.5
17953, 1.9173913043478, 1.6, 0.5
17954, 1.9826086956522, 1.575, 0.5
17955, 1.9608695652174, 1.6, 0.5
17956, 2.0260869565217, 1.575, 0.5
17957, 2.004347826087, 1.6, 0.5
17958, 2.0695652173913, 1.575, 0.5
17959, 2.0478260869565, 1.6, 0.5
17960, 2.1130434782609, 1.575, 0.5
17961, 2.0913043478261, 1.6, 0.5
17962, 2.1565217391304, 1.575, 0.5
17963, 2.1347826086957, 1.6, 0.5
17964, 2.1782608695652, 1.6, 0.5
17965, 1.2434782608696, 1.625, 0.5
17966, 1.2217391304348, 1.65, 0.5
17967, 1.2869565217391, 1.625, 0.5
17968, 1.2652173913043, 1.65, 0.5
17969, 1.3304347826087, 1.625, 0.5
17970, 1.3086956521739, 1.65, 0.5
17971, 1.3739130434783, 1.625, 0.5
17972, 1.3521739130435, 1.65, 0.5
17973, 1.4173913043478, 1.625, 0.5
17974, 1.395652173913, 1.65, 0.5
17975, 1.4608695652174, 1.625, 0.5
17976, 1.4391304347826, 1.65, 0.5
17977, 1.504347826087, 1.625, 0.5
17978, 1.4826086956522, 1.65, 0.5
17979, 1.5478260869565, 1.625, 0.5
17980, 1.5260869565217, 1.65, 0.5
17981, 1.5913043478261, 1.625, 0.5
17982, 1.5695652173913, 1.65, 0.5
17983, 1.6347826086957, 1.625, 0.5
17984, 1.6130434782609, 1.65, 0.5
17985, 1.6782608695652, 1.625, 0.5
17986, 1.6565217391304, 1.65, 0.5
17987, 1.7217391304348, 1.625, 0.5
17988, 1.7, 1.65, 0.5
17989, 1.7652173913043, 1.625, 0.5
17990, 1.7434782608696, 1.65, 0.5
17991, 1.8086956521739, 1.625, 0.5
17992, 1.7869565217391, 1.65, 0.5
17993, 1.8521739130435, 1.625, 0.5
17994, 1.8304347826087, 1.65, 0.5
17995, 1.895652173913, 1.625, 0.5
17996, 1.8739130434783, 1.65, 0.5
17997, 1.9391304347826, 1.625, 0.5
17998, 1.9173913043478, 1.65, 0.5
17999, 1.9826086956522, 1.625, 0.5
18000, 1.9608695652174, 1.65, 0.5
18001, 2.0260869565217, 1.625, 0.5
18002, 2.004347826087, 1.65, 0.5
18003, 2.0695652173913, 1.625, 0.5
18004, 2.0478260869565, 1.65, 0.5
18005, 2.1130434782609, 1.625, 0.5
18006, 2.0913043478261, 1.65, 0.5
18007, 2.1565217391304, 1.625, 0.5
18008, 2.1347826086957, 1.65, 0.5
18009, 2.1782608695652, 1.65, 0.5
18010, 1.2434782608696, 1.675, 0.5
18011, 1.2217391304348, 1.7, 0.5
18012, 1.2869565217391, 1.675, 0.5
18013, 1.2652173913043, 1.7, 0.5
18014, 1.3304347826087, 1.675, 0.5
18015, 1.3086956521739, 1.7, 0.5
18016, 1.3739130434783, 1.675, 0.5
18017, 1.3521739130435, 1.7, 0.5
18018, 1.4173913043478, 1.675, 0.5
18019, 1.395652173913, 1.7, 0.5
18020, 1.4608695652174, 1.675, 0.5
18021, 1.4391304347826, 1.7, 0.5
18022, 1.504347826087, 1.675, 0.5
18023, 1.4826086956522, 1.7, 0.5
18024, 1.5478260869565, 1.675, 0.5
18025, 1.5260869565217, 1.7, 0.5
18026, 1.5913043478261, 1.675, 0.5
18027, 1.5695652173913, 1.7, 0.5
18028, 1.6347826086957, 1.675, 0.5
18029, 1.6130434782609, 1.7, 0.5
18030, 1.6782608695652, 1.675, 0.5
18031, 1.6565217391304, 1.7, 0.5
18032, 1.7217391304348, 1.675, 0.5
18033, 1.7, 1.7, 0.5
18034, 1.7652173913043, 1.675, 0.5
18035, 1.7434782608696, 1.7, 0.5
18036, 1.8086956521739, 1.675, 0.5
18037, 1.7869565217391, 1.7, 0.5
18038, 1.8521739130435, 1.675, 0.5
18039, 1.8304347826087, 1.7, 0.5
18040, 1.895652173913, 1.675, 0.5
18041, 1.8739130434783, 1.7, 0.5
18042, 1.9391304347826, 1.675, 0.5
18043, 1.9173913043478, 1.7, 0.5
18044, 1.9826086956522, 1.675, 0.5
18045, 1.9608695652174, 1.7, 0.5
18046, 2.0260869565217, 1.675, 0.5
18047, 2.004347826087, 1.7, 0.5
18048, 2.0695652173913, 1.675, 0.5
18049, 2.0478260869565, 1.7, 0.5
18050, 2.1130434782609, 1.675, 0.5
18051, 2.0913043478261, 1.7, 0.5
18052, 2.1565217391304, 1.675, 0.5
18053, 2.1347826086957, 1.7, 0.5
18054, 2.1782608695652, 1.7, 0.5
18055, 1.2434782608696, 1.725, 0.5
18056, 1.2869565217391, 1.725, 0.5
18057, 1.3304347826087, 1.725, 0.5
18058, 1.3739130434783, 1.725, 0.5
18059, 1.4173913043478, 1.725, 0.5
18060, 1.4608695652174, 1.725, 0.5
18061, 1.504347826087, 1.725, 0.5
18062, 1.5478260869565, 1.725, 0.5
18063, 1.5913043478261, 1.725, 0.5
18064, 1.6347826086957, 1.725, 0.5
18065, 1.6782608695652, 1.725, 0.5
18066, 1.7217391304348, 1.725, 0.5
18067, 1.7652173913043, 1.725, 0.5
18068, 1.8086956521739, 1.725, 0.5
18069, 1.8521739130435, 1.725, 0.5
18070, 1.895652173913, 1.725, 0.5
18071, 1.9391304347826, 1.725, 0.5
18072, 1.9826086956522, 1.725, 0.5
18073, 2.0260869565217, 1.725, 0.5
18074, 2.0695652173913, 1.725, 0.5
18075, 2.1130434782609, 1.725, 0.5
18076, 2.1565217391304, 1.725, 0.5
18077, 1.2434782608696, 1.6, 0
18078, 1.2869565217391, 1.6, 0
18079, 1.3304347826087, 1.6, 0
18080, 1.3739130434783, 1.6, 0
18081, 1.4173913043478, 1.6, 0
18082, 1.4608695652174, 1.6, 0
18083, 1.504347826087, 1.6, 0
18084, 1.5478260869565, 1.6, 0
18085, 1.5913043478261, 1.6, 0
18086, 1.6347826086957, 1.6, 0
18087, 1.6782608695652, 1.6, 0
18088, 1.7217391304348, 1.6, 0
18089, 1.7652173913043, 1.6, 0
18090, 1.8086956521739, 1.6, 0
18091, 1.8521739130435, 1.6, 0
18092, 1.895652173913, 1.6, 0
18093, 1.9391304347826, 1.6, 0
18094, 1.9826086956522, 1.6, 0
18095, 2.0260869565217, 1.6, 0
18096, 2.0695652173913, 1.6, 0
18097, 2.1130434782609, 1.6, 0
18098, 2.1565217391304, 1.6, 0
18099, 1.2434782608696, 1.65, 0
18100, 1.2869565217391, 1.65, 0
18101, 1.3304347826087, 1.65, 0
18102, 1.3739130434783, 1.65, 0
18103, 1.4173913043478, 1.65, 0
18104, 1.4608695652174, 1.65, 0
18105, 1.504347826087, 1.65, 0
18106, 1.5478260869565, 1.65, 0
18107, 1.5913043478261, 1.65, 0
18108, 1.6347826086957, 1.65, 0
18109, 1.6782608695652, 1.65, 0
18110, 1.7217391304348, 1.65, 0
18111, 1.7652173913043, 1.65, 0
18112, 1.8086956521739, 1.65, 0
18113, 1.8521739130435, 1.65, 0
18114, 1.895652173913, 1.65, 0
18115, 1.9391304347826, 1.65, 0
18116, 1.9826086956522, 1.65, 0
18117, 2.0260869565217, 1.65, 0
18118, 2.0695652173913, 1.65, 0
18119, 2.1130434782609, 1.65, 0
18120, 2.1565217391304, 1.65, 0
18121, 1.2434782608696, 1.7, 0
18122, 1.2869565217391, 1.7, 0
18123, 1.3304347826087, 1.7, 0
18124, 1.3739130434783, 1.7, 0
18125, 1.4173913043478, 1.7, 0
18126, 1.4608695652174, 1.7, 0
18127, 1.504347826087, 1.7, 0
18128, 1.5478260869565, 1.7, 0
18129, 1.5913043478261, 1.7, 0
18130, 1.6347826086957, 1.7, 0
18131, 1.6782608695652, 1.7, 0
18132, 1.7217391304348, 1.7, 0
18133, 1.7652173913043, 1.7, 0
18134, 1.8086956521739, 1.7, 0
18135, 1.8521739130435, 1.7, 0
18136, 1.895652173913, 1.7, 0
18137, 1.9391304347826, 1.7, 0
18138, 1.9826086956522, 1.7, 0
18139, 2.0260869565217, 1.7, 0
18140, 2.0695652173913, 1.7, 0
18141, 2.1130434782609, 1.7, 0
18142, 2.1565217391304, 1.7, 0
18143, 1.2217391304348, 1.6, 0
18144, 1.2434782608696, 1.575, 0
18145, 1.2652173913043, 1.6, 0
18146, 1.2869565217391, 1.575, 0
18147, 1.3086956521739, 1.6, 0
18148, 1.3304347826087, 1.575, 0
18149, 1.3521739130435, 1.6, 0
18150, 1.3739130434783, 1.575, 0
18151, 1.395652173913, 1.6, 0
18152, 1.4173913043478, 1.575, 0
18153, 1.4391304347826, 1.6, 0
18154, 1.4608695652174, 1.575, 0
18155, 1.4826086956522, 1.6, 0
18156, 1.504347826087, 1.575, 0
18157, 1.5260869565217, 1.6, 0
18158, 1.5478260869565, 1.575, 0
18159, 1.5695652173913, 1.6, 0
18160, 1.5913043478261, 1.575, 0
18161, 1.6130434782609, 1.6, 0
18162, 1.6347826086957, 1.575, 0
18163, 1.6565217391304, 1.6, 0
18164, 1.6782608695652, 1.575, 0
18165, 1.7, 1.6, 0
18166, 1.7217391304348, 1.575, 0
18167, 1.7434782608696, 1.6, 0
18168, 1.7652173913043, 1.575, 0
18169, 1.7869565217391, 1.6, 0
18170, 1.8086956521739, 1.575, 0
18171, 1.8304347826087, 1.6, 0
18172, 1.8521739130435, 1.575, 0
18173, 1.8739130434783, 1.6, 0
18174, 1.895652173913, 1.575, 0
18175, 1.9173913043478, 1.6, 0
18176, 1.9391304347826, 1.575, 0
18177, 1.9608695652174, 1.6, 0
18178, 1.9826086956522, 1.575, 0
18179, 2.004347826087, 1.6, 0
18180, 2.0260869565217, 1.575, 0
18181, 2.0478260869565, 1.6, 0
18182, 2.0695652173913, 1.575, 0
18183, 2.0913043478261, 1.6, 0
18184, 2.1130434782609, 1.575, 0
18185, 2.1347826086957, 1.6, 0
18186, 2.1565217391304, 1.575, 0
18187, 2.1782608695652, 1.6, 0
18188, 1.2217391304348, 1.65, 0
18189, 1.2434782608696, 1.625, 0
18190, 1.2652173913043, 1.65, 0
18191, 1.2869565217391, 1.625, 0
18192, 1.3086956521739, 1.65, 0
18193, 1.3304347826087, 1.625, 0
18194, 1.3521739130435, 1.65, 0
18195, 1.3739130434783, 1.625, 0
18196, 1.395652173913, 1.65, 0
18197, 1.4173913043478, 1.625, 0
18198, 1.4391304347826, 1.65, 0
18199, 1.4608695652174, 1.625, 0
18200, 1.4826086956522, 1.65, 0
18201, 1.504347826087, 1.625, 0
18202, 1.5260869565217, 1.65, 0
18203, 1.5478260869565, 1.625, 0
18204, 1.5695652173913, 1.65, 0
18205, 1.5913043478261, 1.625, 0
18206, 1.6130434782609, 1.65, 0
18207, 1.6347826086957, 1.625, 0
18208, 1.6565217391304, 1.65, 0
18209, 1.6782608695652, 1.625, 0
18210, 1.7, 1.65, 0
18211, 1.7217391304348, 1.625, 0
18212, 1.7434782608696, 1.65, 0
18213, 1.7652173913043, 1.625, 0
18214, 1.7869565217391, 1.65, 0
18215, 1.8086956521739, 1.625, 0
18216, 1.8304347826087, 1.65, 0
18217, 1.8521739130435, 1.625, 0
18218, 1.8739130434783, 1.65, 0
18219, 1.895652173913, 1.625, 0
18220, 1.9173913043478, 1.65, 0
18221, 1.9391304347826, 1.625, 0
18222, 1.9608695652174, 1.65, 0
18223, 1.9826086956522, 1.625, 0
18224, 2.004347826087, 1.65, 0
18225, 2.0260869565217, 1.625, 0
18226, 2.0478260869565, 1.65, 0
18227, 2.0695652173913, 1.625, 0
18228, 2.0913043478261, 1.65, 0
18229, 2.1130434782609, 1.625, 0
18230, 2.1347826086957, 1.65, 0
18231, 2.1565217391304, 1.625, 0
18232, 2.1782608695652, 1.65, 0
18233, 1.2217391304348, 1.7, 0
18234, 1.2434782608696, 1.675, 0
18235, 1.2652173913043, 1.7, 0
18236, 1.2869565217391, 1.675, 0
18237, 1.3086956521739, 1.7, 0
18238, 1.3304347826087, 1.675, 0
18239, 1.3521739130435, 1.7, 0
18240, 1.3739130434783, 1.675, 0
18241, 1.395652173913, 1.7, 0
18242, 1.4173913043478, 1.675, 0
18243, 1.4391304347826, 1.7, 0
18244, 1.4608695652174, 1.675, 0
18245, 1.4826086956522, 1.7, 0
18246, 1.504347826087, 1.675, 0
18247, 1.5260869565217, 1.7, 0
18248, 1.5478260869565, 1.675, 0
18249, 1.5695652173913, 1.7, 0
18250, 1.5913043478261, 1.675, 0
18251, 1.6130434782609, 1.7, 0
18252, 1.6347826086957, 1.675, 0
18253, 1.6565217391304, 1.7, 0
18254, 1.6782608695652, 1.675, 0
18255, 1.7, 1.7, 0
18256, 1.7217391304348, 1.675, 0
18257, 1.7434782608696, 1.7, 0
18258, 1.7652173913043, 1.675, 0
18259, 1.7869565217391, 1.7, 0
18260, 1.8086956521739, 1.675, 0
18261, 1.8304347826087, 1.7, 0
18262, 1.8521739130435, 1.675, 0
18263, 1.8739130434783, 1.7, 0
18264, 1.895652173913, 1.675, 0
18265, 1.9173913043478, 1.7, 0
18266, 1.9391304347826, 1.675, 0
18267, 1.9608695652174, 1.7, 0
18268, 1.9826086956522, 1.675, 0
18269, 2.004347826087, 1.7, 0
18270, 2.0260869565217, 1.675, 0
18271, 2.0478260869565, 1.7, 0
18272, 2.0695652173913, 1.675, 0
18273, 2.0913043478261, 1.7, 0
18274, 2.1130434782609, 1.675, 0
18275, 2.1347826086957, 1.7, 0
18276, 2.1565217391304, 1.675, 0
18277, 2.1782608695652, 1.7, 0
18278, 1.2434782608696, 1.725, 0
18279, 1.2869565217391, 1.725, 0
18280, 1.3304347826087, 1.725, 0
18281, 1.3739130434783, 1.725, 0
18282, 1.4173913043478, 1.725, 0
18283, 1.4608695652174, 1.725, 0
18284, 1.504347826087, 1.725, 0
18285, 1.5478260869565, 1.725, 0
18286, 1.5913043478261, 1.725, 0
18287, 1.6347826086957, 1.725, 0
18288, 1.6782608695652, 1.725, 0
18289, 1.7217391304348, 1.725, 0
18290, 1.7652173913043, 1.725, 0
18291, 1.8086956521739, 1.725, 0
18292, 1.8521739130435, 1.725, 0
18293, 1.895652173913, 1.725, 0
18294, 1.9391304347826, 1.725, 0
18295, 1.9826086956522, 1.725, 0
18296, 2.0260869565217, 1.725, 0
18297, 2.0695652173913, 1.725, 0
18298, 2.1130434782609, 1.725, 0
18299, 2.1565217391304, 1.725, 0
18300, 2.2, 1.6, 0.44444444444444
18301, 2.2, 1.6, 0.38888888888889
18302, 2.2, 1.6, 0.33333333333333
18303, 2.2, 1.6, 0.27777777777778
18304, 2.2, 1.6, 0.22222222222222
18305, 2.2, 1.6, 0.16666666666667
18306, 2.2, 1.6, 0.11111111111111
18307, 2.2, 1.6, 0.055555555555556
18308, 2.2, 1.65, 0.44444444444444
18309, 2.2, 1.65, 0.38888888888889
18310, 2.2, 1.65, 0.33333333333333
18311, 2.2, 1.65, 0.27777777777778
18312, 2.2, 1.65, 0.22222222222222
18313, 2.2, 1.65, 0.16666666666667
18314, 2.2, 1.65, 0.11111111111111
18315, 2.2, 1.65, 0.055555555555556
18316, 2.2, 1.7, 0.44444444444444
18317, 2.2, 1.7, 0.38888888888889
18318, 2.2, 1.7, 0.33333333333333
18319, 2.2, 1.7, 0.27777777777778
18320, 2.2, 1.7, 0.22222222222222
18321, 2.2, 1.7, 0.16666666666667
18322, 2.2, 1.7, 0.11111111111111
18323, 2.2, 1.7, 0.055555555555556
18324, 2.2, 1.575, 0.44444444444444
18325, 2.2, 1.6, 0.47222222222222
18326, 2.2, 1.575, 0.38888888888889
18327, 2.2, 1.6, 0.41666666666667
18328, 2.2, 1.575, 0.33333333333333
18329, 2.2, 1.6, 0.36111111111111
18330, 2.2, 1.575, 0.27777777777778
18331, 2.2, 1.6, 0.30555555555556
18332, 2.2, 1.575, 0.22222222222222
18333, 2.2, 1.6, 0.25
18334, 2.2, 1.575, 0.16666666666667
18335, 2.2, 1.6, 0.19444444444444
18336, 2.2, 1.575, 0.11111111111111
18337, 2.2, 1.6, 0.13888888888889
18338, 2.2, 1.575, 0.055555555555556
18339, 2.2, 1.6, 0.083333333333333
18340, 2.2, 1.6, 0.027777777777778
18341, 2.2, 1.625, 0.44444444444444
18342, 2.2, 1.65, 0.47222222222222
18343, 2.2, 1.625, 0.38888888888889
18344, 2.2, 1.65, 0.41666666666667
18345, 2.2, 1.625, 0.33333333333333
18346, 2.2, 1.65, 0.36111111111111
18347, 2.2, 1.625, 0.27777777777778
18348, 2.2, 1.65, 0.30555555555556
18349, 2.2, 1.625, 0.22222222222222
18350, 2.2, 1.65, 0.25
18351, 2.2, 1.625, 0.16666666666667
18352, 2.2, 1.65, 0.19444444444444
18353, 2.2, 1.625, 0.11111111111111
18354, 2.2, 1.65, 0.13888888888889
18355, 2.2, 1.625, 0.055555555555556
18356, 2.2, 1.65, 0.083333333333333
18357, 2.2, 1.65, 0.027777777777778
18358, 2.2, 1.675, 0.44444444444444
18359, 2.2, 1.7, 0.47222222222222
18360, 2.2, 1.675, 0.38888888888889
18361, 2.2, 1.7, 0.41666666666667
18362, 2.2, 1.675, 0.33333333333333
18363, 2.2, 1.7, 0.36111111111111
18364, 2.2, 1.675, 0.27777777777778
18365, 2.2, 1.7, 0.30555555555556
18366, 2.2, 1.675, 0.22222222222222
18367, 2.2, 1.7, 0.25
18368, 2.2, 1.675, 0.16666666666667
18369, 2.2, 1.7, 0.19444444444444
18370, 2.2, 1.675, 0.11111111111111
18371, 2.2, 1.7, 0.13888888888889
18372, 2.2, 1.675, 0.055555555555556
18373, 2.2, 1.7, 0.083333333333333
18374, 2.2, 1.7, 0.027777777777778
18375, 2.2, 1.725, 0.44444444444444
18376, 2.2, 1.725, 0.38888888888889
18377, 2.2, 1.725, 0.33333333333333
18378, 2.2, 1.725, 0.27777777777778
18379, 2.2, 1.725, 0.22222222222222
18380, 2.2, 1.725, 0.16666666666667
18381, 2.2, 1.725, 0.11111111111111
18382, 2.2, 1.725, 0.055555555555556
18383, 1.2434782608696, 1.75, 0.44444444444444
18384, 1.2434782608696, 1.75, 0.38888888888889
18385, 1.2434782608696, 1.75, 0.33333333333333
18386, 1.2434782608696, 1.75, 0.27777777777778
18387, 1.2434782608696, 1.75, 0.22222222222222
18388, 1.2434782608696, 1.75, 0.16666666666667
18389, 1.2434782608696, 1.75, 0.11111111111111
18390, 1.2434782608696, 1.75, 0.055555555555556
18391, 1.2869565217391, 1.75, 0.44444444444444
18392, 1.2869565217391, 1.75, 0.38888888888889
18393, 1.2869565217391, 1.75, 0.33333333333333
18394, 1.2869565217391, 1.75, 0.27777777777778
18395, 1.2869565217391, 1.75, 0.22222222222222
18396, 1.2869565217391, 1.75, 0.16666666666667
18397, 1.2869565217391, 1.75, 0.11111111111111
18398, 1.2869565217391, 1.75, 0.055555555555556
18399, 1.3304347826087, 1.75, 0.44444444444444
18400, 1.3304347826087, 1.75, 0.38888888888889
18401, 1.3304347826087, 1.75, 0.33333333333333
18402, 1.3304347826087, 1.75, 0.27777777777778
18403, 1.3304347826087, 1.75, 0.22222222222222
18404, 1.3304347826087, 1.75, 0.16666666666667
18405, 1.3304347826087, 1.75, 0.11111111111111
18406, 1.3304347826087, 1.75, 0.055555555555556
18407, 1.3739130434783, 1.75, 0.44444444444444
18408, 1.3739130434783, 1.75, 0.38888888888889
18409, 1.3739130434783, 1.75, 0.33333333333333
18410, 1.3739130434783, 1.75, 0.27777777777778
18411, 1.3739130434783, 1.75, 0.22222222222222
18412, 1.3739130434783, 1.75, 0.16666666666667
18413, 1.3739130434783, 1.75, 0.11111111111111
18414, 1.3739130434783, 1.75, 0.055555555555556
18415, 1.4173913043478, 1.75, 0.44444444444444
18416, 1.4173913043478, 1.75, 0.38888888888889
18417, 1.4173913043478, 1.75, 0.33333333333333
18418, 1.4173913043478, 1.75, 0.27777777777778
18419, 1.4173913043478, 1.75, 0.22222222222222
18420, 1.4173913043478, 1.75, 0.16666666666667
18421, 1.4173913043478, 1.75, 0.11111111111111
18422, 1.4173913043478, 1.75, 0.055555555555556
18423, 1.4608695652174, 1.75, 0.44444444444444
18424, 1.4608695652174, 1.75, 0.38888888888889
18425, 1.4608695652174, 1.75, 0.33333333333333
18426, 1.4608695652174, 1.75, 0.27777777777778
18427, 1.4608695652174, 1.75, 0.22222222222222
18428, 1.4608695652174, 1.75, 0.16666666666667
18429, 1.4608695652174, 1.75, 0.11111111111111
18430, 1.4608695652174, 1.75, 0.055555555555556
18431, 1.504347826087, 1.75, 0.44444444444444
18432, 1.504347826087, 1.75, 0.38888888888889
18433, 1.504347826087, 1.75, 0.33333333333333
18434, 1.504347826087, 1.75, 0.27777777777778
18435, 1.504347826087, 1.75, 0.22222222222222
18436, 1.504347826087, 1.75, 0.16666666666667
18437, 1.504347826087, 1.75, 0.11111111111111
18438, 1.504347826087, 1.75, 0.055555555555556
18439, 1.5478260869565, 1.75, 0.44444444444444
18440, 1.5478260869565, 1.75, 0.38888888888889
18441, 1.5478260869565, 1.75, 0.33333333333333
18442, 1.5478260869565, 1.75, 0.27777777777778
18443, 1.5478260869565, 1.75, 0.22222222222222
18444, 1.5478260869565, 1.75, 0.16666666666667
18445, 1.5478260869565, 1.75, 0.11111111111111
18446, 1.5478260869565, 1.75, 0.055555555555556
18447, 1.5913043478261, 1.75, 0.44444444444444
18448, 1.5913043478261, 1.75, 0.38888888888889
18449, 1.5913043478261, 1.75, 0.33333333333333
18450, 1.5913043478261, 1.75, 0.27777777777778
18451, 1.5913043478261, 1.75, 0.22222222222222
18452, 1.5913043478261, 1.75, 0.16666666666667
18453, 1.5913043478261, 1.75, 0.11111111111111
18454, 1.5913043478261, 1.75, 0.055555555555556
18455, 1.6347826086957, 1.75, 0.44444444444444
18456, 1.6347826086957, 1.75, 0.38888888888889
18457, 1.6347826086957, 1.75, 0.33333333333333
18458, 1.6347826086957, 1.75, 0.27777777777778
18459, 1.6347826086957, 1.75, 0.22222222222222
18460, 1.6347826086957, 1.75, 0.16666666666667
18461, 1.6347826086957, 1.75, 0.11111111111111
18462, 1.6347826086957, 1.75, 0.055555555555556
18463, 1.6782608695652, 1.75, 0.44444444444444
18464, 1.6782608695652, 1.75, 0.38888888888889
18465, 1.6782608695652, 1.75, 0.33333333333333
18466, 1.6782608695652, 1.75, 0.27777777777778
18467, 1.6782608695652, 1.75, 0.22222222222222
18468, 1.6782608695652, 1.75, 0.16666666666667
18469, 1.6782608695652, 1.75, 0.11111111111111
18470, 1.6782608695652, 1.75, 0.055555555555556
18471, 1.7217391304348, 1.75, 0.44444444444444
18472, 1.7217391304348, 1.75, 0.38888888888889
18473, 1.7217391304348, 1.75, 0.33333333333333
18474, 1.7217391304348, 1.75, 0.27777777777778
18475, 1.7217391304348, 1.75, 0.22222222222222
18476, 1.7217391304348, 1.75, 0.16666666666667
18477, 1.7217391304348, 1.75, 0.11111111111111
18478, 1.7217391304348, 1.75, 0.055555555555556
18479, 1.7652173913043, 1.75, 0.44444444444444
18480, 1.7652173913043, 1.75, 0.38888888888889
18481, 1.7652173913043, 1.75, 0.33333333333333
18482, 1.7652173913043, 1.75, 0.27777777777778
18483, 1.7652173913043, 1.75, 0.22222222222222
18484, 1.7652173913043, 1.75, 0.16666666666667
18485, 1.7652173913043, 1.75, 0.11111111111111
18486, 1.7652173913043, 1.75, 0.055555555555556
18487, 1.8086956521739, 1.75, 0.44444444444444
18488, 1.8086956521739, 1.75, 0.38888888888889
18489, 1.8086956521739, 1.75, 0.33333333333333
18490, 1.8086956521739, 1.75, 0.27777777777778
18491, 1.8086956521739, 1.75, 0.22222222222222
18492, 1.8086956521739, 1.75, 0.16666666666667
18493, 1.8086956521739, 1.75, 0.11111111111111
18494, 1.8086956521739, 1.75, 0.055555555555556
18495, 1.8521739130435, 1.75, 0.44444444444444
18496, 1.8521739130435, 1.75, 0.38888888888889
18497, 1.8521739130435, 1.75, 0.33333333333333
18498, 1.8521739130435, 1.75, 0.27777777777778
18499, 1.8521739130435, 1.75, 0.22222222222222
18500, 1.8521739130435, 1.75, 0.16666666666667
18501, 1.8521739130435, 1.75, 0.11111111111111
18502, 1.8521739130435, 1.75, 0.055555555555556
18503, 1.895652173913, 1.75, 0.44444444444444
18504, 1.895652173913, 1.75, 0.38888888888889
18505, 1.895652173913, 1.75, 0.33333333333333
18506, 1.895652173913, 1.75, 0.27777777777778
18507, 1.895652173913, 1.75, 0.22222222222222
18508, 1.895652173913, 1.75, 0.16666666666667
18509, 1.895652173913, 1.75, 0.11111111111111
18510, 1.895652173913, 1.75, 0.055555555555556
18511, 1.9391304347826, 1.75, 0.44444444444444
18512, 1.9391304347826, 1.75, 0.38888888888889
18513, 1.9391304347826, 1.75, 0.33333333333333
18514, 1.9391304347826, 1.75, 0.27777777777778
18515, 1.9391304347826, 1.75, 0.22222222222222
18516, 1.9391304347826, 1.75, 0.16666666666667
18517, 1.9391304347826, 1.75, 0.11111111111111
18518, 1.9391304347826, 1.75, 0.055555555555556
18519, 1.9826086956522, 1.75, 0.44444444444444
18520, 1.9826086956522, 1.75, 0.38888888888889
18521, 1.9826086956522, 1.75, 0.33333333333333
18522, 1.9826086956522, 1.75, 0.27777777777778
18523, 1.9826086956522, 1.75, 0.22222222222222
18524, 1.9826086956522, 1.75, 0.16666666666667
18525, 1.9826086956522, 1.75, 0.11111111111111
18526, 1.9826086956522, 1.75, 0.055555555555556
18527, 2.0260869565217, 1.75, 0.44444444444444
18528, 2.0260869565217, 1.75, 0.38888888888889
18529, 2.0260869565217, 1.75, 0.33333333333333
18530, 2.0260869565217, 1.75, 0.27777777777778
18531, 2.0260869565217, 1.75, 0.22222222222222
18532, 2.0260869565217, 1.75, 0.16666666666667
18533, 2.0260869565217, 1.75, 0.11111111111111
18534, 2.0260869565217, 1.75, 0.055555555555556
18535, 2.0695652173913, 1.75, 0.44444444444444
18536, 2.0695652173913, 1.75, 0.38888888888889
18537, 2.0695652173913, 1.75, 0.33333333333333
18538, 2.0695652173913, 1.75, 0.27777777777778
18539, 2.0695652173913, 1.75, 0.22222222222222
18540, 2.0695652173913, 1.75, 0.16666666666667
18541, 2.0695652173913, 1.75, 0.11111111111111
18542, 2.0695652173913, 1.75, 0.055555555555556
18543, 2.1130434782609, 1.75, 0.44444444444444
18544, 2.1130434782609, 1.75, 0.38888888888889
18545, 2.1130434782609, 1.75, 0.33333333333333
18546, 2.1130434782609, 1.75, 0.27777777777778
18547, 2.1130434782609, 1.75, 0.22222222222222
18548, 2.1130434782609, 1.75, 0.16666666666667
18549, 2.1130434782609, 1.75, 0.11111111111111
18550, 2.1130434782609, 1.75, 0.055555555555556
18551, 2.1565217391304, 1.75, 0.44444444444444
18552, 2.1565217391304, 1.75, 0.38888888888889
18553, 2.1565217391304, 1.75, 0.33333333333333
18554, 2.1565217391304, 1.75, 0.27777777777778
18555, 2.1565217391304, 1.75, 0.22222222222222
18556, 2.1565217391304, 1.75, 0.16666666666667
18557, 2.1565217391304, 1.75, 0.11111111111111
18558, 2.1565217391304, 1.75, 0.055555555555556
18559, 1.2434782608696, 1.75, 0.47222222222222
18560, 1.2217391304348, 1.75, 0.44444444444444
18561, 1.2434782608696, 1.75, 0.41666666666667
18562, 1.2217391304348, 1.75, 0.38888888888889
18563, 1.2434782608696, 1.75, 0.36111111111111
18564, 1.2217391304348, 1.75, 0.33333333333333
18565, 1.2434782608696, 1.75, 0.30555555555556
18566, 1.2217391304348, 1.75, 0.27777777777778
18567, 1.2434782608696, 1.75, 0.25
18568, 1.2217391304348, 1.75, 0.22222222222222
18569, 1.2434782608696, 1.75, 0.19444444444444
18570, 1.2217391304348, 1.75, 0.16666666666667
18571, 1.2434782608696, 1.75, 0.13888888888889
18572, 1.2217391304348, 1.75, 0.11111111111111
18573, 1.2434782608696, 1.75, 0.083333333333333
18574, 1.2217391304348, 1.75, 0.055555555555556
18575, 1.2434782608696, 1.75, 0.027777777777778
18576, 1.2869565217391, 1.75, 0.47222222222222
18577, 1.2652173913043, 1.75, 0.44444444444444
18578, 1.2869565217391, 1.75, 0.41666666666667
18579, 1.2652173913043, 1.75, 0.38888888888889
18580, 1.2869565217391, 1.75, 0.36111111111111
18581, 1.2652173913043, 1.75, 0.33333333333333
18582, 1.2869565217391, 1.75, 0.30555555555556
18583, 1.2652173913043, 1.75, 0.27777777777778
18584, 1.2869565217391, 1.75, 0.25
18585, 1.2652173913043, 1.75, 0.22222222222222
18586, 1.2869565217391, 1.75, 0.19444444444444
18587, 1.2652173913043, 1.75, 0.16666666666667
18588, 1.2869565217391, 1.75, 0.13888888888889
18589, 1.2652173913043, 1.75, 0.11111111111111
18590, 1.2869565217391, 1.75, 0.083333333333333
18591, 1.2652173913043, 1.75, 0.055555555555556
18592, 1.2869565217391, 1.75, 0.027777777777778
18593, 1.3304347826087, 1.75, 0.47222222222222
18594, 1.3086956521739, 1.75, 0.44444444444444
18595, 1.3304347826087, 1.75, 0.41666666666667
18596, 1.3086956521739, 1.75, 0.38888888888889
18597, 1.3304347826087, 1.75, 0.36111111111111
18598, 1.3086956521739, 1.75, 0.33333333333333
18599, 1.3304347826087, 1.75, 0.30555555555556
18600, 1.3086956521739, 1.75, 0.27777777777778
18601, 1.3304347826087, 1.75, 0.25
18602, 1.3086956521739, 1.75, 0.22222222222222
18603, 1.3304347826087, 1.75, 0.19444444444444
18604, 1.3086956521739, 1.75, 0.16666666666667
18605, 1.3304347826087, 1.75, 0.13888888888889
18606, 1.3086956521739, 1.75, 0.11111111111111
18607, 1.3304347826087, 1.75, 0.083333333333333
18608, 1.3086956521739, 1.75, 0.055555555555556
18609, 1.3304347826087, 1.75, 0.027777777777778
18610, 1.3739130434783, 1.75, 0.47222222222222
18611, 1.3521739130435, 1.75, 0.44444444444444
18612, 1.3739130434783, 1.75, 0.41666666666667
18613, 1.3521739130435, 1.75, 0.38888888888889
18614, 1.3739130434783, 1.75, 0.36111111111111
18615, 1.3521739130435, 1.75, 0.33333333333333
18616, 1.3739130434783, 1.75, 0.30555555555556
18617, 1.3521739130435, 1.75, 0.27777777777778
18618, 1.3739130434783, 1.75, 0.25
18619, 1.3521739130435, 1.75, 0.22222222222222
18620, 1.3739130434783, 1.75, 0.19444444444444
18621, 1.3521739130435, 1.75, 0.16666666666667
18622, 1.3739130434783, 1.75, 0.13888888888889
18623, 1.3521739130435, 1.75, 0.11111111111111
18624, 1.3739130434783, 1.75, 0.083333333333333
18625, 1.3521739130435, 1.75, 0.055555555555556
18626, 1.3739130434783, 1.75, 0.027777777777778
18627, 1.4173913043478, 1.75, 0.47222222222222
18628, 1.395652173913, 1.75, 0.44444444444444
18629, 1.4173913043478, 1.75, 0.41666666666667
18630, 1.395652173913, 1.75, 0.38888888888889
18631, 1.4173913043478, 1.75, 0.36111111111111
18632, 1.395652173913, 1.75, 0.33333333333333
18633, 1.4173913043478, 1.75, 0.30555555555556
18634, 1.395652173913, 1.75, 0.27777777777778
18635, 1.4173913043478, 1.75, 0.25
18636, 1.395652173913, 1.75, 0.22222222222222
18637, 1.4173913043478, 1.75, 0.19444444444444
18638, 1.395652173913, 1.75, 0.16666666666667
18639, 1.4173913043478, 1.75, 0.13888888888889
18640, 1.395652173913, 1.75, 0.11111111111111
18641, 1.4173913043478, 1.75, 0.083333333333333
18642, 1.395652173913, 1.75, 0.055555555555556
18643, 1.4173913043478, 1.75, 0.027777777777778
18644, 1.4608695652174, 1.75, 0.47222222222222
18645, 1.4391304347826, 1.75, 0.44444444444444
18646, 1.4608695652174, 1.75, 0.41666666666667
18647, 1.4391304347826, 1.75, 0.38888888888889
18648, 1.4608695652174, 1.75, 0.36111111111111
18649, 1.4391304347826, 1.75, 0.33333333333333
18650, 1.4608695652174, 1.75, 0.30555555555556
18651, 1.4391304347826, 1.75, 0.27777777777778
18652, 1.4608695652174, 1.75, 0.25
18653, 1.4391304347826, 1.75, 0.22222222222222
18654, 1.4608695652174, 1.75, 0.19444444444444
18655, 1.4391304347826, 1.75, 0.16666666666667
18656, 1.4608695652174, 1.75, 0.13888888888889
18657, 1.4391304347826, 1.75, 0.11111111111111
18658, 1.4608695652174, 1.75, 0.083333333333333
18659, 1.4391304347826, 1.75, 0.055555555555556
18660, 1.4608695652174, 1.75, 0.027777777777778
18661, 1.504347826087, 1.75, 0.47222222222222
18662, 1.4826086956522, 1.75, 0.44444444444444
18663, 1.504347826087, 1.75, 0.41666666666667
18664, 1.4826086956522, 1.75, 0.38888888888889
18665, 1.504347826087, 1.75, 0.36111111111111
18666, 1.4826086956522, 1.75, 0.33333333333333
18667, 1.504347826087, 1.75, 0.30555555555556
18668, 1.4826086956522, 1.75, 0.27777777777778
18669, 1.504347826087, 1.75, 0.25
18670, 1.4826086956522, 1.75, 0.22222222222222
18671, 1.504347826087, 1.75, 0.19444444444444
18672, 1.4826086956522, 1.75, 0.16666666666667
18673, 1.504347826087, 1.75, 0.13888888888889
18674, 1.4826086956522, 1.75, 0.11111111111111
18675, 1.504347826087, 1.75, 0.083333333333333
18676, 1.4826086956522, 1.75, 0.055555555555556
18677, 1.504347826087, 1.75, 0.027777777777778
18678, 1.5478260869565, 1.75, 0.47222222222222
18679, 1.5260869565217, 1.75, 0.44444444444444
18680, 1.5478260869565, 1.75, 0.41666666666667
18681, 1.5260869565217, 1.75, 0.38888888888889
18682, 1.5478260869565, 1.75, 0.36111111111111
18683, 1.5260869565217, 1.75, 0.33333333333333
18684, 1.5478260869565, 1.75, 0.30555555555556
18685, 1.5260869565217, 1.75, 0.27777777777778
18686, 1.5478260869565, 1.75, 0.25
18687, 1.5260869565217, 1.75, 0.22222222222222
18688, 1.5478260869565, 1.75, 0.19444444444444
18689, 1.5260869565217, 1.75, 0.16666666666667
18690, 1.5478260869565, 1.75, 0.13888888888889
18691, 1.5260869565217, 1.75, 0.11111111111111
18692, 1.5478260869565, 1.75, 0.083333333333333
18693, 1.5260869565217, 1.75, 0.055555555555556
18694, 1.5478260869565, 1.75, 0.027777777777778
18695, 1.5913043478261, 1.75, 0.47222222222222
18696, 1.5695652173913, 1.75, 0.44444444444444
18697, 1.5913043478261, 1.75, 0.41666666666667
18698, 1.5695652173913, 1.75, 0.38888888888889
18699, 1.5913043478261, 1.75, 0.36111111111111
18700, 1.5695652173913, 1.75, 0.33333333333333
18701, 1.5913043478261, 1.75, 0.30555555555556
18702, 1.5695652173913, 1.75, 0.27777777777778
18703, 1.5913043478261, 1.75, 0.25
18704, 1.5695652173913, 1.75, 0.22222222222222
18705, 1.5913043478261, 1.75, 0.19444444444444
18706, 1.5695652173913, 1.75, 0.16666666666667
18707, 1.5913043478261, 1.75, 0.13888888888889
18708, 1.5695652173913, 1.75, 0.11111111111111
18709, 1.5913043478261, 1.75, 0.083333333333333
18710, 1.5695652173913, 1.75, 0.055555555555556
18711, 1.5913043478261, 1.75, 0.027777777777778
18712, 1.6347826086957, 1.75, 0.47222222222222
18713, 1.6130434782609, 1.75, 0.44444444444444
18714, 1.6347826086957, 1.75, 0.41666666666667
18715, 1.6130434782609, 1.75, 0.38888888888889
18716, 1.6347826086957, 1.75, 0.36111111111111
18717, 1.6130434782609, 1.75, 0.33333333333333
18718, 1.6347826086957, 1.75, 0.30555555555556
18719, 1.6130434782609, 1.75, 0.27777777777778
18720, 1.6347826086957, 1.75, 0.25
18721, 1.6130434782609, 1.75, 0.22222222222222
18722, 1.6347826086957, 1.75, 0.19444444444444
18723, 1.6130434782609, 1.75, 0.16666666666667
18724, 1.6347826086957, 1.75, 0.13888888888889
18725, 1.6130434782609, 1.75, 0.11111111111111
18726, 1.6347826086957, 1.75, 0.083333333333333
18727, 1.6130434782609, 1.75, 0.055555555555556
18728, 1.6347826086957, 1.75, 0.027777777777778
18729, 1.6782608695652, 1.75, 0.47222222222222
18730, 1.6565217391304, 1.75, 0.44444444444444
18731, 1.6782608695652, 1.75, 0.41666666666667
18732, 1.6565217391304, 1.75, 0.38888888888889
18733, 1.6782608695652, 1.75, 0.36111111111111
18734, 1.6565217391304, 1.75, 0.33333333333333
18735, 1.6782608695652, 1.75, 0.30555555555556
18736, 1.6565217391304, 1.75, 0.27777777777778
18737, 1.6782608695652, 1.75, 0.25
18738, 1.6565217391304, 1.75, 0.22222222222222
18739, 1.6782608695652, 1.75, 0.19444444444444
18740, 1.6565217391304, 1.75, 0.16666666666667
18741, 1.6782608695652, 1.75, 0.13888888888889
18742, 1.6565217391304, 1.75, 0.11111111111111
18743, 1.6782608695652, 1.75, 0.083333333333333
18744, 1.6565217391304, 1.75, 0.055555555555556
18745, 1.6782608695652, 1.75, 0.027777777777778
18746, 1.7217391304348, 1.75, 0.47222222222222
18747, 1.7, 1.75, 0.44444444444444
18748, 1.7217391304348, 1.75, 0.41666666666667
18749, 1.7, 1.75, 0.38888888888889
18750, 1.7217391304348, 1.75, 0.36111111111111
18751, 1.7, 1.75, 0.33333333333333
18752, 1.7217391304348, 1.75, 0.30555555555556
18753, 1.7, 1.75, 0.27777777777778
18754, 1.7217391304348, 1.75, 0.25
18755, 1.7, 1.75, 0.22222222222222
18756, 1.7217391304348, 1.75, 0.19444444444444
18757, 1.7, 1.75, 0.16666666666667
18758, 1.7217391304348, 1.75, 0.13888888888889
18759, 1.7, 1.75, 0.11111111111111
18760, 1.7217391304348, 1.75, 0.083333333333333
18761, 1.7, 1.75, 0.055555555555556
18762, 1.7217391304348, 1.75, 0.027777777777778
18763, 1.7652173913043, 1.75, 0.47222222222222
18764, 1.7434782608696, 1.75, 0.44444444444444
18765, 1.7652173913043, 1.75, 0.41666666666667
18766, 1.7434782608696, 1.75, 0.38888888888889
18767, 1.7652173913043, 1.75, 0.36111111111111
18768, 1.7434782608696, 1.75, 0.33333333333333
18769, 1.7652173913043, 1.75, 0.30555555555556
18770, 1.7434782608696, 1.75, 0.27777777777778
18771, 1.7652173913043, 1.75, 0.25
18772, 1.7434782608696, 1.75, 0.22222222222222
18773, 1.7652173913043, 1.75, 0.19444444444444
18774, 1.7434782608696, 1.75, 0.16666666666667
18775, 1.7652173913043, 1.75, 0.13888888888889
18776, 1.7434782608696, 1.75, 0.11111111111111
18777, 1.7652173913043, 1.75, 0.083333333333333
18778, 1.7434782608696, 1.75, 0.055555555555556
18779, 1.7652173913043, 1.75, 0.027777777777778
18780, 1.8086956521739, 1.75, 0.47222222222222
18781, 1.7869565217391, 1.75, 0.44444444444444
18782, 1.8086956521739, 1.75, 0.41666666666667
18783, 1.7869565217391, 1.75, 0.38888888888889
18784, 1.8086956521739, 1.75, 0.36111111111111
18785, 1.7869565217391, 1.75, 0.33333333333333
18786, 1.8086956521739, 1.75, 0.30555555555556
18787, 1.7869565217391, 1.75, 0.27777777777778
18788, 1.8086956521739, 1.75, 0.25
18789, 1.7869565217391, 1.75, 0.22222222222222
18790, 1.8086956521739, 1.75, 0.19444444444444
18791, 1.7869565217391, 1.75, 0.16666666666667
18792, 1.8086956521739, 1.75, 0.13888888888889
18793, 1.7869565217391, 1.75, 0.11111111111111
18794, 1.8086956521739, 1.75, 0.083333333333333
18795, 1.7869565217391, 1.75, 0.055555555555556
18796, 1.8086956521739, 1.75, 0.027777777777778
18797, 1.8521739130435, 1.75, 0.47222222222222
18798, 1.8304347826087, 1.75, 0.44444444444444
18799, 1.8521739130435, 1.75, 0.41666666666667
18800, 1.8304347826087, 1.75, 0.38888888888889
18801, 1.8521739130435, 1.75, 0.36111111111111
18802, 1.8304347826087, 1.75, 0.33333333333333
18803, 1.8521739130435, 1.75, 0.30555555555556
18804, 1.8304347826087, 1.75, 0.27777777777778
18805, 1.8521739130435, 1.75, 0.25
18806, 1.8304347826087, 1.75, 0.22222222222222
18807, 1.8521739130435, 1.75, 0.19444444444444
18808, 1.8304347826087, 1.75, 0.16666666666667
18809, 1.8521739130435, 1.75, 0.13888888888889
18810, 1.8304347826087, 1.75, 0.11111111111111
18811, 1.8521739130435, 1.75, 0.083333333333333
18812, 1.8304347826087, 1.75, 0.055555555555556
18813, 1.8521739130435, 1.75, 0.027777777777778
18814, 1.895652173913, 1.75, 0.47222222222222
18815, 1.8739130434783, 1.75, 0.44444444444444
18816, 1.895652173913, 1.75, 0.41666666666667
18817, 1.8739130434783, 1.75, 0.38888888888889
18818, 1.895652173913, 1.75, 0.36111111111111
18819, 1.8739130434783, 1.75, 0.33333333333333
18820, 1.895652173913, 1.75, 0.30555555555556
18821, 1.8739130434783, 1.75, 0.27777777777778
18822, 1.895652173913, 1.75, 0.25
18823, 1.8739130434783, 1.75, 0.22222222222222
18824, 1.895652173913, 1.75, 0.19444444444444
18825, 1.8739130434783, 1.75, 0.16666666666667
18826, 1.895652173913, 1.75, 0.13888888888889
18827, 1.8739130434783, 1.75, 0.11111111111111
18828, 1.895652173913, 1.75, 0.083333333333333
18829, 1.8739130434783, 1.75, 0.055555555555556
18830, 1.895652173913, 1.75, 0.027777777777778
18831, 1.9391304347826, 1.75, 0.47222222222222
18832, 1.9173913043478, 1.75, 0.44444444444444
18833, 1.9391304347826, 1.75, 0.41666666666667
18834, 1.9173913043478, 1.75, 0.38888888888889
18835, 1.9391304347826, 1.75, 0.36111111111111
18836, 1.9173913043478, 1.75, 0.33333333333333
18837, 1.9391304347826, 1.75, 0.30555555555556
18838, 1.9173913043478, 1.75, 0.27777777777778
18839, 1.9391304347826, 1.75, 0.25
18840, 1.9173913043478, 1.75, 0.22222222222222
18841, 1.9391304347826, 1.75, 0.19444444444444
18842, 1.9173913043478, 1.75, 0.16666666666667
18843, 1.9391304347826, 1.75, 0.13888888888889
18844, 1.9173913043478, 1.75, 0.11111111111111
18845, 1.9391304347826, 1.75, 0.083333333333333
18846, 1.9173913043478, 1.75, 0.055555555555556
18847, 1.9391304347826, 1.75, 0.027777777777778
18848, 1.9826086956522, 1.75, 0.47222222222222
18849, 1.9608695652174, 1.75, 0.44444444444444
18850, 1.9826086956522, 1.75, 0.41666666666667
18851, 1.9608695652174, 1.75, 0.38888888888889
18852, 1.9826086956522, 1.75, 0.36111111111111
18853, 1.9608695652174, 1.75, 0.33333333333333
18854, 1.9826086956522, 1.75, 0.30555555555556
18855, 1.9608695652174, 1.75, 0.27777777777778
18856, 1.9826086956522, 1.75, 0.25
18857, 1.9608695652174, 1.75, 0.22222222222222
18858, 1.9826086956522, 1.75, 0.19444444444444
18859, 1.9608695652174, 1.75, 0.16666666666667
18860, 1.9826086956522, 1.75, 0.13888888888889
18861, 1.9608695652174, 1.75, 0.11111111111111
18862, 1.9826086956522, 1.75, 0.083333333333333
18863, 1.9608695652174, 1.75, 0.055555555555556
18864, 1.9826086956522, 1.75, 0.027777777777778
18865, 2.0260869565217, 1.75, 0.47222222222222
18866, 2.004347826087, 1.75, 0.44444444444444
18867, 2.0260869565217, 1.75, 0.41666666666667
18868, 2.004347826087, 1.75, 0.38888888888889
18869, 2.0260869565217, 1.75, 0.36111111111111
18870, 2.004347826087, 1.75, 0.33333333333333
18871, 2.0260869565217, 1.75, 0.30555555555556
18872, 2.004347826087, 1.75, 0.27777777777778
18873, 2.0260869565217, 1.75, 0.25
18874, 2.004347826087, 1.75, 0.22222222222222
18875, 2.0260869565217, 1.75, 0.19444444444444
18876, 2.004347826087, 1.75, 0.16666666666667
18877, 2.0260869565217, 1.75, 0.13888888888889
18878, 2.004347826087, 1.75, 0.11111111111111
18879, 2.0260869565217, 1.75, 0.083333333333333
18880, 2.004347826087, 1.75, 0.055555555555556
18881, 2.0260869565217, 1.75, 0.027777777777778
18882, 2.0695652173913, 1.75, 0.47222222222222
18883, 2.0478260869565, 1.75, 0.44444444444444
18884, 2.0695652173913, 1.75, 0.41666666666667
18885, 2.0478260869565, 1.75, 0.38888888888889
18886, 2.0695652173913, 1.75, 0.36111111111111
18887, 2.0478260869565, 1.75, 0.33333333333333
18888, 2.0695652173913, 1.75, 0.30555555555556
18889, 2.0478260869565, 1.75, 0.27777777777778
18890, 2.0695652173913, 1.75, 0.25
18891, 2.0478260869565, 1.75, 0.22222222222222
18892, 2.0695652173913, 1.75, 0.19444444444444
18893, 2.0478260869565, 1.75, 0.16666666666667
18894, 2.0695652173913, 1.75, 0.13888888888889
18895, 2.0478260869565, 1.75, 0.11111111111111
18896, 2.0695652173913, 1.75, 0.083333333333333
18897, 2.0478260869565, 1.75, 0.055555555555556
18898, 2.0695652173913, 1.75, 0.027777777777778
18899, 2.1130434782609, 1.75, 0.47222222222222
18900, 2.0913043478261, 1.75, 0.44444444444444
18901, 2.1130434782609, 1.75, 0.41666666666667
18902, 2.0913043478261, 1.75, 0.38888888888889
18903, 2.1130434782609, 1.75, 0.36111111111111
18904, 2.0913043478261, 1.75, 0.33333333333333
18905, 2.1130434782609, 1.75, 0.30555555555556
18906, 2.0913043478261, 1.75, 0.27777777777778
18907, 2.1130434782609, 1.75, 0.25
18908, 2.0913043478261, 1.75, 0.22222222222222
18909, 2.1130434782609, 1.75, 0.19444444444444
18910, 2.0913043478261, 1.75, 0.16666666666667
18911, 2.1130434782609, 1.75, 0.13888888888889
18912, 2.0913043478261, 1.75, 0.11111111111111
18913, 2.1130434782609, 1.75, 0.083333333333333
18914, 2.0913043478261, 1.75, 0.055555555555556
18915, 2.1130434782609, 1.75, 0.027777777777778
18916, 2.1565217391304, 1.75, 0.47222222222222
18917, 2.1347826086957, 1.75, 0.44444444444444
18918, 2.1565217391304, 1.75, 0.41666666666667
18919, 2.1347826086957, 1.75, 0.38888888888889
18920, 2.1565217391304, 1.75, 0.36111111111111
18921, 2.1347826086957, 1.75, 0.33333333333333
18922, 2.1565217391304, 1.75, 0.30555555555556
18923, 2.1347826086957, 1.75, 0.27777777777778
18924, 2.1565217391304, 1.75, 0.25
18925, 2.1347826086957, 1.75, 0.22222222222222
18926, 2.1565217391304, 1.75, 0.19444444444444
18927, 2.1347826086957, 1.75, 0.16666666666667
18928, 2.1565217391304, 1.75, 0.13888888888889
18929, 2.1347826086957, 1.75, 0.11111111111111
18930, 2.1565217391304, 1.75, 0.083333333333333
18931, 2.1347826086957, 1.75, 0.055555555555556
18932, 2.1565217391304, 1.75, 0.027777777777778
18933, 2.1782608695652, 1.75, 0.44444444444444
18934, 2.1782608695652, 1.75, 0.38888888888889
18935, 2.1782608695652, 1.75, 0.33333333333333
18936, 2.1782608695652, 1.75, 0.27777777777778
18937, 2.1782608695652, 1.75, 0.22222222222222
18938, 2.1782608695652, 1.75, 0.16666666666667
18939, 2.1782608695652, 1.75, 0.11111111111111
18940, 2.1782608695652, 1.75, 0.055555555555556
18941, 2.25, 1.6, 0.5
18942, 2.25, 1.65, 0.5
18943, 2.25, 1.7, 0.5
18944, 2.25, 1.575, 0.5
18945, 2.225, 1.6, 0.5
18946, 2.25, 1.625, 0.5
18947, 2.225, 1.65, 0.5
18948, 2.25, 1.675, 0.5
18949, 2.225, 1.7, 0.5
18950, 2.25, 1.725, 0.5
18951, 2.275, 1.6, 0.5
18952, 2.275, 1.65, 0.5
18953, 2.275, 1.7, 0.5
18954, 2.25, 1.6, 0
18955, 2.25, 1.65, 0
18956, 2.25, 1.7, 0
18957, 2.225, 1.6, 0
18958, 2.25, 1.575, 0
18959, 2.225, 1.65, 0
18960, 2.25, 1.625, 0
18961, 2.225, 1.7, 0
18962, 2.25, 1.675, 0
18963, 2.25, 1.725, 0
18964, 2.275, 1.6, 0
18965, 2.275, 1.65, 0
18966, 2.275, 1.7, 0
18967, 2.25, 1.55, 0.44444444444444
18968, 2.25, 1.55, 0.38888888888889
18969, 2.25, 1.55, 0.33333333333333
18970, 2.25, 1.55, 0.27777777777778
18971, 2.25, 1.55, 0.22222222222222
18972, 2.25, 1.55, 0.16666666666667
18973, 2.25, 1.55, 0.11111111111111
18974, 2.25, 1.55, 0.055555555555556
18975, 2.225, 1.55, 0.44444444444444
18976, 2.25, 1.55, 0.47222222222222
18977, 2.225, 1.55, 0.38888888888889
18978, 2.25, 1.55, 0.41666666666667
18979, 2.225, 1.55, 0.33333333333333
18980, 2.25, 1.55, 0.36111111111111
18981, 2.225, 1.55, 0.27777777777778
18982, 2.25, 1.55, 0.30555555555556
18983, 2.225, 1.55, 0.22222222222222
18984, 2.25, 1.55, 0.25
18985, 2.225, 1.55, 0.16666666666667
18986, 2.25, 1.55, 0.19444444444444
18987, 2.225, 1.55, 0.11111111111111
18988, 2.25, 1.55, 0.13888888888889
18989, 2.225, 1.55, 0.055555555555556
18990, 2.25, 1.55, 0.083333333333333
18991, 2.25, 1.55, 0.027777777777778
18992, 2.275, 1.55, 0.44444444444444
18993, 2.275, 1.55, 0.38888888888889
18994, 2.275, 1.55, 0.33333333333333
18995, 2.275, 1.55, 0.27777777777778
18996, 2.275, 1.55, 0.22222222222222
18997, 2.275, 1.55, 0.16666666666667
18998, 2.275, 1.55, 0.11111111111111
18999, 2.275, 1.55, 0.055555555555556
19000, 2.25, 1.75, 0.44444444444444
19001, 2.25, 1.75, 0.38888888888889
19002, 2.25, 1.75, 0.33333333333333
19003, 2.25, 1.75, 0.27777777777778
19004, 2.25, 1.75, 0.22222222222222
19005, 2.25, 1.75, 0.16666666666667
19006, 2.25, 1.75, 0.11111111111111
19007, 2.25, 1.75, 0.055555555555556
19008, 2.25, 1.75, 0.47222222222222
19009, 2.225, 1.75, 0.44444444444444
19010, 2.25, 1.75, 0.41666666666667
19011, 2.225, 1.75, 0.38888888888889
19012, 2.25, 1.75, 0.36111111111111
19013, 2.225, 1.75, 0.33333333333333
19014, 2.25, 1.75, 0.30555555555556
19015, 2.225, 1.75, 0.27777777777778
19016, 2.25, 1.75, 0.25
19017, 2.225, 1.75, 0.22222222222222
19018, 2.25, 1.75, 0.19444444444444
19019, 2.225, 1.75, 0.16666666666667
19020, 2.25, 1.75, 0.13888888888889
19021, 2.225, 1.75, 0.11111111111111
19022, 2.25, 1.75, 0.083333333333333
19023, 2.225, 1.75, 0.055555555555556
19024, 2.25, 1.75, 0.027777777777778
19025, 2.275, 1.75, 0.44444444444444
19026, 2.275, 1.75, 0.38888888888889
19027, 2.275, 1.75, 0.33333333333333
19028, 2.275, 1.75, 0.27777777777778
19029, 2.275, 1.75, 0.22222222222222
19030, 2.275, 1.75, 0.16666666666667
19031, 2.275, 1.75, 0.11111111111111
19032, 2.275, 1.75, 0.055555555555556
19033, 2.3, 1.6, 0.44444444444444
19034, 2.3, 1.6, 0.38888888888889
19035, 2.3, 1.6, 0.33333333333333
19036, 2.3, 1.6, 0.27777777777778
19037, 2.3, 1.6, 0.22222222222222
19038, 2.3, 1.6, 0.16666666666667
19039, 2.3, 1.6, 0.11111111111111
19040, 2.3, 1.6, 0.055555555555556
19041, 2.3, 1.65, 0.44444444444444
19042, 2.3, 1.65, 0.38888888888889
19043, 2.3, 1.65, 0.33333333333333
19044, 2.3, 1.65, 0.27777777777778
19045, 2.3, 1.65, 0.22222222222222
19046, 2.3, 1.65, 0.16666666666667
19047, 2.3, 1.65, 0.11111111111111
19048, 2.3, 1.65, 0.055555555555556
19049, 2.3, 1.7, 0.44444444444444
19050, 2.3, 1.7, 0.38888888888889
19051, 2.3, 1.7, 0.33333333333333
19052, 2.3, 1.7, 0.27777777777778
19053, 2.3, 1.7, 0.22222222222222
19054, 2.3, 1.7, 0.16666666666667
19055, 2.3, 1.7, 0.11111111111111
19056, 2.3, 1.7, 0.055555555555556
19057, 2.3, 1.575, 0.44444444444444
19058, 2.3, 1.6, 0.47222222222222
19059, 2.3, 1.575, 0.38888888888889
19060, 2.3, 1.6, 0.41666666666667
19061, 2.3, 1.575, 0.33333333333333
19062, 2.3, 1.6, 0.36111111111111
19063, 2.3, 1.575, 0.27777777777778
19064, 2.3, 1.6, 0.30555555555556
19065, 2.3, 1.575, 0.22222222222222
19066, 2.3, 1.6, 0.25
19067, 2.3, 1.575, 0.16666666666667
19068, 2.3, 1.6, 0.19444444444444
19069, 2.3, 1.575, 0.11111111111111
19070, 2.3, 1.6, 0.13888888888889
19071, 2.3, 1.575, 0.055555555555556
19072, 2.3, 1.6, 0.083333333333333
19073, 2.3, 1.6, 0.027777777777778
19074, 2.3, 1.625, 0.44444444444444
19075, 2.3, 1.65, 0.47222222222222
19076, 2.3, 1.625, 0.38888888888889
19077, 2.3, 1.65, 0.41666666666667
19078, 2.3, 1.625, 0.33333333333333
19079, 2.3, 1.65, 0.36111111111111
19080, 2.3, 1.625, 0.27777777777778
19081, 2.3, 1.65, 0.30555555555556
19082, 2.3, 1.625, 0.22222222222222
19083, 2.3, 1.65, 0.25
19084, 2.3, 1.625, 0.16666666666667
19085, 2.3, 1.65, 0.19444444444444
19086, 2.3, 1.625, 0.11111111111111
19087, 2.3, 1.65, 0.13888888888889
19088, 2.3, 1.625, 0.055555555555556
19089, 2.3, 1.65, 0.083333333333333
19090, 2.3, 1.65, 0.027777777777778
19091, 2.3, 1.675, 0.44444444444444
19092, 2.3, 1.7, 0.47222222222222
19093, 2.3, 1.675, 0.38888888888889
19094, 2.3, 1.7, 0.41666666666667
19095, 2.3, 1.675, 0.33333333333333
19096, 2.3, 1.7, 0.36111111111111
19097, 2.3, 1.675, 0.27777777777778
19098, 2.3, 1.7, 0.30555555555556
19099, 2.3, 1.675, 0.22222222222222
19100, 2.3, 1.7, 0.25
19101, 2.3, 1.675, 0.16666666666667
19102, 2.3, 1.7, 0.19444444444444
19103, 2.3, 1.675, 0.11111111111111
19104, 2.3, 1.7, 0.13888888888889
19105, 2.3, 1.675, 0.055555555555556
19106, 2.3, 1.7, 0.083333333333333
19107, 2.3, 1.7, 0.027777777777778
19108, 2.3, 1.725, 0.44444444444444
19109, 2.3, 1.725, 0.38888888888889
19110, 2.3, 1.725, 0.33333333333333
19111, 2.3, 1.725, 0.27777777777778
19112, 2.3, 1.725, 0.22222222222222
19113, 2.3, 1.725, 0.16666666666667
19114, 2.3, 1.725, 0.11111111111111
19115, 2.3, 1.725, 0.055555555555556
19116, 0.95652173913043, 0.125, 0
19117, 0.91304347826087, 0.125, 0
19118, 0.8695652173913, 0.125, 0
19119, 0.82608695652174, 0.125, 0
19120, 0.78260869565217, 0.125, 0
19121, 0.73913043478261, 0.125, 0
19122, 0.69565217391304, 0.125, 0
19123, 0.65217391304348, 0.125, 0
19124, 0.60869565217391, 0.125, 0
19125, 0.56521739130435, 0.125, 0
19126, 0.52173913043478, 0.125, 0
19127, 0.47826086956522, 0.125, 0
19128, 0.43478260869565, 0.125, 0
19129, 0.39130434782609, 0.125, 0
19130, 0.34782608695652, 0.125, 0
19131, 0.30434782608696, 0.125, 0
19132, 0.26086956521739, 0.125, 0
19133, 0.21739130434783, 0.125, 0
19134, 0.17391304347826, 0.125, 0
19135, 0.1304347826087, 0.125, 0
19136, 0.08695652173913, 0.125, 0
19137, 0.043478260869565, 0.125, 0
19138, 0.95652173913043, 0.1125, 0
19139, 0.97826086956522, 0.125, 0
19140, 0.91304347826087, 0.1125, 0
19141, 0.93478260869565, 0.125, 0
19142, 0.8695652173913, 0.1125, 0
19143, 0.89130434782609, 0.125, 0
19144, 0.82608695652174, 0.1125, 0
19145, 0.84782608695652, 0.125, 0
19146, 0.78260869565217, 0.1125, 0
19147, 0.80434782608696, 0.125, 0
19148, 0.73913043478261, 0.1125, 0
19149, 0.76086956521739, 0.125, 0
19150, 0.69565217391304, 0.1125, 0
19151, 0.71739130434783, 0.125, 0
19152, 0.65217391304348, 0.1125, 0
19153, 0.67391304347826, 0.125, 0
19154, 0.60869565217391, 0.1125, 0
19155, 0.6304347826087, 0.125, 0
19156, 0.56521739130435, 0.1125, 0
19157, 0.58695652173913, 0.125, 0
19158, 0.52173913043478, 0.1125, 0
19159, 0.54347826086957, 0.125, 0
19160, 0.47826086956522, 0.1125, 0
19161, 0.5, 0.125, 0
19162, 0.43478260869565, 0.1125, 0
19163, 0.45652173913043, 0.125, 0
19164, 0.39130434782609, 0.1125, 0
19165, 0.41304347826087, 0.125, 0
19166, 0.34782608695652, 0.1125, 0
19167, 0.3695652173913, 0.125, 0
19168, 0.30434782608696, 0.1125, 0
19169, 0.32608695652174, 0.125, 0
19170, 0.26086956521739, 0.1125, 0
19171, 0.28260869565217, 0.125, 0
19172, 0.21739130434783, 0.1125, 0
19173, 0.23913043478261, 0.125, 0
19174, 0.17391304347826, 0.1125, 0
19175, 0.19565217391304, 0.125, 0
19176, 0.1304347826087, 0.1125, 0
19177, 0.15217391304348, 0.125, 0
19178, 0.08695652173913, 0.1125, 0
19179, 0.10869565217391, 0.125, 0
19180, 0.043478260869565, 0.1125, 0
19181, 0.065217391304348, 0.125, 0
19182, 0.021739130434783, 0.125, 0
19183, 0.95652173913043, 0.1375, 0
19184, 0.91304347826087, 0.1375, 0
19185, 0.8695652173913, 0.1375, 0
19186, 0.82608695652174, 0.1375, 0
19187, 0.78260869565217, 0.1375, 0
19188, 0.73913043478261, 0.1375, 0
19189, 0.69565217391304, 0.1375, 0
19190, 0.65217391304348, 0.1375, 0
19191, 0.60869565217391, 0.1375, 0
19192, 0.56521739130435, 0.1375, 0
19193, 0.52173913043478, 0.1375, 0
19194, 0.47826086956522, 0.1375, 0
19195, 0.43478260869565, 0.1375, 0
19196, 0.39130434782609, 0.1375, 0
19197, 0.34782608695652, 0.1375, 0
19198, 0.30434782608696, 0.1375, 0
19199, 0.26086956521739, 0.1375, 0
19200, 0.21739130434783, 0.1375, 0
19201, 0.17391304347826, 0.1375, 0
19202, 0.1304347826087, 0.1375, 0
19203, 0.08695652173913, 0.1375, 0
19204, 0.043478260869565, 0.1375, 0
19205, 1, 0.125, 0.44444444444444
19206, 1, 0.125, 0.38888888888889
19207, 1, 0.125, 0.33333333333333
19208, 1, 0.125, 0.27777777777778
19209, 1, 0.125, 0.22222222222222
19210, 1, 0.125, 0.16666666666667
19211, 1, 0.125, 0.11111111111111
19212, 1, 0.125, 0.055555555555556
19213, 1, 0.1125, 0.44444444444444
19214, 1, 0.125, 0.47222222222222
19215, 1, 0.1125, 0.38888888888889
19216, 1, 0.125, 0.41666666666667
19217, 1, 0.1125, 0.33333333333333
19218, 1, 0.125, 0.36111111111111
19219, 1, 0.1125, 0.27777777777778
19220, 1, 0.125, 0.30555555555556
19221, 1, 0.1125, 0.22222222222222
19222, 1, 0.125, 0.25
19223, 1, 0.1125, 0.16666666666667
19224, 1, 0.125, 0.19444444444444
19225, 1, 0.1125, 0.11111111111111
19226, 1, 0.125, 0.13888888888889
19227, 1, 0.1125, 0.055555555555556
19228, 1, 0.125, 0.083333333333333
19229, 1, 0.125, 0.027777777777778
19230, 1, 0.1375, 0.44444444444444
19231, 1, 0.1375, 0.38888888888889
19232, 1, 0.1375, 0.33333333333333
19233, 1, 0.1375, 0.27777777777778
19234, 1, 0.1375, 0.22222222222222
19235, 1, 0.1375, 0.16666666666667
19236, 1, 0.1375, 0.11111111111111
19237, 1, 0.1375, 0.055555555555556
19238, 0.95652173913043, 0.125, 0.5
19239, 0.91304347826087, 0.125, 0.5
19240, 0.8695652173913, 0.125, 0.5
19241, 0.82608695652174, 0.125, 0.5
19242, 0.78260869565217, 0.125, 0.5
19243, 0.73913043478261, 0.125, 0.5
19244, 0.69565217391304, 0.125, 0.5
19245, 0.65217391304348, 0.125, 0.5
19246, 0.60869565217391, 0.125, 0.5
19247, 0.56521739130435, 0.125, 0.5
19248, 0.52173913043478, 0.125, 0.5
19249, 0.47826086956522, 0.125, 0.5
19250, 0.43478260869565, 0.125, 0.5
19251, 0.39130434782609, 0.125, 0.5
19252, 0.34782608695652, 0.125, 0.5
19253, 0.30434782608696, 0.125, 0.5
19254, 0.26086956521739, 0.125, 0.5
19255, 0.21739130434783, 0.125, 0.5
19256, 0.17391304347826, 0.125, 0.5
19257, 0.1304347826087, 0.125, 0.5
19258, 0.08695652173913, 0.125, 0.5
19259, 0.043478260869565, 0.125, 0.5
19260, 0.97826086956522, 0.125, 0.5
19261, 0.95652173913043, 0.1125, 0.5
19262, 0.93478260869565, 0.125, 0.5
19263, 0.91304347826087, 0.1125, 0.5
19264, 0.89130434782609, 0.125, 0.5
19265, 0.8695652173913, 0.1125, 0.5
19266, 0.84782608695652, 0.125, 0.5
19267, 0.82608695652174, 0.1125, 0.5
19268, 0.80434782608696, 0.125, 0.5
19269, 0.78260869565217, 0.1125, 0.5
19270, 0.76086956521739, 0.125, 0.5
19271, 0.73913043478261, 0.1125, 0.5
19272, 0.71739130434783, 0.125, 0.5
19273, 0.69565217391304, 0.1125, 0.5
19274, 0.67391304347826, 0.125, 0.5
19275, 0.65217391304348, 0.1125, 0.5
19276, 0.6304347826087, 0.125, 0.5
19277, 0.60869565217391, 0.1125, 0.5
19278, 0.58695652173913, 0.125, 0.5
19279, 0.56521739130435, 0.1125, 0.5
19280, 0.54347826086957, 0.125, 0.5
19281, 0.52173913043478, 0.1125, 0.5
19282, 0.5, 0.125, 0.5
19283, 0.47826086956522, 0.1125, 0.5
19284, 0.45652173913043, 0.125, 0.5
19285, 0.43478260869565, 0.1125, 0.5
19286, 0.41304347826087, 0.125, 0.5
19287, 0.39130434782609, 0.1125, 0.5
19288, 0.3695652173913, 0.125, 0.5
19289, 0.34782608695652, 0.1125, 0.5
19290, 0.32608695652174, 0.125, 0.5
19291, 0.30434782608696, 0.1125, 0.5
19292, 0.28260869565217, 0.125, 0.5
19293, 0.26086956521739, 0.1125, 0.5
19294, 0.23913043478261, 0.125, 0.5
19295, 0.21739130434783, 0.1125, 0.5
19296, 0.19565217391304, 0.125, 0.5
19297, 0.17391304347826, 0.1125, 0.5
19298, 0.15217391304348, 0.125, 0.5
19299, 0.1304347826087, 0.1125, 0.5
19300, 0.10869565217391, 0.125, 0.5
19301, 0.08695652173913, 0.1125, 0.5
19302, 0.065217391304348, 0.125, 0.5
19303, 0.043478260869565, 0.1125, 0.5
19304, 0.021739130434783, 0.125, 0.5
19305, 0.95652173913043, 0.1375, 0.5
19306, 0.91304347826087, 0.1375, 0.5
19307, 0.8695652173913, 0.1375, 0.5
19308, 0.82608695652174, 0.1375, 0.5
19309, 0.78260869565217, 0.1375, 0.5
19310, 0.73913043478261, 0.1375, 0.5
19311, 0.69565217391304, 0.1375, 0.5
19312, 0.65217391304348, 0.1375, 0.5
19313, 0.60869565217391, 0.1375, 0.5
19314, 0.56521739130435, 0.1375, 0.5
19315, 0.52173913043478, 0.1375, 0.5
19316, 0.47826086956522, 0.1375, 0.5
19317, 0.43478260869565, 0.1375, 0.5
19318, 0.39130434782609, 0.1375, 0.5
19319, 0.34782608695652, 0.1375, 0.5
19320, 0.30434782608696, 0.1375, 0.5
19321, 0.26086956521739, 0.1375, 0.5
19322, 0.21739130434783, 0.1375, 0.5
19323, 0.17391304347826, 0.1375, 0.5
19324, 0.1304347826087, 0.1375, 0.5
19325, 0.08695652173913, 0.1375, 0.5
19326, 0.043478260869565, 0.1375, 0.5
19327, 0, 0.125, 0.44444444444444
19328, 0, 0.125, 0.38888888888889
19329, 0, 0.125, 0.33333333333333
19330, 0, 0.125, 0.27777777777778
19331, 0, 0.125, 0.22222222222222
19332, 0, 0.125, 0.16666666666667
19333, 0, 0.125, 0.11111111111111
19334, 0, 0.125, 0.055555555555556
19335, 0, 0.125, 0.47222222222222
19336, 0, 0.1125, 0.44444444444444
19337, 0, 0.125, 0.41666666666667
19338, 0, 0.1125, 0.38888888888889
19339, 0, 0.125, 0.36111111111111
19340, 0, 0.1125, 0.33333333333333
19341, 0, 0.125, 0.30555555555556
19342, 0, 0.1125, 0.27777777777778
19343, 0, 0.125, 0.25
19344, 0, 0.1125, 0.22222222222222
19345, 0, 0.125, 0.19444444444444
19346, 0, 0.1125, 0.16666666666667
19347, 0, 0.125, 0.13888888888889
19348, 0, 0.1125, 0.11111111111111
19349, 0, 0.125, 0.083333333333333
19350, 0, 0.1125, 0.055555555555556
19351, 0, 0.125, 0.027777777777778
19352, 0, 0.1375, 0.44444444444444
19353, 0, 0.1375, 0.38888888888889
19354, 0, 0.1375, 0.33333333333333
19355, 0, 0.1375, 0.27777777777778
19356, 0, 0.1375, 0.22222222222222
19357, 0, 0.1375, 0.16666666666667
19358, 0, 0.1375, 0.11111111111111
19359, 0, 0.1375, 0.055555555555556
19360, 0.043478260869565, 0.1, 0.055555555555556
19361, 0.043478260869565, 0.1, 0.11111111111111
19362, 0.043478260869565, 0.1, 0.16666666666667
19363, 0.043478260869565, 0.1, 0.22222222222222
19364, 0.043478260869565, 0.1, 0.27777777777778
19365, 0.043478260869565, 0.1, 0.33333333333333
19366, 0.043478260869565, 0.1, 0.38888888888889
19367, 0.043478260869565, 0.1, 0.44444444444444
19368, 0.08695652173913, 0.1, 0.055555555555556
19369, 0.08695652173913, 0.1, 0.11111111111111
19370, 0.08695652173913, 0.1, 0.16666666666667
19371, 0.08695652173913, 0.1, 0.22222222222222
19372, 0.08695652173913, 0.1, 0.27777777777778
19373, 0.08695652173913, 0.1, 0.33333333333333
19374, 0.08695652173913, 0.1, 0.38888888888889
19375, 0.08695652173913, 0.1, 0.44444444444444
19376, 0.1304347826087, 0.1, 0.055555555555556
19377, 0.1304347826087, 0.1, 0.11111111111111
19378, 0.1304347826087, 0.1, 0.16666666666667
19379, 0.1304347826087, 0.1, 0.22222222222222
19380, 0.1304347826087, 0.1, 0.27777777777778
19381, 0.1304347826087, 0.1, 0.33333333333333
19382, 0.1304347826087, 0.1, 0.38888888888889
19383, 0.1304347826087, 0.1, 0.44444444444444
19384, 0.17391304347826, 0.1, 0.055555555555556
19385, 0.17391304347826, 0.1, 0.11111111111111
19386, 0.17391304347826, 0.1, 0.16666666666667
19387, 0.17391304347826, 0.1, 0.22222222222222
19388, 0.17391304347826, 0.1, 0.27777777777778
19389, 0.17391304347826, 0.1, 0.33333333333333
19390, 0.17391304347826, 0.1, 0.38888888888889
19391, 0.17391304347826, 0.1, 0.44444444444444
19392, 0.21739130434783, 0.1, 0.055555555555556
19393, 0.21739130434783, 0.1, 0.11111111111111
19394, 0.21739130434783, 0.1, 0.16666666666667
19395, 0.21739130434783, 0.1, 0.22222222222222
19396, 0.21739130434783, 0.1, 0.27777777777778
19397, 0.21739130434783, 0.1, 0.33333333333333
19398, 0.21739130434783, 0.1, 0.38888888888889
19399, 0.21739130434783, 0.1, 0.44444444444444
19400, 0.26086956521739, 0.1, 0.055555555555556
19401, 0.26086956521739, 0.1, 0.11111111111111
19402, 0.26086956521739, 0.1, 0.16666666666667
19403, 0.26086956521739, 0.1, 0.22222222222222
19404, 0.26086956521739, 0.1, 0.27777777777778
19405, 0.26086956521739, 0.1, 0.33333333333333
19406, 0.26086956521739, 0.1, 0.38888888888889
19407, 0.26086956521739, 0.1, 0.44444444444444
19408, 0.30434782608696, 0.1, 0.055555555555556
19409, 0.30434782608696, 0.1, 0.11111111111111
19410, 0.30434782608696, 0.1, 0.16666666666667
19411, 0.30434782608696, 0.1, 0.22222222222222
19412, 0.30434782608696, 0.1, 0.27777777777778
19413, 0.30434782608696, 0.1, 0.33333333333333
19414, 0.30434782608696, 0.1, 0.38888888888889
19415, 0.30434782608696, 0.1, 0.44444444444444
19416, 0.34782608695652, 0.1, 0.055555555555556
19417, 0.34782608695652, 0.1, 0.11111111111111
19418, 0.34782608695652, 0.1, 0.16666666666667
19419, 0.34782608695652, 0.1, 0.22222222222222
19420, 0.34782608695652, 0.1, 0.27777777777778
19421, 0.34782608695652, 0.1, 0.33333333333333
19422, 0.34782608695652, 0.1, 0.38888888888889
19423, 0.34782608695652, 0.1, 0.44444444444444
19424, 0.39130434782609, 0.1, 0.055555555555556
19425, 0.39130434782609, 0.1, 0.11111111111111
19426, 0.39130434782609, 0.1, 0.16666666666667
19427, 0.39130434782609, 0.1, 0.22222222222222
19428, 0.39130434782609, 0.1, 0.27777777777778
19429, 0.39130434782609, 0.1, 0.33333333333333
19430, 0.39130434782609, 0.1, 0.38888888888889
19431, 0.39130434782609, 0.1, 0.44444444444444
19432, 0.43478260869565, 0.1, 0.055555555555556
19433, 0.43478260869565, 0.1, 0.11111111111111
19434, 0.43478260869565, 0.1, 0.16666666666667
19435, 0.43478260869565, 0.1, 0.22222222222222
19436, 0.43478260869565, 0.1, 0.27777777777778
19437, 0.43478260869565, 0.1, 0.33333333333333
19438, 0.43478260869565, 0.1, 0.38888888888889
19439, 0.43478260869565, 0.1, 0.44444444444444
19440, 0.47826086956522, 0.1, 0.055555555555556
19441, 0.47826086956522, 0.1, 0.11111111111111
19442, 0.47826086956522, 0.1, 0.16666666666667
19443, 0.47826086956522, 0.1, 0.22222222222222
19444, 0.47826086956522, 0.1, 0.27777777777778
19445, 0.47826086956522, 0.1, 0.33333333333333
19446, 0.47826086956522, 0.1, 0.38888888888889
19447, 0.47826086956522, 0.1, 0.44444444444444
19448, 0.52173913043478, 0.1, 0.055555555555556
19449, 0.52173913043478, 0.1, 0.11111111111111
19450, 0.52173913043478, 0.1, 0.16666666666667
19451, 0.52173913043478, 0.1, 0.22222222222222
19452, 0.52173913043478, 0.1, 0.27777777777778
19453, 0.52173913043478, 0.1, 0.33333333333333
19454, 0.52173913043478, 0.1, 0.38888888888889
19455, 0.52173913043478, 0.1, 0.44444444444444
19456, 0.56521739130435, 0.1, 0.055555555555556
19457, 0.56521739130435, 0.1, 0.11111111111111
19458, 0.56521739130435, 0.1, 0.16666666666667
19459, 0.56521739130435, 0.1, 0.22222222222222
19460, 0.56521739130435, 0.1, 0.27777777777778
19461, 0.56521739130435, 0.1, 0.33333333333333
19462, 0.56521739130435, 0.1, 0.38888888888889
19463, 0.56521739130435, 0.1, 0.44444444444444
19464, 0.60869565217391, 0.1, 0.055555555555556
19465, 0.60869565217391, 0.1, 0.11111111111111
19466, 0.60869565217391, 0.1, 0.16666666666667
19467, 0.60869565217391, 0.1, 0.22222222222222
19468, 0.60869565217391, 0.1, 0.27777777777778
19469, 0.60869565217391, 0.1, 0.33333333333333
19470, 0.60869565217391, 0.1, 0.38888888888889
19471, 0.60869565217391, 0.1, 0.44444444444444
19472, 0.65217391304348, 0.1, 0.055555555555556
19473, 0.65217391304348, 0.1, 0.11111111111111
19474, 0.65217391304348, 0.1, 0.16666666666667
19475, 0.65217391304348, 0.1, 0.22222222222222
19476, 0.65217391304348, 0.1, 0.27777777777778
19477, 0.65217391304348, 0.1, 0.33333333333333
19478, 0.65217391304348, 0.1, 0.38888888888889
19479, 0.65217391304348, 0.1, 0.44444444444444
19480, 0.69565217391304, 0.1, 0.055555555555556
19481, 0.69565217391304, 0.1, 0.11111111111111
19482, 0.69565217391304, 0.1, 0.16666666666667
19483, 0.69565217391304, 0.1, 0.22222222222222
19484, 0.69565217391304, 0.1, 0.27777777777778
19485, 0.69565217391304, 0.1, 0.33333333333333
19486, 0.69565217391304, 0.1, 0.38888888888889
19487, 0.69565217391304, 0.1, 0.44444444444444
19488, 0.73913043478261, 0.1, 0.055555555555556
19489, 0.73913043478261, 0.1, 0.11111111111111
19490, 0.73913043478261, 0.1, 0.16666666666667
19491, 0.73913043478261, 0.1, 0.22222222222222
19492, 0.73913043478261, 0.1, 0.27777777777778
19493, 0.73913043478261, 0.1, 0.33333333333333
19494, 0.73913043478261, 0.1, 0.38888888888889
19495, 0.73913043478261, 0.1, 0.44444444444444
19496, 0.78260869565217, 0.1, 0.055555555555556
19497, 0.78260869565217, 0.1, 0.11111111111111
19498, 0.78260869565217, 0.1, 0.16666666666667
19499, 0.78260869565217, 0.1, 0.22222222222222
19500, 0.78260869565217, 0.1, 0.27777777777778
19501, 0.78260869565217, 0.1, 0.33333333333333
19502, 0.78260869565217, 0.1, 0.38888888888889
19503, 0.78260869565217, 0.1, 0.44444444444444
19504, 0.82608695652174, 0.1, 0.055555555555556
19505, 0.82608695652174, 0.1, 0.11111111111111
19506, 0.82608695652174, 0.1, 0.16666666666667
19507, 0.82608695652174, 0.1, 0.22222222222222
19508, 0.82608695652174, 0.1, 0.27777777777778
19509, 0.82608695652174, 0.1, 0.33333333333333
19510, 0.82608695652174, 0.1, 0.38888888888889
19511, 0.82608695652174, 0.1, 0.44444444444444
19512, 0.8695652173913, 0.1, 0.055555555555556
19513, 0.8695652173913, 0.1, 0.11111111111111
19514, 0.8695652173913, 0.1, 0.16666666666667
19515, 0.8695652173913, 0.1, 0.22222222222222
19516, 0.8695652173913, 0.1, 0.27777777777778
19517, 0.8695652173913, 0.1, 0.33333333333333
19518, 0.8695652173913, 0.1, 0.38888888888889
19519, 0.8695652173913, 0.1, 0.44444444444444
19520, 0.91304347826087, 0.1, 0.055555555555556
19521, 0.91304347826087, 0.1, 0.11111111111111
19522, 0.91304347826087, 0.1, 0.16666666666667
19523, 0.91304347826087, 0.1, 0.22222222222222
19524, 0.91304347826087, 0.1, 0.27777777777778
19525, 0.91304347826087, 0.1, 0.33333333333333
19526, 0.91304347826087, 0.1, 0.38888888888889
19527, 0.91304347826087, 0.1, 0.44444444444444
19528, 0.95652173913043, 0.1, 0.055555555555556
19529, 0.95652173913043, 0.1, 0.11111111111111
19530, 0.95652173913043, 0.1, 0.16666666666667
19531, 0.95652173913043, 0.1, 0.22222222222222
19532, 0.95652173913043, 0.1, 0.27777777777778
19533, 0.95652173913043, 0.1, 0.33333333333333
19534, 0.95652173913043, 0.1, 0.38888888888889
19535, 0.95652173913043, 0.1, 0.44444444444444
19536, 0.043478260869565, 0.1, 0.027777777777778
19537, 0.021739130434783, 0.1, 0.055555555555556
19538, 0.043478260869565, 0.1, 0.083333333333333
19539, 0.021739130434783, 0.1, 0.11111111111111
19540, 0.043478260869565, 0.1, 0.13888888888889
19541, 0.021739130434783, 0.1, 0.16666666666667
19542, 0.043478260869565, 0.1, 0.19444444444444
19543, 0.021739130434783, 0.1, 0.22222222222222
19544, 0.043478260869565, 0.1, 0.25
19545, 0.021739130434783, 0.1, 0.27777777777778
19546, 0.043478260869565, 0.1, 0.30555555555556
19547, 0.021739130434783, 0.1, 0.33333333333333
19548, 0.043478260869565, 0.1, 0.36111111111111
19549, 0.021739130434783, 0.1, 0.38888888888889
19550, 0.043478260869565, 0.1, 0.41666666666667
19551, 0.021739130434783, 0.1, 0.44444444444444
19552, 0.043478260869565, 0.1, 0.47222222222222
19553, 0.08695652173913, 0.1, 0.027777777777778
19554, 0.065217391304348, 0.1, 0.055555555555556
19555, 0.08695652173913, 0.1, 0.083333333333333
19556, 0.065217391304348, 0.1, 0.11111111111111
19557, 0.08695652173913, 0.1, 0.13888888888889
19558, 0.065217391304348, 0.1, 0.16666666666667
19559, 0.08695652173913, 0.1, 0.19444444444444
19560, 0.065217391304348, 0.1, 0.22222222222222
19561, 0.08695652173913, 0.1, 0.25
19562, 0.065217391304348, 0.1, 0.27777777777778
19563, 0.08695652173913, 0.1, 0.30555555555556
19564, 0.065217391304348, 0.1, 0.33333333333333
19565, 0.08695652173913, 0.1, 0.36111111111111
19566, 0.065217391304348, 0.1, 0.38888888888889
19567, 0.08695652173913, 0.1, 0.41666666666667
19568, 0.065217391304348, 0.1, 0.44444444444444
19569, 0.08695652173913, 0.1, 0.47222222222222
19570, 0.1304347826087, 0.1, 0.027777777777778
19571, 0.10869565217391, 0.1, 0.055555555555556
19572, 0.1304347826087, 0.1, 0.083333333333333
19573, 0.10869565217391, 0.1, 0.11111111111111
19574, 0.1304347826087, 0.1, 0.13888888888889
19575, 0.10869565217391, 0.1, 0.16666666666667
19576, 0.1304347826087, 0.1, 0.19444444444444
19577, 0.10869565217391, 0.1, 0.22222222222222
19578, 0.1304347826087, 0.1, 0.25
19579, 0.10869565217391, 0.1, 0.27777777777778
19580, 0.1304347826087, 0.1, 0.30555555555556
19581, 0.10869565217391, 0.1, 0.33333333333333
19582, 0.1304347826087, 0.1, 0.36111111111111
19583, 0.10869565217391, 0.1, 0.38888888888889
19584, 0.1304347826087, 0.1, 0.41666666666667
19585, 0.10869565217391, 0.1, 0.44444444444444
19586, 0.1304347826087, 0.1, 0.47222222222222
19587, 0.17391304347826, 0.1, 0.027777777777778
19588, 0.15217391304348, 0.1, 0.055555555555556
19589, 0.17391304347826, 0.1, 0.083333333333333
19590, 0.15217391304348, 0.1, 0.11111111111111
19591, 0.17391304347826, 0.1, 0.13888888888889
19592, 0.15217391304348, 0.1, 0.16666666666667
19593, 0.17391304347826, 0.1, 0.19444444444444
19594, 0.15217391304348, 0.1, 0.22222222222222
19595, 0.17391304347826, 0.1, 0.25
19596, 0.15217391304348, 0.1, 0.27777777777778
19597, 0.17391304347826, 0.1, 0.30555555555556
19598, 0.15217391304348, 0.1, 0.33333333333333
19599, 0.17391304347826, 0.1, 0.36111111111111
19600, 0.15217391304348, 0.1, 0.38888888888889
19601, 0.17391304347826, 0.1, 0.41666666666667
19602, 0.15217391304348, 0.1, 0.44444444444444
19603, 0.17391304347826, 0.1, 0.47222222222222
19604, 0.21739130434783, 0.1, 0.027777777777778
19605, 0.19565217391304, 0.1, 0.055555555555556
19606, 0.21739130434783, 0.1, 0.083333333333333
19607, 0.19565217391304, 0.1, 0.11111111111111
19608, 0.21739130434783, 0.1, 0.13888888888889
19609, 0.19565217391304, 0.1, 0.16666666666667
19610, 0.21739130434783, 0.1, 0.19444444444444
19611, 0.19565217391304, 0.1, 0.22222222222222
19612, 0.21739130434783, 0.1, 0.25
19613, 0.19565217391304, 0.1, 0.27777777777778
19614, 0.21739130434783, 0.1, 0.30555555555556
19615, 0.19565217391304, 0.1, 0.33333333333333
19616, 0.21739130434783, 0.1, 0.36111111111111
19617, 0.19565217391304, 0.1, 0.38888888888889
19618, 0.21739130434783, 0.1, 0.41666666666667
19619, 0.19565217391304, 0.1, 0.44444444444444
19620, 0.21739130434783, 0.1, 0.47222222222222
19621, 0.26086956521739, 0.1, 0.027777777777778
19622, 0.23913043478261, 0.1, 0.055555555555556
19623, 0.26086956521739, 0.1, 0.083333333333333
19624, 0.23913043478261, 0.1, 0.11111111111111
19625, 0.26086956521739, 0.1, 0.13888888888889
19626, 0.23913043478261, 0.1, 0.16666666666667
19627, 0.26086956521739, 0.1, 0.19444444444444
19628, 0.23913043478261, 0.1, 0.22222222222222
19629, 0.26086956521739, 0.1, 0.25
19630, 0.23913043478261, 0.1, 0.27777777777778
19631, 0.26086956521739, 0.1, 0.30555555555556
19632, 0.23913043478261, 0.1, 0.33333333333333
19633, 0.26086956521739, 0.1, 0.36111111111111
19634, 0.23913043478261, 0.1, 0.38888888888889
19635, 0.26086956521739, 0.1, 0.41666666666667
19636, 0.23913043478261, 0.1, 0.44444444444444
19637, 0.26086956521739, 0.1, 0.47222222222222
19638, 0.30434782608696, 0.1, 0.027777777777778
19639, 0.28260869565217, 0.1, 0.055555555555556
19640, 0.30434782608696, 0.1, 0.083333333333333
19641, 0.28260869565217, 0.1, 0.11111111111111
19642, 0.30434782608696, 0.1, 0.13888888888889
19643, 0.28260869565217, 0.1, 0.16666666666667
19644, 0.30434782608696, 0.1, 0.19444444444444
19645, 0.28260869565217, 0.1, 0.22222222222222
19646, 0.30434782608696, 0.1, 0.25
19647, 0.28260869565217, 0.1, 0.27777777777778
19648, 0.30434782608696, 0.1, 0.30555555555556
19649, 0.28260869565217, 0.1, 0.33333333333333
19650, 0.30434782608696, 0.1, 0.36111111111111
19651, 0.28260869565217, 0.1, 0.38888888888889
19652, 0.30434782608696, 0.1, 0.41666666666667
19653, 0.28260869565217, 0.1, 0.44444444444444
19654, 0.30434782608696, 0.1, 0.47222222222222
19655, 0.34782608695652, 0.1, 0.027777777777778
19656, 0.32608695652174, 0.1, 0.055555555555556
19657, 0.34782608695652, 0.1, 0.083333333333333
19658, 0.32608695652174, 0.1, 0.11111111111111
19659, 0.34782608695652, 0.1, 0.13888888888889
19660, 0.32608695652174, 0.1, 0.16666666666667
19661, 0.34782608695652, 0.1, 0.19444444444444
19662, 0.32608695652174, 0.1, 0.22222222222222
19663, 0.34782608695652, 0.1, 0.25
19664, 0.32608695652174, 0.1, 0.27777777777778
19665, 0.34782608695652, 0.1, 0.30555555555556
19666, 0.32608695652174, 0.1, 0.33333333333333
19667, 0.34782608695652, 0.1, 0.36111111111111
19668, 0.32608695652174, 0.1, 0.38888888888889
19669, 0.34782608695652, 0.1, 0.41666666666667
19670, 0.32608695652174, 0.1, 0.44444444444444
19671, 0.34782608695652, 0.1, 0.47222222222222
19672, 0.39130434782609, 0.1, 0.027777777777778
19673, 0.3695652173913, 0.1, 0.055555555555556
19674, 0.39130434782609, 0.1, 0.083333333333333
19675, 0.3695652173913, 0.1, 0.11111111111111
19676, 0.39130434782609, 0.1, 0.13888888888889
19677, 0.3695652173913, 0.1, 0.16666666666667
19678, 0.39130434782609, 0.1, 0.19444444444444
19679, 0.3695652173913, 0.1, 0.22222222222222
19680, 0.39130434782609, 0.1, 0.25
19681, 0.3695652173913, 0.1, 0.27777777777778
19682, 0.39130434782609, 0.1, 0.30555555555556
19683, 0.3695652173913, 0.1, 0.33333333333333
19684, 0.39130434782609, 0.1, 0.36111111111111
19685, 0.3695652173913, 0.1, 0.38888888888889
19686, 0.39130434782609, 0.1, 0.41666666666667
19687, 0.3695652173913, 0.1, 0.44444444444444
19688, 0.39130434782609, 0.1, 0.47222222222222
19689, 0.43478260869565, 0.1, 0.027777777777778
19690, 0.41304347826087, 0.1, 0.055555555555556
19691, 0.43478260869565, 0.1, 0.083333333333333
19692, 0.41304347826087, 0.1, 0.11111111111111
19693, 0.43478260869565, 0.1, 0.13888888888889
19694, 0.41304347826087, 0.1, 0.16666666666667
19695, 0.43478260869565, 0.1, 0.19444444444444
19696, 0.41304347826087, 0.1, 0.22222222222222
19697, 0.43478260869565, 0.1, 0.25
19698, 0.41304347826087, 0.1, 0.27777777777778
19699, 0.43478260869565, 0.1, 0.30555555555556
19700, 0.41304347826087, 0.1, 0.33333333333333
19701, 0.43478260869565, 0.1, 0.36111111111111
19702, 0.41304347826087, 0.1, 0.38888888888889
19703, 0.43478260869565, 0.1, 0.41666666666667
19704, 0.41304347826087, 0.1, 0.44444444444444
19705, 0.43478260869565, 0.1, 0.47222222222222
19706, 0.47826086956522, 0.1, 0.027777777777778
19707, 0.45652173913043, 0.1, 0.055555555555556
19708, 0.47826086956522, 0.1, 0.083333333333333
19709, 0.45652173913043, 0.1, 0.11111111111111
19710, 0.47826086956522, 0.1, 0.13888888888889
19711, 0.45652173913043, 0.1, 0.16666666666667
19712, 0.47826086956522, 0.1, 0.19444444444444
19713, 0.45652173913043, 0.1, 0.22222222222222
19714, 0.47826086956522, 0.1, 0.25
19715, 0.45652173913043, 0.1, 0.27777777777778
19716, 0.47826086956522, 0.1, 0.30555555555556
19717, 0.45652173913043, 0.1, 0.33333333333333
19718, 0.47826086956522, 0.1, 0.36111111111111
19719, 0.45652173913043, 0.1, 0.38888888888889
19720, 0.47826086956522, 0.1, 0.41666666666667
19721, 0.45652173913043, 0.1, 0.44444444444444
19722, 0.47826086956522, 0.1, 0.47222222222222
19723, 0.52173913043478, 0.1, 0.027777777777778
19724, 0.5, 0.1, 0.055555555555556
19725, 0.52173913043478, 0.1, 0.083333333333333
19726, 0.5, 0.1, 0.11111111111111
19727, 0.52173913043478, 0.1, 0.13888888888889
19728, 0.5, 0.1, 0.16666666666667
19729, 0.52173913043478, 0.1, 0.19444444444444
19730, 0.5, 0.1, 0.22222222222222
19731, 0.52173913043478, 0.1, 0.25
19732, 0.5, 0.1, 0.27777777777778
19733, 0.52173913043478, 0.1, 0.30555555555556
19734, 0.5, 0.1, 0.33333333333333
19735, 0.52173913043478, 0.1, 0.36111111111111
19736, 0.5, 0.1, 0.38888888888889
19737, 0.52173913043478, 0.1, 0.41666666666667
19738, 0.5, 0.1, 0.44444444444444
19739, 0.52173913043478, 0.1, 0.47222222222222
19740, 0.56521739130435, 0.1, 0.027777777777778
19741, 0.54347826086957, 0.1, 0.055555555555556
19742, 0.56521739130435, 0.1, 0.083333333333333
19743, 0.54347826086957, 0.1, 0.11111111111111
19744, 0.56521739130435, 0.1, 0.13888888888889
19745, 0.54347826086957, 0.1, 0.16666666666667
19746, 0.56521739130435, 0.1, 0.19444444444444
19747, 0.54347826086957, 0.1, 0.22222222222222
19748, 0.56521739130435, 0.1, 0.25
19749, 0.54347826086957, 0.1, 0.27777777777778
19750, 0.56521739130435, 0.1, 0.30555555555556
19751, 0.54347826086957, 0.1, 0.33333333333333
19752, 0.56521739130435, 0.1, 0.36111111111111
19753, 0.54347826086957, 0.1, 0.38888888888889
19754, 0.56521739130435, 0.1, 0.41666666666667
19755, 0.54347826086957, 0.1, 0.44444444444444
19756, 0.56521739130435, 0.1, 0.47222222222222
19757, 0.60869565217391, 0.1, 0.027777777777778
19758, 0.58695652173913, 0.1, 0.055555555555556
19759, 0.60869565217391, 0.1, 0.083333333333333
19760, 0.58695652173913, 0.1, 0.11111111111111
19761, 0.60869565217391, 0.1, 0.13888888888889
19762, 0.58695652173913, 0.1, 0.16666666666667
19763, 0.60869565217391, 0.1, 0.19444444444444
19764, 0.58695652173913, 0.1, 0.22222222222222
19765, 0.60869565217391, 0.1, 0.25
19766, 0.58695652173913, 0.1, 0.27777777777778
19767, 0.60869565217391, 0.1, 0.30555555555556
19768, 0.58695652173913, 0.1, 0.33333333333333
19769, 0.60869565217391, 0.1, 0.36111111111111
19770, 0.58695652173913, 0.1, 0.38888888888889
19771, 0.60869565217391, 0.1, 0.41666666666667
19772, 0.58695652173913, 0.1, 0.44444444444444
19773, 0.60869565217391, 0.1, 0.47222222222222
19774, 0.65217391304348, 0.1, 0.027777777777778
19775, 0.6304347826087, 0.1, 0.055555555555556
19776, 0.65217391304348, 0.1, 0.083333333333333
19777, 0.6304347826087, 0.1, 0.11111111111111
19778, 0.65217391304348, 0.1, 0.13888888888889
19779, 0.6304347826087, 0.1, 0.16666666666667
19780, 0.65217391304348, 0.1, 0.19444444444444
19781, 0.6304347826087, 0.1, 0.22222222222222
19782, 0.65217391304348, 0.1, 0.25
19783, 0.6304347826087, 0.1, 0.27777777777778
19784, 0.65217391304348, 0.1, 0.30555555555556
19785, 0.6304347826087, 0.1, 0.33333333333333
19786, 0.65217391304348, 0.1, 0.36111111111111
19787, 0.6304347826087, 0.1, 0.38888888888889
19788, 0.65217391304348, 0.1, 0.41666666666667
19789, 0.6304347826087, 0.1, 0.44444444444444
19790, 0.65217391304348, 0.1, 0.47222222222222
19791, 0.69565217391304, 0.1, 0.027777777777778
19792, 0.67391304347826, 0.1, 0.055555555555556
19793, 0.69565217391304, 0.1, 0.083333333333333
19794, 0.67391304347826, 0.1, 0.11111111111111
19795, 0.69565217391304, 0.1, 0.13888888888889
19796, 0.67391304347826, 0.1, 0.16666666666667
19797, 0.69565217391304, 0.1, 0.19444444444444
19798, 0.67391304347826, 0.1, 0.22222222222222
19799, 0.69565217391304, 0.1, 0.25
19800, 0.67391304347826, 0.1, 0.27777777777778
19801, 0.69565217391304, 0.1, 0.30555555555556
19802, 0.67391304347826, 0.1, 0.33333333333333
19803, 0.69565217391304, 0.1, 0.36111111111111
19804, 0.67391304347826, 0.1, 0.38888888888889
19805, 0.69565217391304, 0.1, 0.41666666666667
19806, 0.67391304347826, 0.1, 0.44444444444444
19807, 0.69565217391304, 0.1, 0.47222222222222
19808, 0.73913043478261, 0.1, 0.027777777777778
19809, 0.71739130434783, 0.1, 0.055555555555556
19810, 0.73913043478261, 0.1, 0.083333333333333
19811, 0.71739130434783, 0.1, 0.11111111111111
19812, 0.73913043478261, 0.1, 0.13888888888889
19813, 0.71739130434783, 0.1, 0.16666666666667
19814, 0.73913043478261, 0.1, 0.19444444444444
19815, 0.71739130434783, 0.1, 0.22222222222222
19816, 0.73913043478261, 0.1, 0.25
19817, 0.71739130434783, 0.1, 0.27777777777778
19818, 0.73913043478261, 0.1, 0.30555555555556
19819, 0.71739130434783, 0.1, 0.33333333333333
19820, 0.73913043478261, 0.1, 0.36111111111111
19821, 0.71739130434783, 0.1, 0.38888888888889
19822, 0.73913043478261, 0.1, 0.41666666666667
19823, 0.71739130434783, 0.1, 0.44444444444444
19824, 0.73913043478261, 0.1, 0.47222222222222
19825, 0.78260869565217, 0.1, 0.027777777777778
19826, 0.76086956521739, 0.1, 0.055555555555556
19827, 0.78260869565217, 0.1, 0.083333333333333
19828, 0.76086956521739, 0.1, 0.11111111111111
19829, 0.78260869565217, 0.1, 0.13888888888889
19830, 0.76086956521739, 0.1, 0.16666666666667
19831, 0.78260869565217, 0.1, 0.19444444444444
19832, 0.76086956521739, 0.1, 0.22222222222222
19833, 0.78260869565217, 0.1, 0.25
19834, 0.76086956521739, 0.1, 0.27777777777778
19835, 0.78260869565217, 0.1, 0.30555555555556
19836, 0.76086956521739, 0.1, 0.33333333333333
19837, 0.78260869565217, 0.1, 0.36111111111111
19838, 0.76086956521739, 0.1, 0.38888888888889
19839, 0.78260869565217, 0.1, 0.41666666666667
19840, 0.76086956521739, 0.1, 0.44444444444444
19841, 0.78260869565217, 0.1, 0.47222222222222
19842, 0.82608695652174, 0.1, 0.027777777777778
19843, 0.80434782608696, 0.1, 0.055555555555556
19844, 0.82608695652174, 0.1, 0.083333333333333
19845, 0.80434782608696, 0.1, 0.11111111111111
19846, 0.82608695652174, 0.1, 0.13888888888889
19847, 0.80434782608696, 0.1, 0.16666666666667
19848, 0.82608695652174, 0.1, 0.19444444444444
19849, 0.80434782608696, 0.1, 0.22222222222222
19850, 0.82608695652174, 0.1, 0.25
19851, 0.80434782608696, 0.1, 0.27777777777778
19852, 0.82608695652174, 0.1, 0.30555555555556
19853, 0.80434782608696, 0.1, 0.33333333333333
19854, 0.82608695652174, 0.1, 0.36111111111111
19855, 0.80434782608696, 0.1, 0.38888888888889
19856, 0.82608695652174, 0.1, 0.41666666666667
19857, 0.80434782608696, 0.1, 0.44444444444444
19858, 0.82608695652174, 0.1, 0.47222222222222
19859, 0.8695652173913, 0.1, 0.027777777777778
19860, 0.84782608695652, 0.1, 0.055555555555556
19861, 0.8695652173913, 0.1, 0.083333333333333
19862, 0.84782608695652, 0.1, 0.11111111111111
19863, 0.8695652173913, 0.1, 0.13888888888889
19864, 0.84782608695652, 0.1, 0.16666666666667
19865, 0.8695652173913, 0.1, 0.19444444444444
19866, 0.84782608695652, 0.1, 0.22222222222222
19867, 0.8695652173913, 0.1, 0.25
19868, 0.84782608695652, 0.1, 0.27777777777778
19869, 0.8695652173913, 0.1, 0.30555555555556
19870, 0.84782608695652, 0.1, 0.33333333333333
19871, 0.8695652173913, 0.1, 0.36111111111111
19872, 0.84782608695652, 0.1, 0.38888888888889
19873, 0.8695652173913, 0.1, 0.41666666666667
19874, 0.84782608695652, 0.1, 0.44444444444444
19875, 0.8695652173913, 0.1, 0.47222222222222
19876, 0.91304347826087, 0.1, 0.027777777777778
19877, 0.89130434782609, 0.1, 0.055555555555556
19878, 0.91304347826087, 0.1, 0.083333333333333
19879, 0.89130434782609, 0.1, 0.11111111111111
19880, 0.91304347826087, 0.1, 0.13888888888889
19881, 0.89130434782609, 0.1, 0.16666666666667
19882, 0.91304347826087, 0.1, 0.19444444444444
19883, 0.89130434782609, 0.1, 0.22222222222222
19884, 0.91304347826087, 0.1, 0.25
19885, 0.89130434782609, 0.1, 0.27777777777778
19886, 0.91304347826087, 0.1, 0.30555555555556
19887, 0.89130434782609, 0.1, 0.33333333333333
