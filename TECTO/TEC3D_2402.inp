11822, 3221, 3222, 28748, 28740, 3244, 28987, 28988, 28970
11823, 28740, 28748, 28749, 28741, 28988, 28989, 28990, 28972
11824, 28741, 28749, 28750, 28742, 28990, 28991, 28992, 28974
11825, 28742, 28750, 28751, 28743, 28992, 28993, 28994, 28976
11826, 28743, 28751, 28752, 28744, 28994, 28995, 28996, 28978
11827, 28744, 28752, 28753, 28745, 28996, 28997, 28998, 28980
11828, 28745, 28753, 28754, 28746, 28998, 28999, 29000, 28982
11829, 28746, 28754, 28755, 28747, 29000, 29001, 29002, 28984
11830, 28747, 28755, 3357, 3356, 29002, 29003, 3379, 28986
11831, 3222, 3223, 28756, 28748, 3245, 29004, 29005, 28987
11832, 28748, 28756, 28757, 28749, 29005, 29006, 29007, 28989
11833, 28749, 28757, 28758, 28750, 29007, 29008, 29009, 28991
11834, 28750, 28758, 28759, 28751, 29009, 29010, 29011, 28993
11835, 28751, 28759, 28760, 28752, 29011, 29012, 29013, 28995
11836, 28752, 28760, 28761, 28753, 29013, 29014, 29015, 28997
11837, 28753, 28761, 28762, 28754, 29015, 29016, 29017, 28999
11838, 28754, 28762, 28763, 28755, 29017, 29018, 29019, 29001
11839, 28755, 28763, 3358, 3357, 29019, 29020, 3380, 29003
11840, 3223, 3224, 28764, 28756, 3246, 29021, 29022, 29004
11841, 28756, 28764, 28765, 28757, 29022, 29023, 29024, 29006
11842, 28757, 28765, 28766, 28758, 29024, 29025, 29026, 29008
11843, 28758, 28766, 28767, 28759, 29026, 29027, 29028, 29010
11844, 28759, 28767, 28768, 28760, 29028, 29029, 29030, 29012
11845, 28760, 28768, 28769, 28761, 29030, 29031, 29032, 29014
11846, 28761, 28769, 28770, 28762, 29032, 29033, 29034, 29016
11847, 28762, 28770, 28771, 28763, 29034, 29035, 29036, 29018
11848, 28763, 28771, 3359, 3358, 29036, 29037, 3381, 29020
11849, 3224, 3225, 28772, 28764, 3247, 29038, 29039, 29021
11850, 28764, 28772, 28773, 28765, 29039, 29040, 29041, 29023
11851, 28765, 28773, 28774, 28766, 29041, 29042, 29043, 29025
11852, 28766, 28774, 28775, 28767, 29043, 29044, 29045, 29027
11853, 28767, 28775, 28776, 28768, 29045, 29046, 29047, 29029
11854, 28768, 28776, 28777, 28769, 29047, 29048, 29049, 29031
11855, 28769, 28777, 28778, 28770, 29049, 29050, 29051, 29033
11856, 28770, 28778, 28779, 28771, 29051, 29052, 29053, 29035
11857, 28771, 28779, 3360, 3359, 29053, 29054, 3382, 29037
11858, 3225, 3226, 28780, 28772, 3248, 29055, 29056, 29038
11859, 28772, 28780, 28781, 28773, 29056, 29057, 29058, 29040
11860, 28773, 28781, 28782, 28774, 29058, 29059, 29060, 29042
11861, 28774, 28782, 28783, 28775, 29060, 29061, 29062, 29044
11862, 28775, 28783, 28784, 28776, 29062, 29063, 29064, 29046
11863, 28776, 28784, 28785, 28777, 29064, 29065, 29066, 29048
11864, 28777, 28785, 28786, 28778, 29066, 29067, 29068, 29050
11865, 28778, 28786, 28787, 28779, 29068, 29069, 29070, 29052
11866, 28779, 28787, 3361, 3360, 29070, 29071, 3383, 29054
11867, 3226, 3227, 28788, 28780, 3249, 29072, 29073, 29055
11868, 28780, 28788, 28789, 28781, 29073, 29074, 29075, 29057
11869, 28781, 28789, 28790, 28782, 29075, 29076, 29077, 29059
11870, 28782, 28790, 28791, 28783, 29077, 29078, 29079, 29061
11871, 28783, 28791, 28792, 28784, 29079, 29080, 29081, 29063
11872, 28784, 28792, 28793, 28785, 29081, 29082, 29083, 29065
11873, 28785, 28793, 28794, 28786, 29083, 29084, 29085, 29067
11874, 28786, 28794, 28795, 28787, 29085, 29086, 29087, 29069
11875, 28787, 28795, 3362, 3361, 29087, 29088, 3384, 29071
11876, 3227, 3228, 28796, 28788, 3250, 29089, 29090, 29072
11877, 28788, 28796, 28797, 28789, 29090, 29091, 29092, 29074
11878, 28789, 28797, 28798, 28790, 29092, 29093, 29094, 29076
11879, 28790, 28798, 28799, 28791, 29094, 29095, 29096, 29078
11880, 28791, 28799, 28800, 28792, 29096, 29097, 29098, 29080
11881, 28792, 28800, 28801, 28793, 29098, 29099, 29100, 29082
11882, 28793, 28801, 28802, 28794, 29100, 29101, 29102, 29084
11883, 28794, 28802, 28803, 28795, 29102, 29103, 29104, 29086
11884, 28795, 28803, 3363, 3362, 29104, 29105, 3385, 29088
11885, 3228, 3229, 28804, 28796, 3251, 29106, 29107, 29089
11886, 28796, 28804, 28805, 28797, 29107, 29108, 29109, 29091
11887, 28797, 28805, 28806, 28798, 29109, 29110, 29111, 29093
11888, 28798, 28806, 28807, 28799, 29111, 29112, 29113, 29095
11889, 28799, 28807, 28808, 28800, 29113, 29114, 29115, 29097
11890, 28800, 28808, 28809, 28801, 29115, 29116, 29117, 29099
11891, 28801, 28809, 28810, 28802, 29117, 29118, 29119, 29101
11892, 28802, 28810, 28811, 28803, 29119, 29120, 29121, 29103
11893, 28803, 28811, 3364, 3363, 29121, 29122, 3386, 29105
11894, 3229, 3230, 28812, 28804, 3252, 29123, 29124, 29106
11895, 28804, 28812, 28813, 28805, 29124, 29125, 29126, 29108
11896, 28805, 28813, 28814, 28806, 29126, 29127, 29128, 29110
11897, 28806, 28814, 28815, 28807, 29128, 29129, 29130, 29112
11898, 28807, 28815, 28816, 28808, 29130, 29131, 29132, 29114
11899, 28808, 28816, 28817, 28809, 29132, 29133, 29134, 29116
11900, 28809, 28817, 28818, 28810, 29134, 29135, 29136, 29118
11901, 28810, 28818, 28819, 28811, 29136, 29137, 29138, 29120
11902, 28811, 28819, 3365, 3364, 29138, 29139, 3387, 29122
11903, 3230, 3231, 28820, 28812, 3253, 29140, 29141, 29123
11904, 28812, 28820, 28821, 28813, 29141, 29142, 29143, 29125
11905, 28813, 28821, 28822, 28814, 29143, 29144, 29145, 29127
11906, 28814, 28822, 28823, 28815, 29145, 29146, 29147, 29129
11907, 28815, 28823, 28824, 28816, 29147, 29148, 29149, 29131
11908, 28816, 28824, 28825, 28817, 29149, 29150, 29151, 29133
11909, 28817, 28825, 28826, 28818, 29151, 29152, 29153, 29135
11910, 28818, 28826, 28827, 28819, 29153, 29154, 29155, 29137
11911, 28819, 28827, 3366, 3365, 29155, 29156, 3388, 29139
11912, 3231, 3232, 28828, 28820, 3254, 29157, 29158, 29140
11913, 28820, 28828, 28829, 28821, 29158, 29159, 29160, 29142
11914, 28821, 28829, 28830, 28822, 29160, 29161, 29162, 29144
11915, 28822, 28830, 28831, 28823, 29162, 29163, 29164, 29146
11916, 28823, 28831, 28832, 28824, 29164, 29165, 29166, 29148
11917, 28824, 28832, 28833, 28825, 29166, 29167, 29168, 29150
11918, 28825, 28833, 28834, 28826, 29168, 29169, 29170, 29152
11919, 28826, 28834, 28835, 28827, 29170, 29171, 29172, 29154
11920, 28827, 28835, 3367, 3366, 29172, 29173, 3389, 29156
11921, 3232, 3233, 28836, 28828, 3255, 29174, 29175, 29157
11922, 28828, 28836, 28837, 28829, 29175, 29176, 29177, 29159
11923, 28829, 28837, 28838, 28830, 29177, 29178, 29179, 29161
11924, 28830, 28838, 28839, 28831, 29179, 29180, 29181, 29163
11925, 28831, 28839, 28840, 28832, 29181, 29182, 29183, 29165
11926, 28832, 28840, 28841, 28833, 29183, 29184, 29185, 29167
11927, 28833, 28841, 28842, 28834, 29185, 29186, 29187, 29169
11928, 28834, 28842, 28843, 28835, 29187, 29188, 29189, 29171
11929, 28835, 28843, 3368, 3367, 29189, 29190, 3390, 29173
11930, 3233, 3234, 28844, 28836, 3256, 29191, 29192, 29174
11931, 28836, 28844, 28845, 28837, 29192, 29193, 29194, 29176
11932, 28837, 28845, 28846, 28838, 29194, 29195, 29196, 29178
11933, 28838, 28846, 28847, 28839, 29196, 29197, 29198, 29180
11934, 28839, 28847, 28848, 28840, 29198, 29199, 29200, 29182
11935, 28840, 28848, 28849, 28841, 29200, 29201, 29202, 29184
11936, 28841, 28849, 28850, 28842, 29202, 29203, 29204, 29186
11937, 28842, 28850, 28851, 28843, 29204, 29205, 29206, 29188
11938, 28843, 28851, 3369, 3368, 29206, 29207, 3391, 29190
11939, 3234, 3235, 28852, 28844, 3257, 29208, 29209, 29191
11940, 28844, 28852, 28853, 28845, 29209, 29210, 29211, 29193
11941, 28845, 28853, 28854, 28846, 29211, 29212, 29213, 29195
11942, 28846, 28854, 28855, 28847, 29213, 29214, 29215, 29197
11943, 28847, 28855, 28856, 28848, 29215, 29216, 29217, 29199
11944, 28848, 28856, 28857, 28849, 29217, 29218, 29219, 29201
11945, 28849, 28857, 28858, 28850, 29219, 29220, 29221, 29203
11946, 28850, 28858, 28859, 28851, 29221, 29222, 29223, 29205
11947, 28851, 28859, 3370, 3369, 29223, 29224, 3392, 29207
11948, 3235, 3236, 28860, 28852, 3258, 29225, 29226, 29208
11949, 28852, 28860, 28861, 28853, 29226, 29227, 29228, 29210
11950, 28853, 28861, 28862, 28854, 29228, 29229, 29230, 29212
11951, 28854, 28862, 28863, 28855, 29230, 29231, 29232, 29214
11952, 28855, 28863, 28864, 28856, 29232, 29233, 29234, 29216
11953, 28856, 28864, 28865, 28857, 29234, 29235, 29236, 29218
11954, 28857, 28865, 28866, 28858, 29236, 29237, 29238, 29220
11955, 28858, 28866, 28867, 28859, 29238, 29239, 29240, 29222
11956, 28859, 28867, 3371, 3370, 29240, 29241, 3393, 29224
11957, 3236, 94, 3419, 28860, 3259, 3428, 29242, 29225
11958, 28860, 3419, 3418, 28861, 29242, 3427, 29243, 29227
11959, 28861, 3418, 3417, 28862, 29243, 3426, 29244, 29229
11960, 28862, 3417, 3416, 28863, 29244, 3425, 29245, 29231
11961, 28863, 3416, 3415, 28864, 29245, 3424, 29246, 29233
11962, 28864, 3415, 3414, 28865, 29246, 3423, 29247, 29235
11963, 28865, 3414, 3413, 28866, 29247, 3422, 29248, 29237
11964, 28866, 3413, 3412, 28867, 29248, 3421, 29249, 29239
11965, 28867, 3412, 96, 3371, 29249, 3420, 3394, 29241
*ELEMENT, type=CPS8, ELSET=Surface270
11966, 5, 3429, 29250, 233, 3430, 29272, 29273, 255
11967, 233, 29250, 29251, 234, 29273, 29274, 29275, 256
11968, 234, 29251, 29252, 235, 29275, 29276, 29277, 257
11969, 235, 29252, 29253, 236, 29277, 29278, 29279, 258
11970, 236, 29253, 29254, 237, 29279, 29280, 29281, 259
11971, 237, 29254, 29255, 238, 29281, 29282, 29283, 260
11972, 238, 29255, 29256, 239, 29283, 29284, 29285, 261
11973, 239, 29256, 29257, 240, 29285, 29286, 29287, 262
11974, 240, 29257, 29258, 241, 29287, 29288, 29289, 263
11975, 241, 29258, 29259, 242, 29289, 29290, 29291, 264
11976, 242, 29259, 29260, 243, 29291, 29292, 29293, 265
11977, 243, 29260, 29261, 244, 29293, 29294, 29295, 266
11978, 244, 29261, 29262, 245, 29295, 29296, 29297, 267
11979, 245, 29262, 29263, 246, 29297, 29298, 29299, 268
11980, 246, 29263, 29264, 247, 29299, 29300, 29301, 269
11981, 247, 29264, 29265, 248, 29301, 29302, 29303, 270
11982, 248, 29265, 29266, 249, 29303, 29304, 29305, 271
11983, 249, 29266, 29267, 250, 29305, 29306, 29307, 272
11984, 250, 29267, 29268, 251, 29307, 29308, 29309, 273
11985, 251, 29268, 29269, 252, 29309, 29310, 29311, 274
11986, 252, 29269, 29270, 253, 29311, 29312, 29313, 275
11987, 253, 29270, 29271, 254, 29313, 29314, 29315, 276
11988, 254, 29271, 3432, 6, 29315, 29316, 3433, 277
11989, 3429, 97, 3435, 29250, 3431, 3457, 29317, 29272
11990, 29250, 3435, 3436, 29251, 29317, 3458, 29318, 29274
11991, 29251, 3436, 3437, 29252, 29318, 3459, 29319, 29276
11992, 29252, 3437, 3438, 29253, 29319, 3460, 29320, 29278
11993, 29253, 3438, 3439, 29254, 29320, 3461, 29321, 29280
11994, 29254, 3439, 3440, 29255, 29321, 3462, 29322, 29282
11995, 29255, 3440, 3441, 29256, 29322, 3463, 29323, 29284
11996, 29256, 3441, 3442, 29257, 29323, 3464, 29324, 29286
11997, 29257, 3442, 3443, 29258, 29324, 3465, 29325, 29288
11998, 29258, 3443, 3444, 29259, 29325, 3466, 29326, 29290
11999, 29259, 3444, 3445, 29260, 29326, 3467, 29327, 29292
12000, 29260, 3445, 3446, 29261, 29327, 3468, 29328, 29294
12001, 29261, 3446, 3447, 29262, 29328, 3469, 29329, 29296
12002, 29262, 3447, 3448, 29263, 29329, 3470, 29330, 29298
12003, 29263, 3448, 3449, 29264, 29330, 3471, 29331, 29300
12004, 29264, 3449, 3450, 29265, 29331, 3472, 29332, 29302
12005, 29265, 3450, 3451, 29266, 29332, 3473, 29333, 29304
12006, 29266, 3451, 3452, 29267, 29333, 3474, 29334, 29306
12007, 29267, 3452, 3453, 29268, 29334, 3475, 29335, 29308
12008, 29268, 3453, 3454, 29269, 29335, 3476, 29336, 29310
12009, 29269, 3454, 3455, 29270, 29336, 3477, 29337, 29312
12010, 29270, 3455, 3456, 29271, 29337, 3478, 29338, 29314
12011, 29271, 3456, 98, 3432, 29338, 3479, 3434, 29316
*ELEMENT, type=CPS8, ELSET=Surface271
12012, 7, 278, 29339, 3480, 300, 29361, 29362, 3481
12013, 278, 279, 29340, 29339, 301, 29363, 29364, 29361
12014, 279, 280, 29341, 29340, 302, 29365, 29366, 29363
12015, 280, 281, 29342, 29341, 303, 29367, 29368, 29365
12016, 281, 282, 29343, 29342, 304, 29369, 29370, 29367
12017, 282, 283, 29344, 29343, 305, 29371, 29372, 29369
12018, 283, 284, 29345, 29344, 306, 29373, 29374, 29371
12019, 284, 285, 29346, 29345, 307, 29375, 29376, 29373
12020, 285, 286, 29347, 29346, 308, 29377, 29378, 29375
12021, 286, 287, 29348, 29347, 309, 29379, 29380, 29377
12022, 287, 288, 29349, 29348, 310, 29381, 29382, 29379
12023, 288, 289, 29350, 29349, 311, 29383, 29384, 29381
12024, 289, 290, 29351, 29350, 312, 29385, 29386, 29383
12025, 290, 291, 29352, 29351, 313, 29387, 29388, 29385
12026, 291, 292, 29353, 29352, 314, 29389, 29390, 29387
12027, 292, 293, 29354, 29353, 315, 29391, 29392, 29389
12028, 293, 294, 29355, 29354, 316, 29393, 29394, 29391
12029, 294, 295, 29356, 29355, 317, 29395, 29396, 29393
12030, 295, 296, 29357, 29356, 318, 29397, 29398, 29395
12031, 296, 297, 29358, 29357, 319, 29399, 29400, 29397
12032, 297, 298, 29359, 29358, 320, 29401, 29402, 29399
12033, 298, 299, 29360, 29359, 321, 29403, 29404, 29401
12034, 299, 8, 3483, 29360, 322, 3484, 29405, 29403
12035, 3480, 29339, 3486, 99, 29362, 29406, 3508, 3482
12036, 29339, 29340, 3487, 3486, 29364, 29407, 3509, 29406
12037, 29340, 29341, 3488, 3487, 29366, 29408, 3510, 29407
12038, 29341, 29342, 3489, 3488, 29368, 29409, 3511, 29408
12039, 29342, 29343, 3490, 3489, 29370, 29410, 3512, 29409
12040, 29343, 29344, 3491, 3490, 29372, 29411, 3513, 29410
12041, 29344, 29345, 3492, 3491, 29374, 29412, 3514, 29411
12042, 29345, 29346, 3493, 3492, 29376, 29413, 3515, 29412
12043, 29346, 29347, 3494, 3493, 29378, 29414, 3516, 29413
12044, 29347, 29348, 3495, 3494, 29380, 29415, 3517, 29414
12045, 29348, 29349, 3496, 3495, 29382, 29416, 3518, 29415
12046, 29349, 29350, 3497, 3496, 29384, 29417, 3519, 29416
12047, 29350, 29351, 3498, 3497, 29386, 29418, 3520, 29417
12048, 29351, 29352, 3499, 3498, 29388, 29419, 3521, 29418
12049, 29352, 29353, 3500, 3499, 29390, 29420, 3522, 29419
12050, 29353, 29354, 3501, 3500, 29392, 29421, 3523, 29420
12051, 29354, 29355, 3502, 3501, 29394, 29422, 3524, 29421
12052, 29355, 29356, 3503, 3502, 29396, 29423, 3525, 29422
12053, 29356, 29357, 3504, 3503, 29398, 29424, 3526, 29423
12054, 29357, 29358, 3505, 3504, 29400, 29425, 3527, 29424
12055, 29358, 29359, 3506, 3505, 29402, 29426, 3528, 29425
12056, 29359, 29360, 3507, 3506, 29404, 29427, 3529, 29426
12057, 29360, 3483, 100, 3507, 29405, 3485, 3530, 29427
*ELEMENT, type=CPS8, ELSET=Surface272
12058, 5, 330, 29428, 3429, 339, 29436, 29437, 3430
12059, 330, 329, 29429, 29428, 338, 29438, 29439, 29436
12060, 329, 328, 29430, 29429, 337, 29440, 29441, 29438
12061, 328, 327, 29431, 29430, 336, 29442, 29443, 29440
12062, 327, 326, 29432, 29431, 335, 29444, 29445, 29442
12063, 326, 325, 29433, 29432, 334, 29446, 29447, 29444
12064, 325, 324, 29434, 29433, 333, 29448, 29449, 29446
12065, 324, 323, 29435, 29434, 332, 29450, 29451, 29448
12066, 323, 7, 3480, 29435, 331, 3481, 29452, 29450
12067, 3429, 29428, 3538, 97, 29437, 29453, 3547, 3431
12068, 29428, 29429, 3537, 3538, 29439, 29454, 3546, 29453
12069, 29429, 29430, 3536, 3537, 29441, 29455, 3545, 29454
12070, 29430, 29431, 3535, 3536, 29443, 29456, 3544, 29455
12071, 29431, 29432, 3534, 3535, 29445, 29457, 3543, 29456
12072, 29432, 29433, 3533, 3534, 29447, 29458, 3542, 29457
12073, 29433, 29434, 3532, 3533, 29449, 29459, 3541, 29458
12074, 29434, 29435, 3531, 3532, 29451, 29460, 3540, 29459
12075, 29435, 3480, 99, 3531, 29452, 3482, 3539, 29460
*ELEMENT, type=CPS8, ELSET=Surface273
12076, 6, 3432, 29461, 347, 3433, 29469, 29470, 356
12077, 347, 29461, 29462, 346, 29470, 29471, 29472, 355
12078, 346, 29462, 29463, 345, 29472, 29473, 29474, 354
12079, 345, 29463, 29464, 344, 29474, 29475, 29476, 353
12080, 344, 29464, 29465, 343, 29476, 29477, 29478, 352
12081, 343, 29465, 29466, 342, 29478, 29479, 29480, 351
12082, 342, 29466, 29467, 341, 29480, 29481, 29482, 350
12083, 341, 29467, 29468, 340, 29482, 29483, 29484, 349
12084, 340, 29468, 3483, 8, 29484, 29485, 3484, 348
12085, 3432, 98, 3555, 29461, 3434, 3564, 29486, 29469
12086, 29461, 3555, 3554, 29462, 29486, 3563, 29487, 29471
12087, 29462, 3554, 3553, 29463, 29487, 3562, 29488, 29473
12088, 29463, 3553, 3552, 29464, 29488, 3561, 29489, 29475
12089, 29464, 3552, 3551, 29465, 29489, 3560, 29490, 29477
12090, 29465, 3551, 3550, 29466, 29490, 3559, 29491, 29479
12091, 29466, 3550, 3549, 29467, 29491, 3558, 29492, 29481
12092, 29467, 3549, 3548, 29468, 29492, 3557, 29493, 29483
12093, 29468, 3548, 100, 3483, 29493, 3556, 3485, 29485
*ELEMENT, type=CPS8, ELSET=Surface274
12094, 97, 3538, 29494, 3435, 3547, 29670, 29671, 3457
12095, 3538, 3537, 29495, 29494, 3546, 29672, 29673, 29670
12096, 3537, 3536, 29496, 29495, 3545, 29674, 29675, 29672
12097, 3536, 3535, 29497, 29496, 3544, 29676, 29677, 29674
12098, 3535, 3534, 29498, 29497, 3543, 29678, 29679, 29676
12099, 3534, 3533, 29499, 29498, 3542, 29680, 29681, 29678
12100, 3533, 3532, 29500, 29499, 3541, 29682, 29683, 29680
12101, 3532, 3531, 29501, 29500, 3540, 29684, 29685, 29682
12102, 3531, 99, 3486, 29501, 3539, 3508, 29686, 29684
12103, 3435, 29494, 29502, 3436, 29671, 29687, 29688, 3458
12104, 29494, 29495, 29503, 29502, 29673, 29689, 29690, 29687
12105, 29495, 29496, 29504, 29503, 29675, 29691, 29692, 29689
12106, 29496, 29497, 29505, 29504, 29677, 29693, 29694, 29691
12107, 29497, 29498, 29506, 29505, 29679, 29695, 29696, 29693
12108, 29498, 29499, 29507, 29506, 29681, 29697, 29698, 29695
12109, 29499, 29500, 29508, 29507, 29683, 29699, 29700, 29697
12110, 29500, 29501, 29509, 29508, 29685, 29701, 29702, 29699
12111, 29501, 3486, 3487, 29509, 29686, 3509, 29703, 29701
12112, 3436, 29502, 29510, 3437, 29688, 29704, 29705, 3459
12113, 29502, 29503, 29511, 29510, 29690, 29706, 29707, 29704
12114, 29503, 29504, 29512, 29511, 29692, 29708, 29709, 29706
12115, 29504, 29505, 29513, 29512, 29694, 29710, 29711, 29708
12116, 29505, 29506, 29514, 29513, 29696, 29712, 29713, 29710
12117, 29506, 29507, 29515, 29514, 29698, 29714, 29715, 29712
12118, 29507, 29508, 29516, 29515, 29700, 29716, 29717, 29714
12119, 29508, 29509, 29517, 29516, 29702, 29718, 29719, 29716
12120, 29509, 3487, 3488, 29517, 29703, 3510, 29720, 29718
12121, 3437, 29510, 29518, 3438, 29705, 29721, 29722, 3460
12122, 29510, 29511, 29519, 29518, 29707, 29723, 29724, 29721
12123, 29511, 29512, 29520, 29519, 29709, 29725, 29726, 29723
12124, 29512, 29513, 29521, 29520, 29711, 29727, 29728, 29725
12125, 29513, 29514, 29522, 29521, 29713, 29729, 29730, 29727
12126, 29514, 29515, 29523, 29522, 29715, 29731, 29732, 29729
12127, 29515, 29516, 29524, 29523, 29717, 29733, 29734, 29731
12128, 29516, 29517, 29525, 29524, 29719, 29735, 29736, 29733
12129, 29517, 3488, 3489, 29525, 29720, 3511, 29737, 29735
12130, 3438, 29518, 29526, 3439, 29722, 29738, 29739, 3461
12131, 29518, 29519, 29527, 29526, 29724, 29740, 29741, 29738
12132, 29519, 29520, 29528, 29527, 29726, 29742, 29743, 29740
12133, 29520, 29521, 29529, 29528, 29728, 29744, 29745, 29742
12134, 29521, 29522, 29530, 29529, 29730, 29746, 29747, 29744
12135, 29522, 29523, 29531, 29530, 29732, 29748, 29749, 29746
12136, 29523, 29524, 29532, 29531, 29734, 29750, 29751, 29748
12137, 29524, 29525, 29533, 29532, 29736, 29752, 29753, 29750
12138, 29525, 3489, 3490, 29533, 29737, 3512, 29754, 29752
12139, 3439, 29526, 29534, 3440, 29739, 29755, 29756, 3462
12140, 29526, 29527, 29535, 29534, 29741, 29757, 29758, 29755
12141, 29527, 29528, 29536, 29535, 29743, 29759, 29760, 29757
12142, 29528, 29529, 29537, 29536, 29745, 29761, 29762, 29759
12143, 29529, 29530, 29538, 29537, 29747, 29763, 29764, 29761
12144, 29530, 29531, 29539, 29538, 29749, 29765, 29766, 29763
12145, 29531, 29532, 29540, 29539, 29751, 29767, 29768, 29765
12146, 29532, 29533, 29541, 29540, 29753, 29769, 29770, 29767
12147, 29533, 3490, 3491, 29541, 29754, 3513, 29771, 29769
12148, 3440, 29534, 29542, 3441, 29756, 29772, 29773, 3463
12149, 29534, 29535, 29543, 29542, 29758, 29774, 29775, 29772
12150, 29535, 29536, 29544, 29543, 29760, 29776, 29777, 29774
12151, 29536, 29537, 29545, 29544, 29762, 29778, 29779, 29776
12152, 29537, 29538, 29546, 29545, 29764, 29780, 29781, 29778
12153, 29538, 29539, 29547, 29546, 29766, 29782, 29783, 29780
12154, 29539, 29540, 29548, 29547, 29768, 29784, 29785, 29782
12155, 29540, 29541, 29549, 29548, 29770, 29786, 29787, 29784
12156, 29541, 3491, 3492, 29549, 29771, 3514, 29788, 29786
12157, 3441, 29542, 29550, 3442, 29773, 29789, 29790, 3464
12158, 29542, 29543, 29551, 29550, 29775, 29791, 29792, 29789
12159, 29543, 29544, 29552, 29551, 29777, 29793, 29794, 29791
12160, 29544, 29545, 29553, 29552, 29779, 29795, 29796, 29793
12161, 29545, 29546, 29554, 29553, 29781, 29797, 29798, 29795
12162, 29546, 29547, 29555, 29554, 29783, 29799, 29800, 29797
12163, 29547, 29548, 29556, 29555, 29785, 29801, 29802, 29799
12164, 29548, 29549, 29557, 29556, 29787, 29803, 29804, 29801
12165, 29549, 3492, 3493, 29557, 29788, 3515, 29805, 29803
12166, 3442, 29550, 29558, 3443, 29790, 29806, 29807, 3465
12167, 29550, 29551, 29559, 29558, 29792, 29808, 29809, 29806
12168, 29551, 29552, 29560, 29559, 29794, 29810, 29811, 29808
12169, 29552, 29553, 29561, 29560, 29796, 29812, 29813, 29810
12170, 29553, 29554, 29562, 29561, 29798, 29814, 29815, 29812
12171, 29554, 29555, 29563, 29562, 29800, 29816, 29817, 29814
12172, 29555, 29556, 29564, 29563, 29802, 29818, 29819, 29816
12173, 29556, 29557, 29565, 29564, 29804, 29820, 29821, 29818
12174, 29557, 3493, 3494, 29565, 29805, 3516, 29822, 29820
12175, 3443, 29558, 29566, 3444, 29807, 29823, 29824, 3466
12176, 29558, 29559, 29567, 29566, 29809, 29825, 29826, 29823
12177, 29559, 29560, 29568, 29567, 29811, 29827, 29828, 29825
12178, 29560, 29561, 29569, 29568, 29813, 29829, 29830, 29827
12179, 29561, 29562, 29570, 29569, 29815, 29831, 29832, 29829
12180, 29562, 29563, 29571, 29570, 29817, 29833, 29834, 29831
12181, 29563, 29564, 29572, 29571, 29819, 29835, 29836, 29833
12182, 29564, 29565, 29573, 29572, 29821, 29837, 29838, 29835
12183, 29565, 3494, 3495, 29573, 29822, 3517, 29839, 29837
12184, 3444, 29566, 29574, 3445, 29824, 29840, 29841, 3467
12185, 29566, 29567, 29575, 29574, 29826, 29842, 29843, 29840
12186, 29567, 29568, 29576, 29575, 29828, 29844, 29845, 29842
12187, 29568, 29569, 29577, 29576, 29830, 29846, 29847, 29844
12188, 29569, 29570, 29578, 29577, 29832, 29848, 29849, 29846
12189, 29570, 29571, 29579, 29578, 29834, 29850, 29851, 29848
12190, 29571, 29572, 29580, 29579, 29836, 29852, 29853, 29850
12191, 29572, 29573, 29581, 29580, 29838, 29854, 29855, 29852
12192, 29573, 3495, 3496, 29581, 29839, 3518, 29856, 29854
12193, 3445, 29574, 29582, 3446, 29841, 29857, 29858, 3468
12194, 29574, 29575, 29583, 29582, 29843, 29859, 29860, 29857
12195, 29575, 29576, 29584, 29583, 29845, 29861, 29862, 29859
12196, 29576, 29577, 29585, 29584, 29847, 29863, 29864, 29861
12197, 29577, 29578, 29586, 29585, 29849, 29865, 29866, 29863
12198, 29578, 29579, 29587, 29586, 29851, 29867, 29868, 29865
12199, 29579, 29580, 29588, 29587, 29853, 29869, 29870, 29867
12200, 29580, 29581, 29589, 29588, 29855, 29871, 29872, 29869
12201, 29581, 3496, 3497, 29589, 29856, 3519, 29873, 29871
12202, 3446, 29582, 29590, 3447, 29858, 29874, 29875, 3469
12203, 29582, 29583, 29591, 29590, 29860, 29876, 29877, 29874
12204, 29583, 29584, 29592, 29591, 29862, 29878, 29879, 29876
12205, 29584, 29585, 29593, 29592, 29864, 29880, 29881, 29878
12206, 29585, 29586, 29594, 29593, 29866, 29882, 29883, 29880
12207, 29586, 29587, 29595, 29594, 29868, 29884, 29885, 29882
12208, 29587, 29588, 29596, 29595, 29870, 29886, 29887, 29884
12209, 29588, 29589, 29597, 29596, 29872, 29888, 29889, 29886
12210, 29589, 3497, 3498, 29597, 29873, 3520, 29890, 29888
12211, 3447, 29590, 29598, 3448, 29875, 29891, 29892, 3470
12212, 29590, 29591, 29599, 29598, 29877, 29893, 29894, 29891
12213, 29591, 29592, 29600, 29599, 29879, 29895, 29896, 29893
12214, 29592, 29593, 29601, 29600, 29881, 29897, 29898, 29895
12215, 29593, 29594, 29602, 29601, 29883, 29899, 29900, 29897
12216, 29594, 29595, 29603, 29602, 29885, 29901, 29902, 29899
12217, 29595, 29596, 29604, 29603, 29887, 29903, 29904, 29901
12218, 29596, 29597, 29605, 29604, 29889, 29905, 29906, 29903
12219, 29597, 3498, 3499, 29605, 29890, 3521, 29907, 29905
12220, 3448, 29598, 29606, 3449, 29892, 29908, 29909, 3471
12221, 29598, 29599, 29607, 29606, 29894, 29910, 29911, 29908
12222, 29599, 29600, 29608, 29607, 29896, 29912, 29913, 29910
12223, 29600, 29601, 29609, 29608, 29898, 29914, 29915, 29912
12224, 29601, 29602, 29610, 29609, 29900, 29916, 29917, 29914
12225, 29602, 29603, 29611, 29610, 29902, 29918, 29919, 29916
12226, 29603, 29604, 29612, 29611, 29904, 29920, 29921, 29918
12227, 29604, 29605, 29613, 29612, 29906, 29922, 29923, 29920
12228, 29605, 3499, 3500, 29613, 29907, 3522, 29924, 29922
12229, 3449, 29606, 29614, 3450, 29909, 29925, 29926, 3472
12230, 29606, 29607, 29615, 29614, 29911, 29927, 29928, 29925
12231, 29607, 29608, 29616, 29615, 29913, 29929, 29930, 29927
12232, 29608, 29609, 29617, 29616, 29915, 29931, 29932, 29929
12233, 29609, 29610, 29618, 29617, 29917, 29933, 29934, 29931
12234, 29610, 29611, 29619, 29618, 29919, 29935, 29936, 29933
12235, 29611, 29612, 29620, 29619, 29921, 29937, 29938, 29935
12236, 29612, 29613, 29621, 29620, 29923, 29939, 29940, 29937
12237, 29613, 3500, 3501, 29621, 29924, 3523, 29941, 29939
12238, 3450, 29614, 29622, 3451, 29926, 29942, 29943, 3473
12239, 29614, 29615, 29623, 29622, 29928, 29944, 29945, 29942
12240, 29615, 29616, 29624, 29623, 29930, 29946, 29947, 29944
12241, 29616, 29617, 29625, 29624, 29932, 29948, 29949, 29946
12242, 29617, 29618, 29626, 29625, 29934, 29950, 29951, 29948
12243, 29618, 29619, 29627, 29626, 29936, 29952, 29953, 29950
12244, 29619, 29620, 29628, 29627, 29938, 29954, 29955, 29952
12245, 29620, 29621, 29629, 29628, 29940, 29956, 29957, 29954
12246, 29621, 3501, 3502, 29629, 29941, 3524, 29958, 29956
12247, 3451, 29622, 29630, 3452, 29943, 29959, 29960, 3474
12248, 29622, 29623, 29631, 29630, 29945, 29961, 29962, 29959
12249, 29623, 29624, 29632, 29631, 29947, 29963, 29964, 29961
12250, 29624, 29625, 29633, 29632, 29949, 29965, 29966, 29963
12251, 29625, 29626, 29634, 29633, 29951, 29967, 29968, 29965
12252, 29626, 29627, 29635, 29634, 29953, 29969, 29970, 29967
12253, 29627, 29628, 29636, 29635, 29955, 29971, 29972, 29969
12254, 29628, 29629, 29637, 29636, 29957, 29973, 29974, 29971
12255, 29629, 3502, 3503, 29637, 29958, 3525, 29975, 29973
12256, 3452, 29630, 29638, 3453, 29960, 29976, 29977, 3475
12257, 29630, 29631, 29639, 29638, 29962, 29978, 29979, 29976
12258, 29631, 29632, 29640, 29639, 29964, 29980, 29981, 29978
12259, 29632, 29633, 29641, 29640, 29966, 29982, 29983, 29980
12260, 29633, 29634, 29642, 29641, 29968, 29984, 29985, 29982
12261, 29634, 29635, 29643, 29642, 29970, 29986, 29987, 29984
12262, 29635, 29636, 29644, 29643, 29972, 29988, 29989, 29986
12263, 29636, 29637, 29645, 29644, 29974, 29990, 29991, 29988
12264, 29637, 3503, 3504, 29645, 29975, 3526, 29992, 29990
12265, 3453, 29638, 29646, 3454, 29977, 29993, 29994, 3476
12266, 29638, 29639, 29647, 29646, 29979, 29995, 29996, 29993
12267, 29639, 29640, 29648, 29647, 29981, 29997, 29998, 29995
12268, 29640, 29641, 29649, 29648, 29983, 29999, 30000, 29997
12269, 29641, 29642, 29650, 29649, 29985, 30001, 30002, 29999
12270, 29642, 29643, 29651, 29650, 29987, 30003, 30004, 30001
12271, 29643, 29644, 29652, 29651, 29989, 30005, 30006, 30003
12272, 29644, 29645, 29653, 29652, 29991, 30007, 30008, 30005
12273, 29645, 3504, 3505, 29653, 29992, 3527, 30009, 30007
12274, 3454, 29646, 29654, 3455, 29994, 30010, 30011, 3477
12275, 29646, 29647, 29655, 29654, 29996, 30012, 30013, 30010
12276, 29647, 29648, 29656, 29655, 29998, 30014, 30015, 30012
12277, 29648, 29649, 29657, 29656, 30000, 30016, 30017, 30014
12278, 29649, 29650, 29658, 29657, 30002, 30018, 30019, 30016
12279, 29650, 29651, 29659, 29658, 30004, 30020, 30021, 30018
12280, 29651, 29652, 29660, 29659, 30006, 30022, 30023, 30020
12281, 29652, 29653, 29661, 29660, 30008, 30024, 30025, 30022
12282, 29653, 3505, 3506, 29661, 30009, 3528, 30026, 30024
12283, 3455, 29654, 29662, 3456, 30011, 30027, 30028, 3478
12284, 29654, 29655, 29663, 29662, 30013, 30029, 30030, 30027
12285, 29655, 29656, 29664, 29663, 30015, 30031, 30032, 30029
12286, 29656, 29657, 29665, 29664, 30017, 30033, 30034, 30031
12287, 29657, 29658, 29666, 29665, 30019, 30035, 30036, 30033
12288, 29658, 29659, 29667, 29666, 30021, 30037, 30038, 30035
12289, 29659, 29660, 29668, 29667, 30023, 30039, 30040, 30037
12290, 29660, 29661, 29669, 29668, 30025, 30041, 30042, 30039
12291, 29661, 3506, 3507, 29669, 30026, 3529, 30043, 30041
12292, 3456, 29662, 3555, 98, 30028, 30044, 3564, 3479
12293, 29662, 29663, 3554, 3555, 30030, 30045, 3563, 30044
12294, 29663, 29664, 3553, 3554, 30032, 30046, 3562, 30045
12295, 29664, 29665, 3552, 3553, 30034, 30047, 3561, 30046
12296, 29665, 29666, 3551, 3552, 30036, 30048, 3560, 30047
12297, 29666, 29667, 3550, 3551, 30038, 30049, 3559, 30048
12298, 29667, 29668, 3549, 3550, 30040, 30050, 3558, 30049
12299, 29668, 29669, 3548, 3549, 30042, 30051, 3557, 30050
12300, 29669, 3507, 100, 3548, 30043, 3530, 3556, 30051
*ELEMENT, type=CPS8, ELSET=Surface275
12301, 35, 1184, 30052, 3565, 1206, 30074, 30075, 3566
12302, 1184, 1185, 30053, 30052, 1207, 30076, 30077, 30074
12303, 1185, 1186, 30054, 30053, 1208, 30078, 30079, 30076
12304, 1186, 1187, 30055, 30054, 1209, 30080, 30081, 30078
12305, 1187, 1188, 30056, 30055, 1210, 30082, 30083, 30080
12306, 1188, 1189, 30057, 30056, 1211, 30084, 30085, 30082
12307, 1189, 1190, 30058, 30057, 1212, 30086, 30087, 30084
12308, 1190, 1191, 30059, 30058, 1213, 30088, 30089, 30086
12309, 1191, 1192, 30060, 30059, 1214, 30090, 30091, 30088
12310, 1192, 1193, 30061, 30060, 1215, 30092, 30093, 30090
12311, 1193, 1194, 30062, 30061, 1216, 30094, 30095, 30092
12312, 1194, 1195, 30063, 30062, 1217, 30096, 30097, 30094
12313, 1195, 1196, 30064, 30063, 1218, 30098, 30099, 30096
12314, 1196, 1197, 30065, 30064, 1219, 30100, 30101, 30098
12315, 1197, 1198, 30066, 30065, 1220, 30102, 30103, 30100
12316, 1198, 1199, 30067, 30066, 1221, 30104, 30105, 30102
12317, 1199, 1200, 30068, 30067, 1222, 30106, 30107, 30104
12318, 1200, 1201, 30069, 30068, 1223, 30108, 30109, 30106
12319, 1201, 1202, 30070, 30069, 1224, 30110, 30111, 30108
12320, 1202, 1203, 30071, 30070, 1225, 30112, 30113, 30110
12321, 1203, 1204, 30072, 30071, 1226, 30114, 30115, 30112
12322, 1204, 1205, 30073, 30072, 1227, 30116, 30117, 30114
12323, 1205, 36, 3568, 30073, 1228, 3569, 30118, 30116
12324, 3565, 30052, 3435, 97, 30075, 30119, 3457, 3567
12325, 30052, 30053, 3436, 3435, 30077, 30120, 3458, 30119
12326, 30053, 30054, 3437, 3436, 30079, 30121, 3459, 30120
12327, 30054, 30055, 3438, 3437, 30081, 30122, 3460, 30121
12328, 30055, 30056, 3439, 3438, 30083, 30123, 3461, 30122
12329, 30056, 30057, 3440, 3439, 30085, 30124, 3462, 30123
12330, 30057, 30058, 3441, 3440, 30087, 30125, 3463, 30124
12331, 30058, 30059, 3442, 3441, 30089, 30126, 3464, 30125
12332, 30059, 30060, 3443, 3442, 30091, 30127, 3465, 30126
12333, 30060, 30061, 3444, 3443, 30093, 30128, 3466, 30127
12334, 30061, 30062, 3445, 3444, 30095, 30129, 3467, 30128
12335, 30062, 30063, 3446, 3445, 30097, 30130, 3468, 30129
12336, 30063, 30064, 3447, 3446, 30099, 30131, 3469, 30130
12337, 30064, 30065, 3448, 3447, 30101, 30132, 3470, 30131
12338, 30065, 30066, 3449, 3448, 30103, 30133, 3471, 30132
12339, 30066, 30067, 3450, 3449, 30105, 30134, 3472, 30133
12340, 30067, 30068, 3451, 3450, 30107, 30135, 3473, 30134
12341, 30068, 30069, 3452, 3451, 30109, 30136, 3474, 30135
12342, 30069, 30070, 3453, 3452, 30111, 30137, 3475, 30136
12343, 30070, 30071, 3454, 3453, 30113, 30138, 3476, 30137
12344, 30071, 30072, 3455, 3454, 30115, 30139, 3477, 30138
12345, 30072, 30073, 3456, 3455, 30117, 30140, 3478, 30139
12346, 30073, 3568, 98, 3456, 30118, 3570, 3479, 30140
*ELEMENT, type=CPS8, ELSET=Surface276
12347, 37, 3571, 30141, 1239, 3572, 30163, 30164, 1261
12348, 1239, 30141, 30142, 1240, 30164, 30165, 30166, 1262
12349, 1240, 30142, 30143, 1241, 30166, 30167, 30168, 1263
12350, 1241, 30143, 30144, 1242, 30168, 30169, 30170, 1264
12351, 1242, 30144, 30145, 1243, 30170, 30171, 30172, 1265
12352, 1243, 30145, 30146, 1244, 30172, 30173, 30174, 1266
12353, 1244, 30146, 30147, 1245, 30174, 30175, 30176, 1267
12354, 1245, 30147, 30148, 1246, 30176, 30177, 30178, 1268
12355, 1246, 30148, 30149, 1247, 30178, 30179, 30180, 1269
12356, 1247, 30149, 30150, 1248, 30180, 30181, 30182, 1270
12357, 1248, 30150, 30151, 1249, 30182, 30183, 30184, 1271
12358, 1249, 30151, 30152, 1250, 30184, 30185, 30186, 1272
12359, 1250, 30152, 30153, 1251, 30186, 30187, 30188, 1273
12360, 1251, 30153, 30154, 1252, 30188, 30189, 30190, 1274
12361, 1252, 30154, 30155, 1253, 30190, 30191, 30192, 1275
12362, 1253, 30155, 30156, 1254, 30192, 30193, 30194, 1276
12363, 1254, 30156, 30157, 1255, 30194, 30195, 30196, 1277
12364, 1255, 30157, 30158, 1256, 30196, 30197, 30198, 1278
12365, 1256, 30158, 30159, 1257, 30198, 30199, 30200, 1279
12366, 1257, 30159, 30160, 1258, 30200, 30201, 30202, 1280
12367, 1258, 30160, 30161, 1259, 30202, 30203, 30204, 1281
12368, 1259, 30161, 30162, 1260, 30204, 30205, 30206, 1282
12369, 1260, 30162, 3574, 38, 30206, 30207, 3575, 1283
12370, 3571, 99, 3486, 30141, 3573, 3508, 30208, 30163
12371, 30141, 3486, 3487, 30142, 30208, 3509, 30209, 30165
12372, 30142, 3487, 3488, 30143, 30209, 3510, 30210, 30167
12373, 30143, 3488, 3489, 30144, 30210, 3511, 30211, 30169
12374, 30144, 3489, 3490, 30145, 30211, 3512, 30212, 30171
12375, 30145, 3490, 3491, 30146, 30212, 3513, 30213, 30173
12376, 30146, 3491, 3492, 30147, 30213, 3514, 30214, 30175
12377, 30147, 3492, 3493, 30148, 30214, 3515, 30215, 30177
12378, 30148, 3493, 3494, 30149, 30215, 3516, 30216, 30179
12379, 30149, 3494, 3495, 30150, 30216, 3517, 30217, 30181
12380, 30150, 3495, 3496, 30151, 30217, 3518, 30218, 30183
12381, 30151, 3496, 3497, 30152, 30218, 3519, 30219, 30185
12382, 30152, 3497, 3498, 30153, 30219, 3520, 30220, 30187
12383, 30153, 3498, 3499, 30154, 30220, 3521, 30221, 30189
12384, 30154, 3499, 3500, 30155, 30221, 3522, 30222, 30191
12385, 30155, 3500, 3501, 30156, 30222, 3523, 30223, 30193
12386, 30156, 3501, 3502, 30157, 30223, 3524, 30224, 30195
12387, 30157, 3502, 3503, 30158, 30224, 3525, 30225, 30197
12388, 30158, 3503, 3504, 30159, 30225, 3526, 30226, 30199
12389, 30159, 3504, 3505, 30160, 30226, 3527, 30227, 30201
12390, 30160, 3505, 3506, 30161, 30227, 3528, 30228, 30203
12391, 30161, 3506, 3507, 30162, 30228, 3529, 30229, 30205
12392, 30162, 3507, 100, 3574, 30229, 3530, 3576, 30207
*ELEMENT, type=CPS8, ELSET=Surface277
12393, 35, 3565, 30230, 1291, 3566, 30238, 30239, 1300
12394, 1291, 30230, 30231, 1290, 30239, 30240, 30241, 1299
12395, 1290, 30231, 30232, 1289, 30241, 30242, 30243, 1298
12396, 1289, 30232, 30233, 1288, 30243, 30244, 30245, 1297
12397, 1288, 30233, 30234, 1287, 30245, 30246, 30247, 1296
12398, 1287, 30234, 30235, 1286, 30247, 30248, 30249, 1295
12399, 1286, 30235, 30236, 1285, 30249, 30250, 30251, 1294
12400, 1285, 30236, 30237, 1284, 30251, 30252, 30253, 1293
12401, 1284, 30237, 3571, 37, 30253, 30254, 3572, 1292
12402, 3565, 97, 3538, 30230, 3567, 3547, 30255, 30238
12403, 30230, 3538, 3537, 30231, 30255, 3546, 30256, 30240
12404, 30231, 3537, 3536, 30232, 30256, 3545, 30257, 30242
12405, 30232, 3536, 3535, 30233, 30257, 3544, 30258, 30244
12406, 30233, 3535, 3534, 30234, 30258, 3543, 30259, 30246
12407, 30234, 3534, 3533, 30235, 30259, 3542, 30260, 30248
12408, 30235, 3533, 3532, 30236, 30260, 3541, 30261, 30250
12409, 30236, 3532, 3531, 30237, 30261, 3540, 30262, 30252
12410, 30237, 3531, 99, 3571, 30262, 3539, 3573, 30254
*ELEMENT, type=CPS8, ELSET=Surface278
12411, 36, 1308, 30263, 3568, 1317, 30271, 30272, 3569
12412, 1308, 1307, 30264, 30263, 1316, 30273, 30274, 30271
12413, 1307, 1306, 30265, 30264, 1315, 30275, 30276, 30273
12414, 1306, 1305, 30266, 30265, 1314, 30277, 30278, 30275
12415, 1305, 1304, 30267, 30266, 1313, 30279, 30280, 30277
12416, 1304, 1303, 30268, 30267, 1312, 30281, 30282, 30279
12417, 1303, 1302, 30269, 30268, 1311, 30283, 30284, 30281
12418, 1302, 1301, 30270, 30269, 1310, 30285, 30286, 30283
12419, 1301, 38, 3574, 30270, 1309, 3575, 30287, 30285
12420, 3568, 30263, 3555, 98, 30272, 30288, 3564, 3570
12421, 30263, 30264, 3554, 3555, 30274, 30289, 3563, 30288
12422, 30264, 30265, 3553, 3554, 30276, 30290, 3562, 30289
12423, 30265, 30266, 3552, 3553, 30278, 30291, 3561, 30290
12424, 30266, 30267, 3551, 3552, 30280, 30292, 3560, 30291
12425, 30267, 30268, 3550, 3551, 30282, 30293, 3559, 30292
12426, 30268, 30269, 3549, 3550, 30284, 30294, 3558, 30293
12427, 30269, 30270, 3548, 3549, 30286, 30295, 3557, 30294
12428, 30270, 3574, 100, 3548, 30287, 3576, 3556, 30295
*ELEMENT, type=CPS8, ELSET=Surface279
12429, 24, 680, 30296, 3577, 703, 30318, 30319, 3578
12430, 680, 679, 30297, 30296, 702, 30320, 30321, 30318
12431, 679, 678, 30298, 30297, 701, 30322, 30323, 30320
12432, 678, 677, 30299, 30298, 700, 30324, 30325, 30322
12433, 677, 676, 30300, 30299, 699, 30326, 30327, 30324
12434, 676, 675, 30301, 30300, 698, 30328, 30329, 30326
12435, 675, 674, 30302, 30301, 697, 30330, 30331, 30328
12436, 674, 673, 30303, 30302, 696, 30332, 30333, 30330
12437, 673, 672, 30304, 30303, 695, 30334, 30335, 30332
12438, 672, 671, 30305, 30304, 694, 30336, 30337, 30334
12439, 671, 670, 30306, 30305, 693, 30338, 30339, 30336
12440, 670, 669, 30307, 30306, 692, 30340, 30341, 30338
12441, 669, 668, 30308, 30307, 691, 30342, 30343, 30340
12442, 668, 667, 30309, 30308, 690, 30344, 30345, 30342
12443, 667, 666, 30310, 30309, 689, 30346, 30347, 30344
12444, 666, 665, 30311, 30310, 688, 30348, 30349, 30346
12445, 665, 664, 30312, 30311, 687, 30350, 30351, 30348
12446, 664, 663, 30313, 30312, 686, 30352, 30353, 30350
12447, 663, 662, 30314, 30313, 685, 30354, 30355, 30352
12448, 662, 661, 30315, 30314, 684, 30356, 30357, 30354
12449, 661, 660, 30316, 30315, 683, 30358, 30359, 30356
12450, 660, 659, 30317, 30316, 682, 30360, 30361, 30358
12451, 659, 15, 3580, 30317, 681, 3581, 30362, 30360
12452, 3577, 30296, 2712, 85, 30319, 30363, 2735, 3579
12453, 30296, 30297, 2711, 2712, 30321, 30364, 2734, 30363
12454, 30297, 30298, 2710, 2711, 30323, 30365, 2733, 30364
12455, 30298, 30299, 2709, 2710, 30325, 30366, 2732, 30365
12456, 30299, 30300, 2708, 2709, 30327, 30367, 2731, 30366
12457, 30300, 30301, 2707, 2708, 30329, 30368, 2730, 30367
12458, 30301, 30302, 2706, 2707, 30331, 30369, 2729, 30368
12459, 30302, 30303, 2705, 2706, 30333, 30370, 2728, 30369
12460, 30303, 30304, 2704, 2705, 30335, 30371, 2727, 30370
12461, 30304, 30305, 2703, 2704, 30337, 30372, 2726, 30371
12462, 30305, 30306, 2702, 2703, 30339, 30373, 2725, 30372
12463, 30306, 30307, 2701, 2702, 30341, 30374, 2724, 30373
12464, 30307, 30308, 2700, 2701, 30343, 30375, 2723, 30374
12465, 30308, 30309, 2699, 2700, 30345, 30376, 2722, 30375
12466, 30309, 30310, 2698, 2699, 30347, 30377, 2721, 30376
12467, 30310, 30311, 2697, 2698, 30349, 30378, 2720, 30377
12468, 30311, 30312, 2696, 2697, 30351, 30379, 2719, 30378
12469, 30312, 30313, 2695, 2696, 30353, 30380, 2718, 30379
12470, 30313, 30314, 2694, 2695, 30355, 30381, 2717, 30380
12471, 30314, 30315, 2693, 2694, 30357, 30382, 2716, 30381
12472, 30315, 30316, 2692, 2693, 30359, 30383, 2715, 30382
12473, 30316, 30317, 2691, 2692, 30361, 30384, 2714, 30383
12474, 30317, 3580, 86, 2691, 30362, 3582, 2713, 30384
*ELEMENT, type=CPS8, ELSET=Surface280
12475, 23, 554, 30385, 3583, 563, 30393, 30394, 3584
12476, 554, 553, 30386, 30385, 562, 30395, 30396, 30393
12477, 553, 552, 30387, 30386, 561, 30397, 30398, 30395
12478, 552, 551, 30388, 30387, 560, 30399, 30400, 30397
12479, 551, 550, 30389, 30388, 559, 30401, 30402, 30399
12480, 550, 549, 30390, 30389, 558, 30403, 30404, 30401
12481, 549, 548, 30391, 30390, 557, 30405, 30406, 30403
12482, 548, 547, 30392, 30391, 556, 30407, 30408, 30405
12483, 547, 24, 3577, 30392, 555, 3578, 30409, 30407
12484, 3583, 30385, 2746, 87, 30394, 30410, 2755, 3585
12485, 30385, 30386, 2745, 2746, 30396, 30411, 2754, 30410
12486, 30386, 30387, 2744, 2745, 30398, 30412, 2753, 30411
12487, 30387, 30388, 2743, 2744, 30400, 30413, 2752, 30412
12488, 30388, 30389, 2742, 2743, 30402, 30414, 2751, 30413
12489, 30389, 30390, 2741, 2742, 30404, 30415, 2750, 30414
12490, 30390, 30391, 2740, 2741, 30406, 30416, 2749, 30415
12491, 30391, 30392, 2739, 2740, 30408, 30417, 2748, 30416
12492, 30392, 3577, 85, 2739, 30409, 3579, 2747, 30417
*ELEMENT, type=CPS8, ELSET=Surface281
12493, 23, 3583, 30418, 725, 3584, 30440, 30441, 748
12494, 725, 30418, 30419, 724, 30441, 30442, 30443, 747
12495, 724, 30419, 30420, 723, 30443, 30444, 30445, 746
12496, 723, 30420, 30421, 722, 30445, 30446, 30447, 745
12497, 722, 30421, 30422, 721, 30447, 30448, 30449, 744
12498, 721, 30422, 30423, 720, 30449, 30450, 30451, 743
12499, 720, 30423, 30424, 719, 30451, 30452, 30453, 742
12500, 719, 30424, 30425, 718, 30453, 30454, 30455, 741
12501, 718, 30425, 30426, 717, 30455, 30456, 30457, 740
12502, 717, 30426, 30427, 716, 30457, 30458, 30459, 739
12503, 716, 30427, 30428, 715, 30459, 30460, 30461, 738
12504, 715, 30428, 30429, 714, 30461, 30462, 30463, 737
12505, 714, 30429, 30430, 713, 30463, 30464, 30465, 736
12506, 713, 30430, 30431, 712, 30465, 30466, 30467, 735
12507, 712, 30431, 30432, 711, 30467, 30468, 30469, 734
12508, 711, 30432, 30433, 710, 30469, 30470, 30471, 733
12509, 710, 30433, 30434, 709, 30471, 30472, 30473, 732
12510, 709, 30434, 30435, 708, 30473, 30474, 30475, 731
12511, 708, 30435, 30436, 707, 30475, 30476, 30477, 730
12512, 707, 30436, 30437, 706, 30477, 30478, 30479, 729
12513, 706, 30437, 30438, 705, 30479, 30480, 30481, 728
12514, 705, 30438, 30439, 704, 30481, 30482, 30483, 727
12515, 704, 30439, 3586, 9, 30483, 30484, 3587, 726
12516, 3583, 87, 2780, 30418, 3585, 2803, 30485, 30440
12517, 30418, 2780, 2779, 30419, 30485, 2802, 30486, 30442
12518, 30419, 2779, 2778, 30420, 30486, 2801, 30487, 30444
12519, 30420, 2778, 2777, 30421, 30487, 2800, 30488, 30446
12520, 30421, 2777, 2776, 30422, 30488, 2799, 30489, 30448
12521, 30422, 2776, 2775, 30423, 30489, 2798, 30490, 30450
12522, 30423, 2775, 2774, 30424, 30490, 2797, 30491, 30452
12523, 30424, 2774, 2773, 30425, 30491, 2796, 30492, 30454
12524, 30425, 2773, 2772, 30426, 30492, 2795, 30493, 30456
12525, 30426, 2772, 2771, 30427, 30493, 2794, 30494, 30458
12526, 30427, 2771, 2770, 30428, 30494, 2793, 30495, 30460
12527, 30428, 2770, 2769, 30429, 30495, 2792, 30496, 30462
12528, 30429, 2769, 2768, 30430, 30496, 2791, 30497, 30464
12529, 30430, 2768, 2767, 30431, 30497, 2790, 30498, 30466
12530, 30431, 2767, 2766, 30432, 30498, 2789, 30499, 30468
12531, 30432, 2766, 2765, 30433, 30499, 2788, 30500, 30470
12532, 30433, 2765, 2764, 30434, 30500, 2787, 30501, 30472
12533, 30434, 2764, 2763, 30435, 30501, 2786, 30502, 30474
12534, 30435, 2763, 2762, 30436, 30502, 2785, 30503, 30476
12535, 30436, 2762, 2761, 30437, 30503, 2784, 30504, 30478
12536, 30437, 2761, 2760, 30438, 30504, 2783, 30505, 30480
12537, 30438, 2760, 2759, 30439, 30505, 2782, 30506, 30482
12538, 30439, 2759, 88, 3586, 30506, 2781, 3588, 30484
*ELEMENT, type=CPS8, ELSET=Surface282
12539, 9, 3586, 30507, 420, 3587, 30515, 30516, 429
12540, 420, 30507, 30508, 419, 30516, 30517, 30518, 428
12541, 419, 30508, 30509, 418, 30518, 30519, 30520, 427
12542, 418, 30509, 30510, 417, 30520, 30521, 30522, 426
12543, 417, 30510, 30511, 416, 30522, 30523, 30524, 425
12544, 416, 30511, 30512, 415, 30524, 30525, 30526, 424
12545, 415, 30512, 30513, 414, 30526, 30527, 30528, 423
12546, 414, 30513, 30514, 413, 30528, 30529, 30530, 422
12547, 413, 30514, 3580, 15, 30530, 30531, 3581, 421
12548, 3586, 88, 2811, 30507, 3588, 2820, 30532, 30515
12549, 30507, 2811, 2810, 30508, 30532, 2819, 30533, 30517
12550, 30508, 2810, 2809, 30509, 30533, 2818, 30534, 30519
12551, 30509, 2809, 2808, 30510, 30534, 2817, 30535, 30521
12552, 30510, 2808, 2807, 30511, 30535, 2816, 30536, 30523
12553, 30511, 2807, 2806, 30512, 30536, 2815, 30537, 30525
12554, 30512, 2806, 2805, 30513, 30537, 2814, 30538, 30527
12555, 30513, 2805, 2804, 30514, 30538, 2813, 30539, 30529
12556, 30514, 2804, 86, 3580, 30539, 2812, 3582, 30531
*ELEMENT, type=CPS8, ELSET=Surface293
12557, 67, 3589, 30540, 2035, 3590, 30562, 30563, 2058
12558, 2035, 30540, 30541, 2034, 30563, 30564, 30565, 2057
12559, 2034, 30541, 30542, 2033, 30565, 30566, 30567, 2056
12560, 2033, 30542, 30543, 2032, 30567, 30568, 30569, 2055
12561, 2032, 30543, 30544, 2031, 30569, 30570, 30571, 2054
12562, 2031, 30544, 30545, 2030, 30571, 30572, 30573, 2053
12563, 2030, 30545, 30546, 2029, 30573, 30574, 30575, 2052
12564, 2029, 30546, 30547, 2028, 30575, 30576, 30577, 2051
12565, 2028, 30547, 30548, 2027, 30577, 30578, 30579, 2050
12566, 2027, 30548, 30549, 2026, 30579, 30580, 30581, 2049
12567, 2026, 30549, 30550, 2025, 30581, 30582, 30583, 2048
12568, 2025, 30550, 30551, 2024, 30583, 30584, 30585, 2047
12569, 2024, 30551, 30552, 2023, 30585, 30586, 30587, 2046
12570, 2023, 30552, 30553, 2022, 30587, 30588, 30589, 2045
12571, 2022, 30553, 30554, 2021, 30589, 30590, 30591, 2044
12572, 2021, 30554, 30555, 2020, 30591, 30592, 30593, 2043
12573, 2020, 30555, 30556, 2019, 30593, 30594, 30595, 2042
12574, 2019, 30556, 30557, 2018, 30595, 30596, 30597, 2041
12575, 2018, 30557, 30558, 2017, 30597, 30598, 30599, 2040
12576, 2017, 30558, 30559, 2016, 30599, 30600, 30601, 2039
12577, 2016, 30559, 30560, 2015, 30601, 30602, 30603, 2038
12578, 2015, 30560, 30561, 2014, 30603, 30604, 30605, 2037
12579, 2014, 30561, 3592, 68, 30605, 30606, 3593, 2036
12580, 3589, 89, 2932, 30540, 3591, 2955, 30607, 30562
12581, 30540, 2932, 2931, 30541, 30607, 2954, 30608, 30564
12582, 30541, 2931, 2930, 30542, 30608, 2953, 30609, 30566
12583, 30542, 2930, 2929, 30543, 30609, 2952, 30610, 30568
12584, 30543, 2929, 2928, 30544, 30610, 2951, 30611, 30570
12585, 30544, 2928, 2927, 30545, 30611, 2950, 30612, 30572
12586, 30545, 2927, 2926, 30546, 30612, 2949, 30613, 30574
12587, 30546, 2926, 2925, 30547, 30613, 2948, 30614, 30576
12588, 30547, 2925, 2924, 30548, 30614, 2947, 30615, 30578
12589, 30548, 2924, 2923, 30549, 30615, 2946, 30616, 30580
12590, 30549, 2923, 2922, 30550, 30616, 2945, 30617, 30582
12591, 30550, 2922, 2921, 30551, 30617, 2944, 30618, 30584
12592, 30551, 2921, 2920, 30552, 30618, 2943, 30619, 30586
12593, 30552, 2920, 2919, 30553, 30619, 2942, 30620, 30588
12594, 30553, 2919, 2918, 30554, 30620, 2941, 30621, 30590
12595, 30554, 2918, 2917, 30555, 30621, 2940, 30622, 30592
12596, 30555, 2917, 2916, 30556, 30622, 2939, 30623, 30594
12597, 30556, 2916, 2915, 30557, 30623, 2938, 30624, 30596
12598, 30557, 2915, 2914, 30558, 30624, 2937, 30625, 30598
12599, 30558, 2914, 2913, 30559, 30625, 2936, 30626, 30600
12600, 30559, 2913, 2912, 30560, 30626, 2935, 30627, 30602
12601, 30560, 2912, 2911, 30561, 30627, 2934, 30628, 30604
12602, 30561, 2911, 90, 3592, 30628, 2933, 3594, 30606
*ELEMENT, type=CPS8, ELSET=Surface294
12603, 69, 3595, 30629, 2069, 3596, 30637, 30638, 2078
12604, 2069, 30629, 30630, 2068, 30638, 30639, 30640, 2077
12605, 2068, 30630, 30631, 2067, 30640, 30641, 30642, 2076
12606, 2067, 30631, 30632, 2066, 30642, 30643, 30644, 2075
12607, 2066, 30632, 30633, 2065, 30644, 30645, 30646, 2074
12608, 2065, 30633, 30634, 2064, 30646, 30647, 30648, 2073
12609, 2064, 30634, 30635, 2063, 30648, 30649, 30650, 2072
12610, 2063, 30635, 30636, 2062, 30650, 30651, 30652, 2071
12611, 2062, 30636, 3589, 67, 30652, 30653, 3590, 2070
12612, 3595, 91, 3008, 30629, 3597, 3017, 30654, 30637
12613, 30629, 3008, 3007, 30630, 30654, 3016, 30655, 30639
12614, 30630, 3007, 3006, 30631, 30655, 3015, 30656, 30641
12615, 30631, 3006, 3005, 30632, 30656, 3014, 30657, 30643
12616, 30632, 3005, 3004, 30633, 30657, 3013, 30658, 30645
12617, 30633, 3004, 3003, 30634, 30658, 3012, 30659, 30647
12618, 30634, 3003, 3002, 30635, 30659, 3011, 30660, 30649
12619, 30635, 3002, 3001, 30636, 30660, 3010, 30661, 30651
12620, 30636, 3001, 89, 3589, 30661, 3009, 3591, 30653
*ELEMENT, type=CPS8, ELSET=Surface295
12621, 69, 2103, 30662, 3595, 2126, 30684, 30685, 3596
12622, 2103, 2102, 30663, 30662, 2125, 30686, 30687, 30684
12623, 2102, 2101, 30664, 30663, 2124, 30688, 30689, 30686
12624, 2101, 2100, 30665, 30664, 2123, 30690, 30691, 30688
12625, 2100, 2099, 30666, 30665, 2122, 30692, 30693, 30690
12626, 2099, 2098, 30667, 30666, 2121, 30694, 30695, 30692
12627, 2098, 2097, 30668, 30667, 2120, 30696, 30697, 30694
12628, 2097, 2096, 30669, 30668, 2119, 30698, 30699, 30696
12629, 2096, 2095, 30670, 30669, 2118, 30700, 30701, 30698
12630, 2095, 2094, 30671, 30670, 2117, 30702, 30703, 30700
12631, 2094, 2093, 30672, 30671, 2116, 30704, 30705, 30702
12632, 2093, 2092, 30673, 30672, 2115, 30706, 30707, 30704
12633, 2092, 2091, 30674, 30673, 2114, 30708, 30709, 30706
12634, 2091, 2090, 30675, 30674, 2113, 30710, 30711, 30708
12635, 2090, 2089, 30676, 30675, 2112, 30712, 30713, 30710
12636, 2089, 2088, 30677, 30676, 2111, 30714, 30715, 30712
12637, 2088, 2087, 30678, 30677, 2110, 30716, 30717, 30714
12638, 2087, 2086, 30679, 30678, 2109, 30718, 30719, 30716
12639, 2086, 2085, 30680, 30679, 2108, 30720, 30721, 30718
12640, 2085, 2084, 30681, 30680, 2107, 30722, 30723, 30720
12641, 2084, 2083, 30682, 30681, 2106, 30724, 30725, 30722
12642, 2083, 2082, 30683, 30682, 2105, 30726, 30727, 30724
12643, 2082, 70, 3598, 30683, 2104, 3599, 30728, 30726
12644, 3595, 30662, 3084, 91, 30685, 30729, 3107, 3597
12645, 30662, 30663, 3083, 3084, 30687, 30730, 3106, 30729
12646, 30663, 30664, 3082, 3083, 30689, 30731, 3105, 30730
12647, 30664, 30665, 3081, 3082, 30691, 30732, 3104, 30731
12648, 30665, 30666, 3080, 3081, 30693, 30733, 3103, 30732
12649, 30666, 30667, 3079, 3080, 30695, 30734, 3102, 30733
12650, 30667, 30668, 3078, 3079, 30697, 30735, 3101, 30734
12651, 30668, 30669, 3077, 3078, 30699, 30736, 3100, 30735
12652, 30669, 30670, 3076, 3077, 30701, 30737, 3099, 30736
12653, 30670, 30671, 3075, 3076, 30703, 30738, 3098, 30737
12654, 30671, 30672, 3074, 3075, 30705, 30739, 3097, 30738
12655, 30672, 30673, 3073, 3074, 30707, 30740, 3096, 30739
12656, 30673, 30674, 3072, 3073, 30709, 30741, 3095, 30740
12657, 30674, 30675, 3071, 3072, 30711, 30742, 3094, 30741
12658, 30675, 30676, 3070, 3071, 30713, 30743, 3093, 30742
12659, 30676, 30677, 3069, 3070, 30715, 30744, 3092, 30743
12660, 30677, 30678, 3068, 3069, 30717, 30745, 3091, 30744
12661, 30678, 30679, 3067, 3068, 30719, 30746, 3090, 30745
12662, 30679, 30680, 3066, 3067, 30721, 30747, 3089, 30746
12663, 30680, 30681, 3065, 3066, 30723, 30748, 3088, 30747
12664, 30681, 30682, 3064, 3065, 30725, 30749, 3087, 30748
12665, 30682, 30683, 3063, 3064, 30727, 30750, 3086, 30749
12666, 30683, 3598, 92, 3063, 30728, 3600, 3085, 30750
*ELEMENT, type=CPS8, ELSET=Surface296
12667, 70, 2134, 30751, 3598, 2143, 30759, 30760, 3599
12668, 2134, 2133, 30752, 30751, 2142, 30761, 30762, 30759
12669, 2133, 2132, 30753, 30752, 2141, 30763, 30764, 30761
12670, 2132, 2131, 30754, 30753, 2140, 30765, 30766, 30763
12671, 2131, 2130, 30755, 30754, 2139, 30767, 30768, 30765
12672, 2130, 2129, 30756, 30755, 2138, 30769, 30770, 30767
12673, 2129, 2128, 30757, 30756, 2137, 30771, 30772, 30769
12674, 2128, 2127, 30758, 30757, 2136, 30773, 30774, 30771
12675, 2127, 68, 3592, 30758, 2135, 3593, 30775, 30773
12676, 3598, 30751, 3115, 92, 30760, 30776, 3124, 3600
12677, 30751, 30752, 3114, 3115, 30762, 30777, 3123, 30776
12678, 30752, 30753, 3113, 3114, 30764, 30778, 3122, 30777
12679, 30753, 30754, 3112, 3113, 30766, 30779, 3121, 30778
12680, 30754, 30755, 3111, 3112, 30768, 30780, 3120, 30779
12681, 30755, 30756, 3110, 3111, 30770, 30781, 3119, 30780
12682, 30756, 30757, 3109, 3110, 30772, 30782, 3118, 30781
12683, 30757, 30758, 3108, 3109, 30774, 30783, 3117, 30782
12684, 30758, 3592, 90, 3108, 30775, 3594, 3116, 30783
*ELEMENT, type=CPS8, ELSET=Surface297
12685, 71, 3601, 30784, 2195, 3602, 30806, 30807, 2217
12686, 2195, 30784, 30785, 2196, 30807, 30808, 30809, 2218
12687, 2196, 30785, 30786, 2197, 30809, 30810, 30811, 2219
12688, 2197, 30786, 30787, 2198, 30811, 30812, 30813, 2220
12689, 2198, 30787, 30788, 2199, 30813, 30814, 30815, 2221
12690, 2199, 30788, 30789, 2200, 30815, 30816, 30817, 2222
12691, 2200, 30789, 30790, 2201, 30817, 30818, 30819, 2223
12692, 2201, 30790, 30791, 2202, 30819, 30820, 30821, 2224
12693, 2202, 30791, 30792, 2203, 30821, 30822, 30823, 2225
12694, 2203, 30792, 30793, 2204, 30823, 30824, 30825, 2226
12695, 2204, 30793, 30794, 2205, 30825, 30826, 30827, 2227
12696, 2205, 30794, 30795, 2206, 30827, 30828, 30829, 2228
12697, 2206, 30795, 30796, 2207, 30829, 30830, 30831, 2229
12698, 2207, 30796, 30797, 2208, 30831, 30832, 30833, 2230
12699, 2208, 30797, 30798, 2209, 30833, 30834, 30835, 2231
12700, 2209, 30798, 30799, 2210, 30835, 30836, 30837, 2232
12701, 2210, 30799, 30800, 2211, 30837, 30838, 30839, 2233
12702, 2211, 30800, 30801, 2212, 30839, 30840, 30841, 2234
12703, 2212, 30801, 30802, 2213, 30841, 30842, 30843, 2235
12704, 2213, 30802, 30803, 2214, 30843, 30844, 30845, 2236
12705, 2214, 30803, 30804, 2215, 30845, 30846, 30847, 2237
12706, 2215, 30804, 30805, 2216, 30847, 30848, 30849, 2238
12707, 2216, 30805, 3604, 73, 30849, 30850, 3605, 2239
12708, 3601, 93, 3215, 30784, 3603, 3237, 30851, 30806
12709, 30784, 3215, 3216, 30785, 30851, 3238, 30852, 30808
12710, 30785, 3216, 3217, 30786, 30852, 3239, 30853, 30810
12711, 30786, 3217, 3218, 30787, 30853, 3240, 30854, 30812
12712, 30787, 3218, 3219, 30788, 30854, 3241, 30855, 30814
12713, 30788, 3219, 3220, 30789, 30855, 3242, 30856, 30816
12714, 30789, 3220, 3221, 30790, 30856, 3243, 30857, 30818
12715, 30790, 3221, 3222, 30791, 30857, 3244, 30858, 30820
12716, 30791, 3222, 3223, 30792, 30858, 3245, 30859, 30822
12717, 30792, 3223, 3224, 30793, 30859, 3246, 30860, 30824
12718, 30793, 3224, 3225, 30794, 30860, 3247, 30861, 30826
12719, 30794, 3225, 3226, 30795, 30861, 3248, 30862, 30828
12720, 30795, 3226, 3227, 30796, 30862, 3249, 30863, 30830
12721, 30796, 3227, 3228, 30797, 30863, 3250, 30864, 30832
12722, 30797, 3228, 3229, 30798, 30864, 3251, 30865, 30834
12723, 30798, 3229, 3230, 30799, 30865, 3252, 30866, 30836
12724, 30799, 3230, 3231, 30800, 30866, 3253, 30867, 30838
12725, 30800, 3231, 3232, 30801, 30867, 3254, 30868, 30840
12726, 30801, 3232, 3233, 30802, 30868, 3255, 30869, 30842
12727, 30802, 3233, 3234, 30803, 30869, 3256, 30870, 30844
12728, 30803, 3234, 3235, 30804, 30870, 3257, 30871, 30846
12729, 30804, 3235, 3236, 30805, 30871, 3258, 30872, 30848
12730, 30805, 3236, 94, 3604, 30872, 3259, 3606, 30850
*ELEMENT, type=CPS8, ELSET=Surface298
12731, 74, 2291, 30873, 3607, 2313, 30895, 30896, 3608
12732, 2291, 2292, 30874, 30873, 2314, 30897, 30898, 30895
12733, 2292, 2293, 30875, 30874, 2315, 30899, 30900, 30897
12734, 2293, 2294, 30876, 30875, 2316, 30901, 30902, 30899
12735, 2294, 2295, 30877, 30876, 2317, 30903, 30904, 30901
12736, 2295, 2296, 30878, 30877, 2318, 30905, 30906, 30903
12737, 2296, 2297, 30879, 30878, 2319, 30907, 30908, 30905
12738, 2297, 2298, 30880, 30879, 2320, 30909, 30910, 30907
12739, 2298, 2299, 30881, 30880, 2321, 30911, 30912, 30909
12740, 2299, 2300, 30882, 30881, 2322, 30913, 30914, 30911
12741, 2300, 2301, 30883, 30882, 2323, 30915, 30916, 30913
12742, 2301, 2302, 30884, 30883, 2324, 30917, 30918, 30915
12743, 2302, 2303, 30885, 30884, 2325, 30919, 30920, 30917
12744, 2303, 2304, 30886, 30885, 2326, 30921, 30922, 30919
12745, 2304, 2305, 30887, 30886, 2327, 30923, 30924, 30921
12746, 2305, 2306, 30888, 30887, 2328, 30925, 30926, 30923
12747, 2306, 2307, 30889, 30888, 2329, 30927, 30928, 30925
12748, 2307, 2308, 30890, 30889, 2330, 30929, 30930, 30927
12749, 2308, 2309, 30891, 30890, 2331, 30931, 30932, 30929
12750, 2309, 2310, 30892, 30891, 2332, 30933, 30934, 30931
12751, 2310, 2311, 30893, 30892, 2333, 30935, 30936, 30933
12752, 2311, 2312, 30894, 30893, 2334, 30937, 30938, 30935
12753, 2312, 76, 3610, 30894, 2335, 3611, 30939, 30937
12754, 3607, 30873, 3350, 95, 30896, 30940, 3372, 3609
12755, 30873, 30874, 3351, 3350, 30898, 30941, 3373, 30940
12756, 30874, 30875, 3352, 3351, 30900, 30942, 3374, 30941
12757, 30875, 30876, 3353, 3352, 30902, 30943, 3375, 30942
12758, 30876, 30877, 3354, 3353, 30904, 30944, 3376, 30943
12759, 30877, 30878, 3355, 3354, 30906, 30945, 3377, 30944
12760, 30878, 30879, 3356, 3355, 30908, 30946, 3378, 30945
12761, 30879, 30880, 3357, 3356, 30910, 30947, 3379, 30946
12762, 30880, 30881, 3358, 3357, 30912, 30948, 3380, 30947
12763, 30881, 30882, 3359, 3358, 30914, 30949, 3381, 30948
12764, 30882, 30883, 3360, 3359, 30916, 30950, 3382, 30949
12765, 30883, 30884, 3361, 3360, 30918, 30951, 3383, 30950
12766, 30884, 30885, 3362, 3361, 30920, 30952, 3384, 30951
12767, 30885, 30886, 3363, 3362, 30922, 30953, 3385, 30952
12768, 30886, 30887, 3364, 3363, 30924, 30954, 3386, 30953
12769, 30887, 30888, 3365, 3364, 30926, 30955, 3387, 30954
12770, 30888, 30889, 3366, 3365, 30928, 30956, 3388, 30955
12771, 30889, 30890, 3367, 3366, 30930, 30957, 3389, 30956
12772, 30890, 30891, 3368, 3367, 30932, 30958, 3390, 30957
12773, 30891, 30892, 3369, 3368, 30934, 30959, 3391, 30958
12774, 30892, 30893, 3370, 3369, 30936, 30960, 3392, 30959
12775, 30893, 30894, 3371, 3370, 30938, 30961, 3393, 30960
12776, 30894, 3610, 96, 3371, 30939, 3612, 3394, 30961
*ELEMENT, type=CPS8, ELSET=Surface299
12777, 71, 2343, 30962, 3601, 2352, 30970, 30971, 3602
12778, 2343, 2342, 30963, 30962, 2351, 30972, 30973, 30970
12779, 2342, 2341, 30964, 30963, 2350, 30974, 30975, 30972
12780, 2341, 2340, 30965, 30964, 2349, 30976, 30977, 30974
12781, 2340, 2339, 30966, 30965, 2348, 30978, 30979, 30976
12782, 2339, 2338, 30967, 30966, 2347, 30980, 30981, 30978
12783, 2338, 2337, 30968, 30967, 2346, 30982, 30983, 30980
12784, 2337, 2336, 30969, 30968, 2345, 30984, 30985, 30982
12785, 2336, 74, 3607, 30969, 2344, 3608, 30986, 30984
12786, 3601, 30962, 3402, 93, 30971, 30987, 3411, 3603
12787, 30962, 30963, 3401, 3402, 30973, 30988, 3410, 30987
12788, 30963, 30964, 3400, 3401, 30975, 30989, 3409, 30988
12789, 30964, 30965, 3399, 3400, 30977, 30990, 3408, 30989
12790, 30965, 30966, 3398, 3399, 30979, 30991, 3407, 30990
12791, 30966, 30967, 3397, 3398, 30981, 30992, 3406, 30991
12792, 30967, 30968, 3396, 3397, 30983, 30993, 3405, 30992
12793, 30968, 30969, 3395, 3396, 30985, 30994, 3404, 30993
12794, 30969, 3607, 95, 3395, 30986, 3609, 3403, 30994
*ELEMENT, type=CPS8, ELSET=Surface300
12795, 73, 3604, 30995, 2377, 3605, 31003, 31004, 2386
12796, 2377, 30995, 30996, 2376, 31004, 31005, 31006, 2385
12797, 2376, 30996, 30997, 2375, 31006, 31007, 31008, 2384
12798, 2375, 30997, 30998, 2374, 31008, 31009, 31010, 2383
12799, 2374, 30998, 30999, 2373, 31010, 31011, 31012, 2382
12800, 2373, 30999, 31000, 2372, 31012, 31013, 31014, 2381
12801, 2372, 31000, 31001, 2371, 31014, 31015, 31016, 2380
12802, 2371, 31001, 31002, 2370, 31016, 31017, 31018, 2379
12803, 2370, 31002, 3610, 76, 31018, 31019, 3611, 2378
12804, 3604, 94, 3419, 30995, 3606, 3428, 31020, 31003
12805, 30995, 3419, 3418, 30996, 31020, 3427, 31021, 31005
12806, 30996, 3418, 3417, 30997, 31021, 3426, 31022, 31007
12807, 30997, 3417, 3416, 30998, 31022, 3425, 31023, 31009
12808, 30998, 3416, 3415, 30999, 31023, 3424, 31024, 31011
12809, 30999, 3415, 3414, 31000, 31024, 3423, 31025, 31013
12810, 31000, 3414, 3413, 31001, 31025, 3422, 31026, 31015
12811, 31001, 3413, 3412, 31002, 31026, 3421, 31027, 31017
12812, 31002, 3412, 96, 3610, 31027, 3420, 3612, 31019
*ELEMENT, type=CPS8, ELSET=Surface301
12813, 1, 3613, 31028, 2821, 3616, 31094, 31095, 2843
12814, 2821, 31028, 31029, 2822, 31095, 31096, 31097, 2844
12815, 2822, 31029, 31030, 2823, 31097, 31098, 31099, 2845
12816, 2823, 31030, 31031, 2824, 31099, 31100, 31101, 2846
12817, 2824, 31031, 31032, 2825, 31101, 31102, 31103, 2847
12818, 2825, 31032, 31033, 2826, 31103, 31104, 31105, 2848
12819, 2826, 31033, 31034, 2827, 31105, 31106, 31107, 2849
12820, 2827, 31034, 31035, 2828, 31107, 31108, 31109, 2850
12821, 2828, 31035, 31036, 2829, 31109, 31110, 31111, 2851
12822, 2829, 31036, 31037, 2830, 31111, 31112, 31113, 2852
12823, 2830, 31037, 31038, 2831, 31113, 31114, 31115, 2853
12824, 2831, 31038, 31039, 2832, 31115, 31116, 31117, 2854
12825, 2832, 31039, 31040, 2833, 31117, 31118, 31119, 2855
12826, 2833, 31040, 31041, 2834, 31119, 31120, 31121, 2856
12827, 2834, 31041, 31042, 2835, 31121, 31122, 31123, 2857
12828, 2835, 31042, 31043, 2836, 31123, 31124, 31125, 2858
12829, 2836, 31043, 31044, 2837, 31125, 31126, 31127, 2859
12830, 2837, 31044, 31045, 2838, 31127, 31128, 31129, 2860
12831, 2838, 31045, 31046, 2839, 31129, 31130, 31131, 2861
12832, 2839, 31046, 31047, 2840, 31131, 31132, 31133, 2862
12833, 2840, 31047, 31048, 2841, 31133, 31134, 31135, 2863
12834, 2841, 31048, 31049, 2842, 31135, 31136, 31137, 2864
12835, 2842, 31049, 3620, 89, 31137, 31138, 3623, 2865
12836, 3613, 3614, 31050, 31028, 3617, 31139, 31140, 31094
12837, 31028, 31050, 31051, 31029, 31140, 31141, 31142, 31096
12838, 31029, 31051, 31052, 31030, 31142, 31143, 31144, 31098
12839, 31030, 31052, 31053, 31031, 31144, 31145, 31146, 31100
12840, 31031, 31053, 31054, 31032, 31146, 31147, 31148, 31102
12841, 31032, 31054, 31055, 31033, 31148, 31149, 31150, 31104
12842, 31033, 31055, 31056, 31034, 31150, 31151, 31152, 31106
12843, 31034, 31056, 31057, 31035, 31152, 31153, 31154, 31108
12844, 31035, 31057, 31058, 31036, 31154, 31155, 31156, 31110
12845, 31036, 31058, 31059, 31037, 31156, 31157, 31158, 31112
12846, 31037, 31059, 31060, 31038, 31158, 31159, 31160, 31114
12847, 31038, 31060, 31061, 31039, 31160, 31161, 31162, 31116
12848, 31039, 31061, 31062, 31040, 31162, 31163, 31164, 31118
12849, 31040, 31062, 31063, 31041, 31164, 31165, 31166, 31120
12850, 31041, 31063, 31064, 31042, 31166, 31167, 31168, 31122
12851, 31042, 31064, 31065, 31043, 31168, 31169, 31170, 31124
12852, 31043, 31065, 31066, 31044, 31170, 31171, 31172, 31126
12853, 31044, 31066, 31067, 31045, 31172, 31173, 31174, 31128
12854, 31045, 31067, 31068, 31046, 31174, 31175, 31176, 31130
12855, 31046, 31068, 31069, 31047, 31176, 31177, 31178, 31132
12856, 31047, 31069, 31070, 31048, 31178, 31179, 31180, 31134
12857, 31048, 31070, 31071, 31049, 31180, 31181, 31182, 31136
12858, 31049, 31071, 3621, 3620, 31182, 31183, 3624, 31138
12859, 3614, 3615, 31072, 31050, 3618, 31184, 31185, 31139
12860, 31050, 31072, 31073, 31051, 31185, 31186, 31187, 31141
12861, 31051, 31073, 31074, 31052, 31187, 31188, 31189, 31143
12862, 31052, 31074, 31075, 31053, 31189, 31190, 31191, 31145
12863, 31053, 31075, 31076, 31054, 31191, 31192, 31193, 31147
12864, 31054, 31076, 31077, 31055, 31193, 31194, 31195, 31149
12865, 31055, 31077, 31078, 31056, 31195, 31196, 31197, 31151
12866, 31056, 31078, 31079, 31057, 31197, 31198, 31199, 31153
12867, 31057, 31079, 31080, 31058, 31199, 31200, 31201, 31155
12868, 31058, 31080, 31081, 31059, 31201, 31202, 31203, 31157
12869, 31059, 31081, 31082, 31060, 31203, 31204, 31205, 31159
12870, 31060, 31082, 31083, 31061, 31205, 31206, 31207, 31161
12871, 31061, 31083, 31084, 31062, 31207, 31208, 31209, 31163
12872, 31062, 31084, 31085, 31063, 31209, 31210, 31211, 31165
12873, 31063, 31085, 31086, 31064, 31211, 31212, 31213, 31167
12874, 31064, 31086, 31087, 31065, 31213, 31214, 31215, 31169
12875, 31065, 31087, 31088, 31066, 31215, 31216, 31217, 31171
12876, 31066, 31088, 31089, 31067, 31217, 31218, 31219, 31173
12877, 31067, 31089, 31090, 31068, 31219, 31220, 31221, 31175
12878, 31068, 31090, 31091, 31069, 31221, 31222, 31223, 31177
12879, 31069, 31091, 31092, 31070, 31223, 31224, 31225, 31179
12880, 31070, 31092, 31093, 31071, 31225, 31226, 31227, 31181
12881, 31071, 31093, 3622, 3621, 31227, 31228, 3625, 31183
12882, 3615, 101, 3627, 31072, 3619, 3649, 31229, 31184
12883, 31072, 3627, 3628, 31073, 31229, 3650, 31230, 31186
12884, 31073, 3628, 3629, 31074, 31230, 3651, 31231, 31188
12885, 31074, 3629, 3630, 31075, 31231, 3652, 31232, 31190
12886, 31075, 3630, 3631, 31076, 31232, 3653, 31233, 31192
12887, 31076, 3631, 3632, 31077, 31233, 3654, 31234, 31194
12888, 31077, 3632, 3633, 31078, 31234, 3655, 31235, 31196
12889, 31078, 3633, 3634, 31079, 31235, 3656, 31236, 31198
12890, 31079, 3634, 3635, 31080, 31236, 3657, 31237, 31200
12891, 31080, 3635, 3636, 31081, 31237, 3658, 31238, 31202
12892, 31081, 3636, 3637, 31082, 31238, 3659, 31239, 31204
12893, 31082, 3637, 3638, 31083, 31239, 3660, 31240, 31206
12894, 31083, 3638, 3639, 31084, 31240, 3661, 31241, 31208
12895, 31084, 3639, 3640, 31085, 31241, 3662, 31242, 31210
12896, 31085, 3640, 3641, 31086, 31242, 3663, 31243, 31212
12897, 31086, 3641, 3642, 31087, 31243, 3664, 31244, 31214
12898, 31087, 3642, 3643, 31088, 31244, 3665, 31245, 31216
12899, 31088, 3643, 3644, 31089, 31245, 3666, 31246, 31218
12900, 31089, 3644, 3645, 31090, 31246, 3667, 31247, 31220
12901, 31090, 3645, 3646, 31091, 31247, 3668, 31248, 31222
12902, 31091, 3646, 3647, 31092, 31248, 3669, 31249, 31224
12903, 31092, 3647, 3648, 31093, 31249, 3670, 31250, 31226
12904, 31093, 3648, 102, 3622, 31250, 3671, 3626, 31228
*ELEMENT, type=CPS8, ELSET=Surface302
12905, 2, 2866, 31251, 3672, 2888, 31317, 31318, 3675
12906, 2866, 2867, 31252, 31251, 2889, 31319, 31320, 31317
12907, 2867, 2868, 31253, 31252, 2890, 31321, 31322, 31319
12908, 2868, 2869, 31254, 31253, 2891, 31323, 31324, 31321
12909, 2869, 2870, 31255, 31254, 2892, 31325, 31326, 31323
12910, 2870, 2871, 31256, 31255, 2893, 31327, 31328, 31325
12911, 2871, 2872, 31257, 31256, 2894, 31329, 31330, 31327
12912, 2872, 2873, 31258, 31257, 2895, 31331, 31332, 31329
12913, 2873, 2874, 31259, 31258, 2896, 31333, 31334, 31331
12914, 2874, 2875, 31260, 31259, 2897, 31335, 31336, 31333
12915, 2875, 2876, 31261, 31260, 2898, 31337, 31338, 31335
12916, 2876, 2877, 31262, 31261, 2899, 31339, 31340, 31337
12917, 2877, 2878, 31263, 31262, 2900, 31341, 31342, 31339
12918, 2878, 2879, 31264, 31263, 2901, 31343, 31344, 31341
12919, 2879, 2880, 31265, 31264, 2902, 31345, 31346, 31343
12920, 2880, 2881, 31266, 31265, 2903, 31347, 31348, 31345
12921, 2881, 2882, 31267, 31266, 2904, 31349, 31350, 31347
12922, 2882, 2883, 31268, 31267, 2905, 31351, 31352, 31349
12923, 2883, 2884, 31269, 31268, 2906, 31353, 31354, 31351
12924, 2884, 2885, 31270, 31269, 2907, 31355, 31356, 31353
12925, 2885, 2886, 31271, 31270, 2908, 31357, 31358, 31355
12926, 2886, 2887, 31272, 31271, 2909, 31359, 31360, 31357
12927, 2887, 90, 3679, 31272, 2910, 3682, 31361, 31359
12928, 3672, 31251, 31273, 3673, 31318, 31362, 31363, 3676
12929, 31251, 31252, 31274, 31273, 31320, 31364, 31365, 31362
12930, 31252, 31253, 31275, 31274, 31322, 31366, 31367, 31364
12931, 31253, 31254, 31276, 31275, 31324, 31368, 31369, 31366
12932, 31254, 31255, 31277, 31276, 31326, 31370, 31371, 31368
12933, 31255, 31256, 31278, 31277, 31328, 31372, 31373, 31370
12934, 31256, 31257, 31279, 31278, 31330, 31374, 31375, 31372
12935, 31257, 31258, 31280, 31279, 31332, 31376, 31377, 31374
12936, 31258, 31259, 31281, 31280, 31334, 31378, 31379, 31376
12937, 31259, 31260, 31282, 31281, 31336, 31380, 31381, 31378
12938, 31260, 31261, 31283, 31282, 31338, 31382, 31383, 31380
12939, 31261, 31262, 31284, 31283, 31340, 31384, 31385, 31382
12940, 31262, 31263, 31285, 31284, 31342, 31386, 31387, 31384
12941, 31263, 31264, 31286, 31285, 31344, 31388, 31389, 31386
12942, 31264, 31265, 31287, 31286, 31346, 31390, 31391, 31388
12943, 31265, 31266, 31288, 31287, 31348, 31392, 31393, 31390
12944, 31266, 31267, 31289, 31288, 31350, 31394, 31395, 31392
12945, 31267, 31268, 31290, 31289, 31352, 31396, 31397, 31394
12946, 31268, 31269, 31291, 31290, 31354, 31398, 31399, 31396
12947, 31269, 31270, 31292, 31291, 31356, 31400, 31401, 31398
12948, 31270, 31271, 31293, 31292, 31358, 31402, 31403, 31400
12949, 31271, 31272, 31294, 31293, 31360, 31404, 31405, 31402
12950, 31272, 3679, 3680, 31294, 31361, 3683, 31406, 31404
12951, 3673, 31273, 31295, 3674, 31363, 31407, 31408, 3677
12952, 31273, 31274, 31296, 31295, 31365, 31409, 31410, 31407
12953, 31274, 31275, 31297, 31296, 31367, 31411, 31412, 31409
12954, 31275, 31276, 31298, 31297, 31369, 31413, 31414, 31411
12955, 31276, 31277, 31299, 31298, 31371, 31415, 31416, 31413
12956, 31277, 31278, 31300, 31299, 31373, 31417, 31418, 31415
12957, 31278, 31279, 31301, 31300, 31375, 31419, 31420, 31417
12958, 31279, 31280, 31302, 31301, 31377, 31421, 31422, 31419
12959, 31280, 31281, 31303, 31302, 31379, 31423, 31424, 31421
12960, 31281, 31282, 31304, 31303, 31381, 31425, 31426, 31423
12961, 31282, 31283, 31305, 31304, 31383, 31427, 31428, 31425
12962, 31283, 31284, 31306, 31305, 31385, 31429, 31430, 31427
12963, 31284, 31285, 31307, 31306, 31387, 31431, 31432, 31429
12964, 31285, 31286, 31308, 31307, 31389, 31433, 31434, 31431
12965, 31286, 31287, 31309, 31308, 31391, 31435, 31436, 31433
12966, 31287, 31288, 31310, 31309, 31393, 31437, 31438, 31435
12967, 31288, 31289, 31311, 31310, 31395, 31439, 31440, 31437
12968, 31289, 31290, 31312, 31311, 31397, 31441, 31442, 31439
12969, 31290, 31291, 31313, 31312, 31399, 31443, 31444, 31441
12970, 31291, 31292, 31314, 31313, 31401, 31445, 31446, 31443
12971, 31292, 31293, 31315, 31314, 31403, 31447, 31448, 31445
12972, 31293, 31294, 31316, 31315, 31405, 31449, 31450, 31447
12973, 31294, 3680, 3681, 31316, 31406, 3684, 31451, 31449
12974, 3674, 31295, 3686, 103, 31408, 31452, 3708, 3678
12975, 31295, 31296, 3687, 3686, 31410, 31453, 3709, 31452
12976, 31296, 31297, 3688, 3687, 31412, 31454, 3710, 31453
12977, 31297, 31298, 3689, 3688, 31414, 31455, 3711, 31454
12978, 31298, 31299, 3690, 3689, 31416, 31456, 3712, 31455
12979, 31299, 31300, 3691, 3690, 31418, 31457, 3713, 31456
12980, 31300, 31301, 3692, 3691, 31420, 31458, 3714, 31457
12981, 31301, 31302, 3693, 3692, 31422, 31459, 3715, 31458
12982, 31302, 31303, 3694, 3693, 31424, 31460, 3716, 31459
12983, 31303, 31304, 3695, 3694, 31426, 31461, 3717, 31460
12984, 31304, 31305, 3696, 3695, 31428, 31462, 3718, 31461
12985, 31305, 31306, 3697, 3696, 31430, 31463, 3719, 31462
12986, 31306, 31307, 3698, 3697, 31432, 31464, 3720, 31463
12987, 31307, 31308, 3699, 3698, 31434, 31465, 3721, 31464
12988, 31308, 31309, 3700, 3699, 31436, 31466, 3722, 31465
12989, 31309, 31310, 3701, 3700, 31438, 31467, 3723, 31466
12990, 31310, 31311, 3702, 3701, 31440, 31468, 3724, 31467
12991, 31311, 31312, 3703, 3702, 31442, 31469, 3725, 31468
12992, 31312, 31313, 3704, 3703, 31444, 31470, 3726, 31469
12993, 31313, 31314, 3705, 3704, 31446, 31471, 3727, 31470
12994, 31314, 31315, 3706, 3705, 31448, 31472, 3728, 31471
12995, 31315, 31316, 3707, 3706, 31450, 31473, 3729, 31472
12996, 31316, 3681, 104, 3707, 31451, 3685, 3730, 31473
*ELEMENT, type=CPS8, ELSET=Surface303
12997, 1, 130, 31474, 3613, 153, 31540, 31541, 3616
12998, 130, 129, 31475, 31474, 152, 31542, 31543, 31540
12999, 129, 128, 31476, 31475, 151, 31544, 31545, 31542
13000, 128, 127, 31477, 31476, 150, 31546, 31547, 31544
13001, 127, 126, 31478, 31477, 149, 31548, 31549, 31546
13002, 126, 125, 31479, 31478, 148, 31550, 31551, 31548
13003, 125, 124, 31480, 31479, 147, 31552, 31553, 31550
13004, 124, 123, 31481, 31480, 146, 31554, 31555, 31552
13005, 123, 122, 31482, 31481, 145, 31556, 31557, 31554
13006, 122, 121, 31483, 31482, 144, 31558, 31559, 31556
13007, 121, 120, 31484, 31483, 143, 31560, 31561, 31558
13008, 120, 119, 31485, 31484, 142, 31562, 31563, 31560
13009, 119, 118, 31486, 31485, 141, 31564, 31565, 31562
13010, 118, 117, 31487, 31486, 140, 31566, 31567, 31564
13011, 117, 116, 31488, 31487, 139, 31568, 31569, 31566
13012, 116, 115, 31489, 31488, 138, 31570, 31571, 31568
13013, 115, 114, 31490, 31489, 137, 31572, 31573, 31570
13014, 114, 113, 31491, 31490, 136, 31574, 31575, 31572
13015, 113, 112, 31492, 31491, 135, 31576, 31577, 31574
13016, 112, 111, 31493, 31492, 134, 31578, 31579, 31576
13017, 111, 110, 31494, 31493, 133, 31580, 31581, 31578
13018, 110, 109, 31495, 31494, 132, 31582, 31583, 31580
13019, 109, 2, 3672, 31495, 131, 3675, 31584, 31582
13020, 3613, 31474, 31496, 3614, 31541, 31585, 31586, 3617
13021, 31474, 31475, 31497, 31496, 31543, 31587, 31588, 31585
13022, 31475, 31476, 31498, 31497, 31545, 31589, 31590, 31587
13023, 31476, 31477, 31499, 31498, 31547, 31591, 31592, 31589
13024, 31477, 31478, 31500, 31499, 31549, 31593, 31594, 31591
13025, 31478, 31479, 31501, 31500, 31551, 31595, 31596, 31593
13026, 31479, 31480, 31502, 31501, 31553, 31597, 31598, 31595
13027, 31480, 31481, 31503, 31502, 31555, 31599, 31600, 31597
13028, 31481, 31482, 31504, 31503, 31557, 31601, 31602, 31599
13029, 31482, 31483, 31505, 31504, 31559, 31603, 31604, 31601
13030, 31483, 31484, 31506, 31505, 31561, 31605, 31606, 31603
13031, 31484, 31485, 31507, 31506, 31563, 31607, 31608, 31605
13032, 31485, 31486, 31508, 31507, 31565, 31609, 31610, 31607
13033, 31486, 31487, 31509, 31508, 31567, 31611, 31612, 31609
13034, 31487, 31488, 31510, 31509, 31569, 31613, 31614, 31611
13035, 31488, 31489, 31511, 31510, 31571, 31615, 31616, 31613
13036, 31489, 31490, 31512, 31511, 31573, 31617, 31618, 31615
13037, 31490, 31491, 31513, 31512, 31575, 31619, 31620, 31617
13038, 31491, 31492, 31514, 31513, 31577, 31621, 31622, 31619
13039, 31492, 31493, 31515, 31514, 31579, 31623, 31624, 31621
13040, 31493, 31494, 31516, 31515, 31581, 31625, 31626, 31623
13041, 31494, 31495, 31517, 31516, 31583, 31627, 31628, 31625
13042, 31495, 3672, 3673, 31517, 31584, 3676, 31629, 31627
13043, 3614, 31496, 31518, 3615, 31586, 31630, 31631, 3618
13044, 31496, 31497, 31519, 31518, 31588, 31632, 31633, 31630
13045, 31497, 31498, 31520, 31519, 31590, 31634, 31635, 31632
13046, 31498, 31499, 31521, 31520, 31592, 31636, 31637, 31634
13047, 31499, 31500, 31522, 31521, 31594, 31638, 31639, 31636
13048, 31500, 31501, 31523, 31522, 31596, 31640, 31641, 31638
13049, 31501, 31502, 31524, 31523, 31598, 31642, 31643, 31640
13050, 31502, 31503, 31525, 31524, 31600, 31644, 31645, 31642
13051, 31503, 31504, 31526, 31525, 31602, 31646, 31647, 31644
13052, 31504, 31505, 31527, 31526, 31604, 31648, 31649, 31646
13053, 31505, 31506, 31528, 31527, 31606, 31650, 31651, 31648
13054, 31506, 31507, 31529, 31528, 31608, 31652, 31653, 31650
13055, 31507, 31508, 31530, 31529, 31610, 31654, 31655, 31652
13056, 31508, 31509, 31531, 31530, 31612, 31656, 31657, 31654
13057, 31509, 31510, 31532, 31531, 31614, 31658, 31659, 31656
13058, 31510, 31511, 31533, 31532, 31616, 31660, 31661, 31658
13059, 31511, 31512, 31534, 31533, 31618, 31662, 31663, 31660
13060, 31512, 31513, 31535, 31534, 31620, 31664, 31665, 31662
13061, 31513, 31514, 31536, 31535, 31622, 31666, 31667, 31664
13062, 31514, 31515, 31537, 31536, 31624, 31668, 31669, 31666
13063, 31515, 31516, 31538, 31537, 31626, 31670, 31671, 31668
13064, 31516, 31517, 31539, 31538, 31628, 31672, 31673, 31670
13065, 31517, 3673, 3674, 31539, 31629, 3677, 31674, 31672
13066, 3615, 31518, 3752, 101, 31631, 31675, 3775, 3619
13067, 31518, 31519, 3751, 3752, 31633, 31676, 3774, 31675
13068, 31519, 31520, 3750, 3751, 31635, 31677, 3773, 31676
13069, 31520, 31521, 3749, 3750, 31637, 31678, 3772, 31677
13070, 31521, 31522, 3748, 3749, 31639, 31679, 3771, 31678
13071, 31522, 31523, 3747, 3748, 31641, 31680, 3770, 31679
13072, 31523, 31524, 3746, 3747, 31643, 31681, 3769, 31680
13073, 31524, 31525, 3745, 3746, 31645, 31682, 3768, 31681
13074, 31525, 31526, 3744, 3745, 31647, 31683, 3767, 31682
13075, 31526, 31527, 3743, 3744, 31649, 31684, 3766, 31683
13076, 31527, 31528, 3742, 3743, 31651, 31685, 3765, 31684
13077, 31528, 31529, 3741, 3742, 31653, 31686, 3764, 31685
13078, 31529, 31530, 3740, 3741, 31655, 31687, 3763, 31686
13079, 31530, 31531, 3739, 3740, 31657, 31688, 3762, 31687
13080, 31531, 31532, 3738, 3739, 31659, 31689, 3761, 31688
13081, 31532, 31533, 3737, 3738, 31661, 31690, 3760, 31689
13082, 31533, 31534, 3736, 3737, 31663, 31691, 3759, 31690
13083, 31534, 31535, 3735, 3736, 31665, 31692, 3758, 31691
13084, 31535, 31536, 3734, 3735, 31667, 31693, 3757, 31692
13085, 31536, 31537, 3733, 3734, 31669, 31694, 3756, 31693
13086, 31537, 31538, 3732, 3733, 31671, 31695, 3755, 31694
13087, 31538, 31539, 3731, 3732, 31673, 31696, 3754, 31695
13088, 31539, 3674, 103, 3731, 31674, 3678, 3753, 31696
*ELEMENT, type=CPS8, ELSET=Surface304
13089, 90, 2911, 31697, 3679, 2933, 31763, 31764, 3682
13090, 2911, 2912, 31698, 31697, 2934, 31765, 31766, 31763
13091, 2912, 2913, 31699, 31698, 2935, 31767, 31768, 31765
13092, 2913, 2914, 31700, 31699, 2936, 31769, 31770, 31767
13093, 2914, 2915, 31701, 31700, 2937, 31771, 31772, 31769
13094, 2915, 2916, 31702, 31701, 2938, 31773, 31774, 31771
13095, 2916, 2917, 31703, 31702, 2939, 31775, 31776, 31773
13096, 2917, 2918, 31704, 31703, 2940, 31777, 31778, 31775
13097, 2918, 2919, 31705, 31704, 2941, 31779, 31780, 31777
13098, 2919, 2920, 31706, 31705, 2942, 31781, 31782, 31779
13099, 2920, 2921, 31707, 31706, 2943, 31783, 31784, 31781
13100, 2921, 2922, 31708, 31707, 2944, 31785, 31786, 31783
13101, 2922, 2923, 31709, 31708, 2945, 31787, 31788, 31785
13102, 2923, 2924, 31710, 31709, 2946, 31789, 31790, 31787
13103, 2924, 2925, 31711, 31710, 2947, 31791, 31792, 31789
13104, 2925, 2926, 31712, 31711, 2948, 31793, 31794, 31791
13105, 2926, 2927, 31713, 31712, 2949, 31795, 31796, 31793
13106, 2927, 2928, 31714, 31713, 2950, 31797, 31798, 31795
13107, 2928, 2929, 31715, 31714, 2951, 31799, 31800, 31797
13108, 2929, 2930, 31716, 31715, 2952, 31801, 31802, 31799
13109, 2930, 2931, 31717, 31716, 2953, 31803, 31804, 31801
13110, 2931, 2932, 31718, 31717, 2954, 31805, 31806, 31803
13111, 2932, 89, 3620, 31718, 2955, 3623, 31807, 31805
13112, 3679, 31697, 31719, 3680, 31764, 31808, 31809, 3683
13113, 31697, 31698, 31720, 31719, 31766, 31810, 31811, 31808
13114, 31698, 31699, 31721, 31720, 31768, 31812, 31813, 31810
13115, 31699, 31700, 31722, 31721, 31770, 31814, 31815, 31812
13116, 31700, 31701, 31723, 31722, 31772, 31816, 31817, 31814
13117, 31701, 31702, 31724, 31723, 31774, 31818, 31819, 31816
13118, 31702, 31703, 31725, 31724, 31776, 31820, 31821, 31818
13119, 31703, 31704, 31726, 31725, 31778, 31822, 31823, 31820
13120, 31704, 31705, 31727, 31726, 31780, 31824, 31825, 31822
13121, 31705, 31706, 31728, 31727, 31782, 31826, 31827, 31824
13122, 31706, 31707, 31729, 31728, 31784, 31828, 31829, 31826
13123, 31707, 31708, 31730, 31729, 31786, 31830, 31831, 31828
13124, 31708, 31709, 31731, 31730, 31788, 31832, 31833, 31830
13125, 31709, 31710, 31732, 31731, 31790, 31834, 31835, 31832
13126, 31710, 31711, 31733, 31732, 31792, 31836, 31837, 31834
13127, 31711, 31712, 31734, 31733, 31794, 31838, 31839, 31836
13128, 31712, 31713, 31735, 31734, 31796, 31840, 31841, 31838
13129, 31713, 31714, 31736, 31735, 31798, 31842, 31843, 31840
13130, 31714, 31715, 31737, 31736, 31800, 31844, 31845, 31842
13131, 31715, 31716, 31738, 31737, 31802, 31846, 31847, 31844
13132, 31716, 31717, 31739, 31738, 31804, 31848, 31849, 31846
13133, 31717, 31718, 31740, 31739, 31806, 31850, 31851, 31848
13134, 31718, 3620, 3621, 31740, 31807, 3624, 31852, 31850
13135, 3680, 31719, 31741, 3681, 31809, 31853, 31854, 3684
13136, 31719, 31720, 31742, 31741, 31811, 31855, 31856, 31853
13137, 31720, 31721, 31743, 31742, 31813, 31857, 31858, 31855
13138, 31721, 31722, 31744, 31743, 31815, 31859, 31860, 31857
13139, 31722, 31723, 31745, 31744, 31817, 31861, 31862, 31859
13140, 31723, 31724, 31746, 31745, 31819, 31863, 31864, 31861
13141, 31724, 31725, 31747, 31746, 31821, 31865, 31866, 31863
13142, 31725, 31726, 31748, 31747, 31823, 31867, 31868, 31865
13143, 31726, 31727, 31749, 31748, 31825, 31869, 31870, 31867
13144, 31727, 31728, 31750, 31749, 31827, 31871, 31872, 31869
13145, 31728, 31729, 31751, 31750, 31829, 31873, 31874, 31871
13146, 31729, 31730, 31752, 31751, 31831, 31875, 31876, 31873
13147, 31730, 31731, 31753, 31752, 31833, 31877, 31878, 31875
13148, 31731, 31732, 31754, 31753, 31835, 31879, 31880, 31877
13149, 31732, 31733, 31755, 31754, 31837, 31881, 31882, 31879
13150, 31733, 31734, 31756, 31755, 31839, 31883, 31884, 31881
13151, 31734, 31735, 31757, 31756, 31841, 31885, 31886, 31883
13152, 31735, 31736, 31758, 31757, 31843, 31887, 31888, 31885
13153, 31736, 31737, 31759, 31758, 31845, 31889, 31890, 31887
13154, 31737, 31738, 31760, 31759, 31847, 31891, 31892, 31889
13155, 31738, 31739, 31761, 31760, 31849, 31893, 31894, 31891
13156, 31739, 31740, 31762, 31761, 31851, 31895, 31896, 31893
13157, 31740, 3621, 3622, 31762, 31852, 3625, 31897, 31895
13158, 3681, 31741, 3776, 104, 31854, 31898, 3798, 3685
13159, 31741, 31742, 3777, 3776, 31856, 31899, 3799, 31898
13160, 31742, 31743, 3778, 3777, 31858, 31900, 3800, 31899
13161, 31743, 31744, 3779, 3778, 31860, 31901, 3801, 31900
13162, 31744, 31745, 3780, 3779, 31862, 31902, 3802, 31901
13163, 31745, 31746, 3781, 3780, 31864, 31903, 3803, 31902
13164, 31746, 31747, 3782, 3781, 31866, 31904, 3804, 31903
13165, 31747, 31748, 3783, 3782, 31868, 31905, 3805, 31904
13166, 31748, 31749, 3784, 3783, 31870, 31906, 3806, 31905
13167, 31749, 31750, 3785, 3784, 31872, 31907, 3807, 31906
13168, 31750, 31751, 3786, 3785, 31874, 31908, 3808, 31907
13169, 31751, 31752, 3787, 3786, 31876, 31909, 3809, 31908
13170, 31752, 31753, 3788, 3787, 31878, 31910, 3810, 31909
13171, 31753, 31754, 3789, 3788, 31880, 31911, 3811, 31910
13172, 31754, 31755, 3790, 3789, 31882, 31912, 3812, 31911
13173, 31755, 31756, 3791, 3790, 31884, 31913, 3813, 31912
13174, 31756, 31757, 3792, 3791, 31886, 31914, 3814, 31913
13175, 31757, 31758, 3793, 3792, 31888, 31915, 3815, 31914
13176, 31758, 31759, 3794, 3793, 31890, 31916, 3816, 31915
13177, 31759, 31760, 3795, 3794, 31892, 31917, 3817, 31916
13178, 31760, 31761, 3796, 3795, 31894, 31918, 3818, 31917
13179, 31761, 31762, 3797, 3796, 31896, 31919, 3819, 31918
13180, 31762, 3622, 102, 3797, 31897, 3626, 3820, 31919
*ELEMENT, type=CPS8, ELSET=Surface305
13181, 101, 3752, 31920, 3627, 3775, 32404, 32405, 3649
13182, 3752, 3751, 31921, 31920, 3774, 32406, 32407, 32404
13183, 3751, 3750, 31922, 31921, 3773, 32408, 32409, 32406
13184, 3750, 3749, 31923, 31922, 3772, 32410, 32411, 32408
13185, 3749, 3748, 31924, 31923, 3771, 32412, 32413, 32410
13186, 3748, 3747, 31925, 31924, 3770, 32414, 32415, 32412
13187, 3747, 3746, 31926, 31925, 3769, 32416, 32417, 32414
13188, 3746, 3745, 31927, 31926, 3768, 32418, 32419, 32416
13189, 3745, 3744, 31928, 31927, 3767, 32420, 32421, 32418
13190, 3744, 3743, 31929, 31928, 3766, 32422, 32423, 32420
13191, 3743, 3742, 31930, 31929, 3765, 32424, 32425, 32422
13192, 3742, 3741, 31931, 31930, 3764, 32426, 32427, 32424
13193, 3741, 3740, 31932, 31931, 3763, 32428, 32429, 32426
13194, 3740, 3739, 31933, 31932, 3762, 32430, 32431, 32428
13195, 3739, 3738, 31934, 31933, 3761, 32432, 32433, 32430
13196, 3738, 3737, 31935, 31934, 3760, 32434, 32435, 32432
13197, 3737, 3736, 31936, 31935, 3759, 32436, 32437, 32434
13198, 3736, 3735, 31937, 31936, 3758, 32438, 32439, 32436
13199, 3735, 3734, 31938, 31937, 3757, 32440, 32441, 32438
13200, 3734, 3733, 31939, 31938, 3756, 32442, 32443, 32440
13201, 3733, 3732, 31940, 31939, 3755, 32444, 32445, 32442
13202, 3732, 3731, 31941, 31940, 3754, 32446, 32447, 32444
13203, 3731, 103, 3686, 31941, 3753, 3708, 32448, 32446
13204, 3627, 31920, 31942, 3628, 32405, 32449, 32450, 3650
13205, 31920, 31921, 31943, 31942, 32407, 32451, 32452, 32449
13206, 31921, 31922, 31944, 31943, 32409, 32453, 32454, 32451
13207, 31922, 31923, 31945, 31944, 32411, 32455, 32456, 32453
13208, 31923, 31924, 31946, 31945, 32413, 32457, 32458, 32455
13209, 31924, 31925, 31947, 31946, 32415, 32459, 32460, 32457
13210, 31925, 31926, 31948, 31947, 32417, 32461, 32462, 32459
13211, 31926, 31927, 31949, 31948, 32419, 32463, 32464, 32461
13212, 31927, 31928, 31950, 31949, 32421, 32465, 32466, 32463
13213, 31928, 31929, 31951, 31950, 32423, 32467, 32468, 32465
13214, 31929, 31930, 31952, 31951, 32425, 32469, 32470, 32467
13215, 31930, 31931, 31953, 31952, 32427, 32471, 32472, 32469
13216, 31931, 31932, 31954, 31953, 32429, 32473, 32474, 32471
13217, 31932, 31933, 31955, 31954, 32431, 32475, 32476, 32473
13218, 31933, 31934, 31956, 31955, 32433, 32477, 32478, 32475
13219, 31934, 31935, 31957, 31956, 32435, 32479, 32480, 32477
13220, 31935, 31936, 31958, 31957, 32437, 32481, 32482, 32479
13221, 31936, 31937, 31959, 31958, 32439, 32483, 32484, 32481
13222, 31937, 31938, 31960, 31959, 32441, 32485, 32486, 32483
13223, 31938, 31939, 31961, 31960, 32443, 32487, 32488, 32485
13224, 31939, 31940, 31962, 31961, 32445, 32489, 32490, 32487
13225, 31940, 31941, 31963, 31962, 32447, 32491, 32492, 32489
13226, 31941, 3686, 3687, 31963, 32448, 3709, 32493, 32491
13227, 3628, 31942, 31964, 3629, 32450, 32494, 32495, 3651
13228, 31942, 31943, 31965, 31964, 32452, 32496, 32497, 32494
13229, 31943, 31944, 31966, 31965, 32454, 32498, 32499, 32496
13230, 31944, 31945, 31967, 31966, 32456, 32500, 32501, 32498
13231, 31945, 31946, 31968, 31967, 32458, 32502, 32503, 32500
13232, 31946, 31947, 31969, 31968, 32460, 32504, 32505, 32502
13233, 31947, 31948, 31970, 31969, 32462, 32506, 32507, 32504
13234, 31948, 31949, 31971, 31970, 32464, 32508, 32509, 32506
13235, 31949, 31950, 31972, 31971, 32466, 32510, 32511, 32508
13236, 31950, 31951, 31973, 31972, 32468, 32512, 32513, 32510
13237, 31951, 31952, 31974, 31973, 32470, 32514, 32515, 32512
13238, 31952, 31953, 31975, 31974, 32472, 32516, 32517, 32514
13239, 31953, 31954, 31976, 31975, 32474, 32518, 32519, 32516
13240, 31954, 31955, 31977, 31976, 32476, 32520, 32521, 32518
13241, 31955, 31956, 31978, 31977, 32478, 32522, 32523, 32520
13242, 31956, 31957, 31979, 31978, 32480, 32524, 32525, 32522
13243, 31957, 31958, 31980, 31979, 32482, 32526, 32527, 32524
13244, 31958, 31959, 31981, 31980, 32484, 32528, 32529, 32526
13245, 31959, 31960, 31982, 31981, 32486, 32530, 32531, 32528
13246, 31960, 31961, 31983, 31982, 32488, 32532, 32533, 32530
13247, 31961, 31962, 31984, 31983, 32490, 32534, 32535, 32532
13248, 31962, 31963, 31985, 31984, 32492, 32536, 32537, 32534
13249, 31963, 3687, 3688, 31985, 32493, 3710, 32538, 32536
13250, 3629, 31964, 31986, 3630, 32495, 32539, 32540, 3652
13251, 31964, 31965, 31987, 31986, 32497, 32541, 32542, 32539
13252, 31965, 31966, 31988, 31987, 32499, 32543, 32544, 32541
13253, 31966, 31967, 31989, 31988, 32501, 32545, 32546, 32543
13254, 31967, 31968, 31990, 31989, 32503, 32547, 32548, 32545
13255, 31968, 31969, 31991, 31990, 32505, 32549, 32550, 32547
13256, 31969, 31970, 31992, 31991, 32507, 32551, 32552, 32549
13257, 31970, 31971, 31993, 31992, 32509, 32553, 32554, 32551
13258, 31971, 31972, 31994, 31993, 32511, 32555, 32556, 32553
13259, 31972, 31973, 31995, 31994, 32513, 32557, 32558, 32555
13260, 31973, 31974, 31996, 31995, 32515, 32559, 32560, 32557
13261, 31974, 31975, 31997, 31996, 32517, 32561, 32562, 32559
13262, 31975, 31976, 31998, 31997, 32519, 32563, 32564, 32561
13263, 31976, 31977, 31999, 31998, 32521, 32565, 32566, 32563
13264, 31977, 31978, 32000, 31999, 32523, 32567, 32568, 32565
13265, 31978, 31979, 32001, 32000, 32525, 32569, 32570, 32567
13266, 31979, 31980, 32002, 32001, 32527, 32571, 32572, 32569
13267, 31980, 31981, 32003, 32002, 32529, 32573, 32574, 32571
13268, 31981, 31982, 32004, 32003, 32531, 32575, 32576, 32573
13269, 31982, 31983, 32005, 32004, 32533, 32577, 32578, 32575
13270, 31983, 31984, 32006, 32005, 32535, 32579, 32580, 32577
13271, 31984, 31985, 32007, 32006, 32537, 32581, 32582, 32579
13272, 31985, 3688, 3689, 32007, 32538, 3711, 32583, 32581
13273, 3630, 31986, 32008, 3631, 32540, 32584, 32585, 3653
13274, 31986, 31987, 32009, 32008, 32542, 32586, 32587, 32584
13275, 31987, 31988, 32010, 32009, 32544, 32588, 32589, 32586
13276, 31988, 31989, 32011, 32010, 32546, 32590, 32591, 32588
13277, 31989, 31990, 32012, 32011, 32548, 32592, 32593, 32590
13278, 31990, 31991, 32013, 32012, 32550, 32594, 32595, 32592
13279, 31991, 31992, 32014, 32013, 32552, 32596, 32597, 32594
13280, 31992, 31993, 32015, 32014, 32554, 32598, 32599, 32596
13281, 31993, 31994, 32016, 32015, 32556, 32600, 32601, 32598
13282, 31994, 31995, 32017, 32016, 32558, 32602, 32603, 32600
13283, 31995, 31996, 32018, 32017, 32560, 32604, 32605, 32602
13284, 31996, 31997, 32019, 32018, 32562, 32606, 32607, 32604
13285, 31997, 31998, 32020, 32019, 32564, 32608, 32609, 32606
13286, 31998, 31999, 32021, 32020, 32566, 32610, 32611, 32608
13287, 31999, 32000, 32022, 32021, 32568, 32612, 32613, 32610
13288, 32000, 32001, 32023, 32022, 32570, 32614, 32615, 32612
13289, 32001, 32002, 32024, 32023, 32572, 32616, 32617, 32614
13290, 32002, 32003, 32025, 32024, 32574, 32618, 32619, 32616
13291, 32003, 32004, 32026, 32025, 32576, 32620, 32621, 32618
13292, 32004, 32005, 32027, 32026, 32578, 32622, 32623, 32620
13293, 32005, 32006, 32028, 32027, 32580, 32624, 32625, 32622
13294, 32006, 32007, 32029, 32028, 32582, 32626, 32627, 32624
13295, 32007, 3689, 3690, 32029, 32583, 3712, 32628, 32626
13296, 3631, 32008, 32030, 3632, 32585, 32629, 32630, 3654
13297, 32008, 32009, 32031, 32030, 32587, 32631, 32632, 32629
13298, 32009, 32010, 32032, 32031, 32589, 32633, 32634, 32631
13299, 32010, 32011, 32033, 32032, 32591, 32635, 32636, 32633
13300, 32011, 32012, 32034, 32033, 32593, 32637, 32638, 32635
13301, 32012, 32013, 32035, 32034, 32595, 32639, 32640, 32637
13302, 32013, 32014, 32036, 32035, 32597, 32641, 32642, 32639
13303, 32014, 32015, 32037, 32036, 32599, 32643, 32644, 32641
13304, 32015, 32016, 32038, 32037, 32601, 32645, 32646, 32643
13305, 32016, 32017, 32039, 32038, 32603, 32647, 32648, 32645
13306, 32017, 32018, 32040, 32039, 32605, 32649, 32650, 32647
13307, 32018, 32019, 32041, 32040, 32607, 32651, 32652, 32649
13308, 32019, 32020, 32042, 32041, 32609, 32653, 32654, 32651
13309, 32020, 32021, 32043, 32042, 32611, 32655, 32656, 32653
13310, 32021, 32022, 32044, 32043, 32613, 32657, 32658, 32655
13311, 32022, 32023, 32045, 32044, 32615, 32659, 32660, 32657
13312, 32023, 32024, 32046, 32045, 32617, 32661, 32662, 32659
13313, 32024, 32025, 32047, 32046, 32619, 32663, 32664, 32661
13314, 32025, 32026, 32048, 32047, 32621, 32665, 32666, 32663
13315, 32026, 32027, 32049, 32048, 32623, 32667, 32668, 32665
13316, 32027, 32028, 32050, 32049, 32625, 32669, 32670, 32667
13317, 32028, 32029, 32051, 32050, 32627, 32671, 32672, 32669
13318, 32029, 3690, 3691, 32051, 32628, 3713, 32673, 32671
13319, 3632, 32030, 32052, 3633, 32630, 32674, 32675, 3655
13320, 32030, 32031, 32053, 32052, 32632, 32676, 32677, 32674
13321, 32031, 32032, 32054, 32053, 32634, 32678, 32679, 32676
13322, 32032, 32033, 32055, 32054, 32636, 32680, 32681, 32678
13323, 32033, 32034, 32056, 32055, 32638, 32682, 32683, 32680
13324, 32034, 32035, 32057, 32056, 32640, 32684, 32685, 32682
13325, 32035, 32036, 32058, 32057, 32642, 32686, 32687, 32684
13326, 32036, 32037, 32059, 32058, 32644, 32688, 32689, 32686
13327, 32037, 32038, 32060, 32059, 32646, 32690, 32691, 32688
13328, 32038, 32039, 32061, 32060, 32648, 32692, 32693, 32690
13329, 32039, 32040, 32062, 32061, 32650, 32694, 32695, 32692
13330, 32040, 32041, 32063, 32062, 32652, 32696, 32697, 32694
13331, 32041, 32042, 32064, 32063, 32654, 32698, 32699, 32696
13332, 32042, 32043, 32065, 32064, 32656, 32700, 32701, 32698
13333, 32043, 32044, 32066, 32065, 32658, 32702, 32703, 32700
13334, 32044, 32045, 32067, 32066, 32660, 32704, 32705, 32702
13335, 32045, 32046, 32068, 32067, 32662, 32706, 32707, 32704
13336, 32046, 32047, 32069, 32068, 32664, 32708, 32709, 32706
13337, 32047, 32048, 32070, 32069, 32666, 32710, 32711, 32708
13338, 32048, 32049, 32071, 32070, 32668, 32712, 32713, 32710
13339, 32049, 32050, 32072, 32071, 32670, 32714, 32715, 32712
13340, 32050, 32051, 32073, 32072, 32672, 32716, 32717, 32714
13341, 32051, 3691, 3692, 32073, 32673, 3714, 32718, 32716
13342, 3633, 32052, 32074, 3634, 32675, 32719, 32720, 3656
13343, 32052, 32053, 32075, 32074, 32677, 32721, 32722, 32719
13344, 32053, 32054, 32076, 32075, 32679, 32723, 32724, 32721
13345, 32054, 32055, 32077, 32076, 32681, 32725, 32726, 32723
13346, 32055, 32056, 32078, 32077, 32683, 32727, 32728, 32725
13347, 32056, 32057, 32079, 32078, 32685, 32729, 32730, 32727
13348, 32057, 32058, 32080, 32079, 32687, 32731, 32732, 32729
13349, 32058, 32059, 32081, 32080, 32689, 32733, 32734, 32731
13350, 32059, 32060, 32082, 32081, 32691, 32735, 32736, 32733
13351, 32060, 32061, 32083, 32082, 32693, 32737, 32738, 32735
13352, 32061, 32062, 32084, 32083, 32695, 32739, 32740, 32737
13353, 32062, 32063, 32085, 32084, 32697, 32741, 32742, 32739
13354, 32063, 32064, 32086, 32085, 32699, 32743, 32744, 32741
13355, 32064, 32065, 32087, 32086, 32701, 32745, 32746, 32743
13356, 32065, 32066, 32088, 32087, 32703, 32747, 32748, 32745
13357, 32066, 32067, 32089, 32088, 32705, 32749, 32750, 32747
13358, 32067, 32068, 32090, 32089, 32707, 32751, 32752, 32749
13359, 32068, 32069, 32091, 32090, 32709, 32753, 32754, 32751
13360, 32069, 32070, 32092, 32091, 32711, 32755, 32756, 32753
13361, 32070, 32071, 32093, 32092, 32713, 32757, 32758, 32755
13362, 32071, 32072, 32094, 32093, 32715, 32759, 32760, 32757
13363, 32072, 32073, 32095, 32094, 32717, 32761, 32762, 32759
13364, 32073, 3692, 3693, 32095, 32718, 3715, 32763, 32761
13365, 3634, 32074, 32096, 3635, 32720, 32764, 32765, 3657
13366, 32074, 32075, 32097, 32096, 32722, 32766, 32767, 32764
13367, 32075, 32076, 32098, 32097, 32724, 32768, 32769, 32766
13368, 32076, 32077, 32099, 32098, 32726, 32770, 32771, 32768
13369, 32077, 32078, 32100, 32099, 32728, 32772, 32773, 32770
13370, 32078, 32079, 32101, 32100, 32730, 32774, 32775, 32772
13371, 32079, 32080, 32102, 32101, 32732, 32776, 32777, 32774
13372, 32080, 32081, 32103, 32102, 32734, 32778, 32779, 32776
13373, 32081, 32082, 32104, 32103, 32736, 32780, 32781, 32778
13374, 32082, 32083, 32105, 32104, 32738, 32782, 32783, 32780
13375, 32083, 32084, 32106, 32105, 32740, 32784, 32785, 32782
13376, 32084, 32085, 32107, 32106, 32742, 32786, 32787, 32784
13377, 32085, 32086, 32108, 32107, 32744, 32788, 32789, 32786
13378, 32086, 32087, 32109, 32108, 32746, 32790, 32791, 32788
13379, 32087, 32088, 32110, 32109, 32748, 32792, 32793, 32790
13380, 32088, 32089, 32111, 32110, 32750, 32794, 32795, 32792
13381, 32089, 32090, 32112, 32111, 32752, 32796, 32797, 32794
13382, 32090, 32091, 32113, 32112, 32754, 32798, 32799, 32796
13383, 32091, 32092, 32114, 32113, 32756, 32800, 32801, 32798
13384, 32092, 32093, 32115, 32114, 32758, 32802, 32803, 32800
13385, 32093, 32094, 32116, 32115, 32760, 32804, 32805, 32802
13386, 32094, 32095, 32117, 32116, 32762, 32806, 32807, 32804
13387, 32095, 3693, 3694, 32117, 32763, 3716, 32808, 32806
13388, 3635, 32096, 32118, 3636, 32765, 32809, 32810, 3658
13389, 32096, 32097, 32119, 32118, 32767, 32811, 32812, 32809
13390, 32097, 32098, 32120, 32119, 32769, 32813, 32814, 32811
13391, 32098, 32099, 32121, 32120, 32771, 32815, 32816, 32813
13392, 32099, 32100, 32122, 32121, 32773, 32817, 32818, 32815
13393, 32100, 32101, 32123, 32122, 32775, 32819, 32820, 32817
13394, 32101, 32102, 32124, 32123, 32777, 32821, 32822, 32819
13395, 32102, 32103, 32125, 32124, 32779, 32823, 32824, 32821
13396, 32103, 32104, 32126, 32125, 32781, 32825, 32826, 32823
13397, 32104, 32105, 32127, 32126, 32783, 32827, 32828, 32825
13398, 32105, 32106, 32128, 32127, 32785, 32829, 32830, 32827
13399, 32106, 32107, 32129, 32128, 32787, 32831, 32832, 32829
13400, 32107, 32108, 32130, 32129, 32789, 32833, 32834, 32831
13401, 32108, 32109, 32131, 32130, 32791, 32835, 32836, 32833
13402, 32109, 32110, 32132, 32131, 32793, 32837, 32838, 32835
13403, 32110, 32111, 32133, 32132, 32795, 32839, 32840, 32837
13404, 32111, 32112, 32134, 32133, 32797, 32841, 32842, 32839
13405, 32112, 32113, 32135, 32134, 32799, 32843, 32844, 32841
13406, 32113, 32114, 32136, 32135, 32801, 32845, 32846, 32843
13407, 32114, 32115, 32137, 32136, 32803, 32847, 32848, 32845
13408, 32115, 32116, 32138, 32137, 32805, 32849, 32850, 32847
13409, 32116, 32117, 32139, 32138, 32807, 32851, 32852, 32849
13410, 32117, 3694, 3695, 32139, 32808, 3717, 32853, 32851
13411, 3636, 32118, 32140, 3637, 32810, 32854, 32855, 3659
13412, 32118, 32119, 32141, 32140, 32812, 32856, 32857, 32854
13413, 32119, 32120, 32142, 32141, 32814, 32858, 32859, 32856
13414, 32120, 32121, 32143, 32142, 32816, 32860, 32861, 32858
13415, 32121, 32122, 32144, 32143, 32818, 32862, 32863, 32860
13416, 32122, 32123, 32145, 32144, 32820, 32864, 32865, 32862
13417, 32123, 32124, 32146, 32145, 32822, 32866, 32867, 32864
13418, 32124, 32125, 32147, 32146, 32824, 32868, 32869, 32866
13419, 32125, 32126, 32148, 32147, 32826, 32870, 32871, 32868
13420, 32126, 32127, 32149, 32148, 32828, 32872, 32873, 32870
13421, 32127, 32128, 32150, 32149, 32830, 32874, 32875, 32872
13422, 32128, 32129, 32151, 32150, 32832, 32876, 32877, 32874
13423, 32129, 32130, 32152, 32151, 32834, 32878, 32879, 32876
13424, 32130, 32131, 32153, 32152, 32836, 32880, 32881, 32878
13425, 32131, 32132, 32154, 32153, 32838, 32882, 32883, 32880
13426, 32132, 32133, 32155, 32154, 32840, 32884, 32885, 32882
13427, 32133, 32134, 32156, 32155, 32842, 32886, 32887, 32884
13428, 32134, 32135, 32157, 32156, 32844, 32888, 32889, 32886
13429, 32135, 32136, 32158, 32157, 32846, 32890, 32891, 32888
13430, 32136, 32137, 32159, 32158, 32848, 32892, 32893, 32890
13431, 32137, 32138, 32160, 32159, 32850, 32894, 32895, 32892
13432, 32138, 32139, 32161, 32160, 32852, 32896, 32897, 32894
13433, 32139, 3695, 3696, 32161, 32853, 3718, 32898, 32896
13434, 3637, 32140, 32162, 3638, 32855, 32899, 32900, 3660
13435, 32140, 32141, 32163, 32162, 32857, 32901, 32902, 32899
13436, 32141, 32142, 32164, 32163, 32859, 32903, 32904, 32901
13437, 32142, 32143, 32165, 32164, 32861, 32905, 32906, 32903
13438, 32143, 32144, 32166, 32165, 32863, 32907, 32908, 32905
13439, 32144, 32145, 32167, 32166, 32865, 32909, 32910, 32907
13440, 32145, 32146, 32168, 32167, 32867, 32911, 32912, 32909
13441, 32146, 32147, 32169, 32168, 32869, 32913, 32914, 32911
13442, 32147, 32148, 32170, 32169, 32871, 32915, 32916, 32913
13443, 32148, 32149, 32171, 32170, 32873, 32917, 32918, 32915
13444, 32149, 32150, 32172, 32171, 32875, 32919, 32920, 32917
13445, 32150, 32151, 32173, 32172, 32877, 32921, 32922, 32919
13446, 32151, 32152, 32174, 32173, 32879, 32923, 32924, 32921
13447, 32152, 32153, 32175, 32174, 32881, 32925, 32926, 32923
13448, 32153, 32154, 32176, 32175, 32883, 32927, 32928, 32925
13449, 32154, 32155, 32177, 32176, 32885, 32929, 32930, 32927
13450, 32155, 32156, 32178, 32177, 32887, 32931, 32932, 32929
13451, 32156, 32157, 32179, 32178, 32889, 32933, 32934, 32931
13452, 32157, 32158, 32180, 32179, 32891, 32935, 32936, 32933
13453, 32158, 32159, 32181, 32180, 32893, 32937, 32938, 32935
13454, 32159, 32160, 32182, 32181, 32895, 32939, 32940, 32937
13455, 32160, 32161, 32183, 32182, 32897, 32941, 32942, 32939
13456, 32161, 3696, 3697, 32183, 32898, 3719, 32943, 32941
13457, 3638, 32162, 32184, 3639, 32900, 32944, 32945, 3661
13458, 32162, 32163, 32185, 32184, 32902, 32946, 32947, 32944
13459, 32163, 32164, 32186, 32185, 32904, 32948, 32949, 32946
13460, 32164, 32165, 32187, 32186, 32906, 32950, 32951, 32948
13461, 32165, 32166, 32188, 32187, 32908, 32952, 32953, 32950
13462, 32166, 32167, 32189, 32188, 32910, 32954, 32955, 32952
13463, 32167, 32168, 32190, 32189, 32912, 32956, 32957, 32954
13464, 32168, 32169, 32191, 32190, 32914, 32958, 32959, 32956
13465, 32169, 32170, 32192, 32191, 32916, 32960, 32961, 32958
13466, 32170, 32171, 32193, 32192, 32918, 32962, 32963, 32960
13467, 32171, 32172, 32194, 32193, 32920, 32964, 32965, 32962
13468, 32172, 32173, 32195, 32194, 32922, 32966, 32967, 32964
13469, 32173, 32174, 32196, 32195, 32924, 32968, 32969, 32966
13470, 32174, 32175, 32197, 32196, 32926, 32970, 32971, 32968
13471, 32175, 32176, 32198, 32197, 32928, 32972, 32973, 32970
13472, 32176, 32177, 32199, 32198, 32930, 32974, 32975, 32972
13473, 32177, 32178, 32200, 32199, 32932, 32976, 32977, 32974
13474, 32178, 32179, 32201, 32200, 32934, 32978, 32979, 32976
13475, 32179, 32180, 32202, 32201, 32936, 32980, 32981, 32978
13476, 32180, 32181, 32203, 32202, 32938, 32982, 32983, 32980
13477, 32181, 32182, 32204, 32203, 32940, 32984, 32985, 32982
13478, 32182, 32183, 32205, 32204, 32942, 32986, 32987, 32984
13479, 32183, 3697, 3698, 32205, 32943, 3720, 32988, 32986
