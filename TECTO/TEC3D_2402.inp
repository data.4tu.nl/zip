49500, 0.97826086956522, 0.8804347826087, 0.33333333333333
49501, 0.95652173913044, 0.85434782608696, 0.33333333333333
49502, 0.95652173913044, 0.8804347826087, 0.36111111111111
49503, 0.97826086956522, 0.88043478260869, 0.38888888888889
49504, 0.95652173913044, 0.85434782608696, 0.38888888888889
49505, 0.95652173913044, 0.88043478260869, 0.41666666666667
49506, 0.97826086956522, 0.88043478260869, 0.44444444444444
49507, 0.95652173913044, 0.85434782608696, 0.44444444444444
49508, 0.95652173913043, 0.88043478260869, 0.47222222222222
49509, 0.91304347826087, 0.8804347826087, 0.027777777777778
49510, 0.93478260869565, 0.88043478260869, 0.055555555555556
49511, 0.91304347826087, 0.85434782608696, 0.055555555555556
49512, 0.91304347826087, 0.88043478260869, 0.083333333333333
49513, 0.93478260869565, 0.88043478260869, 0.11111111111111
49514, 0.91304347826087, 0.85434782608696, 0.11111111111111
49515, 0.91304347826087, 0.88043478260869, 0.13888888888889
49516, 0.93478260869565, 0.8804347826087, 0.16666666666667
49517, 0.91304347826087, 0.85434782608696, 0.16666666666667
49518, 0.91304347826087, 0.8804347826087, 0.19444444444444
49519, 0.93478260869565, 0.8804347826087, 0.22222222222222
49520, 0.91304347826087, 0.85434782608696, 0.22222222222222
49521, 0.91304347826087, 0.8804347826087, 0.25
49522, 0.93478260869565, 0.88043478260869, 0.27777777777778
49523, 0.91304347826087, 0.85434782608696, 0.27777777777778
49524, 0.91304347826087, 0.88043478260869, 0.30555555555556
49525, 0.93478260869565, 0.8804347826087, 0.33333333333333
49526, 0.91304347826087, 0.85434782608696, 0.33333333333333
49527, 0.91304347826087, 0.88043478260869, 0.36111111111111
49528, 0.93478260869565, 0.88043478260869, 0.38888888888889
49529, 0.91304347826087, 0.85434782608696, 0.38888888888889
49530, 0.91304347826087, 0.88043478260869, 0.41666666666667
49531, 0.93478260869565, 0.88043478260869, 0.44444444444444
49532, 0.91304347826087, 0.85434782608696, 0.44444444444444
49533, 0.91304347826087, 0.8804347826087, 0.47222222222222
49534, 0.8695652173913, 0.88043478260869, 0.027777777777778
49535, 0.89130434782609, 0.88043478260869, 0.055555555555556
49536, 0.8695652173913, 0.85434782608696, 0.055555555555556
49537, 0.8695652173913, 0.88043478260869, 0.083333333333333
49538, 0.89130434782609, 0.88043478260869, 0.11111111111111
49539, 0.8695652173913, 0.85434782608696, 0.11111111111111
49540, 0.8695652173913, 0.8804347826087, 0.13888888888889
49541, 0.89130434782609, 0.8804347826087, 0.16666666666667
49542, 0.8695652173913, 0.85434782608696, 0.16666666666667
49543, 0.8695652173913, 0.88043478260869, 0.19444444444444
49544, 0.89130434782609, 0.88043478260869, 0.22222222222222
49545, 0.8695652173913, 0.85434782608696, 0.22222222222222
49546, 0.8695652173913, 0.88043478260869, 0.25
49547, 0.89130434782609, 0.8804347826087, 0.27777777777778
49548, 0.8695652173913, 0.85434782608696, 0.27777777777778
49549, 0.8695652173913, 0.8804347826087, 0.30555555555556
49550, 0.89130434782609, 0.88043478260869, 0.33333333333333
49551, 0.8695652173913, 0.85434782608696, 0.33333333333333
49552, 0.8695652173913, 0.8804347826087, 0.36111111111111
49553, 0.89130434782609, 0.88043478260869, 0.38888888888889
49554, 0.8695652173913, 0.85434782608696, 0.38888888888889
49555, 0.8695652173913, 0.88043478260869, 0.41666666666667
49556, 0.89130434782609, 0.88043478260869, 0.44444444444444
49557, 0.8695652173913, 0.85434782608696, 0.44444444444444
49558, 0.8695652173913, 0.88043478260869, 0.47222222222222
49559, 0.82608695652174, 0.8804347826087, 0.027777777777778
49560, 0.84782608695652, 0.88043478260869, 0.055555555555556
49561, 0.82608695652174, 0.85434782608696, 0.055555555555556
49562, 0.82608695652174, 0.8804347826087, 0.083333333333333
49563, 0.84782608695652, 0.8804347826087, 0.11111111111111
49564, 0.82608695652174, 0.85434782608696, 0.11111111111111
49565, 0.82608695652174, 0.8804347826087, 0.13888888888889
49566, 0.84782608695652, 0.8804347826087, 0.16666666666667
49567, 0.82608695652174, 0.85434782608696, 0.16666666666667
49568, 0.82608695652174, 0.8804347826087, 0.19444444444444
49569, 0.84782608695652, 0.8804347826087, 0.22222222222222
49570, 0.82608695652174, 0.85434782608696, 0.22222222222222
49571, 0.82608695652174, 0.8804347826087, 0.25
49572, 0.84782608695652, 0.8804347826087, 0.27777777777778
49573, 0.82608695652174, 0.85434782608696, 0.27777777777778
49574, 0.82608695652174, 0.8804347826087, 0.30555555555556
49575, 0.84782608695652, 0.8804347826087, 0.33333333333333
49576, 0.82608695652174, 0.85434782608696, 0.33333333333333
49577, 0.82608695652174, 0.8804347826087, 0.36111111111111
49578, 0.84782608695652, 0.8804347826087, 0.38888888888889
49579, 0.82608695652174, 0.85434782608696, 0.38888888888889
49580, 0.82608695652174, 0.8804347826087, 0.41666666666667
49581, 0.84782608695652, 0.8804347826087, 0.44444444444444
49582, 0.82608695652174, 0.85434782608696, 0.44444444444444
49583, 0.82608695652174, 0.8804347826087, 0.47222222222222
49584, 0.78260869565217, 0.88043478260869, 0.027777777777778
49585, 0.80434782608696, 0.88043478260869, 0.055555555555556
49586, 0.78260869565217, 0.85434782608696, 0.055555555555556
49587, 0.78260869565217, 0.88043478260869, 0.083333333333333
49588, 0.80434782608696, 0.8804347826087, 0.11111111111111
49589, 0.78260869565217, 0.85434782608696, 0.11111111111111
49590, 0.78260869565217, 0.88043478260869, 0.13888888888889
49591, 0.80434782608696, 0.88043478260869, 0.16666666666667
49592, 0.78260869565217, 0.85434782608696, 0.16666666666667
49593, 0.78260869565217, 0.88043478260869, 0.19444444444444
49594, 0.80434782608696, 0.8804347826087, 0.22222222222222
49595, 0.78260869565217, 0.85434782608696, 0.22222222222222
49596, 0.78260869565217, 0.88043478260869, 0.25
49597, 0.80434782608696, 0.8804347826087, 0.27777777777778
49598, 0.78260869565217, 0.85434782608696, 0.27777777777778
49599, 0.78260869565217, 0.88043478260869, 0.30555555555556
49600, 0.80434782608696, 0.8804347826087, 0.33333333333333
49601, 0.78260869565217, 0.85434782608696, 0.33333333333333
49602, 0.78260869565217, 0.88043478260869, 0.36111111111111
49603, 0.80434782608696, 0.8804347826087, 0.38888888888889
49604, 0.78260869565217, 0.85434782608696, 0.38888888888889
49605, 0.78260869565217, 0.88043478260869, 0.41666666666667
49606, 0.80434782608696, 0.8804347826087, 0.44444444444444
49607, 0.78260869565217, 0.85434782608696, 0.44444444444444
49608, 0.78260869565217, 0.88043478260869, 0.47222222222222
49609, 0.73913043478261, 0.8804347826087, 0.027777777777778
49610, 0.76086956521739, 0.88043478260869, 0.055555555555556
49611, 0.73913043478261, 0.85434782608696, 0.055555555555556
49612, 0.73913043478261, 0.8804347826087, 0.083333333333333
49613, 0.76086956521739, 0.88043478260869, 0.11111111111111
49614, 0.73913043478261, 0.85434782608696, 0.11111111111111
49615, 0.73913043478261, 0.88043478260869, 0.13888888888889
49616, 0.76086956521739, 0.88043478260869, 0.16666666666667
49617, 0.73913043478261, 0.85434782608696, 0.16666666666667
49618, 0.73913043478261, 0.88043478260869, 0.19444444444444
49619, 0.76086956521739, 0.88043478260869, 0.22222222222222
49620, 0.73913043478261, 0.85434782608696, 0.22222222222222
49621, 0.73913043478261, 0.88043478260869, 0.25
49622, 0.76086956521739, 0.88043478260869, 0.27777777777778
49623, 0.73913043478261, 0.85434782608696, 0.27777777777778
49624, 0.73913043478261, 0.88043478260869, 0.30555555555556
49625, 0.76086956521739, 0.88043478260869, 0.33333333333333
49626, 0.73913043478261, 0.85434782608696, 0.33333333333333
49627, 0.73913043478261, 0.88043478260869, 0.36111111111111
49628, 0.76086956521739, 0.88043478260869, 0.38888888888889
49629, 0.73913043478261, 0.85434782608696, 0.38888888888889
49630, 0.73913043478261, 0.88043478260869, 0.41666666666667
49631, 0.76086956521739, 0.88043478260869, 0.44444444444444
49632, 0.73913043478261, 0.85434782608696, 0.44444444444444
49633, 0.73913043478261, 0.8804347826087, 0.47222222222222
49634, 0.69565217391304, 0.88043478260869, 0.027777777777778
49635, 0.71739130434783, 0.88043478260869, 0.055555555555556
49636, 0.69565217391304, 0.85434782608696, 0.055555555555556
49637, 0.69565217391304, 0.88043478260869, 0.083333333333333
49638, 0.71739130434783, 0.88043478260869, 0.11111111111111
49639, 0.69565217391304, 0.85434782608696, 0.11111111111111
49640, 0.69565217391304, 0.88043478260869, 0.13888888888889
49641, 0.71739130434783, 0.88043478260869, 0.16666666666667
49642, 0.69565217391304, 0.85434782608696, 0.16666666666667
49643, 0.69565217391304, 0.88043478260869, 0.19444444444444
49644, 0.71739130434783, 0.88043478260869, 0.22222222222222
49645, 0.69565217391304, 0.85434782608696, 0.22222222222222
49646, 0.69565217391304, 0.8804347826087, 0.25
49647, 0.71739130434783, 0.88043478260869, 0.27777777777778
49648, 0.69565217391304, 0.85434782608696, 0.27777777777778
49649, 0.69565217391304, 0.8804347826087, 0.30555555555556
49650, 0.71739130434783, 0.8804347826087, 0.33333333333333
49651, 0.69565217391304, 0.85434782608696, 0.33333333333333
49652, 0.69565217391304, 0.88043478260869, 0.36111111111111
49653, 0.71739130434783, 0.88043478260869, 0.38888888888889
49654, 0.69565217391304, 0.85434782608696, 0.38888888888889
49655, 0.69565217391304, 0.88043478260869, 0.41666666666667
49656, 0.71739130434783, 0.88043478260869, 0.44444444444444
49657, 0.69565217391304, 0.85434782608696, 0.44444444444444
49658, 0.69565217391304, 0.88043478260869, 0.47222222222222
49659, 0.65217391304348, 0.8804347826087, 0.027777777777778
49660, 0.67391304347826, 0.88043478260869, 0.055555555555556
49661, 0.65217391304348, 0.85434782608696, 0.055555555555556
49662, 0.65217391304348, 0.8804347826087, 0.083333333333333
49663, 0.67391304347826, 0.8804347826087, 0.11111111111111
49664, 0.65217391304348, 0.85434782608696, 0.11111111111111
49665, 0.65217391304348, 0.8804347826087, 0.13888888888889
49666, 0.67391304347826, 0.8804347826087, 0.16666666666667
49667, 0.65217391304348, 0.85434782608696, 0.16666666666667
49668, 0.65217391304348, 0.8804347826087, 0.19444444444444
49669, 0.67391304347826, 0.8804347826087, 0.22222222222222
49670, 0.65217391304348, 0.85434782608696, 0.22222222222222
49671, 0.65217391304348, 0.8804347826087, 0.25
49672, 0.67391304347826, 0.8804347826087, 0.27777777777778
49673, 0.65217391304348, 0.85434782608696, 0.27777777777778
49674, 0.65217391304348, 0.8804347826087, 0.30555555555556
49675, 0.67391304347826, 0.8804347826087, 0.33333333333333
49676, 0.65217391304348, 0.85434782608696, 0.33333333333333
49677, 0.65217391304348, 0.8804347826087, 0.36111111111111
49678, 0.67391304347826, 0.8804347826087, 0.38888888888889
49679, 0.65217391304348, 0.85434782608696, 0.38888888888889
49680, 0.65217391304348, 0.8804347826087, 0.41666666666667
49681, 0.67391304347826, 0.8804347826087, 0.44444444444444
49682, 0.65217391304348, 0.85434782608696, 0.44444444444444
49683, 0.65217391304348, 0.8804347826087, 0.47222222222222
49684, 0.60869565217391, 0.8804347826087, 0.027777777777778
49685, 0.6304347826087, 0.8804347826087, 0.055555555555556
49686, 0.60869565217391, 0.85434782608696, 0.055555555555556
49687, 0.60869565217391, 0.8804347826087, 0.083333333333333
49688, 0.6304347826087, 0.8804347826087, 0.11111111111111
49689, 0.60869565217391, 0.85434782608696, 0.11111111111111
49690, 0.60869565217391, 0.8804347826087, 0.13888888888889
49691, 0.6304347826087, 0.8804347826087, 0.16666666666667
49692, 0.60869565217391, 0.85434782608696, 0.16666666666667
49693, 0.60869565217391, 0.8804347826087, 0.19444444444444
49694, 0.6304347826087, 0.8804347826087, 0.22222222222222
49695, 0.60869565217391, 0.85434782608696, 0.22222222222222
49696, 0.60869565217391, 0.8804347826087, 0.25
49697, 0.6304347826087, 0.8804347826087, 0.27777777777778
49698, 0.60869565217391, 0.85434782608696, 0.27777777777778
49699, 0.60869565217391, 0.8804347826087, 0.30555555555556
49700, 0.6304347826087, 0.8804347826087, 0.33333333333333
49701, 0.60869565217391, 0.85434782608696, 0.33333333333333
49702, 0.60869565217391, 0.8804347826087, 0.36111111111111
49703, 0.6304347826087, 0.8804347826087, 0.38888888888889
49704, 0.60869565217391, 0.85434782608696, 0.38888888888889
49705, 0.60869565217391, 0.8804347826087, 0.41666666666667
49706, 0.6304347826087, 0.8804347826087, 0.44444444444444
49707, 0.60869565217391, 0.85434782608696, 0.44444444444444
49708, 0.60869565217391, 0.8804347826087, 0.47222222222222
49709, 0.56521739130435, 0.88043478260869, 0.027777777777778
49710, 0.58695652173913, 0.88043478260869, 0.055555555555556
49711, 0.56521739130435, 0.85434782608696, 0.055555555555556
49712, 0.56521739130435, 0.88043478260869, 0.083333333333333
49713, 0.58695652173913, 0.8804347826087, 0.11111111111111
49714, 0.56521739130435, 0.85434782608696, 0.11111111111111
49715, 0.56521739130435, 0.88043478260869, 0.13888888888889
49716, 0.58695652173913, 0.8804347826087, 0.16666666666667
49717, 0.56521739130435, 0.85434782608696, 0.16666666666667
49718, 0.56521739130435, 0.88043478260869, 0.19444444444444
49719, 0.58695652173913, 0.88043478260869, 0.22222222222222
49720, 0.56521739130435, 0.85434782608696, 0.22222222222222
49721, 0.56521739130435, 0.88043478260869, 0.25
49722, 0.58695652173913, 0.8804347826087, 0.27777777777778
49723, 0.56521739130435, 0.85434782608696, 0.27777777777778
49724, 0.56521739130435, 0.88043478260869, 0.30555555555556
49725, 0.58695652173913, 0.8804347826087, 0.33333333333333
49726, 0.56521739130435, 0.85434782608696, 0.33333333333333
49727, 0.56521739130435, 0.88043478260869, 0.36111111111111
49728, 0.58695652173913, 0.88043478260869, 0.38888888888889
49729, 0.56521739130435, 0.85434782608696, 0.38888888888889
49730, 0.56521739130435, 0.88043478260869, 0.41666666666667
49731, 0.58695652173913, 0.88043478260869, 0.44444444444444
49732, 0.56521739130435, 0.85434782608696, 0.44444444444444
49733, 0.56521739130435, 0.88043478260869, 0.47222222222222
49734, 0.52173913043478, 0.88043478260869, 0.027777777777778
49735, 0.54347826086957, 0.88043478260869, 0.055555555555556
49736, 0.52173913043478, 0.85434782608696, 0.055555555555556
49737, 0.52173913043478, 0.88043478260869, 0.083333333333333
49738, 0.54347826086957, 0.88043478260869, 0.11111111111111
49739, 0.52173913043478, 0.85434782608696, 0.11111111111111
49740, 0.52173913043478, 0.88043478260869, 0.13888888888889
49741, 0.54347826086957, 0.88043478260869, 0.16666666666667
49742, 0.52173913043478, 0.85434782608696, 0.16666666666667
49743, 0.52173913043478, 0.88043478260869, 0.19444444444444
49744, 0.54347826086956, 0.88043478260869, 0.22222222222222
49745, 0.52173913043478, 0.85434782608696, 0.22222222222222
49746, 0.52173913043478, 0.88043478260869, 0.25
49747, 0.54347826086956, 0.88043478260869, 0.27777777777778
49748, 0.52173913043478, 0.85434782608696, 0.27777777777778
49749, 0.52173913043478, 0.88043478260869, 0.30555555555556
49750, 0.54347826086956, 0.8804347826087, 0.33333333333333
49751, 0.52173913043478, 0.85434782608696, 0.33333333333333
49752, 0.52173913043478, 0.88043478260869, 0.36111111111111
49753, 0.54347826086956, 0.88043478260869, 0.38888888888889
49754, 0.52173913043478, 0.85434782608696, 0.38888888888889
49755, 0.52173913043478, 0.88043478260869, 0.41666666666667
49756, 0.54347826086956, 0.88043478260869, 0.44444444444444
49757, 0.52173913043478, 0.85434782608696, 0.44444444444444
49758, 0.52173913043478, 0.88043478260869, 0.47222222222222
49759, 0.47826086956522, 0.88043478260869, 0.027777777777778
49760, 0.5, 0.88043478260869, 0.055555555555556
49761, 0.47826086956522, 0.85434782608696, 0.055555555555556
49762, 0.47826086956522, 0.88043478260869, 0.083333333333333
49763, 0.5, 0.88043478260869, 0.11111111111111
49764, 0.47826086956522, 0.85434782608696, 0.11111111111111
49765, 0.47826086956522, 0.88043478260869, 0.13888888888889
49766, 0.5, 0.88043478260869, 0.16666666666667
49767, 0.47826086956522, 0.85434782608696, 0.16666666666667
49768, 0.47826086956522, 0.88043478260869, 0.19444444444444
49769, 0.5, 0.88043478260869, 0.22222222222222
49770, 0.47826086956522, 0.85434782608696, 0.22222222222222
49771, 0.47826086956522, 0.88043478260869, 0.25
49772, 0.5, 0.88043478260869, 0.27777777777778
49773, 0.47826086956522, 0.85434782608696, 0.27777777777778
49774, 0.47826086956522, 0.88043478260869, 0.30555555555556
49775, 0.5, 0.88043478260869, 0.33333333333333
49776, 0.47826086956522, 0.85434782608696, 0.33333333333333
49777, 0.47826086956522, 0.88043478260869, 0.36111111111111
49778, 0.5, 0.88043478260869, 0.38888888888889
49779, 0.47826086956522, 0.85434782608696, 0.38888888888889
49780, 0.47826086956522, 0.88043478260869, 0.41666666666667
49781, 0.5, 0.88043478260869, 0.44444444444444
49782, 0.47826086956522, 0.85434782608696, 0.44444444444444
49783, 0.47826086956522, 0.88043478260869, 0.47222222222222
49784, 0.43478260869565, 0.88043478260869, 0.027777777777778
49785, 0.45652173913043, 0.88043478260869, 0.055555555555556
49786, 0.43478260869565, 0.85434782608696, 0.055555555555556
49787, 0.43478260869565, 0.88043478260869, 0.083333333333333
49788, 0.45652173913043, 0.88043478260869, 0.11111111111111
49789, 0.43478260869565, 0.85434782608696, 0.11111111111111
49790, 0.43478260869565, 0.88043478260869, 0.13888888888889
49791, 0.45652173913043, 0.88043478260869, 0.16666666666667
49792, 0.43478260869565, 0.85434782608696, 0.16666666666667
49793, 0.43478260869565, 0.88043478260869, 0.19444444444444
49794, 0.45652173913043, 0.88043478260869, 0.22222222222222
49795, 0.43478260869565, 0.85434782608696, 0.22222222222222
49796, 0.43478260869565, 0.88043478260869, 0.25
49797, 0.45652173913043, 0.88043478260869, 0.27777777777778
49798, 0.43478260869565, 0.85434782608696, 0.27777777777778
49799, 0.43478260869565, 0.88043478260869, 0.30555555555556
49800, 0.45652173913043, 0.88043478260869, 0.33333333333333
49801, 0.43478260869565, 0.85434782608696, 0.33333333333333
49802, 0.43478260869565, 0.88043478260869, 0.36111111111111
49803, 0.45652173913044, 0.88043478260869, 0.38888888888889
49804, 0.43478260869565, 0.85434782608696, 0.38888888888889
49805, 0.43478260869565, 0.88043478260869, 0.41666666666667
49806, 0.45652173913043, 0.88043478260869, 0.44444444444444
49807, 0.43478260869565, 0.85434782608696, 0.44444444444444
49808, 0.43478260869565, 0.88043478260869, 0.47222222222222
49809, 0.39130434782609, 0.88043478260869, 0.027777777777778
49810, 0.41304347826087, 0.88043478260869, 0.055555555555556
49811, 0.39130434782609, 0.85434782608696, 0.055555555555556
49812, 0.39130434782609, 0.88043478260869, 0.083333333333333
49813, 0.41304347826087, 0.88043478260869, 0.11111111111111
49814, 0.39130434782609, 0.85434782608696, 0.11111111111111
49815, 0.39130434782609, 0.8804347826087, 0.13888888888889
49816, 0.41304347826087, 0.8804347826087, 0.16666666666667
49817, 0.39130434782609, 0.85434782608696, 0.16666666666667
49818, 0.39130434782609, 0.8804347826087, 0.19444444444444
49819, 0.41304347826087, 0.88043478260869, 0.22222222222222
49820, 0.39130434782609, 0.85434782608696, 0.22222222222222
49821, 0.39130434782609, 0.88043478260869, 0.25
49822, 0.41304347826087, 0.88043478260869, 0.27777777777778
49823, 0.39130434782609, 0.85434782608696, 0.27777777777778
49824, 0.39130434782609, 0.88043478260869, 0.30555555555556
49825, 0.41304347826087, 0.88043478260869, 0.33333333333333
49826, 0.39130434782609, 0.85434782608696, 0.33333333333333
49827, 0.39130434782609, 0.88043478260869, 0.36111111111111
49828, 0.41304347826087, 0.88043478260869, 0.38888888888889
49829, 0.39130434782609, 0.85434782608696, 0.38888888888889
49830, 0.39130434782609, 0.88043478260869, 0.41666666666667
49831, 0.41304347826087, 0.88043478260869, 0.44444444444444
49832, 0.39130434782609, 0.85434782608696, 0.44444444444444
49833, 0.39130434782609, 0.88043478260869, 0.47222222222222
49834, 0.34782608695652, 0.8804347826087, 0.027777777777778
49835, 0.3695652173913, 0.88043478260869, 0.055555555555556
49836, 0.34782608695652, 0.85434782608696, 0.055555555555556
49837, 0.34782608695652, 0.8804347826087, 0.083333333333333
49838, 0.3695652173913, 0.88043478260869, 0.11111111111111
49839, 0.34782608695652, 0.85434782608696, 0.11111111111111
49840, 0.34782608695652, 0.8804347826087, 0.13888888888889
49841, 0.3695652173913, 0.8804347826087, 0.16666666666667
49842, 0.34782608695652, 0.85434782608696, 0.16666666666667
49843, 0.34782608695652, 0.8804347826087, 0.19444444444444
49844, 0.3695652173913, 0.8804347826087, 0.22222222222222
49845, 0.34782608695652, 0.85434782608696, 0.22222222222222
49846, 0.34782608695652, 0.8804347826087, 0.25
49847, 0.3695652173913, 0.8804347826087, 0.27777777777778
49848, 0.34782608695652, 0.85434782608696, 0.27777777777778
49849, 0.34782608695652, 0.8804347826087, 0.30555555555556
49850, 0.3695652173913, 0.88043478260869, 0.33333333333333
49851, 0.34782608695652, 0.85434782608696, 0.33333333333333
49852, 0.34782608695652, 0.8804347826087, 0.36111111111111
49853, 0.3695652173913, 0.8804347826087, 0.38888888888889
49854, 0.34782608695652, 0.85434782608696, 0.38888888888889
49855, 0.34782608695652, 0.88043478260869, 0.41666666666667
49856, 0.3695652173913, 0.88043478260869, 0.44444444444444
49857, 0.34782608695652, 0.85434782608696, 0.44444444444444
49858, 0.34782608695652, 0.88043478260869, 0.47222222222222
49859, 0.30434782608696, 0.88043478260869, 0.027777777777778
49860, 0.32608695652174, 0.88043478260869, 0.055555555555556
49861, 0.30434782608696, 0.85434782608696, 0.055555555555556
49862, 0.30434782608696, 0.88043478260869, 0.083333333333333
49863, 0.32608695652174, 0.8804347826087, 0.11111111111111
49864, 0.30434782608696, 0.85434782608696, 0.11111111111111
49865, 0.30434782608696, 0.88043478260869, 0.13888888888889
49866, 0.32608695652174, 0.88043478260869, 0.16666666666667
49867, 0.30434782608696, 0.85434782608696, 0.16666666666667
49868, 0.30434782608696, 0.88043478260869, 0.19444444444444
49869, 0.32608695652174, 0.8804347826087, 0.22222222222222
49870, 0.30434782608696, 0.85434782608696, 0.22222222222222
49871, 0.30434782608696, 0.88043478260869, 0.25
49872, 0.32608695652174, 0.8804347826087, 0.27777777777778
49873, 0.30434782608696, 0.85434782608696, 0.27777777777778
49874, 0.30434782608696, 0.88043478260869, 0.30555555555556
49875, 0.32608695652174, 0.88043478260869, 0.33333333333333
49876, 0.30434782608696, 0.85434782608696, 0.33333333333333
49877, 0.30434782608696, 0.88043478260869, 0.36111111111111
49878, 0.32608695652174, 0.8804347826087, 0.38888888888889
49879, 0.30434782608696, 0.85434782608696, 0.38888888888889
49880, 0.30434782608696, 0.88043478260869, 0.41666666666667
49881, 0.32608695652174, 0.88043478260869, 0.44444444444444
49882, 0.30434782608696, 0.85434782608696, 0.44444444444444
49883, 0.30434782608696, 0.88043478260869, 0.47222222222222
49884, 0.26086956521739, 0.88043478260869, 0.027777777777778
49885, 0.28260869565217, 0.88043478260869, 0.055555555555556
49886, 0.26086956521739, 0.85434782608696, 0.055555555555556
49887, 0.26086956521739, 0.88043478260869, 0.083333333333333
49888, 0.28260869565217, 0.88043478260869, 0.11111111111111
49889, 0.26086956521739, 0.85434782608696, 0.11111111111111
49890, 0.26086956521739, 0.88043478260869, 0.13888888888889
49891, 0.28260869565217, 0.88043478260869, 0.16666666666667
49892, 0.26086956521739, 0.85434782608696, 0.16666666666667
49893, 0.26086956521739, 0.88043478260869, 0.19444444444444
49894, 0.28260869565217, 0.88043478260869, 0.22222222222222
49895, 0.26086956521739, 0.85434782608696, 0.22222222222222
49896, 0.26086956521739, 0.88043478260869, 0.25
49897, 0.28260869565217, 0.88043478260869, 0.27777777777778
49898, 0.26086956521739, 0.85434782608696, 0.27777777777778
49899, 0.26086956521739, 0.88043478260869, 0.30555555555556
49900, 0.28260869565217, 0.8804347826087, 0.33333333333333
49901, 0.26086956521739, 0.85434782608696, 0.33333333333333
49902, 0.26086956521739, 0.88043478260869, 0.36111111111111
49903, 0.28260869565217, 0.88043478260869, 0.38888888888889
49904, 0.26086956521739, 0.85434782608696, 0.38888888888889
49905, 0.26086956521739, 0.88043478260869, 0.41666666666667
49906, 0.28260869565217, 0.88043478260869, 0.44444444444444
49907, 0.26086956521739, 0.85434782608696, 0.44444444444444
49908, 0.26086956521739, 0.88043478260869, 0.47222222222222
49909, 0.21739130434783, 0.88043478260869, 0.027777777777778
49910, 0.23913043478261, 0.88043478260869, 0.055555555555556
49911, 0.21739130434783, 0.85434782608696, 0.055555555555556
49912, 0.21739130434783, 0.88043478260869, 0.083333333333333
49913, 0.23913043478261, 0.88043478260869, 0.11111111111111
49914, 0.21739130434783, 0.85434782608696, 0.11111111111111
49915, 0.21739130434783, 0.88043478260869, 0.13888888888889
49916, 0.23913043478261, 0.88043478260869, 0.16666666666667
49917, 0.21739130434783, 0.85434782608696, 0.16666666666667
49918, 0.21739130434783, 0.88043478260869, 0.19444444444444
49919, 0.23913043478261, 0.88043478260869, 0.22222222222222
49920, 0.21739130434783, 0.85434782608696, 0.22222222222222
49921, 0.21739130434783, 0.88043478260869, 0.25
49922, 0.23913043478261, 0.88043478260869, 0.27777777777778
49923, 0.21739130434783, 0.85434782608696, 0.27777777777778
49924, 0.21739130434783, 0.88043478260869, 0.30555555555556
49925, 0.23913043478261, 0.88043478260869, 0.33333333333333
49926, 0.21739130434783, 0.85434782608696, 0.33333333333333
49927, 0.21739130434783, 0.88043478260869, 0.36111111111111
49928, 0.23913043478261, 0.88043478260869, 0.38888888888889
49929, 0.21739130434783, 0.85434782608696, 0.38888888888889
49930, 0.21739130434783, 0.88043478260869, 0.41666666666667
49931, 0.23913043478261, 0.88043478260869, 0.44444444444444
49932, 0.21739130434783, 0.85434782608696, 0.44444444444444
49933, 0.21739130434783, 0.88043478260869, 0.47222222222222
49934, 0.17391304347826, 0.8804347826087, 0.027777777777778
49935, 0.19565217391304, 0.88043478260869, 0.055555555555556
49936, 0.17391304347826, 0.85434782608696, 0.055555555555556
49937, 0.17391304347826, 0.88043478260869, 0.083333333333333
49938, 0.19565217391304, 0.88043478260869, 0.11111111111111
49939, 0.17391304347826, 0.85434782608696, 0.11111111111111
49940, 0.17391304347826, 0.88043478260869, 0.13888888888889
49941, 0.19565217391304, 0.88043478260869, 0.16666666666667
49942, 0.17391304347826, 0.85434782608696, 0.16666666666667
49943, 0.17391304347826, 0.88043478260869, 0.19444444444444
49944, 0.19565217391304, 0.88043478260869, 0.22222222222222
49945, 0.17391304347826, 0.85434782608696, 0.22222222222222
49946, 0.17391304347826, 0.88043478260869, 0.25
49947, 0.19565217391304, 0.88043478260869, 0.27777777777778
49948, 0.17391304347826, 0.85434782608696, 0.27777777777778
49949, 0.17391304347826, 0.88043478260869, 0.30555555555556
49950, 0.19565217391304, 0.88043478260869, 0.33333333333333
49951, 0.17391304347826, 0.85434782608696, 0.33333333333333
49952, 0.17391304347826, 0.88043478260869, 0.36111111111111
49953, 0.19565217391304, 0.88043478260869, 0.38888888888889
49954, 0.17391304347826, 0.85434782608696, 0.38888888888889
49955, 0.17391304347826, 0.88043478260869, 0.41666666666667
49956, 0.19565217391304, 0.88043478260869, 0.44444444444444
49957, 0.17391304347826, 0.85434782608696, 0.44444444444444
49958, 0.17391304347826, 0.88043478260869, 0.47222222222222
49959, 0.1304347826087, 0.8804347826087, 0.027777777777778
49960, 0.15217391304348, 0.8804347826087, 0.055555555555556
49961, 0.1304347826087, 0.85434782608696, 0.055555555555556
49962, 0.1304347826087, 0.88043478260869, 0.083333333333333
49963, 0.15217391304348, 0.88043478260869, 0.11111111111111
49964, 0.1304347826087, 0.85434782608696, 0.11111111111111
49965, 0.1304347826087, 0.88043478260869, 0.13888888888889
49966, 0.15217391304348, 0.8804347826087, 0.16666666666667
49967, 0.1304347826087, 0.85434782608696, 0.16666666666667
49968, 0.1304347826087, 0.88043478260869, 0.19444444444444
49969, 0.15217391304348, 0.88043478260869, 0.22222222222222
49970, 0.1304347826087, 0.85434782608696, 0.22222222222222
49971, 0.1304347826087, 0.88043478260869, 0.25
49972, 0.15217391304348, 0.88043478260869, 0.27777777777778
49973, 0.1304347826087, 0.85434782608696, 0.27777777777778
49974, 0.1304347826087, 0.88043478260869, 0.30555555555556
49975, 0.15217391304348, 0.88043478260869, 0.33333333333333
49976, 0.1304347826087, 0.85434782608696, 0.33333333333333
49977, 0.1304347826087, 0.88043478260869, 0.36111111111111
49978, 0.15217391304348, 0.88043478260869, 0.38888888888889
49979, 0.1304347826087, 0.85434782608696, 0.38888888888889
49980, 0.1304347826087, 0.88043478260869, 0.41666666666667
49981, 0.15217391304348, 0.88043478260869, 0.44444444444444
49982, 0.1304347826087, 0.85434782608696, 0.44444444444444
49983, 0.1304347826087, 0.88043478260869, 0.47222222222222
49984, 0.08695652173913, 0.8804347826087, 0.027777777777778
49985, 0.10869565217391, 0.8804347826087, 0.055555555555556
49986, 0.08695652173913, 0.85434782608696, 0.055555555555556
49987, 0.08695652173913, 0.8804347826087, 0.083333333333333
49988, 0.10869565217391, 0.88043478260869, 0.11111111111111
49989, 0.08695652173913, 0.85434782608696, 0.11111111111111
49990, 0.08695652173913, 0.8804347826087, 0.13888888888889
49991, 0.10869565217391, 0.8804347826087, 0.16666666666667
49992, 0.08695652173913, 0.85434782608696, 0.16666666666667
49993, 0.08695652173913, 0.8804347826087, 0.19444444444444
49994, 0.10869565217391, 0.88043478260869, 0.22222222222222
49995, 0.08695652173913, 0.85434782608696, 0.22222222222222
49996, 0.08695652173913, 0.8804347826087, 0.25
49997, 0.10869565217391, 0.88043478260869, 0.27777777777778
49998, 0.08695652173913, 0.85434782608696, 0.27777777777778
49999, 0.08695652173913, 0.8804347826087, 0.30555555555556
50000, 0.10869565217391, 0.8804347826087, 0.33333333333333
50001, 0.08695652173913, 0.85434782608696, 0.33333333333333
50002, 0.08695652173913, 0.8804347826087, 0.36111111111111
50003, 0.10869565217391, 0.88043478260869, 0.38888888888889
50004, 0.08695652173913, 0.85434782608696, 0.38888888888889
50005, 0.08695652173913, 0.8804347826087, 0.41666666666667
50006, 0.10869565217391, 0.88043478260869, 0.44444444444444
50007, 0.08695652173913, 0.85434782608696, 0.44444444444444
50008, 0.08695652173913, 0.8804347826087, 0.47222222222222
50009, 0.043478260869565, 0.88043478260869, 0.027777777777778
50010, 0.065217391304348, 0.8804347826087, 0.055555555555556
50011, 0.043478260869565, 0.85434782608696, 0.055555555555556
50012, 0.043478260869565, 0.88043478260869, 0.083333333333333
50013, 0.065217391304348, 0.88043478260869, 0.11111111111111
50014, 0.043478260869565, 0.85434782608696, 0.11111111111111
50015, 0.043478260869565, 0.88043478260869, 0.13888888888889
50016, 0.065217391304348, 0.8804347826087, 0.16666666666667
50017, 0.043478260869565, 0.85434782608696, 0.16666666666667
50018, 0.043478260869565, 0.88043478260869, 0.19444444444444
50019, 0.065217391304348, 0.8804347826087, 0.22222222222222
50020, 0.043478260869565, 0.85434782608696, 0.22222222222222
50021, 0.043478260869565, 0.88043478260869, 0.25
50022, 0.065217391304348, 0.88043478260869, 0.27777777777778
50023, 0.043478260869565, 0.85434782608696, 0.27777777777778
50024, 0.043478260869565, 0.88043478260869, 0.30555555555556
50025, 0.065217391304348, 0.8804347826087, 0.33333333333333
50026, 0.043478260869565, 0.85434782608696, 0.33333333333333
50027, 0.043478260869565, 0.88043478260869, 0.36111111111111
50028, 0.065217391304348, 0.88043478260869, 0.38888888888889
50029, 0.043478260869565, 0.85434782608696, 0.38888888888889
50030, 0.043478260869565, 0.88043478260869, 0.41666666666667
50031, 0.065217391304348, 0.88043478260869, 0.44444444444444
50032, 0.043478260869565, 0.85434782608696, 0.44444444444444
50033, 0.043478260869565, 0.88043478260869, 0.47222222222222
50034, 0.021739130434783, 0.88043478260869, 0.055555555555556
50035, 0.021739130434783, 0.88043478260869, 0.11111111111111
50036, 0.021739130434783, 0.8804347826087, 0.16666666666667
50037, 0.021739130434783, 0.88043478260869, 0.22222222222222
50038, 0.021739130434783, 0.88043478260869, 0.27777777777778
50039, 0.021739130434783, 0.88043478260869, 0.33333333333333
50040, 0.021739130434783, 0.88043478260869, 0.38888888888889
50041, 0.021739130434783, 0.88043478260869, 0.44444444444444
50042, 0.95652173913043, 0.93260869565217, 0.027777777777778
50043, 0.97826086956522, 0.93260869565217, 0.055555555555556
50044, 0.95652173913043, 0.90652173913043, 0.055555555555556
50045, 0.95652173913043, 0.93260869565217, 0.083333333333333
50046, 0.97826086956522, 0.93260869565217, 0.11111111111111
50047, 0.95652173913044, 0.90652173913043, 0.11111111111111
50048, 0.95652173913044, 0.93260869565217, 0.13888888888889
50049, 0.97826086956522, 0.93260869565217, 0.16666666666667
50050, 0.95652173913044, 0.90652173913043, 0.16666666666667
50051, 0.95652173913044, 0.93260869565217, 0.19444444444444
50052, 0.97826086956522, 0.93260869565217, 0.22222222222222
50053, 0.95652173913044, 0.90652173913043, 0.22222222222222
50054, 0.95652173913044, 0.93260869565217, 0.25
50055, 0.97826086956522, 0.93260869565217, 0.27777777777778
50056, 0.95652173913044, 0.90652173913043, 0.27777777777778
50057, 0.95652173913044, 0.93260869565217, 0.30555555555556
50058, 0.97826086956522, 0.93260869565217, 0.33333333333333
50059, 0.95652173913044, 0.90652173913043, 0.33333333333333
50060, 0.95652173913044, 0.93260869565217, 0.36111111111111
50061, 0.97826086956522, 0.93260869565217, 0.38888888888889
50062, 0.95652173913044, 0.90652173913043, 0.38888888888889
50063, 0.95652173913044, 0.93260869565217, 0.41666666666667
50064, 0.97826086956522, 0.93260869565217, 0.44444444444444
50065, 0.95652173913044, 0.90652173913043, 0.44444444444444
50066, 0.95652173913044, 0.93260869565217, 0.47222222222222
50067, 0.91304347826087, 0.93260869565217, 0.027777777777778
50068, 0.93478260869565, 0.93260869565217, 0.055555555555556
50069, 0.91304347826087, 0.90652173913043, 0.055555555555556
50070, 0.91304347826087, 0.93260869565217, 0.083333333333333
50071, 0.93478260869565, 0.93260869565217, 0.11111111111111
50072, 0.91304347826087, 0.90652173913043, 0.11111111111111
50073, 0.91304347826087, 0.93260869565217, 0.13888888888889
50074, 0.93478260869565, 0.93260869565217, 0.16666666666667
50075, 0.91304347826087, 0.90652173913043, 0.16666666666667
50076, 0.91304347826087, 0.93260869565217, 0.19444444444444
50077, 0.93478260869565, 0.93260869565217, 0.22222222222222
50078, 0.91304347826087, 0.90652173913043, 0.22222222222222
50079, 0.91304347826087, 0.93260869565217, 0.25
50080, 0.93478260869565, 0.93260869565217, 0.27777777777778
50081, 0.91304347826087, 0.90652173913043, 0.27777777777778
50082, 0.91304347826087, 0.93260869565217, 0.30555555555556
50083, 0.93478260869565, 0.93260869565217, 0.33333333333333
50084, 0.91304347826087, 0.90652173913043, 0.33333333333333
50085, 0.91304347826087, 0.93260869565217, 0.36111111111111
50086, 0.93478260869565, 0.93260869565217, 0.38888888888889
50087, 0.91304347826087, 0.90652173913043, 0.38888888888889
50088, 0.91304347826087, 0.93260869565217, 0.41666666666667
50089, 0.93478260869565, 0.93260869565217, 0.44444444444444
50090, 0.91304347826087, 0.90652173913043, 0.44444444444444
50091, 0.91304347826087, 0.93260869565217, 0.47222222222222
50092, 0.8695652173913, 0.93260869565217, 0.027777777777778
50093, 0.89130434782609, 0.93260869565217, 0.055555555555556
50094, 0.8695652173913, 0.90652173913043, 0.055555555555556
50095, 0.8695652173913, 0.93260869565217, 0.083333333333333
50096, 0.89130434782609, 0.93260869565217, 0.11111111111111
50097, 0.8695652173913, 0.90652173913043, 0.11111111111111
50098, 0.8695652173913, 0.93260869565217, 0.13888888888889
50099, 0.89130434782609, 0.93260869565217, 0.16666666666667
50100, 0.8695652173913, 0.90652173913043, 0.16666666666667
50101, 0.8695652173913, 0.93260869565217, 0.19444444444444
50102, 0.89130434782609, 0.93260869565217, 0.22222222222222
50103, 0.8695652173913, 0.90652173913043, 0.22222222222222
50104, 0.8695652173913, 0.93260869565217, 0.25
50105, 0.89130434782609, 0.93260869565217, 0.27777777777778
50106, 0.8695652173913, 0.90652173913043, 0.27777777777778
50107, 0.8695652173913, 0.93260869565217, 0.30555555555556
50108, 0.89130434782609, 0.93260869565217, 0.33333333333333
50109, 0.8695652173913, 0.90652173913043, 0.33333333333333
50110, 0.8695652173913, 0.93260869565217, 0.36111111111111
50111, 0.89130434782609, 0.93260869565217, 0.38888888888889
50112, 0.8695652173913, 0.90652173913043, 0.38888888888889
50113, 0.8695652173913, 0.93260869565217, 0.41666666666667
50114, 0.89130434782609, 0.93260869565217, 0.44444444444444
50115, 0.8695652173913, 0.90652173913043, 0.44444444444444
50116, 0.8695652173913, 0.93260869565217, 0.47222222222222
50117, 0.82608695652174, 0.93260869565217, 0.027777777777778
50118, 0.84782608695652, 0.93260869565217, 0.055555555555556
50119, 0.82608695652174, 0.90652173913043, 0.055555555555556
50120, 0.82608695652174, 0.93260869565217, 0.083333333333333
50121, 0.84782608695652, 0.93260869565217, 0.11111111111111
50122, 0.82608695652174, 0.90652173913043, 0.11111111111111
50123, 0.82608695652174, 0.93260869565217, 0.13888888888889
50124, 0.84782608695652, 0.93260869565217, 0.16666666666667
50125, 0.82608695652174, 0.90652173913043, 0.16666666666667
50126, 0.82608695652174, 0.93260869565217, 0.19444444444444
50127, 0.84782608695652, 0.93260869565217, 0.22222222222222
50128, 0.82608695652174, 0.90652173913043, 0.22222222222222
50129, 0.82608695652174, 0.93260869565217, 0.25
50130, 0.84782608695652, 0.93260869565217, 0.27777777777778
50131, 0.82608695652174, 0.90652173913043, 0.27777777777778
50132, 0.82608695652174, 0.93260869565217, 0.30555555555556
50133, 0.84782608695652, 0.93260869565217, 0.33333333333333
50134, 0.82608695652174, 0.90652173913043, 0.33333333333333
50135, 0.82608695652174, 0.93260869565217, 0.36111111111111
50136, 0.84782608695652, 0.93260869565217, 0.38888888888889
50137, 0.82608695652174, 0.90652173913043, 0.38888888888889
50138, 0.82608695652174, 0.93260869565217, 0.41666666666667
50139, 0.84782608695652, 0.93260869565217, 0.44444444444444
50140, 0.82608695652174, 0.90652173913043, 0.44444444444444
50141, 0.82608695652174, 0.93260869565217, 0.47222222222222
50142, 0.78260869565217, 0.93260869565217, 0.027777777777778
50143, 0.80434782608696, 0.93260869565217, 0.055555555555556
50144, 0.78260869565217, 0.90652173913043, 0.055555555555556
50145, 0.78260869565217, 0.93260869565217, 0.083333333333333
50146, 0.80434782608696, 0.93260869565217, 0.11111111111111
50147, 0.78260869565217, 0.90652173913043, 0.11111111111111
50148, 0.78260869565217, 0.93260869565217, 0.13888888888889
50149, 0.80434782608696, 0.93260869565217, 0.16666666666667
50150, 0.78260869565217, 0.90652173913043, 0.16666666666667
50151, 0.78260869565217, 0.93260869565217, 0.19444444444444
50152, 0.80434782608696, 0.93260869565217, 0.22222222222222
50153, 0.78260869565217, 0.90652173913043, 0.22222222222222
50154, 0.78260869565217, 0.93260869565217, 0.25
50155, 0.80434782608696, 0.93260869565217, 0.27777777777778
50156, 0.78260869565217, 0.90652173913043, 0.27777777777778
50157, 0.78260869565217, 0.93260869565217, 0.30555555555556
50158, 0.80434782608696, 0.93260869565217, 0.33333333333333
50159, 0.78260869565217, 0.90652173913043, 0.33333333333333
50160, 0.78260869565217, 0.93260869565217, 0.36111111111111
50161, 0.80434782608696, 0.93260869565217, 0.38888888888889
50162, 0.78260869565217, 0.90652173913043, 0.38888888888889
50163, 0.78260869565217, 0.93260869565217, 0.41666666666667
50164, 0.80434782608696, 0.93260869565217, 0.44444444444444
50165, 0.78260869565217, 0.90652173913043, 0.44444444444444
50166, 0.78260869565217, 0.93260869565217, 0.47222222222222
50167, 0.73913043478261, 0.93260869565217, 0.027777777777778
50168, 0.76086956521739, 0.93260869565217, 0.055555555555556
50169, 0.73913043478261, 0.90652173913043, 0.055555555555556
50170, 0.73913043478261, 0.93260869565217, 0.083333333333333
50171, 0.76086956521739, 0.93260869565217, 0.11111111111111
50172, 0.73913043478261, 0.90652173913043, 0.11111111111111
50173, 0.73913043478261, 0.93260869565217, 0.13888888888889
50174, 0.76086956521739, 0.93260869565217, 0.16666666666667
50175, 0.73913043478261, 0.90652173913043, 0.16666666666667
50176, 0.73913043478261, 0.93260869565217, 0.19444444444444
50177, 0.76086956521739, 0.93260869565217, 0.22222222222222
50178, 0.73913043478261, 0.90652173913043, 0.22222222222222
50179, 0.73913043478261, 0.93260869565217, 0.25
50180, 0.76086956521739, 0.93260869565217, 0.27777777777778
50181, 0.73913043478261, 0.90652173913043, 0.27777777777778
50182, 0.73913043478261, 0.93260869565217, 0.30555555555556
50183, 0.76086956521739, 0.93260869565217, 0.33333333333333
50184, 0.73913043478261, 0.90652173913043, 0.33333333333333
50185, 0.73913043478261, 0.93260869565217, 0.36111111111111
50186, 0.76086956521739, 0.93260869565217, 0.38888888888889
50187, 0.73913043478261, 0.90652173913043, 0.38888888888889
50188, 0.73913043478261, 0.93260869565217, 0.41666666666667
50189, 0.76086956521739, 0.93260869565217, 0.44444444444444
50190, 0.73913043478261, 0.90652173913043, 0.44444444444444
50191, 0.73913043478261, 0.93260869565217, 0.47222222222222
50192, 0.69565217391304, 0.93260869565217, 0.027777777777778
50193, 0.71739130434783, 0.93260869565217, 0.055555555555556
50194, 0.69565217391304, 0.90652173913043, 0.055555555555556
50195, 0.69565217391304, 0.93260869565217, 0.083333333333333
50196, 0.71739130434783, 0.93260869565217, 0.11111111111111
50197, 0.69565217391304, 0.90652173913043, 0.11111111111111
50198, 0.69565217391304, 0.93260869565217, 0.13888888888889
50199, 0.71739130434783, 0.93260869565217, 0.16666666666667
50200, 0.69565217391304, 0.90652173913043, 0.16666666666667
50201, 0.69565217391304, 0.93260869565217, 0.19444444444444
50202, 0.71739130434783, 0.93260869565217, 0.22222222222222
50203, 0.69565217391304, 0.90652173913043, 0.22222222222222
50204, 0.69565217391304, 0.93260869565217, 0.25
50205, 0.71739130434783, 0.93260869565217, 0.27777777777778
50206, 0.69565217391304, 0.90652173913043, 0.27777777777778
50207, 0.69565217391304, 0.93260869565217, 0.30555555555556
50208, 0.71739130434783, 0.93260869565217, 0.33333333333333
50209, 0.69565217391304, 0.90652173913043, 0.33333333333333
50210, 0.69565217391304, 0.93260869565217, 0.36111111111111
50211, 0.71739130434783, 0.93260869565217, 0.38888888888889
50212, 0.69565217391304, 0.90652173913043, 0.38888888888889
50213, 0.69565217391304, 0.93260869565217, 0.41666666666667
50214, 0.71739130434783, 0.93260869565217, 0.44444444444444
50215, 0.69565217391304, 0.90652173913043, 0.44444444444444
50216, 0.69565217391304, 0.93260869565217, 0.47222222222222
50217, 0.65217391304348, 0.93260869565217, 0.027777777777778
50218, 0.67391304347826, 0.93260869565217, 0.055555555555556
50219, 0.65217391304348, 0.90652173913043, 0.055555555555556
50220, 0.65217391304348, 0.93260869565217, 0.083333333333333
50221, 0.67391304347826, 0.93260869565217, 0.11111111111111
50222, 0.65217391304348, 0.90652173913043, 0.11111111111111
50223, 0.65217391304348, 0.93260869565217, 0.13888888888889
50224, 0.67391304347826, 0.93260869565217, 0.16666666666667
50225, 0.65217391304348, 0.90652173913043, 0.16666666666667
50226, 0.65217391304348, 0.93260869565217, 0.19444444444444
50227, 0.67391304347826, 0.93260869565217, 0.22222222222222
50228, 0.65217391304348, 0.90652173913043, 0.22222222222222
50229, 0.65217391304348, 0.93260869565217, 0.25
50230, 0.67391304347826, 0.93260869565217, 0.27777777777778
50231, 0.65217391304348, 0.90652173913043, 0.27777777777778
50232, 0.65217391304348, 0.93260869565217, 0.30555555555556
50233, 0.67391304347826, 0.93260869565217, 0.33333333333333
50234, 0.65217391304348, 0.90652173913043, 0.33333333333333
50235, 0.65217391304348, 0.93260869565217, 0.36111111111111
50236, 0.67391304347826, 0.93260869565217, 0.38888888888889
50237, 0.65217391304348, 0.90652173913043, 0.38888888888889
50238, 0.65217391304348, 0.93260869565217, 0.41666666666667
50239, 0.67391304347826, 0.93260869565217, 0.44444444444444
50240, 0.65217391304348, 0.90652173913043, 0.44444444444444
50241, 0.65217391304348, 0.93260869565217, 0.47222222222222
50242, 0.60869565217391, 0.93260869565217, 0.027777777777778
50243, 0.6304347826087, 0.93260869565217, 0.055555555555556
50244, 0.60869565217391, 0.90652173913043, 0.055555555555556
50245, 0.60869565217391, 0.93260869565217, 0.083333333333333
50246, 0.6304347826087, 0.93260869565217, 0.11111111111111
50247, 0.60869565217391, 0.90652173913043, 0.11111111111111
50248, 0.60869565217391, 0.93260869565217, 0.13888888888889
50249, 0.6304347826087, 0.93260869565217, 0.16666666666667
50250, 0.60869565217391, 0.90652173913043, 0.16666666666667
50251, 0.60869565217391, 0.93260869565217, 0.19444444444444
50252, 0.6304347826087, 0.93260869565217, 0.22222222222222
50253, 0.60869565217391, 0.90652173913043, 0.22222222222222
50254, 0.60869565217391, 0.93260869565217, 0.25
50255, 0.6304347826087, 0.93260869565217, 0.27777777777778
50256, 0.60869565217391, 0.90652173913043, 0.27777777777778
50257, 0.60869565217391, 0.93260869565217, 0.30555555555556
50258, 0.6304347826087, 0.93260869565217, 0.33333333333333
50259, 0.60869565217391, 0.90652173913043, 0.33333333333333
50260, 0.60869565217391, 0.93260869565217, 0.36111111111111
50261, 0.6304347826087, 0.93260869565217, 0.38888888888889
50262, 0.60869565217391, 0.90652173913043, 0.38888888888889
50263, 0.60869565217391, 0.93260869565217, 0.41666666666667
50264, 0.6304347826087, 0.93260869565217, 0.44444444444444
50265, 0.60869565217391, 0.90652173913043, 0.44444444444444
50266, 0.60869565217391, 0.93260869565217, 0.47222222222222
50267, 0.56521739130435, 0.93260869565217, 0.027777777777778
50268, 0.58695652173913, 0.93260869565217, 0.055555555555556
50269, 0.56521739130435, 0.90652173913043, 0.055555555555556
50270, 0.56521739130435, 0.93260869565217, 0.083333333333333
50271, 0.58695652173913, 0.93260869565217, 0.11111111111111
50272, 0.56521739130435, 0.90652173913043, 0.11111111111111
50273, 0.56521739130435, 0.93260869565217, 0.13888888888889
50274, 0.58695652173913, 0.93260869565217, 0.16666666666667
50275, 0.56521739130435, 0.90652173913043, 0.16666666666667
50276, 0.56521739130435, 0.93260869565217, 0.19444444444444
50277, 0.58695652173913, 0.93260869565217, 0.22222222222222
50278, 0.56521739130435, 0.90652173913043, 0.22222222222222
50279, 0.56521739130435, 0.93260869565217, 0.25
50280, 0.58695652173913, 0.93260869565217, 0.27777777777778
50281, 0.56521739130435, 0.90652173913043, 0.27777777777778
50282, 0.56521739130435, 0.93260869565217, 0.30555555555556
50283, 0.58695652173913, 0.93260869565217, 0.33333333333333
50284, 0.56521739130435, 0.90652173913043, 0.33333333333333
50285, 0.56521739130435, 0.93260869565217, 0.36111111111111
50286, 0.58695652173913, 0.93260869565217, 0.38888888888889
50287, 0.56521739130435, 0.90652173913043, 0.38888888888889
50288, 0.56521739130435, 0.93260869565217, 0.41666666666667
50289, 0.58695652173913, 0.93260869565217, 0.44444444444444
50290, 0.56521739130435, 0.90652173913043, 0.44444444444444
50291, 0.56521739130435, 0.93260869565217, 0.47222222222222
50292, 0.52173913043478, 0.93260869565217, 0.027777777777778
50293, 0.54347826086957, 0.93260869565217, 0.055555555555556
50294, 0.52173913043478, 0.90652173913043, 0.055555555555556
50295, 0.52173913043478, 0.93260869565217, 0.083333333333333
50296, 0.54347826086957, 0.93260869565217, 0.11111111111111
50297, 0.52173913043478, 0.90652173913043, 0.11111111111111
50298, 0.52173913043478, 0.93260869565217, 0.13888888888889
50299, 0.54347826086957, 0.93260869565217, 0.16666666666667
50300, 0.52173913043478, 0.90652173913043, 0.16666666666667
50301, 0.52173913043478, 0.93260869565217, 0.19444444444444
50302, 0.54347826086956, 0.93260869565217, 0.22222222222222
50303, 0.52173913043478, 0.90652173913043, 0.22222222222222
50304, 0.52173913043478, 0.93260869565217, 0.25
50305, 0.54347826086956, 0.93260869565217, 0.27777777777778
50306, 0.52173913043478, 0.90652173913043, 0.27777777777778
50307, 0.52173913043478, 0.93260869565217, 0.30555555555556
50308, 0.54347826086956, 0.93260869565217, 0.33333333333333
50309, 0.52173913043478, 0.90652173913043, 0.33333333333333
50310, 0.52173913043478, 0.93260869565217, 0.36111111111111
50311, 0.54347826086956, 0.93260869565217, 0.38888888888889
50312, 0.52173913043478, 0.90652173913043, 0.38888888888889
50313, 0.52173913043478, 0.93260869565217, 0.41666666666667
50314, 0.54347826086956, 0.93260869565217, 0.44444444444444
50315, 0.52173913043478, 0.90652173913043, 0.44444444444444
50316, 0.52173913043478, 0.93260869565217, 0.47222222222222
50317, 0.47826086956522, 0.93260869565217, 0.027777777777778
50318, 0.5, 0.93260869565217, 0.055555555555556
50319, 0.47826086956522, 0.90652173913043, 0.055555555555556
50320, 0.47826086956522, 0.93260869565217, 0.083333333333333
50321, 0.5, 0.93260869565217, 0.11111111111111
50322, 0.47826086956522, 0.90652173913043, 0.11111111111111
50323, 0.47826086956522, 0.93260869565217, 0.13888888888889
50324, 0.5, 0.93260869565217, 0.16666666666667
50325, 0.47826086956522, 0.90652173913043, 0.16666666666667
50326, 0.47826086956522, 0.93260869565217, 0.19444444444444
50327, 0.5, 0.93260869565217, 0.22222222222222
50328, 0.47826086956522, 0.90652173913043, 0.22222222222222
50329, 0.47826086956522, 0.93260869565217, 0.25
50330, 0.5, 0.93260869565217, 0.27777777777778
50331, 0.47826086956522, 0.90652173913043, 0.27777777777778
50332, 0.47826086956522, 0.93260869565217, 0.30555555555556
50333, 0.5, 0.93260869565217, 0.33333333333333
50334, 0.47826086956522, 0.90652173913043, 0.33333333333333
50335, 0.47826086956522, 0.93260869565217, 0.36111111111111
50336, 0.5, 0.93260869565217, 0.38888888888889
50337, 0.47826086956522, 0.90652173913043, 0.38888888888889
50338, 0.47826086956522, 0.93260869565217, 0.41666666666667
50339, 0.5, 0.93260869565217, 0.44444444444444
50340, 0.47826086956522, 0.90652173913043, 0.44444444444444
50341, 0.47826086956522, 0.93260869565217, 0.47222222222222
50342, 0.43478260869565, 0.93260869565217, 0.027777777777778
50343, 0.45652173913043, 0.93260869565217, 0.055555555555556
50344, 0.43478260869565, 0.90652173913043, 0.055555555555556
50345, 0.43478260869565, 0.93260869565217, 0.083333333333333
50346, 0.45652173913043, 0.93260869565217, 0.11111111111111
50347, 0.43478260869565, 0.90652173913043, 0.11111111111111
50348, 0.43478260869565, 0.93260869565217, 0.13888888888889
50349, 0.45652173913043, 0.93260869565217, 0.16666666666667
50350, 0.43478260869565, 0.90652173913043, 0.16666666666667
50351, 0.43478260869565, 0.93260869565217, 0.19444444444444
50352, 0.45652173913043, 0.93260869565217, 0.22222222222222
50353, 0.43478260869565, 0.90652173913043, 0.22222222222222
50354, 0.43478260869565, 0.93260869565217, 0.25
50355, 0.45652173913043, 0.93260869565217, 0.27777777777778
50356, 0.43478260869565, 0.90652173913043, 0.27777777777778
50357, 0.43478260869565, 0.93260869565217, 0.30555555555556
50358, 0.45652173913043, 0.93260869565217, 0.33333333333333
50359, 0.43478260869565, 0.90652173913043, 0.33333333333333
50360, 0.43478260869565, 0.93260869565217, 0.36111111111111
50361, 0.45652173913043, 0.93260869565217, 0.38888888888889
50362, 0.43478260869565, 0.90652173913043, 0.38888888888889
50363, 0.43478260869565, 0.93260869565217, 0.41666666666667
50364, 0.45652173913043, 0.93260869565217, 0.44444444444444
50365, 0.43478260869565, 0.90652173913043, 0.44444444444444
50366, 0.43478260869565, 0.93260869565217, 0.47222222222222
50367, 0.39130434782609, 0.93260869565217, 0.027777777777778
50368, 0.41304347826087, 0.93260869565217, 0.055555555555556
50369, 0.39130434782609, 0.90652173913043, 0.055555555555556
50370, 0.39130434782609, 0.93260869565217, 0.083333333333333
50371, 0.41304347826087, 0.93260869565217, 0.11111111111111
50372, 0.39130434782609, 0.90652173913043, 0.11111111111111
50373, 0.39130434782609, 0.93260869565217, 0.13888888888889
50374, 0.41304347826087, 0.93260869565217, 0.16666666666667
50375, 0.39130434782609, 0.90652173913043, 0.16666666666667
50376, 0.39130434782609, 0.93260869565217, 0.19444444444444
50377, 0.41304347826087, 0.93260869565217, 0.22222222222222
50378, 0.39130434782609, 0.90652173913043, 0.22222222222222
50379, 0.39130434782609, 0.93260869565217, 0.25
50380, 0.41304347826087, 0.93260869565217, 0.27777777777778
50381, 0.39130434782609, 0.90652173913043, 0.27777777777778
50382, 0.39130434782609, 0.93260869565217, 0.30555555555556
50383, 0.41304347826087, 0.93260869565217, 0.33333333333333
50384, 0.39130434782609, 0.90652173913043, 0.33333333333333
50385, 0.39130434782609, 0.93260869565217, 0.36111111111111
50386, 0.41304347826087, 0.93260869565217, 0.38888888888889
50387, 0.39130434782609, 0.90652173913043, 0.38888888888889
50388, 0.39130434782609, 0.93260869565217, 0.41666666666667
50389, 0.41304347826087, 0.93260869565217, 0.44444444444444
50390, 0.39130434782609, 0.90652173913043, 0.44444444444444
50391, 0.39130434782609, 0.93260869565217, 0.47222222222222
50392, 0.34782608695652, 0.93260869565217, 0.027777777777778
50393, 0.3695652173913, 0.93260869565217, 0.055555555555556
50394, 0.34782608695652, 0.90652173913043, 0.055555555555556
50395, 0.34782608695652, 0.93260869565217, 0.083333333333333
50396, 0.3695652173913, 0.93260869565217, 0.11111111111111
50397, 0.34782608695652, 0.90652173913043, 0.11111111111111
50398, 0.34782608695652, 0.93260869565217, 0.13888888888889
50399, 0.3695652173913, 0.93260869565217, 0.16666666666667
50400, 0.34782608695652, 0.90652173913043, 0.16666666666667
50401, 0.34782608695652, 0.93260869565217, 0.19444444444444
50402, 0.3695652173913, 0.93260869565217, 0.22222222222222
50403, 0.34782608695652, 0.90652173913043, 0.22222222222222
50404, 0.34782608695652, 0.93260869565217, 0.25
50405, 0.3695652173913, 0.93260869565217, 0.27777777777778
50406, 0.34782608695652, 0.90652173913043, 0.27777777777778
50407, 0.34782608695652, 0.93260869565217, 0.30555555555556
50408, 0.3695652173913, 0.93260869565217, 0.33333333333333
50409, 0.34782608695652, 0.90652173913043, 0.33333333333333
50410, 0.34782608695652, 0.93260869565217, 0.36111111111111
50411, 0.3695652173913, 0.93260869565217, 0.38888888888889
50412, 0.34782608695652, 0.90652173913043, 0.38888888888889
50413, 0.34782608695652, 0.93260869565217, 0.41666666666667
50414, 0.3695652173913, 0.93260869565217, 0.44444444444444
50415, 0.34782608695652, 0.90652173913043, 0.44444444444444
50416, 0.34782608695652, 0.93260869565217, 0.47222222222222
50417, 0.30434782608696, 0.93260869565217, 0.027777777777778
50418, 0.32608695652174, 0.93260869565217, 0.055555555555556
50419, 0.30434782608696, 0.90652173913043, 0.055555555555556
50420, 0.30434782608696, 0.93260869565217, 0.083333333333333
50421, 0.32608695652174, 0.93260869565217, 0.11111111111111
50422, 0.30434782608696, 0.90652173913043, 0.11111111111111
50423, 0.30434782608696, 0.93260869565217, 0.13888888888889
50424, 0.32608695652174, 0.93260869565217, 0.16666666666667
50425, 0.30434782608696, 0.90652173913043, 0.16666666666667
50426, 0.30434782608696, 0.93260869565217, 0.19444444444444
50427, 0.32608695652174, 0.93260869565217, 0.22222222222222
50428, 0.30434782608696, 0.90652173913043, 0.22222222222222
50429, 0.30434782608696, 0.93260869565217, 0.25
50430, 0.32608695652174, 0.93260869565217, 0.27777777777778
50431, 0.30434782608696, 0.90652173913043, 0.27777777777778
50432, 0.30434782608696, 0.93260869565217, 0.30555555555556
50433, 0.32608695652174, 0.93260869565217, 0.33333333333333
50434, 0.30434782608696, 0.90652173913043, 0.33333333333333
50435, 0.30434782608696, 0.93260869565217, 0.36111111111111
50436, 0.32608695652174, 0.93260869565217, 0.38888888888889
50437, 0.30434782608696, 0.90652173913043, 0.38888888888889
50438, 0.30434782608696, 0.93260869565217, 0.41666666666667
50439, 0.32608695652174, 0.93260869565217, 0.44444444444444
50440, 0.30434782608696, 0.90652173913043, 0.44444444444444
50441, 0.30434782608696, 0.93260869565217, 0.47222222222222
50442, 0.26086956521739, 0.93260869565217, 0.027777777777778
50443, 0.28260869565217, 0.93260869565217, 0.055555555555556
50444, 0.26086956521739, 0.90652173913043, 0.055555555555556
50445, 0.26086956521739, 0.93260869565217, 0.083333333333333
50446, 0.28260869565217, 0.93260869565217, 0.11111111111111
50447, 0.26086956521739, 0.90652173913043, 0.11111111111111
50448, 0.26086956521739, 0.93260869565217, 0.13888888888889
50449, 0.28260869565217, 0.93260869565217, 0.16666666666667
50450, 0.26086956521739, 0.90652173913043, 0.16666666666667
50451, 0.26086956521739, 0.93260869565217, 0.19444444444444
50452, 0.28260869565217, 0.93260869565217, 0.22222222222222
50453, 0.26086956521739, 0.90652173913043, 0.22222222222222
50454, 0.26086956521739, 0.93260869565217, 0.25
50455, 0.28260869565217, 0.93260869565217, 0.27777777777778
50456, 0.26086956521739, 0.90652173913043, 0.27777777777778
50457, 0.26086956521739, 0.93260869565217, 0.30555555555556
50458, 0.28260869565217, 0.93260869565217, 0.33333333333333
50459, 0.26086956521739, 0.90652173913043, 0.33333333333333
50460, 0.26086956521739, 0.93260869565217, 0.36111111111111
50461, 0.28260869565217, 0.93260869565217, 0.38888888888889
50462, 0.26086956521739, 0.90652173913043, 0.38888888888889
50463, 0.26086956521739, 0.93260869565217, 0.41666666666667
50464, 0.28260869565217, 0.93260869565217, 0.44444444444444
50465, 0.26086956521739, 0.90652173913043, 0.44444444444444
50466, 0.26086956521739, 0.93260869565217, 0.47222222222222
50467, 0.21739130434783, 0.93260869565217, 0.027777777777778
50468, 0.23913043478261, 0.93260869565217, 0.055555555555556
50469, 0.21739130434783, 0.90652173913043, 0.055555555555556
50470, 0.21739130434783, 0.93260869565217, 0.083333333333333
50471, 0.23913043478261, 0.93260869565217, 0.11111111111111
50472, 0.21739130434783, 0.90652173913043, 0.11111111111111
50473, 0.21739130434783, 0.93260869565217, 0.13888888888889
50474, 0.23913043478261, 0.93260869565217, 0.16666666666667
50475, 0.21739130434783, 0.90652173913043, 0.16666666666667
50476, 0.21739130434783, 0.93260869565217, 0.19444444444444
50477, 0.23913043478261, 0.93260869565217, 0.22222222222222
50478, 0.21739130434783, 0.90652173913043, 0.22222222222222
50479, 0.21739130434783, 0.93260869565217, 0.25
50480, 0.23913043478261, 0.93260869565217, 0.27777777777778
50481, 0.21739130434783, 0.90652173913043, 0.27777777777778
50482, 0.21739130434783, 0.93260869565217, 0.30555555555556
50483, 0.23913043478261, 0.93260869565217, 0.33333333333333
50484, 0.21739130434783, 0.90652173913043, 0.33333333333333
50485, 0.21739130434783, 0.93260869565217, 0.36111111111111
50486, 0.23913043478261, 0.93260869565217, 0.38888888888889
50487, 0.21739130434783, 0.90652173913043, 0.38888888888889
50488, 0.21739130434783, 0.93260869565217, 0.41666666666667
50489, 0.23913043478261, 0.93260869565217, 0.44444444444444
50490, 0.21739130434783, 0.90652173913043, 0.44444444444444
50491, 0.21739130434783, 0.93260869565217, 0.47222222222222
50492, 0.17391304347826, 0.93260869565217, 0.027777777777778
50493, 0.19565217391304, 0.93260869565217, 0.055555555555556
50494, 0.17391304347826, 0.90652173913043, 0.055555555555556
50495, 0.17391304347826, 0.93260869565217, 0.083333333333333
50496, 0.19565217391304, 0.93260869565217, 0.11111111111111
50497, 0.17391304347826, 0.90652173913043, 0.11111111111111
50498, 0.17391304347826, 0.93260869565217, 0.13888888888889
50499, 0.19565217391304, 0.93260869565217, 0.16666666666667
50500, 0.17391304347826, 0.90652173913043, 0.16666666666667
50501, 0.17391304347826, 0.93260869565217, 0.19444444444444
50502, 0.19565217391304, 0.93260869565217, 0.22222222222222
50503, 0.17391304347826, 0.90652173913043, 0.22222222222222
50504, 0.17391304347826, 0.93260869565217, 0.25
50505, 0.19565217391304, 0.93260869565217, 0.27777777777778
50506, 0.17391304347826, 0.90652173913043, 0.27777777777778
50507, 0.17391304347826, 0.93260869565217, 0.30555555555556
50508, 0.19565217391304, 0.93260869565217, 0.33333333333333
50509, 0.17391304347826, 0.90652173913043, 0.33333333333333
50510, 0.17391304347826, 0.93260869565217, 0.36111111111111
50511, 0.19565217391304, 0.93260869565217, 0.38888888888889
50512, 0.17391304347826, 0.90652173913043, 0.38888888888889
50513, 0.17391304347826, 0.93260869565217, 0.41666666666667
50514, 0.19565217391304, 0.93260869565217, 0.44444444444444
50515, 0.17391304347826, 0.90652173913043, 0.44444444444444
50516, 0.17391304347826, 0.93260869565217, 0.47222222222222
50517, 0.1304347826087, 0.93260869565217, 0.027777777777778
50518, 0.15217391304348, 0.93260869565217, 0.055555555555556
50519, 0.1304347826087, 0.90652173913043, 0.055555555555556
50520, 0.1304347826087, 0.93260869565217, 0.083333333333333
50521, 0.15217391304348, 0.93260869565217, 0.11111111111111
50522, 0.1304347826087, 0.90652173913043, 0.11111111111111
50523, 0.1304347826087, 0.93260869565217, 0.13888888888889
50524, 0.15217391304348, 0.93260869565217, 0.16666666666667
50525, 0.1304347826087, 0.90652173913043, 0.16666666666667
50526, 0.1304347826087, 0.93260869565217, 0.19444444444444
50527, 0.15217391304348, 0.93260869565217, 0.22222222222222
50528, 0.1304347826087, 0.90652173913043, 0.22222222222222
50529, 0.1304347826087, 0.93260869565217, 0.25
50530, 0.15217391304348, 0.93260869565217, 0.27777777777778
50531, 0.1304347826087, 0.90652173913043, 0.27777777777778
50532, 0.1304347826087, 0.93260869565217, 0.30555555555556
50533, 0.15217391304348, 0.93260869565217, 0.33333333333333
50534, 0.1304347826087, 0.90652173913043, 0.33333333333333
50535, 0.1304347826087, 0.93260869565217, 0.36111111111111
50536, 0.15217391304348, 0.93260869565217, 0.38888888888889
50537, 0.1304347826087, 0.90652173913043, 0.38888888888889
50538, 0.1304347826087, 0.93260869565217, 0.41666666666667
50539, 0.15217391304348, 0.93260869565217, 0.44444444444444
50540, 0.1304347826087, 0.90652173913043, 0.44444444444444
50541, 0.1304347826087, 0.93260869565217, 0.47222222222222
50542, 0.08695652173913, 0.93260869565217, 0.027777777777778
50543, 0.10869565217391, 0.93260869565217, 0.055555555555556
50544, 0.08695652173913, 0.90652173913043, 0.055555555555556
50545, 0.08695652173913, 0.93260869565217, 0.083333333333333
50546, 0.10869565217391, 0.93260869565217, 0.11111111111111
50547, 0.08695652173913, 0.90652173913043, 0.11111111111111
50548, 0.08695652173913, 0.93260869565217, 0.13888888888889
50549, 0.10869565217391, 0.93260869565217, 0.16666666666667
50550, 0.08695652173913, 0.90652173913043, 0.16666666666667
50551, 0.08695652173913, 0.93260869565217, 0.19444444444444
50552, 0.10869565217391, 0.93260869565217, 0.22222222222222
50553, 0.08695652173913, 0.90652173913043, 0.22222222222222
50554, 0.08695652173913, 0.93260869565217, 0.25
50555, 0.10869565217391, 0.93260869565217, 0.27777777777778
50556, 0.08695652173913, 0.90652173913043, 0.27777777777778
50557, 0.08695652173913, 0.93260869565217, 0.30555555555556
50558, 0.10869565217391, 0.93260869565217, 0.33333333333333
50559, 0.08695652173913, 0.90652173913043, 0.33333333333333
50560, 0.08695652173913, 0.93260869565217, 0.36111111111111
50561, 0.10869565217391, 0.93260869565217, 0.38888888888889
50562, 0.08695652173913, 0.90652173913043, 0.38888888888889
50563, 0.08695652173913, 0.93260869565217, 0.41666666666667
50564, 0.10869565217391, 0.93260869565217, 0.44444444444444
50565, 0.08695652173913, 0.90652173913043, 0.44444444444444
50566, 0.08695652173913, 0.93260869565217, 0.47222222222222
50567, 0.043478260869565, 0.93260869565217, 0.027777777777778
50568, 0.065217391304348, 0.93260869565217, 0.055555555555556
50569, 0.043478260869565, 0.90652173913043, 0.055555555555556
50570, 0.043478260869565, 0.93260869565217, 0.083333333333333
50571, 0.065217391304348, 0.93260869565217, 0.11111111111111
50572, 0.043478260869565, 0.90652173913043, 0.11111111111111
50573, 0.043478260869565, 0.93260869565217, 0.13888888888889
50574, 0.065217391304348, 0.93260869565217, 0.16666666666667
50575, 0.043478260869565, 0.90652173913043, 0.16666666666667
50576, 0.043478260869565, 0.93260869565217, 0.19444444444444
50577, 0.065217391304348, 0.93260869565217, 0.22222222222222
50578, 0.043478260869565, 0.90652173913043, 0.22222222222222
50579, 0.043478260869565, 0.93260869565217, 0.25
50580, 0.065217391304348, 0.93260869565217, 0.27777777777778
50581, 0.043478260869565, 0.90652173913043, 0.27777777777778
50582, 0.043478260869565, 0.93260869565217, 0.30555555555556
50583, 0.065217391304348, 0.93260869565217, 0.33333333333333
50584, 0.043478260869565, 0.90652173913043, 0.33333333333333
50585, 0.043478260869565, 0.93260869565217, 0.36111111111111
50586, 0.065217391304348, 0.93260869565217, 0.38888888888889
50587, 0.043478260869565, 0.90652173913043, 0.38888888888889
50588, 0.043478260869565, 0.93260869565217, 0.41666666666667
50589, 0.065217391304348, 0.93260869565217, 0.44444444444444
50590, 0.043478260869565, 0.90652173913043, 0.44444444444444
50591, 0.043478260869565, 0.93260869565217, 0.47222222222222
50592, 0.021739130434783, 0.93260869565217, 0.055555555555556
50593, 0.021739130434783, 0.93260869565217, 0.11111111111111
50594, 0.021739130434783, 0.93260869565217, 0.16666666666667
50595, 0.021739130434783, 0.93260869565217, 0.22222222222222
50596, 0.021739130434783, 0.93260869565217, 0.27777777777778
50597, 0.021739130434783, 0.93260869565217, 0.33333333333333
50598, 0.021739130434783, 0.93260869565217, 0.38888888888889
50599, 0.021739130434783, 0.93260869565217, 0.44444444444444
50600, 0.95652173913043, 0.98478260869565, 0.027777777777778
50601, 0.97826086956522, 0.98478260869565, 0.055555555555556
50602, 0.95652173913043, 0.95869565217391, 0.055555555555556
50603, 0.95652173913043, 0.98478260869565, 0.083333333333333
50604, 0.97826086956522, 0.98478260869565, 0.11111111111111
50605, 0.95652173913044, 0.95869565217391, 0.11111111111111
50606, 0.95652173913044, 0.98478260869565, 0.13888888888889
50607, 0.97826086956522, 0.98478260869565, 0.16666666666667
50608, 0.95652173913044, 0.95869565217391, 0.16666666666667
50609, 0.95652173913044, 0.98478260869565, 0.19444444444444
50610, 0.97826086956522, 0.98478260869565, 0.22222222222222
50611, 0.95652173913044, 0.95869565217391, 0.22222222222222
50612, 0.95652173913044, 0.98478260869565, 0.25
50613, 0.97826086956522, 0.98478260869565, 0.27777777777778
50614, 0.95652173913044, 0.95869565217391, 0.27777777777778
50615, 0.95652173913044, 0.98478260869565, 0.30555555555556
50616, 0.97826086956522, 0.98478260869565, 0.33333333333333
50617, 0.95652173913044, 0.95869565217391, 0.33333333333333
50618, 0.95652173913044, 0.98478260869565, 0.36111111111111
50619, 0.97826086956522, 0.98478260869565, 0.38888888888889
50620, 0.95652173913044, 0.95869565217391, 0.38888888888889
50621, 0.95652173913044, 0.98478260869565, 0.41666666666667
50622, 0.97826086956522, 0.98478260869565, 0.44444444444444
50623, 0.95652173913044, 0.95869565217391, 0.44444444444444
50624, 0.95652173913043, 0.98478260869565, 0.47222222222222
50625, 0.91304347826087, 0.98478260869565, 0.027777777777778
50626, 0.93478260869565, 0.98478260869565, 0.055555555555556
50627, 0.91304347826087, 0.95869565217391, 0.055555555555556
50628, 0.91304347826087, 0.98478260869565, 0.083333333333333
50629, 0.93478260869565, 0.98478260869565, 0.11111111111111
50630, 0.91304347826087, 0.95869565217391, 0.11111111111111
50631, 0.91304347826087, 0.98478260869565, 0.13888888888889
50632, 0.93478260869565, 0.98478260869565, 0.16666666666667
50633, 0.91304347826087, 0.95869565217391, 0.16666666666667
50634, 0.91304347826087, 0.98478260869565, 0.19444444444444
50635, 0.93478260869565, 0.98478260869565, 0.22222222222222
50636, 0.91304347826087, 0.95869565217391, 0.22222222222222
50637, 0.91304347826087, 0.98478260869565, 0.25
50638, 0.93478260869565, 0.98478260869565, 0.27777777777778
50639, 0.91304347826087, 0.95869565217391, 0.27777777777778
50640, 0.91304347826087, 0.98478260869565, 0.30555555555556
50641, 0.93478260869565, 0.98478260869565, 0.33333333333333
50642, 0.91304347826087, 0.95869565217391, 0.33333333333333
50643, 0.91304347826087, 0.98478260869565, 0.36111111111111
50644, 0.93478260869565, 0.98478260869565, 0.38888888888889
50645, 0.91304347826087, 0.95869565217391, 0.38888888888889
50646, 0.91304347826087, 0.98478260869565, 0.41666666666667
50647, 0.93478260869565, 0.98478260869565, 0.44444444444444
50648, 0.91304347826087, 0.95869565217391, 0.44444444444444
50649, 0.91304347826087, 0.98478260869565, 0.47222222222222
50650, 0.8695652173913, 0.98478260869565, 0.027777777777778
50651, 0.89130434782609, 0.98478260869565, 0.055555555555556
50652, 0.8695652173913, 0.95869565217391, 0.055555555555556
50653, 0.8695652173913, 0.98478260869565, 0.083333333333333
50654, 0.89130434782609, 0.98478260869565, 0.11111111111111
50655, 0.8695652173913, 0.95869565217391, 0.11111111111111
50656, 0.8695652173913, 0.98478260869565, 0.13888888888889
50657, 0.89130434782609, 0.98478260869565, 0.16666666666667
50658, 0.8695652173913, 0.95869565217391, 0.16666666666667
50659, 0.8695652173913, 0.98478260869565, 0.19444444444444
50660, 0.89130434782609, 0.98478260869565, 0.22222222222222
50661, 0.8695652173913, 0.95869565217391, 0.22222222222222
50662, 0.8695652173913, 0.98478260869565, 0.25
50663, 0.89130434782609, 0.98478260869565, 0.27777777777778
50664, 0.8695652173913, 0.95869565217391, 0.27777777777778
50665, 0.8695652173913, 0.98478260869565, 0.30555555555556
50666, 0.89130434782609, 0.98478260869565, 0.33333333333333
50667, 0.8695652173913, 0.95869565217391, 0.33333333333333
50668, 0.8695652173913, 0.98478260869565, 0.36111111111111
50669, 0.89130434782609, 0.98478260869565, 0.38888888888889
50670, 0.8695652173913, 0.95869565217391, 0.38888888888889
50671, 0.8695652173913, 0.98478260869565, 0.41666666666667
50672, 0.89130434782609, 0.98478260869565, 0.44444444444444
50673, 0.8695652173913, 0.95869565217391, 0.44444444444444
50674, 0.8695652173913, 0.98478260869565, 0.47222222222222
50675, 0.82608695652174, 0.98478260869565, 0.027777777777778
50676, 0.84782608695652, 0.98478260869565, 0.055555555555556
50677, 0.82608695652174, 0.95869565217391, 0.055555555555556
50678, 0.82608695652174, 0.98478260869565, 0.083333333333333
50679, 0.84782608695652, 0.98478260869565, 0.11111111111111
50680, 0.82608695652174, 0.95869565217391, 0.11111111111111
50681, 0.82608695652174, 0.98478260869565, 0.13888888888889
50682, 0.84782608695652, 0.98478260869565, 0.16666666666667
50683, 0.82608695652174, 0.95869565217391, 0.16666666666667
50684, 0.82608695652174, 0.98478260869565, 0.19444444444444
50685, 0.84782608695652, 0.98478260869565, 0.22222222222222
50686, 0.82608695652174, 0.95869565217391, 0.22222222222222
50687, 0.82608695652174, 0.98478260869565, 0.25
50688, 0.84782608695652, 0.98478260869565, 0.27777777777778
50689, 0.82608695652174, 0.95869565217391, 0.27777777777778
50690, 0.82608695652174, 0.98478260869565, 0.30555555555556
50691, 0.84782608695652, 0.98478260869565, 0.33333333333333
50692, 0.82608695652174, 0.95869565217391, 0.33333333333333
50693, 0.82608695652174, 0.98478260869565, 0.36111111111111
50694, 0.84782608695652, 0.98478260869565, 0.38888888888889
50695, 0.82608695652174, 0.95869565217391, 0.38888888888889
50696, 0.82608695652174, 0.98478260869565, 0.41666666666667
50697, 0.84782608695652, 0.98478260869565, 0.44444444444444
50698, 0.82608695652174, 0.95869565217391, 0.44444444444444
50699, 0.82608695652174, 0.98478260869565, 0.47222222222222
50700, 0.78260869565217, 0.98478260869565, 0.027777777777778
50701, 0.80434782608696, 0.98478260869565, 0.055555555555556
50702, 0.78260869565217, 0.95869565217391, 0.055555555555556
50703, 0.78260869565217, 0.98478260869565, 0.083333333333333
50704, 0.80434782608696, 0.98478260869565, 0.11111111111111
50705, 0.78260869565217, 0.95869565217391, 0.11111111111111
50706, 0.78260869565217, 0.98478260869565, 0.13888888888889
50707, 0.80434782608696, 0.98478260869565, 0.16666666666667
50708, 0.78260869565217, 0.95869565217391, 0.16666666666667
50709, 0.78260869565217, 0.98478260869565, 0.19444444444444
50710, 0.80434782608696, 0.98478260869565, 0.22222222222222
50711, 0.78260869565217, 0.95869565217391, 0.22222222222222
50712, 0.78260869565217, 0.98478260869565, 0.25
50713, 0.80434782608696, 0.98478260869565, 0.27777777777778
50714, 0.78260869565217, 0.95869565217391, 0.27777777777778
50715, 0.78260869565217, 0.98478260869565, 0.30555555555556
50716, 0.80434782608696, 0.98478260869565, 0.33333333333333
50717, 0.78260869565217, 0.95869565217391, 0.33333333333333
50718, 0.78260869565217, 0.98478260869565, 0.36111111111111
50719, 0.80434782608696, 0.98478260869565, 0.38888888888889
50720, 0.78260869565217, 0.95869565217391, 0.38888888888889
50721, 0.78260869565217, 0.98478260869565, 0.41666666666667
50722, 0.80434782608696, 0.98478260869565, 0.44444444444444
50723, 0.78260869565217, 0.95869565217391, 0.44444444444444
50724, 0.78260869565217, 0.98478260869565, 0.47222222222222
50725, 0.73913043478261, 0.98478260869565, 0.027777777777778
50726, 0.76086956521739, 0.98478260869565, 0.055555555555556
50727, 0.73913043478261, 0.95869565217391, 0.055555555555556
50728, 0.73913043478261, 0.98478260869565, 0.083333333333333
50729, 0.76086956521739, 0.98478260869565, 0.11111111111111
50730, 0.73913043478261, 0.95869565217391, 0.11111111111111
50731, 0.73913043478261, 0.98478260869565, 0.13888888888889
50732, 0.76086956521739, 0.98478260869565, 0.16666666666667
50733, 0.73913043478261, 0.95869565217391, 0.16666666666667
50734, 0.73913043478261, 0.98478260869565, 0.19444444444444
50735, 0.76086956521739, 0.98478260869565, 0.22222222222222
50736, 0.73913043478261, 0.95869565217391, 0.22222222222222
50737, 0.73913043478261, 0.98478260869565, 0.25
50738, 0.76086956521739, 0.98478260869565, 0.27777777777778
50739, 0.73913043478261, 0.95869565217391, 0.27777777777778
50740, 0.73913043478261, 0.98478260869565, 0.30555555555556
50741, 0.76086956521739, 0.98478260869565, 0.33333333333333
50742, 0.73913043478261, 0.95869565217391, 0.33333333333333
50743, 0.73913043478261, 0.98478260869565, 0.36111111111111
50744, 0.76086956521739, 0.98478260869565, 0.38888888888889
50745, 0.73913043478261, 0.95869565217391, 0.38888888888889
50746, 0.73913043478261, 0.98478260869565, 0.41666666666667
50747, 0.76086956521739, 0.98478260869565, 0.44444444444444
50748, 0.73913043478261, 0.95869565217391, 0.44444444444444
50749, 0.73913043478261, 0.98478260869565, 0.47222222222222
50750, 0.69565217391304, 0.98478260869565, 0.027777777777778
50751, 0.71739130434783, 0.98478260869565, 0.055555555555556
50752, 0.69565217391304, 0.95869565217391, 0.055555555555556
50753, 0.69565217391304, 0.98478260869565, 0.083333333333333
50754, 0.71739130434783, 0.98478260869565, 0.11111111111111
50755, 0.69565217391304, 0.95869565217391, 0.11111111111111
50756, 0.69565217391304, 0.98478260869565, 0.13888888888889
50757, 0.71739130434783, 0.98478260869565, 0.16666666666667
50758, 0.69565217391304, 0.95869565217391, 0.16666666666667
50759, 0.69565217391304, 0.98478260869565, 0.19444444444444
50760, 0.71739130434783, 0.98478260869565, 0.22222222222222
50761, 0.69565217391304, 0.95869565217391, 0.22222222222222
50762, 0.69565217391304, 0.98478260869565, 0.25
50763, 0.71739130434783, 0.98478260869565, 0.27777777777778
50764, 0.69565217391304, 0.95869565217391, 0.27777777777778
50765, 0.69565217391304, 0.98478260869565, 0.30555555555556
50766, 0.71739130434783, 0.98478260869565, 0.33333333333333
50767, 0.69565217391304, 0.95869565217391, 0.33333333333333
50768, 0.69565217391304, 0.98478260869565, 0.36111111111111
50769, 0.71739130434783, 0.98478260869565, 0.38888888888889
50770, 0.69565217391304, 0.95869565217391, 0.38888888888889
50771, 0.69565217391304, 0.98478260869565, 0.41666666666667
50772, 0.71739130434783, 0.98478260869565, 0.44444444444444
50773, 0.69565217391304, 0.95869565217391, 0.44444444444444
50774, 0.69565217391304, 0.98478260869565, 0.47222222222222
50775, 0.65217391304348, 0.98478260869565, 0.027777777777778
50776, 0.67391304347826, 0.98478260869565, 0.055555555555556
50777, 0.65217391304348, 0.95869565217391, 0.055555555555556
50778, 0.65217391304348, 0.98478260869565, 0.083333333333333
50779, 0.67391304347826, 0.98478260869565, 0.11111111111111
50780, 0.65217391304348, 0.95869565217391, 0.11111111111111
50781, 0.65217391304348, 0.98478260869565, 0.13888888888889
50782, 0.67391304347826, 0.98478260869565, 0.16666666666667
50783, 0.65217391304348, 0.95869565217391, 0.16666666666667
50784, 0.65217391304348, 0.98478260869565, 0.19444444444444
50785, 0.67391304347826, 0.98478260869565, 0.22222222222222
50786, 0.65217391304348, 0.95869565217391, 0.22222222222222
50787, 0.65217391304348, 0.98478260869565, 0.25
50788, 0.67391304347826, 0.98478260869565, 0.27777777777778
50789, 0.65217391304348, 0.95869565217391, 0.27777777777778
50790, 0.65217391304348, 0.98478260869565, 0.30555555555556
50791, 0.67391304347826, 0.98478260869565, 0.33333333333333
50792, 0.65217391304348, 0.95869565217391, 0.33333333333333
50793, 0.65217391304348, 0.98478260869565, 0.36111111111111
50794, 0.67391304347826, 0.98478260869565, 0.38888888888889
50795, 0.65217391304348, 0.95869565217391, 0.38888888888889
50796, 0.65217391304348, 0.98478260869565, 0.41666666666667
50797, 0.67391304347826, 0.98478260869565, 0.44444444444444
50798, 0.65217391304348, 0.95869565217391, 0.44444444444444
50799, 0.65217391304348, 0.98478260869565, 0.47222222222222
50800, 0.60869565217391, 0.98478260869565, 0.027777777777778
50801, 0.6304347826087, 0.98478260869565, 0.055555555555556
50802, 0.60869565217391, 0.95869565217391, 0.055555555555556
50803, 0.60869565217391, 0.98478260869565, 0.083333333333333
50804, 0.6304347826087, 0.98478260869565, 0.11111111111111
50805, 0.60869565217391, 0.95869565217391, 0.11111111111111
50806, 0.60869565217391, 0.98478260869565, 0.13888888888889
50807, 0.6304347826087, 0.98478260869565, 0.16666666666667
50808, 0.60869565217391, 0.95869565217391, 0.16666666666667
50809, 0.60869565217391, 0.98478260869565, 0.19444444444444
50810, 0.6304347826087, 0.98478260869565, 0.22222222222222
50811, 0.60869565217391, 0.95869565217391, 0.22222222222222
50812, 0.60869565217391, 0.98478260869565, 0.25
50813, 0.6304347826087, 0.98478260869565, 0.27777777777778
50814, 0.60869565217391, 0.95869565217391, 0.27777777777778
50815, 0.60869565217391, 0.98478260869565, 0.30555555555556
50816, 0.6304347826087, 0.98478260869565, 0.33333333333333
50817, 0.60869565217391, 0.95869565217391, 0.33333333333333
50818, 0.60869565217391, 0.98478260869565, 0.36111111111111
50819, 0.6304347826087, 0.98478260869565, 0.38888888888889
50820, 0.60869565217391, 0.95869565217391, 0.38888888888889
50821, 0.60869565217391, 0.98478260869565, 0.41666666666667
50822, 0.6304347826087, 0.98478260869565, 0.44444444444444
50823, 0.60869565217391, 0.95869565217391, 0.44444444444444
50824, 0.60869565217391, 0.98478260869565, 0.47222222222222
50825, 0.56521739130435, 0.98478260869565, 0.027777777777778
50826, 0.58695652173913, 0.98478260869565, 0.055555555555556
50827, 0.56521739130435, 0.95869565217391, 0.055555555555556
50828, 0.56521739130435, 0.98478260869565, 0.083333333333333
50829, 0.58695652173913, 0.98478260869565, 0.11111111111111
50830, 0.56521739130435, 0.95869565217391, 0.11111111111111
50831, 0.56521739130435, 0.98478260869565, 0.13888888888889
50832, 0.58695652173913, 0.98478260869565, 0.16666666666667
50833, 0.56521739130435, 0.95869565217391, 0.16666666666667
50834, 0.56521739130435, 0.98478260869565, 0.19444444444444
50835, 0.58695652173913, 0.98478260869565, 0.22222222222222
50836, 0.56521739130435, 0.95869565217391, 0.22222222222222
50837, 0.56521739130435, 0.98478260869565, 0.25
50838, 0.58695652173913, 0.98478260869565, 0.27777777777778
50839, 0.56521739130435, 0.95869565217391, 0.27777777777778
50840, 0.56521739130435, 0.98478260869565, 0.30555555555556
50841, 0.58695652173913, 0.98478260869565, 0.33333333333333
50842, 0.56521739130435, 0.95869565217391, 0.33333333333333
50843, 0.56521739130435, 0.98478260869565, 0.36111111111111
50844, 0.58695652173913, 0.98478260869565, 0.38888888888889
50845, 0.56521739130435, 0.95869565217391, 0.38888888888889
50846, 0.56521739130435, 0.98478260869565, 0.41666666666667
50847, 0.58695652173913, 0.98478260869565, 0.44444444444444
50848, 0.56521739130435, 0.95869565217391, 0.44444444444444
50849, 0.56521739130435, 0.98478260869565, 0.47222222222222
50850, 0.52173913043478, 0.98478260869565, 0.027777777777778
50851, 0.54347826086957, 0.98478260869565, 0.055555555555556
50852, 0.52173913043478, 0.95869565217391, 0.055555555555556
50853, 0.52173913043478, 0.98478260869565, 0.083333333333333
50854, 0.54347826086957, 0.98478260869565, 0.11111111111111
50855, 0.52173913043478, 0.95869565217391, 0.11111111111111
50856, 0.52173913043478, 0.98478260869565, 0.13888888888889
50857, 0.54347826086957, 0.98478260869565, 0.16666666666667
50858, 0.52173913043478, 0.95869565217391, 0.16666666666667
50859, 0.52173913043478, 0.98478260869565, 0.19444444444444
50860, 0.54347826086956, 0.98478260869565, 0.22222222222222
50861, 0.52173913043478, 0.95869565217391, 0.22222222222222
50862, 0.52173913043478, 0.98478260869565, 0.25
50863, 0.54347826086956, 0.98478260869565, 0.27777777777778
50864, 0.52173913043478, 0.95869565217391, 0.27777777777778
50865, 0.52173913043478, 0.98478260869565, 0.30555555555556
50866, 0.54347826086956, 0.98478260869565, 0.33333333333333
50867, 0.52173913043478, 0.95869565217391, 0.33333333333333
50868, 0.52173913043478, 0.98478260869565, 0.36111111111111
50869, 0.54347826086956, 0.98478260869565, 0.38888888888889
50870, 0.52173913043478, 0.95869565217391, 0.38888888888889
50871, 0.52173913043478, 0.98478260869565, 0.41666666666667
50872, 0.54347826086956, 0.98478260869565, 0.44444444444444
50873, 0.52173913043478, 0.95869565217391, 0.44444444444444
50874, 0.52173913043478, 0.98478260869565, 0.47222222222222
50875, 0.47826086956522, 0.98478260869565, 0.027777777777778
50876, 0.5, 0.98478260869565, 0.055555555555556
50877, 0.47826086956522, 0.95869565217391, 0.055555555555556
50878, 0.47826086956522, 0.98478260869565, 0.083333333333333
50879, 0.5, 0.98478260869565, 0.11111111111111
50880, 0.47826086956522, 0.95869565217391, 0.11111111111111
50881, 0.47826086956522, 0.98478260869565, 0.13888888888889
50882, 0.5, 0.98478260869565, 0.16666666666667
50883, 0.47826086956522, 0.95869565217391, 0.16666666666667
50884, 0.47826086956522, 0.98478260869565, 0.19444444444444
50885, 0.5, 0.98478260869565, 0.22222222222222
50886, 0.47826086956522, 0.95869565217391, 0.22222222222222
50887, 0.47826086956522, 0.98478260869565, 0.25
50888, 0.5, 0.98478260869565, 0.27777777777778
50889, 0.47826086956522, 0.95869565217391, 0.27777777777778
50890, 0.47826086956522, 0.98478260869565, 0.30555555555556
50891, 0.5, 0.98478260869565, 0.33333333333333
50892, 0.47826086956522, 0.95869565217391, 0.33333333333333
50893, 0.47826086956522, 0.98478260869565, 0.36111111111111
50894, 0.5, 0.98478260869565, 0.38888888888889
50895, 0.47826086956522, 0.95869565217391, 0.38888888888889
50896, 0.47826086956522, 0.98478260869565, 0.41666666666667
50897, 0.5, 0.98478260869565, 0.44444444444444
50898, 0.47826086956522, 0.95869565217391, 0.44444444444444
50899, 0.47826086956522, 0.98478260869565, 0.47222222222222
50900, 0.43478260869565, 0.98478260869565, 0.027777777777778
50901, 0.45652173913043, 0.98478260869565, 0.055555555555556
50902, 0.43478260869565, 0.95869565217391, 0.055555555555556
50903, 0.43478260869565, 0.98478260869565, 0.083333333333333
50904, 0.45652173913043, 0.98478260869565, 0.11111111111111
50905, 0.43478260869565, 0.95869565217391, 0.11111111111111
50906, 0.43478260869565, 0.98478260869565, 0.13888888888889
50907, 0.45652173913043, 0.98478260869565, 0.16666666666667
50908, 0.43478260869565, 0.95869565217391, 0.16666666666667
50909, 0.43478260869565, 0.98478260869565, 0.19444444444444
50910, 0.45652173913043, 0.98478260869565, 0.22222222222222
50911, 0.43478260869565, 0.95869565217391, 0.22222222222222
50912, 0.43478260869565, 0.98478260869565, 0.25
50913, 0.45652173913043, 0.98478260869565, 0.27777777777778
50914, 0.43478260869565, 0.95869565217391, 0.27777777777778
50915, 0.43478260869565, 0.98478260869565, 0.30555555555556
50916, 0.45652173913043, 0.98478260869565, 0.33333333333333
50917, 0.43478260869565, 0.95869565217391, 0.33333333333333
50918, 0.43478260869565, 0.98478260869565, 0.36111111111111
50919, 0.45652173913043, 0.98478260869565, 0.38888888888889
50920, 0.43478260869565, 0.95869565217391, 0.38888888888889
50921, 0.43478260869565, 0.98478260869565, 0.41666666666667
50922, 0.45652173913043, 0.98478260869565, 0.44444444444444
50923, 0.43478260869565, 0.95869565217391, 0.44444444444444
50924, 0.43478260869565, 0.98478260869565, 0.47222222222222
50925, 0.39130434782609, 0.98478260869565, 0.027777777777778
50926, 0.41304347826087, 0.98478260869565, 0.055555555555556
50927, 0.39130434782609, 0.95869565217391, 0.055555555555556
50928, 0.39130434782609, 0.98478260869565, 0.083333333333333
50929, 0.41304347826087, 0.98478260869565, 0.11111111111111
50930, 0.39130434782609, 0.95869565217391, 0.11111111111111
50931, 0.39130434782609, 0.98478260869565, 0.13888888888889
50932, 0.41304347826087, 0.98478260869565, 0.16666666666667
50933, 0.39130434782609, 0.95869565217391, 0.16666666666667
50934, 0.39130434782609, 0.98478260869565, 0.19444444444444
50935, 0.41304347826087, 0.98478260869565, 0.22222222222222
50936, 0.39130434782609, 0.95869565217391, 0.22222222222222
50937, 0.39130434782609, 0.98478260869565, 0.25
50938, 0.41304347826087, 0.98478260869565, 0.27777777777778
50939, 0.39130434782609, 0.95869565217391, 0.27777777777778
50940, 0.39130434782609, 0.98478260869565, 0.30555555555556
50941, 0.41304347826087, 0.98478260869565, 0.33333333333333
50942, 0.39130434782609, 0.95869565217391, 0.33333333333333
50943, 0.39130434782609, 0.98478260869565, 0.36111111111111
50944, 0.41304347826087, 0.98478260869565, 0.38888888888889
50945, 0.39130434782609, 0.95869565217391, 0.38888888888889
50946, 0.39130434782609, 0.98478260869565, 0.41666666666667
50947, 0.41304347826087, 0.98478260869565, 0.44444444444444
50948, 0.39130434782609, 0.95869565217391, 0.44444444444444
50949, 0.39130434782609, 0.98478260869565, 0.47222222222222
50950, 0.34782608695652, 0.98478260869565, 0.027777777777778
50951, 0.3695652173913, 0.98478260869565, 0.055555555555556
50952, 0.34782608695652, 0.95869565217391, 0.055555555555556
50953, 0.34782608695652, 0.98478260869565, 0.083333333333333
50954, 0.3695652173913, 0.98478260869565, 0.11111111111111
50955, 0.34782608695652, 0.95869565217391, 0.11111111111111
50956, 0.34782608695652, 0.98478260869565, 0.13888888888889
50957, 0.3695652173913, 0.98478260869565, 0.16666666666667
50958, 0.34782608695652, 0.95869565217391, 0.16666666666667
50959, 0.34782608695652, 0.98478260869565, 0.19444444444444
50960, 0.3695652173913, 0.98478260869565, 0.22222222222222
50961, 0.34782608695652, 0.95869565217391, 0.22222222222222
50962, 0.34782608695652, 0.98478260869565, 0.25
50963, 0.3695652173913, 0.98478260869565, 0.27777777777778
50964, 0.34782608695652, 0.95869565217391, 0.27777777777778
50965, 0.34782608695652, 0.98478260869565, 0.30555555555556
50966, 0.3695652173913, 0.98478260869565, 0.33333333333333
50967, 0.34782608695652, 0.95869565217391, 0.33333333333333
50968, 0.34782608695652, 0.98478260869565, 0.36111111111111
50969, 0.3695652173913, 0.98478260869565, 0.38888888888889
50970, 0.34782608695652, 0.95869565217391, 0.38888888888889
50971, 0.34782608695652, 0.98478260869565, 0.41666666666667
50972, 0.3695652173913, 0.98478260869565, 0.44444444444444
50973, 0.34782608695652, 0.95869565217391, 0.44444444444444
50974, 0.34782608695652, 0.98478260869565, 0.47222222222222
50975, 0.30434782608696, 0.98478260869565, 0.027777777777778
50976, 0.32608695652174, 0.98478260869565, 0.055555555555556
50977, 0.30434782608696, 0.95869565217391, 0.055555555555556
50978, 0.30434782608696, 0.98478260869565, 0.083333333333333
50979, 0.32608695652174, 0.98478260869565, 0.11111111111111
50980, 0.30434782608696, 0.95869565217391, 0.11111111111111
50981, 0.30434782608696, 0.98478260869565, 0.13888888888889
50982, 0.32608695652174, 0.98478260869565, 0.16666666666667
50983, 0.30434782608696, 0.95869565217391, 0.16666666666667
50984, 0.30434782608696, 0.98478260869565, 0.19444444444444
50985, 0.32608695652174, 0.98478260869565, 0.22222222222222
50986, 0.30434782608696, 0.95869565217391, 0.22222222222222
50987, 0.30434782608696, 0.98478260869565, 0.25
50988, 0.32608695652174, 0.98478260869565, 0.27777777777778
50989, 0.30434782608696, 0.95869565217391, 0.27777777777778
50990, 0.30434782608696, 0.98478260869565, 0.30555555555556
50991, 0.32608695652174, 0.98478260869565, 0.33333333333333
50992, 0.30434782608696, 0.95869565217391, 0.33333333333333
50993, 0.30434782608696, 0.98478260869565, 0.36111111111111
50994, 0.32608695652174, 0.98478260869565, 0.38888888888889
50995, 0.30434782608696, 0.95869565217391, 0.38888888888889
50996, 0.30434782608696, 0.98478260869565, 0.41666666666667
50997, 0.32608695652174, 0.98478260869565, 0.44444444444444
50998, 0.30434782608696, 0.95869565217391, 0.44444444444444
50999, 0.30434782608696, 0.98478260869565, 0.47222222222222
51000, 0.26086956521739, 0.98478260869565, 0.027777777777778
51001, 0.28260869565217, 0.98478260869565, 0.055555555555556
51002, 0.26086956521739, 0.95869565217391, 0.055555555555556
51003, 0.26086956521739, 0.98478260869565, 0.083333333333333
51004, 0.28260869565217, 0.98478260869565, 0.11111111111111
51005, 0.26086956521739, 0.95869565217391, 0.11111111111111
51006, 0.26086956521739, 0.98478260869565, 0.13888888888889
51007, 0.28260869565217, 0.98478260869565, 0.16666666666667
51008, 0.26086956521739, 0.95869565217391, 0.16666666666667
51009, 0.26086956521739, 0.98478260869565, 0.19444444444444
51010, 0.28260869565217, 0.98478260869565, 0.22222222222222
51011, 0.26086956521739, 0.95869565217391, 0.22222222222222
51012, 0.26086956521739, 0.98478260869565, 0.25
51013, 0.28260869565217, 0.98478260869565, 0.27777777777778
51014, 0.26086956521739, 0.95869565217391, 0.27777777777778
51015, 0.26086956521739, 0.98478260869565, 0.30555555555556
51016, 0.28260869565217, 0.98478260869565, 0.33333333333333
51017, 0.26086956521739, 0.95869565217391, 0.33333333333333
51018, 0.26086956521739, 0.98478260869565, 0.36111111111111
51019, 0.28260869565217, 0.98478260869565, 0.38888888888889
51020, 0.26086956521739, 0.95869565217391, 0.38888888888889
51021, 0.26086956521739, 0.98478260869565, 0.41666666666667
51022, 0.28260869565217, 0.98478260869565, 0.44444444444444
51023, 0.26086956521739, 0.95869565217391, 0.44444444444444
51024, 0.26086956521739, 0.98478260869565, 0.47222222222222
51025, 0.21739130434783, 0.98478260869565, 0.027777777777778
51026, 0.23913043478261, 0.98478260869565, 0.055555555555556
51027, 0.21739130434783, 0.95869565217391, 0.055555555555556
51028, 0.21739130434783, 0.98478260869565, 0.083333333333333
51029, 0.23913043478261, 0.98478260869565, 0.11111111111111
51030, 0.21739130434783, 0.95869565217391, 0.11111111111111
51031, 0.21739130434783, 0.98478260869565, 0.13888888888889
51032, 0.23913043478261, 0.98478260869565, 0.16666666666667
51033, 0.21739130434783, 0.95869565217391, 0.16666666666667
51034, 0.21739130434783, 0.98478260869565, 0.19444444444444
51035, 0.23913043478261, 0.98478260869565, 0.22222222222222
51036, 0.21739130434783, 0.95869565217391, 0.22222222222222
51037, 0.21739130434783, 0.98478260869565, 0.25
51038, 0.23913043478261, 0.98478260869565, 0.27777777777778
51039, 0.21739130434783, 0.95869565217391, 0.27777777777778
51040, 0.21739130434783, 0.98478260869565, 0.30555555555556
51041, 0.23913043478261, 0.98478260869565, 0.33333333333333
51042, 0.21739130434783, 0.95869565217391, 0.33333333333333
51043, 0.21739130434783, 0.98478260869565, 0.36111111111111
51044, 0.23913043478261, 0.98478260869565, 0.38888888888889
51045, 0.21739130434783, 0.95869565217391, 0.38888888888889
51046, 0.21739130434783, 0.98478260869565, 0.41666666666667
51047, 0.23913043478261, 0.98478260869565, 0.44444444444444
51048, 0.21739130434783, 0.95869565217391, 0.44444444444444
51049, 0.21739130434783, 0.98478260869565, 0.47222222222222
51050, 0.17391304347826, 0.98478260869565, 0.027777777777778
51051, 0.19565217391304, 0.98478260869565, 0.055555555555556
51052, 0.17391304347826, 0.95869565217391, 0.055555555555556
51053, 0.17391304347826, 0.98478260869565, 0.083333333333333
51054, 0.19565217391304, 0.98478260869565, 0.11111111111111
51055, 0.17391304347826, 0.95869565217391, 0.11111111111111
51056, 0.17391304347826, 0.98478260869565, 0.13888888888889
51057, 0.19565217391304, 0.98478260869565, 0.16666666666667
51058, 0.17391304347826, 0.95869565217391, 0.16666666666667
51059, 0.17391304347826, 0.98478260869565, 0.19444444444444
51060, 0.19565217391304, 0.98478260869565, 0.22222222222222
51061, 0.17391304347826, 0.95869565217391, 0.22222222222222
51062, 0.17391304347826, 0.98478260869565, 0.25
51063, 0.19565217391304, 0.98478260869565, 0.27777777777778
51064, 0.17391304347826, 0.95869565217391, 0.27777777777778
51065, 0.17391304347826, 0.98478260869565, 0.30555555555556
51066, 0.19565217391304, 0.98478260869565, 0.33333333333333
51067, 0.17391304347826, 0.95869565217391, 0.33333333333333
51068, 0.17391304347826, 0.98478260869565, 0.36111111111111
51069, 0.19565217391304, 0.98478260869565, 0.38888888888889
51070, 0.17391304347826, 0.95869565217391, 0.38888888888889
51071, 0.17391304347826, 0.98478260869565, 0.41666666666667
51072, 0.19565217391304, 0.98478260869565, 0.44444444444444
51073, 0.17391304347826, 0.95869565217391, 0.44444444444444
51074, 0.17391304347826, 0.98478260869565, 0.47222222222222
51075, 0.1304347826087, 0.98478260869565, 0.027777777777778
51076, 0.15217391304348, 0.98478260869565, 0.055555555555556
51077, 0.1304347826087, 0.95869565217391, 0.055555555555556
51078, 0.1304347826087, 0.98478260869565, 0.083333333333333
51079, 0.15217391304348, 0.98478260869565, 0.11111111111111
51080, 0.1304347826087, 0.95869565217391, 0.11111111111111
51081, 0.1304347826087, 0.98478260869565, 0.13888888888889
51082, 0.15217391304348, 0.98478260869565, 0.16666666666667
51083, 0.1304347826087, 0.95869565217391, 0.16666666666667
51084, 0.1304347826087, 0.98478260869565, 0.19444444444444
51085, 0.15217391304348, 0.98478260869565, 0.22222222222222
51086, 0.1304347826087, 0.95869565217391, 0.22222222222222
51087, 0.1304347826087, 0.98478260869565, 0.25
51088, 0.15217391304348, 0.98478260869565, 0.27777777777778
51089, 0.1304347826087, 0.95869565217391, 0.27777777777778
51090, 0.1304347826087, 0.98478260869565, 0.30555555555556
51091, 0.15217391304348, 0.98478260869565, 0.33333333333333
51092, 0.1304347826087, 0.95869565217391, 0.33333333333333
51093, 0.1304347826087, 0.98478260869565, 0.36111111111111
51094, 0.15217391304348, 0.98478260869565, 0.38888888888889
51095, 0.1304347826087, 0.95869565217391, 0.38888888888889
51096, 0.1304347826087, 0.98478260869565, 0.41666666666667
51097, 0.15217391304348, 0.98478260869565, 0.44444444444444
51098, 0.1304347826087, 0.95869565217391, 0.44444444444444
51099, 0.1304347826087, 0.98478260869565, 0.47222222222222
51100, 0.08695652173913, 0.98478260869565, 0.027777777777778
51101, 0.10869565217391, 0.98478260869565, 0.055555555555556
51102, 0.08695652173913, 0.95869565217391, 0.055555555555556
51103, 0.08695652173913, 0.98478260869565, 0.083333333333333
51104, 0.10869565217391, 0.98478260869565, 0.11111111111111
51105, 0.08695652173913, 0.95869565217391, 0.11111111111111
51106, 0.08695652173913, 0.98478260869565, 0.13888888888889
51107, 0.10869565217391, 0.98478260869565, 0.16666666666667
51108, 0.08695652173913, 0.95869565217391, 0.16666666666667
51109, 0.08695652173913, 0.98478260869565, 0.19444444444444
51110, 0.10869565217391, 0.98478260869565, 0.22222222222222
51111, 0.08695652173913, 0.95869565217391, 0.22222222222222
51112, 0.08695652173913, 0.98478260869565, 0.25
51113, 0.10869565217391, 0.98478260869565, 0.27777777777778
51114, 0.08695652173913, 0.95869565217391, 0.27777777777778
51115, 0.08695652173913, 0.98478260869565, 0.30555555555556
51116, 0.10869565217391, 0.98478260869565, 0.33333333333333
51117, 0.08695652173913, 0.95869565217391, 0.33333333333333
51118, 0.08695652173913, 0.98478260869565, 0.36111111111111
51119, 0.10869565217391, 0.98478260869565, 0.38888888888889
51120, 0.08695652173913, 0.95869565217391, 0.38888888888889
51121, 0.08695652173913, 0.98478260869565, 0.41666666666667
51122, 0.10869565217391, 0.98478260869565, 0.44444444444444
51123, 0.08695652173913, 0.95869565217391, 0.44444444444444
51124, 0.08695652173913, 0.98478260869565, 0.47222222222222
51125, 0.043478260869565, 0.98478260869565, 0.027777777777778
51126, 0.065217391304348, 0.98478260869565, 0.055555555555556
51127, 0.043478260869565, 0.95869565217391, 0.055555555555556
51128, 0.043478260869565, 0.98478260869565, 0.083333333333333
51129, 0.065217391304348, 0.98478260869565, 0.11111111111111
51130, 0.043478260869565, 0.95869565217391, 0.11111111111111
51131, 0.043478260869565, 0.98478260869565, 0.13888888888889
51132, 0.065217391304348, 0.98478260869565, 0.16666666666667
51133, 0.043478260869565, 0.95869565217391, 0.16666666666667
51134, 0.043478260869565, 0.98478260869565, 0.19444444444444
51135, 0.065217391304348, 0.98478260869565, 0.22222222222222
51136, 0.043478260869565, 0.95869565217391, 0.22222222222222
51137, 0.043478260869565, 0.98478260869565, 0.25
51138, 0.065217391304348, 0.98478260869565, 0.27777777777778
51139, 0.043478260869565, 0.95869565217391, 0.27777777777778
51140, 0.043478260869565, 0.98478260869565, 0.30555555555556
51141, 0.065217391304348, 0.98478260869565, 0.33333333333333
51142, 0.043478260869565, 0.95869565217391, 0.33333333333333
51143, 0.043478260869565, 0.98478260869565, 0.36111111111111
51144, 0.065217391304348, 0.98478260869565, 0.38888888888889
51145, 0.043478260869565, 0.95869565217391, 0.38888888888889
51146, 0.043478260869565, 0.98478260869565, 0.41666666666667
51147, 0.065217391304348, 0.98478260869565, 0.44444444444444
51148, 0.043478260869565, 0.95869565217391, 0.44444444444444
51149, 0.043478260869565, 0.98478260869565, 0.47222222222222
51150, 0.021739130434783, 0.98478260869565, 0.055555555555556
51151, 0.021739130434783, 0.98478260869565, 0.11111111111111
51152, 0.021739130434783, 0.98478260869565, 0.16666666666667
51153, 0.021739130434783, 0.98478260869565, 0.22222222222222
51154, 0.021739130434783, 0.98478260869565, 0.27777777777778
51155, 0.021739130434783, 0.98478260869565, 0.33333333333333
51156, 0.021739130434783, 0.98478260869565, 0.38888888888889
51157, 0.021739130434783, 0.98478260869565, 0.44444444444444
51158, 0.95652173913043, 1.0369565217391, 0.027777777777778
51159, 0.97826086956522, 1.0369565217391, 0.055555555555556
51160, 0.95652173913043, 1.0108695652174, 0.055555555555556
51161, 0.95652173913043, 1.0369565217391, 0.083333333333333
51162, 0.97826086956522, 1.0369565217391, 0.11111111111111
51163, 0.95652173913044, 1.0108695652174, 0.11111111111111
51164, 0.95652173913044, 1.0369565217391, 0.13888888888889
51165, 0.97826086956522, 1.0369565217391, 0.16666666666667
51166, 0.95652173913044, 1.0108695652174, 0.16666666666667
51167, 0.95652173913044, 1.0369565217391, 0.19444444444444
51168, 0.97826086956522, 1.0369565217391, 0.22222222222222
51169, 0.95652173913044, 1.0108695652174, 0.22222222222222
51170, 0.95652173913044, 1.0369565217391, 0.25
51171, 0.97826086956522, 1.0369565217391, 0.27777777777778
51172, 0.95652173913044, 1.0108695652174, 0.27777777777778
51173, 0.95652173913044, 1.0369565217391, 0.30555555555556
51174, 0.97826086956522, 1.0369565217391, 0.33333333333333
51175, 0.95652173913044, 1.0108695652174, 0.33333333333333
51176, 0.95652173913044, 1.0369565217391, 0.36111111111111
51177, 0.97826086956522, 1.0369565217391, 0.38888888888889
51178, 0.95652173913044, 1.0108695652174, 0.38888888888889
51179, 0.95652173913044, 1.0369565217391, 0.41666666666667
51180, 0.97826086956522, 1.0369565217391, 0.44444444444444
51181, 0.95652173913044, 1.0108695652174, 0.44444444444444
51182, 0.95652173913043, 1.0369565217391, 0.47222222222222
