70547, 2.1130434782609, 0.72391304347826, 0.30555555555556
70548, 2.0913043478261, 0.72391304347826, 0.27777777777778
70549, 2.1130434782609, 0.75, 0.27777777777778
70550, 2.1130434782609, 0.72391304347826, 0.25
70551, 2.0913043478261, 0.72391304347826, 0.22222222222222
70552, 2.1130434782609, 0.75, 0.22222222222222
70553, 2.1130434782609, 0.72391304347826, 0.19444444444444
70554, 2.0913043478261, 0.72391304347826, 0.16666666666667
70555, 2.1130434782609, 0.75, 0.16666666666667
70556, 2.1130434782609, 0.72391304347826, 0.13888888888889
70557, 2.0913043478261, 0.72391304347826, 0.11111111111111
70558, 2.1130434782609, 0.75, 0.11111111111111
70559, 2.1130434782609, 0.72391304347826, 0.083333333333333
70560, 2.0913043478261, 0.72391304347826, 0.055555555555556
70561, 2.1130434782609, 0.75, 0.055555555555556
70562, 2.1130434782609, 0.72391304347826, 0.027777777777778
70563, 2.1565217391304, 0.72391304347826, 0.47222222222222
70564, 2.1347826086957, 0.72391304347826, 0.44444444444444
70565, 2.1565217391304, 0.75, 0.44444444444444
70566, 2.1565217391304, 0.72391304347826, 0.41666666666667
70567, 2.1347826086957, 0.72391304347826, 0.38888888888889
70568, 2.1565217391304, 0.75, 0.38888888888889
70569, 2.1565217391304, 0.72391304347826, 0.36111111111111
70570, 2.1347826086957, 0.72391304347826, 0.33333333333333
70571, 2.1565217391304, 0.75, 0.33333333333333
70572, 2.1565217391304, 0.72391304347826, 0.30555555555556
70573, 2.1347826086957, 0.72391304347826, 0.27777777777778
70574, 2.1565217391304, 0.75, 0.27777777777778
70575, 2.1565217391304, 0.72391304347826, 0.25
70576, 2.1347826086957, 0.72391304347826, 0.22222222222222
70577, 2.1565217391304, 0.75, 0.22222222222222
70578, 2.1565217391304, 0.72391304347826, 0.19444444444444
70579, 2.1347826086957, 0.72391304347826, 0.16666666666667
70580, 2.1565217391304, 0.75, 0.16666666666667
70581, 2.1565217391304, 0.72391304347826, 0.13888888888889
70582, 2.1347826086957, 0.72391304347826, 0.11111111111111
70583, 2.1565217391304, 0.75, 0.11111111111111
70584, 2.1565217391304, 0.72391304347826, 0.083333333333333
70585, 2.1347826086957, 0.72391304347826, 0.055555555555556
70586, 2.1565217391304, 0.75, 0.055555555555556
70587, 2.1565217391304, 0.72391304347826, 0.027777777777778
70588, 2.1782608695652, 0.72391304347826, 0.44444444444444
70589, 2.1782608695652, 0.72391304347826, 0.38888888888889
70590, 2.1782608695652, 0.72391304347826, 0.33333333333333
70591, 2.1782608695652, 0.72391304347826, 0.27777777777778
70592, 2.1782608695652, 0.72391304347826, 0.22222222222222
70593, 2.1782608695652, 0.72391304347826, 0.16666666666667
70594, 2.1782608695652, 0.72391304347826, 0.11111111111111
70595, 2.1782608695652, 0.72391304347826, 0.055555555555556
70596, 1.2434782608696, 0.67173913043478, 0.47222222222222
70597, 1.2217391304348, 0.67173913043478, 0.44444444444444
70598, 1.2434782608696, 0.69782608695652, 0.44444444444444
70599, 1.2434782608696, 0.67173913043478, 0.41666666666667
70600, 1.2217391304348, 0.67173913043478, 0.38888888888889
70601, 1.2434782608696, 0.69782608695652, 0.38888888888889
70602, 1.2434782608696, 0.67173913043478, 0.36111111111111
70603, 1.2217391304348, 0.67173913043478, 0.33333333333333
70604, 1.2434782608696, 0.69782608695652, 0.33333333333333
70605, 1.2434782608696, 0.67173913043478, 0.30555555555556
70606, 1.2217391304348, 0.67173913043478, 0.27777777777778
70607, 1.2434782608696, 0.69782608695652, 0.27777777777778
70608, 1.2434782608696, 0.67173913043478, 0.25
70609, 1.2217391304348, 0.67173913043478, 0.22222222222222
70610, 1.2434782608696, 0.69782608695652, 0.22222222222222
70611, 1.2434782608696, 0.67173913043478, 0.19444444444444
70612, 1.2217391304348, 0.67173913043478, 0.16666666666667
70613, 1.2434782608696, 0.69782608695652, 0.16666666666667
70614, 1.2434782608696, 0.67173913043478, 0.13888888888889
70615, 1.2217391304348, 0.67173913043478, 0.11111111111111
70616, 1.2434782608696, 0.69782608695652, 0.11111111111111
70617, 1.2434782608696, 0.67173913043478, 0.083333333333333
70618, 1.2217391304348, 0.67173913043478, 0.055555555555556
70619, 1.2434782608696, 0.69782608695652, 0.055555555555556
70620, 1.2434782608696, 0.67173913043478, 0.027777777777778
70621, 1.2869565217391, 0.67173913043478, 0.47222222222222
70622, 1.2652173913043, 0.67173913043478, 0.44444444444444
70623, 1.2869565217391, 0.69782608695652, 0.44444444444444
70624, 1.2869565217391, 0.67173913043478, 0.41666666666667
70625, 1.2652173913043, 0.67173913043478, 0.38888888888889
70626, 1.2869565217391, 0.69782608695652, 0.38888888888889
70627, 1.2869565217391, 0.67173913043478, 0.36111111111111
70628, 1.2652173913043, 0.67173913043478, 0.33333333333333
70629, 1.2869565217391, 0.69782608695652, 0.33333333333333
70630, 1.2869565217391, 0.67173913043478, 0.30555555555556
70631, 1.2652173913043, 0.67173913043478, 0.27777777777778
70632, 1.2869565217391, 0.69782608695652, 0.27777777777778
70633, 1.2869565217391, 0.67173913043478, 0.25
70634, 1.2652173913043, 0.67173913043478, 0.22222222222222
70635, 1.2869565217391, 0.69782608695652, 0.22222222222222
70636, 1.2869565217391, 0.67173913043478, 0.19444444444444
70637, 1.2652173913043, 0.67173913043478, 0.16666666666667
70638, 1.2869565217391, 0.69782608695652, 0.16666666666667
70639, 1.2869565217391, 0.67173913043478, 0.13888888888889
70640, 1.2652173913043, 0.67173913043478, 0.11111111111111
70641, 1.2869565217391, 0.69782608695652, 0.11111111111111
70642, 1.2869565217391, 0.67173913043478, 0.083333333333333
70643, 1.2652173913043, 0.67173913043478, 0.055555555555556
70644, 1.2869565217391, 0.69782608695652, 0.055555555555556
70645, 1.2869565217391, 0.67173913043478, 0.027777777777778
70646, 1.3304347826087, 0.67173913043478, 0.47222222222222
70647, 1.3086956521739, 0.67173913043478, 0.44444444444444
70648, 1.3304347826087, 0.69782608695652, 0.44444444444444
70649, 1.3304347826087, 0.67173913043478, 0.41666666666667
70650, 1.3086956521739, 0.67173913043478, 0.38888888888889
70651, 1.3304347826087, 0.69782608695652, 0.38888888888889
70652, 1.3304347826087, 0.67173913043478, 0.36111111111111
70653, 1.3086956521739, 0.67173913043478, 0.33333333333333
70654, 1.3304347826087, 0.69782608695652, 0.33333333333333
70655, 1.3304347826087, 0.67173913043478, 0.30555555555556
70656, 1.3086956521739, 0.67173913043478, 0.27777777777778
70657, 1.3304347826087, 0.69782608695652, 0.27777777777778
70658, 1.3304347826087, 0.67173913043478, 0.25
70659, 1.3086956521739, 0.67173913043478, 0.22222222222222
70660, 1.3304347826087, 0.69782608695652, 0.22222222222222
70661, 1.3304347826087, 0.67173913043478, 0.19444444444444
70662, 1.3086956521739, 0.67173913043478, 0.16666666666667
70663, 1.3304347826087, 0.69782608695652, 0.16666666666667
70664, 1.3304347826087, 0.67173913043478, 0.13888888888889
70665, 1.3086956521739, 0.67173913043478, 0.11111111111111
70666, 1.3304347826087, 0.69782608695652, 0.11111111111111
70667, 1.3304347826087, 0.67173913043478, 0.083333333333333
70668, 1.3086956521739, 0.67173913043478, 0.055555555555556
70669, 1.3304347826087, 0.69782608695652, 0.055555555555556
70670, 1.3304347826087, 0.67173913043478, 0.027777777777778
70671, 1.3739130434783, 0.67173913043478, 0.47222222222222
70672, 1.3521739130435, 0.67173913043478, 0.44444444444444
70673, 1.3739130434783, 0.69782608695652, 0.44444444444444
70674, 1.3739130434783, 0.67173913043478, 0.41666666666667
70675, 1.3521739130435, 0.67173913043478, 0.38888888888889
70676, 1.3739130434783, 0.69782608695652, 0.38888888888889
70677, 1.3739130434783, 0.67173913043478, 0.36111111111111
70678, 1.3521739130435, 0.67173913043478, 0.33333333333333
70679, 1.3739130434783, 0.69782608695652, 0.33333333333333
70680, 1.3739130434783, 0.67173913043478, 0.30555555555556
70681, 1.3521739130435, 0.67173913043478, 0.27777777777778
70682, 1.3739130434783, 0.69782608695652, 0.27777777777778
70683, 1.3739130434783, 0.67173913043478, 0.25
70684, 1.3521739130435, 0.67173913043478, 0.22222222222222
70685, 1.3739130434783, 0.69782608695652, 0.22222222222222
70686, 1.3739130434783, 0.67173913043478, 0.19444444444444
70687, 1.3521739130435, 0.67173913043478, 0.16666666666667
70688, 1.3739130434783, 0.69782608695652, 0.16666666666667
70689, 1.3739130434783, 0.67173913043478, 0.13888888888889
70690, 1.3521739130435, 0.67173913043478, 0.11111111111111
70691, 1.3739130434783, 0.69782608695652, 0.11111111111111
70692, 1.3739130434783, 0.67173913043478, 0.083333333333333
70693, 1.3521739130435, 0.67173913043478, 0.055555555555556
70694, 1.3739130434783, 0.69782608695652, 0.055555555555556
70695, 1.3739130434783, 0.67173913043478, 0.027777777777778
70696, 1.4173913043478, 0.67173913043478, 0.47222222222222
70697, 1.395652173913, 0.67173913043478, 0.44444444444444
70698, 1.4173913043478, 0.69782608695652, 0.44444444444444
70699, 1.4173913043478, 0.67173913043478, 0.41666666666667
70700, 1.395652173913, 0.67173913043478, 0.38888888888889
70701, 1.4173913043478, 0.69782608695652, 0.38888888888889
70702, 1.4173913043478, 0.67173913043478, 0.36111111111111
70703, 1.395652173913, 0.67173913043478, 0.33333333333333
70704, 1.4173913043478, 0.69782608695652, 0.33333333333333
70705, 1.4173913043478, 0.67173913043478, 0.30555555555556
70706, 1.395652173913, 0.67173913043478, 0.27777777777778
70707, 1.4173913043478, 0.69782608695652, 0.27777777777778
70708, 1.4173913043478, 0.67173913043478, 0.25
70709, 1.395652173913, 0.67173913043478, 0.22222222222222
70710, 1.4173913043478, 0.69782608695652, 0.22222222222222
70711, 1.4173913043478, 0.67173913043478, 0.19444444444444
70712, 1.395652173913, 0.67173913043478, 0.16666666666667
70713, 1.4173913043478, 0.69782608695652, 0.16666666666667
70714, 1.4173913043478, 0.67173913043478, 0.13888888888889
70715, 1.395652173913, 0.67173913043478, 0.11111111111111
70716, 1.4173913043478, 0.69782608695652, 0.11111111111111
70717, 1.4173913043478, 0.67173913043478, 0.083333333333333
70718, 1.395652173913, 0.67173913043478, 0.055555555555556
70719, 1.4173913043478, 0.69782608695652, 0.055555555555556
70720, 1.4173913043478, 0.67173913043478, 0.027777777777778
70721, 1.4608695652174, 0.67173913043478, 0.47222222222222
70722, 1.4391304347826, 0.67173913043478, 0.44444444444444
70723, 1.4608695652174, 0.69782608695652, 0.44444444444444
70724, 1.4608695652174, 0.67173913043478, 0.41666666666667
70725, 1.4391304347826, 0.67173913043478, 0.38888888888889
70726, 1.4608695652174, 0.69782608695652, 0.38888888888889
70727, 1.4608695652174, 0.67173913043478, 0.36111111111111
70728, 1.4391304347826, 0.67173913043478, 0.33333333333333
70729, 1.4608695652174, 0.69782608695652, 0.33333333333333
70730, 1.4608695652174, 0.67173913043478, 0.30555555555556
70731, 1.4391304347826, 0.67173913043478, 0.27777777777778
70732, 1.4608695652174, 0.69782608695652, 0.27777777777778
70733, 1.4608695652174, 0.67173913043478, 0.25
70734, 1.4391304347826, 0.67173913043478, 0.22222222222222
70735, 1.4608695652174, 0.69782608695652, 0.22222222222222
70736, 1.4608695652174, 0.67173913043478, 0.19444444444444
70737, 1.4391304347826, 0.67173913043478, 0.16666666666667
70738, 1.4608695652174, 0.69782608695652, 0.16666666666667
70739, 1.4608695652174, 0.67173913043478, 0.13888888888889
70740, 1.4391304347826, 0.67173913043478, 0.11111111111111
70741, 1.4608695652174, 0.69782608695652, 0.11111111111111
70742, 1.4608695652174, 0.67173913043478, 0.083333333333333
70743, 1.4391304347826, 0.67173913043478, 0.055555555555556
70744, 1.4608695652174, 0.69782608695652, 0.055555555555556
70745, 1.4608695652174, 0.67173913043478, 0.027777777777778
70746, 1.504347826087, 0.67173913043478, 0.47222222222222
70747, 1.4826086956522, 0.67173913043478, 0.44444444444444
70748, 1.504347826087, 0.69782608695652, 0.44444444444444
70749, 1.504347826087, 0.67173913043478, 0.41666666666667
70750, 1.4826086956522, 0.67173913043478, 0.38888888888889
70751, 1.504347826087, 0.69782608695652, 0.38888888888889
70752, 1.504347826087, 0.67173913043478, 0.36111111111111
70753, 1.4826086956522, 0.67173913043478, 0.33333333333333
70754, 1.504347826087, 0.69782608695652, 0.33333333333333
70755, 1.504347826087, 0.67173913043478, 0.30555555555556
70756, 1.4826086956522, 0.67173913043478, 0.27777777777778
70757, 1.504347826087, 0.69782608695652, 0.27777777777778
70758, 1.504347826087, 0.67173913043478, 0.25
70759, 1.4826086956522, 0.67173913043478, 0.22222222222222
70760, 1.504347826087, 0.69782608695652, 0.22222222222222
70761, 1.504347826087, 0.67173913043478, 0.19444444444444
70762, 1.4826086956522, 0.67173913043478, 0.16666666666667
70763, 1.504347826087, 0.69782608695652, 0.16666666666667
70764, 1.504347826087, 0.67173913043478, 0.13888888888889
70765, 1.4826086956522, 0.67173913043478, 0.11111111111111
70766, 1.504347826087, 0.69782608695652, 0.11111111111111
70767, 1.504347826087, 0.67173913043478, 0.083333333333333
70768, 1.4826086956522, 0.67173913043478, 0.055555555555556
70769, 1.504347826087, 0.69782608695652, 0.055555555555556
70770, 1.504347826087, 0.67173913043478, 0.027777777777778
70771, 1.5478260869565, 0.67173913043478, 0.47222222222222
70772, 1.5260869565217, 0.67173913043478, 0.44444444444444
70773, 1.5478260869565, 0.69782608695652, 0.44444444444444
70774, 1.5478260869565, 0.67173913043478, 0.41666666666667
70775, 1.5260869565217, 0.67173913043478, 0.38888888888889
70776, 1.5478260869565, 0.69782608695652, 0.38888888888889
70777, 1.5478260869565, 0.67173913043478, 0.36111111111111
70778, 1.5260869565217, 0.67173913043478, 0.33333333333333
70779, 1.5478260869565, 0.69782608695652, 0.33333333333333
70780, 1.5478260869565, 0.67173913043478, 0.30555555555556
70781, 1.5260869565217, 0.67173913043478, 0.27777777777778
70782, 1.5478260869565, 0.69782608695652, 0.27777777777778
70783, 1.5478260869565, 0.67173913043478, 0.25
70784, 1.5260869565217, 0.67173913043478, 0.22222222222222
70785, 1.5478260869565, 0.69782608695652, 0.22222222222222
70786, 1.5478260869565, 0.67173913043478, 0.19444444444444
70787, 1.5260869565217, 0.67173913043478, 0.16666666666667
70788, 1.5478260869565, 0.69782608695652, 0.16666666666667
70789, 1.5478260869565, 0.67173913043478, 0.13888888888889
70790, 1.5260869565217, 0.67173913043478, 0.11111111111111
70791, 1.5478260869565, 0.69782608695652, 0.11111111111111
70792, 1.5478260869565, 0.67173913043478, 0.083333333333333
70793, 1.5260869565217, 0.67173913043478, 0.055555555555556
70794, 1.5478260869565, 0.69782608695652, 0.055555555555556
70795, 1.5478260869565, 0.67173913043478, 0.027777777777778
70796, 1.5913043478261, 0.67173913043478, 0.47222222222222
70797, 1.5695652173913, 0.67173913043478, 0.44444444444444
70798, 1.5913043478261, 0.69782608695652, 0.44444444444444
70799, 1.5913043478261, 0.67173913043478, 0.41666666666667
70800, 1.5695652173913, 0.67173913043478, 0.38888888888889
70801, 1.5913043478261, 0.69782608695652, 0.38888888888889
70802, 1.5913043478261, 0.67173913043478, 0.36111111111111
70803, 1.5695652173913, 0.67173913043478, 0.33333333333333
70804, 1.5913043478261, 0.69782608695652, 0.33333333333333
70805, 1.5913043478261, 0.67173913043478, 0.30555555555556
70806, 1.5695652173913, 0.67173913043478, 0.27777777777778
70807, 1.5913043478261, 0.69782608695652, 0.27777777777778
70808, 1.5913043478261, 0.67173913043478, 0.25
70809, 1.5695652173913, 0.67173913043478, 0.22222222222222
70810, 1.5913043478261, 0.69782608695652, 0.22222222222222
70811, 1.5913043478261, 0.67173913043478, 0.19444444444444
70812, 1.5695652173913, 0.67173913043478, 0.16666666666667
70813, 1.5913043478261, 0.69782608695652, 0.16666666666667
70814, 1.5913043478261, 0.67173913043478, 0.13888888888889
70815, 1.5695652173913, 0.67173913043478, 0.11111111111111
70816, 1.5913043478261, 0.69782608695652, 0.11111111111111
70817, 1.5913043478261, 0.67173913043478, 0.083333333333333
70818, 1.5695652173913, 0.67173913043478, 0.055555555555556
70819, 1.5913043478261, 0.69782608695652, 0.055555555555556
70820, 1.5913043478261, 0.67173913043478, 0.027777777777778
70821, 1.6347826086957, 0.67173913043478, 0.47222222222222
70822, 1.6130434782609, 0.67173913043478, 0.44444444444444
70823, 1.6347826086957, 0.69782608695652, 0.44444444444444
70824, 1.6347826086957, 0.67173913043478, 0.41666666666667
70825, 1.6130434782609, 0.67173913043478, 0.38888888888889
70826, 1.6347826086957, 0.69782608695652, 0.38888888888889
70827, 1.6347826086957, 0.67173913043478, 0.36111111111111
70828, 1.6130434782609, 0.67173913043478, 0.33333333333333
70829, 1.6347826086957, 0.69782608695652, 0.33333333333333
70830, 1.6347826086957, 0.67173913043478, 0.30555555555556
70831, 1.6130434782609, 0.67173913043478, 0.27777777777778
70832, 1.6347826086957, 0.69782608695652, 0.27777777777778
70833, 1.6347826086957, 0.67173913043478, 0.25
70834, 1.6130434782609, 0.67173913043478, 0.22222222222222
70835, 1.6347826086957, 0.69782608695652, 0.22222222222222
70836, 1.6347826086957, 0.67173913043478, 0.19444444444444
70837, 1.6130434782609, 0.67173913043478, 0.16666666666667
70838, 1.6347826086957, 0.69782608695652, 0.16666666666667
70839, 1.6347826086957, 0.67173913043478, 0.13888888888889
70840, 1.6130434782609, 0.67173913043478, 0.11111111111111
70841, 1.6347826086957, 0.69782608695652, 0.11111111111111
70842, 1.6347826086957, 0.67173913043478, 0.083333333333333
70843, 1.6130434782609, 0.67173913043478, 0.055555555555556
70844, 1.6347826086957, 0.69782608695652, 0.055555555555556
70845, 1.6347826086957, 0.67173913043478, 0.027777777777778
70846, 1.6782608695652, 0.67173913043478, 0.47222222222222
70847, 1.6565217391304, 0.67173913043478, 0.44444444444444
70848, 1.6782608695652, 0.69782608695652, 0.44444444444444
70849, 1.6782608695652, 0.67173913043478, 0.41666666666667
70850, 1.6565217391304, 0.67173913043478, 0.38888888888889
70851, 1.6782608695652, 0.69782608695652, 0.38888888888889
70852, 1.6782608695652, 0.67173913043478, 0.36111111111111
70853, 1.6565217391304, 0.67173913043478, 0.33333333333333
70854, 1.6782608695652, 0.69782608695652, 0.33333333333333
70855, 1.6782608695652, 0.67173913043478, 0.30555555555556
70856, 1.6565217391304, 0.67173913043478, 0.27777777777778
70857, 1.6782608695652, 0.69782608695652, 0.27777777777778
70858, 1.6782608695652, 0.67173913043478, 0.25
70859, 1.6565217391304, 0.67173913043478, 0.22222222222222
70860, 1.6782608695652, 0.69782608695652, 0.22222222222222
70861, 1.6782608695652, 0.67173913043478, 0.19444444444444
70862, 1.6565217391304, 0.67173913043478, 0.16666666666667
70863, 1.6782608695652, 0.69782608695652, 0.16666666666667
70864, 1.6782608695652, 0.67173913043478, 0.13888888888889
70865, 1.6565217391304, 0.67173913043478, 0.11111111111111
70866, 1.6782608695652, 0.69782608695652, 0.11111111111111
70867, 1.6782608695652, 0.67173913043478, 0.083333333333333
70868, 1.6565217391304, 0.67173913043478, 0.055555555555556
70869, 1.6782608695652, 0.69782608695652, 0.055555555555556
70870, 1.6782608695652, 0.67173913043478, 0.027777777777778
70871, 1.7217391304348, 0.67173913043478, 0.47222222222222
70872, 1.7, 0.67173913043478, 0.44444444444444
70873, 1.7217391304348, 0.69782608695652, 0.44444444444444
70874, 1.7217391304348, 0.67173913043478, 0.41666666666667
70875, 1.7, 0.67173913043478, 0.38888888888889
70876, 1.7217391304348, 0.69782608695652, 0.38888888888889
70877, 1.7217391304348, 0.67173913043478, 0.36111111111111
70878, 1.7, 0.67173913043478, 0.33333333333333
70879, 1.7217391304348, 0.69782608695652, 0.33333333333333
70880, 1.7217391304348, 0.67173913043478, 0.30555555555556
70881, 1.7, 0.67173913043478, 0.27777777777778
70882, 1.7217391304348, 0.69782608695652, 0.27777777777778
70883, 1.7217391304348, 0.67173913043478, 0.25
70884, 1.7, 0.67173913043478, 0.22222222222222
70885, 1.7217391304348, 0.69782608695652, 0.22222222222222
70886, 1.7217391304348, 0.67173913043478, 0.19444444444444
70887, 1.7, 0.67173913043478, 0.16666666666667
70888, 1.7217391304348, 0.69782608695652, 0.16666666666667
70889, 1.7217391304348, 0.67173913043478, 0.13888888888889
70890, 1.7, 0.67173913043478, 0.11111111111111
70891, 1.7217391304348, 0.69782608695652, 0.11111111111111
70892, 1.7217391304348, 0.67173913043478, 0.083333333333333
70893, 1.7, 0.67173913043478, 0.055555555555556
70894, 1.7217391304348, 0.69782608695652, 0.055555555555556
70895, 1.7217391304348, 0.67173913043478, 0.027777777777778
70896, 1.7652173913043, 0.67173913043478, 0.47222222222222
70897, 1.7434782608696, 0.67173913043478, 0.44444444444444
70898, 1.7652173913043, 0.69782608695652, 0.44444444444444
70899, 1.7652173913043, 0.67173913043478, 0.41666666666667
70900, 1.7434782608696, 0.67173913043478, 0.38888888888889
70901, 1.7652173913043, 0.69782608695652, 0.38888888888889
70902, 1.7652173913043, 0.67173913043478, 0.36111111111111
70903, 1.7434782608696, 0.67173913043478, 0.33333333333333
70904, 1.7652173913043, 0.69782608695652, 0.33333333333333
70905, 1.7652173913043, 0.67173913043478, 0.30555555555556
70906, 1.7434782608696, 0.67173913043478, 0.27777777777778
70907, 1.7652173913043, 0.69782608695652, 0.27777777777778
70908, 1.7652173913043, 0.67173913043478, 0.25
70909, 1.7434782608696, 0.67173913043478, 0.22222222222222
70910, 1.7652173913043, 0.69782608695652, 0.22222222222222
70911, 1.7652173913043, 0.67173913043478, 0.19444444444444
70912, 1.7434782608696, 0.67173913043478, 0.16666666666667
70913, 1.7652173913043, 0.69782608695652, 0.16666666666667
70914, 1.7652173913043, 0.67173913043478, 0.13888888888889
70915, 1.7434782608696, 0.67173913043478, 0.11111111111111
70916, 1.7652173913043, 0.69782608695652, 0.11111111111111
70917, 1.7652173913043, 0.67173913043478, 0.083333333333333
70918, 1.7434782608696, 0.67173913043478, 0.055555555555556
70919, 1.7652173913043, 0.69782608695652, 0.055555555555556
70920, 1.7652173913043, 0.67173913043478, 0.027777777777778
70921, 1.8086956521739, 0.67173913043478, 0.47222222222222
70922, 1.7869565217391, 0.67173913043478, 0.44444444444444
70923, 1.8086956521739, 0.69782608695652, 0.44444444444444
70924, 1.8086956521739, 0.67173913043478, 0.41666666666667
70925, 1.7869565217391, 0.67173913043478, 0.38888888888889
70926, 1.8086956521739, 0.69782608695652, 0.38888888888889
70927, 1.8086956521739, 0.67173913043478, 0.36111111111111
70928, 1.7869565217391, 0.67173913043478, 0.33333333333333
70929, 1.8086956521739, 0.69782608695652, 0.33333333333333
70930, 1.8086956521739, 0.67173913043478, 0.30555555555556
70931, 1.7869565217391, 0.67173913043478, 0.27777777777778
70932, 1.8086956521739, 0.69782608695652, 0.27777777777778
70933, 1.8086956521739, 0.67173913043478, 0.25
70934, 1.7869565217391, 0.67173913043478, 0.22222222222222
70935, 1.8086956521739, 0.69782608695652, 0.22222222222222
70936, 1.8086956521739, 0.67173913043478, 0.19444444444444
70937, 1.7869565217391, 0.67173913043478, 0.16666666666667
70938, 1.8086956521739, 0.69782608695652, 0.16666666666667
70939, 1.8086956521739, 0.67173913043478, 0.13888888888889
70940, 1.7869565217391, 0.67173913043478, 0.11111111111111
70941, 1.8086956521739, 0.69782608695652, 0.11111111111111
70942, 1.8086956521739, 0.67173913043478, 0.083333333333333
70943, 1.7869565217391, 0.67173913043478, 0.055555555555556
70944, 1.8086956521739, 0.69782608695652, 0.055555555555556
70945, 1.8086956521739, 0.67173913043478, 0.027777777777778
70946, 1.8521739130435, 0.67173913043478, 0.47222222222222
70947, 1.8304347826087, 0.67173913043478, 0.44444444444444
70948, 1.8521739130435, 0.69782608695652, 0.44444444444444
70949, 1.8521739130435, 0.67173913043478, 0.41666666666667
70950, 1.8304347826087, 0.67173913043478, 0.38888888888889
70951, 1.8521739130435, 0.69782608695652, 0.38888888888889
70952, 1.8521739130435, 0.67173913043478, 0.36111111111111
70953, 1.8304347826087, 0.67173913043478, 0.33333333333333
70954, 1.8521739130435, 0.69782608695652, 0.33333333333333
70955, 1.8521739130435, 0.67173913043478, 0.30555555555556
70956, 1.8304347826087, 0.67173913043478, 0.27777777777778
70957, 1.8521739130435, 0.69782608695652, 0.27777777777778
70958, 1.8521739130435, 0.67173913043478, 0.25
70959, 1.8304347826087, 0.67173913043478, 0.22222222222222
70960, 1.8521739130435, 0.69782608695652, 0.22222222222222
70961, 1.8521739130435, 0.67173913043478, 0.19444444444444
70962, 1.8304347826087, 0.67173913043478, 0.16666666666667
70963, 1.8521739130435, 0.69782608695652, 0.16666666666667
70964, 1.8521739130435, 0.67173913043478, 0.13888888888889
70965, 1.8304347826087, 0.67173913043478, 0.11111111111111
70966, 1.8521739130435, 0.69782608695652, 0.11111111111111
70967, 1.8521739130435, 0.67173913043478, 0.083333333333333
70968, 1.8304347826087, 0.67173913043478, 0.055555555555556
70969, 1.8521739130435, 0.69782608695652, 0.055555555555556
70970, 1.8521739130435, 0.67173913043478, 0.027777777777778
70971, 1.895652173913, 0.67173913043478, 0.47222222222222
70972, 1.8739130434783, 0.67173913043478, 0.44444444444444
70973, 1.895652173913, 0.69782608695652, 0.44444444444444
70974, 1.895652173913, 0.67173913043478, 0.41666666666667
70975, 1.8739130434783, 0.67173913043478, 0.38888888888889
70976, 1.895652173913, 0.69782608695652, 0.38888888888889
70977, 1.895652173913, 0.67173913043478, 0.36111111111111
70978, 1.8739130434783, 0.67173913043478, 0.33333333333333
70979, 1.895652173913, 0.69782608695652, 0.33333333333333
70980, 1.895652173913, 0.67173913043478, 0.30555555555556
70981, 1.8739130434783, 0.67173913043478, 0.27777777777778
70982, 1.895652173913, 0.69782608695652, 0.27777777777778
70983, 1.895652173913, 0.67173913043478, 0.25
70984, 1.8739130434783, 0.67173913043478, 0.22222222222222
70985, 1.895652173913, 0.69782608695652, 0.22222222222222
70986, 1.895652173913, 0.67173913043478, 0.19444444444444
70987, 1.8739130434783, 0.67173913043478, 0.16666666666667
70988, 1.895652173913, 0.69782608695652, 0.16666666666667
70989, 1.895652173913, 0.67173913043478, 0.13888888888889
70990, 1.8739130434783, 0.67173913043478, 0.11111111111111
70991, 1.895652173913, 0.69782608695652, 0.11111111111111
70992, 1.895652173913, 0.67173913043478, 0.083333333333333
70993, 1.8739130434783, 0.67173913043478, 0.055555555555556
70994, 1.895652173913, 0.69782608695652, 0.055555555555556
70995, 1.895652173913, 0.67173913043478, 0.027777777777778
70996, 1.9391304347826, 0.67173913043478, 0.47222222222222
70997, 1.9173913043478, 0.67173913043478, 0.44444444444444
70998, 1.9391304347826, 0.69782608695652, 0.44444444444444
70999, 1.9391304347826, 0.67173913043478, 0.41666666666667
71000, 1.9173913043478, 0.67173913043478, 0.38888888888889
71001, 1.9391304347826, 0.69782608695652, 0.38888888888889
71002, 1.9391304347826, 0.67173913043478, 0.36111111111111
71003, 1.9173913043478, 0.67173913043478, 0.33333333333333
71004, 1.9391304347826, 0.69782608695652, 0.33333333333333
71005, 1.9391304347826, 0.67173913043478, 0.30555555555556
71006, 1.9173913043478, 0.67173913043478, 0.27777777777778
71007, 1.9391304347826, 0.69782608695652, 0.27777777777778
71008, 1.9391304347826, 0.67173913043478, 0.25
71009, 1.9173913043478, 0.67173913043478, 0.22222222222222
71010, 1.9391304347826, 0.69782608695652, 0.22222222222222
71011, 1.9391304347826, 0.67173913043478, 0.19444444444444
71012, 1.9173913043478, 0.67173913043478, 0.16666666666667
71013, 1.9391304347826, 0.69782608695652, 0.16666666666667
71014, 1.9391304347826, 0.67173913043478, 0.13888888888889
71015, 1.9173913043478, 0.67173913043478, 0.11111111111111
71016, 1.9391304347826, 0.69782608695652, 0.11111111111111
71017, 1.9391304347826, 0.67173913043478, 0.083333333333333
71018, 1.9173913043478, 0.67173913043478, 0.055555555555556
71019, 1.9391304347826, 0.69782608695652, 0.055555555555556
71020, 1.9391304347826, 0.67173913043478, 0.027777777777778
71021, 1.9826086956522, 0.67173913043478, 0.47222222222222
71022, 1.9608695652174, 0.67173913043478, 0.44444444444444
71023, 1.9826086956522, 0.69782608695652, 0.44444444444444
71024, 1.9826086956522, 0.67173913043478, 0.41666666666667
71025, 1.9608695652174, 0.67173913043478, 0.38888888888889
71026, 1.9826086956522, 0.69782608695652, 0.38888888888889
71027, 1.9826086956522, 0.67173913043478, 0.36111111111111
71028, 1.9608695652174, 0.67173913043478, 0.33333333333333
71029, 1.9826086956522, 0.69782608695652, 0.33333333333333
71030, 1.9826086956522, 0.67173913043478, 0.30555555555556
71031, 1.9608695652174, 0.67173913043478, 0.27777777777778
71032, 1.9826086956522, 0.69782608695652, 0.27777777777778
71033, 1.9826086956522, 0.67173913043478, 0.25
71034, 1.9608695652174, 0.67173913043478, 0.22222222222222
71035, 1.9826086956522, 0.69782608695652, 0.22222222222222
71036, 1.9826086956522, 0.67173913043478, 0.19444444444444
71037, 1.9608695652174, 0.67173913043478, 0.16666666666667
71038, 1.9826086956522, 0.69782608695652, 0.16666666666667
71039, 1.9826086956522, 0.67173913043478, 0.13888888888889
71040, 1.9608695652174, 0.67173913043478, 0.11111111111111
71041, 1.9826086956522, 0.69782608695652, 0.11111111111111
71042, 1.9826086956522, 0.67173913043478, 0.083333333333333
71043, 1.9608695652174, 0.67173913043478, 0.055555555555556
71044, 1.9826086956522, 0.69782608695652, 0.055555555555556
71045, 1.9826086956522, 0.67173913043478, 0.027777777777778
71046, 2.0260869565217, 0.67173913043478, 0.47222222222222
71047, 2.004347826087, 0.67173913043478, 0.44444444444444
71048, 2.0260869565217, 0.69782608695652, 0.44444444444444
71049, 2.0260869565217, 0.67173913043478, 0.41666666666667
71050, 2.004347826087, 0.67173913043478, 0.38888888888889
71051, 2.0260869565217, 0.69782608695652, 0.38888888888889
71052, 2.0260869565217, 0.67173913043478, 0.36111111111111
71053, 2.004347826087, 0.67173913043478, 0.33333333333333
71054, 2.0260869565217, 0.69782608695652, 0.33333333333333
71055, 2.0260869565217, 0.67173913043478, 0.30555555555556
71056, 2.004347826087, 0.67173913043478, 0.27777777777778
71057, 2.0260869565217, 0.69782608695652, 0.27777777777778
71058, 2.0260869565217, 0.67173913043478, 0.25
71059, 2.004347826087, 0.67173913043478, 0.22222222222222
71060, 2.0260869565217, 0.69782608695652, 0.22222222222222
71061, 2.0260869565217, 0.67173913043478, 0.19444444444444
71062, 2.004347826087, 0.67173913043478, 0.16666666666667
71063, 2.0260869565217, 0.69782608695652, 0.16666666666667
71064, 2.0260869565217, 0.67173913043478, 0.13888888888889
71065, 2.004347826087, 0.67173913043478, 0.11111111111111
71066, 2.0260869565217, 0.69782608695652, 0.11111111111111
71067, 2.0260869565217, 0.67173913043478, 0.083333333333333
71068, 2.004347826087, 0.67173913043478, 0.055555555555556
71069, 2.0260869565217, 0.69782608695652, 0.055555555555556
71070, 2.0260869565217, 0.67173913043478, 0.027777777777778
71071, 2.0695652173913, 0.67173913043478, 0.47222222222222
71072, 2.0478260869565, 0.67173913043478, 0.44444444444444
71073, 2.0695652173913, 0.69782608695652, 0.44444444444444
71074, 2.0695652173913, 0.67173913043478, 0.41666666666667
71075, 2.0478260869565, 0.67173913043478, 0.38888888888889
71076, 2.0695652173913, 0.69782608695652, 0.38888888888889
71077, 2.0695652173913, 0.67173913043478, 0.36111111111111
71078, 2.0478260869565, 0.67173913043478, 0.33333333333333
71079, 2.0695652173913, 0.69782608695652, 0.33333333333333
71080, 2.0695652173913, 0.67173913043478, 0.30555555555556
71081, 2.0478260869565, 0.67173913043478, 0.27777777777778
71082, 2.0695652173913, 0.69782608695652, 0.27777777777778
71083, 2.0695652173913, 0.67173913043478, 0.25
71084, 2.0478260869565, 0.67173913043478, 0.22222222222222
71085, 2.0695652173913, 0.69782608695652, 0.22222222222222
71086, 2.0695652173913, 0.67173913043478, 0.19444444444444
71087, 2.0478260869565, 0.67173913043478, 0.16666666666667
71088, 2.0695652173913, 0.69782608695652, 0.16666666666667
71089, 2.0695652173913, 0.67173913043478, 0.13888888888889
71090, 2.0478260869565, 0.67173913043478, 0.11111111111111
71091, 2.0695652173913, 0.69782608695652, 0.11111111111111
71092, 2.0695652173913, 0.67173913043478, 0.083333333333333
71093, 2.0478260869565, 0.67173913043478, 0.055555555555556
71094, 2.0695652173913, 0.69782608695652, 0.055555555555556
71095, 2.0695652173913, 0.67173913043478, 0.027777777777778
71096, 2.1130434782609, 0.67173913043478, 0.47222222222222
71097, 2.0913043478261, 0.67173913043478, 0.44444444444444
71098, 2.1130434782609, 0.69782608695652, 0.44444444444444
71099, 2.1130434782609, 0.67173913043478, 0.41666666666667
71100, 2.0913043478261, 0.67173913043478, 0.38888888888889
71101, 2.1130434782609, 0.69782608695652, 0.38888888888889
71102, 2.1130434782609, 0.67173913043478, 0.36111111111111
71103, 2.0913043478261, 0.67173913043478, 0.33333333333333
71104, 2.1130434782609, 0.69782608695652, 0.33333333333333
71105, 2.1130434782609, 0.67173913043478, 0.30555555555556
71106, 2.0913043478261, 0.67173913043478, 0.27777777777778
71107, 2.1130434782609, 0.69782608695652, 0.27777777777778
71108, 2.1130434782609, 0.67173913043478, 0.25
71109, 2.0913043478261, 0.67173913043478, 0.22222222222222
71110, 2.1130434782609, 0.69782608695652, 0.22222222222222
71111, 2.1130434782609, 0.67173913043478, 0.19444444444444
71112, 2.0913043478261, 0.67173913043478, 0.16666666666667
71113, 2.1130434782609, 0.69782608695652, 0.16666666666667
71114, 2.1130434782609, 0.67173913043478, 0.13888888888889
71115, 2.0913043478261, 0.67173913043478, 0.11111111111111
71116, 2.1130434782609, 0.69782608695652, 0.11111111111111
71117, 2.1130434782609, 0.67173913043478, 0.083333333333333
71118, 2.0913043478261, 0.67173913043478, 0.055555555555556
71119, 2.1130434782609, 0.69782608695652, 0.055555555555556
71120, 2.1130434782609, 0.67173913043478, 0.027777777777778
71121, 2.1565217391304, 0.67173913043478, 0.47222222222222
71122, 2.1347826086957, 0.67173913043478, 0.44444444444444
71123, 2.1565217391304, 0.69782608695652, 0.44444444444444
71124, 2.1565217391304, 0.67173913043478, 0.41666666666667
71125, 2.1347826086957, 0.67173913043478, 0.38888888888889
71126, 2.1565217391304, 0.69782608695652, 0.38888888888889
71127, 2.1565217391304, 0.67173913043478, 0.36111111111111
71128, 2.1347826086957, 0.67173913043478, 0.33333333333333
71129, 2.1565217391304, 0.69782608695652, 0.33333333333333
71130, 2.1565217391304, 0.67173913043478, 0.30555555555556
71131, 2.1347826086957, 0.67173913043478, 0.27777777777778
71132, 2.1565217391304, 0.69782608695652, 0.27777777777778
71133, 2.1565217391304, 0.67173913043478, 0.25
71134, 2.1347826086957, 0.67173913043478, 0.22222222222222
71135, 2.1565217391304, 0.69782608695652, 0.22222222222222
71136, 2.1565217391304, 0.67173913043478, 0.19444444444444
71137, 2.1347826086957, 0.67173913043478, 0.16666666666667
71138, 2.1565217391304, 0.69782608695652, 0.16666666666667
71139, 2.1565217391304, 0.67173913043478, 0.13888888888889
71140, 2.1347826086957, 0.67173913043478, 0.11111111111111
71141, 2.1565217391304, 0.69782608695652, 0.11111111111111
71142, 2.1565217391304, 0.67173913043478, 0.083333333333333
71143, 2.1347826086957, 0.67173913043478, 0.055555555555556
71144, 2.1565217391304, 0.69782608695652, 0.055555555555556
71145, 2.1565217391304, 0.67173913043478, 0.027777777777778
71146, 2.1782608695652, 0.67173913043478, 0.44444444444444
71147, 2.1782608695652, 0.67173913043478, 0.38888888888889
71148, 2.1782608695652, 0.67173913043478, 0.33333333333333
71149, 2.1782608695652, 0.67173913043478, 0.27777777777778
71150, 2.1782608695652, 0.67173913043478, 0.22222222222222
71151, 2.1782608695652, 0.67173913043478, 0.16666666666667
71152, 2.1782608695652, 0.67173913043478, 0.11111111111111
71153, 2.1782608695652, 0.67173913043478, 0.055555555555556
71154, 1.2434782608696, 0.61956521739131, 0.47222222222222
71155, 1.2217391304348, 0.61956521739131, 0.44444444444444
71156, 1.2434782608696, 0.64565217391304, 0.44444444444444
71157, 1.2434782608696, 0.61956521739131, 0.41666666666667
71158, 1.2217391304348, 0.61956521739131, 0.38888888888889
71159, 1.2434782608696, 0.64565217391304, 0.38888888888889
71160, 1.2434782608696, 0.61956521739131, 0.36111111111111
71161, 1.2217391304348, 0.61956521739131, 0.33333333333333
71162, 1.2434782608696, 0.64565217391304, 0.33333333333333
71163, 1.2434782608696, 0.61956521739131, 0.30555555555556
71164, 1.2217391304348, 0.61956521739131, 0.27777777777778
71165, 1.2434782608696, 0.64565217391304, 0.27777777777778
71166, 1.2434782608696, 0.61956521739131, 0.25
71167, 1.2217391304348, 0.61956521739131, 0.22222222222222
71168, 1.2434782608696, 0.64565217391304, 0.22222222222222
71169, 1.2434782608696, 0.61956521739131, 0.19444444444444
71170, 1.2217391304348, 0.61956521739131, 0.16666666666667
71171, 1.2434782608696, 0.64565217391304, 0.16666666666667
71172, 1.2434782608696, 0.61956521739131, 0.13888888888889
71173, 1.2217391304348, 0.61956521739131, 0.11111111111111
71174, 1.2434782608696, 0.64565217391304, 0.11111111111111
71175, 1.2434782608696, 0.61956521739131, 0.083333333333333
71176, 1.2217391304348, 0.61956521739131, 0.055555555555556
71177, 1.2434782608696, 0.64565217391304, 0.055555555555556
71178, 1.2434782608696, 0.61956521739131, 0.027777777777778
71179, 1.2869565217391, 0.61956521739131, 0.47222222222222
71180, 1.2652173913043, 0.61956521739131, 0.44444444444444
71181, 1.2869565217391, 0.64565217391304, 0.44444444444444
71182, 1.2869565217391, 0.61956521739131, 0.41666666666667
71183, 1.2652173913043, 0.61956521739131, 0.38888888888889
71184, 1.2869565217391, 0.64565217391304, 0.38888888888889
71185, 1.2869565217391, 0.61956521739131, 0.36111111111111
71186, 1.2652173913043, 0.61956521739131, 0.33333333333333
71187, 1.2869565217391, 0.64565217391304, 0.33333333333333
71188, 1.2869565217391, 0.61956521739131, 0.30555555555556
71189, 1.2652173913043, 0.61956521739131, 0.27777777777778
71190, 1.2869565217391, 0.64565217391304, 0.27777777777778
71191, 1.2869565217391, 0.61956521739131, 0.25
71192, 1.2652173913043, 0.61956521739131, 0.22222222222222
71193, 1.2869565217391, 0.64565217391304, 0.22222222222222
71194, 1.2869565217391, 0.61956521739131, 0.19444444444444
71195, 1.2652173913043, 0.61956521739131, 0.16666666666667
71196, 1.2869565217391, 0.64565217391304, 0.16666666666667
71197, 1.2869565217391, 0.61956521739131, 0.13888888888889
71198, 1.2652173913043, 0.61956521739131, 0.11111111111111
71199, 1.2869565217391, 0.64565217391304, 0.11111111111111
71200, 1.2869565217391, 0.61956521739131, 0.083333333333333
71201, 1.2652173913043, 0.61956521739131, 0.055555555555556
71202, 1.2869565217391, 0.64565217391304, 0.055555555555556
71203, 1.2869565217391, 0.61956521739131, 0.027777777777778
71204, 1.3304347826087, 0.61956521739131, 0.47222222222222
71205, 1.3086956521739, 0.61956521739131, 0.44444444444444
71206, 1.3304347826087, 0.64565217391304, 0.44444444444444
71207, 1.3304347826087, 0.61956521739131, 0.41666666666667
71208, 1.3086956521739, 0.61956521739131, 0.38888888888889
71209, 1.3304347826087, 0.64565217391304, 0.38888888888889
71210, 1.3304347826087, 0.61956521739131, 0.36111111111111
71211, 1.3086956521739, 0.61956521739131, 0.33333333333333
71212, 1.3304347826087, 0.64565217391304, 0.33333333333333
71213, 1.3304347826087, 0.61956521739131, 0.30555555555556
71214, 1.3086956521739, 0.61956521739131, 0.27777777777778
71215, 1.3304347826087, 0.64565217391304, 0.27777777777778
71216, 1.3304347826087, 0.61956521739131, 0.25
71217, 1.3086956521739, 0.61956521739131, 0.22222222222222
71218, 1.3304347826087, 0.64565217391304, 0.22222222222222
71219, 1.3304347826087, 0.61956521739131, 0.19444444444444
71220, 1.3086956521739, 0.61956521739131, 0.16666666666667
71221, 1.3304347826087, 0.64565217391304, 0.16666666666667
71222, 1.3304347826087, 0.61956521739131, 0.13888888888889
71223, 1.3086956521739, 0.61956521739131, 0.11111111111111
71224, 1.3304347826087, 0.64565217391304, 0.11111111111111
71225, 1.3304347826087, 0.61956521739131, 0.083333333333333
71226, 1.3086956521739, 0.61956521739131, 0.055555555555556
71227, 1.3304347826087, 0.64565217391304, 0.055555555555556
71228, 1.3304347826087, 0.61956521739131, 0.027777777777778
71229, 1.3739130434783, 0.61956521739131, 0.47222222222222
71230, 1.3521739130435, 0.61956521739131, 0.44444444444444
71231, 1.3739130434783, 0.64565217391304, 0.44444444444444
71232, 1.3739130434783, 0.61956521739131, 0.41666666666667
71233, 1.3521739130435, 0.61956521739131, 0.38888888888889
71234, 1.3739130434783, 0.64565217391304, 0.38888888888889
71235, 1.3739130434783, 0.61956521739131, 0.36111111111111
71236, 1.3521739130435, 0.61956521739131, 0.33333333333333
71237, 1.3739130434783, 0.64565217391304, 0.33333333333333
71238, 1.3739130434783, 0.61956521739131, 0.30555555555556
71239, 1.3521739130435, 0.61956521739131, 0.27777777777778
71240, 1.3739130434783, 0.64565217391304, 0.27777777777778
71241, 1.3739130434783, 0.61956521739131, 0.25
71242, 1.3521739130435, 0.61956521739131, 0.22222222222222
71243, 1.3739130434783, 0.64565217391304, 0.22222222222222
71244, 1.3739130434783, 0.61956521739131, 0.19444444444444
71245, 1.3521739130435, 0.61956521739131, 0.16666666666667
71246, 1.3739130434783, 0.64565217391304, 0.16666666666667
71247, 1.3739130434783, 0.61956521739131, 0.13888888888889
71248, 1.3521739130435, 0.61956521739131, 0.11111111111111
71249, 1.3739130434783, 0.64565217391304, 0.11111111111111
71250, 1.3739130434783, 0.61956521739131, 0.083333333333333
71251, 1.3521739130435, 0.61956521739131, 0.055555555555556
71252, 1.3739130434783, 0.64565217391304, 0.055555555555556
71253, 1.3739130434783, 0.61956521739131, 0.027777777777778
71254, 1.4173913043478, 0.61956521739131, 0.47222222222222
71255, 1.395652173913, 0.61956521739131, 0.44444444444444
71256, 1.4173913043478, 0.64565217391304, 0.44444444444444
71257, 1.4173913043478, 0.61956521739131, 0.41666666666667
71258, 1.395652173913, 0.61956521739131, 0.38888888888889
71259, 1.4173913043478, 0.64565217391304, 0.38888888888889
71260, 1.4173913043478, 0.61956521739131, 0.36111111111111
71261, 1.395652173913, 0.61956521739131, 0.33333333333333
71262, 1.4173913043478, 0.64565217391304, 0.33333333333333
71263, 1.4173913043478, 0.61956521739131, 0.30555555555556
71264, 1.395652173913, 0.61956521739131, 0.27777777777778
71265, 1.4173913043478, 0.64565217391304, 0.27777777777778
71266, 1.4173913043478, 0.61956521739131, 0.25
71267, 1.395652173913, 0.61956521739131, 0.22222222222222
71268, 1.4173913043478, 0.64565217391304, 0.22222222222222
71269, 1.4173913043478, 0.61956521739131, 0.19444444444444
71270, 1.395652173913, 0.61956521739131, 0.16666666666667
71271, 1.4173913043478, 0.64565217391304, 0.16666666666667
71272, 1.4173913043478, 0.61956521739131, 0.13888888888889
71273, 1.395652173913, 0.61956521739131, 0.11111111111111
71274, 1.4173913043478, 0.64565217391304, 0.11111111111111
71275, 1.4173913043478, 0.61956521739131, 0.083333333333333
71276, 1.395652173913, 0.61956521739131, 0.055555555555556
71277, 1.4173913043478, 0.64565217391304, 0.055555555555556
71278, 1.4173913043478, 0.61956521739131, 0.027777777777778
71279, 1.4608695652174, 0.61956521739131, 0.47222222222222
71280, 1.4391304347826, 0.61956521739131, 0.44444444444444
71281, 1.4608695652174, 0.64565217391304, 0.44444444444444
71282, 1.4608695652174, 0.61956521739131, 0.41666666666667
71283, 1.4391304347826, 0.61956521739131, 0.38888888888889
71284, 1.4608695652174, 0.64565217391304, 0.38888888888889
71285, 1.4608695652174, 0.61956521739131, 0.36111111111111
71286, 1.4391304347826, 0.61956521739131, 0.33333333333333
71287, 1.4608695652174, 0.64565217391304, 0.33333333333333
71288, 1.4608695652174, 0.6195652173913, 0.30555555555556
71289, 1.4391304347826, 0.6195652173913, 0.27777777777778
71290, 1.4608695652174, 0.64565217391304, 0.27777777777778
71291, 1.4608695652174, 0.6195652173913, 0.25
71292, 1.4391304347826, 0.61956521739131, 0.22222222222222
71293, 1.4608695652174, 0.64565217391304, 0.22222222222222
71294, 1.4608695652174, 0.6195652173913, 0.19444444444444
71295, 1.4391304347826, 0.6195652173913, 0.16666666666667
71296, 1.4608695652174, 0.64565217391304, 0.16666666666667
71297, 1.4608695652174, 0.6195652173913, 0.13888888888889
71298, 1.4391304347826, 0.61956521739131, 0.11111111111111
71299, 1.4608695652174, 0.64565217391304, 0.11111111111111
71300, 1.4608695652174, 0.61956521739131, 0.083333333333333
71301, 1.4391304347826, 0.61956521739131, 0.055555555555556
71302, 1.4608695652174, 0.64565217391304, 0.055555555555556
71303, 1.4608695652174, 0.61956521739131, 0.027777777777778
71304, 1.504347826087, 0.61956521739131, 0.47222222222222
71305, 1.4826086956522, 0.61956521739131, 0.44444444444444
71306, 1.504347826087, 0.64565217391304, 0.44444444444444
71307, 1.504347826087, 0.6195652173913, 0.41666666666667
71308, 1.4826086956522, 0.6195652173913, 0.38888888888889
71309, 1.504347826087, 0.64565217391304, 0.38888888888889
71310, 1.504347826087, 0.6195652173913, 0.36111111111111
71311, 1.4826086956522, 0.61956521739131, 0.33333333333333
71312, 1.504347826087, 0.64565217391304, 0.33333333333333
71313, 1.504347826087, 0.6195652173913, 0.30555555555556
71314, 1.4826086956522, 0.6195652173913, 0.27777777777778
71315, 1.504347826087, 0.64565217391304, 0.27777777777778
71316, 1.504347826087, 0.6195652173913, 0.25
71317, 1.4826086956522, 0.6195652173913, 0.22222222222222
71318, 1.504347826087, 0.64565217391304, 0.22222222222222
71319, 1.504347826087, 0.6195652173913, 0.19444444444444
71320, 1.4826086956522, 0.6195652173913, 0.16666666666667
71321, 1.504347826087, 0.64565217391304, 0.16666666666667
71322, 1.504347826087, 0.6195652173913, 0.13888888888889
71323, 1.4826086956522, 0.6195652173913, 0.11111111111111
71324, 1.504347826087, 0.64565217391304, 0.11111111111111
71325, 1.504347826087, 0.6195652173913, 0.083333333333333
71326, 1.4826086956522, 0.6195652173913, 0.055555555555556
71327, 1.504347826087, 0.64565217391304, 0.055555555555556
71328, 1.504347826087, 0.6195652173913, 0.027777777777778
71329, 1.5478260869565, 0.61956521739131, 0.47222222222222
71330, 1.5260869565217, 0.61956521739131, 0.44444444444444
71331, 1.5478260869565, 0.64565217391304, 0.44444444444444
71332, 1.5478260869565, 0.61956521739131, 0.41666666666667
71333, 1.5260869565217, 0.6195652173913, 0.38888888888889
71334, 1.5478260869565, 0.64565217391304, 0.38888888888889
71335, 1.5478260869565, 0.61956521739131, 0.36111111111111
71336, 1.5260869565217, 0.61956521739131, 0.33333333333333
71337, 1.5478260869565, 0.64565217391304, 0.33333333333333
71338, 1.5478260869565, 0.61956521739131, 0.30555555555556
71339, 1.5260869565217, 0.6195652173913, 0.27777777777778
71340, 1.5478260869565, 0.64565217391304, 0.27777777777778
71341, 1.5478260869565, 0.61956521739131, 0.25
71342, 1.5260869565217, 0.6195652173913, 0.22222222222222
71343, 1.5478260869565, 0.64565217391304, 0.22222222222222
71344, 1.5478260869565, 0.61956521739131, 0.19444444444444
71345, 1.5260869565217, 0.6195652173913, 0.16666666666667
71346, 1.5478260869565, 0.64565217391304, 0.16666666666667
71347, 1.5478260869565, 0.61956521739131, 0.13888888888889
71348, 1.5260869565217, 0.6195652173913, 0.11111111111111
71349, 1.5478260869565, 0.64565217391304, 0.11111111111111
71350, 1.5478260869565, 0.61956521739131, 0.083333333333333
71351, 1.5260869565217, 0.6195652173913, 0.055555555555556
71352, 1.5478260869565, 0.64565217391304, 0.055555555555556
71353, 1.5478260869565, 0.61956521739131, 0.027777777777778
71354, 1.5913043478261, 0.61956521739131, 0.47222222222222
71355, 1.5695652173913, 0.61956521739131, 0.44444444444444
71356, 1.5913043478261, 0.64565217391304, 0.44444444444444
71357, 1.5913043478261, 0.61956521739131, 0.41666666666667
71358, 1.5695652173913, 0.61956521739131, 0.38888888888889
71359, 1.5913043478261, 0.64565217391304, 0.38888888888889
71360, 1.5913043478261, 0.61956521739131, 0.36111111111111
71361, 1.5695652173913, 0.61956521739131, 0.33333333333333
71362, 1.5913043478261, 0.64565217391304, 0.33333333333333
71363, 1.5913043478261, 0.6195652173913, 0.30555555555556
71364, 1.5695652173913, 0.6195652173913, 0.27777777777778
71365, 1.5913043478261, 0.64565217391304, 0.27777777777778
71366, 1.5913043478261, 0.6195652173913, 0.25
71367, 1.5695652173913, 0.61956521739131, 0.22222222222222
71368, 1.5913043478261, 0.64565217391304, 0.22222222222222
71369, 1.5913043478261, 0.6195652173913, 0.19444444444444
71370, 1.5695652173913, 0.6195652173913, 0.16666666666667
71371, 1.5913043478261, 0.64565217391304, 0.16666666666667
71372, 1.5913043478261, 0.6195652173913, 0.13888888888889
71373, 1.5695652173913, 0.61956521739131, 0.11111111111111
71374, 1.5913043478261, 0.64565217391304, 0.11111111111111
71375, 1.5913043478261, 0.6195652173913, 0.083333333333333
71376, 1.5695652173913, 0.61956521739131, 0.055555555555556
71377, 1.5913043478261, 0.64565217391304, 0.055555555555556
71378, 1.5913043478261, 0.61956521739131, 0.027777777777778
71379, 1.6347826086957, 0.61956521739131, 0.47222222222222
71380, 1.6130434782609, 0.61956521739131, 0.44444444444444
71381, 1.6347826086957, 0.64565217391304, 0.44444444444444
71382, 1.6347826086957, 0.61956521739131, 0.41666666666667
71383, 1.6130434782609, 0.61956521739131, 0.38888888888889
71384, 1.6347826086957, 0.64565217391304, 0.38888888888889
71385, 1.6347826086957, 0.61956521739131, 0.36111111111111
71386, 1.6130434782609, 0.61956521739131, 0.33333333333333
71387, 1.6347826086957, 0.64565217391304, 0.33333333333333
71388, 1.6347826086957, 0.61956521739131, 0.30555555555556
71389, 1.6130434782609, 0.6195652173913, 0.27777777777778
71390, 1.6347826086957, 0.64565217391304, 0.27777777777778
71391, 1.6347826086957, 0.61956521739131, 0.25
71392, 1.6130434782609, 0.61956521739131, 0.22222222222222
71393, 1.6347826086957, 0.64565217391304, 0.22222222222222
71394, 1.6347826086957, 0.61956521739131, 0.19444444444444
71395, 1.6130434782609, 0.6195652173913, 0.16666666666667
71396, 1.6347826086957, 0.64565217391304, 0.16666666666667
71397, 1.6347826086957, 0.61956521739131, 0.13888888888889
71398, 1.6130434782609, 0.61956521739131, 0.11111111111111
71399, 1.6347826086957, 0.64565217391304, 0.11111111111111
71400, 1.6347826086957, 0.61956521739131, 0.083333333333333
71401, 1.6130434782609, 0.61956521739131, 0.055555555555556
71402, 1.6347826086957, 0.64565217391304, 0.055555555555556
71403, 1.6347826086957, 0.61956521739131, 0.027777777777778
71404, 1.6782608695652, 0.61956521739131, 0.47222222222222
71405, 1.6565217391304, 0.61956521739131, 0.44444444444444
71406, 1.6782608695652, 0.64565217391304, 0.44444444444444
71407, 1.6782608695652, 0.61956521739131, 0.41666666666667
71408, 1.6565217391304, 0.61956521739131, 0.38888888888889
71409, 1.6782608695652, 0.64565217391304, 0.38888888888889
71410, 1.6782608695652, 0.61956521739131, 0.36111111111111
71411, 1.6565217391304, 0.61956521739131, 0.33333333333333
71412, 1.6782608695652, 0.64565217391304, 0.33333333333333
71413, 1.6782608695652, 0.61956521739131, 0.30555555555556
71414, 1.6565217391304, 0.61956521739131, 0.27777777777778
71415, 1.6782608695652, 0.64565217391304, 0.27777777777778
71416, 1.6782608695652, 0.61956521739131, 0.25
71417, 1.6565217391304, 0.61956521739131, 0.22222222222222
71418, 1.6782608695652, 0.64565217391304, 0.22222222222222
71419, 1.6782608695652, 0.61956521739131, 0.19444444444444
71420, 1.6565217391304, 0.61956521739131, 0.16666666666667
71421, 1.6782608695652, 0.64565217391304, 0.16666666666667
71422, 1.6782608695652, 0.61956521739131, 0.13888888888889
71423, 1.6565217391304, 0.61956521739131, 0.11111111111111
71424, 1.6782608695652, 0.64565217391304, 0.11111111111111
71425, 1.6782608695652, 0.61956521739131, 0.083333333333333
71426, 1.6565217391304, 0.61956521739131, 0.055555555555556
71427, 1.6782608695652, 0.64565217391304, 0.055555555555556
71428, 1.6782608695652, 0.61956521739131, 0.027777777777778
71429, 1.7217391304348, 0.61956521739131, 0.47222222222222
71430, 1.7, 0.61956521739131, 0.44444444444444
71431, 1.7217391304348, 0.64565217391304, 0.44444444444444
71432, 1.7217391304348, 0.61956521739131, 0.41666666666667
71433, 1.7, 0.61956521739131, 0.38888888888889
71434, 1.7217391304348, 0.64565217391304, 0.38888888888889
71435, 1.7217391304348, 0.61956521739131, 0.36111111111111
71436, 1.7, 0.61956521739131, 0.33333333333333
71437, 1.7217391304348, 0.64565217391304, 0.33333333333333
71438, 1.7217391304348, 0.61956521739131, 0.30555555555556
71439, 1.7, 0.6195652173913, 0.27777777777778
71440, 1.7217391304348, 0.64565217391304, 0.27777777777778
71441, 1.7217391304348, 0.61956521739131, 0.25
71442, 1.7, 0.61956521739131, 0.22222222222222
71443, 1.7217391304348, 0.64565217391304, 0.22222222222222
71444, 1.7217391304348, 0.61956521739131, 0.19444444444444
71445, 1.7, 0.61956521739131, 0.16666666666667
71446, 1.7217391304348, 0.64565217391304, 0.16666666666667
71447, 1.7217391304348, 0.61956521739131, 0.13888888888889
71448, 1.7, 0.61956521739131, 0.11111111111111
71449, 1.7217391304348, 0.64565217391304, 0.11111111111111
71450, 1.7217391304348, 0.61956521739131, 0.083333333333333
71451, 1.7, 0.61956521739131, 0.055555555555556
71452, 1.7217391304348, 0.64565217391304, 0.055555555555556
71453, 1.7217391304348, 0.61956521739131, 0.027777777777778
71454, 1.7652173913043, 0.61956521739131, 0.47222222222222
71455, 1.7434782608696, 0.61956521739131, 0.44444444444444
71456, 1.7652173913043, 0.64565217391304, 0.44444444444444
71457, 1.7652173913043, 0.61956521739131, 0.41666666666667
71458, 1.7434782608696, 0.61956521739131, 0.38888888888889
71459, 1.7652173913043, 0.64565217391304, 0.38888888888889
71460, 1.7652173913043, 0.61956521739131, 0.36111111111111
71461, 1.7434782608696, 0.61956521739131, 0.33333333333333
71462, 1.7652173913043, 0.64565217391304, 0.33333333333333
71463, 1.7652173913043, 0.61956521739131, 0.30555555555556
71464, 1.7434782608696, 0.61956521739131, 0.27777777777778
71465, 1.7652173913043, 0.64565217391304, 0.27777777777778
71466, 1.7652173913043, 0.61956521739131, 0.25
71467, 1.7434782608696, 0.61956521739131, 0.22222222222222
71468, 1.7652173913043, 0.64565217391304, 0.22222222222222
71469, 1.7652173913043, 0.61956521739131, 0.19444444444444
71470, 1.7434782608696, 0.61956521739131, 0.16666666666667
71471, 1.7652173913043, 0.64565217391304, 0.16666666666667
71472, 1.7652173913043, 0.61956521739131, 0.13888888888889
71473, 1.7434782608696, 0.61956521739131, 0.11111111111111
71474, 1.7652173913043, 0.64565217391304, 0.11111111111111
71475, 1.7652173913043, 0.61956521739131, 0.083333333333333
71476, 1.7434782608696, 0.61956521739131, 0.055555555555556
71477, 1.7652173913043, 0.64565217391304, 0.055555555555556
71478, 1.7652173913043, 0.61956521739131, 0.027777777777778
71479, 1.8086956521739, 0.61956521739131, 0.47222222222222
71480, 1.7869565217391, 0.61956521739131, 0.44444444444444
71481, 1.8086956521739, 0.64565217391304, 0.44444444444444
71482, 1.8086956521739, 0.61956521739131, 0.41666666666667
71483, 1.7869565217391, 0.61956521739131, 0.38888888888889
71484, 1.8086956521739, 0.64565217391304, 0.38888888888889
71485, 1.8086956521739, 0.61956521739131, 0.36111111111111
71486, 1.7869565217391, 0.61956521739131, 0.33333333333333
71487, 1.8086956521739, 0.64565217391304, 0.33333333333333
71488, 1.8086956521739, 0.61956521739131, 0.30555555555556
71489, 1.7869565217391, 0.61956521739131, 0.27777777777778
71490, 1.8086956521739, 0.64565217391304, 0.27777777777778
71491, 1.8086956521739, 0.61956521739131, 0.25
71492, 1.7869565217391, 0.61956521739131, 0.22222222222222
71493, 1.8086956521739, 0.64565217391304, 0.22222222222222
71494, 1.8086956521739, 0.61956521739131, 0.19444444444444
71495, 1.7869565217391, 0.6195652173913, 0.16666666666667
71496, 1.8086956521739, 0.64565217391304, 0.16666666666667
71497, 1.8086956521739, 0.61956521739131, 0.13888888888889
71498, 1.7869565217391, 0.61956521739131, 0.11111111111111
71499, 1.8086956521739, 0.64565217391304, 0.11111111111111
71500, 1.8086956521739, 0.61956521739131, 0.083333333333333
71501, 1.7869565217391, 0.61956521739131, 0.055555555555556
71502, 1.8086956521739, 0.64565217391304, 0.055555555555556
71503, 1.8086956521739, 0.61956521739131, 0.027777777777778
71504, 1.8521739130435, 0.61956521739131, 0.47222222222222
71505, 1.8304347826087, 0.61956521739131, 0.44444444444444
71506, 1.8521739130435, 0.64565217391304, 0.44444444444444
71507, 1.8521739130435, 0.61956521739131, 0.41666666666667
71508, 1.8304347826087, 0.61956521739131, 0.38888888888889
71509, 1.8521739130435, 0.64565217391304, 0.38888888888889
71510, 1.8521739130435, 0.61956521739131, 0.36111111111111
71511, 1.8304347826087, 0.61956521739131, 0.33333333333333
71512, 1.8521739130435, 0.64565217391304, 0.33333333333333
71513, 1.8521739130435, 0.61956521739131, 0.30555555555556
71514, 1.8304347826087, 0.61956521739131, 0.27777777777778
71515, 1.8521739130435, 0.64565217391304, 0.27777777777778
71516, 1.8521739130435, 0.61956521739131, 0.25
71517, 1.8304347826087, 0.61956521739131, 0.22222222222222
71518, 1.8521739130435, 0.64565217391304, 0.22222222222222
71519, 1.8521739130435, 0.61956521739131, 0.19444444444444
71520, 1.8304347826087, 0.6195652173913, 0.16666666666667
71521, 1.8521739130435, 0.64565217391304, 0.16666666666667
71522, 1.8521739130435, 0.61956521739131, 0.13888888888889
71523, 1.8304347826087, 0.61956521739131, 0.11111111111111
71524, 1.8521739130435, 0.64565217391304, 0.11111111111111
71525, 1.8521739130435, 0.61956521739131, 0.083333333333333
71526, 1.8304347826087, 0.61956521739131, 0.055555555555556
71527, 1.8521739130435, 0.64565217391304, 0.055555555555556
71528, 1.8521739130435, 0.61956521739131, 0.027777777777778
71529, 1.895652173913, 0.61956521739131, 0.47222222222222
71530, 1.8739130434783, 0.61956521739131, 0.44444444444444
71531, 1.895652173913, 0.64565217391304, 0.44444444444444
71532, 1.895652173913, 0.61956521739131, 0.41666666666667
71533, 1.8739130434783, 0.61956521739131, 0.38888888888889
71534, 1.895652173913, 0.64565217391304, 0.38888888888889
71535, 1.895652173913, 0.61956521739131, 0.36111111111111
71536, 1.8739130434783, 0.61956521739131, 0.33333333333333
71537, 1.895652173913, 0.64565217391304, 0.33333333333333
71538, 1.895652173913, 0.61956521739131, 0.30555555555556
71539, 1.8739130434783, 0.61956521739131, 0.27777777777778
71540, 1.895652173913, 0.64565217391304, 0.27777777777778
71541, 1.895652173913, 0.61956521739131, 0.25
71542, 1.8739130434783, 0.61956521739131, 0.22222222222222
71543, 1.895652173913, 0.64565217391304, 0.22222222222222
71544, 1.895652173913, 0.61956521739131, 0.19444444444444
71545, 1.8739130434783, 0.61956521739131, 0.16666666666667
71546, 1.895652173913, 0.64565217391304, 0.16666666666667
71547, 1.895652173913, 0.61956521739131, 0.13888888888889
71548, 1.8739130434783, 0.61956521739131, 0.11111111111111
71549, 1.895652173913, 0.64565217391304, 0.11111111111111
71550, 1.895652173913, 0.61956521739131, 0.083333333333333
71551, 1.8739130434783, 0.61956521739131, 0.055555555555556
71552, 1.895652173913, 0.64565217391304, 0.055555555555556
71553, 1.895652173913, 0.61956521739131, 0.027777777777778
71554, 1.9391304347826, 0.61956521739131, 0.47222222222222
71555, 1.9173913043478, 0.61956521739131, 0.44444444444444
71556, 1.9391304347826, 0.64565217391304, 0.44444444444444
71557, 1.9391304347826, 0.61956521739131, 0.41666666666667
71558, 1.9173913043478, 0.61956521739131, 0.38888888888889
71559, 1.9391304347826, 0.64565217391304, 0.38888888888889
71560, 1.9391304347826, 0.61956521739131, 0.36111111111111
71561, 1.9173913043478, 0.61956521739131, 0.33333333333333
71562, 1.9391304347826, 0.64565217391304, 0.33333333333333
71563, 1.9391304347826, 0.61956521739131, 0.30555555555556
71564, 1.9173913043478, 0.61956521739131, 0.27777777777778
71565, 1.9391304347826, 0.64565217391304, 0.27777777777778
71566, 1.9391304347826, 0.61956521739131, 0.25
71567, 1.9173913043478, 0.61956521739131, 0.22222222222222
71568, 1.9391304347826, 0.64565217391304, 0.22222222222222
71569, 1.9391304347826, 0.61956521739131, 0.19444444444444
71570, 1.9173913043478, 0.61956521739131, 0.16666666666667
71571, 1.9391304347826, 0.64565217391304, 0.16666666666667
71572, 1.9391304347826, 0.61956521739131, 0.13888888888889
71573, 1.9173913043478, 0.61956521739131, 0.11111111111111
71574, 1.9391304347826, 0.64565217391304, 0.11111111111111
71575, 1.9391304347826, 0.61956521739131, 0.083333333333333
71576, 1.9173913043478, 0.61956521739131, 0.055555555555556
71577, 1.9391304347826, 0.64565217391304, 0.055555555555556
71578, 1.9391304347826, 0.61956521739131, 0.027777777777778
71579, 1.9826086956522, 0.61956521739131, 0.47222222222222
71580, 1.9608695652174, 0.61956521739131, 0.44444444444444
71581, 1.9826086956522, 0.64565217391304, 0.44444444444444
71582, 1.9826086956522, 0.61956521739131, 0.41666666666667
71583, 1.9608695652174, 0.61956521739131, 0.38888888888889
71584, 1.9826086956522, 0.64565217391304, 0.38888888888889
71585, 1.9826086956522, 0.61956521739131, 0.36111111111111
71586, 1.9608695652174, 0.61956521739131, 0.33333333333333
71587, 1.9826086956522, 0.64565217391304, 0.33333333333333
71588, 1.9826086956522, 0.61956521739131, 0.30555555555556
71589, 1.9608695652174, 0.61956521739131, 0.27777777777778
71590, 1.9826086956522, 0.64565217391304, 0.27777777777778
71591, 1.9826086956522, 0.61956521739131, 0.25
71592, 1.9608695652174, 0.61956521739131, 0.22222222222222
71593, 1.9826086956522, 0.64565217391304, 0.22222222222222
71594, 1.9826086956522, 0.61956521739131, 0.19444444444444
71595, 1.9608695652174, 0.61956521739131, 0.16666666666667
71596, 1.9826086956522, 0.64565217391304, 0.16666666666667
71597, 1.9826086956522, 0.61956521739131, 0.13888888888889
71598, 1.9608695652174, 0.61956521739131, 0.11111111111111
71599, 1.9826086956522, 0.64565217391304, 0.11111111111111
71600, 1.9826086956522, 0.61956521739131, 0.083333333333333
71601, 1.9608695652174, 0.61956521739131, 0.055555555555556
71602, 1.9826086956522, 0.64565217391304, 0.055555555555556
71603, 1.9826086956522, 0.61956521739131, 0.027777777777778
71604, 2.0260869565217, 0.61956521739131, 0.47222222222222
71605, 2.004347826087, 0.61956521739131, 0.44444444444444
71606, 2.0260869565217, 0.64565217391304, 0.44444444444444
71607, 2.0260869565217, 0.61956521739131, 0.41666666666667
71608, 2.004347826087, 0.61956521739131, 0.38888888888889
71609, 2.0260869565217, 0.64565217391304, 0.38888888888889
71610, 2.0260869565217, 0.61956521739131, 0.36111111111111
71611, 2.004347826087, 0.61956521739131, 0.33333333333333
71612, 2.0260869565217, 0.64565217391304, 0.33333333333333
71613, 2.0260869565217, 0.6195652173913, 0.30555555555556
71614, 2.004347826087, 0.61956521739131, 0.27777777777778
71615, 2.0260869565217, 0.64565217391304, 0.27777777777778
71616, 2.0260869565217, 0.61956521739131, 0.25
71617, 2.004347826087, 0.61956521739131, 0.22222222222222
71618, 2.0260869565217, 0.64565217391304, 0.22222222222222
71619, 2.0260869565217, 0.6195652173913, 0.19444444444444
71620, 2.004347826087, 0.6195652173913, 0.16666666666667
71621, 2.0260869565217, 0.64565217391304, 0.16666666666667
71622, 2.0260869565217, 0.6195652173913, 0.13888888888889
71623, 2.004347826087, 0.61956521739131, 0.11111111111111
71624, 2.0260869565217, 0.64565217391304, 0.11111111111111
71625, 2.0260869565217, 0.61956521739131, 0.083333333333333
71626, 2.004347826087, 0.61956521739131, 0.055555555555556
71627, 2.0260869565217, 0.64565217391304, 0.055555555555556
71628, 2.0260869565217, 0.61956521739131, 0.027777777777778
71629, 2.0695652173913, 0.61956521739131, 0.47222222222222
71630, 2.0478260869565, 0.61956521739131, 0.44444444444444
71631, 2.0695652173913, 0.64565217391304, 0.44444444444444
71632, 2.0695652173913, 0.61956521739131, 0.41666666666667
71633, 2.0478260869565, 0.61956521739131, 0.38888888888889
71634, 2.0695652173913, 0.64565217391304, 0.38888888888889
71635, 2.0695652173913, 0.61956521739131, 0.36111111111111
71636, 2.0478260869565, 0.61956521739131, 0.33333333333333
71637, 2.0695652173913, 0.64565217391304, 0.33333333333333
71638, 2.0695652173913, 0.61956521739131, 0.30555555555556
71639, 2.0478260869565, 0.6195652173913, 0.27777777777778
71640, 2.0695652173913, 0.64565217391304, 0.27777777777778
71641, 2.0695652173913, 0.61956521739131, 0.25
71642, 2.0478260869565, 0.61956521739131, 0.22222222222222
71643, 2.0695652173913, 0.64565217391304, 0.22222222222222
71644, 2.0695652173913, 0.61956521739131, 0.19444444444444
71645, 2.0478260869565, 0.6195652173913, 0.16666666666667
71646, 2.0695652173913, 0.64565217391304, 0.16666666666667
71647, 2.0695652173913, 0.61956521739131, 0.13888888888889
71648, 2.0478260869565, 0.61956521739131, 0.11111111111111
71649, 2.0695652173913, 0.64565217391304, 0.11111111111111
71650, 2.0695652173913, 0.61956521739131, 0.083333333333333
71651, 2.0478260869565, 0.61956521739131, 0.055555555555556
71652, 2.0695652173913, 0.64565217391304, 0.055555555555556
71653, 2.0695652173913, 0.61956521739131, 0.027777777777778
71654, 2.1130434782609, 0.61956521739131, 0.47222222222222
71655, 2.0913043478261, 0.61956521739131, 0.44444444444444
71656, 2.1130434782609, 0.64565217391304, 0.44444444444444
71657, 2.1130434782609, 0.61956521739131, 0.41666666666667
71658, 2.0913043478261, 0.61956521739131, 0.38888888888889
71659, 2.1130434782609, 0.64565217391304, 0.38888888888889
71660, 2.1130434782609, 0.61956521739131, 0.36111111111111
71661, 2.0913043478261, 0.61956521739131, 0.33333333333333
71662, 2.1130434782609, 0.64565217391304, 0.33333333333333
71663, 2.1130434782609, 0.61956521739131, 0.30555555555556
71664, 2.0913043478261, 0.61956521739131, 0.27777777777778
71665, 2.1130434782609, 0.64565217391304, 0.27777777777778
71666, 2.1130434782609, 0.61956521739131, 0.25
71667, 2.0913043478261, 0.61956521739131, 0.22222222222222
71668, 2.1130434782609, 0.64565217391304, 0.22222222222222
71669, 2.1130434782609, 0.61956521739131, 0.19444444444444
71670, 2.0913043478261, 0.6195652173913, 0.16666666666667
71671, 2.1130434782609, 0.64565217391304, 0.16666666666667
71672, 2.1130434782609, 0.61956521739131, 0.13888888888889
71673, 2.0913043478261, 0.61956521739131, 0.11111111111111
71674, 2.1130434782609, 0.64565217391304, 0.11111111111111
71675, 2.1130434782609, 0.61956521739131, 0.083333333333333
71676, 2.0913043478261, 0.61956521739131, 0.055555555555556
71677, 2.1130434782609, 0.64565217391304, 0.055555555555556
71678, 2.1130434782609, 0.61956521739131, 0.027777777777778
71679, 2.1565217391304, 0.61956521739131, 0.47222222222222
71680, 2.1347826086957, 0.61956521739131, 0.44444444444444
71681, 2.1565217391304, 0.64565217391304, 0.44444444444444
71682, 2.1565217391304, 0.61956521739131, 0.41666666666667
71683, 2.1347826086957, 0.61956521739131, 0.38888888888889
71684, 2.1565217391304, 0.64565217391304, 0.38888888888889
71685, 2.1565217391304, 0.61956521739131, 0.36111111111111
71686, 2.1347826086957, 0.61956521739131, 0.33333333333333
71687, 2.1565217391304, 0.64565217391304, 0.33333333333333
71688, 2.1565217391304, 0.61956521739131, 0.30555555555556
71689, 2.1347826086957, 0.61956521739131, 0.27777777777778
71690, 2.1565217391304, 0.64565217391304, 0.27777777777778
71691, 2.1565217391304, 0.61956521739131, 0.25
71692, 2.1347826086957, 0.61956521739131, 0.22222222222222
71693, 2.1565217391304, 0.64565217391304, 0.22222222222222
71694, 2.1565217391304, 0.61956521739131, 0.19444444444444
71695, 2.1347826086957, 0.61956521739131, 0.16666666666667
71696, 2.1565217391304, 0.64565217391304, 0.16666666666667
71697, 2.1565217391304, 0.61956521739131, 0.13888888888889
71698, 2.1347826086957, 0.61956521739131, 0.11111111111111
71699, 2.1565217391304, 0.64565217391304, 0.11111111111111
71700, 2.1565217391304, 0.61956521739131, 0.083333333333333
71701, 2.1347826086957, 0.61956521739131, 0.055555555555556
71702, 2.1565217391304, 0.64565217391304, 0.055555555555556
71703, 2.1565217391304, 0.61956521739131, 0.027777777777778
71704, 2.1782608695652, 0.61956521739131, 0.44444444444444
71705, 2.1782608695652, 0.61956521739131, 0.38888888888889
71706, 2.1782608695652, 0.61956521739131, 0.33333333333333
71707, 2.1782608695652, 0.61956521739131, 0.27777777777778
71708, 2.1782608695652, 0.61956521739131, 0.22222222222222
71709, 2.1782608695652, 0.61956521739131, 0.16666666666667
71710, 2.1782608695652, 0.61956521739131, 0.11111111111111
71711, 2.1782608695652, 0.61956521739131, 0.055555555555556
71712, 1.2434782608696, 0.56739130434783, 0.47222222222222
71713, 1.2217391304348, 0.56739130434783, 0.44444444444444
71714, 1.2434782608696, 0.59347826086957, 0.44444444444444
71715, 1.2434782608696, 0.56739130434783, 0.41666666666667
71716, 1.2217391304348, 0.56739130434783, 0.38888888888889
71717, 1.2434782608696, 0.59347826086957, 0.38888888888889
71718, 1.2434782608696, 0.56739130434783, 0.36111111111111
71719, 1.2217391304348, 0.56739130434783, 0.33333333333333
71720, 1.2434782608696, 0.59347826086957, 0.33333333333333
71721, 1.2434782608696, 0.56739130434783, 0.30555555555556
71722, 1.2217391304348, 0.56739130434783, 0.27777777777778
71723, 1.2434782608696, 0.59347826086957, 0.27777777777778
71724, 1.2434782608696, 0.56739130434783, 0.25
71725, 1.2217391304348, 0.56739130434783, 0.22222222222222
71726, 1.2434782608696, 0.59347826086957, 0.22222222222222
71727, 1.2434782608696, 0.56739130434783, 0.19444444444444
71728, 1.2217391304348, 0.56739130434783, 0.16666666666667
71729, 1.2434782608696, 0.59347826086957, 0.16666666666667
71730, 1.2434782608696, 0.56739130434783, 0.13888888888889
71731, 1.2217391304348, 0.56739130434783, 0.11111111111111
71732, 1.2434782608696, 0.59347826086957, 0.11111111111111
71733, 1.2434782608696, 0.56739130434783, 0.083333333333333
71734, 1.2217391304348, 0.56739130434783, 0.055555555555556
71735, 1.2434782608696, 0.59347826086957, 0.055555555555556
71736, 1.2434782608696, 0.56739130434783, 0.027777777777778
71737, 1.2869565217391, 0.56739130434783, 0.47222222222222
71738, 1.2652173913043, 0.56739130434783, 0.44444444444444
71739, 1.2869565217391, 0.59347826086957, 0.44444444444444
71740, 1.2869565217391, 0.56739130434783, 0.41666666666667
71741, 1.2652173913043, 0.56739130434783, 0.38888888888889
71742, 1.2869565217391, 0.59347826086957, 0.38888888888889
71743, 1.2869565217391, 0.56739130434783, 0.36111111111111
71744, 1.2652173913043, 0.56739130434783, 0.33333333333333
71745, 1.2869565217391, 0.59347826086957, 0.33333333333333
71746, 1.2869565217391, 0.56739130434783, 0.30555555555556
71747, 1.2652173913043, 0.56739130434783, 0.27777777777778
71748, 1.2869565217391, 0.59347826086957, 0.27777777777778
71749, 1.2869565217391, 0.56739130434783, 0.25
71750, 1.2652173913043, 0.56739130434783, 0.22222222222222
71751, 1.2869565217391, 0.59347826086957, 0.22222222222222
71752, 1.2869565217391, 0.56739130434783, 0.19444444444444
71753, 1.2652173913043, 0.56739130434783, 0.16666666666667
71754, 1.2869565217391, 0.59347826086957, 0.16666666666667
71755, 1.2869565217391, 0.56739130434783, 0.13888888888889
71756, 1.2652173913043, 0.56739130434783, 0.11111111111111
71757, 1.2869565217391, 0.59347826086957, 0.11111111111111
71758, 1.2869565217391, 0.56739130434783, 0.083333333333333
71759, 1.2652173913043, 0.56739130434783, 0.055555555555556
71760, 1.2869565217391, 0.59347826086957, 0.055555555555556
71761, 1.2869565217391, 0.56739130434783, 0.027777777777778
71762, 1.3304347826087, 0.56739130434783, 0.47222222222222
71763, 1.3086956521739, 0.56739130434783, 0.44444444444444
71764, 1.3304347826087, 0.59347826086957, 0.44444444444444
71765, 1.3304347826087, 0.56739130434783, 0.41666666666667
71766, 1.3086956521739, 0.56739130434783, 0.38888888888889
71767, 1.3304347826087, 0.59347826086957, 0.38888888888889
71768, 1.3304347826087, 0.56739130434783, 0.36111111111111
71769, 1.3086956521739, 0.56739130434783, 0.33333333333333
71770, 1.3304347826087, 0.59347826086957, 0.33333333333333
71771, 1.3304347826087, 0.56739130434783, 0.30555555555556
71772, 1.3086956521739, 0.56739130434783, 0.27777777777778
71773, 1.3304347826087, 0.59347826086957, 0.27777777777778
71774, 1.3304347826087, 0.56739130434783, 0.25
71775, 1.3086956521739, 0.56739130434783, 0.22222222222222
71776, 1.3304347826087, 0.59347826086957, 0.22222222222222
71777, 1.3304347826087, 0.56739130434783, 0.19444444444444
71778, 1.3086956521739, 0.56739130434783, 0.16666666666667
71779, 1.3304347826087, 0.59347826086957, 0.16666666666667
71780, 1.3304347826087, 0.56739130434783, 0.13888888888889
71781, 1.3086956521739, 0.56739130434783, 0.11111111111111
71782, 1.3304347826087, 0.59347826086957, 0.11111111111111
71783, 1.3304347826087, 0.56739130434783, 0.083333333333333
71784, 1.3086956521739, 0.56739130434783, 0.055555555555556
71785, 1.3304347826087, 0.59347826086957, 0.055555555555556
71786, 1.3304347826087, 0.56739130434783, 0.027777777777778
71787, 1.3739130434783, 0.56739130434783, 0.47222222222222
71788, 1.3521739130435, 0.56739130434783, 0.44444444444444
71789, 1.3739130434783, 0.59347826086957, 0.44444444444444
71790, 1.3739130434783, 0.56739130434783, 0.41666666666667
71791, 1.3521739130435, 0.56739130434783, 0.38888888888889
71792, 1.3739130434783, 0.59347826086957, 0.38888888888889
71793, 1.3739130434783, 0.56739130434783, 0.36111111111111
71794, 1.3521739130435, 0.56739130434783, 0.33333333333333
71795, 1.3739130434783, 0.59347826086957, 0.33333333333333
71796, 1.3739130434783, 0.56739130434783, 0.30555555555556
71797, 1.3521739130435, 0.56739130434783, 0.27777777777778
71798, 1.3739130434783, 0.59347826086957, 0.27777777777778
71799, 1.3739130434783, 0.56739130434783, 0.25
71800, 1.3521739130435, 0.56739130434783, 0.22222222222222
71801, 1.3739130434783, 0.59347826086957, 0.22222222222222
71802, 1.3739130434783, 0.56739130434783, 0.19444444444444
71803, 1.3521739130435, 0.56739130434783, 0.16666666666667
71804, 1.3739130434783, 0.59347826086957, 0.16666666666667
71805, 1.3739130434783, 0.56739130434783, 0.13888888888889
71806, 1.3521739130435, 0.56739130434783, 0.11111111111111
71807, 1.3739130434783, 0.59347826086957, 0.11111111111111
71808, 1.3739130434783, 0.56739130434783, 0.083333333333333
71809, 1.3521739130435, 0.56739130434783, 0.055555555555556
71810, 1.3739130434783, 0.59347826086957, 0.055555555555556
71811, 1.3739130434783, 0.56739130434783, 0.027777777777778
71812, 1.4173913043478, 0.56739130434783, 0.47222222222222
71813, 1.395652173913, 0.56739130434783, 0.44444444444444
71814, 1.4173913043478, 0.59347826086957, 0.44444444444444
71815, 1.4173913043478, 0.56739130434783, 0.41666666666667
71816, 1.395652173913, 0.56739130434783, 0.38888888888889
71817, 1.4173913043478, 0.59347826086957, 0.38888888888889
71818, 1.4173913043478, 0.56739130434783, 0.36111111111111
71819, 1.395652173913, 0.56739130434783, 0.33333333333333
71820, 1.4173913043478, 0.59347826086957, 0.33333333333333
71821, 1.4173913043478, 0.56739130434783, 0.30555555555556
71822, 1.395652173913, 0.56739130434783, 0.27777777777778
71823, 1.4173913043478, 0.59347826086957, 0.27777777777778
71824, 1.4173913043478, 0.56739130434783, 0.25
71825, 1.395652173913, 0.56739130434783, 0.22222222222222
71826, 1.4173913043478, 0.59347826086957, 0.22222222222222
71827, 1.4173913043478, 0.56739130434783, 0.19444444444444
71828, 1.395652173913, 0.56739130434783, 0.16666666666667
71829, 1.4173913043478, 0.59347826086957, 0.16666666666667
71830, 1.4173913043478, 0.56739130434783, 0.13888888888889
71831, 1.395652173913, 0.56739130434783, 0.11111111111111
71832, 1.4173913043478, 0.59347826086957, 0.11111111111111
71833, 1.4173913043478, 0.56739130434783, 0.083333333333333
71834, 1.395652173913, 0.56739130434783, 0.055555555555556
71835, 1.4173913043478, 0.59347826086957, 0.055555555555556
71836, 1.4173913043478, 0.56739130434783, 0.027777777777778
71837, 1.4608695652174, 0.56739130434783, 0.47222222222222
71838, 1.4391304347826, 0.56739130434783, 0.44444444444444
71839, 1.4608695652174, 0.59347826086957, 0.44444444444444
71840, 1.4608695652174, 0.56739130434783, 0.41666666666667
71841, 1.4391304347826, 0.56739130434783, 0.38888888888889
71842, 1.4608695652174, 0.59347826086957, 0.38888888888889
71843, 1.4608695652174, 0.56739130434783, 0.36111111111111
71844, 1.4391304347826, 0.56739130434783, 0.33333333333333
71845, 1.4608695652174, 0.59347826086957, 0.33333333333333
71846, 1.4608695652174, 0.56739130434783, 0.30555555555556
71847, 1.4391304347826, 0.56739130434783, 0.27777777777778
71848, 1.4608695652174, 0.59347826086957, 0.27777777777778
71849, 1.4608695652174, 0.56739130434783, 0.25
71850, 1.4391304347826, 0.56739130434783, 0.22222222222222
71851, 1.4608695652174, 0.59347826086957, 0.22222222222222
71852, 1.4608695652174, 0.56739130434783, 0.19444444444444
71853, 1.4391304347826, 0.56739130434783, 0.16666666666667
71854, 1.4608695652174, 0.59347826086957, 0.16666666666667
71855, 1.4608695652174, 0.56739130434783, 0.13888888888889
71856, 1.4391304347826, 0.56739130434783, 0.11111111111111
71857, 1.4608695652174, 0.59347826086957, 0.11111111111111
71858, 1.4608695652174, 0.56739130434783, 0.083333333333333
71859, 1.4391304347826, 0.56739130434783, 0.055555555555556
71860, 1.4608695652174, 0.59347826086957, 0.055555555555556
71861, 1.4608695652174, 0.56739130434783, 0.027777777777778
71862, 1.504347826087, 0.56739130434783, 0.47222222222222
71863, 1.4826086956522, 0.56739130434783, 0.44444444444444
71864, 1.504347826087, 0.59347826086957, 0.44444444444444
71865, 1.504347826087, 0.56739130434783, 0.41666666666667
71866, 1.4826086956522, 0.56739130434783, 0.38888888888889
71867, 1.504347826087, 0.59347826086957, 0.38888888888889
71868, 1.504347826087, 0.56739130434783, 0.36111111111111
71869, 1.4826086956522, 0.56739130434783, 0.33333333333333
71870, 1.504347826087, 0.59347826086957, 0.33333333333333
71871, 1.504347826087, 0.56739130434783, 0.30555555555556
71872, 1.4826086956522, 0.56739130434783, 0.27777777777778
71873, 1.504347826087, 0.59347826086957, 0.27777777777778
71874, 1.504347826087, 0.56739130434783, 0.25
71875, 1.4826086956522, 0.56739130434783, 0.22222222222222
71876, 1.504347826087, 0.59347826086957, 0.22222222222222
71877, 1.504347826087, 0.56739130434783, 0.19444444444444
71878, 1.4826086956522, 0.56739130434783, 0.16666666666667
71879, 1.504347826087, 0.59347826086957, 0.16666666666667
71880, 1.504347826087, 0.56739130434783, 0.13888888888889
71881, 1.4826086956522, 0.56739130434783, 0.11111111111111
71882, 1.504347826087, 0.59347826086957, 0.11111111111111
71883, 1.504347826087, 0.56739130434783, 0.083333333333333
71884, 1.4826086956522, 0.56739130434783, 0.055555555555556
71885, 1.504347826087, 0.59347826086957, 0.055555555555556
71886, 1.504347826087, 0.56739130434783, 0.027777777777778
71887, 1.5478260869565, 0.56739130434783, 0.47222222222222
71888, 1.5260869565217, 0.56739130434783, 0.44444444444444
71889, 1.5478260869565, 0.59347826086957, 0.44444444444444
71890, 1.5478260869565, 0.56739130434783, 0.41666666666667
71891, 1.5260869565217, 0.56739130434783, 0.38888888888889
71892, 1.5478260869565, 0.59347826086957, 0.38888888888889
71893, 1.5478260869565, 0.56739130434783, 0.36111111111111
71894, 1.5260869565217, 0.56739130434783, 0.33333333333333
71895, 1.5478260869565, 0.59347826086957, 0.33333333333333
71896, 1.5478260869565, 0.56739130434783, 0.30555555555556
71897, 1.5260869565217, 0.56739130434783, 0.27777777777778
71898, 1.5478260869565, 0.59347826086957, 0.27777777777778
71899, 1.5478260869565, 0.56739130434783, 0.25
71900, 1.5260869565217, 0.56739130434783, 0.22222222222222
71901, 1.5478260869565, 0.59347826086957, 0.22222222222222
71902, 1.5478260869565, 0.56739130434783, 0.19444444444444
71903, 1.5260869565217, 0.56739130434783, 0.16666666666667
71904, 1.5478260869565, 0.59347826086957, 0.16666666666667
71905, 1.5478260869565, 0.56739130434783, 0.13888888888889
71906, 1.5260869565217, 0.56739130434783, 0.11111111111111
71907, 1.5478260869565, 0.59347826086957, 0.11111111111111
71908, 1.5478260869565, 0.56739130434783, 0.083333333333333
71909, 1.5260869565217, 0.56739130434783, 0.055555555555556
71910, 1.5478260869565, 0.59347826086957, 0.055555555555556
71911, 1.5478260869565, 0.56739130434783, 0.027777777777778
71912, 1.5913043478261, 0.56739130434783, 0.47222222222222
71913, 1.5695652173913, 0.56739130434783, 0.44444444444444
71914, 1.5913043478261, 0.59347826086957, 0.44444444444444
71915, 1.5913043478261, 0.56739130434783, 0.41666666666667
71916, 1.5695652173913, 0.56739130434783, 0.38888888888889
71917, 1.5913043478261, 0.59347826086957, 0.38888888888889
71918, 1.5913043478261, 0.56739130434783, 0.36111111111111
71919, 1.5695652173913, 0.56739130434783, 0.33333333333333
71920, 1.5913043478261, 0.59347826086957, 0.33333333333333
71921, 1.5913043478261, 0.56739130434783, 0.30555555555556
71922, 1.5695652173913, 0.56739130434783, 0.27777777777778
71923, 1.5913043478261, 0.59347826086957, 0.27777777777778
71924, 1.5913043478261, 0.56739130434783, 0.25
71925, 1.5695652173913, 0.56739130434783, 0.22222222222222
71926, 1.5913043478261, 0.59347826086957, 0.22222222222222
71927, 1.5913043478261, 0.56739130434783, 0.19444444444444
71928, 1.5695652173913, 0.56739130434783, 0.16666666666667
71929, 1.5913043478261, 0.59347826086957, 0.16666666666667
71930, 1.5913043478261, 0.56739130434783, 0.13888888888889
71931, 1.5695652173913, 0.56739130434783, 0.11111111111111
71932, 1.5913043478261, 0.59347826086957, 0.11111111111111
71933, 1.5913043478261, 0.56739130434783, 0.083333333333333
71934, 1.5695652173913, 0.56739130434783, 0.055555555555556
71935, 1.5913043478261, 0.59347826086957, 0.055555555555556
71936, 1.5913043478261, 0.56739130434783, 0.027777777777778
71937, 1.6347826086957, 0.56739130434783, 0.47222222222222
71938, 1.6130434782609, 0.56739130434783, 0.44444444444444
71939, 1.6347826086957, 0.59347826086957, 0.44444444444444
71940, 1.6347826086957, 0.56739130434783, 0.41666666666667
71941, 1.6130434782609, 0.56739130434783, 0.38888888888889
71942, 1.6347826086957, 0.59347826086957, 0.38888888888889
71943, 1.6347826086957, 0.56739130434783, 0.36111111111111
71944, 1.6130434782609, 0.56739130434783, 0.33333333333333
71945, 1.6347826086957, 0.59347826086957, 0.33333333333333
71946, 1.6347826086957, 0.56739130434783, 0.30555555555556
71947, 1.6130434782609, 0.56739130434783, 0.27777777777778
71948, 1.6347826086957, 0.59347826086957, 0.27777777777778
71949, 1.6347826086957, 0.56739130434783, 0.25
71950, 1.6130434782609, 0.56739130434783, 0.22222222222222
71951, 1.6347826086957, 0.59347826086957, 0.22222222222222
71952, 1.6347826086957, 0.56739130434783, 0.19444444444444
71953, 1.6130434782609, 0.56739130434783, 0.16666666666667
71954, 1.6347826086957, 0.59347826086957, 0.16666666666667
71955, 1.6347826086957, 0.56739130434783, 0.13888888888889
71956, 1.6130434782609, 0.56739130434783, 0.11111111111111
71957, 1.6347826086957, 0.59347826086957, 0.11111111111111
71958, 1.6347826086957, 0.56739130434783, 0.083333333333333
71959, 1.6130434782609, 0.56739130434783, 0.055555555555556
71960, 1.6347826086957, 0.59347826086957, 0.055555555555556
71961, 1.6347826086957, 0.56739130434783, 0.027777777777778
71962, 1.6782608695652, 0.56739130434783, 0.47222222222222
71963, 1.6565217391304, 0.56739130434783, 0.44444444444444
71964, 1.6782608695652, 0.59347826086957, 0.44444444444444
71965, 1.6782608695652, 0.56739130434783, 0.41666666666667
71966, 1.6565217391304, 0.56739130434783, 0.38888888888889
71967, 1.6782608695652, 0.59347826086957, 0.38888888888889
71968, 1.6782608695652, 0.56739130434783, 0.36111111111111
71969, 1.6565217391304, 0.56739130434783, 0.33333333333333
71970, 1.6782608695652, 0.59347826086957, 0.33333333333333
71971, 1.6782608695652, 0.56739130434783, 0.30555555555556
71972, 1.6565217391304, 0.56739130434783, 0.27777777777778
71973, 1.6782608695652, 0.59347826086957, 0.27777777777778
71974, 1.6782608695652, 0.56739130434783, 0.25
71975, 1.6565217391304, 0.56739130434783, 0.22222222222222
71976, 1.6782608695652, 0.59347826086957, 0.22222222222222
71977, 1.6782608695652, 0.56739130434783, 0.19444444444444
71978, 1.6565217391304, 0.56739130434783, 0.16666666666667
71979, 1.6782608695652, 0.59347826086957, 0.16666666666667
71980, 1.6782608695652, 0.56739130434783, 0.13888888888889
71981, 1.6565217391304, 0.56739130434783, 0.11111111111111
71982, 1.6782608695652, 0.59347826086957, 0.11111111111111
71983, 1.6782608695652, 0.56739130434783, 0.083333333333333
71984, 1.6565217391304, 0.56739130434783, 0.055555555555556
71985, 1.6782608695652, 0.59347826086957, 0.055555555555556
71986, 1.6782608695652, 0.56739130434783, 0.027777777777778
71987, 1.7217391304348, 0.56739130434783, 0.47222222222222
71988, 1.7, 0.56739130434783, 0.44444444444444
71989, 1.7217391304348, 0.59347826086957, 0.44444444444444
71990, 1.7217391304348, 0.56739130434783, 0.41666666666667
71991, 1.7, 0.56739130434783, 0.38888888888889
71992, 1.7217391304348, 0.59347826086957, 0.38888888888889
71993, 1.7217391304348, 0.56739130434783, 0.36111111111111
71994, 1.7, 0.56739130434783, 0.33333333333333
71995, 1.7217391304348, 0.59347826086957, 0.33333333333333
71996, 1.7217391304348, 0.56739130434783, 0.30555555555556
71997, 1.7, 0.56739130434783, 0.27777777777778
71998, 1.7217391304348, 0.59347826086957, 0.27777777777778
71999, 1.7217391304348, 0.56739130434783, 0.25
72000, 1.7, 0.56739130434783, 0.22222222222222
72001, 1.7217391304348, 0.59347826086957, 0.22222222222222
72002, 1.7217391304348, 0.56739130434783, 0.19444444444444
72003, 1.7, 0.56739130434783, 0.16666666666667
72004, 1.7217391304348, 0.59347826086957, 0.16666666666667
72005, 1.7217391304348, 0.56739130434783, 0.13888888888889
72006, 1.7, 0.56739130434783, 0.11111111111111
72007, 1.7217391304348, 0.59347826086957, 0.11111111111111
72008, 1.7217391304348, 0.56739130434783, 0.083333333333333
72009, 1.7, 0.56739130434783, 0.055555555555556
72010, 1.7217391304348, 0.59347826086957, 0.055555555555556
72011, 1.7217391304348, 0.56739130434783, 0.027777777777778
72012, 1.7652173913043, 0.56739130434783, 0.47222222222222
72013, 1.7434782608696, 0.56739130434783, 0.44444444444444
72014, 1.7652173913043, 0.59347826086957, 0.44444444444444
72015, 1.7652173913043, 0.56739130434783, 0.41666666666667
72016, 1.7434782608696, 0.56739130434783, 0.38888888888889
72017, 1.7652173913043, 0.59347826086957, 0.38888888888889
72018, 1.7652173913043, 0.56739130434783, 0.36111111111111
72019, 1.7434782608696, 0.56739130434783, 0.33333333333333
72020, 1.7652173913043, 0.59347826086957, 0.33333333333333
72021, 1.7652173913043, 0.56739130434783, 0.30555555555556
72022, 1.7434782608696, 0.56739130434783, 0.27777777777778
72023, 1.7652173913043, 0.59347826086957, 0.27777777777778
72024, 1.7652173913043, 0.56739130434783, 0.25
72025, 1.7434782608696, 0.56739130434783, 0.22222222222222
72026, 1.7652173913043, 0.59347826086957, 0.22222222222222
72027, 1.7652173913043, 0.56739130434783, 0.19444444444444
72028, 1.7434782608696, 0.56739130434783, 0.16666666666667
72029, 1.7652173913043, 0.59347826086957, 0.16666666666667
72030, 1.7652173913043, 0.56739130434783, 0.13888888888889
72031, 1.7434782608696, 0.56739130434783, 0.11111111111111
72032, 1.7652173913043, 0.59347826086957, 0.11111111111111
72033, 1.7652173913043, 0.56739130434783, 0.083333333333333
72034, 1.7434782608696, 0.56739130434783, 0.055555555555556
72035, 1.7652173913043, 0.59347826086957, 0.055555555555556
72036, 1.7652173913043, 0.56739130434783, 0.027777777777778
72037, 1.8086956521739, 0.56739130434783, 0.47222222222222
72038, 1.7869565217391, 0.56739130434783, 0.44444444444444
72039, 1.8086956521739, 0.59347826086957, 0.44444444444444
72040, 1.8086956521739, 0.56739130434783, 0.41666666666667
72041, 1.7869565217391, 0.56739130434783, 0.38888888888889
72042, 1.8086956521739, 0.59347826086957, 0.38888888888889
72043, 1.8086956521739, 0.56739130434783, 0.36111111111111
72044, 1.7869565217391, 0.56739130434783, 0.33333333333333
72045, 1.8086956521739, 0.59347826086957, 0.33333333333333
72046, 1.8086956521739, 0.56739130434783, 0.30555555555556
72047, 1.7869565217391, 0.56739130434783, 0.27777777777778
72048, 1.8086956521739, 0.59347826086957, 0.27777777777778
72049, 1.8086956521739, 0.56739130434783, 0.25
72050, 1.7869565217391, 0.56739130434783, 0.22222222222222
72051, 1.8086956521739, 0.59347826086957, 0.22222222222222
72052, 1.8086956521739, 0.56739130434783, 0.19444444444444
72053, 1.7869565217391, 0.56739130434783, 0.16666666666667
72054, 1.8086956521739, 0.59347826086957, 0.16666666666667
72055, 1.8086956521739, 0.56739130434783, 0.13888888888889
72056, 1.7869565217391, 0.56739130434783, 0.11111111111111
72057, 1.8086956521739, 0.59347826086957, 0.11111111111111
72058, 1.8086956521739, 0.56739130434783, 0.083333333333333
72059, 1.7869565217391, 0.56739130434783, 0.055555555555556
72060, 1.8086956521739, 0.59347826086957, 0.055555555555556
72061, 1.8086956521739, 0.56739130434783, 0.027777777777778
72062, 1.8521739130435, 0.56739130434783, 0.47222222222222
72063, 1.8304347826087, 0.56739130434783, 0.44444444444444
72064, 1.8521739130435, 0.59347826086957, 0.44444444444444
72065, 1.8521739130435, 0.56739130434783, 0.41666666666667
72066, 1.8304347826087, 0.56739130434783, 0.38888888888889
72067, 1.8521739130435, 0.59347826086957, 0.38888888888889
72068, 1.8521739130435, 0.56739130434783, 0.36111111111111
72069, 1.8304347826087, 0.56739130434783, 0.33333333333333
72070, 1.8521739130435, 0.59347826086957, 0.33333333333333
72071, 1.8521739130435, 0.56739130434783, 0.30555555555556
72072, 1.8304347826087, 0.56739130434783, 0.27777777777778
72073, 1.8521739130435, 0.59347826086957, 0.27777777777778
72074, 1.8521739130435, 0.56739130434783, 0.25
72075, 1.8304347826087, 0.56739130434783, 0.22222222222222
72076, 1.8521739130435, 0.59347826086957, 0.22222222222222
72077, 1.8521739130435, 0.56739130434783, 0.19444444444444
72078, 1.8304347826087, 0.56739130434783, 0.16666666666667
72079, 1.8521739130435, 0.59347826086957, 0.16666666666667
72080, 1.8521739130435, 0.56739130434783, 0.13888888888889
72081, 1.8304347826087, 0.56739130434783, 0.11111111111111
72082, 1.8521739130435, 0.59347826086957, 0.11111111111111
72083, 1.8521739130435, 0.56739130434783, 0.083333333333333
72084, 1.8304347826087, 0.56739130434783, 0.055555555555556
72085, 1.8521739130435, 0.59347826086957, 0.055555555555556
72086, 1.8521739130435, 0.56739130434783, 0.027777777777778
72087, 1.895652173913, 0.56739130434783, 0.47222222222222
72088, 1.8739130434783, 0.56739130434783, 0.44444444444444
72089, 1.895652173913, 0.59347826086957, 0.44444444444444
72090, 1.895652173913, 0.56739130434783, 0.41666666666667
72091, 1.8739130434783, 0.56739130434783, 0.38888888888889
72092, 1.895652173913, 0.59347826086957, 0.38888888888889
72093, 1.895652173913, 0.56739130434783, 0.36111111111111
72094, 1.8739130434783, 0.56739130434783, 0.33333333333333
72095, 1.895652173913, 0.59347826086957, 0.33333333333333
72096, 1.895652173913, 0.56739130434783, 0.30555555555556
72097, 1.8739130434783, 0.56739130434783, 0.27777777777778
72098, 1.895652173913, 0.59347826086957, 0.27777777777778
72099, 1.895652173913, 0.56739130434783, 0.25
72100, 1.8739130434783, 0.56739130434783, 0.22222222222222
72101, 1.895652173913, 0.59347826086957, 0.22222222222222
72102, 1.895652173913, 0.56739130434783, 0.19444444444444
72103, 1.8739130434783, 0.56739130434783, 0.16666666666667
72104, 1.895652173913, 0.59347826086957, 0.16666666666667
72105, 1.895652173913, 0.56739130434783, 0.13888888888889
72106, 1.8739130434783, 0.56739130434783, 0.11111111111111
72107, 1.895652173913, 0.59347826086957, 0.11111111111111
72108, 1.895652173913, 0.56739130434783, 0.083333333333333
72109, 1.8739130434783, 0.56739130434783, 0.055555555555556
72110, 1.895652173913, 0.59347826086957, 0.055555555555556
72111, 1.895652173913, 0.56739130434783, 0.027777777777778
72112, 1.9391304347826, 0.56739130434783, 0.47222222222222
72113, 1.9173913043478, 0.56739130434783, 0.44444444444444
72114, 1.9391304347826, 0.59347826086957, 0.44444444444444
72115, 1.9391304347826, 0.56739130434783, 0.41666666666667
72116, 1.9173913043478, 0.56739130434783, 0.38888888888889
72117, 1.9391304347826, 0.59347826086957, 0.38888888888889
72118, 1.9391304347826, 0.56739130434783, 0.36111111111111
72119, 1.9173913043478, 0.56739130434783, 0.33333333333333
72120, 1.9391304347826, 0.59347826086957, 0.33333333333333
72121, 1.9391304347826, 0.56739130434783, 0.30555555555556
72122, 1.9173913043478, 0.56739130434783, 0.27777777777778
72123, 1.9391304347826, 0.59347826086957, 0.27777777777778
72124, 1.9391304347826, 0.56739130434783, 0.25
72125, 1.9173913043478, 0.56739130434783, 0.22222222222222
72126, 1.9391304347826, 0.59347826086957, 0.22222222222222
72127, 1.9391304347826, 0.56739130434783, 0.19444444444444
72128, 1.9173913043478, 0.56739130434783, 0.16666666666667
72129, 1.9391304347826, 0.59347826086957, 0.16666666666667
72130, 1.9391304347826, 0.56739130434783, 0.13888888888889
72131, 1.9173913043478, 0.56739130434783, 0.11111111111111
72132, 1.9391304347826, 0.59347826086957, 0.11111111111111
72133, 1.9391304347826, 0.56739130434783, 0.083333333333333
72134, 1.9173913043478, 0.56739130434783, 0.055555555555556
72135, 1.9391304347826, 0.59347826086957, 0.055555555555556
72136, 1.9391304347826, 0.56739130434783, 0.027777777777778
72137, 1.9826086956522, 0.56739130434783, 0.47222222222222
72138, 1.9608695652174, 0.56739130434783, 0.44444444444444
72139, 1.9826086956522, 0.59347826086957, 0.44444444444444
72140, 1.9826086956522, 0.56739130434783, 0.41666666666667
72141, 1.9608695652174, 0.56739130434783, 0.38888888888889
72142, 1.9826086956522, 0.59347826086957, 0.38888888888889
72143, 1.9826086956522, 0.56739130434783, 0.36111111111111
72144, 1.9608695652174, 0.56739130434783, 0.33333333333333
72145, 1.9826086956522, 0.59347826086957, 0.33333333333333
72146, 1.9826086956522, 0.56739130434783, 0.30555555555556
72147, 1.9608695652174, 0.56739130434783, 0.27777777777778
72148, 1.9826086956522, 0.59347826086957, 0.27777777777778
72149, 1.9826086956522, 0.56739130434783, 0.25
72150, 1.9608695652174, 0.56739130434783, 0.22222222222222
72151, 1.9826086956522, 0.59347826086957, 0.22222222222222
72152, 1.9826086956522, 0.56739130434783, 0.19444444444444
72153, 1.9608695652174, 0.56739130434783, 0.16666666666667
72154, 1.9826086956522, 0.59347826086957, 0.16666666666667
72155, 1.9826086956522, 0.56739130434783, 0.13888888888889
72156, 1.9608695652174, 0.56739130434783, 0.11111111111111
72157, 1.9826086956522, 0.59347826086957, 0.11111111111111
72158, 1.9826086956522, 0.56739130434783, 0.083333333333333
72159, 1.9608695652174, 0.56739130434783, 0.055555555555556
72160, 1.9826086956522, 0.59347826086957, 0.055555555555556
72161, 1.9826086956522, 0.56739130434783, 0.027777777777778
72162, 2.0260869565217, 0.56739130434783, 0.47222222222222
72163, 2.004347826087, 0.56739130434783, 0.44444444444444
72164, 2.0260869565217, 0.59347826086957, 0.44444444444444
72165, 2.0260869565217, 0.56739130434783, 0.41666666666667
72166, 2.004347826087, 0.56739130434783, 0.38888888888889
72167, 2.0260869565217, 0.59347826086957, 0.38888888888889
72168, 2.0260869565217, 0.56739130434783, 0.36111111111111
72169, 2.004347826087, 0.56739130434783, 0.33333333333333
72170, 2.0260869565217, 0.59347826086957, 0.33333333333333
72171, 2.0260869565217, 0.56739130434783, 0.30555555555556
72172, 2.004347826087, 0.56739130434783, 0.27777777777778
72173, 2.0260869565217, 0.59347826086957, 0.27777777777778
72174, 2.0260869565217, 0.56739130434783, 0.25
72175, 2.004347826087, 0.56739130434783, 0.22222222222222
72176, 2.0260869565217, 0.59347826086957, 0.22222222222222
72177, 2.0260869565217, 0.56739130434783, 0.19444444444444
72178, 2.004347826087, 0.56739130434783, 0.16666666666667
72179, 2.0260869565217, 0.59347826086957, 0.16666666666667
72180, 2.0260869565217, 0.56739130434783, 0.13888888888889
72181, 2.004347826087, 0.56739130434783, 0.11111111111111
72182, 2.0260869565217, 0.59347826086957, 0.11111111111111
72183, 2.0260869565217, 0.56739130434783, 0.083333333333333
72184, 2.004347826087, 0.56739130434783, 0.055555555555556
72185, 2.0260869565217, 0.59347826086957, 0.055555555555556
72186, 2.0260869565217, 0.56739130434783, 0.027777777777778
72187, 2.0695652173913, 0.56739130434783, 0.47222222222222
72188, 2.0478260869565, 0.56739130434783, 0.44444444444444
72189, 2.0695652173913, 0.59347826086957, 0.44444444444444
72190, 2.0695652173913, 0.56739130434783, 0.41666666666667
72191, 2.0478260869565, 0.56739130434783, 0.38888888888889
72192, 2.0695652173913, 0.59347826086957, 0.38888888888889
72193, 2.0695652173913, 0.56739130434783, 0.36111111111111
72194, 2.0478260869565, 0.56739130434783, 0.33333333333333
72195, 2.0695652173913, 0.59347826086957, 0.33333333333333
72196, 2.0695652173913, 0.56739130434783, 0.30555555555556
72197, 2.0478260869565, 0.56739130434783, 0.27777777777778
72198, 2.0695652173913, 0.59347826086957, 0.27777777777778
72199, 2.0695652173913, 0.56739130434783, 0.25
72200, 2.0478260869565, 0.56739130434783, 0.22222222222222
72201, 2.0695652173913, 0.59347826086957, 0.22222222222222
72202, 2.0695652173913, 0.56739130434783, 0.19444444444444
72203, 2.0478260869565, 0.56739130434783, 0.16666666666667
72204, 2.0695652173913, 0.59347826086957, 0.16666666666667
72205, 2.0695652173913, 0.56739130434783, 0.13888888888889
72206, 2.0478260869565, 0.56739130434783, 0.11111111111111
72207, 2.0695652173913, 0.59347826086957, 0.11111111111111
72208, 2.0695652173913, 0.56739130434783, 0.083333333333333
72209, 2.0478260869565, 0.56739130434783, 0.055555555555556
72210, 2.0695652173913, 0.59347826086957, 0.055555555555556
72211, 2.0695652173913, 0.56739130434783, 0.027777777777778
72212, 2.1130434782609, 0.56739130434783, 0.47222222222222
72213, 2.0913043478261, 0.56739130434783, 0.44444444444444
72214, 2.1130434782609, 0.59347826086957, 0.44444444444444
72215, 2.1130434782609, 0.56739130434783, 0.41666666666667
72216, 2.0913043478261, 0.56739130434783, 0.38888888888889
72217, 2.1130434782609, 0.59347826086957, 0.38888888888889
72218, 2.1130434782609, 0.56739130434783, 0.36111111111111
72219, 2.0913043478261, 0.56739130434783, 0.33333333333333
72220, 2.1130434782609, 0.59347826086957, 0.33333333333333
72221, 2.1130434782609, 0.56739130434783, 0.30555555555556
72222, 2.0913043478261, 0.56739130434783, 0.27777777777778
72223, 2.1130434782609, 0.59347826086957, 0.27777777777778
72224, 2.1130434782609, 0.56739130434783, 0.25
72225, 2.0913043478261, 0.56739130434783, 0.22222222222222
72226, 2.1130434782609, 0.59347826086957, 0.22222222222222
72227, 2.1130434782609, 0.56739130434783, 0.19444444444444
72228, 2.0913043478261, 0.56739130434783, 0.16666666666667
72229, 2.1130434782609, 0.59347826086957, 0.16666666666667
72230, 2.1130434782609, 0.56739130434783, 0.13888888888889
72231, 2.0913043478261, 0.56739130434783, 0.11111111111111
72232, 2.1130434782609, 0.59347826086957, 0.11111111111111
72233, 2.1130434782609, 0.56739130434783, 0.083333333333333
72234, 2.0913043478261, 0.56739130434783, 0.055555555555556
72235, 2.1130434782609, 0.59347826086957, 0.055555555555556
72236, 2.1130434782609, 0.56739130434783, 0.027777777777778
72237, 2.1565217391304, 0.56739130434783, 0.47222222222222
72238, 2.1347826086957, 0.56739130434783, 0.44444444444444
72239, 2.1565217391304, 0.59347826086957, 0.44444444444444
72240, 2.1565217391304, 0.56739130434783, 0.41666666666667
72241, 2.1347826086957, 0.56739130434783, 0.38888888888889
72242, 2.1565217391304, 0.59347826086957, 0.38888888888889
72243, 2.1565217391304, 0.56739130434783, 0.36111111111111
72244, 2.1347826086957, 0.56739130434783, 0.33333333333333
72245, 2.1565217391304, 0.59347826086957, 0.33333333333333
72246, 2.1565217391304, 0.56739130434783, 0.30555555555556
72247, 2.1347826086957, 0.56739130434783, 0.27777777777778
72248, 2.1565217391304, 0.59347826086957, 0.27777777777778
72249, 2.1565217391304, 0.56739130434783, 0.25
72250, 2.1347826086957, 0.56739130434783, 0.22222222222222
72251, 2.1565217391304, 0.59347826086957, 0.22222222222222
72252, 2.1565217391304, 0.56739130434783, 0.19444444444444
72253, 2.1347826086957, 0.56739130434783, 0.16666666666667
72254, 2.1565217391304, 0.59347826086957, 0.16666666666667
72255, 2.1565217391304, 0.56739130434783, 0.13888888888889
72256, 2.1347826086957, 0.56739130434783, 0.11111111111111
72257, 2.1565217391304, 0.59347826086957, 0.11111111111111
72258, 2.1565217391304, 0.56739130434783, 0.083333333333333
72259, 2.1347826086957, 0.56739130434783, 0.055555555555556
72260, 2.1565217391304, 0.59347826086957, 0.055555555555556
