27132, 28307, 63897, 63721, 28299, 28308, 63898, 63722, 28300, 76173, 76160, 75615, 28678, 76174, 76163, 75616, 
28680, 28679, 76161, 75603, 28662
27133, 28308, 63898, 63722, 28300, 28309, 63899, 63723, 28301, 76174, 76163, 75616, 28680, 76175, 76166, 75617, 
28682, 28681, 76164, 75606, 28664
27134, 28309, 63899, 63723, 28301, 3326, 26563, 26541, 3325, 76175, 76166, 75617, 28682, 27553, 27551, 27508, 
3348, 28683, 76167, 75609, 28666
27135, 233, 5, 3146, 25046, 4587, 330, 27744, 63724, 255, 3169, 26013, 26058, 4763, 28126, 75619, 
76176, 4764, 339, 28110, 75618
27136, 4587, 330, 27744, 63724, 4588, 329, 27745, 63725, 4763, 28126, 75619, 76176, 4765, 28127, 75622, 
76177, 4766, 338, 28112, 75621
27137, 4588, 329, 27745, 63725, 4589, 328, 27746, 63726, 4765, 28127, 75622, 76177, 4767, 28128, 75625, 
76178, 4768, 337, 28114, 75624
27138, 4589, 328, 27746, 63726, 4590, 327, 27747, 63727, 4767, 28128, 75625, 76178, 4769, 28129, 75628, 
76179, 4770, 336, 28116, 75627
27139, 4590, 327, 27747, 63727, 4591, 326, 27748, 63728, 4769, 28129, 75628, 76179, 4771, 28130, 75631, 
76180, 4772, 335, 28118, 75630
27140, 4591, 326, 27748, 63728, 4592, 325, 27749, 63729, 4771, 28130, 75631, 76180, 4773, 28131, 75634, 
76181, 4774, 334, 28120, 75633
27141, 4592, 325, 27749, 63729, 4593, 324, 27750, 63730, 4773, 28131, 75634, 76181, 4775, 28132, 75637, 
76182, 4776, 333, 28122, 75636
27142, 4593, 324, 27750, 63730, 4594, 323, 27751, 63731, 4775, 28132, 75637, 76182, 4777, 28133, 75640, 
76183, 4778, 332, 28124, 75639
27143, 4594, 323, 27751, 63731, 278, 7, 3281, 26542, 4777, 28133, 75640, 76183, 300, 3304, 27510, 
27554, 4779, 331, 28125, 75642
27144, 234, 233, 25046, 25047, 4595, 4587, 63724, 63732, 256, 26058, 26015, 26059, 4780, 76176, 75644, 
76184, 4781, 4764, 75618, 75643
27145, 4595, 4587, 63724, 63732, 4596, 4588, 63725, 63733, 4780, 76176, 75644, 76184, 4782, 76177, 75647, 
76185, 4783, 4766, 75621, 75646
27146, 4596, 4588, 63725, 63733, 4597, 4589, 63726, 63734, 4782, 76177, 75647, 76185, 4784, 76178, 75650, 
76186, 4785, 4768, 75624, 75649
27147, 4597, 4589, 63726, 63734, 4598, 4590, 63727, 63735, 4784, 76178, 75650, 76186, 4786, 76179, 75653, 
76187, 4787, 4770, 75627, 75652
27148, 4598, 4590, 63727, 63735, 4599, 4591, 63728, 63736, 4786, 76179, 75653, 76187, 4788, 76180, 75656, 
76188, 4789, 4772, 75630, 75655
27149, 4599, 4591, 63728, 63736, 4600, 4592, 63729, 63737, 4788, 76180, 75656, 76188, 4790, 76181, 75659, 
76189, 4791, 4774, 75633, 75658
27150, 4600, 4592, 63729, 63737, 4601, 4593, 63730, 63738, 4790, 76181, 75659, 76189, 4792, 76182, 75662, 
76190, 4793, 4776, 75636, 75661
27151, 4601, 4593, 63730, 63738, 4602, 4594, 63731, 63739, 4792, 76182, 75662, 76190, 4794, 76183, 75665, 
76191, 4795, 4778, 75639, 75664
27152, 4602, 4594, 63731, 63739, 279, 278, 26542, 26543, 4794, 76183, 75665, 76191, 301, 27554, 27512, 
27555, 4796, 4779, 75642, 75667
27153, 235, 234, 25047, 25048, 4603, 4595, 63732, 63740, 257, 26059, 26017, 26060, 4797, 76184, 75669, 
76192, 4798, 4781, 75643, 75668
27154, 4603, 4595, 63732, 63740, 4604, 4596, 63733, 63741, 4797, 76184, 75669, 76192, 4799, 76185, 75672, 
76193, 4800, 4783, 75646, 75671
27155, 4604, 4596, 63733, 63741, 4605, 4597, 63734, 63742, 4799, 76185, 75672, 76193, 4801, 76186, 75675, 
76194, 4802, 4785, 75649, 75674
27156, 4605, 4597, 63734, 63742, 4606, 4598, 63735, 63743, 4801, 76186, 75675, 76194, 4803, 76187, 75678, 
76195, 4804, 4787, 75652, 75677
27157, 4606, 4598, 63735, 63743, 4607, 4599, 63736, 63744, 4803, 76187, 75678, 76195, 4805, 76188, 75681, 
76196, 4806, 4789, 75655, 75680
27158, 4607, 4599, 63736, 63744, 4608, 4600, 63737, 63745, 4805, 76188, 75681, 76196, 4807, 76189, 75684, 
76197, 4808, 4791, 75658, 75683
27159, 4608, 4600, 63737, 63745, 4609, 4601, 63738, 63746, 4807, 76189, 75684, 76197, 4809, 76190, 75687, 
76198, 4810, 4793, 75661, 75686
27160, 4609, 4601, 63738, 63746, 4610, 4602, 63739, 63747, 4809, 76190, 75687, 76198, 4811, 76191, 75690, 
76199, 4812, 4795, 75664, 75689
27161, 4610, 4602, 63739, 63747, 280, 279, 26543, 26544, 4811, 76191, 75690, 76199, 302, 27555, 27514, 
27556, 4813, 4796, 75667, 75692
27162, 236, 235, 25048, 25049, 4611, 4603, 63740, 63748, 258, 26060, 26019, 26061, 4814, 76192, 75694, 
76200, 4815, 4798, 75668, 75693
27163, 4611, 4603, 63740, 63748, 4612, 4604, 63741, 63749, 4814, 76192, 75694, 76200, 4816, 76193, 75697, 
76201, 4817, 4800, 75671, 75696
27164, 4612, 4604, 63741, 63749, 4613, 4605, 63742, 63750, 4816, 76193, 75697, 76201, 4818, 76194, 75700, 
76202, 4819, 4802, 75674, 75699
27165, 4613, 4605, 63742, 63750, 4614, 4606, 63743, 63751, 4818, 76194, 75700, 76202, 4820, 76195, 75703, 
76203, 4821, 4804, 75677, 75702
27166, 4614, 4606, 63743, 63751, 4615, 4607, 63744, 63752, 4820, 76195, 75703, 76203, 4822, 76196, 75706, 
76204, 4823, 4806, 75680, 75705
27167, 4615, 4607, 63744, 63752, 4616, 4608, 63745, 63753, 4822, 76196, 75706, 76204, 4824, 76197, 75709, 
76205, 4825, 4808, 75683, 75708
27168, 4616, 4608, 63745, 63753, 4617, 4609, 63746, 63754, 4824, 76197, 75709, 76205, 4826, 76198, 75712, 
76206, 4827, 4810, 75686, 75711
27169, 4617, 4609, 63746, 63754, 4618, 4610, 63747, 63755, 4826, 76198, 75712, 76206, 4828, 76199, 75715, 
76207, 4829, 4812, 75689, 75714
27170, 4618, 4610, 63747, 63755, 281, 280, 26544, 26545, 4828, 76199, 75715, 76207, 303, 27556, 27516, 
27557, 4830, 4813, 75692, 75717
27171, 237, 236, 25049, 25050, 4619, 4611, 63748, 63756, 259, 26061, 26021, 26062, 4831, 76200, 75719, 
76208, 4832, 4815, 75693, 75718
27172, 4619, 4611, 63748, 63756, 4620, 4612, 63749, 63757, 4831, 76200, 75719, 76208, 4833, 76201, 75722, 
76209, 4834, 4817, 75696, 75721
27173, 4620, 4612, 63749, 63757, 4621, 4613, 63750, 63758, 4833, 76201, 75722, 76209, 4835, 76202, 75725, 
76210, 4836, 4819, 75699, 75724
27174, 4621, 4613, 63750, 63758, 4622, 4614, 63751, 63759, 4835, 76202, 75725, 76210, 4837, 76203, 75728, 
76211, 4838, 4821, 75702, 75727
27175, 4622, 4614, 63751, 63759, 4623, 4615, 63752, 63760, 4837, 76203, 75728, 76211, 4839, 76204, 75731, 
76212, 4840, 4823, 75705, 75730
27176, 4623, 4615, 63752, 63760, 4624, 4616, 63753, 63761, 4839, 76204, 75731, 76212, 4841, 76205, 75734, 
76213, 4842, 4825, 75708, 75733
27177, 4624, 4616, 63753, 63761, 4625, 4617, 63754, 63762, 4841, 76205, 75734, 76213, 4843, 76206, 75737, 
76214, 4844, 4827, 75711, 75736
27178, 4625, 4617, 63754, 63762, 4626, 4618, 63755, 63763, 4843, 76206, 75737, 76214, 4845, 76207, 75740, 
76215, 4846, 4829, 75714, 75739
27179, 4626, 4618, 63755, 63763, 282, 281, 26545, 26546, 4845, 76207, 75740, 76215, 304, 27557, 27518, 
27558, 4847, 4830, 75717, 75742
27180, 238, 237, 25050, 25051, 4627, 4619, 63756, 63764, 260, 26062, 26023, 26063, 4848, 76208, 75744, 
76216, 4849, 4832, 75718, 75743
27181, 4627, 4619, 63756, 63764, 4628, 4620, 63757, 63765, 4848, 76208, 75744, 76216, 4850, 76209, 75747, 
76217, 4851, 4834, 75721, 75746
27182, 4628, 4620, 63757, 63765, 4629, 4621, 63758, 63766, 4850, 76209, 75747, 76217, 4852, 76210, 75750, 
76218, 4853, 4836, 75724, 75749
27183, 4629, 4621, 63758, 63766, 4630, 4622, 63759, 63767, 4852, 76210, 75750, 76218, 4854, 76211, 75753, 
76219, 4855, 4838, 75727, 75752
27184, 4630, 4622, 63759, 63767, 4631, 4623, 63760, 63768, 4854, 76211, 75753, 76219, 4856, 76212, 75756, 
76220, 4857, 4840, 75730, 75755
27185, 4631, 4623, 63760, 63768, 4632, 4624, 63761, 63769, 4856, 76212, 75756, 76220, 4858, 76213, 75759, 
76221, 4859, 4842, 75733, 75758
27186, 4632, 4624, 63761, 63769, 4633, 4625, 63762, 63770, 4858, 76213, 75759, 76221, 4860, 76214, 75762, 
76222, 4861, 4844, 75736, 75761
27187, 4633, 4625, 63762, 63770, 4634, 4626, 63763, 63771, 4860, 76214, 75762, 76222, 4862, 76215, 75765, 
76223, 4863, 4846, 75739, 75764
27188, 4634, 4626, 63763, 63771, 283, 282, 26546, 26547, 4862, 76215, 75765, 76223, 305, 27558, 27520, 
27559, 4864, 4847, 75742, 75767
27189, 239, 238, 25051, 25052, 4635, 4627, 63764, 63772, 261, 26063, 26025, 26064, 4865, 76216, 75769, 
76224, 4866, 4849, 75743, 75768
27190, 4635, 4627, 63764, 63772, 4636, 4628, 63765, 63773, 4865, 76216, 75769, 76224, 4867, 76217, 75772, 
76225, 4868, 4851, 75746, 75771
27191, 4636, 4628, 63765, 63773, 4637, 4629, 63766, 63774, 4867, 76217, 75772, 76225, 4869, 76218, 75775, 
76226, 4870, 4853, 75749, 75774
27192, 4637, 4629, 63766, 63774, 4638, 4630, 63767, 63775, 4869, 76218, 75775, 76226, 4871, 76219, 75778, 
76227, 4872, 4855, 75752, 75777
27193, 4638, 4630, 63767, 63775, 4639, 4631, 63768, 63776, 4871, 76219, 75778, 76227, 4873, 76220, 75781, 
76228, 4874, 4857, 75755, 75780
27194, 4639, 4631, 63768, 63776, 4640, 4632, 63769, 63777, 4873, 76220, 75781, 76228, 4875, 76221, 75784, 
76229, 4876, 4859, 75758, 75783
27195, 4640, 4632, 63769, 63777, 4641, 4633, 63770, 63778, 4875, 76221, 75784, 76229, 4877, 76222, 75787, 
76230, 4878, 4861, 75761, 75786
27196, 4641, 4633, 63770, 63778, 4642, 4634, 63771, 63779, 4877, 76222, 75787, 76230, 4879, 76223, 75790, 
76231, 4880, 4863, 75764, 75789
27197, 4642, 4634, 63771, 63779, 284, 283, 26547, 26548, 4879, 76223, 75790, 76231, 306, 27559, 27522, 
27560, 4881, 4864, 75767, 75792
27198, 240, 239, 25052, 25053, 4643, 4635, 63772, 63780, 262, 26064, 26027, 26065, 4882, 76224, 75794, 
76232, 4883, 4866, 75768, 75793
27199, 4643, 4635, 63772, 63780, 4644, 4636, 63773, 63781, 4882, 76224, 75794, 76232, 4884, 76225, 75797, 
76233, 4885, 4868, 75771, 75796
27200, 4644, 4636, 63773, 63781, 4645, 4637, 63774, 63782, 4884, 76225, 75797, 76233, 4886, 76226, 75800, 
76234, 4887, 4870, 75774, 75799
27201, 4645, 4637, 63774, 63782, 4646, 4638, 63775, 63783, 4886, 76226, 75800, 76234, 4888, 76227, 75803, 
76235, 4889, 4872, 75777, 75802
27202, 4646, 4638, 63775, 63783, 4647, 4639, 63776, 63784, 4888, 76227, 75803, 76235, 4890, 76228, 75806, 
76236, 4891, 4874, 75780, 75805
27203, 4647, 4639, 63776, 63784, 4648, 4640, 63777, 63785, 4890, 76228, 75806, 76236, 4892, 76229, 75809, 
76237, 4893, 4876, 75783, 75808
27204, 4648, 4640, 63777, 63785, 4649, 4641, 63778, 63786, 4892, 76229, 75809, 76237, 4894, 76230, 75812, 
76238, 4895, 4878, 75786, 75811
27205, 4649, 4641, 63778, 63786, 4650, 4642, 63779, 63787, 4894, 76230, 75812, 76238, 4896, 76231, 75815, 
76239, 4897, 4880, 75789, 75814
27206, 4650, 4642, 63779, 63787, 285, 284, 26548, 26549, 4896, 76231, 75815, 76239, 307, 27560, 27524, 
27561, 4898, 4881, 75792, 75817
27207, 241, 240, 25053, 25054, 4651, 4643, 63780, 63788, 263, 26065, 26029, 26066, 4899, 76232, 75819, 
76240, 4900, 4883, 75793, 75818
27208, 4651, 4643, 63780, 63788, 4652, 4644, 63781, 63789, 4899, 76232, 75819, 76240, 4901, 76233, 75822, 
76241, 4902, 4885, 75796, 75821
27209, 4652, 4644, 63781, 63789, 4653, 4645, 63782, 63790, 4901, 76233, 75822, 76241, 4903, 76234, 75825, 
76242, 4904, 4887, 75799, 75824
27210, 4653, 4645, 63782, 63790, 4654, 4646, 63783, 63791, 4903, 76234, 75825, 76242, 4905, 76235, 75828, 
76243, 4906, 4889, 75802, 75827
27211, 4654, 4646, 63783, 63791, 4655, 4647, 63784, 63792, 4905, 76235, 75828, 76243, 4907, 76236, 75831, 
76244, 4908, 4891, 75805, 75830
27212, 4655, 4647, 63784, 63792, 4656, 4648, 63785, 63793, 4907, 76236, 75831, 76244, 4909, 76237, 75834, 
76245, 4910, 4893, 75808, 75833
27213, 4656, 4648, 63785, 63793, 4657, 4649, 63786, 63794, 4909, 76237, 75834, 76245, 4911, 76238, 75837, 
76246, 4912, 4895, 75811, 75836
27214, 4657, 4649, 63786, 63794, 4658, 4650, 63787, 63795, 4911, 76238, 75837, 76246, 4913, 76239, 75840, 
76247, 4914, 4897, 75814, 75839
27215, 4658, 4650, 63787, 63795, 286, 285, 26549, 26550, 4913, 76239, 75840, 76247, 308, 27561, 27526, 
27562, 4915, 4898, 75817, 75842
27216, 242, 241, 25054, 25055, 4659, 4651, 63788, 63796, 264, 26066, 26031, 26067, 4916, 76240, 75844, 
76248, 4917, 4900, 75818, 75843
27217, 4659, 4651, 63788, 63796, 4660, 4652, 63789, 63797, 4916, 76240, 75844, 76248, 4918, 76241, 75847, 
76249, 4919, 4902, 75821, 75846
27218, 4660, 4652, 63789, 63797, 4661, 4653, 63790, 63798, 4918, 76241, 75847, 76249, 4920, 76242, 75850, 
76250, 4921, 4904, 75824, 75849
27219, 4661, 4653, 63790, 63798, 4662, 4654, 63791, 63799, 4920, 76242, 75850, 76250, 4922, 76243, 75853, 
76251, 4923, 4906, 75827, 75852
27220, 4662, 4654, 63791, 63799, 4663, 4655, 63792, 63800, 4922, 76243, 75853, 76251, 4924, 76244, 75856, 
76252, 4925, 4908, 75830, 75855
27221, 4663, 4655, 63792, 63800, 4664, 4656, 63793, 63801, 4924, 76244, 75856, 76252, 4926, 76245, 75859, 
76253, 4927, 4910, 75833, 75858
27222, 4664, 4656, 63793, 63801, 4665, 4657, 63794, 63802, 4926, 76245, 75859, 76253, 4928, 76246, 75862, 
76254, 4929, 4912, 75836, 75861
27223, 4665, 4657, 63794, 63802, 4666, 4658, 63795, 63803, 4928, 76246, 75862, 76254, 4930, 76247, 75865, 
76255, 4931, 4914, 75839, 75864
27224, 4666, 4658, 63795, 63803, 287, 286, 26550, 26551, 4930, 76247, 75865, 76255, 309, 27562, 27528, 
27563, 4932, 4915, 75842, 75867
27225, 243, 242, 25055, 25056, 4667, 4659, 63796, 63804, 265, 26067, 26033, 26068, 4933, 76248, 75869, 
76256, 4934, 4917, 75843, 75868
27226, 4667, 4659, 63796, 63804, 4668, 4660, 63797, 63805, 4933, 76248, 75869, 76256, 4935, 76249, 75872, 
76257, 4936, 4919, 75846, 75871
27227, 4668, 4660, 63797, 63805, 4669, 4661, 63798, 63806, 4935, 76249, 75872, 76257, 4937, 76250, 75875, 
76258, 4938, 4921, 75849, 75874
27228, 4669, 4661, 63798, 63806, 4670, 4662, 63799, 63807, 4937, 76250, 75875, 76258, 4939, 76251, 75878, 
76259, 4940, 4923, 75852, 75877
27229, 4670, 4662, 63799, 63807, 4671, 4663, 63800, 63808, 4939, 76251, 75878, 76259, 4941, 76252, 75881, 
76260, 4942, 4925, 75855, 75880
27230, 4671, 4663, 63800, 63808, 4672, 4664, 63801, 63809, 4941, 76252, 75881, 76260, 4943, 76253, 75884, 
76261, 4944, 4927, 75858, 75883
27231, 4672, 4664, 63801, 63809, 4673, 4665, 63802, 63810, 4943, 76253, 75884, 76261, 4945, 76254, 75887, 
76262, 4946, 4929, 75861, 75886
27232, 4673, 4665, 63802, 63810, 4674, 4666, 63803, 63811, 4945, 76254, 75887, 76262, 4947, 76255, 75890, 
76263, 4948, 4931, 75864, 75889
27233, 4674, 4666, 63803, 63811, 288, 287, 26551, 26552, 4947, 76255, 75890, 76263, 310, 27563, 27530, 
27564, 4949, 4932, 75867, 75892
27234, 244, 243, 25056, 25057, 4675, 4667, 63804, 63812, 266, 26068, 26035, 26069, 4950, 76256, 75894, 
76264, 4951, 4934, 75868, 75893
27235, 4675, 4667, 63804, 63812, 4676, 4668, 63805, 63813, 4950, 76256, 75894, 76264, 4952, 76257, 75897, 
76265, 4953, 4936, 75871, 75896
27236, 4676, 4668, 63805, 63813, 4677, 4669, 63806, 63814, 4952, 76257, 75897, 76265, 4954, 76258, 75900, 
76266, 4955, 4938, 75874, 75899
27237, 4677, 4669, 63806, 63814, 4678, 4670, 63807, 63815, 4954, 76258, 75900, 76266, 4956, 76259, 75903, 
76267, 4957, 4940, 75877, 75902
27238, 4678, 4670, 63807, 63815, 4679, 4671, 63808, 63816, 4956, 76259, 75903, 76267, 4958, 76260, 75906, 
76268, 4959, 4942, 75880, 75905
27239, 4679, 4671, 63808, 63816, 4680, 4672, 63809, 63817, 4958, 76260, 75906, 76268, 4960, 76261, 75909, 
76269, 4961, 4944, 75883, 75908
27240, 4680, 4672, 63809, 63817, 4681, 4673, 63810, 63818, 4960, 76261, 75909, 76269, 4962, 76262, 75912, 
76270, 4963, 4946, 75886, 75911
27241, 4681, 4673, 63810, 63818, 4682, 4674, 63811, 63819, 4962, 76262, 75912, 76270, 4964, 76263, 75915, 
76271, 4965, 4948, 75889, 75914
27242, 4682, 4674, 63811, 63819, 289, 288, 26552, 26553, 4964, 76263, 75915, 76271, 311, 27564, 27532, 
27565, 4966, 4949, 75892, 75917
27243, 245, 244, 25057, 25058, 4683, 4675, 63812, 63820, 267, 26069, 26037, 26070, 4967, 76264, 75919, 
76272, 4968, 4951, 75893, 75918
27244, 4683, 4675, 63812, 63820, 4684, 4676, 63813, 63821, 4967, 76264, 75919, 76272, 4969, 76265, 75922, 
76273, 4970, 4953, 75896, 75921
27245, 4684, 4676, 63813, 63821, 4685, 4677, 63814, 63822, 4969, 76265, 75922, 76273, 4971, 76266, 75925, 
76274, 4972, 4955, 75899, 75924
27246, 4685, 4677, 63814, 63822, 4686, 4678, 63815, 63823, 4971, 76266, 75925, 76274, 4973, 76267, 75928, 
76275, 4974, 4957, 75902, 75927
27247, 4686, 4678, 63815, 63823, 4687, 4679, 63816, 63824, 4973, 76267, 75928, 76275, 4975, 76268, 75931, 
76276, 4976, 4959, 75905, 75930
27248, 4687, 4679, 63816, 63824, 4688, 4680, 63817, 63825, 4975, 76268, 75931, 76276, 4977, 76269, 75934, 
76277, 4978, 4961, 75908, 75933
27249, 4688, 4680, 63817, 63825, 4689, 4681, 63818, 63826, 4977, 76269, 75934, 76277, 4979, 76270, 75937, 
76278, 4980, 4963, 75911, 75936
27250, 4689, 4681, 63818, 63826, 4690, 4682, 63819, 63827, 4979, 76270, 75937, 76278, 4981, 76271, 75940, 
76279, 4982, 4965, 75914, 75939
27251, 4690, 4682, 63819, 63827, 290, 289, 26553, 26554, 4981, 76271, 75940, 76279, 312, 27565, 27534, 
27566, 4983, 4966, 75917, 75942
27252, 246, 245, 25058, 25059, 4691, 4683, 63820, 63828, 268, 26070, 26039, 26071, 4984, 76272, 75944, 
76280, 4985, 4968, 75918, 75943
27253, 4691, 4683, 63820, 63828, 4692, 4684, 63821, 63829, 4984, 76272, 75944, 76280, 4986, 76273, 75947, 
76281, 4987, 4970, 75921, 75946
27254, 4692, 4684, 63821, 63829, 4693, 4685, 63822, 63830, 4986, 76273, 75947, 76281, 4988, 76274, 75950, 
76282, 4989, 4972, 75924, 75949
27255, 4693, 4685, 63822, 63830, 4694, 4686, 63823, 63831, 4988, 76274, 75950, 76282, 4990, 76275, 75953, 
76283, 4991, 4974, 75927, 75952
27256, 4694, 4686, 63823, 63831, 4695, 4687, 63824, 63832, 4990, 76275, 75953, 76283, 4992, 76276, 75956, 
76284, 4993, 4976, 75930, 75955
27257, 4695, 4687, 63824, 63832, 4696, 4688, 63825, 63833, 4992, 76276, 75956, 76284, 4994, 76277, 75959, 
76285, 4995, 4978, 75933, 75958
27258, 4696, 4688, 63825, 63833, 4697, 4689, 63826, 63834, 4994, 76277, 75959, 76285, 4996, 76278, 75962, 
76286, 4997, 4980, 75936, 75961
27259, 4697, 4689, 63826, 63834, 4698, 4690, 63827, 63835, 4996, 76278, 75962, 76286, 4998, 76279, 75965, 
76287, 4999, 4982, 75939, 75964
27260, 4698, 4690, 63827, 63835, 291, 290, 26554, 26555, 4998, 76279, 75965, 76287, 313, 27566, 27536, 
27567, 5000, 4983, 75942, 75967
27261, 247, 246, 25059, 25060, 4699, 4691, 63828, 63836, 269, 26071, 26041, 26072, 5001, 76280, 75969, 
76288, 5002, 4985, 75943, 75968
27262, 4699, 4691, 63828, 63836, 4700, 4692, 63829, 63837, 5001, 76280, 75969, 76288, 5003, 76281, 75972, 
76289, 5004, 4987, 75946, 75971
27263, 4700, 4692, 63829, 63837, 4701, 4693, 63830, 63838, 5003, 76281, 75972, 76289, 5005, 76282, 75975, 
76290, 5006, 4989, 75949, 75974
27264, 4701, 4693, 63830, 63838, 4702, 4694, 63831, 63839, 5005, 76282, 75975, 76290, 5007, 76283, 75978, 
76291, 5008, 4991, 75952, 75977
27265, 4702, 4694, 63831, 63839, 4703, 4695, 63832, 63840, 5007, 76283, 75978, 76291, 5009, 76284, 75981, 
76292, 5010, 4993, 75955, 75980
27266, 4703, 4695, 63832, 63840, 4704, 4696, 63833, 63841, 5009, 76284, 75981, 76292, 5011, 76285, 75984, 
76293, 5012, 4995, 75958, 75983
27267, 4704, 4696, 63833, 63841, 4705, 4697, 63834, 63842, 5011, 76285, 75984, 76293, 5013, 76286, 75987, 
76294, 5014, 4997, 75961, 75986
27268, 4705, 4697, 63834, 63842, 4706, 4698, 63835, 63843, 5013, 76286, 75987, 76294, 5015, 76287, 75990, 
76295, 5016, 4999, 75964, 75989
27269, 4706, 4698, 63835, 63843, 292, 291, 26555, 26556, 5015, 76287, 75990, 76295, 314, 27567, 27538, 
27568, 5017, 5000, 75967, 75992
27270, 248, 247, 25060, 25061, 4707, 4699, 63836, 63844, 270, 26072, 26043, 26073, 5018, 76288, 75994, 
76296, 5019, 5002, 75968, 75993
27271, 4707, 4699, 63836, 63844, 4708, 4700, 63837, 63845, 5018, 76288, 75994, 76296, 5020, 76289, 75997, 
76297, 5021, 5004, 75971, 75996
27272, 4708, 4700, 63837, 63845, 4709, 4701, 63838, 63846, 5020, 76289, 75997, 76297, 5022, 76290, 76000, 
76298, 5023, 5006, 75974, 75999
27273, 4709, 4701, 63838, 63846, 4710, 4702, 63839, 63847, 5022, 76290, 76000, 76298, 5024, 76291, 76003, 
76299, 5025, 5008, 75977, 76002
27274, 4710, 4702, 63839, 63847, 4711, 4703, 63840, 63848, 5024, 76291, 76003, 76299, 5026, 76292, 76006, 
76300, 5027, 5010, 75980, 76005
27275, 4711, 4703, 63840, 63848, 4712, 4704, 63841, 63849, 5026, 76292, 76006, 76300, 5028, 76293, 76009, 
76301, 5029, 5012, 75983, 76008
27276, 4712, 4704, 63841, 63849, 4713, 4705, 63842, 63850, 5028, 76293, 76009, 76301, 5030, 76294, 76012, 
76302, 5031, 5014, 75986, 76011
27277, 4713, 4705, 63842, 63850, 4714, 4706, 63843, 63851, 5030, 76294, 76012, 76302, 5032, 76295, 76015, 
76303, 5033, 5016, 75989, 76014
27278, 4714, 4706, 63843, 63851, 293, 292, 26556, 26557, 5032, 76295, 76015, 76303, 315, 27568, 27540, 
27569, 5034, 5017, 75992, 76017
27279, 249, 248, 25061, 25062, 4715, 4707, 63844, 63852, 271, 26073, 26045, 26074, 5035, 76296, 76019, 
76304, 5036, 5019, 75993, 76018
27280, 4715, 4707, 63844, 63852, 4716, 4708, 63845, 63853, 5035, 76296, 76019, 76304, 5037, 76297, 76022, 
76305, 5038, 5021, 75996, 76021
27281, 4716, 4708, 63845, 63853, 4717, 4709, 63846, 63854, 5037, 76297, 76022, 76305, 5039, 76298, 76025, 
76306, 5040, 5023, 75999, 76024
27282, 4717, 4709, 63846, 63854, 4718, 4710, 63847, 63855, 5039, 76298, 76025, 76306, 5041, 76299, 76028, 
76307, 5042, 5025, 76002, 76027
27283, 4718, 4710, 63847, 63855, 4719, 4711, 63848, 63856, 5041, 76299, 76028, 76307, 5043, 76300, 76031, 
76308, 5044, 5027, 76005, 76030
27284, 4719, 4711, 63848, 63856, 4720, 4712, 63849, 63857, 5043, 76300, 76031, 76308, 5045, 76301, 76034, 
76309, 5046, 5029, 76008, 76033
27285, 4720, 4712, 63849, 63857, 4721, 4713, 63850, 63858, 5045, 76301, 76034, 76309, 5047, 76302, 76037, 
76310, 5048, 5031, 76011, 76036
27286, 4721, 4713, 63850, 63858, 4722, 4714, 63851, 63859, 5047, 76302, 76037, 76310, 5049, 76303, 76040, 
76311, 5050, 5033, 76014, 76039
27287, 4722, 4714, 63851, 63859, 294, 293, 26557, 26558, 5049, 76303, 76040, 76311, 316, 27569, 27542, 
27570, 5051, 5034, 76017, 76042
27288, 250, 249, 25062, 25063, 4723, 4715, 63852, 63860, 272, 26074, 26047, 26075, 5052, 76304, 76044, 
76312, 5053, 5036, 76018, 76043
27289, 4723, 4715, 63852, 63860, 4724, 4716, 63853, 63861, 5052, 76304, 76044, 76312, 5054, 76305, 76047, 
76313, 5055, 5038, 76021, 76046
27290, 4724, 4716, 63853, 63861, 4725, 4717, 63854, 63862, 5054, 76305, 76047, 76313, 5056, 76306, 76050, 
76314, 5057, 5040, 76024, 76049
27291, 4725, 4717, 63854, 63862, 4726, 4718, 63855, 63863, 5056, 76306, 76050, 76314, 5058, 76307, 76053, 
76315, 5059, 5042, 76027, 76052
27292, 4726, 4718, 63855, 63863, 4727, 4719, 63856, 63864, 5058, 76307, 76053, 76315, 5060, 76308, 76056, 
76316, 5061, 5044, 76030, 76055
27293, 4727, 4719, 63856, 63864, 4728, 4720, 63857, 63865, 5060, 76308, 76056, 76316, 5062, 76309, 76059, 
76317, 5063, 5046, 76033, 76058
27294, 4728, 4720, 63857, 63865, 4729, 4721, 63858, 63866, 5062, 76309, 76059, 76317, 5064, 76310, 76062, 
76318, 5065, 5048, 76036, 76061
27295, 4729, 4721, 63858, 63866, 4730, 4722, 63859, 63867, 5064, 76310, 76062, 76318, 5066, 76311, 76065, 
76319, 5067, 5050, 76039, 76064
27296, 4730, 4722, 63859, 63867, 295, 294, 26558, 26559, 5066, 76311, 76065, 76319, 317, 27570, 27544, 
27571, 5068, 5051, 76042, 76067
27297, 251, 250, 25063, 25064, 4731, 4723, 63860, 63868, 273, 26075, 26049, 26076, 5069, 76312, 76069, 
76320, 5070, 5053, 76043, 76068
27298, 4731, 4723, 63860, 63868, 4732, 4724, 63861, 63869, 5069, 76312, 76069, 76320, 5071, 76313, 76072, 
76321, 5072, 5055, 76046, 76071
27299, 4732, 4724, 63861, 63869, 4733, 4725, 63862, 63870, 5071, 76313, 76072, 76321, 5073, 76314, 76075, 
76322, 5074, 5057, 76049, 76074
27300, 4733, 4725, 63862, 63870, 4734, 4726, 63863, 63871, 5073, 76314, 76075, 76322, 5075, 76315, 76078, 
76323, 5076, 5059, 76052, 76077
27301, 4734, 4726, 63863, 63871, 4735, 4727, 63864, 63872, 5075, 76315, 76078, 76323, 5077, 76316, 76081, 
76324, 5078, 5061, 76055, 76080
27302, 4735, 4727, 63864, 63872, 4736, 4728, 63865, 63873, 5077, 76316, 76081, 76324, 5079, 76317, 76084, 
76325, 5080, 5063, 76058, 76083
27303, 4736, 4728, 63865, 63873, 4737, 4729, 63866, 63874, 5079, 76317, 76084, 76325, 5081, 76318, 76087, 
76326, 5082, 5065, 76061, 76086
27304, 4737, 4729, 63866, 63874, 4738, 4730, 63867, 63875, 5081, 76318, 76087, 76326, 5083, 76319, 76090, 
76327, 5084, 5067, 76064, 76089
27305, 4738, 4730, 63867, 63875, 296, 295, 26559, 26560, 5083, 76319, 76090, 76327, 318, 27571, 27546, 
27572, 5085, 5068, 76067, 76092
27306, 252, 251, 25064, 25065, 4739, 4731, 63868, 63876, 274, 26076, 26051, 26077, 5086, 76320, 76094, 
76328, 5087, 5070, 76068, 76093
27307, 4739, 4731, 63868, 63876, 4740, 4732, 63869, 63877, 5086, 76320, 76094, 76328, 5088, 76321, 76097, 
76329, 5089, 5072, 76071, 76096
27308, 4740, 4732, 63869, 63877, 4741, 4733, 63870, 63878, 5088, 76321, 76097, 76329, 5090, 76322, 76100, 
76330, 5091, 5074, 76074, 76099
27309, 4741, 4733, 63870, 63878, 4742, 4734, 63871, 63879, 5090, 76322, 76100, 76330, 5092, 76323, 76103, 
76331, 5093, 5076, 76077, 76102
27310, 4742, 4734, 63871, 63879, 4743, 4735, 63872, 63880, 5092, 76323, 76103, 76331, 5094, 76324, 76106, 
76332, 5095, 5078, 76080, 76105
27311, 4743, 4735, 63872, 63880, 4744, 4736, 63873, 63881, 5094, 76324, 76106, 76332, 5096, 76325, 76109, 
76333, 5097, 5080, 76083, 76108
27312, 4744, 4736, 63873, 63881, 4745, 4737, 63874, 63882, 5096, 76325, 76109, 76333, 5098, 76326, 76112, 
76334, 5099, 5082, 76086, 76111
27313, 4745, 4737, 63874, 63882, 4746, 4738, 63875, 63883, 5098, 76326, 76112, 76334, 5100, 76327, 76115, 
76335, 5101, 5084, 76089, 76114
27314, 4746, 4738, 63875, 63883, 297, 296, 26560, 26561, 5100, 76327, 76115, 76335, 319, 27572, 27548, 
27573, 5102, 5085, 76092, 76117
27315, 253, 252, 25065, 25066, 4747, 4739, 63876, 63884, 275, 26077, 26053, 26078, 5103, 76328, 76119, 
76336, 5104, 5087, 76093, 76118
27316, 4747, 4739, 63876, 63884, 4748, 4740, 63877, 63885, 5103, 76328, 76119, 76336, 5105, 76329, 76122, 
76337, 5106, 5089, 76096, 76121
27317, 4748, 4740, 63877, 63885, 4749, 4741, 63878, 63886, 5105, 76329, 76122, 76337, 5107, 76330, 76125, 
76338, 5108, 5091, 76099, 76124
27318, 4749, 4741, 63878, 63886, 4750, 4742, 63879, 63887, 5107, 76330, 76125, 76338, 5109, 76331, 76128, 
76339, 5110, 5093, 76102, 76127
27319, 4750, 4742, 63879, 63887, 4751, 4743, 63880, 63888, 5109, 76331, 76128, 76339, 5111, 76332, 76131, 
76340, 5112, 5095, 76105, 76130
27320, 4751, 4743, 63880, 63888, 4752, 4744, 63881, 63889, 5111, 76332, 76131, 76340, 5113, 76333, 76134, 
76341, 5114, 5097, 76108, 76133
27321, 4752, 4744, 63881, 63889, 4753, 4745, 63882, 63890, 5113, 76333, 76134, 76341, 5115, 76334, 76137, 
76342, 5116, 5099, 76111, 76136
27322, 4753, 4745, 63882, 63890, 4754, 4746, 63883, 63891, 5115, 76334, 76137, 76342, 5117, 76335, 76140, 
76343, 5118, 5101, 76114, 76139
27323, 4754, 4746, 63883, 63891, 298, 297, 26561, 26562, 5117, 76335, 76140, 76343, 320, 27573, 27550, 
27574, 5119, 5102, 76117, 76142
27324, 254, 253, 25066, 25067, 4755, 4747, 63884, 63892, 276, 26078, 26055, 26079, 5120, 76336, 76144, 
76344, 5121, 5104, 76118, 76143
27325, 4755, 4747, 63884, 63892, 4756, 4748, 63885, 63893, 5120, 76336, 76144, 76344, 5122, 76337, 76147, 
76345, 5123, 5106, 76121, 76146
27326, 4756, 4748, 63885, 63893, 4757, 4749, 63886, 63894, 5122, 76337, 76147, 76345, 5124, 76338, 76150, 
76346, 5125, 5108, 76124, 76149
27327, 4757, 4749, 63886, 63894, 4758, 4750, 63887, 63895, 5124, 76338, 76150, 76346, 5126, 76339, 76153, 
76347, 5127, 5110, 76127, 76152
27328, 4758, 4750, 63887, 63895, 4759, 4751, 63888, 63896, 5126, 76339, 76153, 76347, 5128, 76340, 76156, 
76348, 5129, 5112, 76130, 76155
27329, 4759, 4751, 63888, 63896, 4760, 4752, 63889, 63897, 5128, 76340, 76156, 76348, 5130, 76341, 76159, 
76349, 5131, 5114, 76133, 76158
27330, 4760, 4752, 63889, 63897, 4761, 4753, 63890, 63898, 5130, 76341, 76159, 76349, 5132, 76342, 76162, 
76350, 5133, 5116, 76136, 76161
27331, 4761, 4753, 63890, 63898, 4762, 4754, 63891, 63899, 5132, 76342, 76162, 76350, 5134, 76343, 76165, 
76351, 5135, 5118, 76139, 76164
27332, 4762, 4754, 63891, 63899, 299, 298, 26562, 26563, 5134, 76343, 76165, 76351, 321, 27574, 27552, 
27575, 5136, 5119, 76142, 76167
27333, 6, 254, 25067, 3191, 347, 4755, 63892, 28302, 277, 26079, 26057, 3214, 5137, 76344, 76168, 
28684, 356, 5121, 76143, 28667
27334, 347, 4755, 63892, 28302, 346, 4756, 63893, 28303, 5137, 76344, 76168, 28684, 5138, 76345, 76169, 
28685, 355, 5123, 76146, 28669
27335, 346, 4756, 63893, 28303, 345, 4757, 63894, 28304, 5138, 76345, 76169, 28685, 5139, 76346, 76170, 
28686, 354, 5125, 76149, 28671
27336, 345, 4757, 63894, 28304, 344, 4758, 63895, 28305, 5139, 76346, 76170, 28686, 5140, 76347, 76171, 
28687, 353, 5127, 76152, 28673
27337, 344, 4758, 63895, 28305, 343, 4759, 63896, 28306, 5140, 76347, 76171, 28687, 5141, 76348, 76172, 
28688, 352, 5129, 76155, 28675
27338, 343, 4759, 63896, 28306, 342, 4760, 63897, 28307, 5141, 76348, 76172, 28688, 5142, 76349, 76173, 
28689, 351, 5131, 76158, 28677
27339, 342, 4760, 63897, 28307, 341, 4761, 63898, 28308, 5142, 76349, 76173, 28689, 5143, 76350, 76174, 
28690, 350, 5133, 76161, 28679
27340, 341, 4761, 63898, 28308, 340, 4762, 63899, 28309, 5143, 76350, 76174, 28690, 5144, 76351, 76175, 
28691, 349, 5135, 76164, 28681
27341, 340, 4762, 63899, 28309, 8, 299, 26563, 3326, 5144, 76351, 76175, 28691, 322, 27575, 27553, 
3349, 348, 5136, 76167, 28683
*ELEMENT, type=C3D20, ELSET=Volume10
27342, 29250, 3429, 5, 233, 76352, 29428, 330, 4587, 29272, 3430, 255, 29273, 76529, 29436, 4763, 
76530, 76528, 29437, 339, 4764
27343, 76352, 29428, 330, 4587, 76353, 29429, 329, 4588, 76529, 29436, 4763, 76530, 76532, 29438, 4765, 
76533, 76531, 29439, 338, 4766
27344, 76353, 29429, 329, 4588, 76354, 29430, 328, 4589, 76532, 29438, 4765, 76533, 76535, 29440, 4767, 
76536, 76534, 29441, 337, 4768
27345, 76354, 29430, 328, 4589, 76355, 29431, 327, 4590, 76535, 29440, 4767, 76536, 76538, 29442, 4769, 
76539, 76537, 29443, 336, 4770
27346, 76355, 29431, 327, 4590, 76356, 29432, 326, 4591, 76538, 29442, 4769, 76539, 76541, 29444, 4771, 
76542, 76540, 29445, 335, 4772
27347, 76356, 29432, 326, 4591, 76357, 29433, 325, 4592, 76541, 29444, 4771, 76542, 76544, 29446, 4773, 
76545, 76543, 29447, 334, 4774
27348, 76357, 29433, 325, 4592, 76358, 29434, 324, 4593, 76544, 29446, 4773, 76545, 76547, 29448, 4775, 
76548, 76546, 29449, 333, 4776
27349, 76358, 29434, 324, 4593, 76359, 29435, 323, 4594, 76547, 29448, 4775, 76548, 76550, 29450, 4777, 
76551, 76549, 29451, 332, 4778
27350, 76359, 29435, 323, 4594, 29339, 3480, 7, 278, 76550, 29450, 4777, 76551, 29362, 3481, 300, 
29361, 76552, 29452, 331, 4779
27351, 29251, 29250, 233, 234, 76360, 76352, 4587, 4595, 29274, 29273, 256, 29275, 76554, 76530, 4780, 
76555, 76553, 76528, 4764, 4781
27352, 76360, 76352, 4587, 4595, 76361, 76353, 4588, 4596, 76554, 76530, 4780, 76555, 76557, 76533, 4782, 
76558, 76556, 76531, 4766, 4783
27353, 76361, 76353, 4588, 4596, 76362, 76354, 4589, 4597, 76557, 76533, 4782, 76558, 76560, 76536, 4784, 
76561, 76559, 76534, 4768, 4785
27354, 76362, 76354, 4589, 4597, 76363, 76355, 4590, 4598, 76560, 76536, 4784, 76561, 76563, 76539, 4786, 
76564, 76562, 76537, 4770, 4787
27355, 76363, 76355, 4590, 4598, 76364, 76356, 4591, 4599, 76563, 76539, 4786, 76564, 76566, 76542, 4788, 
76567, 76565, 76540, 4772, 4789
27356, 76364, 76356, 4591, 4599, 76365, 76357, 4592, 4600, 76566, 76542, 4788, 76567, 76569, 76545, 4790, 
76570, 76568, 76543, 4774, 4791
27357, 76365, 76357, 4592, 4600, 76366, 76358, 4593, 4601, 76569, 76545, 4790, 76570, 76572, 76548, 4792, 
76573, 76571, 76546, 4776, 4793
27358, 76366, 76358, 4593, 4601, 76367, 76359, 4594, 4602, 76572, 76548, 4792, 76573, 76575, 76551, 4794, 
76576, 76574, 76549, 4778, 4795
27359, 76367, 76359, 4594, 4602, 29340, 29339, 278, 279, 76575, 76551, 4794, 76576, 29364, 29361, 301, 
29363, 76577, 76552, 4779, 4796
27360, 29252, 29251, 234, 235, 76368, 76360, 4595, 4603, 29276, 29275, 257, 29277, 76579, 76555, 4797, 
76580, 76578, 76553, 4781, 4798
27361, 76368, 76360, 4595, 4603, 76369, 76361, 4596, 4604, 76579, 76555, 4797, 76580, 76582, 76558, 4799, 
76583, 76581, 76556, 4783, 4800
27362, 76369, 76361, 4596, 4604, 76370, 76362, 4597, 4605, 76582, 76558, 4799, 76583, 76585, 76561, 4801, 
76586, 76584, 76559, 4785, 4802
27363, 76370, 76362, 4597, 4605, 76371, 76363, 4598, 4606, 76585, 76561, 4801, 76586, 76588, 76564, 4803, 
76589, 76587, 76562, 4787, 4804
27364, 76371, 76363, 4598, 4606, 76372, 76364, 4599, 4607, 76588, 76564, 4803, 76589, 76591, 76567, 4805, 
76592, 76590, 76565, 4789, 4806
27365, 76372, 76364, 4599, 4607, 76373, 76365, 4600, 4608, 76591, 76567, 4805, 76592, 76594, 76570, 4807, 
76595, 76593, 76568, 4791, 4808
27366, 76373, 76365, 4600, 4608, 76374, 76366, 4601, 4609, 76594, 76570, 4807, 76595, 76597, 76573, 4809, 
76598, 76596, 76571, 4793, 4810
27367, 76374, 76366, 4601, 4609, 76375, 76367, 4602, 4610, 76597, 76573, 4809, 76598, 76600, 76576, 4811, 
76601, 76599, 76574, 4795, 4812
27368, 76375, 76367, 4602, 4610, 29341, 29340, 279, 280, 76600, 76576, 4811, 76601, 29366, 29363, 302, 
29365, 76602, 76577, 4796, 4813
27369, 29253, 29252, 235, 236, 76376, 76368, 4603, 4611, 29278, 29277, 258, 29279, 76604, 76580, 4814, 
76605, 76603, 76578, 4798, 4815
27370, 76376, 76368, 4603, 4611, 76377, 76369, 4604, 4612, 76604, 76580, 4814, 76605, 76607, 76583, 4816, 
76608, 76606, 76581, 4800, 4817
27371, 76377, 76369, 4604, 4612, 76378, 76370, 4605, 4613, 76607, 76583, 4816, 76608, 76610, 76586, 4818, 
76611, 76609, 76584, 4802, 4819
27372, 76378, 76370, 4605, 4613, 76379, 76371, 4606, 4614, 76610, 76586, 4818, 76611, 76613, 76589, 4820, 
76614, 76612, 76587, 4804, 4821
27373, 76379, 76371, 4606, 4614, 76380, 76372, 4607, 4615, 76613, 76589, 4820, 76614, 76616, 76592, 4822, 
76617, 76615, 76590, 4806, 4823
27374, 76380, 76372, 4607, 4615, 76381, 76373, 4608, 4616, 76616, 76592, 4822, 76617, 76619, 76595, 4824, 
76620, 76618, 76593, 4808, 4825
27375, 76381, 76373, 4608, 4616, 76382, 76374, 4609, 4617, 76619, 76595, 4824, 76620, 76622, 76598, 4826, 
76623, 76621, 76596, 4810, 4827
27376, 76382, 76374, 4609, 4617, 76383, 76375, 4610, 4618, 76622, 76598, 4826, 76623, 76625, 76601, 4828, 
76626, 76624, 76599, 4812, 4829
27377, 76383, 76375, 4610, 4618, 29342, 29341, 280, 281, 76625, 76601, 4828, 76626, 29368, 29365, 303, 
29367, 76627, 76602, 4813, 4830
27378, 29254, 29253, 236, 237, 76384, 76376, 4611, 4619, 29280, 29279, 259, 29281, 76629, 76605, 4831, 
76630, 76628, 76603, 4815, 4832
27379, 76384, 76376, 4611, 4619, 76385, 76377, 4612, 4620, 76629, 76605, 4831, 76630, 76632, 76608, 4833, 
76633, 76631, 76606, 4817, 4834
27380, 76385, 76377, 4612, 4620, 76386, 76378, 4613, 4621, 76632, 76608, 4833, 76633, 76635, 76611, 4835, 
76636, 76634, 76609, 4819, 4836
27381, 76386, 76378, 4613, 4621, 76387, 76379, 4614, 4622, 76635, 76611, 4835, 76636, 76638, 76614, 4837, 
76639, 76637, 76612, 4821, 4838
27382, 76387, 76379, 4614, 4622, 76388, 76380, 4615, 4623, 76638, 76614, 4837, 76639, 76641, 76617, 4839, 
76642, 76640, 76615, 4823, 4840
27383, 76388, 76380, 4615, 4623, 76389, 76381, 4616, 4624, 76641, 76617, 4839, 76642, 76644, 76620, 4841, 
76645, 76643, 76618, 4825, 4842
27384, 76389, 76381, 4616, 4624, 76390, 76382, 4617, 4625, 76644, 76620, 4841, 76645, 76647, 76623, 4843, 
76648, 76646, 76621, 4827, 4844
27385, 76390, 76382, 4617, 4625, 76391, 76383, 4618, 4626, 76647, 76623, 4843, 76648, 76650, 76626, 4845, 
76651, 76649, 76624, 4829, 4846
27386, 76391, 76383, 4618, 4626, 29343, 29342, 281, 282, 76650, 76626, 4845, 76651, 29370, 29367, 304, 
29369, 76652, 76627, 4830, 4847
27387, 29255, 29254, 237, 238, 76392, 76384, 4619, 4627, 29282, 29281, 260, 29283, 76654, 76630, 4848, 
76655, 76653, 76628, 4832, 4849
27388, 76392, 76384, 4619, 4627, 76393, 76385, 4620, 4628, 76654, 76630, 4848, 76655, 76657, 76633, 4850, 
76658, 76656, 76631, 4834, 4851
27389, 76393, 76385, 4620, 4628, 76394, 76386, 4621, 4629, 76657, 76633, 4850, 76658, 76660, 76636, 4852, 
76661, 76659, 76634, 4836, 4853
27390, 76394, 76386, 4621, 4629, 76395, 76387, 4622, 4630, 76660, 76636, 4852, 76661, 76663, 76639, 4854, 
76664, 76662, 76637, 4838, 4855
27391, 76395, 76387, 4622, 4630, 76396, 76388, 4623, 4631, 76663, 76639, 4854, 76664, 76666, 76642, 4856, 
76667, 76665, 76640, 4840, 4857
27392, 76396, 76388, 4623, 4631, 76397, 76389, 4624, 4632, 76666, 76642, 4856, 76667, 76669, 76645, 4858, 
76670, 76668, 76643, 4842, 4859
27393, 76397, 76389, 4624, 4632, 76398, 76390, 4625, 4633, 76669, 76645, 4858, 76670, 76672, 76648, 4860, 
76673, 76671, 76646, 4844, 4861
27394, 76398, 76390, 4625, 4633, 76399, 76391, 4626, 4634, 76672, 76648, 4860, 76673, 76675, 76651, 4862, 
76676, 76674, 76649, 4846, 4863
27395, 76399, 76391, 4626, 4634, 29344, 29343, 282, 283, 76675, 76651, 4862, 76676, 29372, 29369, 305, 
29371, 76677, 76652, 4847, 4864
27396, 29256, 29255, 238, 239, 76400, 76392, 4627, 4635, 29284, 29283, 261, 29285, 76679, 76655, 4865, 
76680, 76678, 76653, 4849, 4866
27397, 76400, 76392, 4627, 4635, 76401, 76393, 4628, 4636, 76679, 76655, 4865, 76680, 76682, 76658, 4867, 
76683, 76681, 76656, 4851, 4868
27398, 76401, 76393, 4628, 4636, 76402, 76394, 4629, 4637, 76682, 76658, 4867, 76683, 76685, 76661, 4869, 
76686, 76684, 76659, 4853, 4870
27399, 76402, 76394, 4629, 4637, 76403, 76395, 4630, 4638, 76685, 76661, 4869, 76686, 76688, 76664, 4871, 
76689, 76687, 76662, 4855, 4872
27400, 76403, 76395, 4630, 4638, 76404, 76396, 4631, 4639, 76688, 76664, 4871, 76689, 76691, 76667, 4873, 
76692, 76690, 76665, 4857, 4874
27401, 76404, 76396, 4631, 4639, 76405, 76397, 4632, 4640, 76691, 76667, 4873, 76692, 76694, 76670, 4875, 
76695, 76693, 76668, 4859, 4876
27402, 76405, 76397, 4632, 4640, 76406, 76398, 4633, 4641, 76694, 76670, 4875, 76695, 76697, 76673, 4877, 
76698, 76696, 76671, 4861, 4878
27403, 76406, 76398, 4633, 4641, 76407, 76399, 4634, 4642, 76697, 76673, 4877, 76698, 76700, 76676, 4879, 
76701, 76699, 76674, 4863, 4880
27404, 76407, 76399, 4634, 4642, 29345, 29344, 283, 284, 76700, 76676, 4879, 76701, 29374, 29371, 306, 
29373, 76702, 76677, 4864, 4881
27405, 29257, 29256, 239, 240, 76408, 76400, 4635, 4643, 29286, 29285, 262, 29287, 76704, 76680, 4882, 
76705, 76703, 76678, 4866, 4883
27406, 76408, 76400, 4635, 4643, 76409, 76401, 4636, 4644, 76704, 76680, 4882, 76705, 76707, 76683, 4884, 
76708, 76706, 76681, 4868, 4885
27407, 76409, 76401, 4636, 4644, 76410, 76402, 4637, 4645, 76707, 76683, 4884, 76708, 76710, 76686, 4886, 
76711, 76709, 76684, 4870, 4887
27408, 76410, 76402, 4637, 4645, 76411, 76403, 4638, 4646, 76710, 76686, 4886, 76711, 76713, 76689, 4888, 
76714, 76712, 76687, 4872, 4889
27409, 76411, 76403, 4638, 4646, 76412, 76404, 4639, 4647, 76713, 76689, 4888, 76714, 76716, 76692, 4890, 
76717, 76715, 76690, 4874, 4891
27410, 76412, 76404, 4639, 4647, 76413, 76405, 4640, 4648, 76716, 76692, 4890, 76717, 76719, 76695, 4892, 
76720, 76718, 76693, 4876, 4893
27411, 76413, 76405, 4640, 4648, 76414, 76406, 4641, 4649, 76719, 76695, 4892, 76720, 76722, 76698, 4894, 
76723, 76721, 76696, 4878, 4895
27412, 76414, 76406, 4641, 4649, 76415, 76407, 4642, 4650, 76722, 76698, 4894, 76723, 76725, 76701, 4896, 
76726, 76724, 76699, 4880, 4897
27413, 76415, 76407, 4642, 4650, 29346, 29345, 284, 285, 76725, 76701, 4896, 76726, 29376, 29373, 307, 
29375, 76727, 76702, 4881, 4898
27414, 29258, 29257, 240, 241, 76416, 76408, 4643, 4651, 29288, 29287, 263, 29289, 76729, 76705, 4899, 
76730, 76728, 76703, 4883, 4900
27415, 76416, 76408, 4643, 4651, 76417, 76409, 4644, 4652, 76729, 76705, 4899, 76730, 76732, 76708, 4901, 
76733, 76731, 76706, 4885, 4902
27416, 76417, 76409, 4644, 4652, 76418, 76410, 4645, 4653, 76732, 76708, 4901, 76733, 76735, 76711, 4903, 
76736, 76734, 76709, 4887, 4904
27417, 76418, 76410, 4645, 4653, 76419, 76411, 4646, 4654, 76735, 76711, 4903, 76736, 76738, 76714, 4905, 
76739, 76737, 76712, 4889, 4906
27418, 76419, 76411, 4646, 4654, 76420, 76412, 4647, 4655, 76738, 76714, 4905, 76739, 76741, 76717, 4907, 
76742, 76740, 76715, 4891, 4908
27419, 76420, 76412, 4647, 4655, 76421, 76413, 4648, 4656, 76741, 76717, 4907, 76742, 76744, 76720, 4909, 
76745, 76743, 76718, 4893, 4910
27420, 76421, 76413, 4648, 4656, 76422, 76414, 4649, 4657, 76744, 76720, 4909, 76745, 76747, 76723, 4911, 
76748, 76746, 76721, 4895, 4912
27421, 76422, 76414, 4649, 4657, 76423, 76415, 4650, 4658, 76747, 76723, 4911, 76748, 76750, 76726, 4913, 
76751, 76749, 76724, 4897, 4914
27422, 76423, 76415, 4650, 4658, 29347, 29346, 285, 286, 76750, 76726, 4913, 76751, 29378, 29375, 308, 
29377, 76752, 76727, 4898, 4915
27423, 29259, 29258, 241, 242, 76424, 76416, 4651, 4659, 29290, 29289, 264, 29291, 76754, 76730, 4916, 
76755, 76753, 76728, 4900, 4917
27424, 76424, 76416, 4651, 4659, 76425, 76417, 4652, 4660, 76754, 76730, 4916, 76755, 76757, 76733, 4918, 
76758, 76756, 76731, 4902, 4919
27425, 76425, 76417, 4652, 4660, 76426, 76418, 4653, 4661, 76757, 76733, 4918, 76758, 76760, 76736, 4920, 
76761, 76759, 76734, 4904, 4921
27426, 76426, 76418, 4653, 4661, 76427, 76419, 4654, 4662, 76760, 76736, 4920, 76761, 76763, 76739, 4922, 
76764, 76762, 76737, 4906, 4923
27427, 76427, 76419, 4654, 4662, 76428, 76420, 4655, 4663, 76763, 76739, 4922, 76764, 76766, 76742, 4924, 
76767, 76765, 76740, 4908, 4925
27428, 76428, 76420, 4655, 4663, 76429, 76421, 4656, 4664, 76766, 76742, 4924, 76767, 76769, 76745, 4926, 
76770, 76768, 76743, 4910, 4927
27429, 76429, 76421, 4656, 4664, 76430, 76422, 4657, 4665, 76769, 76745, 4926, 76770, 76772, 76748, 4928, 
76773, 76771, 76746, 4912, 4929
27430, 76430, 76422, 4657, 4665, 76431, 76423, 4658, 4666, 76772, 76748, 4928, 76773, 76775, 76751, 4930, 
76776, 76774, 76749, 4914, 4931
27431, 76431, 76423, 4658, 4666, 29348, 29347, 286, 287, 76775, 76751, 4930, 76776, 29380, 29377, 309, 
29379, 76777, 76752, 4915, 4932
27432, 29260, 29259, 242, 243, 76432, 76424, 4659, 4667, 29292, 29291, 265, 29293, 76779, 76755, 4933, 
76780, 76778, 76753, 4917, 4934
27433, 76432, 76424, 4659, 4667, 76433, 76425, 4660, 4668, 76779, 76755, 4933, 76780, 76782, 76758, 4935, 
76783, 76781, 76756, 4919, 4936
27434, 76433, 76425, 4660, 4668, 76434, 76426, 4661, 4669, 76782, 76758, 4935, 76783, 76785, 76761, 4937, 
76786, 76784, 76759, 4921, 4938
27435, 76434, 76426, 4661, 4669, 76435, 76427, 4662, 4670, 76785, 76761, 4937, 76786, 76788, 76764, 4939, 
76789, 76787, 76762, 4923, 4940
27436, 76435, 76427, 4662, 4670, 76436, 76428, 4663, 4671, 76788, 76764, 4939, 76789, 76791, 76767, 4941, 
76792, 76790, 76765, 4925, 4942
27437, 76436, 76428, 4663, 4671, 76437, 76429, 4664, 4672, 76791, 76767, 4941, 76792, 76794, 76770, 4943, 
76795, 76793, 76768, 4927, 4944
27438, 76437, 76429, 4664, 4672, 76438, 76430, 4665, 4673, 76794, 76770, 4943, 76795, 76797, 76773, 4945, 
76798, 76796, 76771, 4929, 4946
27439, 76438, 76430, 4665, 4673, 76439, 76431, 4666, 4674, 76797, 76773, 4945, 76798, 76800, 76776, 4947, 
76801, 76799, 76774, 4931, 4948
27440, 76439, 76431, 4666, 4674, 29349, 29348, 287, 288, 76800, 76776, 4947, 76801, 29382, 29379, 310, 
29381, 76802, 76777, 4932, 4949
27441, 29261, 29260, 243, 244, 76440, 76432, 4667, 4675, 29294, 29293, 266, 29295, 76804, 76780, 4950, 
76805, 76803, 76778, 4934, 4951
27442, 76440, 76432, 4667, 4675, 76441, 76433, 4668, 4676, 76804, 76780, 4950, 76805, 76807, 76783, 4952, 
76808, 76806, 76781, 4936, 4953
27443, 76441, 76433, 4668, 4676, 76442, 76434, 4669, 4677, 76807, 76783, 4952, 76808, 76810, 76786, 4954, 
76811, 76809, 76784, 4938, 4955
27444, 76442, 76434, 4669, 4677, 76443, 76435, 4670, 4678, 76810, 76786, 4954, 76811, 76813, 76789, 4956, 
76814, 76812, 76787, 4940, 4957
27445, 76443, 76435, 4670, 4678, 76444, 76436, 4671, 4679, 76813, 76789, 4956, 76814, 76816, 76792, 4958, 
76817, 76815, 76790, 4942, 4959
27446, 76444, 76436, 4671, 4679, 76445, 76437, 4672, 4680, 76816, 76792, 4958, 76817, 76819, 76795, 4960, 
76820, 76818, 76793, 4944, 4961
27447, 76445, 76437, 4672, 4680, 76446, 76438, 4673, 4681, 76819, 76795, 4960, 76820, 76822, 76798, 4962, 
76823, 76821, 76796, 4946, 4963
27448, 76446, 76438, 4673, 4681, 76447, 76439, 4674, 4682, 76822, 76798, 4962, 76823, 76825, 76801, 4964, 
76826, 76824, 76799, 4948, 4965
27449, 76447, 76439, 4674, 4682, 29350, 29349, 288, 289, 76825, 76801, 4964, 76826, 29384, 29381, 311, 
29383, 76827, 76802, 4949, 4966
27450, 29262, 29261, 244, 245, 76448, 76440, 4675, 4683, 29296, 29295, 267, 29297, 76829, 76805, 4967, 
76830, 76828, 76803, 4951, 4968
27451, 76448, 76440, 4675, 4683, 76449, 76441, 4676, 4684, 76829, 76805, 4967, 76830, 76832, 76808, 4969, 
76833, 76831, 76806, 4953, 4970
27452, 76449, 76441, 4676, 4684, 76450, 76442, 4677, 4685, 76832, 76808, 4969, 76833, 76835, 76811, 4971, 
76836, 76834, 76809, 4955, 4972
27453, 76450, 76442, 4677, 4685, 76451, 76443, 4678, 4686, 76835, 76811, 4971, 76836, 76838, 76814, 4973, 
76839, 76837, 76812, 4957, 4974
27454, 76451, 76443, 4678, 4686, 76452, 76444, 4679, 4687, 76838, 76814, 4973, 76839, 76841, 76817, 4975, 
76842, 76840, 76815, 4959, 4976
27455, 76452, 76444, 4679, 4687, 76453, 76445, 4680, 4688, 76841, 76817, 4975, 76842, 76844, 76820, 4977, 
76845, 76843, 76818, 4961, 4978
27456, 76453, 76445, 4680, 4688, 76454, 76446, 4681, 4689, 76844, 76820, 4977, 76845, 76847, 76823, 4979, 
76848, 76846, 76821, 4963, 4980
27457, 76454, 76446, 4681, 4689, 76455, 76447, 4682, 4690, 76847, 76823, 4979, 76848, 76850, 76826, 4981, 
76851, 76849, 76824, 4965, 4982
27458, 76455, 76447, 4682, 4690, 29351, 29350, 289, 290, 76850, 76826, 4981, 76851, 29386, 29383, 312, 
29385, 76852, 76827, 4966, 4983
27459, 29263, 29262, 245, 246, 76456, 76448, 4683, 4691, 29298, 29297, 268, 29299, 76854, 76830, 4984, 
76855, 76853, 76828, 4968, 4985
27460, 76456, 76448, 4683, 4691, 76457, 76449, 4684, 4692, 76854, 76830, 4984, 76855, 76857, 76833, 4986, 
76858, 76856, 76831, 4970, 4987
27461, 76457, 76449, 4684, 4692, 76458, 76450, 4685, 4693, 76857, 76833, 4986, 76858, 76860, 76836, 4988, 
76861, 76859, 76834, 4972, 4989
27462, 76458, 76450, 4685, 4693, 76459, 76451, 4686, 4694, 76860, 76836, 4988, 76861, 76863, 76839, 4990, 
76864, 76862, 76837, 4974, 4991
27463, 76459, 76451, 4686, 4694, 76460, 76452, 4687, 4695, 76863, 76839, 4990, 76864, 76866, 76842, 4992, 
76867, 76865, 76840, 4976, 4993
27464, 76460, 76452, 4687, 4695, 76461, 76453, 4688, 4696, 76866, 76842, 4992, 76867, 76869, 76845, 4994, 
76870, 76868, 76843, 4978, 4995
27465, 76461, 76453, 4688, 4696, 76462, 76454, 4689, 4697, 76869, 76845, 4994, 76870, 76872, 76848, 4996, 
76873, 76871, 76846, 4980, 4997
27466, 76462, 76454, 4689, 4697, 76463, 76455, 4690, 4698, 76872, 76848, 4996, 76873, 76875, 76851, 4998, 
76876, 76874, 76849, 4982, 4999
27467, 76463, 76455, 4690, 4698, 29352, 29351, 290, 291, 76875, 76851, 4998, 76876, 29388, 29385, 313, 
29387, 76877, 76852, 4983, 5000
27468, 29264, 29263, 246, 247, 76464, 76456, 4691, 4699, 29300, 29299, 269, 29301, 76879, 76855, 5001, 
76880, 76878, 76853, 4985, 5002
27469, 76464, 76456, 4691, 4699, 76465, 76457, 4692, 4700, 76879, 76855, 5001, 76880, 76882, 76858, 5003, 
76883, 76881, 76856, 4987, 5004
27470, 76465, 76457, 4692, 4700, 76466, 76458, 4693, 4701, 76882, 76858, 5003, 76883, 76885, 76861, 5005, 
76886, 76884, 76859, 4989, 5006
27471, 76466, 76458, 4693, 4701, 76467, 76459, 4694, 4702, 76885, 76861, 5005, 76886, 76888, 76864, 5007, 
76889, 76887, 76862, 4991, 5008
27472, 76467, 76459, 4694, 4702, 76468, 76460, 4695, 4703, 76888, 76864, 5007, 76889, 76891, 76867, 5009, 
76892, 76890, 76865, 4993, 5010
27473, 76468, 76460, 4695, 4703, 76469, 76461, 4696, 4704, 76891, 76867, 5009, 76892, 76894, 76870, 5011, 
76895, 76893, 76868, 4995, 5012
27474, 76469, 76461, 4696, 4704, 76470, 76462, 4697, 4705, 76894, 76870, 5011, 76895, 76897, 76873, 5013, 
76898, 76896, 76871, 4997, 5014
27475, 76470, 76462, 4697, 4705, 76471, 76463, 4698, 4706, 76897, 76873, 5013, 76898, 76900, 76876, 5015, 
76901, 76899, 76874, 4999, 5016
27476, 76471, 76463, 4698, 4706, 29353, 29352, 291, 292, 76900, 76876, 5015, 76901, 29390, 29387, 314, 
29389, 76902, 76877, 5000, 5017
27477, 29265, 29264, 247, 248, 76472, 76464, 4699, 4707, 29302, 29301, 270, 29303, 76904, 76880, 5018, 
76905, 76903, 76878, 5002, 5019
27478, 76472, 76464, 4699, 4707, 76473, 76465, 4700, 4708, 76904, 76880, 5018, 76905, 76907, 76883, 5020, 
76908, 76906, 76881, 5004, 5021
27479, 76473, 76465, 4700, 4708, 76474, 76466, 4701, 4709, 76907, 76883, 5020, 76908, 76910, 76886, 5022, 
76911, 76909, 76884, 5006, 5023
27480, 76474, 76466, 4701, 4709, 76475, 76467, 4702, 4710, 76910, 76886, 5022, 76911, 76913, 76889, 5024, 
76914, 76912, 76887, 5008, 5025
27481, 76475, 76467, 4702, 4710, 76476, 76468, 4703, 4711, 76913, 76889, 5024, 76914, 76916, 76892, 5026, 
76917, 76915, 76890, 5010, 5027
27482, 76476, 76468, 4703, 4711, 76477, 76469, 4704, 4712, 76916, 76892, 5026, 76917, 76919, 76895, 5028, 
76920, 76918, 76893, 5012, 5029
27483, 76477, 76469, 4704, 4712, 76478, 76470, 4705, 4713, 76919, 76895, 5028, 76920, 76922, 76898, 5030, 
76923, 76921, 76896, 5014, 5031
27484, 76478, 76470, 4705, 4713, 76479, 76471, 4706, 4714, 76922, 76898, 5030, 76923, 76925, 76901, 5032, 
76926, 76924, 76899, 5016, 5033
27485, 76479, 76471, 4706, 4714, 29354, 29353, 292, 293, 76925, 76901, 5032, 76926, 29392, 29389, 315, 
29391, 76927, 76902, 5017, 5034
27486, 29266, 29265, 248, 249, 76480, 76472, 4707, 4715, 29304, 29303, 271, 29305, 76929, 76905, 5035, 
76930, 76928, 76903, 5019, 5036
27487, 76480, 76472, 4707, 4715, 76481, 76473, 4708, 4716, 76929, 76905, 5035, 76930, 76932, 76908, 5037, 
76933, 76931, 76906, 5021, 5038
27488, 76481, 76473, 4708, 4716, 76482, 76474, 4709, 4717, 76932, 76908, 5037, 76933, 76935, 76911, 5039, 
76936, 76934, 76909, 5023, 5040
27489, 76482, 76474, 4709, 4717, 76483, 76475, 4710, 4718, 76935, 76911, 5039, 76936, 76938, 76914, 5041, 
76939, 76937, 76912, 5025, 5042
27490, 76483, 76475, 4710, 4718, 76484, 76476, 4711, 4719, 76938, 76914, 5041, 76939, 76941, 76917, 5043, 
76942, 76940, 76915, 5027, 5044
27491, 76484, 76476, 4711, 4719, 76485, 76477, 4712, 4720, 76941, 76917, 5043, 76942, 76944, 76920, 5045, 
76945, 76943, 76918, 5029, 5046
27492, 76485, 76477, 4712, 4720, 76486, 76478, 4713, 4721, 76944, 76920, 5045, 76945, 76947, 76923, 5047, 
76948, 76946, 76921, 5031, 5048
27493, 76486, 76478, 4713, 4721, 76487, 76479, 4714, 4722, 76947, 76923, 5047, 76948, 76950, 76926, 5049, 
76951, 76949, 76924, 5033, 5050
27494, 76487, 76479, 4714, 4722, 29355, 29354, 293, 294, 76950, 76926, 5049, 76951, 29394, 29391, 316, 
29393, 76952, 76927, 5034, 5051
27495, 29267, 29266, 249, 250, 76488, 76480, 4715, 4723, 29306, 29305, 272, 29307, 76954, 76930, 5052, 
76955, 76953, 76928, 5036, 5053
27496, 76488, 76480, 4715, 4723, 76489, 76481, 4716, 4724, 76954, 76930, 5052, 76955, 76957, 76933, 5054, 
76958, 76956, 76931, 5038, 5055
27497, 76489, 76481, 4716, 4724, 76490, 76482, 4717, 4725, 76957, 76933, 5054, 76958, 76960, 76936, 5056, 
76961, 76959, 76934, 5040, 5057
27498, 76490, 76482, 4717, 4725, 76491, 76483, 4718, 4726, 76960, 76936, 5056, 76961, 76963, 76939, 5058, 
76964, 76962, 76937, 5042, 5059
27499, 76491, 76483, 4718, 4726, 76492, 76484, 4719, 4727, 76963, 76939, 5058, 76964, 76966, 76942, 5060, 
76967, 76965, 76940, 5044, 5061
27500, 76492, 76484, 4719, 4727, 76493, 76485, 4720, 4728, 76966, 76942, 5060, 76967, 76969, 76945, 5062, 
76970, 76968, 76943, 5046, 5063
27501, 76493, 76485, 4720, 4728, 76494, 76486, 4721, 4729, 76969, 76945, 5062, 76970, 76972, 76948, 5064, 
76973, 76971, 76946, 5048, 5065
27502, 76494, 76486, 4721, 4729, 76495, 76487, 4722, 4730, 76972, 76948, 5064, 76973, 76975, 76951, 5066, 
76976, 76974, 76949, 5050, 5067
27503, 76495, 76487, 4722, 4730, 29356, 29355, 294, 295, 76975, 76951, 5066, 76976, 29396, 29393, 317, 
29395, 76977, 76952, 5051, 5068
27504, 29268, 29267, 250, 251, 76496, 76488, 4723, 4731, 29308, 29307, 273, 29309, 76979, 76955, 5069, 
76980, 76978, 76953, 5053, 5070
27505, 76496, 76488, 4723, 4731, 76497, 76489, 4724, 4732, 76979, 76955, 5069, 76980, 76982, 76958, 5071, 
76983, 76981, 76956, 5055, 5072
27506, 76497, 76489, 4724, 4732, 76498, 76490, 4725, 4733, 76982, 76958, 5071, 76983, 76985, 76961, 5073, 
76986, 76984, 76959, 5057, 5074
27507, 76498, 76490, 4725, 4733, 76499, 76491, 4726, 4734, 76985, 76961, 5073, 76986, 76988, 76964, 5075, 
76989, 76987, 76962, 5059, 5076
27508, 76499, 76491, 4726, 4734, 76500, 76492, 4727, 4735, 76988, 76964, 5075, 76989, 76991, 76967, 5077, 
76992, 76990, 76965, 5061, 5078
27509, 76500, 76492, 4727, 4735, 76501, 76493, 4728, 4736, 76991, 76967, 5077, 76992, 76994, 76970, 5079, 
76995, 76993, 76968, 5063, 5080
27510, 76501, 76493, 4728, 4736, 76502, 76494, 4729, 4737, 76994, 76970, 5079, 76995, 76997, 76973, 5081, 
76998, 76996, 76971, 5065, 5082
27511, 76502, 76494, 4729, 4737, 76503, 76495, 4730, 4738, 76997, 76973, 5081, 76998, 77000, 76976, 5083, 
77001, 76999, 76974, 5067, 5084
27512, 76503, 76495, 4730, 4738, 29357, 29356, 295, 296, 77000, 76976, 5083, 77001, 29398, 29395, 318, 
29397, 77002, 76977, 5068, 5085
27513, 29269, 29268, 251, 252, 76504, 76496, 4731, 4739, 29310, 29309, 274, 29311, 77004, 76980, 5086, 
77005, 77003, 76978, 5070, 5087
27514, 76504, 76496, 4731, 4739, 76505, 76497, 4732, 4740, 77004, 76980, 5086, 77005, 77007, 76983, 5088, 
77008, 77006, 76981, 5072, 5089
27515, 76505, 76497, 4732, 4740, 76506, 76498, 4733, 4741, 77007, 76983, 5088, 77008, 77010, 76986, 5090, 
77011, 77009, 76984, 5074, 5091
27516, 76506, 76498, 4733, 4741, 76507, 76499, 4734, 4742, 77010, 76986, 5090, 77011, 77013, 76989, 5092, 
77014, 77012, 76987, 5076, 5093
27517, 76507, 76499, 4734, 4742, 76508, 76500, 4735, 4743, 77013, 76989, 5092, 77014, 77016, 76992, 5094, 
77017, 77015, 76990, 5078, 5095
27518, 76508, 76500, 4735, 4743, 76509, 76501, 4736, 4744, 77016, 76992, 5094, 77017, 77019, 76995, 5096, 
77020, 77018, 76993, 5080, 5097
27519, 76509, 76501, 4736, 4744, 76510, 76502, 4737, 4745, 77019, 76995, 5096, 77020, 77022, 76998, 5098, 
77023, 77021, 76996, 5082, 5099
27520, 76510, 76502, 4737, 4745, 76511, 76503, 4738, 4746, 77022, 76998, 5098, 77023, 77025, 77001, 5100, 
77026, 77024, 76999, 5084, 5101
27521, 76511, 76503, 4738, 4746, 29358, 29357, 296, 297, 77025, 77001, 5100, 77026, 29400, 29397, 319, 
29399, 77027, 77002, 5085, 5102
27522, 29270, 29269, 252, 253, 76512, 76504, 4739, 4747, 29312, 29311, 275, 29313, 77029, 77005, 5103, 
77030, 77028, 77003, 5087, 5104
27523, 76512, 76504, 4739, 4747, 76513, 76505, 4740, 4748, 77029, 77005, 5103, 77030, 77032, 77008, 5105, 
77033, 77031, 77006, 5089, 5106
27524, 76513, 76505, 4740, 4748, 76514, 76506, 4741, 4749, 77032, 77008, 5105, 77033, 77035, 77011, 5107, 
77036, 77034, 77009, 5091, 5108
27525, 76514, 76506, 4741, 4749, 76515, 76507, 4742, 4750, 77035, 77011, 5107, 77036, 77038, 77014, 5109, 
77039, 77037, 77012, 5093, 5110
27526, 76515, 76507, 4742, 4750, 76516, 76508, 4743, 4751, 77038, 77014, 5109, 77039, 77041, 77017, 5111, 
77042, 77040, 77015, 5095, 5112
27527, 76516, 76508, 4743, 4751, 76517, 76509, 4744, 4752, 77041, 77017, 5111, 77042, 77044, 77020, 5113, 
77045, 77043, 77018, 5097, 5114
27528, 76517, 76509, 4744, 4752, 76518, 76510, 4745, 4753, 77044, 77020, 5113, 77045, 77047, 77023, 5115, 
77048, 77046, 77021, 5099, 5116
27529, 76518, 76510, 4745, 4753, 76519, 76511, 4746, 4754, 77047, 77023, 5115, 77048, 77050, 77026, 5117, 
77051, 77049, 77024, 5101, 5118
27530, 76519, 76511, 4746, 4754, 29359, 29358, 297, 298, 77050, 77026, 5117, 77051, 29402, 29399, 320, 
29401, 77052, 77027, 5102, 5119
27531, 29271, 29270, 253, 254, 76520, 76512, 4747, 4755, 29314, 29313, 276, 29315, 77054, 77030, 5120, 
77055, 77053, 77028, 5104, 5121
27532, 76520, 76512, 4747, 4755, 76521, 76513, 4748, 4756, 77054, 77030, 5120, 77055, 77057, 77033, 5122, 
77058, 77056, 77031, 5106, 5123
27533, 76521, 76513, 4748, 4756, 76522, 76514, 4749, 4757, 77057, 77033, 5122, 77058, 77060, 77036, 5124, 
77061, 77059, 77034, 5108, 5125
27534, 76522, 76514, 4749, 4757, 76523, 76515, 4750, 4758, 77060, 77036, 5124, 77061, 77063, 77039, 5126, 
77064, 77062, 77037, 5110, 5127
27535, 76523, 76515, 4750, 4758, 76524, 76516, 4751, 4759, 77063, 77039, 5126, 77064, 77066, 77042, 5128, 
77067, 77065, 77040, 5112, 5129
27536, 76524, 76516, 4751, 4759, 76525, 76517, 4752, 4760, 77066, 77042, 5128, 77067, 77069, 77045, 5130, 
77070, 77068, 77043, 5114, 5131
27537, 76525, 76517, 4752, 4760, 76526, 76518, 4753, 4761, 77069, 77045, 5130, 77070, 77072, 77048, 5132, 
77073, 77071, 77046, 5116, 5133
27538, 76526, 76518, 4753, 4761, 76527, 76519, 4754, 4762, 77072, 77048, 5132, 77073, 77075, 77051, 5134, 
77076, 77074, 77049, 5118, 5135
27539, 76527, 76519, 4754, 4762, 29360, 29359, 298, 299, 77075, 77051, 5134, 77076, 29404, 29401, 321, 
29403, 77077, 77052, 5119, 5136
27540, 3432, 29271, 254, 6, 29461, 76520, 4755, 347, 29316, 29315, 277, 3433, 77078, 77055, 5137, 
29470, 29469, 77053, 5121, 356
27541, 29461, 76520, 4755, 347, 29462, 76521, 4756, 346, 77078, 77055, 5137, 29470, 77079, 77058, 5138, 
29472, 29471, 77056, 5123, 355
27542, 29462, 76521, 4756, 346, 29463, 76522, 4757, 345, 77079, 77058, 5138, 29472, 77080, 77061, 5139, 
29474, 29473, 77059, 5125, 354
27543, 29463, 76522, 4757, 345, 29464, 76523, 4758, 344, 77080, 77061, 5139, 29474, 77081, 77064, 5140, 
29476, 29475, 77062, 5127, 353
27544, 29464, 76523, 4758, 344, 29465, 76524, 4759, 343, 77081, 77064, 5140, 29476, 77082, 77067, 5141, 
29478, 29477, 77065, 5129, 352
27545, 29465, 76524, 4759, 343, 29466, 76525, 4760, 342, 77082, 77067, 5141, 29478, 77083, 77070, 5142, 
29480, 29479, 77068, 5131, 351
27546, 29466, 76525, 4760, 342, 29467, 76526, 4761, 341, 77083, 77070, 5142, 29480, 77084, 77073, 5143, 
29482, 29481, 77071, 5133, 350
27547, 29467, 76526, 4761, 341, 29468, 76527, 4762, 340, 77084, 77073, 5143, 29482, 77085, 77076, 5144, 
29484, 29483, 77074, 5135, 349
27548, 29468, 76527, 4762, 340, 3483, 29360, 299, 8, 77085, 77076, 5144, 29484, 29405, 29403, 322, 
3484, 29485, 77077, 5136, 348
27549, 3435, 97, 3429, 29250, 29494, 3538, 29428, 76352, 3457, 3431, 29272, 29317, 29670, 29453, 76529, 
77086, 29671, 3547, 29437, 76528
27550, 29494, 3538, 29428, 76352, 29495, 3537, 29429, 76353, 29670, 29453, 76529, 77086, 29672, 29454, 76532, 
77087, 29673, 3546, 29439, 76531
27551, 29495, 3537, 29429, 76353, 29496, 3536, 29430, 76354, 29672, 29454, 76532, 77087, 29674, 29455, 76535, 
77088, 29675, 3545, 29441, 76534
27552, 29496, 3536, 29430, 76354, 29497, 3535, 29431, 76355, 29674, 29455, 76535, 77088, 29676, 29456, 76538, 
77089, 29677, 3544, 29443, 76537
27553, 29497, 3535, 29431, 76355, 29498, 3534, 29432, 76356, 29676, 29456, 76538, 77089, 29678, 29457, 76541, 
77090, 29679, 3543, 29445, 76540
27554, 29498, 3534, 29432, 76356, 29499, 3533, 29433, 76357, 29678, 29457, 76541, 77090, 29680, 29458, 76544, 
77091, 29681, 3542, 29447, 76543
27555, 29499, 3533, 29433, 76357, 29500, 3532, 29434, 76358, 29680, 29458, 76544, 77091, 29682, 29459, 76547, 
77092, 29683, 3541, 29449, 76546
27556, 29500, 3532, 29434, 76358, 29501, 3531, 29435, 76359, 29682, 29459, 76547, 77092, 29684, 29460, 76550, 
77093, 29685, 3540, 29451, 76549
27557, 29501, 3531, 29435, 76359, 3486, 99, 3480, 29339, 29684, 29460, 76550, 77093, 3508, 3482, 29362, 
29406, 29686, 3539, 29452, 76552
27558, 3436, 3435, 29250, 29251, 29502, 29494, 76352, 76360, 3458, 29317, 29274, 29318, 29687, 77086, 76554, 
77094, 29688, 29671, 76528, 76553
27559, 29502, 29494, 76352, 76360, 29503, 29495, 76353, 76361, 29687, 77086, 76554, 77094, 29689, 77087, 76557, 
77095, 29690, 29673, 76531, 76556
27560, 29503, 29495, 76353, 76361, 29504, 29496, 76354, 76362, 29689, 77087, 76557, 77095, 29691, 77088, 76560, 
77096, 29692, 29675, 76534, 76559
27561, 29504, 29496, 76354, 76362, 29505, 29497, 76355, 76363, 29691, 77088, 76560, 77096, 29693, 77089, 76563, 
77097, 29694, 29677, 76537, 76562
27562, 29505, 29497, 76355, 76363, 29506, 29498, 76356, 76364, 29693, 77089, 76563, 77097, 29695, 77090, 76566, 
77098, 29696, 29679, 76540, 76565
27563, 29506, 29498, 76356, 76364, 29507, 29499, 76357, 76365, 29695, 77090, 76566, 77098, 29697, 77091, 76569, 
77099, 29698, 29681, 76543, 76568
27564, 29507, 29499, 76357, 76365, 29508, 29500, 76358, 76366, 29697, 77091, 76569, 77099, 29699, 77092, 76572, 
77100, 29700, 29683, 76546, 76571
27565, 29508, 29500, 76358, 76366, 29509, 29501, 76359, 76367, 29699, 77092, 76572, 77100, 29701, 77093, 76575, 
77101, 29702, 29685, 76549, 76574
27566, 29509, 29501, 76359, 76367, 3487, 3486, 29339, 29340, 29701, 77093, 76575, 77101, 3509, 29406, 29364, 
29407, 29703, 29686, 76552, 76577
27567, 3437, 3436, 29251, 29252, 29510, 29502, 76360, 76368, 3459, 29318, 29276, 29319, 29704, 77094, 76579, 
77102, 29705, 29688, 76553, 76578
27568, 29510, 29502, 76360, 76368, 29511, 29503, 76361, 76369, 29704, 77094, 76579, 77102, 29706, 77095, 76582, 
77103, 29707, 29690, 76556, 76581
27569, 29511, 29503, 76361, 76369, 29512, 29504, 76362, 76370, 29706, 77095, 76582, 77103, 29708, 77096, 76585, 
77104, 29709, 29692, 76559, 76584
27570, 29512, 29504, 76362, 76370, 29513, 29505, 76363, 76371, 29708, 77096, 76585, 77104, 29710, 77097, 76588, 
77105, 29711, 29694, 76562, 76587
27571, 29513, 29505, 76363, 76371, 29514, 29506, 76364, 76372, 29710, 77097, 76588, 77105, 29712, 77098, 76591, 
77106, 29713, 29696, 76565, 76590
27572, 29514, 29506, 76364, 76372, 29515, 29507, 76365, 76373, 29712, 77098, 76591, 77106, 29714, 77099, 76594, 
77107, 29715, 29698, 76568, 76593
27573, 29515, 29507, 76365, 76373, 29516, 29508, 76366, 76374, 29714, 77099, 76594, 77107, 29716, 77100, 76597, 
77108, 29717, 29700, 76571, 76596
27574, 29516, 29508, 76366, 76374, 29517, 29509, 76367, 76375, 29716, 77100, 76597, 77108, 29718, 77101, 76600, 
77109, 29719, 29702, 76574, 76599
27575, 29517, 29509, 76367, 76375, 3488, 3487, 29340, 29341, 29718, 77101, 76600, 77109, 3510, 29407, 29366, 
29408, 29720, 29703, 76577, 76602
27576, 3438, 3437, 29252, 29253, 29518, 29510, 76368, 76376, 3460, 29319, 29278, 29320, 29721, 77102, 76604, 
77110, 29722, 29705, 76578, 76603
27577, 29518, 29510, 76368, 76376, 29519, 29511, 76369, 76377, 29721, 77102, 76604, 77110, 29723, 77103, 76607, 
77111, 29724, 29707, 76581, 76606
27578, 29519, 29511, 76369, 76377, 29520, 29512, 76370, 76378, 29723, 77103, 76607, 77111, 29725, 77104, 76610, 
77112, 29726, 29709, 76584, 76609
27579, 29520, 29512, 76370, 76378, 29521, 29513, 76371, 76379, 29725, 77104, 76610, 77112, 29727, 77105, 76613, 
77113, 29728, 29711, 76587, 76612
27580, 29521, 29513, 76371, 76379, 29522, 29514, 76372, 76380, 29727, 77105, 76613, 77113, 29729, 77106, 76616, 
77114, 29730, 29713, 76590, 76615
27581, 29522, 29514, 76372, 76380, 29523, 29515, 76373, 76381, 29729, 77106, 76616, 77114, 29731, 77107, 76619, 
77115, 29732, 29715, 76593, 76618
27582, 29523, 29515, 76373, 76381, 29524, 29516, 76374, 76382, 29731, 77107, 76619, 77115, 29733, 77108, 76622, 
77116, 29734, 29717, 76596, 76621
27583, 29524, 29516, 76374, 76382, 29525, 29517, 76375, 76383, 29733, 77108, 76622, 77116, 29735, 77109, 76625, 
77117, 29736, 29719, 76599, 76624
27584, 29525, 29517, 76375, 76383, 3489, 3488, 29341, 29342, 29735, 77109, 76625, 77117, 3511, 29408, 29368, 
29409, 29737, 29720, 76602, 76627
27585, 3439, 3438, 29253, 29254, 29526, 29518, 76376, 76384, 3461, 29320, 29280, 29321, 29738, 77110, 76629, 
77118, 29739, 29722, 76603, 76628
27586, 29526, 29518, 76376, 76384, 29527, 29519, 76377, 76385, 29738, 77110, 76629, 77118, 29740, 77111, 76632, 
77119, 29741, 29724, 76606, 76631
27587, 29527, 29519, 76377, 76385, 29528, 29520, 76378, 76386, 29740, 77111, 76632, 77119, 29742, 77112, 76635, 
77120, 29743, 29726, 76609, 76634
27588, 29528, 29520, 76378, 76386, 29529, 29521, 76379, 76387, 29742, 77112, 76635, 77120, 29744, 77113, 76638, 
77121, 29745, 29728, 76612, 76637
27589, 29529, 29521, 76379, 76387, 29530, 29522, 76380, 76388, 29744, 77113, 76638, 77121, 29746, 77114, 76641, 
77122, 29747, 29730, 76615, 76640
27590, 29530, 29522, 76380, 76388, 29531, 29523, 76381, 76389, 29746, 77114, 76641, 77122, 29748, 77115, 76644, 
77123, 29749, 29732, 76618, 76643
27591, 29531, 29523, 76381, 76389, 29532, 29524, 76382, 76390, 29748, 77115, 76644, 77123, 29750, 77116, 76647, 
77124, 29751, 29734, 76621, 76646
27592, 29532, 29524, 76382, 76390, 29533, 29525, 76383, 76391, 29750, 77116, 76647, 77124, 29752, 77117, 76650, 
77125, 29753, 29736, 76624, 76649
27593, 29533, 29525, 76383, 76391, 3490, 3489, 29342, 29343, 29752, 77117, 76650, 77125, 3512, 29409, 29370, 
29410, 29754, 29737, 76627, 76652
27594, 3440, 3439, 29254, 29255, 29534, 29526, 76384, 76392, 3462, 29321, 29282, 29322, 29755, 77118, 76654, 
77126, 29756, 29739, 76628, 76653
27595, 29534, 29526, 76384, 76392, 29535, 29527, 76385, 76393, 29755, 77118, 76654, 77126, 29757, 77119, 76657, 
77127, 29758, 29741, 76631, 76656
27596, 29535, 29527, 76385, 76393, 29536, 29528, 76386, 76394, 29757, 77119, 76657, 77127, 29759, 77120, 76660, 
77128, 29760, 29743, 76634, 76659
27597, 29536, 29528, 76386, 76394, 29537, 29529, 76387, 76395, 29759, 77120, 76660, 77128, 29761, 77121, 76663, 
77129, 29762, 29745, 76637, 76662
27598, 29537, 29529, 76387, 76395, 29538, 29530, 76388, 76396, 29761, 77121, 76663, 77129, 29763, 77122, 76666, 
77130, 29764, 29747, 76640, 76665
27599, 29538, 29530, 76388, 76396, 29539, 29531, 76389, 76397, 29763, 77122, 76666, 77130, 29765, 77123, 76669, 
77131, 29766, 29749, 76643, 76668
27600, 29539, 29531, 76389, 76397, 29540, 29532, 76390, 76398, 29765, 77123, 76669, 77131, 29767, 77124, 76672, 
77132, 29768, 29751, 76646, 76671
27601, 29540, 29532, 76390, 76398, 29541, 29533, 76391, 76399, 29767, 77124, 76672, 77132, 29769, 77125, 76675, 
77133, 29770, 29753, 76649, 76674
27602, 29541, 29533, 76391, 76399, 3491, 3490, 29343, 29344, 29769, 77125, 76675, 77133, 3513, 29410, 29372, 
29411, 29771, 29754, 76652, 76677
27603, 3441, 3440, 29255, 29256, 29542, 29534, 76392, 76400, 3463, 29322, 29284, 29323, 29772, 77126, 76679, 
77134, 29773, 29756, 76653, 76678
27604, 29542, 29534, 76392, 76400, 29543, 29535, 76393, 76401, 29772, 77126, 76679, 77134, 29774, 77127, 76682, 
77135, 29775, 29758, 76656, 76681
27605, 29543, 29535, 76393, 76401, 29544, 29536, 76394, 76402, 29774, 77127, 76682, 77135, 29776, 77128, 76685, 
77136, 29777, 29760, 76659, 76684
27606, 29544, 29536, 76394, 76402, 29545, 29537, 76395, 76403, 29776, 77128, 76685, 77136, 29778, 77129, 76688, 
77137, 29779, 29762, 76662, 76687
27607, 29545, 29537, 76395, 76403, 29546, 29538, 76396, 76404, 29778, 77129, 76688, 77137, 29780, 77130, 76691, 
77138, 29781, 29764, 76665, 76690
27608, 29546, 29538, 76396, 76404, 29547, 29539, 76397, 76405, 29780, 77130, 76691, 77138, 29782, 77131, 76694, 
77139, 29783, 29766, 76668, 76693
27609, 29547, 29539, 76397, 76405, 29548, 29540, 76398, 76406, 29782, 77131, 76694, 77139, 29784, 77132, 76697, 
77140, 29785, 29768, 76671, 76696
27610, 29548, 29540, 76398, 76406, 29549, 29541, 76399, 76407, 29784, 77132, 76697, 77140, 29786, 77133, 76700, 
77141, 29787, 29770, 76674, 76699
27611, 29549, 29541, 76399, 76407, 3492, 3491, 29344, 29345, 29786, 77133, 76700, 77141, 3514, 29411, 29374, 
29412, 29788, 29771, 76677, 76702
27612, 3442, 3441, 29256, 29257, 29550, 29542, 76400, 76408, 3464, 29323, 29286, 29324, 29789, 77134, 76704, 
77142, 29790, 29773, 76678, 76703
27613, 29550, 29542, 76400, 76408, 29551, 29543, 76401, 76409, 29789, 77134, 76704, 77142, 29791, 77135, 76707, 
77143, 29792, 29775, 76681, 76706
27614, 29551, 29543, 76401, 76409, 29552, 29544, 76402, 76410, 29791, 77135, 76707, 77143, 29793, 77136, 76710, 
77144, 29794, 29777, 76684, 76709
27615, 29552, 29544, 76402, 76410, 29553, 29545, 76403, 76411, 29793, 77136, 76710, 77144, 29795, 77137, 76713, 
77145, 29796, 29779, 76687, 76712
27616, 29553, 29545, 76403, 76411, 29554, 29546, 76404, 76412, 29795, 77137, 76713, 77145, 29797, 77138, 76716, 
77146, 29798, 29781, 76690, 76715
27617, 29554, 29546, 76404, 76412, 29555, 29547, 76405, 76413, 29797, 77138, 76716, 77146, 29799, 77139, 76719, 
77147, 29800, 29783, 76693, 76718
27618, 29555, 29547, 76405, 76413, 29556, 29548, 76406, 76414, 29799, 77139, 76719, 77147, 29801, 77140, 76722, 
77148, 29802, 29785, 76696, 76721
27619, 29556, 29548, 76406, 76414, 29557, 29549, 76407, 76415, 29801, 77140, 76722, 77148, 29803, 77141, 76725, 
77149, 29804, 29787, 76699, 76724
27620, 29557, 29549, 76407, 76415, 3493, 3492, 29345, 29346, 29803, 77141, 76725, 77149, 3515, 29412, 29376, 
29413, 29805, 29788, 76702, 76727
27621, 3443, 3442, 29257, 29258, 29558, 29550, 76408, 76416, 3465, 29324, 29288, 29325, 29806, 77142, 76729, 
77150, 29807, 29790, 76703, 76728
27622, 29558, 29550, 76408, 76416, 29559, 29551, 76409, 76417, 29806, 77142, 76729, 77150, 29808, 77143, 76732, 
77151, 29809, 29792, 76706, 76731
27623, 29559, 29551, 76409, 76417, 29560, 29552, 76410, 76418, 29808, 77143, 76732, 77151, 29810, 77144, 76735, 
77152, 29811, 29794, 76709, 76734
27624, 29560, 29552, 76410, 76418, 29561, 29553, 76411, 76419, 29810, 77144, 76735, 77152, 29812, 77145, 76738, 
77153, 29813, 29796, 76712, 76737
27625, 29561, 29553, 76411, 76419, 29562, 29554, 76412, 76420, 29812, 77145, 76738, 77153, 29814, 77146, 76741, 
77154, 29815, 29798, 76715, 76740
27626, 29562, 29554, 76412, 76420, 29563, 29555, 76413, 76421, 29814, 77146, 76741, 77154, 29816, 77147, 76744, 
77155, 29817, 29800, 76718, 76743
27627, 29563, 29555, 76413, 76421, 29564, 29556, 76414, 76422, 29816, 77147, 76744, 77155, 29818, 77148, 76747, 
77156, 29819, 29802, 76721, 76746
27628, 29564, 29556, 76414, 76422, 29565, 29557, 76415, 76423, 29818, 77148, 76747, 77156, 29820, 77149, 76750, 
77157, 29821, 29804, 76724, 76749
27629, 29565, 29557, 76415, 76423, 3494, 3493, 29346, 29347, 29820, 77149, 76750, 77157, 3516, 29413, 29378, 
29414, 29822, 29805, 76727, 76752
27630, 3444, 3443, 29258, 29259, 29566, 29558, 76416, 76424, 3466, 29325, 29290, 29326, 29823, 77150, 76754, 
77158, 29824, 29807, 76728, 76753
27631, 29566, 29558, 76416, 76424, 29567, 29559, 76417, 76425, 29823, 77150, 76754, 77158, 29825, 77151, 76757, 
77159, 29826, 29809, 76731, 76756
27632, 29567, 29559, 76417, 76425, 29568, 29560, 76418, 76426, 29825, 77151, 76757, 77159, 29827, 77152, 76760, 
77160, 29828, 29811, 76734, 76759
27633, 29568, 29560, 76418, 76426, 29569, 29561, 76419, 76427, 29827, 77152, 76760, 77160, 29829, 77153, 76763, 
77161, 29830, 29813, 76737, 76762
27634, 29569, 29561, 76419, 76427, 29570, 29562, 76420, 76428, 29829, 77153, 76763, 77161, 29831, 77154, 76766, 
77162, 29832, 29815, 76740, 76765
27635, 29570, 29562, 76420, 76428, 29571, 29563, 76421, 76429, 29831, 77154, 76766, 77162, 29833, 77155, 76769, 
77163, 29834, 29817, 76743, 76768
27636, 29571, 29563, 76421, 76429, 29572, 29564, 76422, 76430, 29833, 77155, 76769, 77163, 29835, 77156, 76772, 
77164, 29836, 29819, 76746, 76771
27637, 29572, 29564, 76422, 76430, 29573, 29565, 76423, 76431, 29835, 77156, 76772, 77164, 29837, 77157, 76775, 
77165, 29838, 29821, 76749, 76774
27638, 29573, 29565, 76423, 76431, 3495, 3494, 29347, 29348, 29837, 77157, 76775, 77165, 3517, 29414, 29380, 
29415, 29839, 29822, 76752, 76777
27639, 3445, 3444, 29259, 29260, 29574, 29566, 76424, 76432, 3467, 29326, 29292, 29327, 29840, 77158, 76779, 
77166, 29841, 29824, 76753, 76778
27640, 29574, 29566, 76424, 76432, 29575, 29567, 76425, 76433, 29840, 77158, 76779, 77166, 29842, 77159, 76782, 
77167, 29843, 29826, 76756, 76781
27641, 29575, 29567, 76425, 76433, 29576, 29568, 76426, 76434, 29842, 77159, 76782, 77167, 29844, 77160, 76785, 
77168, 29845, 29828, 76759, 76784
27642, 29576, 29568, 76426, 76434, 29577, 29569, 76427, 76435, 29844, 77160, 76785, 77168, 29846, 77161, 76788, 
77169, 29847, 29830, 76762, 76787
27643, 29577, 29569, 76427, 76435, 29578, 29570, 76428, 76436, 29846, 77161, 76788, 77169, 29848, 77162, 76791, 
77170, 29849, 29832, 76765, 76790
27644, 29578, 29570, 76428, 76436, 29579, 29571, 76429, 76437, 29848, 77162, 76791, 77170, 29850, 77163, 76794, 
77171, 29851, 29834, 76768, 76793
27645, 29579, 29571, 76429, 76437, 29580, 29572, 76430, 76438, 29850, 77163, 76794, 77171, 29852, 77164, 76797, 
77172, 29853, 29836, 76771, 76796
27646, 29580, 29572, 76430, 76438, 29581, 29573, 76431, 76439, 29852, 77164, 76797, 77172, 29854, 77165, 76800, 
77173, 29855, 29838, 76774, 76799
27647, 29581, 29573, 76431, 76439, 3496, 3495, 29348, 29349, 29854, 77165, 76800, 77173, 3518, 29415, 29382, 
29416, 29856, 29839, 76777, 76802
27648, 3446, 3445, 29260, 29261, 29582, 29574, 76432, 76440, 3468, 29327, 29294, 29328, 29857, 77166, 76804, 
77174, 29858, 29841, 76778, 76803
27649, 29582, 29574, 76432, 76440, 29583, 29575, 76433, 76441, 29857, 77166, 76804, 77174, 29859, 77167, 76807, 
77175, 29860, 29843, 76781, 76806
27650, 29583, 29575, 76433, 76441, 29584, 29576, 76434, 76442, 29859, 77167, 76807, 77175, 29861, 77168, 76810, 
77176, 29862, 29845, 76784, 76809
27651, 29584, 29576, 76434, 76442, 29585, 29577, 76435, 76443, 29861, 77168, 76810, 77176, 29863, 77169, 76813, 
77177, 29864, 29847, 76787, 76812
27652, 29585, 29577, 76435, 76443, 29586, 29578, 76436, 76444, 29863, 77169, 76813, 77177, 29865, 77170, 76816, 
77178, 29866, 29849, 76790, 76815
27653, 29586, 29578, 76436, 76444, 29587, 29579, 76437, 76445, 29865, 77170, 76816, 77178, 29867, 77171, 76819, 
77179, 29868, 29851, 76793, 76818
27654, 29587, 29579, 76437, 76445, 29588, 29580, 76438, 76446, 29867, 77171, 76819, 77179, 29869, 77172, 76822, 
77180, 29870, 29853, 76796, 76821
27655, 29588, 29580, 76438, 76446, 29589, 29581, 76439, 76447, 29869, 77172, 76822, 77180, 29871, 77173, 76825, 
77181, 29872, 29855, 76799, 76824
27656, 29589, 29581, 76439, 76447, 3497, 3496, 29349, 29350, 29871, 77173, 76825, 77181, 3519, 29416, 29384, 
29417, 29873, 29856, 76802, 76827
27657, 3447, 3446, 29261, 29262, 29590, 29582, 76440, 76448, 3469, 29328, 29296, 29329, 29874, 77174, 76829, 
77182, 29875, 29858, 76803, 76828
27658, 29590, 29582, 76440, 76448, 29591, 29583, 76441, 76449, 29874, 77174, 76829, 77182, 29876, 77175, 76832, 
77183, 29877, 29860, 76806, 76831
27659, 29591, 29583, 76441, 76449, 29592, 29584, 76442, 76450, 29876, 77175, 76832, 77183, 29878, 77176, 76835, 
77184, 29879, 29862, 76809, 76834
27660, 29592, 29584, 76442, 76450, 29593, 29585, 76443, 76451, 29878, 77176, 76835, 77184, 29880, 77177, 76838, 
77185, 29881, 29864, 76812, 76837
27661, 29593, 29585, 76443, 76451, 29594, 29586, 76444, 76452, 29880, 77177, 76838, 77185, 29882, 77178, 76841, 
77186, 29883, 29866, 76815, 76840
27662, 29594, 29586, 76444, 76452, 29595, 29587, 76445, 76453, 29882, 77178, 76841, 77186, 29884, 77179, 76844, 
77187, 29885, 29868, 76818, 76843
27663, 29595, 29587, 76445, 76453, 29596, 29588, 76446, 76454, 29884, 77179, 76844, 77187, 29886, 77180, 76847, 
77188, 29887, 29870, 76821, 76846
27664, 29596, 29588, 76446, 76454, 29597, 29589, 76447, 76455, 29886, 77180, 76847, 77188, 29888, 77181, 76850, 
77189, 29889, 29872, 76824, 76849
27665, 29597, 29589, 76447, 76455, 3498, 3497, 29350, 29351, 29888, 77181, 76850, 77189, 3520, 29417, 29386, 
29418, 29890, 29873, 76827, 76852
27666, 3448, 3447, 29262, 29263, 29598, 29590, 76448, 76456, 3470, 29329, 29298, 29330, 29891, 77182, 76854, 
77190, 29892, 29875, 76828, 76853
27667, 29598, 29590, 76448, 76456, 29599, 29591, 76449, 76457, 29891, 77182, 76854, 77190, 29893, 77183, 76857, 
77191, 29894, 29877, 76831, 76856
27668, 29599, 29591, 76449, 76457, 29600, 29592, 76450, 76458, 29893, 77183, 76857, 77191, 29895, 77184, 76860, 
77192, 29896, 29879, 76834, 76859
27669, 29600, 29592, 76450, 76458, 29601, 29593, 76451, 76459, 29895, 77184, 76860, 77192, 29897, 77185, 76863, 
77193, 29898, 29881, 76837, 76862
27670, 29601, 29593, 76451, 76459, 29602, 29594, 76452, 76460, 29897, 77185, 76863, 77193, 29899, 77186, 76866, 
77194, 29900, 29883, 76840, 76865
27671, 29602, 29594, 76452, 76460, 29603, 29595, 76453, 76461, 29899, 77186, 76866, 77194, 29901, 77187, 76869, 
77195, 29902, 29885, 76843, 76868
27672, 29603, 29595, 76453, 76461, 29604, 29596, 76454, 76462, 29901, 77187, 76869, 77195, 29903, 77188, 76872, 
77196, 29904, 29887, 76846, 76871
27673, 29604, 29596, 76454, 76462, 29605, 29597, 76455, 76463, 29903, 77188, 76872, 77196, 29905, 77189, 76875, 
77197, 29906, 29889, 76849, 76874
27674, 29605, 29597, 76455, 76463, 3499, 3498, 29351, 29352, 29905, 77189, 76875, 77197, 3521, 29418, 29388, 
29419, 29907, 29890, 76852, 76877
27675, 3449, 3448, 29263, 29264, 29606, 29598, 76456, 76464, 3471, 29330, 29300, 29331, 29908, 77190, 76879, 
77198, 29909, 29892, 76853, 76878
27676, 29606, 29598, 76456, 76464, 29607, 29599, 76457, 76465, 29908, 77190, 76879, 77198, 29910, 77191, 76882, 
77199, 29911, 29894, 76856, 76881
27677, 29607, 29599, 76457, 76465, 29608, 29600, 76458, 76466, 29910, 77191, 76882, 77199, 29912, 77192, 76885, 
77200, 29913, 29896, 76859, 76884
27678, 29608, 29600, 76458, 76466, 29609, 29601, 76459, 76467, 29912, 77192, 76885, 77200, 29914, 77193, 76888, 
77201, 29915, 29898, 76862, 76887
27679, 29609, 29601, 76459, 76467, 29610, 29602, 76460, 76468, 29914, 77193, 76888, 77201, 29916, 77194, 76891, 
77202, 29917, 29900, 76865, 76890
27680, 29610, 29602, 76460, 76468, 29611, 29603, 76461, 76469, 29916, 77194, 76891, 77202, 29918, 77195, 76894, 
77203, 29919, 29902, 76868, 76893
27681, 29611, 29603, 76461, 76469, 29612, 29604, 76462, 76470, 29918, 77195, 76894, 77203, 29920, 77196, 76897, 
77204, 29921, 29904, 76871, 76896
27682, 29612, 29604, 76462, 76470, 29613, 29605, 76463, 76471, 29920, 77196, 76897, 77204, 29922, 77197, 76900, 
77205, 29923, 29906, 76874, 76899
27683, 29613, 29605, 76463, 76471, 3500, 3499, 29352, 29353, 29922, 77197, 76900, 77205, 3522, 29419, 29390, 
29420, 29924, 29907, 76877, 76902
27684, 3450, 3449, 29264, 29265, 29614, 29606, 76464, 76472, 3472, 29331, 29302, 29332, 29925, 77198, 76904, 
77206, 29926, 29909, 76878, 76903
27685, 29614, 29606, 76464, 76472, 29615, 29607, 76465, 76473, 29925, 77198, 76904, 77206, 29927, 77199, 76907, 
77207, 29928, 29911, 76881, 76906
27686, 29615, 29607, 76465, 76473, 29616, 29608, 76466, 76474, 29927, 77199, 76907, 77207, 29929, 77200, 76910, 
77208, 29930, 29913, 76884, 76909
27687, 29616, 29608, 76466, 76474, 29617, 29609, 76467, 76475, 29929, 77200, 76910, 77208, 29931, 77201, 76913, 
77209, 29932, 29915, 76887, 76912
27688, 29617, 29609, 76467, 76475, 29618, 29610, 76468, 76476, 29931, 77201, 76913, 77209, 29933, 77202, 76916, 
77210, 29934, 29917, 76890, 76915
27689, 29618, 29610, 76468, 76476, 29619, 29611, 76469, 76477, 29933, 77202, 76916, 77210, 29935, 77203, 76919, 
77211, 29936, 29919, 76893, 76918
27690, 29619, 29611, 76469, 76477, 29620, 29612, 76470, 76478, 29935, 77203, 76919, 77211, 29937, 77204, 76922, 
77212, 29938, 29921, 76896, 76921
27691, 29620, 29612, 76470, 76478, 29621, 29613, 76471, 76479, 29937, 77204, 76922, 77212, 29939, 77205, 76925, 
77213, 29940, 29923, 76899, 76924
27692, 29621, 29613, 76471, 76479, 3501, 3500, 29353, 29354, 29939, 77205, 76925, 77213, 3523, 29420, 29392, 
29421, 29941, 29924, 76902, 76927
27693, 3451, 3450, 29265, 29266, 29622, 29614, 76472, 76480, 3473, 29332, 29304, 29333, 29942, 77206, 76929, 
77214, 29943, 29926, 76903, 76928
27694, 29622, 29614, 76472, 76480, 29623, 29615, 76473, 76481, 29942, 77206, 76929, 77214, 29944, 77207, 76932, 
77215, 29945, 29928, 76906, 76931
27695, 29623, 29615, 76473, 76481, 29624, 29616, 76474, 76482, 29944, 77207, 76932, 77215, 29946, 77208, 76935, 
77216, 29947, 29930, 76909, 76934
27696, 29624, 29616, 76474, 76482, 29625, 29617, 76475, 76483, 29946, 77208, 76935, 77216, 29948, 77209, 76938, 
77217, 29949, 29932, 76912, 76937
27697, 29625, 29617, 76475, 76483, 29626, 29618, 76476, 76484, 29948, 77209, 76938, 77217, 29950, 77210, 76941, 
77218, 29951, 29934, 76915, 76940
27698, 29626, 29618, 76476, 76484, 29627, 29619, 76477, 76485, 29950, 77210, 76941, 77218, 29952, 77211, 76944, 
77219, 29953, 29936, 76918, 76943
27699, 29627, 29619, 76477, 76485, 29628, 29620, 76478, 76486, 29952, 77211, 76944, 77219, 29954, 77212, 76947, 
77220, 29955, 29938, 76921, 76946
27700, 29628, 29620, 76478, 76486, 29629, 29621, 76479, 76487, 29954, 77212, 76947, 77220, 29956, 77213, 76950, 
77221, 29957, 29940, 76924, 76949
27701, 29629, 29621, 76479, 76487, 3502, 3501, 29354, 29355, 29956, 77213, 76950, 77221, 3524, 29421, 29394, 
29422, 29958, 29941, 76927, 76952
27702, 3452, 3451, 29266, 29267, 29630, 29622, 76480, 76488, 3474, 29333, 29306, 29334, 29959, 77214, 76954, 
77222, 29960, 29943, 76928, 76953
27703, 29630, 29622, 76480, 76488, 29631, 29623, 76481, 76489, 29959, 77214, 76954, 77222, 29961, 77215, 76957, 
77223, 29962, 29945, 76931, 76956
27704, 29631, 29623, 76481, 76489, 29632, 29624, 76482, 76490, 29961, 77215, 76957, 77223, 29963, 77216, 76960, 
77224, 29964, 29947, 76934, 76959
27705, 29632, 29624, 76482, 76490, 29633, 29625, 76483, 76491, 29963, 77216, 76960, 77224, 29965, 77217, 76963, 
77225, 29966, 29949, 76937, 76962
27706, 29633, 29625, 76483, 76491, 29634, 29626, 76484, 76492, 29965, 77217, 76963, 77225, 29967, 77218, 76966, 
77226, 29968, 29951, 76940, 76965
27707, 29634, 29626, 76484, 76492, 29635, 29627, 76485, 76493, 29967, 77218, 76966, 77226, 29969, 77219, 76969, 
77227, 29970, 29953, 76943, 76968
27708, 29635, 29627, 76485, 76493, 29636, 29628, 76486, 76494, 29969, 77219, 76969, 77227, 29971, 77220, 76972, 
77228, 29972, 29955, 76946, 76971
27709, 29636, 29628, 76486, 76494, 29637, 29629, 76487, 76495, 29971, 77220, 76972, 77228, 29973, 77221, 76975, 
77229, 29974, 29957, 76949, 76974
27710, 29637, 29629, 76487, 76495, 3503, 3502, 29355, 29356, 29973, 77221, 76975, 77229, 3525, 29422, 29396, 
29423, 29975, 29958, 76952, 76977
27711, 3453, 3452, 29267, 29268, 29638, 29630, 76488, 76496, 3475, 29334, 29308, 29335, 29976, 77222, 76979, 
77230, 29977, 29960, 76953, 76978
27712, 29638, 29630, 76488, 76496, 29639, 29631, 76489, 76497, 29976, 77222, 76979, 77230, 29978, 77223, 76982, 
77231, 29979, 29962, 76956, 76981
27713, 29639, 29631, 76489, 76497, 29640, 29632, 76490, 76498, 29978, 77223, 76982, 77231, 29980, 77224, 76985, 
77232, 29981, 29964, 76959, 76984
27714, 29640, 29632, 76490, 76498, 29641, 29633, 76491, 76499, 29980, 77224, 76985, 77232, 29982, 77225, 76988, 
77233, 29983, 29966, 76962, 76987
27715, 29641, 29633, 76491, 76499, 29642, 29634, 76492, 76500, 29982, 77225, 76988, 77233, 29984, 77226, 76991, 
77234, 29985, 29968, 76965, 76990
27716, 29642, 29634, 76492, 76500, 29643, 29635, 76493, 76501, 29984, 77226, 76991, 77234, 29986, 77227, 76994, 
77235, 29987, 29970, 76968, 76993
27717, 29643, 29635, 76493, 76501, 29644, 29636, 76494, 76502, 29986, 77227, 76994, 77235, 29988, 77228, 76997, 
77236, 29989, 29972, 76971, 76996
27718, 29644, 29636, 76494, 76502, 29645, 29637, 76495, 76503, 29988, 77228, 76997, 77236, 29990, 77229, 77000, 
77237, 29991, 29974, 76974, 76999
27719, 29645, 29637, 76495, 76503, 3504, 3503, 29356, 29357, 29990, 77229, 77000, 77237, 3526, 29423, 29398, 
29424, 29992, 29975, 76977, 77002
27720, 3454, 3453, 29268, 29269, 29646, 29638, 76496, 76504, 3476, 29335, 29310, 29336, 29993, 77230, 77004, 
77238, 29994, 29977, 76978, 77003
27721, 29646, 29638, 76496, 76504, 29647, 29639, 76497, 76505, 29993, 77230, 77004, 77238, 29995, 77231, 77007, 
77239, 29996, 29979, 76981, 77006
27722, 29647, 29639, 76497, 76505, 29648, 29640, 76498, 76506, 29995, 77231, 77007, 77239, 29997, 77232, 77010, 
77240, 29998, 29981, 76984, 77009
27723, 29648, 29640, 76498, 76506, 29649, 29641, 76499, 76507, 29997, 77232, 77010, 77240, 29999, 77233, 77013, 
77241, 30000, 29983, 76987, 77012
27724, 29649, 29641, 76499, 76507, 29650, 29642, 76500, 76508, 29999, 77233, 77013, 77241, 30001, 77234, 77016, 
77242, 30002, 29985, 76990, 77015
27725, 29650, 29642, 76500, 76508, 29651, 29643, 76501, 76509, 30001, 77234, 77016, 77242, 30003, 77235, 77019, 
77243, 30004, 29987, 76993, 77018
27726, 29651, 29643, 76501, 76509, 29652, 29644, 76502, 76510, 30003, 77235, 77019, 77243, 30005, 77236, 77022, 
77244, 30006, 29989, 76996, 77021
27727, 29652, 29644, 76502, 76510, 29653, 29645, 76503, 76511, 30005, 77236, 77022, 77244, 30007, 77237, 77025, 
77245, 30008, 29991, 76999, 77024
27728, 29653, 29645, 76503, 76511, 3505, 3504, 29357, 29358, 30007, 77237, 77025, 77245, 3527, 29424, 29400, 
29425, 30009, 29992, 77002, 77027
27729, 3455, 3454, 29269, 29270, 29654, 29646, 76504, 76512, 3477, 29336, 29312, 29337, 30010, 77238, 77029, 
77246, 30011, 29994, 77003, 77028
27730, 29654, 29646, 76504, 76512, 29655, 29647, 76505, 76513, 30010, 77238, 77029, 77246, 30012, 77239, 77032, 
77247, 30013, 29996, 77006, 77031
27731, 29655, 29647, 76505, 76513, 29656, 29648, 76506, 76514, 30012, 77239, 77032, 77247, 30014, 77240, 77035, 
77248, 30015, 29998, 77009, 77034
27732, 29656, 29648, 76506, 76514, 29657, 29649, 76507, 76515, 30014, 77240, 77035, 77248, 30016, 77241, 77038, 
77249, 30017, 30000, 77012, 77037
27733, 29657, 29649, 76507, 76515, 29658, 29650, 76508, 76516, 30016, 77241, 77038, 77249, 30018, 77242, 77041, 
77250, 30019, 30002, 77015, 77040
27734, 29658, 29650, 76508, 76516, 29659, 29651, 76509, 76517, 30018, 77242, 77041, 77250, 30020, 77243, 77044, 
77251, 30021, 30004, 77018, 77043
27735, 29659, 29651, 76509, 76517, 29660, 29652, 76510, 76518, 30020, 77243, 77044, 77251, 30022, 77244, 77047, 
77252, 30023, 30006, 77021, 77046
27736, 29660, 29652, 76510, 76518, 29661, 29653, 76511, 76519, 30022, 77244, 77047, 77252, 30024, 77245, 77050, 
77253, 30025, 30008, 77024, 77049
27737, 29661, 29653, 76511, 76519, 3506, 3505, 29358, 29359, 30024, 77245, 77050, 77253, 3528, 29425, 29402, 
29426, 30026, 30009, 77027, 77052
27738, 3456, 3455, 29270, 29271, 29662, 29654, 76512, 76520, 3478, 29337, 29314, 29338, 30027, 77246, 77054, 
77254, 30028, 30011, 77028, 77053
27739, 29662, 29654, 76512, 76520, 29663, 29655, 76513, 76521, 30027, 77246, 77054, 77254, 30029, 77247, 77057, 
77255, 30030, 30013, 77031, 77056
27740, 29663, 29655, 76513, 76521, 29664, 29656, 76514, 76522, 30029, 77247, 77057, 77255, 30031, 77248, 77060, 
77256, 30032, 30015, 77034, 77059
27741, 29664, 29656, 76514, 76522, 29665, 29657, 76515, 76523, 30031, 77248, 77060, 77256, 30033, 77249, 77063, 
77257, 30034, 30017, 77037, 77062
27742, 29665, 29657, 76515, 76523, 29666, 29658, 76516, 76524, 30033, 77249, 77063, 77257, 30035, 77250, 77066, 
77258, 30036, 30019, 77040, 77065
27743, 29666, 29658, 76516, 76524, 29667, 29659, 76517, 76525, 30035, 77250, 77066, 77258, 30037, 77251, 77069, 
77259, 30038, 30021, 77043, 77068
27744, 29667, 29659, 76517, 76525, 29668, 29660, 76518, 76526, 30037, 77251, 77069, 77259, 30039, 77252, 77072, 
77260, 30040, 30023, 77046, 77071
27745, 29668, 29660, 76518, 76526, 29669, 29661, 76519, 76527, 30039, 77252, 77072, 77260, 30041, 77253, 77075, 
77261, 30042, 30025, 77049, 77074
27746, 29669, 29661, 76519, 76527, 3507, 3506, 29359, 29360, 30041, 77253, 77075, 77261, 3529, 29426, 29404, 
29427, 30043, 30026, 77052, 77077
27747, 98, 3456, 29271, 3432, 3555, 29662, 76520, 29461, 3479, 29338, 29316, 3434, 30044, 77254, 77078, 
29486, 3564, 30028, 77053, 29469
27748, 3555, 29662, 76520, 29461, 3554, 29663, 76521, 29462, 30044, 77254, 77078, 29486, 30045, 77255, 77079, 
29487, 3563, 30030, 77056, 29471
27749, 3554, 29663, 76521, 29462, 3553, 29664, 76522, 29463, 30045, 77255, 77079, 29487, 30046, 77256, 77080, 
29488, 3562, 30032, 77059, 29473
27750, 3553, 29664, 76522, 29463, 3552, 29665, 76523, 29464, 30046, 77256, 77080, 29488, 30047, 77257, 77081, 
29489, 3561, 30034, 77062, 29475
27751, 3552, 29665, 76523, 29464, 3551, 29666, 76524, 29465, 30047, 77257, 77081, 29489, 30048, 77258, 77082, 
29490, 3560, 30036, 77065, 29477
27752, 3551, 29666, 76524, 29465, 3550, 29667, 76525, 29466, 30048, 77258, 77082, 29490, 30049, 77259, 77083, 
29491, 3559, 30038, 77068, 29479
27753, 3550, 29667, 76525, 29466, 3549, 29668, 76526, 29467, 30049, 77259, 77083, 29491, 30050, 77260, 77084, 
29492, 3558, 30040, 77071, 29481
27754, 3549, 29668, 76526, 29467, 3548, 29669, 76527, 29468, 30050, 77260, 77084, 29492, 30051, 77261, 77085, 
29493, 3557, 30042, 77074, 29483
27755, 3548, 29669, 76527, 29468, 100, 3507, 29360, 3483, 30051, 77261, 77085, 29493, 3530, 29427, 29405, 
3485, 3556, 30043, 77077, 29485
*ELEMENT, type=C3D20, ELSET=Volume11
27756, 10103, 1174, 35, 1184, 77262, 10415, 1291, 10531, 10147, 1176, 1206, 10148, 77615, 10431, 10708, 
77616, 77614, 10432, 1300, 10707
27757, 77262, 10415, 1291, 10531, 77263, 10416, 1290, 10532, 77615, 10431, 10708, 77616, 77618, 10433, 10710, 
77619, 77617, 10434, 1299, 10709
27758, 77263, 10416, 1290, 10532, 77264, 10417, 1289, 10533, 77618, 10433, 10710, 77619, 77621, 10435, 10712, 
77622, 77620, 10436, 1298, 10711
27759, 77264, 10417, 1289, 10533, 77265, 10418, 1288, 10534, 77621, 10435, 10712, 77622, 77624, 10437, 10714, 
77625, 77623, 10438, 1297, 10713
27760, 77265, 10418, 1288, 10534, 77266, 10419, 1287, 10535, 77624, 10437, 10714, 77625, 77627, 10439, 10716, 
77628, 77626, 10440, 1296, 10715
27761, 77266, 10419, 1287, 10535, 77267, 10420, 1286, 10536, 77627, 10439, 10716, 77628, 77630, 10441, 10718, 
77631, 77629, 10442, 1295, 10717
27762, 77267, 10420, 1286, 10536, 77268, 10421, 1285, 10537, 77630, 10441, 10718, 77631, 77633, 10443, 10720, 
77634, 77632, 10444, 1294, 10719
27763, 77268, 10421, 1285, 10537, 77269, 10422, 1284, 10538, 77633, 10443, 10720, 77634, 77636, 10445, 10722, 
77637, 77635, 10446, 1293, 10721
27764, 77269, 10422, 1284, 10538, 10259, 1229, 37, 1239, 77636, 10445, 10722, 77637, 10304, 1231, 1261, 
10303, 77638, 10447, 1292, 10723
27765, 10104, 10103, 1184, 1185, 77270, 77262, 10531, 10539, 10149, 10148, 1207, 10150, 77640, 77616, 10725, 
77641, 77639, 77614, 10707, 10724
27766, 77270, 77262, 10531, 10539, 77271, 77263, 10532, 10540, 77640, 77616, 10725, 77641, 77643, 77619, 10727, 
77644, 77642, 77617, 10709, 10726
27767, 77271, 77263, 10532, 10540, 77272, 77264, 10533, 10541, 77643, 77619, 10727, 77644, 77646, 77622, 10729, 
77647, 77645, 77620, 10711, 10728
27768, 77272, 77264, 10533, 10541, 77273, 77265, 10534, 10542, 77646, 77622, 10729, 77647, 77649, 77625, 10731, 
77650, 77648, 77623, 10713, 10730
27769, 77273, 77265, 10534, 10542, 77274, 77266, 10535, 10543, 77649, 77625, 10731, 77650, 77652, 77628, 10733, 
77653, 77651, 77626, 10715, 10732
27770, 77274, 77266, 10535, 10543, 77275, 77267, 10536, 10544, 77652, 77628, 10733, 77653, 77655, 77631, 10735, 
77656, 77654, 77629, 10717, 10734
27771, 77275, 77267, 10536, 10544, 77276, 77268, 10537, 10545, 77655, 77631, 10735, 77656, 77658, 77634, 10737, 
77659, 77657, 77632, 10719, 10736
27772, 77276, 77268, 10537, 10545, 77277, 77269, 10538, 10546, 77658, 77634, 10737, 77659, 77661, 77637, 10739, 
77662, 77660, 77635, 10721, 10738
27773, 77277, 77269, 10538, 10546, 10260, 10259, 1239, 1240, 77661, 77637, 10739, 77662, 10306, 10303, 1262, 
10305, 77663, 77638, 10723, 10740
27774, 10105, 10104, 1185, 1186, 77278, 77270, 10539, 10547, 10151, 10150, 1208, 10152, 77665, 77641, 10742, 
77666, 77664, 77639, 10724, 10741
27775, 77278, 77270, 10539, 10547, 77279, 77271, 10540, 10548, 77665, 77641, 10742, 77666, 77668, 77644, 10744, 
77669, 77667, 77642, 10726, 10743
27776, 77279, 77271, 10540, 10548, 77280, 77272, 10541, 10549, 77668, 77644, 10744, 77669, 77671, 77647, 10746, 
77672, 77670, 77645, 10728, 10745
27777, 77280, 77272, 10541, 10549, 77281, 77273, 10542, 10550, 77671, 77647, 10746, 77672, 77674, 77650, 10748, 
77675, 77673, 77648, 10730, 10747
27778, 77281, 77273, 10542, 10550, 77282, 77274, 10543, 10551, 77674, 77650, 10748, 77675, 77677, 77653, 10750, 
77678, 77676, 77651, 10732, 10749
27779, 77282, 77274, 10543, 10551, 77283, 77275, 10544, 10552, 77677, 77653, 10750, 77678, 77680, 77656, 10752, 
77681, 77679, 77654, 10734, 10751
27780, 77283, 77275, 10544, 10552, 77284, 77276, 10545, 10553, 77680, 77656, 10752, 77681, 77683, 77659, 10754, 
77684, 77682, 77657, 10736, 10753
27781, 77284, 77276, 10545, 10553, 77285, 77277, 10546, 10554, 77683, 77659, 10754, 77684, 77686, 77662, 10756, 
77687, 77685, 77660, 10738, 10755
27782, 77285, 77277, 10546, 10554, 10261, 10260, 1240, 1241, 77686, 77662, 10756, 77687, 10308, 10305, 1263, 
10307, 77688, 77663, 10740, 10757
27783, 10106, 10105, 1186, 1187, 77286, 77278, 10547, 10555, 10153, 10152, 1209, 10154, 77690, 77666, 10759, 
77691, 77689, 77664, 10741, 10758
27784, 77286, 77278, 10547, 10555, 77287, 77279, 10548, 10556, 77690, 77666, 10759, 77691, 77693, 77669, 10761, 
77694, 77692, 77667, 10743, 10760
27785, 77287, 77279, 10548, 10556, 77288, 77280, 10549, 10557, 77693, 77669, 10761, 77694, 77696, 77672, 10763, 
77697, 77695, 77670, 10745, 10762
27786, 77288, 77280, 10549, 10557, 77289, 77281, 10550, 10558, 77696, 77672, 10763, 77697, 77699, 77675, 10765, 
77700, 77698, 77673, 10747, 10764
27787, 77289, 77281, 10550, 10558, 77290, 77282, 10551, 10559, 77699, 77675, 10765, 77700, 77702, 77678, 10767, 
77703, 77701, 77676, 10749, 10766
27788, 77290, 77282, 10551, 10559, 77291, 77283, 10552, 10560, 77702, 77678, 10767, 77703, 77705, 77681, 10769, 
77706, 77704, 77679, 10751, 10768
27789, 77291, 77283, 10552, 10560, 77292, 77284, 10553, 10561, 77705, 77681, 10769, 77706, 77708, 77684, 10771, 
77709, 77707, 77682, 10753, 10770
27790, 77292, 77284, 10553, 10561, 77293, 77285, 10554, 10562, 77708, 77684, 10771, 77709, 77711, 77687, 10773, 
77712, 77710, 77685, 10755, 10772
27791, 77293, 77285, 10554, 10562, 10262, 10261, 1241, 1242, 77711, 77687, 10773, 77712, 10310, 10307, 1264, 
10309, 77713, 77688, 10757, 10774
27792, 10107, 10106, 1187, 1188, 77294, 77286, 10555, 10563, 10155, 10154, 1210, 10156, 77715, 77691, 10776, 
77716, 77714, 77689, 10758, 10775
27793, 77294, 77286, 10555, 10563, 77295, 77287, 10556, 10564, 77715, 77691, 10776, 77716, 77718, 77694, 10778, 
77719, 77717, 77692, 10760, 10777
27794, 77295, 77287, 10556, 10564, 77296, 77288, 10557, 10565, 77718, 77694, 10778, 77719, 77721, 77697, 10780, 
77722, 77720, 77695, 10762, 10779
27795, 77296, 77288, 10557, 10565, 77297, 77289, 10558, 10566, 77721, 77697, 10780, 77722, 77724, 77700, 10782, 
77725, 77723, 77698, 10764, 10781
27796, 77297, 77289, 10558, 10566, 77298, 77290, 10559, 10567, 77724, 77700, 10782, 77725, 77727, 77703, 10784, 
77728, 77726, 77701, 10766, 10783
27797, 77298, 77290, 10559, 10567, 77299, 77291, 10560, 10568, 77727, 77703, 10784, 77728, 77730, 77706, 10786, 
77731, 77729, 77704, 10768, 10785
27798, 77299, 77291, 10560, 10568, 77300, 77292, 10561, 10569, 77730, 77706, 10786, 77731, 77733, 77709, 10788, 
77734, 77732, 77707, 10770, 10787
27799, 77300, 77292, 10561, 10569, 77301, 77293, 10562, 10570, 77733, 77709, 10788, 77734, 77736, 77712, 10790, 
77737, 77735, 77710, 10772, 10789
27800, 77301, 77293, 10562, 10570, 10263, 10262, 1242, 1243, 77736, 77712, 10790, 77737, 10312, 10309, 1265, 
10311, 77738, 77713, 10774, 10791
27801, 10108, 10107, 1188, 1189, 77302, 77294, 10563, 10571, 10157, 10156, 1211, 10158, 77740, 77716, 10793, 
77741, 77739, 77714, 10775, 10792
27802, 77302, 77294, 10563, 10571, 77303, 77295, 10564, 10572, 77740, 77716, 10793, 77741, 77743, 77719, 10795, 
77744, 77742, 77717, 10777, 10794
27803, 77303, 77295, 10564, 10572, 77304, 77296, 10565, 10573, 77743, 77719, 10795, 77744, 77746, 77722, 10797, 
77747, 77745, 77720, 10779, 10796
27804, 77304, 77296, 10565, 10573, 77305, 77297, 10566, 10574, 77746, 77722, 10797, 77747, 77749, 77725, 10799, 
77750, 77748, 77723, 10781, 10798
27805, 77305, 77297, 10566, 10574, 77306, 77298, 10567, 10575, 77749, 77725, 10799, 77750, 77752, 77728, 10801, 
77753, 77751, 77726, 10783, 10800
27806, 77306, 77298, 10567, 10575, 77307, 77299, 10568, 10576, 77752, 77728, 10801, 77753, 77755, 77731, 10803, 
77756, 77754, 77729, 10785, 10802
27807, 77307, 77299, 10568, 10576, 77308, 77300, 10569, 10577, 77755, 77731, 10803, 77756, 77758, 77734, 10805, 
77759, 77757, 77732, 10787, 10804
27808, 77308, 77300, 10569, 10577, 77309, 77301, 10570, 10578, 77758, 77734, 10805, 77759, 77761, 77737, 10807, 
77762, 77760, 77735, 10789, 10806
27809, 77309, 77301, 10570, 10578, 10264, 10263, 1243, 1244, 77761, 77737, 10807, 77762, 10314, 10311, 1266, 
10313, 77763, 77738, 10791, 10808
27810, 10109, 10108, 1189, 1190, 77310, 77302, 10571, 10579, 10159, 10158, 1212, 10160, 77765, 77741, 10810, 
77766, 77764, 77739, 10792, 10809
27811, 77310, 77302, 10571, 10579, 77311, 77303, 10572, 10580, 77765, 77741, 10810, 77766, 77768, 77744, 10812, 
77769, 77767, 77742, 10794, 10811
27812, 77311, 77303, 10572, 10580, 77312, 77304, 10573, 10581, 77768, 77744, 10812, 77769, 77771, 77747, 10814, 
77772, 77770, 77745, 10796, 10813
27813, 77312, 77304, 10573, 10581, 77313, 77305, 10574, 10582, 77771, 77747, 10814, 77772, 77774, 77750, 10816, 
77775, 77773, 77748, 10798, 10815
27814, 77313, 77305, 10574, 10582, 77314, 77306, 10575, 10583, 77774, 77750, 10816, 77775, 77777, 77753, 10818, 
77778, 77776, 77751, 10800, 10817
27815, 77314, 77306, 10575, 10583, 77315, 77307, 10576, 10584, 77777, 77753, 10818, 77778, 77780, 77756, 10820, 
77781, 77779, 77754, 10802, 10819
27816, 77315, 77307, 10576, 10584, 77316, 77308, 10577, 10585, 77780, 77756, 10820, 77781, 77783, 77759, 10822, 
77784, 77782, 77757, 10804, 10821
27817, 77316, 77308, 10577, 10585, 77317, 77309, 10578, 10586, 77783, 77759, 10822, 77784, 77786, 77762, 10824, 
77787, 77785, 77760, 10806, 10823
27818, 77317, 77309, 10578, 10586, 10265, 10264, 1244, 1245, 77786, 77762, 10824, 77787, 10316, 10313, 1267, 
10315, 77788, 77763, 10808, 10825
27819, 10110, 10109, 1190, 1191, 77318, 77310, 10579, 10587, 10161, 10160, 1213, 10162, 77790, 77766, 10827, 
77791, 77789, 77764, 10809, 10826
27820, 77318, 77310, 10579, 10587, 77319, 77311, 10580, 10588, 77790, 77766, 10827, 77791, 77793, 77769, 10829, 
77794, 77792, 77767, 10811, 10828
27821, 77319, 77311, 10580, 10588, 77320, 77312, 10581, 10589, 77793, 77769, 10829, 77794, 77796, 77772, 10831, 
77797, 77795, 77770, 10813, 10830
27822, 77320, 77312, 10581, 10589, 77321, 77313, 10582, 10590, 77796, 77772, 10831, 77797, 77799, 77775, 10833, 
77800, 77798, 77773, 10815, 10832
27823, 77321, 77313, 10582, 10590, 77322, 77314, 10583, 10591, 77799, 77775, 10833, 77800, 77802, 77778, 10835, 
77803, 77801, 77776, 10817, 10834
27824, 77322, 77314, 10583, 10591, 77323, 77315, 10584, 10592, 77802, 77778, 10835, 77803, 77805, 77781, 10837, 
77806, 77804, 77779, 10819, 10836
27825, 77323, 77315, 10584, 10592, 77324, 77316, 10585, 10593, 77805, 77781, 10837, 77806, 77808, 77784, 10839, 
77809, 77807, 77782, 10821, 10838
27826, 77324, 77316, 10585, 10593, 77325, 77317, 10586, 10594, 77808, 77784, 10839, 77809, 77811, 77787, 10841, 
77812, 77810, 77785, 10823, 10840
27827, 77325, 77317, 10586, 10594, 10266, 10265, 1245, 1246, 77811, 77787, 10841, 77812, 10318, 10315, 1268, 
10317, 77813, 77788, 10825, 10842
27828, 10111, 10110, 1191, 1192, 77326, 77318, 10587, 10595, 10163, 10162, 1214, 10164, 77815, 77791, 10844, 
77816, 77814, 77789, 10826, 10843
27829, 77326, 77318, 10587, 10595, 77327, 77319, 10588, 10596, 77815, 77791, 10844, 77816, 77818, 77794, 10846, 
77819, 77817, 77792, 10828, 10845
27830, 77327, 77319, 10588, 10596, 77328, 77320, 10589, 10597, 77818, 77794, 10846, 77819, 77821, 77797, 10848, 
77822, 77820, 77795, 10830, 10847
27831, 77328, 77320, 10589, 10597, 77329, 77321, 10590, 10598, 77821, 77797, 10848, 77822, 77824, 77800, 10850, 
77825, 77823, 77798, 10832, 10849
27832, 77329, 77321, 10590, 10598, 77330, 77322, 10591, 10599, 77824, 77800, 10850, 77825, 77827, 77803, 10852, 
77828, 77826, 77801, 10834, 10851
27833, 77330, 77322, 10591, 10599, 77331, 77323, 10592, 10600, 77827, 77803, 10852, 77828, 77830, 77806, 10854, 
77831, 77829, 77804, 10836, 10853
27834, 77331, 77323, 10592, 10600, 77332, 77324, 10593, 10601, 77830, 77806, 10854, 77831, 77833, 77809, 10856, 
77834, 77832, 77807, 10838, 10855
27835, 77332, 77324, 10593, 10601, 77333, 77325, 10594, 10602, 77833, 77809, 10856, 77834, 77836, 77812, 10858, 
77837, 77835, 77810, 10840, 10857
27836, 77333, 77325, 10594, 10602, 10267, 10266, 1246, 1247, 77836, 77812, 10858, 77837, 10320, 10317, 1269, 
10319, 77838, 77813, 10842, 10859
27837, 10112, 10111, 1192, 1193, 77334, 77326, 10595, 10603, 10165, 10164, 1215, 10166, 77840, 77816, 10861, 
77841, 77839, 77814, 10843, 10860
27838, 77334, 77326, 10595, 10603, 77335, 77327, 10596, 10604, 77840, 77816, 10861, 77841, 77843, 77819, 10863, 
77844, 77842, 77817, 10845, 10862
