65338, 1.7434782608696, 1.1934782608696, 0.055555555555556
65339, 1.7652173913043, 1.2195652173913, 0.055555555555556
65340, 1.7652173913043, 1.1934782608696, 0.027777777777778
65341, 1.8086956521739, 1.1934782608696, 0.47222222222222
65342, 1.7869565217391, 1.1934782608696, 0.44444444444444
65343, 1.8086956521739, 1.2195652173913, 0.44444444444444
65344, 1.8086956521739, 1.1934782608696, 0.41666666666667
65345, 1.7869565217391, 1.1934782608696, 0.38888888888889
65346, 1.8086956521739, 1.2195652173913, 0.38888888888889
65347, 1.8086956521739, 1.1934782608696, 0.36111111111111
65348, 1.7869565217391, 1.1934782608696, 0.33333333333333
65349, 1.8086956521739, 1.2195652173913, 0.33333333333333
65350, 1.8086956521739, 1.1934782608696, 0.30555555555556
65351, 1.7869565217391, 1.1934782608696, 0.27777777777778
65352, 1.8086956521739, 1.2195652173913, 0.27777777777778
65353, 1.8086956521739, 1.1934782608696, 0.25
65354, 1.7869565217391, 1.1934782608696, 0.22222222222222
65355, 1.8086956521739, 1.2195652173913, 0.22222222222222
65356, 1.8086956521739, 1.1934782608696, 0.19444444444444
65357, 1.7869565217391, 1.1934782608696, 0.16666666666667
65358, 1.8086956521739, 1.2195652173913, 0.16666666666667
65359, 1.8086956521739, 1.1934782608696, 0.13888888888889
65360, 1.7869565217391, 1.1934782608696, 0.11111111111111
65361, 1.8086956521739, 1.2195652173913, 0.11111111111111
65362, 1.8086956521739, 1.1934782608696, 0.083333333333333
65363, 1.7869565217391, 1.1934782608696, 0.055555555555556
65364, 1.8086956521739, 1.2195652173913, 0.055555555555556
65365, 1.8086956521739, 1.1934782608696, 0.027777777777778
65366, 1.8521739130435, 1.1934782608696, 0.47222222222222
65367, 1.8304347826087, 1.1934782608696, 0.44444444444444
65368, 1.8521739130435, 1.2195652173913, 0.44444444444444
65369, 1.8521739130435, 1.1934782608696, 0.41666666666667
65370, 1.8304347826087, 1.1934782608696, 0.38888888888889
65371, 1.8521739130435, 1.2195652173913, 0.38888888888889
65372, 1.8521739130435, 1.1934782608696, 0.36111111111111
65373, 1.8304347826087, 1.1934782608696, 0.33333333333333
65374, 1.8521739130435, 1.2195652173913, 0.33333333333333
65375, 1.8521739130435, 1.1934782608696, 0.30555555555556
65376, 1.8304347826087, 1.1934782608696, 0.27777777777778
65377, 1.8521739130435, 1.2195652173913, 0.27777777777778
65378, 1.8521739130435, 1.1934782608696, 0.25
65379, 1.8304347826087, 1.1934782608696, 0.22222222222222
65380, 1.8521739130435, 1.2195652173913, 0.22222222222222
65381, 1.8521739130435, 1.1934782608696, 0.19444444444444
65382, 1.8304347826087, 1.1934782608696, 0.16666666666667
65383, 1.8521739130435, 1.2195652173913, 0.16666666666667
65384, 1.8521739130435, 1.1934782608696, 0.13888888888889
65385, 1.8304347826087, 1.1934782608696, 0.11111111111111
65386, 1.8521739130435, 1.2195652173913, 0.11111111111111
65387, 1.8521739130435, 1.1934782608696, 0.083333333333333
65388, 1.8304347826087, 1.1934782608696, 0.055555555555556
65389, 1.8521739130435, 1.2195652173913, 0.055555555555556
65390, 1.8521739130435, 1.1934782608696, 0.027777777777778
65391, 1.895652173913, 1.1934782608696, 0.47222222222222
65392, 1.8739130434783, 1.1934782608696, 0.44444444444444
65393, 1.895652173913, 1.2195652173913, 0.44444444444444
65394, 1.895652173913, 1.1934782608696, 0.41666666666667
65395, 1.8739130434783, 1.1934782608696, 0.38888888888889
65396, 1.895652173913, 1.2195652173913, 0.38888888888889
65397, 1.895652173913, 1.1934782608696, 0.36111111111111
65398, 1.8739130434783, 1.1934782608696, 0.33333333333333
65399, 1.895652173913, 1.2195652173913, 0.33333333333333
65400, 1.895652173913, 1.1934782608696, 0.30555555555556
65401, 1.8739130434783, 1.1934782608696, 0.27777777777778
65402, 1.895652173913, 1.2195652173913, 0.27777777777778
65403, 1.895652173913, 1.1934782608696, 0.25
65404, 1.8739130434783, 1.1934782608696, 0.22222222222222
65405, 1.895652173913, 1.2195652173913, 0.22222222222222
65406, 1.895652173913, 1.1934782608696, 0.19444444444444
65407, 1.8739130434783, 1.1934782608696, 0.16666666666667
65408, 1.895652173913, 1.2195652173913, 0.16666666666667
65409, 1.895652173913, 1.1934782608696, 0.13888888888889
65410, 1.8739130434783, 1.1934782608696, 0.11111111111111
65411, 1.895652173913, 1.2195652173913, 0.11111111111111
65412, 1.895652173913, 1.1934782608696, 0.083333333333333
65413, 1.8739130434783, 1.1934782608696, 0.055555555555556
65414, 1.895652173913, 1.2195652173913, 0.055555555555556
65415, 1.895652173913, 1.1934782608696, 0.027777777777778
65416, 1.9391304347826, 1.1934782608696, 0.47222222222222
65417, 1.9173913043478, 1.1934782608696, 0.44444444444444
65418, 1.9391304347826, 1.2195652173913, 0.44444444444444
65419, 1.9391304347826, 1.1934782608696, 0.41666666666667
65420, 1.9173913043478, 1.1934782608696, 0.38888888888889
65421, 1.9391304347826, 1.2195652173913, 0.38888888888889
65422, 1.9391304347826, 1.1934782608696, 0.36111111111111
65423, 1.9173913043478, 1.1934782608696, 0.33333333333333
65424, 1.9391304347826, 1.2195652173913, 0.33333333333333
65425, 1.9391304347826, 1.1934782608696, 0.30555555555556
65426, 1.9173913043478, 1.1934782608696, 0.27777777777778
65427, 1.9391304347826, 1.2195652173913, 0.27777777777778
65428, 1.9391304347826, 1.1934782608696, 0.25
65429, 1.9173913043478, 1.1934782608696, 0.22222222222222
65430, 1.9391304347826, 1.2195652173913, 0.22222222222222
65431, 1.9391304347826, 1.1934782608696, 0.19444444444444
65432, 1.9173913043478, 1.1934782608696, 0.16666666666667
65433, 1.9391304347826, 1.2195652173913, 0.16666666666667
65434, 1.9391304347826, 1.1934782608696, 0.13888888888889
65435, 1.9173913043478, 1.1934782608696, 0.11111111111111
65436, 1.9391304347826, 1.2195652173913, 0.11111111111111
65437, 1.9391304347826, 1.1934782608696, 0.083333333333333
65438, 1.9173913043478, 1.1934782608696, 0.055555555555556
65439, 1.9391304347826, 1.2195652173913, 0.055555555555556
65440, 1.9391304347826, 1.1934782608696, 0.027777777777778
65441, 1.9826086956522, 1.1934782608696, 0.47222222222222
65442, 1.9608695652174, 1.1934782608696, 0.44444444444444
65443, 1.9826086956522, 1.2195652173913, 0.44444444444444
65444, 1.9826086956522, 1.1934782608696, 0.41666666666667
65445, 1.9608695652174, 1.1934782608696, 0.38888888888889
65446, 1.9826086956522, 1.2195652173913, 0.38888888888889
65447, 1.9826086956522, 1.1934782608696, 0.36111111111111
65448, 1.9608695652174, 1.1934782608696, 0.33333333333333
65449, 1.9826086956522, 1.2195652173913, 0.33333333333333
65450, 1.9826086956522, 1.1934782608696, 0.30555555555556
65451, 1.9608695652174, 1.1934782608696, 0.27777777777778
65452, 1.9826086956522, 1.2195652173913, 0.27777777777778
65453, 1.9826086956522, 1.1934782608696, 0.25
65454, 1.9608695652174, 1.1934782608696, 0.22222222222222
65455, 1.9826086956522, 1.2195652173913, 0.22222222222222
65456, 1.9826086956522, 1.1934782608696, 0.19444444444444
65457, 1.9608695652174, 1.1934782608696, 0.16666666666667
65458, 1.9826086956522, 1.2195652173913, 0.16666666666667
65459, 1.9826086956522, 1.1934782608696, 0.13888888888889
65460, 1.9608695652174, 1.1934782608696, 0.11111111111111
65461, 1.9826086956522, 1.2195652173913, 0.11111111111111
65462, 1.9826086956522, 1.1934782608696, 0.083333333333333
65463, 1.9608695652174, 1.1934782608696, 0.055555555555556
65464, 1.9826086956522, 1.2195652173913, 0.055555555555556
65465, 1.9826086956522, 1.1934782608696, 0.027777777777778
65466, 2.0260869565217, 1.1934782608696, 0.47222222222222
65467, 2.004347826087, 1.1934782608696, 0.44444444444444
65468, 2.0260869565217, 1.2195652173913, 0.44444444444444
65469, 2.0260869565217, 1.1934782608696, 0.41666666666667
65470, 2.004347826087, 1.1934782608696, 0.38888888888889
65471, 2.0260869565217, 1.2195652173913, 0.38888888888889
65472, 2.0260869565217, 1.1934782608696, 0.36111111111111
65473, 2.004347826087, 1.1934782608696, 0.33333333333333
65474, 2.0260869565217, 1.2195652173913, 0.33333333333333
65475, 2.0260869565217, 1.1934782608696, 0.30555555555556
65476, 2.004347826087, 1.1934782608696, 0.27777777777778
65477, 2.0260869565217, 1.2195652173913, 0.27777777777778
65478, 2.0260869565217, 1.1934782608696, 0.25
65479, 2.004347826087, 1.1934782608696, 0.22222222222222
65480, 2.0260869565217, 1.2195652173913, 0.22222222222222
65481, 2.0260869565217, 1.1934782608696, 0.19444444444444
65482, 2.004347826087, 1.1934782608696, 0.16666666666667
65483, 2.0260869565217, 1.2195652173913, 0.16666666666667
65484, 2.0260869565217, 1.1934782608696, 0.13888888888889
65485, 2.004347826087, 1.1934782608696, 0.11111111111111
65486, 2.0260869565217, 1.2195652173913, 0.11111111111111
65487, 2.0260869565217, 1.1934782608696, 0.083333333333333
65488, 2.004347826087, 1.1934782608696, 0.055555555555556
65489, 2.0260869565217, 1.2195652173913, 0.055555555555556
65490, 2.0260869565217, 1.1934782608696, 0.027777777777778
65491, 2.0695652173913, 1.1934782608696, 0.47222222222222
65492, 2.0478260869565, 1.1934782608696, 0.44444444444444
65493, 2.0695652173913, 1.2195652173913, 0.44444444444444
65494, 2.0695652173913, 1.1934782608696, 0.41666666666667
65495, 2.0478260869565, 1.1934782608696, 0.38888888888889
65496, 2.0695652173913, 1.2195652173913, 0.38888888888889
65497, 2.0695652173913, 1.1934782608696, 0.36111111111111
65498, 2.0478260869565, 1.1934782608696, 0.33333333333333
65499, 2.0695652173913, 1.2195652173913, 0.33333333333333
65500, 2.0695652173913, 1.1934782608696, 0.30555555555556
65501, 2.0478260869565, 1.1934782608696, 0.27777777777778
65502, 2.0695652173913, 1.2195652173913, 0.27777777777778
65503, 2.0695652173913, 1.1934782608696, 0.25
65504, 2.0478260869565, 1.1934782608696, 0.22222222222222
65505, 2.0695652173913, 1.2195652173913, 0.22222222222222
65506, 2.0695652173913, 1.1934782608696, 0.19444444444444
65507, 2.0478260869565, 1.1934782608696, 0.16666666666667
65508, 2.0695652173913, 1.2195652173913, 0.16666666666667
65509, 2.0695652173913, 1.1934782608696, 0.13888888888889
65510, 2.0478260869565, 1.1934782608696, 0.11111111111111
65511, 2.0695652173913, 1.2195652173913, 0.11111111111111
65512, 2.0695652173913, 1.1934782608696, 0.083333333333333
65513, 2.0478260869565, 1.1934782608696, 0.055555555555556
65514, 2.0695652173913, 1.2195652173913, 0.055555555555556
65515, 2.0695652173913, 1.1934782608696, 0.027777777777778
65516, 2.1130434782609, 1.1934782608696, 0.47222222222222
65517, 2.0913043478261, 1.1934782608696, 0.44444444444444
65518, 2.1130434782609, 1.2195652173913, 0.44444444444444
65519, 2.1130434782609, 1.1934782608696, 0.41666666666667
65520, 2.0913043478261, 1.1934782608696, 0.38888888888889
65521, 2.1130434782609, 1.2195652173913, 0.38888888888889
65522, 2.1130434782609, 1.1934782608696, 0.36111111111111
65523, 2.0913043478261, 1.1934782608696, 0.33333333333333
65524, 2.1130434782609, 1.2195652173913, 0.33333333333333
65525, 2.1130434782609, 1.1934782608696, 0.30555555555556
65526, 2.0913043478261, 1.1934782608696, 0.27777777777778
65527, 2.1130434782609, 1.2195652173913, 0.27777777777778
65528, 2.1130434782609, 1.1934782608696, 0.25
65529, 2.0913043478261, 1.1934782608696, 0.22222222222222
65530, 2.1130434782609, 1.2195652173913, 0.22222222222222
65531, 2.1130434782609, 1.1934782608696, 0.19444444444444
65532, 2.0913043478261, 1.1934782608696, 0.16666666666667
65533, 2.1130434782609, 1.2195652173913, 0.16666666666667
65534, 2.1130434782609, 1.1934782608696, 0.13888888888889
65535, 2.0913043478261, 1.1934782608696, 0.11111111111111
65536, 2.1130434782609, 1.2195652173913, 0.11111111111111
65537, 2.1130434782609, 1.1934782608696, 0.083333333333333
65538, 2.0913043478261, 1.1934782608696, 0.055555555555556
65539, 2.1130434782609, 1.2195652173913, 0.055555555555556
65540, 2.1130434782609, 1.1934782608696, 0.027777777777778
65541, 2.1565217391304, 1.1934782608696, 0.47222222222222
65542, 2.1347826086957, 1.1934782608696, 0.44444444444444
65543, 2.1565217391304, 1.2195652173913, 0.44444444444444
65544, 2.1565217391304, 1.1934782608696, 0.41666666666667
65545, 2.1347826086957, 1.1934782608696, 0.38888888888889
65546, 2.1565217391304, 1.2195652173913, 0.38888888888889
65547, 2.1565217391304, 1.1934782608696, 0.36111111111111
65548, 2.1347826086957, 1.1934782608696, 0.33333333333333
65549, 2.1565217391304, 1.2195652173913, 0.33333333333333
65550, 2.1565217391304, 1.1934782608696, 0.30555555555556
65551, 2.1347826086957, 1.1934782608696, 0.27777777777778
65552, 2.1565217391304, 1.2195652173913, 0.27777777777778
65553, 2.1565217391304, 1.1934782608696, 0.25
65554, 2.1347826086957, 1.1934782608696, 0.22222222222222
65555, 2.1565217391304, 1.2195652173913, 0.22222222222222
65556, 2.1565217391304, 1.1934782608696, 0.19444444444444
65557, 2.1347826086957, 1.1934782608696, 0.16666666666667
65558, 2.1565217391304, 1.2195652173913, 0.16666666666667
65559, 2.1565217391304, 1.1934782608696, 0.13888888888889
65560, 2.1347826086957, 1.1934782608696, 0.11111111111111
65561, 2.1565217391304, 1.2195652173913, 0.11111111111111
65562, 2.1565217391304, 1.1934782608696, 0.083333333333333
65563, 2.1347826086957, 1.1934782608696, 0.055555555555556
65564, 2.1565217391304, 1.2195652173913, 0.055555555555556
65565, 2.1565217391304, 1.1934782608696, 0.027777777777778
65566, 2.1782608695652, 1.1934782608696, 0.44444444444444
65567, 2.1782608695652, 1.1934782608696, 0.38888888888889
65568, 2.1782608695652, 1.1934782608696, 0.33333333333333
65569, 2.1782608695652, 1.1934782608696, 0.27777777777778
65570, 2.1782608695652, 1.1934782608696, 0.22222222222222
65571, 2.1782608695652, 1.1934782608696, 0.16666666666667
65572, 2.1782608695652, 1.1934782608696, 0.11111111111111
65573, 2.1782608695652, 1.1934782608696, 0.055555555555556
65574, 1.2434782608696, 1.1413043478261, 0.47222222222222
65575, 1.2217391304348, 1.1413043478261, 0.44444444444444
65576, 1.2434782608696, 1.1673913043478, 0.44444444444444
65577, 1.2434782608696, 1.1413043478261, 0.41666666666667
65578, 1.2217391304348, 1.1413043478261, 0.38888888888889
65579, 1.2434782608696, 1.1673913043478, 0.38888888888889
65580, 1.2434782608696, 1.1413043478261, 0.36111111111111
65581, 1.2217391304348, 1.1413043478261, 0.33333333333333
65582, 1.2434782608696, 1.1673913043478, 0.33333333333333
65583, 1.2434782608696, 1.1413043478261, 0.30555555555556
65584, 1.2217391304348, 1.1413043478261, 0.27777777777778
65585, 1.2434782608696, 1.1673913043478, 0.27777777777778
65586, 1.2434782608696, 1.1413043478261, 0.25
65587, 1.2217391304348, 1.1413043478261, 0.22222222222222
65588, 1.2434782608696, 1.1673913043478, 0.22222222222222
65589, 1.2434782608696, 1.1413043478261, 0.19444444444444
65590, 1.2217391304348, 1.1413043478261, 0.16666666666667
65591, 1.2434782608696, 1.1673913043478, 0.16666666666667
65592, 1.2434782608696, 1.1413043478261, 0.13888888888889
65593, 1.2217391304348, 1.1413043478261, 0.11111111111111
65594, 1.2434782608696, 1.1673913043478, 0.11111111111111
65595, 1.2434782608696, 1.1413043478261, 0.083333333333333
65596, 1.2217391304348, 1.1413043478261, 0.055555555555556
65597, 1.2434782608696, 1.1673913043478, 0.055555555555556
65598, 1.2434782608696, 1.1413043478261, 0.027777777777778
65599, 1.2869565217391, 1.1413043478261, 0.47222222222222
65600, 1.2652173913043, 1.1413043478261, 0.44444444444444
65601, 1.2869565217391, 1.1673913043478, 0.44444444444444
65602, 1.2869565217391, 1.1413043478261, 0.41666666666667
65603, 1.2652173913043, 1.1413043478261, 0.38888888888889
65604, 1.2869565217391, 1.1673913043478, 0.38888888888889
65605, 1.2869565217391, 1.1413043478261, 0.36111111111111
65606, 1.2652173913043, 1.1413043478261, 0.33333333333333
65607, 1.2869565217391, 1.1673913043478, 0.33333333333333
65608, 1.2869565217391, 1.1413043478261, 0.30555555555556
65609, 1.2652173913043, 1.1413043478261, 0.27777777777778
65610, 1.2869565217391, 1.1673913043478, 0.27777777777778
65611, 1.2869565217391, 1.1413043478261, 0.25
65612, 1.2652173913043, 1.1413043478261, 0.22222222222222
65613, 1.2869565217391, 1.1673913043478, 0.22222222222222
65614, 1.2869565217391, 1.1413043478261, 0.19444444444444
65615, 1.2652173913043, 1.1413043478261, 0.16666666666667
65616, 1.2869565217391, 1.1673913043478, 0.16666666666667
65617, 1.2869565217391, 1.1413043478261, 0.13888888888889
65618, 1.2652173913043, 1.1413043478261, 0.11111111111111
65619, 1.2869565217391, 1.1673913043478, 0.11111111111111
65620, 1.2869565217391, 1.1413043478261, 0.083333333333333
65621, 1.2652173913043, 1.1413043478261, 0.055555555555556
65622, 1.2869565217391, 1.1673913043478, 0.055555555555556
65623, 1.2869565217391, 1.1413043478261, 0.027777777777778
65624, 1.3304347826087, 1.1413043478261, 0.47222222222222
65625, 1.3086956521739, 1.1413043478261, 0.44444444444444
65626, 1.3304347826087, 1.1673913043478, 0.44444444444444
65627, 1.3304347826087, 1.1413043478261, 0.41666666666667
65628, 1.3086956521739, 1.1413043478261, 0.38888888888889
65629, 1.3304347826087, 1.1673913043478, 0.38888888888889
65630, 1.3304347826087, 1.1413043478261, 0.36111111111111
65631, 1.3086956521739, 1.1413043478261, 0.33333333333333
65632, 1.3304347826087, 1.1673913043478, 0.33333333333333
65633, 1.3304347826087, 1.1413043478261, 0.30555555555556
65634, 1.3086956521739, 1.1413043478261, 0.27777777777778
65635, 1.3304347826087, 1.1673913043478, 0.27777777777778
65636, 1.3304347826087, 1.1413043478261, 0.25
65637, 1.3086956521739, 1.1413043478261, 0.22222222222222
65638, 1.3304347826087, 1.1673913043478, 0.22222222222222
65639, 1.3304347826087, 1.1413043478261, 0.19444444444444
65640, 1.3086956521739, 1.1413043478261, 0.16666666666667
65641, 1.3304347826087, 1.1673913043478, 0.16666666666667
65642, 1.3304347826087, 1.1413043478261, 0.13888888888889
65643, 1.3086956521739, 1.1413043478261, 0.11111111111111
65644, 1.3304347826087, 1.1673913043478, 0.11111111111111
65645, 1.3304347826087, 1.1413043478261, 0.083333333333333
65646, 1.3086956521739, 1.1413043478261, 0.055555555555556
65647, 1.3304347826087, 1.1673913043478, 0.055555555555556
65648, 1.3304347826087, 1.1413043478261, 0.027777777777778
65649, 1.3739130434783, 1.1413043478261, 0.47222222222222
65650, 1.3521739130435, 1.1413043478261, 0.44444444444444
65651, 1.3739130434783, 1.1673913043478, 0.44444444444444
65652, 1.3739130434783, 1.1413043478261, 0.41666666666667
65653, 1.3521739130435, 1.1413043478261, 0.38888888888889
65654, 1.3739130434783, 1.1673913043478, 0.38888888888889
65655, 1.3739130434783, 1.1413043478261, 0.36111111111111
65656, 1.3521739130435, 1.1413043478261, 0.33333333333333
65657, 1.3739130434783, 1.1673913043478, 0.33333333333333
65658, 1.3739130434783, 1.1413043478261, 0.30555555555556
65659, 1.3521739130435, 1.1413043478261, 0.27777777777778
65660, 1.3739130434783, 1.1673913043478, 0.27777777777778
65661, 1.3739130434783, 1.1413043478261, 0.25
65662, 1.3521739130435, 1.1413043478261, 0.22222222222222
65663, 1.3739130434783, 1.1673913043478, 0.22222222222222
65664, 1.3739130434783, 1.1413043478261, 0.19444444444444
65665, 1.3521739130435, 1.1413043478261, 0.16666666666667
65666, 1.3739130434783, 1.1673913043478, 0.16666666666667
65667, 1.3739130434783, 1.1413043478261, 0.13888888888889
65668, 1.3521739130435, 1.1413043478261, 0.11111111111111
65669, 1.3739130434783, 1.1673913043478, 0.11111111111111
65670, 1.3739130434783, 1.1413043478261, 0.083333333333333
65671, 1.3521739130435, 1.1413043478261, 0.055555555555556
65672, 1.3739130434783, 1.1673913043478, 0.055555555555556
65673, 1.3739130434783, 1.1413043478261, 0.027777777777778
65674, 1.4173913043478, 1.1413043478261, 0.47222222222222
65675, 1.395652173913, 1.1413043478261, 0.44444444444444
65676, 1.4173913043478, 1.1673913043478, 0.44444444444444
65677, 1.4173913043478, 1.1413043478261, 0.41666666666667
65678, 1.395652173913, 1.1413043478261, 0.38888888888889
65679, 1.4173913043478, 1.1673913043478, 0.38888888888889
65680, 1.4173913043478, 1.1413043478261, 0.36111111111111
65681, 1.395652173913, 1.1413043478261, 0.33333333333333
65682, 1.4173913043478, 1.1673913043478, 0.33333333333333
65683, 1.4173913043478, 1.1413043478261, 0.30555555555556
65684, 1.395652173913, 1.1413043478261, 0.27777777777778
65685, 1.4173913043478, 1.1673913043478, 0.27777777777778
65686, 1.4173913043478, 1.1413043478261, 0.25
65687, 1.395652173913, 1.1413043478261, 0.22222222222222
65688, 1.4173913043478, 1.1673913043478, 0.22222222222222
65689, 1.4173913043478, 1.1413043478261, 0.19444444444444
65690, 1.395652173913, 1.1413043478261, 0.16666666666667
65691, 1.4173913043478, 1.1673913043478, 0.16666666666667
65692, 1.4173913043478, 1.1413043478261, 0.13888888888889
65693, 1.395652173913, 1.1413043478261, 0.11111111111111
65694, 1.4173913043478, 1.1673913043478, 0.11111111111111
65695, 1.4173913043478, 1.1413043478261, 0.083333333333333
65696, 1.395652173913, 1.1413043478261, 0.055555555555556
65697, 1.4173913043478, 1.1673913043478, 0.055555555555556
65698, 1.4173913043478, 1.1413043478261, 0.027777777777778
65699, 1.4608695652174, 1.1413043478261, 0.47222222222222
65700, 1.4391304347826, 1.1413043478261, 0.44444444444444
65701, 1.4608695652174, 1.1673913043478, 0.44444444444444
65702, 1.4608695652174, 1.1413043478261, 0.41666666666667
65703, 1.4391304347826, 1.1413043478261, 0.38888888888889
65704, 1.4608695652174, 1.1673913043478, 0.38888888888889
65705, 1.4608695652174, 1.1413043478261, 0.36111111111111
65706, 1.4391304347826, 1.1413043478261, 0.33333333333333
65707, 1.4608695652174, 1.1673913043478, 0.33333333333333
65708, 1.4608695652174, 1.1413043478261, 0.30555555555556
65709, 1.4391304347826, 1.1413043478261, 0.27777777777778
65710, 1.4608695652174, 1.1673913043478, 0.27777777777778
65711, 1.4608695652174, 1.1413043478261, 0.25
65712, 1.4391304347826, 1.1413043478261, 0.22222222222222
65713, 1.4608695652174, 1.1673913043478, 0.22222222222222
65714, 1.4608695652174, 1.1413043478261, 0.19444444444444
65715, 1.4391304347826, 1.1413043478261, 0.16666666666667
65716, 1.4608695652174, 1.1673913043478, 0.16666666666667
65717, 1.4608695652174, 1.1413043478261, 0.13888888888889
65718, 1.4391304347826, 1.1413043478261, 0.11111111111111
65719, 1.4608695652174, 1.1673913043478, 0.11111111111111
65720, 1.4608695652174, 1.1413043478261, 0.083333333333333
65721, 1.4391304347826, 1.1413043478261, 0.055555555555556
65722, 1.4608695652174, 1.1673913043478, 0.055555555555556
65723, 1.4608695652174, 1.1413043478261, 0.027777777777778
65724, 1.504347826087, 1.1413043478261, 0.47222222222222
65725, 1.4826086956522, 1.1413043478261, 0.44444444444444
65726, 1.504347826087, 1.1673913043478, 0.44444444444444
65727, 1.504347826087, 1.1413043478261, 0.41666666666667
65728, 1.4826086956522, 1.1413043478261, 0.38888888888889
65729, 1.504347826087, 1.1673913043478, 0.38888888888889
65730, 1.504347826087, 1.1413043478261, 0.36111111111111
65731, 1.4826086956522, 1.1413043478261, 0.33333333333333
65732, 1.504347826087, 1.1673913043478, 0.33333333333333
65733, 1.504347826087, 1.1413043478261, 0.30555555555556
65734, 1.4826086956522, 1.1413043478261, 0.27777777777778
65735, 1.504347826087, 1.1673913043478, 0.27777777777778
65736, 1.504347826087, 1.1413043478261, 0.25
65737, 1.4826086956522, 1.1413043478261, 0.22222222222222
65738, 1.504347826087, 1.1673913043478, 0.22222222222222
65739, 1.504347826087, 1.1413043478261, 0.19444444444444
65740, 1.4826086956522, 1.1413043478261, 0.16666666666667
65741, 1.504347826087, 1.1673913043478, 0.16666666666667
65742, 1.504347826087, 1.1413043478261, 0.13888888888889
65743, 1.4826086956522, 1.1413043478261, 0.11111111111111
65744, 1.504347826087, 1.1673913043478, 0.11111111111111
65745, 1.504347826087, 1.1413043478261, 0.083333333333333
65746, 1.4826086956522, 1.1413043478261, 0.055555555555556
65747, 1.504347826087, 1.1673913043478, 0.055555555555556
65748, 1.504347826087, 1.1413043478261, 0.027777777777778
65749, 1.5478260869565, 1.1413043478261, 0.47222222222222
65750, 1.5260869565217, 1.1413043478261, 0.44444444444444
65751, 1.5478260869565, 1.1673913043478, 0.44444444444444
65752, 1.5478260869565, 1.1413043478261, 0.41666666666667
65753, 1.5260869565217, 1.1413043478261, 0.38888888888889
65754, 1.5478260869565, 1.1673913043478, 0.38888888888889
65755, 1.5478260869565, 1.1413043478261, 0.36111111111111
65756, 1.5260869565217, 1.1413043478261, 0.33333333333333
65757, 1.5478260869565, 1.1673913043478, 0.33333333333333
65758, 1.5478260869565, 1.1413043478261, 0.30555555555556
65759, 1.5260869565217, 1.1413043478261, 0.27777777777778
65760, 1.5478260869565, 1.1673913043478, 0.27777777777778
65761, 1.5478260869565, 1.1413043478261, 0.25
65762, 1.5260869565217, 1.1413043478261, 0.22222222222222
65763, 1.5478260869565, 1.1673913043478, 0.22222222222222
65764, 1.5478260869565, 1.1413043478261, 0.19444444444444
65765, 1.5260869565217, 1.1413043478261, 0.16666666666667
65766, 1.5478260869565, 1.1673913043478, 0.16666666666667
65767, 1.5478260869565, 1.1413043478261, 0.13888888888889
65768, 1.5260869565217, 1.1413043478261, 0.11111111111111
65769, 1.5478260869565, 1.1673913043478, 0.11111111111111
65770, 1.5478260869565, 1.1413043478261, 0.083333333333333
65771, 1.5260869565217, 1.1413043478261, 0.055555555555556
65772, 1.5478260869565, 1.1673913043478, 0.055555555555556
65773, 1.5478260869565, 1.1413043478261, 0.027777777777778
65774, 1.5913043478261, 1.1413043478261, 0.47222222222222
65775, 1.5695652173913, 1.1413043478261, 0.44444444444444
65776, 1.5913043478261, 1.1673913043478, 0.44444444444444
65777, 1.5913043478261, 1.1413043478261, 0.41666666666667
65778, 1.5695652173913, 1.1413043478261, 0.38888888888889
65779, 1.5913043478261, 1.1673913043478, 0.38888888888889
65780, 1.5913043478261, 1.1413043478261, 0.36111111111111
65781, 1.5695652173913, 1.1413043478261, 0.33333333333333
65782, 1.5913043478261, 1.1673913043478, 0.33333333333333
65783, 1.5913043478261, 1.1413043478261, 0.30555555555556
65784, 1.5695652173913, 1.1413043478261, 0.27777777777778
65785, 1.5913043478261, 1.1673913043478, 0.27777777777778
65786, 1.5913043478261, 1.1413043478261, 0.25
65787, 1.5695652173913, 1.1413043478261, 0.22222222222222
65788, 1.5913043478261, 1.1673913043478, 0.22222222222222
65789, 1.5913043478261, 1.1413043478261, 0.19444444444444
65790, 1.5695652173913, 1.1413043478261, 0.16666666666667
65791, 1.5913043478261, 1.1673913043478, 0.16666666666667
65792, 1.5913043478261, 1.1413043478261, 0.13888888888889
65793, 1.5695652173913, 1.1413043478261, 0.11111111111111
65794, 1.5913043478261, 1.1673913043478, 0.11111111111111
65795, 1.5913043478261, 1.1413043478261, 0.083333333333333
65796, 1.5695652173913, 1.1413043478261, 0.055555555555556
65797, 1.5913043478261, 1.1673913043478, 0.055555555555556
65798, 1.5913043478261, 1.1413043478261, 0.027777777777778
65799, 1.6347826086957, 1.1413043478261, 0.47222222222222
65800, 1.6130434782609, 1.1413043478261, 0.44444444444444
65801, 1.6347826086957, 1.1673913043478, 0.44444444444444
65802, 1.6347826086957, 1.1413043478261, 0.41666666666667
65803, 1.6130434782609, 1.1413043478261, 0.38888888888889
65804, 1.6347826086957, 1.1673913043478, 0.38888888888889
65805, 1.6347826086957, 1.1413043478261, 0.36111111111111
65806, 1.6130434782609, 1.1413043478261, 0.33333333333333
65807, 1.6347826086957, 1.1673913043478, 0.33333333333333
65808, 1.6347826086957, 1.1413043478261, 0.30555555555556
65809, 1.6130434782609, 1.1413043478261, 0.27777777777778
65810, 1.6347826086957, 1.1673913043478, 0.27777777777778
65811, 1.6347826086957, 1.1413043478261, 0.25
65812, 1.6130434782609, 1.1413043478261, 0.22222222222222
65813, 1.6347826086957, 1.1673913043478, 0.22222222222222
65814, 1.6347826086957, 1.1413043478261, 0.19444444444444
65815, 1.6130434782609, 1.1413043478261, 0.16666666666667
65816, 1.6347826086957, 1.1673913043478, 0.16666666666667
65817, 1.6347826086957, 1.1413043478261, 0.13888888888889
65818, 1.6130434782609, 1.1413043478261, 0.11111111111111
65819, 1.6347826086957, 1.1673913043478, 0.11111111111111
65820, 1.6347826086957, 1.1413043478261, 0.083333333333333
65821, 1.6130434782609, 1.1413043478261, 0.055555555555556
65822, 1.6347826086957, 1.1673913043478, 0.055555555555556
65823, 1.6347826086957, 1.1413043478261, 0.027777777777778
65824, 1.6782608695652, 1.1413043478261, 0.47222222222222
65825, 1.6565217391304, 1.1413043478261, 0.44444444444444
65826, 1.6782608695652, 1.1673913043478, 0.44444444444444
65827, 1.6782608695652, 1.1413043478261, 0.41666666666667
65828, 1.6565217391304, 1.1413043478261, 0.38888888888889
65829, 1.6782608695652, 1.1673913043478, 0.38888888888889
65830, 1.6782608695652, 1.1413043478261, 0.36111111111111
65831, 1.6565217391304, 1.1413043478261, 0.33333333333333
65832, 1.6782608695652, 1.1673913043478, 0.33333333333333
65833, 1.6782608695652, 1.1413043478261, 0.30555555555556
65834, 1.6565217391304, 1.1413043478261, 0.27777777777778
65835, 1.6782608695652, 1.1673913043478, 0.27777777777778
65836, 1.6782608695652, 1.1413043478261, 0.25
65837, 1.6565217391304, 1.1413043478261, 0.22222222222222
65838, 1.6782608695652, 1.1673913043478, 0.22222222222222
65839, 1.6782608695652, 1.1413043478261, 0.19444444444444
65840, 1.6565217391304, 1.1413043478261, 0.16666666666667
65841, 1.6782608695652, 1.1673913043478, 0.16666666666667
65842, 1.6782608695652, 1.1413043478261, 0.13888888888889
65843, 1.6565217391304, 1.1413043478261, 0.11111111111111
65844, 1.6782608695652, 1.1673913043478, 0.11111111111111
65845, 1.6782608695652, 1.1413043478261, 0.083333333333333
65846, 1.6565217391304, 1.1413043478261, 0.055555555555556
65847, 1.6782608695652, 1.1673913043478, 0.055555555555556
65848, 1.6782608695652, 1.1413043478261, 0.027777777777778
65849, 1.7217391304348, 1.1413043478261, 0.47222222222222
65850, 1.7, 1.1413043478261, 0.44444444444444
65851, 1.7217391304348, 1.1673913043478, 0.44444444444444
65852, 1.7217391304348, 1.1413043478261, 0.41666666666667
65853, 1.7, 1.1413043478261, 0.38888888888889
65854, 1.7217391304348, 1.1673913043478, 0.38888888888889
65855, 1.7217391304348, 1.1413043478261, 0.36111111111111
65856, 1.7, 1.1413043478261, 0.33333333333333
65857, 1.7217391304348, 1.1673913043478, 0.33333333333333
65858, 1.7217391304348, 1.1413043478261, 0.30555555555556
65859, 1.7, 1.1413043478261, 0.27777777777778
65860, 1.7217391304348, 1.1673913043478, 0.27777777777778
65861, 1.7217391304348, 1.1413043478261, 0.25
65862, 1.7, 1.1413043478261, 0.22222222222222
65863, 1.7217391304348, 1.1673913043478, 0.22222222222222
65864, 1.7217391304348, 1.1413043478261, 0.19444444444444
65865, 1.7, 1.1413043478261, 0.16666666666667
65866, 1.7217391304348, 1.1673913043478, 0.16666666666667
65867, 1.7217391304348, 1.1413043478261, 0.13888888888889
65868, 1.7, 1.1413043478261, 0.11111111111111
65869, 1.7217391304348, 1.1673913043478, 0.11111111111111
65870, 1.7217391304348, 1.1413043478261, 0.083333333333333
65871, 1.7, 1.1413043478261, 0.055555555555556
65872, 1.7217391304348, 1.1673913043478, 0.055555555555556
65873, 1.7217391304348, 1.1413043478261, 0.027777777777778
65874, 1.7652173913043, 1.1413043478261, 0.47222222222222
65875, 1.7434782608696, 1.1413043478261, 0.44444444444444
65876, 1.7652173913043, 1.1673913043478, 0.44444444444444
65877, 1.7652173913043, 1.1413043478261, 0.41666666666667
65878, 1.7434782608696, 1.1413043478261, 0.38888888888889
65879, 1.7652173913043, 1.1673913043478, 0.38888888888889
65880, 1.7652173913043, 1.1413043478261, 0.36111111111111
65881, 1.7434782608696, 1.1413043478261, 0.33333333333333
65882, 1.7652173913043, 1.1673913043478, 0.33333333333333
65883, 1.7652173913043, 1.1413043478261, 0.30555555555556
65884, 1.7434782608696, 1.1413043478261, 0.27777777777778
65885, 1.7652173913043, 1.1673913043478, 0.27777777777778
65886, 1.7652173913043, 1.1413043478261, 0.25
65887, 1.7434782608696, 1.1413043478261, 0.22222222222222
65888, 1.7652173913043, 1.1673913043478, 0.22222222222222
65889, 1.7652173913043, 1.1413043478261, 0.19444444444444
65890, 1.7434782608696, 1.1413043478261, 0.16666666666667
65891, 1.7652173913043, 1.1673913043478, 0.16666666666667
65892, 1.7652173913043, 1.1413043478261, 0.13888888888889
65893, 1.7434782608696, 1.1413043478261, 0.11111111111111
65894, 1.7652173913043, 1.1673913043478, 0.11111111111111
65895, 1.7652173913043, 1.1413043478261, 0.083333333333333
65896, 1.7434782608696, 1.1413043478261, 0.055555555555556
65897, 1.7652173913043, 1.1673913043478, 0.055555555555556
65898, 1.7652173913043, 1.1413043478261, 0.027777777777778
65899, 1.8086956521739, 1.1413043478261, 0.47222222222222
65900, 1.7869565217391, 1.1413043478261, 0.44444444444444
65901, 1.8086956521739, 1.1673913043478, 0.44444444444444
65902, 1.8086956521739, 1.1413043478261, 0.41666666666667
65903, 1.7869565217391, 1.1413043478261, 0.38888888888889
65904, 1.8086956521739, 1.1673913043478, 0.38888888888889
65905, 1.8086956521739, 1.1413043478261, 0.36111111111111
65906, 1.7869565217391, 1.1413043478261, 0.33333333333333
65907, 1.8086956521739, 1.1673913043478, 0.33333333333333
65908, 1.8086956521739, 1.1413043478261, 0.30555555555556
65909, 1.7869565217391, 1.1413043478261, 0.27777777777778
65910, 1.8086956521739, 1.1673913043478, 0.27777777777778
65911, 1.8086956521739, 1.1413043478261, 0.25
65912, 1.7869565217391, 1.1413043478261, 0.22222222222222
65913, 1.8086956521739, 1.1673913043478, 0.22222222222222
65914, 1.8086956521739, 1.1413043478261, 0.19444444444444
65915, 1.7869565217391, 1.1413043478261, 0.16666666666667
65916, 1.8086956521739, 1.1673913043478, 0.16666666666667
65917, 1.8086956521739, 1.1413043478261, 0.13888888888889
65918, 1.7869565217391, 1.1413043478261, 0.11111111111111
65919, 1.8086956521739, 1.1673913043478, 0.11111111111111
65920, 1.8086956521739, 1.1413043478261, 0.083333333333333
65921, 1.7869565217391, 1.1413043478261, 0.055555555555556
65922, 1.8086956521739, 1.1673913043478, 0.055555555555556
65923, 1.8086956521739, 1.1413043478261, 0.027777777777778
65924, 1.8521739130435, 1.1413043478261, 0.47222222222222
65925, 1.8304347826087, 1.1413043478261, 0.44444444444444
65926, 1.8521739130435, 1.1673913043478, 0.44444444444444
65927, 1.8521739130435, 1.1413043478261, 0.41666666666667
65928, 1.8304347826087, 1.1413043478261, 0.38888888888889
65929, 1.8521739130435, 1.1673913043478, 0.38888888888889
65930, 1.8521739130435, 1.1413043478261, 0.36111111111111
65931, 1.8304347826087, 1.1413043478261, 0.33333333333333
65932, 1.8521739130435, 1.1673913043478, 0.33333333333333
65933, 1.8521739130435, 1.1413043478261, 0.30555555555556
65934, 1.8304347826087, 1.1413043478261, 0.27777777777778
65935, 1.8521739130435, 1.1673913043478, 0.27777777777778
65936, 1.8521739130435, 1.1413043478261, 0.25
65937, 1.8304347826087, 1.1413043478261, 0.22222222222222
65938, 1.8521739130435, 1.1673913043478, 0.22222222222222
65939, 1.8521739130435, 1.1413043478261, 0.19444444444444
65940, 1.8304347826087, 1.1413043478261, 0.16666666666667
65941, 1.8521739130435, 1.1673913043478, 0.16666666666667
65942, 1.8521739130435, 1.1413043478261, 0.13888888888889
65943, 1.8304347826087, 1.1413043478261, 0.11111111111111
65944, 1.8521739130435, 1.1673913043478, 0.11111111111111
65945, 1.8521739130435, 1.1413043478261, 0.083333333333333
65946, 1.8304347826087, 1.1413043478261, 0.055555555555556
65947, 1.8521739130435, 1.1673913043478, 0.055555555555556
65948, 1.8521739130435, 1.1413043478261, 0.027777777777778
65949, 1.895652173913, 1.1413043478261, 0.47222222222222
65950, 1.8739130434783, 1.1413043478261, 0.44444444444444
65951, 1.895652173913, 1.1673913043478, 0.44444444444444
65952, 1.895652173913, 1.1413043478261, 0.41666666666667
65953, 1.8739130434783, 1.1413043478261, 0.38888888888889
65954, 1.895652173913, 1.1673913043478, 0.38888888888889
65955, 1.895652173913, 1.1413043478261, 0.36111111111111
65956, 1.8739130434783, 1.1413043478261, 0.33333333333333
65957, 1.895652173913, 1.1673913043478, 0.33333333333333
65958, 1.895652173913, 1.1413043478261, 0.30555555555556
65959, 1.8739130434783, 1.1413043478261, 0.27777777777778
65960, 1.895652173913, 1.1673913043478, 0.27777777777778
65961, 1.895652173913, 1.1413043478261, 0.25
65962, 1.8739130434783, 1.1413043478261, 0.22222222222222
65963, 1.895652173913, 1.1673913043478, 0.22222222222222
65964, 1.895652173913, 1.1413043478261, 0.19444444444444
65965, 1.8739130434783, 1.1413043478261, 0.16666666666667
65966, 1.895652173913, 1.1673913043478, 0.16666666666667
65967, 1.895652173913, 1.1413043478261, 0.13888888888889
65968, 1.8739130434783, 1.1413043478261, 0.11111111111111
65969, 1.895652173913, 1.1673913043478, 0.11111111111111
65970, 1.895652173913, 1.1413043478261, 0.083333333333333
65971, 1.8739130434783, 1.1413043478261, 0.055555555555556
65972, 1.895652173913, 1.1673913043478, 0.055555555555556
65973, 1.895652173913, 1.1413043478261, 0.027777777777778
65974, 1.9391304347826, 1.1413043478261, 0.47222222222222
65975, 1.9173913043478, 1.1413043478261, 0.44444444444444
65976, 1.9391304347826, 1.1673913043478, 0.44444444444444
65977, 1.9391304347826, 1.1413043478261, 0.41666666666667
65978, 1.9173913043478, 1.1413043478261, 0.38888888888889
65979, 1.9391304347826, 1.1673913043478, 0.38888888888889
65980, 1.9391304347826, 1.1413043478261, 0.36111111111111
65981, 1.9173913043478, 1.1413043478261, 0.33333333333333
65982, 1.9391304347826, 1.1673913043478, 0.33333333333333
65983, 1.9391304347826, 1.1413043478261, 0.30555555555556
65984, 1.9173913043478, 1.1413043478261, 0.27777777777778
65985, 1.9391304347826, 1.1673913043478, 0.27777777777778
65986, 1.9391304347826, 1.1413043478261, 0.25
65987, 1.9173913043478, 1.1413043478261, 0.22222222222222
65988, 1.9391304347826, 1.1673913043478, 0.22222222222222
65989, 1.9391304347826, 1.1413043478261, 0.19444444444444
65990, 1.9173913043478, 1.1413043478261, 0.16666666666667
65991, 1.9391304347826, 1.1673913043478, 0.16666666666667
65992, 1.9391304347826, 1.1413043478261, 0.13888888888889
65993, 1.9173913043478, 1.1413043478261, 0.11111111111111
65994, 1.9391304347826, 1.1673913043478, 0.11111111111111
65995, 1.9391304347826, 1.1413043478261, 0.083333333333333
65996, 1.9173913043478, 1.1413043478261, 0.055555555555556
65997, 1.9391304347826, 1.1673913043478, 0.055555555555556
65998, 1.9391304347826, 1.1413043478261, 0.027777777777778
65999, 1.9826086956522, 1.1413043478261, 0.47222222222222
66000, 1.9608695652174, 1.1413043478261, 0.44444444444444
66001, 1.9826086956522, 1.1673913043478, 0.44444444444444
66002, 1.9826086956522, 1.1413043478261, 0.41666666666667
66003, 1.9608695652174, 1.1413043478261, 0.38888888888889
66004, 1.9826086956522, 1.1673913043478, 0.38888888888889
66005, 1.9826086956522, 1.1413043478261, 0.36111111111111
66006, 1.9608695652174, 1.1413043478261, 0.33333333333333
66007, 1.9826086956522, 1.1673913043478, 0.33333333333333
66008, 1.9826086956522, 1.1413043478261, 0.30555555555556
66009, 1.9608695652174, 1.1413043478261, 0.27777777777778
66010, 1.9826086956522, 1.1673913043478, 0.27777777777778
66011, 1.9826086956522, 1.1413043478261, 0.25
66012, 1.9608695652174, 1.1413043478261, 0.22222222222222
66013, 1.9826086956522, 1.1673913043478, 0.22222222222222
66014, 1.9826086956522, 1.1413043478261, 0.19444444444444
66015, 1.9608695652174, 1.1413043478261, 0.16666666666667
66016, 1.9826086956522, 1.1673913043478, 0.16666666666667
66017, 1.9826086956522, 1.1413043478261, 0.13888888888889
66018, 1.9608695652174, 1.1413043478261, 0.11111111111111
66019, 1.9826086956522, 1.1673913043478, 0.11111111111111
66020, 1.9826086956522, 1.1413043478261, 0.083333333333333
66021, 1.9608695652174, 1.1413043478261, 0.055555555555556
66022, 1.9826086956522, 1.1673913043478, 0.055555555555556
66023, 1.9826086956522, 1.1413043478261, 0.027777777777778
66024, 2.0260869565217, 1.1413043478261, 0.47222222222222
66025, 2.004347826087, 1.1413043478261, 0.44444444444444
66026, 2.0260869565217, 1.1673913043478, 0.44444444444444
66027, 2.0260869565217, 1.1413043478261, 0.41666666666667
66028, 2.004347826087, 1.1413043478261, 0.38888888888889
66029, 2.0260869565217, 1.1673913043478, 0.38888888888889
66030, 2.0260869565217, 1.1413043478261, 0.36111111111111
66031, 2.004347826087, 1.1413043478261, 0.33333333333333
66032, 2.0260869565217, 1.1673913043478, 0.33333333333333
66033, 2.0260869565217, 1.1413043478261, 0.30555555555556
66034, 2.004347826087, 1.1413043478261, 0.27777777777778
66035, 2.0260869565217, 1.1673913043478, 0.27777777777778
66036, 2.0260869565217, 1.1413043478261, 0.25
66037, 2.004347826087, 1.1413043478261, 0.22222222222222
66038, 2.0260869565217, 1.1673913043478, 0.22222222222222
66039, 2.0260869565217, 1.1413043478261, 0.19444444444444
66040, 2.004347826087, 1.1413043478261, 0.16666666666667
66041, 2.0260869565217, 1.1673913043478, 0.16666666666667
66042, 2.0260869565217, 1.1413043478261, 0.13888888888889
66043, 2.004347826087, 1.1413043478261, 0.11111111111111
66044, 2.0260869565217, 1.1673913043478, 0.11111111111111
66045, 2.0260869565217, 1.1413043478261, 0.083333333333333
66046, 2.004347826087, 1.1413043478261, 0.055555555555556
66047, 2.0260869565217, 1.1673913043478, 0.055555555555556
66048, 2.0260869565217, 1.1413043478261, 0.027777777777778
66049, 2.0695652173913, 1.1413043478261, 0.47222222222222
66050, 2.0478260869565, 1.1413043478261, 0.44444444444444
66051, 2.0695652173913, 1.1673913043478, 0.44444444444444
66052, 2.0695652173913, 1.1413043478261, 0.41666666666667
66053, 2.0478260869565, 1.1413043478261, 0.38888888888889
66054, 2.0695652173913, 1.1673913043478, 0.38888888888889
66055, 2.0695652173913, 1.1413043478261, 0.36111111111111
66056, 2.0478260869565, 1.1413043478261, 0.33333333333333
66057, 2.0695652173913, 1.1673913043478, 0.33333333333333
66058, 2.0695652173913, 1.1413043478261, 0.30555555555556
66059, 2.0478260869565, 1.1413043478261, 0.27777777777778
66060, 2.0695652173913, 1.1673913043478, 0.27777777777778
66061, 2.0695652173913, 1.1413043478261, 0.25
66062, 2.0478260869565, 1.1413043478261, 0.22222222222222
66063, 2.0695652173913, 1.1673913043478, 0.22222222222222
66064, 2.0695652173913, 1.1413043478261, 0.19444444444444
66065, 2.0478260869565, 1.1413043478261, 0.16666666666667
66066, 2.0695652173913, 1.1673913043478, 0.16666666666667
66067, 2.0695652173913, 1.1413043478261, 0.13888888888889
66068, 2.0478260869565, 1.1413043478261, 0.11111111111111
66069, 2.0695652173913, 1.1673913043478, 0.11111111111111
66070, 2.0695652173913, 1.1413043478261, 0.083333333333333
66071, 2.0478260869565, 1.1413043478261, 0.055555555555556
66072, 2.0695652173913, 1.1673913043478, 0.055555555555556
66073, 2.0695652173913, 1.1413043478261, 0.027777777777778
66074, 2.1130434782609, 1.1413043478261, 0.47222222222222
66075, 2.0913043478261, 1.1413043478261, 0.44444444444444
66076, 2.1130434782609, 1.1673913043478, 0.44444444444444
66077, 2.1130434782609, 1.1413043478261, 0.41666666666667
66078, 2.0913043478261, 1.1413043478261, 0.38888888888889
66079, 2.1130434782609, 1.1673913043478, 0.38888888888889
66080, 2.1130434782609, 1.1413043478261, 0.36111111111111
66081, 2.0913043478261, 1.1413043478261, 0.33333333333333
66082, 2.1130434782609, 1.1673913043478, 0.33333333333333
66083, 2.1130434782609, 1.1413043478261, 0.30555555555556
66084, 2.0913043478261, 1.1413043478261, 0.27777777777778
66085, 2.1130434782609, 1.1673913043478, 0.27777777777778
66086, 2.1130434782609, 1.1413043478261, 0.25
66087, 2.0913043478261, 1.1413043478261, 0.22222222222222
66088, 2.1130434782609, 1.1673913043478, 0.22222222222222
66089, 2.1130434782609, 1.1413043478261, 0.19444444444444
66090, 2.0913043478261, 1.1413043478261, 0.16666666666667
66091, 2.1130434782609, 1.1673913043478, 0.16666666666667
66092, 2.1130434782609, 1.1413043478261, 0.13888888888889
66093, 2.0913043478261, 1.1413043478261, 0.11111111111111
66094, 2.1130434782609, 1.1673913043478, 0.11111111111111
66095, 2.1130434782609, 1.1413043478261, 0.083333333333333
66096, 2.0913043478261, 1.1413043478261, 0.055555555555556
66097, 2.1130434782609, 1.1673913043478, 0.055555555555556
66098, 2.1130434782609, 1.1413043478261, 0.027777777777778
66099, 2.1565217391304, 1.1413043478261, 0.47222222222222
66100, 2.1347826086957, 1.1413043478261, 0.44444444444444
66101, 2.1565217391304, 1.1673913043478, 0.44444444444444
66102, 2.1565217391304, 1.1413043478261, 0.41666666666667
66103, 2.1347826086957, 1.1413043478261, 0.38888888888889
66104, 2.1565217391304, 1.1673913043478, 0.38888888888889
66105, 2.1565217391304, 1.1413043478261, 0.36111111111111
66106, 2.1347826086957, 1.1413043478261, 0.33333333333333
66107, 2.1565217391304, 1.1673913043478, 0.33333333333333
66108, 2.1565217391304, 1.1413043478261, 0.30555555555556
66109, 2.1347826086957, 1.1413043478261, 0.27777777777778
66110, 2.1565217391304, 1.1673913043478, 0.27777777777778
66111, 2.1565217391304, 1.1413043478261, 0.25
66112, 2.1347826086957, 1.1413043478261, 0.22222222222222
66113, 2.1565217391304, 1.1673913043478, 0.22222222222222
66114, 2.1565217391304, 1.1413043478261, 0.19444444444444
66115, 2.1347826086957, 1.1413043478261, 0.16666666666667
66116, 2.1565217391304, 1.1673913043478, 0.16666666666667
66117, 2.1565217391304, 1.1413043478261, 0.13888888888889
66118, 2.1347826086957, 1.1413043478261, 0.11111111111111
66119, 2.1565217391304, 1.1673913043478, 0.11111111111111
66120, 2.1565217391304, 1.1413043478261, 0.083333333333333
66121, 2.1347826086957, 1.1413043478261, 0.055555555555556
66122, 2.1565217391304, 1.1673913043478, 0.055555555555556
66123, 2.1565217391304, 1.1413043478261, 0.027777777777778
66124, 2.1782608695652, 1.1413043478261, 0.44444444444444
66125, 2.1782608695652, 1.1413043478261, 0.38888888888889
66126, 2.1782608695652, 1.1413043478261, 0.33333333333333
66127, 2.1782608695652, 1.1413043478261, 0.27777777777778
66128, 2.1782608695652, 1.1413043478261, 0.22222222222222
66129, 2.1782608695652, 1.1413043478261, 0.16666666666667
66130, 2.1782608695652, 1.1413043478261, 0.11111111111111
66131, 2.1782608695652, 1.1413043478261, 0.055555555555556
66132, 1.2434782608696, 1.0891304347826, 0.47222222222222
66133, 1.2217391304348, 1.0891304347826, 0.44444444444444
66134, 1.2434782608696, 1.1152173913043, 0.44444444444444
66135, 1.2434782608696, 1.0891304347826, 0.41666666666667
66136, 1.2217391304348, 1.0891304347826, 0.38888888888889
66137, 1.2434782608696, 1.1152173913043, 0.38888888888889
66138, 1.2434782608696, 1.0891304347826, 0.36111111111111
66139, 1.2217391304348, 1.0891304347826, 0.33333333333333
66140, 1.2434782608696, 1.1152173913043, 0.33333333333333
66141, 1.2434782608696, 1.0891304347826, 0.30555555555556
66142, 1.2217391304348, 1.0891304347826, 0.27777777777778
66143, 1.2434782608696, 1.1152173913043, 0.27777777777778
66144, 1.2434782608696, 1.0891304347826, 0.25
66145, 1.2217391304348, 1.0891304347826, 0.22222222222222
66146, 1.2434782608696, 1.1152173913043, 0.22222222222222
66147, 1.2434782608696, 1.0891304347826, 0.19444444444444
66148, 1.2217391304348, 1.0891304347826, 0.16666666666667
66149, 1.2434782608696, 1.1152173913043, 0.16666666666667
66150, 1.2434782608696, 1.0891304347826, 0.13888888888889
66151, 1.2217391304348, 1.0891304347826, 0.11111111111111
66152, 1.2434782608696, 1.1152173913043, 0.11111111111111
66153, 1.2434782608696, 1.0891304347826, 0.083333333333333
66154, 1.2217391304348, 1.0891304347826, 0.055555555555556
66155, 1.2434782608696, 1.1152173913043, 0.055555555555556
66156, 1.2434782608696, 1.0891304347826, 0.027777777777778
66157, 1.2869565217391, 1.0891304347826, 0.47222222222222
66158, 1.2652173913043, 1.0891304347826, 0.44444444444444
66159, 1.2869565217391, 1.1152173913043, 0.44444444444444
66160, 1.2869565217391, 1.0891304347826, 0.41666666666667
66161, 1.2652173913043, 1.0891304347826, 0.38888888888889
66162, 1.2869565217391, 1.1152173913043, 0.38888888888889
66163, 1.2869565217391, 1.0891304347826, 0.36111111111111
66164, 1.2652173913043, 1.0891304347826, 0.33333333333333
66165, 1.2869565217391, 1.1152173913043, 0.33333333333333
66166, 1.2869565217391, 1.0891304347826, 0.30555555555556
66167, 1.2652173913043, 1.0891304347826, 0.27777777777778
66168, 1.2869565217391, 1.1152173913043, 0.27777777777778
66169, 1.2869565217391, 1.0891304347826, 0.25
66170, 1.2652173913043, 1.0891304347826, 0.22222222222222
66171, 1.2869565217391, 1.1152173913043, 0.22222222222222
66172, 1.2869565217391, 1.0891304347826, 0.19444444444444
66173, 1.2652173913043, 1.0891304347826, 0.16666666666667
66174, 1.2869565217391, 1.1152173913043, 0.16666666666667
66175, 1.2869565217391, 1.0891304347826, 0.13888888888889
66176, 1.2652173913043, 1.0891304347826, 0.11111111111111
66177, 1.2869565217391, 1.1152173913043, 0.11111111111111
66178, 1.2869565217391, 1.0891304347826, 0.083333333333333
66179, 1.2652173913043, 1.0891304347826, 0.055555555555556
66180, 1.2869565217391, 1.1152173913043, 0.055555555555556
66181, 1.2869565217391, 1.0891304347826, 0.027777777777778
66182, 1.3304347826087, 1.0891304347826, 0.47222222222222
66183, 1.3086956521739, 1.0891304347826, 0.44444444444444
66184, 1.3304347826087, 1.1152173913043, 0.44444444444444
66185, 1.3304347826087, 1.0891304347826, 0.41666666666667
66186, 1.3086956521739, 1.0891304347826, 0.38888888888889
66187, 1.3304347826087, 1.1152173913043, 0.38888888888889
66188, 1.3304347826087, 1.0891304347826, 0.36111111111111
66189, 1.3086956521739, 1.0891304347826, 0.33333333333333
66190, 1.3304347826087, 1.1152173913043, 0.33333333333333
66191, 1.3304347826087, 1.0891304347826, 0.30555555555556
66192, 1.3086956521739, 1.0891304347826, 0.27777777777778
66193, 1.3304347826087, 1.1152173913043, 0.27777777777778
66194, 1.3304347826087, 1.0891304347826, 0.25
66195, 1.3086956521739, 1.0891304347826, 0.22222222222222
66196, 1.3304347826087, 1.1152173913043, 0.22222222222222
66197, 1.3304347826087, 1.0891304347826, 0.19444444444444
66198, 1.3086956521739, 1.0891304347826, 0.16666666666667
66199, 1.3304347826087, 1.1152173913043, 0.16666666666667
66200, 1.3304347826087, 1.0891304347826, 0.13888888888889
66201, 1.3086956521739, 1.0891304347826, 0.11111111111111
66202, 1.3304347826087, 1.1152173913043, 0.11111111111111
66203, 1.3304347826087, 1.0891304347826, 0.083333333333333
66204, 1.3086956521739, 1.0891304347826, 0.055555555555556
66205, 1.3304347826087, 1.1152173913043, 0.055555555555556
66206, 1.3304347826087, 1.0891304347826, 0.027777777777778
66207, 1.3739130434783, 1.0891304347826, 0.47222222222222
66208, 1.3521739130435, 1.0891304347826, 0.44444444444444
66209, 1.3739130434783, 1.1152173913043, 0.44444444444444
66210, 1.3739130434783, 1.0891304347826, 0.41666666666667
66211, 1.3521739130435, 1.0891304347826, 0.38888888888889
66212, 1.3739130434783, 1.1152173913043, 0.38888888888889
66213, 1.3739130434783, 1.0891304347826, 0.36111111111111
66214, 1.3521739130435, 1.0891304347826, 0.33333333333333
66215, 1.3739130434783, 1.1152173913043, 0.33333333333333
66216, 1.3739130434783, 1.0891304347826, 0.30555555555556
66217, 1.3521739130435, 1.0891304347826, 0.27777777777778
66218, 1.3739130434783, 1.1152173913043, 0.27777777777778
66219, 1.3739130434783, 1.0891304347826, 0.25
66220, 1.3521739130435, 1.0891304347826, 0.22222222222222
66221, 1.3739130434783, 1.1152173913043, 0.22222222222222
66222, 1.3739130434783, 1.0891304347826, 0.19444444444444
66223, 1.3521739130435, 1.0891304347826, 0.16666666666667
66224, 1.3739130434783, 1.1152173913043, 0.16666666666667
66225, 1.3739130434783, 1.0891304347826, 0.13888888888889
66226, 1.3521739130435, 1.0891304347826, 0.11111111111111
66227, 1.3739130434783, 1.1152173913043, 0.11111111111111
66228, 1.3739130434783, 1.0891304347826, 0.083333333333333
66229, 1.3521739130435, 1.0891304347826, 0.055555555555556
66230, 1.3739130434783, 1.1152173913043, 0.055555555555556
66231, 1.3739130434783, 1.0891304347826, 0.027777777777778
66232, 1.4173913043478, 1.0891304347826, 0.47222222222222
66233, 1.395652173913, 1.0891304347826, 0.44444444444444
66234, 1.4173913043478, 1.1152173913043, 0.44444444444444
66235, 1.4173913043478, 1.0891304347826, 0.41666666666667
66236, 1.395652173913, 1.0891304347826, 0.38888888888889
66237, 1.4173913043478, 1.1152173913043, 0.38888888888889
66238, 1.4173913043478, 1.0891304347826, 0.36111111111111
66239, 1.395652173913, 1.0891304347826, 0.33333333333333
66240, 1.4173913043478, 1.1152173913043, 0.33333333333333
66241, 1.4173913043478, 1.0891304347826, 0.30555555555556
66242, 1.395652173913, 1.0891304347826, 0.27777777777778
66243, 1.4173913043478, 1.1152173913043, 0.27777777777778
66244, 1.4173913043478, 1.0891304347826, 0.25
66245, 1.395652173913, 1.0891304347826, 0.22222222222222
66246, 1.4173913043478, 1.1152173913043, 0.22222222222222
66247, 1.4173913043478, 1.0891304347826, 0.19444444444444
66248, 1.395652173913, 1.0891304347826, 0.16666666666667
66249, 1.4173913043478, 1.1152173913043, 0.16666666666667
66250, 1.4173913043478, 1.0891304347826, 0.13888888888889
66251, 1.395652173913, 1.0891304347826, 0.11111111111111
66252, 1.4173913043478, 1.1152173913043, 0.11111111111111
66253, 1.4173913043478, 1.0891304347826, 0.083333333333333
66254, 1.395652173913, 1.0891304347826, 0.055555555555556
66255, 1.4173913043478, 1.1152173913043, 0.055555555555556
66256, 1.4173913043478, 1.0891304347826, 0.027777777777778
66257, 1.4608695652174, 1.0891304347826, 0.47222222222222
66258, 1.4391304347826, 1.0891304347826, 0.44444444444444
66259, 1.4608695652174, 1.1152173913043, 0.44444444444444
66260, 1.4608695652174, 1.0891304347826, 0.41666666666667
66261, 1.4391304347826, 1.0891304347826, 0.38888888888889
66262, 1.4608695652174, 1.1152173913043, 0.38888888888889
66263, 1.4608695652174, 1.0891304347826, 0.36111111111111
66264, 1.4391304347826, 1.0891304347826, 0.33333333333333
66265, 1.4608695652174, 1.1152173913043, 0.33333333333333
66266, 1.4608695652174, 1.0891304347826, 0.30555555555556
66267, 1.4391304347826, 1.0891304347826, 0.27777777777778
66268, 1.4608695652174, 1.1152173913043, 0.27777777777778
66269, 1.4608695652174, 1.0891304347826, 0.25
66270, 1.4391304347826, 1.0891304347826, 0.22222222222222
66271, 1.4608695652174, 1.1152173913043, 0.22222222222222
66272, 1.4608695652174, 1.0891304347826, 0.19444444444444
66273, 1.4391304347826, 1.0891304347826, 0.16666666666667
66274, 1.4608695652174, 1.1152173913043, 0.16666666666667
66275, 1.4608695652174, 1.0891304347826, 0.13888888888889
66276, 1.4391304347826, 1.0891304347826, 0.11111111111111
66277, 1.4608695652174, 1.1152173913043, 0.11111111111111
66278, 1.4608695652174, 1.0891304347826, 0.083333333333333
66279, 1.4391304347826, 1.0891304347826, 0.055555555555556
66280, 1.4608695652174, 1.1152173913043, 0.055555555555556
66281, 1.4608695652174, 1.0891304347826, 0.027777777777778
66282, 1.504347826087, 1.0891304347826, 0.47222222222222
66283, 1.4826086956522, 1.0891304347826, 0.44444444444444
66284, 1.504347826087, 1.1152173913043, 0.44444444444444
66285, 1.504347826087, 1.0891304347826, 0.41666666666667
66286, 1.4826086956522, 1.0891304347826, 0.38888888888889
66287, 1.504347826087, 1.1152173913043, 0.38888888888889
66288, 1.504347826087, 1.0891304347826, 0.36111111111111
66289, 1.4826086956522, 1.0891304347826, 0.33333333333333
66290, 1.504347826087, 1.1152173913043, 0.33333333333333
66291, 1.504347826087, 1.0891304347826, 0.30555555555556
66292, 1.4826086956522, 1.0891304347826, 0.27777777777778
66293, 1.504347826087, 1.1152173913043, 0.27777777777778
66294, 1.504347826087, 1.0891304347826, 0.25
66295, 1.4826086956522, 1.0891304347826, 0.22222222222222
66296, 1.504347826087, 1.1152173913043, 0.22222222222222
66297, 1.504347826087, 1.0891304347826, 0.19444444444444
66298, 1.4826086956522, 1.0891304347826, 0.16666666666667
66299, 1.504347826087, 1.1152173913043, 0.16666666666667
66300, 1.504347826087, 1.0891304347826, 0.13888888888889
66301, 1.4826086956522, 1.0891304347826, 0.11111111111111
66302, 1.504347826087, 1.1152173913043, 0.11111111111111
66303, 1.504347826087, 1.0891304347826, 0.083333333333333
66304, 1.4826086956522, 1.0891304347826, 0.055555555555556
66305, 1.504347826087, 1.1152173913043, 0.055555555555556
66306, 1.504347826087, 1.0891304347826, 0.027777777777778
66307, 1.5478260869565, 1.0891304347826, 0.47222222222222
66308, 1.5260869565217, 1.0891304347826, 0.44444444444444
66309, 1.5478260869565, 1.1152173913043, 0.44444444444444
66310, 1.5478260869565, 1.0891304347826, 0.41666666666667
66311, 1.5260869565217, 1.0891304347826, 0.38888888888889
66312, 1.5478260869565, 1.1152173913043, 0.38888888888889
66313, 1.5478260869565, 1.0891304347826, 0.36111111111111
66314, 1.5260869565217, 1.0891304347826, 0.33333333333333
66315, 1.5478260869565, 1.1152173913043, 0.33333333333333
66316, 1.5478260869565, 1.0891304347826, 0.30555555555556
66317, 1.5260869565217, 1.0891304347826, 0.27777777777778
66318, 1.5478260869565, 1.1152173913043, 0.27777777777778
66319, 1.5478260869565, 1.0891304347826, 0.25
66320, 1.5260869565217, 1.0891304347826, 0.22222222222222
66321, 1.5478260869565, 1.1152173913043, 0.22222222222222
66322, 1.5478260869565, 1.0891304347826, 0.19444444444444
66323, 1.5260869565217, 1.0891304347826, 0.16666666666667
66324, 1.5478260869565, 1.1152173913043, 0.16666666666667
66325, 1.5478260869565, 1.0891304347826, 0.13888888888889
66326, 1.5260869565217, 1.0891304347826, 0.11111111111111
66327, 1.5478260869565, 1.1152173913043, 0.11111111111111
66328, 1.5478260869565, 1.0891304347826, 0.083333333333333
66329, 1.5260869565217, 1.0891304347826, 0.055555555555556
66330, 1.5478260869565, 1.1152173913043, 0.055555555555556
66331, 1.5478260869565, 1.0891304347826, 0.027777777777778
66332, 1.5913043478261, 1.0891304347826, 0.47222222222222
66333, 1.5695652173913, 1.0891304347826, 0.44444444444444
66334, 1.5913043478261, 1.1152173913043, 0.44444444444444
66335, 1.5913043478261, 1.0891304347826, 0.41666666666667
66336, 1.5695652173913, 1.0891304347826, 0.38888888888889
66337, 1.5913043478261, 1.1152173913043, 0.38888888888889
66338, 1.5913043478261, 1.0891304347826, 0.36111111111111
66339, 1.5695652173913, 1.0891304347826, 0.33333333333333
66340, 1.5913043478261, 1.1152173913043, 0.33333333333333
66341, 1.5913043478261, 1.0891304347826, 0.30555555555556
66342, 1.5695652173913, 1.0891304347826, 0.27777777777778
66343, 1.5913043478261, 1.1152173913043, 0.27777777777778
66344, 1.5913043478261, 1.0891304347826, 0.25
66345, 1.5695652173913, 1.0891304347826, 0.22222222222222
66346, 1.5913043478261, 1.1152173913043, 0.22222222222222
66347, 1.5913043478261, 1.0891304347826, 0.19444444444444
66348, 1.5695652173913, 1.0891304347826, 0.16666666666667
66349, 1.5913043478261, 1.1152173913043, 0.16666666666667
66350, 1.5913043478261, 1.0891304347826, 0.13888888888889
66351, 1.5695652173913, 1.0891304347826, 0.11111111111111
66352, 1.5913043478261, 1.1152173913043, 0.11111111111111
66353, 1.5913043478261, 1.0891304347826, 0.083333333333333
66354, 1.5695652173913, 1.0891304347826, 0.055555555555556
66355, 1.5913043478261, 1.1152173913043, 0.055555555555556
66356, 1.5913043478261, 1.0891304347826, 0.027777777777778
66357, 1.6347826086957, 1.0891304347826, 0.47222222222222
66358, 1.6130434782609, 1.0891304347826, 0.44444444444444
66359, 1.6347826086957, 1.1152173913043, 0.44444444444444
66360, 1.6347826086957, 1.0891304347826, 0.41666666666667
66361, 1.6130434782609, 1.0891304347826, 0.38888888888889
66362, 1.6347826086957, 1.1152173913043, 0.38888888888889
66363, 1.6347826086957, 1.0891304347826, 0.36111111111111
66364, 1.6130434782609, 1.0891304347826, 0.33333333333333
66365, 1.6347826086957, 1.1152173913043, 0.33333333333333
66366, 1.6347826086957, 1.0891304347826, 0.30555555555556
66367, 1.6130434782609, 1.0891304347826, 0.27777777777778
66368, 1.6347826086957, 1.1152173913043, 0.27777777777778
66369, 1.6347826086957, 1.0891304347826, 0.25
66370, 1.6130434782609, 1.0891304347826, 0.22222222222222
66371, 1.6347826086957, 1.1152173913043, 0.22222222222222
66372, 1.6347826086957, 1.0891304347826, 0.19444444444444
66373, 1.6130434782609, 1.0891304347826, 0.16666666666667
66374, 1.6347826086957, 1.1152173913043, 0.16666666666667
66375, 1.6347826086957, 1.0891304347826, 0.13888888888889
66376, 1.6130434782609, 1.0891304347826, 0.11111111111111
66377, 1.6347826086957, 1.1152173913043, 0.11111111111111
66378, 1.6347826086957, 1.0891304347826, 0.083333333333333
66379, 1.6130434782609, 1.0891304347826, 0.055555555555556
66380, 1.6347826086957, 1.1152173913043, 0.055555555555556
66381, 1.6347826086957, 1.0891304347826, 0.027777777777778
66382, 1.6782608695652, 1.0891304347826, 0.47222222222222
66383, 1.6565217391304, 1.0891304347826, 0.44444444444444
66384, 1.6782608695652, 1.1152173913043, 0.44444444444444
66385, 1.6782608695652, 1.0891304347826, 0.41666666666667
66386, 1.6565217391304, 1.0891304347826, 0.38888888888889
66387, 1.6782608695652, 1.1152173913043, 0.38888888888889
66388, 1.6782608695652, 1.0891304347826, 0.36111111111111
66389, 1.6565217391304, 1.0891304347826, 0.33333333333333
66390, 1.6782608695652, 1.1152173913043, 0.33333333333333
66391, 1.6782608695652, 1.0891304347826, 0.30555555555556
66392, 1.6565217391304, 1.0891304347826, 0.27777777777778
66393, 1.6782608695652, 1.1152173913043, 0.27777777777778
66394, 1.6782608695652, 1.0891304347826, 0.25
66395, 1.6565217391304, 1.0891304347826, 0.22222222222222
66396, 1.6782608695652, 1.1152173913043, 0.22222222222222
66397, 1.6782608695652, 1.0891304347826, 0.19444444444444
66398, 1.6565217391304, 1.0891304347826, 0.16666666666667
66399, 1.6782608695652, 1.1152173913043, 0.16666666666667
66400, 1.6782608695652, 1.0891304347826, 0.13888888888889
66401, 1.6565217391304, 1.0891304347826, 0.11111111111111
66402, 1.6782608695652, 1.1152173913043, 0.11111111111111
66403, 1.6782608695652, 1.0891304347826, 0.083333333333333
66404, 1.6565217391304, 1.0891304347826, 0.055555555555556
66405, 1.6782608695652, 1.1152173913043, 0.055555555555556
66406, 1.6782608695652, 1.0891304347826, 0.027777777777778
66407, 1.7217391304348, 1.0891304347826, 0.47222222222222
66408, 1.7, 1.0891304347826, 0.44444444444444
66409, 1.7217391304348, 1.1152173913043, 0.44444444444444
66410, 1.7217391304348, 1.0891304347826, 0.41666666666667
66411, 1.7, 1.0891304347826, 0.38888888888889
66412, 1.7217391304348, 1.1152173913043, 0.38888888888889
66413, 1.7217391304348, 1.0891304347826, 0.36111111111111
66414, 1.7, 1.0891304347826, 0.33333333333333
66415, 1.7217391304348, 1.1152173913043, 0.33333333333333
66416, 1.7217391304348, 1.0891304347826, 0.30555555555556
66417, 1.7, 1.0891304347826, 0.27777777777778
66418, 1.7217391304348, 1.1152173913043, 0.27777777777778
66419, 1.7217391304348, 1.0891304347826, 0.25
66420, 1.7, 1.0891304347826, 0.22222222222222
66421, 1.7217391304348, 1.1152173913043, 0.22222222222222
66422, 1.7217391304348, 1.0891304347826, 0.19444444444444
66423, 1.7, 1.0891304347826, 0.16666666666667
66424, 1.7217391304348, 1.1152173913043, 0.16666666666667
66425, 1.7217391304348, 1.0891304347826, 0.13888888888889
66426, 1.7, 1.0891304347826, 0.11111111111111
66427, 1.7217391304348, 1.1152173913043, 0.11111111111111
66428, 1.7217391304348, 1.0891304347826, 0.083333333333333
66429, 1.7, 1.0891304347826, 0.055555555555556
66430, 1.7217391304348, 1.1152173913043, 0.055555555555556
66431, 1.7217391304348, 1.0891304347826, 0.027777777777778
66432, 1.7652173913043, 1.0891304347826, 0.47222222222222
66433, 1.7434782608696, 1.0891304347826, 0.44444444444444
66434, 1.7652173913043, 1.1152173913043, 0.44444444444444
66435, 1.7652173913043, 1.0891304347826, 0.41666666666667
66436, 1.7434782608696, 1.0891304347826, 0.38888888888889
66437, 1.7652173913043, 1.1152173913043, 0.38888888888889
66438, 1.7652173913043, 1.0891304347826, 0.36111111111111
66439, 1.7434782608696, 1.0891304347826, 0.33333333333333
66440, 1.7652173913043, 1.1152173913043, 0.33333333333333
66441, 1.7652173913043, 1.0891304347826, 0.30555555555556
66442, 1.7434782608696, 1.0891304347826, 0.27777777777778
66443, 1.7652173913043, 1.1152173913043, 0.27777777777778
66444, 1.7652173913043, 1.0891304347826, 0.25
66445, 1.7434782608696, 1.0891304347826, 0.22222222222222
66446, 1.7652173913043, 1.1152173913043, 0.22222222222222
66447, 1.7652173913043, 1.0891304347826, 0.19444444444444
66448, 1.7434782608696, 1.0891304347826, 0.16666666666667
66449, 1.7652173913043, 1.1152173913043, 0.16666666666667
66450, 1.7652173913043, 1.0891304347826, 0.13888888888889
66451, 1.7434782608696, 1.0891304347826, 0.11111111111111
66452, 1.7652173913043, 1.1152173913043, 0.11111111111111
66453, 1.7652173913043, 1.0891304347826, 0.083333333333333
66454, 1.7434782608696, 1.0891304347826, 0.055555555555556
66455, 1.7652173913043, 1.1152173913043, 0.055555555555556
66456, 1.7652173913043, 1.0891304347826, 0.027777777777778
66457, 1.8086956521739, 1.0891304347826, 0.47222222222222
66458, 1.7869565217391, 1.0891304347826, 0.44444444444444
66459, 1.8086956521739, 1.1152173913043, 0.44444444444444
66460, 1.8086956521739, 1.0891304347826, 0.41666666666667
66461, 1.7869565217391, 1.0891304347826, 0.38888888888889
66462, 1.8086956521739, 1.1152173913043, 0.38888888888889
66463, 1.8086956521739, 1.0891304347826, 0.36111111111111
66464, 1.7869565217391, 1.0891304347826, 0.33333333333333
66465, 1.8086956521739, 1.1152173913043, 0.33333333333333
66466, 1.8086956521739, 1.0891304347826, 0.30555555555556
66467, 1.7869565217391, 1.0891304347826, 0.27777777777778
66468, 1.8086956521739, 1.1152173913043, 0.27777777777778
66469, 1.8086956521739, 1.0891304347826, 0.25
66470, 1.7869565217391, 1.0891304347826, 0.22222222222222
66471, 1.8086956521739, 1.1152173913043, 0.22222222222222
66472, 1.8086956521739, 1.0891304347826, 0.19444444444444
66473, 1.7869565217391, 1.0891304347826, 0.16666666666667
66474, 1.8086956521739, 1.1152173913043, 0.16666666666667
66475, 1.8086956521739, 1.0891304347826, 0.13888888888889
66476, 1.7869565217391, 1.0891304347826, 0.11111111111111
66477, 1.8086956521739, 1.1152173913043, 0.11111111111111
66478, 1.8086956521739, 1.0891304347826, 0.083333333333333
66479, 1.7869565217391, 1.0891304347826, 0.055555555555556
66480, 1.8086956521739, 1.1152173913043, 0.055555555555556
66481, 1.8086956521739, 1.0891304347826, 0.027777777777778
66482, 1.8521739130435, 1.0891304347826, 0.47222222222222
66483, 1.8304347826087, 1.0891304347826, 0.44444444444444
66484, 1.8521739130435, 1.1152173913043, 0.44444444444444
66485, 1.8521739130435, 1.0891304347826, 0.41666666666667
66486, 1.8304347826087, 1.0891304347826, 0.38888888888889
66487, 1.8521739130435, 1.1152173913043, 0.38888888888889
66488, 1.8521739130435, 1.0891304347826, 0.36111111111111
66489, 1.8304347826087, 1.0891304347826, 0.33333333333333
66490, 1.8521739130435, 1.1152173913043, 0.33333333333333
66491, 1.8521739130435, 1.0891304347826, 0.30555555555556
66492, 1.8304347826087, 1.0891304347826, 0.27777777777778
66493, 1.8521739130435, 1.1152173913043, 0.27777777777778
66494, 1.8521739130435, 1.0891304347826, 0.25
66495, 1.8304347826087, 1.0891304347826, 0.22222222222222
66496, 1.8521739130435, 1.1152173913043, 0.22222222222222
66497, 1.8521739130435, 1.0891304347826, 0.19444444444444
66498, 1.8304347826087, 1.0891304347826, 0.16666666666667
66499, 1.8521739130435, 1.1152173913043, 0.16666666666667
66500, 1.8521739130435, 1.0891304347826, 0.13888888888889
66501, 1.8304347826087, 1.0891304347826, 0.11111111111111
66502, 1.8521739130435, 1.1152173913043, 0.11111111111111
66503, 1.8521739130435, 1.0891304347826, 0.083333333333333
66504, 1.8304347826087, 1.0891304347826, 0.055555555555556
66505, 1.8521739130435, 1.1152173913043, 0.055555555555556
66506, 1.8521739130435, 1.0891304347826, 0.027777777777778
66507, 1.895652173913, 1.0891304347826, 0.47222222222222
66508, 1.8739130434783, 1.0891304347826, 0.44444444444444
66509, 1.895652173913, 1.1152173913043, 0.44444444444444
66510, 1.895652173913, 1.0891304347826, 0.41666666666667
66511, 1.8739130434783, 1.0891304347826, 0.38888888888889
66512, 1.895652173913, 1.1152173913043, 0.38888888888889
66513, 1.895652173913, 1.0891304347826, 0.36111111111111
66514, 1.8739130434783, 1.0891304347826, 0.33333333333333
66515, 1.895652173913, 1.1152173913043, 0.33333333333333
66516, 1.895652173913, 1.0891304347826, 0.30555555555556
66517, 1.8739130434783, 1.0891304347826, 0.27777777777778
66518, 1.895652173913, 1.1152173913043, 0.27777777777778
66519, 1.895652173913, 1.0891304347826, 0.25
66520, 1.8739130434783, 1.0891304347826, 0.22222222222222
66521, 1.895652173913, 1.1152173913043, 0.22222222222222
66522, 1.895652173913, 1.0891304347826, 0.19444444444444
66523, 1.8739130434783, 1.0891304347826, 0.16666666666667
66524, 1.895652173913, 1.1152173913043, 0.16666666666667
66525, 1.895652173913, 1.0891304347826, 0.13888888888889
66526, 1.8739130434783, 1.0891304347826, 0.11111111111111
66527, 1.895652173913, 1.1152173913043, 0.11111111111111
66528, 1.895652173913, 1.0891304347826, 0.083333333333333
66529, 1.8739130434783, 1.0891304347826, 0.055555555555556
66530, 1.895652173913, 1.1152173913043, 0.055555555555556
66531, 1.895652173913, 1.0891304347826, 0.027777777777778
66532, 1.9391304347826, 1.0891304347826, 0.47222222222222
66533, 1.9173913043478, 1.0891304347826, 0.44444444444444
66534, 1.9391304347826, 1.1152173913043, 0.44444444444444
66535, 1.9391304347826, 1.0891304347826, 0.41666666666667
66536, 1.9173913043478, 1.0891304347826, 0.38888888888889
66537, 1.9391304347826, 1.1152173913043, 0.38888888888889
66538, 1.9391304347826, 1.0891304347826, 0.36111111111111
66539, 1.9173913043478, 1.0891304347826, 0.33333333333333
66540, 1.9391304347826, 1.1152173913043, 0.33333333333333
66541, 1.9391304347826, 1.0891304347826, 0.30555555555556
66542, 1.9173913043478, 1.0891304347826, 0.27777777777778
66543, 1.9391304347826, 1.1152173913043, 0.27777777777778
66544, 1.9391304347826, 1.0891304347826, 0.25
66545, 1.9173913043478, 1.0891304347826, 0.22222222222222
66546, 1.9391304347826, 1.1152173913043, 0.22222222222222
66547, 1.9391304347826, 1.0891304347826, 0.19444444444444
66548, 1.9173913043478, 1.0891304347826, 0.16666666666667
66549, 1.9391304347826, 1.1152173913043, 0.16666666666667
66550, 1.9391304347826, 1.0891304347826, 0.13888888888889
66551, 1.9173913043478, 1.0891304347826, 0.11111111111111
66552, 1.9391304347826, 1.1152173913043, 0.11111111111111
66553, 1.9391304347826, 1.0891304347826, 0.083333333333333
66554, 1.9173913043478, 1.0891304347826, 0.055555555555556
66555, 1.9391304347826, 1.1152173913043, 0.055555555555556
66556, 1.9391304347826, 1.0891304347826, 0.027777777777778
66557, 1.9826086956522, 1.0891304347826, 0.47222222222222
66558, 1.9608695652174, 1.0891304347826, 0.44444444444444
66559, 1.9826086956522, 1.1152173913043, 0.44444444444444
66560, 1.9826086956522, 1.0891304347826, 0.41666666666667
66561, 1.9608695652174, 1.0891304347826, 0.38888888888889
66562, 1.9826086956522, 1.1152173913043, 0.38888888888889
66563, 1.9826086956522, 1.0891304347826, 0.36111111111111
66564, 1.9608695652174, 1.0891304347826, 0.33333333333333
66565, 1.9826086956522, 1.1152173913043, 0.33333333333333
66566, 1.9826086956522, 1.0891304347826, 0.30555555555556
66567, 1.9608695652174, 1.0891304347826, 0.27777777777778
66568, 1.9826086956522, 1.1152173913043, 0.27777777777778
66569, 1.9826086956522, 1.0891304347826, 0.25
66570, 1.9608695652174, 1.0891304347826, 0.22222222222222
66571, 1.9826086956522, 1.1152173913043, 0.22222222222222
66572, 1.9826086956522, 1.0891304347826, 0.19444444444444
66573, 1.9608695652174, 1.0891304347826, 0.16666666666667
66574, 1.9826086956522, 1.1152173913043, 0.16666666666667
66575, 1.9826086956522, 1.0891304347826, 0.13888888888889
66576, 1.9608695652174, 1.0891304347826, 0.11111111111111
66577, 1.9826086956522, 1.1152173913043, 0.11111111111111
66578, 1.9826086956522, 1.0891304347826, 0.083333333333333
66579, 1.9608695652174, 1.0891304347826, 0.055555555555556
66580, 1.9826086956522, 1.1152173913043, 0.055555555555556
66581, 1.9826086956522, 1.0891304347826, 0.027777777777778
66582, 2.0260869565217, 1.0891304347826, 0.47222222222222
66583, 2.004347826087, 1.0891304347826, 0.44444444444444
66584, 2.0260869565217, 1.1152173913043, 0.44444444444444
66585, 2.0260869565217, 1.0891304347826, 0.41666666666667
66586, 2.004347826087, 1.0891304347826, 0.38888888888889
66587, 2.0260869565217, 1.1152173913043, 0.38888888888889
66588, 2.0260869565217, 1.0891304347826, 0.36111111111111
66589, 2.004347826087, 1.0891304347826, 0.33333333333333
66590, 2.0260869565217, 1.1152173913043, 0.33333333333333
66591, 2.0260869565217, 1.0891304347826, 0.30555555555556
66592, 2.004347826087, 1.0891304347826, 0.27777777777778
66593, 2.0260869565217, 1.1152173913043, 0.27777777777778
66594, 2.0260869565217, 1.0891304347826, 0.25
66595, 2.004347826087, 1.0891304347826, 0.22222222222222
66596, 2.0260869565217, 1.1152173913043, 0.22222222222222
66597, 2.0260869565217, 1.0891304347826, 0.19444444444444
66598, 2.004347826087, 1.0891304347826, 0.16666666666667
66599, 2.0260869565217, 1.1152173913043, 0.16666666666667
66600, 2.0260869565217, 1.0891304347826, 0.13888888888889
66601, 2.004347826087, 1.0891304347826, 0.11111111111111
66602, 2.0260869565217, 1.1152173913043, 0.11111111111111
66603, 2.0260869565217, 1.0891304347826, 0.083333333333333
66604, 2.004347826087, 1.0891304347826, 0.055555555555556
66605, 2.0260869565217, 1.1152173913043, 0.055555555555556
66606, 2.0260869565217, 1.0891304347826, 0.027777777777778
66607, 2.0695652173913, 1.0891304347826, 0.47222222222222
66608, 2.0478260869565, 1.0891304347826, 0.44444444444444
66609, 2.0695652173913, 1.1152173913043, 0.44444444444444
66610, 2.0695652173913, 1.0891304347826, 0.41666666666667
66611, 2.0478260869565, 1.0891304347826, 0.38888888888889
66612, 2.0695652173913, 1.1152173913043, 0.38888888888889
66613, 2.0695652173913, 1.0891304347826, 0.36111111111111
66614, 2.0478260869565, 1.0891304347826, 0.33333333333333
66615, 2.0695652173913, 1.1152173913043, 0.33333333333333
66616, 2.0695652173913, 1.0891304347826, 0.30555555555556
66617, 2.0478260869565, 1.0891304347826, 0.27777777777778
66618, 2.0695652173913, 1.1152173913043, 0.27777777777778
66619, 2.0695652173913, 1.0891304347826, 0.25
66620, 2.0478260869565, 1.0891304347826, 0.22222222222222
66621, 2.0695652173913, 1.1152173913043, 0.22222222222222
66622, 2.0695652173913, 1.0891304347826, 0.19444444444444
66623, 2.0478260869565, 1.0891304347826, 0.16666666666667
66624, 2.0695652173913, 1.1152173913043, 0.16666666666667
66625, 2.0695652173913, 1.0891304347826, 0.13888888888889
66626, 2.0478260869565, 1.0891304347826, 0.11111111111111
66627, 2.0695652173913, 1.1152173913043, 0.11111111111111
66628, 2.0695652173913, 1.0891304347826, 0.083333333333333
66629, 2.0478260869565, 1.0891304347826, 0.055555555555556
66630, 2.0695652173913, 1.1152173913043, 0.055555555555556
66631, 2.0695652173913, 1.0891304347826, 0.027777777777778
66632, 2.1130434782609, 1.0891304347826, 0.47222222222222
66633, 2.0913043478261, 1.0891304347826, 0.44444444444444
66634, 2.1130434782609, 1.1152173913043, 0.44444444444444
66635, 2.1130434782609, 1.0891304347826, 0.41666666666667
66636, 2.0913043478261, 1.0891304347826, 0.38888888888889
66637, 2.1130434782609, 1.1152173913043, 0.38888888888889
66638, 2.1130434782609, 1.0891304347826, 0.36111111111111
66639, 2.0913043478261, 1.0891304347826, 0.33333333333333
66640, 2.1130434782609, 1.1152173913043, 0.33333333333333
66641, 2.1130434782609, 1.0891304347826, 0.30555555555556
66642, 2.0913043478261, 1.0891304347826, 0.27777777777778
66643, 2.1130434782609, 1.1152173913043, 0.27777777777778
66644, 2.1130434782609, 1.0891304347826, 0.25
66645, 2.0913043478261, 1.0891304347826, 0.22222222222222
66646, 2.1130434782609, 1.1152173913043, 0.22222222222222
66647, 2.1130434782609, 1.0891304347826, 0.19444444444444
66648, 2.0913043478261, 1.0891304347826, 0.16666666666667
66649, 2.1130434782609, 1.1152173913043, 0.16666666666667
66650, 2.1130434782609, 1.0891304347826, 0.13888888888889
66651, 2.0913043478261, 1.0891304347826, 0.11111111111111
66652, 2.1130434782609, 1.1152173913043, 0.11111111111111
66653, 2.1130434782609, 1.0891304347826, 0.083333333333333
66654, 2.0913043478261, 1.0891304347826, 0.055555555555556
66655, 2.1130434782609, 1.1152173913043, 0.055555555555556
66656, 2.1130434782609, 1.0891304347826, 0.027777777777778
66657, 2.1565217391304, 1.0891304347826, 0.47222222222222
66658, 2.1347826086957, 1.0891304347826, 0.44444444444444
66659, 2.1565217391304, 1.1152173913043, 0.44444444444444
66660, 2.1565217391304, 1.0891304347826, 0.41666666666667
66661, 2.1347826086957, 1.0891304347826, 0.38888888888889
66662, 2.1565217391304, 1.1152173913043, 0.38888888888889
66663, 2.1565217391304, 1.0891304347826, 0.36111111111111
66664, 2.1347826086957, 1.0891304347826, 0.33333333333333
66665, 2.1565217391304, 1.1152173913043, 0.33333333333333
66666, 2.1565217391304, 1.0891304347826, 0.30555555555556
66667, 2.1347826086957, 1.0891304347826, 0.27777777777778
66668, 2.1565217391304, 1.1152173913043, 0.27777777777778
66669, 2.1565217391304, 1.0891304347826, 0.25
66670, 2.1347826086957, 1.0891304347826, 0.22222222222222
66671, 2.1565217391304, 1.1152173913043, 0.22222222222222
66672, 2.1565217391304, 1.0891304347826, 0.19444444444444
66673, 2.1347826086957, 1.0891304347826, 0.16666666666667
66674, 2.1565217391304, 1.1152173913043, 0.16666666666667
66675, 2.1565217391304, 1.0891304347826, 0.13888888888889
66676, 2.1347826086957, 1.0891304347826, 0.11111111111111
66677, 2.1565217391304, 1.1152173913043, 0.11111111111111
66678, 2.1565217391304, 1.0891304347826, 0.083333333333333
66679, 2.1347826086957, 1.0891304347826, 0.055555555555556
66680, 2.1565217391304, 1.1152173913043, 0.055555555555556
66681, 2.1565217391304, 1.0891304347826, 0.027777777777778
66682, 2.1782608695652, 1.0891304347826, 0.44444444444444
66683, 2.1782608695652, 1.0891304347826, 0.38888888888889
66684, 2.1782608695652, 1.0891304347826, 0.33333333333333
66685, 2.1782608695652, 1.0891304347826, 0.27777777777778
66686, 2.1782608695652, 1.0891304347826, 0.22222222222222
66687, 2.1782608695652, 1.0891304347826, 0.16666666666667
66688, 2.1782608695652, 1.0891304347826, 0.11111111111111
66689, 2.1782608695652, 1.0891304347826, 0.055555555555556
66690, 1.2434782608696, 1.0369565217391, 0.47222222222222
66691, 1.2217391304348, 1.0369565217391, 0.44444444444444
66692, 1.2434782608696, 1.0630434782609, 0.44444444444444
66693, 1.2434782608696, 1.0369565217391, 0.41666666666667
66694, 1.2217391304348, 1.0369565217391, 0.38888888888889
66695, 1.2434782608696, 1.0630434782609, 0.38888888888889
66696, 1.2434782608696, 1.0369565217391, 0.36111111111111
66697, 1.2217391304348, 1.0369565217391, 0.33333333333333
66698, 1.2434782608696, 1.0630434782609, 0.33333333333333
66699, 1.2434782608696, 1.0369565217391, 0.30555555555556
66700, 1.2217391304348, 1.0369565217391, 0.27777777777778
66701, 1.2434782608696, 1.0630434782609, 0.27777777777778
66702, 1.2434782608696, 1.0369565217391, 0.25
66703, 1.2217391304348, 1.0369565217391, 0.22222222222222
66704, 1.2434782608696, 1.0630434782609, 0.22222222222222
66705, 1.2434782608696, 1.0369565217391, 0.19444444444444
66706, 1.2217391304348, 1.0369565217391, 0.16666666666667
66707, 1.2434782608696, 1.0630434782609, 0.16666666666667
66708, 1.2434782608696, 1.0369565217391, 0.13888888888889
66709, 1.2217391304348, 1.0369565217391, 0.11111111111111
66710, 1.2434782608696, 1.0630434782609, 0.11111111111111
66711, 1.2434782608696, 1.0369565217391, 0.083333333333333
66712, 1.2217391304348, 1.0369565217391, 0.055555555555556
66713, 1.2434782608696, 1.0630434782609, 0.055555555555556
66714, 1.2434782608696, 1.0369565217391, 0.027777777777778
66715, 1.2869565217391, 1.0369565217391, 0.47222222222222
66716, 1.2652173913043, 1.0369565217391, 0.44444444444444
66717, 1.2869565217391, 1.0630434782609, 0.44444444444444
66718, 1.2869565217391, 1.0369565217391, 0.41666666666667
66719, 1.2652173913043, 1.0369565217391, 0.38888888888889
66720, 1.2869565217391, 1.0630434782609, 0.38888888888889
66721, 1.2869565217391, 1.0369565217391, 0.36111111111111
66722, 1.2652173913043, 1.0369565217391, 0.33333333333333
66723, 1.2869565217391, 1.0630434782609, 0.33333333333333
66724, 1.2869565217391, 1.0369565217391, 0.30555555555556
66725, 1.2652173913043, 1.0369565217391, 0.27777777777778
66726, 1.2869565217391, 1.0630434782609, 0.27777777777778
66727, 1.2869565217391, 1.0369565217391, 0.25
66728, 1.2652173913043, 1.0369565217391, 0.22222222222222
66729, 1.2869565217391, 1.0630434782609, 0.22222222222222
66730, 1.2869565217391, 1.0369565217391, 0.19444444444444
66731, 1.2652173913043, 1.0369565217391, 0.16666666666667
66732, 1.2869565217391, 1.0630434782609, 0.16666666666667
66733, 1.2869565217391, 1.0369565217391, 0.13888888888889
66734, 1.2652173913043, 1.0369565217391, 0.11111111111111
66735, 1.2869565217391, 1.0630434782609, 0.11111111111111
66736, 1.2869565217391, 1.0369565217391, 0.083333333333333
66737, 1.2652173913043, 1.0369565217391, 0.055555555555556
66738, 1.2869565217391, 1.0630434782609, 0.055555555555556
66739, 1.2869565217391, 1.0369565217391, 0.027777777777778
66740, 1.3304347826087, 1.0369565217391, 0.47222222222222
66741, 1.3086956521739, 1.0369565217391, 0.44444444444444
66742, 1.3304347826087, 1.0630434782609, 0.44444444444444
66743, 1.3304347826087, 1.0369565217391, 0.41666666666667
66744, 1.3086956521739, 1.0369565217391, 0.38888888888889
66745, 1.3304347826087, 1.0630434782609, 0.38888888888889
66746, 1.3304347826087, 1.0369565217391, 0.36111111111111
66747, 1.3086956521739, 1.0369565217391, 0.33333333333333
66748, 1.3304347826087, 1.0630434782609, 0.33333333333333
66749, 1.3304347826087, 1.0369565217391, 0.30555555555556
66750, 1.3086956521739, 1.0369565217391, 0.27777777777778
66751, 1.3304347826087, 1.0630434782609, 0.27777777777778
66752, 1.3304347826087, 1.0369565217391, 0.25
66753, 1.3086956521739, 1.0369565217391, 0.22222222222222
66754, 1.3304347826087, 1.0630434782609, 0.22222222222222
66755, 1.3304347826087, 1.0369565217391, 0.19444444444444
66756, 1.3086956521739, 1.0369565217391, 0.16666666666667
66757, 1.3304347826087, 1.0630434782609, 0.16666666666667
66758, 1.3304347826087, 1.0369565217391, 0.13888888888889
66759, 1.3086956521739, 1.0369565217391, 0.11111111111111
66760, 1.3304347826087, 1.0630434782609, 0.11111111111111
66761, 1.3304347826087, 1.0369565217391, 0.083333333333333
66762, 1.3086956521739, 1.0369565217391, 0.055555555555556
66763, 1.3304347826087, 1.0630434782609, 0.055555555555556
66764, 1.3304347826087, 1.0369565217391, 0.027777777777778
66765, 1.3739130434783, 1.0369565217391, 0.47222222222222
66766, 1.3521739130435, 1.0369565217391, 0.44444444444444
66767, 1.3739130434783, 1.0630434782609, 0.44444444444444
66768, 1.3739130434783, 1.0369565217391, 0.41666666666667
66769, 1.3521739130435, 1.0369565217391, 0.38888888888889
66770, 1.3739130434783, 1.0630434782609, 0.38888888888889
66771, 1.3739130434783, 1.0369565217391, 0.36111111111111
66772, 1.3521739130435, 1.0369565217391, 0.33333333333333
66773, 1.3739130434783, 1.0630434782609, 0.33333333333333
66774, 1.3739130434783, 1.0369565217391, 0.30555555555556
66775, 1.3521739130435, 1.0369565217391, 0.27777777777778
66776, 1.3739130434783, 1.0630434782609, 0.27777777777778
66777, 1.3739130434783, 1.0369565217391, 0.25
66778, 1.3521739130435, 1.0369565217391, 0.22222222222222
66779, 1.3739130434783, 1.0630434782609, 0.22222222222222
66780, 1.3739130434783, 1.0369565217391, 0.19444444444444
66781, 1.3521739130435, 1.0369565217391, 0.16666666666667
66782, 1.3739130434783, 1.0630434782609, 0.16666666666667
66783, 1.3739130434783, 1.0369565217391, 0.13888888888889
66784, 1.3521739130435, 1.0369565217391, 0.11111111111111
66785, 1.3739130434783, 1.0630434782609, 0.11111111111111
66786, 1.3739130434783, 1.0369565217391, 0.083333333333333
66787, 1.3521739130435, 1.0369565217391, 0.055555555555556
66788, 1.3739130434783, 1.0630434782609, 0.055555555555556
66789, 1.3739130434783, 1.0369565217391, 0.027777777777778
66790, 1.4173913043478, 1.0369565217391, 0.47222222222222
66791, 1.395652173913, 1.0369565217391, 0.44444444444444
66792, 1.4173913043478, 1.0630434782609, 0.44444444444444
66793, 1.4173913043478, 1.0369565217391, 0.41666666666667
66794, 1.395652173913, 1.0369565217391, 0.38888888888889
66795, 1.4173913043478, 1.0630434782609, 0.38888888888889
66796, 1.4173913043478, 1.0369565217391, 0.36111111111111
66797, 1.395652173913, 1.0369565217391, 0.33333333333333
66798, 1.4173913043478, 1.0630434782609, 0.33333333333333
66799, 1.4173913043478, 1.0369565217391, 0.30555555555556
66800, 1.395652173913, 1.0369565217391, 0.27777777777778
66801, 1.4173913043478, 1.0630434782609, 0.27777777777778
66802, 1.4173913043478, 1.0369565217391, 0.25
66803, 1.395652173913, 1.0369565217391, 0.22222222222222
66804, 1.4173913043478, 1.0630434782609, 0.22222222222222
66805, 1.4173913043478, 1.0369565217391, 0.19444444444444
66806, 1.395652173913, 1.0369565217391, 0.16666666666667
66807, 1.4173913043478, 1.0630434782609, 0.16666666666667
66808, 1.4173913043478, 1.0369565217391, 0.13888888888889
66809, 1.395652173913, 1.0369565217391, 0.11111111111111
66810, 1.4173913043478, 1.0630434782609, 0.11111111111111
66811, 1.4173913043478, 1.0369565217391, 0.083333333333333
66812, 1.395652173913, 1.0369565217391, 0.055555555555556
66813, 1.4173913043478, 1.0630434782609, 0.055555555555556
66814, 1.4173913043478, 1.0369565217391, 0.027777777777778
66815, 1.4608695652174, 1.0369565217391, 0.47222222222222
66816, 1.4391304347826, 1.0369565217391, 0.44444444444444
66817, 1.4608695652174, 1.0630434782609, 0.44444444444444
66818, 1.4608695652174, 1.0369565217391, 0.41666666666667
66819, 1.4391304347826, 1.0369565217391, 0.38888888888889
66820, 1.4608695652174, 1.0630434782609, 0.38888888888889
66821, 1.4608695652174, 1.0369565217391, 0.36111111111111
66822, 1.4391304347826, 1.0369565217391, 0.33333333333333
66823, 1.4608695652174, 1.0630434782609, 0.33333333333333
66824, 1.4608695652174, 1.0369565217391, 0.30555555555556
66825, 1.4391304347826, 1.0369565217391, 0.27777777777778
66826, 1.4608695652174, 1.0630434782609, 0.27777777777778
66827, 1.4608695652174, 1.0369565217391, 0.25
66828, 1.4391304347826, 1.0369565217391, 0.22222222222222
66829, 1.4608695652174, 1.0630434782609, 0.22222222222222
66830, 1.4608695652174, 1.0369565217391, 0.19444444444444
66831, 1.4391304347826, 1.0369565217391, 0.16666666666667
66832, 1.4608695652174, 1.0630434782609, 0.16666666666667
66833, 1.4608695652174, 1.0369565217391, 0.13888888888889
66834, 1.4391304347826, 1.0369565217391, 0.11111111111111
66835, 1.4608695652174, 1.0630434782609, 0.11111111111111
66836, 1.4608695652174, 1.0369565217391, 0.083333333333333
66837, 1.4391304347826, 1.0369565217391, 0.055555555555556
66838, 1.4608695652174, 1.0630434782609, 0.055555555555556
66839, 1.4608695652174, 1.0369565217391, 0.027777777777778
66840, 1.504347826087, 1.0369565217391, 0.47222222222222
66841, 1.4826086956522, 1.0369565217391, 0.44444444444444
66842, 1.504347826087, 1.0630434782609, 0.44444444444444
66843, 1.504347826087, 1.0369565217391, 0.41666666666667
66844, 1.4826086956522, 1.0369565217391, 0.38888888888889
66845, 1.504347826087, 1.0630434782609, 0.38888888888889
66846, 1.504347826087, 1.0369565217391, 0.36111111111111
66847, 1.4826086956522, 1.0369565217391, 0.33333333333333
66848, 1.504347826087, 1.0630434782609, 0.33333333333333
66849, 1.504347826087, 1.0369565217391, 0.30555555555556
66850, 1.4826086956522, 1.0369565217391, 0.27777777777778
66851, 1.504347826087, 1.0630434782609, 0.27777777777778
66852, 1.504347826087, 1.0369565217391, 0.25
66853, 1.4826086956522, 1.0369565217391, 0.22222222222222
66854, 1.504347826087, 1.0630434782609, 0.22222222222222
66855, 1.504347826087, 1.0369565217391, 0.19444444444444
66856, 1.4826086956522, 1.0369565217391, 0.16666666666667
66857, 1.504347826087, 1.0630434782609, 0.16666666666667
66858, 1.504347826087, 1.0369565217391, 0.13888888888889
66859, 1.4826086956522, 1.0369565217391, 0.11111111111111
66860, 1.504347826087, 1.0630434782609, 0.11111111111111
66861, 1.504347826087, 1.0369565217391, 0.083333333333333
66862, 1.4826086956522, 1.0369565217391, 0.055555555555556
66863, 1.504347826087, 1.0630434782609, 0.055555555555556
66864, 1.504347826087, 1.0369565217391, 0.027777777777778
66865, 1.5478260869565, 1.0369565217391, 0.47222222222222
66866, 1.5260869565217, 1.0369565217391, 0.44444444444444
66867, 1.5478260869565, 1.0630434782609, 0.44444444444444
66868, 1.5478260869565, 1.0369565217391, 0.41666666666667
66869, 1.5260869565217, 1.0369565217391, 0.38888888888889
66870, 1.5478260869565, 1.0630434782609, 0.38888888888889
66871, 1.5478260869565, 1.0369565217391, 0.36111111111111
66872, 1.5260869565217, 1.0369565217391, 0.33333333333333
66873, 1.5478260869565, 1.0630434782609, 0.33333333333333
66874, 1.5478260869565, 1.0369565217391, 0.30555555555556
66875, 1.5260869565217, 1.0369565217391, 0.27777777777778
66876, 1.5478260869565, 1.0630434782609, 0.27777777777778
66877, 1.5478260869565, 1.0369565217391, 0.25
66878, 1.5260869565217, 1.0369565217391, 0.22222222222222
66879, 1.5478260869565, 1.0630434782609, 0.22222222222222
66880, 1.5478260869565, 1.0369565217391, 0.19444444444444
66881, 1.5260869565217, 1.0369565217391, 0.16666666666667
66882, 1.5478260869565, 1.0630434782609, 0.16666666666667
66883, 1.5478260869565, 1.0369565217391, 0.13888888888889
66884, 1.5260869565217, 1.0369565217391, 0.11111111111111
66885, 1.5478260869565, 1.0630434782609, 0.11111111111111
66886, 1.5478260869565, 1.0369565217391, 0.083333333333333
66887, 1.5260869565217, 1.0369565217391, 0.055555555555556
66888, 1.5478260869565, 1.0630434782609, 0.055555555555556
66889, 1.5478260869565, 1.0369565217391, 0.027777777777778
66890, 1.5913043478261, 1.0369565217391, 0.47222222222222
66891, 1.5695652173913, 1.0369565217391, 0.44444444444444
66892, 1.5913043478261, 1.0630434782609, 0.44444444444444
66893, 1.5913043478261, 1.0369565217391, 0.41666666666667
66894, 1.5695652173913, 1.0369565217391, 0.38888888888889
66895, 1.5913043478261, 1.0630434782609, 0.38888888888889
66896, 1.5913043478261, 1.0369565217391, 0.36111111111111
66897, 1.5695652173913, 1.0369565217391, 0.33333333333333
66898, 1.5913043478261, 1.0630434782609, 0.33333333333333
66899, 1.5913043478261, 1.0369565217391, 0.30555555555556
66900, 1.5695652173913, 1.0369565217391, 0.27777777777778
66901, 1.5913043478261, 1.0630434782609, 0.27777777777778
66902, 1.5913043478261, 1.0369565217391, 0.25
66903, 1.5695652173913, 1.0369565217391, 0.22222222222222
66904, 1.5913043478261, 1.0630434782609, 0.22222222222222
66905, 1.5913043478261, 1.0369565217391, 0.19444444444444
66906, 1.5695652173913, 1.0369565217391, 0.16666666666667
66907, 1.5913043478261, 1.0630434782609, 0.16666666666667
66908, 1.5913043478261, 1.0369565217391, 0.13888888888889
66909, 1.5695652173913, 1.0369565217391, 0.11111111111111
66910, 1.5913043478261, 1.0630434782609, 0.11111111111111
66911, 1.5913043478261, 1.0369565217391, 0.083333333333333
66912, 1.5695652173913, 1.0369565217391, 0.055555555555556
66913, 1.5913043478261, 1.0630434782609, 0.055555555555556
66914, 1.5913043478261, 1.0369565217391, 0.027777777777778
66915, 1.6347826086957, 1.0369565217391, 0.47222222222222
66916, 1.6130434782609, 1.0369565217391, 0.44444444444444
66917, 1.6347826086957, 1.0630434782609, 0.44444444444444
66918, 1.6347826086957, 1.0369565217391, 0.41666666666667
66919, 1.6130434782609, 1.0369565217391, 0.38888888888889
66920, 1.6347826086957, 1.0630434782609, 0.38888888888889
66921, 1.6347826086957, 1.0369565217391, 0.36111111111111
66922, 1.6130434782609, 1.0369565217391, 0.33333333333333
66923, 1.6347826086957, 1.0630434782609, 0.33333333333333
66924, 1.6347826086957, 1.0369565217391, 0.30555555555556
66925, 1.6130434782609, 1.0369565217391, 0.27777777777778
66926, 1.6347826086957, 1.0630434782609, 0.27777777777778
66927, 1.6347826086957, 1.0369565217391, 0.25
66928, 1.6130434782609, 1.0369565217391, 0.22222222222222
66929, 1.6347826086957, 1.0630434782609, 0.22222222222222
66930, 1.6347826086957, 1.0369565217391, 0.19444444444444
66931, 1.6130434782609, 1.0369565217391, 0.16666666666667
66932, 1.6347826086957, 1.0630434782609, 0.16666666666667
66933, 1.6347826086957, 1.0369565217391, 0.13888888888889
66934, 1.6130434782609, 1.0369565217391, 0.11111111111111
66935, 1.6347826086957, 1.0630434782609, 0.11111111111111
66936, 1.6347826086957, 1.0369565217391, 0.083333333333333
66937, 1.6130434782609, 1.0369565217391, 0.055555555555556
66938, 1.6347826086957, 1.0630434782609, 0.055555555555556
66939, 1.6347826086957, 1.0369565217391, 0.027777777777778
66940, 1.6782608695652, 1.0369565217391, 0.47222222222222
66941, 1.6565217391304, 1.0369565217391, 0.44444444444444
66942, 1.6782608695652, 1.0630434782609, 0.44444444444444
66943, 1.6782608695652, 1.0369565217391, 0.41666666666667
66944, 1.6565217391304, 1.0369565217391, 0.38888888888889
66945, 1.6782608695652, 1.0630434782609, 0.38888888888889
66946, 1.6782608695652, 1.0369565217391, 0.36111111111111
66947, 1.6565217391304, 1.0369565217391, 0.33333333333333
66948, 1.6782608695652, 1.0630434782609, 0.33333333333333
66949, 1.6782608695652, 1.0369565217391, 0.30555555555556
66950, 1.6565217391304, 1.0369565217391, 0.27777777777778
66951, 1.6782608695652, 1.0630434782609, 0.27777777777778
66952, 1.6782608695652, 1.0369565217391, 0.25
66953, 1.6565217391304, 1.0369565217391, 0.22222222222222
66954, 1.6782608695652, 1.0630434782609, 0.22222222222222
66955, 1.6782608695652, 1.0369565217391, 0.19444444444444
66956, 1.6565217391304, 1.0369565217391, 0.16666666666667
66957, 1.6782608695652, 1.0630434782609, 0.16666666666667
66958, 1.6782608695652, 1.0369565217391, 0.13888888888889
66959, 1.6565217391304, 1.0369565217391, 0.11111111111111
66960, 1.6782608695652, 1.0630434782609, 0.11111111111111
66961, 1.6782608695652, 1.0369565217391, 0.083333333333333
66962, 1.6565217391304, 1.0369565217391, 0.055555555555556
66963, 1.6782608695652, 1.0630434782609, 0.055555555555556
66964, 1.6782608695652, 1.0369565217391, 0.027777777777778
66965, 1.7217391304348, 1.0369565217391, 0.47222222222222
66966, 1.7, 1.0369565217391, 0.44444444444444
66967, 1.7217391304348, 1.0630434782609, 0.44444444444444
66968, 1.7217391304348, 1.0369565217391, 0.41666666666667
66969, 1.7, 1.0369565217391, 0.38888888888889
66970, 1.7217391304348, 1.0630434782609, 0.38888888888889
66971, 1.7217391304348, 1.0369565217391, 0.36111111111111
66972, 1.7, 1.0369565217391, 0.33333333333333
66973, 1.7217391304348, 1.0630434782609, 0.33333333333333
66974, 1.7217391304348, 1.0369565217391, 0.30555555555556
66975, 1.7, 1.0369565217391, 0.27777777777778
66976, 1.7217391304348, 1.0630434782609, 0.27777777777778
66977, 1.7217391304348, 1.0369565217391, 0.25
66978, 1.7, 1.0369565217391, 0.22222222222222
66979, 1.7217391304348, 1.0630434782609, 0.22222222222222
66980, 1.7217391304348, 1.0369565217391, 0.19444444444444
66981, 1.7, 1.0369565217391, 0.16666666666667
66982, 1.7217391304348, 1.0630434782609, 0.16666666666667
66983, 1.7217391304348, 1.0369565217391, 0.13888888888889
66984, 1.7, 1.0369565217391, 0.11111111111111
66985, 1.7217391304348, 1.0630434782609, 0.11111111111111
66986, 1.7217391304348, 1.0369565217391, 0.083333333333333
66987, 1.7, 1.0369565217391, 0.055555555555556
66988, 1.7217391304348, 1.0630434782609, 0.055555555555556
66989, 1.7217391304348, 1.0369565217391, 0.027777777777778
66990, 1.7652173913043, 1.0369565217391, 0.47222222222222
66991, 1.7434782608696, 1.0369565217391, 0.44444444444444
66992, 1.7652173913043, 1.0630434782609, 0.44444444444444
66993, 1.7652173913043, 1.0369565217391, 0.41666666666667
66994, 1.7434782608696, 1.0369565217391, 0.38888888888889
66995, 1.7652173913043, 1.0630434782609, 0.38888888888889
66996, 1.7652173913043, 1.0369565217391, 0.36111111111111
66997, 1.7434782608696, 1.0369565217391, 0.33333333333333
66998, 1.7652173913043, 1.0630434782609, 0.33333333333333
66999, 1.7652173913043, 1.0369565217391, 0.30555555555556
67000, 1.7434782608696, 1.0369565217391, 0.27777777777778
67001, 1.7652173913043, 1.0630434782609, 0.27777777777778
67002, 1.7652173913043, 1.0369565217391, 0.25
67003, 1.7434782608696, 1.0369565217391, 0.22222222222222
67004, 1.7652173913043, 1.0630434782609, 0.22222222222222
67005, 1.7652173913043, 1.0369565217391, 0.19444444444444
67006, 1.7434782608696, 1.0369565217391, 0.16666666666667
67007, 1.7652173913043, 1.0630434782609, 0.16666666666667
67008, 1.7652173913043, 1.0369565217391, 0.13888888888889
67009, 1.7434782608696, 1.0369565217391, 0.11111111111111
67010, 1.7652173913043, 1.0630434782609, 0.11111111111111
67011, 1.7652173913043, 1.0369565217391, 0.083333333333333
67012, 1.7434782608696, 1.0369565217391, 0.055555555555556
67013, 1.7652173913043, 1.0630434782609, 0.055555555555556
67014, 1.7652173913043, 1.0369565217391, 0.027777777777778
67015, 1.8086956521739, 1.0369565217391, 0.47222222222222
67016, 1.7869565217391, 1.0369565217391, 0.44444444444444
67017, 1.8086956521739, 1.0630434782609, 0.44444444444444
67018, 1.8086956521739, 1.0369565217391, 0.41666666666667
67019, 1.7869565217391, 1.0369565217391, 0.38888888888889
67020, 1.8086956521739, 1.0630434782609, 0.38888888888889
67021, 1.8086956521739, 1.0369565217391, 0.36111111111111
67022, 1.7869565217391, 1.0369565217391, 0.33333333333333
67023, 1.8086956521739, 1.0630434782609, 0.33333333333333
67024, 1.8086956521739, 1.0369565217391, 0.30555555555556
67025, 1.7869565217391, 1.0369565217391, 0.27777777777778
67026, 1.8086956521739, 1.0630434782609, 0.27777777777778
67027, 1.8086956521739, 1.0369565217391, 0.25
67028, 1.7869565217391, 1.0369565217391, 0.22222222222222
67029, 1.8086956521739, 1.0630434782609, 0.22222222222222
67030, 1.8086956521739, 1.0369565217391, 0.19444444444444
67031, 1.7869565217391, 1.0369565217391, 0.16666666666667
67032, 1.8086956521739, 1.0630434782609, 0.16666666666667
67033, 1.8086956521739, 1.0369565217391, 0.13888888888889
67034, 1.7869565217391, 1.0369565217391, 0.11111111111111
67035, 1.8086956521739, 1.0630434782609, 0.11111111111111
67036, 1.8086956521739, 1.0369565217391, 0.083333333333333
67037, 1.7869565217391, 1.0369565217391, 0.055555555555556
67038, 1.8086956521739, 1.0630434782609, 0.055555555555556
67039, 1.8086956521739, 1.0369565217391, 0.027777777777778
67040, 1.8521739130435, 1.0369565217391, 0.47222222222222
67041, 1.8304347826087, 1.0369565217391, 0.44444444444444
67042, 1.8521739130435, 1.0630434782609, 0.44444444444444
67043, 1.8521739130435, 1.0369565217391, 0.41666666666667
67044, 1.8304347826087, 1.0369565217391, 0.38888888888889
67045, 1.8521739130435, 1.0630434782609, 0.38888888888889
67046, 1.8521739130435, 1.0369565217391, 0.36111111111111
67047, 1.8304347826087, 1.0369565217391, 0.33333333333333
67048, 1.8521739130435, 1.0630434782609, 0.33333333333333
67049, 1.8521739130435, 1.0369565217391, 0.30555555555556
67050, 1.8304347826087, 1.0369565217391, 0.27777777777778
67051, 1.8521739130435, 1.0630434782609, 0.27777777777778
67052, 1.8521739130435, 1.0369565217391, 0.25
67053, 1.8304347826087, 1.0369565217391, 0.22222222222222
67054, 1.8521739130435, 1.0630434782609, 0.22222222222222
67055, 1.8521739130435, 1.0369565217391, 0.19444444444444
67056, 1.8304347826087, 1.0369565217391, 0.16666666666667
67057, 1.8521739130435, 1.0630434782609, 0.16666666666667
67058, 1.8521739130435, 1.0369565217391, 0.13888888888889
67059, 1.8304347826087, 1.0369565217391, 0.11111111111111
67060, 1.8521739130435, 1.0630434782609, 0.11111111111111
67061, 1.8521739130435, 1.0369565217391, 0.083333333333333
67062, 1.8304347826087, 1.0369565217391, 0.055555555555556
67063, 1.8521739130435, 1.0630434782609, 0.055555555555556
67064, 1.8521739130435, 1.0369565217391, 0.027777777777778
67065, 1.895652173913, 1.0369565217391, 0.47222222222222
67066, 1.8739130434783, 1.0369565217391, 0.44444444444444
67067, 1.895652173913, 1.0630434782609, 0.44444444444444
67068, 1.895652173913, 1.0369565217391, 0.41666666666667
67069, 1.8739130434783, 1.0369565217391, 0.38888888888889
67070, 1.895652173913, 1.0630434782609, 0.38888888888889
67071, 1.895652173913, 1.0369565217391, 0.36111111111111
67072, 1.8739130434783, 1.0369565217391, 0.33333333333333
67073, 1.895652173913, 1.0630434782609, 0.33333333333333
67074, 1.895652173913, 1.0369565217391, 0.30555555555556
67075, 1.8739130434783, 1.0369565217391, 0.27777777777778
67076, 1.895652173913, 1.0630434782609, 0.27777777777778
67077, 1.895652173913, 1.0369565217391, 0.25
67078, 1.8739130434783, 1.0369565217391, 0.22222222222222
