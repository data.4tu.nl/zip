87816, 1.2869565217391, -0.15, 0.30555555555556
87817, 1.2652173913043, -0.15, 0.27777777777778
87818, 1.2869565217391, -0.125, 0.27777777777778
87819, 1.2869565217391, -0.15, 0.25
87820, 1.2652173913043, -0.15, 0.22222222222222
87821, 1.2869565217391, -0.125, 0.22222222222222
87822, 1.2869565217391, -0.15, 0.19444444444444
87823, 1.2652173913043, -0.15, 0.16666666666667
87824, 1.2869565217391, -0.125, 0.16666666666667
87825, 1.2869565217391, -0.15, 0.13888888888889
87826, 1.2652173913043, -0.15, 0.11111111111111
87827, 1.2869565217391, -0.125, 0.11111111111111
87828, 1.2869565217391, -0.15, 0.083333333333333
87829, 1.2652173913043, -0.15, 0.055555555555556
87830, 1.2869565217391, -0.125, 0.055555555555556
87831, 1.2869565217391, -0.15, 0.027777777777778
87832, 1.3304347826087, -0.15, 0.47222222222222
87833, 1.3086956521739, -0.15, 0.44444444444444
87834, 1.3304347826087, -0.125, 0.44444444444444
87835, 1.3304347826087, -0.15, 0.41666666666667
87836, 1.3086956521739, -0.15, 0.38888888888889
87837, 1.3304347826087, -0.125, 0.38888888888889
87838, 1.3304347826087, -0.15, 0.36111111111111
87839, 1.3086956521739, -0.15, 0.33333333333333
87840, 1.3304347826087, -0.125, 0.33333333333333
87841, 1.3304347826087, -0.15, 0.30555555555556
87842, 1.3086956521739, -0.15, 0.27777777777778
87843, 1.3304347826087, -0.125, 0.27777777777778
87844, 1.3304347826087, -0.15, 0.25
87845, 1.3086956521739, -0.15, 0.22222222222222
87846, 1.3304347826087, -0.125, 0.22222222222222
87847, 1.3304347826087, -0.15, 0.19444444444444
87848, 1.3086956521739, -0.15, 0.16666666666667
87849, 1.3304347826087, -0.125, 0.16666666666667
87850, 1.3304347826087, -0.15, 0.13888888888889
87851, 1.3086956521739, -0.15, 0.11111111111111
87852, 1.3304347826087, -0.125, 0.11111111111111
87853, 1.3304347826087, -0.15, 0.083333333333333
87854, 1.3086956521739, -0.15, 0.055555555555556
87855, 1.3304347826087, -0.125, 0.055555555555556
87856, 1.3304347826087, -0.15, 0.027777777777778
87857, 1.3739130434783, -0.15, 0.47222222222222
87858, 1.3521739130435, -0.15, 0.44444444444444
87859, 1.3739130434783, -0.125, 0.44444444444444
87860, 1.3739130434783, -0.15, 0.41666666666667
87861, 1.3521739130435, -0.15, 0.38888888888889
87862, 1.3739130434783, -0.125, 0.38888888888889
87863, 1.3739130434783, -0.15, 0.36111111111111
87864, 1.3521739130435, -0.15, 0.33333333333333
87865, 1.3739130434783, -0.125, 0.33333333333333
87866, 1.3739130434783, -0.15, 0.30555555555556
87867, 1.3521739130435, -0.15, 0.27777777777778
87868, 1.3739130434783, -0.125, 0.27777777777778
87869, 1.3739130434783, -0.15, 0.25
87870, 1.3521739130435, -0.15, 0.22222222222222
87871, 1.3739130434783, -0.125, 0.22222222222222
87872, 1.3739130434783, -0.15, 0.19444444444444
87873, 1.3521739130435, -0.15, 0.16666666666667
87874, 1.3739130434783, -0.125, 0.16666666666667
87875, 1.3739130434783, -0.15, 0.13888888888889
87876, 1.3521739130435, -0.15, 0.11111111111111
87877, 1.3739130434783, -0.125, 0.11111111111111
87878, 1.3739130434783, -0.15, 0.083333333333333
87879, 1.3521739130435, -0.15, 0.055555555555556
87880, 1.3739130434783, -0.125, 0.055555555555556
87881, 1.3739130434783, -0.15, 0.027777777777778
87882, 1.4173913043478, -0.15, 0.47222222222222
87883, 1.395652173913, -0.15, 0.44444444444444
87884, 1.4173913043478, -0.125, 0.44444444444444
87885, 1.4173913043478, -0.15, 0.41666666666667
87886, 1.395652173913, -0.15, 0.38888888888889
87887, 1.4173913043478, -0.125, 0.38888888888889
87888, 1.4173913043478, -0.15, 0.36111111111111
87889, 1.395652173913, -0.15, 0.33333333333333
87890, 1.4173913043478, -0.125, 0.33333333333333
87891, 1.4173913043478, -0.15, 0.30555555555556
87892, 1.395652173913, -0.15, 0.27777777777778
87893, 1.4173913043478, -0.125, 0.27777777777778
87894, 1.4173913043478, -0.15, 0.25
87895, 1.395652173913, -0.15, 0.22222222222222
87896, 1.4173913043478, -0.125, 0.22222222222222
87897, 1.4173913043478, -0.15, 0.19444444444444
87898, 1.395652173913, -0.15, 0.16666666666667
87899, 1.4173913043478, -0.125, 0.16666666666667
87900, 1.4173913043478, -0.15, 0.13888888888889
87901, 1.395652173913, -0.15, 0.11111111111111
87902, 1.4173913043478, -0.125, 0.11111111111111
87903, 1.4173913043478, -0.15, 0.083333333333333
87904, 1.395652173913, -0.15, 0.055555555555556
87905, 1.4173913043478, -0.125, 0.055555555555556
87906, 1.4173913043478, -0.15, 0.027777777777778
87907, 1.4608695652174, -0.15, 0.47222222222222
87908, 1.4391304347826, -0.15, 0.44444444444444
87909, 1.4608695652174, -0.125, 0.44444444444444
87910, 1.4608695652174, -0.15, 0.41666666666667
87911, 1.4391304347826, -0.15, 0.38888888888889
87912, 1.4608695652174, -0.125, 0.38888888888889
87913, 1.4608695652174, -0.15, 0.36111111111111
87914, 1.4391304347826, -0.15, 0.33333333333333
87915, 1.4608695652174, -0.125, 0.33333333333333
87916, 1.4608695652174, -0.15, 0.30555555555556
87917, 1.4391304347826, -0.15, 0.27777777777778
87918, 1.4608695652174, -0.125, 0.27777777777778
87919, 1.4608695652174, -0.15, 0.25
87920, 1.4391304347826, -0.15, 0.22222222222222
87921, 1.4608695652174, -0.125, 0.22222222222222
87922, 1.4608695652174, -0.15, 0.19444444444444
87923, 1.4391304347826, -0.15, 0.16666666666667
87924, 1.4608695652174, -0.125, 0.16666666666667
87925, 1.4608695652174, -0.15, 0.13888888888889
87926, 1.4391304347826, -0.15, 0.11111111111111
87927, 1.4608695652174, -0.125, 0.11111111111111
87928, 1.4608695652174, -0.15, 0.083333333333333
87929, 1.4391304347826, -0.15, 0.055555555555556
87930, 1.4608695652174, -0.125, 0.055555555555556
87931, 1.4608695652174, -0.15, 0.027777777777778
87932, 1.504347826087, -0.15, 0.47222222222222
87933, 1.4826086956522, -0.15, 0.44444444444444
87934, 1.504347826087, -0.125, 0.44444444444444
87935, 1.504347826087, -0.15, 0.41666666666667
87936, 1.4826086956522, -0.15, 0.38888888888889
87937, 1.504347826087, -0.125, 0.38888888888889
87938, 1.504347826087, -0.15, 0.36111111111111
87939, 1.4826086956522, -0.15, 0.33333333333333
87940, 1.504347826087, -0.125, 0.33333333333333
87941, 1.504347826087, -0.15, 0.30555555555556
87942, 1.4826086956522, -0.15, 0.27777777777778
87943, 1.504347826087, -0.125, 0.27777777777778
87944, 1.504347826087, -0.15, 0.25
87945, 1.4826086956522, -0.15, 0.22222222222222
87946, 1.504347826087, -0.125, 0.22222222222222
87947, 1.504347826087, -0.15, 0.19444444444444
87948, 1.4826086956522, -0.15, 0.16666666666667
87949, 1.504347826087, -0.125, 0.16666666666667
87950, 1.504347826087, -0.15, 0.13888888888889
87951, 1.4826086956522, -0.15, 0.11111111111111
87952, 1.504347826087, -0.125, 0.11111111111111
87953, 1.504347826087, -0.15, 0.083333333333333
87954, 1.4826086956522, -0.15, 0.055555555555556
87955, 1.504347826087, -0.125, 0.055555555555556
87956, 1.504347826087, -0.15, 0.027777777777778
87957, 1.5478260869565, -0.15, 0.47222222222222
87958, 1.5260869565217, -0.15, 0.44444444444444
87959, 1.5478260869565, -0.125, 0.44444444444444
87960, 1.5478260869565, -0.15, 0.41666666666667
87961, 1.5260869565217, -0.15, 0.38888888888889
87962, 1.5478260869565, -0.125, 0.38888888888889
87963, 1.5478260869565, -0.15, 0.36111111111111
87964, 1.5260869565217, -0.15, 0.33333333333333
87965, 1.5478260869565, -0.125, 0.33333333333333
87966, 1.5478260869565, -0.15, 0.30555555555556
87967, 1.5260869565217, -0.15, 0.27777777777778
87968, 1.5478260869565, -0.125, 0.27777777777778
87969, 1.5478260869565, -0.15, 0.25
87970, 1.5260869565217, -0.15, 0.22222222222222
87971, 1.5478260869565, -0.125, 0.22222222222222
87972, 1.5478260869565, -0.15, 0.19444444444444
87973, 1.5260869565217, -0.15, 0.16666666666667
87974, 1.5478260869565, -0.125, 0.16666666666667
87975, 1.5478260869565, -0.15, 0.13888888888889
87976, 1.5260869565217, -0.15, 0.11111111111111
87977, 1.5478260869565, -0.125, 0.11111111111111
87978, 1.5478260869565, -0.15, 0.083333333333333
87979, 1.5260869565217, -0.15, 0.055555555555556
87980, 1.5478260869565, -0.125, 0.055555555555556
87981, 1.5478260869565, -0.15, 0.027777777777778
87982, 1.5913043478261, -0.15, 0.47222222222222
87983, 1.5695652173913, -0.15, 0.44444444444444
87984, 1.5913043478261, -0.125, 0.44444444444444
87985, 1.5913043478261, -0.15, 0.41666666666667
87986, 1.5695652173913, -0.15, 0.38888888888889
87987, 1.5913043478261, -0.125, 0.38888888888889
87988, 1.5913043478261, -0.15, 0.36111111111111
87989, 1.5695652173913, -0.15, 0.33333333333333
87990, 1.5913043478261, -0.125, 0.33333333333333
87991, 1.5913043478261, -0.15, 0.30555555555556
87992, 1.5695652173913, -0.15, 0.27777777777778
87993, 1.5913043478261, -0.125, 0.27777777777778
87994, 1.5913043478261, -0.15, 0.25
87995, 1.5695652173913, -0.15, 0.22222222222222
87996, 1.5913043478261, -0.125, 0.22222222222222
87997, 1.5913043478261, -0.15, 0.19444444444444
87998, 1.5695652173913, -0.15, 0.16666666666667
87999, 1.5913043478261, -0.125, 0.16666666666667
88000, 1.5913043478261, -0.15, 0.13888888888889
88001, 1.5695652173913, -0.15, 0.11111111111111
88002, 1.5913043478261, -0.125, 0.11111111111111
88003, 1.5913043478261, -0.15, 0.083333333333333
88004, 1.5695652173913, -0.15, 0.055555555555556
88005, 1.5913043478261, -0.125, 0.055555555555556
88006, 1.5913043478261, -0.15, 0.027777777777778
88007, 1.6347826086957, -0.15, 0.47222222222222
88008, 1.6130434782609, -0.15, 0.44444444444444
88009, 1.6347826086957, -0.125, 0.44444444444444
88010, 1.6347826086957, -0.15, 0.41666666666667
88011, 1.6130434782609, -0.15, 0.38888888888889
88012, 1.6347826086957, -0.125, 0.38888888888889
88013, 1.6347826086957, -0.15, 0.36111111111111
88014, 1.6130434782609, -0.15, 0.33333333333333
88015, 1.6347826086957, -0.125, 0.33333333333333
88016, 1.6347826086957, -0.15, 0.30555555555556
88017, 1.6130434782609, -0.15, 0.27777777777778
88018, 1.6347826086957, -0.125, 0.27777777777778
88019, 1.6347826086957, -0.15, 0.25
88020, 1.6130434782609, -0.15, 0.22222222222222
88021, 1.6347826086957, -0.125, 0.22222222222222
88022, 1.6347826086957, -0.15, 0.19444444444444
88023, 1.6130434782609, -0.15, 0.16666666666667
88024, 1.6347826086957, -0.125, 0.16666666666667
88025, 1.6347826086957, -0.15, 0.13888888888889
88026, 1.6130434782609, -0.15, 0.11111111111111
88027, 1.6347826086957, -0.125, 0.11111111111111
88028, 1.6347826086957, -0.15, 0.083333333333333
88029, 1.6130434782609, -0.15, 0.055555555555556
88030, 1.6347826086957, -0.125, 0.055555555555556
88031, 1.6347826086957, -0.15, 0.027777777777778
88032, 1.6782608695652, -0.15, 0.47222222222222
88033, 1.6565217391304, -0.15, 0.44444444444444
88034, 1.6782608695652, -0.125, 0.44444444444444
88035, 1.6782608695652, -0.15, 0.41666666666667
88036, 1.6565217391304, -0.15, 0.38888888888889
88037, 1.6782608695652, -0.125, 0.38888888888889
88038, 1.6782608695652, -0.15, 0.36111111111111
88039, 1.6565217391304, -0.15, 0.33333333333333
88040, 1.6782608695652, -0.125, 0.33333333333333
88041, 1.6782608695652, -0.15, 0.30555555555556
88042, 1.6565217391304, -0.15, 0.27777777777778
88043, 1.6782608695652, -0.125, 0.27777777777778
88044, 1.6782608695652, -0.15, 0.25
88045, 1.6565217391304, -0.15, 0.22222222222222
88046, 1.6782608695652, -0.125, 0.22222222222222
88047, 1.6782608695652, -0.15, 0.19444444444444
88048, 1.6565217391304, -0.15, 0.16666666666667
88049, 1.6782608695652, -0.125, 0.16666666666667
88050, 1.6782608695652, -0.15, 0.13888888888889
88051, 1.6565217391304, -0.15, 0.11111111111111
88052, 1.6782608695652, -0.125, 0.11111111111111
88053, 1.6782608695652, -0.15, 0.083333333333333
88054, 1.6565217391304, -0.15, 0.055555555555556
88055, 1.6782608695652, -0.125, 0.055555555555556
88056, 1.6782608695652, -0.15, 0.027777777777778
88057, 1.7217391304348, -0.15, 0.47222222222222
88058, 1.7, -0.15, 0.44444444444444
88059, 1.7217391304348, -0.125, 0.44444444444444
88060, 1.7217391304348, -0.15, 0.41666666666667
88061, 1.7, -0.15, 0.38888888888889
88062, 1.7217391304348, -0.125, 0.38888888888889
88063, 1.7217391304348, -0.15, 0.36111111111111
88064, 1.7, -0.15, 0.33333333333333
88065, 1.7217391304348, -0.125, 0.33333333333333
88066, 1.7217391304348, -0.15, 0.30555555555556
88067, 1.7, -0.15, 0.27777777777778
88068, 1.7217391304348, -0.125, 0.27777777777778
88069, 1.7217391304348, -0.15, 0.25
88070, 1.7, -0.15, 0.22222222222222
88071, 1.7217391304348, -0.125, 0.22222222222222
88072, 1.7217391304348, -0.15, 0.19444444444444
88073, 1.7, -0.15, 0.16666666666667
88074, 1.7217391304348, -0.125, 0.16666666666667
88075, 1.7217391304348, -0.15, 0.13888888888889
88076, 1.7, -0.15, 0.11111111111111
88077, 1.7217391304348, -0.125, 0.11111111111111
88078, 1.7217391304348, -0.15, 0.083333333333333
88079, 1.7, -0.15, 0.055555555555556
88080, 1.7217391304348, -0.125, 0.055555555555556
88081, 1.7217391304348, -0.15, 0.027777777777778
88082, 1.7652173913043, -0.15, 0.47222222222222
88083, 1.7434782608696, -0.15, 0.44444444444444
88084, 1.7652173913043, -0.125, 0.44444444444444
88085, 1.7652173913043, -0.15, 0.41666666666667
88086, 1.7434782608696, -0.15, 0.38888888888889
88087, 1.7652173913043, -0.125, 0.38888888888889
88088, 1.7652173913043, -0.15, 0.36111111111111
88089, 1.7434782608696, -0.15, 0.33333333333333
88090, 1.7652173913043, -0.125, 0.33333333333333
88091, 1.7652173913043, -0.15, 0.30555555555556
88092, 1.7434782608696, -0.15, 0.27777777777778
88093, 1.7652173913043, -0.125, 0.27777777777778
88094, 1.7652173913043, -0.15, 0.25
88095, 1.7434782608696, -0.15, 0.22222222222222
88096, 1.7652173913043, -0.125, 0.22222222222222
88097, 1.7652173913043, -0.15, 0.19444444444444
88098, 1.7434782608696, -0.15, 0.16666666666667
88099, 1.7652173913043, -0.125, 0.16666666666667
88100, 1.7652173913043, -0.15, 0.13888888888889
88101, 1.7434782608696, -0.15, 0.11111111111111
88102, 1.7652173913043, -0.125, 0.11111111111111
88103, 1.7652173913043, -0.15, 0.083333333333333
88104, 1.7434782608696, -0.15, 0.055555555555556
88105, 1.7652173913043, -0.125, 0.055555555555556
88106, 1.7652173913043, -0.15, 0.027777777777778
88107, 1.8086956521739, -0.15, 0.47222222222222
88108, 1.7869565217391, -0.15, 0.44444444444444
88109, 1.8086956521739, -0.125, 0.44444444444444
88110, 1.8086956521739, -0.15, 0.41666666666667
88111, 1.7869565217391, -0.15, 0.38888888888889
88112, 1.8086956521739, -0.125, 0.38888888888889
88113, 1.8086956521739, -0.15, 0.36111111111111
88114, 1.7869565217391, -0.15, 0.33333333333333
88115, 1.8086956521739, -0.125, 0.33333333333333
88116, 1.8086956521739, -0.15, 0.30555555555556
88117, 1.7869565217391, -0.15, 0.27777777777778
88118, 1.8086956521739, -0.125, 0.27777777777778
88119, 1.8086956521739, -0.15, 0.25
88120, 1.7869565217391, -0.15, 0.22222222222222
88121, 1.8086956521739, -0.125, 0.22222222222222
88122, 1.8086956521739, -0.15, 0.19444444444444
88123, 1.7869565217391, -0.15, 0.16666666666667
88124, 1.8086956521739, -0.125, 0.16666666666667
88125, 1.8086956521739, -0.15, 0.13888888888889
88126, 1.7869565217391, -0.15, 0.11111111111111
88127, 1.8086956521739, -0.125, 0.11111111111111
88128, 1.8086956521739, -0.15, 0.083333333333333
88129, 1.7869565217391, -0.15, 0.055555555555556
88130, 1.8086956521739, -0.125, 0.055555555555556
88131, 1.8086956521739, -0.15, 0.027777777777778
88132, 1.8521739130435, -0.15, 0.47222222222222
88133, 1.8304347826087, -0.15, 0.44444444444444
88134, 1.8521739130435, -0.125, 0.44444444444444
88135, 1.8521739130435, -0.15, 0.41666666666667
88136, 1.8304347826087, -0.15, 0.38888888888889
88137, 1.8521739130435, -0.125, 0.38888888888889
88138, 1.8521739130435, -0.15, 0.36111111111111
88139, 1.8304347826087, -0.15, 0.33333333333333
88140, 1.8521739130435, -0.125, 0.33333333333333
88141, 1.8521739130435, -0.15, 0.30555555555556
88142, 1.8304347826087, -0.15, 0.27777777777778
88143, 1.8521739130435, -0.125, 0.27777777777778
88144, 1.8521739130435, -0.15, 0.25
88145, 1.8304347826087, -0.15, 0.22222222222222
88146, 1.8521739130435, -0.125, 0.22222222222222
88147, 1.8521739130435, -0.15, 0.19444444444444
88148, 1.8304347826087, -0.15, 0.16666666666667
88149, 1.8521739130435, -0.125, 0.16666666666667
88150, 1.8521739130435, -0.15, 0.13888888888889
88151, 1.8304347826087, -0.15, 0.11111111111111
88152, 1.8521739130435, -0.125, 0.11111111111111
88153, 1.8521739130435, -0.15, 0.083333333333333
88154, 1.8304347826087, -0.15, 0.055555555555556
88155, 1.8521739130435, -0.125, 0.055555555555556
88156, 1.8521739130435, -0.15, 0.027777777777778
88157, 1.895652173913, -0.15, 0.47222222222222
88158, 1.8739130434783, -0.15, 0.44444444444444
88159, 1.895652173913, -0.125, 0.44444444444444
88160, 1.895652173913, -0.15, 0.41666666666667
88161, 1.8739130434783, -0.15, 0.38888888888889
88162, 1.895652173913, -0.125, 0.38888888888889
88163, 1.895652173913, -0.15, 0.36111111111111
88164, 1.8739130434783, -0.15, 0.33333333333333
88165, 1.895652173913, -0.125, 0.33333333333333
88166, 1.895652173913, -0.15, 0.30555555555556
88167, 1.8739130434783, -0.15, 0.27777777777778
88168, 1.895652173913, -0.125, 0.27777777777778
88169, 1.895652173913, -0.15, 0.25
88170, 1.8739130434783, -0.15, 0.22222222222222
88171, 1.895652173913, -0.125, 0.22222222222222
88172, 1.895652173913, -0.15, 0.19444444444444
88173, 1.8739130434783, -0.15, 0.16666666666667
88174, 1.895652173913, -0.125, 0.16666666666667
88175, 1.895652173913, -0.15, 0.13888888888889
88176, 1.8739130434783, -0.15, 0.11111111111111
88177, 1.895652173913, -0.125, 0.11111111111111
88178, 1.895652173913, -0.15, 0.083333333333333
88179, 1.8739130434783, -0.15, 0.055555555555556
88180, 1.895652173913, -0.125, 0.055555555555556
88181, 1.895652173913, -0.15, 0.027777777777778
88182, 1.9391304347826, -0.15, 0.47222222222222
88183, 1.9173913043478, -0.15, 0.44444444444444
88184, 1.9391304347826, -0.125, 0.44444444444444
88185, 1.9391304347826, -0.15, 0.41666666666667
88186, 1.9173913043478, -0.15, 0.38888888888889
88187, 1.9391304347826, -0.125, 0.38888888888889
88188, 1.9391304347826, -0.15, 0.36111111111111
88189, 1.9173913043478, -0.15, 0.33333333333333
88190, 1.9391304347826, -0.125, 0.33333333333333
88191, 1.9391304347826, -0.15, 0.30555555555556
88192, 1.9173913043478, -0.15, 0.27777777777778
88193, 1.9391304347826, -0.125, 0.27777777777778
88194, 1.9391304347826, -0.15, 0.25
88195, 1.9173913043478, -0.15, 0.22222222222222
88196, 1.9391304347826, -0.125, 0.22222222222222
88197, 1.9391304347826, -0.15, 0.19444444444444
88198, 1.9173913043478, -0.15, 0.16666666666667
88199, 1.9391304347826, -0.125, 0.16666666666667
88200, 1.9391304347826, -0.15, 0.13888888888889
88201, 1.9173913043478, -0.15, 0.11111111111111
88202, 1.9391304347826, -0.125, 0.11111111111111
88203, 1.9391304347826, -0.15, 0.083333333333333
88204, 1.9173913043478, -0.15, 0.055555555555556
88205, 1.9391304347826, -0.125, 0.055555555555556
88206, 1.9391304347826, -0.15, 0.027777777777778
88207, 1.9826086956522, -0.15, 0.47222222222222
88208, 1.9608695652174, -0.15, 0.44444444444444
88209, 1.9826086956522, -0.125, 0.44444444444444
88210, 1.9826086956522, -0.15, 0.41666666666667
88211, 1.9608695652174, -0.15, 0.38888888888889
88212, 1.9826086956522, -0.125, 0.38888888888889
88213, 1.9826086956522, -0.15, 0.36111111111111
88214, 1.9608695652174, -0.15, 0.33333333333333
88215, 1.9826086956522, -0.125, 0.33333333333333
88216, 1.9826086956522, -0.15, 0.30555555555556
88217, 1.9608695652174, -0.15, 0.27777777777778
88218, 1.9826086956522, -0.125, 0.27777777777778
88219, 1.9826086956522, -0.15, 0.25
88220, 1.9608695652174, -0.15, 0.22222222222222
88221, 1.9826086956522, -0.125, 0.22222222222222
88222, 1.9826086956522, -0.15, 0.19444444444444
88223, 1.9608695652174, -0.15, 0.16666666666667
88224, 1.9826086956522, -0.125, 0.16666666666667
88225, 1.9826086956522, -0.15, 0.13888888888889
88226, 1.9608695652174, -0.15, 0.11111111111111
88227, 1.9826086956522, -0.125, 0.11111111111111
88228, 1.9826086956522, -0.15, 0.083333333333333
88229, 1.9608695652174, -0.15, 0.055555555555556
88230, 1.9826086956522, -0.125, 0.055555555555556
88231, 1.9826086956522, -0.15, 0.027777777777778
88232, 2.0260869565217, -0.15, 0.47222222222222
88233, 2.004347826087, -0.15, 0.44444444444444
88234, 2.0260869565217, -0.125, 0.44444444444444
88235, 2.0260869565217, -0.15, 0.41666666666667
88236, 2.004347826087, -0.15, 0.38888888888889
88237, 2.0260869565217, -0.125, 0.38888888888889
88238, 2.0260869565217, -0.15, 0.36111111111111
88239, 2.004347826087, -0.15, 0.33333333333333
88240, 2.0260869565217, -0.125, 0.33333333333333
88241, 2.0260869565217, -0.15, 0.30555555555556
88242, 2.004347826087, -0.15, 0.27777777777778
88243, 2.0260869565217, -0.125, 0.27777777777778
88244, 2.0260869565217, -0.15, 0.25
88245, 2.004347826087, -0.15, 0.22222222222222
88246, 2.0260869565217, -0.125, 0.22222222222222
88247, 2.0260869565217, -0.15, 0.19444444444444
88248, 2.004347826087, -0.15, 0.16666666666667
88249, 2.0260869565217, -0.125, 0.16666666666667
88250, 2.0260869565217, -0.15, 0.13888888888889
88251, 2.004347826087, -0.15, 0.11111111111111
88252, 2.0260869565217, -0.125, 0.11111111111111
88253, 2.0260869565217, -0.15, 0.083333333333333
88254, 2.004347826087, -0.15, 0.055555555555556
88255, 2.0260869565217, -0.125, 0.055555555555556
88256, 2.0260869565217, -0.15, 0.027777777777778
88257, 2.0695652173913, -0.15, 0.47222222222222
88258, 2.0478260869565, -0.15, 0.44444444444444
88259, 2.0695652173913, -0.125, 0.44444444444444
88260, 2.0695652173913, -0.15, 0.41666666666667
88261, 2.0478260869565, -0.15, 0.38888888888889
88262, 2.0695652173913, -0.125, 0.38888888888889
88263, 2.0695652173913, -0.15, 0.36111111111111
88264, 2.0478260869565, -0.15, 0.33333333333333
88265, 2.0695652173913, -0.125, 0.33333333333333
88266, 2.0695652173913, -0.15, 0.30555555555556
88267, 2.0478260869565, -0.15, 0.27777777777778
88268, 2.0695652173913, -0.125, 0.27777777777778
88269, 2.0695652173913, -0.15, 0.25
88270, 2.0478260869565, -0.15, 0.22222222222222
88271, 2.0695652173913, -0.125, 0.22222222222222
88272, 2.0695652173913, -0.15, 0.19444444444444
88273, 2.0478260869565, -0.15, 0.16666666666667
88274, 2.0695652173913, -0.125, 0.16666666666667
88275, 2.0695652173913, -0.15, 0.13888888888889
88276, 2.0478260869565, -0.15, 0.11111111111111
88277, 2.0695652173913, -0.125, 0.11111111111111
88278, 2.0695652173913, -0.15, 0.083333333333333
88279, 2.0478260869565, -0.15, 0.055555555555556
88280, 2.0695652173913, -0.125, 0.055555555555556
88281, 2.0695652173913, -0.15, 0.027777777777778
88282, 2.1130434782609, -0.15, 0.47222222222222
88283, 2.0913043478261, -0.15, 0.44444444444444
88284, 2.1130434782609, -0.125, 0.44444444444444
88285, 2.1130434782609, -0.15, 0.41666666666667
88286, 2.0913043478261, -0.15, 0.38888888888889
88287, 2.1130434782609, -0.125, 0.38888888888889
88288, 2.1130434782609, -0.15, 0.36111111111111
88289, 2.0913043478261, -0.15, 0.33333333333333
88290, 2.1130434782609, -0.125, 0.33333333333333
88291, 2.1130434782609, -0.15, 0.30555555555556
88292, 2.0913043478261, -0.15, 0.27777777777778
88293, 2.1130434782609, -0.125, 0.27777777777778
88294, 2.1130434782609, -0.15, 0.25
88295, 2.0913043478261, -0.15, 0.22222222222222
88296, 2.1130434782609, -0.125, 0.22222222222222
88297, 2.1130434782609, -0.15, 0.19444444444444
88298, 2.0913043478261, -0.15, 0.16666666666667
88299, 2.1130434782609, -0.125, 0.16666666666667
88300, 2.1130434782609, -0.15, 0.13888888888889
88301, 2.0913043478261, -0.15, 0.11111111111111
88302, 2.1130434782609, -0.125, 0.11111111111111
88303, 2.1130434782609, -0.15, 0.083333333333333
88304, 2.0913043478261, -0.15, 0.055555555555556
88305, 2.1130434782609, -0.125, 0.055555555555556
88306, 2.1130434782609, -0.15, 0.027777777777778
88307, 2.1565217391304, -0.15, 0.47222222222222
88308, 2.1347826086957, -0.15, 0.44444444444444
88309, 2.1565217391304, -0.125, 0.44444444444444
88310, 2.1565217391304, -0.15, 0.41666666666667
88311, 2.1347826086957, -0.15, 0.38888888888889
88312, 2.1565217391304, -0.125, 0.38888888888889
88313, 2.1565217391304, -0.15, 0.36111111111111
88314, 2.1347826086957, -0.15, 0.33333333333333
88315, 2.1565217391304, -0.125, 0.33333333333333
88316, 2.1565217391304, -0.15, 0.30555555555556
88317, 2.1347826086957, -0.15, 0.27777777777778
88318, 2.1565217391304, -0.125, 0.27777777777778
88319, 2.1565217391304, -0.15, 0.25
88320, 2.1347826086957, -0.15, 0.22222222222222
88321, 2.1565217391304, -0.125, 0.22222222222222
88322, 2.1565217391304, -0.15, 0.19444444444444
88323, 2.1347826086957, -0.15, 0.16666666666667
88324, 2.1565217391304, -0.125, 0.16666666666667
88325, 2.1565217391304, -0.15, 0.13888888888889
88326, 2.1347826086957, -0.15, 0.11111111111111
88327, 2.1565217391304, -0.125, 0.11111111111111
88328, 2.1565217391304, -0.15, 0.083333333333333
88329, 2.1347826086957, -0.15, 0.055555555555556
88330, 2.1565217391304, -0.125, 0.055555555555556
88331, 2.1565217391304, -0.15, 0.027777777777778
88332, 2.1782608695652, -0.15, 0.44444444444444
88333, 2.1782608695652, -0.15, 0.38888888888889
88334, 2.1782608695652, -0.15, 0.33333333333333
88335, 2.1782608695652, -0.15, 0.27777777777778
88336, 2.1782608695652, -0.15, 0.22222222222222
88337, 2.1782608695652, -0.15, 0.16666666666667
88338, 2.1782608695652, -0.15, 0.11111111111111
88339, 2.1782608695652, -0.15, 0.055555555555556
88340, 1.2434782608696, -0.2, 0.47222222222222
88341, 1.2217391304348, -0.2, 0.44444444444444
88342, 1.2434782608696, -0.175, 0.44444444444444
88343, 1.2434782608696, -0.2, 0.41666666666667
88344, 1.2217391304348, -0.2, 0.38888888888889
88345, 1.2434782608696, -0.175, 0.38888888888889
88346, 1.2434782608696, -0.2, 0.36111111111111
88347, 1.2217391304348, -0.2, 0.33333333333333
88348, 1.2434782608696, -0.175, 0.33333333333333
88349, 1.2434782608696, -0.2, 0.30555555555556
88350, 1.2217391304348, -0.2, 0.27777777777778
88351, 1.2434782608696, -0.175, 0.27777777777778
88352, 1.2434782608696, -0.2, 0.25
88353, 1.2217391304348, -0.2, 0.22222222222222
88354, 1.2434782608696, -0.175, 0.22222222222222
88355, 1.2434782608696, -0.2, 0.19444444444444
88356, 1.2217391304348, -0.2, 0.16666666666667
88357, 1.2434782608696, -0.175, 0.16666666666667
88358, 1.2434782608696, -0.2, 0.13888888888889
88359, 1.2217391304348, -0.2, 0.11111111111111
88360, 1.2434782608696, -0.175, 0.11111111111111
88361, 1.2434782608696, -0.2, 0.083333333333333
88362, 1.2217391304348, -0.2, 0.055555555555556
88363, 1.2434782608696, -0.175, 0.055555555555556
88364, 1.2434782608696, -0.2, 0.027777777777778
88365, 1.2869565217391, -0.2, 0.47222222222222
88366, 1.2652173913043, -0.2, 0.44444444444444
88367, 1.2869565217391, -0.175, 0.44444444444444
88368, 1.2869565217391, -0.2, 0.41666666666667
88369, 1.2652173913043, -0.2, 0.38888888888889
88370, 1.2869565217391, -0.175, 0.38888888888889
88371, 1.2869565217391, -0.2, 0.36111111111111
88372, 1.2652173913043, -0.2, 0.33333333333333
88373, 1.2869565217391, -0.175, 0.33333333333333
88374, 1.2869565217391, -0.2, 0.30555555555556
88375, 1.2652173913043, -0.2, 0.27777777777778
88376, 1.2869565217391, -0.175, 0.27777777777778
88377, 1.2869565217391, -0.2, 0.25
88378, 1.2652173913043, -0.2, 0.22222222222222
88379, 1.2869565217391, -0.175, 0.22222222222222
88380, 1.2869565217391, -0.2, 0.19444444444444
88381, 1.2652173913043, -0.2, 0.16666666666667
88382, 1.2869565217391, -0.175, 0.16666666666667
88383, 1.2869565217391, -0.2, 0.13888888888889
88384, 1.2652173913043, -0.2, 0.11111111111111
88385, 1.2869565217391, -0.175, 0.11111111111111
88386, 1.2869565217391, -0.2, 0.083333333333333
88387, 1.2652173913043, -0.2, 0.055555555555556
88388, 1.2869565217391, -0.175, 0.055555555555556
88389, 1.2869565217391, -0.2, 0.027777777777778
88390, 1.3304347826087, -0.2, 0.47222222222222
88391, 1.3086956521739, -0.2, 0.44444444444444
88392, 1.3304347826087, -0.175, 0.44444444444444
88393, 1.3304347826087, -0.2, 0.41666666666667
88394, 1.3086956521739, -0.2, 0.38888888888889
88395, 1.3304347826087, -0.175, 0.38888888888889
88396, 1.3304347826087, -0.2, 0.36111111111111
88397, 1.3086956521739, -0.2, 0.33333333333333
88398, 1.3304347826087, -0.175, 0.33333333333333
88399, 1.3304347826087, -0.2, 0.30555555555556
88400, 1.3086956521739, -0.2, 0.27777777777778
88401, 1.3304347826087, -0.175, 0.27777777777778
88402, 1.3304347826087, -0.2, 0.25
88403, 1.3086956521739, -0.2, 0.22222222222222
88404, 1.3304347826087, -0.175, 0.22222222222222
88405, 1.3304347826087, -0.2, 0.19444444444444
88406, 1.3086956521739, -0.2, 0.16666666666667
88407, 1.3304347826087, -0.175, 0.16666666666667
88408, 1.3304347826087, -0.2, 0.13888888888889
88409, 1.3086956521739, -0.2, 0.11111111111111
88410, 1.3304347826087, -0.175, 0.11111111111111
88411, 1.3304347826087, -0.2, 0.083333333333333
88412, 1.3086956521739, -0.2, 0.055555555555556
88413, 1.3304347826087, -0.175, 0.055555555555556
88414, 1.3304347826087, -0.2, 0.027777777777778
88415, 1.3739130434783, -0.2, 0.47222222222222
88416, 1.3521739130435, -0.2, 0.44444444444444
88417, 1.3739130434783, -0.175, 0.44444444444444
88418, 1.3739130434783, -0.2, 0.41666666666667
88419, 1.3521739130435, -0.2, 0.38888888888889
88420, 1.3739130434783, -0.175, 0.38888888888889
88421, 1.3739130434783, -0.2, 0.36111111111111
88422, 1.3521739130435, -0.2, 0.33333333333333
88423, 1.3739130434783, -0.175, 0.33333333333333
88424, 1.3739130434783, -0.2, 0.30555555555556
88425, 1.3521739130435, -0.2, 0.27777777777778
88426, 1.3739130434783, -0.175, 0.27777777777778
88427, 1.3739130434783, -0.2, 0.25
88428, 1.3521739130435, -0.2, 0.22222222222222
88429, 1.3739130434783, -0.175, 0.22222222222222
88430, 1.3739130434783, -0.2, 0.19444444444444
88431, 1.3521739130435, -0.2, 0.16666666666667
88432, 1.3739130434783, -0.175, 0.16666666666667
88433, 1.3739130434783, -0.2, 0.13888888888889
88434, 1.3521739130435, -0.2, 0.11111111111111
88435, 1.3739130434783, -0.175, 0.11111111111111
88436, 1.3739130434783, -0.2, 0.083333333333333
88437, 1.3521739130435, -0.2, 0.055555555555556
88438, 1.3739130434783, -0.175, 0.055555555555556
88439, 1.3739130434783, -0.2, 0.027777777777778
88440, 1.4173913043478, -0.2, 0.47222222222222
88441, 1.395652173913, -0.2, 0.44444444444444
88442, 1.4173913043478, -0.175, 0.44444444444444
88443, 1.4173913043478, -0.2, 0.41666666666667
88444, 1.395652173913, -0.2, 0.38888888888889
88445, 1.4173913043478, -0.175, 0.38888888888889
88446, 1.4173913043478, -0.2, 0.36111111111111
88447, 1.395652173913, -0.2, 0.33333333333333
88448, 1.4173913043478, -0.175, 0.33333333333333
88449, 1.4173913043478, -0.2, 0.30555555555556
88450, 1.395652173913, -0.2, 0.27777777777778
88451, 1.4173913043478, -0.175, 0.27777777777778
88452, 1.4173913043478, -0.2, 0.25
88453, 1.395652173913, -0.2, 0.22222222222222
88454, 1.4173913043478, -0.175, 0.22222222222222
88455, 1.4173913043478, -0.2, 0.19444444444444
88456, 1.395652173913, -0.2, 0.16666666666667
88457, 1.4173913043478, -0.175, 0.16666666666667
88458, 1.4173913043478, -0.2, 0.13888888888889
88459, 1.395652173913, -0.2, 0.11111111111111
88460, 1.4173913043478, -0.175, 0.11111111111111
88461, 1.4173913043478, -0.2, 0.083333333333333
88462, 1.395652173913, -0.2, 0.055555555555556
88463, 1.4173913043478, -0.175, 0.055555555555556
88464, 1.4173913043478, -0.2, 0.027777777777778
88465, 1.4608695652174, -0.2, 0.47222222222222
88466, 1.4391304347826, -0.2, 0.44444444444444
88467, 1.4608695652174, -0.175, 0.44444444444444
88468, 1.4608695652174, -0.2, 0.41666666666667
88469, 1.4391304347826, -0.2, 0.38888888888889
88470, 1.4608695652174, -0.175, 0.38888888888889
88471, 1.4608695652174, -0.2, 0.36111111111111
88472, 1.4391304347826, -0.2, 0.33333333333333
88473, 1.4608695652174, -0.175, 0.33333333333333
88474, 1.4608695652174, -0.2, 0.30555555555556
88475, 1.4391304347826, -0.2, 0.27777777777778
88476, 1.4608695652174, -0.175, 0.27777777777778
88477, 1.4608695652174, -0.2, 0.25
88478, 1.4391304347826, -0.2, 0.22222222222222
88479, 1.4608695652174, -0.175, 0.22222222222222
88480, 1.4608695652174, -0.2, 0.19444444444444
88481, 1.4391304347826, -0.2, 0.16666666666667
88482, 1.4608695652174, -0.175, 0.16666666666667
88483, 1.4608695652174, -0.2, 0.13888888888889
88484, 1.4391304347826, -0.2, 0.11111111111111
88485, 1.4608695652174, -0.175, 0.11111111111111
88486, 1.4608695652174, -0.2, 0.083333333333333
88487, 1.4391304347826, -0.2, 0.055555555555556
88488, 1.4608695652174, -0.175, 0.055555555555556
88489, 1.4608695652174, -0.2, 0.027777777777778
88490, 1.504347826087, -0.2, 0.47222222222222
88491, 1.4826086956522, -0.2, 0.44444444444444
88492, 1.504347826087, -0.175, 0.44444444444444
88493, 1.504347826087, -0.2, 0.41666666666667
88494, 1.4826086956522, -0.2, 0.38888888888889
88495, 1.504347826087, -0.175, 0.38888888888889
88496, 1.504347826087, -0.2, 0.36111111111111
88497, 1.4826086956522, -0.2, 0.33333333333333
88498, 1.504347826087, -0.175, 0.33333333333333
88499, 1.504347826087, -0.2, 0.30555555555556
88500, 1.4826086956522, -0.2, 0.27777777777778
88501, 1.504347826087, -0.175, 0.27777777777778
88502, 1.504347826087, -0.2, 0.25
88503, 1.4826086956522, -0.2, 0.22222222222222
88504, 1.504347826087, -0.175, 0.22222222222222
88505, 1.504347826087, -0.2, 0.19444444444444
88506, 1.4826086956522, -0.2, 0.16666666666667
88507, 1.504347826087, -0.175, 0.16666666666667
88508, 1.504347826087, -0.2, 0.13888888888889
88509, 1.4826086956522, -0.2, 0.11111111111111
88510, 1.504347826087, -0.175, 0.11111111111111
88511, 1.504347826087, -0.2, 0.083333333333333
88512, 1.4826086956522, -0.2, 0.055555555555556
88513, 1.504347826087, -0.175, 0.055555555555556
88514, 1.504347826087, -0.2, 0.027777777777778
88515, 1.5478260869565, -0.2, 0.47222222222222
88516, 1.5260869565217, -0.2, 0.44444444444444
88517, 1.5478260869565, -0.175, 0.44444444444444
88518, 1.5478260869565, -0.2, 0.41666666666667
88519, 1.5260869565217, -0.2, 0.38888888888889
88520, 1.5478260869565, -0.175, 0.38888888888889
88521, 1.5478260869565, -0.2, 0.36111111111111
88522, 1.5260869565217, -0.2, 0.33333333333333
88523, 1.5478260869565, -0.175, 0.33333333333333
88524, 1.5478260869565, -0.2, 0.30555555555556
88525, 1.5260869565217, -0.2, 0.27777777777778
88526, 1.5478260869565, -0.175, 0.27777777777778
88527, 1.5478260869565, -0.2, 0.25
88528, 1.5260869565217, -0.2, 0.22222222222222
88529, 1.5478260869565, -0.175, 0.22222222222222
88530, 1.5478260869565, -0.2, 0.19444444444444
88531, 1.5260869565217, -0.2, 0.16666666666667
88532, 1.5478260869565, -0.175, 0.16666666666667
88533, 1.5478260869565, -0.2, 0.13888888888889
88534, 1.5260869565217, -0.2, 0.11111111111111
88535, 1.5478260869565, -0.175, 0.11111111111111
88536, 1.5478260869565, -0.2, 0.083333333333333
88537, 1.5260869565217, -0.2, 0.055555555555556
88538, 1.5478260869565, -0.175, 0.055555555555556
88539, 1.5478260869565, -0.2, 0.027777777777778
88540, 1.5913043478261, -0.2, 0.47222222222222
88541, 1.5695652173913, -0.2, 0.44444444444444
88542, 1.5913043478261, -0.175, 0.44444444444444
88543, 1.5913043478261, -0.2, 0.41666666666667
88544, 1.5695652173913, -0.2, 0.38888888888889
88545, 1.5913043478261, -0.175, 0.38888888888889
88546, 1.5913043478261, -0.2, 0.36111111111111
88547, 1.5695652173913, -0.2, 0.33333333333333
88548, 1.5913043478261, -0.175, 0.33333333333333
88549, 1.5913043478261, -0.2, 0.30555555555556
88550, 1.5695652173913, -0.2, 0.27777777777778
88551, 1.5913043478261, -0.175, 0.27777777777778
88552, 1.5913043478261, -0.2, 0.25
88553, 1.5695652173913, -0.2, 0.22222222222222
88554, 1.5913043478261, -0.175, 0.22222222222222
88555, 1.5913043478261, -0.2, 0.19444444444444
88556, 1.5695652173913, -0.2, 0.16666666666667
88557, 1.5913043478261, -0.175, 0.16666666666667
88558, 1.5913043478261, -0.2, 0.13888888888889
88559, 1.5695652173913, -0.2, 0.11111111111111
88560, 1.5913043478261, -0.175, 0.11111111111111
88561, 1.5913043478261, -0.2, 0.083333333333333
88562, 1.5695652173913, -0.2, 0.055555555555556
88563, 1.5913043478261, -0.175, 0.055555555555556
88564, 1.5913043478261, -0.2, 0.027777777777778
88565, 1.6347826086957, -0.2, 0.47222222222222
88566, 1.6130434782609, -0.2, 0.44444444444444
88567, 1.6347826086957, -0.175, 0.44444444444444
88568, 1.6347826086957, -0.2, 0.41666666666667
88569, 1.6130434782609, -0.2, 0.38888888888889
88570, 1.6347826086957, -0.175, 0.38888888888889
88571, 1.6347826086957, -0.2, 0.36111111111111
88572, 1.6130434782609, -0.2, 0.33333333333333
88573, 1.6347826086957, -0.175, 0.33333333333333
88574, 1.6347826086957, -0.2, 0.30555555555556
88575, 1.6130434782609, -0.2, 0.27777777777778
88576, 1.6347826086957, -0.175, 0.27777777777778
88577, 1.6347826086957, -0.2, 0.25
88578, 1.6130434782609, -0.2, 0.22222222222222
88579, 1.6347826086957, -0.175, 0.22222222222222
88580, 1.6347826086957, -0.2, 0.19444444444444
88581, 1.6130434782609, -0.2, 0.16666666666667
88582, 1.6347826086957, -0.175, 0.16666666666667
88583, 1.6347826086957, -0.2, 0.13888888888889
88584, 1.6130434782609, -0.2, 0.11111111111111
88585, 1.6347826086957, -0.175, 0.11111111111111
88586, 1.6347826086957, -0.2, 0.083333333333333
88587, 1.6130434782609, -0.2, 0.055555555555556
88588, 1.6347826086957, -0.175, 0.055555555555556
88589, 1.6347826086957, -0.2, 0.027777777777778
88590, 1.6782608695652, -0.2, 0.47222222222222
88591, 1.6565217391304, -0.2, 0.44444444444444
88592, 1.6782608695652, -0.175, 0.44444444444444
88593, 1.6782608695652, -0.2, 0.41666666666667
88594, 1.6565217391304, -0.2, 0.38888888888889
88595, 1.6782608695652, -0.175, 0.38888888888889
88596, 1.6782608695652, -0.2, 0.36111111111111
88597, 1.6565217391304, -0.2, 0.33333333333333
88598, 1.6782608695652, -0.175, 0.33333333333333
88599, 1.6782608695652, -0.2, 0.30555555555556
88600, 1.6565217391304, -0.2, 0.27777777777778
88601, 1.6782608695652, -0.175, 0.27777777777778
88602, 1.6782608695652, -0.2, 0.25
88603, 1.6565217391304, -0.2, 0.22222222222222
88604, 1.6782608695652, -0.175, 0.22222222222222
88605, 1.6782608695652, -0.2, 0.19444444444444
88606, 1.6565217391304, -0.2, 0.16666666666667
88607, 1.6782608695652, -0.175, 0.16666666666667
88608, 1.6782608695652, -0.2, 0.13888888888889
88609, 1.6565217391304, -0.2, 0.11111111111111
88610, 1.6782608695652, -0.175, 0.11111111111111
88611, 1.6782608695652, -0.2, 0.083333333333333
88612, 1.6565217391304, -0.2, 0.055555555555556
88613, 1.6782608695652, -0.175, 0.055555555555556
88614, 1.6782608695652, -0.2, 0.027777777777778
88615, 1.7217391304348, -0.2, 0.47222222222222
88616, 1.7, -0.2, 0.44444444444444
88617, 1.7217391304348, -0.175, 0.44444444444444
88618, 1.7217391304348, -0.2, 0.41666666666667
88619, 1.7, -0.2, 0.38888888888889
88620, 1.7217391304348, -0.175, 0.38888888888889
88621, 1.7217391304348, -0.2, 0.36111111111111
88622, 1.7, -0.2, 0.33333333333333
88623, 1.7217391304348, -0.175, 0.33333333333333
88624, 1.7217391304348, -0.2, 0.30555555555556
88625, 1.7, -0.2, 0.27777777777778
88626, 1.7217391304348, -0.175, 0.27777777777778
88627, 1.7217391304348, -0.2, 0.25
88628, 1.7, -0.2, 0.22222222222222
88629, 1.7217391304348, -0.175, 0.22222222222222
88630, 1.7217391304348, -0.2, 0.19444444444444
88631, 1.7, -0.2, 0.16666666666667
88632, 1.7217391304348, -0.175, 0.16666666666667
88633, 1.7217391304348, -0.2, 0.13888888888889
88634, 1.7, -0.2, 0.11111111111111
88635, 1.7217391304348, -0.175, 0.11111111111111
88636, 1.7217391304348, -0.2, 0.083333333333333
88637, 1.7, -0.2, 0.055555555555556
88638, 1.7217391304348, -0.175, 0.055555555555556
88639, 1.7217391304348, -0.2, 0.027777777777778
88640, 1.7652173913043, -0.2, 0.47222222222222
88641, 1.7434782608696, -0.2, 0.44444444444444
88642, 1.7652173913043, -0.175, 0.44444444444444
88643, 1.7652173913043, -0.2, 0.41666666666667
88644, 1.7434782608696, -0.2, 0.38888888888889
88645, 1.7652173913043, -0.175, 0.38888888888889
88646, 1.7652173913043, -0.2, 0.36111111111111
88647, 1.7434782608696, -0.2, 0.33333333333333
88648, 1.7652173913043, -0.175, 0.33333333333333
88649, 1.7652173913043, -0.2, 0.30555555555556
88650, 1.7434782608696, -0.2, 0.27777777777778
88651, 1.7652173913043, -0.175, 0.27777777777778
88652, 1.7652173913043, -0.2, 0.25
88653, 1.7434782608696, -0.2, 0.22222222222222
88654, 1.7652173913043, -0.175, 0.22222222222222
88655, 1.7652173913043, -0.2, 0.19444444444444
88656, 1.7434782608696, -0.2, 0.16666666666667
88657, 1.7652173913043, -0.175, 0.16666666666667
88658, 1.7652173913043, -0.2, 0.13888888888889
88659, 1.7434782608696, -0.2, 0.11111111111111
88660, 1.7652173913043, -0.175, 0.11111111111111
88661, 1.7652173913043, -0.2, 0.083333333333333
88662, 1.7434782608696, -0.2, 0.055555555555556
88663, 1.7652173913043, -0.175, 0.055555555555556
88664, 1.7652173913043, -0.2, 0.027777777777778
88665, 1.8086956521739, -0.2, 0.47222222222222
88666, 1.7869565217391, -0.2, 0.44444444444444
88667, 1.8086956521739, -0.175, 0.44444444444444
88668, 1.8086956521739, -0.2, 0.41666666666667
88669, 1.7869565217391, -0.2, 0.38888888888889
88670, 1.8086956521739, -0.175, 0.38888888888889
88671, 1.8086956521739, -0.2, 0.36111111111111
88672, 1.7869565217391, -0.2, 0.33333333333333
88673, 1.8086956521739, -0.175, 0.33333333333333
88674, 1.8086956521739, -0.2, 0.30555555555556
88675, 1.7869565217391, -0.2, 0.27777777777778
88676, 1.8086956521739, -0.175, 0.27777777777778
88677, 1.8086956521739, -0.2, 0.25
88678, 1.7869565217391, -0.2, 0.22222222222222
88679, 1.8086956521739, -0.175, 0.22222222222222
88680, 1.8086956521739, -0.2, 0.19444444444444
88681, 1.7869565217391, -0.2, 0.16666666666667
88682, 1.8086956521739, -0.175, 0.16666666666667
88683, 1.8086956521739, -0.2, 0.13888888888889
88684, 1.7869565217391, -0.2, 0.11111111111111
88685, 1.8086956521739, -0.175, 0.11111111111111
88686, 1.8086956521739, -0.2, 0.083333333333333
88687, 1.7869565217391, -0.2, 0.055555555555556
88688, 1.8086956521739, -0.175, 0.055555555555556
88689, 1.8086956521739, -0.2, 0.027777777777778
88690, 1.8521739130435, -0.2, 0.47222222222222
88691, 1.8304347826087, -0.2, 0.44444444444444
88692, 1.8521739130435, -0.175, 0.44444444444444
88693, 1.8521739130435, -0.2, 0.41666666666667
88694, 1.8304347826087, -0.2, 0.38888888888889
88695, 1.8521739130435, -0.175, 0.38888888888889
88696, 1.8521739130435, -0.2, 0.36111111111111
88697, 1.8304347826087, -0.2, 0.33333333333333
88698, 1.8521739130435, -0.175, 0.33333333333333
88699, 1.8521739130435, -0.2, 0.30555555555556
88700, 1.8304347826087, -0.2, 0.27777777777778
88701, 1.8521739130435, -0.175, 0.27777777777778
88702, 1.8521739130435, -0.2, 0.25
88703, 1.8304347826087, -0.2, 0.22222222222222
88704, 1.8521739130435, -0.175, 0.22222222222222
88705, 1.8521739130435, -0.2, 0.19444444444444
88706, 1.8304347826087, -0.2, 0.16666666666667
88707, 1.8521739130435, -0.175, 0.16666666666667
88708, 1.8521739130435, -0.2, 0.13888888888889
88709, 1.8304347826087, -0.2, 0.11111111111111
88710, 1.8521739130435, -0.175, 0.11111111111111
88711, 1.8521739130435, -0.2, 0.083333333333333
88712, 1.8304347826087, -0.2, 0.055555555555556
88713, 1.8521739130435, -0.175, 0.055555555555556
88714, 1.8521739130435, -0.2, 0.027777777777778
88715, 1.895652173913, -0.2, 0.47222222222222
88716, 1.8739130434783, -0.2, 0.44444444444444
88717, 1.895652173913, -0.175, 0.44444444444444
88718, 1.895652173913, -0.2, 0.41666666666667
88719, 1.8739130434783, -0.2, 0.38888888888889
88720, 1.895652173913, -0.175, 0.38888888888889
88721, 1.895652173913, -0.2, 0.36111111111111
88722, 1.8739130434783, -0.2, 0.33333333333333
88723, 1.895652173913, -0.175, 0.33333333333333
88724, 1.895652173913, -0.2, 0.30555555555556
88725, 1.8739130434783, -0.2, 0.27777777777778
88726, 1.895652173913, -0.175, 0.27777777777778
88727, 1.895652173913, -0.2, 0.25
88728, 1.8739130434783, -0.2, 0.22222222222222
88729, 1.895652173913, -0.175, 0.22222222222222
88730, 1.895652173913, -0.2, 0.19444444444444
88731, 1.8739130434783, -0.2, 0.16666666666667
88732, 1.895652173913, -0.175, 0.16666666666667
88733, 1.895652173913, -0.2, 0.13888888888889
88734, 1.8739130434783, -0.2, 0.11111111111111
88735, 1.895652173913, -0.175, 0.11111111111111
88736, 1.895652173913, -0.2, 0.083333333333333
88737, 1.8739130434783, -0.2, 0.055555555555556
88738, 1.895652173913, -0.175, 0.055555555555556
88739, 1.895652173913, -0.2, 0.027777777777778
88740, 1.9391304347826, -0.2, 0.47222222222222
88741, 1.9173913043478, -0.2, 0.44444444444444
88742, 1.9391304347826, -0.175, 0.44444444444444
88743, 1.9391304347826, -0.2, 0.41666666666667
88744, 1.9173913043478, -0.2, 0.38888888888889
88745, 1.9391304347826, -0.175, 0.38888888888889
88746, 1.9391304347826, -0.2, 0.36111111111111
88747, 1.9173913043478, -0.2, 0.33333333333333
88748, 1.9391304347826, -0.175, 0.33333333333333
88749, 1.9391304347826, -0.2, 0.30555555555556
88750, 1.9173913043478, -0.2, 0.27777777777778
88751, 1.9391304347826, -0.175, 0.27777777777778
88752, 1.9391304347826, -0.2, 0.25
88753, 1.9173913043478, -0.2, 0.22222222222222
88754, 1.9391304347826, -0.175, 0.22222222222222
88755, 1.9391304347826, -0.2, 0.19444444444444
88756, 1.9173913043478, -0.2, 0.16666666666667
88757, 1.9391304347826, -0.175, 0.16666666666667
88758, 1.9391304347826, -0.2, 0.13888888888889
88759, 1.9173913043478, -0.2, 0.11111111111111
88760, 1.9391304347826, -0.175, 0.11111111111111
88761, 1.9391304347826, -0.2, 0.083333333333333
88762, 1.9173913043478, -0.2, 0.055555555555556
88763, 1.9391304347826, -0.175, 0.055555555555556
88764, 1.9391304347826, -0.2, 0.027777777777778
88765, 1.9826086956522, -0.2, 0.47222222222222
88766, 1.9608695652174, -0.2, 0.44444444444444
88767, 1.9826086956522, -0.175, 0.44444444444444
88768, 1.9826086956522, -0.2, 0.41666666666667
88769, 1.9608695652174, -0.2, 0.38888888888889
88770, 1.9826086956522, -0.175, 0.38888888888889
88771, 1.9826086956522, -0.2, 0.36111111111111
88772, 1.9608695652174, -0.2, 0.33333333333333
88773, 1.9826086956522, -0.175, 0.33333333333333
88774, 1.9826086956522, -0.2, 0.30555555555556
88775, 1.9608695652174, -0.2, 0.27777777777778
88776, 1.9826086956522, -0.175, 0.27777777777778
88777, 1.9826086956522, -0.2, 0.25
88778, 1.9608695652174, -0.2, 0.22222222222222
88779, 1.9826086956522, -0.175, 0.22222222222222
88780, 1.9826086956522, -0.2, 0.19444444444444
88781, 1.9608695652174, -0.2, 0.16666666666667
88782, 1.9826086956522, -0.175, 0.16666666666667
88783, 1.9826086956522, -0.2, 0.13888888888889
88784, 1.9608695652174, -0.2, 0.11111111111111
88785, 1.9826086956522, -0.175, 0.11111111111111
88786, 1.9826086956522, -0.2, 0.083333333333333
88787, 1.9608695652174, -0.2, 0.055555555555556
88788, 1.9826086956522, -0.175, 0.055555555555556
88789, 1.9826086956522, -0.2, 0.027777777777778
88790, 2.0260869565217, -0.2, 0.47222222222222
88791, 2.004347826087, -0.2, 0.44444444444444
88792, 2.0260869565217, -0.175, 0.44444444444444
88793, 2.0260869565217, -0.2, 0.41666666666667
88794, 2.004347826087, -0.2, 0.38888888888889
88795, 2.0260869565217, -0.175, 0.38888888888889
88796, 2.0260869565217, -0.2, 0.36111111111111
88797, 2.004347826087, -0.2, 0.33333333333333
88798, 2.0260869565217, -0.175, 0.33333333333333
88799, 2.0260869565217, -0.2, 0.30555555555556
88800, 2.004347826087, -0.2, 0.27777777777778
88801, 2.0260869565217, -0.175, 0.27777777777778
88802, 2.0260869565217, -0.2, 0.25
88803, 2.004347826087, -0.2, 0.22222222222222
88804, 2.0260869565217, -0.175, 0.22222222222222
88805, 2.0260869565217, -0.2, 0.19444444444444
88806, 2.004347826087, -0.2, 0.16666666666667
88807, 2.0260869565217, -0.175, 0.16666666666667
88808, 2.0260869565217, -0.2, 0.13888888888889
88809, 2.004347826087, -0.2, 0.11111111111111
88810, 2.0260869565217, -0.175, 0.11111111111111
88811, 2.0260869565217, -0.2, 0.083333333333333
88812, 2.004347826087, -0.2, 0.055555555555556
88813, 2.0260869565217, -0.175, 0.055555555555556
88814, 2.0260869565217, -0.2, 0.027777777777778
88815, 2.0695652173913, -0.2, 0.47222222222222
88816, 2.0478260869565, -0.2, 0.44444444444444
88817, 2.0695652173913, -0.175, 0.44444444444444
88818, 2.0695652173913, -0.2, 0.41666666666667
88819, 2.0478260869565, -0.2, 0.38888888888889
88820, 2.0695652173913, -0.175, 0.38888888888889
88821, 2.0695652173913, -0.2, 0.36111111111111
88822, 2.0478260869565, -0.2, 0.33333333333333
88823, 2.0695652173913, -0.175, 0.33333333333333
88824, 2.0695652173913, -0.2, 0.30555555555556
88825, 2.0478260869565, -0.2, 0.27777777777778
88826, 2.0695652173913, -0.175, 0.27777777777778
88827, 2.0695652173913, -0.2, 0.25
88828, 2.0478260869565, -0.2, 0.22222222222222
88829, 2.0695652173913, -0.175, 0.22222222222222
88830, 2.0695652173913, -0.2, 0.19444444444444
88831, 2.0478260869565, -0.2, 0.16666666666667
88832, 2.0695652173913, -0.175, 0.16666666666667
88833, 2.0695652173913, -0.2, 0.13888888888889
88834, 2.0478260869565, -0.2, 0.11111111111111
88835, 2.0695652173913, -0.175, 0.11111111111111
88836, 2.0695652173913, -0.2, 0.083333333333333
88837, 2.0478260869565, -0.2, 0.055555555555556
88838, 2.0695652173913, -0.175, 0.055555555555556
88839, 2.0695652173913, -0.2, 0.027777777777778
88840, 2.1130434782609, -0.2, 0.47222222222222
88841, 2.0913043478261, -0.2, 0.44444444444444
88842, 2.1130434782609, -0.175, 0.44444444444444
88843, 2.1130434782609, -0.2, 0.41666666666667
88844, 2.0913043478261, -0.2, 0.38888888888889
88845, 2.1130434782609, -0.175, 0.38888888888889
88846, 2.1130434782609, -0.2, 0.36111111111111
88847, 2.0913043478261, -0.2, 0.33333333333333
88848, 2.1130434782609, -0.175, 0.33333333333333
88849, 2.1130434782609, -0.2, 0.30555555555556
88850, 2.0913043478261, -0.2, 0.27777777777778
88851, 2.1130434782609, -0.175, 0.27777777777778
88852, 2.1130434782609, -0.2, 0.25
88853, 2.0913043478261, -0.2, 0.22222222222222
88854, 2.1130434782609, -0.175, 0.22222222222222
88855, 2.1130434782609, -0.2, 0.19444444444444
88856, 2.0913043478261, -0.2, 0.16666666666667
88857, 2.1130434782609, -0.175, 0.16666666666667
88858, 2.1130434782609, -0.2, 0.13888888888889
88859, 2.0913043478261, -0.2, 0.11111111111111
88860, 2.1130434782609, -0.175, 0.11111111111111
88861, 2.1130434782609, -0.2, 0.083333333333333
88862, 2.0913043478261, -0.2, 0.055555555555556
88863, 2.1130434782609, -0.175, 0.055555555555556
88864, 2.1130434782609, -0.2, 0.027777777777778
88865, 2.1565217391304, -0.2, 0.47222222222222
88866, 2.1347826086957, -0.2, 0.44444444444444
88867, 2.1565217391304, -0.175, 0.44444444444444
88868, 2.1565217391304, -0.2, 0.41666666666667
88869, 2.1347826086957, -0.2, 0.38888888888889
88870, 2.1565217391304, -0.175, 0.38888888888889
88871, 2.1565217391304, -0.2, 0.36111111111111
88872, 2.1347826086957, -0.2, 0.33333333333333
88873, 2.1565217391304, -0.175, 0.33333333333333
88874, 2.1565217391304, -0.2, 0.30555555555556
88875, 2.1347826086957, -0.2, 0.27777777777778
88876, 2.1565217391304, -0.175, 0.27777777777778
88877, 2.1565217391304, -0.2, 0.25
88878, 2.1347826086957, -0.2, 0.22222222222222
88879, 2.1565217391304, -0.175, 0.22222222222222
88880, 2.1565217391304, -0.2, 0.19444444444444
88881, 2.1347826086957, -0.2, 0.16666666666667
88882, 2.1565217391304, -0.175, 0.16666666666667
88883, 2.1565217391304, -0.2, 0.13888888888889
88884, 2.1347826086957, -0.2, 0.11111111111111
88885, 2.1565217391304, -0.175, 0.11111111111111
88886, 2.1565217391304, -0.2, 0.083333333333333
88887, 2.1347826086957, -0.2, 0.055555555555556
88888, 2.1565217391304, -0.175, 0.055555555555556
88889, 2.1565217391304, -0.2, 0.027777777777778
88890, 2.1782608695652, -0.2, 0.44444444444444
88891, 2.1782608695652, -0.2, 0.38888888888889
88892, 2.1782608695652, -0.2, 0.33333333333333
88893, 2.1782608695652, -0.2, 0.27777777777778
88894, 2.1782608695652, -0.2, 0.22222222222222
88895, 2.1782608695652, -0.2, 0.16666666666667
88896, 2.1782608695652, -0.2, 0.11111111111111
88897, 2.1782608695652, -0.2, 0.055555555555556
88898, 1.2434782608696, -0.225, 0.44444444444444
88899, 1.2434782608696, -0.225, 0.38888888888889
88900, 1.2434782608696, -0.225, 0.33333333333333
88901, 1.2434782608696, -0.225, 0.27777777777778
88902, 1.2434782608696, -0.225, 0.22222222222222
88903, 1.2434782608696, -0.225, 0.16666666666667
88904, 1.2434782608696, -0.225, 0.11111111111111
88905, 1.2434782608696, -0.225, 0.055555555555556
88906, 1.2869565217391, -0.225, 0.44444444444444
88907, 1.2869565217391, -0.225, 0.38888888888889
88908, 1.2869565217391, -0.225, 0.33333333333333
88909, 1.2869565217391, -0.225, 0.27777777777778
88910, 1.2869565217391, -0.225, 0.22222222222222
88911, 1.2869565217391, -0.225, 0.16666666666667
88912, 1.2869565217391, -0.225, 0.11111111111111
88913, 1.2869565217391, -0.225, 0.055555555555556
88914, 1.3304347826087, -0.225, 0.44444444444444
88915, 1.3304347826087, -0.225, 0.38888888888889
88916, 1.3304347826087, -0.225, 0.33333333333333
88917, 1.3304347826087, -0.225, 0.27777777777778
88918, 1.3304347826087, -0.225, 0.22222222222222
88919, 1.3304347826087, -0.225, 0.16666666666667
88920, 1.3304347826087, -0.225, 0.11111111111111
88921, 1.3304347826087, -0.225, 0.055555555555556
88922, 1.3739130434783, -0.225, 0.44444444444444
88923, 1.3739130434783, -0.225, 0.38888888888889
88924, 1.3739130434783, -0.225, 0.33333333333333
88925, 1.3739130434783, -0.225, 0.27777777777778
88926, 1.3739130434783, -0.225, 0.22222222222222
88927, 1.3739130434783, -0.225, 0.16666666666667
88928, 1.3739130434783, -0.225, 0.11111111111111
88929, 1.3739130434783, -0.225, 0.055555555555556
88930, 1.4173913043478, -0.225, 0.44444444444444
88931, 1.4173913043478, -0.225, 0.38888888888889
88932, 1.4173913043478, -0.225, 0.33333333333333
88933, 1.4173913043478, -0.225, 0.27777777777778
88934, 1.4173913043478, -0.225, 0.22222222222222
88935, 1.4173913043478, -0.225, 0.16666666666667
88936, 1.4173913043478, -0.225, 0.11111111111111
88937, 1.4173913043478, -0.225, 0.055555555555556
88938, 1.4608695652174, -0.225, 0.44444444444444
88939, 1.4608695652174, -0.225, 0.38888888888889
88940, 1.4608695652174, -0.225, 0.33333333333333
88941, 1.4608695652174, -0.225, 0.27777777777778
88942, 1.4608695652174, -0.225, 0.22222222222222
88943, 1.4608695652174, -0.225, 0.16666666666667
88944, 1.4608695652174, -0.225, 0.11111111111111
88945, 1.4608695652174, -0.225, 0.055555555555556
88946, 1.504347826087, -0.225, 0.44444444444444
88947, 1.504347826087, -0.225, 0.38888888888889
88948, 1.504347826087, -0.225, 0.33333333333333
88949, 1.504347826087, -0.225, 0.27777777777778
88950, 1.504347826087, -0.225, 0.22222222222222
88951, 1.504347826087, -0.225, 0.16666666666667
88952, 1.504347826087, -0.225, 0.11111111111111
88953, 1.504347826087, -0.225, 0.055555555555556
88954, 1.5478260869565, -0.225, 0.44444444444444
88955, 1.5478260869565, -0.225, 0.38888888888889
88956, 1.5478260869565, -0.225, 0.33333333333333
88957, 1.5478260869565, -0.225, 0.27777777777778
88958, 1.5478260869565, -0.225, 0.22222222222222
88959, 1.5478260869565, -0.225, 0.16666666666667
88960, 1.5478260869565, -0.225, 0.11111111111111
88961, 1.5478260869565, -0.225, 0.055555555555556
88962, 1.5913043478261, -0.225, 0.44444444444444
88963, 1.5913043478261, -0.225, 0.38888888888889
88964, 1.5913043478261, -0.225, 0.33333333333333
88965, 1.5913043478261, -0.225, 0.27777777777778
88966, 1.5913043478261, -0.225, 0.22222222222222
88967, 1.5913043478261, -0.225, 0.16666666666667
88968, 1.5913043478261, -0.225, 0.11111111111111
88969, 1.5913043478261, -0.225, 0.055555555555556
88970, 1.6347826086957, -0.225, 0.44444444444444
88971, 1.6347826086957, -0.225, 0.38888888888889
88972, 1.6347826086957, -0.225, 0.33333333333333
88973, 1.6347826086957, -0.225, 0.27777777777778
88974, 1.6347826086957, -0.225, 0.22222222222222
88975, 1.6347826086957, -0.225, 0.16666666666667
88976, 1.6347826086957, -0.225, 0.11111111111111
88977, 1.6347826086957, -0.225, 0.055555555555556
88978, 1.6782608695652, -0.225, 0.44444444444444
88979, 1.6782608695652, -0.225, 0.38888888888889
88980, 1.6782608695652, -0.225, 0.33333333333333
88981, 1.6782608695652, -0.225, 0.27777777777778
88982, 1.6782608695652, -0.225, 0.22222222222222
88983, 1.6782608695652, -0.225, 0.16666666666667
88984, 1.6782608695652, -0.225, 0.11111111111111
88985, 1.6782608695652, -0.225, 0.055555555555556
88986, 1.7217391304348, -0.225, 0.44444444444444
88987, 1.7217391304348, -0.225, 0.38888888888889
88988, 1.7217391304348, -0.225, 0.33333333333333
88989, 1.7217391304348, -0.225, 0.27777777777778
88990, 1.7217391304348, -0.225, 0.22222222222222
88991, 1.7217391304348, -0.225, 0.16666666666667
88992, 1.7217391304348, -0.225, 0.11111111111111
88993, 1.7217391304348, -0.225, 0.055555555555556
88994, 1.7652173913043, -0.225, 0.44444444444444
88995, 1.7652173913043, -0.225, 0.38888888888889
88996, 1.7652173913043, -0.225, 0.33333333333333
88997, 1.7652173913043, -0.225, 0.27777777777778
88998, 1.7652173913043, -0.225, 0.22222222222222
88999, 1.7652173913043, -0.225, 0.16666666666667
89000, 1.7652173913043, -0.225, 0.11111111111111
89001, 1.7652173913043, -0.225, 0.055555555555556
89002, 1.8086956521739, -0.225, 0.44444444444444
89003, 1.8086956521739, -0.225, 0.38888888888889
89004, 1.8086956521739, -0.225, 0.33333333333333
89005, 1.8086956521739, -0.225, 0.27777777777778
89006, 1.8086956521739, -0.225, 0.22222222222222
89007, 1.8086956521739, -0.225, 0.16666666666667
89008, 1.8086956521739, -0.225, 0.11111111111111
89009, 1.8086956521739, -0.225, 0.055555555555556
89010, 1.8521739130435, -0.225, 0.44444444444444
89011, 1.8521739130435, -0.225, 0.38888888888889
89012, 1.8521739130435, -0.225, 0.33333333333333
89013, 1.8521739130435, -0.225, 0.27777777777778
89014, 1.8521739130435, -0.225, 0.22222222222222
89015, 1.8521739130435, -0.225, 0.16666666666667
89016, 1.8521739130435, -0.225, 0.11111111111111
89017, 1.8521739130435, -0.225, 0.055555555555556
89018, 1.895652173913, -0.225, 0.44444444444444
89019, 1.895652173913, -0.225, 0.38888888888889
89020, 1.895652173913, -0.225, 0.33333333333333
89021, 1.895652173913, -0.225, 0.27777777777778
89022, 1.895652173913, -0.225, 0.22222222222222
89023, 1.895652173913, -0.225, 0.16666666666667
89024, 1.895652173913, -0.225, 0.11111111111111
89025, 1.895652173913, -0.225, 0.055555555555556
89026, 1.9391304347826, -0.225, 0.44444444444444
89027, 1.9391304347826, -0.225, 0.38888888888889
89028, 1.9391304347826, -0.225, 0.33333333333333
89029, 1.9391304347826, -0.225, 0.27777777777778
89030, 1.9391304347826, -0.225, 0.22222222222222
89031, 1.9391304347826, -0.225, 0.16666666666667
89032, 1.9391304347826, -0.225, 0.11111111111111
89033, 1.9391304347826, -0.225, 0.055555555555556
89034, 1.9826086956522, -0.225, 0.44444444444444
89035, 1.9826086956522, -0.225, 0.38888888888889
89036, 1.9826086956522, -0.225, 0.33333333333333
89037, 1.9826086956522, -0.225, 0.27777777777778
89038, 1.9826086956522, -0.225, 0.22222222222222
89039, 1.9826086956522, -0.225, 0.16666666666667
89040, 1.9826086956522, -0.225, 0.11111111111111
89041, 1.9826086956522, -0.225, 0.055555555555556
89042, 2.0260869565217, -0.225, 0.44444444444444
89043, 2.0260869565217, -0.225, 0.38888888888889
89044, 2.0260869565217, -0.225, 0.33333333333333
89045, 2.0260869565217, -0.225, 0.27777777777778
89046, 2.0260869565217, -0.225, 0.22222222222222
89047, 2.0260869565217, -0.225, 0.16666666666667
89048, 2.0260869565217, -0.225, 0.11111111111111
89049, 2.0260869565217, -0.225, 0.055555555555556
89050, 2.0695652173913, -0.225, 0.44444444444444
89051, 2.0695652173913, -0.225, 0.38888888888889
89052, 2.0695652173913, -0.225, 0.33333333333333
89053, 2.0695652173913, -0.225, 0.27777777777778
89054, 2.0695652173913, -0.225, 0.22222222222222
89055, 2.0695652173913, -0.225, 0.16666666666667
89056, 2.0695652173913, -0.225, 0.11111111111111
89057, 2.0695652173913, -0.225, 0.055555555555556
89058, 2.1130434782609, -0.225, 0.44444444444444
89059, 2.1130434782609, -0.225, 0.38888888888889
89060, 2.1130434782609, -0.225, 0.33333333333333
89061, 2.1130434782609, -0.225, 0.27777777777778
89062, 2.1130434782609, -0.225, 0.22222222222222
89063, 2.1130434782609, -0.225, 0.16666666666667
89064, 2.1130434782609, -0.225, 0.11111111111111
89065, 2.1130434782609, -0.225, 0.055555555555556
89066, 2.1565217391304, -0.225, 0.44444444444444
89067, 2.1565217391304, -0.225, 0.38888888888889
89068, 2.1565217391304, -0.225, 0.33333333333333
89069, 2.1565217391304, -0.225, 0.27777777777778
89070, 2.1565217391304, -0.225, 0.22222222222222
89071, 2.1565217391304, -0.225, 0.16666666666667
89072, 2.1565217391304, -0.225, 0.11111111111111
89073, 2.1565217391304, -0.225, 0.055555555555556
89074, 2.25, -0.1, 0.44444444444444
89075, 2.25, -0.1, 0.38888888888889
89076, 2.25, -0.1, 0.33333333333333
89077, 2.25, -0.1, 0.27777777777778
89078, 2.25, -0.1, 0.22222222222222
89079, 2.25, -0.1, 0.16666666666667
89080, 2.25, -0.1, 0.11111111111111
89081, 2.25, -0.1, 0.055555555555556
89082, 2.25, -0.15, 0.44444444444444
89083, 2.25, -0.15, 0.38888888888889
89084, 2.25, -0.15, 0.33333333333333
89085, 2.25, -0.15, 0.27777777777778
89086, 2.25, -0.15, 0.22222222222222
89087, 2.25, -0.15, 0.16666666666667
89088, 2.25, -0.15, 0.11111111111111
89089, 2.25, -0.15, 0.055555555555556
89090, 2.25, -0.2, 0.44444444444444
89091, 2.25, -0.2, 0.38888888888889
89092, 2.25, -0.2, 0.33333333333333
89093, 2.25, -0.2, 0.27777777777778
89094, 2.25, -0.2, 0.22222222222222
89095, 2.25, -0.2, 0.16666666666667
89096, 2.25, -0.2, 0.11111111111111
89097, 2.25, -0.2, 0.055555555555556
89098, 2.25, -0.1, 0.47222222222222
89099, 2.225, -0.1, 0.44444444444444
89100, 2.25, -0.075, 0.44444444444444
89101, 2.25, -0.1, 0.41666666666667
89102, 2.225, -0.1, 0.38888888888889
89103, 2.25, -0.075, 0.38888888888889
89104, 2.25, -0.1, 0.36111111111111
89105, 2.225, -0.1, 0.33333333333333
89106, 2.25, -0.075, 0.33333333333333
89107, 2.25, -0.1, 0.30555555555556
89108, 2.225, -0.1, 0.27777777777778
89109, 2.25, -0.075, 0.27777777777778
89110, 2.25, -0.1, 0.25
89111, 2.225, -0.1, 0.22222222222222
89112, 2.25, -0.075, 0.22222222222222
89113, 2.25, -0.1, 0.19444444444444
89114, 2.225, -0.1, 0.16666666666667
89115, 2.25, -0.075, 0.16666666666667
89116, 2.25, -0.1, 0.13888888888889
89117, 2.225, -0.1, 0.11111111111111
89118, 2.25, -0.075, 0.11111111111111
89119, 2.25, -0.1, 0.083333333333333
89120, 2.225, -0.1, 0.055555555555556
89121, 2.25, -0.075, 0.055555555555556
89122, 2.25, -0.1, 0.027777777777778
89123, 2.275, -0.1, 0.44444444444444
89124, 2.275, -0.1, 0.38888888888889
89125, 2.275, -0.1, 0.33333333333333
89126, 2.275, -0.1, 0.27777777777778
89127, 2.275, -0.1, 0.22222222222222
89128, 2.275, -0.1, 0.16666666666667
89129, 2.275, -0.1, 0.11111111111111
89130, 2.275, -0.1, 0.055555555555556
89131, 2.25, -0.15, 0.47222222222222
89132, 2.225, -0.15, 0.44444444444444
89133, 2.25, -0.125, 0.44444444444444
89134, 2.25, -0.15, 0.41666666666667
89135, 2.225, -0.15, 0.38888888888889
89136, 2.25, -0.125, 0.38888888888889
89137, 2.25, -0.15, 0.36111111111111
89138, 2.225, -0.15, 0.33333333333333
89139, 2.25, -0.125, 0.33333333333333
89140, 2.25, -0.15, 0.30555555555556
89141, 2.225, -0.15, 0.27777777777778
89142, 2.25, -0.125, 0.27777777777778
89143, 2.25, -0.15, 0.25
89144, 2.225, -0.15, 0.22222222222222
89145, 2.25, -0.125, 0.22222222222222
89146, 2.25, -0.15, 0.19444444444444
89147, 2.225, -0.15, 0.16666666666667
89148, 2.25, -0.125, 0.16666666666667
89149, 2.25, -0.15, 0.13888888888889
89150, 2.225, -0.15, 0.11111111111111
89151, 2.25, -0.125, 0.11111111111111
89152, 2.25, -0.15, 0.083333333333333
89153, 2.225, -0.15, 0.055555555555556
89154, 2.25, -0.125, 0.055555555555556
89155, 2.25, -0.15, 0.027777777777778
89156, 2.275, -0.15, 0.44444444444444
89157, 2.275, -0.15, 0.38888888888889
89158, 2.275, -0.15, 0.33333333333333
89159, 2.275, -0.15, 0.27777777777778
89160, 2.275, -0.15, 0.22222222222222
89161, 2.275, -0.15, 0.16666666666667
89162, 2.275, -0.15, 0.11111111111111
89163, 2.275, -0.15, 0.055555555555556
89164, 2.25, -0.2, 0.47222222222222
89165, 2.225, -0.2, 0.44444444444444
89166, 2.25, -0.175, 0.44444444444444
89167, 2.25, -0.2, 0.41666666666667
89168, 2.225, -0.2, 0.38888888888889
89169, 2.25, -0.175, 0.38888888888889
89170, 2.25, -0.2, 0.36111111111111
89171, 2.225, -0.2, 0.33333333333333
89172, 2.25, -0.175, 0.33333333333333
89173, 2.25, -0.2, 0.30555555555556
89174, 2.225, -0.2, 0.27777777777778
89175, 2.25, -0.175, 0.27777777777778
89176, 2.25, -0.2, 0.25
89177, 2.225, -0.2, 0.22222222222222
89178, 2.25, -0.175, 0.22222222222222
89179, 2.25, -0.2, 0.19444444444444
89180, 2.225, -0.2, 0.16666666666667
89181, 2.25, -0.175, 0.16666666666667
89182, 2.25, -0.2, 0.13888888888889
89183, 2.225, -0.2, 0.11111111111111
89184, 2.25, -0.175, 0.11111111111111
89185, 2.25, -0.2, 0.083333333333333
89186, 2.225, -0.2, 0.055555555555556
89187, 2.25, -0.175, 0.055555555555556
89188, 2.25, -0.2, 0.027777777777778
89189, 2.275, -0.2, 0.44444444444444
89190, 2.275, -0.2, 0.38888888888889
89191, 2.275, -0.2, 0.33333333333333
89192, 2.275, -0.2, 0.27777777777778
89193, 2.275, -0.2, 0.22222222222222
89194, 2.275, -0.2, 0.16666666666667
89195, 2.275, -0.2, 0.11111111111111
89196, 2.275, -0.2, 0.055555555555556
89197, 2.25, -0.225, 0.44444444444444
89198, 2.25, -0.225, 0.38888888888889
89199, 2.25, -0.225, 0.33333333333333
89200, 2.25, -0.225, 0.27777777777778
89201, 2.25, -0.225, 0.22222222222222
89202, 2.25, -0.225, 0.16666666666667
89203, 2.25, -0.225, 0.11111111111111
89204, 2.25, -0.225, 0.055555555555556
89205, 1.05, -0.1, 0.44444444444444
89206, 1.05, -0.1, 0.38888888888889
89207, 1.05, -0.1, 0.33333333333333
89208, 1.05, -0.1, 0.27777777777778
89209, 1.05, -0.1, 0.22222222222222
89210, 1.05, -0.1, 0.16666666666667
89211, 1.05, -0.1, 0.11111111111111
89212, 1.05, -0.1, 0.055555555555556
89213, 1.05, -0.15, 0.44444444444444
89214, 1.05, -0.15, 0.38888888888889
89215, 1.05, -0.15, 0.33333333333333
89216, 1.05, -0.15, 0.27777777777778
89217, 1.05, -0.15, 0.22222222222222
89218, 1.05, -0.15, 0.16666666666667
89219, 1.05, -0.15, 0.11111111111111
89220, 1.05, -0.15, 0.055555555555556
89221, 1.05, -0.2, 0.44444444444444
89222, 1.05, -0.2, 0.38888888888889
89223, 1.05, -0.2, 0.33333333333333
89224, 1.05, -0.2, 0.27777777777778
89225, 1.05, -0.2, 0.22222222222222
89226, 1.05, -0.2, 0.16666666666667
89227, 1.05, -0.2, 0.11111111111111
89228, 1.05, -0.2, 0.055555555555556
89229, 1.1, -0.1, 0.44444444444444
89230, 1.1, -0.1, 0.38888888888889
89231, 1.1, -0.1, 0.33333333333333
89232, 1.1, -0.1, 0.27777777777778
89233, 1.1, -0.1, 0.22222222222222
89234, 1.1, -0.1, 0.16666666666667
89235, 1.1, -0.1, 0.11111111111111
89236, 1.1, -0.1, 0.055555555555556
89237, 1.1, -0.15, 0.44444444444444
89238, 1.1, -0.15, 0.38888888888889
89239, 1.1, -0.15, 0.33333333333333
89240, 1.1, -0.15, 0.27777777777778
89241, 1.1, -0.15, 0.22222222222222
89242, 1.1, -0.15, 0.16666666666667
89243, 1.1, -0.15, 0.11111111111111
89244, 1.1, -0.15, 0.055555555555556
89245, 1.1, -0.2, 0.44444444444444
89246, 1.1, -0.2, 0.38888888888889
89247, 1.1, -0.2, 0.33333333333333
89248, 1.1, -0.2, 0.27777777777778
89249, 1.1, -0.2, 0.22222222222222
89250, 1.1, -0.2, 0.16666666666667
89251, 1.1, -0.2, 0.11111111111111
89252, 1.1, -0.2, 0.055555555555556
89253, 1.15, -0.1, 0.44444444444444
89254, 1.15, -0.1, 0.38888888888889
89255, 1.15, -0.1, 0.33333333333333
89256, 1.15, -0.1, 0.27777777777778
89257, 1.15, -0.1, 0.22222222222222
89258, 1.15, -0.1, 0.16666666666667
89259, 1.15, -0.1, 0.11111111111111
89260, 1.15, -0.1, 0.055555555555556
89261, 1.15, -0.15, 0.44444444444444
89262, 1.15, -0.15, 0.38888888888889
89263, 1.15, -0.15, 0.33333333333333
89264, 1.15, -0.15, 0.27777777777778
89265, 1.15, -0.15, 0.22222222222222
89266, 1.15, -0.15, 0.16666666666667
89267, 1.15, -0.15, 0.11111111111111
89268, 1.15, -0.15, 0.055555555555556
89269, 1.15, -0.2, 0.44444444444444
89270, 1.15, -0.2, 0.38888888888889
89271, 1.15, -0.2, 0.33333333333333
89272, 1.15, -0.2, 0.27777777777778
89273, 1.15, -0.2, 0.22222222222222
89274, 1.15, -0.2, 0.16666666666667
89275, 1.15, -0.2, 0.11111111111111
89276, 1.15, -0.2, 0.055555555555556
89277, 1.05, -0.1, 0.47222222222222
89278, 1.05, -0.075, 0.44444444444444
89279, 1.025, -0.1, 0.44444444444444
89280, 1.05, -0.1, 0.41666666666667
89281, 1.05, -0.075, 0.38888888888889
89282, 1.025, -0.1, 0.38888888888889
89283, 1.05, -0.1, 0.36111111111111
89284, 1.05, -0.075, 0.33333333333333
89285, 1.025, -0.1, 0.33333333333333
89286, 1.05, -0.1, 0.30555555555556
89287, 1.05, -0.075, 0.27777777777778
89288, 1.025, -0.1, 0.27777777777778
89289, 1.05, -0.1, 0.25
89290, 1.05, -0.075, 0.22222222222222
89291, 1.025, -0.1, 0.22222222222222
89292, 1.05, -0.1, 0.19444444444444
89293, 1.05, -0.075, 0.16666666666667
89294, 1.025, -0.1, 0.16666666666667
89295, 1.05, -0.1, 0.13888888888889
89296, 1.05, -0.075, 0.11111111111111
89297, 1.025, -0.1, 0.11111111111111
89298, 1.05, -0.1, 0.083333333333333
89299, 1.05, -0.075, 0.055555555555556
89300, 1.025, -0.1, 0.055555555555556
89301, 1.05, -0.1, 0.027777777777778
89302, 1.05, -0.15, 0.47222222222222
89303, 1.05, -0.125, 0.44444444444444
89304, 1.025, -0.15, 0.44444444444444
89305, 1.05, -0.15, 0.41666666666667
89306, 1.05, -0.125, 0.38888888888889
89307, 1.025, -0.15, 0.38888888888889
89308, 1.05, -0.15, 0.36111111111111
89309, 1.05, -0.125, 0.33333333333333
89310, 1.025, -0.15, 0.33333333333333
89311, 1.05, -0.15, 0.30555555555556
89312, 1.05, -0.125, 0.27777777777778
89313, 1.025, -0.15, 0.27777777777778
89314, 1.05, -0.15, 0.25
89315, 1.05, -0.125, 0.22222222222222
89316, 1.025, -0.15, 0.22222222222222
89317, 1.05, -0.15, 0.19444444444444
89318, 1.05, -0.125, 0.16666666666667
89319, 1.025, -0.15, 0.16666666666667
89320, 1.05, -0.15, 0.13888888888889
89321, 1.05, -0.125, 0.11111111111111
89322, 1.025, -0.15, 0.11111111111111
89323, 1.05, -0.15, 0.083333333333333
89324, 1.05, -0.125, 0.055555555555556
89325, 1.025, -0.15, 0.055555555555556
89326, 1.05, -0.15, 0.027777777777778
89327, 1.05, -0.2, 0.47222222222222
89328, 1.05, -0.175, 0.44444444444444
89329, 1.025, -0.2, 0.44444444444444
89330, 1.05, -0.2, 0.41666666666667
89331, 1.05, -0.175, 0.38888888888889
89332, 1.025, -0.2, 0.38888888888889
89333, 1.05, -0.2, 0.36111111111111
89334, 1.05, -0.175, 0.33333333333333
89335, 1.025, -0.2, 0.33333333333333
89336, 1.05, -0.2, 0.30555555555556
89337, 1.05, -0.175, 0.27777777777778
89338, 1.025, -0.2, 0.27777777777778
89339, 1.05, -0.2, 0.25
89340, 1.05, -0.175, 0.22222222222222
89341, 1.025, -0.2, 0.22222222222222
89342, 1.05, -0.2, 0.19444444444444
89343, 1.05, -0.175, 0.16666666666667
89344, 1.025, -0.2, 0.16666666666667
89345, 1.05, -0.2, 0.13888888888889
89346, 1.05, -0.175, 0.11111111111111
89347, 1.025, -0.2, 0.11111111111111
89348, 1.05, -0.2, 0.083333333333333
89349, 1.05, -0.175, 0.055555555555556
89350, 1.025, -0.2, 0.055555555555556
89351, 1.05, -0.2, 0.027777777777778
89352, 1.05, -0.225, 0.44444444444444
89353, 1.05, -0.225, 0.38888888888889
89354, 1.05, -0.225, 0.33333333333333
89355, 1.05, -0.225, 0.27777777777778
89356, 1.05, -0.225, 0.22222222222222
89357, 1.05, -0.225, 0.16666666666667
89358, 1.05, -0.225, 0.11111111111111
89359, 1.05, -0.225, 0.055555555555556
89360, 1.1, -0.1, 0.47222222222222
89361, 1.1, -0.075, 0.44444444444444
89362, 1.075, -0.1, 0.44444444444444
89363, 1.1, -0.1, 0.41666666666667
89364, 1.1, -0.075, 0.38888888888889
89365, 1.075, -0.1, 0.38888888888889
89366, 1.1, -0.1, 0.36111111111111
89367, 1.1, -0.075, 0.33333333333333
89368, 1.075, -0.1, 0.33333333333333
89369, 1.1, -0.1, 0.30555555555556
89370, 1.1, -0.075, 0.27777777777778
89371, 1.075, -0.1, 0.27777777777778
89372, 1.1, -0.1, 0.25
89373, 1.1, -0.075, 0.22222222222222
89374, 1.075, -0.1, 0.22222222222222
89375, 1.1, -0.1, 0.19444444444444
89376, 1.1, -0.075, 0.16666666666667
89377, 1.075, -0.1, 0.16666666666667
89378, 1.1, -0.1, 0.13888888888889
89379, 1.1, -0.075, 0.11111111111111
89380, 1.075, -0.1, 0.11111111111111
89381, 1.1, -0.1, 0.083333333333333
89382, 1.1, -0.075, 0.055555555555556
89383, 1.075, -0.1, 0.055555555555556
89384, 1.1, -0.1, 0.027777777777778
89385, 1.1, -0.15, 0.47222222222222
89386, 1.1, -0.125, 0.44444444444444
89387, 1.075, -0.15, 0.44444444444444
89388, 1.1, -0.15, 0.41666666666667
89389, 1.1, -0.125, 0.38888888888889
89390, 1.075, -0.15, 0.38888888888889
89391, 1.1, -0.15, 0.36111111111111
89392, 1.1, -0.125, 0.33333333333333
89393, 1.075, -0.15, 0.33333333333333
89394, 1.1, -0.15, 0.30555555555556
89395, 1.1, -0.125, 0.27777777777778
89396, 1.075, -0.15, 0.27777777777778
89397, 1.1, -0.15, 0.25
89398, 1.1, -0.125, 0.22222222222222
89399, 1.075, -0.15, 0.22222222222222
89400, 1.1, -0.15, 0.19444444444444
89401, 1.1, -0.125, 0.16666666666667
89402, 1.075, -0.15, 0.16666666666667
89403, 1.1, -0.15, 0.13888888888889
89404, 1.1, -0.125, 0.11111111111111
89405, 1.075, -0.15, 0.11111111111111
89406, 1.1, -0.15, 0.083333333333333
89407, 1.1, -0.125, 0.055555555555556
89408, 1.075, -0.15, 0.055555555555556
89409, 1.1, -0.15, 0.027777777777778
89410, 1.1, -0.2, 0.47222222222222
89411, 1.1, -0.175, 0.44444444444444
89412, 1.075, -0.2, 0.44444444444444
89413, 1.1, -0.2, 0.41666666666667
89414, 1.1, -0.175, 0.38888888888889
89415, 1.075, -0.2, 0.38888888888889
89416, 1.1, -0.2, 0.36111111111111
89417, 1.1, -0.175, 0.33333333333333
89418, 1.075, -0.2, 0.33333333333333
89419, 1.1, -0.2, 0.30555555555556
89420, 1.1, -0.175, 0.27777777777778
89421, 1.075, -0.2, 0.27777777777778
89422, 1.1, -0.2, 0.25
89423, 1.1, -0.175, 0.22222222222222
89424, 1.075, -0.2, 0.22222222222222
89425, 1.1, -0.2, 0.19444444444444
89426, 1.1, -0.175, 0.16666666666667
89427, 1.075, -0.2, 0.16666666666667
89428, 1.1, -0.2, 0.13888888888889
89429, 1.1, -0.175, 0.11111111111111
89430, 1.075, -0.2, 0.11111111111111
89431, 1.1, -0.2, 0.083333333333333
89432, 1.1, -0.175, 0.055555555555556
89433, 1.075, -0.2, 0.055555555555556
89434, 1.1, -0.2, 0.027777777777778
89435, 1.1, -0.225, 0.44444444444444
89436, 1.1, -0.225, 0.38888888888889
89437, 1.1, -0.225, 0.33333333333333
89438, 1.1, -0.225, 0.27777777777778
89439, 1.1, -0.225, 0.22222222222222
89440, 1.1, -0.225, 0.16666666666667
89441, 1.1, -0.225, 0.11111111111111
89442, 1.1, -0.225, 0.055555555555556
89443, 1.15, -0.1, 0.47222222222222
89444, 1.15, -0.075, 0.44444444444444
89445, 1.125, -0.1, 0.44444444444444
89446, 1.15, -0.1, 0.41666666666667
89447, 1.15, -0.075, 0.38888888888889
89448, 1.125, -0.1, 0.38888888888889
89449, 1.15, -0.1, 0.36111111111111
89450, 1.15, -0.075, 0.33333333333333
89451, 1.125, -0.1, 0.33333333333333
89452, 1.15, -0.1, 0.30555555555556
89453, 1.15, -0.075, 0.27777777777778
89454, 1.125, -0.1, 0.27777777777778
89455, 1.15, -0.1, 0.25
89456, 1.15, -0.075, 0.22222222222222
89457, 1.125, -0.1, 0.22222222222222
89458, 1.15, -0.1, 0.19444444444444
89459, 1.15, -0.075, 0.16666666666667
89460, 1.125, -0.1, 0.16666666666667
89461, 1.15, -0.1, 0.13888888888889
89462, 1.15, -0.075, 0.11111111111111
89463, 1.125, -0.1, 0.11111111111111
89464, 1.15, -0.1, 0.083333333333333
89465, 1.15, -0.075, 0.055555555555556
89466, 1.125, -0.1, 0.055555555555556
89467, 1.15, -0.1, 0.027777777777778
89468, 1.15, -0.15, 0.47222222222222
89469, 1.15, -0.125, 0.44444444444444
89470, 1.125, -0.15, 0.44444444444444
89471, 1.15, -0.15, 0.41666666666667
89472, 1.15, -0.125, 0.38888888888889
89473, 1.125, -0.15, 0.38888888888889
89474, 1.15, -0.15, 0.36111111111111
89475, 1.15, -0.125, 0.33333333333333
89476, 1.125, -0.15, 0.33333333333333
89477, 1.15, -0.15, 0.30555555555556
89478, 1.15, -0.125, 0.27777777777778
89479, 1.125, -0.15, 0.27777777777778
89480, 1.15, -0.15, 0.25
89481, 1.15, -0.125, 0.22222222222222
89482, 1.125, -0.15, 0.22222222222222
89483, 1.15, -0.15, 0.19444444444444
89484, 1.15, -0.125, 0.16666666666667
89485, 1.125, -0.15, 0.16666666666667
89486, 1.15, -0.15, 0.13888888888889
89487, 1.15, -0.125, 0.11111111111111
89488, 1.125, -0.15, 0.11111111111111
89489, 1.15, -0.15, 0.083333333333333
89490, 1.15, -0.125, 0.055555555555556
89491, 1.125, -0.15, 0.055555555555556
89492, 1.15, -0.15, 0.027777777777778
89493, 1.15, -0.2, 0.47222222222222
89494, 1.15, -0.175, 0.44444444444444
89495, 1.125, -0.2, 0.44444444444444
89496, 1.15, -0.2, 0.41666666666667
89497, 1.15, -0.175, 0.38888888888889
89498, 1.125, -0.2, 0.38888888888889
89499, 1.15, -0.2, 0.36111111111111
89500, 1.15, -0.175, 0.33333333333333
89501, 1.125, -0.2, 0.33333333333333
89502, 1.15, -0.2, 0.30555555555556
89503, 1.15, -0.175, 0.27777777777778
89504, 1.125, -0.2, 0.27777777777778
89505, 1.15, -0.2, 0.25
89506, 1.15, -0.175, 0.22222222222222
89507, 1.125, -0.2, 0.22222222222222
89508, 1.15, -0.2, 0.19444444444444
89509, 1.15, -0.175, 0.16666666666667
89510, 1.125, -0.2, 0.16666666666667
89511, 1.15, -0.2, 0.13888888888889
89512, 1.15, -0.175, 0.11111111111111
89513, 1.125, -0.2, 0.11111111111111
89514, 1.15, -0.2, 0.083333333333333
89515, 1.15, -0.175, 0.055555555555556
89516, 1.125, -0.2, 0.055555555555556
89517, 1.15, -0.2, 0.027777777777778
89518, 1.15, -0.225, 0.44444444444444
89519, 1.15, -0.225, 0.38888888888889
89520, 1.15, -0.225, 0.33333333333333
89521, 1.15, -0.225, 0.27777777777778
89522, 1.15, -0.225, 0.22222222222222
89523, 1.15, -0.225, 0.16666666666667
89524, 1.15, -0.225, 0.11111111111111
89525, 1.15, -0.225, 0.055555555555556
89526, 1.175, -0.1, 0.44444444444444
89527, 1.175, -0.1, 0.38888888888889
89528, 1.175, -0.1, 0.33333333333333
89529, 1.175, -0.1, 0.27777777777778
89530, 1.175, -0.1, 0.22222222222222
89531, 1.175, -0.1, 0.16666666666667
89532, 1.175, -0.1, 0.11111111111111
89533, 1.175, -0.1, 0.055555555555556
89534, 1.175, -0.15, 0.44444444444444
89535, 1.175, -0.15, 0.38888888888889
89536, 1.175, -0.15, 0.33333333333333
89537, 1.175, -0.15, 0.27777777777778
89538, 1.175, -0.15, 0.22222222222222
89539, 1.175, -0.15, 0.16666666666667
89540, 1.175, -0.15, 0.11111111111111
89541, 1.175, -0.15, 0.055555555555556
89542, 1.175, -0.2, 0.44444444444444
89543, 1.175, -0.2, 0.38888888888889
89544, 1.175, -0.2, 0.33333333333333
89545, 1.175, -0.2, 0.27777777777778
89546, 1.175, -0.2, 0.22222222222222
89547, 1.175, -0.2, 0.16666666666667
89548, 1.175, -0.2, 0.11111111111111
89549, 1.175, -0.2, 0.055555555555556
89550, -0.05, 1.6, 0.44444444444444
89551, -0.05, 1.6, 0.38888888888889
89552, -0.05, 1.6, 0.33333333333333
89553, -0.05, 1.6, 0.27777777777778
89554, -0.05, 1.6, 0.22222222222222
89555, -0.05, 1.6, 0.16666666666667
89556, -0.05, 1.6, 0.11111111111111
89557, -0.05, 1.6, 0.055555555555556
89558, -0.05, 1.65, 0.44444444444444
89559, -0.05, 1.65, 0.38888888888889
89560, -0.05, 1.65, 0.33333333333333
89561, -0.05, 1.65, 0.27777777777778
89562, -0.05, 1.65, 0.22222222222222
89563, -0.05, 1.65, 0.16666666666667
89564, -0.05, 1.65, 0.11111111111111
89565, -0.05, 1.65, 0.055555555555556
89566, -0.05, 1.7, 0.44444444444444
89567, -0.05, 1.7, 0.38888888888889
89568, -0.05, 1.7, 0.33333333333333
89569, -0.05, 1.7, 0.27777777777778
89570, -0.05, 1.7, 0.22222222222222
89571, -0.05, 1.7, 0.16666666666667
89572, -0.05, 1.7, 0.11111111111111
89573, -0.05, 1.7, 0.055555555555556
89574, -0.05, 1.6, 0.47222222222222
89575, -0.05, 1.575, 0.44444444444444
89576, -0.025, 1.6, 0.44444444444444
89577, -0.05, 1.6, 0.41666666666667
89578, -0.05, 1.575, 0.38888888888889
89579, -0.025, 1.6, 0.38888888888889
89580, -0.05, 1.6, 0.36111111111111
89581, -0.05, 1.575, 0.33333333333333
89582, -0.025, 1.6, 0.33333333333333
89583, -0.05, 1.6, 0.30555555555556
89584, -0.05, 1.575, 0.27777777777778
89585, -0.025, 1.6, 0.27777777777778
89586, -0.05, 1.6, 0.25
89587, -0.05, 1.575, 0.22222222222222
89588, -0.025, 1.6, 0.22222222222222
89589, -0.05, 1.6, 0.19444444444444
89590, -0.05, 1.575, 0.16666666666667
89591, -0.025, 1.6, 0.16666666666667
89592, -0.05, 1.6, 0.13888888888889
89593, -0.05, 1.575, 0.11111111111111
89594, -0.025, 1.6, 0.11111111111111
89595, -0.05, 1.6, 0.083333333333333
89596, -0.05, 1.575, 0.055555555555556
89597, -0.025, 1.6, 0.055555555555556
89598, -0.05, 1.6, 0.027777777777778
89599, -0.05, 1.65, 0.47222222222222
89600, -0.05, 1.625, 0.44444444444444
89601, -0.025, 1.65, 0.44444444444444
89602, -0.05, 1.65, 0.41666666666667
89603, -0.05, 1.625, 0.38888888888889
89604, -0.025, 1.65, 0.38888888888889
89605, -0.05, 1.65, 0.36111111111111
89606, -0.05, 1.625, 0.33333333333333
89607, -0.025, 1.65, 0.33333333333333
89608, -0.05, 1.65, 0.30555555555556
89609, -0.05, 1.625, 0.27777777777778
89610, -0.025, 1.65, 0.27777777777778
89611, -0.05, 1.65, 0.25
89612, -0.05, 1.625, 0.22222222222222
89613, -0.025, 1.65, 0.22222222222222
89614, -0.05, 1.65, 0.19444444444444
89615, -0.05, 1.625, 0.16666666666667
89616, -0.025, 1.65, 0.16666666666667
89617, -0.05, 1.65, 0.13888888888889
89618, -0.05, 1.625, 0.11111111111111
89619, -0.025, 1.65, 0.11111111111111
89620, -0.05, 1.65, 0.083333333333333
89621, -0.05, 1.625, 0.055555555555556
89622, -0.025, 1.65, 0.055555555555556
89623, -0.05, 1.65, 0.027777777777778
89624, -0.05, 1.7, 0.47222222222222
89625, -0.05, 1.675, 0.44444444444444
89626, -0.025, 1.7, 0.44444444444444
89627, -0.05, 1.7, 0.41666666666667
89628, -0.05, 1.675, 0.38888888888889
89629, -0.025, 1.7, 0.38888888888889
89630, -0.05, 1.7, 0.36111111111111
89631, -0.05, 1.675, 0.33333333333333
89632, -0.025, 1.7, 0.33333333333333
89633, -0.05, 1.7, 0.30555555555556
89634, -0.05, 1.675, 0.27777777777778
89635, -0.025, 1.7, 0.27777777777778
89636, -0.05, 1.7, 0.25
89637, -0.05, 1.675, 0.22222222222222
89638, -0.025, 1.7, 0.22222222222222
89639, -0.05, 1.7, 0.19444444444444
89640, -0.05, 1.675, 0.16666666666667
89641, -0.025, 1.7, 0.16666666666667
89642, -0.05, 1.7, 0.13888888888889
89643, -0.05, 1.675, 0.11111111111111
89644, -0.025, 1.7, 0.11111111111111
89645, -0.05, 1.7, 0.083333333333333
89646, -0.05, 1.675, 0.055555555555556
89647, -0.025, 1.7, 0.055555555555556
89648, -0.05, 1.7, 0.027777777777778
89649, -0.05, 1.725, 0.44444444444444
89650, -0.05, 1.725, 0.38888888888889
89651, -0.05, 1.725, 0.33333333333333
89652, -0.05, 1.725, 0.27777777777778
89653, -0.05, 1.725, 0.22222222222222
89654, -0.05, 1.725, 0.16666666666667
89655, -0.05, 1.725, 0.11111111111111
89656, -0.05, 1.725, 0.055555555555556
89657, -0.075, 1.6, 0.44444444444444
89658, -0.075, 1.6, 0.38888888888889
89659, -0.075, 1.6, 0.33333333333333
89660, -0.075, 1.6, 0.27777777777778
89661, -0.075, 1.6, 0.22222222222222
89662, -0.075, 1.6, 0.16666666666667
89663, -0.075, 1.6, 0.11111111111111
89664, -0.075, 1.6, 0.055555555555556
89665, -0.075, 1.65, 0.44444444444444
89666, -0.075, 1.65, 0.38888888888889
89667, -0.075, 1.65, 0.33333333333333
89668, -0.075, 1.65, 0.27777777777778
89669, -0.075, 1.65, 0.22222222222222
89670, -0.075, 1.65, 0.16666666666667
89671, -0.075, 1.65, 0.11111111111111
89672, -0.075, 1.65, 0.055555555555556
89673, -0.075, 1.7, 0.44444444444444
89674, -0.075, 1.7, 0.38888888888889
89675, -0.075, 1.7, 0.33333333333333
89676, -0.075, 1.7, 0.27777777777778
89677, -0.075, 1.7, 0.22222222222222
89678, -0.075, 1.7, 0.16666666666667
89679, -0.075, 1.7, 0.11111111111111
89680, -0.075, 1.7, 0.055555555555556
89681, 2.25, 1.6, 0.44444444444444
89682, 2.25, 1.6, 0.38888888888889
89683, 2.25, 1.6, 0.33333333333333
89684, 2.25, 1.6, 0.27777777777778
89685, 2.25, 1.6, 0.22222222222222
89686, 2.25, 1.6, 0.16666666666667
89687, 2.25, 1.6, 0.11111111111111
89688, 2.25, 1.6, 0.055555555555556
89689, 2.25, 1.65, 0.44444444444444
89690, 2.25, 1.65, 0.38888888888889
89691, 2.25, 1.65, 0.33333333333333
89692, 2.25, 1.65, 0.27777777777778
89693, 2.25, 1.65, 0.22222222222222
89694, 2.25, 1.65, 0.16666666666667
89695, 2.25, 1.65, 0.11111111111111
89696, 2.25, 1.65, 0.055555555555556
89697, 2.25, 1.7, 0.44444444444444
89698, 2.25, 1.7, 0.38888888888889
89699, 2.25, 1.7, 0.33333333333333
89700, 2.25, 1.7, 0.27777777777778
89701, 2.25, 1.7, 0.22222222222222
89702, 2.25, 1.7, 0.16666666666667
89703, 2.25, 1.7, 0.11111111111111
89704, 2.25, 1.7, 0.055555555555556
89705, 2.25, 1.6, 0.47222222222222
89706, 2.25, 1.575, 0.44444444444444
89707, 2.225, 1.6, 0.44444444444444
89708, 2.25, 1.6, 0.41666666666667
89709, 2.25, 1.575, 0.38888888888889
89710, 2.225, 1.6, 0.38888888888889
89711, 2.25, 1.6, 0.36111111111111
89712, 2.25, 1.575, 0.33333333333333
89713, 2.225, 1.6, 0.33333333333333
89714, 2.25, 1.6, 0.30555555555556
89715, 2.25, 1.575, 0.27777777777778
89716, 2.225, 1.6, 0.27777777777778
89717, 2.25, 1.6, 0.25
89718, 2.25, 1.575, 0.22222222222222
89719, 2.225, 1.6, 0.22222222222222
89720, 2.25, 1.6, 0.19444444444444
89721, 2.25, 1.575, 0.16666666666667
89722, 2.225, 1.6, 0.16666666666667
89723, 2.25, 1.6, 0.13888888888889
89724, 2.25, 1.575, 0.11111111111111
89725, 2.225, 1.6, 0.11111111111111
89726, 2.25, 1.6, 0.083333333333333
89727, 2.25, 1.575, 0.055555555555556
89728, 2.225, 1.6, 0.055555555555556
89729, 2.25, 1.6, 0.027777777777778
89730, 2.25, 1.65, 0.47222222222222
89731, 2.25, 1.625, 0.44444444444444
89732, 2.225, 1.65, 0.44444444444444
89733, 2.25, 1.65, 0.41666666666667
89734, 2.25, 1.625, 0.38888888888889
89735, 2.225, 1.65, 0.38888888888889
89736, 2.25, 1.65, 0.36111111111111
89737, 2.25, 1.625, 0.33333333333333
89738, 2.225, 1.65, 0.33333333333333
89739, 2.25, 1.65, 0.30555555555556
89740, 2.25, 1.625, 0.27777777777778
89741, 2.225, 1.65, 0.27777777777778
89742, 2.25, 1.65, 0.25
89743, 2.25, 1.625, 0.22222222222222
89744, 2.225, 1.65, 0.22222222222222
89745, 2.25, 1.65, 0.19444444444444
89746, 2.25, 1.625, 0.16666666666667
89747, 2.225, 1.65, 0.16666666666667
89748, 2.25, 1.65, 0.13888888888889
89749, 2.25, 1.625, 0.11111111111111
89750, 2.225, 1.65, 0.11111111111111
89751, 2.25, 1.65, 0.083333333333333
89752, 2.25, 1.625, 0.055555555555556
89753, 2.225, 1.65, 0.055555555555556
89754, 2.25, 1.65, 0.027777777777778
89755, 2.25, 1.7, 0.47222222222222
89756, 2.25, 1.675, 0.44444444444444
89757, 2.225, 1.7, 0.44444444444444
89758, 2.25, 1.7, 0.41666666666667
89759, 2.25, 1.675, 0.38888888888889
89760, 2.225, 1.7, 0.38888888888889
89761, 2.25, 1.7, 0.36111111111111
89762, 2.25, 1.675, 0.33333333333333
89763, 2.225, 1.7, 0.33333333333333
89764, 2.25, 1.7, 0.30555555555556
89765, 2.25, 1.675, 0.27777777777778
89766, 2.225, 1.7, 0.27777777777778
89767, 2.25, 1.7, 0.25
89768, 2.25, 1.675, 0.22222222222222
89769, 2.225, 1.7, 0.22222222222222
89770, 2.25, 1.7, 0.19444444444444
89771, 2.25, 1.675, 0.16666666666667
89772, 2.225, 1.7, 0.16666666666667
89773, 2.25, 1.7, 0.13888888888889
89774, 2.25, 1.675, 0.11111111111111
89775, 2.225, 1.7, 0.11111111111111
89776, 2.25, 1.7, 0.083333333333333
89777, 2.25, 1.675, 0.055555555555556
89778, 2.225, 1.7, 0.055555555555556
89779, 2.25, 1.7, 0.027777777777778
89780, 2.25, 1.725, 0.44444444444444
89781, 2.25, 1.725, 0.38888888888889
89782, 2.25, 1.725, 0.33333333333333
89783, 2.25, 1.725, 0.27777777777778
89784, 2.25, 1.725, 0.22222222222222
89785, 2.25, 1.725, 0.16666666666667
89786, 2.25, 1.725, 0.11111111111111
89787, 2.25, 1.725, 0.055555555555556
89788, 2.275, 1.6, 0.44444444444444
89789, 2.275, 1.6, 0.38888888888889
89790, 2.275, 1.6, 0.33333333333333
89791, 2.275, 1.6, 0.27777777777778
89792, 2.275, 1.6, 0.22222222222222
89793, 2.275, 1.6, 0.16666666666667
89794, 2.275, 1.6, 0.11111111111111
89795, 2.275, 1.6, 0.055555555555556
89796, 2.275, 1.65, 0.44444444444444
89797, 2.275, 1.65, 0.38888888888889
89798, 2.275, 1.65, 0.33333333333333
89799, 2.275, 1.65, 0.27777777777778
89800, 2.275, 1.65, 0.22222222222222
89801, 2.275, 1.65, 0.16666666666667
89802, 2.275, 1.65, 0.11111111111111
89803, 2.275, 1.65, 0.055555555555556
89804, 2.275, 1.7, 0.44444444444444
89805, 2.275, 1.7, 0.38888888888889
89806, 2.275, 1.7, 0.33333333333333
89807, 2.275, 1.7, 0.27777777777778
89808, 2.275, 1.7, 0.22222222222222
89809, 2.275, 1.7, 0.16666666666667
89810, 2.275, 1.7, 0.11111111111111
89811, 2.275, 1.7, 0.055555555555556
89812, 1.2434782608696, 0.075, 0.44444444444444
89813, 1.2434782608696, 0.075, 0.38888888888889
89814, 1.2434782608696, 0.075, 0.33333333333333
89815, 1.2434782608696, 0.075, 0.27777777777778
89816, 1.2434782608696, 0.075, 0.22222222222222
89817, 1.2434782608696, 0.075, 0.16666666666667
89818, 1.2434782608696, 0.075, 0.11111111111111
89819, 1.2434782608696, 0.075, 0.055555555555556
89820, 1.2869565217391, 0.075, 0.44444444444444
89821, 1.2869565217391, 0.075, 0.38888888888889
89822, 1.2869565217391, 0.075, 0.33333333333333
89823, 1.2869565217391, 0.075, 0.27777777777778
89824, 1.2869565217391, 0.075, 0.22222222222222
89825, 1.2869565217391, 0.075, 0.16666666666667
89826, 1.2869565217391, 0.075, 0.11111111111111
89827, 1.2869565217391, 0.075, 0.055555555555556
89828, 1.3304347826087, 0.075, 0.44444444444444
89829, 1.3304347826087, 0.075, 0.38888888888889
89830, 1.3304347826087, 0.075, 0.33333333333333
89831, 1.3304347826087, 0.075, 0.27777777777778
89832, 1.3304347826087, 0.075, 0.22222222222222
89833, 1.3304347826087, 0.075, 0.16666666666667
89834, 1.3304347826087, 0.075, 0.11111111111111
89835, 1.3304347826087, 0.075, 0.055555555555556
89836, 1.3739130434783, 0.075, 0.44444444444444
89837, 1.3739130434783, 0.075, 0.38888888888889
89838, 1.3739130434783, 0.075, 0.33333333333333
89839, 1.3739130434783, 0.075, 0.27777777777778
89840, 1.3739130434783, 0.075, 0.22222222222222
89841, 1.3739130434783, 0.075, 0.16666666666667
89842, 1.3739130434783, 0.075, 0.11111111111111
89843, 1.3739130434783, 0.075, 0.055555555555556
89844, 1.4173913043478, 0.075, 0.44444444444444
89845, 1.4173913043478, 0.075, 0.38888888888889
89846, 1.4173913043478, 0.075, 0.33333333333333
89847, 1.4173913043478, 0.075, 0.27777777777778
89848, 1.4173913043478, 0.075, 0.22222222222222
89849, 1.4173913043478, 0.075, 0.16666666666667
89850, 1.4173913043478, 0.075, 0.11111111111111
89851, 1.4173913043478, 0.075, 0.055555555555556
89852, 1.4608695652174, 0.075, 0.44444444444444
89853, 1.4608695652174, 0.075, 0.38888888888889
89854, 1.4608695652174, 0.075, 0.33333333333333
89855, 1.4608695652174, 0.075, 0.27777777777778
89856, 1.4608695652174, 0.075, 0.22222222222222
89857, 1.4608695652174, 0.075, 0.16666666666667
89858, 1.4608695652174, 0.075, 0.11111111111111
89859, 1.4608695652174, 0.075, 0.055555555555556
89860, 1.504347826087, 0.075, 0.44444444444444
89861, 1.504347826087, 0.075, 0.38888888888889
89862, 1.504347826087, 0.075, 0.33333333333333
89863, 1.504347826087, 0.075, 0.27777777777778
89864, 1.504347826087, 0.075, 0.22222222222222
89865, 1.504347826087, 0.075, 0.16666666666667
89866, 1.504347826087, 0.075, 0.11111111111111
89867, 1.504347826087, 0.075, 0.055555555555556
89868, 1.5478260869565, 0.075, 0.44444444444444
89869, 1.5478260869565, 0.075, 0.38888888888889
89870, 1.5478260869565, 0.075, 0.33333333333333
89871, 1.5478260869565, 0.075, 0.27777777777778
89872, 1.5478260869565, 0.075, 0.22222222222222
89873, 1.5478260869565, 0.075, 0.16666666666667
89874, 1.5478260869565, 0.075, 0.11111111111111
89875, 1.5478260869565, 0.075, 0.055555555555556
89876, 1.5913043478261, 0.075, 0.44444444444444
89877, 1.5913043478261, 0.075, 0.38888888888889
89878, 1.5913043478261, 0.075, 0.33333333333333
89879, 1.5913043478261, 0.075, 0.27777777777778
89880, 1.5913043478261, 0.075, 0.22222222222222
89881, 1.5913043478261, 0.075, 0.16666666666667
89882, 1.5913043478261, 0.075, 0.11111111111111
89883, 1.5913043478261, 0.075, 0.055555555555556
89884, 1.6347826086957, 0.075, 0.44444444444444
89885, 1.6347826086957, 0.075, 0.38888888888889
89886, 1.6347826086957, 0.075, 0.33333333333333
89887, 1.6347826086957, 0.075, 0.27777777777778
89888, 1.6347826086957, 0.075, 0.22222222222222
89889, 1.6347826086957, 0.075, 0.16666666666667
89890, 1.6347826086957, 0.075, 0.11111111111111
89891, 1.6347826086957, 0.075, 0.055555555555556
89892, 1.6782608695652, 0.075, 0.44444444444444
89893, 1.6782608695652, 0.075, 0.38888888888889
89894, 1.6782608695652, 0.075, 0.33333333333333
89895, 1.6782608695652, 0.075, 0.27777777777778
89896, 1.6782608695652, 0.075, 0.22222222222222
89897, 1.6782608695652, 0.075, 0.16666666666667
89898, 1.6782608695652, 0.075, 0.11111111111111
89899, 1.6782608695652, 0.075, 0.055555555555556
89900, 1.7217391304348, 0.075, 0.44444444444444
89901, 1.7217391304348, 0.075, 0.38888888888889
89902, 1.7217391304348, 0.075, 0.33333333333333
89903, 1.7217391304348, 0.075, 0.27777777777778
89904, 1.7217391304348, 0.075, 0.22222222222222
89905, 1.7217391304348, 0.075, 0.16666666666667
89906, 1.7217391304348, 0.075, 0.11111111111111
89907, 1.7217391304348, 0.075, 0.055555555555556
89908, 1.7652173913043, 0.075, 0.44444444444444
89909, 1.7652173913043, 0.075, 0.38888888888889
89910, 1.7652173913043, 0.075, 0.33333333333333
89911, 1.7652173913043, 0.075, 0.27777777777778
89912, 1.7652173913043, 0.075, 0.22222222222222
89913, 1.7652173913043, 0.075, 0.16666666666667
89914, 1.7652173913043, 0.075, 0.11111111111111
89915, 1.7652173913043, 0.075, 0.055555555555556
89916, 1.8086956521739, 0.075, 0.44444444444444
89917, 1.8086956521739, 0.075, 0.38888888888889
89918, 1.8086956521739, 0.075, 0.33333333333333
89919, 1.8086956521739, 0.075, 0.27777777777778
89920, 1.8086956521739, 0.075, 0.22222222222222
89921, 1.8086956521739, 0.075, 0.16666666666667
89922, 1.8086956521739, 0.075, 0.11111111111111
89923, 1.8086956521739, 0.075, 0.055555555555556
89924, 1.8521739130435, 0.075, 0.44444444444444
89925, 1.8521739130435, 0.075, 0.38888888888889
89926, 1.8521739130435, 0.075, 0.33333333333333
89927, 1.8521739130435, 0.075, 0.27777777777778
89928, 1.8521739130435, 0.075, 0.22222222222222
89929, 1.8521739130435, 0.075, 0.16666666666667
89930, 1.8521739130435, 0.075, 0.11111111111111
89931, 1.8521739130435, 0.075, 0.055555555555556
89932, 1.895652173913, 0.075, 0.44444444444444
89933, 1.895652173913, 0.075, 0.38888888888889
89934, 1.895652173913, 0.075, 0.33333333333333
89935, 1.895652173913, 0.075, 0.27777777777778
89936, 1.895652173913, 0.075, 0.22222222222222
89937, 1.895652173913, 0.075, 0.16666666666667
89938, 1.895652173913, 0.075, 0.11111111111111
89939, 1.895652173913, 0.075, 0.055555555555556
89940, 1.9391304347826, 0.075, 0.44444444444444
89941, 1.9391304347826, 0.075, 0.38888888888889
89942, 1.9391304347826, 0.075, 0.33333333333333
89943, 1.9391304347826, 0.075, 0.27777777777778
89944, 1.9391304347826, 0.075, 0.22222222222222
89945, 1.9391304347826, 0.075, 0.16666666666667
89946, 1.9391304347826, 0.075, 0.11111111111111
89947, 1.9391304347826, 0.075, 0.055555555555556
89948, 1.9826086956522, 0.075, 0.44444444444444
89949, 1.9826086956522, 0.075, 0.38888888888889
89950, 1.9826086956522, 0.075, 0.33333333333333
89951, 1.9826086956522, 0.075, 0.27777777777778
89952, 1.9826086956522, 0.075, 0.22222222222222
89953, 1.9826086956522, 0.075, 0.16666666666667
89954, 1.9826086956522, 0.075, 0.11111111111111
89955, 1.9826086956522, 0.075, 0.055555555555556
89956, 2.0260869565217, 0.075, 0.44444444444444
89957, 2.0260869565217, 0.075, 0.38888888888889
89958, 2.0260869565217, 0.075, 0.33333333333333
89959, 2.0260869565217, 0.075, 0.27777777777778
89960, 2.0260869565217, 0.075, 0.22222222222222
89961, 2.0260869565217, 0.075, 0.16666666666667
89962, 2.0260869565217, 0.075, 0.11111111111111
89963, 2.0260869565217, 0.075, 0.055555555555556
89964, 2.0695652173913, 0.075, 0.44444444444444
89965, 2.0695652173913, 0.075, 0.38888888888889
89966, 2.0695652173913, 0.075, 0.33333333333333
89967, 2.0695652173913, 0.075, 0.27777777777778
89968, 2.0695652173913, 0.075, 0.22222222222222
89969, 2.0695652173913, 0.075, 0.16666666666667
89970, 2.0695652173913, 0.075, 0.11111111111111
89971, 2.0695652173913, 0.075, 0.055555555555556
89972, 2.1130434782609, 0.075, 0.44444444444444
89973, 2.1130434782609, 0.075, 0.38888888888889
89974, 2.1130434782609, 0.075, 0.33333333333333
89975, 2.1130434782609, 0.075, 0.27777777777778
89976, 2.1130434782609, 0.075, 0.22222222222222
89977, 2.1130434782609, 0.075, 0.16666666666667
89978, 2.1130434782609, 0.075, 0.11111111111111
89979, 2.1130434782609, 0.075, 0.055555555555556
89980, 2.1565217391304, 0.075, 0.44444444444444
89981, 2.1565217391304, 0.075, 0.38888888888889
89982, 2.1565217391304, 0.075, 0.33333333333333
89983, 2.1565217391304, 0.075, 0.27777777777778
89984, 2.1565217391304, 0.075, 0.22222222222222
89985, 2.1565217391304, 0.075, 0.16666666666667
89986, 2.1565217391304, 0.075, 0.11111111111111
89987, 2.1565217391304, 0.075, 0.055555555555556
89988, 1.2434782608696, 0.075, 0.47222222222222
89989, 1.2217391304348, 0.075, 0.44444444444444
89990, 1.2434782608696, 0.0625, 0.44444444444444
89991, 1.2434782608696, 0.075, 0.41666666666667
89992, 1.2217391304348, 0.075, 0.38888888888889
89993, 1.2434782608696, 0.0625, 0.38888888888889
89994, 1.2434782608696, 0.075, 0.36111111111111
89995, 1.2217391304348, 0.075, 0.33333333333333
89996, 1.2434782608696, 0.0625, 0.33333333333333
89997, 1.2434782608696, 0.075, 0.30555555555556
89998, 1.2217391304348, 0.075, 0.27777777777778
89999, 1.2434782608696, 0.0625, 0.27777777777778
90000, 1.2434782608696, 0.075, 0.25
90001, 1.2217391304348, 0.075, 0.22222222222222
90002, 1.2434782608696, 0.0625, 0.22222222222222
90003, 1.2434782608696, 0.075, 0.19444444444444
90004, 1.2217391304348, 0.075, 0.16666666666667
90005, 1.2434782608696, 0.0625, 0.16666666666667
90006, 1.2434782608696, 0.075, 0.13888888888889
90007, 1.2217391304348, 0.075, 0.11111111111111
90008, 1.2434782608696, 0.0625, 0.11111111111111
90009, 1.2434782608696, 0.075, 0.083333333333333
90010, 1.2217391304348, 0.075, 0.055555555555556
90011, 1.2434782608696, 0.0625, 0.055555555555556
90012, 1.2434782608696, 0.075, 0.027777777777778
90013, 1.2869565217391, 0.075, 0.47222222222222
90014, 1.2652173913043, 0.075, 0.44444444444444
90015, 1.2869565217391, 0.0625, 0.44444444444444
90016, 1.2869565217391, 0.075, 0.41666666666667
90017, 1.2652173913043, 0.075, 0.38888888888889
90018, 1.2869565217391, 0.0625, 0.38888888888889
90019, 1.2869565217391, 0.075, 0.36111111111111
90020, 1.2652173913043, 0.075, 0.33333333333333
90021, 1.2869565217391, 0.0625, 0.33333333333333
90022, 1.2869565217391, 0.075, 0.30555555555556
90023, 1.2652173913043, 0.075, 0.27777777777778
90024, 1.2869565217391, 0.0625, 0.27777777777778
90025, 1.2869565217391, 0.075, 0.25
90026, 1.2652173913043, 0.075, 0.22222222222222
90027, 1.2869565217391, 0.0625, 0.22222222222222
90028, 1.2869565217391, 0.075, 0.19444444444444
90029, 1.2652173913043, 0.075, 0.16666666666667
90030, 1.2869565217391, 0.0625, 0.16666666666667
90031, 1.2869565217391, 0.075, 0.13888888888889
90032, 1.2652173913043, 0.075, 0.11111111111111
90033, 1.2869565217391, 0.0625, 0.11111111111111
90034, 1.2869565217391, 0.075, 0.083333333333333
90035, 1.2652173913043, 0.075, 0.055555555555556
90036, 1.2869565217391, 0.0625, 0.055555555555556
90037, 1.2869565217391, 0.075, 0.027777777777778
90038, 1.3304347826087, 0.075, 0.47222222222222
90039, 1.3086956521739, 0.075, 0.44444444444444
90040, 1.3304347826087, 0.0625, 0.44444444444444
90041, 1.3304347826087, 0.075, 0.41666666666667
90042, 1.3086956521739, 0.075, 0.38888888888889
90043, 1.3304347826087, 0.0625, 0.38888888888889
90044, 1.3304347826087, 0.075, 0.36111111111111
90045, 1.3086956521739, 0.075, 0.33333333333333
90046, 1.3304347826087, 0.0625, 0.33333333333333
90047, 1.3304347826087, 0.075, 0.30555555555556
90048, 1.3086956521739, 0.075, 0.27777777777778
90049, 1.3304347826087, 0.0625, 0.27777777777778
90050, 1.3304347826087, 0.075, 0.25
90051, 1.3086956521739, 0.075, 0.22222222222222
90052, 1.3304347826087, 0.0625, 0.22222222222222
90053, 1.3304347826087, 0.075, 0.19444444444444
90054, 1.3086956521739, 0.075, 0.16666666666667
90055, 1.3304347826087, 0.0625, 0.16666666666667
90056, 1.3304347826087, 0.075, 0.13888888888889
90057, 1.3086956521739, 0.075, 0.11111111111111
90058, 1.3304347826087, 0.0625, 0.11111111111111
90059, 1.3304347826087, 0.075, 0.083333333333333
90060, 1.3086956521739, 0.075, 0.055555555555556
90061, 1.3304347826087, 0.0625, 0.055555555555556
90062, 1.3304347826087, 0.075, 0.027777777777778
90063, 1.3739130434783, 0.075, 0.47222222222222
90064, 1.3521739130435, 0.075, 0.44444444444444
90065, 1.3739130434783, 0.0625, 0.44444444444444
90066, 1.3739130434783, 0.075, 0.41666666666667
90067, 1.3521739130435, 0.075, 0.38888888888889
90068, 1.3739130434783, 0.0625, 0.38888888888889
90069, 1.3739130434783, 0.075, 0.36111111111111
90070, 1.3521739130435, 0.075, 0.33333333333333
90071, 1.3739130434783, 0.0625, 0.33333333333333
90072, 1.3739130434783, 0.075, 0.30555555555556
90073, 1.3521739130435, 0.075, 0.27777777777778
90074, 1.3739130434783, 0.0625, 0.27777777777778
90075, 1.3739130434783, 0.075, 0.25
90076, 1.3521739130435, 0.075, 0.22222222222222
90077, 1.3739130434783, 0.0625, 0.22222222222222
90078, 1.3739130434783, 0.075, 0.19444444444444
90079, 1.3521739130435, 0.075, 0.16666666666667
90080, 1.3739130434783, 0.0625, 0.16666666666667
90081, 1.3739130434783, 0.075, 0.13888888888889
90082, 1.3521739130435, 0.075, 0.11111111111111
90083, 1.3739130434783, 0.0625, 0.11111111111111
