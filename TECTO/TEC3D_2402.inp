41042, 0.73913043478261, 0.98478260869565, 0.27777777777778
41043, 0.73913043478261, 0.98478260869565, 0.33333333333333
41044, 0.73913043478261, 0.98478260869565, 0.38888888888889
41045, 0.73913043478261, 0.98478260869565, 0.44444444444444
41046, 0.69565217391304, 0.98478260869565, 0.055555555555556
41047, 0.69565217391304, 0.98478260869565, 0.11111111111111
41048, 0.69565217391304, 0.98478260869565, 0.16666666666667
41049, 0.69565217391304, 0.98478260869565, 0.22222222222222
41050, 0.69565217391304, 0.98478260869565, 0.27777777777778
41051, 0.69565217391304, 0.98478260869565, 0.33333333333333
41052, 0.69565217391304, 0.98478260869565, 0.38888888888889
41053, 0.69565217391304, 0.98478260869565, 0.44444444444444
41054, 0.65217391304348, 0.98478260869565, 0.055555555555556
41055, 0.65217391304348, 0.98478260869565, 0.11111111111111
41056, 0.65217391304348, 0.98478260869565, 0.16666666666667
41057, 0.65217391304348, 0.98478260869565, 0.22222222222222
41058, 0.65217391304348, 0.98478260869565, 0.27777777777778
41059, 0.65217391304348, 0.98478260869565, 0.33333333333333
41060, 0.65217391304348, 0.98478260869565, 0.38888888888889
41061, 0.65217391304348, 0.98478260869565, 0.44444444444444
41062, 0.60869565217391, 0.98478260869565, 0.055555555555556
41063, 0.60869565217391, 0.98478260869565, 0.11111111111111
41064, 0.60869565217391, 0.98478260869565, 0.16666666666667
41065, 0.60869565217391, 0.98478260869565, 0.22222222222222
41066, 0.60869565217391, 0.98478260869565, 0.27777777777778
41067, 0.60869565217391, 0.98478260869565, 0.33333333333333
41068, 0.60869565217391, 0.98478260869565, 0.38888888888889
41069, 0.60869565217391, 0.98478260869565, 0.44444444444444
41070, 0.56521739130435, 0.98478260869565, 0.055555555555556
41071, 0.56521739130435, 0.98478260869565, 0.11111111111111
41072, 0.56521739130435, 0.98478260869565, 0.16666666666667
41073, 0.56521739130435, 0.98478260869565, 0.22222222222222
41074, 0.56521739130435, 0.98478260869565, 0.27777777777778
41075, 0.56521739130435, 0.98478260869565, 0.33333333333333
41076, 0.56521739130435, 0.98478260869565, 0.38888888888889
41077, 0.56521739130435, 0.98478260869565, 0.44444444444444
41078, 0.52173913043478, 0.98478260869565, 0.055555555555556
41079, 0.52173913043478, 0.98478260869565, 0.11111111111111
41080, 0.52173913043478, 0.98478260869565, 0.16666666666667
41081, 0.52173913043478, 0.98478260869565, 0.22222222222222
41082, 0.52173913043478, 0.98478260869565, 0.27777777777778
41083, 0.52173913043478, 0.98478260869565, 0.33333333333333
41084, 0.52173913043478, 0.98478260869565, 0.38888888888889
41085, 0.52173913043478, 0.98478260869565, 0.44444444444444
41086, 0.47826086956522, 0.98478260869565, 0.055555555555556
41087, 0.47826086956522, 0.98478260869565, 0.11111111111111
41088, 0.47826086956522, 0.98478260869565, 0.16666666666667
41089, 0.47826086956522, 0.98478260869565, 0.22222222222222
41090, 0.47826086956522, 0.98478260869565, 0.27777777777778
41091, 0.47826086956522, 0.98478260869565, 0.33333333333333
41092, 0.47826086956522, 0.98478260869565, 0.38888888888889
41093, 0.47826086956522, 0.98478260869565, 0.44444444444444
41094, 0.43478260869565, 0.98478260869565, 0.055555555555556
41095, 0.43478260869565, 0.98478260869565, 0.11111111111111
41096, 0.43478260869565, 0.98478260869565, 0.16666666666667
41097, 0.43478260869565, 0.98478260869565, 0.22222222222222
41098, 0.43478260869565, 0.98478260869565, 0.27777777777778
41099, 0.43478260869565, 0.98478260869565, 0.33333333333333
41100, 0.43478260869565, 0.98478260869565, 0.38888888888889
41101, 0.43478260869565, 0.98478260869565, 0.44444444444444
41102, 0.39130434782609, 0.98478260869565, 0.055555555555556
41103, 0.39130434782609, 0.98478260869565, 0.11111111111111
41104, 0.39130434782609, 0.98478260869565, 0.16666666666667
41105, 0.39130434782609, 0.98478260869565, 0.22222222222222
41106, 0.39130434782609, 0.98478260869565, 0.27777777777778
41107, 0.39130434782609, 0.98478260869565, 0.33333333333333
41108, 0.39130434782609, 0.98478260869565, 0.38888888888889
41109, 0.39130434782609, 0.98478260869565, 0.44444444444444
41110, 0.34782608695652, 0.98478260869565, 0.055555555555556
41111, 0.34782608695652, 0.98478260869565, 0.11111111111111
41112, 0.34782608695652, 0.98478260869565, 0.16666666666667
41113, 0.34782608695652, 0.98478260869565, 0.22222222222222
41114, 0.34782608695652, 0.98478260869565, 0.27777777777778
41115, 0.34782608695652, 0.98478260869565, 0.33333333333333
41116, 0.34782608695652, 0.98478260869565, 0.38888888888889
41117, 0.34782608695652, 0.98478260869565, 0.44444444444444
41118, 0.30434782608696, 0.98478260869565, 0.055555555555556
41119, 0.30434782608696, 0.98478260869565, 0.11111111111111
41120, 0.30434782608696, 0.98478260869565, 0.16666666666667
41121, 0.30434782608696, 0.98478260869565, 0.22222222222222
41122, 0.30434782608696, 0.98478260869565, 0.27777777777778
41123, 0.30434782608696, 0.98478260869565, 0.33333333333333
41124, 0.30434782608696, 0.98478260869565, 0.38888888888889
41125, 0.30434782608696, 0.98478260869565, 0.44444444444444
41126, 0.26086956521739, 0.98478260869565, 0.055555555555556
41127, 0.26086956521739, 0.98478260869565, 0.11111111111111
41128, 0.26086956521739, 0.98478260869565, 0.16666666666667
41129, 0.26086956521739, 0.98478260869565, 0.22222222222222
41130, 0.26086956521739, 0.98478260869565, 0.27777777777778
41131, 0.26086956521739, 0.98478260869565, 0.33333333333333
41132, 0.26086956521739, 0.98478260869565, 0.38888888888889
41133, 0.26086956521739, 0.98478260869565, 0.44444444444444
41134, 0.21739130434783, 0.98478260869565, 0.055555555555556
41135, 0.21739130434783, 0.98478260869565, 0.11111111111111
41136, 0.21739130434783, 0.98478260869565, 0.16666666666667
41137, 0.21739130434783, 0.98478260869565, 0.22222222222222
41138, 0.21739130434783, 0.98478260869565, 0.27777777777778
41139, 0.21739130434783, 0.98478260869565, 0.33333333333333
41140, 0.21739130434783, 0.98478260869565, 0.38888888888889
41141, 0.21739130434783, 0.98478260869565, 0.44444444444444
41142, 0.17391304347826, 0.98478260869565, 0.055555555555556
41143, 0.17391304347826, 0.98478260869565, 0.11111111111111
41144, 0.17391304347826, 0.98478260869565, 0.16666666666667
41145, 0.17391304347826, 0.98478260869565, 0.22222222222222
41146, 0.17391304347826, 0.98478260869565, 0.27777777777778
41147, 0.17391304347826, 0.98478260869565, 0.33333333333333
41148, 0.17391304347826, 0.98478260869565, 0.38888888888889
41149, 0.17391304347826, 0.98478260869565, 0.44444444444444
41150, 0.1304347826087, 0.98478260869565, 0.055555555555556
41151, 0.1304347826087, 0.98478260869565, 0.11111111111111
41152, 0.1304347826087, 0.98478260869565, 0.16666666666667
41153, 0.1304347826087, 0.98478260869565, 0.22222222222222
41154, 0.1304347826087, 0.98478260869565, 0.27777777777778
41155, 0.1304347826087, 0.98478260869565, 0.33333333333333
41156, 0.1304347826087, 0.98478260869565, 0.38888888888889
41157, 0.1304347826087, 0.98478260869565, 0.44444444444444
41158, 0.08695652173913, 0.98478260869565, 0.055555555555556
41159, 0.08695652173913, 0.98478260869565, 0.11111111111111
41160, 0.08695652173913, 0.98478260869565, 0.16666666666667
41161, 0.08695652173913, 0.98478260869565, 0.22222222222222
41162, 0.08695652173913, 0.98478260869565, 0.27777777777778
41163, 0.08695652173913, 0.98478260869565, 0.33333333333333
41164, 0.08695652173913, 0.98478260869565, 0.38888888888889
41165, 0.08695652173913, 0.98478260869565, 0.44444444444444
41166, 0.043478260869565, 0.98478260869565, 0.055555555555556
41167, 0.043478260869565, 0.98478260869565, 0.11111111111111
41168, 0.043478260869565, 0.98478260869565, 0.16666666666667
41169, 0.043478260869565, 0.98478260869565, 0.22222222222222
41170, 0.043478260869565, 0.98478260869565, 0.27777777777778
41171, 0.043478260869565, 0.98478260869565, 0.33333333333333
41172, 0.043478260869565, 0.98478260869565, 0.38888888888889
41173, 0.043478260869565, 0.98478260869565, 0.44444444444444
41174, 0.95652173913043, 1.0369565217391, 0.055555555555556
41175, 0.95652173913044, 1.0369565217391, 0.11111111111111
41176, 0.95652173913044, 1.0369565217391, 0.16666666666667
41177, 0.95652173913044, 1.0369565217391, 0.22222222222222
41178, 0.95652173913044, 1.0369565217391, 0.27777777777778
41179, 0.95652173913044, 1.0369565217391, 0.33333333333333
41180, 0.95652173913044, 1.0369565217391, 0.38888888888889
41181, 0.95652173913044, 1.0369565217391, 0.44444444444444
41182, 0.91304347826087, 1.0369565217391, 0.055555555555556
41183, 0.91304347826087, 1.0369565217391, 0.11111111111111
41184, 0.91304347826087, 1.0369565217391, 0.16666666666667
41185, 0.91304347826087, 1.0369565217391, 0.22222222222222
41186, 0.91304347826087, 1.0369565217391, 0.27777777777778
41187, 0.91304347826087, 1.0369565217391, 0.33333333333333
41188, 0.91304347826087, 1.0369565217391, 0.38888888888889
41189, 0.91304347826087, 1.0369565217391, 0.44444444444444
41190, 0.8695652173913, 1.0369565217391, 0.055555555555556
41191, 0.8695652173913, 1.0369565217391, 0.11111111111111
41192, 0.8695652173913, 1.0369565217391, 0.16666666666667
41193, 0.8695652173913, 1.0369565217391, 0.22222222222222
41194, 0.8695652173913, 1.0369565217391, 0.27777777777778
41195, 0.8695652173913, 1.0369565217391, 0.33333333333333
41196, 0.8695652173913, 1.0369565217391, 0.38888888888889
41197, 0.8695652173913, 1.0369565217391, 0.44444444444444
41198, 0.82608695652174, 1.0369565217391, 0.055555555555556
41199, 0.82608695652174, 1.0369565217391, 0.11111111111111
41200, 0.82608695652174, 1.0369565217391, 0.16666666666667
41201, 0.82608695652174, 1.0369565217391, 0.22222222222222
41202, 0.82608695652174, 1.0369565217391, 0.27777777777778
41203, 0.82608695652174, 1.0369565217391, 0.33333333333333
41204, 0.82608695652174, 1.0369565217391, 0.38888888888889
41205, 0.82608695652174, 1.0369565217391, 0.44444444444444
41206, 0.78260869565217, 1.0369565217391, 0.055555555555556
41207, 0.78260869565217, 1.0369565217391, 0.11111111111111
41208, 0.78260869565217, 1.0369565217391, 0.16666666666667
41209, 0.78260869565217, 1.0369565217391, 0.22222222222222
41210, 0.78260869565217, 1.0369565217391, 0.27777777777778
41211, 0.78260869565217, 1.0369565217391, 0.33333333333333
41212, 0.78260869565217, 1.0369565217391, 0.38888888888889
41213, 0.78260869565217, 1.0369565217391, 0.44444444444444
41214, 0.73913043478261, 1.0369565217391, 0.055555555555556
41215, 0.73913043478261, 1.0369565217391, 0.11111111111111
41216, 0.73913043478261, 1.0369565217391, 0.16666666666667
41217, 0.73913043478261, 1.0369565217391, 0.22222222222222
41218, 0.73913043478261, 1.0369565217391, 0.27777777777778
41219, 0.73913043478261, 1.0369565217391, 0.33333333333333
41220, 0.73913043478261, 1.0369565217391, 0.38888888888889
41221, 0.73913043478261, 1.0369565217391, 0.44444444444444
41222, 0.69565217391304, 1.0369565217391, 0.055555555555556
41223, 0.69565217391304, 1.0369565217391, 0.11111111111111
41224, 0.69565217391304, 1.0369565217391, 0.16666666666667
41225, 0.69565217391304, 1.0369565217391, 0.22222222222222
41226, 0.69565217391304, 1.0369565217391, 0.27777777777778
41227, 0.69565217391304, 1.0369565217391, 0.33333333333333
41228, 0.69565217391304, 1.0369565217391, 0.38888888888889
41229, 0.69565217391304, 1.0369565217391, 0.44444444444444
41230, 0.65217391304348, 1.0369565217391, 0.055555555555556
41231, 0.65217391304348, 1.0369565217391, 0.11111111111111
41232, 0.65217391304348, 1.0369565217391, 0.16666666666667
41233, 0.65217391304348, 1.0369565217391, 0.22222222222222
41234, 0.65217391304348, 1.0369565217391, 0.27777777777778
41235, 0.65217391304348, 1.0369565217391, 0.33333333333333
41236, 0.65217391304348, 1.0369565217391, 0.38888888888889
41237, 0.65217391304348, 1.0369565217391, 0.44444444444444
41238, 0.60869565217391, 1.0369565217391, 0.055555555555556
41239, 0.60869565217391, 1.0369565217391, 0.11111111111111
41240, 0.60869565217391, 1.0369565217391, 0.16666666666667
41241, 0.60869565217391, 1.0369565217391, 0.22222222222222
41242, 0.60869565217391, 1.0369565217391, 0.27777777777778
41243, 0.60869565217391, 1.0369565217391, 0.33333333333333
41244, 0.60869565217391, 1.0369565217391, 0.38888888888889
41245, 0.60869565217391, 1.0369565217391, 0.44444444444444
41246, 0.56521739130435, 1.0369565217391, 0.055555555555556
41247, 0.56521739130435, 1.0369565217391, 0.11111111111111
41248, 0.56521739130435, 1.0369565217391, 0.16666666666667
41249, 0.56521739130435, 1.0369565217391, 0.22222222222222
41250, 0.56521739130435, 1.0369565217391, 0.27777777777778
41251, 0.56521739130435, 1.0369565217391, 0.33333333333333
41252, 0.56521739130435, 1.0369565217391, 0.38888888888889
41253, 0.56521739130435, 1.0369565217391, 0.44444444444444
41254, 0.52173913043478, 1.0369565217391, 0.055555555555556
41255, 0.52173913043478, 1.0369565217391, 0.11111111111111
41256, 0.52173913043478, 1.0369565217391, 0.16666666666667
41257, 0.52173913043478, 1.0369565217391, 0.22222222222222
41258, 0.52173913043478, 1.0369565217391, 0.27777777777778
41259, 0.52173913043478, 1.0369565217391, 0.33333333333333
41260, 0.52173913043478, 1.0369565217391, 0.38888888888889
41261, 0.52173913043478, 1.0369565217391, 0.44444444444444
41262, 0.47826086956522, 1.0369565217391, 0.055555555555556
41263, 0.47826086956522, 1.0369565217391, 0.11111111111111
41264, 0.47826086956522, 1.0369565217391, 0.16666666666667
41265, 0.47826086956522, 1.0369565217391, 0.22222222222222
41266, 0.47826086956522, 1.0369565217391, 0.27777777777778
41267, 0.47826086956522, 1.0369565217391, 0.33333333333333
41268, 0.47826086956522, 1.0369565217391, 0.38888888888889
41269, 0.47826086956522, 1.0369565217391, 0.44444444444444
41270, 0.43478260869565, 1.0369565217391, 0.055555555555556
41271, 0.43478260869565, 1.0369565217391, 0.11111111111111
41272, 0.43478260869565, 1.0369565217391, 0.16666666666667
41273, 0.43478260869565, 1.0369565217391, 0.22222222222222
41274, 0.43478260869565, 1.0369565217391, 0.27777777777778
41275, 0.43478260869565, 1.0369565217391, 0.33333333333333
41276, 0.43478260869565, 1.0369565217391, 0.38888888888889
41277, 0.43478260869565, 1.0369565217391, 0.44444444444444
41278, 0.39130434782609, 1.0369565217391, 0.055555555555556
41279, 0.39130434782609, 1.0369565217391, 0.11111111111111
41280, 0.39130434782609, 1.0369565217391, 0.16666666666667
41281, 0.39130434782609, 1.0369565217391, 0.22222222222222
41282, 0.39130434782609, 1.0369565217391, 0.27777777777778
41283, 0.39130434782609, 1.0369565217391, 0.33333333333333
41284, 0.39130434782609, 1.0369565217391, 0.38888888888889
41285, 0.39130434782609, 1.0369565217391, 0.44444444444444
41286, 0.34782608695652, 1.0369565217391, 0.055555555555556
41287, 0.34782608695652, 1.0369565217391, 0.11111111111111
41288, 0.34782608695652, 1.0369565217391, 0.16666666666667
41289, 0.34782608695652, 1.0369565217391, 0.22222222222222
41290, 0.34782608695652, 1.0369565217391, 0.27777777777778
41291, 0.34782608695652, 1.0369565217391, 0.33333333333333
41292, 0.34782608695652, 1.0369565217391, 0.38888888888889
41293, 0.34782608695652, 1.0369565217391, 0.44444444444444
41294, 0.30434782608696, 1.0369565217391, 0.055555555555556
41295, 0.30434782608696, 1.0369565217391, 0.11111111111111
41296, 0.30434782608696, 1.0369565217391, 0.16666666666667
41297, 0.30434782608696, 1.0369565217391, 0.22222222222222
41298, 0.30434782608696, 1.0369565217391, 0.27777777777778
41299, 0.30434782608696, 1.0369565217391, 0.33333333333333
41300, 0.30434782608696, 1.0369565217391, 0.38888888888889
41301, 0.30434782608696, 1.0369565217391, 0.44444444444444
41302, 0.26086956521739, 1.0369565217391, 0.055555555555556
41303, 0.26086956521739, 1.0369565217391, 0.11111111111111
41304, 0.26086956521739, 1.0369565217391, 0.16666666666667
41305, 0.26086956521739, 1.0369565217391, 0.22222222222222
41306, 0.26086956521739, 1.0369565217391, 0.27777777777778
41307, 0.26086956521739, 1.0369565217391, 0.33333333333333
41308, 0.26086956521739, 1.0369565217391, 0.38888888888889
41309, 0.26086956521739, 1.0369565217391, 0.44444444444444
41310, 0.21739130434783, 1.0369565217391, 0.055555555555556
41311, 0.21739130434783, 1.0369565217391, 0.11111111111111
41312, 0.21739130434783, 1.0369565217391, 0.16666666666667
41313, 0.21739130434783, 1.0369565217391, 0.22222222222222
41314, 0.21739130434783, 1.0369565217391, 0.27777777777778
41315, 0.21739130434783, 1.0369565217391, 0.33333333333333
41316, 0.21739130434783, 1.0369565217391, 0.38888888888889
41317, 0.21739130434783, 1.0369565217391, 0.44444444444444
41318, 0.17391304347826, 1.0369565217391, 0.055555555555556
41319, 0.17391304347826, 1.0369565217391, 0.11111111111111
41320, 0.17391304347826, 1.0369565217391, 0.16666666666667
41321, 0.17391304347826, 1.0369565217391, 0.22222222222222
41322, 0.17391304347826, 1.0369565217391, 0.27777777777778
41323, 0.17391304347826, 1.0369565217391, 0.33333333333333
41324, 0.17391304347826, 1.0369565217391, 0.38888888888889
41325, 0.17391304347826, 1.0369565217391, 0.44444444444444
41326, 0.1304347826087, 1.0369565217391, 0.055555555555556
41327, 0.1304347826087, 1.0369565217391, 0.11111111111111
41328, 0.1304347826087, 1.0369565217391, 0.16666666666667
41329, 0.1304347826087, 1.0369565217391, 0.22222222222222
41330, 0.1304347826087, 1.0369565217391, 0.27777777777778
41331, 0.1304347826087, 1.0369565217391, 0.33333333333333
41332, 0.1304347826087, 1.0369565217391, 0.38888888888889
41333, 0.1304347826087, 1.0369565217391, 0.44444444444444
41334, 0.08695652173913, 1.0369565217391, 0.055555555555556
41335, 0.08695652173913, 1.0369565217391, 0.11111111111111
41336, 0.08695652173913, 1.0369565217391, 0.16666666666667
41337, 0.08695652173913, 1.0369565217391, 0.22222222222222
41338, 0.08695652173913, 1.0369565217391, 0.27777777777778
41339, 0.08695652173913, 1.0369565217391, 0.33333333333333
41340, 0.08695652173913, 1.0369565217391, 0.38888888888889
41341, 0.08695652173913, 1.0369565217391, 0.44444444444444
41342, 0.043478260869565, 1.0369565217391, 0.055555555555556
41343, 0.043478260869565, 1.0369565217391, 0.11111111111111
41344, 0.043478260869565, 1.0369565217391, 0.16666666666667
41345, 0.043478260869565, 1.0369565217391, 0.22222222222222
41346, 0.043478260869565, 1.0369565217391, 0.27777777777778
41347, 0.043478260869565, 1.0369565217391, 0.33333333333333
41348, 0.043478260869565, 1.0369565217391, 0.38888888888889
41349, 0.043478260869565, 1.0369565217391, 0.44444444444444
41350, 0.95652173913043, 1.0891304347826, 0.055555555555556
41351, 0.95652173913043, 1.0891304347826, 0.11111111111111
41352, 0.95652173913043, 1.0891304347826, 0.16666666666667
41353, 0.95652173913043, 1.0891304347826, 0.22222222222222
41354, 0.95652173913044, 1.0891304347826, 0.27777777777778
41355, 0.95652173913044, 1.0891304347826, 0.33333333333333
41356, 0.95652173913043, 1.0891304347826, 0.38888888888889
41357, 0.95652173913044, 1.0891304347826, 0.44444444444444
41358, 0.91304347826087, 1.0891304347826, 0.055555555555556
41359, 0.91304347826087, 1.0891304347826, 0.11111111111111
41360, 0.91304347826087, 1.0891304347826, 0.16666666666667
41361, 0.91304347826087, 1.0891304347826, 0.22222222222222
41362, 0.91304347826087, 1.0891304347826, 0.27777777777778
41363, 0.91304347826087, 1.0891304347826, 0.33333333333333
41364, 0.91304347826087, 1.0891304347826, 0.38888888888889
41365, 0.91304347826087, 1.0891304347826, 0.44444444444444
41366, 0.8695652173913, 1.0891304347826, 0.055555555555556
41367, 0.8695652173913, 1.0891304347826, 0.11111111111111
41368, 0.8695652173913, 1.0891304347826, 0.16666666666667
41369, 0.8695652173913, 1.0891304347826, 0.22222222222222
41370, 0.8695652173913, 1.0891304347826, 0.27777777777778
41371, 0.8695652173913, 1.0891304347826, 0.33333333333333
41372, 0.8695652173913, 1.0891304347826, 0.38888888888889
41373, 0.8695652173913, 1.0891304347826, 0.44444444444444
41374, 0.82608695652174, 1.0891304347826, 0.055555555555556
41375, 0.82608695652174, 1.0891304347826, 0.11111111111111
41376, 0.82608695652174, 1.0891304347826, 0.16666666666667
41377, 0.82608695652174, 1.0891304347826, 0.22222222222222
41378, 0.82608695652174, 1.0891304347826, 0.27777777777778
41379, 0.82608695652174, 1.0891304347826, 0.33333333333333
41380, 0.82608695652174, 1.0891304347826, 0.38888888888889
41381, 0.82608695652174, 1.0891304347826, 0.44444444444444
41382, 0.78260869565217, 1.0891304347826, 0.055555555555556
41383, 0.78260869565217, 1.0891304347826, 0.11111111111111
41384, 0.78260869565217, 1.0891304347826, 0.16666666666667
41385, 0.78260869565217, 1.0891304347826, 0.22222222222222
41386, 0.78260869565217, 1.0891304347826, 0.27777777777778
41387, 0.78260869565217, 1.0891304347826, 0.33333333333333
41388, 0.78260869565217, 1.0891304347826, 0.38888888888889
41389, 0.78260869565217, 1.0891304347826, 0.44444444444444
41390, 0.73913043478261, 1.0891304347826, 0.055555555555556
41391, 0.73913043478261, 1.0891304347826, 0.11111111111111
41392, 0.73913043478261, 1.0891304347826, 0.16666666666667
41393, 0.73913043478261, 1.0891304347826, 0.22222222222222
41394, 0.73913043478261, 1.0891304347826, 0.27777777777778
41395, 0.73913043478261, 1.0891304347826, 0.33333333333333
41396, 0.73913043478261, 1.0891304347826, 0.38888888888889
41397, 0.73913043478261, 1.0891304347826, 0.44444444444444
41398, 0.69565217391304, 1.0891304347826, 0.055555555555556
41399, 0.69565217391304, 1.0891304347826, 0.11111111111111
41400, 0.69565217391304, 1.0891304347826, 0.16666666666667
41401, 0.69565217391304, 1.0891304347826, 0.22222222222222
41402, 0.69565217391304, 1.0891304347826, 0.27777777777778
41403, 0.69565217391304, 1.0891304347826, 0.33333333333333
41404, 0.69565217391304, 1.0891304347826, 0.38888888888889
41405, 0.69565217391304, 1.0891304347826, 0.44444444444444
41406, 0.65217391304348, 1.0891304347826, 0.055555555555556
41407, 0.65217391304348, 1.0891304347826, 0.11111111111111
41408, 0.65217391304348, 1.0891304347826, 0.16666666666667
41409, 0.65217391304348, 1.0891304347826, 0.22222222222222
41410, 0.65217391304348, 1.0891304347826, 0.27777777777778
41411, 0.65217391304348, 1.0891304347826, 0.33333333333333
41412, 0.65217391304348, 1.0891304347826, 0.38888888888889
41413, 0.65217391304348, 1.0891304347826, 0.44444444444444
41414, 0.60869565217391, 1.0891304347826, 0.055555555555556
41415, 0.60869565217391, 1.0891304347826, 0.11111111111111
41416, 0.60869565217391, 1.0891304347826, 0.16666666666667
41417, 0.60869565217391, 1.0891304347826, 0.22222222222222
41418, 0.60869565217391, 1.0891304347826, 0.27777777777778
41419, 0.60869565217391, 1.0891304347826, 0.33333333333333
41420, 0.60869565217391, 1.0891304347826, 0.38888888888889
41421, 0.60869565217391, 1.0891304347826, 0.44444444444444
41422, 0.56521739130435, 1.0891304347826, 0.055555555555556
41423, 0.56521739130435, 1.0891304347826, 0.11111111111111
41424, 0.56521739130435, 1.0891304347826, 0.16666666666667
41425, 0.56521739130435, 1.0891304347826, 0.22222222222222
41426, 0.56521739130435, 1.0891304347826, 0.27777777777778
41427, 0.56521739130435, 1.0891304347826, 0.33333333333333
41428, 0.56521739130435, 1.0891304347826, 0.38888888888889
41429, 0.56521739130435, 1.0891304347826, 0.44444444444444
41430, 0.52173913043478, 1.0891304347826, 0.055555555555556
41431, 0.52173913043478, 1.0891304347826, 0.11111111111111
41432, 0.52173913043478, 1.0891304347826, 0.16666666666667
41433, 0.52173913043478, 1.0891304347826, 0.22222222222222
41434, 0.52173913043478, 1.0891304347826, 0.27777777777778
41435, 0.52173913043478, 1.0891304347826, 0.33333333333333
41436, 0.52173913043478, 1.0891304347826, 0.38888888888889
41437, 0.52173913043478, 1.0891304347826, 0.44444444444444
41438, 0.47826086956522, 1.0891304347826, 0.055555555555556
41439, 0.47826086956522, 1.0891304347826, 0.11111111111111
41440, 0.47826086956522, 1.0891304347826, 0.16666666666667
41441, 0.47826086956522, 1.0891304347826, 0.22222222222222
41442, 0.47826086956522, 1.0891304347826, 0.27777777777778
41443, 0.47826086956522, 1.0891304347826, 0.33333333333333
41444, 0.47826086956522, 1.0891304347826, 0.38888888888889
41445, 0.47826086956522, 1.0891304347826, 0.44444444444444
41446, 0.43478260869565, 1.0891304347826, 0.055555555555556
41447, 0.43478260869565, 1.0891304347826, 0.11111111111111
41448, 0.43478260869565, 1.0891304347826, 0.16666666666667
41449, 0.43478260869565, 1.0891304347826, 0.22222222222222
41450, 0.43478260869565, 1.0891304347826, 0.27777777777778
41451, 0.43478260869565, 1.0891304347826, 0.33333333333333
41452, 0.43478260869565, 1.0891304347826, 0.38888888888889
41453, 0.43478260869565, 1.0891304347826, 0.44444444444444
41454, 0.39130434782609, 1.0891304347826, 0.055555555555556
41455, 0.39130434782609, 1.0891304347826, 0.11111111111111
41456, 0.39130434782609, 1.0891304347826, 0.16666666666667
41457, 0.39130434782609, 1.0891304347826, 0.22222222222222
41458, 0.39130434782609, 1.0891304347826, 0.27777777777778
41459, 0.39130434782609, 1.0891304347826, 0.33333333333333
41460, 0.39130434782609, 1.0891304347826, 0.38888888888889
41461, 0.39130434782609, 1.0891304347826, 0.44444444444444
41462, 0.34782608695652, 1.0891304347826, 0.055555555555556
41463, 0.34782608695652, 1.0891304347826, 0.11111111111111
41464, 0.34782608695652, 1.0891304347826, 0.16666666666667
41465, 0.34782608695652, 1.0891304347826, 0.22222222222222
41466, 0.34782608695652, 1.0891304347826, 0.27777777777778
41467, 0.34782608695652, 1.0891304347826, 0.33333333333333
41468, 0.34782608695652, 1.0891304347826, 0.38888888888889
41469, 0.34782608695652, 1.0891304347826, 0.44444444444444
41470, 0.30434782608696, 1.0891304347826, 0.055555555555556
41471, 0.30434782608696, 1.0891304347826, 0.11111111111111
41472, 0.30434782608696, 1.0891304347826, 0.16666666666667
41473, 0.30434782608696, 1.0891304347826, 0.22222222222222
41474, 0.30434782608696, 1.0891304347826, 0.27777777777778
41475, 0.30434782608696, 1.0891304347826, 0.33333333333333
41476, 0.30434782608696, 1.0891304347826, 0.38888888888889
41477, 0.30434782608696, 1.0891304347826, 0.44444444444444
41478, 0.26086956521739, 1.0891304347826, 0.055555555555556
41479, 0.26086956521739, 1.0891304347826, 0.11111111111111
41480, 0.26086956521739, 1.0891304347826, 0.16666666666667
41481, 0.26086956521739, 1.0891304347826, 0.22222222222222
41482, 0.26086956521739, 1.0891304347826, 0.27777777777778
41483, 0.26086956521739, 1.0891304347826, 0.33333333333333
41484, 0.26086956521739, 1.0891304347826, 0.38888888888889
41485, 0.26086956521739, 1.0891304347826, 0.44444444444444
41486, 0.21739130434783, 1.0891304347826, 0.055555555555556
41487, 0.21739130434783, 1.0891304347826, 0.11111111111111
41488, 0.21739130434783, 1.0891304347826, 0.16666666666667
41489, 0.21739130434783, 1.0891304347826, 0.22222222222222
41490, 0.21739130434783, 1.0891304347826, 0.27777777777778
41491, 0.21739130434783, 1.0891304347826, 0.33333333333333
41492, 0.21739130434783, 1.0891304347826, 0.38888888888889
41493, 0.21739130434783, 1.0891304347826, 0.44444444444444
41494, 0.17391304347826, 1.0891304347826, 0.055555555555556
41495, 0.17391304347826, 1.0891304347826, 0.11111111111111
41496, 0.17391304347826, 1.0891304347826, 0.16666666666667
41497, 0.17391304347826, 1.0891304347826, 0.22222222222222
41498, 0.17391304347826, 1.0891304347826, 0.27777777777778
41499, 0.17391304347826, 1.0891304347826, 0.33333333333333
41500, 0.17391304347826, 1.0891304347826, 0.38888888888889
41501, 0.17391304347826, 1.0891304347826, 0.44444444444444
41502, 0.1304347826087, 1.0891304347826, 0.055555555555556
41503, 0.1304347826087, 1.0891304347826, 0.11111111111111
41504, 0.1304347826087, 1.0891304347826, 0.16666666666667
41505, 0.1304347826087, 1.0891304347826, 0.22222222222222
41506, 0.1304347826087, 1.0891304347826, 0.27777777777778
41507, 0.1304347826087, 1.0891304347826, 0.33333333333333
41508, 0.1304347826087, 1.0891304347826, 0.38888888888889
41509, 0.1304347826087, 1.0891304347826, 0.44444444444444
41510, 0.08695652173913, 1.0891304347826, 0.055555555555556
41511, 0.08695652173913, 1.0891304347826, 0.11111111111111
41512, 0.08695652173913, 1.0891304347826, 0.16666666666667
41513, 0.08695652173913, 1.0891304347826, 0.22222222222222
41514, 0.08695652173913, 1.0891304347826, 0.27777777777778
41515, 0.08695652173913, 1.0891304347826, 0.33333333333333
41516, 0.08695652173913, 1.0891304347826, 0.38888888888889
41517, 0.08695652173913, 1.0891304347826, 0.44444444444444
41518, 0.043478260869565, 1.0891304347826, 0.055555555555556
41519, 0.043478260869565, 1.0891304347826, 0.11111111111111
41520, 0.043478260869565, 1.0891304347826, 0.16666666666667
41521, 0.043478260869565, 1.0891304347826, 0.22222222222222
41522, 0.043478260869565, 1.0891304347826, 0.27777777777778
41523, 0.043478260869565, 1.0891304347826, 0.33333333333333
41524, 0.043478260869565, 1.0891304347826, 0.38888888888889
41525, 0.043478260869565, 1.0891304347826, 0.44444444444444
41526, 0.95652173913043, 1.1413043478261, 0.055555555555556
41527, 0.95652173913043, 1.1413043478261, 0.11111111111111
41528, 0.95652173913043, 1.1413043478261, 0.16666666666667
41529, 0.95652173913044, 1.1413043478261, 0.22222222222222
41530, 0.95652173913044, 1.1413043478261, 0.27777777777778
41531, 0.95652173913043, 1.1413043478261, 0.33333333333333
41532, 0.95652173913044, 1.1413043478261, 0.38888888888889
41533, 0.95652173913044, 1.1413043478261, 0.44444444444444
41534, 0.91304347826087, 1.1413043478261, 0.055555555555556
41535, 0.91304347826087, 1.1413043478261, 0.11111111111111
41536, 0.91304347826087, 1.1413043478261, 0.16666666666667
41537, 0.91304347826087, 1.1413043478261, 0.22222222222222
41538, 0.91304347826087, 1.1413043478261, 0.27777777777778
41539, 0.91304347826087, 1.1413043478261, 0.33333333333333
41540, 0.91304347826087, 1.1413043478261, 0.38888888888889
41541, 0.91304347826087, 1.1413043478261, 0.44444444444444
41542, 0.8695652173913, 1.1413043478261, 0.055555555555556
41543, 0.8695652173913, 1.1413043478261, 0.11111111111111
41544, 0.8695652173913, 1.1413043478261, 0.16666666666667
41545, 0.8695652173913, 1.1413043478261, 0.22222222222222
41546, 0.8695652173913, 1.1413043478261, 0.27777777777778
41547, 0.8695652173913, 1.1413043478261, 0.33333333333333
41548, 0.8695652173913, 1.1413043478261, 0.38888888888889
41549, 0.8695652173913, 1.1413043478261, 0.44444444444444
41550, 0.82608695652174, 1.1413043478261, 0.055555555555556
41551, 0.82608695652174, 1.1413043478261, 0.11111111111111
41552, 0.82608695652174, 1.1413043478261, 0.16666666666667
41553, 0.82608695652174, 1.1413043478261, 0.22222222222222
41554, 0.82608695652174, 1.1413043478261, 0.27777777777778
41555, 0.82608695652174, 1.1413043478261, 0.33333333333333
41556, 0.82608695652174, 1.1413043478261, 0.38888888888889
41557, 0.82608695652174, 1.1413043478261, 0.44444444444444
41558, 0.78260869565217, 1.1413043478261, 0.055555555555556
41559, 0.78260869565217, 1.1413043478261, 0.11111111111111
41560, 0.78260869565217, 1.1413043478261, 0.16666666666667
41561, 0.78260869565217, 1.1413043478261, 0.22222222222222
41562, 0.78260869565217, 1.1413043478261, 0.27777777777778
41563, 0.78260869565217, 1.1413043478261, 0.33333333333333
41564, 0.78260869565217, 1.1413043478261, 0.38888888888889
41565, 0.78260869565217, 1.1413043478261, 0.44444444444444
41566, 0.73913043478261, 1.1413043478261, 0.055555555555556
41567, 0.73913043478261, 1.1413043478261, 0.11111111111111
41568, 0.73913043478261, 1.1413043478261, 0.16666666666667
41569, 0.73913043478261, 1.1413043478261, 0.22222222222222
41570, 0.73913043478261, 1.1413043478261, 0.27777777777778
41571, 0.73913043478261, 1.1413043478261, 0.33333333333333
41572, 0.73913043478261, 1.1413043478261, 0.38888888888889
41573, 0.73913043478261, 1.1413043478261, 0.44444444444444
41574, 0.69565217391304, 1.1413043478261, 0.055555555555556
41575, 0.69565217391304, 1.1413043478261, 0.11111111111111
41576, 0.69565217391304, 1.1413043478261, 0.16666666666667
41577, 0.69565217391304, 1.1413043478261, 0.22222222222222
41578, 0.69565217391304, 1.1413043478261, 0.27777777777778
41579, 0.69565217391304, 1.1413043478261, 0.33333333333333
41580, 0.69565217391304, 1.1413043478261, 0.38888888888889
41581, 0.69565217391304, 1.1413043478261, 0.44444444444444
41582, 0.65217391304348, 1.1413043478261, 0.055555555555556
41583, 0.65217391304348, 1.1413043478261, 0.11111111111111
41584, 0.65217391304348, 1.1413043478261, 0.16666666666667
41585, 0.65217391304348, 1.1413043478261, 0.22222222222222
41586, 0.65217391304348, 1.1413043478261, 0.27777777777778
41587, 0.65217391304348, 1.1413043478261, 0.33333333333333
41588, 0.65217391304348, 1.1413043478261, 0.38888888888889
41589, 0.65217391304348, 1.1413043478261, 0.44444444444444
41590, 0.60869565217391, 1.1413043478261, 0.055555555555556
41591, 0.60869565217391, 1.1413043478261, 0.11111111111111
41592, 0.60869565217391, 1.1413043478261, 0.16666666666667
41593, 0.60869565217391, 1.1413043478261, 0.22222222222222
41594, 0.60869565217391, 1.1413043478261, 0.27777777777778
41595, 0.60869565217391, 1.1413043478261, 0.33333333333333
41596, 0.60869565217391, 1.1413043478261, 0.38888888888889
41597, 0.60869565217391, 1.1413043478261, 0.44444444444444
41598, 0.56521739130435, 1.1413043478261, 0.055555555555556
41599, 0.56521739130435, 1.1413043478261, 0.11111111111111
41600, 0.56521739130435, 1.1413043478261, 0.16666666666667
41601, 0.56521739130435, 1.1413043478261, 0.22222222222222
41602, 0.56521739130435, 1.1413043478261, 0.27777777777778
41603, 0.56521739130435, 1.1413043478261, 0.33333333333333
41604, 0.56521739130435, 1.1413043478261, 0.38888888888889
41605, 0.56521739130435, 1.1413043478261, 0.44444444444444
41606, 0.52173913043478, 1.1413043478261, 0.055555555555556
41607, 0.52173913043478, 1.1413043478261, 0.11111111111111
41608, 0.52173913043478, 1.1413043478261, 0.16666666666667
41609, 0.52173913043478, 1.1413043478261, 0.22222222222222
41610, 0.52173913043478, 1.1413043478261, 0.27777777777778
41611, 0.52173913043478, 1.1413043478261, 0.33333333333333
41612, 0.52173913043478, 1.1413043478261, 0.38888888888889
41613, 0.52173913043478, 1.1413043478261, 0.44444444444444
41614, 0.47826086956522, 1.1413043478261, 0.055555555555556
41615, 0.47826086956522, 1.1413043478261, 0.11111111111111
41616, 0.47826086956522, 1.1413043478261, 0.16666666666667
41617, 0.47826086956522, 1.1413043478261, 0.22222222222222
41618, 0.47826086956522, 1.1413043478261, 0.27777777777778
41619, 0.47826086956522, 1.1413043478261, 0.33333333333333
41620, 0.47826086956522, 1.1413043478261, 0.38888888888889
41621, 0.47826086956522, 1.1413043478261, 0.44444444444444
41622, 0.43478260869565, 1.1413043478261, 0.055555555555556
41623, 0.43478260869565, 1.1413043478261, 0.11111111111111
41624, 0.43478260869565, 1.1413043478261, 0.16666666666667
41625, 0.43478260869565, 1.1413043478261, 0.22222222222222
41626, 0.43478260869565, 1.1413043478261, 0.27777777777778
41627, 0.43478260869565, 1.1413043478261, 0.33333333333333
41628, 0.43478260869565, 1.1413043478261, 0.38888888888889
41629, 0.43478260869565, 1.1413043478261, 0.44444444444444
41630, 0.39130434782609, 1.1413043478261, 0.055555555555556
41631, 0.39130434782609, 1.1413043478261, 0.11111111111111
41632, 0.39130434782609, 1.1413043478261, 0.16666666666667
41633, 0.39130434782609, 1.1413043478261, 0.22222222222222
41634, 0.39130434782609, 1.1413043478261, 0.27777777777778
41635, 0.39130434782609, 1.1413043478261, 0.33333333333333
41636, 0.39130434782609, 1.1413043478261, 0.38888888888889
41637, 0.39130434782609, 1.1413043478261, 0.44444444444444
41638, 0.34782608695652, 1.1413043478261, 0.055555555555556
41639, 0.34782608695652, 1.1413043478261, 0.11111111111111
41640, 0.34782608695652, 1.1413043478261, 0.16666666666667
41641, 0.34782608695652, 1.1413043478261, 0.22222222222222
41642, 0.34782608695652, 1.1413043478261, 0.27777777777778
41643, 0.34782608695652, 1.1413043478261, 0.33333333333333
41644, 0.34782608695652, 1.1413043478261, 0.38888888888889
41645, 0.34782608695652, 1.1413043478261, 0.44444444444444
41646, 0.30434782608696, 1.1413043478261, 0.055555555555556
41647, 0.30434782608696, 1.1413043478261, 0.11111111111111
41648, 0.30434782608696, 1.1413043478261, 0.16666666666667
41649, 0.30434782608696, 1.1413043478261, 0.22222222222222
41650, 0.30434782608696, 1.1413043478261, 0.27777777777778
41651, 0.30434782608696, 1.1413043478261, 0.33333333333333
41652, 0.30434782608696, 1.1413043478261, 0.38888888888889
41653, 0.30434782608696, 1.1413043478261, 0.44444444444444
41654, 0.26086956521739, 1.1413043478261, 0.055555555555556
41655, 0.26086956521739, 1.1413043478261, 0.11111111111111
41656, 0.26086956521739, 1.1413043478261, 0.16666666666667
41657, 0.26086956521739, 1.1413043478261, 0.22222222222222
41658, 0.26086956521739, 1.1413043478261, 0.27777777777778
41659, 0.26086956521739, 1.1413043478261, 0.33333333333333
41660, 0.26086956521739, 1.1413043478261, 0.38888888888889
41661, 0.26086956521739, 1.1413043478261, 0.44444444444444
41662, 0.21739130434783, 1.1413043478261, 0.055555555555556
41663, 0.21739130434783, 1.1413043478261, 0.11111111111111
41664, 0.21739130434783, 1.1413043478261, 0.16666666666667
41665, 0.21739130434783, 1.1413043478261, 0.22222222222222
41666, 0.21739130434783, 1.1413043478261, 0.27777777777778
41667, 0.21739130434783, 1.1413043478261, 0.33333333333333
41668, 0.21739130434783, 1.1413043478261, 0.38888888888889
41669, 0.21739130434783, 1.1413043478261, 0.44444444444444
41670, 0.17391304347826, 1.1413043478261, 0.055555555555556
41671, 0.17391304347826, 1.1413043478261, 0.11111111111111
41672, 0.17391304347826, 1.1413043478261, 0.16666666666667
41673, 0.17391304347826, 1.1413043478261, 0.22222222222222
41674, 0.17391304347826, 1.1413043478261, 0.27777777777778
41675, 0.17391304347826, 1.1413043478261, 0.33333333333333
41676, 0.17391304347826, 1.1413043478261, 0.38888888888889
41677, 0.17391304347826, 1.1413043478261, 0.44444444444444
41678, 0.1304347826087, 1.1413043478261, 0.055555555555556
41679, 0.1304347826087, 1.1413043478261, 0.11111111111111
41680, 0.1304347826087, 1.1413043478261, 0.16666666666667
41681, 0.1304347826087, 1.1413043478261, 0.22222222222222
41682, 0.1304347826087, 1.1413043478261, 0.27777777777778
41683, 0.1304347826087, 1.1413043478261, 0.33333333333333
41684, 0.1304347826087, 1.1413043478261, 0.38888888888889
41685, 0.1304347826087, 1.1413043478261, 0.44444444444444
41686, 0.08695652173913, 1.1413043478261, 0.055555555555556
41687, 0.08695652173913, 1.1413043478261, 0.11111111111111
41688, 0.08695652173913, 1.1413043478261, 0.16666666666667
41689, 0.08695652173913, 1.1413043478261, 0.22222222222222
41690, 0.08695652173913, 1.1413043478261, 0.27777777777778
41691, 0.08695652173913, 1.1413043478261, 0.33333333333333
41692, 0.08695652173913, 1.1413043478261, 0.38888888888889
41693, 0.08695652173913, 1.1413043478261, 0.44444444444444
41694, 0.043478260869565, 1.1413043478261, 0.055555555555556
41695, 0.043478260869565, 1.1413043478261, 0.11111111111111
41696, 0.043478260869565, 1.1413043478261, 0.16666666666667
41697, 0.043478260869565, 1.1413043478261, 0.22222222222222
41698, 0.043478260869565, 1.1413043478261, 0.27777777777778
41699, 0.043478260869565, 1.1413043478261, 0.33333333333333
41700, 0.043478260869565, 1.1413043478261, 0.38888888888889
41701, 0.043478260869565, 1.1413043478261, 0.44444444444444
41702, 0.95652173913043, 1.1934782608696, 0.055555555555556
41703, 0.95652173913043, 1.1934782608696, 0.11111111111111
41704, 0.95652173913044, 1.1934782608696, 0.16666666666667
41705, 0.95652173913044, 1.1934782608696, 0.22222222222222
41706, 0.95652173913044, 1.1934782608696, 0.27777777777778
41707, 0.95652173913044, 1.1934782608696, 0.33333333333333
41708, 0.95652173913044, 1.1934782608696, 0.38888888888889
41709, 0.95652173913044, 1.1934782608696, 0.44444444444444
41710, 0.91304347826087, 1.1934782608696, 0.055555555555556
41711, 0.91304347826087, 1.1934782608696, 0.11111111111111
41712, 0.91304347826087, 1.1934782608696, 0.16666666666667
41713, 0.91304347826087, 1.1934782608696, 0.22222222222222
41714, 0.91304347826087, 1.1934782608696, 0.27777777777778
41715, 0.91304347826087, 1.1934782608696, 0.33333333333333
41716, 0.91304347826087, 1.1934782608696, 0.38888888888889
41717, 0.91304347826087, 1.1934782608696, 0.44444444444444
41718, 0.8695652173913, 1.1934782608696, 0.055555555555556
41719, 0.8695652173913, 1.1934782608696, 0.11111111111111
41720, 0.8695652173913, 1.1934782608696, 0.16666666666667
41721, 0.8695652173913, 1.1934782608696, 0.22222222222222
41722, 0.8695652173913, 1.1934782608696, 0.27777777777778
41723, 0.8695652173913, 1.1934782608696, 0.33333333333333
41724, 0.8695652173913, 1.1934782608696, 0.38888888888889
41725, 0.8695652173913, 1.1934782608696, 0.44444444444444
41726, 0.82608695652174, 1.1934782608696, 0.055555555555556
41727, 0.82608695652174, 1.1934782608696, 0.11111111111111
41728, 0.82608695652174, 1.1934782608696, 0.16666666666667
41729, 0.82608695652174, 1.1934782608696, 0.22222222222222
41730, 0.82608695652174, 1.1934782608696, 0.27777777777778
41731, 0.82608695652174, 1.1934782608696, 0.33333333333333
41732, 0.82608695652174, 1.1934782608696, 0.38888888888889
41733, 0.82608695652174, 1.1934782608696, 0.44444444444444
41734, 0.78260869565217, 1.1934782608696, 0.055555555555556
41735, 0.78260869565217, 1.1934782608696, 0.11111111111111
41736, 0.78260869565217, 1.1934782608696, 0.16666666666667
41737, 0.78260869565217, 1.1934782608696, 0.22222222222222
41738, 0.78260869565217, 1.1934782608696, 0.27777777777778
41739, 0.78260869565217, 1.1934782608696, 0.33333333333333
41740, 0.78260869565217, 1.1934782608696, 0.38888888888889
41741, 0.78260869565217, 1.1934782608696, 0.44444444444444
41742, 0.73913043478261, 1.1934782608696, 0.055555555555556
41743, 0.73913043478261, 1.1934782608696, 0.11111111111111
41744, 0.73913043478261, 1.1934782608696, 0.16666666666667
41745, 0.73913043478261, 1.1934782608696, 0.22222222222222
41746, 0.73913043478261, 1.1934782608696, 0.27777777777778
41747, 0.73913043478261, 1.1934782608696, 0.33333333333333
41748, 0.73913043478261, 1.1934782608696, 0.38888888888889
41749, 0.73913043478261, 1.1934782608696, 0.44444444444444
41750, 0.69565217391304, 1.1934782608696, 0.055555555555556
41751, 0.69565217391304, 1.1934782608696, 0.11111111111111
41752, 0.69565217391304, 1.1934782608696, 0.16666666666667
41753, 0.69565217391304, 1.1934782608696, 0.22222222222222
41754, 0.69565217391304, 1.1934782608696, 0.27777777777778
41755, 0.69565217391304, 1.1934782608696, 0.33333333333333
41756, 0.69565217391304, 1.1934782608696, 0.38888888888889
41757, 0.69565217391304, 1.1934782608696, 0.44444444444444
41758, 0.65217391304348, 1.1934782608696, 0.055555555555556
41759, 0.65217391304348, 1.1934782608696, 0.11111111111111
41760, 0.65217391304348, 1.1934782608696, 0.16666666666667
41761, 0.65217391304348, 1.1934782608696, 0.22222222222222
41762, 0.65217391304348, 1.1934782608696, 0.27777777777778
41763, 0.65217391304348, 1.1934782608696, 0.33333333333333
41764, 0.65217391304348, 1.1934782608696, 0.38888888888889
41765, 0.65217391304348, 1.1934782608696, 0.44444444444444
41766, 0.60869565217391, 1.1934782608696, 0.055555555555556
41767, 0.60869565217391, 1.1934782608696, 0.11111111111111
41768, 0.60869565217391, 1.1934782608696, 0.16666666666667
41769, 0.60869565217391, 1.1934782608696, 0.22222222222222
41770, 0.60869565217391, 1.1934782608696, 0.27777777777778
41771, 0.60869565217391, 1.1934782608696, 0.33333333333333
41772, 0.60869565217391, 1.1934782608696, 0.38888888888889
41773, 0.60869565217391, 1.1934782608696, 0.44444444444444
41774, 0.56521739130435, 1.1934782608696, 0.055555555555556
41775, 0.56521739130435, 1.1934782608696, 0.11111111111111
41776, 0.56521739130435, 1.1934782608696, 0.16666666666667
41777, 0.56521739130435, 1.1934782608696, 0.22222222222222
41778, 0.56521739130435, 1.1934782608696, 0.27777777777778
41779, 0.56521739130435, 1.1934782608696, 0.33333333333333
41780, 0.56521739130435, 1.1934782608696, 0.38888888888889
41781, 0.56521739130435, 1.1934782608696, 0.44444444444444
41782, 0.52173913043478, 1.1934782608696, 0.055555555555556
41783, 0.52173913043478, 1.1934782608696, 0.11111111111111
41784, 0.52173913043478, 1.1934782608696, 0.16666666666667
41785, 0.52173913043478, 1.1934782608696, 0.22222222222222
41786, 0.52173913043478, 1.1934782608696, 0.27777777777778
41787, 0.52173913043478, 1.1934782608696, 0.33333333333333
41788, 0.52173913043478, 1.1934782608696, 0.38888888888889
41789, 0.52173913043478, 1.1934782608696, 0.44444444444444
41790, 0.47826086956522, 1.1934782608696, 0.055555555555556
41791, 0.47826086956522, 1.1934782608696, 0.11111111111111
41792, 0.47826086956522, 1.1934782608696, 0.16666666666667
41793, 0.47826086956522, 1.1934782608696, 0.22222222222222
41794, 0.47826086956522, 1.1934782608696, 0.27777777777778
41795, 0.47826086956522, 1.1934782608696, 0.33333333333333
41796, 0.47826086956522, 1.1934782608696, 0.38888888888889
41797, 0.47826086956522, 1.1934782608696, 0.44444444444444
41798, 0.43478260869565, 1.1934782608696, 0.055555555555556
41799, 0.43478260869565, 1.1934782608696, 0.11111111111111
41800, 0.43478260869565, 1.1934782608696, 0.16666666666667
41801, 0.43478260869565, 1.1934782608696, 0.22222222222222
41802, 0.43478260869565, 1.1934782608696, 0.27777777777778
41803, 0.43478260869565, 1.1934782608696, 0.33333333333333
41804, 0.43478260869565, 1.1934782608696, 0.38888888888889
41805, 0.43478260869565, 1.1934782608696, 0.44444444444444
41806, 0.39130434782609, 1.1934782608696, 0.055555555555556
41807, 0.39130434782609, 1.1934782608696, 0.11111111111111
41808, 0.39130434782609, 1.1934782608696, 0.16666666666667
41809, 0.39130434782609, 1.1934782608696, 0.22222222222222
41810, 0.39130434782609, 1.1934782608696, 0.27777777777778
41811, 0.39130434782609, 1.1934782608696, 0.33333333333333
41812, 0.39130434782609, 1.1934782608696, 0.38888888888889
41813, 0.39130434782609, 1.1934782608696, 0.44444444444444
41814, 0.34782608695652, 1.1934782608696, 0.055555555555556
41815, 0.34782608695652, 1.1934782608696, 0.11111111111111
41816, 0.34782608695652, 1.1934782608696, 0.16666666666667
41817, 0.34782608695652, 1.1934782608696, 0.22222222222222
41818, 0.34782608695652, 1.1934782608696, 0.27777777777778
41819, 0.34782608695652, 1.1934782608696, 0.33333333333333
41820, 0.34782608695652, 1.1934782608696, 0.38888888888889
41821, 0.34782608695652, 1.1934782608696, 0.44444444444444
41822, 0.30434782608696, 1.1934782608696, 0.055555555555556
41823, 0.30434782608696, 1.1934782608696, 0.11111111111111
41824, 0.30434782608696, 1.1934782608696, 0.16666666666667
41825, 0.30434782608696, 1.1934782608696, 0.22222222222222
41826, 0.30434782608696, 1.1934782608696, 0.27777777777778
41827, 0.30434782608696, 1.1934782608696, 0.33333333333333
41828, 0.30434782608696, 1.1934782608696, 0.38888888888889
41829, 0.30434782608696, 1.1934782608696, 0.44444444444444
41830, 0.26086956521739, 1.1934782608696, 0.055555555555556
41831, 0.26086956521739, 1.1934782608696, 0.11111111111111
41832, 0.26086956521739, 1.1934782608696, 0.16666666666667
41833, 0.26086956521739, 1.1934782608696, 0.22222222222222
41834, 0.26086956521739, 1.1934782608696, 0.27777777777778
41835, 0.26086956521739, 1.1934782608696, 0.33333333333333
41836, 0.26086956521739, 1.1934782608696, 0.38888888888889
41837, 0.26086956521739, 1.1934782608696, 0.44444444444444
41838, 0.21739130434783, 1.1934782608696, 0.055555555555556
41839, 0.21739130434783, 1.1934782608696, 0.11111111111111
41840, 0.21739130434783, 1.1934782608696, 0.16666666666667
41841, 0.21739130434783, 1.1934782608696, 0.22222222222222
41842, 0.21739130434783, 1.1934782608696, 0.27777777777778
41843, 0.21739130434783, 1.1934782608696, 0.33333333333333
41844, 0.21739130434783, 1.1934782608696, 0.38888888888889
41845, 0.21739130434783, 1.1934782608696, 0.44444444444444
41846, 0.17391304347826, 1.1934782608696, 0.055555555555556
41847, 0.17391304347826, 1.1934782608696, 0.11111111111111
41848, 0.17391304347826, 1.1934782608696, 0.16666666666667
41849, 0.17391304347826, 1.1934782608696, 0.22222222222222
41850, 0.17391304347826, 1.1934782608696, 0.27777777777778
41851, 0.17391304347826, 1.1934782608696, 0.33333333333333
41852, 0.17391304347826, 1.1934782608696, 0.38888888888889
41853, 0.17391304347826, 1.1934782608696, 0.44444444444444
41854, 0.1304347826087, 1.1934782608696, 0.055555555555556
41855, 0.1304347826087, 1.1934782608696, 0.11111111111111
41856, 0.1304347826087, 1.1934782608696, 0.16666666666667
41857, 0.1304347826087, 1.1934782608696, 0.22222222222222
41858, 0.1304347826087, 1.1934782608696, 0.27777777777778
41859, 0.1304347826087, 1.1934782608696, 0.33333333333333
41860, 0.1304347826087, 1.1934782608696, 0.38888888888889
41861, 0.1304347826087, 1.1934782608696, 0.44444444444444
41862, 0.08695652173913, 1.1934782608696, 0.055555555555556
41863, 0.08695652173913, 1.1934782608696, 0.11111111111111
41864, 0.08695652173913, 1.1934782608696, 0.16666666666667
41865, 0.08695652173913, 1.1934782608696, 0.22222222222222
41866, 0.08695652173913, 1.1934782608696, 0.27777777777778
41867, 0.08695652173913, 1.1934782608696, 0.33333333333333
41868, 0.08695652173913, 1.1934782608696, 0.38888888888889
41869, 0.08695652173913, 1.1934782608696, 0.44444444444444
41870, 0.043478260869565, 1.1934782608696, 0.055555555555556
41871, 0.043478260869565, 1.1934782608696, 0.11111111111111
41872, 0.043478260869565, 1.1934782608696, 0.16666666666667
41873, 0.043478260869565, 1.1934782608696, 0.22222222222222
41874, 0.043478260869565, 1.1934782608696, 0.27777777777778
41875, 0.043478260869565, 1.1934782608696, 0.33333333333333
41876, 0.043478260869565, 1.1934782608696, 0.38888888888889
41877, 0.043478260869565, 1.1934782608696, 0.44444444444444
41878, 0.95652173913043, 1.245652173913, 0.055555555555556
41879, 0.95652173913044, 1.245652173913, 0.11111111111111
41880, 0.95652173913044, 1.245652173913, 0.16666666666667
41881, 0.95652173913043, 1.245652173913, 0.22222222222222
41882, 0.95652173913044, 1.245652173913, 0.27777777777778
41883, 0.95652173913044, 1.245652173913, 0.33333333333333
41884, 0.95652173913044, 1.245652173913, 0.38888888888889
41885, 0.95652173913044, 1.245652173913, 0.44444444444444
41886, 0.91304347826087, 1.245652173913, 0.055555555555556
41887, 0.91304347826087, 1.245652173913, 0.11111111111111
41888, 0.91304347826087, 1.245652173913, 0.16666666666667
41889, 0.91304347826087, 1.245652173913, 0.22222222222222
41890, 0.91304347826087, 1.245652173913, 0.27777777777778
41891, 0.91304347826087, 1.245652173913, 0.33333333333333
41892, 0.91304347826087, 1.245652173913, 0.38888888888889
41893, 0.91304347826087, 1.245652173913, 0.44444444444444
41894, 0.8695652173913, 1.245652173913, 0.055555555555556
41895, 0.8695652173913, 1.245652173913, 0.11111111111111
41896, 0.8695652173913, 1.245652173913, 0.16666666666667
41897, 0.8695652173913, 1.245652173913, 0.22222222222222
41898, 0.8695652173913, 1.245652173913, 0.27777777777778
41899, 0.8695652173913, 1.245652173913, 0.33333333333333
41900, 0.8695652173913, 1.245652173913, 0.38888888888889
41901, 0.8695652173913, 1.245652173913, 0.44444444444444
41902, 0.82608695652174, 1.245652173913, 0.055555555555556
41903, 0.82608695652174, 1.245652173913, 0.11111111111111
41904, 0.82608695652174, 1.245652173913, 0.16666666666667
41905, 0.82608695652174, 1.245652173913, 0.22222222222222
41906, 0.82608695652174, 1.245652173913, 0.27777777777778
41907, 0.82608695652174, 1.245652173913, 0.33333333333333
41908, 0.82608695652174, 1.245652173913, 0.38888888888889
41909, 0.82608695652174, 1.245652173913, 0.44444444444444
41910, 0.78260869565217, 1.245652173913, 0.055555555555556
41911, 0.78260869565217, 1.245652173913, 0.11111111111111
41912, 0.78260869565217, 1.245652173913, 0.16666666666667
41913, 0.78260869565217, 1.245652173913, 0.22222222222222
41914, 0.78260869565217, 1.245652173913, 0.27777777777778
41915, 0.78260869565217, 1.245652173913, 0.33333333333333
41916, 0.78260869565217, 1.245652173913, 0.38888888888889
41917, 0.78260869565217, 1.245652173913, 0.44444444444444
41918, 0.73913043478261, 1.245652173913, 0.055555555555556
41919, 0.73913043478261, 1.245652173913, 0.11111111111111
41920, 0.73913043478261, 1.245652173913, 0.16666666666667
41921, 0.73913043478261, 1.245652173913, 0.22222222222222
41922, 0.73913043478261, 1.245652173913, 0.27777777777778
41923, 0.73913043478261, 1.245652173913, 0.33333333333333
41924, 0.73913043478261, 1.245652173913, 0.38888888888889
41925, 0.73913043478261, 1.245652173913, 0.44444444444444
41926, 0.69565217391304, 1.245652173913, 0.055555555555556
41927, 0.69565217391304, 1.245652173913, 0.11111111111111
41928, 0.69565217391304, 1.245652173913, 0.16666666666667
41929, 0.69565217391304, 1.245652173913, 0.22222222222222
41930, 0.69565217391304, 1.245652173913, 0.27777777777778
41931, 0.69565217391304, 1.245652173913, 0.33333333333333
41932, 0.69565217391304, 1.245652173913, 0.38888888888889
41933, 0.69565217391304, 1.245652173913, 0.44444444444444
41934, 0.65217391304348, 1.245652173913, 0.055555555555556
41935, 0.65217391304348, 1.245652173913, 0.11111111111111
41936, 0.65217391304348, 1.245652173913, 0.16666666666667
41937, 0.65217391304348, 1.245652173913, 0.22222222222222
41938, 0.65217391304348, 1.245652173913, 0.27777777777778
41939, 0.65217391304348, 1.245652173913, 0.33333333333333
41940, 0.65217391304348, 1.245652173913, 0.38888888888889
41941, 0.65217391304348, 1.245652173913, 0.44444444444444
41942, 0.60869565217391, 1.245652173913, 0.055555555555556
41943, 0.60869565217391, 1.245652173913, 0.11111111111111
41944, 0.60869565217391, 1.245652173913, 0.16666666666667
41945, 0.60869565217391, 1.245652173913, 0.22222222222222
41946, 0.60869565217391, 1.245652173913, 0.27777777777778
41947, 0.60869565217391, 1.245652173913, 0.33333333333333
41948, 0.60869565217391, 1.245652173913, 0.38888888888889
41949, 0.60869565217391, 1.245652173913, 0.44444444444444
41950, 0.56521739130435, 1.245652173913, 0.055555555555556
41951, 0.56521739130435, 1.245652173913, 0.11111111111111
41952, 0.56521739130435, 1.245652173913, 0.16666666666667
41953, 0.56521739130435, 1.245652173913, 0.22222222222222
41954, 0.56521739130435, 1.245652173913, 0.27777777777778
41955, 0.56521739130435, 1.245652173913, 0.33333333333333
41956, 0.56521739130435, 1.245652173913, 0.38888888888889
41957, 0.56521739130435, 1.245652173913, 0.44444444444444
41958, 0.52173913043478, 1.245652173913, 0.055555555555556
41959, 0.52173913043478, 1.245652173913, 0.11111111111111
41960, 0.52173913043478, 1.245652173913, 0.16666666666667
41961, 0.52173913043478, 1.245652173913, 0.22222222222222
41962, 0.52173913043478, 1.245652173913, 0.27777777777778
41963, 0.52173913043478, 1.245652173913, 0.33333333333333
41964, 0.52173913043478, 1.245652173913, 0.38888888888889
41965, 0.52173913043478, 1.245652173913, 0.44444444444444
41966, 0.47826086956522, 1.245652173913, 0.055555555555556
41967, 0.47826086956522, 1.245652173913, 0.11111111111111
41968, 0.47826086956522, 1.245652173913, 0.16666666666667
41969, 0.47826086956522, 1.245652173913, 0.22222222222222
41970, 0.47826086956522, 1.245652173913, 0.27777777777778
41971, 0.47826086956522, 1.245652173913, 0.33333333333333
41972, 0.47826086956522, 1.245652173913, 0.38888888888889
41973, 0.47826086956522, 1.245652173913, 0.44444444444444
41974, 0.43478260869565, 1.245652173913, 0.055555555555556
41975, 0.43478260869565, 1.245652173913, 0.11111111111111
41976, 0.43478260869565, 1.245652173913, 0.16666666666667
41977, 0.43478260869565, 1.245652173913, 0.22222222222222
41978, 0.43478260869565, 1.245652173913, 0.27777777777778
41979, 0.43478260869565, 1.245652173913, 0.33333333333333
41980, 0.43478260869565, 1.245652173913, 0.38888888888889
41981, 0.43478260869565, 1.245652173913, 0.44444444444444
41982, 0.39130434782609, 1.245652173913, 0.055555555555556
41983, 0.39130434782609, 1.245652173913, 0.11111111111111
41984, 0.39130434782609, 1.245652173913, 0.16666666666667
41985, 0.39130434782609, 1.245652173913, 0.22222222222222
41986, 0.39130434782609, 1.245652173913, 0.27777777777778
41987, 0.39130434782609, 1.245652173913, 0.33333333333333
41988, 0.39130434782609, 1.245652173913, 0.38888888888889
41989, 0.39130434782609, 1.245652173913, 0.44444444444444
41990, 0.34782608695652, 1.245652173913, 0.055555555555556
41991, 0.34782608695652, 1.245652173913, 0.11111111111111
41992, 0.34782608695652, 1.245652173913, 0.16666666666667
41993, 0.34782608695652, 1.245652173913, 0.22222222222222
41994, 0.34782608695652, 1.245652173913, 0.27777777777778
41995, 0.34782608695652, 1.245652173913, 0.33333333333333
41996, 0.34782608695652, 1.245652173913, 0.38888888888889
41997, 0.34782608695652, 1.245652173913, 0.44444444444444
41998, 0.30434782608696, 1.245652173913, 0.055555555555556
41999, 0.30434782608696, 1.245652173913, 0.11111111111111
42000, 0.30434782608696, 1.245652173913, 0.16666666666667
42001, 0.30434782608696, 1.245652173913, 0.22222222222222
42002, 0.30434782608696, 1.245652173913, 0.27777777777778
42003, 0.30434782608696, 1.245652173913, 0.33333333333333
42004, 0.30434782608696, 1.245652173913, 0.38888888888889
42005, 0.30434782608696, 1.245652173913, 0.44444444444444
42006, 0.26086956521739, 1.245652173913, 0.055555555555556
42007, 0.26086956521739, 1.245652173913, 0.11111111111111
42008, 0.26086956521739, 1.245652173913, 0.16666666666667
42009, 0.26086956521739, 1.245652173913, 0.22222222222222
42010, 0.26086956521739, 1.245652173913, 0.27777777777778
42011, 0.26086956521739, 1.245652173913, 0.33333333333333
42012, 0.26086956521739, 1.245652173913, 0.38888888888889
42013, 0.26086956521739, 1.245652173913, 0.44444444444444
42014, 0.21739130434783, 1.245652173913, 0.055555555555556
42015, 0.21739130434783, 1.245652173913, 0.11111111111111
42016, 0.21739130434783, 1.245652173913, 0.16666666666667
42017, 0.21739130434783, 1.245652173913, 0.22222222222222
42018, 0.21739130434783, 1.245652173913, 0.27777777777778
42019, 0.21739130434783, 1.245652173913, 0.33333333333333
42020, 0.21739130434783, 1.245652173913, 0.38888888888889
42021, 0.21739130434783, 1.245652173913, 0.44444444444444
42022, 0.17391304347826, 1.245652173913, 0.055555555555556
42023, 0.17391304347826, 1.245652173913, 0.11111111111111
42024, 0.17391304347826, 1.245652173913, 0.16666666666667
42025, 0.17391304347826, 1.245652173913, 0.22222222222222
42026, 0.17391304347826, 1.245652173913, 0.27777777777778
42027, 0.17391304347826, 1.245652173913, 0.33333333333333
42028, 0.17391304347826, 1.245652173913, 0.38888888888889
42029, 0.17391304347826, 1.245652173913, 0.44444444444444
42030, 0.1304347826087, 1.245652173913, 0.055555555555556
42031, 0.1304347826087, 1.245652173913, 0.11111111111111
42032, 0.1304347826087, 1.245652173913, 0.16666666666667
42033, 0.1304347826087, 1.245652173913, 0.22222222222222
42034, 0.1304347826087, 1.245652173913, 0.27777777777778
42035, 0.1304347826087, 1.245652173913, 0.33333333333333
42036, 0.1304347826087, 1.245652173913, 0.38888888888889
42037, 0.1304347826087, 1.245652173913, 0.44444444444444
42038, 0.08695652173913, 1.245652173913, 0.055555555555556
42039, 0.08695652173913, 1.245652173913, 0.11111111111111
42040, 0.08695652173913, 1.245652173913, 0.16666666666667
42041, 0.08695652173913, 1.245652173913, 0.22222222222222
42042, 0.08695652173913, 1.245652173913, 0.27777777777778
42043, 0.08695652173913, 1.245652173913, 0.33333333333333
42044, 0.08695652173913, 1.245652173913, 0.38888888888889
42045, 0.08695652173913, 1.245652173913, 0.44444444444444
42046, 0.043478260869565, 1.245652173913, 0.055555555555556
42047, 0.043478260869565, 1.245652173913, 0.11111111111111
42048, 0.043478260869565, 1.245652173913, 0.16666666666667
42049, 0.043478260869565, 1.245652173913, 0.22222222222222
42050, 0.043478260869565, 1.245652173913, 0.27777777777778
42051, 0.043478260869565, 1.245652173913, 0.33333333333333
42052, 0.043478260869565, 1.245652173913, 0.38888888888889
42053, 0.043478260869565, 1.245652173913, 0.44444444444444
42054, 0.95652173913043, 1.2978260869565, 0.055555555555556
42055, 0.95652173913044, 1.2978260869565, 0.11111111111111
42056, 0.95652173913044, 1.2978260869565, 0.16666666666667
42057, 0.95652173913044, 1.2978260869565, 0.22222222222222
42058, 0.95652173913044, 1.2978260869565, 0.27777777777778
42059, 0.95652173913044, 1.2978260869565, 0.33333333333333
42060, 0.95652173913044, 1.2978260869565, 0.38888888888889
42061, 0.95652173913044, 1.2978260869565, 0.44444444444444
42062, 0.91304347826087, 1.2978260869565, 0.055555555555556
42063, 0.91304347826087, 1.2978260869565, 0.11111111111111
42064, 0.91304347826087, 1.2978260869565, 0.16666666666667
42065, 0.91304347826087, 1.2978260869565, 0.22222222222222
42066, 0.91304347826087, 1.2978260869565, 0.27777777777778
42067, 0.91304347826087, 1.2978260869565, 0.33333333333333
42068, 0.91304347826087, 1.2978260869565, 0.38888888888889
42069, 0.91304347826087, 1.2978260869565, 0.44444444444444
42070, 0.8695652173913, 1.2978260869565, 0.055555555555556
42071, 0.8695652173913, 1.2978260869565, 0.11111111111111
42072, 0.8695652173913, 1.2978260869565, 0.16666666666667
42073, 0.8695652173913, 1.2978260869565, 0.22222222222222
42074, 0.8695652173913, 1.2978260869565, 0.27777777777778
42075, 0.8695652173913, 1.2978260869565, 0.33333333333333
42076, 0.8695652173913, 1.2978260869565, 0.38888888888889
42077, 0.8695652173913, 1.2978260869565, 0.44444444444444
42078, 0.82608695652174, 1.2978260869565, 0.055555555555556
42079, 0.82608695652174, 1.2978260869565, 0.11111111111111
42080, 0.82608695652174, 1.2978260869565, 0.16666666666667
42081, 0.82608695652174, 1.2978260869565, 0.22222222222222
42082, 0.82608695652174, 1.2978260869565, 0.27777777777778
42083, 0.82608695652174, 1.2978260869565, 0.33333333333333
42084, 0.82608695652174, 1.2978260869565, 0.38888888888889
42085, 0.82608695652174, 1.2978260869565, 0.44444444444444
42086, 0.78260869565217, 1.2978260869565, 0.055555555555556
42087, 0.78260869565217, 1.2978260869565, 0.11111111111111
42088, 0.78260869565217, 1.2978260869565, 0.16666666666667
42089, 0.78260869565217, 1.2978260869565, 0.22222222222222
42090, 0.78260869565217, 1.2978260869565, 0.27777777777778
42091, 0.78260869565217, 1.2978260869565, 0.33333333333333
42092, 0.78260869565217, 1.2978260869565, 0.38888888888889
42093, 0.78260869565217, 1.2978260869565, 0.44444444444444
42094, 0.73913043478261, 1.2978260869565, 0.055555555555556
42095, 0.73913043478261, 1.2978260869565, 0.11111111111111
42096, 0.73913043478261, 1.2978260869565, 0.16666666666667
42097, 0.73913043478261, 1.2978260869565, 0.22222222222222
42098, 0.73913043478261, 1.2978260869565, 0.27777777777778
42099, 0.73913043478261, 1.2978260869565, 0.33333333333333
42100, 0.73913043478261, 1.2978260869565, 0.38888888888889
42101, 0.73913043478261, 1.2978260869565, 0.44444444444444
42102, 0.69565217391304, 1.2978260869565, 0.055555555555556
42103, 0.69565217391304, 1.2978260869565, 0.11111111111111
42104, 0.69565217391304, 1.2978260869565, 0.16666666666667
42105, 0.69565217391304, 1.2978260869565, 0.22222222222222
42106, 0.69565217391304, 1.2978260869565, 0.27777777777778
42107, 0.69565217391304, 1.2978260869565, 0.33333333333333
42108, 0.69565217391304, 1.2978260869565, 0.38888888888889
42109, 0.69565217391304, 1.2978260869565, 0.44444444444444
42110, 0.65217391304348, 1.2978260869565, 0.055555555555556
42111, 0.65217391304348, 1.2978260869565, 0.11111111111111
42112, 0.65217391304348, 1.2978260869565, 0.16666666666667
42113, 0.65217391304348, 1.2978260869565, 0.22222222222222
42114, 0.65217391304348, 1.2978260869565, 0.27777777777778
42115, 0.65217391304348, 1.2978260869565, 0.33333333333333
42116, 0.65217391304348, 1.2978260869565, 0.38888888888889
42117, 0.65217391304348, 1.2978260869565, 0.44444444444444
42118, 0.60869565217391, 1.2978260869565, 0.055555555555556
42119, 0.60869565217391, 1.2978260869565, 0.11111111111111
42120, 0.60869565217391, 1.2978260869565, 0.16666666666667
42121, 0.60869565217391, 1.2978260869565, 0.22222222222222
42122, 0.60869565217391, 1.2978260869565, 0.27777777777778
42123, 0.60869565217391, 1.2978260869565, 0.33333333333333
42124, 0.60869565217391, 1.2978260869565, 0.38888888888889
42125, 0.60869565217391, 1.2978260869565, 0.44444444444444
42126, 0.56521739130435, 1.2978260869565, 0.055555555555556
42127, 0.56521739130435, 1.2978260869565, 0.11111111111111
42128, 0.56521739130435, 1.2978260869565, 0.16666666666667
42129, 0.56521739130435, 1.2978260869565, 0.22222222222222
42130, 0.56521739130435, 1.2978260869565, 0.27777777777778
42131, 0.56521739130435, 1.2978260869565, 0.33333333333333
42132, 0.56521739130435, 1.2978260869565, 0.38888888888889
42133, 0.56521739130435, 1.2978260869565, 0.44444444444444
42134, 0.52173913043478, 1.2978260869565, 0.055555555555556
42135, 0.52173913043478, 1.2978260869565, 0.11111111111111
42136, 0.52173913043478, 1.2978260869565, 0.16666666666667
42137, 0.52173913043478, 1.2978260869565, 0.22222222222222
42138, 0.52173913043478, 1.2978260869565, 0.27777777777778
42139, 0.52173913043478, 1.2978260869565, 0.33333333333333
42140, 0.52173913043478, 1.2978260869565, 0.38888888888889
42141, 0.52173913043478, 1.2978260869565, 0.44444444444444
42142, 0.47826086956522, 1.2978260869565, 0.055555555555556
42143, 0.47826086956522, 1.2978260869565, 0.11111111111111
42144, 0.47826086956522, 1.2978260869565, 0.16666666666667
42145, 0.47826086956522, 1.2978260869565, 0.22222222222222
42146, 0.47826086956522, 1.2978260869565, 0.27777777777778
42147, 0.47826086956522, 1.2978260869565, 0.33333333333333
42148, 0.47826086956522, 1.2978260869565, 0.38888888888889
42149, 0.47826086956522, 1.2978260869565, 0.44444444444444
42150, 0.43478260869565, 1.2978260869565, 0.055555555555556
42151, 0.43478260869565, 1.2978260869565, 0.11111111111111
42152, 0.43478260869565, 1.2978260869565, 0.16666666666667
42153, 0.43478260869565, 1.2978260869565, 0.22222222222222
42154, 0.43478260869565, 1.2978260869565, 0.27777777777778
42155, 0.43478260869565, 1.2978260869565, 0.33333333333333
42156, 0.43478260869565, 1.2978260869565, 0.38888888888889
42157, 0.43478260869565, 1.2978260869565, 0.44444444444444
42158, 0.39130434782609, 1.2978260869565, 0.055555555555556
42159, 0.39130434782609, 1.2978260869565, 0.11111111111111
42160, 0.39130434782609, 1.2978260869565, 0.16666666666667
42161, 0.39130434782609, 1.2978260869565, 0.22222222222222
42162, 0.39130434782609, 1.2978260869565, 0.27777777777778
42163, 0.39130434782609, 1.2978260869565, 0.33333333333333
42164, 0.39130434782609, 1.2978260869565, 0.38888888888889
42165, 0.39130434782609, 1.2978260869565, 0.44444444444444
42166, 0.34782608695652, 1.2978260869565, 0.055555555555556
42167, 0.34782608695652, 1.2978260869565, 0.11111111111111
42168, 0.34782608695652, 1.2978260869565, 0.16666666666667
42169, 0.34782608695652, 1.2978260869565, 0.22222222222222
42170, 0.34782608695652, 1.2978260869565, 0.27777777777778
42171, 0.34782608695652, 1.2978260869565, 0.33333333333333
42172, 0.34782608695652, 1.2978260869565, 0.38888888888889
42173, 0.34782608695652, 1.2978260869565, 0.44444444444444
42174, 0.30434782608696, 1.2978260869565, 0.055555555555556
42175, 0.30434782608696, 1.2978260869565, 0.11111111111111
42176, 0.30434782608696, 1.2978260869565, 0.16666666666667
42177, 0.30434782608696, 1.2978260869565, 0.22222222222222
42178, 0.30434782608696, 1.2978260869565, 0.27777777777778
42179, 0.30434782608696, 1.2978260869565, 0.33333333333333
42180, 0.30434782608696, 1.2978260869565, 0.38888888888889
42181, 0.30434782608696, 1.2978260869565, 0.44444444444444
42182, 0.26086956521739, 1.2978260869565, 0.055555555555556
42183, 0.26086956521739, 1.2978260869565, 0.11111111111111
42184, 0.26086956521739, 1.2978260869565, 0.16666666666667
42185, 0.26086956521739, 1.2978260869565, 0.22222222222222
42186, 0.26086956521739, 1.2978260869565, 0.27777777777778
42187, 0.26086956521739, 1.2978260869565, 0.33333333333333
42188, 0.26086956521739, 1.2978260869565, 0.38888888888889
42189, 0.26086956521739, 1.2978260869565, 0.44444444444444
42190, 0.21739130434783, 1.2978260869565, 0.055555555555556
42191, 0.21739130434783, 1.2978260869565, 0.11111111111111
42192, 0.21739130434783, 1.2978260869565, 0.16666666666667
42193, 0.21739130434783, 1.2978260869565, 0.22222222222222
42194, 0.21739130434783, 1.2978260869565, 0.27777777777778
42195, 0.21739130434783, 1.2978260869565, 0.33333333333333
42196, 0.21739130434783, 1.2978260869565, 0.38888888888889
42197, 0.21739130434783, 1.2978260869565, 0.44444444444444
42198, 0.17391304347826, 1.2978260869565, 0.055555555555556
42199, 0.17391304347826, 1.2978260869565, 0.11111111111111
42200, 0.17391304347826, 1.2978260869565, 0.16666666666667
42201, 0.17391304347826, 1.2978260869565, 0.22222222222222
42202, 0.17391304347826, 1.2978260869565, 0.27777777777778
42203, 0.17391304347826, 1.2978260869565, 0.33333333333333
42204, 0.17391304347826, 1.2978260869565, 0.38888888888889
42205, 0.17391304347826, 1.2978260869565, 0.44444444444444
42206, 0.1304347826087, 1.2978260869565, 0.055555555555556
42207, 0.1304347826087, 1.2978260869565, 0.11111111111111
42208, 0.1304347826087, 1.2978260869565, 0.16666666666667
42209, 0.1304347826087, 1.2978260869565, 0.22222222222222
42210, 0.1304347826087, 1.2978260869565, 0.27777777777778
42211, 0.1304347826087, 1.2978260869565, 0.33333333333333
42212, 0.1304347826087, 1.2978260869565, 0.38888888888889
42213, 0.1304347826087, 1.2978260869565, 0.44444444444444
42214, 0.08695652173913, 1.2978260869565, 0.055555555555556
42215, 0.08695652173913, 1.2978260869565, 0.11111111111111
42216, 0.08695652173913, 1.2978260869565, 0.16666666666667
42217, 0.08695652173913, 1.2978260869565, 0.22222222222222
42218, 0.08695652173913, 1.2978260869565, 0.27777777777778
42219, 0.08695652173913, 1.2978260869565, 0.33333333333333
42220, 0.08695652173913, 1.2978260869565, 0.38888888888889
42221, 0.08695652173913, 1.2978260869565, 0.44444444444444
42222, 0.043478260869565, 1.2978260869565, 0.055555555555556
42223, 0.043478260869565, 1.2978260869565, 0.11111111111111
42224, 0.043478260869565, 1.2978260869565, 0.16666666666667
42225, 0.043478260869565, 1.2978260869565, 0.22222222222222
42226, 0.043478260869565, 1.2978260869565, 0.27777777777778
42227, 0.043478260869565, 1.2978260869565, 0.33333333333333
42228, 0.043478260869565, 1.2978260869565, 0.38888888888889
42229, 0.043478260869565, 1.2978260869565, 0.44444444444444
42230, 0.95652173913043, 0.20217391304348, 0.027777777777778
42231, 0.97826086956522, 0.20217391304348, 0.055555555555556
42232, 0.95652173913043, 0.17608695652174, 0.055555555555556
42233, 0.95652173913043, 0.20217391304348, 0.083333333333333
42234, 0.97826086956522, 0.20217391304348, 0.11111111111111
42235, 0.95652173913043, 0.17608695652174, 0.11111111111111
42236, 0.95652173913044, 0.20217391304348, 0.13888888888889
42237, 0.97826086956522, 0.20217391304348, 0.16666666666667
42238, 0.95652173913043, 0.17608695652174, 0.16666666666667
42239, 0.95652173913044, 0.20217391304348, 0.19444444444444
42240, 0.97826086956522, 0.20217391304348, 0.22222222222222
42241, 0.95652173913044, 0.17608695652174, 0.22222222222222
42242, 0.95652173913044, 0.20217391304348, 0.25
42243, 0.97826086956522, 0.20217391304348, 0.27777777777778
42244, 0.95652173913043, 0.17608695652174, 0.27777777777778
42245, 0.95652173913044, 0.20217391304348, 0.30555555555556
42246, 0.97826086956522, 0.20217391304348, 0.33333333333333
42247, 0.95652173913043, 0.17608695652174, 0.33333333333333
42248, 0.95652173913044, 0.20217391304348, 0.36111111111111
42249, 0.97826086956522, 0.20217391304348, 0.38888888888889
42250, 0.95652173913043, 0.17608695652174, 0.38888888888889
42251, 0.95652173913044, 0.20217391304348, 0.41666666666667
42252, 0.97826086956522, 0.20217391304348, 0.44444444444444
42253, 0.95652173913043, 0.17608695652174, 0.44444444444444
42254, 0.95652173913043, 0.20217391304348, 0.47222222222222
42255, 0.91304347826087, 0.20217391304348, 0.027777777777778
42256, 0.93478260869565, 0.20217391304348, 0.055555555555556
42257, 0.91304347826087, 0.17608695652174, 0.055555555555556
42258, 0.91304347826087, 0.20217391304348, 0.083333333333333
42259, 0.93478260869565, 0.20217391304348, 0.11111111111111
42260, 0.91304347826087, 0.17608695652174, 0.11111111111111
42261, 0.91304347826087, 0.20217391304348, 0.13888888888889
42262, 0.93478260869565, 0.20217391304348, 0.16666666666667
42263, 0.91304347826087, 0.17608695652174, 0.16666666666667
42264, 0.91304347826087, 0.20217391304348, 0.19444444444444
42265, 0.93478260869565, 0.20217391304348, 0.22222222222222
42266, 0.91304347826087, 0.17608695652174, 0.22222222222222
42267, 0.91304347826087, 0.20217391304348, 0.25
42268, 0.93478260869565, 0.20217391304348, 0.27777777777778
42269, 0.91304347826087, 0.17608695652174, 0.27777777777778
42270, 0.91304347826087, 0.20217391304348, 0.30555555555556
42271, 0.93478260869565, 0.20217391304348, 0.33333333333333
42272, 0.91304347826087, 0.17608695652174, 0.33333333333333
42273, 0.91304347826087, 0.20217391304348, 0.36111111111111
42274, 0.93478260869565, 0.20217391304348, 0.38888888888889
42275, 0.91304347826087, 0.17608695652174, 0.38888888888889
42276, 0.91304347826087, 0.20217391304348, 0.41666666666667
42277, 0.93478260869565, 0.20217391304348, 0.44444444444444
42278, 0.91304347826087, 0.17608695652174, 0.44444444444444
42279, 0.91304347826087, 0.20217391304348, 0.47222222222222
42280, 0.8695652173913, 0.20217391304348, 0.027777777777778
42281, 0.89130434782609, 0.20217391304348, 0.055555555555556
42282, 0.8695652173913, 0.17608695652174, 0.055555555555556
42283, 0.8695652173913, 0.20217391304348, 0.083333333333333
42284, 0.89130434782609, 0.20217391304348, 0.11111111111111
42285, 0.8695652173913, 0.17608695652174, 0.11111111111111
42286, 0.8695652173913, 0.20217391304348, 0.13888888888889
42287, 0.89130434782609, 0.20217391304348, 0.16666666666667
42288, 0.8695652173913, 0.17608695652174, 0.16666666666667
42289, 0.8695652173913, 0.20217391304348, 0.19444444444444
42290, 0.89130434782609, 0.20217391304348, 0.22222222222222
42291, 0.8695652173913, 0.17608695652174, 0.22222222222222
42292, 0.8695652173913, 0.20217391304348, 0.25
42293, 0.89130434782609, 0.20217391304348, 0.27777777777778
42294, 0.8695652173913, 0.17608695652174, 0.27777777777778
42295, 0.8695652173913, 0.20217391304348, 0.30555555555556
42296, 0.89130434782609, 0.20217391304348, 0.33333333333333
42297, 0.8695652173913, 0.17608695652174, 0.33333333333333
42298, 0.8695652173913, 0.20217391304348, 0.36111111111111
42299, 0.89130434782609, 0.20217391304348, 0.38888888888889
42300, 0.8695652173913, 0.17608695652174, 0.38888888888889
42301, 0.8695652173913, 0.20217391304348, 0.41666666666667
42302, 0.89130434782609, 0.20217391304348, 0.44444444444444
42303, 0.8695652173913, 0.17608695652174, 0.44444444444444
42304, 0.8695652173913, 0.20217391304348, 0.47222222222222
42305, 0.82608695652174, 0.20217391304348, 0.027777777777778
42306, 0.84782608695652, 0.20217391304348, 0.055555555555556
42307, 0.82608695652174, 0.17608695652174, 0.055555555555556
42308, 0.82608695652174, 0.20217391304348, 0.083333333333333
42309, 0.84782608695652, 0.20217391304348, 0.11111111111111
42310, 0.82608695652174, 0.17608695652174, 0.11111111111111
42311, 0.82608695652174, 0.20217391304348, 0.13888888888889
42312, 0.84782608695652, 0.20217391304348, 0.16666666666667
42313, 0.82608695652174, 0.17608695652174, 0.16666666666667
42314, 0.82608695652174, 0.20217391304348, 0.19444444444444
42315, 0.84782608695652, 0.20217391304348, 0.22222222222222
42316, 0.82608695652174, 0.17608695652174, 0.22222222222222
42317, 0.82608695652174, 0.20217391304348, 0.25
42318, 0.84782608695652, 0.20217391304348, 0.27777777777778
42319, 0.82608695652174, 0.17608695652174, 0.27777777777778
42320, 0.82608695652174, 0.20217391304348, 0.30555555555556
42321, 0.84782608695652, 0.20217391304348, 0.33333333333333
42322, 0.82608695652174, 0.17608695652174, 0.33333333333333
42323, 0.82608695652174, 0.20217391304348, 0.36111111111111
42324, 0.84782608695652, 0.20217391304348, 0.38888888888889
42325, 0.82608695652174, 0.17608695652174, 0.38888888888889
42326, 0.82608695652174, 0.20217391304348, 0.41666666666667
42327, 0.84782608695652, 0.20217391304348, 0.44444444444444
42328, 0.82608695652174, 0.17608695652174, 0.44444444444444
42329, 0.82608695652174, 0.20217391304348, 0.47222222222222
42330, 0.78260869565217, 0.20217391304348, 0.027777777777778
42331, 0.80434782608696, 0.20217391304348, 0.055555555555556
42332, 0.78260869565217, 0.17608695652174, 0.055555555555556
42333, 0.78260869565217, 0.20217391304348, 0.083333333333333
42334, 0.80434782608696, 0.20217391304348, 0.11111111111111
42335, 0.78260869565217, 0.17608695652174, 0.11111111111111
42336, 0.78260869565217, 0.20217391304348, 0.13888888888889
42337, 0.80434782608696, 0.20217391304348, 0.16666666666667
42338, 0.78260869565217, 0.17608695652174, 0.16666666666667
42339, 0.78260869565217, 0.20217391304348, 0.19444444444444
42340, 0.80434782608696, 0.20217391304348, 0.22222222222222
42341, 0.78260869565217, 0.17608695652174, 0.22222222222222
42342, 0.78260869565217, 0.20217391304348, 0.25
42343, 0.80434782608696, 0.20217391304348, 0.27777777777778
42344, 0.78260869565217, 0.17608695652174, 0.27777777777778
42345, 0.78260869565217, 0.20217391304348, 0.30555555555556
42346, 0.80434782608696, 0.20217391304348, 0.33333333333333
42347, 0.78260869565217, 0.17608695652174, 0.33333333333333
42348, 0.78260869565217, 0.20217391304348, 0.36111111111111
42349, 0.80434782608696, 0.20217391304348, 0.38888888888889
42350, 0.78260869565217, 0.17608695652174, 0.38888888888889
42351, 0.78260869565217, 0.20217391304348, 0.41666666666667
42352, 0.80434782608696, 0.20217391304348, 0.44444444444444
42353, 0.78260869565217, 0.17608695652174, 0.44444444444444
42354, 0.78260869565217, 0.20217391304348, 0.47222222222222
42355, 0.73913043478261, 0.20217391304348, 0.027777777777778
42356, 0.76086956521739, 0.20217391304348, 0.055555555555556
42357, 0.73913043478261, 0.17608695652174, 0.055555555555556
42358, 0.73913043478261, 0.20217391304348, 0.083333333333333
42359, 0.76086956521739, 0.20217391304348, 0.11111111111111
42360, 0.73913043478261, 0.17608695652174, 0.11111111111111
42361, 0.73913043478261, 0.20217391304348, 0.13888888888889
42362, 0.76086956521739, 0.20217391304348, 0.16666666666667
42363, 0.73913043478261, 0.17608695652174, 0.16666666666667
42364, 0.73913043478261, 0.20217391304348, 0.19444444444444
42365, 0.76086956521739, 0.20217391304348, 0.22222222222222
42366, 0.73913043478261, 0.17608695652174, 0.22222222222222
42367, 0.73913043478261, 0.20217391304348, 0.25
42368, 0.76086956521739, 0.20217391304348, 0.27777777777778
42369, 0.73913043478261, 0.17608695652174, 0.27777777777778
42370, 0.73913043478261, 0.20217391304348, 0.30555555555556
42371, 0.76086956521739, 0.20217391304348, 0.33333333333333
42372, 0.73913043478261, 0.17608695652174, 0.33333333333333
42373, 0.73913043478261, 0.20217391304348, 0.36111111111111
42374, 0.76086956521739, 0.20217391304348, 0.38888888888889
42375, 0.73913043478261, 0.17608695652174, 0.38888888888889
42376, 0.73913043478261, 0.20217391304348, 0.41666666666667
42377, 0.76086956521739, 0.20217391304348, 0.44444444444444
42378, 0.73913043478261, 0.17608695652174, 0.44444444444444
42379, 0.73913043478261, 0.20217391304348, 0.47222222222222
42380, 0.69565217391304, 0.20217391304348, 0.027777777777778
42381, 0.71739130434783, 0.20217391304348, 0.055555555555556
42382, 0.69565217391304, 0.17608695652174, 0.055555555555556
42383, 0.69565217391304, 0.20217391304348, 0.083333333333333
42384, 0.71739130434783, 0.20217391304348, 0.11111111111111
42385, 0.69565217391304, 0.17608695652174, 0.11111111111111
42386, 0.69565217391304, 0.20217391304348, 0.13888888888889
42387, 0.71739130434783, 0.20217391304348, 0.16666666666667
42388, 0.69565217391304, 0.17608695652174, 0.16666666666667
42389, 0.69565217391304, 0.20217391304348, 0.19444444444444
42390, 0.71739130434783, 0.20217391304348, 0.22222222222222
42391, 0.69565217391304, 0.17608695652174, 0.22222222222222
42392, 0.69565217391304, 0.20217391304348, 0.25
42393, 0.71739130434783, 0.20217391304348, 0.27777777777778
42394, 0.69565217391304, 0.17608695652174, 0.27777777777778
42395, 0.69565217391304, 0.20217391304348, 0.30555555555556
42396, 0.71739130434783, 0.20217391304348, 0.33333333333333
42397, 0.69565217391304, 0.17608695652174, 0.33333333333333
42398, 0.69565217391304, 0.20217391304348, 0.36111111111111
42399, 0.71739130434783, 0.20217391304348, 0.38888888888889
42400, 0.69565217391304, 0.17608695652174, 0.38888888888889
42401, 0.69565217391304, 0.20217391304348, 0.41666666666667
42402, 0.71739130434783, 0.20217391304348, 0.44444444444444
42403, 0.69565217391304, 0.17608695652174, 0.44444444444444
42404, 0.69565217391304, 0.20217391304348, 0.47222222222222
42405, 0.65217391304348, 0.20217391304348, 0.027777777777778
42406, 0.67391304347826, 0.20217391304348, 0.055555555555556
42407, 0.65217391304348, 0.17608695652174, 0.055555555555556
42408, 0.65217391304348, 0.20217391304348, 0.083333333333333
42409, 0.67391304347826, 0.20217391304348, 0.11111111111111
42410, 0.65217391304348, 0.17608695652174, 0.11111111111111
42411, 0.65217391304348, 0.20217391304348, 0.13888888888889
42412, 0.67391304347826, 0.20217391304348, 0.16666666666667
42413, 0.65217391304348, 0.17608695652174, 0.16666666666667
42414, 0.65217391304348, 0.20217391304348, 0.19444444444444
42415, 0.67391304347826, 0.20217391304348, 0.22222222222222
42416, 0.65217391304348, 0.17608695652174, 0.22222222222222
42417, 0.65217391304348, 0.20217391304348, 0.25
42418, 0.67391304347826, 0.20217391304348, 0.27777777777778
42419, 0.65217391304348, 0.17608695652174, 0.27777777777778
42420, 0.65217391304348, 0.20217391304348, 0.30555555555556
42421, 0.67391304347826, 0.20217391304348, 0.33333333333333
42422, 0.65217391304348, 0.17608695652174, 0.33333333333333
42423, 0.65217391304348, 0.20217391304348, 0.36111111111111
42424, 0.67391304347826, 0.20217391304348, 0.38888888888889
42425, 0.65217391304348, 0.17608695652174, 0.38888888888889
42426, 0.65217391304348, 0.20217391304348, 0.41666666666667
42427, 0.67391304347826, 0.20217391304348, 0.44444444444444
42428, 0.65217391304348, 0.17608695652174, 0.44444444444444
42429, 0.65217391304348, 0.20217391304348, 0.47222222222222
42430, 0.60869565217391, 0.20217391304348, 0.027777777777778
42431, 0.6304347826087, 0.20217391304348, 0.055555555555556
42432, 0.60869565217391, 0.17608695652174, 0.055555555555556
42433, 0.60869565217391, 0.20217391304348, 0.083333333333333
42434, 0.6304347826087, 0.20217391304348, 0.11111111111111
42435, 0.60869565217391, 0.17608695652174, 0.11111111111111
42436, 0.60869565217391, 0.20217391304348, 0.13888888888889
42437, 0.6304347826087, 0.20217391304348, 0.16666666666667
42438, 0.60869565217391, 0.17608695652174, 0.16666666666667
42439, 0.60869565217391, 0.20217391304348, 0.19444444444444
42440, 0.6304347826087, 0.20217391304348, 0.22222222222222
42441, 0.60869565217391, 0.17608695652174, 0.22222222222222
42442, 0.60869565217391, 0.20217391304348, 0.25
42443, 0.6304347826087, 0.20217391304348, 0.27777777777778
42444, 0.60869565217391, 0.17608695652174, 0.27777777777778
42445, 0.60869565217391, 0.20217391304348, 0.30555555555556
42446, 0.6304347826087, 0.20217391304348, 0.33333333333333
42447, 0.60869565217391, 0.17608695652174, 0.33333333333333
42448, 0.60869565217391, 0.20217391304348, 0.36111111111111
42449, 0.6304347826087, 0.20217391304348, 0.38888888888889
42450, 0.60869565217391, 0.17608695652174, 0.38888888888889
42451, 0.60869565217391, 0.20217391304348, 0.41666666666667
42452, 0.6304347826087, 0.20217391304348, 0.44444444444444
42453, 0.60869565217391, 0.17608695652174, 0.44444444444444
42454, 0.60869565217391, 0.20217391304348, 0.47222222222222
42455, 0.56521739130435, 0.20217391304348, 0.027777777777778
42456, 0.58695652173913, 0.20217391304348, 0.055555555555556
42457, 0.56521739130435, 0.17608695652174, 0.055555555555556
42458, 0.56521739130435, 0.20217391304348, 0.083333333333333
42459, 0.58695652173913, 0.20217391304348, 0.11111111111111
42460, 0.56521739130435, 0.17608695652174, 0.11111111111111
42461, 0.56521739130435, 0.20217391304348, 0.13888888888889
42462, 0.58695652173913, 0.20217391304348, 0.16666666666667
42463, 0.56521739130435, 0.17608695652174, 0.16666666666667
42464, 0.56521739130435, 0.20217391304348, 0.19444444444444
42465, 0.58695652173913, 0.20217391304348, 0.22222222222222
42466, 0.56521739130435, 0.17608695652174, 0.22222222222222
42467, 0.56521739130435, 0.20217391304348, 0.25
42468, 0.58695652173913, 0.20217391304348, 0.27777777777778
42469, 0.56521739130435, 0.17608695652174, 0.27777777777778
42470, 0.56521739130435, 0.20217391304348, 0.30555555555556
42471, 0.58695652173913, 0.20217391304348, 0.33333333333333
42472, 0.56521739130435, 0.17608695652174, 0.33333333333333
42473, 0.56521739130435, 0.20217391304348, 0.36111111111111
42474, 0.58695652173913, 0.20217391304348, 0.38888888888889
42475, 0.56521739130435, 0.17608695652174, 0.38888888888889
42476, 0.56521739130435, 0.20217391304348, 0.41666666666667
42477, 0.58695652173913, 0.20217391304348, 0.44444444444444
42478, 0.56521739130435, 0.17608695652174, 0.44444444444444
42479, 0.56521739130435, 0.20217391304348, 0.47222222222222
42480, 0.52173913043478, 0.20217391304348, 0.027777777777778
42481, 0.54347826086957, 0.20217391304348, 0.055555555555556
42482, 0.52173913043478, 0.17608695652174, 0.055555555555556
42483, 0.52173913043478, 0.20217391304348, 0.083333333333333
42484, 0.54347826086956, 0.20217391304348, 0.11111111111111
42485, 0.52173913043478, 0.17608695652174, 0.11111111111111
42486, 0.52173913043478, 0.20217391304348, 0.13888888888889
42487, 0.54347826086957, 0.20217391304348, 0.16666666666667
42488, 0.52173913043478, 0.17608695652174, 0.16666666666667
42489, 0.52173913043478, 0.20217391304348, 0.19444444444444
42490, 0.54347826086957, 0.20217391304348, 0.22222222222222
42491, 0.52173913043478, 0.17608695652174, 0.22222222222222
42492, 0.52173913043478, 0.20217391304348, 0.25
42493, 0.54347826086957, 0.20217391304348, 0.27777777777778
42494, 0.52173913043478, 0.17608695652174, 0.27777777777778
42495, 0.52173913043478, 0.20217391304348, 0.30555555555556
42496, 0.54347826086956, 0.20217391304348, 0.33333333333333
42497, 0.52173913043478, 0.17608695652174, 0.33333333333333
42498, 0.52173913043478, 0.20217391304348, 0.36111111111111
42499, 0.54347826086957, 0.20217391304348, 0.38888888888889
42500, 0.52173913043478, 0.17608695652174, 0.38888888888889
42501, 0.52173913043478, 0.20217391304348, 0.41666666666667
42502, 0.54347826086956, 0.20217391304348, 0.44444444444444
42503, 0.52173913043478, 0.17608695652174, 0.44444444444444
42504, 0.52173913043478, 0.20217391304348, 0.47222222222222
42505, 0.47826086956522, 0.20217391304348, 0.027777777777778
42506, 0.5, 0.20217391304348, 0.055555555555556
42507, 0.47826086956522, 0.17608695652174, 0.055555555555556
42508, 0.47826086956522, 0.20217391304348, 0.083333333333333
42509, 0.5, 0.20217391304348, 0.11111111111111
42510, 0.47826086956522, 0.17608695652174, 0.11111111111111
42511, 0.47826086956522, 0.20217391304348, 0.13888888888889
42512, 0.5, 0.20217391304348, 0.16666666666667
42513, 0.47826086956522, 0.17608695652174, 0.16666666666667
42514, 0.47826086956522, 0.20217391304348, 0.19444444444444
42515, 0.5, 0.20217391304348, 0.22222222222222
42516, 0.47826086956522, 0.17608695652174, 0.22222222222222
42517, 0.47826086956522, 0.20217391304348, 0.25
42518, 0.5, 0.20217391304348, 0.27777777777778
42519, 0.47826086956522, 0.17608695652174, 0.27777777777778
42520, 0.47826086956522, 0.20217391304348, 0.30555555555556
42521, 0.5, 0.20217391304348, 0.33333333333333
42522, 0.47826086956522, 0.17608695652174, 0.33333333333333
42523, 0.47826086956522, 0.20217391304348, 0.36111111111111
42524, 0.5, 0.20217391304348, 0.38888888888889
42525, 0.47826086956522, 0.17608695652174, 0.38888888888889
42526, 0.47826086956522, 0.20217391304348, 0.41666666666667
42527, 0.5, 0.20217391304348, 0.44444444444444
42528, 0.47826086956522, 0.17608695652174, 0.44444444444444
42529, 0.47826086956522, 0.20217391304348, 0.47222222222222
42530, 0.43478260869565, 0.20217391304348, 0.027777777777778
42531, 0.45652173913043, 0.20217391304348, 0.055555555555556
42532, 0.43478260869565, 0.17608695652174, 0.055555555555556
42533, 0.43478260869565, 0.20217391304348, 0.083333333333333
42534, 0.45652173913043, 0.20217391304348, 0.11111111111111
42535, 0.43478260869565, 0.17608695652174, 0.11111111111111
42536, 0.43478260869565, 0.20217391304348, 0.13888888888889
42537, 0.45652173913043, 0.20217391304348, 0.16666666666667
42538, 0.43478260869565, 0.17608695652174, 0.16666666666667
42539, 0.43478260869565, 0.20217391304348, 0.19444444444444
42540, 0.45652173913043, 0.20217391304348, 0.22222222222222
42541, 0.43478260869565, 0.17608695652174, 0.22222222222222
42542, 0.43478260869565, 0.20217391304348, 0.25
42543, 0.45652173913043, 0.20217391304348, 0.27777777777778
42544, 0.43478260869565, 0.17608695652174, 0.27777777777778
42545, 0.43478260869565, 0.20217391304348, 0.30555555555556
42546, 0.45652173913043, 0.20217391304348, 0.33333333333333
42547, 0.43478260869565, 0.17608695652174, 0.33333333333333
42548, 0.43478260869565, 0.20217391304348, 0.36111111111111
42549, 0.45652173913043, 0.20217391304348, 0.38888888888889
42550, 0.43478260869565, 0.17608695652174, 0.38888888888889
42551, 0.43478260869565, 0.20217391304348, 0.41666666666667
42552, 0.45652173913043, 0.20217391304348, 0.44444444444444
42553, 0.43478260869565, 0.17608695652174, 0.44444444444444
42554, 0.43478260869565, 0.20217391304348, 0.47222222222222
42555, 0.39130434782609, 0.20217391304348, 0.027777777777778
42556, 0.41304347826087, 0.20217391304348, 0.055555555555556
42557, 0.39130434782609, 0.17608695652174, 0.055555555555556
42558, 0.39130434782609, 0.20217391304348, 0.083333333333333
42559, 0.41304347826087, 0.20217391304348, 0.11111111111111
42560, 0.39130434782609, 0.17608695652174, 0.11111111111111
42561, 0.39130434782609, 0.20217391304348, 0.13888888888889
42562, 0.41304347826087, 0.20217391304348, 0.16666666666667
42563, 0.39130434782609, 0.17608695652174, 0.16666666666667
42564, 0.39130434782609, 0.20217391304348, 0.19444444444444
42565, 0.41304347826087, 0.20217391304348, 0.22222222222222
42566, 0.39130434782609, 0.17608695652174, 0.22222222222222
42567, 0.39130434782609, 0.20217391304348, 0.25
42568, 0.41304347826087, 0.20217391304348, 0.27777777777778
42569, 0.39130434782609, 0.17608695652174, 0.27777777777778
42570, 0.39130434782609, 0.20217391304348, 0.30555555555556
42571, 0.41304347826087, 0.20217391304348, 0.33333333333333
42572, 0.39130434782609, 0.17608695652174, 0.33333333333333
42573, 0.39130434782609, 0.20217391304348, 0.36111111111111
42574, 0.41304347826087, 0.20217391304348, 0.38888888888889
42575, 0.39130434782609, 0.17608695652174, 0.38888888888889
42576, 0.39130434782609, 0.20217391304348, 0.41666666666667
42577, 0.41304347826087, 0.20217391304348, 0.44444444444444
42578, 0.39130434782609, 0.17608695652174, 0.44444444444444
42579, 0.39130434782609, 0.20217391304348, 0.47222222222222
42580, 0.34782608695652, 0.20217391304348, 0.027777777777778
42581, 0.3695652173913, 0.20217391304348, 0.055555555555556
42582, 0.34782608695652, 0.17608695652174, 0.055555555555556
42583, 0.34782608695652, 0.20217391304348, 0.083333333333333
42584, 0.3695652173913, 0.20217391304348, 0.11111111111111
42585, 0.34782608695652, 0.17608695652174, 0.11111111111111
42586, 0.34782608695652, 0.20217391304348, 0.13888888888889
42587, 0.3695652173913, 0.20217391304348, 0.16666666666667
42588, 0.34782608695652, 0.17608695652174, 0.16666666666667
42589, 0.34782608695652, 0.20217391304348, 0.19444444444444
42590, 0.3695652173913, 0.20217391304348, 0.22222222222222
42591, 0.34782608695652, 0.17608695652174, 0.22222222222222
42592, 0.34782608695652, 0.20217391304348, 0.25
42593, 0.3695652173913, 0.20217391304348, 0.27777777777778
42594, 0.34782608695652, 0.17608695652174, 0.27777777777778
42595, 0.34782608695652, 0.20217391304348, 0.30555555555556
42596, 0.3695652173913, 0.20217391304348, 0.33333333333333
42597, 0.34782608695652, 0.17608695652174, 0.33333333333333
42598, 0.34782608695652, 0.20217391304348, 0.36111111111111
42599, 0.3695652173913, 0.20217391304348, 0.38888888888889
42600, 0.34782608695652, 0.17608695652174, 0.38888888888889
42601, 0.34782608695652, 0.20217391304348, 0.41666666666667
42602, 0.3695652173913, 0.20217391304348, 0.44444444444444
42603, 0.34782608695652, 0.17608695652174, 0.44444444444444
42604, 0.34782608695652, 0.20217391304348, 0.47222222222222
42605, 0.30434782608696, 0.20217391304348, 0.027777777777778
42606, 0.32608695652174, 0.20217391304348, 0.055555555555556
42607, 0.30434782608696, 0.17608695652174, 0.055555555555556
42608, 0.30434782608696, 0.20217391304348, 0.083333333333333
42609, 0.32608695652174, 0.20217391304348, 0.11111111111111
42610, 0.30434782608696, 0.17608695652174, 0.11111111111111
42611, 0.30434782608696, 0.20217391304348, 0.13888888888889
42612, 0.32608695652174, 0.20217391304348, 0.16666666666667
42613, 0.30434782608696, 0.17608695652174, 0.16666666666667
42614, 0.30434782608696, 0.20217391304348, 0.19444444444444
42615, 0.32608695652174, 0.20217391304348, 0.22222222222222
42616, 0.30434782608696, 0.17608695652174, 0.22222222222222
42617, 0.30434782608696, 0.20217391304348, 0.25
42618, 0.32608695652174, 0.20217391304348, 0.27777777777778
42619, 0.30434782608696, 0.17608695652174, 0.27777777777778
42620, 0.30434782608696, 0.20217391304348, 0.30555555555556
42621, 0.32608695652174, 0.20217391304348, 0.33333333333333
42622, 0.30434782608696, 0.17608695652174, 0.33333333333333
42623, 0.30434782608696, 0.20217391304348, 0.36111111111111
42624, 0.32608695652174, 0.20217391304348, 0.38888888888889
42625, 0.30434782608696, 0.17608695652174, 0.38888888888889
42626, 0.30434782608696, 0.20217391304348, 0.41666666666667
42627, 0.32608695652174, 0.20217391304348, 0.44444444444444
42628, 0.30434782608696, 0.17608695652174, 0.44444444444444
42629, 0.30434782608696, 0.20217391304348, 0.47222222222222
42630, 0.26086956521739, 0.20217391304348, 0.027777777777778
42631, 0.28260869565217, 0.20217391304348, 0.055555555555556
42632, 0.26086956521739, 0.17608695652174, 0.055555555555556
42633, 0.26086956521739, 0.20217391304348, 0.083333333333333
42634, 0.28260869565217, 0.20217391304348, 0.11111111111111
42635, 0.26086956521739, 0.17608695652174, 0.11111111111111
42636, 0.26086956521739, 0.20217391304348, 0.13888888888889
42637, 0.28260869565217, 0.20217391304348, 0.16666666666667
42638, 0.26086956521739, 0.17608695652174, 0.16666666666667
42639, 0.26086956521739, 0.20217391304348, 0.19444444444444
42640, 0.28260869565217, 0.20217391304348, 0.22222222222222
42641, 0.26086956521739, 0.17608695652174, 0.22222222222222
42642, 0.26086956521739, 0.20217391304348, 0.25
42643, 0.28260869565217, 0.20217391304348, 0.27777777777778
42644, 0.26086956521739, 0.17608695652174, 0.27777777777778
42645, 0.26086956521739, 0.20217391304348, 0.30555555555556
42646, 0.28260869565217, 0.20217391304348, 0.33333333333333
42647, 0.26086956521739, 0.17608695652174, 0.33333333333333
42648, 0.26086956521739, 0.20217391304348, 0.36111111111111
42649, 0.28260869565217, 0.20217391304348, 0.38888888888889
42650, 0.26086956521739, 0.17608695652174, 0.38888888888889
42651, 0.26086956521739, 0.20217391304348, 0.41666666666667
42652, 0.28260869565217, 0.20217391304348, 0.44444444444444
42653, 0.26086956521739, 0.17608695652174, 0.44444444444444
42654, 0.26086956521739, 0.20217391304348, 0.47222222222222
42655, 0.21739130434783, 0.20217391304348, 0.027777777777778
42656, 0.23913043478261, 0.20217391304348, 0.055555555555556
42657, 0.21739130434783, 0.17608695652174, 0.055555555555556
42658, 0.21739130434783, 0.20217391304348, 0.083333333333333
42659, 0.23913043478261, 0.20217391304348, 0.11111111111111
42660, 0.21739130434783, 0.17608695652174, 0.11111111111111
42661, 0.21739130434783, 0.20217391304348, 0.13888888888889
42662, 0.23913043478261, 0.20217391304348, 0.16666666666667
42663, 0.21739130434783, 0.17608695652174, 0.16666666666667
42664, 0.21739130434783, 0.20217391304348, 0.19444444444444
42665, 0.23913043478261, 0.20217391304348, 0.22222222222222
42666, 0.21739130434783, 0.17608695652174, 0.22222222222222
42667, 0.21739130434783, 0.20217391304348, 0.25
42668, 0.23913043478261, 0.20217391304348, 0.27777777777778
42669, 0.21739130434783, 0.17608695652174, 0.27777777777778
42670, 0.21739130434783, 0.20217391304348, 0.30555555555556
42671, 0.23913043478261, 0.20217391304348, 0.33333333333333
42672, 0.21739130434783, 0.17608695652174, 0.33333333333333
42673, 0.21739130434783, 0.20217391304348, 0.36111111111111
42674, 0.23913043478261, 0.20217391304348, 0.38888888888889
42675, 0.21739130434783, 0.17608695652174, 0.38888888888889
42676, 0.21739130434783, 0.20217391304348, 0.41666666666667
42677, 0.23913043478261, 0.20217391304348, 0.44444444444444
42678, 0.21739130434783, 0.17608695652174, 0.44444444444444
42679, 0.21739130434783, 0.20217391304348, 0.47222222222222
42680, 0.17391304347826, 0.20217391304348, 0.027777777777778
42681, 0.19565217391304, 0.20217391304348, 0.055555555555556
42682, 0.17391304347826, 0.17608695652174, 0.055555555555556
42683, 0.17391304347826, 0.20217391304348, 0.083333333333333
42684, 0.19565217391304, 0.20217391304348, 0.11111111111111
42685, 0.17391304347826, 0.17608695652174, 0.11111111111111
42686, 0.17391304347826, 0.20217391304348, 0.13888888888889
42687, 0.19565217391304, 0.20217391304348, 0.16666666666667
42688, 0.17391304347826, 0.17608695652174, 0.16666666666667
42689, 0.17391304347826, 0.20217391304348, 0.19444444444444
42690, 0.19565217391304, 0.20217391304348, 0.22222222222222
42691, 0.17391304347826, 0.17608695652174, 0.22222222222222
42692, 0.17391304347826, 0.20217391304348, 0.25
42693, 0.19565217391304, 0.20217391304348, 0.27777777777778
42694, 0.17391304347826, 0.17608695652174, 0.27777777777778
42695, 0.17391304347826, 0.20217391304348, 0.30555555555556
42696, 0.19565217391304, 0.20217391304348, 0.33333333333333
42697, 0.17391304347826, 0.17608695652174, 0.33333333333333
42698, 0.17391304347826, 0.20217391304348, 0.36111111111111
42699, 0.19565217391304, 0.20217391304348, 0.38888888888889
42700, 0.17391304347826, 0.17608695652174, 0.38888888888889
42701, 0.17391304347826, 0.20217391304348, 0.41666666666667
42702, 0.19565217391304, 0.20217391304348, 0.44444444444444
42703, 0.17391304347826, 0.17608695652174, 0.44444444444444
42704, 0.17391304347826, 0.20217391304348, 0.47222222222222
42705, 0.1304347826087, 0.20217391304348, 0.027777777777778
42706, 0.15217391304348, 0.20217391304348, 0.055555555555556
42707, 0.1304347826087, 0.17608695652174, 0.055555555555556
42708, 0.1304347826087, 0.20217391304348, 0.083333333333333
42709, 0.15217391304348, 0.20217391304348, 0.11111111111111
42710, 0.1304347826087, 0.17608695652174, 0.11111111111111
42711, 0.1304347826087, 0.20217391304348, 0.13888888888889
42712, 0.15217391304348, 0.20217391304348, 0.16666666666667
42713, 0.1304347826087, 0.17608695652174, 0.16666666666667
42714, 0.1304347826087, 0.20217391304348, 0.19444444444444
42715, 0.15217391304348, 0.20217391304348, 0.22222222222222
42716, 0.1304347826087, 0.17608695652174, 0.22222222222222
42717, 0.1304347826087, 0.20217391304348, 0.25
42718, 0.15217391304348, 0.20217391304348, 0.27777777777778
42719, 0.1304347826087, 0.17608695652174, 0.27777777777778
42720, 0.1304347826087, 0.20217391304348, 0.30555555555556
42721, 0.15217391304348, 0.20217391304348, 0.33333333333333
42722, 0.1304347826087, 0.17608695652174, 0.33333333333333
42723, 0.1304347826087, 0.20217391304348, 0.36111111111111
42724, 0.15217391304348, 0.20217391304348, 0.38888888888889
42725, 0.1304347826087, 0.17608695652174, 0.38888888888889
42726, 0.1304347826087, 0.20217391304348, 0.41666666666667
42727, 0.15217391304348, 0.20217391304348, 0.44444444444444
42728, 0.1304347826087, 0.17608695652174, 0.44444444444444
42729, 0.1304347826087, 0.20217391304348, 0.47222222222222
42730, 0.08695652173913, 0.20217391304348, 0.027777777777778
42731, 0.10869565217391, 0.20217391304348, 0.055555555555556
