37565, 0.34782608695652, 0.125, 0.33333333333333
37566, 0.34782608695652, 0.125, 0.38888888888889
37567, 0.34782608695652, 0.125, 0.44444444444444
37568, 0.30434782608696, 0.125, 0.055555555555556
37569, 0.30434782608696, 0.125, 0.11111111111111
37570, 0.30434782608696, 0.125, 0.16666666666667
37571, 0.30434782608696, 0.125, 0.22222222222222
37572, 0.30434782608696, 0.125, 0.27777777777778
37573, 0.30434782608696, 0.125, 0.33333333333333
37574, 0.30434782608696, 0.125, 0.38888888888889
37575, 0.30434782608696, 0.125, 0.44444444444444
37576, 0.26086956521739, 0.125, 0.055555555555556
37577, 0.26086956521739, 0.125, 0.11111111111111
37578, 0.26086956521739, 0.125, 0.16666666666667
37579, 0.26086956521739, 0.125, 0.22222222222222
37580, 0.26086956521739, 0.125, 0.27777777777778
37581, 0.26086956521739, 0.125, 0.33333333333333
37582, 0.26086956521739, 0.125, 0.38888888888889
37583, 0.26086956521739, 0.125, 0.44444444444444
37584, 0.21739130434783, 0.125, 0.055555555555556
37585, 0.21739130434783, 0.125, 0.11111111111111
37586, 0.21739130434783, 0.125, 0.16666666666667
37587, 0.21739130434783, 0.125, 0.22222222222222
37588, 0.21739130434783, 0.125, 0.27777777777778
37589, 0.21739130434783, 0.125, 0.33333333333333
37590, 0.21739130434783, 0.125, 0.38888888888889
37591, 0.21739130434783, 0.125, 0.44444444444444
37592, 0.17391304347826, 0.125, 0.055555555555556
37593, 0.17391304347826, 0.125, 0.11111111111111
37594, 0.17391304347826, 0.125, 0.16666666666667
37595, 0.17391304347826, 0.125, 0.22222222222222
37596, 0.17391304347826, 0.125, 0.27777777777778
37597, 0.17391304347826, 0.125, 0.33333333333333
37598, 0.17391304347826, 0.125, 0.38888888888889
37599, 0.17391304347826, 0.125, 0.44444444444444
37600, 0.1304347826087, 0.125, 0.055555555555556
37601, 0.1304347826087, 0.125, 0.11111111111111
37602, 0.1304347826087, 0.125, 0.16666666666667
37603, 0.1304347826087, 0.125, 0.22222222222222
37604, 0.1304347826087, 0.125, 0.27777777777778
37605, 0.1304347826087, 0.125, 0.33333333333333
37606, 0.1304347826087, 0.125, 0.38888888888889
37607, 0.1304347826087, 0.125, 0.44444444444444
37608, 0.08695652173913, 0.125, 0.055555555555556
37609, 0.08695652173913, 0.125, 0.11111111111111
37610, 0.08695652173913, 0.125, 0.16666666666667
37611, 0.08695652173913, 0.125, 0.22222222222222
37612, 0.08695652173913, 0.125, 0.27777777777778
37613, 0.08695652173913, 0.125, 0.33333333333333
37614, 0.08695652173913, 0.125, 0.38888888888889
37615, 0.08695652173913, 0.125, 0.44444444444444
37616, 0.043478260869565, 0.125, 0.055555555555556
37617, 0.043478260869565, 0.125, 0.11111111111111
37618, 0.043478260869565, 0.125, 0.16666666666667
37619, 0.043478260869565, 0.125, 0.22222222222222
37620, 0.043478260869565, 0.125, 0.27777777777778
37621, 0.043478260869565, 0.125, 0.33333333333333
37622, 0.043478260869565, 0.125, 0.38888888888889
37623, 0.043478260869565, 0.125, 0.44444444444444
37624, 0.95652173913043, 0.125, 0.027777777777778
37625, 0.97826086956522, 0.125, 0.055555555555556
37626, 0.95652173913043, 0.1125, 0.055555555555556
37627, 0.95652173913043, 0.125, 0.083333333333333
37628, 0.97826086956522, 0.125, 0.11111111111111
37629, 0.95652173913044, 0.1125, 0.11111111111111
37630, 0.95652173913044, 0.125, 0.13888888888889
37631, 0.97826086956522, 0.125, 0.16666666666667
37632, 0.95652173913044, 0.1125, 0.16666666666667
37633, 0.95652173913044, 0.125, 0.19444444444444
37634, 0.97826086956522, 0.125, 0.22222222222222
37635, 0.95652173913043, 0.1125, 0.22222222222222
37636, 0.95652173913044, 0.125, 0.25
37637, 0.97826086956522, 0.125, 0.27777777777778
37638, 0.95652173913043, 0.1125, 0.27777777777778
37639, 0.95652173913044, 0.125, 0.30555555555556
37640, 0.97826086956522, 0.125, 0.33333333333333
37641, 0.95652173913043, 0.1125, 0.33333333333333
37642, 0.95652173913044, 0.125, 0.36111111111111
37643, 0.97826086956522, 0.125, 0.38888888888889
37644, 0.95652173913043, 0.1125, 0.38888888888889
37645, 0.95652173913044, 0.125, 0.41666666666667
37646, 0.97826086956522, 0.125, 0.44444444444444
37647, 0.95652173913043, 0.1125, 0.44444444444444
37648, 0.95652173913043, 0.125, 0.47222222222222
37649, 0.91304347826087, 0.125, 0.027777777777778
37650, 0.93478260869565, 0.125, 0.055555555555556
37651, 0.91304347826087, 0.1125, 0.055555555555556
37652, 0.91304347826087, 0.125, 0.083333333333333
37653, 0.93478260869565, 0.125, 0.11111111111111
37654, 0.91304347826087, 0.1125, 0.11111111111111
37655, 0.91304347826087, 0.125, 0.13888888888889
37656, 0.93478260869565, 0.125, 0.16666666666667
37657, 0.91304347826087, 0.1125, 0.16666666666667
37658, 0.91304347826087, 0.125, 0.19444444444444
37659, 0.93478260869565, 0.125, 0.22222222222222
37660, 0.91304347826087, 0.1125, 0.22222222222222
37661, 0.91304347826087, 0.125, 0.25
37662, 0.93478260869565, 0.125, 0.27777777777778
37663, 0.91304347826087, 0.1125, 0.27777777777778
37664, 0.91304347826087, 0.125, 0.30555555555556
37665, 0.93478260869565, 0.125, 0.33333333333333
37666, 0.91304347826087, 0.1125, 0.33333333333333
37667, 0.91304347826087, 0.125, 0.36111111111111
37668, 0.93478260869565, 0.125, 0.38888888888889
37669, 0.91304347826087, 0.1125, 0.38888888888889
37670, 0.91304347826087, 0.125, 0.41666666666667
37671, 0.93478260869565, 0.125, 0.44444444444444
37672, 0.91304347826087, 0.1125, 0.44444444444444
37673, 0.91304347826087, 0.125, 0.47222222222222
37674, 0.8695652173913, 0.125, 0.027777777777778
37675, 0.89130434782609, 0.125, 0.055555555555556
37676, 0.8695652173913, 0.1125, 0.055555555555556
37677, 0.8695652173913, 0.125, 0.083333333333333
37678, 0.89130434782609, 0.125, 0.11111111111111
37679, 0.8695652173913, 0.1125, 0.11111111111111
37680, 0.8695652173913, 0.125, 0.13888888888889
37681, 0.89130434782609, 0.125, 0.16666666666667
37682, 0.8695652173913, 0.1125, 0.16666666666667
37683, 0.8695652173913, 0.125, 0.19444444444444
37684, 0.89130434782609, 0.125, 0.22222222222222
37685, 0.8695652173913, 0.1125, 0.22222222222222
37686, 0.8695652173913, 0.125, 0.25
37687, 0.89130434782609, 0.125, 0.27777777777778
37688, 0.8695652173913, 0.1125, 0.27777777777778
37689, 0.8695652173913, 0.125, 0.30555555555556
37690, 0.89130434782609, 0.125, 0.33333333333333
37691, 0.8695652173913, 0.1125, 0.33333333333333
37692, 0.8695652173913, 0.125, 0.36111111111111
37693, 0.89130434782609, 0.125, 0.38888888888889
37694, 0.8695652173913, 0.1125, 0.38888888888889
37695, 0.8695652173913, 0.125, 0.41666666666667
37696, 0.89130434782609, 0.125, 0.44444444444444
37697, 0.8695652173913, 0.1125, 0.44444444444444
37698, 0.8695652173913, 0.125, 0.47222222222222
37699, 0.82608695652174, 0.125, 0.027777777777778
37700, 0.84782608695652, 0.125, 0.055555555555556
37701, 0.82608695652174, 0.1125, 0.055555555555556
37702, 0.82608695652174, 0.125, 0.083333333333333
37703, 0.84782608695652, 0.125, 0.11111111111111
37704, 0.82608695652174, 0.1125, 0.11111111111111
37705, 0.82608695652174, 0.125, 0.13888888888889
37706, 0.84782608695652, 0.125, 0.16666666666667
37707, 0.82608695652174, 0.1125, 0.16666666666667
37708, 0.82608695652174, 0.125, 0.19444444444444
37709, 0.84782608695652, 0.125, 0.22222222222222
37710, 0.82608695652174, 0.1125, 0.22222222222222
37711, 0.82608695652174, 0.125, 0.25
37712, 0.84782608695652, 0.125, 0.27777777777778
37713, 0.82608695652174, 0.1125, 0.27777777777778
37714, 0.82608695652174, 0.125, 0.30555555555556
37715, 0.84782608695652, 0.125, 0.33333333333333
37716, 0.82608695652174, 0.1125, 0.33333333333333
37717, 0.82608695652174, 0.125, 0.36111111111111
37718, 0.84782608695652, 0.125, 0.38888888888889
37719, 0.82608695652174, 0.1125, 0.38888888888889
37720, 0.82608695652174, 0.125, 0.41666666666667
37721, 0.84782608695652, 0.125, 0.44444444444444
37722, 0.82608695652174, 0.1125, 0.44444444444444
37723, 0.82608695652174, 0.125, 0.47222222222222
37724, 0.78260869565217, 0.125, 0.027777777777778
37725, 0.80434782608696, 0.125, 0.055555555555556
37726, 0.78260869565217, 0.1125, 0.055555555555556
37727, 0.78260869565217, 0.125, 0.083333333333333
37728, 0.80434782608696, 0.125, 0.11111111111111
37729, 0.78260869565217, 0.1125, 0.11111111111111
37730, 0.78260869565217, 0.125, 0.13888888888889
37731, 0.80434782608696, 0.125, 0.16666666666667
37732, 0.78260869565217, 0.1125, 0.16666666666667
37733, 0.78260869565217, 0.125, 0.19444444444444
37734, 0.80434782608696, 0.125, 0.22222222222222
37735, 0.78260869565217, 0.1125, 0.22222222222222
37736, 0.78260869565217, 0.125, 0.25
37737, 0.80434782608696, 0.125, 0.27777777777778
37738, 0.78260869565217, 0.1125, 0.27777777777778
37739, 0.78260869565217, 0.125, 0.30555555555556
37740, 0.80434782608696, 0.125, 0.33333333333333
37741, 0.78260869565217, 0.1125, 0.33333333333333
37742, 0.78260869565217, 0.125, 0.36111111111111
37743, 0.80434782608696, 0.125, 0.38888888888889
37744, 0.78260869565217, 0.1125, 0.38888888888889
37745, 0.78260869565217, 0.125, 0.41666666666667
37746, 0.80434782608696, 0.125, 0.44444444444444
37747, 0.78260869565217, 0.1125, 0.44444444444444
37748, 0.78260869565217, 0.125, 0.47222222222222
37749, 0.73913043478261, 0.125, 0.027777777777778
37750, 0.76086956521739, 0.125, 0.055555555555556
37751, 0.73913043478261, 0.1125, 0.055555555555556
37752, 0.73913043478261, 0.125, 0.083333333333333
37753, 0.76086956521739, 0.125, 0.11111111111111
37754, 0.73913043478261, 0.1125, 0.11111111111111
37755, 0.73913043478261, 0.125, 0.13888888888889
37756, 0.76086956521739, 0.125, 0.16666666666667
37757, 0.73913043478261, 0.1125, 0.16666666666667
37758, 0.73913043478261, 0.125, 0.19444444444444
37759, 0.76086956521739, 0.125, 0.22222222222222
37760, 0.73913043478261, 0.1125, 0.22222222222222
37761, 0.73913043478261, 0.125, 0.25
37762, 0.76086956521739, 0.125, 0.27777777777778
37763, 0.73913043478261, 0.1125, 0.27777777777778
37764, 0.73913043478261, 0.125, 0.30555555555556
37765, 0.76086956521739, 0.125, 0.33333333333333
37766, 0.73913043478261, 0.1125, 0.33333333333333
37767, 0.73913043478261, 0.125, 0.36111111111111
37768, 0.76086956521739, 0.125, 0.38888888888889
37769, 0.73913043478261, 0.1125, 0.38888888888889
37770, 0.73913043478261, 0.125, 0.41666666666667
37771, 0.76086956521739, 0.125, 0.44444444444444
37772, 0.73913043478261, 0.1125, 0.44444444444444
37773, 0.73913043478261, 0.125, 0.47222222222222
37774, 0.69565217391304, 0.125, 0.027777777777778
37775, 0.71739130434783, 0.125, 0.055555555555556
37776, 0.69565217391304, 0.1125, 0.055555555555556
37777, 0.69565217391304, 0.125, 0.083333333333333
37778, 0.71739130434783, 0.125, 0.11111111111111
37779, 0.69565217391304, 0.1125, 0.11111111111111
37780, 0.69565217391304, 0.125, 0.13888888888889
37781, 0.71739130434783, 0.125, 0.16666666666667
37782, 0.69565217391304, 0.1125, 0.16666666666667
37783, 0.69565217391304, 0.125, 0.19444444444444
37784, 0.71739130434783, 0.125, 0.22222222222222
37785, 0.69565217391304, 0.1125, 0.22222222222222
37786, 0.69565217391304, 0.125, 0.25
37787, 0.71739130434783, 0.125, 0.27777777777778
37788, 0.69565217391304, 0.1125, 0.27777777777778
37789, 0.69565217391304, 0.125, 0.30555555555556
37790, 0.71739130434783, 0.125, 0.33333333333333
37791, 0.69565217391304, 0.1125, 0.33333333333333
37792, 0.69565217391304, 0.125, 0.36111111111111
37793, 0.71739130434783, 0.125, 0.38888888888889
37794, 0.69565217391304, 0.1125, 0.38888888888889
37795, 0.69565217391304, 0.125, 0.41666666666667
37796, 0.71739130434783, 0.125, 0.44444444444444
37797, 0.69565217391304, 0.1125, 0.44444444444444
37798, 0.69565217391304, 0.125, 0.47222222222222
37799, 0.65217391304348, 0.125, 0.027777777777778
37800, 0.67391304347826, 0.125, 0.055555555555556
37801, 0.65217391304348, 0.1125, 0.055555555555556
37802, 0.65217391304348, 0.125, 0.083333333333333
37803, 0.67391304347826, 0.125, 0.11111111111111
37804, 0.65217391304348, 0.1125, 0.11111111111111
37805, 0.65217391304348, 0.125, 0.13888888888889
37806, 0.67391304347826, 0.125, 0.16666666666667
37807, 0.65217391304348, 0.1125, 0.16666666666667
37808, 0.65217391304348, 0.125, 0.19444444444444
37809, 0.67391304347826, 0.125, 0.22222222222222
37810, 0.65217391304348, 0.1125, 0.22222222222222
37811, 0.65217391304348, 0.125, 0.25
37812, 0.67391304347826, 0.125, 0.27777777777778
37813, 0.65217391304348, 0.1125, 0.27777777777778
37814, 0.65217391304348, 0.125, 0.30555555555556
37815, 0.67391304347826, 0.125, 0.33333333333333
37816, 0.65217391304348, 0.1125, 0.33333333333333
37817, 0.65217391304348, 0.125, 0.36111111111111
37818, 0.67391304347826, 0.125, 0.38888888888889
37819, 0.65217391304348, 0.1125, 0.38888888888889
37820, 0.65217391304348, 0.125, 0.41666666666667
37821, 0.67391304347826, 0.125, 0.44444444444444
37822, 0.65217391304348, 0.1125, 0.44444444444444
37823, 0.65217391304348, 0.125, 0.47222222222222
37824, 0.60869565217391, 0.125, 0.027777777777778
37825, 0.6304347826087, 0.125, 0.055555555555556
37826, 0.60869565217391, 0.1125, 0.055555555555556
37827, 0.60869565217391, 0.125, 0.083333333333333
37828, 0.6304347826087, 0.125, 0.11111111111111
37829, 0.60869565217391, 0.1125, 0.11111111111111
37830, 0.60869565217391, 0.125, 0.13888888888889
37831, 0.6304347826087, 0.125, 0.16666666666667
37832, 0.60869565217391, 0.1125, 0.16666666666667
37833, 0.60869565217391, 0.125, 0.19444444444444
37834, 0.6304347826087, 0.125, 0.22222222222222
37835, 0.60869565217391, 0.1125, 0.22222222222222
37836, 0.60869565217391, 0.125, 0.25
37837, 0.6304347826087, 0.125, 0.27777777777778
37838, 0.60869565217391, 0.1125, 0.27777777777778
37839, 0.60869565217391, 0.125, 0.30555555555556
37840, 0.6304347826087, 0.125, 0.33333333333333
37841, 0.60869565217391, 0.1125, 0.33333333333333
37842, 0.60869565217391, 0.125, 0.36111111111111
37843, 0.6304347826087, 0.125, 0.38888888888889
37844, 0.60869565217391, 0.1125, 0.38888888888889
37845, 0.60869565217391, 0.125, 0.41666666666667
37846, 0.6304347826087, 0.125, 0.44444444444444
37847, 0.60869565217391, 0.1125, 0.44444444444444
37848, 0.60869565217391, 0.125, 0.47222222222222
37849, 0.56521739130435, 0.125, 0.027777777777778
37850, 0.58695652173913, 0.125, 0.055555555555556
37851, 0.56521739130435, 0.1125, 0.055555555555556
37852, 0.56521739130435, 0.125, 0.083333333333333
37853, 0.58695652173913, 0.125, 0.11111111111111
37854, 0.56521739130435, 0.1125, 0.11111111111111
37855, 0.56521739130435, 0.125, 0.13888888888889
37856, 0.58695652173913, 0.125, 0.16666666666667
37857, 0.56521739130435, 0.1125, 0.16666666666667
37858, 0.56521739130435, 0.125, 0.19444444444444
37859, 0.58695652173913, 0.125, 0.22222222222222
37860, 0.56521739130435, 0.1125, 0.22222222222222
37861, 0.56521739130435, 0.125, 0.25
37862, 0.58695652173913, 0.125, 0.27777777777778
37863, 0.56521739130435, 0.1125, 0.27777777777778
37864, 0.56521739130435, 0.125, 0.30555555555556
37865, 0.58695652173913, 0.125, 0.33333333333333
37866, 0.56521739130435, 0.1125, 0.33333333333333
37867, 0.56521739130435, 0.125, 0.36111111111111
37868, 0.58695652173913, 0.125, 0.38888888888889
37869, 0.56521739130435, 0.1125, 0.38888888888889
37870, 0.56521739130435, 0.125, 0.41666666666667
37871, 0.58695652173913, 0.125, 0.44444444444444
37872, 0.56521739130435, 0.1125, 0.44444444444444
37873, 0.56521739130435, 0.125, 0.47222222222222
37874, 0.52173913043478, 0.125, 0.027777777777778
37875, 0.54347826086957, 0.125, 0.055555555555556
37876, 0.52173913043478, 0.1125, 0.055555555555556
37877, 0.52173913043478, 0.125, 0.083333333333333
37878, 0.54347826086957, 0.125, 0.11111111111111
37879, 0.52173913043478, 0.1125, 0.11111111111111
37880, 0.52173913043478, 0.125, 0.13888888888889
37881, 0.54347826086957, 0.125, 0.16666666666667
37882, 0.52173913043478, 0.1125, 0.16666666666667
37883, 0.52173913043478, 0.125, 0.19444444444444
37884, 0.54347826086956, 0.125, 0.22222222222222
37885, 0.52173913043478, 0.1125, 0.22222222222222
37886, 0.52173913043478, 0.125, 0.25
37887, 0.54347826086956, 0.125, 0.27777777777778
37888, 0.52173913043478, 0.1125, 0.27777777777778
37889, 0.52173913043478, 0.125, 0.30555555555556
37890, 0.54347826086956, 0.125, 0.33333333333333
37891, 0.52173913043478, 0.1125, 0.33333333333333
37892, 0.52173913043478, 0.125, 0.36111111111111
37893, 0.54347826086956, 0.125, 0.38888888888889
37894, 0.52173913043478, 0.1125, 0.38888888888889
37895, 0.52173913043478, 0.125, 0.41666666666667
37896, 0.54347826086956, 0.125, 0.44444444444444
37897, 0.52173913043478, 0.1125, 0.44444444444444
37898, 0.52173913043478, 0.125, 0.47222222222222
37899, 0.47826086956522, 0.125, 0.027777777777778
37900, 0.5, 0.125, 0.055555555555556
37901, 0.47826086956522, 0.1125, 0.055555555555556
37902, 0.47826086956522, 0.125, 0.083333333333333
37903, 0.5, 0.125, 0.11111111111111
37904, 0.47826086956522, 0.1125, 0.11111111111111
37905, 0.47826086956522, 0.125, 0.13888888888889
37906, 0.5, 0.125, 0.16666666666667
37907, 0.47826086956522, 0.1125, 0.16666666666667
37908, 0.47826086956522, 0.125, 0.19444444444444
37909, 0.5, 0.125, 0.22222222222222
37910, 0.47826086956522, 0.1125, 0.22222222222222
37911, 0.47826086956522, 0.125, 0.25
37912, 0.5, 0.125, 0.27777777777778
37913, 0.47826086956522, 0.1125, 0.27777777777778
37914, 0.47826086956522, 0.125, 0.30555555555556
37915, 0.5, 0.125, 0.33333333333333
37916, 0.47826086956522, 0.1125, 0.33333333333333
37917, 0.47826086956522, 0.125, 0.36111111111111
37918, 0.5, 0.125, 0.38888888888889
37919, 0.47826086956522, 0.1125, 0.38888888888889
37920, 0.47826086956522, 0.125, 0.41666666666667
37921, 0.5, 0.125, 0.44444444444444
37922, 0.47826086956522, 0.1125, 0.44444444444444
37923, 0.47826086956522, 0.125, 0.47222222222222
37924, 0.43478260869565, 0.125, 0.027777777777778
37925, 0.45652173913043, 0.125, 0.055555555555556
37926, 0.43478260869565, 0.1125, 0.055555555555556
37927, 0.43478260869565, 0.125, 0.083333333333333
37928, 0.45652173913043, 0.125, 0.11111111111111
37929, 0.43478260869565, 0.1125, 0.11111111111111
37930, 0.43478260869565, 0.125, 0.13888888888889
37931, 0.45652173913043, 0.125, 0.16666666666667
37932, 0.43478260869565, 0.1125, 0.16666666666667
37933, 0.43478260869565, 0.125, 0.19444444444444
37934, 0.45652173913043, 0.125, 0.22222222222222
37935, 0.43478260869565, 0.1125, 0.22222222222222
37936, 0.43478260869565, 0.125, 0.25
37937, 0.45652173913043, 0.125, 0.27777777777778
37938, 0.43478260869565, 0.1125, 0.27777777777778
37939, 0.43478260869565, 0.125, 0.30555555555556
37940, 0.45652173913043, 0.125, 0.33333333333333
37941, 0.43478260869565, 0.1125, 0.33333333333333
37942, 0.43478260869565, 0.125, 0.36111111111111
37943, 0.45652173913043, 0.125, 0.38888888888889
37944, 0.43478260869565, 0.1125, 0.38888888888889
37945, 0.43478260869565, 0.125, 0.41666666666667
37946, 0.45652173913043, 0.125, 0.44444444444444
37947, 0.43478260869565, 0.1125, 0.44444444444444
37948, 0.43478260869565, 0.125, 0.47222222222222
37949, 0.39130434782609, 0.125, 0.027777777777778
37950, 0.41304347826087, 0.125, 0.055555555555556
37951, 0.39130434782609, 0.1125, 0.055555555555556
37952, 0.39130434782609, 0.125, 0.083333333333333
37953, 0.41304347826087, 0.125, 0.11111111111111
37954, 0.39130434782609, 0.1125, 0.11111111111111
37955, 0.39130434782609, 0.125, 0.13888888888889
37956, 0.41304347826087, 0.125, 0.16666666666667
37957, 0.39130434782609, 0.1125, 0.16666666666667
37958, 0.39130434782609, 0.125, 0.19444444444444
37959, 0.41304347826087, 0.125, 0.22222222222222
37960, 0.39130434782609, 0.1125, 0.22222222222222
37961, 0.39130434782609, 0.125, 0.25
37962, 0.41304347826087, 0.125, 0.27777777777778
37963, 0.39130434782609, 0.1125, 0.27777777777778
37964, 0.39130434782609, 0.125, 0.30555555555556
37965, 0.41304347826087, 0.125, 0.33333333333333
37966, 0.39130434782609, 0.1125, 0.33333333333333
37967, 0.39130434782609, 0.125, 0.36111111111111
37968, 0.41304347826087, 0.125, 0.38888888888889
37969, 0.39130434782609, 0.1125, 0.38888888888889
37970, 0.39130434782609, 0.125, 0.41666666666667
37971, 0.41304347826087, 0.125, 0.44444444444444
37972, 0.39130434782609, 0.1125, 0.44444444444444
37973, 0.39130434782609, 0.125, 0.47222222222222
37974, 0.34782608695652, 0.125, 0.027777777777778
37975, 0.3695652173913, 0.125, 0.055555555555556
37976, 0.34782608695652, 0.1125, 0.055555555555556
37977, 0.34782608695652, 0.125, 0.083333333333333
37978, 0.3695652173913, 0.125, 0.11111111111111
37979, 0.34782608695652, 0.1125, 0.11111111111111
37980, 0.34782608695652, 0.125, 0.13888888888889
37981, 0.3695652173913, 0.125, 0.16666666666667
37982, 0.34782608695652, 0.1125, 0.16666666666667
37983, 0.34782608695652, 0.125, 0.19444444444444
37984, 0.3695652173913, 0.125, 0.22222222222222
37985, 0.34782608695652, 0.1125, 0.22222222222222
37986, 0.34782608695652, 0.125, 0.25
37987, 0.3695652173913, 0.125, 0.27777777777778
37988, 0.34782608695652, 0.1125, 0.27777777777778
37989, 0.34782608695652, 0.125, 0.30555555555556
37990, 0.3695652173913, 0.125, 0.33333333333333
37991, 0.34782608695652, 0.1125, 0.33333333333333
37992, 0.34782608695652, 0.125, 0.36111111111111
37993, 0.3695652173913, 0.125, 0.38888888888889
37994, 0.34782608695652, 0.1125, 0.38888888888889
37995, 0.34782608695652, 0.125, 0.41666666666667
37996, 0.3695652173913, 0.125, 0.44444444444444
37997, 0.34782608695652, 0.1125, 0.44444444444444
37998, 0.34782608695652, 0.125, 0.47222222222222
37999, 0.30434782608696, 0.125, 0.027777777777778
38000, 0.32608695652174, 0.125, 0.055555555555556
38001, 0.30434782608696, 0.1125, 0.055555555555556
38002, 0.30434782608696, 0.125, 0.083333333333333
38003, 0.32608695652174, 0.125, 0.11111111111111
38004, 0.30434782608696, 0.1125, 0.11111111111111
38005, 0.30434782608696, 0.125, 0.13888888888889
38006, 0.32608695652174, 0.125, 0.16666666666667
38007, 0.30434782608696, 0.1125, 0.16666666666667
38008, 0.30434782608696, 0.125, 0.19444444444444
38009, 0.32608695652174, 0.125, 0.22222222222222
38010, 0.30434782608696, 0.1125, 0.22222222222222
38011, 0.30434782608696, 0.125, 0.25
38012, 0.32608695652174, 0.125, 0.27777777777778
38013, 0.30434782608696, 0.1125, 0.27777777777778
38014, 0.30434782608696, 0.125, 0.30555555555556
38015, 0.32608695652174, 0.125, 0.33333333333333
38016, 0.30434782608696, 0.1125, 0.33333333333333
38017, 0.30434782608696, 0.125, 0.36111111111111
38018, 0.32608695652174, 0.125, 0.38888888888889
38019, 0.30434782608696, 0.1125, 0.38888888888889
38020, 0.30434782608696, 0.125, 0.41666666666667
38021, 0.32608695652174, 0.125, 0.44444444444444
38022, 0.30434782608696, 0.1125, 0.44444444444444
38023, 0.30434782608696, 0.125, 0.47222222222222
38024, 0.26086956521739, 0.125, 0.027777777777778
38025, 0.28260869565217, 0.125, 0.055555555555556
38026, 0.26086956521739, 0.1125, 0.055555555555556
38027, 0.26086956521739, 0.125, 0.083333333333333
38028, 0.28260869565217, 0.125, 0.11111111111111
38029, 0.26086956521739, 0.1125, 0.11111111111111
38030, 0.26086956521739, 0.125, 0.13888888888889
38031, 0.28260869565217, 0.125, 0.16666666666667
38032, 0.26086956521739, 0.1125, 0.16666666666667
38033, 0.26086956521739, 0.125, 0.19444444444444
38034, 0.28260869565217, 0.125, 0.22222222222222
38035, 0.26086956521739, 0.1125, 0.22222222222222
38036, 0.26086956521739, 0.125, 0.25
38037, 0.28260869565217, 0.125, 0.27777777777778
38038, 0.26086956521739, 0.1125, 0.27777777777778
38039, 0.26086956521739, 0.125, 0.30555555555556
38040, 0.28260869565217, 0.125, 0.33333333333333
38041, 0.26086956521739, 0.1125, 0.33333333333333
38042, 0.26086956521739, 0.125, 0.36111111111111
38043, 0.28260869565217, 0.125, 0.38888888888889
38044, 0.26086956521739, 0.1125, 0.38888888888889
38045, 0.26086956521739, 0.125, 0.41666666666667
38046, 0.28260869565217, 0.125, 0.44444444444444
38047, 0.26086956521739, 0.1125, 0.44444444444444
38048, 0.26086956521739, 0.125, 0.47222222222222
38049, 0.21739130434783, 0.125, 0.027777777777778
38050, 0.23913043478261, 0.125, 0.055555555555556
38051, 0.21739130434783, 0.1125, 0.055555555555556
38052, 0.21739130434783, 0.125, 0.083333333333333
38053, 0.23913043478261, 0.125, 0.11111111111111
38054, 0.21739130434783, 0.1125, 0.11111111111111
38055, 0.21739130434783, 0.125, 0.13888888888889
38056, 0.23913043478261, 0.125, 0.16666666666667
38057, 0.21739130434783, 0.1125, 0.16666666666667
38058, 0.21739130434783, 0.125, 0.19444444444444
38059, 0.23913043478261, 0.125, 0.22222222222222
38060, 0.21739130434783, 0.1125, 0.22222222222222
38061, 0.21739130434783, 0.125, 0.25
38062, 0.23913043478261, 0.125, 0.27777777777778
38063, 0.21739130434783, 0.1125, 0.27777777777778
38064, 0.21739130434783, 0.125, 0.30555555555556
38065, 0.23913043478261, 0.125, 0.33333333333333
38066, 0.21739130434783, 0.1125, 0.33333333333333
38067, 0.21739130434783, 0.125, 0.36111111111111
38068, 0.23913043478261, 0.125, 0.38888888888889
38069, 0.21739130434783, 0.1125, 0.38888888888889
38070, 0.21739130434783, 0.125, 0.41666666666667
38071, 0.23913043478261, 0.125, 0.44444444444444
38072, 0.21739130434783, 0.1125, 0.44444444444444
38073, 0.21739130434783, 0.125, 0.47222222222222
38074, 0.17391304347826, 0.125, 0.027777777777778
38075, 0.19565217391304, 0.125, 0.055555555555556
38076, 0.17391304347826, 0.1125, 0.055555555555556
38077, 0.17391304347826, 0.125, 0.083333333333333
38078, 0.19565217391304, 0.125, 0.11111111111111
38079, 0.17391304347826, 0.1125, 0.11111111111111
38080, 0.17391304347826, 0.125, 0.13888888888889
38081, 0.19565217391304, 0.125, 0.16666666666667
38082, 0.17391304347826, 0.1125, 0.16666666666667
38083, 0.17391304347826, 0.125, 0.19444444444444
38084, 0.19565217391304, 0.125, 0.22222222222222
38085, 0.17391304347826, 0.1125, 0.22222222222222
38086, 0.17391304347826, 0.125, 0.25
38087, 0.19565217391304, 0.125, 0.27777777777778
38088, 0.17391304347826, 0.1125, 0.27777777777778
38089, 0.17391304347826, 0.125, 0.30555555555556
38090, 0.19565217391304, 0.125, 0.33333333333333
38091, 0.17391304347826, 0.1125, 0.33333333333333
38092, 0.17391304347826, 0.125, 0.36111111111111
38093, 0.19565217391304, 0.125, 0.38888888888889
38094, 0.17391304347826, 0.1125, 0.38888888888889
38095, 0.17391304347826, 0.125, 0.41666666666667
38096, 0.19565217391304, 0.125, 0.44444444444444
38097, 0.17391304347826, 0.1125, 0.44444444444444
38098, 0.17391304347826, 0.125, 0.47222222222222
38099, 0.1304347826087, 0.125, 0.027777777777778
38100, 0.15217391304348, 0.125, 0.055555555555556
38101, 0.1304347826087, 0.1125, 0.055555555555556
38102, 0.1304347826087, 0.125, 0.083333333333333
38103, 0.15217391304348, 0.125, 0.11111111111111
38104, 0.1304347826087, 0.1125, 0.11111111111111
38105, 0.1304347826087, 0.125, 0.13888888888889
38106, 0.15217391304348, 0.125, 0.16666666666667
38107, 0.1304347826087, 0.1125, 0.16666666666667
38108, 0.1304347826087, 0.125, 0.19444444444444
38109, 0.15217391304348, 0.125, 0.22222222222222
38110, 0.1304347826087, 0.1125, 0.22222222222222
38111, 0.1304347826087, 0.125, 0.25
38112, 0.15217391304348, 0.125, 0.27777777777778
38113, 0.1304347826087, 0.1125, 0.27777777777778
38114, 0.1304347826087, 0.125, 0.30555555555556
38115, 0.15217391304348, 0.125, 0.33333333333333
38116, 0.1304347826087, 0.1125, 0.33333333333333
38117, 0.1304347826087, 0.125, 0.36111111111111
38118, 0.15217391304348, 0.125, 0.38888888888889
38119, 0.1304347826087, 0.1125, 0.38888888888889
38120, 0.1304347826087, 0.125, 0.41666666666667
38121, 0.15217391304348, 0.125, 0.44444444444444
38122, 0.1304347826087, 0.1125, 0.44444444444444
38123, 0.1304347826087, 0.125, 0.47222222222222
38124, 0.08695652173913, 0.125, 0.027777777777778
38125, 0.10869565217391, 0.125, 0.055555555555556
38126, 0.08695652173913, 0.1125, 0.055555555555556
38127, 0.08695652173913, 0.125, 0.083333333333333
38128, 0.10869565217391, 0.125, 0.11111111111111
38129, 0.08695652173913, 0.1125, 0.11111111111111
38130, 0.08695652173913, 0.125, 0.13888888888889
38131, 0.10869565217391, 0.125, 0.16666666666667
38132, 0.08695652173913, 0.1125, 0.16666666666667
38133, 0.08695652173913, 0.125, 0.19444444444444
38134, 0.10869565217391, 0.125, 0.22222222222222
38135, 0.08695652173913, 0.1125, 0.22222222222222
38136, 0.08695652173913, 0.125, 0.25
38137, 0.10869565217391, 0.125, 0.27777777777778
38138, 0.08695652173913, 0.1125, 0.27777777777778
38139, 0.08695652173913, 0.125, 0.30555555555556
38140, 0.10869565217391, 0.125, 0.33333333333333
38141, 0.08695652173913, 0.1125, 0.33333333333333
38142, 0.08695652173913, 0.125, 0.36111111111111
38143, 0.10869565217391, 0.125, 0.38888888888889
38144, 0.08695652173913, 0.1125, 0.38888888888889
38145, 0.08695652173913, 0.125, 0.41666666666667
38146, 0.10869565217391, 0.125, 0.44444444444444
38147, 0.08695652173913, 0.1125, 0.44444444444444
38148, 0.08695652173913, 0.125, 0.47222222222222
38149, 0.043478260869565, 0.125, 0.027777777777778
38150, 0.065217391304348, 0.125, 0.055555555555556
38151, 0.043478260869565, 0.1125, 0.055555555555556
38152, 0.043478260869565, 0.125, 0.083333333333333
38153, 0.065217391304348, 0.125, 0.11111111111111
38154, 0.043478260869565, 0.1125, 0.11111111111111
38155, 0.043478260869565, 0.125, 0.13888888888889
38156, 0.065217391304348, 0.125, 0.16666666666667
38157, 0.043478260869565, 0.1125, 0.16666666666667
38158, 0.043478260869565, 0.125, 0.19444444444444
38159, 0.065217391304348, 0.125, 0.22222222222222
38160, 0.043478260869565, 0.1125, 0.22222222222222
38161, 0.043478260869565, 0.125, 0.25
38162, 0.065217391304348, 0.125, 0.27777777777778
38163, 0.043478260869565, 0.1125, 0.27777777777778
38164, 0.043478260869565, 0.125, 0.30555555555556
38165, 0.065217391304348, 0.125, 0.33333333333333
38166, 0.043478260869565, 0.1125, 0.33333333333333
38167, 0.043478260869565, 0.125, 0.36111111111111
38168, 0.065217391304348, 0.125, 0.38888888888889
38169, 0.043478260869565, 0.1125, 0.38888888888889
38170, 0.043478260869565, 0.125, 0.41666666666667
38171, 0.065217391304348, 0.125, 0.44444444444444
38172, 0.043478260869565, 0.1125, 0.44444444444444
38173, 0.043478260869565, 0.125, 0.47222222222222
38174, 0.021739130434783, 0.125, 0.055555555555556
38175, 0.021739130434783, 0.125, 0.11111111111111
38176, 0.021739130434783, 0.125, 0.16666666666667
38177, 0.021739130434783, 0.125, 0.22222222222222
38178, 0.021739130434783, 0.125, 0.27777777777778
38179, 0.021739130434783, 0.125, 0.33333333333333
38180, 0.021739130434783, 0.125, 0.38888888888889
38181, 0.021739130434783, 0.125, 0.44444444444444
38182, 0.95652173913043, 0.1375, 0.055555555555556
38183, 0.95652173913044, 0.1375, 0.11111111111111
38184, 0.95652173913044, 0.1375, 0.16666666666667
38185, 0.95652173913043, 0.1375, 0.22222222222222
38186, 0.95652173913043, 0.1375, 0.27777777777778
38187, 0.95652173913043, 0.1375, 0.33333333333333
38188, 0.95652173913043, 0.1375, 0.38888888888889
38189, 0.95652173913043, 0.1375, 0.44444444444444
38190, 0.91304347826087, 0.1375, 0.055555555555556
38191, 0.91304347826087, 0.1375, 0.11111111111111
38192, 0.91304347826087, 0.1375, 0.16666666666667
38193, 0.91304347826087, 0.1375, 0.22222222222222
38194, 0.91304347826087, 0.1375, 0.27777777777778
38195, 0.91304347826087, 0.1375, 0.33333333333333
38196, 0.91304347826087, 0.1375, 0.38888888888889
38197, 0.91304347826087, 0.1375, 0.44444444444444
38198, 0.8695652173913, 0.1375, 0.055555555555556
38199, 0.8695652173913, 0.1375, 0.11111111111111
38200, 0.8695652173913, 0.1375, 0.16666666666667
38201, 0.8695652173913, 0.1375, 0.22222222222222
38202, 0.8695652173913, 0.1375, 0.27777777777778
38203, 0.8695652173913, 0.1375, 0.33333333333333
38204, 0.8695652173913, 0.1375, 0.38888888888889
38205, 0.8695652173913, 0.1375, 0.44444444444444
38206, 0.82608695652174, 0.1375, 0.055555555555556
38207, 0.82608695652174, 0.1375, 0.11111111111111
38208, 0.82608695652174, 0.1375, 0.16666666666667
38209, 0.82608695652174, 0.1375, 0.22222222222222
38210, 0.82608695652174, 0.1375, 0.27777777777778
38211, 0.82608695652174, 0.1375, 0.33333333333333
38212, 0.82608695652174, 0.1375, 0.38888888888889
38213, 0.82608695652174, 0.1375, 0.44444444444444
38214, 0.78260869565217, 0.1375, 0.055555555555556
38215, 0.78260869565217, 0.1375, 0.11111111111111
38216, 0.78260869565217, 0.1375, 0.16666666666667
38217, 0.78260869565217, 0.1375, 0.22222222222222
38218, 0.78260869565217, 0.1375, 0.27777777777778
38219, 0.78260869565217, 0.1375, 0.33333333333333
38220, 0.78260869565217, 0.1375, 0.38888888888889
38221, 0.78260869565217, 0.1375, 0.44444444444444
38222, 0.73913043478261, 0.1375, 0.055555555555556
38223, 0.73913043478261, 0.1375, 0.11111111111111
38224, 0.73913043478261, 0.1375, 0.16666666666667
38225, 0.73913043478261, 0.1375, 0.22222222222222
38226, 0.73913043478261, 0.1375, 0.27777777777778
38227, 0.73913043478261, 0.1375, 0.33333333333333
38228, 0.73913043478261, 0.1375, 0.38888888888889
38229, 0.73913043478261, 0.1375, 0.44444444444444
38230, 0.69565217391304, 0.1375, 0.055555555555556
38231, 0.69565217391304, 0.1375, 0.11111111111111
38232, 0.69565217391304, 0.1375, 0.16666666666667
38233, 0.69565217391304, 0.1375, 0.22222222222222
38234, 0.69565217391304, 0.1375, 0.27777777777778
38235, 0.69565217391304, 0.1375, 0.33333333333333
38236, 0.69565217391304, 0.1375, 0.38888888888889
38237, 0.69565217391304, 0.1375, 0.44444444444444
38238, 0.65217391304348, 0.1375, 0.055555555555556
38239, 0.65217391304348, 0.1375, 0.11111111111111
38240, 0.65217391304348, 0.1375, 0.16666666666667
38241, 0.65217391304348, 0.1375, 0.22222222222222
38242, 0.65217391304348, 0.1375, 0.27777777777778
38243, 0.65217391304348, 0.1375, 0.33333333333333
38244, 0.65217391304348, 0.1375, 0.38888888888889
38245, 0.65217391304348, 0.1375, 0.44444444444444
38246, 0.60869565217391, 0.1375, 0.055555555555556
38247, 0.60869565217391, 0.1375, 0.11111111111111
38248, 0.60869565217391, 0.1375, 0.16666666666667
38249, 0.60869565217391, 0.1375, 0.22222222222222
38250, 0.60869565217391, 0.1375, 0.27777777777778
38251, 0.60869565217391, 0.1375, 0.33333333333333
38252, 0.60869565217391, 0.1375, 0.38888888888889
38253, 0.60869565217391, 0.1375, 0.44444444444444
38254, 0.56521739130435, 0.1375, 0.055555555555556
38255, 0.56521739130435, 0.1375, 0.11111111111111
38256, 0.56521739130435, 0.1375, 0.16666666666667
38257, 0.56521739130435, 0.1375, 0.22222222222222
38258, 0.56521739130435, 0.1375, 0.27777777777778
38259, 0.56521739130435, 0.1375, 0.33333333333333
38260, 0.56521739130435, 0.1375, 0.38888888888889
38261, 0.56521739130435, 0.1375, 0.44444444444444
38262, 0.52173913043478, 0.1375, 0.055555555555556
38263, 0.52173913043478, 0.1375, 0.11111111111111
38264, 0.52173913043478, 0.1375, 0.16666666666667
38265, 0.52173913043478, 0.1375, 0.22222222222222
38266, 0.52173913043478, 0.1375, 0.27777777777778
38267, 0.52173913043478, 0.1375, 0.33333333333333
38268, 0.52173913043478, 0.1375, 0.38888888888889
38269, 0.52173913043478, 0.1375, 0.44444444444444
38270, 0.47826086956522, 0.1375, 0.055555555555556
38271, 0.47826086956522, 0.1375, 0.11111111111111
38272, 0.47826086956522, 0.1375, 0.16666666666667
38273, 0.47826086956522, 0.1375, 0.22222222222222
38274, 0.47826086956522, 0.1375, 0.27777777777778
38275, 0.47826086956522, 0.1375, 0.33333333333333
38276, 0.47826086956522, 0.1375, 0.38888888888889
38277, 0.47826086956522, 0.1375, 0.44444444444444
38278, 0.43478260869565, 0.1375, 0.055555555555556
38279, 0.43478260869565, 0.1375, 0.11111111111111
38280, 0.43478260869565, 0.1375, 0.16666666666667
38281, 0.43478260869565, 0.1375, 0.22222222222222
38282, 0.43478260869565, 0.1375, 0.27777777777778
38283, 0.43478260869565, 0.1375, 0.33333333333333
38284, 0.43478260869565, 0.1375, 0.38888888888889
38285, 0.43478260869565, 0.1375, 0.44444444444444
38286, 0.39130434782609, 0.1375, 0.055555555555556
38287, 0.39130434782609, 0.1375, 0.11111111111111
38288, 0.39130434782609, 0.1375, 0.16666666666667
38289, 0.39130434782609, 0.1375, 0.22222222222222
38290, 0.39130434782609, 0.1375, 0.27777777777778
38291, 0.39130434782609, 0.1375, 0.33333333333333
38292, 0.39130434782609, 0.1375, 0.38888888888889
38293, 0.39130434782609, 0.1375, 0.44444444444444
38294, 0.34782608695652, 0.1375, 0.055555555555556
38295, 0.34782608695652, 0.1375, 0.11111111111111
38296, 0.34782608695652, 0.1375, 0.16666666666667
38297, 0.34782608695652, 0.1375, 0.22222222222222
38298, 0.34782608695652, 0.1375, 0.27777777777778
38299, 0.34782608695652, 0.1375, 0.33333333333333
38300, 0.34782608695652, 0.1375, 0.38888888888889
38301, 0.34782608695652, 0.1375, 0.44444444444444
38302, 0.30434782608696, 0.1375, 0.055555555555556
38303, 0.30434782608696, 0.1375, 0.11111111111111
38304, 0.30434782608696, 0.1375, 0.16666666666667
38305, 0.30434782608696, 0.1375, 0.22222222222222
38306, 0.30434782608696, 0.1375, 0.27777777777778
38307, 0.30434782608696, 0.1375, 0.33333333333333
38308, 0.30434782608696, 0.1375, 0.38888888888889
38309, 0.30434782608696, 0.1375, 0.44444444444444
38310, 0.26086956521739, 0.1375, 0.055555555555556
38311, 0.26086956521739, 0.1375, 0.11111111111111
38312, 0.26086956521739, 0.1375, 0.16666666666667
38313, 0.26086956521739, 0.1375, 0.22222222222222
38314, 0.26086956521739, 0.1375, 0.27777777777778
38315, 0.26086956521739, 0.1375, 0.33333333333333
38316, 0.26086956521739, 0.1375, 0.38888888888889
38317, 0.26086956521739, 0.1375, 0.44444444444444
38318, 0.21739130434783, 0.1375, 0.055555555555556
38319, 0.21739130434783, 0.1375, 0.11111111111111
38320, 0.21739130434783, 0.1375, 0.16666666666667
38321, 0.21739130434783, 0.1375, 0.22222222222222
38322, 0.21739130434783, 0.1375, 0.27777777777778
38323, 0.21739130434783, 0.1375, 0.33333333333333
38324, 0.21739130434783, 0.1375, 0.38888888888889
38325, 0.21739130434783, 0.1375, 0.44444444444444
38326, 0.17391304347826, 0.1375, 0.055555555555556
38327, 0.17391304347826, 0.1375, 0.11111111111111
38328, 0.17391304347826, 0.1375, 0.16666666666667
38329, 0.17391304347826, 0.1375, 0.22222222222222
38330, 0.17391304347826, 0.1375, 0.27777777777778
38331, 0.17391304347826, 0.1375, 0.33333333333333
38332, 0.17391304347826, 0.1375, 0.38888888888889
38333, 0.17391304347826, 0.1375, 0.44444444444444
38334, 0.1304347826087, 0.1375, 0.055555555555556
38335, 0.1304347826087, 0.1375, 0.11111111111111
38336, 0.1304347826087, 0.1375, 0.16666666666667
38337, 0.1304347826087, 0.1375, 0.22222222222222
38338, 0.1304347826087, 0.1375, 0.27777777777778
38339, 0.1304347826087, 0.1375, 0.33333333333333
38340, 0.1304347826087, 0.1375, 0.38888888888889
38341, 0.1304347826087, 0.1375, 0.44444444444444
38342, 0.08695652173913, 0.1375, 0.055555555555556
38343, 0.08695652173913, 0.1375, 0.11111111111111
38344, 0.08695652173913, 0.1375, 0.16666666666667
38345, 0.08695652173913, 0.1375, 0.22222222222222
38346, 0.08695652173913, 0.1375, 0.27777777777778
38347, 0.08695652173913, 0.1375, 0.33333333333333
38348, 0.08695652173913, 0.1375, 0.38888888888889
38349, 0.08695652173913, 0.1375, 0.44444444444444
38350, 0.043478260869565, 0.1375, 0.055555555555556
38351, 0.043478260869565, 0.1375, 0.11111111111111
38352, 0.043478260869565, 0.1375, 0.16666666666667
38353, 0.043478260869565, 0.1375, 0.22222222222222
38354, 0.043478260869565, 0.1375, 0.27777777777778
38355, 0.043478260869565, 0.1375, 0.33333333333333
38356, 0.043478260869565, 0.1375, 0.38888888888889
38357, 0.043478260869565, 0.1375, 0.44444444444444
38358, 0.95652173913043, 0.20217391304348, 0.055555555555556
38359, 0.95652173913044, 0.20217391304348, 0.11111111111111
38360, 0.95652173913044, 0.20217391304348, 0.16666666666667
38361, 0.95652173913044, 0.20217391304348, 0.22222222222222
38362, 0.95652173913044, 0.20217391304348, 0.27777777777778
38363, 0.95652173913044, 0.20217391304348, 0.33333333333333
38364, 0.95652173913043, 0.20217391304348, 0.38888888888889
38365, 0.95652173913044, 0.20217391304348, 0.44444444444444
38366, 0.91304347826087, 0.20217391304348, 0.055555555555556
38367, 0.91304347826087, 0.20217391304348, 0.11111111111111
38368, 0.91304347826087, 0.20217391304348, 0.16666666666667
38369, 0.91304347826087, 0.20217391304348, 0.22222222222222
38370, 0.91304347826087, 0.20217391304348, 0.27777777777778
38371, 0.91304347826087, 0.20217391304348, 0.33333333333333
38372, 0.91304347826087, 0.20217391304348, 0.38888888888889
38373, 0.91304347826087, 0.20217391304348, 0.44444444444444
38374, 0.8695652173913, 0.20217391304348, 0.055555555555556
38375, 0.8695652173913, 0.20217391304348, 0.11111111111111
38376, 0.8695652173913, 0.20217391304348, 0.16666666666667
38377, 0.8695652173913, 0.20217391304348, 0.22222222222222
38378, 0.8695652173913, 0.20217391304348, 0.27777777777778
38379, 0.8695652173913, 0.20217391304348, 0.33333333333333
38380, 0.8695652173913, 0.20217391304348, 0.38888888888889
38381, 0.8695652173913, 0.20217391304348, 0.44444444444444
38382, 0.82608695652174, 0.20217391304348, 0.055555555555556
38383, 0.82608695652174, 0.20217391304348, 0.11111111111111
38384, 0.82608695652174, 0.20217391304348, 0.16666666666667
38385, 0.82608695652174, 0.20217391304348, 0.22222222222222
38386, 0.82608695652174, 0.20217391304348, 0.27777777777778
38387, 0.82608695652174, 0.20217391304348, 0.33333333333333
38388, 0.82608695652174, 0.20217391304348, 0.38888888888889
38389, 0.82608695652174, 0.20217391304348, 0.44444444444444
38390, 0.78260869565217, 0.20217391304348, 0.055555555555556
38391, 0.78260869565217, 0.20217391304348, 0.11111111111111
38392, 0.78260869565217, 0.20217391304348, 0.16666666666667
38393, 0.78260869565217, 0.20217391304348, 0.22222222222222
38394, 0.78260869565217, 0.20217391304348, 0.27777777777778
38395, 0.78260869565217, 0.20217391304348, 0.33333333333333
38396, 0.78260869565217, 0.20217391304348, 0.38888888888889
38397, 0.78260869565217, 0.20217391304348, 0.44444444444444
38398, 0.73913043478261, 0.20217391304348, 0.055555555555556
38399, 0.73913043478261, 0.20217391304348, 0.11111111111111
38400, 0.73913043478261, 0.20217391304348, 0.16666666666667
38401, 0.73913043478261, 0.20217391304348, 0.22222222222222
38402, 0.73913043478261, 0.20217391304348, 0.27777777777778
38403, 0.73913043478261, 0.20217391304348, 0.33333333333333
38404, 0.73913043478261, 0.20217391304348, 0.38888888888889
38405, 0.73913043478261, 0.20217391304348, 0.44444444444444
38406, 0.69565217391304, 0.20217391304348, 0.055555555555556
38407, 0.69565217391304, 0.20217391304348, 0.11111111111111
38408, 0.69565217391304, 0.20217391304348, 0.16666666666667
38409, 0.69565217391304, 0.20217391304348, 0.22222222222222
38410, 0.69565217391304, 0.20217391304348, 0.27777777777778
38411, 0.69565217391304, 0.20217391304348, 0.33333333333333
38412, 0.69565217391304, 0.20217391304348, 0.38888888888889
38413, 0.69565217391304, 0.20217391304348, 0.44444444444444
38414, 0.65217391304348, 0.20217391304348, 0.055555555555556
38415, 0.65217391304348, 0.20217391304348, 0.11111111111111
38416, 0.65217391304348, 0.20217391304348, 0.16666666666667
38417, 0.65217391304348, 0.20217391304348, 0.22222222222222
38418, 0.65217391304348, 0.20217391304348, 0.27777777777778
38419, 0.65217391304348, 0.20217391304348, 0.33333333333333
38420, 0.65217391304348, 0.20217391304348, 0.38888888888889
38421, 0.65217391304348, 0.20217391304348, 0.44444444444444
38422, 0.60869565217391, 0.20217391304348, 0.055555555555556
38423, 0.60869565217391, 0.20217391304348, 0.11111111111111
38424, 0.60869565217391, 0.20217391304348, 0.16666666666667
38425, 0.60869565217391, 0.20217391304348, 0.22222222222222
38426, 0.60869565217391, 0.20217391304348, 0.27777777777778
38427, 0.60869565217391, 0.20217391304348, 0.33333333333333
38428, 0.60869565217391, 0.20217391304348, 0.38888888888889
38429, 0.60869565217391, 0.20217391304348, 0.44444444444444
38430, 0.56521739130435, 0.20217391304348, 0.055555555555556
38431, 0.56521739130435, 0.20217391304348, 0.11111111111111
38432, 0.56521739130435, 0.20217391304348, 0.16666666666667
38433, 0.56521739130435, 0.20217391304348, 0.22222222222222
38434, 0.56521739130435, 0.20217391304348, 0.27777777777778
38435, 0.56521739130435, 0.20217391304348, 0.33333333333333
38436, 0.56521739130435, 0.20217391304348, 0.38888888888889
38437, 0.56521739130435, 0.20217391304348, 0.44444444444444
38438, 0.52173913043478, 0.20217391304348, 0.055555555555556
38439, 0.52173913043478, 0.20217391304348, 0.11111111111111
38440, 0.52173913043478, 0.20217391304348, 0.16666666666667
38441, 0.52173913043478, 0.20217391304348, 0.22222222222222
38442, 0.52173913043478, 0.20217391304348, 0.27777777777778
38443, 0.52173913043478, 0.20217391304348, 0.33333333333333
38444, 0.52173913043478, 0.20217391304348, 0.38888888888889
38445, 0.52173913043478, 0.20217391304348, 0.44444444444444
38446, 0.47826086956522, 0.20217391304348, 0.055555555555556
38447, 0.47826086956522, 0.20217391304348, 0.11111111111111
38448, 0.47826086956522, 0.20217391304348, 0.16666666666667
38449, 0.47826086956522, 0.20217391304348, 0.22222222222222
38450, 0.47826086956522, 0.20217391304348, 0.27777777777778
38451, 0.47826086956522, 0.20217391304348, 0.33333333333333
38452, 0.47826086956522, 0.20217391304348, 0.38888888888889
38453, 0.47826086956522, 0.20217391304348, 0.44444444444444
38454, 0.43478260869565, 0.20217391304348, 0.055555555555556
38455, 0.43478260869565, 0.20217391304348, 0.11111111111111
38456, 0.43478260869565, 0.20217391304348, 0.16666666666667
38457, 0.43478260869565, 0.20217391304348, 0.22222222222222
38458, 0.43478260869565, 0.20217391304348, 0.27777777777778
38459, 0.43478260869565, 0.20217391304348, 0.33333333333333
38460, 0.43478260869565, 0.20217391304348, 0.38888888888889
38461, 0.43478260869565, 0.20217391304348, 0.44444444444444
38462, 0.39130434782609, 0.20217391304348, 0.055555555555556
38463, 0.39130434782609, 0.20217391304348, 0.11111111111111
38464, 0.39130434782609, 0.20217391304348, 0.16666666666667
38465, 0.39130434782609, 0.20217391304348, 0.22222222222222
38466, 0.39130434782609, 0.20217391304348, 0.27777777777778
38467, 0.39130434782609, 0.20217391304348, 0.33333333333333
38468, 0.39130434782609, 0.20217391304348, 0.38888888888889
38469, 0.39130434782609, 0.20217391304348, 0.44444444444444
38470, 0.34782608695652, 0.20217391304348, 0.055555555555556
38471, 0.34782608695652, 0.20217391304348, 0.11111111111111
38472, 0.34782608695652, 0.20217391304348, 0.16666666666667
38473, 0.34782608695652, 0.20217391304348, 0.22222222222222
38474, 0.34782608695652, 0.20217391304348, 0.27777777777778
38475, 0.34782608695652, 0.20217391304348, 0.33333333333333
38476, 0.34782608695652, 0.20217391304348, 0.38888888888889
38477, 0.34782608695652, 0.20217391304348, 0.44444444444444
38478, 0.30434782608696, 0.20217391304348, 0.055555555555556
38479, 0.30434782608696, 0.20217391304348, 0.11111111111111
38480, 0.30434782608696, 0.20217391304348, 0.16666666666667
38481, 0.30434782608696, 0.20217391304348, 0.22222222222222
38482, 0.30434782608696, 0.20217391304348, 0.27777777777778
38483, 0.30434782608696, 0.20217391304348, 0.33333333333333
38484, 0.30434782608696, 0.20217391304348, 0.38888888888889
38485, 0.30434782608696, 0.20217391304348, 0.44444444444444
38486, 0.26086956521739, 0.20217391304348, 0.055555555555556
38487, 0.26086956521739, 0.20217391304348, 0.11111111111111
38488, 0.26086956521739, 0.20217391304348, 0.16666666666667
38489, 0.26086956521739, 0.20217391304348, 0.22222222222222
38490, 0.26086956521739, 0.20217391304348, 0.27777777777778
38491, 0.26086956521739, 0.20217391304348, 0.33333333333333
38492, 0.26086956521739, 0.20217391304348, 0.38888888888889
38493, 0.26086956521739, 0.20217391304348, 0.44444444444444
38494, 0.21739130434783, 0.20217391304348, 0.055555555555556
38495, 0.21739130434783, 0.20217391304348, 0.11111111111111
38496, 0.21739130434783, 0.20217391304348, 0.16666666666667
38497, 0.21739130434783, 0.20217391304348, 0.22222222222222
38498, 0.21739130434783, 0.20217391304348, 0.27777777777778
38499, 0.21739130434783, 0.20217391304348, 0.33333333333333
38500, 0.21739130434783, 0.20217391304348, 0.38888888888889
38501, 0.21739130434783, 0.20217391304348, 0.44444444444444
38502, 0.17391304347826, 0.20217391304348, 0.055555555555556
38503, 0.17391304347826, 0.20217391304348, 0.11111111111111
38504, 0.17391304347826, 0.20217391304348, 0.16666666666667
38505, 0.17391304347826, 0.20217391304348, 0.22222222222222
38506, 0.17391304347826, 0.20217391304348, 0.27777777777778
38507, 0.17391304347826, 0.20217391304348, 0.33333333333333
38508, 0.17391304347826, 0.20217391304348, 0.38888888888889
38509, 0.17391304347826, 0.20217391304348, 0.44444444444444
38510, 0.1304347826087, 0.20217391304348, 0.055555555555556
38511, 0.1304347826087, 0.20217391304348, 0.11111111111111
38512, 0.1304347826087, 0.20217391304348, 0.16666666666667
38513, 0.1304347826087, 0.20217391304348, 0.22222222222222
38514, 0.1304347826087, 0.20217391304348, 0.27777777777778
38515, 0.1304347826087, 0.20217391304348, 0.33333333333333
38516, 0.1304347826087, 0.20217391304348, 0.38888888888889
38517, 0.1304347826087, 0.20217391304348, 0.44444444444444
38518, 0.08695652173913, 0.20217391304348, 0.055555555555556
38519, 0.08695652173913, 0.20217391304348, 0.11111111111111
38520, 0.08695652173913, 0.20217391304348, 0.16666666666667
38521, 0.08695652173913, 0.20217391304348, 0.22222222222222
38522, 0.08695652173913, 0.20217391304348, 0.27777777777778
38523, 0.08695652173913, 0.20217391304348, 0.33333333333333
38524, 0.08695652173913, 0.20217391304348, 0.38888888888889
38525, 0.08695652173913, 0.20217391304348, 0.44444444444444
38526, 0.043478260869565, 0.20217391304348, 0.055555555555556
38527, 0.043478260869565, 0.20217391304348, 0.11111111111111
38528, 0.043478260869565, 0.20217391304348, 0.16666666666667
38529, 0.043478260869565, 0.20217391304348, 0.22222222222222
38530, 0.043478260869565, 0.20217391304348, 0.27777777777778
38531, 0.043478260869565, 0.20217391304348, 0.33333333333333
38532, 0.043478260869565, 0.20217391304348, 0.38888888888889
38533, 0.043478260869565, 0.20217391304348, 0.44444444444444
38534, 0.95652173913043, 0.25434782608696, 0.055555555555556
38535, 0.95652173913043, 0.25434782608696, 0.11111111111111
38536, 0.95652173913044, 0.25434782608696, 0.16666666666667
38537, 0.95652173913043, 0.25434782608696, 0.22222222222222
38538, 0.95652173913043, 0.25434782608696, 0.27777777777778
38539, 0.95652173913043, 0.25434782608696, 0.33333333333333
38540, 0.95652173913043, 0.25434782608696, 0.38888888888889
38541, 0.95652173913043, 0.25434782608696, 0.44444444444444
38542, 0.91304347826087, 0.25434782608696, 0.055555555555556
38543, 0.91304347826087, 0.25434782608696, 0.11111111111111
38544, 0.91304347826087, 0.25434782608696, 0.16666666666667
38545, 0.91304347826087, 0.25434782608696, 0.22222222222222
38546, 0.91304347826087, 0.25434782608696, 0.27777777777778
38547, 0.91304347826087, 0.25434782608696, 0.33333333333333
38548, 0.91304347826087, 0.25434782608696, 0.38888888888889
38549, 0.91304347826087, 0.25434782608696, 0.44444444444444
38550, 0.8695652173913, 0.25434782608696, 0.055555555555556
38551, 0.8695652173913, 0.25434782608696, 0.11111111111111
38552, 0.8695652173913, 0.25434782608696, 0.16666666666667
38553, 0.8695652173913, 0.25434782608696, 0.22222222222222
38554, 0.8695652173913, 0.25434782608696, 0.27777777777778
38555, 0.8695652173913, 0.25434782608696, 0.33333333333333
38556, 0.8695652173913, 0.25434782608696, 0.38888888888889
38557, 0.8695652173913, 0.25434782608696, 0.44444444444444
38558, 0.82608695652174, 0.25434782608696, 0.055555555555556
38559, 0.82608695652174, 0.25434782608696, 0.11111111111111
38560, 0.82608695652174, 0.25434782608696, 0.16666666666667
38561, 0.82608695652174, 0.25434782608696, 0.22222222222222
38562, 0.82608695652174, 0.25434782608696, 0.27777777777778
38563, 0.82608695652174, 0.25434782608696, 0.33333333333333
38564, 0.82608695652174, 0.25434782608696, 0.38888888888889
38565, 0.82608695652174, 0.25434782608696, 0.44444444444444
38566, 0.78260869565217, 0.25434782608696, 0.055555555555556
38567, 0.78260869565217, 0.25434782608696, 0.11111111111111
38568, 0.78260869565217, 0.25434782608696, 0.16666666666667
38569, 0.78260869565217, 0.25434782608696, 0.22222222222222
38570, 0.78260869565217, 0.25434782608696, 0.27777777777778
38571, 0.78260869565217, 0.25434782608696, 0.33333333333333
38572, 0.78260869565217, 0.25434782608696, 0.38888888888889
38573, 0.78260869565217, 0.25434782608696, 0.44444444444444
38574, 0.73913043478261, 0.25434782608696, 0.055555555555556
38575, 0.73913043478261, 0.25434782608696, 0.11111111111111
38576, 0.73913043478261, 0.25434782608696, 0.16666666666667
38577, 0.73913043478261, 0.25434782608696, 0.22222222222222
38578, 0.73913043478261, 0.25434782608696, 0.27777777777778
38579, 0.73913043478261, 0.25434782608696, 0.33333333333333
38580, 0.73913043478261, 0.25434782608696, 0.38888888888889
38581, 0.73913043478261, 0.25434782608696, 0.44444444444444
38582, 0.69565217391304, 0.25434782608696, 0.055555555555556
38583, 0.69565217391304, 0.25434782608696, 0.11111111111111
38584, 0.69565217391304, 0.25434782608696, 0.16666666666667
38585, 0.69565217391304, 0.25434782608696, 0.22222222222222
38586, 0.69565217391304, 0.25434782608696, 0.27777777777778
38587, 0.69565217391304, 0.25434782608696, 0.33333333333333
38588, 0.69565217391304, 0.25434782608696, 0.38888888888889
38589, 0.69565217391304, 0.25434782608696, 0.44444444444444
38590, 0.65217391304348, 0.25434782608696, 0.055555555555556
38591, 0.65217391304348, 0.25434782608696, 0.11111111111111
38592, 0.65217391304348, 0.25434782608696, 0.16666666666667
38593, 0.65217391304348, 0.25434782608696, 0.22222222222222
38594, 0.65217391304348, 0.25434782608696, 0.27777777777778
38595, 0.65217391304348, 0.25434782608696, 0.33333333333333
38596, 0.65217391304348, 0.25434782608696, 0.38888888888889
38597, 0.65217391304348, 0.25434782608696, 0.44444444444444
38598, 0.60869565217391, 0.25434782608696, 0.055555555555556
38599, 0.60869565217391, 0.25434782608696, 0.11111111111111
38600, 0.60869565217391, 0.25434782608696, 0.16666666666667
38601, 0.60869565217391, 0.25434782608696, 0.22222222222222
38602, 0.60869565217391, 0.25434782608696, 0.27777777777778
38603, 0.60869565217391, 0.25434782608696, 0.33333333333333
38604, 0.60869565217391, 0.25434782608696, 0.38888888888889
38605, 0.60869565217391, 0.25434782608696, 0.44444444444444
38606, 0.56521739130435, 0.25434782608696, 0.055555555555556
38607, 0.56521739130435, 0.25434782608696, 0.11111111111111
38608, 0.56521739130435, 0.25434782608696, 0.16666666666667
38609, 0.56521739130435, 0.25434782608696, 0.22222222222222
38610, 0.56521739130435, 0.25434782608696, 0.27777777777778
38611, 0.56521739130435, 0.25434782608696, 0.33333333333333
38612, 0.56521739130435, 0.25434782608696, 0.38888888888889
38613, 0.56521739130435, 0.25434782608696, 0.44444444444444
38614, 0.52173913043478, 0.25434782608696, 0.055555555555556
38615, 0.52173913043478, 0.25434782608696, 0.11111111111111
38616, 0.52173913043478, 0.25434782608696, 0.16666666666667
38617, 0.52173913043478, 0.25434782608696, 0.22222222222222
38618, 0.52173913043478, 0.25434782608696, 0.27777777777778
38619, 0.52173913043478, 0.25434782608696, 0.33333333333333
38620, 0.52173913043478, 0.25434782608696, 0.38888888888889
38621, 0.52173913043478, 0.25434782608696, 0.44444444444444
38622, 0.47826086956522, 0.25434782608696, 0.055555555555556
38623, 0.47826086956522, 0.25434782608696, 0.11111111111111
38624, 0.47826086956522, 0.25434782608696, 0.16666666666667
38625, 0.47826086956522, 0.25434782608696, 0.22222222222222
38626, 0.47826086956522, 0.25434782608696, 0.27777777777778
38627, 0.47826086956522, 0.25434782608696, 0.33333333333333
38628, 0.47826086956522, 0.25434782608696, 0.38888888888889
38629, 0.47826086956522, 0.25434782608696, 0.44444444444444
38630, 0.43478260869565, 0.25434782608696, 0.055555555555556
38631, 0.43478260869565, 0.25434782608696, 0.11111111111111
38632, 0.43478260869565, 0.25434782608696, 0.16666666666667
38633, 0.43478260869565, 0.25434782608696, 0.22222222222222
38634, 0.43478260869565, 0.25434782608696, 0.27777777777778
38635, 0.43478260869565, 0.25434782608696, 0.33333333333333
38636, 0.43478260869565, 0.25434782608696, 0.38888888888889
38637, 0.43478260869565, 0.25434782608696, 0.44444444444444
38638, 0.39130434782609, 0.25434782608696, 0.055555555555556
38639, 0.39130434782609, 0.25434782608696, 0.11111111111111
38640, 0.39130434782609, 0.25434782608696, 0.16666666666667
38641, 0.39130434782609, 0.25434782608696, 0.22222222222222
38642, 0.39130434782609, 0.25434782608696, 0.27777777777778
38643, 0.39130434782609, 0.25434782608696, 0.33333333333333
38644, 0.39130434782609, 0.25434782608696, 0.38888888888889
38645, 0.39130434782609, 0.25434782608696, 0.44444444444444
38646, 0.34782608695652, 0.25434782608696, 0.055555555555556
38647, 0.34782608695652, 0.25434782608696, 0.11111111111111
38648, 0.34782608695652, 0.25434782608696, 0.16666666666667
38649, 0.34782608695652, 0.25434782608696, 0.22222222222222
38650, 0.34782608695652, 0.25434782608696, 0.27777777777778
38651, 0.34782608695652, 0.25434782608696, 0.33333333333333
38652, 0.34782608695652, 0.25434782608696, 0.38888888888889
38653, 0.34782608695652, 0.25434782608696, 0.44444444444444
38654, 0.30434782608696, 0.25434782608696, 0.055555555555556
38655, 0.30434782608696, 0.25434782608696, 0.11111111111111
38656, 0.30434782608696, 0.25434782608696, 0.16666666666667
38657, 0.30434782608696, 0.25434782608696, 0.22222222222222
38658, 0.30434782608696, 0.25434782608696, 0.27777777777778
38659, 0.30434782608696, 0.25434782608696, 0.33333333333333
38660, 0.30434782608696, 0.25434782608696, 0.38888888888889
38661, 0.30434782608696, 0.25434782608696, 0.44444444444444
38662, 0.26086956521739, 0.25434782608696, 0.055555555555556
38663, 0.26086956521739, 0.25434782608696, 0.11111111111111
38664, 0.26086956521739, 0.25434782608696, 0.16666666666667
38665, 0.26086956521739, 0.25434782608696, 0.22222222222222
38666, 0.26086956521739, 0.25434782608696, 0.27777777777778
38667, 0.26086956521739, 0.25434782608696, 0.33333333333333
38668, 0.26086956521739, 0.25434782608696, 0.38888888888889
38669, 0.26086956521739, 0.25434782608696, 0.44444444444444
38670, 0.21739130434783, 0.25434782608696, 0.055555555555556
38671, 0.21739130434783, 0.25434782608696, 0.11111111111111
38672, 0.21739130434783, 0.25434782608696, 0.16666666666667
38673, 0.21739130434783, 0.25434782608696, 0.22222222222222
38674, 0.21739130434783, 0.25434782608696, 0.27777777777778
38675, 0.21739130434783, 0.25434782608696, 0.33333333333333
38676, 0.21739130434783, 0.25434782608696, 0.38888888888889
38677, 0.21739130434783, 0.25434782608696, 0.44444444444444
38678, 0.17391304347826, 0.25434782608696, 0.055555555555556
38679, 0.17391304347826, 0.25434782608696, 0.11111111111111
38680, 0.17391304347826, 0.25434782608696, 0.16666666666667
38681, 0.17391304347826, 0.25434782608696, 0.22222222222222
38682, 0.17391304347826, 0.25434782608696, 0.27777777777778
38683, 0.17391304347826, 0.25434782608696, 0.33333333333333
38684, 0.17391304347826, 0.25434782608696, 0.38888888888889
38685, 0.17391304347826, 0.25434782608696, 0.44444444444444
38686, 0.1304347826087, 0.25434782608696, 0.055555555555556
38687, 0.1304347826087, 0.25434782608696, 0.11111111111111
38688, 0.1304347826087, 0.25434782608696, 0.16666666666667
38689, 0.1304347826087, 0.25434782608696, 0.22222222222222
38690, 0.1304347826087, 0.25434782608696, 0.27777777777778
38691, 0.1304347826087, 0.25434782608696, 0.33333333333333
38692, 0.1304347826087, 0.25434782608696, 0.38888888888889
38693, 0.1304347826087, 0.25434782608696, 0.44444444444444
38694, 0.08695652173913, 0.25434782608696, 0.055555555555556
38695, 0.08695652173913, 0.25434782608696, 0.11111111111111
38696, 0.08695652173913, 0.25434782608696, 0.16666666666667
38697, 0.08695652173913, 0.25434782608696, 0.22222222222222
38698, 0.08695652173913, 0.25434782608696, 0.27777777777778
38699, 0.08695652173913, 0.25434782608696, 0.33333333333333
38700, 0.08695652173913, 0.25434782608696, 0.38888888888889
38701, 0.08695652173913, 0.25434782608696, 0.44444444444444
38702, 0.043478260869565, 0.25434782608696, 0.055555555555556
38703, 0.043478260869565, 0.25434782608696, 0.11111111111111
38704, 0.043478260869565, 0.25434782608696, 0.16666666666667
38705, 0.043478260869565, 0.25434782608696, 0.22222222222222
38706, 0.043478260869565, 0.25434782608696, 0.27777777777778
38707, 0.043478260869565, 0.25434782608696, 0.33333333333333
38708, 0.043478260869565, 0.25434782608696, 0.38888888888889
38709, 0.043478260869565, 0.25434782608696, 0.44444444444444
38710, 0.95652173913044, 0.30652173913043, 0.055555555555556
38711, 0.95652173913044, 0.30652173913043, 0.11111111111111
38712, 0.95652173913044, 0.30652173913043, 0.16666666666667
38713, 0.95652173913044, 0.30652173913043, 0.22222222222222
38714, 0.95652173913044, 0.30652173913043, 0.27777777777778
38715, 0.95652173913044, 0.30652173913043, 0.33333333333333
38716, 0.95652173913044, 0.30652173913043, 0.38888888888889
38717, 0.95652173913044, 0.30652173913043, 0.44444444444444
38718, 0.91304347826087, 0.30652173913043, 0.055555555555556
38719, 0.91304347826087, 0.30652173913043, 0.11111111111111
38720, 0.91304347826087, 0.30652173913043, 0.16666666666667
38721, 0.91304347826087, 0.30652173913043, 0.22222222222222
38722, 0.91304347826087, 0.30652173913043, 0.27777777777778
38723, 0.91304347826087, 0.30652173913043, 0.33333333333333
38724, 0.91304347826087, 0.30652173913043, 0.38888888888889
38725, 0.91304347826087, 0.30652173913043, 0.44444444444444
38726, 0.8695652173913, 0.30652173913043, 0.055555555555556
38727, 0.8695652173913, 0.30652173913043, 0.11111111111111
38728, 0.8695652173913, 0.30652173913043, 0.16666666666667
38729, 0.8695652173913, 0.30652173913043, 0.22222222222222
38730, 0.8695652173913, 0.30652173913043, 0.27777777777778
38731, 0.8695652173913, 0.30652173913043, 0.33333333333333
38732, 0.8695652173913, 0.30652173913043, 0.38888888888889
38733, 0.8695652173913, 0.30652173913043, 0.44444444444444
38734, 0.82608695652174, 0.30652173913043, 0.055555555555556
38735, 0.82608695652174, 0.30652173913043, 0.11111111111111
38736, 0.82608695652174, 0.30652173913043, 0.16666666666667
38737, 0.82608695652174, 0.30652173913043, 0.22222222222222
38738, 0.82608695652174, 0.30652173913043, 0.27777777777778
38739, 0.82608695652174, 0.30652173913043, 0.33333333333333
38740, 0.82608695652174, 0.30652173913043, 0.38888888888889
38741, 0.82608695652174, 0.30652173913043, 0.44444444444444
38742, 0.78260869565217, 0.30652173913043, 0.055555555555556
38743, 0.78260869565217, 0.30652173913043, 0.11111111111111
38744, 0.78260869565217, 0.30652173913043, 0.16666666666667
38745, 0.78260869565217, 0.30652173913043, 0.22222222222222
38746, 0.78260869565217, 0.30652173913043, 0.27777777777778
38747, 0.78260869565217, 0.30652173913043, 0.33333333333333
38748, 0.78260869565217, 0.30652173913043, 0.38888888888889
38749, 0.78260869565217, 0.30652173913043, 0.44444444444444
38750, 0.73913043478261, 0.30652173913043, 0.055555555555556
38751, 0.73913043478261, 0.30652173913043, 0.11111111111111
38752, 0.73913043478261, 0.30652173913043, 0.16666666666667
38753, 0.73913043478261, 0.30652173913043, 0.22222222222222
38754, 0.73913043478261, 0.30652173913043, 0.27777777777778
38755, 0.73913043478261, 0.30652173913043, 0.33333333333333
38756, 0.73913043478261, 0.30652173913043, 0.38888888888889
38757, 0.73913043478261, 0.30652173913043, 0.44444444444444
38758, 0.69565217391304, 0.30652173913043, 0.055555555555556
38759, 0.69565217391304, 0.30652173913043, 0.11111111111111
38760, 0.69565217391304, 0.30652173913043, 0.16666666666667
38761, 0.69565217391304, 0.30652173913044, 0.22222222222222
38762, 0.69565217391304, 0.30652173913043, 0.27777777777778
38763, 0.69565217391304, 0.30652173913043, 0.33333333333333
38764, 0.69565217391304, 0.30652173913043, 0.38888888888889
38765, 0.69565217391304, 0.30652173913043, 0.44444444444444
38766, 0.65217391304348, 0.30652173913043, 0.055555555555556
38767, 0.65217391304348, 0.30652173913043, 0.11111111111111
38768, 0.65217391304348, 0.30652173913043, 0.16666666666667
38769, 0.65217391304348, 0.30652173913043, 0.22222222222222
38770, 0.65217391304348, 0.30652173913043, 0.27777777777778
38771, 0.65217391304348, 0.30652173913043, 0.33333333333333
38772, 0.65217391304348, 0.30652173913043, 0.38888888888889
38773, 0.65217391304348, 0.30652173913043, 0.44444444444444
38774, 0.60869565217391, 0.30652173913043, 0.055555555555556
38775, 0.60869565217391, 0.30652173913043, 0.11111111111111
38776, 0.60869565217391, 0.30652173913043, 0.16666666666667
38777, 0.60869565217391, 0.30652173913043, 0.22222222222222
38778, 0.60869565217391, 0.30652173913043, 0.27777777777778
38779, 0.60869565217391, 0.30652173913043, 0.33333333333333
38780, 0.60869565217391, 0.30652173913043, 0.38888888888889
38781, 0.60869565217391, 0.30652173913043, 0.44444444444444
38782, 0.56521739130435, 0.30652173913043, 0.055555555555556
38783, 0.56521739130435, 0.30652173913043, 0.11111111111111
38784, 0.56521739130435, 0.30652173913043, 0.16666666666667
38785, 0.56521739130435, 0.30652173913043, 0.22222222222222
38786, 0.56521739130435, 0.30652173913043, 0.27777777777778
38787, 0.56521739130435, 0.30652173913043, 0.33333333333333
38788, 0.56521739130435, 0.30652173913043, 0.38888888888889
38789, 0.56521739130435, 0.30652173913043, 0.44444444444444
38790, 0.52173913043478, 0.30652173913043, 0.055555555555556
38791, 0.52173913043478, 0.30652173913043, 0.11111111111111
38792, 0.52173913043478, 0.30652173913043, 0.16666666666667
38793, 0.52173913043478, 0.30652173913043, 0.22222222222222
38794, 0.52173913043478, 0.30652173913043, 0.27777777777778
38795, 0.52173913043478, 0.30652173913043, 0.33333333333333
38796, 0.52173913043478, 0.30652173913043, 0.38888888888889
38797, 0.52173913043478, 0.30652173913043, 0.44444444444444
38798, 0.47826086956522, 0.30652173913043, 0.055555555555556
38799, 0.47826086956522, 0.30652173913043, 0.11111111111111
38800, 0.47826086956522, 0.30652173913043, 0.16666666666667
38801, 0.47826086956522, 0.30652173913043, 0.22222222222222
38802, 0.47826086956522, 0.30652173913043, 0.27777777777778
38803, 0.47826086956522, 0.30652173913043, 0.33333333333333
38804, 0.47826086956522, 0.30652173913043, 0.38888888888889
38805, 0.47826086956522, 0.30652173913043, 0.44444444444444
38806, 0.43478260869565, 0.30652173913043, 0.055555555555556
38807, 0.43478260869565, 0.30652173913043, 0.11111111111111
38808, 0.43478260869565, 0.30652173913043, 0.16666666666667
38809, 0.43478260869565, 0.30652173913043, 0.22222222222222
38810, 0.43478260869565, 0.30652173913043, 0.27777777777778
38811, 0.43478260869565, 0.30652173913043, 0.33333333333333
38812, 0.43478260869565, 0.30652173913043, 0.38888888888889
38813, 0.43478260869565, 0.30652173913043, 0.44444444444444
38814, 0.39130434782609, 0.30652173913043, 0.055555555555556
38815, 0.39130434782609, 0.30652173913043, 0.11111111111111
38816, 0.39130434782609, 0.30652173913043, 0.16666666666667
38817, 0.39130434782609, 0.30652173913043, 0.22222222222222
38818, 0.39130434782609, 0.30652173913043, 0.27777777777778
38819, 0.39130434782609, 0.30652173913043, 0.33333333333333
38820, 0.39130434782609, 0.30652173913043, 0.38888888888889
38821, 0.39130434782609, 0.30652173913043, 0.44444444444444
38822, 0.34782608695652, 0.30652173913043, 0.055555555555556
38823, 0.34782608695652, 0.30652173913043, 0.11111111111111
38824, 0.34782608695652, 0.30652173913043, 0.16666666666667
38825, 0.34782608695652, 0.30652173913043, 0.22222222222222
38826, 0.34782608695652, 0.30652173913043, 0.27777777777778
38827, 0.34782608695652, 0.30652173913043, 0.33333333333333
38828, 0.34782608695652, 0.30652173913043, 0.38888888888889
38829, 0.34782608695652, 0.30652173913043, 0.44444444444444
38830, 0.30434782608696, 0.30652173913043, 0.055555555555556
38831, 0.30434782608696, 0.30652173913043, 0.11111111111111
38832, 0.30434782608696, 0.30652173913043, 0.16666666666667
38833, 0.30434782608696, 0.30652173913043, 0.22222222222222
38834, 0.30434782608696, 0.30652173913043, 0.27777777777778
38835, 0.30434782608696, 0.30652173913043, 0.33333333333333
38836, 0.30434782608696, 0.30652173913043, 0.38888888888889
38837, 0.30434782608696, 0.30652173913043, 0.44444444444444
38838, 0.26086956521739, 0.30652173913043, 0.055555555555556
38839, 0.26086956521739, 0.30652173913043, 0.11111111111111
38840, 0.26086956521739, 0.30652173913043, 0.16666666666667
38841, 0.26086956521739, 0.30652173913043, 0.22222222222222
38842, 0.26086956521739, 0.30652173913043, 0.27777777777778
38843, 0.26086956521739, 0.30652173913043, 0.33333333333333
38844, 0.26086956521739, 0.30652173913043, 0.38888888888889
38845, 0.26086956521739, 0.30652173913043, 0.44444444444444
38846, 0.21739130434783, 0.30652173913043, 0.055555555555556
38847, 0.21739130434783, 0.30652173913043, 0.11111111111111
38848, 0.21739130434783, 0.30652173913043, 0.16666666666667
38849, 0.21739130434783, 0.30652173913043, 0.22222222222222
38850, 0.21739130434783, 0.30652173913043, 0.27777777777778
38851, 0.21739130434783, 0.30652173913043, 0.33333333333333
38852, 0.21739130434783, 0.30652173913043, 0.38888888888889
38853, 0.21739130434783, 0.30652173913043, 0.44444444444444
38854, 0.17391304347826, 0.30652173913043, 0.055555555555556
38855, 0.17391304347826, 0.30652173913043, 0.11111111111111
38856, 0.17391304347826, 0.30652173913043, 0.16666666666667
38857, 0.17391304347826, 0.30652173913043, 0.22222222222222
38858, 0.17391304347826, 0.30652173913043, 0.27777777777778
38859, 0.17391304347826, 0.30652173913043, 0.33333333333333
38860, 0.17391304347826, 0.30652173913043, 0.38888888888889
38861, 0.17391304347826, 0.30652173913043, 0.44444444444444
38862, 0.1304347826087, 0.30652173913043, 0.055555555555556
38863, 0.1304347826087, 0.30652173913043, 0.11111111111111
38864, 0.1304347826087, 0.30652173913043, 0.16666666666667
38865, 0.1304347826087, 0.30652173913043, 0.22222222222222
38866, 0.1304347826087, 0.30652173913043, 0.27777777777778
38867, 0.1304347826087, 0.30652173913043, 0.33333333333333
38868, 0.1304347826087, 0.30652173913043, 0.38888888888889
38869, 0.1304347826087, 0.30652173913043, 0.44444444444444
38870, 0.08695652173913, 0.30652173913043, 0.055555555555556
38871, 0.08695652173913, 0.30652173913043, 0.11111111111111
38872, 0.08695652173913, 0.30652173913043, 0.16666666666667
38873, 0.08695652173913, 0.30652173913043, 0.22222222222222
38874, 0.08695652173913, 0.30652173913043, 0.27777777777778
38875, 0.08695652173913, 0.30652173913043, 0.33333333333333
38876, 0.08695652173913, 0.30652173913043, 0.38888888888889
38877, 0.08695652173913, 0.30652173913043, 0.44444444444444
38878, 0.043478260869565, 0.30652173913043, 0.055555555555556
38879, 0.043478260869565, 0.30652173913043, 0.11111111111111
38880, 0.043478260869565, 0.30652173913043, 0.16666666666667
38881, 0.043478260869565, 0.30652173913043, 0.22222222222222
38882, 0.043478260869565, 0.30652173913043, 0.27777777777778
38883, 0.043478260869565, 0.30652173913043, 0.33333333333333
38884, 0.043478260869565, 0.30652173913043, 0.38888888888889
38885, 0.043478260869565, 0.30652173913043, 0.44444444444444
38886, 0.95652173913043, 0.35869565217391, 0.055555555555556
38887, 0.95652173913044, 0.35869565217391, 0.11111111111111
38888, 0.95652173913044, 0.35869565217391, 0.16666666666667
38889, 0.95652173913044, 0.35869565217391, 0.22222222222222
38890, 0.95652173913044, 0.35869565217391, 0.27777777777778
38891, 0.95652173913044, 0.35869565217391, 0.33333333333333
38892, 0.95652173913043, 0.35869565217391, 0.38888888888889
38893, 0.95652173913044, 0.35869565217391, 0.44444444444444
38894, 0.91304347826087, 0.35869565217391, 0.055555555555556
38895, 0.91304347826087, 0.35869565217391, 0.11111111111111
38896, 0.91304347826087, 0.35869565217391, 0.16666666666667
38897, 0.91304347826087, 0.35869565217391, 0.22222222222222
38898, 0.91304347826087, 0.35869565217391, 0.27777777777778
38899, 0.91304347826087, 0.35869565217391, 0.33333333333333
38900, 0.91304347826087, 0.35869565217391, 0.38888888888889
38901, 0.91304347826087, 0.35869565217391, 0.44444444444444
38902, 0.8695652173913, 0.35869565217391, 0.055555555555556
38903, 0.8695652173913, 0.35869565217391, 0.11111111111111
38904, 0.8695652173913, 0.35869565217391, 0.16666666666667
38905, 0.8695652173913, 0.35869565217391, 0.22222222222222
38906, 0.8695652173913, 0.35869565217391, 0.27777777777778
38907, 0.8695652173913, 0.35869565217391, 0.33333333333333
38908, 0.8695652173913, 0.35869565217391, 0.38888888888889
38909, 0.8695652173913, 0.35869565217391, 0.44444444444444
38910, 0.82608695652174, 0.35869565217391, 0.055555555555556
38911, 0.82608695652174, 0.35869565217391, 0.11111111111111
38912, 0.82608695652174, 0.35869565217391, 0.16666666666667
38913, 0.82608695652174, 0.35869565217391, 0.22222222222222
38914, 0.82608695652174, 0.35869565217391, 0.27777777777778
38915, 0.82608695652174, 0.35869565217391, 0.33333333333333
38916, 0.82608695652174, 0.35869565217391, 0.38888888888889
38917, 0.82608695652174, 0.35869565217391, 0.44444444444444
38918, 0.78260869565217, 0.35869565217391, 0.055555555555556
38919, 0.78260869565217, 0.35869565217391, 0.11111111111111
38920, 0.78260869565217, 0.35869565217391, 0.16666666666667
38921, 0.78260869565217, 0.35869565217391, 0.22222222222222
38922, 0.78260869565217, 0.35869565217391, 0.27777777777778
38923, 0.78260869565217, 0.35869565217391, 0.33333333333333
38924, 0.78260869565217, 0.35869565217391, 0.38888888888889
38925, 0.78260869565217, 0.35869565217391, 0.44444444444444
38926, 0.73913043478261, 0.35869565217391, 0.055555555555556
38927, 0.73913043478261, 0.35869565217391, 0.11111111111111
38928, 0.73913043478261, 0.35869565217391, 0.16666666666667
38929, 0.73913043478261, 0.35869565217391, 0.22222222222222
38930, 0.73913043478261, 0.35869565217391, 0.27777777777778
38931, 0.73913043478261, 0.35869565217391, 0.33333333333333
38932, 0.73913043478261, 0.35869565217391, 0.38888888888889
38933, 0.73913043478261, 0.35869565217391, 0.44444444444444
38934, 0.69565217391304, 0.35869565217391, 0.055555555555556
38935, 0.69565217391304, 0.35869565217391, 0.11111111111111
38936, 0.69565217391304, 0.35869565217391, 0.16666666666667
38937, 0.69565217391304, 0.35869565217391, 0.22222222222222
38938, 0.69565217391304, 0.35869565217391, 0.27777777777778
38939, 0.69565217391304, 0.35869565217391, 0.33333333333333
38940, 0.69565217391304, 0.35869565217391, 0.38888888888889
38941, 0.69565217391304, 0.35869565217391, 0.44444444444444
38942, 0.65217391304348, 0.35869565217391, 0.055555555555556
38943, 0.65217391304348, 0.35869565217391, 0.11111111111111
38944, 0.65217391304348, 0.35869565217391, 0.16666666666667
38945, 0.65217391304348, 0.35869565217391, 0.22222222222222
38946, 0.65217391304348, 0.35869565217391, 0.27777777777778
38947, 0.65217391304348, 0.35869565217391, 0.33333333333333
38948, 0.65217391304348, 0.35869565217391, 0.38888888888889
38949, 0.65217391304348, 0.35869565217391, 0.44444444444444
38950, 0.60869565217391, 0.35869565217391, 0.055555555555556
38951, 0.60869565217391, 0.35869565217391, 0.11111111111111
38952, 0.60869565217391, 0.35869565217391, 0.16666666666667
38953, 0.60869565217391, 0.35869565217391, 0.22222222222222
38954, 0.60869565217391, 0.35869565217391, 0.27777777777778
38955, 0.60869565217391, 0.35869565217391, 0.33333333333333
38956, 0.60869565217391, 0.35869565217391, 0.38888888888889
38957, 0.60869565217391, 0.35869565217391, 0.44444444444444
38958, 0.56521739130435, 0.35869565217391, 0.055555555555556
38959, 0.56521739130435, 0.35869565217391, 0.11111111111111
38960, 0.56521739130435, 0.35869565217391, 0.16666666666667
38961, 0.56521739130435, 0.35869565217391, 0.22222222222222
38962, 0.56521739130435, 0.35869565217391, 0.27777777777778
38963, 0.56521739130435, 0.35869565217391, 0.33333333333333
38964, 0.56521739130435, 0.35869565217391, 0.38888888888889
38965, 0.56521739130435, 0.35869565217391, 0.44444444444444
38966, 0.52173913043478, 0.35869565217391, 0.055555555555556
38967, 0.52173913043478, 0.35869565217391, 0.11111111111111
38968, 0.52173913043478, 0.35869565217391, 0.16666666666667
38969, 0.52173913043478, 0.35869565217391, 0.22222222222222
38970, 0.52173913043478, 0.35869565217391, 0.27777777777778
38971, 0.52173913043478, 0.35869565217391, 0.33333333333333
38972, 0.52173913043478, 0.35869565217391, 0.38888888888889
38973, 0.52173913043478, 0.35869565217391, 0.44444444444444
38974, 0.47826086956522, 0.35869565217391, 0.055555555555556
38975, 0.47826086956522, 0.35869565217391, 0.11111111111111
38976, 0.47826086956522, 0.35869565217391, 0.16666666666667
38977, 0.47826086956522, 0.35869565217391, 0.22222222222222
38978, 0.47826086956522, 0.35869565217391, 0.27777777777778
38979, 0.47826086956522, 0.35869565217391, 0.33333333333333
38980, 0.47826086956522, 0.35869565217391, 0.38888888888889
38981, 0.47826086956522, 0.35869565217391, 0.44444444444444
38982, 0.43478260869565, 0.35869565217391, 0.055555555555556
38983, 0.43478260869565, 0.35869565217391, 0.11111111111111
38984, 0.43478260869565, 0.35869565217391, 0.16666666666667
38985, 0.43478260869565, 0.35869565217391, 0.22222222222222
38986, 0.43478260869565, 0.35869565217391, 0.27777777777778
38987, 0.43478260869565, 0.35869565217391, 0.33333333333333
38988, 0.43478260869565, 0.35869565217391, 0.38888888888889
38989, 0.43478260869565, 0.35869565217391, 0.44444444444444
38990, 0.39130434782609, 0.35869565217391, 0.055555555555556
38991, 0.39130434782609, 0.35869565217391, 0.11111111111111
38992, 0.39130434782609, 0.35869565217391, 0.16666666666667
38993, 0.39130434782609, 0.35869565217391, 0.22222222222222
38994, 0.39130434782609, 0.35869565217391, 0.27777777777778
38995, 0.39130434782609, 0.35869565217391, 0.33333333333333
38996, 0.39130434782609, 0.35869565217391, 0.38888888888889
38997, 0.39130434782609, 0.35869565217391, 0.44444444444444
38998, 0.34782608695652, 0.35869565217391, 0.055555555555556
38999, 0.34782608695652, 0.35869565217391, 0.11111111111111
39000, 0.34782608695652, 0.35869565217391, 0.16666666666667
39001, 0.34782608695652, 0.35869565217391, 0.22222222222222
39002, 0.34782608695652, 0.35869565217391, 0.27777777777778
39003, 0.34782608695652, 0.35869565217391, 0.33333333333333
39004, 0.34782608695652, 0.35869565217391, 0.38888888888889
39005, 0.34782608695652, 0.35869565217391, 0.44444444444444
39006, 0.30434782608696, 0.35869565217391, 0.055555555555556
39007, 0.30434782608696, 0.35869565217391, 0.11111111111111
39008, 0.30434782608696, 0.35869565217391, 0.16666666666667
39009, 0.30434782608696, 0.35869565217391, 0.22222222222222
39010, 0.30434782608696, 0.35869565217391, 0.27777777777778
39011, 0.30434782608696, 0.35869565217391, 0.33333333333333
39012, 0.30434782608696, 0.35869565217391, 0.38888888888889
39013, 0.30434782608696, 0.35869565217391, 0.44444444444444
39014, 0.26086956521739, 0.35869565217391, 0.055555555555556
39015, 0.26086956521739, 0.35869565217391, 0.11111111111111
39016, 0.26086956521739, 0.35869565217391, 0.16666666666667
39017, 0.26086956521739, 0.35869565217391, 0.22222222222222
39018, 0.26086956521739, 0.35869565217391, 0.27777777777778
39019, 0.26086956521739, 0.35869565217391, 0.33333333333333
39020, 0.26086956521739, 0.35869565217391, 0.38888888888889
39021, 0.26086956521739, 0.35869565217391, 0.44444444444444
39022, 0.21739130434783, 0.35869565217391, 0.055555555555556
39023, 0.21739130434783, 0.35869565217391, 0.11111111111111
39024, 0.21739130434783, 0.35869565217391, 0.16666666666667
39025, 0.21739130434783, 0.35869565217391, 0.22222222222222
39026, 0.21739130434783, 0.35869565217391, 0.27777777777778
39027, 0.21739130434783, 0.35869565217391, 0.33333333333333
39028, 0.21739130434783, 0.35869565217391, 0.38888888888889
39029, 0.21739130434783, 0.35869565217391, 0.44444444444444
39030, 0.17391304347826, 0.35869565217391, 0.055555555555556
39031, 0.17391304347826, 0.35869565217391, 0.11111111111111
39032, 0.17391304347826, 0.35869565217391, 0.16666666666667
39033, 0.17391304347826, 0.35869565217391, 0.22222222222222
39034, 0.17391304347826, 0.35869565217391, 0.27777777777778
39035, 0.17391304347826, 0.35869565217391, 0.33333333333333
39036, 0.17391304347826, 0.35869565217391, 0.38888888888889
39037, 0.17391304347826, 0.35869565217391, 0.44444444444444
39038, 0.1304347826087, 0.35869565217391, 0.055555555555556
39039, 0.1304347826087, 0.35869565217391, 0.11111111111111
39040, 0.1304347826087, 0.35869565217391, 0.16666666666667
39041, 0.1304347826087, 0.35869565217391, 0.22222222222222
39042, 0.1304347826087, 0.35869565217391, 0.27777777777778
39043, 0.1304347826087, 0.35869565217391, 0.33333333333333
39044, 0.1304347826087, 0.35869565217391, 0.38888888888889
39045, 0.1304347826087, 0.35869565217391, 0.44444444444444
39046, 0.08695652173913, 0.35869565217391, 0.055555555555556
39047, 0.08695652173913, 0.35869565217391, 0.11111111111111
39048, 0.08695652173913, 0.35869565217391, 0.16666666666667
39049, 0.08695652173913, 0.35869565217391, 0.22222222222222
39050, 0.08695652173913, 0.35869565217391, 0.27777777777778
39051, 0.08695652173913, 0.35869565217391, 0.33333333333333
39052, 0.08695652173913, 0.35869565217391, 0.38888888888889
39053, 0.08695652173913, 0.35869565217391, 0.44444444444444
39054, 0.043478260869565, 0.35869565217391, 0.055555555555556
39055, 0.043478260869565, 0.35869565217391, 0.11111111111111
39056, 0.043478260869565, 0.35869565217391, 0.16666666666667
39057, 0.043478260869565, 0.35869565217391, 0.22222222222222
39058, 0.043478260869565, 0.35869565217391, 0.27777777777778
39059, 0.043478260869565, 0.35869565217391, 0.33333333333333
39060, 0.043478260869565, 0.35869565217391, 0.38888888888889
39061, 0.043478260869565, 0.35869565217391, 0.44444444444444
39062, 0.95652173913043, 0.41086956521739, 0.055555555555556
39063, 0.95652173913044, 0.41086956521739, 0.11111111111111
39064, 0.95652173913044, 0.41086956521739, 0.16666666666667
39065, 0.95652173913044, 0.41086956521739, 0.22222222222222
39066, 0.95652173913044, 0.41086956521739, 0.27777777777778
39067, 0.95652173913044, 0.41086956521739, 0.33333333333333
39068, 0.95652173913044, 0.41086956521739, 0.38888888888889
39069, 0.95652173913043, 0.41086956521739, 0.44444444444444
39070, 0.91304347826087, 0.41086956521739, 0.055555555555556
39071, 0.91304347826087, 0.41086956521739, 0.11111111111111
39072, 0.91304347826087, 0.41086956521739, 0.16666666666667
39073, 0.91304347826087, 0.41086956521739, 0.22222222222222
39074, 0.91304347826087, 0.41086956521739, 0.27777777777778
39075, 0.91304347826087, 0.41086956521739, 0.33333333333333
39076, 0.91304347826087, 0.41086956521739, 0.38888888888889
39077, 0.91304347826087, 0.41086956521739, 0.44444444444444
39078, 0.8695652173913, 0.41086956521739, 0.055555555555556
39079, 0.8695652173913, 0.41086956521739, 0.11111111111111
39080, 0.8695652173913, 0.41086956521739, 0.16666666666667
39081, 0.8695652173913, 0.41086956521739, 0.22222222222222
39082, 0.8695652173913, 0.41086956521739, 0.27777777777778
39083, 0.8695652173913, 0.41086956521739, 0.33333333333333
39084, 0.8695652173913, 0.41086956521739, 0.38888888888889
39085, 0.8695652173913, 0.41086956521739, 0.44444444444444
39086, 0.82608695652174, 0.41086956521739, 0.055555555555556
39087, 0.82608695652174, 0.41086956521739, 0.11111111111111
39088, 0.82608695652174, 0.41086956521739, 0.16666666666667
39089, 0.82608695652174, 0.41086956521739, 0.22222222222222
39090, 0.82608695652174, 0.41086956521739, 0.27777777777778
39091, 0.82608695652174, 0.41086956521739, 0.33333333333333
39092, 0.82608695652174, 0.41086956521739, 0.38888888888889
39093, 0.82608695652174, 0.41086956521739, 0.44444444444444
39094, 0.78260869565217, 0.41086956521739, 0.055555555555556
39095, 0.78260869565217, 0.41086956521739, 0.11111111111111
39096, 0.78260869565217, 0.41086956521739, 0.16666666666667
39097, 0.78260869565217, 0.41086956521739, 0.22222222222222
39098, 0.78260869565217, 0.41086956521739, 0.27777777777778
39099, 0.78260869565217, 0.41086956521739, 0.33333333333333
39100, 0.78260869565217, 0.41086956521739, 0.38888888888889
39101, 0.78260869565217, 0.41086956521739, 0.44444444444444
39102, 0.73913043478261, 0.41086956521739, 0.055555555555556
39103, 0.73913043478261, 0.41086956521739, 0.11111111111111
39104, 0.73913043478261, 0.41086956521739, 0.16666666666667
39105, 0.73913043478261, 0.41086956521739, 0.22222222222222
39106, 0.73913043478261, 0.41086956521739, 0.27777777777778
39107, 0.73913043478261, 0.41086956521739, 0.33333333333333
39108, 0.73913043478261, 0.41086956521739, 0.38888888888889
39109, 0.73913043478261, 0.41086956521739, 0.44444444444444
39110, 0.69565217391304, 0.41086956521739, 0.055555555555556
39111, 0.69565217391304, 0.41086956521739, 0.11111111111111
39112, 0.69565217391304, 0.41086956521739, 0.16666666666667
39113, 0.69565217391304, 0.41086956521739, 0.22222222222222
39114, 0.69565217391304, 0.41086956521739, 0.27777777777778
39115, 0.69565217391304, 0.41086956521739, 0.33333333333333
39116, 0.69565217391304, 0.41086956521739, 0.38888888888889
39117, 0.69565217391304, 0.41086956521739, 0.44444444444444
39118, 0.65217391304348, 0.41086956521739, 0.055555555555556
39119, 0.65217391304348, 0.41086956521739, 0.11111111111111
39120, 0.65217391304348, 0.41086956521739, 0.16666666666667
39121, 0.65217391304348, 0.41086956521739, 0.22222222222222
39122, 0.65217391304348, 0.41086956521739, 0.27777777777778
39123, 0.65217391304348, 0.41086956521739, 0.33333333333333
39124, 0.65217391304348, 0.41086956521739, 0.38888888888889
39125, 0.65217391304348, 0.41086956521739, 0.44444444444444
39126, 0.60869565217391, 0.41086956521739, 0.055555555555556
39127, 0.60869565217391, 0.41086956521739, 0.11111111111111
39128, 0.60869565217391, 0.41086956521739, 0.16666666666667
39129, 0.60869565217391, 0.41086956521739, 0.22222222222222
39130, 0.60869565217391, 0.41086956521739, 0.27777777777778
39131, 0.60869565217391, 0.41086956521739, 0.33333333333333
39132, 0.60869565217391, 0.41086956521739, 0.38888888888889
39133, 0.60869565217391, 0.41086956521739, 0.44444444444444
39134, 0.56521739130435, 0.41086956521739, 0.055555555555556
39135, 0.56521739130435, 0.41086956521739, 0.11111111111111
39136, 0.56521739130435, 0.41086956521739, 0.16666666666667
39137, 0.56521739130435, 0.41086956521739, 0.22222222222222
39138, 0.56521739130435, 0.41086956521739, 0.27777777777778
39139, 0.56521739130435, 0.41086956521739, 0.33333333333333
39140, 0.56521739130435, 0.41086956521739, 0.38888888888889
39141, 0.56521739130435, 0.41086956521739, 0.44444444444444
39142, 0.52173913043478, 0.41086956521739, 0.055555555555556
39143, 0.52173913043478, 0.41086956521739, 0.11111111111111
39144, 0.52173913043478, 0.41086956521739, 0.16666666666667
39145, 0.52173913043478, 0.41086956521739, 0.22222222222222
39146, 0.52173913043478, 0.41086956521739, 0.27777777777778
39147, 0.52173913043478, 0.41086956521739, 0.33333333333333
39148, 0.52173913043478, 0.41086956521739, 0.38888888888889
39149, 0.52173913043478, 0.41086956521739, 0.44444444444444
39150, 0.47826086956522, 0.41086956521739, 0.055555555555556
39151, 0.47826086956522, 0.41086956521739, 0.11111111111111
39152, 0.47826086956522, 0.41086956521739, 0.16666666666667
39153, 0.47826086956522, 0.41086956521739, 0.22222222222222
39154, 0.47826086956522, 0.41086956521739, 0.27777777777778
39155, 0.47826086956522, 0.41086956521739, 0.33333333333333
39156, 0.47826086956522, 0.41086956521739, 0.38888888888889
39157, 0.47826086956522, 0.41086956521739, 0.44444444444444
39158, 0.43478260869565, 0.41086956521739, 0.055555555555556
39159, 0.43478260869565, 0.41086956521739, 0.11111111111111
39160, 0.43478260869565, 0.41086956521739, 0.16666666666667
39161, 0.43478260869565, 0.41086956521739, 0.22222222222222
39162, 0.43478260869565, 0.41086956521739, 0.27777777777778
39163, 0.43478260869565, 0.41086956521739, 0.33333333333333
39164, 0.43478260869565, 0.41086956521739, 0.38888888888889
39165, 0.43478260869565, 0.41086956521739, 0.44444444444444
39166, 0.39130434782609, 0.41086956521739, 0.055555555555556
39167, 0.39130434782609, 0.41086956521739, 0.11111111111111
39168, 0.39130434782609, 0.41086956521739, 0.16666666666667
39169, 0.39130434782609, 0.41086956521739, 0.22222222222222
39170, 0.39130434782609, 0.41086956521739, 0.27777777777778
39171, 0.39130434782609, 0.41086956521739, 0.33333333333333
39172, 0.39130434782609, 0.41086956521739, 0.38888888888889
39173, 0.39130434782609, 0.41086956521739, 0.44444444444444
39174, 0.34782608695652, 0.41086956521739, 0.055555555555556
39175, 0.34782608695652, 0.41086956521739, 0.11111111111111
39176, 0.34782608695652, 0.41086956521739, 0.16666666666667
39177, 0.34782608695652, 0.41086956521739, 0.22222222222222
39178, 0.34782608695652, 0.41086956521739, 0.27777777777778
39179, 0.34782608695652, 0.41086956521739, 0.33333333333333
39180, 0.34782608695652, 0.41086956521739, 0.38888888888889
39181, 0.34782608695652, 0.41086956521739, 0.44444444444444
39182, 0.30434782608696, 0.41086956521739, 0.055555555555556
39183, 0.30434782608696, 0.41086956521739, 0.11111111111111
39184, 0.30434782608696, 0.41086956521739, 0.16666666666667
39185, 0.30434782608696, 0.41086956521739, 0.22222222222222
39186, 0.30434782608696, 0.41086956521739, 0.27777777777778
39187, 0.30434782608696, 0.41086956521739, 0.33333333333333
39188, 0.30434782608696, 0.41086956521739, 0.38888888888889
39189, 0.30434782608696, 0.41086956521739, 0.44444444444444
39190, 0.26086956521739, 0.41086956521739, 0.055555555555556
39191, 0.26086956521739, 0.41086956521739, 0.11111111111111
39192, 0.26086956521739, 0.41086956521739, 0.16666666666667
39193, 0.26086956521739, 0.41086956521739, 0.22222222222222
39194, 0.26086956521739, 0.41086956521739, 0.27777777777778
39195, 0.26086956521739, 0.41086956521739, 0.33333333333333
39196, 0.26086956521739, 0.41086956521739, 0.38888888888889
39197, 0.26086956521739, 0.41086956521739, 0.44444444444444
39198, 0.21739130434783, 0.41086956521739, 0.055555555555556
39199, 0.21739130434783, 0.41086956521739, 0.11111111111111
39200, 0.21739130434783, 0.41086956521739, 0.16666666666667
39201, 0.21739130434783, 0.41086956521739, 0.22222222222222
39202, 0.21739130434783, 0.41086956521739, 0.27777777777778
39203, 0.21739130434783, 0.41086956521739, 0.33333333333333
39204, 0.21739130434783, 0.41086956521739, 0.38888888888889
39205, 0.21739130434783, 0.41086956521739, 0.44444444444444
39206, 0.17391304347826, 0.41086956521739, 0.055555555555556
39207, 0.17391304347826, 0.41086956521739, 0.11111111111111
39208, 0.17391304347826, 0.41086956521739, 0.16666666666667
39209, 0.17391304347826, 0.41086956521739, 0.22222222222222
39210, 0.17391304347826, 0.41086956521739, 0.27777777777778
39211, 0.17391304347826, 0.41086956521739, 0.33333333333333
39212, 0.17391304347826, 0.41086956521739, 0.38888888888889
39213, 0.17391304347826, 0.41086956521739, 0.44444444444444
39214, 0.1304347826087, 0.41086956521739, 0.055555555555556
39215, 0.1304347826087, 0.41086956521739, 0.11111111111111
39216, 0.1304347826087, 0.41086956521739, 0.16666666666667
39217, 0.1304347826087, 0.41086956521739, 0.22222222222222
39218, 0.1304347826087, 0.41086956521739, 0.27777777777778
39219, 0.1304347826087, 0.41086956521739, 0.33333333333333
39220, 0.1304347826087, 0.41086956521739, 0.38888888888889
39221, 0.1304347826087, 0.41086956521739, 0.44444444444444
39222, 0.08695652173913, 0.41086956521739, 0.055555555555556
39223, 0.08695652173913, 0.41086956521739, 0.11111111111111
39224, 0.08695652173913, 0.41086956521739, 0.16666666666667
39225, 0.08695652173913, 0.41086956521739, 0.22222222222222
39226, 0.08695652173913, 0.41086956521739, 0.27777777777778
39227, 0.08695652173913, 0.41086956521739, 0.33333333333333
39228, 0.08695652173913, 0.41086956521739, 0.38888888888889
39229, 0.08695652173913, 0.41086956521739, 0.44444444444444
39230, 0.043478260869565, 0.41086956521739, 0.055555555555556
39231, 0.043478260869565, 0.41086956521739, 0.11111111111111
39232, 0.043478260869565, 0.41086956521739, 0.16666666666667
39233, 0.043478260869565, 0.41086956521739, 0.22222222222222
39234, 0.043478260869565, 0.41086956521739, 0.27777777777778
39235, 0.043478260869565, 0.41086956521739, 0.33333333333333
39236, 0.043478260869565, 0.41086956521739, 0.38888888888889
39237, 0.043478260869565, 0.41086956521739, 0.44444444444444
39238, 0.95652173913043, 0.46304347826087, 0.055555555555556
39239, 0.95652173913044, 0.46304347826087, 0.11111111111111
39240, 0.95652173913043, 0.46304347826087, 0.16666666666667
39241, 0.95652173913044, 0.46304347826087, 0.22222222222222
39242, 0.95652173913044, 0.46304347826087, 0.27777777777778
39243, 0.95652173913044, 0.46304347826087, 0.33333333333333
39244, 0.95652173913044, 0.46304347826087, 0.38888888888889
39245, 0.95652173913044, 0.46304347826087, 0.44444444444444
39246, 0.91304347826087, 0.46304347826087, 0.055555555555556
39247, 0.91304347826087, 0.46304347826087, 0.11111111111111
39248, 0.91304347826087, 0.46304347826087, 0.16666666666667
39249, 0.91304347826087, 0.46304347826087, 0.22222222222222
39250, 0.91304347826087, 0.46304347826087, 0.27777777777778
39251, 0.91304347826087, 0.46304347826087, 0.33333333333333
39252, 0.91304347826087, 0.46304347826087, 0.38888888888889
39253, 0.91304347826087, 0.46304347826087, 0.44444444444444
39254, 0.8695652173913, 0.46304347826087, 0.055555555555556
39255, 0.8695652173913, 0.46304347826087, 0.11111111111111
39256, 0.8695652173913, 0.46304347826087, 0.16666666666667
39257, 0.8695652173913, 0.46304347826087, 0.22222222222222
39258, 0.8695652173913, 0.46304347826087, 0.27777777777778
39259, 0.8695652173913, 0.46304347826087, 0.33333333333333
39260, 0.8695652173913, 0.46304347826087, 0.38888888888889
39261, 0.8695652173913, 0.46304347826087, 0.44444444444444
39262, 0.82608695652174, 0.46304347826087, 0.055555555555556
39263, 0.82608695652174, 0.46304347826087, 0.11111111111111
39264, 0.82608695652174, 0.46304347826087, 0.16666666666667
39265, 0.82608695652174, 0.46304347826087, 0.22222222222222
39266, 0.82608695652174, 0.46304347826087, 0.27777777777778
39267, 0.82608695652174, 0.46304347826087, 0.33333333333333
39268, 0.82608695652174, 0.46304347826087, 0.38888888888889
39269, 0.82608695652174, 0.46304347826087, 0.44444444444444
39270, 0.78260869565217, 0.46304347826087, 0.055555555555556
39271, 0.78260869565217, 0.46304347826087, 0.11111111111111
39272, 0.78260869565217, 0.46304347826087, 0.16666666666667
39273, 0.78260869565217, 0.46304347826087, 0.22222222222222
39274, 0.78260869565217, 0.46304347826087, 0.27777777777778
39275, 0.78260869565217, 0.46304347826087, 0.33333333333333
39276, 0.78260869565217, 0.46304347826087, 0.38888888888889
39277, 0.78260869565217, 0.46304347826087, 0.44444444444444
39278, 0.73913043478261, 0.46304347826087, 0.055555555555556
39279, 0.73913043478261, 0.46304347826087, 0.11111111111111
39280, 0.73913043478261, 0.46304347826087, 0.16666666666667
39281, 0.73913043478261, 0.46304347826087, 0.22222222222222
39282, 0.73913043478261, 0.46304347826087, 0.27777777777778
39283, 0.73913043478261, 0.46304347826087, 0.33333333333333
39284, 0.73913043478261, 0.46304347826087, 0.38888888888889
39285, 0.73913043478261, 0.46304347826087, 0.44444444444444
39286, 0.69565217391304, 0.46304347826087, 0.055555555555556
39287, 0.69565217391304, 0.46304347826087, 0.11111111111111
39288, 0.69565217391304, 0.46304347826087, 0.16666666666667
39289, 0.69565217391304, 0.46304347826087, 0.22222222222222
39290, 0.69565217391304, 0.46304347826087, 0.27777777777778
39291, 0.69565217391304, 0.46304347826087, 0.33333333333333
39292, 0.69565217391304, 0.46304347826087, 0.38888888888889
39293, 0.69565217391304, 0.46304347826087, 0.44444444444444
39294, 0.65217391304348, 0.46304347826087, 0.055555555555556
39295, 0.65217391304348, 0.46304347826087, 0.11111111111111
39296, 0.65217391304348, 0.46304347826087, 0.16666666666667
39297, 0.65217391304348, 0.46304347826087, 0.22222222222222
39298, 0.65217391304348, 0.46304347826087, 0.27777777777778
39299, 0.65217391304348, 0.46304347826087, 0.33333333333333
39300, 0.65217391304348, 0.46304347826087, 0.38888888888889
39301, 0.65217391304348, 0.46304347826087, 0.44444444444444
39302, 0.60869565217391, 0.46304347826087, 0.055555555555556
39303, 0.60869565217391, 0.46304347826087, 0.11111111111111
39304, 0.60869565217391, 0.46304347826087, 0.16666666666667
39305, 0.60869565217391, 0.46304347826087, 0.22222222222222
39306, 0.60869565217391, 0.46304347826087, 0.27777777777778
39307, 0.60869565217391, 0.46304347826087, 0.33333333333333
39308, 0.60869565217391, 0.46304347826087, 0.38888888888889
39309, 0.60869565217391, 0.46304347826087, 0.44444444444444
39310, 0.56521739130435, 0.46304347826087, 0.055555555555556
39311, 0.56521739130435, 0.46304347826087, 0.11111111111111
39312, 0.56521739130435, 0.46304347826087, 0.16666666666667
39313, 0.56521739130435, 0.46304347826087, 0.22222222222222
39314, 0.56521739130435, 0.46304347826087, 0.27777777777778
39315, 0.56521739130435, 0.46304347826087, 0.33333333333333
39316, 0.56521739130435, 0.46304347826087, 0.38888888888889
39317, 0.56521739130435, 0.46304347826087, 0.44444444444444
39318, 0.52173913043478, 0.46304347826087, 0.055555555555556
39319, 0.52173913043478, 0.46304347826087, 0.11111111111111
39320, 0.52173913043478, 0.46304347826087, 0.16666666666667
39321, 0.52173913043478, 0.46304347826087, 0.22222222222222
39322, 0.52173913043478, 0.46304347826087, 0.27777777777778
39323, 0.52173913043478, 0.46304347826087, 0.33333333333333
39324, 0.52173913043478, 0.46304347826087, 0.38888888888889
39325, 0.52173913043478, 0.46304347826087, 0.44444444444444
39326, 0.47826086956522, 0.46304347826087, 0.055555555555556
39327, 0.47826086956522, 0.46304347826087, 0.11111111111111
39328, 0.47826086956522, 0.46304347826087, 0.16666666666667
39329, 0.47826086956522, 0.46304347826087, 0.22222222222222
39330, 0.47826086956522, 0.46304347826087, 0.27777777777778
39331, 0.47826086956522, 0.46304347826087, 0.33333333333333
39332, 0.47826086956522, 0.46304347826087, 0.38888888888889
39333, 0.47826086956522, 0.46304347826087, 0.44444444444444
39334, 0.43478260869565, 0.46304347826087, 0.055555555555556
39335, 0.43478260869565, 0.46304347826087, 0.11111111111111
39336, 0.43478260869565, 0.46304347826087, 0.16666666666667
39337, 0.43478260869565, 0.46304347826087, 0.22222222222222
39338, 0.43478260869565, 0.46304347826087, 0.27777777777778
39339, 0.43478260869565, 0.46304347826087, 0.33333333333333
39340, 0.43478260869565, 0.46304347826087, 0.38888888888889
39341, 0.43478260869565, 0.46304347826087, 0.44444444444444
39342, 0.39130434782609, 0.46304347826087, 0.055555555555556
39343, 0.39130434782609, 0.46304347826087, 0.11111111111111
39344, 0.39130434782609, 0.46304347826087, 0.16666666666667
39345, 0.39130434782609, 0.46304347826087, 0.22222222222222
39346, 0.39130434782609, 0.46304347826087, 0.27777777777778
39347, 0.39130434782609, 0.46304347826087, 0.33333333333333
39348, 0.39130434782609, 0.46304347826087, 0.38888888888889
39349, 0.39130434782609, 0.46304347826087, 0.44444444444444
39350, 0.34782608695652, 0.46304347826087, 0.055555555555556
39351, 0.34782608695652, 0.46304347826087, 0.11111111111111
39352, 0.34782608695652, 0.46304347826087, 0.16666666666667
39353, 0.34782608695652, 0.46304347826087, 0.22222222222222
39354, 0.34782608695652, 0.46304347826087, 0.27777777777778
39355, 0.34782608695652, 0.46304347826087, 0.33333333333333
39356, 0.34782608695652, 0.46304347826087, 0.38888888888889
39357, 0.34782608695652, 0.46304347826087, 0.44444444444444
39358, 0.30434782608696, 0.46304347826087, 0.055555555555556
39359, 0.30434782608696, 0.46304347826087, 0.11111111111111
39360, 0.30434782608696, 0.46304347826087, 0.16666666666667
39361, 0.30434782608696, 0.46304347826087, 0.22222222222222
39362, 0.30434782608696, 0.46304347826087, 0.27777777777778
39363, 0.30434782608696, 0.46304347826087, 0.33333333333333
39364, 0.30434782608696, 0.46304347826087, 0.38888888888889
39365, 0.30434782608696, 0.46304347826087, 0.44444444444444
39366, 0.26086956521739, 0.46304347826087, 0.055555555555556
39367, 0.26086956521739, 0.46304347826087, 0.11111111111111
39368, 0.26086956521739, 0.46304347826087, 0.16666666666667
39369, 0.26086956521739, 0.46304347826087, 0.22222222222222
39370, 0.26086956521739, 0.46304347826087, 0.27777777777778
39371, 0.26086956521739, 0.46304347826087, 0.33333333333333
39372, 0.26086956521739, 0.46304347826087, 0.38888888888889
39373, 0.26086956521739, 0.46304347826087, 0.44444444444444
