26536, 1.9391304347826, 0.25434782608696, 0
26537, 1.9826086956522, 0.25434782608696, 0
26538, 2.0260869565217, 0.25434782608696, 0
26539, 2.0695652173913, 0.25434782608696, 0
26540, 2.1130434782609, 0.25434782608696, 0
26541, 2.1565217391304, 0.25434782608696, 0
26542, 1.2434782608696, 0.20217391304348, 0
26543, 1.2869565217391, 0.20217391304348, 0
26544, 1.3304347826087, 0.20217391304348, 0
26545, 1.3739130434783, 0.20217391304348, 0
26546, 1.4173913043478, 0.20217391304348, 0
26547, 1.4608695652174, 0.20217391304348, 0
26548, 1.504347826087, 0.20217391304348, 0
26549, 1.5478260869565, 0.20217391304348, 0
26550, 1.5913043478261, 0.20217391304348, 0
26551, 1.6347826086957, 0.20217391304348, 0
26552, 1.6782608695652, 0.20217391304348, 0
26553, 1.7217391304348, 0.20217391304348, 0
26554, 1.7652173913043, 0.20217391304348, 0
26555, 1.8086956521739, 0.20217391304348, 0
26556, 1.8521739130435, 0.20217391304348, 0
26557, 1.895652173913, 0.20217391304348, 0
26558, 1.9391304347826, 0.20217391304348, 0
26559, 1.9826086956522, 0.20217391304348, 0
26560, 2.0260869565217, 0.20217391304348, 0
26561, 2.0695652173913, 0.20217391304348, 0
26562, 2.1130434782609, 0.20217391304348, 0
26563, 2.1565217391304, 0.20217391304348, 0
26564, 1.2434782608696, 1.3239130434783, 0
26565, 1.2217391304348, 1.2978260869565, 0
26566, 1.2869565217391, 1.3239130434783, 0
26567, 1.2652173913043, 1.2978260869565, 0
26568, 1.3304347826087, 1.3239130434783, 0
26569, 1.3086956521739, 1.2978260869565, 0
26570, 1.3739130434783, 1.3239130434783, 0
26571, 1.3521739130435, 1.2978260869565, 0
26572, 1.4173913043478, 1.3239130434783, 0
26573, 1.395652173913, 1.2978260869565, 0
26574, 1.4608695652174, 1.3239130434783, 0
26575, 1.4391304347826, 1.2978260869565, 0
26576, 1.504347826087, 1.3239130434783, 0
26577, 1.4826086956522, 1.2978260869565, 0
26578, 1.5478260869565, 1.3239130434783, 0
26579, 1.5260869565217, 1.2978260869565, 0
26580, 1.5913043478261, 1.3239130434783, 0
26581, 1.5695652173913, 1.2978260869565, 0
26582, 1.6347826086957, 1.3239130434783, 0
26583, 1.6130434782609, 1.2978260869565, 0
26584, 1.6782608695652, 1.3239130434783, 0
26585, 1.6565217391304, 1.2978260869565, 0
26586, 1.7217391304348, 1.3239130434783, 0
26587, 1.7, 1.2978260869565, 0
26588, 1.7652173913043, 1.3239130434783, 0
26589, 1.7434782608696, 1.2978260869565, 0
26590, 1.8086956521739, 1.3239130434783, 0
26591, 1.7869565217391, 1.2978260869565, 0
26592, 1.8521739130435, 1.3239130434783, 0
26593, 1.8304347826087, 1.2978260869565, 0
26594, 1.895652173913, 1.3239130434783, 0
26595, 1.8739130434783, 1.2978260869565, 0
26596, 1.9391304347826, 1.3239130434783, 0
26597, 1.9173913043478, 1.2978260869565, 0
26598, 1.9826086956522, 1.3239130434783, 0
26599, 1.9608695652174, 1.2978260869565, 0
26600, 2.0260869565217, 1.3239130434783, 0
26601, 2.004347826087, 1.2978260869565, 0
26602, 2.0695652173913, 1.3239130434783, 0
26603, 2.0478260869565, 1.2978260869565, 0
26604, 2.1130434782609, 1.3239130434783, 0
26605, 2.0913043478261, 1.2978260869565, 0
26606, 2.1565217391304, 1.3239130434783, 0
26607, 2.1347826086957, 1.2978260869565, 0
26608, 2.1782608695652, 1.2978260869565, 0
26609, 1.2434782608696, 1.2717391304348, 0
26610, 1.2217391304348, 1.245652173913, 0
26611, 1.2869565217391, 1.2717391304348, 0
26612, 1.2652173913043, 1.245652173913, 0
26613, 1.3304347826087, 1.2717391304348, 0
26614, 1.3086956521739, 1.245652173913, 0
26615, 1.3739130434783, 1.2717391304348, 0
26616, 1.3521739130435, 1.245652173913, 0
26617, 1.4173913043478, 1.2717391304348, 0
26618, 1.395652173913, 1.245652173913, 0
26619, 1.4608695652174, 1.2717391304348, 0
26620, 1.4391304347826, 1.245652173913, 0
26621, 1.504347826087, 1.2717391304348, 0
26622, 1.4826086956522, 1.245652173913, 0
26623, 1.5478260869565, 1.2717391304348, 0
26624, 1.5260869565217, 1.245652173913, 0
26625, 1.5913043478261, 1.2717391304348, 0
26626, 1.5695652173913, 1.245652173913, 0
26627, 1.6347826086957, 1.2717391304348, 0
26628, 1.6130434782609, 1.245652173913, 0
26629, 1.6782608695652, 1.2717391304348, 0
26630, 1.6565217391304, 1.245652173913, 0
26631, 1.7217391304348, 1.2717391304348, 0
26632, 1.7, 1.245652173913, 0
26633, 1.7652173913043, 1.2717391304348, 0
26634, 1.7434782608696, 1.245652173913, 0
26635, 1.8086956521739, 1.2717391304348, 0
26636, 1.7869565217391, 1.245652173913, 0
26637, 1.8521739130435, 1.2717391304348, 0
26638, 1.8304347826087, 1.245652173913, 0
26639, 1.895652173913, 1.2717391304348, 0
26640, 1.8739130434783, 1.245652173913, 0
26641, 1.9391304347826, 1.2717391304348, 0
26642, 1.9173913043478, 1.245652173913, 0
26643, 1.9826086956522, 1.2717391304348, 0
26644, 1.9608695652174, 1.245652173913, 0
26645, 2.0260869565217, 1.2717391304348, 0
26646, 2.004347826087, 1.245652173913, 0
26647, 2.0695652173913, 1.2717391304348, 0
26648, 2.0478260869565, 1.245652173913, 0
26649, 2.1130434782609, 1.2717391304348, 0
26650, 2.0913043478261, 1.245652173913, 0
26651, 2.1565217391304, 1.2717391304348, 0
26652, 2.1347826086957, 1.245652173913, 0
26653, 2.1782608695652, 1.245652173913, 0
26654, 1.2434782608696, 1.2195652173913, 0
26655, 1.2217391304348, 1.1934782608696, 0
26656, 1.2869565217391, 1.2195652173913, 0
26657, 1.2652173913043, 1.1934782608696, 0
26658, 1.3304347826087, 1.2195652173913, 0
26659, 1.3086956521739, 1.1934782608696, 0
26660, 1.3739130434783, 1.2195652173913, 0
26661, 1.3521739130435, 1.1934782608696, 0
26662, 1.4173913043478, 1.2195652173913, 0
26663, 1.395652173913, 1.1934782608696, 0
26664, 1.4608695652174, 1.2195652173913, 0
26665, 1.4391304347826, 1.1934782608696, 0
26666, 1.504347826087, 1.2195652173913, 0
26667, 1.4826086956522, 1.1934782608696, 0
26668, 1.5478260869565, 1.2195652173913, 0
26669, 1.5260869565217, 1.1934782608696, 0
26670, 1.5913043478261, 1.2195652173913, 0
26671, 1.5695652173913, 1.1934782608696, 0
26672, 1.6347826086957, 1.2195652173913, 0
26673, 1.6130434782609, 1.1934782608696, 0
26674, 1.6782608695652, 1.2195652173913, 0
26675, 1.6565217391304, 1.1934782608696, 0
26676, 1.7217391304348, 1.2195652173913, 0
26677, 1.7, 1.1934782608696, 0
26678, 1.7652173913043, 1.2195652173913, 0
26679, 1.7434782608696, 1.1934782608696, 0
26680, 1.8086956521739, 1.2195652173913, 0
26681, 1.7869565217391, 1.1934782608696, 0
26682, 1.8521739130435, 1.2195652173913, 0
26683, 1.8304347826087, 1.1934782608696, 0
26684, 1.895652173913, 1.2195652173913, 0
26685, 1.8739130434783, 1.1934782608696, 0
26686, 1.9391304347826, 1.2195652173913, 0
26687, 1.9173913043478, 1.1934782608696, 0
26688, 1.9826086956522, 1.2195652173913, 0
26689, 1.9608695652174, 1.1934782608696, 0
26690, 2.0260869565217, 1.2195652173913, 0
26691, 2.004347826087, 1.1934782608696, 0
26692, 2.0695652173913, 1.2195652173913, 0
26693, 2.0478260869565, 1.1934782608696, 0
26694, 2.1130434782609, 1.2195652173913, 0
26695, 2.0913043478261, 1.1934782608696, 0
26696, 2.1565217391304, 1.2195652173913, 0
26697, 2.1347826086957, 1.1934782608696, 0
26698, 2.1782608695652, 1.1934782608696, 0
26699, 1.2434782608696, 1.1673913043478, 0
26700, 1.2217391304348, 1.1413043478261, 0
26701, 1.2869565217391, 1.1673913043478, 0
26702, 1.2652173913043, 1.1413043478261, 0
26703, 1.3304347826087, 1.1673913043478, 0
26704, 1.3086956521739, 1.1413043478261, 0
26705, 1.3739130434783, 1.1673913043478, 0
26706, 1.3521739130435, 1.1413043478261, 0
26707, 1.4173913043478, 1.1673913043478, 0
26708, 1.395652173913, 1.1413043478261, 0
26709, 1.4608695652174, 1.1673913043478, 0
26710, 1.4391304347826, 1.1413043478261, 0
26711, 1.504347826087, 1.1673913043478, 0
26712, 1.4826086956522, 1.1413043478261, 0
26713, 1.5478260869565, 1.1673913043478, 0
26714, 1.5260869565217, 1.1413043478261, 0
26715, 1.5913043478261, 1.1673913043478, 0
26716, 1.5695652173913, 1.1413043478261, 0
26717, 1.6347826086957, 1.1673913043478, 0
26718, 1.6130434782609, 1.1413043478261, 0
26719, 1.6782608695652, 1.1673913043478, 0
26720, 1.6565217391304, 1.1413043478261, 0
26721, 1.7217391304348, 1.1673913043478, 0
26722, 1.7, 1.1413043478261, 0
26723, 1.7652173913043, 1.1673913043478, 0
26724, 1.7434782608696, 1.1413043478261, 0
26725, 1.8086956521739, 1.1673913043478, 0
26726, 1.7869565217391, 1.1413043478261, 0
26727, 1.8521739130435, 1.1673913043478, 0
26728, 1.8304347826087, 1.1413043478261, 0
26729, 1.895652173913, 1.1673913043478, 0
26730, 1.8739130434783, 1.1413043478261, 0
26731, 1.9391304347826, 1.1673913043478, 0
26732, 1.9173913043478, 1.1413043478261, 0
26733, 1.9826086956522, 1.1673913043478, 0
26734, 1.9608695652174, 1.1413043478261, 0
26735, 2.0260869565217, 1.1673913043478, 0
26736, 2.004347826087, 1.1413043478261, 0
26737, 2.0695652173913, 1.1673913043478, 0
26738, 2.0478260869565, 1.1413043478261, 0
26739, 2.1130434782609, 1.1673913043478, 0
26740, 2.0913043478261, 1.1413043478261, 0
26741, 2.1565217391304, 1.1673913043478, 0
26742, 2.1347826086957, 1.1413043478261, 0
26743, 2.1782608695652, 1.1413043478261, 0
26744, 1.2434782608696, 1.1152173913043, 0
26745, 1.2217391304348, 1.0891304347826, 0
26746, 1.2869565217391, 1.1152173913043, 0
26747, 1.2652173913043, 1.0891304347826, 0
26748, 1.3304347826087, 1.1152173913043, 0
26749, 1.3086956521739, 1.0891304347826, 0
26750, 1.3739130434783, 1.1152173913043, 0
26751, 1.3521739130435, 1.0891304347826, 0
26752, 1.4173913043478, 1.1152173913043, 0
26753, 1.395652173913, 1.0891304347826, 0
26754, 1.4608695652174, 1.1152173913043, 0
26755, 1.4391304347826, 1.0891304347826, 0
26756, 1.504347826087, 1.1152173913043, 0
26757, 1.4826086956522, 1.0891304347826, 0
26758, 1.5478260869565, 1.1152173913043, 0
26759, 1.5260869565217, 1.0891304347826, 0
26760, 1.5913043478261, 1.1152173913043, 0
26761, 1.5695652173913, 1.0891304347826, 0
26762, 1.6347826086957, 1.1152173913043, 0
26763, 1.6130434782609, 1.0891304347826, 0
26764, 1.6782608695652, 1.1152173913043, 0
26765, 1.6565217391304, 1.0891304347826, 0
26766, 1.7217391304348, 1.1152173913043, 0
26767, 1.7, 1.0891304347826, 0
26768, 1.7652173913043, 1.1152173913043, 0
26769, 1.7434782608696, 1.0891304347826, 0
26770, 1.8086956521739, 1.1152173913043, 0
26771, 1.7869565217391, 1.0891304347826, 0
26772, 1.8521739130435, 1.1152173913043, 0
26773, 1.8304347826087, 1.0891304347826, 0
26774, 1.895652173913, 1.1152173913043, 0
26775, 1.8739130434783, 1.0891304347826, 0
26776, 1.9391304347826, 1.1152173913043, 0
26777, 1.9173913043478, 1.0891304347826, 0
26778, 1.9826086956522, 1.1152173913043, 0
26779, 1.9608695652174, 1.0891304347826, 0
26780, 2.0260869565217, 1.1152173913043, 0
26781, 2.004347826087, 1.0891304347826, 0
26782, 2.0695652173913, 1.1152173913043, 0
26783, 2.0478260869565, 1.0891304347826, 0
26784, 2.1130434782609, 1.1152173913043, 0
26785, 2.0913043478261, 1.0891304347826, 0
26786, 2.1565217391304, 1.1152173913043, 0
26787, 2.1347826086957, 1.0891304347826, 0
26788, 2.1782608695652, 1.0891304347826, 0
26789, 1.2434782608696, 1.0630434782609, 0
26790, 1.2217391304348, 1.0369565217391, 0
26791, 1.2869565217391, 1.0630434782609, 0
26792, 1.2652173913043, 1.0369565217391, 0
26793, 1.3304347826087, 1.0630434782609, 0
26794, 1.3086956521739, 1.0369565217391, 0
26795, 1.3739130434783, 1.0630434782609, 0
26796, 1.3521739130435, 1.0369565217391, 0
26797, 1.4173913043478, 1.0630434782609, 0
26798, 1.395652173913, 1.0369565217391, 0
26799, 1.4608695652174, 1.0630434782609, 0
26800, 1.4391304347826, 1.0369565217391, 0
26801, 1.504347826087, 1.0630434782609, 0
26802, 1.4826086956522, 1.0369565217391, 0
26803, 1.5478260869565, 1.0630434782609, 0
26804, 1.5260869565217, 1.0369565217391, 0
26805, 1.5913043478261, 1.0630434782609, 0
26806, 1.5695652173913, 1.0369565217391, 0
26807, 1.6347826086957, 1.0630434782609, 0
26808, 1.6130434782609, 1.0369565217391, 0
26809, 1.6782608695652, 1.0630434782609, 0
26810, 1.6565217391304, 1.0369565217391, 0
26811, 1.7217391304348, 1.0630434782609, 0
26812, 1.7, 1.0369565217391, 0
26813, 1.7652173913043, 1.0630434782609, 0
26814, 1.7434782608696, 1.0369565217391, 0
26815, 1.8086956521739, 1.0630434782609, 0
26816, 1.7869565217391, 1.0369565217391, 0
26817, 1.8521739130435, 1.0630434782609, 0
26818, 1.8304347826087, 1.0369565217391, 0
26819, 1.895652173913, 1.0630434782609, 0
26820, 1.8739130434783, 1.0369565217391, 0
26821, 1.9391304347826, 1.0630434782609, 0
26822, 1.9173913043478, 1.0369565217391, 0
26823, 1.9826086956522, 1.0630434782609, 0
26824, 1.9608695652174, 1.0369565217391, 0
26825, 2.0260869565217, 1.0630434782609, 0
26826, 2.004347826087, 1.0369565217391, 0
26827, 2.0695652173913, 1.0630434782609, 0
26828, 2.0478260869565, 1.0369565217391, 0
26829, 2.1130434782609, 1.0630434782609, 0
26830, 2.0913043478261, 1.0369565217391, 0
26831, 2.1565217391304, 1.0630434782609, 0
26832, 2.1347826086957, 1.0369565217391, 0
26833, 2.1782608695652, 1.0369565217391, 0
26834, 1.2434782608696, 1.0108695652174, 0
26835, 1.2217391304348, 0.98478260869565, 0
26836, 1.2869565217391, 1.0108695652174, 0
26837, 1.2652173913043, 0.98478260869565, 0
26838, 1.3304347826087, 1.0108695652174, 0
26839, 1.3086956521739, 0.98478260869565, 0
26840, 1.3739130434783, 1.0108695652174, 0
26841, 1.3521739130435, 0.98478260869565, 0
26842, 1.4173913043478, 1.0108695652174, 0
26843, 1.395652173913, 0.98478260869565, 0
26844, 1.4608695652174, 1.0108695652174, 0
26845, 1.4391304347826, 0.98478260869565, 0
26846, 1.504347826087, 1.0108695652174, 0
26847, 1.4826086956522, 0.98478260869565, 0
26848, 1.5478260869565, 1.0108695652174, 0
26849, 1.5260869565217, 0.98478260869565, 0
26850, 1.5913043478261, 1.0108695652174, 0
26851, 1.5695652173913, 0.98478260869565, 0
26852, 1.6347826086957, 1.0108695652174, 0
26853, 1.6130434782609, 0.98478260869565, 0
26854, 1.6782608695652, 1.0108695652174, 0
26855, 1.6565217391304, 0.98478260869565, 0
26856, 1.7217391304348, 1.0108695652174, 0
26857, 1.7, 0.98478260869565, 0
26858, 1.7652173913043, 1.0108695652174, 0
26859, 1.7434782608696, 0.98478260869565, 0
26860, 1.8086956521739, 1.0108695652174, 0
26861, 1.7869565217391, 0.98478260869565, 0
26862, 1.8521739130435, 1.0108695652174, 0
26863, 1.8304347826087, 0.98478260869565, 0
26864, 1.895652173913, 1.0108695652174, 0
26865, 1.8739130434783, 0.98478260869565, 0
26866, 1.9391304347826, 1.0108695652174, 0
26867, 1.9173913043478, 0.98478260869565, 0
26868, 1.9826086956522, 1.0108695652174, 0
26869, 1.9608695652174, 0.98478260869565, 0
26870, 2.0260869565217, 1.0108695652174, 0
26871, 2.004347826087, 0.98478260869565, 0
26872, 2.0695652173913, 1.0108695652174, 0
26873, 2.0478260869565, 0.98478260869565, 0
26874, 2.1130434782609, 1.0108695652174, 0
26875, 2.0913043478261, 0.98478260869565, 0
26876, 2.1565217391304, 1.0108695652174, 0
26877, 2.1347826086957, 0.98478260869565, 0
26878, 2.1782608695652, 0.98478260869565, 0
26879, 1.2434782608696, 0.95869565217391, 0
26880, 1.2217391304348, 0.93260869565217, 0
26881, 1.2869565217391, 0.95869565217391, 0
26882, 1.2652173913043, 0.93260869565217, 0
26883, 1.3304347826087, 0.95869565217391, 0
26884, 1.3086956521739, 0.93260869565217, 0
26885, 1.3739130434783, 0.95869565217391, 0
26886, 1.3521739130435, 0.93260869565217, 0
26887, 1.4173913043478, 0.95869565217391, 0
26888, 1.395652173913, 0.93260869565217, 0
26889, 1.4608695652174, 0.95869565217391, 0
26890, 1.4391304347826, 0.93260869565217, 0
26891, 1.504347826087, 0.95869565217391, 0
26892, 1.4826086956522, 0.93260869565217, 0
26893, 1.5478260869565, 0.95869565217391, 0
26894, 1.5260869565217, 0.93260869565217, 0
26895, 1.5913043478261, 0.95869565217391, 0
26896, 1.5695652173913, 0.93260869565217, 0
26897, 1.6347826086957, 0.95869565217391, 0
26898, 1.6130434782609, 0.93260869565217, 0
26899, 1.6782608695652, 0.95869565217391, 0
26900, 1.6565217391304, 0.93260869565217, 0
26901, 1.7217391304348, 0.95869565217391, 0
26902, 1.7, 0.93260869565217, 0
26903, 1.7652173913043, 0.95869565217391, 0
26904, 1.7434782608696, 0.93260869565217, 0
26905, 1.8086956521739, 0.95869565217391, 0
26906, 1.7869565217391, 0.93260869565217, 0
26907, 1.8521739130435, 0.95869565217391, 0
26908, 1.8304347826087, 0.93260869565217, 0
26909, 1.895652173913, 0.95869565217391, 0
26910, 1.8739130434783, 0.93260869565217, 0
26911, 1.9391304347826, 0.95869565217391, 0
26912, 1.9173913043478, 0.93260869565217, 0
26913, 1.9826086956522, 0.95869565217391, 0
26914, 1.9608695652174, 0.93260869565217, 0
26915, 2.0260869565217, 0.95869565217391, 0
26916, 2.004347826087, 0.93260869565217, 0
26917, 2.0695652173913, 0.95869565217391, 0
26918, 2.0478260869565, 0.93260869565217, 0
26919, 2.1130434782609, 0.95869565217391, 0
26920, 2.0913043478261, 0.93260869565217, 0
26921, 2.1565217391304, 0.95869565217391, 0
26922, 2.1347826086957, 0.93260869565217, 0
26923, 2.1782608695652, 0.93260869565217, 0
26924, 1.2434782608696, 0.90652173913044, 0
26925, 1.2217391304348, 0.8804347826087, 0
26926, 1.2869565217391, 0.90652173913044, 0
26927, 1.2652173913043, 0.8804347826087, 0
26928, 1.3304347826087, 0.90652173913044, 0
26929, 1.3086956521739, 0.8804347826087, 0
26930, 1.3739130434783, 0.90652173913044, 0
26931, 1.3521739130435, 0.8804347826087, 0
26932, 1.4173913043478, 0.90652173913044, 0
26933, 1.395652173913, 0.8804347826087, 0
26934, 1.4608695652174, 0.90652173913044, 0
26935, 1.4391304347826, 0.8804347826087, 0
26936, 1.504347826087, 0.90652173913044, 0
26937, 1.4826086956522, 0.8804347826087, 0
26938, 1.5478260869565, 0.90652173913044, 0
26939, 1.5260869565217, 0.8804347826087, 0
26940, 1.5913043478261, 0.90652173913044, 0
26941, 1.5695652173913, 0.8804347826087, 0
26942, 1.6347826086957, 0.90652173913044, 0
26943, 1.6130434782609, 0.8804347826087, 0
26944, 1.6782608695652, 0.90652173913044, 0
26945, 1.6565217391304, 0.8804347826087, 0
26946, 1.7217391304348, 0.90652173913044, 0
26947, 1.7, 0.8804347826087, 0
26948, 1.7652173913043, 0.90652173913044, 0
26949, 1.7434782608696, 0.8804347826087, 0
26950, 1.8086956521739, 0.90652173913044, 0
26951, 1.7869565217391, 0.8804347826087, 0
26952, 1.8521739130435, 0.90652173913044, 0
26953, 1.8304347826087, 0.8804347826087, 0
26954, 1.895652173913, 0.90652173913044, 0
26955, 1.8739130434783, 0.8804347826087, 0
26956, 1.9391304347826, 0.90652173913044, 0
26957, 1.9173913043478, 0.8804347826087, 0
26958, 1.9826086956522, 0.90652173913044, 0
26959, 1.9608695652174, 0.8804347826087, 0
26960, 2.0260869565217, 0.90652173913044, 0
26961, 2.004347826087, 0.8804347826087, 0
26962, 2.0695652173913, 0.90652173913044, 0
26963, 2.0478260869565, 0.8804347826087, 0
26964, 2.1130434782609, 0.90652173913044, 0
26965, 2.0913043478261, 0.8804347826087, 0
26966, 2.1565217391304, 0.90652173913044, 0
26967, 2.1347826086957, 0.8804347826087, 0
26968, 2.1782608695652, 0.8804347826087, 0
26969, 1.2434782608696, 0.85434782608696, 0
26970, 1.2217391304348, 0.82826086956522, 0
26971, 1.2869565217391, 0.85434782608696, 0
26972, 1.2652173913043, 0.82826086956522, 0
26973, 1.3304347826087, 0.85434782608696, 0
26974, 1.3086956521739, 0.82826086956522, 0
26975, 1.3739130434783, 0.85434782608696, 0
26976, 1.3521739130435, 0.82826086956522, 0
26977, 1.4173913043478, 0.85434782608696, 0
26978, 1.395652173913, 0.82826086956522, 0
26979, 1.4608695652174, 0.85434782608696, 0
26980, 1.4391304347826, 0.82826086956522, 0
26981, 1.504347826087, 0.85434782608696, 0
26982, 1.4826086956522, 0.82826086956522, 0
26983, 1.5478260869565, 0.85434782608696, 0
26984, 1.5260869565217, 0.82826086956522, 0
26985, 1.5913043478261, 0.85434782608696, 0
26986, 1.5695652173913, 0.82826086956522, 0
26987, 1.6347826086957, 0.85434782608696, 0
26988, 1.6130434782609, 0.82826086956522, 0
26989, 1.6782608695652, 0.85434782608696, 0
26990, 1.6565217391304, 0.82826086956522, 0
26991, 1.7217391304348, 0.85434782608696, 0
26992, 1.7, 0.82826086956522, 0
26993, 1.7652173913043, 0.85434782608696, 0
26994, 1.7434782608696, 0.82826086956522, 0
26995, 1.8086956521739, 0.85434782608696, 0
26996, 1.7869565217391, 0.82826086956522, 0
26997, 1.8521739130435, 0.85434782608696, 0
26998, 1.8304347826087, 0.82826086956522, 0
26999, 1.895652173913, 0.85434782608696, 0
27000, 1.8739130434783, 0.82826086956522, 0
27001, 1.9391304347826, 0.85434782608696, 0
27002, 1.9173913043478, 0.82826086956522, 0
27003, 1.9826086956522, 0.85434782608696, 0
27004, 1.9608695652174, 0.82826086956522, 0
27005, 2.0260869565217, 0.85434782608696, 0
27006, 2.004347826087, 0.82826086956522, 0
27007, 2.0695652173913, 0.85434782608696, 0
27008, 2.0478260869565, 0.82826086956522, 0
27009, 2.1130434782609, 0.85434782608696, 0
27010, 2.0913043478261, 0.82826086956522, 0
27011, 2.1565217391304, 0.85434782608696, 0
27012, 2.1347826086957, 0.82826086956522, 0
27013, 2.1782608695652, 0.82826086956522, 0
27014, 1.2434782608696, 0.80217391304348, 0
27015, 1.2217391304348, 0.77608695652174, 0
27016, 1.2869565217391, 0.80217391304348, 0
27017, 1.2652173913043, 0.77608695652174, 0
27018, 1.3304347826087, 0.80217391304348, 0
27019, 1.3086956521739, 0.77608695652174, 0
27020, 1.3739130434783, 0.80217391304348, 0
27021, 1.3521739130435, 0.77608695652174, 0
27022, 1.4173913043478, 0.80217391304348, 0
27023, 1.395652173913, 0.77608695652174, 0
27024, 1.4608695652174, 0.80217391304348, 0
27025, 1.4391304347826, 0.77608695652174, 0
27026, 1.504347826087, 0.80217391304348, 0
27027, 1.4826086956522, 0.77608695652174, 0
27028, 1.5478260869565, 0.80217391304348, 0
27029, 1.5260869565217, 0.77608695652174, 0
27030, 1.5913043478261, 0.80217391304348, 0
27031, 1.5695652173913, 0.77608695652174, 0
27032, 1.6347826086957, 0.80217391304348, 0
27033, 1.6130434782609, 0.77608695652174, 0
27034, 1.6782608695652, 0.80217391304348, 0
27035, 1.6565217391304, 0.77608695652174, 0
27036, 1.7217391304348, 0.80217391304348, 0
27037, 1.7, 0.77608695652174, 0
27038, 1.7652173913043, 0.80217391304348, 0
27039, 1.7434782608696, 0.77608695652174, 0
27040, 1.8086956521739, 0.80217391304348, 0
27041, 1.7869565217391, 0.77608695652174, 0
27042, 1.8521739130435, 0.80217391304348, 0
27043, 1.8304347826087, 0.77608695652174, 0
27044, 1.895652173913, 0.80217391304348, 0
27045, 1.8739130434783, 0.77608695652174, 0
27046, 1.9391304347826, 0.80217391304348, 0
27047, 1.9173913043478, 0.77608695652174, 0
27048, 1.9826086956522, 0.80217391304348, 0
27049, 1.9608695652174, 0.77608695652174, 0
27050, 2.0260869565217, 0.80217391304348, 0
27051, 2.004347826087, 0.77608695652174, 0
27052, 2.0695652173913, 0.80217391304348, 0
27053, 2.0478260869565, 0.77608695652174, 0
27054, 2.1130434782609, 0.80217391304348, 0
27055, 2.0913043478261, 0.77608695652174, 0
27056, 2.1565217391304, 0.80217391304348, 0
27057, 2.1347826086957, 0.77608695652174, 0
27058, 2.1782608695652, 0.77608695652174, 0
27059, 1.2434782608696, 0.75, 0
27060, 1.2217391304348, 0.72391304347826, 0
27061, 1.2869565217391, 0.75, 0
27062, 1.2652173913043, 0.72391304347826, 0
27063, 1.3304347826087, 0.75, 0
27064, 1.3086956521739, 0.72391304347826, 0
27065, 1.3739130434783, 0.75, 0
27066, 1.3521739130435, 0.72391304347826, 0
27067, 1.4173913043478, 0.75, 0
27068, 1.395652173913, 0.72391304347826, 0
27069, 1.4608695652174, 0.75, 0
27070, 1.4391304347826, 0.72391304347826, 0
27071, 1.504347826087, 0.75, 0
27072, 1.4826086956522, 0.72391304347826, 0
27073, 1.5478260869565, 0.75, 0
27074, 1.5260869565217, 0.72391304347826, 0
27075, 1.5913043478261, 0.75, 0
27076, 1.5695652173913, 0.72391304347826, 0
27077, 1.6347826086957, 0.75, 0
27078, 1.6130434782609, 0.72391304347826, 0
27079, 1.6782608695652, 0.75, 0
27080, 1.6565217391304, 0.72391304347826, 0
27081, 1.7217391304348, 0.75, 0
27082, 1.7, 0.72391304347826, 0
27083, 1.7652173913043, 0.75, 0
27084, 1.7434782608696, 0.72391304347826, 0
27085, 1.8086956521739, 0.75, 0
27086, 1.7869565217391, 0.72391304347826, 0
27087, 1.8521739130435, 0.75, 0
27088, 1.8304347826087, 0.72391304347826, 0
27089, 1.895652173913, 0.75, 0
27090, 1.8739130434783, 0.72391304347826, 0
27091, 1.9391304347826, 0.75, 0
27092, 1.9173913043478, 0.72391304347826, 0
27093, 1.9826086956522, 0.75, 0
27094, 1.9608695652174, 0.72391304347826, 0
27095, 2.0260869565217, 0.75, 0
27096, 2.004347826087, 0.72391304347826, 0
27097, 2.0695652173913, 0.75, 0
27098, 2.0478260869565, 0.72391304347826, 0
27099, 2.1130434782609, 0.75, 0
27100, 2.0913043478261, 0.72391304347826, 0
27101, 2.1565217391304, 0.75, 0
27102, 2.1347826086957, 0.72391304347826, 0
27103, 2.1782608695652, 0.72391304347826, 0
27104, 1.2434782608696, 0.69782608695652, 0
27105, 1.2217391304348, 0.67173913043478, 0
27106, 1.2869565217391, 0.69782608695652, 0
27107, 1.2652173913043, 0.67173913043478, 0
27108, 1.3304347826087, 0.69782608695652, 0
27109, 1.3086956521739, 0.67173913043478, 0
27110, 1.3739130434783, 0.69782608695652, 0
27111, 1.3521739130435, 0.67173913043478, 0
27112, 1.4173913043478, 0.69782608695652, 0
27113, 1.395652173913, 0.67173913043478, 0
27114, 1.4608695652174, 0.69782608695652, 0
27115, 1.4391304347826, 0.67173913043478, 0
27116, 1.504347826087, 0.69782608695652, 0
27117, 1.4826086956522, 0.67173913043478, 0
27118, 1.5478260869565, 0.69782608695652, 0
27119, 1.5260869565217, 0.67173913043478, 0
27120, 1.5913043478261, 0.69782608695652, 0
27121, 1.5695652173913, 0.67173913043478, 0
27122, 1.6347826086957, 0.69782608695652, 0
27123, 1.6130434782609, 0.67173913043478, 0
27124, 1.6782608695652, 0.69782608695652, 0
27125, 1.6565217391304, 0.67173913043478, 0
27126, 1.7217391304348, 0.69782608695652, 0
27127, 1.7, 0.67173913043478, 0
27128, 1.7652173913043, 0.69782608695652, 0
27129, 1.7434782608696, 0.67173913043478, 0
27130, 1.8086956521739, 0.69782608695652, 0
27131, 1.7869565217391, 0.67173913043478, 0
27132, 1.8521739130435, 0.69782608695652, 0
27133, 1.8304347826087, 0.67173913043478, 0
27134, 1.895652173913, 0.69782608695652, 0
27135, 1.8739130434783, 0.67173913043478, 0
27136, 1.9391304347826, 0.69782608695652, 0
27137, 1.9173913043478, 0.67173913043478, 0
27138, 1.9826086956522, 0.69782608695652, 0
27139, 1.9608695652174, 0.67173913043478, 0
27140, 2.0260869565217, 0.69782608695652, 0
27141, 2.004347826087, 0.67173913043478, 0
27142, 2.0695652173913, 0.69782608695652, 0
27143, 2.0478260869565, 0.67173913043478, 0
27144, 2.1130434782609, 0.69782608695652, 0
27145, 2.0913043478261, 0.67173913043478, 0
27146, 2.1565217391304, 0.69782608695652, 0
27147, 2.1347826086957, 0.67173913043478, 0
27148, 2.1782608695652, 0.67173913043478, 0
27149, 1.2434782608696, 0.64565217391304, 0
27150, 1.2217391304348, 0.61956521739131, 0
27151, 1.2869565217391, 0.64565217391304, 0
27152, 1.2652173913043, 0.61956521739131, 0
27153, 1.3304347826087, 0.64565217391304, 0
27154, 1.3086956521739, 0.61956521739131, 0
27155, 1.3739130434783, 0.64565217391304, 0
27156, 1.3521739130435, 0.61956521739131, 0
27157, 1.4173913043478, 0.64565217391304, 0
27158, 1.395652173913, 0.61956521739131, 0
27159, 1.4608695652174, 0.64565217391304, 0
27160, 1.4391304347826, 0.61956521739131, 0
27161, 1.504347826087, 0.64565217391304, 0
27162, 1.4826086956522, 0.61956521739131, 0
27163, 1.5478260869565, 0.64565217391304, 0
27164, 1.5260869565217, 0.61956521739131, 0
27165, 1.5913043478261, 0.64565217391304, 0
27166, 1.5695652173913, 0.61956521739131, 0
27167, 1.6347826086957, 0.64565217391304, 0
27168, 1.6130434782609, 0.61956521739131, 0
27169, 1.6782608695652, 0.64565217391304, 0
27170, 1.6565217391304, 0.61956521739131, 0
27171, 1.7217391304348, 0.64565217391304, 0
27172, 1.7, 0.61956521739131, 0
27173, 1.7652173913043, 0.64565217391304, 0
27174, 1.7434782608696, 0.61956521739131, 0
27175, 1.8086956521739, 0.64565217391304, 0
27176, 1.7869565217391, 0.61956521739131, 0
27177, 1.8521739130435, 0.64565217391304, 0
27178, 1.8304347826087, 0.61956521739131, 0
27179, 1.895652173913, 0.64565217391304, 0
27180, 1.8739130434783, 0.61956521739131, 0
27181, 1.9391304347826, 0.64565217391304, 0
27182, 1.9173913043478, 0.61956521739131, 0
27183, 1.9826086956522, 0.64565217391304, 0
27184, 1.9608695652174, 0.61956521739131, 0
27185, 2.0260869565217, 0.64565217391304, 0
27186, 2.004347826087, 0.61956521739131, 0
27187, 2.0695652173913, 0.64565217391304, 0
27188, 2.0478260869565, 0.61956521739131, 0
27189, 2.1130434782609, 0.64565217391304, 0
27190, 2.0913043478261, 0.61956521739131, 0
27191, 2.1565217391304, 0.64565217391304, 0
27192, 2.1347826086957, 0.61956521739131, 0
27193, 2.1782608695652, 0.61956521739131, 0
27194, 1.2434782608696, 0.59347826086957, 0
27195, 1.2217391304348, 0.56739130434783, 0
27196, 1.2869565217391, 0.59347826086957, 0
27197, 1.2652173913043, 0.56739130434783, 0
27198, 1.3304347826087, 0.59347826086957, 0
27199, 1.3086956521739, 0.56739130434783, 0
27200, 1.3739130434783, 0.59347826086957, 0
27201, 1.3521739130435, 0.56739130434783, 0
27202, 1.4173913043478, 0.59347826086957, 0
27203, 1.395652173913, 0.56739130434783, 0
27204, 1.4608695652174, 0.59347826086957, 0
27205, 1.4391304347826, 0.56739130434783, 0
27206, 1.504347826087, 0.59347826086957, 0
27207, 1.4826086956522, 0.56739130434783, 0
27208, 1.5478260869565, 0.59347826086957, 0
27209, 1.5260869565217, 0.56739130434783, 0
27210, 1.5913043478261, 0.59347826086957, 0
27211, 1.5695652173913, 0.56739130434783, 0
27212, 1.6347826086957, 0.59347826086957, 0
27213, 1.6130434782609, 0.56739130434783, 0
27214, 1.6782608695652, 0.59347826086957, 0
27215, 1.6565217391304, 0.56739130434783, 0
27216, 1.7217391304348, 0.59347826086957, 0
27217, 1.7, 0.56739130434783, 0
27218, 1.7652173913043, 0.59347826086957, 0
27219, 1.7434782608696, 0.56739130434783, 0
27220, 1.8086956521739, 0.59347826086957, 0
27221, 1.7869565217391, 0.56739130434783, 0
27222, 1.8521739130435, 0.59347826086957, 0
27223, 1.8304347826087, 0.56739130434783, 0
27224, 1.895652173913, 0.59347826086957, 0
27225, 1.8739130434783, 0.56739130434783, 0
27226, 1.9391304347826, 0.59347826086957, 0
27227, 1.9173913043478, 0.56739130434783, 0
27228, 1.9826086956522, 0.59347826086957, 0
27229, 1.9608695652174, 0.56739130434783, 0
27230, 2.0260869565217, 0.59347826086957, 0
27231, 2.004347826087, 0.56739130434783, 0
27232, 2.0695652173913, 0.59347826086957, 0
27233, 2.0478260869565, 0.56739130434783, 0
27234, 2.1130434782609, 0.59347826086957, 0
27235, 2.0913043478261, 0.56739130434783, 0
27236, 2.1565217391304, 0.59347826086957, 0
27237, 2.1347826086957, 0.56739130434783, 0
27238, 2.1782608695652, 0.56739130434783, 0
27239, 1.2434782608696, 0.54130434782609, 0
27240, 1.2217391304348, 0.51521739130435, 0
27241, 1.2869565217391, 0.54130434782609, 0
27242, 1.2652173913043, 0.51521739130435, 0
27243, 1.3304347826087, 0.54130434782609, 0
27244, 1.3086956521739, 0.51521739130435, 0
27245, 1.3739130434783, 0.54130434782609, 0
27246, 1.3521739130435, 0.51521739130435, 0
27247, 1.4173913043478, 0.54130434782609, 0
27248, 1.395652173913, 0.51521739130435, 0
27249, 1.4608695652174, 0.54130434782609, 0
27250, 1.4391304347826, 0.51521739130435, 0
27251, 1.504347826087, 0.54130434782609, 0
27252, 1.4826086956522, 0.51521739130435, 0
27253, 1.5478260869565, 0.54130434782609, 0
27254, 1.5260869565217, 0.51521739130435, 0
27255, 1.5913043478261, 0.54130434782609, 0
27256, 1.5695652173913, 0.51521739130435, 0
27257, 1.6347826086957, 0.54130434782609, 0
27258, 1.6130434782609, 0.51521739130435, 0
27259, 1.6782608695652, 0.54130434782609, 0
27260, 1.6565217391304, 0.51521739130435, 0
27261, 1.7217391304348, 0.54130434782609, 0
27262, 1.7, 0.51521739130435, 0
27263, 1.7652173913043, 0.54130434782609, 0
27264, 1.7434782608696, 0.51521739130435, 0
27265, 1.8086956521739, 0.54130434782609, 0
27266, 1.7869565217391, 0.51521739130435, 0
27267, 1.8521739130435, 0.54130434782609, 0
27268, 1.8304347826087, 0.51521739130435, 0
27269, 1.895652173913, 0.54130434782609, 0
27270, 1.8739130434783, 0.51521739130435, 0
27271, 1.9391304347826, 0.54130434782609, 0
27272, 1.9173913043478, 0.51521739130435, 0
27273, 1.9826086956522, 0.54130434782609, 0
27274, 1.9608695652174, 0.51521739130435, 0
27275, 2.0260869565217, 0.54130434782609, 0
27276, 2.004347826087, 0.51521739130435, 0
27277, 2.0695652173913, 0.54130434782609, 0
27278, 2.0478260869565, 0.51521739130435, 0
27279, 2.1130434782609, 0.54130434782609, 0
27280, 2.0913043478261, 0.51521739130435, 0
27281, 2.1565217391304, 0.54130434782609, 0
27282, 2.1347826086957, 0.51521739130435, 0
27283, 2.1782608695652, 0.51521739130435, 0
27284, 1.2434782608696, 0.48913043478261, 0
27285, 1.2217391304348, 0.46304347826087, 0
27286, 1.2869565217391, 0.48913043478261, 0
27287, 1.2652173913043, 0.46304347826087, 0
27288, 1.3304347826087, 0.48913043478261, 0
27289, 1.3086956521739, 0.46304347826087, 0
27290, 1.3739130434783, 0.48913043478261, 0
27291, 1.3521739130435, 0.46304347826087, 0
27292, 1.4173913043478, 0.48913043478261, 0
27293, 1.395652173913, 0.46304347826087, 0
27294, 1.4608695652174, 0.48913043478261, 0
27295, 1.4391304347826, 0.46304347826087, 0
27296, 1.504347826087, 0.48913043478261, 0
27297, 1.4826086956522, 0.46304347826087, 0
27298, 1.5478260869565, 0.48913043478261, 0
27299, 1.5260869565217, 0.46304347826087, 0
27300, 1.5913043478261, 0.48913043478261, 0
27301, 1.5695652173913, 0.46304347826087, 0
27302, 1.6347826086957, 0.48913043478261, 0
27303, 1.6130434782609, 0.46304347826087, 0
27304, 1.6782608695652, 0.48913043478261, 0
27305, 1.6565217391304, 0.46304347826087, 0
27306, 1.7217391304348, 0.48913043478261, 0
27307, 1.7, 0.46304347826087, 0
27308, 1.7652173913043, 0.48913043478261, 0
27309, 1.7434782608696, 0.46304347826087, 0
27310, 1.8086956521739, 0.48913043478261, 0
27311, 1.7869565217391, 0.46304347826087, 0
27312, 1.8521739130435, 0.48913043478261, 0
27313, 1.8304347826087, 0.46304347826087, 0
27314, 1.895652173913, 0.48913043478261, 0
27315, 1.8739130434783, 0.46304347826087, 0
27316, 1.9391304347826, 0.48913043478261, 0
27317, 1.9173913043478, 0.46304347826087, 0
27318, 1.9826086956522, 0.48913043478261, 0
27319, 1.9608695652174, 0.46304347826087, 0
27320, 2.0260869565217, 0.48913043478261, 0
27321, 2.004347826087, 0.46304347826087, 0
27322, 2.0695652173913, 0.48913043478261, 0
27323, 2.0478260869565, 0.46304347826087, 0
27324, 2.1130434782609, 0.48913043478261, 0
27325, 2.0913043478261, 0.46304347826087, 0
27326, 2.1565217391304, 0.48913043478261, 0
27327, 2.1347826086957, 0.46304347826087, 0
27328, 2.1782608695652, 0.46304347826087, 0
27329, 1.2434782608696, 0.43695652173913, 0
27330, 1.2217391304348, 0.41086956521739, 0
27331, 1.2869565217391, 0.43695652173913, 0
27332, 1.2652173913043, 0.41086956521739, 0
27333, 1.3304347826087, 0.43695652173913, 0
27334, 1.3086956521739, 0.41086956521739, 0
27335, 1.3739130434783, 0.43695652173913, 0
27336, 1.3521739130435, 0.41086956521739, 0
27337, 1.4173913043478, 0.43695652173913, 0
27338, 1.395652173913, 0.41086956521739, 0
27339, 1.4608695652174, 0.43695652173913, 0
27340, 1.4391304347826, 0.41086956521739, 0
27341, 1.504347826087, 0.43695652173913, 0
27342, 1.4826086956522, 0.41086956521739, 0
27343, 1.5478260869565, 0.43695652173913, 0
27344, 1.5260869565217, 0.41086956521739, 0
27345, 1.5913043478261, 0.43695652173913, 0
27346, 1.5695652173913, 0.41086956521739, 0
27347, 1.6347826086957, 0.43695652173913, 0
27348, 1.6130434782609, 0.41086956521739, 0
27349, 1.6782608695652, 0.43695652173913, 0
27350, 1.6565217391304, 0.41086956521739, 0
27351, 1.7217391304348, 0.43695652173913, 0
27352, 1.7, 0.41086956521739, 0
27353, 1.7652173913043, 0.43695652173913, 0
27354, 1.7434782608696, 0.41086956521739, 0
27355, 1.8086956521739, 0.43695652173913, 0
27356, 1.7869565217391, 0.41086956521739, 0
27357, 1.8521739130435, 0.43695652173913, 0
27358, 1.8304347826087, 0.41086956521739, 0
27359, 1.895652173913, 0.43695652173913, 0
27360, 1.8739130434783, 0.41086956521739, 0
27361, 1.9391304347826, 0.43695652173913, 0
27362, 1.9173913043478, 0.41086956521739, 0
27363, 1.9826086956522, 0.43695652173913, 0
27364, 1.9608695652174, 0.41086956521739, 0
27365, 2.0260869565217, 0.43695652173913, 0
27366, 2.004347826087, 0.41086956521739, 0
27367, 2.0695652173913, 0.43695652173913, 0
27368, 2.0478260869565, 0.41086956521739, 0
27369, 2.1130434782609, 0.43695652173913, 0
27370, 2.0913043478261, 0.41086956521739, 0
27371, 2.1565217391304, 0.43695652173913, 0
27372, 2.1347826086957, 0.41086956521739, 0
27373, 2.1782608695652, 0.41086956521739, 0
27374, 1.2434782608696, 0.38478260869565, 0
27375, 1.2217391304348, 0.35869565217391, 0
27376, 1.2869565217391, 0.38478260869565, 0
27377, 1.2652173913043, 0.35869565217391, 0
27378, 1.3304347826087, 0.38478260869565, 0
27379, 1.3086956521739, 0.35869565217391, 0
27380, 1.3739130434783, 0.38478260869565, 0
27381, 1.3521739130435, 0.35869565217391, 0
27382, 1.4173913043478, 0.38478260869565, 0
27383, 1.395652173913, 0.35869565217391, 0
27384, 1.4608695652174, 0.38478260869565, 0
27385, 1.4391304347826, 0.35869565217391, 0
27386, 1.504347826087, 0.38478260869565, 0
27387, 1.4826086956522, 0.35869565217391, 0
27388, 1.5478260869565, 0.38478260869565, 0
27389, 1.5260869565217, 0.35869565217391, 0
27390, 1.5913043478261, 0.38478260869565, 0
27391, 1.5695652173913, 0.35869565217391, 0
27392, 1.6347826086957, 0.38478260869565, 0
27393, 1.6130434782609, 0.35869565217391, 0
27394, 1.6782608695652, 0.38478260869565, 0
27395, 1.6565217391304, 0.35869565217391, 0
27396, 1.7217391304348, 0.38478260869565, 0
27397, 1.7, 0.35869565217391, 0
27398, 1.7652173913043, 0.38478260869565, 0
27399, 1.7434782608696, 0.35869565217391, 0
27400, 1.8086956521739, 0.38478260869565, 0
27401, 1.7869565217391, 0.35869565217391, 0
27402, 1.8521739130435, 0.38478260869565, 0
27403, 1.8304347826087, 0.35869565217391, 0
27404, 1.895652173913, 0.38478260869565, 0
27405, 1.8739130434783, 0.35869565217391, 0
27406, 1.9391304347826, 0.38478260869565, 0
27407, 1.9173913043478, 0.35869565217391, 0
27408, 1.9826086956522, 0.38478260869565, 0
27409, 1.9608695652174, 0.35869565217391, 0
27410, 2.0260869565217, 0.38478260869565, 0
27411, 2.004347826087, 0.35869565217391, 0
27412, 2.0695652173913, 0.38478260869565, 0
27413, 2.0478260869565, 0.35869565217391, 0
27414, 2.1130434782609, 0.38478260869565, 0
27415, 2.0913043478261, 0.35869565217391, 0
27416, 2.1565217391304, 0.38478260869565, 0
27417, 2.1347826086957, 0.35869565217391, 0
27418, 2.1782608695652, 0.35869565217391, 0
27419, 1.2434782608696, 0.33260869565217, 0
27420, 1.2217391304348, 0.30652173913044, 0
27421, 1.2869565217391, 0.33260869565217, 0
27422, 1.2652173913043, 0.30652173913044, 0
27423, 1.3304347826087, 0.33260869565217, 0
27424, 1.3086956521739, 0.30652173913043, 0
27425, 1.3739130434783, 0.33260869565217, 0
27426, 1.3521739130435, 0.30652173913044, 0
27427, 1.4173913043478, 0.33260869565217, 0
27428, 1.395652173913, 0.30652173913044, 0
27429, 1.4608695652174, 0.33260869565217, 0
27430, 1.4391304347826, 0.30652173913044, 0
27431, 1.504347826087, 0.33260869565217, 0
27432, 1.4826086956522, 0.30652173913044, 0
27433, 1.5478260869565, 0.33260869565217, 0
27434, 1.5260869565217, 0.30652173913044, 0
27435, 1.5913043478261, 0.33260869565217, 0
27436, 1.5695652173913, 0.30652173913044, 0
27437, 1.6347826086957, 0.33260869565217, 0
27438, 1.6130434782609, 0.30652173913044, 0
27439, 1.6782608695652, 0.33260869565217, 0
27440, 1.6565217391304, 0.30652173913043, 0
27441, 1.7217391304348, 0.33260869565217, 0
27442, 1.7, 0.30652173913043, 0
27443, 1.7652173913043, 0.33260869565217, 0
27444, 1.7434782608696, 0.30652173913043, 0
27445, 1.8086956521739, 0.33260869565217, 0
27446, 1.7869565217391, 0.30652173913044, 0
27447, 1.8521739130435, 0.33260869565217, 0
27448, 1.8304347826087, 0.30652173913044, 0
27449, 1.895652173913, 0.33260869565217, 0
27450, 1.8739130434783, 0.30652173913043, 0
27451, 1.9391304347826, 0.33260869565217, 0
27452, 1.9173913043478, 0.30652173913044, 0
27453, 1.9826086956522, 0.33260869565217, 0
27454, 1.9608695652174, 0.30652173913044, 0
27455, 2.0260869565217, 0.33260869565217, 0
27456, 2.004347826087, 0.30652173913044, 0
27457, 2.0695652173913, 0.33260869565217, 0
27458, 2.0478260869565, 0.30652173913044, 0
27459, 2.1130434782609, 0.33260869565217, 0
27460, 2.0913043478261, 0.30652173913043, 0
27461, 2.1565217391304, 0.33260869565217, 0
27462, 2.1347826086957, 0.30652173913043, 0
27463, 2.1782608695652, 0.30652173913044, 0
27464, 1.2434782608696, 0.2804347826087, 0
27465, 1.2217391304348, 0.25434782608696, 0
27466, 1.2869565217391, 0.2804347826087, 0
27467, 1.2652173913043, 0.25434782608696, 0
27468, 1.3304347826087, 0.2804347826087, 0
27469, 1.3086956521739, 0.25434782608696, 0
27470, 1.3739130434783, 0.2804347826087, 0
27471, 1.3521739130435, 0.25434782608696, 0
27472, 1.4173913043478, 0.2804347826087, 0
27473, 1.395652173913, 0.25434782608696, 0
27474, 1.4608695652174, 0.2804347826087, 0
27475, 1.4391304347826, 0.25434782608696, 0
27476, 1.504347826087, 0.2804347826087, 0
27477, 1.4826086956522, 0.25434782608696, 0
27478, 1.5478260869565, 0.2804347826087, 0
27479, 1.5260869565217, 0.25434782608696, 0
27480, 1.5913043478261, 0.2804347826087, 0
27481, 1.5695652173913, 0.25434782608696, 0
27482, 1.6347826086957, 0.2804347826087, 0
27483, 1.6130434782609, 0.25434782608696, 0
27484, 1.6782608695652, 0.2804347826087, 0
27485, 1.6565217391304, 0.25434782608696, 0
27486, 1.7217391304348, 0.2804347826087, 0
27487, 1.7, 0.25434782608696, 0
27488, 1.7652173913043, 0.2804347826087, 0
27489, 1.7434782608696, 0.25434782608696, 0
27490, 1.8086956521739, 0.2804347826087, 0
27491, 1.7869565217391, 0.25434782608696, 0
27492, 1.8521739130435, 0.2804347826087, 0
27493, 1.8304347826087, 0.25434782608696, 0
27494, 1.895652173913, 0.2804347826087, 0
27495, 1.8739130434783, 0.25434782608696, 0
27496, 1.9391304347826, 0.2804347826087, 0
27497, 1.9173913043478, 0.25434782608696, 0
27498, 1.9826086956522, 0.2804347826087, 0
27499, 1.9608695652174, 0.25434782608696, 0
27500, 2.0260869565217, 0.2804347826087, 0
27501, 2.004347826087, 0.25434782608696, 0
27502, 2.0695652173913, 0.2804347826087, 0
27503, 2.0478260869565, 0.25434782608696, 0
27504, 2.1130434782609, 0.2804347826087, 0
27505, 2.0913043478261, 0.25434782608696, 0
27506, 2.1565217391304, 0.2804347826087, 0
27507, 2.1347826086957, 0.25434782608696, 0
27508, 2.1782608695652, 0.25434782608696, 0
27509, 1.2434782608696, 0.22826086956522, 0
27510, 1.2217391304348, 0.20217391304348, 0
27511, 1.2869565217391, 0.22826086956522, 0
27512, 1.2652173913043, 0.20217391304348, 0
27513, 1.3304347826087, 0.22826086956522, 0
27514, 1.3086956521739, 0.20217391304348, 0
27515, 1.3739130434783, 0.22826086956522, 0
27516, 1.3521739130435, 0.20217391304348, 0
27517, 1.4173913043478, 0.22826086956522, 0
27518, 1.395652173913, 0.20217391304348, 0
27519, 1.4608695652174, 0.22826086956522, 0
27520, 1.4391304347826, 0.20217391304348, 0
27521, 1.504347826087, 0.22826086956522, 0
27522, 1.4826086956522, 0.20217391304348, 0
27523, 1.5478260869565, 0.22826086956522, 0
27524, 1.5260869565217, 0.20217391304348, 0
27525, 1.5913043478261, 0.22826086956522, 0
27526, 1.5695652173913, 0.20217391304348, 0
27527, 1.6347826086957, 0.22826086956522, 0
27528, 1.6130434782609, 0.20217391304348, 0
27529, 1.6782608695652, 0.22826086956522, 0
27530, 1.6565217391304, 0.20217391304348, 0
27531, 1.7217391304348, 0.22826086956522, 0
27532, 1.7, 0.20217391304348, 0
27533, 1.7652173913043, 0.22826086956522, 0
27534, 1.7434782608696, 0.20217391304348, 0
27535, 1.8086956521739, 0.22826086956522, 0
27536, 1.7869565217391, 0.20217391304348, 0
27537, 1.8521739130435, 0.22826086956522, 0
27538, 1.8304347826087, 0.20217391304348, 0
27539, 1.895652173913, 0.22826086956522, 0
27540, 1.8739130434783, 0.20217391304348, 0
27541, 1.9391304347826, 0.22826086956522, 0
27542, 1.9173913043478, 0.20217391304348, 0
27543, 1.9826086956522, 0.22826086956522, 0
27544, 1.9608695652174, 0.20217391304348, 0
27545, 2.0260869565217, 0.22826086956522, 0
27546, 2.004347826087, 0.20217391304348, 0
27547, 2.0695652173913, 0.22826086956522, 0
27548, 2.0478260869565, 0.20217391304348, 0
27549, 2.1130434782609, 0.22826086956522, 0
27550, 2.0913043478261, 0.20217391304348, 0
27551, 2.1565217391304, 0.22826086956522, 0
27552, 2.1347826086957, 0.20217391304348, 0
27553, 2.1782608695652, 0.20217391304348, 0
27554, 1.2434782608696, 0.17608695652174, 0
27555, 1.2869565217391, 0.17608695652174, 0
27556, 1.3304347826087, 0.17608695652174, 0
27557, 1.3739130434783, 0.17608695652174, 0
27558, 1.4173913043478, 0.17608695652174, 0
27559, 1.4608695652174, 0.17608695652174, 0
27560, 1.504347826087, 0.17608695652174, 0
27561, 1.5478260869565, 0.17608695652174, 0
27562, 1.5913043478261, 0.17608695652174, 0
27563, 1.6347826086957, 0.17608695652174, 0
27564, 1.6782608695652, 0.17608695652174, 0
27565, 1.7217391304348, 0.17608695652174, 0
27566, 1.7652173913043, 0.17608695652174, 0
27567, 1.8086956521739, 0.17608695652174, 0
27568, 1.8521739130435, 0.17608695652174, 0
27569, 1.895652173913, 0.17608695652174, 0
27570, 1.9391304347826, 0.17608695652174, 0
27571, 1.9826086956522, 0.17608695652174, 0
27572, 2.0260869565217, 0.17608695652174, 0
27573, 2.0695652173913, 0.17608695652174, 0
27574, 2.1130434782609, 0.17608695652174, 0
27575, 2.1565217391304, 0.17608695652174, 0
27576, 1.2, 1.2978260869565, 0.44444444444444
27577, 1.2, 1.2978260869565, 0.38888888888889
27578, 1.2, 1.2978260869565, 0.33333333333333
27579, 1.2, 1.2978260869565, 0.27777777777778
27580, 1.2, 1.2978260869565, 0.22222222222222
27581, 1.2, 1.2978260869565, 0.16666666666667
27582, 1.2, 1.2978260869565, 0.11111111111111
27583, 1.2, 1.2978260869565, 0.055555555555556
27584, 1.2, 1.245652173913, 0.44444444444444
27585, 1.2, 1.245652173913, 0.38888888888889
27586, 1.2, 1.245652173913, 0.33333333333333
27587, 1.2, 1.245652173913, 0.27777777777778
27588, 1.2, 1.245652173913, 0.22222222222222
27589, 1.2, 1.245652173913, 0.16666666666667
27590, 1.2, 1.245652173913, 0.11111111111111
27591, 1.2, 1.245652173913, 0.055555555555556
27592, 1.2, 1.1934782608696, 0.44444444444444
27593, 1.2, 1.1934782608696, 0.38888888888889
27594, 1.2, 1.1934782608696, 0.33333333333333
27595, 1.2, 1.1934782608696, 0.27777777777778
27596, 1.2, 1.1934782608696, 0.22222222222222
27597, 1.2, 1.1934782608696, 0.16666666666667
27598, 1.2, 1.1934782608696, 0.11111111111111
27599, 1.2, 1.1934782608696, 0.055555555555556
27600, 1.2, 1.1413043478261, 0.44444444444444
27601, 1.2, 1.1413043478261, 0.38888888888889
27602, 1.2, 1.1413043478261, 0.33333333333333
27603, 1.2, 1.1413043478261, 0.27777777777778
27604, 1.2, 1.1413043478261, 0.22222222222222
27605, 1.2, 1.1413043478261, 0.16666666666667
27606, 1.2, 1.1413043478261, 0.11111111111111
27607, 1.2, 1.1413043478261, 0.055555555555556
27608, 1.2, 1.0891304347826, 0.44444444444444
27609, 1.2, 1.0891304347826, 0.38888888888889
27610, 1.2, 1.0891304347826, 0.33333333333333
27611, 1.2, 1.0891304347826, 0.27777777777778
27612, 1.2, 1.0891304347826, 0.22222222222222
27613, 1.2, 1.0891304347826, 0.16666666666667
27614, 1.2, 1.0891304347826, 0.11111111111111
27615, 1.2, 1.0891304347826, 0.055555555555556
27616, 1.2, 1.0369565217391, 0.44444444444444
27617, 1.2, 1.0369565217391, 0.38888888888889
27618, 1.2, 1.0369565217391, 0.33333333333333
27619, 1.2, 1.0369565217391, 0.27777777777778
27620, 1.2, 1.0369565217391, 0.22222222222222
27621, 1.2, 1.0369565217391, 0.16666666666667
27622, 1.2, 1.0369565217391, 0.11111111111111
27623, 1.2, 1.0369565217391, 0.055555555555556
27624, 1.2, 0.98478260869565, 0.44444444444444
27625, 1.2, 0.98478260869565, 0.38888888888889
27626, 1.2, 0.98478260869565, 0.33333333333333
27627, 1.2, 0.98478260869565, 0.27777777777778
27628, 1.2, 0.98478260869565, 0.22222222222222
27629, 1.2, 0.98478260869565, 0.16666666666667
27630, 1.2, 0.98478260869565, 0.11111111111111
27631, 1.2, 0.98478260869565, 0.055555555555556
27632, 1.2, 0.93260869565217, 0.44444444444444
27633, 1.2, 0.93260869565217, 0.38888888888889
27634, 1.2, 0.93260869565217, 0.33333333333333
27635, 1.2, 0.93260869565217, 0.27777777777778
27636, 1.2, 0.93260869565217, 0.22222222222222
27637, 1.2, 0.93260869565217, 0.16666666666667
27638, 1.2, 0.93260869565217, 0.11111111111111
27639, 1.2, 0.93260869565217, 0.055555555555556
27640, 1.2, 0.8804347826087, 0.44444444444444
27641, 1.2, 0.8804347826087, 0.38888888888889
27642, 1.2, 0.8804347826087, 0.33333333333333
27643, 1.2, 0.8804347826087, 0.27777777777778
27644, 1.2, 0.8804347826087, 0.22222222222222
27645, 1.2, 0.8804347826087, 0.16666666666667
27646, 1.2, 0.8804347826087, 0.11111111111111
27647, 1.2, 0.8804347826087, 0.055555555555556
27648, 1.2, 0.82826086956522, 0.44444444444444
27649, 1.2, 0.82826086956522, 0.38888888888889
27650, 1.2, 0.82826086956522, 0.33333333333333
27651, 1.2, 0.82826086956522, 0.27777777777778
27652, 1.2, 0.82826086956522, 0.22222222222222
27653, 1.2, 0.82826086956522, 0.16666666666667
27654, 1.2, 0.82826086956522, 0.11111111111111
27655, 1.2, 0.82826086956522, 0.055555555555556
27656, 1.2, 0.77608695652174, 0.44444444444444
27657, 1.2, 0.77608695652174, 0.38888888888889
27658, 1.2, 0.77608695652174, 0.33333333333333
27659, 1.2, 0.77608695652174, 0.27777777777778
27660, 1.2, 0.77608695652174, 0.22222222222222
27661, 1.2, 0.77608695652174, 0.16666666666667
27662, 1.2, 0.77608695652174, 0.11111111111111
27663, 1.2, 0.77608695652174, 0.055555555555556
27664, 1.2, 0.72391304347826, 0.44444444444444
27665, 1.2, 0.72391304347826, 0.38888888888889
27666, 1.2, 0.72391304347826, 0.33333333333333
27667, 1.2, 0.72391304347826, 0.27777777777778
27668, 1.2, 0.72391304347826, 0.22222222222222
27669, 1.2, 0.72391304347826, 0.16666666666667
27670, 1.2, 0.72391304347826, 0.11111111111111
27671, 1.2, 0.72391304347826, 0.055555555555556
27672, 1.2, 0.67173913043478, 0.44444444444444
27673, 1.2, 0.67173913043478, 0.38888888888889
27674, 1.2, 0.67173913043478, 0.33333333333333
27675, 1.2, 0.67173913043478, 0.27777777777778
27676, 1.2, 0.67173913043478, 0.22222222222222
27677, 1.2, 0.67173913043478, 0.16666666666667
27678, 1.2, 0.67173913043478, 0.11111111111111
27679, 1.2, 0.67173913043478, 0.055555555555556
27680, 1.2, 0.61956521739131, 0.44444444444444
27681, 1.2, 0.61956521739131, 0.38888888888889
27682, 1.2, 0.61956521739131, 0.33333333333333
27683, 1.2, 0.61956521739131, 0.27777777777778
27684, 1.2, 0.61956521739131, 0.22222222222222
27685, 1.2, 0.61956521739131, 0.16666666666667
27686, 1.2, 0.61956521739131, 0.11111111111111
27687, 1.2, 0.61956521739131, 0.055555555555556
27688, 1.2, 0.56739130434783, 0.44444444444444
27689, 1.2, 0.56739130434783, 0.38888888888889
27690, 1.2, 0.56739130434783, 0.33333333333333
27691, 1.2, 0.56739130434783, 0.27777777777778
27692, 1.2, 0.56739130434783, 0.22222222222222
27693, 1.2, 0.56739130434783, 0.16666666666667
27694, 1.2, 0.56739130434783, 0.11111111111111
27695, 1.2, 0.56739130434783, 0.055555555555556
27696, 1.2, 0.51521739130435, 0.44444444444444
27697, 1.2, 0.51521739130435, 0.38888888888889
27698, 1.2, 0.51521739130435, 0.33333333333333
27699, 1.2, 0.51521739130435, 0.27777777777778
27700, 1.2, 0.51521739130435, 0.22222222222222
27701, 1.2, 0.51521739130435, 0.16666666666667
27702, 1.2, 0.51521739130435, 0.11111111111111
27703, 1.2, 0.51521739130435, 0.055555555555556
27704, 1.2, 0.46304347826087, 0.44444444444444
27705, 1.2, 0.46304347826087, 0.38888888888889
27706, 1.2, 0.46304347826087, 0.33333333333333
27707, 1.2, 0.46304347826087, 0.27777777777778
27708, 1.2, 0.46304347826087, 0.22222222222222
27709, 1.2, 0.46304347826087, 0.16666666666667
27710, 1.2, 0.46304347826087, 0.11111111111111
27711, 1.2, 0.46304347826087, 0.055555555555556
27712, 1.2, 0.41086956521739, 0.44444444444444
27713, 1.2, 0.41086956521739, 0.38888888888889
27714, 1.2, 0.41086956521739, 0.33333333333333
27715, 1.2, 0.41086956521739, 0.27777777777778
27716, 1.2, 0.41086956521739, 0.22222222222222
27717, 1.2, 0.41086956521739, 0.16666666666667
27718, 1.2, 0.41086956521739, 0.11111111111111
27719, 1.2, 0.41086956521739, 0.055555555555556
27720, 1.2, 0.35869565217391, 0.44444444444444
27721, 1.2, 0.35869565217391, 0.38888888888889
27722, 1.2, 0.35869565217391, 0.33333333333333
27723, 1.2, 0.35869565217391, 0.27777777777778
27724, 1.2, 0.35869565217391, 0.22222222222222
27725, 1.2, 0.35869565217391, 0.16666666666667
27726, 1.2, 0.35869565217391, 0.11111111111111
27727, 1.2, 0.35869565217391, 0.055555555555556
27728, 1.2, 0.30652173913044, 0.44444444444444
27729, 1.2, 0.30652173913044, 0.38888888888889
27730, 1.2, 0.30652173913044, 0.33333333333333
27731, 1.2, 0.30652173913044, 0.27777777777778
27732, 1.2, 0.30652173913044, 0.22222222222222
27733, 1.2, 0.30652173913044, 0.16666666666667
27734, 1.2, 0.30652173913044, 0.11111111111111
27735, 1.2, 0.30652173913044, 0.055555555555556
27736, 1.2, 0.25434782608696, 0.44444444444444
27737, 1.2, 0.25434782608696, 0.38888888888889
27738, 1.2, 0.25434782608696, 0.33333333333333
27739, 1.2, 0.25434782608696, 0.27777777777778
27740, 1.2, 0.25434782608696, 0.22222222222222
27741, 1.2, 0.25434782608696, 0.16666666666667
27742, 1.2, 0.25434782608696, 0.11111111111111
27743, 1.2, 0.25434782608696, 0.055555555555556
27744, 1.2, 0.20217391304348, 0.44444444444444
27745, 1.2, 0.20217391304348, 0.38888888888889
27746, 1.2, 0.20217391304348, 0.33333333333333
27747, 1.2, 0.20217391304348, 0.27777777777778
27748, 1.2, 0.20217391304348, 0.22222222222222
27749, 1.2, 0.20217391304348, 0.16666666666667
27750, 1.2, 0.20217391304348, 0.11111111111111
27751, 1.2, 0.20217391304348, 0.055555555555556
27752, 1.2, 1.3239130434783, 0.44444444444444
27753, 1.2, 1.2978260869565, 0.47222222222222
27754, 1.2, 1.3239130434783, 0.38888888888889
27755, 1.2, 1.2978260869565, 0.41666666666667
27756, 1.2, 1.3239130434783, 0.33333333333333
27757, 1.2, 1.2978260869565, 0.36111111111111
27758, 1.2, 1.3239130434783, 0.27777777777778
27759, 1.2, 1.2978260869565, 0.30555555555556
27760, 1.2, 1.3239130434783, 0.22222222222222
27761, 1.2, 1.2978260869565, 0.25
27762, 1.2, 1.3239130434783, 0.16666666666667
27763, 1.2, 1.2978260869565, 0.19444444444444
27764, 1.2, 1.3239130434783, 0.11111111111111
27765, 1.2, 1.2978260869565, 0.13888888888889
27766, 1.2, 1.3239130434783, 0.055555555555556
27767, 1.2, 1.2978260869565, 0.083333333333333
27768, 1.2, 1.2978260869565, 0.027777777777778
27769, 1.2, 1.2717391304348, 0.44444444444444
27770, 1.2, 1.245652173913, 0.47222222222222
27771, 1.2, 1.2717391304348, 0.38888888888889
27772, 1.2, 1.245652173913, 0.41666666666667
27773, 1.2, 1.2717391304348, 0.33333333333333
27774, 1.2, 1.245652173913, 0.36111111111111
27775, 1.2, 1.2717391304348, 0.27777777777778
27776, 1.2, 1.245652173913, 0.30555555555556
27777, 1.2, 1.2717391304348, 0.22222222222222
27778, 1.2, 1.245652173913, 0.25
27779, 1.2, 1.2717391304348, 0.16666666666667
27780, 1.2, 1.245652173913, 0.19444444444444
27781, 1.2, 1.2717391304348, 0.11111111111111
27782, 1.2, 1.245652173913, 0.13888888888889
27783, 1.2, 1.2717391304348, 0.055555555555556
27784, 1.2, 1.245652173913, 0.083333333333333
27785, 1.2, 1.245652173913, 0.027777777777778
27786, 1.2, 1.2195652173913, 0.44444444444444
27787, 1.2, 1.1934782608696, 0.47222222222222
27788, 1.2, 1.2195652173913, 0.38888888888889
27789, 1.2, 1.1934782608696, 0.41666666666667
27790, 1.2, 1.2195652173913, 0.33333333333333
27791, 1.2, 1.1934782608696, 0.36111111111111
27792, 1.2, 1.2195652173913, 0.27777777777778
27793, 1.2, 1.1934782608696, 0.30555555555556
27794, 1.2, 1.2195652173913, 0.22222222222222
27795, 1.2, 1.1934782608696, 0.25
27796, 1.2, 1.2195652173913, 0.16666666666667
27797, 1.2, 1.1934782608696, 0.19444444444444
27798, 1.2, 1.2195652173913, 0.11111111111111
27799, 1.2, 1.1934782608696, 0.13888888888889
27800, 1.2, 1.2195652173913, 0.055555555555556
27801, 1.2, 1.1934782608696, 0.083333333333333
27802, 1.2, 1.1934782608696, 0.027777777777778
27803, 1.2, 1.1673913043478, 0.44444444444444
27804, 1.2, 1.1413043478261, 0.47222222222222
27805, 1.2, 1.1673913043478, 0.38888888888889
27806, 1.2, 1.1413043478261, 0.41666666666667
27807, 1.2, 1.1673913043478, 0.33333333333333
27808, 1.2, 1.1413043478261, 0.36111111111111
27809, 1.2, 1.1673913043478, 0.27777777777778
27810, 1.2, 1.1413043478261, 0.30555555555556
27811, 1.2, 1.1673913043478, 0.22222222222222
27812, 1.2, 1.1413043478261, 0.25
27813, 1.2, 1.1673913043478, 0.16666666666667
27814, 1.2, 1.1413043478261, 0.19444444444444
27815, 1.2, 1.1673913043478, 0.11111111111111
27816, 1.2, 1.1413043478261, 0.13888888888889
27817, 1.2, 1.1673913043478, 0.055555555555556
27818, 1.2, 1.1413043478261, 0.083333333333333
27819, 1.2, 1.1413043478261, 0.027777777777778
27820, 1.2, 1.1152173913043, 0.44444444444444
27821, 1.2, 1.0891304347826, 0.47222222222222
27822, 1.2, 1.1152173913043, 0.38888888888889
27823, 1.2, 1.0891304347826, 0.41666666666667
27824, 1.2, 1.1152173913043, 0.33333333333333
27825, 1.2, 1.0891304347826, 0.36111111111111
27826, 1.2, 1.1152173913043, 0.27777777777778
27827, 1.2, 1.0891304347826, 0.30555555555556
27828, 1.2, 1.1152173913043, 0.22222222222222
27829, 1.2, 1.0891304347826, 0.25
27830, 1.2, 1.1152173913043, 0.16666666666667
27831, 1.2, 1.0891304347826, 0.19444444444444
27832, 1.2, 1.1152173913043, 0.11111111111111
27833, 1.2, 1.0891304347826, 0.13888888888889
27834, 1.2, 1.1152173913043, 0.055555555555556
27835, 1.2, 1.0891304347826, 0.083333333333333
27836, 1.2, 1.0891304347826, 0.027777777777778
27837, 1.2, 1.0630434782609, 0.44444444444444
27838, 1.2, 1.0369565217391, 0.47222222222222
27839, 1.2, 1.0630434782609, 0.38888888888889
27840, 1.2, 1.0369565217391, 0.41666666666667
27841, 1.2, 1.0630434782609, 0.33333333333333
27842, 1.2, 1.0369565217391, 0.36111111111111
27843, 1.2, 1.0630434782609, 0.27777777777778
27844, 1.2, 1.0369565217391, 0.30555555555556
27845, 1.2, 1.0630434782609, 0.22222222222222
27846, 1.2, 1.0369565217391, 0.25
27847, 1.2, 1.0630434782609, 0.16666666666667
27848, 1.2, 1.0369565217391, 0.19444444444444
27849, 1.2, 1.0630434782609, 0.11111111111111
27850, 1.2, 1.0369565217391, 0.13888888888889
27851, 1.2, 1.0630434782609, 0.055555555555556
27852, 1.2, 1.0369565217391, 0.083333333333333
27853, 1.2, 1.0369565217391, 0.027777777777778
27854, 1.2, 1.0108695652174, 0.44444444444444
27855, 1.2, 0.98478260869565, 0.47222222222222
27856, 1.2, 1.0108695652174, 0.38888888888889
27857, 1.2, 0.98478260869565, 0.41666666666667
27858, 1.2, 1.0108695652174, 0.33333333333333
27859, 1.2, 0.98478260869565, 0.36111111111111
27860, 1.2, 1.0108695652174, 0.27777777777778
27861, 1.2, 0.98478260869565, 0.30555555555556
27862, 1.2, 1.0108695652174, 0.22222222222222
27863, 1.2, 0.98478260869565, 0.25
27864, 1.2, 1.0108695652174, 0.16666666666667
27865, 1.2, 0.98478260869565, 0.19444444444444
27866, 1.2, 1.0108695652174, 0.11111111111111
27867, 1.2, 0.98478260869565, 0.13888888888889
27868, 1.2, 1.0108695652174, 0.055555555555556
27869, 1.2, 0.98478260869565, 0.083333333333333
27870, 1.2, 0.98478260869565, 0.027777777777778
27871, 1.2, 0.95869565217391, 0.44444444444444
27872, 1.2, 0.93260869565217, 0.47222222222222
27873, 1.2, 0.95869565217391, 0.38888888888889
27874, 1.2, 0.93260869565217, 0.41666666666667
27875, 1.2, 0.95869565217391, 0.33333333333333
27876, 1.2, 0.93260869565217, 0.36111111111111
27877, 1.2, 0.95869565217391, 0.27777777777778
27878, 1.2, 0.93260869565217, 0.30555555555556
27879, 1.2, 0.95869565217391, 0.22222222222222
27880, 1.2, 0.93260869565217, 0.25
27881, 1.2, 0.95869565217391, 0.16666666666667
27882, 1.2, 0.93260869565217, 0.19444444444444
27883, 1.2, 0.95869565217391, 0.11111111111111
27884, 1.2, 0.93260869565217, 0.13888888888889
27885, 1.2, 0.95869565217391, 0.055555555555556
27886, 1.2, 0.93260869565217, 0.083333333333333
27887, 1.2, 0.93260869565217, 0.027777777777778
27888, 1.2, 0.90652173913044, 0.44444444444444
27889, 1.2, 0.8804347826087, 0.47222222222222
27890, 1.2, 0.90652173913044, 0.38888888888889
27891, 1.2, 0.8804347826087, 0.41666666666667
27892, 1.2, 0.90652173913044, 0.33333333333333
27893, 1.2, 0.8804347826087, 0.36111111111111
27894, 1.2, 0.90652173913044, 0.27777777777778
27895, 1.2, 0.8804347826087, 0.30555555555556
27896, 1.2, 0.90652173913044, 0.22222222222222
27897, 1.2, 0.8804347826087, 0.25
27898, 1.2, 0.90652173913044, 0.16666666666667
27899, 1.2, 0.8804347826087, 0.19444444444444
27900, 1.2, 0.90652173913044, 0.11111111111111
27901, 1.2, 0.8804347826087, 0.13888888888889
27902, 1.2, 0.90652173913044, 0.055555555555556
27903, 1.2, 0.8804347826087, 0.083333333333333
27904, 1.2, 0.8804347826087, 0.027777777777778
27905, 1.2, 0.85434782608696, 0.44444444444444
27906, 1.2, 0.82826086956522, 0.47222222222222
27907, 1.2, 0.85434782608696, 0.38888888888889
27908, 1.2, 0.82826086956522, 0.41666666666667
27909, 1.2, 0.85434782608696, 0.33333333333333
27910, 1.2, 0.82826086956522, 0.36111111111111
27911, 1.2, 0.85434782608696, 0.27777777777778
27912, 1.2, 0.82826086956522, 0.30555555555556
27913, 1.2, 0.85434782608696, 0.22222222222222
27914, 1.2, 0.82826086956522, 0.25
27915, 1.2, 0.85434782608696, 0.16666666666667
27916, 1.2, 0.82826086956522, 0.19444444444444
27917, 1.2, 0.85434782608696, 0.11111111111111
27918, 1.2, 0.82826086956522, 0.13888888888889
27919, 1.2, 0.85434782608696, 0.055555555555556
27920, 1.2, 0.82826086956522, 0.083333333333333
27921, 1.2, 0.82826086956522, 0.027777777777778
27922, 1.2, 0.80217391304348, 0.44444444444444
27923, 1.2, 0.77608695652174, 0.47222222222222
27924, 1.2, 0.80217391304348, 0.38888888888889
27925, 1.2, 0.77608695652174, 0.41666666666667
27926, 1.2, 0.80217391304348, 0.33333333333333
27927, 1.2, 0.77608695652174, 0.36111111111111
27928, 1.2, 0.80217391304348, 0.27777777777778
27929, 1.2, 0.77608695652174, 0.30555555555556
27930, 1.2, 0.80217391304348, 0.22222222222222
27931, 1.2, 0.77608695652174, 0.25
27932, 1.2, 0.80217391304348, 0.16666666666667
27933, 1.2, 0.77608695652174, 0.19444444444444
27934, 1.2, 0.80217391304348, 0.11111111111111
27935, 1.2, 0.77608695652174, 0.13888888888889
27936, 1.2, 0.80217391304348, 0.055555555555556
27937, 1.2, 0.77608695652174, 0.083333333333333
27938, 1.2, 0.77608695652174, 0.027777777777778
27939, 1.2, 0.75, 0.44444444444444
27940, 1.2, 0.72391304347826, 0.47222222222222
27941, 1.2, 0.75, 0.38888888888889
27942, 1.2, 0.72391304347826, 0.41666666666667
27943, 1.2, 0.75, 0.33333333333333
27944, 1.2, 0.72391304347826, 0.36111111111111
27945, 1.2, 0.75, 0.27777777777778
27946, 1.2, 0.72391304347826, 0.30555555555556
27947, 1.2, 0.75, 0.22222222222222
27948, 1.2, 0.72391304347826, 0.25
27949, 1.2, 0.75, 0.16666666666667
27950, 1.2, 0.72391304347826, 0.19444444444444
27951, 1.2, 0.75, 0.11111111111111
27952, 1.2, 0.72391304347826, 0.13888888888889
27953, 1.2, 0.75, 0.055555555555556
27954, 1.2, 0.72391304347826, 0.083333333333333
27955, 1.2, 0.72391304347826, 0.027777777777778
27956, 1.2, 0.69782608695652, 0.44444444444444
27957, 1.2, 0.67173913043478, 0.47222222222222
27958, 1.2, 0.69782608695652, 0.38888888888889
27959, 1.2, 0.67173913043478, 0.41666666666667
27960, 1.2, 0.69782608695652, 0.33333333333333
27961, 1.2, 0.67173913043478, 0.36111111111111
27962, 1.2, 0.69782608695652, 0.27777777777778
27963, 1.2, 0.67173913043478, 0.30555555555556
27964, 1.2, 0.69782608695652, 0.22222222222222
27965, 1.2, 0.67173913043478, 0.25
27966, 1.2, 0.69782608695652, 0.16666666666667
27967, 1.2, 0.67173913043478, 0.19444444444444
27968, 1.2, 0.69782608695652, 0.11111111111111
27969, 1.2, 0.67173913043478, 0.13888888888889
27970, 1.2, 0.69782608695652, 0.055555555555556
27971, 1.2, 0.67173913043478, 0.083333333333333
27972, 1.2, 0.67173913043478, 0.027777777777778
27973, 1.2, 0.64565217391304, 0.44444444444444
27974, 1.2, 0.61956521739131, 0.47222222222222
27975, 1.2, 0.64565217391304, 0.38888888888889
27976, 1.2, 0.61956521739131, 0.41666666666667
27977, 1.2, 0.64565217391304, 0.33333333333333
27978, 1.2, 0.61956521739131, 0.36111111111111
27979, 1.2, 0.64565217391304, 0.27777777777778
27980, 1.2, 0.61956521739131, 0.30555555555556
27981, 1.2, 0.64565217391304, 0.22222222222222
27982, 1.2, 0.61956521739131, 0.25
27983, 1.2, 0.64565217391304, 0.16666666666667
27984, 1.2, 0.61956521739131, 0.19444444444444
27985, 1.2, 0.64565217391304, 0.11111111111111
27986, 1.2, 0.61956521739131, 0.13888888888889
27987, 1.2, 0.64565217391304, 0.055555555555556
27988, 1.2, 0.61956521739131, 0.083333333333333
27989, 1.2, 0.61956521739131, 0.027777777777778
27990, 1.2, 0.59347826086957, 0.44444444444444
27991, 1.2, 0.56739130434783, 0.47222222222222
27992, 1.2, 0.59347826086957, 0.38888888888889
27993, 1.2, 0.56739130434783, 0.41666666666667
27994, 1.2, 0.59347826086957, 0.33333333333333
27995, 1.2, 0.56739130434783, 0.36111111111111
27996, 1.2, 0.59347826086957, 0.27777777777778
27997, 1.2, 0.56739130434783, 0.30555555555556
27998, 1.2, 0.59347826086957, 0.22222222222222
27999, 1.2, 0.56739130434783, 0.25
28000, 1.2, 0.59347826086957, 0.16666666666667
28001, 1.2, 0.56739130434783, 0.19444444444444
28002, 1.2, 0.59347826086957, 0.11111111111111
28003, 1.2, 0.56739130434783, 0.13888888888889
28004, 1.2, 0.59347826086957, 0.055555555555556
28005, 1.2, 0.56739130434783, 0.083333333333333
28006, 1.2, 0.56739130434783, 0.027777777777778
28007, 1.2, 0.54130434782609, 0.44444444444444
28008, 1.2, 0.51521739130435, 0.47222222222222
28009, 1.2, 0.54130434782609, 0.38888888888889
28010, 1.2, 0.51521739130435, 0.41666666666667
28011, 1.2, 0.54130434782609, 0.33333333333333
28012, 1.2, 0.51521739130435, 0.36111111111111
28013, 1.2, 0.54130434782609, 0.27777777777778
28014, 1.2, 0.51521739130435, 0.30555555555556
28015, 1.2, 0.54130434782609, 0.22222222222222
28016, 1.2, 0.51521739130435, 0.25
28017, 1.2, 0.54130434782609, 0.16666666666667
28018, 1.2, 0.51521739130435, 0.19444444444444
28019, 1.2, 0.54130434782609, 0.11111111111111
28020, 1.2, 0.51521739130435, 0.13888888888889
28021, 1.2, 0.54130434782609, 0.055555555555556
28022, 1.2, 0.51521739130435, 0.083333333333333
28023, 1.2, 0.51521739130435, 0.027777777777778
28024, 1.2, 0.48913043478261, 0.44444444444444
28025, 1.2, 0.46304347826087, 0.47222222222222
28026, 1.2, 0.48913043478261, 0.38888888888889
28027, 1.2, 0.46304347826087, 0.41666666666667
28028, 1.2, 0.48913043478261, 0.33333333333333
28029, 1.2, 0.46304347826087, 0.36111111111111
28030, 1.2, 0.48913043478261, 0.27777777777778
28031, 1.2, 0.46304347826087, 0.30555555555556
28032, 1.2, 0.48913043478261, 0.22222222222222
28033, 1.2, 0.46304347826087, 0.25
28034, 1.2, 0.48913043478261, 0.16666666666667
28035, 1.2, 0.46304347826087, 0.19444444444444
28036, 1.2, 0.48913043478261, 0.11111111111111
28037, 1.2, 0.46304347826087, 0.13888888888889
28038, 1.2, 0.48913043478261, 0.055555555555556
28039, 1.2, 0.46304347826087, 0.083333333333333
28040, 1.2, 0.46304347826087, 0.027777777777778
28041, 1.2, 0.43695652173913, 0.44444444444444
28042, 1.2, 0.41086956521739, 0.47222222222222
28043, 1.2, 0.43695652173913, 0.38888888888889
28044, 1.2, 0.41086956521739, 0.41666666666667
28045, 1.2, 0.43695652173913, 0.33333333333333
28046, 1.2, 0.41086956521739, 0.36111111111111
28047, 1.2, 0.43695652173913, 0.27777777777778
28048, 1.2, 0.41086956521739, 0.30555555555556
28049, 1.2, 0.43695652173913, 0.22222222222222
28050, 1.2, 0.41086956521739, 0.25
28051, 1.2, 0.43695652173913, 0.16666666666667
28052, 1.2, 0.41086956521739, 0.19444444444444
28053, 1.2, 0.43695652173913, 0.11111111111111
28054, 1.2, 0.41086956521739, 0.13888888888889
28055, 1.2, 0.43695652173913, 0.055555555555556
28056, 1.2, 0.41086956521739, 0.083333333333333
28057, 1.2, 0.41086956521739, 0.027777777777778
28058, 1.2, 0.38478260869565, 0.44444444444444
28059, 1.2, 0.35869565217391, 0.47222222222222
28060, 1.2, 0.38478260869565, 0.38888888888889
28061, 1.2, 0.35869565217391, 0.41666666666667
28062, 1.2, 0.38478260869565, 0.33333333333333
28063, 1.2, 0.35869565217391, 0.36111111111111
28064, 1.2, 0.38478260869565, 0.27777777777778
28065, 1.2, 0.35869565217391, 0.30555555555556
28066, 1.2, 0.38478260869565, 0.22222222222222
28067, 1.2, 0.35869565217391, 0.25
28068, 1.2, 0.38478260869565, 0.16666666666667
28069, 1.2, 0.35869565217391, 0.19444444444444
28070, 1.2, 0.38478260869565, 0.11111111111111
28071, 1.2, 0.35869565217391, 0.13888888888889
28072, 1.2, 0.38478260869565, 0.055555555555556
28073, 1.2, 0.35869565217391, 0.083333333333333
28074, 1.2, 0.35869565217391, 0.027777777777778
28075, 1.2, 0.33260869565217, 0.44444444444444
28076, 1.2, 0.30652173913044, 0.47222222222222
28077, 1.2, 0.33260869565217, 0.38888888888889
28078, 1.2, 0.30652173913044, 0.41666666666667
28079, 1.2, 0.33260869565217, 0.33333333333333
28080, 1.2, 0.30652173913044, 0.36111111111111
28081, 1.2, 0.33260869565217, 0.27777777777778
28082, 1.2, 0.30652173913044, 0.30555555555556
28083, 1.2, 0.33260869565217, 0.22222222222222
28084, 1.2, 0.30652173913044, 0.25
28085, 1.2, 0.33260869565217, 0.16666666666667
28086, 1.2, 0.30652173913044, 0.19444444444444
28087, 1.2, 0.33260869565217, 0.11111111111111
28088, 1.2, 0.30652173913044, 0.13888888888889
28089, 1.2, 0.33260869565217, 0.055555555555556
28090, 1.2, 0.30652173913044, 0.083333333333333
28091, 1.2, 0.30652173913044, 0.027777777777778
28092, 1.2, 0.2804347826087, 0.44444444444444
28093, 1.2, 0.25434782608696, 0.47222222222222
28094, 1.2, 0.2804347826087, 0.38888888888889
28095, 1.2, 0.25434782608696, 0.41666666666667
28096, 1.2, 0.2804347826087, 0.33333333333333
28097, 1.2, 0.25434782608696, 0.36111111111111
28098, 1.2, 0.2804347826087, 0.27777777777778
28099, 1.2, 0.25434782608696, 0.30555555555556
28100, 1.2, 0.2804347826087, 0.22222222222222
28101, 1.2, 0.25434782608696, 0.25
28102, 1.2, 0.2804347826087, 0.16666666666667
28103, 1.2, 0.25434782608696, 0.19444444444444
28104, 1.2, 0.2804347826087, 0.11111111111111
28105, 1.2, 0.25434782608696, 0.13888888888889
28106, 1.2, 0.2804347826087, 0.055555555555556
28107, 1.2, 0.25434782608696, 0.083333333333333
28108, 1.2, 0.25434782608696, 0.027777777777778
28109, 1.2, 0.22826086956522, 0.44444444444444
28110, 1.2, 0.20217391304348, 0.47222222222222
28111, 1.2, 0.22826086956522, 0.38888888888889
28112, 1.2, 0.20217391304348, 0.41666666666667
28113, 1.2, 0.22826086956522, 0.33333333333333
28114, 1.2, 0.20217391304348, 0.36111111111111
28115, 1.2, 0.22826086956522, 0.27777777777778
28116, 1.2, 0.20217391304348, 0.30555555555556
28117, 1.2, 0.22826086956522, 0.22222222222222
28118, 1.2, 0.20217391304348, 0.25
28119, 1.2, 0.22826086956522, 0.16666666666667
28120, 1.2, 0.20217391304348, 0.19444444444444
28121, 1.2, 0.22826086956522, 0.11111111111111
28122, 1.2, 0.20217391304348, 0.13888888888889
28123, 1.2, 0.22826086956522, 0.055555555555556
28124, 1.2, 0.20217391304348, 0.083333333333333
28125, 1.2, 0.20217391304348, 0.027777777777778
28126, 1.2, 0.17608695652174, 0.44444444444444
28127, 1.2, 0.17608695652174, 0.38888888888889
28128, 1.2, 0.17608695652174, 0.33333333333333
28129, 1.2, 0.17608695652174, 0.27777777777778
28130, 1.2, 0.17608695652174, 0.22222222222222
28131, 1.2, 0.17608695652174, 0.16666666666667
28132, 1.2, 0.17608695652174, 0.11111111111111
28133, 1.2, 0.17608695652174, 0.055555555555556
28134, 2.2, 1.2978260869565, 0.44444444444444
28135, 2.2, 1.2978260869565, 0.38888888888889
28136, 2.2, 1.2978260869565, 0.33333333333333
28137, 2.2, 1.2978260869565, 0.27777777777778
28138, 2.2, 1.2978260869565, 0.22222222222222
28139, 2.2, 1.2978260869565, 0.16666666666667
28140, 2.2, 1.2978260869565, 0.11111111111111
28141, 2.2, 1.2978260869565, 0.055555555555556
28142, 2.2, 1.245652173913, 0.44444444444444
28143, 2.2, 1.245652173913, 0.38888888888889
28144, 2.2, 1.245652173913, 0.33333333333333
28145, 2.2, 1.245652173913, 0.27777777777778
28146, 2.2, 1.245652173913, 0.22222222222222
28147, 2.2, 1.245652173913, 0.16666666666667
28148, 2.2, 1.245652173913, 0.11111111111111
28149, 2.2, 1.245652173913, 0.055555555555556
28150, 2.2, 1.1934782608696, 0.44444444444444
28151, 2.2, 1.1934782608696, 0.38888888888889
28152, 2.2, 1.1934782608696, 0.33333333333333
28153, 2.2, 1.1934782608696, 0.27777777777778
28154, 2.2, 1.1934782608696, 0.22222222222222
28155, 2.2, 1.1934782608696, 0.16666666666667
28156, 2.2, 1.1934782608696, 0.11111111111111
28157, 2.2, 1.1934782608696, 0.055555555555556
28158, 2.2, 1.1413043478261, 0.44444444444444
28159, 2.2, 1.1413043478261, 0.38888888888889
28160, 2.2, 1.1413043478261, 0.33333333333333
28161, 2.2, 1.1413043478261, 0.27777777777778
28162, 2.2, 1.1413043478261, 0.22222222222222
28163, 2.2, 1.1413043478261, 0.16666666666667
28164, 2.2, 1.1413043478261, 0.11111111111111
28165, 2.2, 1.1413043478261, 0.055555555555556
28166, 2.2, 1.0891304347826, 0.44444444444444
28167, 2.2, 1.0891304347826, 0.38888888888889
28168, 2.2, 1.0891304347826, 0.33333333333333
28169, 2.2, 1.0891304347826, 0.27777777777778
28170, 2.2, 1.0891304347826, 0.22222222222222
28171, 2.2, 1.0891304347826, 0.16666666666667
28172, 2.2, 1.0891304347826, 0.11111111111111
28173, 2.2, 1.0891304347826, 0.055555555555556
28174, 2.2, 1.0369565217391, 0.44444444444444
28175, 2.2, 1.0369565217391, 0.38888888888889
28176, 2.2, 1.0369565217391, 0.33333333333333
28177, 2.2, 1.0369565217391, 0.27777777777778
28178, 2.2, 1.0369565217391, 0.22222222222222
28179, 2.2, 1.0369565217391, 0.16666666666667
28180, 2.2, 1.0369565217391, 0.11111111111111
28181, 2.2, 1.0369565217391, 0.055555555555556
28182, 2.2, 0.98478260869565, 0.44444444444444
28183, 2.2, 0.98478260869565, 0.38888888888889
28184, 2.2, 0.98478260869565, 0.33333333333333
28185, 2.2, 0.98478260869565, 0.27777777777778
28186, 2.2, 0.98478260869565, 0.22222222222222
28187, 2.2, 0.98478260869565, 0.16666666666667
28188, 2.2, 0.98478260869565, 0.11111111111111
28189, 2.2, 0.98478260869565, 0.055555555555556
28190, 2.2, 0.93260869565217, 0.44444444444444
28191, 2.2, 0.93260869565217, 0.38888888888889
28192, 2.2, 0.93260869565217, 0.33333333333333
28193, 2.2, 0.93260869565217, 0.27777777777778
28194, 2.2, 0.93260869565217, 0.22222222222222
28195, 2.2, 0.93260869565217, 0.16666666666667
28196, 2.2, 0.93260869565217, 0.11111111111111
28197, 2.2, 0.93260869565217, 0.055555555555556
28198, 2.2, 0.8804347826087, 0.44444444444444
28199, 2.2, 0.8804347826087, 0.38888888888889
28200, 2.2, 0.8804347826087, 0.33333333333333
28201, 2.2, 0.8804347826087, 0.27777777777778
28202, 2.2, 0.8804347826087, 0.22222222222222
28203, 2.2, 0.8804347826087, 0.16666666666667
28204, 2.2, 0.8804347826087, 0.11111111111111
28205, 2.2, 0.8804347826087, 0.055555555555556
28206, 2.2, 0.82826086956522, 0.44444444444444
28207, 2.2, 0.82826086956522, 0.38888888888889
28208, 2.2, 0.82826086956522, 0.33333333333333
28209, 2.2, 0.82826086956522, 0.27777777777778
28210, 2.2, 0.82826086956522, 0.22222222222222
28211, 2.2, 0.82826086956522, 0.16666666666667
28212, 2.2, 0.82826086956522, 0.11111111111111
28213, 2.2, 0.82826086956522, 0.055555555555556
28214, 2.2, 0.77608695652174, 0.44444444444444
28215, 2.2, 0.77608695652174, 0.38888888888889
28216, 2.2, 0.77608695652174, 0.33333333333333
28217, 2.2, 0.77608695652174, 0.27777777777778
28218, 2.2, 0.77608695652174, 0.22222222222222
28219, 2.2, 0.77608695652174, 0.16666666666667
28220, 2.2, 0.77608695652174, 0.11111111111111
28221, 2.2, 0.77608695652174, 0.055555555555556
28222, 2.2, 0.72391304347826, 0.44444444444444
28223, 2.2, 0.72391304347826, 0.38888888888889
28224, 2.2, 0.72391304347826, 0.33333333333333
28225, 2.2, 0.72391304347826, 0.27777777777778
28226, 2.2, 0.72391304347826, 0.22222222222222
28227, 2.2, 0.72391304347826, 0.16666666666667
28228, 2.2, 0.72391304347826, 0.11111111111111
28229, 2.2, 0.72391304347826, 0.055555555555556
28230, 2.2, 0.67173913043478, 0.44444444444444
28231, 2.2, 0.67173913043478, 0.38888888888889
28232, 2.2, 0.67173913043478, 0.33333333333333
28233, 2.2, 0.67173913043478, 0.27777777777778
28234, 2.2, 0.67173913043478, 0.22222222222222
28235, 2.2, 0.67173913043478, 0.16666666666667
28236, 2.2, 0.67173913043478, 0.11111111111111
28237, 2.2, 0.67173913043478, 0.055555555555556
28238, 2.2, 0.61956521739131, 0.44444444444444
28239, 2.2, 0.61956521739131, 0.38888888888889
28240, 2.2, 0.61956521739131, 0.33333333333333
28241, 2.2, 0.61956521739131, 0.27777777777778
28242, 2.2, 0.61956521739131, 0.22222222222222
28243, 2.2, 0.61956521739131, 0.16666666666667
28244, 2.2, 0.61956521739131, 0.11111111111111
28245, 2.2, 0.61956521739131, 0.055555555555556
28246, 2.2, 0.56739130434783, 0.44444444444444
28247, 2.2, 0.56739130434783, 0.38888888888889
28248, 2.2, 0.56739130434783, 0.33333333333333
28249, 2.2, 0.56739130434783, 0.27777777777778
28250, 2.2, 0.56739130434783, 0.22222222222222
28251, 2.2, 0.56739130434783, 0.16666666666667
28252, 2.2, 0.56739130434783, 0.11111111111111
28253, 2.2, 0.56739130434783, 0.055555555555556
28254, 2.2, 0.51521739130435, 0.44444444444444
28255, 2.2, 0.51521739130435, 0.38888888888889
28256, 2.2, 0.51521739130435, 0.33333333333333
28257, 2.2, 0.51521739130435, 0.27777777777778
28258, 2.2, 0.51521739130435, 0.22222222222222
28259, 2.2, 0.51521739130435, 0.16666666666667
28260, 2.2, 0.51521739130435, 0.11111111111111
28261, 2.2, 0.51521739130435, 0.055555555555556
28262, 2.2, 0.46304347826087, 0.44444444444444
28263, 2.2, 0.46304347826087, 0.38888888888889
28264, 2.2, 0.46304347826087, 0.33333333333333
28265, 2.2, 0.46304347826087, 0.27777777777778
28266, 2.2, 0.46304347826087, 0.22222222222222
28267, 2.2, 0.46304347826087, 0.16666666666667
28268, 2.2, 0.46304347826087, 0.11111111111111
28269, 2.2, 0.46304347826087, 0.055555555555556
28270, 2.2, 0.41086956521739, 0.44444444444444
28271, 2.2, 0.41086956521739, 0.38888888888889
28272, 2.2, 0.41086956521739, 0.33333333333333
28273, 2.2, 0.41086956521739, 0.27777777777778
28274, 2.2, 0.41086956521739, 0.22222222222222
28275, 2.2, 0.41086956521739, 0.16666666666667
28276, 2.2, 0.41086956521739, 0.11111111111111
28277, 2.2, 0.41086956521739, 0.055555555555556
28278, 2.2, 0.35869565217391, 0.44444444444444
28279, 2.2, 0.35869565217391, 0.38888888888889
28280, 2.2, 0.35869565217391, 0.33333333333333
28281, 2.2, 0.35869565217391, 0.27777777777778
28282, 2.2, 0.35869565217391, 0.22222222222222
28283, 2.2, 0.35869565217391, 0.16666666666667
28284, 2.2, 0.35869565217391, 0.11111111111111
28285, 2.2, 0.35869565217391, 0.055555555555556
28286, 2.2, 0.30652173913044, 0.44444444444444
28287, 2.2, 0.30652173913044, 0.38888888888889
28288, 2.2, 0.30652173913044, 0.33333333333333
28289, 2.2, 0.30652173913044, 0.27777777777778
28290, 2.2, 0.30652173913044, 0.22222222222222
28291, 2.2, 0.30652173913044, 0.16666666666667
28292, 2.2, 0.30652173913044, 0.11111111111111
28293, 2.2, 0.30652173913044, 0.055555555555556
28294, 2.2, 0.25434782608696, 0.44444444444444
28295, 2.2, 0.25434782608696, 0.38888888888889
28296, 2.2, 0.25434782608696, 0.33333333333333
28297, 2.2, 0.25434782608696, 0.27777777777778
28298, 2.2, 0.25434782608696, 0.22222222222222
28299, 2.2, 0.25434782608696, 0.16666666666667
28300, 2.2, 0.25434782608696, 0.11111111111111
28301, 2.2, 0.25434782608696, 0.055555555555556
28302, 2.2, 0.20217391304348, 0.44444444444444
28303, 2.2, 0.20217391304348, 0.38888888888889
28304, 2.2, 0.20217391304348, 0.33333333333333
28305, 2.2, 0.20217391304348, 0.27777777777778
28306, 2.2, 0.20217391304348, 0.22222222222222
28307, 2.2, 0.20217391304348, 0.16666666666667
28308, 2.2, 0.20217391304348, 0.11111111111111
28309, 2.2, 0.20217391304348, 0.055555555555556
28310, 2.2, 1.2978260869565, 0.47222222222222
28311, 2.2, 1.3239130434783, 0.44444444444444
28312, 2.2, 1.2978260869565, 0.41666666666667
28313, 2.2, 1.3239130434783, 0.38888888888889
28314, 2.2, 1.2978260869565, 0.36111111111111
28315, 2.2, 1.3239130434783, 0.33333333333333
28316, 2.2, 1.2978260869565, 0.30555555555556
28317, 2.2, 1.3239130434783, 0.27777777777778
28318, 2.2, 1.2978260869565, 0.25
28319, 2.2, 1.3239130434783, 0.22222222222222
28320, 2.2, 1.2978260869565, 0.19444444444444
28321, 2.2, 1.3239130434783, 0.16666666666667
28322, 2.2, 1.2978260869565, 0.13888888888889
28323, 2.2, 1.3239130434783, 0.11111111111111
28324, 2.2, 1.2978260869565, 0.083333333333333
28325, 2.2, 1.3239130434783, 0.055555555555556
28326, 2.2, 1.2978260869565, 0.027777777777778
28327, 2.2, 1.245652173913, 0.47222222222222
28328, 2.2, 1.2717391304348, 0.44444444444444
28329, 2.2, 1.245652173913, 0.41666666666667
28330, 2.2, 1.2717391304348, 0.38888888888889
28331, 2.2, 1.245652173913, 0.36111111111111
28332, 2.2, 1.2717391304348, 0.33333333333333
28333, 2.2, 1.245652173913, 0.30555555555556
28334, 2.2, 1.2717391304348, 0.27777777777778
28335, 2.2, 1.245652173913, 0.25
28336, 2.2, 1.2717391304348, 0.22222222222222
28337, 2.2, 1.245652173913, 0.19444444444444
28338, 2.2, 1.2717391304348, 0.16666666666667
28339, 2.2, 1.245652173913, 0.13888888888889
28340, 2.2, 1.2717391304348, 0.11111111111111
28341, 2.2, 1.245652173913, 0.083333333333333
28342, 2.2, 1.2717391304348, 0.055555555555556
28343, 2.2, 1.245652173913, 0.027777777777778
28344, 2.2, 1.1934782608696, 0.47222222222222
28345, 2.2, 1.2195652173913, 0.44444444444444
28346, 2.2, 1.1934782608696, 0.41666666666667
28347, 2.2, 1.2195652173913, 0.38888888888889
28348, 2.2, 1.1934782608696, 0.36111111111111
28349, 2.2, 1.2195652173913, 0.33333333333333
28350, 2.2, 1.1934782608696, 0.30555555555556
28351, 2.2, 1.2195652173913, 0.27777777777778
28352, 2.2, 1.1934782608696, 0.25
28353, 2.2, 1.2195652173913, 0.22222222222222
28354, 2.2, 1.1934782608696, 0.19444444444444
28355, 2.2, 1.2195652173913, 0.16666666666667
28356, 2.2, 1.1934782608696, 0.13888888888889
28357, 2.2, 1.2195652173913, 0.11111111111111
28358, 2.2, 1.1934782608696, 0.083333333333333
28359, 2.2, 1.2195652173913, 0.055555555555556
28360, 2.2, 1.1934782608696, 0.027777777777778
28361, 2.2, 1.1413043478261, 0.47222222222222
28362, 2.2, 1.1673913043478, 0.44444444444444
28363, 2.2, 1.1413043478261, 0.41666666666667
28364, 2.2, 1.1673913043478, 0.38888888888889
28365, 2.2, 1.1413043478261, 0.36111111111111
28366, 2.2, 1.1673913043478, 0.33333333333333
28367, 2.2, 1.1413043478261, 0.30555555555556
28368, 2.2, 1.1673913043478, 0.27777777777778
28369, 2.2, 1.1413043478261, 0.25
28370, 2.2, 1.1673913043478, 0.22222222222222
28371, 2.2, 1.1413043478261, 0.19444444444444
28372, 2.2, 1.1673913043478, 0.16666666666667
28373, 2.2, 1.1413043478261, 0.13888888888889
28374, 2.2, 1.1673913043478, 0.11111111111111
28375, 2.2, 1.1413043478261, 0.083333333333333
28376, 2.2, 1.1673913043478, 0.055555555555556
28377, 2.2, 1.1413043478261, 0.027777777777778
28378, 2.2, 1.0891304347826, 0.47222222222222
28379, 2.2, 1.1152173913043, 0.44444444444444
28380, 2.2, 1.0891304347826, 0.41666666666667
28381, 2.2, 1.1152173913043, 0.38888888888889
28382, 2.2, 1.0891304347826, 0.36111111111111
28383, 2.2, 1.1152173913043, 0.33333333333333
28384, 2.2, 1.0891304347826, 0.30555555555556
28385, 2.2, 1.1152173913043, 0.27777777777778
28386, 2.2, 1.0891304347826, 0.25
28387, 2.2, 1.1152173913043, 0.22222222222222
28388, 2.2, 1.0891304347826, 0.19444444444444
28389, 2.2, 1.1152173913043, 0.16666666666667
28390, 2.2, 1.0891304347826, 0.13888888888889
28391, 2.2, 1.1152173913043, 0.11111111111111
28392, 2.2, 1.0891304347826, 0.083333333333333
28393, 2.2, 1.1152173913043, 0.055555555555556
28394, 2.2, 1.0891304347826, 0.027777777777778
28395, 2.2, 1.0369565217391, 0.47222222222222
28396, 2.2, 1.0630434782609, 0.44444444444444
28397, 2.2, 1.0369565217391, 0.41666666666667
28398, 2.2, 1.0630434782609, 0.38888888888889
28399, 2.2, 1.0369565217391, 0.36111111111111
28400, 2.2, 1.0630434782609, 0.33333333333333
28401, 2.2, 1.0369565217391, 0.30555555555556
28402, 2.2, 1.0630434782609, 0.27777777777778
28403, 2.2, 1.0369565217391, 0.25
28404, 2.2, 1.0630434782609, 0.22222222222222
28405, 2.2, 1.0369565217391, 0.19444444444444
28406, 2.2, 1.0630434782609, 0.16666666666667
28407, 2.2, 1.0369565217391, 0.13888888888889
28408, 2.2, 1.0630434782609, 0.11111111111111
28409, 2.2, 1.0369565217391, 0.083333333333333
28410, 2.2, 1.0630434782609, 0.055555555555556
28411, 2.2, 1.0369565217391, 0.027777777777778
28412, 2.2, 0.98478260869565, 0.47222222222222
28413, 2.2, 1.0108695652174, 0.44444444444444
28414, 2.2, 0.98478260869565, 0.41666666666667
28415, 2.2, 1.0108695652174, 0.38888888888889
28416, 2.2, 0.98478260869565, 0.36111111111111
28417, 2.2, 1.0108695652174, 0.33333333333333
28418, 2.2, 0.98478260869565, 0.30555555555556
28419, 2.2, 1.0108695652174, 0.27777777777778
28420, 2.2, 0.98478260869565, 0.25
28421, 2.2, 1.0108695652174, 0.22222222222222
28422, 2.2, 0.98478260869565, 0.19444444444444
28423, 2.2, 1.0108695652174, 0.16666666666667
28424, 2.2, 0.98478260869565, 0.13888888888889
28425, 2.2, 1.0108695652174, 0.11111111111111
28426, 2.2, 0.98478260869565, 0.083333333333333
28427, 2.2, 1.0108695652174, 0.055555555555556
28428, 2.2, 0.98478260869565, 0.027777777777778
28429, 2.2, 0.93260869565217, 0.47222222222222
28430, 2.2, 0.95869565217391, 0.44444444444444
28431, 2.2, 0.93260869565217, 0.41666666666667
28432, 2.2, 0.95869565217391, 0.38888888888889
28433, 2.2, 0.93260869565217, 0.36111111111111
28434, 2.2, 0.95869565217391, 0.33333333333333
28435, 2.2, 0.93260869565217, 0.30555555555556
28436, 2.2, 0.95869565217391, 0.27777777777778
28437, 2.2, 0.93260869565217, 0.25
28438, 2.2, 0.95869565217391, 0.22222222222222
28439, 2.2, 0.93260869565217, 0.19444444444444
28440, 2.2, 0.95869565217391, 0.16666666666667
28441, 2.2, 0.93260869565217, 0.13888888888889
28442, 2.2, 0.95869565217391, 0.11111111111111
28443, 2.2, 0.93260869565217, 0.083333333333333
28444, 2.2, 0.95869565217391, 0.055555555555556
28445, 2.2, 0.93260869565217, 0.027777777777778
28446, 2.2, 0.8804347826087, 0.47222222222222
28447, 2.2, 0.90652173913044, 0.44444444444444
28448, 2.2, 0.8804347826087, 0.41666666666667
28449, 2.2, 0.90652173913044, 0.38888888888889
28450, 2.2, 0.8804347826087, 0.36111111111111
28451, 2.2, 0.90652173913044, 0.33333333333333
28452, 2.2, 0.8804347826087, 0.30555555555556
28453, 2.2, 0.90652173913044, 0.27777777777778
28454, 2.2, 0.8804347826087, 0.25
28455, 2.2, 0.90652173913044, 0.22222222222222
28456, 2.2, 0.8804347826087, 0.19444444444444
28457, 2.2, 0.90652173913044, 0.16666666666667
28458, 2.2, 0.8804347826087, 0.13888888888889
28459, 2.2, 0.90652173913044, 0.11111111111111
28460, 2.2, 0.8804347826087, 0.083333333333333
28461, 2.2, 0.90652173913044, 0.055555555555556
28462, 2.2, 0.8804347826087, 0.027777777777778
28463, 2.2, 0.82826086956522, 0.47222222222222
28464, 2.2, 0.85434782608696, 0.44444444444444
28465, 2.2, 0.82826086956522, 0.41666666666667
28466, 2.2, 0.85434782608696, 0.38888888888889
28467, 2.2, 0.82826086956522, 0.36111111111111
28468, 2.2, 0.85434782608696, 0.33333333333333
28469, 2.2, 0.82826086956522, 0.30555555555556
28470, 2.2, 0.85434782608696, 0.27777777777778
28471, 2.2, 0.82826086956522, 0.25
28472, 2.2, 0.85434782608696, 0.22222222222222
28473, 2.2, 0.82826086956522, 0.19444444444444
28474, 2.2, 0.85434782608696, 0.16666666666667
28475, 2.2, 0.82826086956522, 0.13888888888889
28476, 2.2, 0.85434782608696, 0.11111111111111
28477, 2.2, 0.82826086956522, 0.083333333333333
28478, 2.2, 0.85434782608696, 0.055555555555556
28479, 2.2, 0.82826086956522, 0.027777777777778
28480, 2.2, 0.77608695652174, 0.47222222222222
28481, 2.2, 0.80217391304348, 0.44444444444444
28482, 2.2, 0.77608695652174, 0.41666666666667
28483, 2.2, 0.80217391304348, 0.38888888888889
28484, 2.2, 0.77608695652174, 0.36111111111111
28485, 2.2, 0.80217391304348, 0.33333333333333
28486, 2.2, 0.77608695652174, 0.30555555555556
28487, 2.2, 0.80217391304348, 0.27777777777778
28488, 2.2, 0.77608695652174, 0.25
28489, 2.2, 0.80217391304348, 0.22222222222222
28490, 2.2, 0.77608695652174, 0.19444444444444
28491, 2.2, 0.80217391304348, 0.16666666666667
28492, 2.2, 0.77608695652174, 0.13888888888889
28493, 2.2, 0.80217391304348, 0.11111111111111
28494, 2.2, 0.77608695652174, 0.083333333333333
28495, 2.2, 0.80217391304348, 0.055555555555556
28496, 2.2, 0.77608695652174, 0.027777777777778
28497, 2.2, 0.72391304347826, 0.47222222222222
28498, 2.2, 0.75, 0.44444444444444
28499, 2.2, 0.72391304347826, 0.41666666666667
28500, 2.2, 0.75, 0.38888888888889
28501, 2.2, 0.72391304347826, 0.36111111111111
28502, 2.2, 0.75, 0.33333333333333
28503, 2.2, 0.72391304347826, 0.30555555555556
28504, 2.2, 0.75, 0.27777777777778
28505, 2.2, 0.72391304347826, 0.25
28506, 2.2, 0.75, 0.22222222222222
28507, 2.2, 0.72391304347826, 0.19444444444444
28508, 2.2, 0.75, 0.16666666666667
28509, 2.2, 0.72391304347826, 0.13888888888889
28510, 2.2, 0.75, 0.11111111111111
28511, 2.2, 0.72391304347826, 0.083333333333333
28512, 2.2, 0.75, 0.055555555555556
28513, 2.2, 0.72391304347826, 0.027777777777778
28514, 2.2, 0.67173913043478, 0.47222222222222
28515, 2.2, 0.69782608695652, 0.44444444444444
28516, 2.2, 0.67173913043478, 0.41666666666667
28517, 2.2, 0.69782608695652, 0.38888888888889
28518, 2.2, 0.67173913043478, 0.36111111111111
28519, 2.2, 0.69782608695652, 0.33333333333333
28520, 2.2, 0.67173913043478, 0.30555555555556
28521, 2.2, 0.69782608695652, 0.27777777777778
28522, 2.2, 0.67173913043478, 0.25
28523, 2.2, 0.69782608695652, 0.22222222222222
28524, 2.2, 0.67173913043478, 0.19444444444444
28525, 2.2, 0.69782608695652, 0.16666666666667
28526, 2.2, 0.67173913043478, 0.13888888888889
28527, 2.2, 0.69782608695652, 0.11111111111111
28528, 2.2, 0.67173913043478, 0.083333333333333
28529, 2.2, 0.69782608695652, 0.055555555555556
28530, 2.2, 0.67173913043478, 0.027777777777778
28531, 2.2, 0.61956521739131, 0.47222222222222
28532, 2.2, 0.64565217391304, 0.44444444444444
28533, 2.2, 0.61956521739131, 0.41666666666667
28534, 2.2, 0.64565217391304, 0.38888888888889
28535, 2.2, 0.61956521739131, 0.36111111111111
28536, 2.2, 0.64565217391304, 0.33333333333333
28537, 2.2, 0.61956521739131, 0.30555555555556
28538, 2.2, 0.64565217391304, 0.27777777777778
28539, 2.2, 0.61956521739131, 0.25
28540, 2.2, 0.64565217391304, 0.22222222222222
28541, 2.2, 0.61956521739131, 0.19444444444444
28542, 2.2, 0.64565217391304, 0.16666666666667
28543, 2.2, 0.61956521739131, 0.13888888888889
28544, 2.2, 0.64565217391304, 0.11111111111111
28545, 2.2, 0.61956521739131, 0.083333333333333
28546, 2.2, 0.64565217391304, 0.055555555555556
28547, 2.2, 0.61956521739131, 0.027777777777778
28548, 2.2, 0.56739130434783, 0.47222222222222
28549, 2.2, 0.59347826086957, 0.44444444444444
28550, 2.2, 0.56739130434783, 0.41666666666667
28551, 2.2, 0.59347826086957, 0.38888888888889
28552, 2.2, 0.56739130434783, 0.36111111111111
28553, 2.2, 0.59347826086957, 0.33333333333333
28554, 2.2, 0.56739130434783, 0.30555555555556
28555, 2.2, 0.59347826086957, 0.27777777777778
28556, 2.2, 0.56739130434783, 0.25
28557, 2.2, 0.59347826086957, 0.22222222222222
28558, 2.2, 0.56739130434783, 0.19444444444444
28559, 2.2, 0.59347826086957, 0.16666666666667
28560, 2.2, 0.56739130434783, 0.13888888888889
28561, 2.2, 0.59347826086957, 0.11111111111111
28562, 2.2, 0.56739130434783, 0.083333333333333
28563, 2.2, 0.59347826086957, 0.055555555555556
28564, 2.2, 0.56739130434783, 0.027777777777778
28565, 2.2, 0.51521739130435, 0.47222222222222
28566, 2.2, 0.54130434782609, 0.44444444444444
28567, 2.2, 0.51521739130435, 0.41666666666667
28568, 2.2, 0.54130434782609, 0.38888888888889
28569, 2.2, 0.51521739130435, 0.36111111111111
28570, 2.2, 0.54130434782609, 0.33333333333333
28571, 2.2, 0.51521739130435, 0.30555555555556
28572, 2.2, 0.54130434782609, 0.27777777777778
28573, 2.2, 0.51521739130435, 0.25
28574, 2.2, 0.54130434782609, 0.22222222222222
28575, 2.2, 0.51521739130435, 0.19444444444444
28576, 2.2, 0.54130434782609, 0.16666666666667
28577, 2.2, 0.51521739130435, 0.13888888888889
28578, 2.2, 0.54130434782609, 0.11111111111111
28579, 2.2, 0.51521739130435, 0.083333333333333
28580, 2.2, 0.54130434782609, 0.055555555555556
28581, 2.2, 0.51521739130435, 0.027777777777778
28582, 2.2, 0.46304347826087, 0.47222222222222
28583, 2.2, 0.48913043478261, 0.44444444444444
28584, 2.2, 0.46304347826087, 0.41666666666667
28585, 2.2, 0.48913043478261, 0.38888888888889
28586, 2.2, 0.46304347826087, 0.36111111111111
28587, 2.2, 0.48913043478261, 0.33333333333333
28588, 2.2, 0.46304347826087, 0.30555555555556
28589, 2.2, 0.48913043478261, 0.27777777777778
28590, 2.2, 0.46304347826087, 0.25
28591, 2.2, 0.48913043478261, 0.22222222222222
28592, 2.2, 0.46304347826087, 0.19444444444444
28593, 2.2, 0.48913043478261, 0.16666666666667
28594, 2.2, 0.46304347826087, 0.13888888888889
28595, 2.2, 0.48913043478261, 0.11111111111111
28596, 2.2, 0.46304347826087, 0.083333333333333
28597, 2.2, 0.48913043478261, 0.055555555555556
28598, 2.2, 0.46304347826087, 0.027777777777778
28599, 2.2, 0.41086956521739, 0.47222222222222
28600, 2.2, 0.43695652173913, 0.44444444444444
28601, 2.2, 0.41086956521739, 0.41666666666667
28602, 2.2, 0.43695652173913, 0.38888888888889
28603, 2.2, 0.41086956521739, 0.36111111111111
28604, 2.2, 0.43695652173913, 0.33333333333333
28605, 2.2, 0.41086956521739, 0.30555555555556
28606, 2.2, 0.43695652173913, 0.27777777777778
28607, 2.2, 0.41086956521739, 0.25
28608, 2.2, 0.43695652173913, 0.22222222222222
28609, 2.2, 0.41086956521739, 0.19444444444444
28610, 2.2, 0.43695652173913, 0.16666666666667
28611, 2.2, 0.41086956521739, 0.13888888888889
28612, 2.2, 0.43695652173913, 0.11111111111111
28613, 2.2, 0.41086956521739, 0.083333333333333
28614, 2.2, 0.43695652173913, 0.055555555555556
28615, 2.2, 0.41086956521739, 0.027777777777778
28616, 2.2, 0.35869565217391, 0.47222222222222
28617, 2.2, 0.38478260869565, 0.44444444444444
28618, 2.2, 0.35869565217391, 0.41666666666667
28619, 2.2, 0.38478260869565, 0.38888888888889
28620, 2.2, 0.35869565217391, 0.36111111111111
28621, 2.2, 0.38478260869565, 0.33333333333333
28622, 2.2, 0.35869565217391, 0.30555555555556
28623, 2.2, 0.38478260869565, 0.27777777777778
28624, 2.2, 0.35869565217391, 0.25
28625, 2.2, 0.38478260869565, 0.22222222222222
28626, 2.2, 0.35869565217391, 0.19444444444444
28627, 2.2, 0.38478260869565, 0.16666666666667
28628, 2.2, 0.35869565217391, 0.13888888888889
28629, 2.2, 0.38478260869565, 0.11111111111111
28630, 2.2, 0.35869565217391, 0.083333333333333
28631, 2.2, 0.38478260869565, 0.055555555555556
28632, 2.2, 0.35869565217391, 0.027777777777778
28633, 2.2, 0.30652173913044, 0.47222222222222
28634, 2.2, 0.33260869565217, 0.44444444444444
28635, 2.2, 0.30652173913044, 0.41666666666667
28636, 2.2, 0.33260869565217, 0.38888888888889
28637, 2.2, 0.30652173913044, 0.36111111111111
28638, 2.2, 0.33260869565217, 0.33333333333333
28639, 2.2, 0.30652173913044, 0.30555555555556
28640, 2.2, 0.33260869565217, 0.27777777777778
28641, 2.2, 0.30652173913044, 0.25
28642, 2.2, 0.33260869565217, 0.22222222222222
28643, 2.2, 0.30652173913044, 0.19444444444444
28644, 2.2, 0.33260869565217, 0.16666666666667
28645, 2.2, 0.30652173913044, 0.13888888888889
28646, 2.2, 0.33260869565217, 0.11111111111111
28647, 2.2, 0.30652173913044, 0.083333333333333
28648, 2.2, 0.33260869565217, 0.055555555555556
28649, 2.2, 0.30652173913044, 0.027777777777778
28650, 2.2, 0.25434782608696, 0.47222222222222
28651, 2.2, 0.2804347826087, 0.44444444444444
28652, 2.2, 0.25434782608696, 0.41666666666667
28653, 2.2, 0.2804347826087, 0.38888888888889
28654, 2.2, 0.25434782608696, 0.36111111111111
28655, 2.2, 0.2804347826087, 0.33333333333333
28656, 2.2, 0.25434782608696, 0.30555555555556
28657, 2.2, 0.2804347826087, 0.27777777777778
28658, 2.2, 0.25434782608696, 0.25
28659, 2.2, 0.2804347826087, 0.22222222222222
28660, 2.2, 0.25434782608696, 0.19444444444444
28661, 2.2, 0.2804347826087, 0.16666666666667
28662, 2.2, 0.25434782608696, 0.13888888888889
28663, 2.2, 0.2804347826087, 0.11111111111111
28664, 2.2, 0.25434782608696, 0.083333333333333
28665, 2.2, 0.2804347826087, 0.055555555555556
28666, 2.2, 0.25434782608696, 0.027777777777778
28667, 2.2, 0.20217391304348, 0.47222222222222
28668, 2.2, 0.22826086956522, 0.44444444444444
28669, 2.2, 0.20217391304348, 0.41666666666667
28670, 2.2, 0.22826086956522, 0.38888888888889
28671, 2.2, 0.20217391304348, 0.36111111111111
28672, 2.2, 0.22826086956522, 0.33333333333333
28673, 2.2, 0.20217391304348, 0.30555555555556
28674, 2.2, 0.22826086956522, 0.27777777777778
28675, 2.2, 0.20217391304348, 0.25
28676, 2.2, 0.22826086956522, 0.22222222222222
28677, 2.2, 0.20217391304348, 0.19444444444444
28678, 2.2, 0.22826086956522, 0.16666666666667
28679, 2.2, 0.20217391304348, 0.13888888888889
28680, 2.2, 0.22826086956522, 0.11111111111111
28681, 2.2, 0.20217391304348, 0.083333333333333
28682, 2.2, 0.22826086956522, 0.055555555555556
28683, 2.2, 0.20217391304348, 0.027777777777778
28684, 2.2, 0.17608695652174, 0.44444444444444
28685, 2.2, 0.17608695652174, 0.38888888888889
28686, 2.2, 0.17608695652174, 0.33333333333333
28687, 2.2, 0.17608695652174, 0.27777777777778
28688, 2.2, 0.17608695652174, 0.22222222222222
28689, 2.2, 0.17608695652174, 0.16666666666667
28690, 2.2, 0.17608695652174, 0.11111111111111
28691, 2.2, 0.17608695652174, 0.055555555555556
28692, 1.2434782608696, 1.35, 0.44444444444444
28693, 1.2434782608696, 1.35, 0.38888888888889
28694, 1.2434782608696, 1.35, 0.33333333333333
28695, 1.2434782608696, 1.35, 0.27777777777778
28696, 1.2434782608696, 1.35, 0.22222222222222
28697, 1.2434782608696, 1.35, 0.16666666666667
28698, 1.2434782608696, 1.35, 0.11111111111111
28699, 1.2434782608696, 1.35, 0.055555555555556
28700, 1.2869565217391, 1.35, 0.44444444444444
28701, 1.2869565217391, 1.35, 0.38888888888889
28702, 1.2869565217391, 1.35, 0.33333333333333
28703, 1.2869565217391, 1.35, 0.27777777777778
28704, 1.2869565217391, 1.35, 0.22222222222222
28705, 1.2869565217391, 1.35, 0.16666666666667
28706, 1.2869565217391, 1.35, 0.11111111111111
28707, 1.2869565217391, 1.35, 0.055555555555556
28708, 1.3304347826087, 1.35, 0.44444444444444
28709, 1.3304347826087, 1.35, 0.38888888888889
28710, 1.3304347826087, 1.35, 0.33333333333333
28711, 1.3304347826087, 1.35, 0.27777777777778
28712, 1.3304347826087, 1.35, 0.22222222222222
28713, 1.3304347826087, 1.35, 0.16666666666667
28714, 1.3304347826087, 1.35, 0.11111111111111
28715, 1.3304347826087, 1.35, 0.055555555555556
28716, 1.3739130434783, 1.35, 0.44444444444444
28717, 1.3739130434783, 1.35, 0.38888888888889
28718, 1.3739130434783, 1.35, 0.33333333333333
28719, 1.3739130434783, 1.35, 0.27777777777778
28720, 1.3739130434783, 1.35, 0.22222222222222
28721, 1.3739130434783, 1.35, 0.16666666666667
28722, 1.3739130434783, 1.35, 0.11111111111111
28723, 1.3739130434783, 1.35, 0.055555555555556
28724, 1.4173913043478, 1.35, 0.44444444444444
28725, 1.4173913043478, 1.35, 0.38888888888889
28726, 1.4173913043478, 1.35, 0.33333333333333
28727, 1.4173913043478, 1.35, 0.27777777777778
28728, 1.4173913043478, 1.35, 0.22222222222222
28729, 1.4173913043478, 1.35, 0.16666666666667
28730, 1.4173913043478, 1.35, 0.11111111111111
28731, 1.4173913043478, 1.35, 0.055555555555556
28732, 1.4608695652174, 1.35, 0.44444444444444
28733, 1.4608695652174, 1.35, 0.38888888888889
28734, 1.4608695652174, 1.35, 0.33333333333333
28735, 1.4608695652174, 1.35, 0.27777777777778
28736, 1.4608695652174, 1.35, 0.22222222222222
28737, 1.4608695652174, 1.35, 0.16666666666667
28738, 1.4608695652174, 1.35, 0.11111111111111
28739, 1.4608695652174, 1.35, 0.055555555555556
28740, 1.504347826087, 1.35, 0.44444444444444
28741, 1.504347826087, 1.35, 0.38888888888889
28742, 1.504347826087, 1.35, 0.33333333333333
28743, 1.504347826087, 1.35, 0.27777777777778
28744, 1.504347826087, 1.35, 0.22222222222222
28745, 1.504347826087, 1.35, 0.16666666666667
28746, 1.504347826087, 1.35, 0.11111111111111
28747, 1.504347826087, 1.35, 0.055555555555556
28748, 1.5478260869565, 1.35, 0.44444444444444
28749, 1.5478260869565, 1.35, 0.38888888888889
28750, 1.5478260869565, 1.35, 0.33333333333333
28751, 1.5478260869565, 1.35, 0.27777777777778
28752, 1.5478260869565, 1.35, 0.22222222222222
28753, 1.5478260869565, 1.35, 0.16666666666667
28754, 1.5478260869565, 1.35, 0.11111111111111
28755, 1.5478260869565, 1.35, 0.055555555555556
28756, 1.5913043478261, 1.35, 0.44444444444444
28757, 1.5913043478261, 1.35, 0.38888888888889
28758, 1.5913043478261, 1.35, 0.33333333333333
28759, 1.5913043478261, 1.35, 0.27777777777778
28760, 1.5913043478261, 1.35, 0.22222222222222
28761, 1.5913043478261, 1.35, 0.16666666666667
28762, 1.5913043478261, 1.35, 0.11111111111111
28763, 1.5913043478261, 1.35, 0.055555555555556
28764, 1.6347826086957, 1.35, 0.44444444444444
28765, 1.6347826086957, 1.35, 0.38888888888889
28766, 1.6347826086957, 1.35, 0.33333333333333
28767, 1.6347826086957, 1.35, 0.27777777777778
28768, 1.6347826086957, 1.35, 0.22222222222222
28769, 1.6347826086957, 1.35, 0.16666666666667
