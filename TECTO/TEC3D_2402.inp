89121, 89119, 8942, 1149, 11163
32021, 89081, 8911, 1140, 11147, 11244, 1043, 33, 1332, 89120, 8943, 11162, 89121, 11248, 1046, 1333, 
11247, 89122, 8944, 1148, 11164
32022, 1374, 11231, 1321, 40, 11257, 89074, 11140, 1364, 11236, 11235, 1323, 1377, 89123, 89100, 11165, 
11282, 11281, 89098, 11149, 1373
32023, 11257, 89074, 11140, 1364, 11258, 89075, 11141, 1363, 89123, 89100, 11165, 11282, 89124, 89103, 11166, 
11284, 11283, 89101, 11151, 1372
32024, 11258, 89075, 11141, 1363, 11259, 89076, 11142, 1362, 89124, 89103, 11166, 11284, 89125, 89106, 11167, 
11286, 11285, 89104, 11153, 1371
32025, 11259, 89076, 11142, 1362, 11260, 89077, 11143, 1361, 89125, 89106, 11167, 11286, 89126, 89109, 11168, 
11288, 11287, 89107, 11155, 1370
32026, 11260, 89077, 11143, 1361, 11261, 89078, 11144, 1360, 89126, 89109, 11168, 11288, 89127, 89112, 11169, 
11290, 11289, 89110, 11157, 1369
32027, 11261, 89078, 11144, 1360, 11262, 89079, 11145, 1359, 89127, 89112, 11169, 11290, 89128, 89115, 11170, 
11292, 11291, 89113, 11159, 1368
32028, 11262, 89079, 11145, 1359, 11263, 89080, 11146, 1358, 89128, 89115, 11170, 11292, 89129, 89118, 11171, 
11294, 11293, 89116, 11161, 1367
32029, 11263, 89080, 11146, 1358, 11264, 89081, 11147, 1357, 89129, 89118, 11171, 11294, 89130, 89121, 11172, 
11296, 11295, 89119, 11163, 1366
32030, 11264, 89081, 11147, 1357, 1384, 11244, 1332, 42, 89130, 89121, 11172, 11296, 11249, 11247, 1334, 
1387, 11297, 89122, 11164, 1365
32031, 11232, 947, 946, 11231, 89082, 8912, 8904, 89074, 11237, 950, 11234, 11238, 89132, 8946, 89099, 
89133, 89131, 8945, 8928, 89098
32032, 89082, 8912, 8904, 89074, 89083, 8913, 8905, 89075, 89132, 8946, 89099, 89133, 89135, 8948, 89102, 
89136, 89134, 8947, 8930, 89101
32033, 89083, 8913, 8905, 89075, 89084, 8914, 8906, 89076, 89135, 8948, 89102, 89136, 89138, 8950, 89105, 
89139, 89137, 8949, 8932, 89104
32034, 89084, 8914, 8906, 89076, 89085, 8915, 8907, 89077, 89138, 8950, 89105, 89139, 89141, 8952, 89108, 
89142, 89140, 8951, 8934, 89107
32035, 89085, 8915, 8907, 89077, 89086, 8916, 8908, 89078, 89141, 8952, 89108, 89142, 89144, 8954, 89111, 
89145, 89143, 8953, 8936, 89110
32036, 89086, 8916, 8908, 89078, 89087, 8917, 8909, 89079, 89144, 8954, 89111, 89145, 89147, 8956, 89114, 
89148, 89146, 8955, 8938, 89113
32037, 89087, 8917, 8909, 89079, 89088, 8918, 8910, 89080, 89147, 8956, 89114, 89148, 89150, 8958, 89117, 
89151, 89149, 8957, 8940, 89116
32038, 89088, 8918, 8910, 89080, 89089, 8919, 8911, 89081, 89150, 8958, 89117, 89151, 89153, 8960, 89120, 
89154, 89152, 8959, 8942, 89119
32039, 89089, 8919, 8911, 89081, 11245, 1044, 1043, 11244, 89153, 8960, 89120, 89154, 11251, 1047, 11248, 
11250, 89155, 8961, 8944, 89122
32040, 1375, 11232, 11231, 1374, 11265, 89082, 89074, 11257, 11239, 11238, 11236, 1378, 89156, 89133, 89123, 
11299, 11298, 89131, 89098, 11281
32041, 11265, 89082, 89074, 11257, 11266, 89083, 89075, 11258, 89156, 89133, 89123, 11299, 89157, 89136, 89124, 
11301, 11300, 89134, 89101, 11283
32042, 11266, 89083, 89075, 11258, 11267, 89084, 89076, 11259, 89157, 89136, 89124, 11301, 89158, 89139, 89125, 
11303, 11302, 89137, 89104, 11285
32043, 11267, 89084, 89076, 11259, 11268, 89085, 89077, 11260, 89158, 89139, 89125, 11303, 89159, 89142, 89126, 
11305, 11304, 89140, 89107, 11287
32044, 11268, 89085, 89077, 11260, 11269, 89086, 89078, 11261, 89159, 89142, 89126, 11305, 89160, 89145, 89127, 
11307, 11306, 89143, 89110, 11289
32045, 11269, 89086, 89078, 11261, 11270, 89087, 89079, 11262, 89160, 89145, 89127, 11307, 89161, 89148, 89128, 
11309, 11308, 89146, 89113, 11291
32046, 11270, 89087, 89079, 11262, 11271, 89088, 89080, 11263, 89161, 89148, 89128, 11309, 89162, 89151, 89129, 
11311, 11310, 89149, 89116, 11293
32047, 11271, 89088, 89080, 11263, 11272, 89089, 89081, 11264, 89162, 89151, 89129, 11311, 89163, 89154, 89130, 
11313, 11312, 89152, 89119, 11295
32048, 11272, 89089, 89081, 11264, 1385, 11245, 11244, 1384, 89163, 89154, 89130, 11313, 11252, 11250, 11249, 
1388, 11314, 89155, 89122, 11297
32049, 11233, 948, 947, 11232, 89090, 8920, 8912, 89082, 11240, 951, 11237, 11241, 89165, 8963, 89132, 
89166, 89164, 8962, 8945, 89131
32050, 89090, 8920, 8912, 89082, 89091, 8921, 8913, 89083, 89165, 8963, 89132, 89166, 89168, 8965, 89135, 
89169, 89167, 8964, 8947, 89134
32051, 89091, 8921, 8913, 89083, 89092, 8922, 8914, 89084, 89168, 8965, 89135, 89169, 89171, 8967, 89138, 
89172, 89170, 8966, 8949, 89137
32052, 89092, 8922, 8914, 89084, 89093, 8923, 8915, 89085, 89171, 8967, 89138, 89172, 89174, 8969, 89141, 
89175, 89173, 8968, 8951, 89140
32053, 89093, 8923, 8915, 89085, 89094, 8924, 8916, 89086, 89174, 8969, 89141, 89175, 89177, 8971, 89144, 
89178, 89176, 8970, 8953, 89143
32054, 89094, 8924, 8916, 89086, 89095, 8925, 8917, 89087, 89177, 8971, 89144, 89178, 89180, 8973, 89147, 
89181, 89179, 8972, 8955, 89146
32055, 89095, 8925, 8917, 89087, 89096, 8926, 8918, 89088, 89180, 8973, 89147, 89181, 89183, 8975, 89150, 
89184, 89182, 8974, 8957, 89149
32056, 89096, 8926, 8918, 89088, 89097, 8927, 8919, 89089, 89183, 8975, 89150, 89184, 89186, 8977, 89153, 
89187, 89185, 8976, 8959, 89152
32057, 89097, 8927, 8919, 89089, 11246, 1045, 1044, 11245, 89186, 8977, 89153, 89187, 11254, 1048, 11251, 
11253, 89188, 8978, 8961, 89155
32058, 1376, 11233, 11232, 1375, 11273, 89090, 89082, 11265, 11242, 11241, 11239, 1379, 89189, 89166, 89156, 
11316, 11315, 89164, 89131, 11298
32059, 11273, 89090, 89082, 11265, 11274, 89091, 89083, 11266, 89189, 89166, 89156, 11316, 89190, 89169, 89157, 
11318, 11317, 89167, 89134, 11300
32060, 11274, 89091, 89083, 11266, 11275, 89092, 89084, 11267, 89190, 89169, 89157, 11318, 89191, 89172, 89158, 
11320, 11319, 89170, 89137, 11302
32061, 11275, 89092, 89084, 11267, 11276, 89093, 89085, 11268, 89191, 89172, 89158, 11320, 89192, 89175, 89159, 
11322, 11321, 89173, 89140, 11304
32062, 11276, 89093, 89085, 11268, 11277, 89094, 89086, 11269, 89192, 89175, 89159, 11322, 89193, 89178, 89160, 
11324, 11323, 89176, 89143, 11306
32063, 11277, 89094, 89086, 11269, 11278, 89095, 89087, 11270, 89193, 89178, 89160, 11324, 89194, 89181, 89161, 
11326, 11325, 89179, 89146, 11308
32064, 11278, 89095, 89087, 11270, 11279, 89096, 89088, 11271, 89194, 89181, 89161, 11326, 89195, 89184, 89162, 
11328, 11327, 89182, 89149, 11310
32065, 11279, 89096, 89088, 11271, 11280, 89097, 89089, 11272, 89195, 89184, 89162, 11328, 89196, 89187, 89163, 
11330, 11329, 89185, 89152, 11312
32066, 11280, 89097, 89089, 11272, 1386, 11246, 11245, 1385, 89196, 89187, 89163, 11330, 11255, 11253, 11252, 
1389, 11331, 89188, 89155, 11314
32067, 1381, 32, 948, 11233, 11340, 1164, 8920, 89090, 1382, 952, 11240, 11243, 11348, 8979, 89165, 
89197, 11349, 1173, 8962, 89164
32068, 11340, 1164, 8920, 89090, 11341, 1163, 8921, 89091, 11348, 8979, 89165, 89197, 11350, 8980, 89168, 
89198, 11351, 1172, 8964, 89167
32069, 11341, 1163, 8921, 89091, 11342, 1162, 8922, 89092, 11350, 8980, 89168, 89198, 11352, 8981, 89171, 
89199, 11353, 1171, 8966, 89170
32070, 11342, 1162, 8922, 89092, 11343, 1161, 8923, 89093, 11352, 8981, 89171, 89199, 11354, 8982, 89174, 
89200, 11355, 1170, 8968, 89173
32071, 11343, 1161, 8923, 89093, 11344, 1160, 8924, 89094, 11354, 8982, 89174, 89200, 11356, 8983, 89177, 
89201, 11357, 1169, 8970, 89176
32072, 11344, 1160, 8924, 89094, 11345, 1159, 8925, 89095, 11356, 8983, 89177, 89201, 11358, 8984, 89180, 
89202, 11359, 1168, 8972, 89179
32073, 11345, 1159, 8925, 89095, 11346, 1158, 8926, 89096, 11358, 8984, 89180, 89202, 11360, 8985, 89183, 
89203, 11361, 1167, 8974, 89182
32074, 11346, 1158, 8926, 89096, 11347, 1157, 8927, 89097, 11360, 8985, 89183, 89203, 11362, 8986, 89186, 
89204, 11363, 1166, 8976, 89185
32075, 11347, 1157, 8927, 89097, 1391, 34, 1045, 11246, 11362, 8986, 89186, 89204, 1392, 1049, 11254, 
11256, 11364, 1165, 8978, 89188
32076, 43, 1381, 11233, 1376, 1401, 11340, 89090, 11273, 1383, 11243, 11242, 1380, 11365, 89197, 89189, 
11332, 1410, 11349, 89164, 11315
32077, 1401, 11340, 89090, 11273, 1400, 11341, 89091, 11274, 11365, 89197, 89189, 11332, 11366, 89198, 89190, 
11333, 1409, 11351, 89167, 11317
32078, 1400, 11341, 89091, 11274, 1399, 11342, 89092, 11275, 11366, 89198, 89190, 11333, 11367, 89199, 89191, 
11334, 1408, 11353, 89170, 11319
32079, 1399, 11342, 89092, 11275, 1398, 11343, 89093, 11276, 11367, 89199, 89191, 11334, 11368, 89200, 89192, 
11335, 1407, 11355, 89173, 11321
32080, 1398, 11343, 89093, 11276, 1397, 11344, 89094, 11277, 11368, 89200, 89192, 11335, 11369, 89201, 89193, 
11336, 1406, 11357, 89176, 11323
32081, 1397, 11344, 89094, 11277, 1396, 11345, 89095, 11278, 11369, 89201, 89193, 11336, 11370, 89202, 89194, 
11337, 1405, 11359, 89179, 11325
32082, 1396, 11345, 89095, 11278, 1395, 11346, 89096, 11279, 11370, 89202, 89194, 11337, 11371, 89203, 89195, 
11338, 1404, 11361, 89182, 11327
32083, 1395, 11346, 89096, 11279, 1394, 11347, 89097, 11280, 11371, 89203, 89195, 11338, 11372, 89204, 89196, 
11339, 1403, 11363, 89185, 11329
32084, 1394, 11347, 89097, 11280, 44, 1391, 11246, 1386, 11372, 89204, 89196, 11339, 1393, 11256, 11255, 
1390, 1402, 11364, 89188, 11331
*ELEMENT, type=C3D20, ELSET=Volume27
32085, 21, 870, 8143, 801, 532, 8209, 89205, 7279, 873, 8153, 8152, 804, 8234, 89278, 89279, 
7304, 541, 8233, 89277, 7303
32086, 532, 8209, 89205, 7279, 531, 8210, 89206, 7280, 8234, 89278, 89279, 7304, 8236, 89281, 89282, 
7306, 540, 8235, 89280, 7305
32087, 531, 8210, 89206, 7280, 530, 8211, 89207, 7281, 8236, 89281, 89282, 7306, 8238, 89284, 89285, 
7308, 539, 8237, 89283, 7307
32088, 530, 8211, 89207, 7281, 529, 8212, 89208, 7282, 8238, 89284, 89285, 7308, 8240, 89287, 89288, 
7310, 538, 8239, 89286, 7309
32089, 529, 8212, 89208, 7282, 528, 8213, 89209, 7283, 8240, 89287, 89288, 7310, 8242, 89290, 89291, 
7312, 537, 8241, 89289, 7311
32090, 528, 8213, 89209, 7283, 527, 8214, 89210, 7284, 8242, 89290, 89291, 7312, 8244, 89293, 89294, 
7314, 536, 8243, 89292, 7313
32091, 527, 8214, 89210, 7284, 526, 8215, 89211, 7285, 8244, 89293, 89294, 7314, 8246, 89296, 89297, 
7316, 535, 8245, 89295, 7315
32092, 526, 8215, 89211, 7285, 525, 8216, 89212, 7286, 8246, 89296, 89297, 7316, 8248, 89299, 89300, 
7318, 534, 8247, 89298, 7317
32093, 525, 8216, 89212, 7286, 22, 891, 8176, 749, 8248, 89299, 89300, 7318, 894, 8185, 8186, 
752, 533, 8249, 89301, 7319
32094, 801, 8143, 8144, 802, 7279, 89205, 89213, 7287, 8152, 8155, 8154, 805, 89279, 89303, 89304, 
7321, 7303, 89277, 89302, 7320
32095, 7279, 89205, 89213, 7287, 7280, 89206, 89214, 7288, 89279, 89303, 89304, 7321, 89282, 89306, 89307, 
7323, 7305, 89280, 89305, 7322
32096, 7280, 89206, 89214, 7288, 7281, 89207, 89215, 7289, 89282, 89306, 89307, 7323, 89285, 89309, 89310, 
7325, 7307, 89283, 89308, 7324
32097, 7281, 89207, 89215, 7289, 7282, 89208, 89216, 7290, 89285, 89309, 89310, 7325, 89288, 89312, 89313, 
7327, 7309, 89286, 89311, 7326
32098, 7282, 89208, 89216, 7290, 7283, 89209, 89217, 7291, 89288, 89312, 89313, 7327, 89291, 89315, 89316, 
7329, 7311, 89289, 89314, 7328
32099, 7283, 89209, 89217, 7291, 7284, 89210, 89218, 7292, 89291, 89315, 89316, 7329, 89294, 89318, 89319, 
7331, 7313, 89292, 89317, 7330
32100, 7284, 89210, 89218, 7292, 7285, 89211, 89219, 7293, 89294, 89318, 89319, 7331, 89297, 89321, 89322, 
7333, 7315, 89295, 89320, 7332
32101, 7285, 89211, 89219, 7293, 7286, 89212, 89220, 7294, 89297, 89321, 89322, 7333, 89300, 89324, 89325, 
7335, 7317, 89298, 89323, 7334
32102, 7286, 89212, 89220, 7294, 749, 8176, 8177, 750, 89300, 89324, 89325, 7335, 8186, 8187, 8188, 
753, 7319, 89301, 89326, 7336
32103, 802, 8144, 8145, 803, 7287, 89213, 89221, 7295, 8154, 8157, 8156, 806, 89304, 89328, 89329, 
7338, 7320, 89302, 89327, 7337
32104, 7287, 89213, 89221, 7295, 7288, 89214, 89222, 7296, 89304, 89328, 89329, 7338, 89307, 89331, 89332, 
7340, 7322, 89305, 89330, 7339
32105, 7288, 89214, 89222, 7296, 7289, 89215, 89223, 7297, 89307, 89331, 89332, 7340, 89310, 89334, 89335, 
7342, 7324, 89308, 89333, 7341
32106, 7289, 89215, 89223, 7297, 7290, 89216, 89224, 7298, 89310, 89334, 89335, 7342, 89313, 89337, 89338, 
7344, 7326, 89311, 89336, 7343
32107, 7290, 89216, 89224, 7298, 7291, 89217, 89225, 7299, 89313, 89337, 89338, 7344, 89316, 89340, 89341, 
7346, 7328, 89314, 89339, 7345
32108, 7291, 89217, 89225, 7299, 7292, 89218, 89226, 7300, 89316, 89340, 89341, 7346, 89319, 89343, 89344, 
7348, 7330, 89317, 89342, 7347
32109, 7292, 89218, 89226, 7300, 7293, 89219, 89227, 7301, 89319, 89343, 89344, 7348, 89322, 89346, 89347, 
7350, 7332, 89320, 89345, 7349
32110, 7293, 89219, 89227, 7301, 7294, 89220, 89228, 7302, 89322, 89346, 89347, 7350, 89325, 89349, 89350, 
7352, 7334, 89323, 89348, 7351
32111, 7294, 89220, 89228, 7302, 750, 8177, 8178, 751, 89325, 89349, 89350, 7352, 8188, 8189, 8190, 
754, 7336, 89326, 89351, 7353
32112, 803, 8145, 877, 26, 7295, 89221, 8292, 815, 8156, 8158, 880, 807, 89329, 89352, 8316, 
7354, 7337, 89327, 8317, 824
32113, 7295, 89221, 8292, 815, 7296, 89222, 8293, 814, 89329, 89352, 8316, 7354, 89332, 89353, 8318, 
7355, 7339, 89330, 8319, 823
32114, 7296, 89222, 8293, 814, 7297, 89223, 8294, 813, 89332, 89353, 8318, 7355, 89335, 89354, 8320, 
7356, 7341, 89333, 8321, 822
32115, 7297, 89223, 8294, 813, 7298, 89224, 8295, 812, 89335, 89354, 8320, 7356, 89338, 89355, 8322, 
7357, 7343, 89336, 8323, 821
32116, 7298, 89224, 8295, 812, 7299, 89225, 8296, 811, 89338, 89355, 8322, 7357, 89341, 89356, 8324, 
7358, 7345, 89339, 8325, 820
32117, 7299, 89225, 8296, 811, 7300, 89226, 8297, 810, 89341, 89356, 8324, 7358, 89344, 89357, 8326, 
7359, 7347, 89342, 8327, 819
32118, 7300, 89226, 8297, 810, 7301, 89227, 8298, 809, 89344, 89357, 8326, 7359, 89347, 89358, 8328, 
7360, 7349, 89345, 8329, 818
32119, 7301, 89227, 8298, 809, 7302, 89228, 8299, 808, 89347, 89358, 8328, 7360, 89350, 89359, 8330, 
7361, 7351, 89348, 8331, 817
32120, 7302, 89228, 8299, 808, 751, 8178, 898, 25, 89350, 89359, 8330, 7361, 8190, 8191, 901, 
755, 7353, 89351, 8332, 816
32121, 870, 871, 8146, 8143, 8209, 8217, 89229, 89205, 874, 8160, 8159, 8153, 8251, 89361, 89362, 
89278, 8233, 8250, 89360, 89277
32122, 8209, 8217, 89229, 89205, 8210, 8218, 89230, 89206, 8251, 89361, 89362, 89278, 8253, 89364, 89365, 
89281, 8235, 8252, 89363, 89280
32123, 8210, 8218, 89230, 89206, 8211, 8219, 89231, 89207, 8253, 89364, 89365, 89281, 8255, 89367, 89368, 
89284, 8237, 8254, 89366, 89283
32124, 8211, 8219, 89231, 89207, 8212, 8220, 89232, 89208, 8255, 89367, 89368, 89284, 8257, 89370, 89371, 
89287, 8239, 8256, 89369, 89286
32125, 8212, 8220, 89232, 89208, 8213, 8221, 89233, 89209, 8257, 89370, 89371, 89287, 8259, 89373, 89374, 
89290, 8241, 8258, 89372, 89289
32126, 8213, 8221, 89233, 89209, 8214, 8222, 89234, 89210, 8259, 89373, 89374, 89290, 8261, 89376, 89377, 
89293, 8243, 8260, 89375, 89292
32127, 8214, 8222, 89234, 89210, 8215, 8223, 89235, 89211, 8261, 89376, 89377, 89293, 8263, 89379, 89380, 
89296, 8245, 8262, 89378, 89295
32128, 8215, 8223, 89235, 89211, 8216, 8224, 89236, 89212, 8263, 89379, 89380, 89296, 8265, 89382, 89383, 
89299, 8247, 8264, 89381, 89298
32129, 8216, 8224, 89236, 89212, 891, 892, 8179, 8176, 8265, 89382, 89383, 89299, 895, 8192, 8193, 
8185, 8249, 8266, 89384, 89301
32130, 8143, 8146, 8147, 8144, 89205, 89229, 89237, 89213, 8159, 8162, 8161, 8155, 89362, 89386, 89387, 
89303, 89277, 89360, 89385, 89302
32131, 89205, 89229, 89237, 89213, 89206, 89230, 89238, 89214, 89362, 89386, 89387, 89303, 89365, 89389, 89390, 
89306, 89280, 89363, 89388, 89305
32132, 89206, 89230, 89238, 89214, 89207, 89231, 89239, 89215, 89365, 89389, 89390, 89306, 89368, 89392, 89393, 
89309, 89283, 89366, 89391, 89308
32133, 89207, 89231, 89239, 89215, 89208, 89232, 89240, 89216, 89368, 89392, 89393, 89309, 89371, 89395, 89396, 
89312, 89286, 89369, 89394, 89311
32134, 89208, 89232, 89240, 89216, 89209, 89233, 89241, 89217, 89371, 89395, 89396, 89312, 89374, 89398, 89399, 
89315, 89289, 89372, 89397, 89314
32135, 89209, 89233, 89241, 89217, 89210, 89234, 89242, 89218, 89374, 89398, 89399, 89315, 89377, 89401, 89402, 
89318, 89292, 89375, 89400, 89317
32136, 89210, 89234, 89242, 89218, 89211, 89235, 89243, 89219, 89377, 89401, 89402, 89318, 89380, 89404, 89405, 
89321, 89295, 89378, 89403, 89320
32137, 89211, 89235, 89243, 89219, 89212, 89236, 89244, 89220, 89380, 89404, 89405, 89321, 89383, 89407, 89408, 
89324, 89298, 89381, 89406, 89323
32138, 89212, 89236, 89244, 89220, 8176, 8179, 8180, 8177, 89383, 89407, 89408, 89324, 8193, 8194, 8195, 
8187, 89301, 89384, 89409, 89326
32139, 8144, 8147, 8148, 8145, 89213, 89237, 89245, 89221, 8161, 8164, 8163, 8157, 89387, 89411, 89412, 
89328, 89302, 89385, 89410, 89327
32140, 89213, 89237, 89245, 89221, 89214, 89238, 89246, 89222, 89387, 89411, 89412, 89328, 89390, 89414, 89415, 
89331, 89305, 89388, 89413, 89330
32141, 89214, 89238, 89246, 89222, 89215, 89239, 89247, 89223, 89390, 89414, 89415, 89331, 89393, 89417, 89418, 
89334, 89308, 89391, 89416, 89333
32142, 89215, 89239, 89247, 89223, 89216, 89240, 89248, 89224, 89393, 89417, 89418, 89334, 89396, 89420, 89421, 
89337, 89311, 89394, 89419, 89336
32143, 89216, 89240, 89248, 89224, 89217, 89241, 89249, 89225, 89396, 89420, 89421, 89337, 89399, 89423, 89424, 
89340, 89314, 89397, 89422, 89339
32144, 89217, 89241, 89249, 89225, 89218, 89242, 89250, 89226, 89399, 89423, 89424, 89340, 89402, 89426, 89427, 
89343, 89317, 89400, 89425, 89342
32145, 89218, 89242, 89250, 89226, 89219, 89243, 89251, 89227, 89402, 89426, 89427, 89343, 89405, 89429, 89430, 
89346, 89320, 89403, 89428, 89345
32146, 89219, 89243, 89251, 89227, 89220, 89244, 89252, 89228, 89405, 89429, 89430, 89346, 89408, 89432, 89433, 
89349, 89323, 89406, 89431, 89348
32147, 89220, 89244, 89252, 89228, 8177, 8180, 8181, 8178, 89408, 89432, 89433, 89349, 8195, 8196, 8197, 
8189, 89326, 89409, 89434, 89351
32148, 8145, 8148, 878, 877, 89221, 89245, 8300, 8292, 8163, 8165, 881, 8158, 89412, 89435, 8333, 
89352, 89327, 89410, 8334, 8317
32149, 89221, 89245, 8300, 8292, 89222, 89246, 8301, 8293, 89412, 89435, 8333, 89352, 89415, 89436, 8335, 
89353, 89330, 89413, 8336, 8319
32150, 89222, 89246, 8301, 8293, 89223, 89247, 8302, 8294, 89415, 89436, 8335, 89353, 89418, 89437, 8337, 
89354, 89333, 89416, 8338, 8321
32151, 89223, 89247, 8302, 8294, 89224, 89248, 8303, 8295, 89418, 89437, 8337, 89354, 89421, 89438, 8339, 
89355, 89336, 89419, 8340, 8323
32152, 89224, 89248, 8303, 8295, 89225, 89249, 8304, 8296, 89421, 89438, 8339, 89355, 89424, 89439, 8341, 
89356, 89339, 89422, 8342, 8325
32153, 89225, 89249, 8304, 8296, 89226, 89250, 8305, 8297, 89424, 89439, 8341, 89356, 89427, 89440, 8343, 
89357, 89342, 89425, 8344, 8327
32154, 89226, 89250, 8305, 8297, 89227, 89251, 8306, 8298, 89427, 89440, 8343, 89357, 89430, 89441, 8345, 
89358, 89345, 89428, 8346, 8329
32155, 89227, 89251, 8306, 8298, 89228, 89252, 8307, 8299, 89430, 89441, 8345, 89358, 89433, 89442, 8347, 
89359, 89348, 89431, 8348, 8331
32156, 89228, 89252, 8307, 8299, 8178, 8181, 899, 898, 89433, 89442, 8347, 89359, 8197, 8198, 902, 
8191, 89351, 89434, 8349, 8332
32157, 871, 872, 8149, 8146, 8217, 8225, 89253, 89229, 875, 8167, 8166, 8160, 8268, 89444, 89445, 
89361, 8250, 8267, 89443, 89360
32158, 8217, 8225, 89253, 89229, 8218, 8226, 89254, 89230, 8268, 89444, 89445, 89361, 8270, 89447, 89448, 
89364, 8252, 8269, 89446, 89363
32159, 8218, 8226, 89254, 89230, 8219, 8227, 89255, 89231, 8270, 89447, 89448, 89364, 8272, 89450, 89451, 
89367, 8254, 8271, 89449, 89366
32160, 8219, 8227, 89255, 89231, 8220, 8228, 89256, 89232, 8272, 89450, 89451, 89367, 8274, 89453, 89454, 
89370, 8256, 8273, 89452, 89369
32161, 8220, 8228, 89256, 89232, 8221, 8229, 89257, 89233, 8274, 89453, 89454, 89370, 8276, 89456, 89457, 
89373, 8258, 8275, 89455, 89372
32162, 8221, 8229, 89257, 89233, 8222, 8230, 89258, 89234, 8276, 89456, 89457, 89373, 8278, 89459, 89460, 
89376, 8260, 8277, 89458, 89375
32163, 8222, 8230, 89258, 89234, 8223, 8231, 89259, 89235, 8278, 89459, 89460, 89376, 8280, 89462, 89463, 
89379, 8262, 8279, 89461, 89378
32164, 8223, 8231, 89259, 89235, 8224, 8232, 89260, 89236, 8280, 89462, 89463, 89379, 8282, 89465, 89466, 
89382, 8264, 8281, 89464, 89381
32165, 8224, 8232, 89260, 89236, 892, 893, 8182, 8179, 8282, 89465, 89466, 89382, 896, 8199, 8200, 
8192, 8266, 8283, 89467, 89384
32166, 8146, 8149, 8150, 8147, 89229, 89253, 89261, 89237, 8166, 8169, 8168, 8162, 89445, 89469, 89470, 
89386, 89360, 89443, 89468, 89385
32167, 89229, 89253, 89261, 89237, 89230, 89254, 89262, 89238, 89445, 89469, 89470, 89386, 89448, 89472, 89473, 
89389, 89363, 89446, 89471, 89388
32168, 89230, 89254, 89262, 89238, 89231, 89255, 89263, 89239, 89448, 89472, 89473, 89389, 89451, 89475, 89476, 
89392, 89366, 89449, 89474, 89391
32169, 89231, 89255, 89263, 89239, 89232, 89256, 89264, 89240, 89451, 89475, 89476, 89392, 89454, 89478, 89479, 
89395, 89369, 89452, 89477, 89394
32170, 89232, 89256, 89264, 89240, 89233, 89257, 89265, 89241, 89454, 89478, 89479, 89395, 89457, 89481, 89482, 
89398, 89372, 89455, 89480, 89397
32171, 89233, 89257, 89265, 89241, 89234, 89258, 89266, 89242, 89457, 89481, 89482, 89398, 89460, 89484, 89485, 
89401, 89375, 89458, 89483, 89400
32172, 89234, 89258, 89266, 89242, 89235, 89259, 89267, 89243, 89460, 89484, 89485, 89401, 89463, 89487, 89488, 
89404, 89378, 89461, 89486, 89403
32173, 89235, 89259, 89267, 89243, 89236, 89260, 89268, 89244, 89463, 89487, 89488, 89404, 89466, 89490, 89491, 
89407, 89381, 89464, 89489, 89406
32174, 89236, 89260, 89268, 89244, 8179, 8182, 8183, 8180, 89466, 89490, 89491, 89407, 8200, 8201, 8202, 
8194, 89384, 89467, 89492, 89409
32175, 8147, 8150, 8151, 8148, 89237, 89261, 89269, 89245, 8168, 8171, 8170, 8164, 89470, 89494, 89495, 
89411, 89385, 89468, 89493, 89410
32176, 89237, 89261, 89269, 89245, 89238, 89262, 89270, 89246, 89470, 89494, 89495, 89411, 89473, 89497, 89498, 
89414, 89388, 89471, 89496, 89413
32177, 89238, 89262, 89270, 89246, 89239, 89263, 89271, 89247, 89473, 89497, 89498, 89414, 89476, 89500, 89501, 
89417, 89391, 89474, 89499, 89416
32178, 89239, 89263, 89271, 89247, 89240, 89264, 89272, 89248, 89476, 89500, 89501, 89417, 89479, 89503, 89504, 
89420, 89394, 89477, 89502, 89419
32179, 89240, 89264, 89272, 89248, 89241, 89265, 89273, 89249, 89479, 89503, 89504, 89420, 89482, 89506, 89507, 
89423, 89397, 89480, 89505, 89422
32180, 89241, 89265, 89273, 89249, 89242, 89266, 89274, 89250, 89482, 89506, 89507, 89423, 89485, 89509, 89510, 
89426, 89400, 89483, 89508, 89425
32181, 89242, 89266, 89274, 89250, 89243, 89267, 89275, 89251, 89485, 89509, 89510, 89426, 89488, 89512, 89513, 
89429, 89403, 89486, 89511, 89428
32182, 89243, 89267, 89275, 89251, 89244, 89268, 89276, 89252, 89488, 89512, 89513, 89429, 89491, 89515, 89516, 
89432, 89406, 89489, 89514, 89431
32183, 89244, 89268, 89276, 89252, 8180, 8183, 8184, 8181, 89491, 89515, 89516, 89432, 8202, 8203, 8204, 
8196, 89409, 89492, 89517, 89434
32184, 8148, 8151, 879, 878, 89245, 89269, 8308, 8300, 8170, 8172, 882, 8165, 89495, 89518, 8350, 
89435, 89410, 89493, 8351, 8334
32185, 89245, 89269, 8308, 8300, 89246, 89270, 8309, 8301, 89495, 89518, 8350, 89435, 89498, 89519, 8352, 
89436, 89413, 89496, 8353, 8336
32186, 89246, 89270, 8309, 8301, 89247, 89271, 8310, 8302, 89498, 89519, 8352, 89436, 89501, 89520, 8354, 
89437, 89416, 89499, 8355, 8338
32187, 89247, 89271, 8310, 8302, 89248, 89272, 8311, 8303, 89501, 89520, 8354, 89437, 89504, 89521, 8356, 
89438, 89419, 89502, 8357, 8340
32188, 89248, 89272, 8311, 8303, 89249, 89273, 8312, 8304, 89504, 89521, 8356, 89438, 89507, 89522, 8358, 
89439, 89422, 89505, 8359, 8342
32189, 89249, 89273, 8312, 8304, 89250, 89274, 8313, 8305, 89507, 89522, 8358, 89439, 89510, 89523, 8360, 
89440, 89425, 89508, 8361, 8344
32190, 89250, 89274, 8313, 8305, 89251, 89275, 8314, 8306, 89510, 89523, 8360, 89440, 89513, 89524, 8362, 
89441, 89428, 89511, 8363, 8346
32191, 89251, 89275, 8314, 8306, 89252, 89276, 8315, 8307, 89513, 89524, 8362, 89441, 89516, 89525, 8364, 
89442, 89431, 89514, 8365, 8348
32192, 89252, 89276, 8315, 8307, 8181, 8184, 900, 899, 89516, 89525, 8364, 89442, 8204, 8205, 903, 
8198, 89434, 89517, 8366, 8349
32193, 872, 27, 884, 8149, 8225, 919, 8375, 89253, 876, 887, 8173, 8167, 8284, 8400, 89526, 
89444, 8267, 928, 8399, 89443
32194, 8225, 919, 8375, 89253, 8226, 918, 8376, 89254, 8284, 8400, 89526, 89444, 8285, 8402, 89527, 
89447, 8269, 927, 8401, 89446
32195, 8226, 918, 8376, 89254, 8227, 917, 8377, 89255, 8285, 8402, 89527, 89447, 8286, 8404, 89528, 
89450, 8271, 926, 8403, 89449
32196, 8227, 917, 8377, 89255, 8228, 916, 8378, 89256, 8286, 8404, 89528, 89450, 8287, 8406, 89529, 
89453, 8273, 925, 8405, 89452
32197, 8228, 916, 8378, 89256, 8229, 915, 8379, 89257, 8287, 8406, 89529, 89453, 8288, 8408, 89530, 
89456, 8275, 924, 8407, 89455
32198, 8229, 915, 8379, 89257, 8230, 914, 8380, 89258, 8288, 8408, 89530, 89456, 8289, 8410, 89531, 
89459, 8277, 923, 8409, 89458
32199, 8230, 914, 8380, 89258, 8231, 913, 8381, 89259, 8289, 8410, 89531, 89459, 8290, 8412, 89532, 
89462, 8279, 922, 8411, 89461
32200, 8231, 913, 8381, 89259, 8232, 912, 8382, 89260, 8290, 8412, 89532, 89462, 8291, 8414, 89533, 
89465, 8281, 921, 8413, 89464
32201, 8232, 912, 8382, 89260, 893, 29, 905, 8182, 8291, 8414, 89533, 89465, 897, 908, 8206, 
8199, 8283, 920, 8415, 89467
32202, 8149, 884, 885, 8150, 89253, 8375, 8383, 89261, 8173, 888, 8174, 8169, 89526, 8417, 89534, 
89469, 89443, 8399, 8416, 89468
32203, 89253, 8375, 8383, 89261, 89254, 8376, 8384, 89262, 89526, 8417, 89534, 89469, 89527, 8419, 89535, 
89472, 89446, 8401, 8418, 89471
32204, 89254, 8376, 8384, 89262, 89255, 8377, 8385, 89263, 89527, 8419, 89535, 89472, 89528, 8421, 89536, 
89475, 89449, 8403, 8420, 89474
32205, 89255, 8377, 8385, 89263, 89256, 8378, 8386, 89264, 89528, 8421, 89536, 89475, 89529, 8423, 89537, 
89478, 89452, 8405, 8422, 89477
32206, 89256, 8378, 8386, 89264, 89257, 8379, 8387, 89265, 89529, 8423, 89537, 89478, 89530, 8425, 89538, 
89481, 89455, 8407, 8424, 89480
32207, 89257, 8379, 8387, 89265, 89258, 8380, 8388, 89266, 89530, 8425, 89538, 89481, 89531, 8427, 89539, 
89484, 89458, 8409, 8426, 89483
32208, 89258, 8380, 8388, 89266, 89259, 8381, 8389, 89267, 89531, 8427, 89539, 89484, 89532, 8429, 89540, 
89487, 89461, 8411, 8428, 89486
32209, 89259, 8381, 8389, 89267, 89260, 8382, 8390, 89268, 89532, 8429, 89540, 89487, 89533, 8431, 89541, 
89490, 89464, 8413, 8430, 89489
32210, 89260, 8382, 8390, 89268, 8182, 905, 906, 8183, 89533, 8431, 89541, 89490, 8206, 909, 8207, 
8201, 89467, 8415, 8432, 89492
32211, 8150, 885, 886, 8151, 89261, 8383, 8391, 89269, 8174, 889, 8175, 8171, 89534, 8434, 89542, 
89494, 89468, 8416, 8433, 89493
32212, 89261, 8383, 8391, 89269, 89262, 8384, 8392, 89270, 89534, 8434, 89542, 89494, 89535, 8436, 89543, 
89497, 89471, 8418, 8435, 89496
32213, 89262, 8384, 8392, 89270, 89263, 8385, 8393, 89271, 89535, 8436, 89543, 89497, 89536, 8438, 89544, 
89500, 89474, 8420, 8437, 89499
32214, 89263, 8385, 8393, 89271, 89264, 8386, 8394, 89272, 89536, 8438, 89544, 89500, 89537, 8440, 89545, 
89503, 89477, 8422, 8439, 89502
32215, 89264, 8386, 8394, 89272, 89265, 8387, 8395, 89273, 89537, 8440, 89545, 89503, 89538, 8442, 89546, 
89506, 89480, 8424, 8441, 89505
32216, 89265, 8387, 8395, 89273, 89266, 8388, 8396, 89274, 89538, 8442, 89546, 89506, 89539, 8444, 89547, 
89509, 89483, 8426, 8443, 89508
32217, 89266, 8388, 8396, 89274, 89267, 8389, 8397, 89275, 89539, 8444, 89547, 89509, 89540, 8446, 89548, 
89512, 89486, 8428, 8445, 89511
32218, 89267, 8389, 8397, 89275, 89268, 8390, 8398, 89276, 89540, 8446, 89548, 89512, 89541, 8448, 89549, 
89515, 89489, 8430, 8447, 89514
32219, 89268, 8390, 8398, 89276, 8183, 906, 907, 8184, 89541, 8448, 89549, 89515, 8207, 910, 8208, 
8203, 89492, 8432, 8449, 89517
32220, 8151, 886, 28, 879, 89269, 8391, 936, 8308, 8175, 890, 883, 8172, 89542, 8450, 8367, 
89518, 89493, 8433, 945, 8351
32221, 89269, 8391, 936, 8308, 89270, 8392, 935, 8309, 89542, 8450, 8367, 89518, 89543, 8451, 8368, 
89519, 89496, 8435, 944, 8353
32222, 89270, 8392, 935, 8309, 89271, 8393, 934, 8310, 89543, 8451, 8368, 89519, 89544, 8452, 8369, 
89520, 89499, 8437, 943, 8355
32223, 89271, 8393, 934, 8310, 89272, 8394, 933, 8311, 89544, 8452, 8369, 89520, 89545, 8453, 8370, 
89521, 89502, 8439, 942, 8357
32224, 89272, 8394, 933, 8311, 89273, 8395, 932, 8312, 89545, 8453, 8370, 89521, 89546, 8454, 8371, 
89522, 89505, 8441, 941, 8359
32225, 89273, 8395, 932, 8312, 89274, 8396, 931, 8313, 89546, 8454, 8371, 89522, 89547, 8455, 8372, 
89523, 89508, 8443, 940, 8361
32226, 89274, 8396, 931, 8313, 89275, 8397, 930, 8314, 89547, 8455, 8372, 89523, 89548, 8456, 8373, 
89524, 89511, 8445, 939, 8363
32227, 89275, 8397, 930, 8314, 89276, 8398, 929, 8315, 89548, 8456, 8373, 89524, 89549, 8457, 8374, 
89525, 89514, 8447, 938, 8365
32228, 89276, 8398, 929, 8315, 8184, 907, 30, 900, 89549, 8457, 8374, 89525, 8208, 911, 904, 
8205, 89517, 8449, 937, 8366
*ELEMENT, type=C3D20, ELSET=Volume28
32229, 52, 1948, 14589, 1879, 1669, 14615, 89550, 13948, 1949, 14593, 14592, 1882, 14624, 89575, 89576, 
13973, 1678, 14623, 89574, 13972
32230, 1669, 14615, 89550, 13948, 1668, 14616, 89551, 13949, 14624, 89575, 89576, 13973, 14626, 89578, 89579, 
13975, 1677, 14625, 89577, 13974
32231, 1668, 14616, 89551, 13949, 1667, 14617, 89552, 13950, 14626, 89578, 89579, 13975, 14628, 89581, 89582, 
13977, 1676, 14627, 89580, 13976
32232, 1667, 14617, 89552, 13950, 1666, 14618, 89553, 13951, 14628, 89581, 89582, 13977, 14630, 89584, 89585, 
13979, 1675, 14629, 89583, 13978
32233, 1666, 14618, 89553, 13951, 1665, 14619, 89554, 13952, 14630, 89584, 89585, 13979, 14632, 89587, 89588, 
13981, 1674, 14631, 89586, 13980
32234, 1665, 14619, 89554, 13952, 1664, 14620, 89555, 13953, 14632, 89587, 89588, 13981, 14634, 89590, 89591, 
13983, 1673, 14633, 89589, 13982
32235, 1664, 14620, 89555, 13953, 1663, 14621, 89556, 13954, 14634, 89590, 89591, 13983, 14636, 89593, 89594, 
13985, 1672, 14635, 89592, 13984
32236, 1663, 14621, 89556, 13954, 1662, 14622, 89557, 13955, 14636, 89593, 89594, 13985, 14638, 89596, 89597, 
13987, 1671, 14637, 89595, 13986
32237, 1662, 14622, 89557, 13955, 48, 1961, 14602, 1827, 14638, 89596, 89597, 13987, 1962, 14605, 14606, 
1830, 1670, 14639, 89598, 13988
32238, 1879, 14589, 14590, 1880, 13948, 89550, 89558, 13956, 14592, 14595, 14594, 1883, 89576, 89600, 89601, 
13990, 13972, 89574, 89599, 13989
32239, 13948, 89550, 89558, 13956, 13949, 89551, 89559, 13957, 89576, 89600, 89601, 13990, 89579, 89603, 89604, 
13992, 13974, 89577, 89602, 13991
32240, 13949, 89551, 89559, 13957, 13950, 89552, 89560, 13958, 89579, 89603, 89604, 13992, 89582, 89606, 89607, 
13994, 13976, 89580, 89605, 13993
32241, 13950, 89552, 89560, 13958, 13951, 89553, 89561, 13959, 89582, 89606, 89607, 13994, 89585, 89609, 89610, 
13996, 13978, 89583, 89608, 13995
32242, 13951, 89553, 89561, 13959, 13952, 89554, 89562, 13960, 89585, 89609, 89610, 13996, 89588, 89612, 89613, 
13998, 13980, 89586, 89611, 13997
32243, 13952, 89554, 89562, 13960, 13953, 89555, 89563, 13961, 89588, 89612, 89613, 13998, 89591, 89615, 89616, 
14000, 13982, 89589, 89614, 13999
32244, 13953, 89555, 89563, 13961, 13954, 89556, 89564, 13962, 89591, 89615, 89616, 14000, 89594, 89618, 89619, 
14002, 13984, 89592, 89617, 14001
32245, 13954, 89556, 89564, 13962, 13955, 89557, 89565, 13963, 89594, 89618, 89619, 14002, 89597, 89621, 89622, 
14004, 13986, 89595, 89620, 14003
32246, 13955, 89557, 89565, 13963, 1827, 14602, 14603, 1828, 89597, 89621, 89622, 14004, 14606, 14607, 14608, 
1831, 13988, 89598, 89623, 14005
32247, 1880, 14590, 14591, 1881, 13956, 89558, 89566, 13964, 14594, 14597, 14596, 1884, 89601, 89625, 89626, 
14007, 13989, 89599, 89624, 14006
32248, 13956, 89558, 89566, 13964, 13957, 89559, 89567, 13965, 89601, 89625, 89626, 14007, 89604, 89628, 89629, 
14009, 13991, 89602, 89627, 14008
32249, 13957, 89559, 89567, 13965, 13958, 89560, 89568, 13966, 89604, 89628, 89629, 14009, 89607, 89631, 89632, 
14011, 13993, 89605, 89630, 14010
32250, 13958, 89560, 89568, 13966, 13959, 89561, 89569, 13967, 89607, 89631, 89632, 14011, 89610, 89634, 89635, 
14013, 13995, 89608, 89633, 14012
32251, 13959, 89561, 89569, 13967, 13960, 89562, 89570, 13968, 89610, 89634, 89635, 14013, 89613, 89637, 89638, 
14015, 13997, 89611, 89636, 14014
32252, 13960, 89562, 89570, 13968, 13961, 89563, 89571, 13969, 89613, 89637, 89638, 14015, 89616, 89640, 89641, 
14017, 13999, 89614, 89639, 14016
32253, 13961, 89563, 89571, 13969, 13962, 89564, 89572, 13970, 89616, 89640, 89641, 14017, 89619, 89643, 89644, 
14019, 14001, 89617, 89642, 14018
32254, 13962, 89564, 89572, 13970, 13963, 89565, 89573, 13971, 89619, 89643, 89644, 14019, 89622, 89646, 89647, 
14021, 14003, 89620, 89645, 14020
32255, 13963, 89565, 89573, 13971, 1828, 14603, 14604, 1829, 89622, 89646, 89647, 14021, 14608, 14609, 14610, 
1832, 14005, 89623, 89648, 14022
32256, 1881, 14591, 1951, 62, 13964, 89566, 14648, 1938, 14596, 14598, 1952, 1885, 89626, 89649, 14656, 
14023, 14006, 89624, 14657, 1947
32257, 13964, 89566, 14648, 1938, 13965, 89567, 14649, 1937, 89626, 89649, 14656, 14023, 89629, 89650, 14658, 
14024, 14008, 89627, 14659, 1946
32258, 13965, 89567, 14649, 1937, 13966, 89568, 14650, 1936, 89629, 89650, 14658, 14024, 89632, 89651, 14660, 
14025, 14010, 89630, 14661, 1945
32259, 13966, 89568, 14650, 1936, 13967, 89569, 14651, 1935, 89632, 89651, 14660, 14025, 89635, 89652, 14662, 
14026, 14012, 89633, 14663, 1944
32260, 13967, 89569, 14651, 1935, 13968, 89570, 14652, 1934, 89635, 89652, 14662, 14026, 89638, 89653, 14664, 
14027, 14014, 89636, 14665, 1943
32261, 13968, 89570, 14652, 1934, 13969, 89571, 14653, 1933, 89638, 89653, 14664, 14027, 89641, 89654, 14666, 
14028, 14016, 89639, 14667, 1942
32262, 13969, 89571, 14653, 1933, 13970, 89572, 14654, 1932, 89641, 89654, 14666, 14028, 89644, 89655, 14668, 
14029, 14018, 89642, 14669, 1941
32263, 13970, 89572, 14654, 1932, 13971, 89573, 14655, 1931, 89644, 89655, 14668, 14029, 89647, 89656, 14670, 
14030, 14020, 89645, 14671, 1940
32264, 13971, 89573, 14655, 1931, 1829, 14604, 1964, 61, 89647, 89656, 14670, 14030, 14610, 14611, 1965, 
1833, 14022, 89648, 14672, 1939
32265, 1948, 63, 1954, 14589, 14615, 1981, 14681, 89550, 1950, 1957, 14599, 14593, 14640, 14706, 89657, 
89575, 14623, 1990, 14705, 89574
32266, 14615, 1981, 14681, 89550, 14616, 1980, 14682, 89551, 14640, 14706, 89657, 89575, 14641, 14708, 89658, 
89578, 14625, 1989, 14707, 89577
32267, 14616, 1980, 14682, 89551, 14617, 1979, 14683, 89552, 14641, 14708, 89658, 89578, 14642, 14710, 89659, 
89581, 14627, 1988, 14709, 89580
32268, 14617, 1979, 14683, 89552, 14618, 1978, 14684, 89553, 14642, 14710, 89659, 89581, 14643, 14712, 89660, 
89584, 14629, 1987, 14711, 89583
32269, 14618, 1978, 14684, 89553, 14619, 1977, 14685, 89554, 14643, 14712, 89660, 89584, 14644, 14714, 89661, 
89587, 14631, 1986, 14713, 89586
32270, 14619, 1977, 14685, 89554, 14620, 1976, 14686, 89555, 14644, 14714, 89661, 89587, 14645, 14716, 89662, 
89590, 14633, 1985, 14715, 89589
32271, 14620, 1976, 14686, 89555, 14621, 1975, 14687, 89556, 14645, 14716, 89662, 89590, 14646, 14718, 89663, 
89593, 14635, 1984, 14717, 89592
32272, 14621, 1975, 14687, 89556, 14622, 1974, 14688, 89557, 14646, 14718, 89663, 89593, 14647, 14720, 89664, 
89596, 14637, 1983, 14719, 89595
32273, 14622, 1974, 14688, 89557, 1961, 65, 1967, 14602, 14647, 14720, 89664, 89596, 1963, 1970, 14612, 
14605, 14639, 1982, 14721, 89598
32274, 14589, 1954, 1955, 14590, 89550, 14681, 14689, 89558, 14599, 1958, 14600, 14595, 89657, 14723, 89665, 
89600, 89574, 14705, 14722, 89599
32275, 89550, 14681, 14689, 89558, 89551, 14682, 14690, 89559, 89657, 14723, 89665, 89600, 89658, 14725, 89666, 
89603, 89577, 14707, 14724, 89602
32276, 89551, 14682, 14690, 89559, 89552, 14683, 14691, 89560, 89658, 14725, 89666, 89603, 89659, 14727, 89667, 
89606, 89580, 14709, 14726, 89605
32277, 89552, 14683, 14691, 89560, 89553, 14684, 14692, 89561, 89659, 14727, 89667, 89606, 89660, 14729, 89668, 
89609, 89583, 14711, 14728, 89608
32278, 89553, 14684, 14692, 89561, 89554, 14685, 14693, 89562, 89660, 14729, 89668, 89609, 89661, 14731, 89669, 
89612, 89586, 14713, 14730, 89611
32279, 89554, 14685, 14693, 89562, 89555, 14686, 14694, 89563, 89661, 14731, 89669, 89612, 89662, 14733, 89670, 
89615, 89589, 14715, 14732, 89614
32280, 89555, 14686, 14694, 89563, 89556, 14687, 14695, 89564, 89662, 14733, 89670, 89615, 89663, 14735, 89671, 
89618, 89592, 14717, 14734, 89617
32281, 89556, 14687, 14695, 89564, 89557, 14688, 14696, 89565, 89663, 14735, 89671, 89618, 89664, 14737, 89672, 
89621, 89595, 14719, 14736, 89620
32282, 89557, 14688, 14696, 89565, 14602, 1967, 1968, 14603, 89664, 14737, 89672, 89621, 14612, 1971, 14613, 
14607, 89598, 14721, 14738, 89623
32283, 14590, 1955, 1956, 14591, 89558, 14689, 14697, 89566, 14600, 1959, 14601, 14597, 89665, 14740, 89673, 
89625, 89599, 14722, 14739, 89624
32284, 89558, 14689, 14697, 89566, 89559, 14690, 14698, 89567, 89665, 14740, 89673, 89625, 89666, 14742, 89674, 
89628, 89602, 14724, 14741, 89627
32285, 89559, 14690, 14698, 89567, 89560, 14691, 14699, 89568, 89666, 14742, 89674, 89628, 89667, 14744, 89675, 
89631, 89605, 14726, 14743, 89630
32286, 89560, 14691, 14699, 89568, 89561, 14692, 14700, 89569, 89667, 14744, 89675, 89631, 89668, 14746, 89676, 
89634, 89608, 14728, 14745, 89633
32287, 89561, 14692, 14700, 89569, 89562, 14693, 14701, 89570, 89668, 14746, 89676, 89634, 89669, 14748, 89677, 
89637, 89611, 14730, 14747, 89636
32288, 89562, 14693, 14701, 89570, 89563, 14694, 14702, 89571, 89669, 14748, 89677, 89637, 89670, 14750, 89678, 
89640, 89614, 14732, 14749, 89639
32289, 89563, 14694, 14702, 89571, 89564, 14695, 14703, 89572, 89670, 14750, 89678, 89640, 89671, 14752, 89679, 
89643, 89617, 14734, 14751, 89642
32290, 89564, 14695, 14703, 89572, 89565, 14696, 14704, 89573, 89671, 14752, 89679, 89643, 89672, 14754, 89680, 
89646, 89620, 14736, 14753, 89645
32291, 89565, 14696, 14704, 89573, 14603, 1968, 1969, 14604, 89672, 14754, 89680, 89646, 14613, 1972, 14614, 
14609, 89623, 14738, 14755, 89648
32292, 14591, 1956, 64, 1951, 89566, 14697, 1998, 14648, 14601, 1960, 1953, 14598, 89673, 14756, 14673, 
89649, 89624, 14739, 2007, 14657
32293, 89566, 14697, 1998, 14648, 89567, 14698, 1997, 14649, 89673, 14756, 14673, 89649, 89674, 14757, 14674, 
89650, 89627, 14741, 2006, 14659
32294, 89567, 14698, 1997, 14649, 89568, 14699, 1996, 14650, 89674, 14757, 14674, 89650, 89675, 14758, 14675, 
89651, 89630, 14743, 2005, 14661
32295, 89568, 14699, 1996, 14650, 89569, 14700, 1995, 14651, 89675, 14758, 14675, 89651, 89676, 14759, 14676, 
89652, 89633, 14745, 2004, 14663
32296, 89569, 14700, 1995, 14651, 89570, 14701, 1994, 14652, 89676, 14759, 14676, 89652, 89677, 14760, 14677, 
89653, 89636, 14747, 2003, 14665
32297, 89570, 14701, 1994, 14652, 89571, 14702, 1993, 14653, 89677, 14760, 14677, 89653, 89678, 14761, 14678, 
89654, 89639, 14749, 2002, 14667
32298, 89571, 14702, 1993, 14653, 89572, 14703, 1992, 14654, 89678, 14761, 14678, 89654, 89679, 14762, 14679, 
89655, 89642, 14751, 2001, 14669
32299, 89572, 14703, 1992, 14654, 89573, 14704, 1991, 14655, 89679, 14762, 14679, 89655, 89680, 14763, 14680, 
89656, 89645, 14753, 2000, 14671
32300, 89573, 14704, 1991, 14655, 14604, 1969, 66, 1964, 89680, 14763, 14680, 89656, 14614, 1973, 1966, 
14611, 89648, 14755, 1999, 14672
*ELEMENT, type=C3D20, ELSET=Volume29
32301, 18941, 2625, 77, 2504, 89681, 18967, 2494, 18300, 18944, 2626, 2507, 18945, 89706, 18975, 18324, 
89707, 89705, 18976, 2503, 18325
32302, 89681, 18967, 2494, 18300, 89682, 18968, 2493, 18301, 89706, 18975, 18324, 89707, 89709, 18977, 18326, 
89710, 89708, 18978, 2502, 18327
32303, 89682, 18968, 2493, 18301, 89683, 18969, 2492, 18302, 89709, 18977, 18326, 89710, 89712, 18979, 18328, 
89713, 89711, 18980, 2501, 18329
32304, 89683, 18969, 2492, 18302, 89684, 18970, 2491, 18303, 89712, 18979, 18328, 89713, 89715, 18981, 18330, 
89716, 89714, 18982, 2500, 18331
32305, 89684, 18970, 2491, 18303, 89685, 18971, 2490, 18304, 89715, 18981, 18330, 89716, 89718, 18983, 18332, 
89719, 89717, 18984, 2499, 18333
32306, 89685, 18971, 2490, 18304, 89686, 18972, 2489, 18305, 89718, 18983, 18332, 89719, 89721, 18985, 18334, 
89722, 89720, 18986, 2498, 18335
32307, 89686, 18972, 2489, 18305, 89687, 18973, 2488, 18306, 89721, 18985, 18334, 89722, 89724, 18987, 18336, 
89725, 89723, 18988, 2497, 18337
32308, 89687, 18973, 2488, 18306, 89688, 18974, 2487, 18307, 89724, 18987, 18336, 89725, 89727, 18989, 18338, 
89728, 89726, 18990, 2496, 18339
32309, 89688, 18974, 2487, 18307, 18954, 2638, 78, 2556, 89727, 18989, 18338, 89728, 18958, 2639, 2559, 
18957, 89729, 18991, 2495, 18340
32310, 18942, 18941, 2504, 2505, 89689, 89681, 18300, 18308, 18946, 18945, 2508, 18947, 89731, 89707, 18341, 
89732, 89730, 89705, 18325, 18342
32311, 89689, 89681, 18300, 18308, 89690, 89682, 18301, 18309, 89731, 89707, 18341, 89732, 89734, 89710, 18343, 
89735, 89733, 89708, 18327, 18344
32312, 89690, 89682, 18301, 18309, 89691, 89683, 18302, 18310, 89734, 89710, 18343, 89735, 89737, 89713, 18345, 
89738, 89736, 89711, 18329, 18346
32313, 89691, 89683, 18302, 18310, 89692, 89684, 18303, 18311, 89737, 89713, 18345, 89738, 89740, 89716, 18347, 
89741, 89739, 89714, 18331, 18348
32314, 89692, 89684, 18303, 18311, 89693, 89685, 18304, 18312, 89740, 89716, 18347, 89741, 89743, 89719, 18349, 
89744, 89742, 89717, 18333, 18350
32315, 89693, 89685, 18304, 18312, 89694, 89686, 18305, 18313, 89743, 89719, 18349, 89744, 89746, 89722, 18351, 
89747, 89745, 89720, 18335, 18352
32316, 89694, 89686, 18305, 18313, 89695, 89687, 18306, 18314, 89746, 89722, 18351, 89747, 89749, 89725, 18353, 
89750, 89748, 89723, 18337, 18354
32317, 89695, 89687, 18306, 18314, 89696, 89688, 18307, 18315, 89749, 89725, 18353, 89750, 89752, 89728, 18355, 
89753, 89751, 89726, 18339, 18356
32318, 89696, 89688, 18307, 18315, 18955, 18954, 2556, 2557, 89752, 89728, 18355, 89753, 18960, 18957, 2560, 
18959, 89754, 89729, 18340, 18357
32319, 18943, 18942, 2505, 2506, 89697, 89689, 18308, 18316, 18948, 18947, 2509, 18949, 89756, 89732, 18358, 
89757, 89755, 89730, 18342, 18359
32320, 89697, 89689, 18308, 18316, 89698, 89690, 18309, 18317, 89756, 89732, 18358, 89757, 89759, 89735, 18360, 
89760, 89758, 89733, 18344, 18361
32321, 89698, 89690, 18309, 18317, 89699, 89691, 18310, 18318, 89759, 89735, 18360, 89760, 89762, 89738, 18362, 
89763, 89761, 89736, 18346, 18363
32322, 89699, 89691, 18310, 18318, 89700, 89692, 18311, 18319, 89762, 89738, 18362, 89763, 89765, 89741, 18364, 
89766, 89764, 89739, 18348, 18365
32323, 89700, 89692, 18311, 18319, 89701, 89693, 18312, 18320, 89765, 89741, 18364, 89766, 89768, 89744, 18366, 
89769, 89767, 89742, 18350, 18367
32324, 89701, 89693, 18312, 18320, 89702, 89694, 18313, 18321, 89768, 89744, 18366, 89769, 89771, 89747, 18368, 
89772, 89770, 89745, 18352, 18369
32325, 89702, 89694, 18313, 18321, 89703, 89695, 18314, 18322, 89771, 89747, 18368, 89772, 89774, 89750, 18370, 
89775, 89773, 89748, 18354, 18371
32326, 89703, 89695, 18314, 18322, 89704, 89696, 18315, 18323, 89774, 89750, 18370, 89775, 89777, 89753, 18372, 
89778, 89776, 89751, 18356, 18373
32327, 89704, 89696, 18315, 18323, 18956, 18955, 2557, 2558, 89777, 89753, 18372, 89778, 18962, 18959, 2561, 
18961, 89779, 89754, 18357, 18374
32328, 2628, 18943, 2506, 79, 19000, 89697, 18316, 2615, 18950, 18949, 2510, 2629, 89780, 89757, 18375, 
19009, 19008, 89755, 18359, 2624
32329, 19000, 89697, 18316, 2615, 19001, 89698, 18317, 2614, 89780, 89757, 18375, 19009, 89781, 89760, 18376, 
19011, 19010, 89758, 18361, 2623
32330, 19001, 89698, 18317, 2614, 19002, 89699, 18318, 2613, 89781, 89760, 18376, 19011, 89782, 89763, 18377, 
19013, 19012, 89761, 18363, 2622
32331, 19002, 89699, 18318, 2613, 19003, 89700, 18319, 2612, 89782, 89763, 18377, 19013, 89783, 89766, 18378, 
19015, 19014, 89764, 18365, 2621
32332, 19003, 89700, 18319, 2612, 19004, 89701, 18320, 2611, 89783, 89766, 18378, 19015, 89784, 89769, 18379, 
19017, 19016, 89767, 18367, 2620
32333, 19004, 89701, 18320, 2611, 19005, 89702, 18321, 2610, 89784, 89769, 18379, 19017, 89785, 89772, 18380, 
19019, 19018, 89770, 18369, 2619
32334, 19005, 89702, 18321, 2610, 19006, 89703, 18322, 2609, 89785, 89772, 18380, 19019, 89786, 89775, 18381, 
19021, 19020, 89773, 18371, 2618
32335, 19006, 89703, 18322, 2609, 19007, 89704, 18323, 2608, 89786, 89775, 18381, 19021, 89787, 89778, 18382, 
19023, 19022, 89776, 18373, 2617
32336, 19007, 89704, 18323, 2608, 2641, 18956, 2558, 80, 89787, 89778, 18382, 19023, 18963, 18961, 2562, 
2642, 19024, 89779, 18374, 2616
32337, 2631, 81, 2625, 18941, 19033, 2658, 18967, 89681, 2634, 2627, 18944, 18951, 19057, 18992, 89706, 
89788, 19058, 2667, 18976, 89705
32338, 19033, 2658, 18967, 89681, 19034, 2657, 18968, 89682, 19057, 18992, 89706, 89788, 19059, 18993, 89709, 
89789, 19060, 2666, 18978, 89708
32339, 19034, 2657, 18968, 89682, 19035, 2656, 18969, 89683, 19059, 18993, 89709, 89789, 19061, 18994, 89712, 
89790, 19062, 2665, 18980, 89711
32340, 19035, 2656, 18969, 89683, 19036, 2655, 18970, 89684, 19061, 18994, 89712, 89790, 19063, 18995, 89715, 
89791, 19064, 2664, 18982, 89714
32341, 19036, 2655, 18970, 89684, 19037, 2654, 18971, 89685, 19063, 18995, 89715, 89791, 19065, 18996, 89718, 
89792, 19066, 2663, 18984, 89717
32342, 19037, 2654, 18971, 89685, 19038, 2653, 18972, 89686, 19065, 18996, 89718, 89792, 19067, 18997, 89721, 
89793, 19068, 2662, 18986, 89720
32343, 19038, 2653, 18972, 89686, 19039, 2652, 18973, 89687, 19067, 18997, 89721, 89793, 19069, 18998, 89724, 
89794, 19070, 2661, 18988, 89723
32344, 19039, 2652, 18973, 89687, 19040, 2651, 18974, 89688, 19069, 18998, 89724, 89794, 19071, 18999, 89727, 
89795, 19072, 2660, 18990, 89726
32345, 19040, 2651, 18974, 89688, 2644, 83, 2638, 18954, 19071, 18999, 89727, 89795, 2647, 2640, 18958, 
18964, 19073, 2659, 18991, 89729
32346, 2632, 2631, 18941, 18942, 19041, 19033, 89681, 89689, 2635, 18951, 18946, 18952, 19074, 89788, 89731, 
89796, 19075, 19058, 89705, 89730
32347, 19041, 19033, 89681, 89689, 19042, 19034, 89682, 89690, 19074, 89788, 89731, 89796, 19076, 89789, 89734, 
89797, 19077, 19060, 89708, 89733
32348, 19042, 19034, 89682, 89690, 19043, 19035, 89683, 89691, 19076, 89789, 89734, 89797, 19078, 89790, 89737, 
89798, 19079, 19062, 89711, 89736
32349, 19043, 19035, 89683, 89691, 19044, 19036, 89684, 89692, 19078, 89790, 89737, 89798, 19080, 89791, 89740, 
89799, 19081, 19064, 89714, 89739
32350, 19044, 19036, 89684, 89692, 19045, 19037, 89685, 89693, 19080, 89791, 89740, 89799, 19082, 89792, 89743, 
89800, 19083, 19066, 89717, 89742
32351, 19045, 19037, 89685, 89693, 19046, 19038, 89686, 89694, 19082, 89792, 89743, 89800, 19084, 89793, 89746, 
89801, 19085, 19068, 89720, 89745
32352, 19046, 19038, 89686, 89694, 19047, 19039, 89687, 89695, 19084, 89793, 89746, 89801, 19086, 89794, 89749, 
89802, 19087, 19070, 89723, 89748
32353, 19047, 19039, 89687, 89695, 19048, 19040, 89688, 89696, 19086, 89794, 89749, 89802, 19088, 89795, 89752, 
89803, 19089, 19072, 89726, 89751
32354, 19048, 19040, 89688, 89696, 2645, 2644, 18954, 18955, 19088, 89795, 89752, 89803, 2648, 18964, 18960, 
18965, 19090, 19073, 89729, 89754
32355, 2633, 2632, 18942, 18943, 19049, 19041, 89689, 89697, 2636, 18952, 18948, 18953, 19091, 89796, 89756, 
89804, 19092, 19075, 89730, 89755
32356, 19049, 19041, 89689, 89697, 19050, 19042, 89690, 89698, 19091, 89796, 89756, 89804, 19093, 89797, 89759, 
89805, 19094, 19077, 89733, 89758
32357, 19050, 19042, 89690, 89698, 19051, 19043, 89691, 89699, 19093, 89797, 89759, 89805, 19095, 89798, 89762, 
89806, 19096, 19079, 89736, 89761
32358, 19051, 19043, 89691, 89699, 19052, 19044, 89692, 89700, 19095, 89798, 89762, 89806, 19097, 89799, 89765, 
89807, 19098, 19081, 89739, 89764
32359, 19052, 19044, 89692, 89700, 19053, 19045, 89693, 89701, 19097, 89799, 89765, 89807, 19099, 89800, 89768, 
89808, 19100, 19083, 89742, 89767
32360, 19053, 19045, 89693, 89701, 19054, 19046, 89694, 89702, 19099, 89800, 89768, 89808, 19101, 89801, 89771, 
89809, 19102, 19085, 89745, 89770
32361, 19054, 19046, 89694, 89702, 19055, 19047, 89695, 89703, 19101, 89801, 89771, 89809, 19103, 89802, 89774, 
89810, 19104, 19087, 89748, 89773
32362, 19055, 19047, 89695, 89703, 19056, 19048, 89696, 89704, 19103, 89802, 89774, 89810, 19105, 89803, 89777, 
89811, 19106, 19089, 89751, 89776
32363, 19056, 19048, 89696, 89704, 2646, 2645, 18955, 18956, 19105, 89803, 89777, 89811, 2649, 18965, 18962, 
18966, 19107, 19090, 89754, 89779
32364, 82, 2633, 18943, 2628, 2675, 19049, 89697, 19000, 2637, 18953, 18950, 2630, 19108, 89804, 89780, 
19025, 2684, 19092, 89755, 19008
32365, 2675, 19049, 89697, 19000, 2674, 19050, 89698, 19001, 19108, 89804, 89780, 19025, 19109, 89805, 89781, 
19026, 2683, 19094, 89758, 19010
32366, 2674, 19050, 89698, 19001, 2673, 19051, 89699, 19002, 19109, 89805, 89781, 19026, 19110, 89806, 89782, 
19027, 2682, 19096, 89761, 19012
32367, 2673, 19051, 89699, 19002, 2672, 19052, 89700, 19003, 19110, 89806, 89782, 19027, 19111, 89807, 89783, 
19028, 2681, 19098, 89764, 19014
32368, 2672, 19052, 89700, 19003, 2671, 19053, 89701, 19004, 19111, 89807, 89783, 19028, 19112, 89808, 89784, 
19029, 2680, 19100, 89767, 19016
32369, 2671, 19053, 89701, 19004, 2670, 19054, 89702, 19005, 19112, 89808, 89784, 19029, 19113, 89809, 89785, 
19030, 2679, 19102, 89770, 19018
32370, 2670, 19054, 89702, 19005, 2669, 19055, 89703, 19006, 19113, 89809, 89785, 19030, 19114, 89810, 89786, 
19031, 2678, 19104, 89773, 19020
32371, 2669, 19055, 89703, 19006, 2668, 19056, 89704, 19007, 19114, 89810, 89786, 19031, 19115, 89811, 89787, 
19032, 2677, 19106, 89776, 19022
32372, 2668, 19056, 89704, 19007, 84, 2646, 18956, 2641, 19115, 89811, 89787, 19032, 2650, 18966, 18963, 
2643, 2676, 19107, 89779, 19024
*ELEMENT, type=C3D20, ELSET=Volume30
32373, 35, 3565, 30052, 1184, 1291, 30230, 89812, 10531, 3566, 30075, 30074, 1206, 30239, 89989, 89990, 
10708, 1300, 30238, 89988, 10707
32374, 1291, 30230, 89812, 10531, 1290, 30231, 89813, 10532, 30239, 89989, 89990, 10708, 30241, 89992, 89993, 
10710, 1299, 30240, 89991, 10709
32375, 1290, 30231, 89813, 10532, 1289, 30232, 89814, 10533, 30241, 89992, 89993, 10710, 30243, 89995, 89996, 
10712, 1298, 30242, 89994, 10711
32376, 1289, 30232, 89814, 10533, 1288, 30233, 89815, 10534, 30243, 89995, 89996, 10712, 30245, 89998, 89999, 
10714, 1297, 30244, 89997, 10713
32377, 1288, 30233, 89815, 10534, 1287, 30234, 89816, 10535, 30245, 89998, 89999, 10714, 30247, 90001, 90002, 
10716, 1296, 30246, 90000, 10715
32378, 1287, 30234, 89816, 10535, 1286, 30235, 89817, 10536, 30247, 90001, 90002, 10716, 30249, 90004, 90005, 
10718, 1295, 30248, 90003, 10717
32379, 1286, 30235, 89817, 10536, 1285, 30236, 89818, 10537, 30249, 90004, 90005, 10718, 30251, 90007, 90008, 
10720, 1294, 30250, 90006, 10719
32380, 1285, 30236, 89818, 10537, 1284, 30237, 89819, 10538, 30251, 90007, 90008, 10720, 30253, 90010, 90011, 
10722, 1293, 30252, 90009, 10721
32381, 1284, 30237, 89819, 10538, 37, 3571, 30141, 1239, 30253, 90010, 90011, 10722, 3572, 30163, 30164, 
1261, 1292, 30254, 90012, 10723
32382, 1184, 30052, 30053, 1185, 10531, 89812, 89820, 10539, 30074, 30077, 30076, 1207, 89990, 90014, 90015, 
10725, 10707, 89988, 90013, 10724
32383, 10531, 89812, 89820, 10539, 10532, 89813, 89821, 10540, 89990, 90014, 90015, 10725, 89993, 90017, 90018, 
10727, 10709, 89991, 90016, 10726
32384, 10532, 89813, 89821, 10540, 10533, 89814, 89822, 10541, 89993, 90017, 90018, 10727, 89996, 90020, 90021, 
10729, 10711, 89994, 90019, 10728
32385, 10533, 89814, 89822, 10541, 10534, 89815, 89823, 10542, 89996, 90020, 90021, 10729, 89999, 90023, 90024, 
10731, 10713, 89997, 90022, 10730
32386, 10534, 89815, 89823, 10542, 10535, 89816, 89824, 10543, 89999, 90023, 90024, 10731, 90002, 90026, 90027, 
10733, 10715, 90000, 90025, 10732
32387, 10535, 89816, 89824, 10543, 10536, 89817, 89825, 10544, 90002, 90026, 90027, 10733, 90005, 90029, 90030, 
10735, 10717, 90003, 90028, 10734
32388, 10536, 89817, 89825, 10544, 10537, 89818, 89826, 10545, 90005, 90029, 90030, 10735, 90008, 90032, 90033, 
10737, 10719, 90006, 90031, 10736
32389, 10537, 89818, 89826, 10545, 10538, 89819, 89827, 10546, 90008, 90032, 90033, 10737, 90011, 90035, 90036, 
10739, 10721, 90009, 90034, 10738
32390, 10538, 89819, 89827, 10546, 1239, 30141, 30142, 1240, 90011, 90035, 90036, 10739, 30164, 30165, 30166, 
1262, 10723, 90012, 90037, 10740
32391, 1185, 30053, 30054, 1186, 10539, 89820, 89828, 10547, 30076, 30079, 30078, 1208, 90015, 90039, 90040, 
10742, 10724, 90013, 90038, 10741
32392, 10539, 89820, 89828, 10547, 10540, 89821, 89829, 10548, 90015, 90039, 90040, 10742, 90018, 90042, 90043, 
10744, 10726, 90016, 90041, 10743
32393, 10540, 89821, 89829, 10548, 10541, 89822, 89830, 10549, 90018, 90042, 90043, 10744, 90021, 90045, 90046, 
10746, 10728, 90019, 90044, 10745
32394, 10541, 89822, 89830, 10549, 10542, 89823, 89831, 10550, 90021, 90045, 90046, 10746, 90024, 90048, 90049, 
10748, 10730, 90022, 90047, 10747
32395, 10542, 89823, 89831, 10550, 10543, 89824, 89832, 10551, 90024, 90048, 90049, 10748, 90027, 90051, 90052, 
10750, 10732, 90025, 90050, 10749
32396, 10543, 89824, 89832, 10551, 10544, 89825, 89833, 10552, 90027, 90051, 90052, 10750, 90030, 90054, 90055, 
10752, 10734, 90028, 90053, 10751
32397, 10544, 89825, 89833, 10552, 10545, 89826, 89834, 10553, 90030, 90054, 90055, 10752, 90033, 90057, 90058, 
10754, 10736, 90031, 90056, 10753
32398, 10545, 89826, 89834, 10553, 10546, 89827, 89835, 10554, 90033, 90057, 90058, 10754, 90036, 90060, 90061, 
10756, 10738, 90034, 90059, 10755
32399, 10546, 89827, 89835, 10554, 1240, 30142, 30143, 1241, 90036, 90060, 90061, 10756, 30166, 30167, 30168, 
1263, 10740, 90037, 90062, 10757
32400, 1186, 30054, 30055, 1187, 10547, 89828, 89836, 10555, 30078, 30081, 30080, 1209, 90040, 90064, 90065, 
10759, 10741, 90038, 90063, 10758
32401, 10547, 89828, 89836, 10555, 10548, 89829, 89837, 10556, 90040, 90064, 90065, 10759, 90043, 90067, 90068, 
10761, 10743, 90041, 90066, 10760
32402, 10548, 89829, 89837, 10556, 10549, 89830, 89838, 10557, 90043, 90067, 90068, 10761, 90046, 90070, 90071, 
10763, 10745, 90044, 90069, 10762
32403, 10549, 89830, 89838, 10557, 10550, 89831, 89839, 10558, 90046, 90070, 90071, 10763, 90049, 90073, 90074, 
10765, 10747, 90047, 90072, 10764
32404, 10550, 89831, 89839, 10558, 10551, 89832, 89840, 10559, 90049, 90073, 90074, 10765, 90052, 90076, 90077, 
10767, 10749, 90050, 90075, 10766
32405, 10551, 89832, 89840, 10559, 10552, 89833, 89841, 10560, 90052, 90076, 90077, 10767, 90055, 90079, 90080, 
10769, 10751, 90053, 90078, 10768
32406, 10552, 89833, 89841, 10560, 10553, 89834, 89842, 10561, 90055, 90079, 90080, 10769, 90058, 90082, 90083, 
10771, 10753, 90056, 90081, 10770
32407, 10553, 89834, 89842, 10561, 10554, 89835, 89843, 10562, 90058, 90082, 90083, 10771, 90061, 90085, 90086, 
10773, 10755, 90059, 90084, 10772
32408, 10554, 89835, 89843, 10562, 1241, 30143, 30144, 1242, 90061, 90085, 90086, 10773, 30168, 30169, 30170, 
1264, 10757, 90062, 90087, 10774
32409, 1187, 30055, 30056, 1188, 10555, 89836, 89844, 10563, 30080, 30083, 30082, 1210, 90065, 90089, 90090, 
10776, 10758, 90063, 90088, 10775
32410, 10555, 89836, 89844, 10563, 10556, 89837, 89845, 10564, 90065, 90089, 90090, 10776, 90068, 90092, 90093, 
10778, 10760, 90066, 90091, 10777
32411, 10556, 89837, 89845, 10564, 10557, 89838, 89846, 10565, 90068, 90092, 90093, 10778, 90071, 90095, 90096, 
10780, 10762, 90069, 90094, 10779
32412, 10557, 89838, 89846, 10565, 10558, 89839, 89847, 10566, 90071, 90095, 90096, 10780, 90074, 90098, 90099, 
10782, 10764, 90072, 90097, 10781
32413, 10558, 89839, 89847, 10566, 10559, 89840, 89848, 10567, 90074, 90098, 90099, 10782, 90077, 90101, 90102, 
10784, 10766, 90075, 90100, 10783
32414, 10559, 89840, 89848, 10567, 10560, 89841, 89849, 10568, 90077, 90101, 90102, 10784, 90080, 90104, 90105, 
10786, 10768, 90078, 90103, 10785
32415, 10560, 89841, 89849, 10568, 10561, 89842, 89850, 10569, 90080, 90104, 90105, 10786, 90083, 90107, 90108, 
10788, 10770, 90081, 90106, 10787
32416, 10561, 89842, 89850, 10569, 10562, 89843, 89851, 10570, 90083, 90107, 90108, 10788, 90086, 90110, 90111, 
10790, 10772, 90084, 90109, 10789
32417, 10562, 89843, 89851, 10570, 1242, 30144, 30145, 1243, 90086, 90110, 90111, 10790, 30170, 30171, 30172, 
1265, 10774, 90087, 90112, 10791
32418, 1188, 30056, 30057, 1189, 10563, 89844, 89852, 10571, 30082, 30085, 30084, 1211, 90090, 90114, 90115, 
10793, 10775, 90088, 90113, 10792
32419, 10563, 89844, 89852, 10571, 10564, 89845, 89853, 10572, 90090, 90114, 90115, 10793, 90093, 90117, 90118, 
10795, 10777, 90091, 90116, 10794
32420, 10564, 89845, 89853, 10572, 10565, 89846, 89854, 10573, 90093, 90117, 90118, 10795, 90096, 90120, 90121, 
10797, 10779, 90094, 90119, 10796
32421, 10565, 89846, 89854, 10573, 10566, 89847, 89855, 10574, 90096, 90120, 90121, 10797, 90099, 90123, 90124, 
10799, 10781, 90097, 90122, 10798
32422, 10566, 89847, 89855, 10574, 10567, 89848, 89856, 10575, 90099, 90123, 90124, 10799, 90102, 90126, 90127, 
10801, 10783, 90100, 90125, 10800
32423, 10567, 89848, 89856, 10575, 10568, 89849, 89857, 10576, 90102, 90126, 90127, 10801, 90105, 90129, 90130, 
10803, 10785, 90103, 90128, 10802
32424, 10568, 89849, 89857, 10576, 10569, 89850, 89858, 10577, 90105, 90129, 90130, 10803, 90108, 90132, 90133, 
10805, 10787, 90106, 90131, 10804
32425, 10569, 89850, 89858, 10577, 10570, 89851, 89859, 10578, 90108, 90132, 90133, 10805, 90111, 90135, 90136, 
10807, 10789, 90109, 90134, 10806
32426, 10570, 89851, 89859, 10578, 1243, 30145, 30146, 1244, 90111, 90135, 90136, 10807, 30172, 30173, 30174, 
1266, 10791, 90112, 90137, 10808
32427, 1189, 30057, 30058, 1190, 10571, 89852, 89860, 10579, 30084, 30087, 30086, 1212, 90115, 90139, 90140, 
10810, 10792, 90113, 90138, 10809
32428, 10571, 89852, 89860, 10579, 10572, 89853, 89861, 10580, 90115, 90139, 90140, 10810, 90118, 90142, 90143, 
10812, 10794, 90116, 90141, 10811
32429, 10572, 89853, 89861, 10580, 10573, 89854, 89862, 10581, 90118, 90142, 90143, 10812, 90121, 90145, 90146, 
10814, 10796, 90119, 90144, 10813
32430, 10573, 89854, 89862, 10581, 10574, 89855, 89863, 10582, 90121, 90145, 90146, 10814, 90124, 90148, 90149, 
10816, 10798, 90122, 90147, 10815
32431, 10574, 89855, 89863, 10582, 10575, 89856, 89864, 10583, 90124, 90148, 90149, 10816, 90127, 90151, 90152, 
10818, 10800, 90125, 90150, 10817
32432, 10575, 89856, 89864, 10583, 10576, 89857, 89865, 10584, 90127, 90151, 90152, 10818, 90130, 90154, 90155, 
10820, 10802, 90128, 90153, 10819
32433, 10576, 89857, 89865, 10584, 10577, 89858, 89866, 10585, 90130, 90154, 90155, 10820, 90133, 90157, 90158, 
10822, 10804, 90131, 90156, 10821
32434, 10577, 89858, 89866, 10585, 10578, 89859, 89867, 10586, 90133, 90157, 90158, 10822, 90136, 90160, 90161, 
10824, 10806, 90134, 90159, 10823
32435, 10578, 89859, 89867, 10586, 1244, 30146, 30147, 1245, 90136, 90160, 90161, 10824, 30174, 30175, 30176, 
1267, 10808, 90137, 90162, 10825
32436, 1190, 30058, 30059, 1191, 10579, 89860, 89868, 10587, 30086, 30089, 30088, 1213, 90140, 90164, 90165, 
10827, 10809, 90138, 90163, 10826
32437, 10579, 89860, 89868, 10587, 10580, 89861, 89869, 10588, 90140, 90164, 90165, 10827, 90143, 90167, 90168, 
10829, 10811, 90141, 90166, 10828
32438, 10580, 89861, 89869, 10588, 10581, 89862, 89870, 10589, 90143, 90167, 90168, 10829, 90146, 90170, 90171, 
10831, 10813, 90144, 90169, 10830
32439, 10581, 89862, 89870, 10589, 10582, 89863, 89871, 10590, 90146, 90170, 90171, 10831, 90149, 90173, 90174, 
10833, 10815, 90147, 90172, 10832
32440, 10582, 89863, 89871, 10590, 10583, 89864, 89872, 10591, 90149, 90173, 90174, 10833, 90152, 90176, 90177, 
10835, 10817, 90150, 90175, 10834
32441, 10583, 89864, 89872, 10591, 10584, 89865, 89873, 10592, 90152, 90176, 90177, 10835, 90155, 90179, 90180, 
10837, 10819, 90153, 90178, 10836
32442, 10584, 89865, 89873, 10592, 10585, 89866, 89874, 10593, 90155, 90179, 90180, 10837, 90158, 90182, 90183, 
10839, 10821, 90156, 90181, 10838
32443, 10585, 89866, 89874, 10593, 10586, 89867, 89875, 10594, 90158, 90182, 90183, 10839, 90161, 90185, 90186, 
10841, 10823, 90159, 90184, 10840
32444, 10586, 89867, 89875, 10594, 1245, 30147, 30148, 1246, 90161, 90185, 90186, 10841, 30176, 30177, 30178, 
1268, 10825, 90162, 90187, 10842
32445, 1191, 30059, 30060, 1192, 10587, 89868, 89876, 10595, 30088, 30091, 30090, 1214, 90165, 90189, 90190, 
10844, 10826, 90163, 90188, 10843
32446, 10587, 89868, 89876, 10595, 10588, 89869, 89877, 10596, 90165, 90189, 90190, 10844, 90168, 90192, 90193, 
10846, 10828, 90166, 90191, 10845
32447, 10588, 89869, 89877, 10596, 10589, 89870, 89878, 10597, 90168, 90192, 90193, 10846, 90171, 90195, 90196, 
10848, 10830, 90169, 90194, 10847
32448, 10589, 89870, 89878, 10597, 10590, 89871, 89879, 10598, 90171, 90195, 90196, 10848, 90174, 90198, 90199, 
10850, 10832, 90172, 90197, 10849
32449, 10590, 89871, 89879, 10598, 10591, 89872, 89880, 10599, 90174, 90198, 90199, 10850, 90177, 90201, 90202, 
10852, 10834, 90175, 90200, 10851
32450, 10591, 89872, 89880, 10599, 10592, 89873, 89881, 10600, 90177, 90201, 90202, 10852, 90180, 90204, 90205, 
10854, 10836, 90178, 90203, 10853
32451, 10592, 89873, 89881, 10600, 10593, 89874, 89882, 10601, 90180, 90204, 90205, 10854, 90183, 90207, 90208, 
10856, 10838, 90181, 90206, 10855
32452, 10593, 89874, 89882, 10601, 10594, 89875, 89883, 10602, 90183, 90207, 90208, 10856, 90186, 90210, 90211, 
10858, 10840, 90184, 90209, 10857
32453, 10594, 89875, 89883, 10602, 1246, 30148, 30149, 1247, 90186, 90210, 90211, 10858, 30178, 30179, 30180, 
1269, 10842, 90187, 90212, 10859
32454, 1192, 30060, 30061, 1193, 10595, 89876, 89884, 10603, 30090, 30093, 30092, 1215, 90190, 90214, 90215, 
10861, 10843, 90188, 90213, 10860
32455, 10595, 89876, 89884, 10603, 10596, 89877, 89885, 10604, 90190, 90214, 90215, 10861, 90193, 90217, 90218, 
10863, 10845, 90191, 90216, 10862
32456, 10596, 89877, 89885, 10604, 10597, 89878, 89886, 10605, 90193, 90217, 90218, 10863, 90196, 90220, 90221, 
10865, 10847, 90194, 90219, 10864
32457, 10597, 89878, 89886, 10605, 10598, 89879, 89887, 10606, 90196, 90220, 90221, 10865, 90199, 90223, 90224, 
10867, 10849, 90197, 90222, 10866
32458, 10598, 89879, 89887, 10606, 10599, 89880, 89888, 10607, 90199, 90223, 90224, 10867, 90202, 90226, 90227, 
10869, 10851, 90200, 90225, 10868
32459, 10599, 89880, 89888, 10607, 10600, 89881, 89889, 10608, 90202, 90226, 90227, 10869, 90205, 90229, 90230, 
10871, 10853, 90203, 90228, 10870
32460, 10600, 89881, 89889, 10608, 10601, 89882, 89890, 10609, 90205, 90229, 90230, 10871, 90208, 90232, 90233, 
10873, 10855, 90206, 90231, 10872
32461, 10601, 89882, 89890, 10609, 10602, 89883, 89891, 10610, 90208, 90232, 90233, 10873, 90211, 90235, 90236, 
10875, 10857, 90209, 90234, 10874
32462, 10602, 89883, 89891, 10610, 1247, 30149, 30150, 1248, 90211, 90235, 90236, 10875, 30180, 30181, 30182, 
1270, 10859, 90212, 90237, 10876
32463, 1193, 30061, 30062, 1194, 10603, 89884, 89892, 10611, 30092, 30095, 30094, 1216, 90215, 90239, 90240, 
10878, 10860, 90213, 90238, 10877
32464, 10603, 89884, 89892, 10611, 10604, 89885, 89893, 10612, 90215, 90239, 90240, 10878, 90218, 90242, 90243, 
10880, 10862, 90216, 90241, 10879
32465, 10604, 89885, 89893, 10612, 10605, 89886, 89894, 10613, 90218, 90242, 90243, 10880, 90221, 90245, 90246, 
10882, 10864, 90219, 90244, 10881
32466, 10605, 89886, 89894, 10613, 10606, 89887, 89895, 10614, 90221, 90245, 90246, 10882, 90224, 90248, 90249, 
10884, 10866, 90222, 90247, 10883
32467, 10606, 89887, 89895, 10614, 10607, 89888, 89896, 10615, 90224, 90248, 90249, 10884, 90227, 90251, 90252, 
10886, 10868, 90225, 90250, 10885
32468, 10607, 89888, 89896, 10615, 10608, 89889, 89897, 10616, 90227, 90251, 90252, 10886, 90230, 90254, 90255, 
10888, 10870, 90228, 90253, 10887
32469, 10608, 89889, 89897, 10616, 10609, 89890, 89898, 10617, 90230, 90254, 90255, 10888, 90233, 90257, 90258, 
10890, 10872, 90231, 90256, 10889
32470, 10609, 89890, 89898, 10617, 10610, 89891, 89899, 10618, 90233, 90257, 90258, 10890, 90236, 90260, 90261, 
10892, 10874, 90234, 90259, 10891
32471, 10610, 89891, 89899, 10618, 1248, 30150, 30151, 1249, 90236, 90260, 90261, 10892, 30182, 30183, 30184, 
1271, 10876, 90237, 90262, 10893
32472, 1194, 30062, 30063, 1195, 10611, 89892, 89900, 10619, 30094, 30097, 30096, 1217, 90240, 90264, 90265, 
10895, 10877, 90238, 90263, 10894
32473, 10611, 89892, 89900, 10619, 10612, 89893, 89901, 10620, 90240, 90264, 90265, 10895, 90243, 90267, 90268, 
10897, 10879, 90241, 90266, 10896
32474, 10612, 89893, 89901, 10620, 10613, 89894, 89902, 10621, 90243, 90267, 90268, 10897, 90246, 90270, 90271, 
10899, 10881, 90244, 90269, 10898
32475, 10613, 89894, 89902, 10621, 10614, 89895, 89903, 10622, 90246, 90270, 90271, 10899, 90249, 90273, 90274, 
10901, 10883, 90247, 90272, 10900
32476, 10614, 89895, 89903, 10622, 10615, 89896, 89904, 10623, 90249, 90273, 90274, 10901, 90252, 90276, 90277, 
10903, 10885, 90250, 90275, 10902
32477, 10615, 89896, 89904, 10623, 10616, 89897, 89905, 10624, 90252, 90276, 90277, 10903, 90255, 90279, 90280, 
10905, 10887, 90253, 90278, 10904
32478, 10616, 89897, 89905, 10624, 10617, 89898, 89906, 10625, 90255, 90279, 90280, 10905, 90258, 90282, 90283, 
10907, 10889, 90256, 90281, 10906
32479, 10617, 89898, 89906, 10625, 10618, 89899, 89907, 10626, 90258, 90282, 90283, 10907, 90261, 90285, 90286, 
10909, 10891, 90259, 90284, 10908
32480, 10618, 89899, 89907, 10626, 1249, 30151, 30152, 1250, 90261, 90285, 90286, 10909, 30184, 30185, 30186, 
1272, 10893, 90262, 90287, 10910
32481, 1195, 30063, 30064, 1196, 10619, 89900, 89908, 10627, 30096, 30099, 30098, 1218, 90265, 90289, 90290, 
10912, 10894, 90263, 90288, 10911
32482, 10619, 89900, 89908, 10627, 10620, 89901, 89909, 10628, 90265, 90289, 90290, 10912, 90268, 90292, 90293, 
10914, 10896, 90266, 90291, 10913
32483, 10620, 89901, 89909, 10628, 10621, 89902, 89910, 10629, 90268, 90292, 90293, 10914, 90271, 90295, 90296, 
10916, 10898, 90269, 90294, 10915
32484, 10621, 89902, 89910, 10629, 10622, 89903, 89911, 10630, 90271, 90295, 90296, 10916, 90274, 90298, 90299, 
10918, 10900, 90272, 90297, 10917
32485, 10622, 89903, 89911, 10630, 10623, 89904, 89912, 10631, 90274, 90298, 90299, 10918, 90277, 90301, 90302, 
10920, 10902, 90275, 90300, 10919
32486, 10623, 89904, 89912, 10631, 10624, 89905, 89913, 10632, 90277, 90301, 90302, 10920, 90280, 90304, 90305, 
10922, 10904, 90278, 90303, 10921
32487, 10624, 89905, 89913, 10632, 10625, 89906, 89914, 10633, 90280, 90304, 90305, 10922, 90283, 90307, 90308, 
10924, 10906, 90281, 90306, 10923
32488, 10625, 89906, 89914, 10633, 10626, 89907, 89915, 10634, 90283, 90307, 90308, 10924, 90286, 90310, 90311, 
10926, 10908, 90284, 90309, 10925
32489, 10626, 89907, 89915, 10634, 1250, 30152, 30153, 1251, 90286, 90310, 90311, 10926, 30186, 30187, 30188, 
1273, 10910, 90287, 90312, 10927
32490, 1196, 30064, 30065, 1197, 10627, 89908, 89916, 10635, 30098, 30101, 30100, 1219, 90290, 90314, 90315, 
10929, 10911, 90288, 90313, 10928
32491, 10627, 89908, 89916, 10635, 10628, 89909, 89917, 10636, 90290, 90314, 90315, 10929, 90293, 90317, 90318, 
10931, 10913, 90291, 90316, 10930
32492, 10628, 89909, 89917, 10636, 10629, 89910, 89918, 10637, 90293, 90317, 90318, 10931, 90296, 90320, 90321, 
10933, 10915, 90294, 90319, 10932
32493, 10629, 89910, 89918, 10637, 10630, 89911, 89919, 10638, 90296, 90320, 90321, 10933, 90299, 90323, 90324, 
10935, 10917, 90297, 90322, 10934
32494, 10630, 89911, 89919, 10638, 10631, 89912, 89920, 10639, 90299, 90323, 90324, 10935, 90302, 90326, 90327, 
10937, 10919, 90300, 90325, 10936
32495, 10631, 89912, 89920, 10639, 10632, 89913, 89921, 10640, 90302, 90326, 90327, 10937, 90305, 90329, 90330, 
10939, 10921, 90303, 90328, 10938
32496, 10632, 89913, 89921, 10640, 10633, 89914, 89922, 10641, 90305, 90329, 90330, 10939, 90308, 90332, 90333, 
10941, 10923, 90306, 90331, 10940
32497, 10633, 89914, 89922, 10641, 10634, 89915, 89923, 10642, 90308, 90332, 90333, 10941, 90311, 90335, 90336, 
10943, 10925, 90309, 90334, 10942
32498, 10634, 89915, 89923, 10642, 1251, 30153, 30154, 1252, 90311, 90335, 90336, 10943, 30188, 30189, 30190, 
1274, 10927, 90312, 90337, 10944
32499, 1197, 30065, 30066, 1198, 10635, 89916, 89924, 10643, 30100, 30103, 30102, 1220, 90315, 90339, 90340, 
10946, 10928, 90313, 90338, 10945
32500, 10635, 89916, 89924, 10643, 10636, 89917, 89925, 10644, 90315, 90339, 90340, 10946, 90318, 90342, 90343, 
10948, 10930, 90316, 90341, 10947
32501, 10636, 89917, 89925, 10644, 10637, 89918, 89926, 10645, 90318, 90342, 90343, 10948, 90321, 90345, 90346, 
10950, 10932, 90319, 90344, 10949
32502, 10637, 89918, 89926, 10645, 10638, 89919, 89927, 10646, 90321, 90345, 90346, 10950, 90324, 90348, 90349, 
10952, 10934, 90322, 90347, 10951
32503, 10638, 89919, 89927, 10646, 10639, 89920, 89928, 10647, 90324, 90348, 90349, 10952, 90327, 90351, 90352, 
10954, 10936, 90325, 90350, 10953
32504, 10639, 89920, 89928, 10647, 10640, 89921, 89929, 10648, 90327, 90351, 90352, 10954, 90330, 90354, 90355, 
10956, 10938, 90328, 90353, 10955
32505, 10640, 89921, 89929, 10648, 10641, 89922, 89930, 10649, 90330, 90354, 90355, 10956, 90333, 90357, 90358, 
10958, 10940, 90331, 90356, 10957
32506, 10641, 89922, 89930, 10649, 10642, 89923, 89931, 10650, 90333, 90357, 90358, 10958, 90336, 90360, 90361, 
10960, 10942, 90334, 90359, 10959
32507, 10642, 89923, 89931, 10650, 1252, 30154, 30155, 1253, 90336, 90360, 90361, 10960, 30190, 30191, 30192, 
1275, 10944, 90337, 90362, 10961
32508, 1198, 30066, 30067, 1199, 10643, 89924, 89932, 10651, 30102, 30105, 30104, 1221, 90340, 90364, 90365, 
10963, 10945, 90338, 90363, 10962
32509, 10643, 89924, 89932, 10651, 10644, 89925, 89933, 10652, 90340, 90364, 90365, 10963, 90343, 90367, 90368, 
10965, 10947, 90341, 90366, 10964
32510, 10644, 89925, 89933, 10652, 10645, 89926, 89934, 10653, 90343, 90367, 90368, 10965, 90346, 90370, 90371, 
10967, 10949, 90344, 90369, 10966
32511, 10645, 89926, 89934, 10653, 10646, 89927, 89935, 10654, 90346, 90370, 90371, 10967, 90349, 90373, 90374, 
10969, 10951, 90347, 90372, 10968
32512, 10646, 89927, 89935, 10654, 10647, 89928, 89936, 10655, 90349, 90373, 90374, 10969, 90352, 90376, 90377, 
10971, 10953, 90350, 90375, 10970
32513, 10647, 89928, 89936, 10655, 10648, 89929, 89937, 10656, 90352, 90376, 90377, 10971, 90355, 90379, 90380, 
10973, 10955, 90353, 90378, 10972
32514, 10648, 89929, 89937, 10656, 10649, 89930, 89938, 10657, 90355, 90379, 90380, 10973, 90358, 90382, 90383, 
10975, 10957, 90356, 90381, 10974
32515, 10649, 89930, 89938, 10657, 10650, 89931, 89939, 10658, 90358, 90382, 90383, 10975, 90361, 90385, 90386, 
10977, 10959, 90359, 90384, 10976
32516, 10650, 89931, 89939, 10658, 1253, 30155, 30156, 1254, 90361, 90385, 90386, 10977, 30192, 30193, 30194, 
1276, 10961, 90362, 90387, 10978
32517, 1199, 30067, 30068, 1200, 10651, 89932, 89940, 10659, 30104, 30107, 30106, 1222, 90365, 90389, 90390, 
10980, 10962, 90363, 90388, 10979
32518, 10651, 89932, 89940, 10659, 10652, 89933, 89941, 10660, 90365, 90389, 90390, 10980, 90368, 90392, 90393, 
10982, 10964, 90366, 90391, 10981
32519, 10652, 89933, 89941, 10660, 10653, 89934, 89942, 10661, 90368, 90392, 90393, 10982, 90371, 90395, 90396, 
10984, 10966, 90369, 90394, 10983
32520, 10653, 89934, 89942, 10661, 10654, 89935, 89943, 10662, 90371, 90395, 90396, 10984, 90374, 90398, 90399, 
10986, 10968, 90372, 90397, 10985
32521, 10654, 89935, 89943, 10662, 10655, 89936, 89944, 10663, 90374, 90398, 90399, 10986, 90377, 90401, 90402, 
10988, 10970, 90375, 90400, 10987
32522, 10655, 89936, 89944, 10663, 10656, 89937, 89945, 10664, 90377, 90401, 90402, 10988, 90380, 90404, 90405, 
10990, 10972, 90378, 90403, 10989
32523, 10656, 89937, 89945, 10664, 10657, 89938, 89946, 10665, 90380, 90404, 90405, 10990, 90383, 90407, 90408, 
10992, 10974, 90381, 90406, 10991
32524, 10657, 89938, 89946, 10665, 10658, 89939, 89947, 10666, 90383, 90407, 90408, 10992, 90386, 90410, 90411, 
10994, 10976, 90384, 90409, 10993
32525, 10658, 89939, 89947, 10666, 1254, 30156, 30157, 1255, 90386, 90410, 90411, 10994, 30194, 30195, 30196, 
1277, 10978, 90387, 90412, 10995
32526, 1200, 30068, 30069, 1201, 10659, 89940, 89948, 10667, 30106, 30109, 30108, 1223, 90390, 90414, 90415, 
10997, 10979, 90388, 90413, 10996
32527, 10659, 89940, 89948, 10667, 10660, 89941, 89949, 10668, 90390, 90414, 90415, 10997, 90393, 90417, 90418, 
10999, 10981, 90391, 90416, 10998
32528, 10660, 89941, 89949, 10668, 10661, 89942, 89950, 10669, 90393, 90417, 90418, 10999, 90396, 90420, 90421, 
11001, 10983, 90394, 90419, 11000
32529, 10661, 89942, 89950, 10669, 10662, 89943, 89951, 10670, 90396, 90420, 90421, 11001, 90399, 90423, 90424, 
11003, 10985, 90397, 90422, 11002
32530, 10662, 89943, 89951, 10670, 10663, 89944, 89952, 10671, 90399, 90423, 90424, 11003, 90402, 90426, 90427, 
11005, 10987, 90400, 90425, 11004
32531, 10663, 89944, 89952, 10671, 10664, 89945, 89953, 10672, 90402, 90426, 90427, 11005, 90405, 90429, 90430, 
11007, 10989, 90403, 90428, 11006
32532, 10664, 89945, 89953, 10672, 10665, 89946, 89954, 10673, 90405, 90429, 90430, 11007, 90408, 90432, 90433, 
11009, 10991, 90406, 90431, 11008
32533, 10665, 89946, 89954, 10673, 10666, 89947, 89955, 10674, 90408, 90432, 90433, 11009, 90411, 90435, 90436, 
11011, 10993, 90409, 90434, 11010
32534, 10666, 89947, 89955, 10674, 1255, 30157, 30158, 1256, 90411, 90435, 90436, 11011, 30196, 30197, 30198, 
1278, 10995, 90412, 90437, 11012
32535, 1201, 30069, 30070, 1202, 10667, 89948, 89956, 10675, 30108, 30111, 30110, 1224, 90415, 90439, 90440, 
11014, 10996, 90413, 90438, 11013
32536, 10667, 89948, 89956, 10675, 10668, 89949, 89957, 10676, 90415, 90439, 90440, 11014, 90418, 90442, 90443, 
11016, 10998, 90416, 90441, 11015
32537, 10668, 89949, 89957, 10676, 10669, 89950, 89958, 10677, 90418, 90442, 90443, 11016, 90421, 90445, 90446, 
11018, 11000, 90419, 90444, 11017
32538, 10669, 89950, 89958, 10677, 10670, 89951, 89959, 10678, 90421, 90445, 90446, 11018, 90424, 90448, 90449, 
11020, 11002, 90422, 90447, 11019
32539, 10670, 89951, 89959, 10678, 10671, 89952, 89960, 10679, 90424, 90448, 90449, 11020, 90427, 90451, 90452, 
11022, 11004, 90425, 90450, 11021
32540, 10671, 89952, 89960, 10679, 10672, 89953, 89961, 10680, 90427, 90451, 90452, 11022, 90430, 90454, 90455, 
11024, 11006, 90428, 90453, 11023
32541, 10672, 89953, 89961, 10680, 10673, 89954, 89962, 10681, 90430, 90454, 90455, 11024, 90433, 90457, 90458, 
11026, 11008, 90431, 90456, 11025
32542, 10673, 89954, 89962, 10681, 10674, 89955, 89963, 10682, 90433, 90457, 90458, 11026, 90436, 90460, 90461, 
11028, 11010, 90434, 90459, 11027
32543, 10674, 89955, 89963, 10682, 1256, 30158, 30159, 1257, 90436, 90460, 90461, 11028, 30198, 30199, 30200, 
1279, 11012, 90437, 90462, 11029
32544, 1202, 30070, 30071, 1203, 10675, 89956, 89964, 10683, 30110, 30113, 30112, 1225, 90440, 90464, 90465, 
11031, 11013, 90438, 90463, 11030
32545, 10675, 89956, 89964, 10683, 10676, 89957, 89965, 10684, 90440, 90464, 90465, 11031, 90443, 90467, 90468, 
11033, 11015, 90441, 90466, 11032
32546, 10676, 89957, 89965, 10684, 10677, 89958, 89966, 10685, 90443, 90467, 90468, 11033, 90446, 90470, 90471, 
11035, 11017, 90444, 90469, 11034
32547, 10677, 89958, 89966, 10685, 10678, 89959, 89967, 10686, 90446, 90470, 90471, 11035, 90449, 90473, 90474, 
11037, 11019, 90447, 90472, 11036
32548, 10678, 89959, 89967, 10686, 10679, 89960, 89968, 10687, 90449, 90473, 90474, 11037, 90452, 90476, 90477, 
11039, 11021, 90450, 90475, 11038
32549, 10679, 89960, 89968, 10687, 10680, 89961, 89969, 10688, 90452, 90476, 90477, 11039, 90455, 90479, 90480, 
11041, 11023, 90453, 90478, 11040
32550, 10680, 89961, 89969, 10688, 10681, 89962, 89970, 10689, 90455, 90479, 90480, 11041, 90458, 90482, 90483, 
11043, 11025, 90456, 90481, 11042
32551, 10681, 89962, 89970, 10689, 10682, 89963, 89971, 10690, 90458, 90482, 90483, 11043, 90461, 90485, 90486, 
11045, 11027, 90459, 90484, 11044
32552, 10682, 89963, 89971, 10690, 1257, 30159, 30160, 1258, 90461, 90485, 90486, 11045, 30200, 30201, 30202, 
1280, 11029, 90462, 90487, 11046
32553, 1203, 30071, 30072, 1204, 10683, 89964, 89972, 10691, 30112, 30115, 30114, 1226, 90465, 90489, 90490, 
11048, 11030, 90463, 90488, 11047
32554, 10683, 89964, 89972, 10691, 10684, 89965, 89973, 10692, 90465, 90489, 90490, 11048, 90468, 90492, 90493, 
11050, 11032, 90466, 90491, 11049
32555, 10684, 89965, 89973, 10692, 10685, 89966, 89974, 10693, 90468, 90492, 90493, 11050, 90471, 90495, 90496, 
11052, 11034, 90469, 90494, 11051
32556, 10685, 89966, 89974, 10693, 10686, 89967, 89975, 10694, 90471, 90495, 90496, 11052, 90474, 90498, 90499, 
11054, 11036, 90472, 90497, 11053
32557, 10686, 89967, 89975, 10694, 10687, 89968, 89976, 10695, 90474, 90498, 90499, 11054, 90477, 90501, 90502, 
11056, 11038, 90475, 90500, 11055
32558, 10687, 89968, 89976, 10695, 10688, 89969, 89977, 10696, 90477, 90501, 90502, 11056, 90480, 90504, 90505, 
11058, 11040, 90478, 90503, 11057
32559, 10688, 89969, 89977, 10696, 10689, 89970, 89978, 10697, 90480, 90504, 90505, 11058, 90483, 90507, 90508, 
11060, 11042, 90481, 90506, 11059
32560, 10689, 89970, 89978, 10697, 10690, 89971, 89979, 10698, 90483, 90507, 90508, 11060, 90486, 90510, 90511, 
11062, 11044, 90484, 90509, 11061
32561, 10690, 89971, 89979, 10698, 1258, 30160, 30161, 1259, 90486, 90510, 90511, 11062, 30202, 30203, 30204, 
1281, 11046, 90487, 90512, 11063
32562, 1204, 30072, 30073, 1205, 10691, 89972, 89980, 10699, 30114, 30117, 30116, 1227, 90490, 90514, 90515, 
11065, 11047, 90488, 90513, 11064
32563, 10691, 89972, 89980, 10699, 10692, 89973, 89981, 10700, 90490, 90514, 90515, 11065, 90493, 90517, 90518, 
11067, 11049, 90491, 90516, 11066
32564, 10692, 89973, 89981, 10700, 10693, 89974, 89982, 10701, 90493, 90517, 90518, 11067, 90496, 90520, 90521, 
11069, 11051, 90494, 90519, 11068
32565, 10693, 89974, 89982, 10701, 10694, 89975, 89983, 10702, 90496, 90520, 90521, 11069, 90499, 90523, 90524, 
11071, 11053, 90497, 90522, 11070
32566, 10694, 89975, 89983, 10702, 10695, 89976, 89984, 10703, 90499, 90523, 90524, 11071, 90502, 90526, 90527, 
11073, 11055, 90500, 90525, 11072
32567, 10695, 89976, 89984, 10703, 10696, 89977, 89985, 10704, 90502, 90526, 90527, 11073, 90505, 90529, 90530, 
11075, 11057, 90503, 90528, 11074
32568, 10696, 89977, 89985, 10704, 10697, 89978, 89986, 10705, 90505, 90529, 90530, 11075, 90508, 90532, 90533, 
11077, 11059, 90506, 90531, 11076
32569, 10697, 89978, 89986, 10705, 10698, 89979, 89987, 10706, 90508, 90532, 90533, 11077, 90511, 90535, 90536, 
11079, 11061, 90509, 90534, 11078
32570, 10698, 89979, 89987, 10706, 1259, 30161, 30162, 1260, 90511, 90535, 90536, 11079, 30204, 30205, 30206, 
1282, 11063, 90512, 90537, 11080
32571, 1205, 30073, 3568, 36, 10699, 89980, 30263, 1308, 30116, 30118, 3569, 1228, 90515, 90538, 30271, 
11081, 11064, 90513, 30272, 1317
32572, 10699, 89980, 30263, 1308, 10700, 89981, 30264, 1307, 90515, 90538, 30271, 11081, 90518, 90539, 30273, 
11082, 11066, 90516, 30274, 1316
32573, 10700, 89981, 30264, 1307, 10701, 89982, 30265, 1306, 90518, 90539, 30273, 11082, 90521, 90540, 30275, 
11083, 11068, 90519, 30276, 1315
32574, 10701, 89982, 30265, 1306, 10702, 89983, 30266, 1305, 90521, 90540, 30275, 11083, 90524, 90541, 30277, 
11084, 11070, 90522, 30278, 1314
32575, 10702, 89983, 30266, 1305, 10703, 89984, 30267, 1304, 90524, 90541, 30277, 11084, 90527, 90542, 30279, 
11085, 11072, 90525, 30280, 1313
32576, 10703, 89984, 30267, 1304, 10704, 89985, 30268, 1303, 90527, 90542, 30279, 11085, 90530, 90543, 30281, 
11086, 11074, 90528, 30282, 1312
32577, 10704, 89985, 30268, 1303, 10705, 89986, 30269, 1302, 90530, 90543, 30281, 11086, 90533, 90544, 30283, 
11087, 11076, 90531, 30284, 1311
32578, 10705, 89986, 30269, 1302, 10706, 89987, 30270, 1301, 90533, 90544, 30283, 11087, 90536, 90545, 30285, 
11088, 11078, 90534, 30286, 1310
32579, 10706, 89987, 30270, 1301, 1260, 30162, 3574, 38, 90536, 90545, 30285, 11088, 30206, 30207, 3575, 
1283, 11080, 90537, 30287, 1309
32580, 3565, 97, 3435, 30052, 30230, 3538, 29494, 89812, 3567, 3457, 30119, 30075, 30255, 29670, 90546, 
89989, 30238, 3547, 29671, 89988
32581, 30230, 3538, 29494, 89812, 30231, 3537, 29495, 89813, 30255, 29670, 90546, 89989, 30256, 29672, 90547, 
89992, 30240, 3546, 29673, 89991
32582, 30231, 3537, 29495, 89813, 30232, 3536, 29496, 89814, 30256, 29672, 90547, 89992, 30257, 29674, 90548, 
89995, 30242, 3545, 29675, 89994
32583, 30232, 3536, 29496, 89814, 30233, 3535, 29497, 89815, 30257, 29674, 90548, 89995, 30258, 29676, 90549, 
89998, 30244, 3544, 29677, 89997
32584, 30233, 3535, 29497, 89815, 30234, 3534, 29498, 89816, 30258, 29676, 90549, 89998, 30259, 29678, 90550, 
90001, 30246, 3543, 29679, 90000
32585, 30234, 3534, 29498, 89816, 30235, 3533, 29499, 89817, 30259, 29678, 90550, 90001, 30260, 29680, 90551, 
90004, 30248, 3542, 29681, 90003
32586, 30235, 3533, 29499, 89817, 30236, 3532, 29500, 89818, 30260, 29680, 90551, 90004, 30261, 29682, 90552, 
90007, 30250, 3541, 29683, 90006
32587, 30236, 3532, 29500, 89818, 30237, 3531, 29501, 89819, 30261, 29682, 90552, 90007, 30262, 29684, 90553, 
90010, 30252, 3540, 29685, 90009
32588, 30237, 3531, 29501, 89819, 3571, 99, 3486, 30141, 30262, 29684, 90553, 90010, 3573, 3508, 30208, 
30163, 30254, 3539, 29686, 90012
32589, 30052, 3435, 3436, 30053, 89812, 29494, 29502, 89820, 30119, 3458, 30120, 30077, 90546, 29687, 90554, 
90014, 89988, 29671, 29688, 90013
32590, 89812, 29494, 29502, 89820, 89813, 29495, 29503, 89821, 90546, 29687, 90554, 90014, 90547, 29689, 90555, 
90017, 89991, 29673, 29690, 90016
32591, 89813, 29495, 29503, 89821, 89814, 29496, 29504, 89822, 90547, 29689, 90555, 90017, 90548, 29691, 90556, 
90020, 89994, 29675, 29692, 90019
32592, 89814, 29496, 29504, 89822, 89815, 29497, 29505, 89823, 90548, 29691, 90556, 90020, 90549, 29693, 90557, 
90023, 89997, 29677, 29694, 90022
32593, 89815, 29497, 29505, 89823, 89816, 29498, 29506, 89824, 90549, 29693, 90557, 90023, 90550, 29695, 90558, 
90026, 90000, 29679, 29696, 90025
32594, 89816, 29498, 29506, 89824, 89817, 29499, 29507, 89825, 90550, 29695, 90558, 90026, 90551, 29697, 90559, 
90029, 90003, 29681, 29698, 90028
32595, 89817, 29499, 29507, 89825, 89818, 29500, 29508, 89826, 90551, 29697, 90559, 90029, 90552, 29699, 90560, 
90032, 90006, 29683, 29700, 90031
32596, 89818, 29500, 29508, 89826, 89819, 29501, 29509, 89827, 90552, 29699, 90560, 90032, 90553, 29701, 90561, 
90035, 90009, 29685, 29702, 90034
32597, 89819, 29501, 29509, 89827, 30141, 3486, 3487, 30142, 90553, 29701, 90561, 90035, 30208, 3509, 30209, 
30165, 90012, 29686, 29703, 90037
32598, 30053, 3436, 3437, 30054, 89820, 29502, 29510, 89828, 30120, 3459, 30121, 30079, 90554, 29704, 90562, 
90039, 90013, 29688, 29705, 90038
32599, 89820, 29502, 29510, 89828, 89821, 29503, 29511, 89829, 90554, 29704, 90562, 90039, 90555, 29706, 90563, 
90042, 90016, 29690, 29707, 90041
32600, 89821, 29503, 29511, 89829, 89822, 29504, 29512, 89830, 90555, 29706, 90563, 90042, 90556, 29708, 90564, 
90045, 90019, 29692, 29709, 90044
32601, 89822, 29504, 29512, 89830, 89823, 29505, 29513, 89831, 90556, 29708, 90564, 90045, 90557, 29710, 90565, 
90048, 90022, 29694, 29711, 90047
32602, 89823, 29505, 29513, 89831, 89824, 29506, 29514, 89832, 90557, 29710, 90565, 90048, 90558, 29712, 90566, 
90051, 90025, 29696, 29713, 90050
32603, 89824, 29506, 29514, 89832, 89825, 29507, 29515, 89833, 90558, 29712, 90566, 90051, 90559, 29714, 90567, 
90054, 90028, 29698, 29715, 90053
32604, 89825, 29507, 29515, 89833, 89826, 29508, 29516, 89834, 90559, 29714, 90567, 90054, 90560, 29716, 90568, 
90057, 90031, 29700, 29717, 90056
32605, 89826, 29508, 29516, 89834, 89827, 29509, 29517, 89835, 90560, 29716, 90568, 90057, 90561, 29718, 90569, 
90060, 90034, 29702, 29719, 90059
32606, 89827, 29509, 29517, 89835, 30142, 3487, 3488, 30143, 90561, 29718, 90569, 90060, 30209, 3510, 30210, 
30167, 90037, 29703, 29720, 90062
32607, 30054, 3437, 3438, 30055, 89828, 29510, 29518, 89836, 30121, 3460, 30122, 30081, 90562, 29721, 90570, 
90064, 90038, 29705, 29722, 90063
32608, 89828, 29510, 29518, 89836, 89829, 29511, 29519, 89837, 90562, 29721, 90570, 90064, 90563, 29723, 90571, 
90067, 90041, 29707, 29724, 90066
32609, 89829, 29511, 29519, 89837, 89830, 29512, 29520, 89838, 90563, 29723, 90571, 90067, 90564, 29725, 90572, 
90070, 90044, 29709, 29726, 90069
32610, 89830, 29512, 29520, 89838, 89831, 29513, 29521, 89839, 90564, 29725, 90572, 90070, 90565, 29727, 90573, 
90073, 90047, 29711, 29728, 90072
32611, 89831, 29513, 29521, 89839, 89832, 29514, 29522, 89840, 90565, 29727, 90573, 90073, 90566, 29729, 90574, 
90076, 90050, 29713, 29730, 90075
32612, 89832, 29514, 29522, 89840, 89833, 29515, 29523, 89841, 90566, 29729, 90574, 90076, 90567, 29731, 90575, 
90079, 90053, 29715, 29732, 90078
32613, 89833, 29515, 29523, 89841, 89834, 29516, 29524, 89842, 90567, 29731, 90575, 90079, 90568, 29733, 90576, 
90082, 90056, 29717, 29734, 90081
32614, 89834, 29516, 29524, 89842, 89835, 29517, 29525, 89843, 90568, 29733, 90576, 90082, 90569, 29735, 90577, 
90085, 90059, 29719, 29736, 90084
32615, 89835, 29517, 29525, 89843, 30143, 3488, 3489, 30144, 90569, 29735, 90577, 90085, 30210, 3511, 30211, 
30169, 90062, 29720, 29737, 90087
32616, 30055, 3438, 3439, 30056, 89836, 29518, 29526, 89844, 30122, 3461, 30123, 30083, 90570, 29738, 90578, 
90089, 90063, 29722, 29739, 90088
32617, 89836, 29518, 29526, 89844, 89837, 29519, 29527, 89845, 90570, 29738, 90578, 90089, 90571, 29740, 90579, 
90092, 90066, 29724, 29741, 90091
32618, 89837, 29519, 29527, 89845, 89838, 29520, 29528, 89846, 90571, 29740, 90579, 90092, 90572, 29742, 90580, 
90095, 90069, 29726, 29743, 90094
32619, 89838, 29520, 29528, 89846, 89839, 29521, 29529, 89847, 90572, 29742, 90580, 90095, 90573, 29744, 90581, 
90098, 90072, 29728, 29745, 90097
32620, 89839, 29521, 29529, 89847, 89840, 29522, 29530, 89848, 90573, 29744, 90581, 90098, 90574, 29746, 90582, 
90101, 90075, 29730, 29747, 90100
32621, 89840, 29522, 29530, 89848, 89841, 29523, 29531, 89849, 90574, 29746, 90582, 90101, 90575, 29748, 90583, 
90104, 90078, 29732, 29749, 90103
32622, 89841, 29523, 29531, 89849, 89842, 29524, 29532, 89850, 90575, 29748, 90583, 90104, 90576, 29750, 90584, 
90107, 90081, 29734, 29751, 90106
32623, 89842, 29524, 29532, 89850, 89843, 29525, 29533, 89851, 90576, 29750, 90584, 90107, 90577, 29752, 90585, 
90110, 90084, 29736, 29753, 90109
32624, 89843, 29525, 29533, 89851, 30144, 3489, 3490, 30145, 90577, 29752, 90585, 90110, 30211, 3512, 30212, 
30171, 90087, 29737, 29754, 90112
32625, 30056, 3439, 3440, 30057, 89844, 29526, 29534, 89852, 30123, 3462, 30124, 30085, 90578, 29755, 90586, 
90114, 90088, 29739, 29756, 90113
32626, 89844, 29526, 29534, 89852, 89845, 29527, 29535, 89853, 90578, 29755, 90586, 90114, 90579, 29757, 90587, 
90117, 90091, 29741, 29758, 90116
32627, 89845, 29527, 29535, 89853, 89846, 29528, 29536, 89854, 90579, 29757, 90587, 90117, 90580, 29759, 90588, 
90120, 90094, 29743, 29760, 90119
32628, 89846, 29528, 29536, 89854, 89847, 29529, 29537, 89855, 90580, 29759, 90588, 90120, 90581, 29761, 90589, 
90123, 90097, 29745, 29762, 90122
32629, 89847, 29529, 29537, 89855, 89848, 29530, 29538, 89856, 90581, 29761, 90589, 90123, 90582, 29763, 90590, 
90126, 90100, 29747, 29764, 90125
32630, 89848, 29530, 29538, 89856, 89849, 29531, 29539, 89857, 90582, 29763, 90590, 90126, 90583, 29765, 90591, 
90129, 90103, 29749, 29766, 90128
32631, 89849, 29531, 29539, 89857, 89850, 29532, 29540, 89858, 90583, 29765, 90591, 90129, 90584, 29767, 90592, 
90132, 90106, 29751, 29768, 90131
32632, 89850, 29532, 29540, 89858, 89851, 29533, 29541, 89859, 90584, 29767, 90592, 90132, 90585, 29769, 90593, 
90135, 90109, 29753, 29770, 90134
32633, 89851, 29533, 29541, 89859, 30145, 3490, 3491, 30146, 90585, 29769, 90593, 90135, 30212, 3513, 30213, 
30173, 90112, 29754, 29771, 90137
32634, 30057, 3440, 3441, 30058, 89852, 29534, 29542, 89860, 30124, 3463, 30125, 30087, 90586, 29772, 90594, 
90139, 90113, 29756, 29773, 90138
32635, 89852, 29534, 29542, 89860, 89853, 29535, 29543, 89861, 90586, 29772, 90594, 90139, 90587, 29774, 90595, 
90142, 90116, 29758, 29775, 90141
32636, 89853, 29535, 29543, 89861, 89854, 29536, 29544, 89862, 90587, 29774, 90595, 90142, 90588, 29776, 90596, 
90145, 90119, 29760, 29777, 90144
32637, 89854, 29536, 29544, 89862, 89855, 29537, 29545, 89863, 90588, 29776, 90596, 90145, 90589, 29778, 90597, 
90148, 90122, 29762, 29779, 90147
32638, 89855, 29537, 29545, 89863, 89856, 29538, 29546, 89864, 90589, 29778, 90597, 90148, 90590, 29780, 90598, 
90151, 90125, 29764, 29781, 90150
32639, 89856, 29538, 29546, 89864, 89857, 29539, 29547, 89865, 90590, 29780, 90598, 90151, 90591, 29782, 90599, 
90154, 90128, 29766, 29783, 90153
32640, 89857, 29539, 29547, 89865, 89858, 29540, 29548, 89866, 90591, 29782, 90599, 90154, 90592, 29784, 90600, 
90157, 90131, 29768, 29785, 90156
32641, 89858, 29540, 29548, 89866, 89859, 29541, 29549, 89867, 90592, 29784, 90600, 90157, 90593, 29786, 90601, 
90160, 90134, 29770, 29787, 90159
32642, 89859, 29541, 29549, 89867, 30146, 3491, 3492, 30147, 90593, 29786, 90601, 90160, 30213, 3514, 30214, 
30175, 90137, 29771, 29788, 90162
32643, 30058, 3441, 3442, 30059, 89860, 29542, 29550, 89868, 30125, 3464, 30126, 30089, 90594, 29789, 90602, 
90164, 90138, 29773, 29790, 90163
32644, 89860, 29542, 29550, 89868, 89861, 29543, 29551, 89869, 90594, 29789, 90602, 90164, 90595, 29791, 90603, 
90167, 90141, 29775, 29792, 90166
32645, 89861, 29543, 29551, 89869, 89862, 29544, 29552, 89870, 90595, 29791, 90603, 90167, 90596, 29793, 90604, 
90170, 90144, 29777, 29794, 90169
32646, 89862, 29544, 29552, 89870, 89863, 29545, 29553, 89871, 90596, 29793, 90604, 90170, 90597, 29795, 90605, 
90173, 90147, 29779, 29796, 90172
32647, 89863, 29545, 29553, 89871, 89864, 29546, 29554, 89872, 90597, 29795, 90605, 90173, 90598, 29797, 90606, 
90176, 90150, 29781, 29798, 90175
32648, 89864, 29546, 29554, 89872, 89865, 29547, 29555, 89873, 90598, 29797, 90606, 90176, 90599, 29799, 90607, 
90179, 90153, 29783, 29800, 90178
32649, 89865, 29547, 29555, 89873, 89866, 29548, 29556, 89874, 90599, 29799, 90607, 90179, 90600, 29801, 90608, 
90182, 90156, 29785, 29802, 90181
32650, 89866, 29548, 29556, 89874, 89867, 29549, 29557, 89875, 90600, 29801, 90608, 90182, 90601, 29803, 90609, 
90185, 90159, 29787, 29804, 90184
32651, 89867, 29549, 29557, 89875, 30147, 3492, 3493, 30148, 90601, 29803, 90609, 90185, 30214, 3515, 30215, 
30177, 90162, 29788, 29805, 90187
32652, 30059, 3442, 3443, 30060, 89868, 29550, 29558, 89876, 30126, 3465, 30127, 30091, 90602, 29806, 90610, 
90189, 90163, 29790, 29807, 90188
32653, 89868, 29550, 29558, 89876, 89869, 29551, 29559, 89877, 90602, 29806, 90610, 90189, 90603, 29808, 90611, 
90192, 90166, 29792, 29809, 90191
32654, 89869, 29551, 29559, 89877, 89870, 29552, 29560, 89878, 90603, 29808, 90611, 90192, 90604, 29810, 90612, 
90195, 90169, 29794, 29811, 90194
32655, 89870, 29552, 29560, 89878, 89871, 29553, 29561, 89879, 90604, 29810, 90612, 90195, 90605, 29812, 90613, 
90198, 90172, 29796, 29813, 90197
32656, 89871, 29553, 29561, 89879, 89872, 29554, 29562, 89880, 90605, 29812, 90613, 90198, 90606, 29814, 90614, 
90201, 90175, 29798, 29815, 90200
32657, 89872, 29554, 29562, 89880, 89873, 29555, 29563, 89881, 90606, 29814, 90614, 90201, 90607, 29816, 90615, 
90204, 90178, 29800, 29817, 90203
32658, 89873, 29555, 29563, 89881, 89874, 29556, 29564, 89882, 90607, 29816, 90615, 90204, 90608, 29818, 90616, 
90207, 90181, 29802, 29819, 90206
32659, 89874, 29556, 29564, 89882, 89875, 29557, 29565, 89883, 90608, 29818, 90616, 90207, 90609, 29820, 90617, 
90210, 90184, 29804, 29821, 90209
32660, 89875, 29557, 29565, 89883, 30148, 3493, 3494, 30149, 90609, 29820, 90617, 90210, 30215, 3516, 30216, 
30179, 90187, 29805, 29822, 90212
32661, 30060, 3443, 3444, 30061, 89876, 29558, 29566, 89884, 30127, 3466, 30128, 30093, 90610, 29823, 90618, 
90214, 90188, 29807, 29824, 90213
32662, 89876, 29558, 29566, 89884, 89877, 29559, 29567, 89885, 90610, 29823, 90618, 90214, 90611, 29825, 90619, 
90217, 90191, 29809, 29826, 90216
32663, 89877, 29559, 29567, 89885, 89878, 29560, 29568, 89886, 90611, 29825, 90619, 90217, 90612, 29827, 90620, 
90220, 90194, 29811, 29828, 90219
32664, 89878, 29560, 29568, 89886, 89879, 29561, 29569, 89887, 90612, 29827, 90620, 90220, 90613, 29829, 90621, 
90223, 90197, 29813, 29830, 90222
32665, 89879, 29561, 29569, 89887, 89880, 29562, 29570, 89888, 90613, 29829, 90621, 90223, 90614, 29831, 90622, 
90226, 90200, 29815, 29832, 90225
32666, 89880, 29562, 29570, 89888, 89881, 29563, 29571, 89889, 90614, 29831, 90622, 90226, 90615, 29833, 90623, 
90229, 90203, 29817, 29834, 90228
32667, 89881, 29563, 29571, 89889, 89882, 29564, 29572, 89890, 90615, 29833, 90623, 90229, 90616, 29835, 90624, 
90232, 90206, 29819, 29836, 90231
32668, 89882, 29564, 29572, 89890, 89883, 29565, 29573, 89891, 90616, 29835, 90624, 90232, 90617, 29837, 90625, 
90235, 90209, 29821, 29838, 90234
32669, 89883, 29565, 29573, 89891, 30149, 3494, 3495, 30150, 90617, 29837, 90625, 90235, 30216, 3517, 30217, 
30181, 90212, 29822, 29839, 90237
32670, 30061, 3444, 3445, 30062, 89884, 29566, 29574, 89892, 30128, 3467, 30129, 30095, 90618, 29840, 90626, 
90239, 90213, 29824, 29841, 90238
32671, 89884, 29566, 29574, 89892, 89885, 29567, 29575, 89893, 90618, 29840, 90626, 90239, 90619, 29842, 90627, 
90242, 90216, 29826, 29843, 90241
32672, 89885, 29567, 29575, 89893, 89886, 29568, 29576, 89894, 90619, 29842, 90627, 90242, 90620, 29844, 90628, 
90245, 90219, 29828, 29845, 90244
32673, 89886, 29568, 29576, 89894, 89887, 29569, 29577, 89895, 90620, 29844, 90628, 90245, 90621, 29846, 90629, 
90248, 90222, 29830, 29847, 90247
32674, 89887, 29569, 29577, 89895, 89888, 29570, 29578, 89896, 90621, 29846, 90629, 90248, 90622, 29848, 90630, 
90251, 90225, 29832, 29849, 90250
32675, 89888, 29570, 29578, 89896, 89889, 29571, 29579, 89897, 90622, 29848, 90630, 90251, 90623, 29850, 90631, 
90254, 90228, 29834, 29851, 90253
32676, 89889, 29571, 29579, 89897, 89890, 29572, 29580, 89898, 90623, 29850, 90631, 90254, 90624, 29852, 90632, 
90257, 90231, 29836, 29853, 90256
32677, 89890, 29572, 29580, 89898, 89891, 29573, 29581, 89899, 90624, 29852, 90632, 90257, 90625, 29854, 90633, 
90260, 90234, 29838, 29855, 90259
32678, 89891, 29573, 29581, 89899, 30150, 3495, 3496, 30151, 90625, 29854, 90633, 90260, 30217, 3518, 30218, 
30183, 90237, 29839, 29856, 90262
32679, 30062, 3445, 3446, 30063, 89892, 29574, 29582, 89900, 30129, 3468, 30130, 30097, 90626, 29857, 90634, 
90264, 90238, 29841, 29858, 90263
32680, 89892, 29574, 29582, 89900, 89893, 29575, 29583, 89901, 90626, 29857, 90634, 90264, 90627, 29859, 90635, 
90267, 90241, 29843, 29860, 90266
32681, 89893, 29575, 29583, 89901, 89894, 29576, 29584, 89902, 90627, 29859, 90635, 90267, 90628, 29861, 90636, 
90270, 90244, 29845, 29862, 90269
32682, 89894, 29576, 29584, 89902, 89895, 29577, 29585, 89903, 90628, 29861, 90636, 90270, 90629, 29863, 90637, 
90273, 90247, 29847, 29864, 90272
32683, 89895, 29577, 29585, 89903, 89896, 29578, 29586, 89904, 90629, 29863, 90637, 90273, 90630, 29865, 90638, 
90276, 90250, 29849, 29866, 90275
32684, 89896, 29578, 29586, 89904, 89897, 29579, 29587, 89905, 90630, 29865, 90638, 90276, 90631, 29867, 90639, 
90279, 90253, 29851, 29868, 90278
32685, 89897, 29579, 29587, 89905, 89898, 29580, 29588, 89906, 90631, 29867, 90639, 90279, 90632, 29869, 90640, 
90282, 90256, 29853, 29870, 90281
32686, 89898, 29580, 29588, 89906, 89899, 29581, 29589, 89907, 90632, 29869, 90640, 90282, 90633, 29871, 90641, 
90285, 90259, 29855, 29872, 90284
32687, 89899, 29581, 29589, 89907, 30151, 3496, 3497, 30152, 90633, 29871, 90641, 90285, 30218, 3519, 30219, 
30185, 90262, 29856, 29873, 90287
32688, 30063, 3446, 3447, 30064, 89900, 29582, 29590, 89908, 30130, 3469, 30131, 30099, 90634, 29874, 90642, 
90289, 90263, 29858, 29875, 90288
32689, 89900, 29582, 29590, 89908, 89901, 29583, 29591, 89909, 90634, 29874, 90642, 90289, 90635, 29876, 90643, 
90292, 90266, 29860, 29877, 90291
32690, 89901, 29583, 29591, 89909, 89902, 29584, 29592, 89910, 90635, 29876, 90643, 90292, 90636, 29878, 90644, 
90295, 90269, 29862, 29879, 90294
32691, 89902, 29584, 29592, 89910, 89903, 29585, 29593, 89911, 90636, 29878, 90644, 90295, 90637, 29880, 90645, 
90298, 90272, 29864, 29881, 90297
32692, 89903, 29585, 29593, 89911, 89904, 29586, 29594, 89912, 90637, 29880, 90645, 90298, 90638, 29882, 90646, 
90301, 90275, 29866, 29883, 90300
32693, 89904, 29586, 29594, 89912, 89905, 29587, 29595, 89913, 90638, 29882, 90646, 90301, 90639, 29884, 90647, 
90304, 90278, 29868, 29885, 90303
32694, 89905, 29587, 29595, 89913, 89906, 29588, 29596, 89914, 90639, 29884, 90647, 90304, 90640, 29886, 90648, 
90307, 90281, 29870, 29887, 90306
32695, 89906, 29588, 29596, 89914, 89907, 29589, 29597, 89915, 90640, 29886, 90648, 90307, 90641, 29888, 90649, 
90310, 90284, 29872, 29889, 90309
32696, 89907, 29589, 29597, 89915, 30152, 3497, 3498, 30153, 90641, 29888, 90649, 90310, 30219, 3520, 30220, 
30187, 90287, 29873, 29890, 90312
32697, 30064, 3447, 3448, 30065, 89908, 29590, 29598, 89916, 30131, 3470, 30132, 30101, 90642, 29891, 90650, 
90314, 90288, 29875, 29892, 90313
32698, 89908, 29590, 29598, 89916, 89909, 29591, 29599, 89917, 90642, 29891, 90650, 90314, 90643, 29893, 90651, 
90317, 90291, 29877, 29894, 90316
32699, 89909, 29591, 29599, 89917, 89910, 29592, 29600, 89918, 90643, 29893, 90651, 90317, 90644, 29895, 90652, 
90320, 90294, 29879, 29896, 90319
32700, 89910, 29592, 29600, 89918, 89911, 29593, 29601, 89919, 90644, 29895, 90652, 90320, 90645, 29897, 90653, 
90323, 90297, 29881, 29898, 90322
32701, 89911, 29593, 29601, 89919, 89912, 29594, 29602, 89920, 90645, 29897, 90653, 90323, 90646, 29899, 90654, 
90326, 90300, 29883, 29900, 90325
32702, 89912, 29594, 29602, 89920, 89913, 29595, 29603, 89921, 90646, 29899, 90654, 90326, 90647, 29901, 90655, 
90329, 90303, 29885, 29902, 90328
32703, 89913, 29595, 29603, 89921, 89914, 29596, 29604, 89922, 90647, 29901, 90655, 90329, 90648, 29903, 90656, 
90332, 90306, 29887, 29904, 90331
32704, 89914, 29596, 29604, 89922, 89915, 29597, 29605, 89923, 90648, 29903, 90656, 90332, 90649, 29905, 90657, 
90335, 90309, 29889, 29906, 90334
32705, 89915, 29597, 29605, 89923, 30153, 3498, 3499, 30154, 90649, 29905, 90657, 90335, 30220, 3521, 30221, 
30189, 90312, 29890, 29907, 90337
32706, 30065, 3448, 3449, 30066, 89916, 29598, 29606, 89924, 30132, 3471, 30133, 30103, 90650, 29908, 90658, 
90339, 90313, 29892, 29909, 90338
32707, 89916, 29598, 29606, 89924, 89917, 29599, 29607, 89925, 90650, 29908, 90658, 90339, 90651, 29910, 90659, 
90342, 90316, 29894, 29911, 90341
32708, 89917, 29599, 29607, 89925, 89918, 29600, 29608, 89926, 90651, 29910, 90659, 90342, 90652, 29912, 90660, 
90345, 90319, 29896, 29913, 90344
32709, 89918, 29600, 29608, 89926, 89919, 29601, 29609, 89927, 90652, 29912, 90660, 90345, 90653, 29914, 90661, 
90348, 90322, 29898, 29915, 90347
32710, 89919, 29601, 29609, 89927, 89920, 29602, 29610, 89928, 90653, 29914, 90661, 90348, 90654, 29916, 90662, 
90351, 90325, 29900, 29917, 90350
32711, 89920, 29602, 29610, 89928, 89921, 29603, 29611, 89929, 90654, 29916, 90662, 90351, 90655, 29918, 90663, 
90354, 90328, 29902, 29919, 90353
32712, 89921, 29603, 29611, 89929, 89922, 29604, 29612, 89930, 90655, 29918, 90663, 90354, 90656, 29920, 90664, 
90357, 90331, 29904, 29921, 90356
32713, 89922, 29604, 29612, 89930, 89923, 29605, 29613, 89931, 90656, 29920, 90664, 90357, 90657, 29922, 90665, 
90360, 90334, 29906, 29923, 90359
32714, 89923, 29605, 29613, 89931, 30154, 3499, 3500, 30155, 90657, 29922, 90665, 90360, 30221, 3522, 30222, 
30191, 90337, 29907, 29924, 90362
32715, 30066, 3449, 3450, 30067, 89924, 29606, 29614, 89932, 30133, 3472, 30134, 30105, 90658, 29925, 90666, 
90364, 90338, 29909, 29926, 90363
