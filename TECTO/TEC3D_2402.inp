10192, 24117, 24118, 24126, 24125, 24398, 24414, 24415, 24412
10193, 24118, 24119, 24127, 24126, 24400, 24416, 24417, 24414
10194, 24119, 24120, 24128, 24127, 24402, 24418, 24419, 24416
10195, 24120, 24121, 24129, 24128, 24404, 24420, 24421, 24418
10196, 24121, 3074, 3075, 24129, 24405, 3097, 24422, 24420
10197, 2923, 24122, 24130, 2924, 24407, 24423, 24424, 2946
10198, 24122, 24123, 24131, 24130, 24409, 24425, 24426, 24423
10199, 24123, 24124, 24132, 24131, 24411, 24427, 24428, 24425
10200, 24124, 24125, 24133, 24132, 24413, 24429, 24430, 24427
10201, 24125, 24126, 24134, 24133, 24415, 24431, 24432, 24429
10202, 24126, 24127, 24135, 24134, 24417, 24433, 24434, 24431
10203, 24127, 24128, 24136, 24135, 24419, 24435, 24436, 24433
10204, 24128, 24129, 24137, 24136, 24421, 24437, 24438, 24435
10205, 24129, 3075, 3076, 24137, 24422, 3098, 24439, 24437
10206, 2924, 24130, 24138, 2925, 24424, 24440, 24441, 2947
10207, 24130, 24131, 24139, 24138, 24426, 24442, 24443, 24440
10208, 24131, 24132, 24140, 24139, 24428, 24444, 24445, 24442
10209, 24132, 24133, 24141, 24140, 24430, 24446, 24447, 24444
10210, 24133, 24134, 24142, 24141, 24432, 24448, 24449, 24446
10211, 24134, 24135, 24143, 24142, 24434, 24450, 24451, 24448
10212, 24135, 24136, 24144, 24143, 24436, 24452, 24453, 24450
10213, 24136, 24137, 24145, 24144, 24438, 24454, 24455, 24452
10214, 24137, 3076, 3077, 24145, 24439, 3099, 24456, 24454
10215, 2925, 24138, 24146, 2926, 24441, 24457, 24458, 2948
10216, 24138, 24139, 24147, 24146, 24443, 24459, 24460, 24457
10217, 24139, 24140, 24148, 24147, 24445, 24461, 24462, 24459
10218, 24140, 24141, 24149, 24148, 24447, 24463, 24464, 24461
10219, 24141, 24142, 24150, 24149, 24449, 24465, 24466, 24463
10220, 24142, 24143, 24151, 24150, 24451, 24467, 24468, 24465
10221, 24143, 24144, 24152, 24151, 24453, 24469, 24470, 24467
10222, 24144, 24145, 24153, 24152, 24455, 24471, 24472, 24469
10223, 24145, 3077, 3078, 24153, 24456, 3100, 24473, 24471
10224, 2926, 24146, 24154, 2927, 24458, 24474, 24475, 2949
10225, 24146, 24147, 24155, 24154, 24460, 24476, 24477, 24474
10226, 24147, 24148, 24156, 24155, 24462, 24478, 24479, 24476
10227, 24148, 24149, 24157, 24156, 24464, 24480, 24481, 24478
10228, 24149, 24150, 24158, 24157, 24466, 24482, 24483, 24480
10229, 24150, 24151, 24159, 24158, 24468, 24484, 24485, 24482
10230, 24151, 24152, 24160, 24159, 24470, 24486, 24487, 24484
10231, 24152, 24153, 24161, 24160, 24472, 24488, 24489, 24486
10232, 24153, 3078, 3079, 24161, 24473, 3101, 24490, 24488
10233, 2927, 24154, 24162, 2928, 24475, 24491, 24492, 2950
10234, 24154, 24155, 24163, 24162, 24477, 24493, 24494, 24491
10235, 24155, 24156, 24164, 24163, 24479, 24495, 24496, 24493
10236, 24156, 24157, 24165, 24164, 24481, 24497, 24498, 24495
10237, 24157, 24158, 24166, 24165, 24483, 24499, 24500, 24497
10238, 24158, 24159, 24167, 24166, 24485, 24501, 24502, 24499
10239, 24159, 24160, 24168, 24167, 24487, 24503, 24504, 24501
10240, 24160, 24161, 24169, 24168, 24489, 24505, 24506, 24503
10241, 24161, 3079, 3080, 24169, 24490, 3102, 24507, 24505
10242, 2928, 24162, 24170, 2929, 24492, 24508, 24509, 2951
10243, 24162, 24163, 24171, 24170, 24494, 24510, 24511, 24508
10244, 24163, 24164, 24172, 24171, 24496, 24512, 24513, 24510
10245, 24164, 24165, 24173, 24172, 24498, 24514, 24515, 24512
10246, 24165, 24166, 24174, 24173, 24500, 24516, 24517, 24514
10247, 24166, 24167, 24175, 24174, 24502, 24518, 24519, 24516
10248, 24167, 24168, 24176, 24175, 24504, 24520, 24521, 24518
10249, 24168, 24169, 24177, 24176, 24506, 24522, 24523, 24520
10250, 24169, 3080, 3081, 24177, 24507, 3103, 24524, 24522
10251, 2929, 24170, 24178, 2930, 24509, 24525, 24526, 2952
10252, 24170, 24171, 24179, 24178, 24511, 24527, 24528, 24525
10253, 24171, 24172, 24180, 24179, 24513, 24529, 24530, 24527
10254, 24172, 24173, 24181, 24180, 24515, 24531, 24532, 24529
10255, 24173, 24174, 24182, 24181, 24517, 24533, 24534, 24531
10256, 24174, 24175, 24183, 24182, 24519, 24535, 24536, 24533
10257, 24175, 24176, 24184, 24183, 24521, 24537, 24538, 24535
10258, 24176, 24177, 24185, 24184, 24523, 24539, 24540, 24537
10259, 24177, 3081, 3082, 24185, 24524, 3104, 24541, 24539
10260, 2930, 24178, 24186, 2931, 24526, 24542, 24543, 2953
10261, 24178, 24179, 24187, 24186, 24528, 24544, 24545, 24542
10262, 24179, 24180, 24188, 24187, 24530, 24546, 24547, 24544
10263, 24180, 24181, 24189, 24188, 24532, 24548, 24549, 24546
10264, 24181, 24182, 24190, 24189, 24534, 24550, 24551, 24548
10265, 24182, 24183, 24191, 24190, 24536, 24552, 24553, 24550
10266, 24183, 24184, 24192, 24191, 24538, 24554, 24555, 24552
10267, 24184, 24185, 24193, 24192, 24540, 24556, 24557, 24554
10268, 24185, 3082, 3083, 24193, 24541, 3105, 24558, 24556
10269, 2931, 24186, 24194, 2932, 24543, 24559, 24560, 2954
10270, 24186, 24187, 24195, 24194, 24545, 24561, 24562, 24559
10271, 24187, 24188, 24196, 24195, 24547, 24563, 24564, 24561
10272, 24188, 24189, 24197, 24196, 24549, 24565, 24566, 24563
10273, 24189, 24190, 24198, 24197, 24551, 24567, 24568, 24565
10274, 24190, 24191, 24199, 24198, 24553, 24569, 24570, 24567
10275, 24191, 24192, 24200, 24199, 24555, 24571, 24572, 24569
10276, 24192, 24193, 24201, 24200, 24557, 24573, 24574, 24571
10277, 24193, 3083, 3084, 24201, 24558, 3106, 24575, 24573
10278, 2932, 24194, 3001, 89, 24560, 24576, 3009, 2955
10279, 24194, 24195, 3002, 3001, 24562, 24577, 3010, 24576
10280, 24195, 24196, 3003, 3002, 24564, 24578, 3011, 24577
10281, 24196, 24197, 3004, 3003, 24566, 24579, 3012, 24578
10282, 24197, 24198, 3005, 3004, 24568, 24580, 3013, 24579
10283, 24198, 24199, 3006, 3005, 24570, 24581, 3014, 24580
10284, 24199, 24200, 3007, 3006, 24572, 24582, 3015, 24581
10285, 24200, 24201, 3008, 3007, 24574, 24583, 3016, 24582
10286, 24201, 3084, 91, 3008, 24575, 3107, 3017, 24583
*ELEMENT, type=CPS8, ELSET=Surface265
10287, 93, 3125, 24584, 3215, 3147, 25068, 25069, 3237
10288, 3215, 24584, 24585, 3216, 25069, 25070, 25071, 3238
10289, 3216, 24585, 24586, 3217, 25071, 25072, 25073, 3239
10290, 3217, 24586, 24587, 3218, 25073, 25074, 25075, 3240
10291, 3218, 24587, 24588, 3219, 25075, 25076, 25077, 3241
10292, 3219, 24588, 24589, 3220, 25077, 25078, 25079, 3242
10293, 3220, 24589, 24590, 3221, 25079, 25080, 25081, 3243
10294, 3221, 24590, 24591, 3222, 25081, 25082, 25083, 3244
10295, 3222, 24591, 24592, 3223, 25083, 25084, 25085, 3245
10296, 3223, 24592, 24593, 3224, 25085, 25086, 25087, 3246
10297, 3224, 24593, 24594, 3225, 25087, 25088, 25089, 3247
10298, 3225, 24594, 24595, 3226, 25089, 25090, 25091, 3248
10299, 3226, 24595, 24596, 3227, 25091, 25092, 25093, 3249
10300, 3227, 24596, 24597, 3228, 25093, 25094, 25095, 3250
10301, 3228, 24597, 24598, 3229, 25095, 25096, 25097, 3251
10302, 3229, 24598, 24599, 3230, 25097, 25098, 25099, 3252
10303, 3230, 24599, 24600, 3231, 25099, 25100, 25101, 3253
10304, 3231, 24600, 24601, 3232, 25101, 25102, 25103, 3254
10305, 3232, 24601, 24602, 3233, 25103, 25104, 25105, 3255
10306, 3233, 24602, 24603, 3234, 25105, 25106, 25107, 3256
10307, 3234, 24603, 24604, 3235, 25107, 25108, 25109, 3257
10308, 3235, 24604, 24605, 3236, 25109, 25110, 25111, 3258
10309, 3236, 24605, 3170, 94, 25111, 25112, 3192, 3259
10310, 3125, 3126, 24606, 24584, 3148, 25113, 25114, 25068
10311, 24584, 24606, 24607, 24585, 25114, 25115, 25116, 25070
10312, 24585, 24607, 24608, 24586, 25116, 25117, 25118, 25072
10313, 24586, 24608, 24609, 24587, 25118, 25119, 25120, 25074
10314, 24587, 24609, 24610, 24588, 25120, 25121, 25122, 25076
10315, 24588, 24610, 24611, 24589, 25122, 25123, 25124, 25078
10316, 24589, 24611, 24612, 24590, 25124, 25125, 25126, 25080
10317, 24590, 24612, 24613, 24591, 25126, 25127, 25128, 25082
10318, 24591, 24613, 24614, 24592, 25128, 25129, 25130, 25084
10319, 24592, 24614, 24615, 24593, 25130, 25131, 25132, 25086
10320, 24593, 24615, 24616, 24594, 25132, 25133, 25134, 25088
10321, 24594, 24616, 24617, 24595, 25134, 25135, 25136, 25090
10322, 24595, 24617, 24618, 24596, 25136, 25137, 25138, 25092
10323, 24596, 24618, 24619, 24597, 25138, 25139, 25140, 25094
10324, 24597, 24619, 24620, 24598, 25140, 25141, 25142, 25096
10325, 24598, 24620, 24621, 24599, 25142, 25143, 25144, 25098
10326, 24599, 24621, 24622, 24600, 25144, 25145, 25146, 25100
10327, 24600, 24622, 24623, 24601, 25146, 25147, 25148, 25102
10328, 24601, 24623, 24624, 24602, 25148, 25149, 25150, 25104
10329, 24602, 24624, 24625, 24603, 25150, 25151, 25152, 25106
10330, 24603, 24625, 24626, 24604, 25152, 25153, 25154, 25108
10331, 24604, 24626, 24627, 24605, 25154, 25155, 25156, 25110
10332, 24605, 24627, 3171, 3170, 25156, 25157, 3193, 25112
10333, 3126, 3127, 24628, 24606, 3149, 25158, 25159, 25113
10334, 24606, 24628, 24629, 24607, 25159, 25160, 25161, 25115
10335, 24607, 24629, 24630, 24608, 25161, 25162, 25163, 25117
10336, 24608, 24630, 24631, 24609, 25163, 25164, 25165, 25119
10337, 24609, 24631, 24632, 24610, 25165, 25166, 25167, 25121
10338, 24610, 24632, 24633, 24611, 25167, 25168, 25169, 25123
10339, 24611, 24633, 24634, 24612, 25169, 25170, 25171, 25125
10340, 24612, 24634, 24635, 24613, 25171, 25172, 25173, 25127
10341, 24613, 24635, 24636, 24614, 25173, 25174, 25175, 25129
10342, 24614, 24636, 24637, 24615, 25175, 25176, 25177, 25131
10343, 24615, 24637, 24638, 24616, 25177, 25178, 25179, 25133
10344, 24616, 24638, 24639, 24617, 25179, 25180, 25181, 25135
10345, 24617, 24639, 24640, 24618, 25181, 25182, 25183, 25137
10346, 24618, 24640, 24641, 24619, 25183, 25184, 25185, 25139
10347, 24619, 24641, 24642, 24620, 25185, 25186, 25187, 25141
10348, 24620, 24642, 24643, 24621, 25187, 25188, 25189, 25143
10349, 24621, 24643, 24644, 24622, 25189, 25190, 25191, 25145
10350, 24622, 24644, 24645, 24623, 25191, 25192, 25193, 25147
10351, 24623, 24645, 24646, 24624, 25193, 25194, 25195, 25149
10352, 24624, 24646, 24647, 24625, 25195, 25196, 25197, 25151
10353, 24625, 24647, 24648, 24626, 25197, 25198, 25199, 25153
10354, 24626, 24648, 24649, 24627, 25199, 25200, 25201, 25155
10355, 24627, 24649, 3172, 3171, 25201, 25202, 3194, 25157
10356, 3127, 3128, 24650, 24628, 3150, 25203, 25204, 25158
10357, 24628, 24650, 24651, 24629, 25204, 25205, 25206, 25160
10358, 24629, 24651, 24652, 24630, 25206, 25207, 25208, 25162
10359, 24630, 24652, 24653, 24631, 25208, 25209, 25210, 25164
10360, 24631, 24653, 24654, 24632, 25210, 25211, 25212, 25166
10361, 24632, 24654, 24655, 24633, 25212, 25213, 25214, 25168
10362, 24633, 24655, 24656, 24634, 25214, 25215, 25216, 25170
10363, 24634, 24656, 24657, 24635, 25216, 25217, 25218, 25172
10364, 24635, 24657, 24658, 24636, 25218, 25219, 25220, 25174
10365, 24636, 24658, 24659, 24637, 25220, 25221, 25222, 25176
10366, 24637, 24659, 24660, 24638, 25222, 25223, 25224, 25178
10367, 24638, 24660, 24661, 24639, 25224, 25225, 25226, 25180
10368, 24639, 24661, 24662, 24640, 25226, 25227, 25228, 25182
10369, 24640, 24662, 24663, 24641, 25228, 25229, 25230, 25184
10370, 24641, 24663, 24664, 24642, 25230, 25231, 25232, 25186
10371, 24642, 24664, 24665, 24643, 25232, 25233, 25234, 25188
10372, 24643, 24665, 24666, 24644, 25234, 25235, 25236, 25190
10373, 24644, 24666, 24667, 24645, 25236, 25237, 25238, 25192
10374, 24645, 24667, 24668, 24646, 25238, 25239, 25240, 25194
10375, 24646, 24668, 24669, 24647, 25240, 25241, 25242, 25196
10376, 24647, 24669, 24670, 24648, 25242, 25243, 25244, 25198
10377, 24648, 24670, 24671, 24649, 25244, 25245, 25246, 25200
10378, 24649, 24671, 3173, 3172, 25246, 25247, 3195, 25202
10379, 3128, 3129, 24672, 24650, 3151, 25248, 25249, 25203
10380, 24650, 24672, 24673, 24651, 25249, 25250, 25251, 25205
10381, 24651, 24673, 24674, 24652, 25251, 25252, 25253, 25207
10382, 24652, 24674, 24675, 24653, 25253, 25254, 25255, 25209
10383, 24653, 24675, 24676, 24654, 25255, 25256, 25257, 25211
10384, 24654, 24676, 24677, 24655, 25257, 25258, 25259, 25213
10385, 24655, 24677, 24678, 24656, 25259, 25260, 25261, 25215
10386, 24656, 24678, 24679, 24657, 25261, 25262, 25263, 25217
10387, 24657, 24679, 24680, 24658, 25263, 25264, 25265, 25219
10388, 24658, 24680, 24681, 24659, 25265, 25266, 25267, 25221
10389, 24659, 24681, 24682, 24660, 25267, 25268, 25269, 25223
10390, 24660, 24682, 24683, 24661, 25269, 25270, 25271, 25225
10391, 24661, 24683, 24684, 24662, 25271, 25272, 25273, 25227
10392, 24662, 24684, 24685, 24663, 25273, 25274, 25275, 25229
10393, 24663, 24685, 24686, 24664, 25275, 25276, 25277, 25231
10394, 24664, 24686, 24687, 24665, 25277, 25278, 25279, 25233
10395, 24665, 24687, 24688, 24666, 25279, 25280, 25281, 25235
10396, 24666, 24688, 24689, 24667, 25281, 25282, 25283, 25237
10397, 24667, 24689, 24690, 24668, 25283, 25284, 25285, 25239
10398, 24668, 24690, 24691, 24669, 25285, 25286, 25287, 25241
10399, 24669, 24691, 24692, 24670, 25287, 25288, 25289, 25243
10400, 24670, 24692, 24693, 24671, 25289, 25290, 25291, 25245
10401, 24671, 24693, 3174, 3173, 25291, 25292, 3196, 25247
10402, 3129, 3130, 24694, 24672, 3152, 25293, 25294, 25248
10403, 24672, 24694, 24695, 24673, 25294, 25295, 25296, 25250
10404, 24673, 24695, 24696, 24674, 25296, 25297, 25298, 25252
10405, 24674, 24696, 24697, 24675, 25298, 25299, 25300, 25254
10406, 24675, 24697, 24698, 24676, 25300, 25301, 25302, 25256
10407, 24676, 24698, 24699, 24677, 25302, 25303, 25304, 25258
10408, 24677, 24699, 24700, 24678, 25304, 25305, 25306, 25260
10409, 24678, 24700, 24701, 24679, 25306, 25307, 25308, 25262
10410, 24679, 24701, 24702, 24680, 25308, 25309, 25310, 25264
10411, 24680, 24702, 24703, 24681, 25310, 25311, 25312, 25266
10412, 24681, 24703, 24704, 24682, 25312, 25313, 25314, 25268
10413, 24682, 24704, 24705, 24683, 25314, 25315, 25316, 25270
10414, 24683, 24705, 24706, 24684, 25316, 25317, 25318, 25272
10415, 24684, 24706, 24707, 24685, 25318, 25319, 25320, 25274
10416, 24685, 24707, 24708, 24686, 25320, 25321, 25322, 25276
10417, 24686, 24708, 24709, 24687, 25322, 25323, 25324, 25278
10418, 24687, 24709, 24710, 24688, 25324, 25325, 25326, 25280
10419, 24688, 24710, 24711, 24689, 25326, 25327, 25328, 25282
10420, 24689, 24711, 24712, 24690, 25328, 25329, 25330, 25284
10421, 24690, 24712, 24713, 24691, 25330, 25331, 25332, 25286
10422, 24691, 24713, 24714, 24692, 25332, 25333, 25334, 25288
10423, 24692, 24714, 24715, 24693, 25334, 25335, 25336, 25290
10424, 24693, 24715, 3175, 3174, 25336, 25337, 3197, 25292
10425, 3130, 3131, 24716, 24694, 3153, 25338, 25339, 25293
10426, 24694, 24716, 24717, 24695, 25339, 25340, 25341, 25295
10427, 24695, 24717, 24718, 24696, 25341, 25342, 25343, 25297
10428, 24696, 24718, 24719, 24697, 25343, 25344, 25345, 25299
10429, 24697, 24719, 24720, 24698, 25345, 25346, 25347, 25301
10430, 24698, 24720, 24721, 24699, 25347, 25348, 25349, 25303
10431, 24699, 24721, 24722, 24700, 25349, 25350, 25351, 25305
10432, 24700, 24722, 24723, 24701, 25351, 25352, 25353, 25307
10433, 24701, 24723, 24724, 24702, 25353, 25354, 25355, 25309
10434, 24702, 24724, 24725, 24703, 25355, 25356, 25357, 25311
10435, 24703, 24725, 24726, 24704, 25357, 25358, 25359, 25313
10436, 24704, 24726, 24727, 24705, 25359, 25360, 25361, 25315
10437, 24705, 24727, 24728, 24706, 25361, 25362, 25363, 25317
10438, 24706, 24728, 24729, 24707, 25363, 25364, 25365, 25319
10439, 24707, 24729, 24730, 24708, 25365, 25366, 25367, 25321
10440, 24708, 24730, 24731, 24709, 25367, 25368, 25369, 25323
10441, 24709, 24731, 24732, 24710, 25369, 25370, 25371, 25325
10442, 24710, 24732, 24733, 24711, 25371, 25372, 25373, 25327
10443, 24711, 24733, 24734, 24712, 25373, 25374, 25375, 25329
10444, 24712, 24734, 24735, 24713, 25375, 25376, 25377, 25331
10445, 24713, 24735, 24736, 24714, 25377, 25378, 25379, 25333
10446, 24714, 24736, 24737, 24715, 25379, 25380, 25381, 25335
10447, 24715, 24737, 3176, 3175, 25381, 25382, 3198, 25337
10448, 3131, 3132, 24738, 24716, 3154, 25383, 25384, 25338
10449, 24716, 24738, 24739, 24717, 25384, 25385, 25386, 25340
10450, 24717, 24739, 24740, 24718, 25386, 25387, 25388, 25342
10451, 24718, 24740, 24741, 24719, 25388, 25389, 25390, 25344
10452, 24719, 24741, 24742, 24720, 25390, 25391, 25392, 25346
10453, 24720, 24742, 24743, 24721, 25392, 25393, 25394, 25348
10454, 24721, 24743, 24744, 24722, 25394, 25395, 25396, 25350
10455, 24722, 24744, 24745, 24723, 25396, 25397, 25398, 25352
10456, 24723, 24745, 24746, 24724, 25398, 25399, 25400, 25354
10457, 24724, 24746, 24747, 24725, 25400, 25401, 25402, 25356
10458, 24725, 24747, 24748, 24726, 25402, 25403, 25404, 25358
10459, 24726, 24748, 24749, 24727, 25404, 25405, 25406, 25360
10460, 24727, 24749, 24750, 24728, 25406, 25407, 25408, 25362
10461, 24728, 24750, 24751, 24729, 25408, 25409, 25410, 25364
10462, 24729, 24751, 24752, 24730, 25410, 25411, 25412, 25366
10463, 24730, 24752, 24753, 24731, 25412, 25413, 25414, 25368
10464, 24731, 24753, 24754, 24732, 25414, 25415, 25416, 25370
10465, 24732, 24754, 24755, 24733, 25416, 25417, 25418, 25372
10466, 24733, 24755, 24756, 24734, 25418, 25419, 25420, 25374
10467, 24734, 24756, 24757, 24735, 25420, 25421, 25422, 25376
10468, 24735, 24757, 24758, 24736, 25422, 25423, 25424, 25378
10469, 24736, 24758, 24759, 24737, 25424, 25425, 25426, 25380
10470, 24737, 24759, 3177, 3176, 25426, 25427, 3199, 25382
10471, 3132, 3133, 24760, 24738, 3155, 25428, 25429, 25383
10472, 24738, 24760, 24761, 24739, 25429, 25430, 25431, 25385
10473, 24739, 24761, 24762, 24740, 25431, 25432, 25433, 25387
10474, 24740, 24762, 24763, 24741, 25433, 25434, 25435, 25389
10475, 24741, 24763, 24764, 24742, 25435, 25436, 25437, 25391
10476, 24742, 24764, 24765, 24743, 25437, 25438, 25439, 25393
10477, 24743, 24765, 24766, 24744, 25439, 25440, 25441, 25395
10478, 24744, 24766, 24767, 24745, 25441, 25442, 25443, 25397
10479, 24745, 24767, 24768, 24746, 25443, 25444, 25445, 25399
10480, 24746, 24768, 24769, 24747, 25445, 25446, 25447, 25401
10481, 24747, 24769, 24770, 24748, 25447, 25448, 25449, 25403
10482, 24748, 24770, 24771, 24749, 25449, 25450, 25451, 25405
10483, 24749, 24771, 24772, 24750, 25451, 25452, 25453, 25407
10484, 24750, 24772, 24773, 24751, 25453, 25454, 25455, 25409
10485, 24751, 24773, 24774, 24752, 25455, 25456, 25457, 25411
10486, 24752, 24774, 24775, 24753, 25457, 25458, 25459, 25413
10487, 24753, 24775, 24776, 24754, 25459, 25460, 25461, 25415
10488, 24754, 24776, 24777, 24755, 25461, 25462, 25463, 25417
10489, 24755, 24777, 24778, 24756, 25463, 25464, 25465, 25419
10490, 24756, 24778, 24779, 24757, 25465, 25466, 25467, 25421
10491, 24757, 24779, 24780, 24758, 25467, 25468, 25469, 25423
10492, 24758, 24780, 24781, 24759, 25469, 25470, 25471, 25425
10493, 24759, 24781, 3178, 3177, 25471, 25472, 3200, 25427
10494, 3133, 3134, 24782, 24760, 3156, 25473, 25474, 25428
10495, 24760, 24782, 24783, 24761, 25474, 25475, 25476, 25430
10496, 24761, 24783, 24784, 24762, 25476, 25477, 25478, 25432
10497, 24762, 24784, 24785, 24763, 25478, 25479, 25480, 25434
10498, 24763, 24785, 24786, 24764, 25480, 25481, 25482, 25436
10499, 24764, 24786, 24787, 24765, 25482, 25483, 25484, 25438
10500, 24765, 24787, 24788, 24766, 25484, 25485, 25486, 25440
10501, 24766, 24788, 24789, 24767, 25486, 25487, 25488, 25442
10502, 24767, 24789, 24790, 24768, 25488, 25489, 25490, 25444
10503, 24768, 24790, 24791, 24769, 25490, 25491, 25492, 25446
10504, 24769, 24791, 24792, 24770, 25492, 25493, 25494, 25448
10505, 24770, 24792, 24793, 24771, 25494, 25495, 25496, 25450
10506, 24771, 24793, 24794, 24772, 25496, 25497, 25498, 25452
10507, 24772, 24794, 24795, 24773, 25498, 25499, 25500, 25454
10508, 24773, 24795, 24796, 24774, 25500, 25501, 25502, 25456
10509, 24774, 24796, 24797, 24775, 25502, 25503, 25504, 25458
10510, 24775, 24797, 24798, 24776, 25504, 25505, 25506, 25460
10511, 24776, 24798, 24799, 24777, 25506, 25507, 25508, 25462
10512, 24777, 24799, 24800, 24778, 25508, 25509, 25510, 25464
10513, 24778, 24800, 24801, 24779, 25510, 25511, 25512, 25466
10514, 24779, 24801, 24802, 24780, 25512, 25513, 25514, 25468
10515, 24780, 24802, 24803, 24781, 25514, 25515, 25516, 25470
10516, 24781, 24803, 3179, 3178, 25516, 25517, 3201, 25472
10517, 3134, 3135, 24804, 24782, 3157, 25518, 25519, 25473
10518, 24782, 24804, 24805, 24783, 25519, 25520, 25521, 25475
10519, 24783, 24805, 24806, 24784, 25521, 25522, 25523, 25477
10520, 24784, 24806, 24807, 24785, 25523, 25524, 25525, 25479
10521, 24785, 24807, 24808, 24786, 25525, 25526, 25527, 25481
10522, 24786, 24808, 24809, 24787, 25527, 25528, 25529, 25483
10523, 24787, 24809, 24810, 24788, 25529, 25530, 25531, 25485
10524, 24788, 24810, 24811, 24789, 25531, 25532, 25533, 25487
10525, 24789, 24811, 24812, 24790, 25533, 25534, 25535, 25489
10526, 24790, 24812, 24813, 24791, 25535, 25536, 25537, 25491
10527, 24791, 24813, 24814, 24792, 25537, 25538, 25539, 25493
10528, 24792, 24814, 24815, 24793, 25539, 25540, 25541, 25495
10529, 24793, 24815, 24816, 24794, 25541, 25542, 25543, 25497
10530, 24794, 24816, 24817, 24795, 25543, 25544, 25545, 25499
10531, 24795, 24817, 24818, 24796, 25545, 25546, 25547, 25501
10532, 24796, 24818, 24819, 24797, 25547, 25548, 25549, 25503
10533, 24797, 24819, 24820, 24798, 25549, 25550, 25551, 25505
10534, 24798, 24820, 24821, 24799, 25551, 25552, 25553, 25507
10535, 24799, 24821, 24822, 24800, 25553, 25554, 25555, 25509
10536, 24800, 24822, 24823, 24801, 25555, 25556, 25557, 25511
10537, 24801, 24823, 24824, 24802, 25557, 25558, 25559, 25513
10538, 24802, 24824, 24825, 24803, 25559, 25560, 25561, 25515
10539, 24803, 24825, 3180, 3179, 25561, 25562, 3202, 25517
10540, 3135, 3136, 24826, 24804, 3158, 25563, 25564, 25518
10541, 24804, 24826, 24827, 24805, 25564, 25565, 25566, 25520
10542, 24805, 24827, 24828, 24806, 25566, 25567, 25568, 25522
10543, 24806, 24828, 24829, 24807, 25568, 25569, 25570, 25524
10544, 24807, 24829, 24830, 24808, 25570, 25571, 25572, 25526
10545, 24808, 24830, 24831, 24809, 25572, 25573, 25574, 25528
10546, 24809, 24831, 24832, 24810, 25574, 25575, 25576, 25530
10547, 24810, 24832, 24833, 24811, 25576, 25577, 25578, 25532
10548, 24811, 24833, 24834, 24812, 25578, 25579, 25580, 25534
10549, 24812, 24834, 24835, 24813, 25580, 25581, 25582, 25536
10550, 24813, 24835, 24836, 24814, 25582, 25583, 25584, 25538
10551, 24814, 24836, 24837, 24815, 25584, 25585, 25586, 25540
10552, 24815, 24837, 24838, 24816, 25586, 25587, 25588, 25542
10553, 24816, 24838, 24839, 24817, 25588, 25589, 25590, 25544
10554, 24817, 24839, 24840, 24818, 25590, 25591, 25592, 25546
10555, 24818, 24840, 24841, 24819, 25592, 25593, 25594, 25548
10556, 24819, 24841, 24842, 24820, 25594, 25595, 25596, 25550
10557, 24820, 24842, 24843, 24821, 25596, 25597, 25598, 25552
10558, 24821, 24843, 24844, 24822, 25598, 25599, 25600, 25554
10559, 24822, 24844, 24845, 24823, 25600, 25601, 25602, 25556
10560, 24823, 24845, 24846, 24824, 25602, 25603, 25604, 25558
10561, 24824, 24846, 24847, 24825, 25604, 25605, 25606, 25560
10562, 24825, 24847, 3181, 3180, 25606, 25607, 3203, 25562
10563, 3136, 3137, 24848, 24826, 3159, 25608, 25609, 25563
10564, 24826, 24848, 24849, 24827, 25609, 25610, 25611, 25565
10565, 24827, 24849, 24850, 24828, 25611, 25612, 25613, 25567
10566, 24828, 24850, 24851, 24829, 25613, 25614, 25615, 25569
10567, 24829, 24851, 24852, 24830, 25615, 25616, 25617, 25571
10568, 24830, 24852, 24853, 24831, 25617, 25618, 25619, 25573
10569, 24831, 24853, 24854, 24832, 25619, 25620, 25621, 25575
10570, 24832, 24854, 24855, 24833, 25621, 25622, 25623, 25577
10571, 24833, 24855, 24856, 24834, 25623, 25624, 25625, 25579
10572, 24834, 24856, 24857, 24835, 25625, 25626, 25627, 25581
10573, 24835, 24857, 24858, 24836, 25627, 25628, 25629, 25583
10574, 24836, 24858, 24859, 24837, 25629, 25630, 25631, 25585
10575, 24837, 24859, 24860, 24838, 25631, 25632, 25633, 25587
10576, 24838, 24860, 24861, 24839, 25633, 25634, 25635, 25589
10577, 24839, 24861, 24862, 24840, 25635, 25636, 25637, 25591
10578, 24840, 24862, 24863, 24841, 25637, 25638, 25639, 25593
10579, 24841, 24863, 24864, 24842, 25639, 25640, 25641, 25595
10580, 24842, 24864, 24865, 24843, 25641, 25642, 25643, 25597
10581, 24843, 24865, 24866, 24844, 25643, 25644, 25645, 25599
10582, 24844, 24866, 24867, 24845, 25645, 25646, 25647, 25601
10583, 24845, 24867, 24868, 24846, 25647, 25648, 25649, 25603
10584, 24846, 24868, 24869, 24847, 25649, 25650, 25651, 25605
10585, 24847, 24869, 3182, 3181, 25651, 25652, 3204, 25607
10586, 3137, 3138, 24870, 24848, 3160, 25653, 25654, 25608
10587, 24848, 24870, 24871, 24849, 25654, 25655, 25656, 25610
10588, 24849, 24871, 24872, 24850, 25656, 25657, 25658, 25612
10589, 24850, 24872, 24873, 24851, 25658, 25659, 25660, 25614
10590, 24851, 24873, 24874, 24852, 25660, 25661, 25662, 25616
10591, 24852, 24874, 24875, 24853, 25662, 25663, 25664, 25618
10592, 24853, 24875, 24876, 24854, 25664, 25665, 25666, 25620
10593, 24854, 24876, 24877, 24855, 25666, 25667, 25668, 25622
10594, 24855, 24877, 24878, 24856, 25668, 25669, 25670, 25624
10595, 24856, 24878, 24879, 24857, 25670, 25671, 25672, 25626
10596, 24857, 24879, 24880, 24858, 25672, 25673, 25674, 25628
10597, 24858, 24880, 24881, 24859, 25674, 25675, 25676, 25630
10598, 24859, 24881, 24882, 24860, 25676, 25677, 25678, 25632
10599, 24860, 24882, 24883, 24861, 25678, 25679, 25680, 25634
10600, 24861, 24883, 24884, 24862, 25680, 25681, 25682, 25636
10601, 24862, 24884, 24885, 24863, 25682, 25683, 25684, 25638
10602, 24863, 24885, 24886, 24864, 25684, 25685, 25686, 25640
10603, 24864, 24886, 24887, 24865, 25686, 25687, 25688, 25642
10604, 24865, 24887, 24888, 24866, 25688, 25689, 25690, 25644
10605, 24866, 24888, 24889, 24867, 25690, 25691, 25692, 25646
10606, 24867, 24889, 24890, 24868, 25692, 25693, 25694, 25648
10607, 24868, 24890, 24891, 24869, 25694, 25695, 25696, 25650
10608, 24869, 24891, 3183, 3182, 25696, 25697, 3205, 25652
10609, 3138, 3139, 24892, 24870, 3161, 25698, 25699, 25653
10610, 24870, 24892, 24893, 24871, 25699, 25700, 25701, 25655
10611, 24871, 24893, 24894, 24872, 25701, 25702, 25703, 25657
10612, 24872, 24894, 24895, 24873, 25703, 25704, 25705, 25659
10613, 24873, 24895, 24896, 24874, 25705, 25706, 25707, 25661
10614, 24874, 24896, 24897, 24875, 25707, 25708, 25709, 25663
10615, 24875, 24897, 24898, 24876, 25709, 25710, 25711, 25665
10616, 24876, 24898, 24899, 24877, 25711, 25712, 25713, 25667
10617, 24877, 24899, 24900, 24878, 25713, 25714, 25715, 25669
10618, 24878, 24900, 24901, 24879, 25715, 25716, 25717, 25671
10619, 24879, 24901, 24902, 24880, 25717, 25718, 25719, 25673
10620, 24880, 24902, 24903, 24881, 25719, 25720, 25721, 25675
10621, 24881, 24903, 24904, 24882, 25721, 25722, 25723, 25677
10622, 24882, 24904, 24905, 24883, 25723, 25724, 25725, 25679
10623, 24883, 24905, 24906, 24884, 25725, 25726, 25727, 25681
10624, 24884, 24906, 24907, 24885, 25727, 25728, 25729, 25683
10625, 24885, 24907, 24908, 24886, 25729, 25730, 25731, 25685
10626, 24886, 24908, 24909, 24887, 25731, 25732, 25733, 25687
10627, 24887, 24909, 24910, 24888, 25733, 25734, 25735, 25689
10628, 24888, 24910, 24911, 24889, 25735, 25736, 25737, 25691
10629, 24889, 24911, 24912, 24890, 25737, 25738, 25739, 25693
10630, 24890, 24912, 24913, 24891, 25739, 25740, 25741, 25695
10631, 24891, 24913, 3184, 3183, 25741, 25742, 3206, 25697
10632, 3139, 3140, 24914, 24892, 3162, 25743, 25744, 25698
10633, 24892, 24914, 24915, 24893, 25744, 25745, 25746, 25700
10634, 24893, 24915, 24916, 24894, 25746, 25747, 25748, 25702
10635, 24894, 24916, 24917, 24895, 25748, 25749, 25750, 25704
10636, 24895, 24917, 24918, 24896, 25750, 25751, 25752, 25706
10637, 24896, 24918, 24919, 24897, 25752, 25753, 25754, 25708
10638, 24897, 24919, 24920, 24898, 25754, 25755, 25756, 25710
10639, 24898, 24920, 24921, 24899, 25756, 25757, 25758, 25712
10640, 24899, 24921, 24922, 24900, 25758, 25759, 25760, 25714
10641, 24900, 24922, 24923, 24901, 25760, 25761, 25762, 25716
10642, 24901, 24923, 24924, 24902, 25762, 25763, 25764, 25718
10643, 24902, 24924, 24925, 24903, 25764, 25765, 25766, 25720
10644, 24903, 24925, 24926, 24904, 25766, 25767, 25768, 25722
10645, 24904, 24926, 24927, 24905, 25768, 25769, 25770, 25724
10646, 24905, 24927, 24928, 24906, 25770, 25771, 25772, 25726
10647, 24906, 24928, 24929, 24907, 25772, 25773, 25774, 25728
10648, 24907, 24929, 24930, 24908, 25774, 25775, 25776, 25730
10649, 24908, 24930, 24931, 24909, 25776, 25777, 25778, 25732
10650, 24909, 24931, 24932, 24910, 25778, 25779, 25780, 25734
10651, 24910, 24932, 24933, 24911, 25780, 25781, 25782, 25736
10652, 24911, 24933, 24934, 24912, 25782, 25783, 25784, 25738
10653, 24912, 24934, 24935, 24913, 25784, 25785, 25786, 25740
10654, 24913, 24935, 3185, 3184, 25786, 25787, 3207, 25742
10655, 3140, 3141, 24936, 24914, 3163, 25788, 25789, 25743
10656, 24914, 24936, 24937, 24915, 25789, 25790, 25791, 25745
10657, 24915, 24937, 24938, 24916, 25791, 25792, 25793, 25747
10658, 24916, 24938, 24939, 24917, 25793, 25794, 25795, 25749
10659, 24917, 24939, 24940, 24918, 25795, 25796, 25797, 25751
10660, 24918, 24940, 24941, 24919, 25797, 25798, 25799, 25753
10661, 24919, 24941, 24942, 24920, 25799, 25800, 25801, 25755
10662, 24920, 24942, 24943, 24921, 25801, 25802, 25803, 25757
10663, 24921, 24943, 24944, 24922, 25803, 25804, 25805, 25759
10664, 24922, 24944, 24945, 24923, 25805, 25806, 25807, 25761
10665, 24923, 24945, 24946, 24924, 25807, 25808, 25809, 25763
10666, 24924, 24946, 24947, 24925, 25809, 25810, 25811, 25765
10667, 24925, 24947, 24948, 24926, 25811, 25812, 25813, 25767
10668, 24926, 24948, 24949, 24927, 25813, 25814, 25815, 25769
10669, 24927, 24949, 24950, 24928, 25815, 25816, 25817, 25771
10670, 24928, 24950, 24951, 24929, 25817, 25818, 25819, 25773
10671, 24929, 24951, 24952, 24930, 25819, 25820, 25821, 25775
10672, 24930, 24952, 24953, 24931, 25821, 25822, 25823, 25777
10673, 24931, 24953, 24954, 24932, 25823, 25824, 25825, 25779
10674, 24932, 24954, 24955, 24933, 25825, 25826, 25827, 25781
10675, 24933, 24955, 24956, 24934, 25827, 25828, 25829, 25783
10676, 24934, 24956, 24957, 24935, 25829, 25830, 25831, 25785
10677, 24935, 24957, 3186, 3185, 25831, 25832, 3208, 25787
10678, 3141, 3142, 24958, 24936, 3164, 25833, 25834, 25788
10679, 24936, 24958, 24959, 24937, 25834, 25835, 25836, 25790
10680, 24937, 24959, 24960, 24938, 25836, 25837, 25838, 25792
10681, 24938, 24960, 24961, 24939, 25838, 25839, 25840, 25794
10682, 24939, 24961, 24962, 24940, 25840, 25841, 25842, 25796
10683, 24940, 24962, 24963, 24941, 25842, 25843, 25844, 25798
10684, 24941, 24963, 24964, 24942, 25844, 25845, 25846, 25800
10685, 24942, 24964, 24965, 24943, 25846, 25847, 25848, 25802
10686, 24943, 24965, 24966, 24944, 25848, 25849, 25850, 25804
10687, 24944, 24966, 24967, 24945, 25850, 25851, 25852, 25806
10688, 24945, 24967, 24968, 24946, 25852, 25853, 25854, 25808
10689, 24946, 24968, 24969, 24947, 25854, 25855, 25856, 25810
10690, 24947, 24969, 24970, 24948, 25856, 25857, 25858, 25812
10691, 24948, 24970, 24971, 24949, 25858, 25859, 25860, 25814
10692, 24949, 24971, 24972, 24950, 25860, 25861, 25862, 25816
10693, 24950, 24972, 24973, 24951, 25862, 25863, 25864, 25818
10694, 24951, 24973, 24974, 24952, 25864, 25865, 25866, 25820
10695, 24952, 24974, 24975, 24953, 25866, 25867, 25868, 25822
10696, 24953, 24975, 24976, 24954, 25868, 25869, 25870, 25824
10697, 24954, 24976, 24977, 24955, 25870, 25871, 25872, 25826
10698, 24955, 24977, 24978, 24956, 25872, 25873, 25874, 25828
10699, 24956, 24978, 24979, 24957, 25874, 25875, 25876, 25830
10700, 24957, 24979, 3187, 3186, 25876, 25877, 3209, 25832
10701, 3142, 3143, 24980, 24958, 3165, 25878, 25879, 25833
10702, 24958, 24980, 24981, 24959, 25879, 25880, 25881, 25835
10703, 24959, 24981, 24982, 24960, 25881, 25882, 25883, 25837
10704, 24960, 24982, 24983, 24961, 25883, 25884, 25885, 25839
10705, 24961, 24983, 24984, 24962, 25885, 25886, 25887, 25841
10706, 24962, 24984, 24985, 24963, 25887, 25888, 25889, 25843
10707, 24963, 24985, 24986, 24964, 25889, 25890, 25891, 25845
10708, 24964, 24986, 24987, 24965, 25891, 25892, 25893, 25847
10709, 24965, 24987, 24988, 24966, 25893, 25894, 25895, 25849
10710, 24966, 24988, 24989, 24967, 25895, 25896, 25897, 25851
10711, 24967, 24989, 24990, 24968, 25897, 25898, 25899, 25853
10712, 24968, 24990, 24991, 24969, 25899, 25900, 25901, 25855
10713, 24969, 24991, 24992, 24970, 25901, 25902, 25903, 25857
10714, 24970, 24992, 24993, 24971, 25903, 25904, 25905, 25859
10715, 24971, 24993, 24994, 24972, 25905, 25906, 25907, 25861
10716, 24972, 24994, 24995, 24973, 25907, 25908, 25909, 25863
10717, 24973, 24995, 24996, 24974, 25909, 25910, 25911, 25865
10718, 24974, 24996, 24997, 24975, 25911, 25912, 25913, 25867
10719, 24975, 24997, 24998, 24976, 25913, 25914, 25915, 25869
10720, 24976, 24998, 24999, 24977, 25915, 25916, 25917, 25871
10721, 24977, 24999, 25000, 24978, 25917, 25918, 25919, 25873
10722, 24978, 25000, 25001, 24979, 25919, 25920, 25921, 25875
10723, 24979, 25001, 3188, 3187, 25921, 25922, 3210, 25877
10724, 3143, 3144, 25002, 24980, 3166, 25923, 25924, 25878
10725, 24980, 25002, 25003, 24981, 25924, 25925, 25926, 25880
10726, 24981, 25003, 25004, 24982, 25926, 25927, 25928, 25882
10727, 24982, 25004, 25005, 24983, 25928, 25929, 25930, 25884
10728, 24983, 25005, 25006, 24984, 25930, 25931, 25932, 25886
10729, 24984, 25006, 25007, 24985, 25932, 25933, 25934, 25888
10730, 24985, 25007, 25008, 24986, 25934, 25935, 25936, 25890
10731, 24986, 25008, 25009, 24987, 25936, 25937, 25938, 25892
10732, 24987, 25009, 25010, 24988, 25938, 25939, 25940, 25894
10733, 24988, 25010, 25011, 24989, 25940, 25941, 25942, 25896
10734, 24989, 25011, 25012, 24990, 25942, 25943, 25944, 25898
10735, 24990, 25012, 25013, 24991, 25944, 25945, 25946, 25900
10736, 24991, 25013, 25014, 24992, 25946, 25947, 25948, 25902
10737, 24992, 25014, 25015, 24993, 25948, 25949, 25950, 25904
10738, 24993, 25015, 25016, 24994, 25950, 25951, 25952, 25906
10739, 24994, 25016, 25017, 24995, 25952, 25953, 25954, 25908
10740, 24995, 25017, 25018, 24996, 25954, 25955, 25956, 25910
10741, 24996, 25018, 25019, 24997, 25956, 25957, 25958, 25912
10742, 24997, 25019, 25020, 24998, 25958, 25959, 25960, 25914
10743, 24998, 25020, 25021, 24999, 25960, 25961, 25962, 25916
10744, 24999, 25021, 25022, 25000, 25962, 25963, 25964, 25918
10745, 25000, 25022, 25023, 25001, 25964, 25965, 25966, 25920
10746, 25001, 25023, 3189, 3188, 25966, 25967, 3211, 25922
10747, 3144, 3145, 25024, 25002, 3167, 25968, 25969, 25923
10748, 25002, 25024, 25025, 25003, 25969, 25970, 25971, 25925
10749, 25003, 25025, 25026, 25004, 25971, 25972, 25973, 25927
10750, 25004, 25026, 25027, 25005, 25973, 25974, 25975, 25929
10751, 25005, 25027, 25028, 25006, 25975, 25976, 25977, 25931
10752, 25006, 25028, 25029, 25007, 25977, 25978, 25979, 25933
10753, 25007, 25029, 25030, 25008, 25979, 25980, 25981, 25935
10754, 25008, 25030, 25031, 25009, 25981, 25982, 25983, 25937
10755, 25009, 25031, 25032, 25010, 25983, 25984, 25985, 25939
10756, 25010, 25032, 25033, 25011, 25985, 25986, 25987, 25941
10757, 25011, 25033, 25034, 25012, 25987, 25988, 25989, 25943
10758, 25012, 25034, 25035, 25013, 25989, 25990, 25991, 25945
10759, 25013, 25035, 25036, 25014, 25991, 25992, 25993, 25947
10760, 25014, 25036, 25037, 25015, 25993, 25994, 25995, 25949
10761, 25015, 25037, 25038, 25016, 25995, 25996, 25997, 25951
10762, 25016, 25038, 25039, 25017, 25997, 25998, 25999, 25953
10763, 25017, 25039, 25040, 25018, 25999, 26000, 26001, 25955
10764, 25018, 25040, 25041, 25019, 26001, 26002, 26003, 25957
10765, 25019, 25041, 25042, 25020, 26003, 26004, 26005, 25959
10766, 25020, 25042, 25043, 25021, 26005, 26006, 26007, 25961
10767, 25021, 25043, 25044, 25022, 26007, 26008, 26009, 25963
10768, 25022, 25044, 25045, 25023, 26009, 26010, 26011, 25965
10769, 25023, 25045, 3190, 3189, 26011, 26012, 3212, 25967
10770, 3145, 3146, 25046, 25024, 3168, 26013, 26014, 25968
10771, 25024, 25046, 25047, 25025, 26014, 26015, 26016, 25970
10772, 25025, 25047, 25048, 25026, 26016, 26017, 26018, 25972
10773, 25026, 25048, 25049, 25027, 26018, 26019, 26020, 25974
10774, 25027, 25049, 25050, 25028, 26020, 26021, 26022, 25976
10775, 25028, 25050, 25051, 25029, 26022, 26023, 26024, 25978
10776, 25029, 25051, 25052, 25030, 26024, 26025, 26026, 25980
10777, 25030, 25052, 25053, 25031, 26026, 26027, 26028, 25982
10778, 25031, 25053, 25054, 25032, 26028, 26029, 26030, 25984
10779, 25032, 25054, 25055, 25033, 26030, 26031, 26032, 25986
10780, 25033, 25055, 25056, 25034, 26032, 26033, 26034, 25988
10781, 25034, 25056, 25057, 25035, 26034, 26035, 26036, 25990
10782, 25035, 25057, 25058, 25036, 26036, 26037, 26038, 25992
10783, 25036, 25058, 25059, 25037, 26038, 26039, 26040, 25994
10784, 25037, 25059, 25060, 25038, 26040, 26041, 26042, 25996
10785, 25038, 25060, 25061, 25039, 26042, 26043, 26044, 25998
10786, 25039, 25061, 25062, 25040, 26044, 26045, 26046, 26000
10787, 25040, 25062, 25063, 25041, 26046, 26047, 26048, 26002
10788, 25041, 25063, 25064, 25042, 26048, 26049, 26050, 26004
10789, 25042, 25064, 25065, 25043, 26050, 26051, 26052, 26006
10790, 25043, 25065, 25066, 25044, 26052, 26053, 26054, 26008
10791, 25044, 25066, 25067, 25045, 26054, 26055, 26056, 26010
10792, 25045, 25067, 3191, 3190, 26056, 26057, 3213, 26012
10793, 3146, 5, 233, 25046, 3169, 255, 26058, 26013
10794, 25046, 233, 234, 25047, 26058, 256, 26059, 26015
10795, 25047, 234, 235, 25048, 26059, 257, 26060, 26017
10796, 25048, 235, 236, 25049, 26060, 258, 26061, 26019
10797, 25049, 236, 237, 25050, 26061, 259, 26062, 26021
10798, 25050, 237, 238, 25051, 26062, 260, 26063, 26023
10799, 25051, 238, 239, 25052, 26063, 261, 26064, 26025
10800, 25052, 239, 240, 25053, 26064, 262, 26065, 26027
10801, 25053, 240, 241, 25054, 26065, 263, 26066, 26029
10802, 25054, 241, 242, 25055, 26066, 264, 26067, 26031
10803, 25055, 242, 243, 25056, 26067, 265, 26068, 26033
10804, 25056, 243, 244, 25057, 26068, 266, 26069, 26035
10805, 25057, 244, 245, 25058, 26069, 267, 26070, 26037
10806, 25058, 245, 246, 25059, 26070, 268, 26071, 26039
10807, 25059, 246, 247, 25060, 26071, 269, 26072, 26041
10808, 25060, 247, 248, 25061, 26072, 270, 26073, 26043
10809, 25061, 248, 249, 25062, 26073, 271, 26074, 26045
10810, 25062, 249, 250, 25063, 26074, 272, 26075, 26047
10811, 25063, 250, 251, 25064, 26075, 273, 26076, 26049
10812, 25064, 251, 252, 25065, 26076, 274, 26077, 26051
10813, 25065, 252, 253, 25066, 26077, 275, 26078, 26053
10814, 25066, 253, 254, 25067, 26078, 276, 26079, 26055
10815, 25067, 254, 6, 3191, 26079, 277, 3214, 26057
*ELEMENT, type=CPS8, ELSET=Surface266
10816, 95, 3350, 26080, 3260, 3372, 26564, 26565, 3282
10817, 3350, 3351, 26081, 26080, 3373, 26566, 26567, 26564
10818, 3351, 3352, 26082, 26081, 3374, 26568, 26569, 26566
10819, 3352, 3353, 26083, 26082, 3375, 26570, 26571, 26568
10820, 3353, 3354, 26084, 26083, 3376, 26572, 26573, 26570
10821, 3354, 3355, 26085, 26084, 3377, 26574, 26575, 26572
10822, 3355, 3356, 26086, 26085, 3378, 26576, 26577, 26574
10823, 3356, 3357, 26087, 26086, 3379, 26578, 26579, 26576
10824, 3357, 3358, 26088, 26087, 3380, 26580, 26581, 26578
10825, 3358, 3359, 26089, 26088, 3381, 26582, 26583, 26580
10826, 3359, 3360, 26090, 26089, 3382, 26584, 26585, 26582
10827, 3360, 3361, 26091, 26090, 3383, 26586, 26587, 26584
10828, 3361, 3362, 26092, 26091, 3384, 26588, 26589, 26586
10829, 3362, 3363, 26093, 26092, 3385, 26590, 26591, 26588
10830, 3363, 3364, 26094, 26093, 3386, 26592, 26593, 26590
10831, 3364, 3365, 26095, 26094, 3387, 26594, 26595, 26592
10832, 3365, 3366, 26096, 26095, 3388, 26596, 26597, 26594
10833, 3366, 3367, 26097, 26096, 3389, 26598, 26599, 26596
10834, 3367, 3368, 26098, 26097, 3390, 26600, 26601, 26598
10835, 3368, 3369, 26099, 26098, 3391, 26602, 26603, 26600
10836, 3369, 3370, 26100, 26099, 3392, 26604, 26605, 26602
10837, 3370, 3371, 26101, 26100, 3393, 26606, 26607, 26604
10838, 3371, 96, 3305, 26101, 3394, 3327, 26608, 26606
10839, 3260, 26080, 26102, 3261, 26565, 26609, 26610, 3283
10840, 26080, 26081, 26103, 26102, 26567, 26611, 26612, 26609
10841, 26081, 26082, 26104, 26103, 26569, 26613, 26614, 26611
10842, 26082, 26083, 26105, 26104, 26571, 26615, 26616, 26613
10843, 26083, 26084, 26106, 26105, 26573, 26617, 26618, 26615
10844, 26084, 26085, 26107, 26106, 26575, 26619, 26620, 26617
10845, 26085, 26086, 26108, 26107, 26577, 26621, 26622, 26619
10846, 26086, 26087, 26109, 26108, 26579, 26623, 26624, 26621
10847, 26087, 26088, 26110, 26109, 26581, 26625, 26626, 26623
10848, 26088, 26089, 26111, 26110, 26583, 26627, 26628, 26625
10849, 26089, 26090, 26112, 26111, 26585, 26629, 26630, 26627
10850, 26090, 26091, 26113, 26112, 26587, 26631, 26632, 26629
10851, 26091, 26092, 26114, 26113, 26589, 26633, 26634, 26631
10852, 26092, 26093, 26115, 26114, 26591, 26635, 26636, 26633
10853, 26093, 26094, 26116, 26115, 26593, 26637, 26638, 26635
10854, 26094, 26095, 26117, 26116, 26595, 26639, 26640, 26637
10855, 26095, 26096, 26118, 26117, 26597, 26641, 26642, 26639
10856, 26096, 26097, 26119, 26118, 26599, 26643, 26644, 26641
10857, 26097, 26098, 26120, 26119, 26601, 26645, 26646, 26643
10858, 26098, 26099, 26121, 26120, 26603, 26647, 26648, 26645
10859, 26099, 26100, 26122, 26121, 26605, 26649, 26650, 26647
10860, 26100, 26101, 26123, 26122, 26607, 26651, 26652, 26649
10861, 26101, 3305, 3306, 26123, 26608, 3328, 26653, 26651
10862, 3261, 26102, 26124, 3262, 26610, 26654, 26655, 3284
10863, 26102, 26103, 26125, 26124, 26612, 26656, 26657, 26654
10864, 26103, 26104, 26126, 26125, 26614, 26658, 26659, 26656
10865, 26104, 26105, 26127, 26126, 26616, 26660, 26661, 26658
10866, 26105, 26106, 26128, 26127, 26618, 26662, 26663, 26660
10867, 26106, 26107, 26129, 26128, 26620, 26664, 26665, 26662
10868, 26107, 26108, 26130, 26129, 26622, 26666, 26667, 26664
10869, 26108, 26109, 26131, 26130, 26624, 26668, 26669, 26666
10870, 26109, 26110, 26132, 26131, 26626, 26670, 26671, 26668
10871, 26110, 26111, 26133, 26132, 26628, 26672, 26673, 26670
10872, 26111, 26112, 26134, 26133, 26630, 26674, 26675, 26672
10873, 26112, 26113, 26135, 26134, 26632, 26676, 26677, 26674
10874, 26113, 26114, 26136, 26135, 26634, 26678, 26679, 26676
10875, 26114, 26115, 26137, 26136, 26636, 26680, 26681, 26678
10876, 26115, 26116, 26138, 26137, 26638, 26682, 26683, 26680
10877, 26116, 26117, 26139, 26138, 26640, 26684, 26685, 26682
10878, 26117, 26118, 26140, 26139, 26642, 26686, 26687, 26684
10879, 26118, 26119, 26141, 26140, 26644, 26688, 26689, 26686
10880, 26119, 26120, 26142, 26141, 26646, 26690, 26691, 26688
10881, 26120, 26121, 26143, 26142, 26648, 26692, 26693, 26690
10882, 26121, 26122, 26144, 26143, 26650, 26694, 26695, 26692
10883, 26122, 26123, 26145, 26144, 26652, 26696, 26697, 26694
10884, 26123, 3306, 3307, 26145, 26653, 3329, 26698, 26696
10885, 3262, 26124, 26146, 3263, 26655, 26699, 26700, 3285
10886, 26124, 26125, 26147, 26146, 26657, 26701, 26702, 26699
10887, 26125, 26126, 26148, 26147, 26659, 26703, 26704, 26701
10888, 26126, 26127, 26149, 26148, 26661, 26705, 26706, 26703
10889, 26127, 26128, 26150, 26149, 26663, 26707, 26708, 26705
10890, 26128, 26129, 26151, 26150, 26665, 26709, 26710, 26707
10891, 26129, 26130, 26152, 26151, 26667, 26711, 26712, 26709
10892, 26130, 26131, 26153, 26152, 26669, 26713, 26714, 26711
10893, 26131, 26132, 26154, 26153, 26671, 26715, 26716, 26713
10894, 26132, 26133, 26155, 26154, 26673, 26717, 26718, 26715
10895, 26133, 26134, 26156, 26155, 26675, 26719, 26720, 26717
10896, 26134, 26135, 26157, 26156, 26677, 26721, 26722, 26719
10897, 26135, 26136, 26158, 26157, 26679, 26723, 26724, 26721
10898, 26136, 26137, 26159, 26158, 26681, 26725, 26726, 26723
10899, 26137, 26138, 26160, 26159, 26683, 26727, 26728, 26725
10900, 26138, 26139, 26161, 26160, 26685, 26729, 26730, 26727
10901, 26139, 26140, 26162, 26161, 26687, 26731, 26732, 26729
10902, 26140, 26141, 26163, 26162, 26689, 26733, 26734, 26731
10903, 26141, 26142, 26164, 26163, 26691, 26735, 26736, 26733
10904, 26142, 26143, 26165, 26164, 26693, 26737, 26738, 26735
10905, 26143, 26144, 26166, 26165, 26695, 26739, 26740, 26737
10906, 26144, 26145, 26167, 26166, 26697, 26741, 26742, 26739
10907, 26145, 3307, 3308, 26167, 26698, 3330, 26743, 26741
10908, 3263, 26146, 26168, 3264, 26700, 26744, 26745, 3286
10909, 26146, 26147, 26169, 26168, 26702, 26746, 26747, 26744
10910, 26147, 26148, 26170, 26169, 26704, 26748, 26749, 26746
10911, 26148, 26149, 26171, 26170, 26706, 26750, 26751, 26748
10912, 26149, 26150, 26172, 26171, 26708, 26752, 26753, 26750
10913, 26150, 26151, 26173, 26172, 26710, 26754, 26755, 26752
10914, 26151, 26152, 26174, 26173, 26712, 26756, 26757, 26754
10915, 26152, 26153, 26175, 26174, 26714, 26758, 26759, 26756
10916, 26153, 26154, 26176, 26175, 26716, 26760, 26761, 26758
10917, 26154, 26155, 26177, 26176, 26718, 26762, 26763, 26760
10918, 26155, 26156, 26178, 26177, 26720, 26764, 26765, 26762
10919, 26156, 26157, 26179, 26178, 26722, 26766, 26767, 26764
10920, 26157, 26158, 26180, 26179, 26724, 26768, 26769, 26766
10921, 26158, 26159, 26181, 26180, 26726, 26770, 26771, 26768
10922, 26159, 26160, 26182, 26181, 26728, 26772, 26773, 26770
10923, 26160, 26161, 26183, 26182, 26730, 26774, 26775, 26772
10924, 26161, 26162, 26184, 26183, 26732, 26776, 26777, 26774
10925, 26162, 26163, 26185, 26184, 26734, 26778, 26779, 26776
10926, 26163, 26164, 26186, 26185, 26736, 26780, 26781, 26778
10927, 26164, 26165, 26187, 26186, 26738, 26782, 26783, 26780
10928, 26165, 26166, 26188, 26187, 26740, 26784, 26785, 26782
10929, 26166, 26167, 26189, 26188, 26742, 26786, 26787, 26784
10930, 26167, 3308, 3309, 26189, 26743, 3331, 26788, 26786
10931, 3264, 26168, 26190, 3265, 26745, 26789, 26790, 3287
10932, 26168, 26169, 26191, 26190, 26747, 26791, 26792, 26789
10933, 26169, 26170, 26192, 26191, 26749, 26793, 26794, 26791
10934, 26170, 26171, 26193, 26192, 26751, 26795, 26796, 26793
10935, 26171, 26172, 26194, 26193, 26753, 26797, 26798, 26795
10936, 26172, 26173, 26195, 26194, 26755, 26799, 26800, 26797
10937, 26173, 26174, 26196, 26195, 26757, 26801, 26802, 26799
10938, 26174, 26175, 26197, 26196, 26759, 26803, 26804, 26801
10939, 26175, 26176, 26198, 26197, 26761, 26805, 26806, 26803
10940, 26176, 26177, 26199, 26198, 26763, 26807, 26808, 26805
10941, 26177, 26178, 26200, 26199, 26765, 26809, 26810, 26807
10942, 26178, 26179, 26201, 26200, 26767, 26811, 26812, 26809
10943, 26179, 26180, 26202, 26201, 26769, 26813, 26814, 26811
10944, 26180, 26181, 26203, 26202, 26771, 26815, 26816, 26813
10945, 26181, 26182, 26204, 26203, 26773, 26817, 26818, 26815
10946, 26182, 26183, 26205, 26204, 26775, 26819, 26820, 26817
10947, 26183, 26184, 26206, 26205, 26777, 26821, 26822, 26819
10948, 26184, 26185, 26207, 26206, 26779, 26823, 26824, 26821
10949, 26185, 26186, 26208, 26207, 26781, 26825, 26826, 26823
10950, 26186, 26187, 26209, 26208, 26783, 26827, 26828, 26825
10951, 26187, 26188, 26210, 26209, 26785, 26829, 26830, 26827
10952, 26188, 26189, 26211, 26210, 26787, 26831, 26832, 26829
10953, 26189, 3309, 3310, 26211, 26788, 3332, 26833, 26831
10954, 3265, 26190, 26212, 3266, 26790, 26834, 26835, 3288
10955, 26190, 26191, 26213, 26212, 26792, 26836, 26837, 26834
10956, 26191, 26192, 26214, 26213, 26794, 26838, 26839, 26836
10957, 26192, 26193, 26215, 26214, 26796, 26840, 26841, 26838
10958, 26193, 26194, 26216, 26215, 26798, 26842, 26843, 26840
10959, 26194, 26195, 26217, 26216, 26800, 26844, 26845, 26842
10960, 26195, 26196, 26218, 26217, 26802, 26846, 26847, 26844
10961, 26196, 26197, 26219, 26218, 26804, 26848, 26849, 26846
10962, 26197, 26198, 26220, 26219, 26806, 26850, 26851, 26848
10963, 26198, 26199, 26221, 26220, 26808, 26852, 26853, 26850
10964, 26199, 26200, 26222, 26221, 26810, 26854, 26855, 26852
10965, 26200, 26201, 26223, 26222, 26812, 26856, 26857, 26854
10966, 26201, 26202, 26224, 26223, 26814, 26858, 26859, 26856
10967, 26202, 26203, 26225, 26224, 26816, 26860, 26861, 26858
10968, 26203, 26204, 26226, 26225, 26818, 26862, 26863, 26860
10969, 26204, 26205, 26227, 26226, 26820, 26864, 26865, 26862
10970, 26205, 26206, 26228, 26227, 26822, 26866, 26867, 26864
10971, 26206, 26207, 26229, 26228, 26824, 26868, 26869, 26866
10972, 26207, 26208, 26230, 26229, 26826, 26870, 26871, 26868
10973, 26208, 26209, 26231, 26230, 26828, 26872, 26873, 26870
10974, 26209, 26210, 26232, 26231, 26830, 26874, 26875, 26872
10975, 26210, 26211, 26233, 26232, 26832, 26876, 26877, 26874
10976, 26211, 3310, 3311, 26233, 26833, 3333, 26878, 26876
10977, 3266, 26212, 26234, 3267, 26835, 26879, 26880, 3289
10978, 26212, 26213, 26235, 26234, 26837, 26881, 26882, 26879
10979, 26213, 26214, 26236, 26235, 26839, 26883, 26884, 26881
10980, 26214, 26215, 26237, 26236, 26841, 26885, 26886, 26883
10981, 26215, 26216, 26238, 26237, 26843, 26887, 26888, 26885
10982, 26216, 26217, 26239, 26238, 26845, 26889, 26890, 26887
10983, 26217, 26218, 26240, 26239, 26847, 26891, 26892, 26889
10984, 26218, 26219, 26241, 26240, 26849, 26893, 26894, 26891
10985, 26219, 26220, 26242, 26241, 26851, 26895, 26896, 26893
10986, 26220, 26221, 26243, 26242, 26853, 26897, 26898, 26895
10987, 26221, 26222, 26244, 26243, 26855, 26899, 26900, 26897
10988, 26222, 26223, 26245, 26244, 26857, 26901, 26902, 26899
10989, 26223, 26224, 26246, 26245, 26859, 26903, 26904, 26901
10990, 26224, 26225, 26247, 26246, 26861, 26905, 26906, 26903
10991, 26225, 26226, 26248, 26247, 26863, 26907, 26908, 26905
10992, 26226, 26227, 26249, 26248, 26865, 26909, 26910, 26907
10993, 26227, 26228, 26250, 26249, 26867, 26911, 26912, 26909
10994, 26228, 26229, 26251, 26250, 26869, 26913, 26914, 26911
10995, 26229, 26230, 26252, 26251, 26871, 26915, 26916, 26913
10996, 26230, 26231, 26253, 26252, 26873, 26917, 26918, 26915
10997, 26231, 26232, 26254, 26253, 26875, 26919, 26920, 26917
10998, 26232, 26233, 26255, 26254, 26877, 26921, 26922, 26919
10999, 26233, 3311, 3312, 26255, 26878, 3334, 26923, 26921
11000, 3267, 26234, 26256, 3268, 26880, 26924, 26925, 3290
11001, 26234, 26235, 26257, 26256, 26882, 26926, 26927, 26924
11002, 26235, 26236, 26258, 26257, 26884, 26928, 26929, 26926
11003, 26236, 26237, 26259, 26258, 26886, 26930, 26931, 26928
11004, 26237, 26238, 26260, 26259, 26888, 26932, 26933, 26930
11005, 26238, 26239, 26261, 26260, 26890, 26934, 26935, 26932
11006, 26239, 26240, 26262, 26261, 26892, 26936, 26937, 26934
11007, 26240, 26241, 26263, 26262, 26894, 26938, 26939, 26936
11008, 26241, 26242, 26264, 26263, 26896, 26940, 26941, 26938
11009, 26242, 26243, 26265, 26264, 26898, 26942, 26943, 26940
11010, 26243, 26244, 26266, 26265, 26900, 26944, 26945, 26942
11011, 26244, 26245, 26267, 26266, 26902, 26946, 26947, 26944
11012, 26245, 26246, 26268, 26267, 26904, 26948, 26949, 26946
11013, 26246, 26247, 26269, 26268, 26906, 26950, 26951, 26948
11014, 26247, 26248, 26270, 26269, 26908, 26952, 26953, 26950
11015, 26248, 26249, 26271, 26270, 26910, 26954, 26955, 26952
11016, 26249, 26250, 26272, 26271, 26912, 26956, 26957, 26954
11017, 26250, 26251, 26273, 26272, 26914, 26958, 26959, 26956
11018, 26251, 26252, 26274, 26273, 26916, 26960, 26961, 26958
11019, 26252, 26253, 26275, 26274, 26918, 26962, 26963, 26960
11020, 26253, 26254, 26276, 26275, 26920, 26964, 26965, 26962
11021, 26254, 26255, 26277, 26276, 26922, 26966, 26967, 26964
11022, 26255, 3312, 3313, 26277, 26923, 3335, 26968, 26966
11023, 3268, 26256, 26278, 3269, 26925, 26969, 26970, 3291
11024, 26256, 26257, 26279, 26278, 26927, 26971, 26972, 26969
11025, 26257, 26258, 26280, 26279, 26929, 26973, 26974, 26971
11026, 26258, 26259, 26281, 26280, 26931, 26975, 26976, 26973
11027, 26259, 26260, 26282, 26281, 26933, 26977, 26978, 26975
11028, 26260, 26261, 26283, 26282, 26935, 26979, 26980, 26977
11029, 26261, 26262, 26284, 26283, 26937, 26981, 26982, 26979
11030, 26262, 26263, 26285, 26284, 26939, 26983, 26984, 26981
11031, 26263, 26264, 26286, 26285, 26941, 26985, 26986, 26983
11032, 26264, 26265, 26287, 26286, 26943, 26987, 26988, 26985
11033, 26265, 26266, 26288, 26287, 26945, 26989, 26990, 26987
11034, 26266, 26267, 26289, 26288, 26947, 26991, 26992, 26989
11035, 26267, 26268, 26290, 26289, 26949, 26993, 26994, 26991
11036, 26268, 26269, 26291, 26290, 26951, 26995, 26996, 26993
11037, 26269, 26270, 26292, 26291, 26953, 26997, 26998, 26995
11038, 26270, 26271, 26293, 26292, 26955, 26999, 27000, 26997
11039, 26271, 26272, 26294, 26293, 26957, 27001, 27002, 26999
11040, 26272, 26273, 26295, 26294, 26959, 27003, 27004, 27001
11041, 26273, 26274, 26296, 26295, 26961, 27005, 27006, 27003
11042, 26274, 26275, 26297, 26296, 26963, 27007, 27008, 27005
11043, 26275, 26276, 26298, 26297, 26965, 27009, 27010, 27007
11044, 26276, 26277, 26299, 26298, 26967, 27011, 27012, 27009
11045, 26277, 3313, 3314, 26299, 26968, 3336, 27013, 27011
11046, 3269, 26278, 26300, 3270, 26970, 27014, 27015, 3292
11047, 26278, 26279, 26301, 26300, 26972, 27016, 27017, 27014
11048, 26279, 26280, 26302, 26301, 26974, 27018, 27019, 27016
11049, 26280, 26281, 26303, 26302, 26976, 27020, 27021, 27018
11050, 26281, 26282, 26304, 26303, 26978, 27022, 27023, 27020
11051, 26282, 26283, 26305, 26304, 26980, 27024, 27025, 27022
11052, 26283, 26284, 26306, 26305, 26982, 27026, 27027, 27024
11053, 26284, 26285, 26307, 26306, 26984, 27028, 27029, 27026
11054, 26285, 26286, 26308, 26307, 26986, 27030, 27031, 27028
11055, 26286, 26287, 26309, 26308, 26988, 27032, 27033, 27030
11056, 26287, 26288, 26310, 26309, 26990, 27034, 27035, 27032
11057, 26288, 26289, 26311, 26310, 26992, 27036, 27037, 27034
11058, 26289, 26290, 26312, 26311, 26994, 27038, 27039, 27036
11059, 26290, 26291, 26313, 26312, 26996, 27040, 27041, 27038
11060, 26291, 26292, 26314, 26313, 26998, 27042, 27043, 27040
11061, 26292, 26293, 26315, 26314, 27000, 27044, 27045, 27042
11062, 26293, 26294, 26316, 26315, 27002, 27046, 27047, 27044
11063, 26294, 26295, 26317, 26316, 27004, 27048, 27049, 27046
11064, 26295, 26296, 26318, 26317, 27006, 27050, 27051, 27048
11065, 26296, 26297, 26319, 26318, 27008, 27052, 27053, 27050
11066, 26297, 26298, 26320, 26319, 27010, 27054, 27055, 27052
11067, 26298, 26299, 26321, 26320, 27012, 27056, 27057, 27054
11068, 26299, 3314, 3315, 26321, 27013, 3337, 27058, 27056
11069, 3270, 26300, 26322, 3271, 27015, 27059, 27060, 3293
11070, 26300, 26301, 26323, 26322, 27017, 27061, 27062, 27059
11071, 26301, 26302, 26324, 26323, 27019, 27063, 27064, 27061
11072, 26302, 26303, 26325, 26324, 27021, 27065, 27066, 27063
11073, 26303, 26304, 26326, 26325, 27023, 27067, 27068, 27065
11074, 26304, 26305, 26327, 26326, 27025, 27069, 27070, 27067
11075, 26305, 26306, 26328, 26327, 27027, 27071, 27072, 27069
11076, 26306, 26307, 26329, 26328, 27029, 27073, 27074, 27071
11077, 26307, 26308, 26330, 26329, 27031, 27075, 27076, 27073
11078, 26308, 26309, 26331, 26330, 27033, 27077, 27078, 27075
11079, 26309, 26310, 26332, 26331, 27035, 27079, 27080, 27077
11080, 26310, 26311, 26333, 26332, 27037, 27081, 27082, 27079
11081, 26311, 26312, 26334, 26333, 27039, 27083, 27084, 27081
11082, 26312, 26313, 26335, 26334, 27041, 27085, 27086, 27083
11083, 26313, 26314, 26336, 26335, 27043, 27087, 27088, 27085
11084, 26314, 26315, 26337, 26336, 27045, 27089, 27090, 27087
11085, 26315, 26316, 26338, 26337, 27047, 27091, 27092, 27089
11086, 26316, 26317, 26339, 26338, 27049, 27093, 27094, 27091
11087, 26317, 26318, 26340, 26339, 27051, 27095, 27096, 27093
11088, 26318, 26319, 26341, 26340, 27053, 27097, 27098, 27095
11089, 26319, 26320, 26342, 26341, 27055, 27099, 27100, 27097
11090, 26320, 26321, 26343, 26342, 27057, 27101, 27102, 27099
11091, 26321, 3315, 3316, 26343, 27058, 3338, 27103, 27101
11092, 3271, 26322, 26344, 3272, 27060, 27104, 27105, 3294
11093, 26322, 26323, 26345, 26344, 27062, 27106, 27107, 27104
11094, 26323, 26324, 26346, 26345, 27064, 27108, 27109, 27106
11095, 26324, 26325, 26347, 26346, 27066, 27110, 27111, 27108
11096, 26325, 26326, 26348, 26347, 27068, 27112, 27113, 27110
11097, 26326, 26327, 26349, 26348, 27070, 27114, 27115, 27112
11098, 26327, 26328, 26350, 26349, 27072, 27116, 27117, 27114
11099, 26328, 26329, 26351, 26350, 27074, 27118, 27119, 27116
11100, 26329, 26330, 26352, 26351, 27076, 27120, 27121, 27118
11101, 26330, 26331, 26353, 26352, 27078, 27122, 27123, 27120
11102, 26331, 26332, 26354, 26353, 27080, 27124, 27125, 27122
11103, 26332, 26333, 26355, 26354, 27082, 27126, 27127, 27124
11104, 26333, 26334, 26356, 26355, 27084, 27128, 27129, 27126
11105, 26334, 26335, 26357, 26356, 27086, 27130, 27131, 27128
11106, 26335, 26336, 26358, 26357, 27088, 27132, 27133, 27130
11107, 26336, 26337, 26359, 26358, 27090, 27134, 27135, 27132
11108, 26337, 26338, 26360, 26359, 27092, 27136, 27137, 27134
11109, 26338, 26339, 26361, 26360, 27094, 27138, 27139, 27136
11110, 26339, 26340, 26362, 26361, 27096, 27140, 27141, 27138
11111, 26340, 26341, 26363, 26362, 27098, 27142, 27143, 27140
11112, 26341, 26342, 26364, 26363, 27100, 27144, 27145, 27142
11113, 26342, 26343, 26365, 26364, 27102, 27146, 27147, 27144
11114, 26343, 3316, 3317, 26365, 27103, 3339, 27148, 27146
11115, 3272, 26344, 26366, 3273, 27105, 27149, 27150, 3295
11116, 26344, 26345, 26367, 26366, 27107, 27151, 27152, 27149
11117, 26345, 26346, 26368, 26367, 27109, 27153, 27154, 27151
11118, 26346, 26347, 26369, 26368, 27111, 27155, 27156, 27153
11119, 26347, 26348, 26370, 26369, 27113, 27157, 27158, 27155
11120, 26348, 26349, 26371, 26370, 27115, 27159, 27160, 27157
11121, 26349, 26350, 26372, 26371, 27117, 27161, 27162, 27159
11122, 26350, 26351, 26373, 26372, 27119, 27163, 27164, 27161
11123, 26351, 26352, 26374, 26373, 27121, 27165, 27166, 27163
11124, 26352, 26353, 26375, 26374, 27123, 27167, 27168, 27165
11125, 26353, 26354, 26376, 26375, 27125, 27169, 27170, 27167
11126, 26354, 26355, 26377, 26376, 27127, 27171, 27172, 27169
11127, 26355, 26356, 26378, 26377, 27129, 27173, 27174, 27171
11128, 26356, 26357, 26379, 26378, 27131, 27175, 27176, 27173
11129, 26357, 26358, 26380, 26379, 27133, 27177, 27178, 27175
11130, 26358, 26359, 26381, 26380, 27135, 27179, 27180, 27177
11131, 26359, 26360, 26382, 26381, 27137, 27181, 27182, 27179
11132, 26360, 26361, 26383, 26382, 27139, 27183, 27184, 27181
11133, 26361, 26362, 26384, 26383, 27141, 27185, 27186, 27183
11134, 26362, 26363, 26385, 26384, 27143, 27187, 27188, 27185
11135, 26363, 26364, 26386, 26385, 27145, 27189, 27190, 27187
11136, 26364, 26365, 26387, 26386, 27147, 27191, 27192, 27189
11137, 26365, 3317, 3318, 26387, 27148, 3340, 27193, 27191
11138, 3273, 26366, 26388, 3274, 27150, 27194, 27195, 3296
11139, 26366, 26367, 26389, 26388, 27152, 27196, 27197, 27194
11140, 26367, 26368, 26390, 26389, 27154, 27198, 27199, 27196
11141, 26368, 26369, 26391, 26390, 27156, 27200, 27201, 27198
11142, 26369, 26370, 26392, 26391, 27158, 27202, 27203, 27200
11143, 26370, 26371, 26393, 26392, 27160, 27204, 27205, 27202
11144, 26371, 26372, 26394, 26393, 27162, 27206, 27207, 27204
11145, 26372, 26373, 26395, 26394, 27164, 27208, 27209, 27206
11146, 26373, 26374, 26396, 26395, 27166, 27210, 27211, 27208
11147, 26374, 26375, 26397, 26396, 27168, 27212, 27213, 27210
11148, 26375, 26376, 26398, 26397, 27170, 27214, 27215, 27212
11149, 26376, 26377, 26399, 26398, 27172, 27216, 27217, 27214
11150, 26377, 26378, 26400, 26399, 27174, 27218, 27219, 27216
11151, 26378, 26379, 26401, 26400, 27176, 27220, 27221, 27218
11152, 26379, 26380, 26402, 26401, 27178, 27222, 27223, 27220
11153, 26380, 26381, 26403, 26402, 27180, 27224, 27225, 27222
11154, 26381, 26382, 26404, 26403, 27182, 27226, 27227, 27224
11155, 26382, 26383, 26405, 26404, 27184, 27228, 27229, 27226
11156, 26383, 26384, 26406, 26405, 27186, 27230, 27231, 27228
11157, 26384, 26385, 26407, 26406, 27188, 27232, 27233, 27230
11158, 26385, 26386, 26408, 26407, 27190, 27234, 27235, 27232
11159, 26386, 26387, 26409, 26408, 27192, 27236, 27237, 27234
11160, 26387, 3318, 3319, 26409, 27193, 3341, 27238, 27236
11161, 3274, 26388, 26410, 3275, 27195, 27239, 27240, 3297
11162, 26388, 26389, 26411, 26410, 27197, 27241, 27242, 27239
11163, 26389, 26390, 26412, 26411, 27199, 27243, 27244, 27241
11164, 26390, 26391, 26413, 26412, 27201, 27245, 27246, 27243
11165, 26391, 26392, 26414, 26413, 27203, 27247, 27248, 27245
11166, 26392, 26393, 26415, 26414, 27205, 27249, 27250, 27247
11167, 26393, 26394, 26416, 26415, 27207, 27251, 27252, 27249
11168, 26394, 26395, 26417, 26416, 27209, 27253, 27254, 27251
11169, 26395, 26396, 26418, 26417, 27211, 27255, 27256, 27253
11170, 26396, 26397, 26419, 26418, 27213, 27257, 27258, 27255
11171, 26397, 26398, 26420, 26419, 27215, 27259, 27260, 27257
11172, 26398, 26399, 26421, 26420, 27217, 27261, 27262, 27259
11173, 26399, 26400, 26422, 26421, 27219, 27263, 27264, 27261
11174, 26400, 26401, 26423, 26422, 27221, 27265, 27266, 27263
11175, 26401, 26402, 26424, 26423, 27223, 27267, 27268, 27265
11176, 26402, 26403, 26425, 26424, 27225, 27269, 27270, 27267
11177, 26403, 26404, 26426, 26425, 27227, 27271, 27272, 27269
11178, 26404, 26405, 26427, 26426, 27229, 27273, 27274, 27271
11179, 26405, 26406, 26428, 26427, 27231, 27275, 27276, 27273
11180, 26406, 26407, 26429, 26428, 27233, 27277, 27278, 27275
11181, 26407, 26408, 26430, 26429, 27235, 27279, 27280, 27277
11182, 26408, 26409, 26431, 26430, 27237, 27281, 27282, 27279
11183, 26409, 3319, 3320, 26431, 27238, 3342, 27283, 27281
11184, 3275, 26410, 26432, 3276, 27240, 27284, 27285, 3298
11185, 26410, 26411, 26433, 26432, 27242, 27286, 27287, 27284
11186, 26411, 26412, 26434, 26433, 27244, 27288, 27289, 27286
11187, 26412, 26413, 26435, 26434, 27246, 27290, 27291, 27288
11188, 26413, 26414, 26436, 26435, 27248, 27292, 27293, 27290
11189, 26414, 26415, 26437, 26436, 27250, 27294, 27295, 27292
11190, 26415, 26416, 26438, 26437, 27252, 27296, 27297, 27294
11191, 26416, 26417, 26439, 26438, 27254, 27298, 27299, 27296
11192, 26417, 26418, 26440, 26439, 27256, 27300, 27301, 27298
11193, 26418, 26419, 26441, 26440, 27258, 27302, 27303, 27300
11194, 26419, 26420, 26442, 26441, 27260, 27304, 27305, 27302
11195, 26420, 26421, 26443, 26442, 27262, 27306, 27307, 27304
11196, 26421, 26422, 26444, 26443, 27264, 27308, 27309, 27306
11197, 26422, 26423, 26445, 26444, 27266, 27310, 27311, 27308
11198, 26423, 26424, 26446, 26445, 27268, 27312, 27313, 27310
11199, 26424, 26425, 26447, 26446, 27270, 27314, 27315, 27312
11200, 26425, 26426, 26448, 26447, 27272, 27316, 27317, 27314
11201, 26426, 26427, 26449, 26448, 27274, 27318, 27319, 27316
11202, 26427, 26428, 26450, 26449, 27276, 27320, 27321, 27318
11203, 26428, 26429, 26451, 26450, 27278, 27322, 27323, 27320
11204, 26429, 26430, 26452, 26451, 27280, 27324, 27325, 27322
11205, 26430, 26431, 26453, 26452, 27282, 27326, 27327, 27324
11206, 26431, 3320, 3321, 26453, 27283, 3343, 27328, 27326
11207, 3276, 26432, 26454, 3277, 27285, 27329, 27330, 3299
11208, 26432, 26433, 26455, 26454, 27287, 27331, 27332, 27329
11209, 26433, 26434, 26456, 26455, 27289, 27333, 27334, 27331
11210, 26434, 26435, 26457, 26456, 27291, 27335, 27336, 27333
11211, 26435, 26436, 26458, 26457, 27293, 27337, 27338, 27335
11212, 26436, 26437, 26459, 26458, 27295, 27339, 27340, 27337
11213, 26437, 26438, 26460, 26459, 27297, 27341, 27342, 27339
11214, 26438, 26439, 26461, 26460, 27299, 27343, 27344, 27341
11215, 26439, 26440, 26462, 26461, 27301, 27345, 27346, 27343
11216, 26440, 26441, 26463, 26462, 27303, 27347, 27348, 27345
11217, 26441, 26442, 26464, 26463, 27305, 27349, 27350, 27347
11218, 26442, 26443, 26465, 26464, 27307, 27351, 27352, 27349
11219, 26443, 26444, 26466, 26465, 27309, 27353, 27354, 27351
11220, 26444, 26445, 26467, 26466, 27311, 27355, 27356, 27353
11221, 26445, 26446, 26468, 26467, 27313, 27357, 27358, 27355
11222, 26446, 26447, 26469, 26468, 27315, 27359, 27360, 27357
11223, 26447, 26448, 26470, 26469, 27317, 27361, 27362, 27359
11224, 26448, 26449, 26471, 26470, 27319, 27363, 27364, 27361
11225, 26449, 26450, 26472, 26471, 27321, 27365, 27366, 27363
11226, 26450, 26451, 26473, 26472, 27323, 27367, 27368, 27365
11227, 26451, 26452, 26474, 26473, 27325, 27369, 27370, 27367
11228, 26452, 26453, 26475, 26474, 27327, 27371, 27372, 27369
11229, 26453, 3321, 3322, 26475, 27328, 3344, 27373, 27371
11230, 3277, 26454, 26476, 3278, 27330, 27374, 27375, 3300
11231, 26454, 26455, 26477, 26476, 27332, 27376, 27377, 27374
11232, 26455, 26456, 26478, 26477, 27334, 27378, 27379, 27376
11233, 26456, 26457, 26479, 26478, 27336, 27380, 27381, 27378
11234, 26457, 26458, 26480, 26479, 27338, 27382, 27383, 27380
11235, 26458, 26459, 26481, 26480, 27340, 27384, 27385, 27382
11236, 26459, 26460, 26482, 26481, 27342, 27386, 27387, 27384
11237, 26460, 26461, 26483, 26482, 27344, 27388, 27389, 27386
11238, 26461, 26462, 26484, 26483, 27346, 27390, 27391, 27388
11239, 26462, 26463, 26485, 26484, 27348, 27392, 27393, 27390
11240, 26463, 26464, 26486, 26485, 27350, 27394, 27395, 27392
11241, 26464, 26465, 26487, 26486, 27352, 27396, 27397, 27394
11242, 26465, 26466, 26488, 26487, 27354, 27398, 27399, 27396
11243, 26466, 26467, 26489, 26488, 27356, 27400, 27401, 27398
11244, 26467, 26468, 26490, 26489, 27358, 27402, 27403, 27400
11245, 26468, 26469, 26491, 26490, 27360, 27404, 27405, 27402
11246, 26469, 26470, 26492, 26491, 27362, 27406, 27407, 27404
11247, 26470, 26471, 26493, 26492, 27364, 27408, 27409, 27406
11248, 26471, 26472, 26494, 26493, 27366, 27410, 27411, 27408
11249, 26472, 26473, 26495, 26494, 27368, 27412, 27413, 27410
11250, 26473, 26474, 26496, 26495, 27370, 27414, 27415, 27412
11251, 26474, 26475, 26497, 26496, 27372, 27416, 27417, 27414
11252, 26475, 3322, 3323, 26497, 27373, 3345, 27418, 27416
11253, 3278, 26476, 26498, 3279, 27375, 27419, 27420, 3301
11254, 26476, 26477, 26499, 26498, 27377, 27421, 27422, 27419
11255, 26477, 26478, 26500, 26499, 27379, 27423, 27424, 27421
11256, 26478, 26479, 26501, 26500, 27381, 27425, 27426, 27423
11257, 26479, 26480, 26502, 26501, 27383, 27427, 27428, 27425
11258, 26480, 26481, 26503, 26502, 27385, 27429, 27430, 27427
11259, 26481, 26482, 26504, 26503, 27387, 27431, 27432, 27429
11260, 26482, 26483, 26505, 26504, 27389, 27433, 27434, 27431
11261, 26483, 26484, 26506, 26505, 27391, 27435, 27436, 27433
11262, 26484, 26485, 26507, 26506, 27393, 27437, 27438, 27435
11263, 26485, 26486, 26508, 26507, 27395, 27439, 27440, 27437
11264, 26486, 26487, 26509, 26508, 27397, 27441, 27442, 27439
11265, 26487, 26488, 26510, 26509, 27399, 27443, 27444, 27441
11266, 26488, 26489, 26511, 26510, 27401, 27445, 27446, 27443
11267, 26489, 26490, 26512, 26511, 27403, 27447, 27448, 27445
11268, 26490, 26491, 26513, 26512, 27405, 27449, 27450, 27447
11269, 26491, 26492, 26514, 26513, 27407, 27451, 27452, 27449
11270, 26492, 26493, 26515, 26514, 27409, 27453, 27454, 27451
11271, 26493, 26494, 26516, 26515, 27411, 27455, 27456, 27453
11272, 26494, 26495, 26517, 26516, 27413, 27457, 27458, 27455
11273, 26495, 26496, 26518, 26517, 27415, 27459, 27460, 27457
11274, 26496, 26497, 26519, 26518, 27417, 27461, 27462, 27459
11275, 26497, 3323, 3324, 26519, 27418, 3346, 27463, 27461
11276, 3279, 26498, 26520, 3280, 27420, 27464, 27465, 3302
11277, 26498, 26499, 26521, 26520, 27422, 27466, 27467, 27464
11278, 26499, 26500, 26522, 26521, 27424, 27468, 27469, 27466
11279, 26500, 26501, 26523, 26522, 27426, 27470, 27471, 27468
11280, 26501, 26502, 26524, 26523, 27428, 27472, 27473, 27470
11281, 26502, 26503, 26525, 26524, 27430, 27474, 27475, 27472
11282, 26503, 26504, 26526, 26525, 27432, 27476, 27477, 27474
11283, 26504, 26505, 26527, 26526, 27434, 27478, 27479, 27476
11284, 26505, 26506, 26528, 26527, 27436, 27480, 27481, 27478
11285, 26506, 26507, 26529, 26528, 27438, 27482, 27483, 27480
11286, 26507, 26508, 26530, 26529, 27440, 27484, 27485, 27482
11287, 26508, 26509, 26531, 26530, 27442, 27486, 27487, 27484
11288, 26509, 26510, 26532, 26531, 27444, 27488, 27489, 27486
11289, 26510, 26511, 26533, 26532, 27446, 27490, 27491, 27488
11290, 26511, 26512, 26534, 26533, 27448, 27492, 27493, 27490
11291, 26512, 26513, 26535, 26534, 27450, 27494, 27495, 27492
11292, 26513, 26514, 26536, 26535, 27452, 27496, 27497, 27494
11293, 26514, 26515, 26537, 26536, 27454, 27498, 27499, 27496
11294, 26515, 26516, 26538, 26537, 27456, 27500, 27501, 27498
11295, 26516, 26517, 26539, 26538, 27458, 27502, 27503, 27500
11296, 26517, 26518, 26540, 26539, 27460, 27504, 27505, 27502
11297, 26518, 26519, 26541, 26540, 27462, 27506, 27507, 27504
11298, 26519, 3324, 3325, 26541, 27463, 3347, 27508, 27506
11299, 3280, 26520, 26542, 3281, 27465, 27509, 27510, 3303
11300, 26520, 26521, 26543, 26542, 27467, 27511, 27512, 27509
11301, 26521, 26522, 26544, 26543, 27469, 27513, 27514, 27511
11302, 26522, 26523, 26545, 26544, 27471, 27515, 27516, 27513
11303, 26523, 26524, 26546, 26545, 27473, 27517, 27518, 27515
11304, 26524, 26525, 26547, 26546, 27475, 27519, 27520, 27517
11305, 26525, 26526, 26548, 26547, 27477, 27521, 27522, 27519
11306, 26526, 26527, 26549, 26548, 27479, 27523, 27524, 27521
11307, 26527, 26528, 26550, 26549, 27481, 27525, 27526, 27523
11308, 26528, 26529, 26551, 26550, 27483, 27527, 27528, 27525
11309, 26529, 26530, 26552, 26551, 27485, 27529, 27530, 27527
11310, 26530, 26531, 26553, 26552, 27487, 27531, 27532, 27529
11311, 26531, 26532, 26554, 26553, 27489, 27533, 27534, 27531
11312, 26532, 26533, 26555, 26554, 27491, 27535, 27536, 27533
11313, 26533, 26534, 26556, 26555, 27493, 27537, 27538, 27535
11314, 26534, 26535, 26557, 26556, 27495, 27539, 27540, 27537
11315, 26535, 26536, 26558, 26557, 27497, 27541, 27542, 27539
11316, 26536, 26537, 26559, 26558, 27499, 27543, 27544, 27541
11317, 26537, 26538, 26560, 26559, 27501, 27545, 27546, 27543
11318, 26538, 26539, 26561, 26560, 27503, 27547, 27548, 27545
11319, 26539, 26540, 26562, 26561, 27505, 27549, 27550, 27547
11320, 26540, 26541, 26563, 26562, 27507, 27551, 27552, 27549
11321, 26541, 3325, 3326, 26563, 27508, 3348, 27553, 27551
11322, 3281, 26542, 278, 7, 27510, 27554, 300, 3304
11323, 26542, 26543, 279, 278, 27512, 27555, 301, 27554
11324, 26543, 26544, 280, 279, 27514, 27556, 302, 27555
11325, 26544, 26545, 281, 280, 27516, 27557, 303, 27556
11326, 26545, 26546, 282, 281, 27518, 27558, 304, 27557
11327, 26546, 26547, 283, 282, 27520, 27559, 305, 27558
11328, 26547, 26548, 284, 283, 27522, 27560, 306, 27559
11329, 26548, 26549, 285, 284, 27524, 27561, 307, 27560
11330, 26549, 26550, 286, 285, 27526, 27562, 308, 27561
11331, 26550, 26551, 287, 286, 27528, 27563, 309, 27562
11332, 26551, 26552, 288, 287, 27530, 27564, 310, 27563
11333, 26552, 26553, 289, 288, 27532, 27565, 311, 27564
11334, 26553, 26554, 290, 289, 27534, 27566, 312, 27565
11335, 26554, 26555, 291, 290, 27536, 27567, 313, 27566
11336, 26555, 26556, 292, 291, 27538, 27568, 314, 27567
11337, 26556, 26557, 293, 292, 27540, 27569, 315, 27568
11338, 26557, 26558, 294, 293, 27542, 27570, 316, 27569
11339, 26558, 26559, 295, 294, 27544, 27571, 317, 27570
11340, 26559, 26560, 296, 295, 27546, 27572, 318, 27571
11341, 26560, 26561, 297, 296, 27548, 27573, 319, 27572
11342, 26561, 26562, 298, 297, 27550, 27574, 320, 27573
11343, 26562, 26563, 299, 298, 27552, 27575, 321, 27574
11344, 26563, 3326, 8, 299, 27553, 3349, 322, 27575
*ELEMENT, type=CPS8, ELSET=Surface267
11345, 93, 3402, 27576, 3125, 3411, 27752, 27753, 3147
11346, 3402, 3401, 27577, 27576, 3410, 27754, 27755, 27752
11347, 3401, 3400, 27578, 27577, 3409, 27756, 27757, 27754
11348, 3400, 3399, 27579, 27578, 3408, 27758, 27759, 27756
11349, 3399, 3398, 27580, 27579, 3407, 27760, 27761, 27758
11350, 3398, 3397, 27581, 27580, 3406, 27762, 27763, 27760
11351, 3397, 3396, 27582, 27581, 3405, 27764, 27765, 27762
11352, 3396, 3395, 27583, 27582, 3404, 27766, 27767, 27764
11353, 3395, 95, 3260, 27583, 3403, 3282, 27768, 27766
11354, 3125, 27576, 27584, 3126, 27753, 27769, 27770, 3148
11355, 27576, 27577, 27585, 27584, 27755, 27771, 27772, 27769
11356, 27577, 27578, 27586, 27585, 27757, 27773, 27774, 27771
11357, 27578, 27579, 27587, 27586, 27759, 27775, 27776, 27773
11358, 27579, 27580, 27588, 27587, 27761, 27777, 27778, 27775
11359, 27580, 27581, 27589, 27588, 27763, 27779, 27780, 27777
11360, 27581, 27582, 27590, 27589, 27765, 27781, 27782, 27779
11361, 27582, 27583, 27591, 27590, 27767, 27783, 27784, 27781
11362, 27583, 3260, 3261, 27591, 27768, 3283, 27785, 27783
11363, 3126, 27584, 27592, 3127, 27770, 27786, 27787, 3149
11364, 27584, 27585, 27593, 27592, 27772, 27788, 27789, 27786
11365, 27585, 27586, 27594, 27593, 27774, 27790, 27791, 27788
11366, 27586, 27587, 27595, 27594, 27776, 27792, 27793, 27790
11367, 27587, 27588, 27596, 27595, 27778, 27794, 27795, 27792
11368, 27588, 27589, 27597, 27596, 27780, 27796, 27797, 27794
11369, 27589, 27590, 27598, 27597, 27782, 27798, 27799, 27796
11370, 27590, 27591, 27599, 27598, 27784, 27800, 27801, 27798
11371, 27591, 3261, 3262, 27599, 27785, 3284, 27802, 27800
11372, 3127, 27592, 27600, 3128, 27787, 27803, 27804, 3150
11373, 27592, 27593, 27601, 27600, 27789, 27805, 27806, 27803
11374, 27593, 27594, 27602, 27601, 27791, 27807, 27808, 27805
11375, 27594, 27595, 27603, 27602, 27793, 27809, 27810, 27807
11376, 27595, 27596, 27604, 27603, 27795, 27811, 27812, 27809
11377, 27596, 27597, 27605, 27604, 27797, 27813, 27814, 27811
11378, 27597, 27598, 27606, 27605, 27799, 27815, 27816, 27813
11379, 27598, 27599, 27607, 27606, 27801, 27817, 27818, 27815
11380, 27599, 3262, 3263, 27607, 27802, 3285, 27819, 27817
11381, 3128, 27600, 27608, 3129, 27804, 27820, 27821, 3151
11382, 27600, 27601, 27609, 27608, 27806, 27822, 27823, 27820
11383, 27601, 27602, 27610, 27609, 27808, 27824, 27825, 27822
11384, 27602, 27603, 27611, 27610, 27810, 27826, 27827, 27824
11385, 27603, 27604, 27612, 27611, 27812, 27828, 27829, 27826
11386, 27604, 27605, 27613, 27612, 27814, 27830, 27831, 27828
11387, 27605, 27606, 27614, 27613, 27816, 27832, 27833, 27830
11388, 27606, 27607, 27615, 27614, 27818, 27834, 27835, 27832
11389, 27607, 3263, 3264, 27615, 27819, 3286, 27836, 27834
11390, 3129, 27608, 27616, 3130, 27821, 27837, 27838, 3152
11391, 27608, 27609, 27617, 27616, 27823, 27839, 27840, 27837
11392, 27609, 27610, 27618, 27617, 27825, 27841, 27842, 27839
11393, 27610, 27611, 27619, 27618, 27827, 27843, 27844, 27841
11394, 27611, 27612, 27620, 27619, 27829, 27845, 27846, 27843
11395, 27612, 27613, 27621, 27620, 27831, 27847, 27848, 27845
11396, 27613, 27614, 27622, 27621, 27833, 27849, 27850, 27847
11397, 27614, 27615, 27623, 27622, 27835, 27851, 27852, 27849
11398, 27615, 3264, 3265, 27623, 27836, 3287, 27853, 27851
11399, 3130, 27616, 27624, 3131, 27838, 27854, 27855, 3153
11400, 27616, 27617, 27625, 27624, 27840, 27856, 27857, 27854
11401, 27617, 27618, 27626, 27625, 27842, 27858, 27859, 27856
11402, 27618, 27619, 27627, 27626, 27844, 27860, 27861, 27858
11403, 27619, 27620, 27628, 27627, 27846, 27862, 27863, 27860
11404, 27620, 27621, 27629, 27628, 27848, 27864, 27865, 27862
11405, 27621, 27622, 27630, 27629, 27850, 27866, 27867, 27864
11406, 27622, 27623, 27631, 27630, 27852, 27868, 27869, 27866
11407, 27623, 3265, 3266, 27631, 27853, 3288, 27870, 27868
11408, 3131, 27624, 27632, 3132, 27855, 27871, 27872, 3154
11409, 27624, 27625, 27633, 27632, 27857, 27873, 27874, 27871
11410, 27625, 27626, 27634, 27633, 27859, 27875, 27876, 27873
11411, 27626, 27627, 27635, 27634, 27861, 27877, 27878, 27875
11412, 27627, 27628, 27636, 27635, 27863, 27879, 27880, 27877
11413, 27628, 27629, 27637, 27636, 27865, 27881, 27882, 27879
11414, 27629, 27630, 27638, 27637, 27867, 27883, 27884, 27881
11415, 27630, 27631, 27639, 27638, 27869, 27885, 27886, 27883
11416, 27631, 3266, 3267, 27639, 27870, 3289, 27887, 27885
11417, 3132, 27632, 27640, 3133, 27872, 27888, 27889, 3155
11418, 27632, 27633, 27641, 27640, 27874, 27890, 27891, 27888
11419, 27633, 27634, 27642, 27641, 27876, 27892, 27893, 27890
11420, 27634, 27635, 27643, 27642, 27878, 27894, 27895, 27892
11421, 27635, 27636, 27644, 27643, 27880, 27896, 27897, 27894
11422, 27636, 27637, 27645, 27644, 27882, 27898, 27899, 27896
11423, 27637, 27638, 27646, 27645, 27884, 27900, 27901, 27898
11424, 27638, 27639, 27647, 27646, 27886, 27902, 27903, 27900
11425, 27639, 3267, 3268, 27647, 27887, 3290, 27904, 27902
11426, 3133, 27640, 27648, 3134, 27889, 27905, 27906, 3156
11427, 27640, 27641, 27649, 27648, 27891, 27907, 27908, 27905
11428, 27641, 27642, 27650, 27649, 27893, 27909, 27910, 27907
11429, 27642, 27643, 27651, 27650, 27895, 27911, 27912, 27909
11430, 27643, 27644, 27652, 27651, 27897, 27913, 27914, 27911
11431, 27644, 27645, 27653, 27652, 27899, 27915, 27916, 27913
11432, 27645, 27646, 27654, 27653, 27901, 27917, 27918, 27915
11433, 27646, 27647, 27655, 27654, 27903, 27919, 27920, 27917
11434, 27647, 3268, 3269, 27655, 27904, 3291, 27921, 27919
11435, 3134, 27648, 27656, 3135, 27906, 27922, 27923, 3157
11436, 27648, 27649, 27657, 27656, 27908, 27924, 27925, 27922
11437, 27649, 27650, 27658, 27657, 27910, 27926, 27927, 27924
11438, 27650, 27651, 27659, 27658, 27912, 27928, 27929, 27926
11439, 27651, 27652, 27660, 27659, 27914, 27930, 27931, 27928
11440, 27652, 27653, 27661, 27660, 27916, 27932, 27933, 27930
11441, 27653, 27654, 27662, 27661, 27918, 27934, 27935, 27932
11442, 27654, 27655, 27663, 27662, 27920, 27936, 27937, 27934
11443, 27655, 3269, 3270, 27663, 27921, 3292, 27938, 27936
11444, 3135, 27656, 27664, 3136, 27923, 27939, 27940, 3158
11445, 27656, 27657, 27665, 27664, 27925, 27941, 27942, 27939
11446, 27657, 27658, 27666, 27665, 27927, 27943, 27944, 27941
11447, 27658, 27659, 27667, 27666, 27929, 27945, 27946, 27943
11448, 27659, 27660, 27668, 27667, 27931, 27947, 27948, 27945
11449, 27660, 27661, 27669, 27668, 27933, 27949, 27950, 27947
11450, 27661, 27662, 27670, 27669, 27935, 27951, 27952, 27949
11451, 27662, 27663, 27671, 27670, 27937, 27953, 27954, 27951
11452, 27663, 3270, 3271, 27671, 27938, 3293, 27955, 27953
11453, 3136, 27664, 27672, 3137, 27940, 27956, 27957, 3159
11454, 27664, 27665, 27673, 27672, 27942, 27958, 27959, 27956
11455, 27665, 27666, 27674, 27673, 27944, 27960, 27961, 27958
11456, 27666, 27667, 27675, 27674, 27946, 27962, 27963, 27960
11457, 27667, 27668, 27676, 27675, 27948, 27964, 27965, 27962
11458, 27668, 27669, 27677, 27676, 27950, 27966, 27967, 27964
11459, 27669, 27670, 27678, 27677, 27952, 27968, 27969, 27966
11460, 27670, 27671, 27679, 27678, 27954, 27970, 27971, 27968
11461, 27671, 3271, 3272, 27679, 27955, 3294, 27972, 27970
11462, 3137, 27672, 27680, 3138, 27957, 27973, 27974, 3160
11463, 27672, 27673, 27681, 27680, 27959, 27975, 27976, 27973
11464, 27673, 27674, 27682, 27681, 27961, 27977, 27978, 27975
11465, 27674, 27675, 27683, 27682, 27963, 27979, 27980, 27977
11466, 27675, 27676, 27684, 27683, 27965, 27981, 27982, 27979
11467, 27676, 27677, 27685, 27684, 27967, 27983, 27984, 27981
11468, 27677, 27678, 27686, 27685, 27969, 27985, 27986, 27983
11469, 27678, 27679, 27687, 27686, 27971, 27987, 27988, 27985
11470, 27679, 3272, 3273, 27687, 27972, 3295, 27989, 27987
11471, 3138, 27680, 27688, 3139, 27974, 27990, 27991, 3161
11472, 27680, 27681, 27689, 27688, 27976, 27992, 27993, 27990
11473, 27681, 27682, 27690, 27689, 27978, 27994, 27995, 27992
11474, 27682, 27683, 27691, 27690, 27980, 27996, 27997, 27994
11475, 27683, 27684, 27692, 27691, 27982, 27998, 27999, 27996
11476, 27684, 27685, 27693, 27692, 27984, 28000, 28001, 27998
11477, 27685, 27686, 27694, 27693, 27986, 28002, 28003, 28000
11478, 27686, 27687, 27695, 27694, 27988, 28004, 28005, 28002
11479, 27687, 3273, 3274, 27695, 27989, 3296, 28006, 28004
11480, 3139, 27688, 27696, 3140, 27991, 28007, 28008, 3162
11481, 27688, 27689, 27697, 27696, 27993, 28009, 28010, 28007
11482, 27689, 27690, 27698, 27697, 27995, 28011, 28012, 28009
11483, 27690, 27691, 27699, 27698, 27997, 28013, 28014, 28011
11484, 27691, 27692, 27700, 27699, 27999, 28015, 28016, 28013
11485, 27692, 27693, 27701, 27700, 28001, 28017, 28018, 28015
11486, 27693, 27694, 27702, 27701, 28003, 28019, 28020, 28017
11487, 27694, 27695, 27703, 27702, 28005, 28021, 28022, 28019
11488, 27695, 3274, 3275, 27703, 28006, 3297, 28023, 28021
11489, 3140, 27696, 27704, 3141, 28008, 28024, 28025, 3163
11490, 27696, 27697, 27705, 27704, 28010, 28026, 28027, 28024
11491, 27697, 27698, 27706, 27705, 28012, 28028, 28029, 28026
11492, 27698, 27699, 27707, 27706, 28014, 28030, 28031, 28028
11493, 27699, 27700, 27708, 27707, 28016, 28032, 28033, 28030
11494, 27700, 27701, 27709, 27708, 28018, 28034, 28035, 28032
11495, 27701, 27702, 27710, 27709, 28020, 28036, 28037, 28034
11496, 27702, 27703, 27711, 27710, 28022, 28038, 28039, 28036
11497, 27703, 3275, 3276, 27711, 28023, 3298, 28040, 28038
11498, 3141, 27704, 27712, 3142, 28025, 28041, 28042, 3164
11499, 27704, 27705, 27713, 27712, 28027, 28043, 28044, 28041
11500, 27705, 27706, 27714, 27713, 28029, 28045, 28046, 28043
11501, 27706, 27707, 27715, 27714, 28031, 28047, 28048, 28045
11502, 27707, 27708, 27716, 27715, 28033, 28049, 28050, 28047
11503, 27708, 27709, 27717, 27716, 28035, 28051, 28052, 28049
11504, 27709, 27710, 27718, 27717, 28037, 28053, 28054, 28051
11505, 27710, 27711, 27719, 27718, 28039, 28055, 28056, 28053
11506, 27711, 3276, 3277, 27719, 28040, 3299, 28057, 28055
11507, 3142, 27712, 27720, 3143, 28042, 28058, 28059, 3165
11508, 27712, 27713, 27721, 27720, 28044, 28060, 28061, 28058
11509, 27713, 27714, 27722, 27721, 28046, 28062, 28063, 28060
11510, 27714, 27715, 27723, 27722, 28048, 28064, 28065, 28062
11511, 27715, 27716, 27724, 27723, 28050, 28066, 28067, 28064
11512, 27716, 27717, 27725, 27724, 28052, 28068, 28069, 28066
11513, 27717, 27718, 27726, 27725, 28054, 28070, 28071, 28068
11514, 27718, 27719, 27727, 27726, 28056, 28072, 28073, 28070
11515, 27719, 3277, 3278, 27727, 28057, 3300, 28074, 28072
11516, 3143, 27720, 27728, 3144, 28059, 28075, 28076, 3166
11517, 27720, 27721, 27729, 27728, 28061, 28077, 28078, 28075
11518, 27721, 27722, 27730, 27729, 28063, 28079, 28080, 28077
11519, 27722, 27723, 27731, 27730, 28065, 28081, 28082, 28079
11520, 27723, 27724, 27732, 27731, 28067, 28083, 28084, 28081
11521, 27724, 27725, 27733, 27732, 28069, 28085, 28086, 28083
11522, 27725, 27726, 27734, 27733, 28071, 28087, 28088, 28085
11523, 27726, 27727, 27735, 27734, 28073, 28089, 28090, 28087
11524, 27727, 3278, 3279, 27735, 28074, 3301, 28091, 28089
11525, 3144, 27728, 27736, 3145, 28076, 28092, 28093, 3167
11526, 27728, 27729, 27737, 27736, 28078, 28094, 28095, 28092
11527, 27729, 27730, 27738, 27737, 28080, 28096, 28097, 28094
11528, 27730, 27731, 27739, 27738, 28082, 28098, 28099, 28096
11529, 27731, 27732, 27740, 27739, 28084, 28100, 28101, 28098
11530, 27732, 27733, 27741, 27740, 28086, 28102, 28103, 28100
11531, 27733, 27734, 27742, 27741, 28088, 28104, 28105, 28102
11532, 27734, 27735, 27743, 27742, 28090, 28106, 28107, 28104
11533, 27735, 3279, 3280, 27743, 28091, 3302, 28108, 28106
11534, 3145, 27736, 27744, 3146, 28093, 28109, 28110, 3168
11535, 27736, 27737, 27745, 27744, 28095, 28111, 28112, 28109
11536, 27737, 27738, 27746, 27745, 28097, 28113, 28114, 28111
11537, 27738, 27739, 27747, 27746, 28099, 28115, 28116, 28113
11538, 27739, 27740, 27748, 27747, 28101, 28117, 28118, 28115
11539, 27740, 27741, 27749, 27748, 28103, 28119, 28120, 28117
11540, 27741, 27742, 27750, 27749, 28105, 28121, 28122, 28119
11541, 27742, 27743, 27751, 27750, 28107, 28123, 28124, 28121
11542, 27743, 3280, 3281, 27751, 28108, 3303, 28125, 28123
11543, 3146, 27744, 330, 5, 28110, 28126, 339, 3169
11544, 27744, 27745, 329, 330, 28112, 28127, 338, 28126
11545, 27745, 27746, 328, 329, 28114, 28128, 337, 28127
11546, 27746, 27747, 327, 328, 28116, 28129, 336, 28128
11547, 27747, 27748, 326, 327, 28118, 28130, 335, 28129
11548, 27748, 27749, 325, 326, 28120, 28131, 334, 28130
11549, 27749, 27750, 324, 325, 28122, 28132, 333, 28131
11550, 27750, 27751, 323, 324, 28124, 28133, 332, 28132
11551, 27751, 3281, 7, 323, 28125, 3304, 331, 28133
*ELEMENT, type=CPS8, ELSET=Surface268
11552, 94, 3170, 28134, 3419, 3192, 28310, 28311, 3428
11553, 3419, 28134, 28135, 3418, 28311, 28312, 28313, 3427
11554, 3418, 28135, 28136, 3417, 28313, 28314, 28315, 3426
11555, 3417, 28136, 28137, 3416, 28315, 28316, 28317, 3425
11556, 3416, 28137, 28138, 3415, 28317, 28318, 28319, 3424
11557, 3415, 28138, 28139, 3414, 28319, 28320, 28321, 3423
11558, 3414, 28139, 28140, 3413, 28321, 28322, 28323, 3422
11559, 3413, 28140, 28141, 3412, 28323, 28324, 28325, 3421
11560, 3412, 28141, 3305, 96, 28325, 28326, 3327, 3420
11561, 3170, 3171, 28142, 28134, 3193, 28327, 28328, 28310
11562, 28134, 28142, 28143, 28135, 28328, 28329, 28330, 28312
11563, 28135, 28143, 28144, 28136, 28330, 28331, 28332, 28314
11564, 28136, 28144, 28145, 28137, 28332, 28333, 28334, 28316
11565, 28137, 28145, 28146, 28138, 28334, 28335, 28336, 28318
11566, 28138, 28146, 28147, 28139, 28336, 28337, 28338, 28320
11567, 28139, 28147, 28148, 28140, 28338, 28339, 28340, 28322
11568, 28140, 28148, 28149, 28141, 28340, 28341, 28342, 28324
11569, 28141, 28149, 3306, 3305, 28342, 28343, 3328, 28326
11570, 3171, 3172, 28150, 28142, 3194, 28344, 28345, 28327
11571, 28142, 28150, 28151, 28143, 28345, 28346, 28347, 28329
11572, 28143, 28151, 28152, 28144, 28347, 28348, 28349, 28331
11573, 28144, 28152, 28153, 28145, 28349, 28350, 28351, 28333
11574, 28145, 28153, 28154, 28146, 28351, 28352, 28353, 28335
11575, 28146, 28154, 28155, 28147, 28353, 28354, 28355, 28337
11576, 28147, 28155, 28156, 28148, 28355, 28356, 28357, 28339
11577, 28148, 28156, 28157, 28149, 28357, 28358, 28359, 28341
11578, 28149, 28157, 3307, 3306, 28359, 28360, 3329, 28343
11579, 3172, 3173, 28158, 28150, 3195, 28361, 28362, 28344
11580, 28150, 28158, 28159, 28151, 28362, 28363, 28364, 28346
11581, 28151, 28159, 28160, 28152, 28364, 28365, 28366, 28348
11582, 28152, 28160, 28161, 28153, 28366, 28367, 28368, 28350
11583, 28153, 28161, 28162, 28154, 28368, 28369, 28370, 28352
11584, 28154, 28162, 28163, 28155, 28370, 28371, 28372, 28354
11585, 28155, 28163, 28164, 28156, 28372, 28373, 28374, 28356
11586, 28156, 28164, 28165, 28157, 28374, 28375, 28376, 28358
11587, 28157, 28165, 3308, 3307, 28376, 28377, 3330, 28360
11588, 3173, 3174, 28166, 28158, 3196, 28378, 28379, 28361
11589, 28158, 28166, 28167, 28159, 28379, 28380, 28381, 28363
11590, 28159, 28167, 28168, 28160, 28381, 28382, 28383, 28365
11591, 28160, 28168, 28169, 28161, 28383, 28384, 28385, 28367
11592, 28161, 28169, 28170, 28162, 28385, 28386, 28387, 28369
11593, 28162, 28170, 28171, 28163, 28387, 28388, 28389, 28371
11594, 28163, 28171, 28172, 28164, 28389, 28390, 28391, 28373
11595, 28164, 28172, 28173, 28165, 28391, 28392, 28393, 28375
11596, 28165, 28173, 3309, 3308, 28393, 28394, 3331, 28377
11597, 3174, 3175, 28174, 28166, 3197, 28395, 28396, 28378
11598, 28166, 28174, 28175, 28167, 28396, 28397, 28398, 28380
11599, 28167, 28175, 28176, 28168, 28398, 28399, 28400, 28382
11600, 28168, 28176, 28177, 28169, 28400, 28401, 28402, 28384
11601, 28169, 28177, 28178, 28170, 28402, 28403, 28404, 28386
11602, 28170, 28178, 28179, 28171, 28404, 28405, 28406, 28388
11603, 28171, 28179, 28180, 28172, 28406, 28407, 28408, 28390
11604, 28172, 28180, 28181, 28173, 28408, 28409, 28410, 28392
11605, 28173, 28181, 3310, 3309, 28410, 28411, 3332, 28394
11606, 3175, 3176, 28182, 28174, 3198, 28412, 28413, 28395
11607, 28174, 28182, 28183, 28175, 28413, 28414, 28415, 28397
11608, 28175, 28183, 28184, 28176, 28415, 28416, 28417, 28399
11609, 28176, 28184, 28185, 28177, 28417, 28418, 28419, 28401
11610, 28177, 28185, 28186, 28178, 28419, 28420, 28421, 28403
11611, 28178, 28186, 28187, 28179, 28421, 28422, 28423, 28405
11612, 28179, 28187, 28188, 28180, 28423, 28424, 28425, 28407
11613, 28180, 28188, 28189, 28181, 28425, 28426, 28427, 28409
11614, 28181, 28189, 3311, 3310, 28427, 28428, 3333, 28411
11615, 3176, 3177, 28190, 28182, 3199, 28429, 28430, 28412
11616, 28182, 28190, 28191, 28183, 28430, 28431, 28432, 28414
11617, 28183, 28191, 28192, 28184, 28432, 28433, 28434, 28416
11618, 28184, 28192, 28193, 28185, 28434, 28435, 28436, 28418
11619, 28185, 28193, 28194, 28186, 28436, 28437, 28438, 28420
11620, 28186, 28194, 28195, 28187, 28438, 28439, 28440, 28422
11621, 28187, 28195, 28196, 28188, 28440, 28441, 28442, 28424
11622, 28188, 28196, 28197, 28189, 28442, 28443, 28444, 28426
11623, 28189, 28197, 3312, 3311, 28444, 28445, 3334, 28428
11624, 3177, 3178, 28198, 28190, 3200, 28446, 28447, 28429
11625, 28190, 28198, 28199, 28191, 28447, 28448, 28449, 28431
11626, 28191, 28199, 28200, 28192, 28449, 28450, 28451, 28433
11627, 28192, 28200, 28201, 28193, 28451, 28452, 28453, 28435
11628, 28193, 28201, 28202, 28194, 28453, 28454, 28455, 28437
11629, 28194, 28202, 28203, 28195, 28455, 28456, 28457, 28439
11630, 28195, 28203, 28204, 28196, 28457, 28458, 28459, 28441
11631, 28196, 28204, 28205, 28197, 28459, 28460, 28461, 28443
11632, 28197, 28205, 3313, 3312, 28461, 28462, 3335, 28445
11633, 3178, 3179, 28206, 28198, 3201, 28463, 28464, 28446
11634, 28198, 28206, 28207, 28199, 28464, 28465, 28466, 28448
11635, 28199, 28207, 28208, 28200, 28466, 28467, 28468, 28450
11636, 28200, 28208, 28209, 28201, 28468, 28469, 28470, 28452
11637, 28201, 28209, 28210, 28202, 28470, 28471, 28472, 28454
11638, 28202, 28210, 28211, 28203, 28472, 28473, 28474, 28456
11639, 28203, 28211, 28212, 28204, 28474, 28475, 28476, 28458
11640, 28204, 28212, 28213, 28205, 28476, 28477, 28478, 28460
11641, 28205, 28213, 3314, 3313, 28478, 28479, 3336, 28462
11642, 3179, 3180, 28214, 28206, 3202, 28480, 28481, 28463
11643, 28206, 28214, 28215, 28207, 28481, 28482, 28483, 28465
11644, 28207, 28215, 28216, 28208, 28483, 28484, 28485, 28467
11645, 28208, 28216, 28217, 28209, 28485, 28486, 28487, 28469
11646, 28209, 28217, 28218, 28210, 28487, 28488, 28489, 28471
11647, 28210, 28218, 28219, 28211, 28489, 28490, 28491, 28473
11648, 28211, 28219, 28220, 28212, 28491, 28492, 28493, 28475
11649, 28212, 28220, 28221, 28213, 28493, 28494, 28495, 28477
11650, 28213, 28221, 3315, 3314, 28495, 28496, 3337, 28479
11651, 3180, 3181, 28222, 28214, 3203, 28497, 28498, 28480
11652, 28214, 28222, 28223, 28215, 28498, 28499, 28500, 28482
11653, 28215, 28223, 28224, 28216, 28500, 28501, 28502, 28484
11654, 28216, 28224, 28225, 28217, 28502, 28503, 28504, 28486
11655, 28217, 28225, 28226, 28218, 28504, 28505, 28506, 28488
11656, 28218, 28226, 28227, 28219, 28506, 28507, 28508, 28490
11657, 28219, 28227, 28228, 28220, 28508, 28509, 28510, 28492
11658, 28220, 28228, 28229, 28221, 28510, 28511, 28512, 28494
11659, 28221, 28229, 3316, 3315, 28512, 28513, 3338, 28496
11660, 3181, 3182, 28230, 28222, 3204, 28514, 28515, 28497
11661, 28222, 28230, 28231, 28223, 28515, 28516, 28517, 28499
11662, 28223, 28231, 28232, 28224, 28517, 28518, 28519, 28501
11663, 28224, 28232, 28233, 28225, 28519, 28520, 28521, 28503
11664, 28225, 28233, 28234, 28226, 28521, 28522, 28523, 28505
11665, 28226, 28234, 28235, 28227, 28523, 28524, 28525, 28507
11666, 28227, 28235, 28236, 28228, 28525, 28526, 28527, 28509
11667, 28228, 28236, 28237, 28229, 28527, 28528, 28529, 28511
11668, 28229, 28237, 3317, 3316, 28529, 28530, 3339, 28513
11669, 3182, 3183, 28238, 28230, 3205, 28531, 28532, 28514
11670, 28230, 28238, 28239, 28231, 28532, 28533, 28534, 28516
11671, 28231, 28239, 28240, 28232, 28534, 28535, 28536, 28518
11672, 28232, 28240, 28241, 28233, 28536, 28537, 28538, 28520
11673, 28233, 28241, 28242, 28234, 28538, 28539, 28540, 28522
11674, 28234, 28242, 28243, 28235, 28540, 28541, 28542, 28524
11675, 28235, 28243, 28244, 28236, 28542, 28543, 28544, 28526
11676, 28236, 28244, 28245, 28237, 28544, 28545, 28546, 28528
11677, 28237, 28245, 3318, 3317, 28546, 28547, 3340, 28530
11678, 3183, 3184, 28246, 28238, 3206, 28548, 28549, 28531
11679, 28238, 28246, 28247, 28239, 28549, 28550, 28551, 28533
11680, 28239, 28247, 28248, 28240, 28551, 28552, 28553, 28535
11681, 28240, 28248, 28249, 28241, 28553, 28554, 28555, 28537
11682, 28241, 28249, 28250, 28242, 28555, 28556, 28557, 28539
11683, 28242, 28250, 28251, 28243, 28557, 28558, 28559, 28541
11684, 28243, 28251, 28252, 28244, 28559, 28560, 28561, 28543
11685, 28244, 28252, 28253, 28245, 28561, 28562, 28563, 28545
11686, 28245, 28253, 3319, 3318, 28563, 28564, 3341, 28547
11687, 3184, 3185, 28254, 28246, 3207, 28565, 28566, 28548
11688, 28246, 28254, 28255, 28247, 28566, 28567, 28568, 28550
11689, 28247, 28255, 28256, 28248, 28568, 28569, 28570, 28552
11690, 28248, 28256, 28257, 28249, 28570, 28571, 28572, 28554
11691, 28249, 28257, 28258, 28250, 28572, 28573, 28574, 28556
11692, 28250, 28258, 28259, 28251, 28574, 28575, 28576, 28558
11693, 28251, 28259, 28260, 28252, 28576, 28577, 28578, 28560
11694, 28252, 28260, 28261, 28253, 28578, 28579, 28580, 28562
11695, 28253, 28261, 3320, 3319, 28580, 28581, 3342, 28564
11696, 3185, 3186, 28262, 28254, 3208, 28582, 28583, 28565
11697, 28254, 28262, 28263, 28255, 28583, 28584, 28585, 28567
11698, 28255, 28263, 28264, 28256, 28585, 28586, 28587, 28569
11699, 28256, 28264, 28265, 28257, 28587, 28588, 28589, 28571
11700, 28257, 28265, 28266, 28258, 28589, 28590, 28591, 28573
11701, 28258, 28266, 28267, 28259, 28591, 28592, 28593, 28575
11702, 28259, 28267, 28268, 28260, 28593, 28594, 28595, 28577
11703, 28260, 28268, 28269, 28261, 28595, 28596, 28597, 28579
11704, 28261, 28269, 3321, 3320, 28597, 28598, 3343, 28581
11705, 3186, 3187, 28270, 28262, 3209, 28599, 28600, 28582
11706, 28262, 28270, 28271, 28263, 28600, 28601, 28602, 28584
11707, 28263, 28271, 28272, 28264, 28602, 28603, 28604, 28586
11708, 28264, 28272, 28273, 28265, 28604, 28605, 28606, 28588
11709, 28265, 28273, 28274, 28266, 28606, 28607, 28608, 28590
11710, 28266, 28274, 28275, 28267, 28608, 28609, 28610, 28592
11711, 28267, 28275, 28276, 28268, 28610, 28611, 28612, 28594
11712, 28268, 28276, 28277, 28269, 28612, 28613, 28614, 28596
11713, 28269, 28277, 3322, 3321, 28614, 28615, 3344, 28598
11714, 3187, 3188, 28278, 28270, 3210, 28616, 28617, 28599
11715, 28270, 28278, 28279, 28271, 28617, 28618, 28619, 28601
11716, 28271, 28279, 28280, 28272, 28619, 28620, 28621, 28603
11717, 28272, 28280, 28281, 28273, 28621, 28622, 28623, 28605
11718, 28273, 28281, 28282, 28274, 28623, 28624, 28625, 28607
11719, 28274, 28282, 28283, 28275, 28625, 28626, 28627, 28609
11720, 28275, 28283, 28284, 28276, 28627, 28628, 28629, 28611
11721, 28276, 28284, 28285, 28277, 28629, 28630, 28631, 28613
11722, 28277, 28285, 3323, 3322, 28631, 28632, 3345, 28615
11723, 3188, 3189, 28286, 28278, 3211, 28633, 28634, 28616
11724, 28278, 28286, 28287, 28279, 28634, 28635, 28636, 28618
11725, 28279, 28287, 28288, 28280, 28636, 28637, 28638, 28620
11726, 28280, 28288, 28289, 28281, 28638, 28639, 28640, 28622
11727, 28281, 28289, 28290, 28282, 28640, 28641, 28642, 28624
11728, 28282, 28290, 28291, 28283, 28642, 28643, 28644, 28626
11729, 28283, 28291, 28292, 28284, 28644, 28645, 28646, 28628
11730, 28284, 28292, 28293, 28285, 28646, 28647, 28648, 28630
11731, 28285, 28293, 3324, 3323, 28648, 28649, 3346, 28632
11732, 3189, 3190, 28294, 28286, 3212, 28650, 28651, 28633
11733, 28286, 28294, 28295, 28287, 28651, 28652, 28653, 28635
11734, 28287, 28295, 28296, 28288, 28653, 28654, 28655, 28637
11735, 28288, 28296, 28297, 28289, 28655, 28656, 28657, 28639
11736, 28289, 28297, 28298, 28290, 28657, 28658, 28659, 28641
11737, 28290, 28298, 28299, 28291, 28659, 28660, 28661, 28643
11738, 28291, 28299, 28300, 28292, 28661, 28662, 28663, 28645
11739, 28292, 28300, 28301, 28293, 28663, 28664, 28665, 28647
11740, 28293, 28301, 3325, 3324, 28665, 28666, 3347, 28649
11741, 3190, 3191, 28302, 28294, 3213, 28667, 28668, 28650
11742, 28294, 28302, 28303, 28295, 28668, 28669, 28670, 28652
11743, 28295, 28303, 28304, 28296, 28670, 28671, 28672, 28654
11744, 28296, 28304, 28305, 28297, 28672, 28673, 28674, 28656
11745, 28297, 28305, 28306, 28298, 28674, 28675, 28676, 28658
11746, 28298, 28306, 28307, 28299, 28676, 28677, 28678, 28660
11747, 28299, 28307, 28308, 28300, 28678, 28679, 28680, 28662
11748, 28300, 28308, 28309, 28301, 28680, 28681, 28682, 28664
11749, 28301, 28309, 3326, 3325, 28682, 28683, 3348, 28666
11750, 3191, 6, 347, 28302, 3214, 356, 28684, 28667
11751, 28302, 347, 346, 28303, 28684, 355, 28685, 28669
11752, 28303, 346, 345, 28304, 28685, 354, 28686, 28671
11753, 28304, 345, 344, 28305, 28686, 353, 28687, 28673
11754, 28305, 344, 343, 28306, 28687, 352, 28688, 28675
11755, 28306, 343, 342, 28307, 28688, 351, 28689, 28677
11756, 28307, 342, 341, 28308, 28689, 350, 28690, 28679
11757, 28308, 341, 340, 28309, 28690, 349, 28691, 28681
11758, 28309, 340, 8, 3326, 28691, 348, 3349, 28683
*ELEMENT, type=CPS8, ELSET=Surface269
11759, 93, 3215, 28692, 3402, 3237, 28868, 28869, 3411
11760, 3402, 28692, 28693, 3401, 28869, 28870, 28871, 3410
11761, 3401, 28693, 28694, 3400, 28871, 28872, 28873, 3409
11762, 3400, 28694, 28695, 3399, 28873, 28874, 28875, 3408
11763, 3399, 28695, 28696, 3398, 28875, 28876, 28877, 3407
11764, 3398, 28696, 28697, 3397, 28877, 28878, 28879, 3406
11765, 3397, 28697, 28698, 3396, 28879, 28880, 28881, 3405
11766, 3396, 28698, 28699, 3395, 28881, 28882, 28883, 3404
11767, 3395, 28699, 3350, 95, 28883, 28884, 3372, 3403
11768, 3215, 3216, 28700, 28692, 3238, 28885, 28886, 28868
11769, 28692, 28700, 28701, 28693, 28886, 28887, 28888, 28870
11770, 28693, 28701, 28702, 28694, 28888, 28889, 28890, 28872
11771, 28694, 28702, 28703, 28695, 28890, 28891, 28892, 28874
11772, 28695, 28703, 28704, 28696, 28892, 28893, 28894, 28876
11773, 28696, 28704, 28705, 28697, 28894, 28895, 28896, 28878
11774, 28697, 28705, 28706, 28698, 28896, 28897, 28898, 28880
11775, 28698, 28706, 28707, 28699, 28898, 28899, 28900, 28882
11776, 28699, 28707, 3351, 3350, 28900, 28901, 3373, 28884
11777, 3216, 3217, 28708, 28700, 3239, 28902, 28903, 28885
11778, 28700, 28708, 28709, 28701, 28903, 28904, 28905, 28887
11779, 28701, 28709, 28710, 28702, 28905, 28906, 28907, 28889
11780, 28702, 28710, 28711, 28703, 28907, 28908, 28909, 28891
11781, 28703, 28711, 28712, 28704, 28909, 28910, 28911, 28893
11782, 28704, 28712, 28713, 28705, 28911, 28912, 28913, 28895
11783, 28705, 28713, 28714, 28706, 28913, 28914, 28915, 28897
11784, 28706, 28714, 28715, 28707, 28915, 28916, 28917, 28899
11785, 28707, 28715, 3352, 3351, 28917, 28918, 3374, 28901
11786, 3217, 3218, 28716, 28708, 3240, 28919, 28920, 28902
11787, 28708, 28716, 28717, 28709, 28920, 28921, 28922, 28904
11788, 28709, 28717, 28718, 28710, 28922, 28923, 28924, 28906
11789, 28710, 28718, 28719, 28711, 28924, 28925, 28926, 28908
11790, 28711, 28719, 28720, 28712, 28926, 28927, 28928, 28910
11791, 28712, 28720, 28721, 28713, 28928, 28929, 28930, 28912
11792, 28713, 28721, 28722, 28714, 28930, 28931, 28932, 28914
11793, 28714, 28722, 28723, 28715, 28932, 28933, 28934, 28916
11794, 28715, 28723, 3353, 3352, 28934, 28935, 3375, 28918
11795, 3218, 3219, 28724, 28716, 3241, 28936, 28937, 28919
11796, 28716, 28724, 28725, 28717, 28937, 28938, 28939, 28921
11797, 28717, 28725, 28726, 28718, 28939, 28940, 28941, 28923
11798, 28718, 28726, 28727, 28719, 28941, 28942, 28943, 28925
11799, 28719, 28727, 28728, 28720, 28943, 28944, 28945, 28927
11800, 28720, 28728, 28729, 28721, 28945, 28946, 28947, 28929
11801, 28721, 28729, 28730, 28722, 28947, 28948, 28949, 28931
11802, 28722, 28730, 28731, 28723, 28949, 28950, 28951, 28933
11803, 28723, 28731, 3354, 3353, 28951, 28952, 3376, 28935
11804, 3219, 3220, 28732, 28724, 3242, 28953, 28954, 28936
11805, 28724, 28732, 28733, 28725, 28954, 28955, 28956, 28938
11806, 28725, 28733, 28734, 28726, 28956, 28957, 28958, 28940
11807, 28726, 28734, 28735, 28727, 28958, 28959, 28960, 28942
11808, 28727, 28735, 28736, 28728, 28960, 28961, 28962, 28944
11809, 28728, 28736, 28737, 28729, 28962, 28963, 28964, 28946
11810, 28729, 28737, 28738, 28730, 28964, 28965, 28966, 28948
11811, 28730, 28738, 28739, 28731, 28966, 28967, 28968, 28950
11812, 28731, 28739, 3355, 3354, 28968, 28969, 3377, 28952
11813, 3220, 3221, 28740, 28732, 3243, 28970, 28971, 28953
11814, 28732, 28740, 28741, 28733, 28971, 28972, 28973, 28955
11815, 28733, 28741, 28742, 28734, 28973, 28974, 28975, 28957
11816, 28734, 28742, 28743, 28735, 28975, 28976, 28977, 28959
11817, 28735, 28743, 28744, 28736, 28977, 28978, 28979, 28961
11818, 28736, 28744, 28745, 28737, 28979, 28980, 28981, 28963
11819, 28737, 28745, 28746, 28738, 28981, 28982, 28983, 28965
11820, 28738, 28746, 28747, 28739, 28983, 28984, 28985, 28967
11821, 28739, 28747, 3356, 3355, 28985, 28986, 3378, 28969
