3375, 6939, 6940, 722, 721, 7026, 7052, 744, 7051
3376, 6940, 6941, 723, 722, 7028, 7053, 745, 7052
3377, 6941, 6942, 724, 723, 7030, 7054, 746, 7053
3378, 6942, 6943, 725, 724, 7032, 7055, 747, 7054
3379, 6943, 543, 23, 725, 7033, 546, 748, 7055
*ELEMENT, type=CPS8, ELSET=Surface178
3380, 22, 749, 7056, 590, 752, 7122, 7123, 613
3381, 590, 7056, 7057, 589, 7123, 7124, 7125, 612
3382, 589, 7057, 7058, 588, 7125, 7126, 7127, 611
3383, 588, 7058, 7059, 587, 7127, 7128, 7129, 610
3384, 587, 7059, 7060, 586, 7129, 7130, 7131, 609
3385, 586, 7060, 7061, 585, 7131, 7132, 7133, 608
3386, 585, 7061, 7062, 584, 7133, 7134, 7135, 607
3387, 584, 7062, 7063, 583, 7135, 7136, 7137, 606
3388, 583, 7063, 7064, 582, 7137, 7138, 7139, 605
3389, 582, 7064, 7065, 581, 7139, 7140, 7141, 604
3390, 581, 7065, 7066, 580, 7141, 7142, 7143, 603
3391, 580, 7066, 7067, 579, 7143, 7144, 7145, 602
3392, 579, 7067, 7068, 578, 7145, 7146, 7147, 601
3393, 578, 7068, 7069, 577, 7147, 7148, 7149, 600
3394, 577, 7069, 7070, 576, 7149, 7150, 7151, 599
3395, 576, 7070, 7071, 575, 7151, 7152, 7153, 598
3396, 575, 7071, 7072, 574, 7153, 7154, 7155, 597
3397, 574, 7072, 7073, 573, 7155, 7156, 7157, 596
3398, 573, 7073, 7074, 572, 7157, 7158, 7159, 595
3399, 572, 7074, 7075, 571, 7159, 7160, 7161, 594
3400, 571, 7075, 7076, 570, 7161, 7162, 7163, 593
3401, 570, 7076, 7077, 569, 7163, 7164, 7165, 592
3402, 569, 7077, 474, 13, 7165, 7166, 477, 591
3403, 749, 750, 7078, 7056, 753, 7167, 7168, 7122
3404, 7056, 7078, 7079, 7057, 7168, 7169, 7170, 7124
3405, 7057, 7079, 7080, 7058, 7170, 7171, 7172, 7126
3406, 7058, 7080, 7081, 7059, 7172, 7173, 7174, 7128
3407, 7059, 7081, 7082, 7060, 7174, 7175, 7176, 7130
3408, 7060, 7082, 7083, 7061, 7176, 7177, 7178, 7132
3409, 7061, 7083, 7084, 7062, 7178, 7179, 7180, 7134
3410, 7062, 7084, 7085, 7063, 7180, 7181, 7182, 7136
3411, 7063, 7085, 7086, 7064, 7182, 7183, 7184, 7138
3412, 7064, 7086, 7087, 7065, 7184, 7185, 7186, 7140
3413, 7065, 7087, 7088, 7066, 7186, 7187, 7188, 7142
3414, 7066, 7088, 7089, 7067, 7188, 7189, 7190, 7144
3415, 7067, 7089, 7090, 7068, 7190, 7191, 7192, 7146
3416, 7068, 7090, 7091, 7069, 7192, 7193, 7194, 7148
3417, 7069, 7091, 7092, 7070, 7194, 7195, 7196, 7150
3418, 7070, 7092, 7093, 7071, 7196, 7197, 7198, 7152
3419, 7071, 7093, 7094, 7072, 7198, 7199, 7200, 7154
3420, 7072, 7094, 7095, 7073, 7200, 7201, 7202, 7156
3421, 7073, 7095, 7096, 7074, 7202, 7203, 7204, 7158
3422, 7074, 7096, 7097, 7075, 7204, 7205, 7206, 7160
3423, 7075, 7097, 7098, 7076, 7206, 7207, 7208, 7162
3424, 7076, 7098, 7099, 7077, 7208, 7209, 7210, 7164
3425, 7077, 7099, 475, 474, 7210, 7211, 478, 7166
3426, 750, 751, 7100, 7078, 754, 7212, 7213, 7167
3427, 7078, 7100, 7101, 7079, 7213, 7214, 7215, 7169
3428, 7079, 7101, 7102, 7080, 7215, 7216, 7217, 7171
3429, 7080, 7102, 7103, 7081, 7217, 7218, 7219, 7173
3430, 7081, 7103, 7104, 7082, 7219, 7220, 7221, 7175
3431, 7082, 7104, 7105, 7083, 7221, 7222, 7223, 7177
3432, 7083, 7105, 7106, 7084, 7223, 7224, 7225, 7179
3433, 7084, 7106, 7107, 7085, 7225, 7226, 7227, 7181
3434, 7085, 7107, 7108, 7086, 7227, 7228, 7229, 7183
3435, 7086, 7108, 7109, 7087, 7229, 7230, 7231, 7185
3436, 7087, 7109, 7110, 7088, 7231, 7232, 7233, 7187
3437, 7088, 7110, 7111, 7089, 7233, 7234, 7235, 7189
3438, 7089, 7111, 7112, 7090, 7235, 7236, 7237, 7191
3439, 7090, 7112, 7113, 7091, 7237, 7238, 7239, 7193
3440, 7091, 7113, 7114, 7092, 7239, 7240, 7241, 7195
3441, 7092, 7114, 7115, 7093, 7241, 7242, 7243, 7197
3442, 7093, 7115, 7116, 7094, 7243, 7244, 7245, 7199
3443, 7094, 7116, 7117, 7095, 7245, 7246, 7247, 7201
3444, 7095, 7117, 7118, 7096, 7247, 7248, 7249, 7203
3445, 7096, 7118, 7119, 7097, 7249, 7250, 7251, 7205
3446, 7097, 7119, 7120, 7098, 7251, 7252, 7253, 7207
3447, 7098, 7120, 7121, 7099, 7253, 7254, 7255, 7209
3448, 7099, 7121, 476, 475, 7255, 7256, 479, 7211
3449, 751, 25, 777, 7100, 755, 800, 7257, 7212
3450, 7100, 777, 776, 7101, 7257, 799, 7258, 7214
3451, 7101, 776, 775, 7102, 7258, 798, 7259, 7216
3452, 7102, 775, 774, 7103, 7259, 797, 7260, 7218
3453, 7103, 774, 773, 7104, 7260, 796, 7261, 7220
3454, 7104, 773, 772, 7105, 7261, 795, 7262, 7222
3455, 7105, 772, 771, 7106, 7262, 794, 7263, 7224
3456, 7106, 771, 770, 7107, 7263, 793, 7264, 7226
3457, 7107, 770, 769, 7108, 7264, 792, 7265, 7228
3458, 7108, 769, 768, 7109, 7265, 791, 7266, 7230
3459, 7109, 768, 767, 7110, 7266, 790, 7267, 7232
3460, 7110, 767, 766, 7111, 7267, 789, 7268, 7234
3461, 7111, 766, 765, 7112, 7268, 788, 7269, 7236
3462, 7112, 765, 764, 7113, 7269, 787, 7270, 7238
3463, 7113, 764, 763, 7114, 7270, 786, 7271, 7240
3464, 7114, 763, 762, 7115, 7271, 785, 7272, 7242
3465, 7115, 762, 761, 7116, 7272, 784, 7273, 7244
3466, 7116, 761, 760, 7117, 7273, 783, 7274, 7246
3467, 7117, 760, 759, 7118, 7274, 782, 7275, 7248
3468, 7118, 759, 758, 7119, 7275, 781, 7276, 7250
3469, 7119, 758, 757, 7120, 7276, 780, 7277, 7252
3470, 7120, 757, 756, 7121, 7277, 779, 7278, 7254
3471, 7121, 756, 19, 476, 7278, 778, 480, 7256
*ELEMENT, type=CPS8, ELSET=Surface179
3472, 21, 801, 7279, 532, 804, 7303, 7304, 541
3473, 532, 7279, 7280, 531, 7304, 7305, 7306, 540
3474, 531, 7280, 7281, 530, 7306, 7307, 7308, 539
3475, 530, 7281, 7282, 529, 7308, 7309, 7310, 538
3476, 529, 7282, 7283, 528, 7310, 7311, 7312, 537
3477, 528, 7283, 7284, 527, 7312, 7313, 7314, 536
3478, 527, 7284, 7285, 526, 7314, 7315, 7316, 535
3479, 526, 7285, 7286, 525, 7316, 7317, 7318, 534
3480, 525, 7286, 749, 22, 7318, 7319, 752, 533
3481, 801, 802, 7287, 7279, 805, 7320, 7321, 7303
3482, 7279, 7287, 7288, 7280, 7321, 7322, 7323, 7305
3483, 7280, 7288, 7289, 7281, 7323, 7324, 7325, 7307
3484, 7281, 7289, 7290, 7282, 7325, 7326, 7327, 7309
3485, 7282, 7290, 7291, 7283, 7327, 7328, 7329, 7311
3486, 7283, 7291, 7292, 7284, 7329, 7330, 7331, 7313
3487, 7284, 7292, 7293, 7285, 7331, 7332, 7333, 7315
3488, 7285, 7293, 7294, 7286, 7333, 7334, 7335, 7317
3489, 7286, 7294, 750, 749, 7335, 7336, 753, 7319
3490, 802, 803, 7295, 7287, 806, 7337, 7338, 7320
3491, 7287, 7295, 7296, 7288, 7338, 7339, 7340, 7322
3492, 7288, 7296, 7297, 7289, 7340, 7341, 7342, 7324
3493, 7289, 7297, 7298, 7290, 7342, 7343, 7344, 7326
3494, 7290, 7298, 7299, 7291, 7344, 7345, 7346, 7328
3495, 7291, 7299, 7300, 7292, 7346, 7347, 7348, 7330
3496, 7292, 7300, 7301, 7293, 7348, 7349, 7350, 7332
3497, 7293, 7301, 7302, 7294, 7350, 7351, 7352, 7334
3498, 7294, 7302, 751, 750, 7352, 7353, 754, 7336
3499, 803, 26, 815, 7295, 807, 824, 7354, 7337
3500, 7295, 815, 814, 7296, 7354, 823, 7355, 7339
3501, 7296, 814, 813, 7297, 7355, 822, 7356, 7341
3502, 7297, 813, 812, 7298, 7356, 821, 7357, 7343
3503, 7298, 812, 811, 7299, 7357, 820, 7358, 7345
3504, 7299, 811, 810, 7300, 7358, 819, 7359, 7347
3505, 7300, 810, 809, 7301, 7359, 818, 7360, 7349
3506, 7301, 809, 808, 7302, 7360, 817, 7361, 7351
3507, 7302, 808, 25, 751, 7361, 816, 755, 7353
*ELEMENT, type=CPS8, ELSET=Surface180
3508, 21, 635, 7362, 801, 658, 7428, 7429, 804
3509, 635, 634, 7363, 7362, 657, 7430, 7431, 7428
3510, 634, 633, 7364, 7363, 656, 7432, 7433, 7430
3511, 633, 632, 7365, 7364, 655, 7434, 7435, 7432
3512, 632, 631, 7366, 7365, 654, 7436, 7437, 7434
3513, 631, 630, 7367, 7366, 653, 7438, 7439, 7436
3514, 630, 629, 7368, 7367, 652, 7440, 7441, 7438
3515, 629, 628, 7369, 7368, 651, 7442, 7443, 7440
3516, 628, 627, 7370, 7369, 650, 7444, 7445, 7442
3517, 627, 626, 7371, 7370, 649, 7446, 7447, 7444
3518, 626, 625, 7372, 7371, 648, 7448, 7449, 7446
3519, 625, 624, 7373, 7372, 647, 7450, 7451, 7448
3520, 624, 623, 7374, 7373, 646, 7452, 7453, 7450
3521, 623, 622, 7375, 7374, 645, 7454, 7455, 7452
3522, 622, 621, 7376, 7375, 644, 7456, 7457, 7454
3523, 621, 620, 7377, 7376, 643, 7458, 7459, 7456
3524, 620, 619, 7378, 7377, 642, 7460, 7461, 7458
3525, 619, 618, 7379, 7378, 641, 7462, 7463, 7460
3526, 618, 617, 7380, 7379, 640, 7464, 7465, 7462
3527, 617, 616, 7381, 7380, 639, 7466, 7467, 7464
3528, 616, 615, 7382, 7381, 638, 7468, 7469, 7466
3529, 615, 614, 7383, 7382, 637, 7470, 7471, 7468
3530, 614, 11, 457, 7383, 636, 460, 7472, 7470
3531, 801, 7362, 7384, 802, 7429, 7473, 7474, 805
3532, 7362, 7363, 7385, 7384, 7431, 7475, 7476, 7473
3533, 7363, 7364, 7386, 7385, 7433, 7477, 7478, 7475
3534, 7364, 7365, 7387, 7386, 7435, 7479, 7480, 7477
3535, 7365, 7366, 7388, 7387, 7437, 7481, 7482, 7479
3536, 7366, 7367, 7389, 7388, 7439, 7483, 7484, 7481
3537, 7367, 7368, 7390, 7389, 7441, 7485, 7486, 7483
3538, 7368, 7369, 7391, 7390, 7443, 7487, 7488, 7485
3539, 7369, 7370, 7392, 7391, 7445, 7489, 7490, 7487
3540, 7370, 7371, 7393, 7392, 7447, 7491, 7492, 7489
3541, 7371, 7372, 7394, 7393, 7449, 7493, 7494, 7491
3542, 7372, 7373, 7395, 7394, 7451, 7495, 7496, 7493
3543, 7373, 7374, 7396, 7395, 7453, 7497, 7498, 7495
3544, 7374, 7375, 7397, 7396, 7455, 7499, 7500, 7497
3545, 7375, 7376, 7398, 7397, 7457, 7501, 7502, 7499
3546, 7376, 7377, 7399, 7398, 7459, 7503, 7504, 7501
3547, 7377, 7378, 7400, 7399, 7461, 7505, 7506, 7503
3548, 7378, 7379, 7401, 7400, 7463, 7507, 7508, 7505
3549, 7379, 7380, 7402, 7401, 7465, 7509, 7510, 7507
3550, 7380, 7381, 7403, 7402, 7467, 7511, 7512, 7509
3551, 7381, 7382, 7404, 7403, 7469, 7513, 7514, 7511
3552, 7382, 7383, 7405, 7404, 7471, 7515, 7516, 7513
3553, 7383, 457, 458, 7405, 7472, 461, 7517, 7515
3554, 802, 7384, 7406, 803, 7474, 7518, 7519, 806
3555, 7384, 7385, 7407, 7406, 7476, 7520, 7521, 7518
3556, 7385, 7386, 7408, 7407, 7478, 7522, 7523, 7520
3557, 7386, 7387, 7409, 7408, 7480, 7524, 7525, 7522
3558, 7387, 7388, 7410, 7409, 7482, 7526, 7527, 7524
3559, 7388, 7389, 7411, 7410, 7484, 7528, 7529, 7526
3560, 7389, 7390, 7412, 7411, 7486, 7530, 7531, 7528
3561, 7390, 7391, 7413, 7412, 7488, 7532, 7533, 7530
3562, 7391, 7392, 7414, 7413, 7490, 7534, 7535, 7532
3563, 7392, 7393, 7415, 7414, 7492, 7536, 7537, 7534
3564, 7393, 7394, 7416, 7415, 7494, 7538, 7539, 7536
3565, 7394, 7395, 7417, 7416, 7496, 7540, 7541, 7538
3566, 7395, 7396, 7418, 7417, 7498, 7542, 7543, 7540
3567, 7396, 7397, 7419, 7418, 7500, 7544, 7545, 7542
3568, 7397, 7398, 7420, 7419, 7502, 7546, 7547, 7544
3569, 7398, 7399, 7421, 7420, 7504, 7548, 7549, 7546
3570, 7399, 7400, 7422, 7421, 7506, 7550, 7551, 7548
3571, 7400, 7401, 7423, 7422, 7508, 7552, 7553, 7550
3572, 7401, 7402, 7424, 7423, 7510, 7554, 7555, 7552
3573, 7402, 7403, 7425, 7424, 7512, 7556, 7557, 7554
3574, 7403, 7404, 7426, 7425, 7514, 7558, 7559, 7556
3575, 7404, 7405, 7427, 7426, 7516, 7560, 7561, 7558
3576, 7405, 458, 459, 7427, 7517, 462, 7562, 7560
3577, 803, 7406, 846, 26, 7519, 7563, 869, 807
3578, 7406, 7407, 845, 846, 7521, 7564, 868, 7563
3579, 7407, 7408, 844, 845, 7523, 7565, 867, 7564
3580, 7408, 7409, 843, 844, 7525, 7566, 866, 7565
3581, 7409, 7410, 842, 843, 7527, 7567, 865, 7566
3582, 7410, 7411, 841, 842, 7529, 7568, 864, 7567
3583, 7411, 7412, 840, 841, 7531, 7569, 863, 7568
3584, 7412, 7413, 839, 840, 7533, 7570, 862, 7569
3585, 7413, 7414, 838, 839, 7535, 7571, 861, 7570
3586, 7414, 7415, 837, 838, 7537, 7572, 860, 7571
3587, 7415, 7416, 836, 837, 7539, 7573, 859, 7572
3588, 7416, 7417, 835, 836, 7541, 7574, 858, 7573
3589, 7417, 7418, 834, 835, 7543, 7575, 857, 7574
3590, 7418, 7419, 833, 834, 7545, 7576, 856, 7575
3591, 7419, 7420, 832, 833, 7547, 7577, 855, 7576
3592, 7420, 7421, 831, 832, 7549, 7578, 854, 7577
3593, 7421, 7422, 830, 831, 7551, 7579, 853, 7578
3594, 7422, 7423, 829, 830, 7553, 7580, 852, 7579
3595, 7423, 7424, 828, 829, 7555, 7581, 851, 7580
3596, 7424, 7425, 827, 828, 7557, 7582, 850, 7581
3597, 7425, 7426, 826, 827, 7559, 7583, 849, 7582
3598, 7426, 7427, 825, 826, 7561, 7584, 848, 7583
3599, 7427, 459, 17, 825, 7562, 463, 847, 7584
*ELEMENT, type=CPS8, ELSET=Surface181
3600, 19, 756, 7585, 491, 778, 7761, 7762, 499
3601, 491, 7585, 7586, 492, 7762, 7763, 7764, 500
3602, 492, 7586, 7587, 493, 7764, 7765, 7766, 501
3603, 493, 7587, 7588, 494, 7766, 7767, 7768, 502
3604, 494, 7588, 7589, 495, 7768, 7769, 7770, 503
3605, 495, 7589, 7590, 496, 7770, 7771, 7772, 504
3606, 496, 7590, 7591, 497, 7772, 7773, 7774, 505
3607, 497, 7591, 7592, 498, 7774, 7775, 7776, 506
3608, 498, 7592, 825, 17, 7776, 7777, 847, 507
3609, 756, 757, 7593, 7585, 779, 7778, 7779, 7761
3610, 7585, 7593, 7594, 7586, 7779, 7780, 7781, 7763
3611, 7586, 7594, 7595, 7587, 7781, 7782, 7783, 7765
3612, 7587, 7595, 7596, 7588, 7783, 7784, 7785, 7767
3613, 7588, 7596, 7597, 7589, 7785, 7786, 7787, 7769
3614, 7589, 7597, 7598, 7590, 7787, 7788, 7789, 7771
3615, 7590, 7598, 7599, 7591, 7789, 7790, 7791, 7773
3616, 7591, 7599, 7600, 7592, 7791, 7792, 7793, 7775
3617, 7592, 7600, 826, 825, 7793, 7794, 848, 7777
3618, 757, 758, 7601, 7593, 780, 7795, 7796, 7778
3619, 7593, 7601, 7602, 7594, 7796, 7797, 7798, 7780
3620, 7594, 7602, 7603, 7595, 7798, 7799, 7800, 7782
3621, 7595, 7603, 7604, 7596, 7800, 7801, 7802, 7784
3622, 7596, 7604, 7605, 7597, 7802, 7803, 7804, 7786
3623, 7597, 7605, 7606, 7598, 7804, 7805, 7806, 7788
3624, 7598, 7606, 7607, 7599, 7806, 7807, 7808, 7790
3625, 7599, 7607, 7608, 7600, 7808, 7809, 7810, 7792
3626, 7600, 7608, 827, 826, 7810, 7811, 849, 7794
3627, 758, 759, 7609, 7601, 781, 7812, 7813, 7795
3628, 7601, 7609, 7610, 7602, 7813, 7814, 7815, 7797
3629, 7602, 7610, 7611, 7603, 7815, 7816, 7817, 7799
3630, 7603, 7611, 7612, 7604, 7817, 7818, 7819, 7801
3631, 7604, 7612, 7613, 7605, 7819, 7820, 7821, 7803
3632, 7605, 7613, 7614, 7606, 7821, 7822, 7823, 7805
3633, 7606, 7614, 7615, 7607, 7823, 7824, 7825, 7807
3634, 7607, 7615, 7616, 7608, 7825, 7826, 7827, 7809
3635, 7608, 7616, 828, 827, 7827, 7828, 850, 7811
3636, 759, 760, 7617, 7609, 782, 7829, 7830, 7812
3637, 7609, 7617, 7618, 7610, 7830, 7831, 7832, 7814
3638, 7610, 7618, 7619, 7611, 7832, 7833, 7834, 7816
3639, 7611, 7619, 7620, 7612, 7834, 7835, 7836, 7818
3640, 7612, 7620, 7621, 7613, 7836, 7837, 7838, 7820
3641, 7613, 7621, 7622, 7614, 7838, 7839, 7840, 7822
3642, 7614, 7622, 7623, 7615, 7840, 7841, 7842, 7824
3643, 7615, 7623, 7624, 7616, 7842, 7843, 7844, 7826
3644, 7616, 7624, 829, 828, 7844, 7845, 851, 7828
3645, 760, 761, 7625, 7617, 783, 7846, 7847, 7829
3646, 7617, 7625, 7626, 7618, 7847, 7848, 7849, 7831
3647, 7618, 7626, 7627, 7619, 7849, 7850, 7851, 7833
3648, 7619, 7627, 7628, 7620, 7851, 7852, 7853, 7835
3649, 7620, 7628, 7629, 7621, 7853, 7854, 7855, 7837
3650, 7621, 7629, 7630, 7622, 7855, 7856, 7857, 7839
3651, 7622, 7630, 7631, 7623, 7857, 7858, 7859, 7841
3652, 7623, 7631, 7632, 7624, 7859, 7860, 7861, 7843
3653, 7624, 7632, 830, 829, 7861, 7862, 852, 7845
3654, 761, 762, 7633, 7625, 784, 7863, 7864, 7846
3655, 7625, 7633, 7634, 7626, 7864, 7865, 7866, 7848
3656, 7626, 7634, 7635, 7627, 7866, 7867, 7868, 7850
3657, 7627, 7635, 7636, 7628, 7868, 7869, 7870, 7852
3658, 7628, 7636, 7637, 7629, 7870, 7871, 7872, 7854
3659, 7629, 7637, 7638, 7630, 7872, 7873, 7874, 7856
3660, 7630, 7638, 7639, 7631, 7874, 7875, 7876, 7858
3661, 7631, 7639, 7640, 7632, 7876, 7877, 7878, 7860
3662, 7632, 7640, 831, 830, 7878, 7879, 853, 7862
3663, 762, 763, 7641, 7633, 785, 7880, 7881, 7863
3664, 7633, 7641, 7642, 7634, 7881, 7882, 7883, 7865
3665, 7634, 7642, 7643, 7635, 7883, 7884, 7885, 7867
3666, 7635, 7643, 7644, 7636, 7885, 7886, 7887, 7869
3667, 7636, 7644, 7645, 7637, 7887, 7888, 7889, 7871
3668, 7637, 7645, 7646, 7638, 7889, 7890, 7891, 7873
3669, 7638, 7646, 7647, 7639, 7891, 7892, 7893, 7875
3670, 7639, 7647, 7648, 7640, 7893, 7894, 7895, 7877
3671, 7640, 7648, 832, 831, 7895, 7896, 854, 7879
3672, 763, 764, 7649, 7641, 786, 7897, 7898, 7880
3673, 7641, 7649, 7650, 7642, 7898, 7899, 7900, 7882
3674, 7642, 7650, 7651, 7643, 7900, 7901, 7902, 7884
3675, 7643, 7651, 7652, 7644, 7902, 7903, 7904, 7886
3676, 7644, 7652, 7653, 7645, 7904, 7905, 7906, 7888
3677, 7645, 7653, 7654, 7646, 7906, 7907, 7908, 7890
3678, 7646, 7654, 7655, 7647, 7908, 7909, 7910, 7892
3679, 7647, 7655, 7656, 7648, 7910, 7911, 7912, 7894
3680, 7648, 7656, 833, 832, 7912, 7913, 855, 7896
3681, 764, 765, 7657, 7649, 787, 7914, 7915, 7897
3682, 7649, 7657, 7658, 7650, 7915, 7916, 7917, 7899
3683, 7650, 7658, 7659, 7651, 7917, 7918, 7919, 7901
3684, 7651, 7659, 7660, 7652, 7919, 7920, 7921, 7903
3685, 7652, 7660, 7661, 7653, 7921, 7922, 7923, 7905
3686, 7653, 7661, 7662, 7654, 7923, 7924, 7925, 7907
3687, 7654, 7662, 7663, 7655, 7925, 7926, 7927, 7909
3688, 7655, 7663, 7664, 7656, 7927, 7928, 7929, 7911
3689, 7656, 7664, 834, 833, 7929, 7930, 856, 7913
3690, 765, 766, 7665, 7657, 788, 7931, 7932, 7914
3691, 7657, 7665, 7666, 7658, 7932, 7933, 7934, 7916
3692, 7658, 7666, 7667, 7659, 7934, 7935, 7936, 7918
3693, 7659, 7667, 7668, 7660, 7936, 7937, 7938, 7920
3694, 7660, 7668, 7669, 7661, 7938, 7939, 7940, 7922
3695, 7661, 7669, 7670, 7662, 7940, 7941, 7942, 7924
3696, 7662, 7670, 7671, 7663, 7942, 7943, 7944, 7926
3697, 7663, 7671, 7672, 7664, 7944, 7945, 7946, 7928
3698, 7664, 7672, 835, 834, 7946, 7947, 857, 7930
3699, 766, 767, 7673, 7665, 789, 7948, 7949, 7931
3700, 7665, 7673, 7674, 7666, 7949, 7950, 7951, 7933
3701, 7666, 7674, 7675, 7667, 7951, 7952, 7953, 7935
3702, 7667, 7675, 7676, 7668, 7953, 7954, 7955, 7937
3703, 7668, 7676, 7677, 7669, 7955, 7956, 7957, 7939
3704, 7669, 7677, 7678, 7670, 7957, 7958, 7959, 7941
3705, 7670, 7678, 7679, 7671, 7959, 7960, 7961, 7943
3706, 7671, 7679, 7680, 7672, 7961, 7962, 7963, 7945
3707, 7672, 7680, 836, 835, 7963, 7964, 858, 7947
3708, 767, 768, 7681, 7673, 790, 7965, 7966, 7948
3709, 7673, 7681, 7682, 7674, 7966, 7967, 7968, 7950
3710, 7674, 7682, 7683, 7675, 7968, 7969, 7970, 7952
3711, 7675, 7683, 7684, 7676, 7970, 7971, 7972, 7954
3712, 7676, 7684, 7685, 7677, 7972, 7973, 7974, 7956
3713, 7677, 7685, 7686, 7678, 7974, 7975, 7976, 7958
3714, 7678, 7686, 7687, 7679, 7976, 7977, 7978, 7960
3715, 7679, 7687, 7688, 7680, 7978, 7979, 7980, 7962
3716, 7680, 7688, 837, 836, 7980, 7981, 859, 7964
3717, 768, 769, 7689, 7681, 791, 7982, 7983, 7965
3718, 7681, 7689, 7690, 7682, 7983, 7984, 7985, 7967
3719, 7682, 7690, 7691, 7683, 7985, 7986, 7987, 7969
3720, 7683, 7691, 7692, 7684, 7987, 7988, 7989, 7971
3721, 7684, 7692, 7693, 7685, 7989, 7990, 7991, 7973
3722, 7685, 7693, 7694, 7686, 7991, 7992, 7993, 7975
3723, 7686, 7694, 7695, 7687, 7993, 7994, 7995, 7977
3724, 7687, 7695, 7696, 7688, 7995, 7996, 7997, 7979
3725, 7688, 7696, 838, 837, 7997, 7998, 860, 7981
3726, 769, 770, 7697, 7689, 792, 7999, 8000, 7982
3727, 7689, 7697, 7698, 7690, 8000, 8001, 8002, 7984
3728, 7690, 7698, 7699, 7691, 8002, 8003, 8004, 7986
3729, 7691, 7699, 7700, 7692, 8004, 8005, 8006, 7988
3730, 7692, 7700, 7701, 7693, 8006, 8007, 8008, 7990
3731, 7693, 7701, 7702, 7694, 8008, 8009, 8010, 7992
3732, 7694, 7702, 7703, 7695, 8010, 8011, 8012, 7994
3733, 7695, 7703, 7704, 7696, 8012, 8013, 8014, 7996
3734, 7696, 7704, 839, 838, 8014, 8015, 861, 7998
3735, 770, 771, 7705, 7697, 793, 8016, 8017, 7999
3736, 7697, 7705, 7706, 7698, 8017, 8018, 8019, 8001
3737, 7698, 7706, 7707, 7699, 8019, 8020, 8021, 8003
3738, 7699, 7707, 7708, 7700, 8021, 8022, 8023, 8005
3739, 7700, 7708, 7709, 7701, 8023, 8024, 8025, 8007
3740, 7701, 7709, 7710, 7702, 8025, 8026, 8027, 8009
3741, 7702, 7710, 7711, 7703, 8027, 8028, 8029, 8011
3742, 7703, 7711, 7712, 7704, 8029, 8030, 8031, 8013
3743, 7704, 7712, 840, 839, 8031, 8032, 862, 8015
3744, 771, 772, 7713, 7705, 794, 8033, 8034, 8016
3745, 7705, 7713, 7714, 7706, 8034, 8035, 8036, 8018
3746, 7706, 7714, 7715, 7707, 8036, 8037, 8038, 8020
3747, 7707, 7715, 7716, 7708, 8038, 8039, 8040, 8022
3748, 7708, 7716, 7717, 7709, 8040, 8041, 8042, 8024
3749, 7709, 7717, 7718, 7710, 8042, 8043, 8044, 8026
3750, 7710, 7718, 7719, 7711, 8044, 8045, 8046, 8028
3751, 7711, 7719, 7720, 7712, 8046, 8047, 8048, 8030
3752, 7712, 7720, 841, 840, 8048, 8049, 863, 8032
3753, 772, 773, 7721, 7713, 795, 8050, 8051, 8033
3754, 7713, 7721, 7722, 7714, 8051, 8052, 8053, 8035
3755, 7714, 7722, 7723, 7715, 8053, 8054, 8055, 8037
3756, 7715, 7723, 7724, 7716, 8055, 8056, 8057, 8039
3757, 7716, 7724, 7725, 7717, 8057, 8058, 8059, 8041
3758, 7717, 7725, 7726, 7718, 8059, 8060, 8061, 8043
3759, 7718, 7726, 7727, 7719, 8061, 8062, 8063, 8045
3760, 7719, 7727, 7728, 7720, 8063, 8064, 8065, 8047
3761, 7720, 7728, 842, 841, 8065, 8066, 864, 8049
3762, 773, 774, 7729, 7721, 796, 8067, 8068, 8050
3763, 7721, 7729, 7730, 7722, 8068, 8069, 8070, 8052
3764, 7722, 7730, 7731, 7723, 8070, 8071, 8072, 8054
3765, 7723, 7731, 7732, 7724, 8072, 8073, 8074, 8056
3766, 7724, 7732, 7733, 7725, 8074, 8075, 8076, 8058
3767, 7725, 7733, 7734, 7726, 8076, 8077, 8078, 8060
3768, 7726, 7734, 7735, 7727, 8078, 8079, 8080, 8062
3769, 7727, 7735, 7736, 7728, 8080, 8081, 8082, 8064
3770, 7728, 7736, 843, 842, 8082, 8083, 865, 8066
3771, 774, 775, 7737, 7729, 797, 8084, 8085, 8067
3772, 7729, 7737, 7738, 7730, 8085, 8086, 8087, 8069
3773, 7730, 7738, 7739, 7731, 8087, 8088, 8089, 8071
3774, 7731, 7739, 7740, 7732, 8089, 8090, 8091, 8073
3775, 7732, 7740, 7741, 7733, 8091, 8092, 8093, 8075
3776, 7733, 7741, 7742, 7734, 8093, 8094, 8095, 8077
3777, 7734, 7742, 7743, 7735, 8095, 8096, 8097, 8079
3778, 7735, 7743, 7744, 7736, 8097, 8098, 8099, 8081
3779, 7736, 7744, 844, 843, 8099, 8100, 866, 8083
3780, 775, 776, 7745, 7737, 798, 8101, 8102, 8084
3781, 7737, 7745, 7746, 7738, 8102, 8103, 8104, 8086
3782, 7738, 7746, 7747, 7739, 8104, 8105, 8106, 8088
3783, 7739, 7747, 7748, 7740, 8106, 8107, 8108, 8090
3784, 7740, 7748, 7749, 7741, 8108, 8109, 8110, 8092
3785, 7741, 7749, 7750, 7742, 8110, 8111, 8112, 8094
3786, 7742, 7750, 7751, 7743, 8112, 8113, 8114, 8096
3787, 7743, 7751, 7752, 7744, 8114, 8115, 8116, 8098
3788, 7744, 7752, 845, 844, 8116, 8117, 867, 8100
3789, 776, 777, 7753, 7745, 799, 8118, 8119, 8101
3790, 7745, 7753, 7754, 7746, 8119, 8120, 8121, 8103
3791, 7746, 7754, 7755, 7747, 8121, 8122, 8123, 8105
3792, 7747, 7755, 7756, 7748, 8123, 8124, 8125, 8107
3793, 7748, 7756, 7757, 7749, 8125, 8126, 8127, 8109
3794, 7749, 7757, 7758, 7750, 8127, 8128, 8129, 8111
3795, 7750, 7758, 7759, 7751, 8129, 8130, 8131, 8113
3796, 7751, 7759, 7760, 7752, 8131, 8132, 8133, 8115
3797, 7752, 7760, 846, 845, 8133, 8134, 868, 8117
3798, 777, 25, 808, 7753, 800, 816, 8135, 8118
3799, 7753, 808, 809, 7754, 8135, 817, 8136, 8120
3800, 7754, 809, 810, 7755, 8136, 818, 8137, 8122
3801, 7755, 810, 811, 7756, 8137, 819, 8138, 8124
3802, 7756, 811, 812, 7757, 8138, 820, 8139, 8126
3803, 7757, 812, 813, 7758, 8139, 821, 8140, 8128
3804, 7758, 813, 814, 7759, 8140, 822, 8141, 8130
3805, 7759, 814, 815, 7760, 8141, 823, 8142, 8132
3806, 7760, 815, 26, 846, 8142, 824, 869, 8134
*ELEMENT, type=CPS8, ELSET=Surface182
3807, 21, 801, 8143, 870, 804, 8152, 8153, 873
3808, 801, 802, 8144, 8143, 805, 8154, 8155, 8152
3809, 802, 803, 8145, 8144, 806, 8156, 8157, 8154
3810, 803, 26, 877, 8145, 807, 880, 8158, 8156
3811, 870, 8143, 8146, 871, 8153, 8159, 8160, 874
3812, 8143, 8144, 8147, 8146, 8155, 8161, 8162, 8159
3813, 8144, 8145, 8148, 8147, 8157, 8163, 8164, 8161
3814, 8145, 877, 878, 8148, 8158, 881, 8165, 8163
3815, 871, 8146, 8149, 872, 8160, 8166, 8167, 875
3816, 8146, 8147, 8150, 8149, 8162, 8168, 8169, 8166
3817, 8147, 8148, 8151, 8150, 8164, 8170, 8171, 8168
3818, 8148, 878, 879, 8151, 8165, 882, 8172, 8170
3819, 872, 8149, 884, 27, 8167, 8173, 887, 876
3820, 8149, 8150, 885, 884, 8169, 8174, 888, 8173
3821, 8150, 8151, 886, 885, 8171, 8175, 889, 8174
3822, 8151, 879, 28, 886, 8172, 883, 890, 8175
*ELEMENT, type=CPS8, ELSET=Surface183
3823, 22, 891, 8176, 749, 894, 8185, 8186, 752
3824, 749, 8176, 8177, 750, 8186, 8187, 8188, 753
3825, 750, 8177, 8178, 751, 8188, 8189, 8190, 754
3826, 751, 8178, 898, 25, 8190, 8191, 901, 755
3827, 891, 892, 8179, 8176, 895, 8192, 8193, 8185
3828, 8176, 8179, 8180, 8177, 8193, 8194, 8195, 8187
3829, 8177, 8180, 8181, 8178, 8195, 8196, 8197, 8189
3830, 8178, 8181, 899, 898, 8197, 8198, 902, 8191
3831, 892, 893, 8182, 8179, 896, 8199, 8200, 8192
3832, 8179, 8182, 8183, 8180, 8200, 8201, 8202, 8194
3833, 8180, 8183, 8184, 8181, 8202, 8203, 8204, 8196
3834, 8181, 8184, 900, 899, 8204, 8205, 903, 8198
3835, 893, 29, 905, 8182, 897, 908, 8206, 8199
3836, 8182, 905, 906, 8183, 8206, 909, 8207, 8201
3837, 8183, 906, 907, 8184, 8207, 910, 8208, 8203
3838, 8184, 907, 30, 900, 8208, 911, 904, 8205
*ELEMENT, type=CPS8, ELSET=Surface184
3839, 21, 870, 8209, 532, 873, 8233, 8234, 541
3840, 532, 8209, 8210, 531, 8234, 8235, 8236, 540
3841, 531, 8210, 8211, 530, 8236, 8237, 8238, 539
3842, 530, 8211, 8212, 529, 8238, 8239, 8240, 538
3843, 529, 8212, 8213, 528, 8240, 8241, 8242, 537
3844, 528, 8213, 8214, 527, 8242, 8243, 8244, 536
3845, 527, 8214, 8215, 526, 8244, 8245, 8246, 535
3846, 526, 8215, 8216, 525, 8246, 8247, 8248, 534
3847, 525, 8216, 891, 22, 8248, 8249, 894, 533
3848, 870, 871, 8217, 8209, 874, 8250, 8251, 8233
3849, 8209, 8217, 8218, 8210, 8251, 8252, 8253, 8235
3850, 8210, 8218, 8219, 8211, 8253, 8254, 8255, 8237
3851, 8211, 8219, 8220, 8212, 8255, 8256, 8257, 8239
3852, 8212, 8220, 8221, 8213, 8257, 8258, 8259, 8241
3853, 8213, 8221, 8222, 8214, 8259, 8260, 8261, 8243
3854, 8214, 8222, 8223, 8215, 8261, 8262, 8263, 8245
3855, 8215, 8223, 8224, 8216, 8263, 8264, 8265, 8247
3856, 8216, 8224, 892, 891, 8265, 8266, 895, 8249
3857, 871, 872, 8225, 8217, 875, 8267, 8268, 8250
3858, 8217, 8225, 8226, 8218, 8268, 8269, 8270, 8252
3859, 8218, 8226, 8227, 8219, 8270, 8271, 8272, 8254
3860, 8219, 8227, 8228, 8220, 8272, 8273, 8274, 8256
3861, 8220, 8228, 8229, 8221, 8274, 8275, 8276, 8258
3862, 8221, 8229, 8230, 8222, 8276, 8277, 8278, 8260
3863, 8222, 8230, 8231, 8223, 8278, 8279, 8280, 8262
3864, 8223, 8231, 8232, 8224, 8280, 8281, 8282, 8264
3865, 8224, 8232, 893, 892, 8282, 8283, 896, 8266
3866, 872, 27, 919, 8225, 876, 928, 8284, 8267
3867, 8225, 919, 918, 8226, 8284, 927, 8285, 8269
3868, 8226, 918, 917, 8227, 8285, 926, 8286, 8271
3869, 8227, 917, 916, 8228, 8286, 925, 8287, 8273
3870, 8228, 916, 915, 8229, 8287, 924, 8288, 8275
3871, 8229, 915, 914, 8230, 8288, 923, 8289, 8277
3872, 8230, 914, 913, 8231, 8289, 922, 8290, 8279
3873, 8231, 913, 912, 8232, 8290, 921, 8291, 8281
3874, 8232, 912, 29, 893, 8291, 920, 897, 8283
*ELEMENT, type=CPS8, ELSET=Surface185
3875, 26, 815, 8292, 877, 824, 8316, 8317, 880
3876, 815, 814, 8293, 8292, 823, 8318, 8319, 8316
3877, 814, 813, 8294, 8293, 822, 8320, 8321, 8318
3878, 813, 812, 8295, 8294, 821, 8322, 8323, 8320
3879, 812, 811, 8296, 8295, 820, 8324, 8325, 8322
3880, 811, 810, 8297, 8296, 819, 8326, 8327, 8324
3881, 810, 809, 8298, 8297, 818, 8328, 8329, 8326
3882, 809, 808, 8299, 8298, 817, 8330, 8331, 8328
3883, 808, 25, 898, 8299, 816, 901, 8332, 8330
3884, 877, 8292, 8300, 878, 8317, 8333, 8334, 881
3885, 8292, 8293, 8301, 8300, 8319, 8335, 8336, 8333
3886, 8293, 8294, 8302, 8301, 8321, 8337, 8338, 8335
3887, 8294, 8295, 8303, 8302, 8323, 8339, 8340, 8337
3888, 8295, 8296, 8304, 8303, 8325, 8341, 8342, 8339
3889, 8296, 8297, 8305, 8304, 8327, 8343, 8344, 8341
3890, 8297, 8298, 8306, 8305, 8329, 8345, 8346, 8343
3891, 8298, 8299, 8307, 8306, 8331, 8347, 8348, 8345
3892, 8299, 898, 899, 8307, 8332, 902, 8349, 8347
3893, 878, 8300, 8308, 879, 8334, 8350, 8351, 882
3894, 8300, 8301, 8309, 8308, 8336, 8352, 8353, 8350
3895, 8301, 8302, 8310, 8309, 8338, 8354, 8355, 8352
3896, 8302, 8303, 8311, 8310, 8340, 8356, 8357, 8354
3897, 8303, 8304, 8312, 8311, 8342, 8358, 8359, 8356
3898, 8304, 8305, 8313, 8312, 8344, 8360, 8361, 8358
3899, 8305, 8306, 8314, 8313, 8346, 8362, 8363, 8360
3900, 8306, 8307, 8315, 8314, 8348, 8364, 8365, 8362
3901, 8307, 899, 900, 8315, 8349, 903, 8366, 8364
3902, 879, 8308, 936, 28, 8351, 8367, 945, 883
3903, 8308, 8309, 935, 936, 8353, 8368, 944, 8367
3904, 8309, 8310, 934, 935, 8355, 8369, 943, 8368
3905, 8310, 8311, 933, 934, 8357, 8370, 942, 8369
3906, 8311, 8312, 932, 933, 8359, 8371, 941, 8370
3907, 8312, 8313, 931, 932, 8361, 8372, 940, 8371
3908, 8313, 8314, 930, 931, 8363, 8373, 939, 8372
3909, 8314, 8315, 929, 930, 8365, 8374, 938, 8373
3910, 8315, 900, 30, 929, 8366, 904, 937, 8374
*ELEMENT, type=CPS8, ELSET=Surface186
3911, 27, 884, 8375, 919, 887, 8399, 8400, 928
3912, 919, 8375, 8376, 918, 8400, 8401, 8402, 927
3913, 918, 8376, 8377, 917, 8402, 8403, 8404, 926
3914, 917, 8377, 8378, 916, 8404, 8405, 8406, 925
3915, 916, 8378, 8379, 915, 8406, 8407, 8408, 924
3916, 915, 8379, 8380, 914, 8408, 8409, 8410, 923
3917, 914, 8380, 8381, 913, 8410, 8411, 8412, 922
3918, 913, 8381, 8382, 912, 8412, 8413, 8414, 921
3919, 912, 8382, 905, 29, 8414, 8415, 908, 920
3920, 884, 885, 8383, 8375, 888, 8416, 8417, 8399
3921, 8375, 8383, 8384, 8376, 8417, 8418, 8419, 8401
3922, 8376, 8384, 8385, 8377, 8419, 8420, 8421, 8403
3923, 8377, 8385, 8386, 8378, 8421, 8422, 8423, 8405
3924, 8378, 8386, 8387, 8379, 8423, 8424, 8425, 8407
3925, 8379, 8387, 8388, 8380, 8425, 8426, 8427, 8409
3926, 8380, 8388, 8389, 8381, 8427, 8428, 8429, 8411
3927, 8381, 8389, 8390, 8382, 8429, 8430, 8431, 8413
3928, 8382, 8390, 906, 905, 8431, 8432, 909, 8415
3929, 885, 886, 8391, 8383, 889, 8433, 8434, 8416
3930, 8383, 8391, 8392, 8384, 8434, 8435, 8436, 8418
3931, 8384, 8392, 8393, 8385, 8436, 8437, 8438, 8420
3932, 8385, 8393, 8394, 8386, 8438, 8439, 8440, 8422
3933, 8386, 8394, 8395, 8387, 8440, 8441, 8442, 8424
3934, 8387, 8395, 8396, 8388, 8442, 8443, 8444, 8426
3935, 8388, 8396, 8397, 8389, 8444, 8445, 8446, 8428
3936, 8389, 8397, 8398, 8390, 8446, 8447, 8448, 8430
3937, 8390, 8398, 907, 906, 8448, 8449, 910, 8432
3938, 886, 28, 936, 8391, 890, 945, 8450, 8433
3939, 8391, 936, 935, 8392, 8450, 944, 8451, 8435
3940, 8392, 935, 934, 8393, 8451, 943, 8452, 8437
3941, 8393, 934, 933, 8394, 8452, 942, 8453, 8439
3942, 8394, 933, 932, 8395, 8453, 941, 8454, 8441
3943, 8395, 932, 931, 8396, 8454, 940, 8455, 8443
3944, 8396, 931, 930, 8397, 8455, 939, 8456, 8445
3945, 8397, 930, 929, 8398, 8456, 938, 8457, 8447
3946, 8398, 929, 30, 907, 8457, 937, 911, 8449
*ELEMENT, type=CPS8, ELSET=Surface187
3947, 27, 884, 8458, 953, 887, 8524, 8525, 975
3948, 953, 8458, 8459, 954, 8525, 8526, 8527, 976
3949, 954, 8459, 8460, 955, 8527, 8528, 8529, 977
3950, 955, 8460, 8461, 956, 8529, 8530, 8531, 978
3951, 956, 8461, 8462, 957, 8531, 8532, 8533, 979
3952, 957, 8462, 8463, 958, 8533, 8534, 8535, 980
3953, 958, 8463, 8464, 959, 8535, 8536, 8537, 981
3954, 959, 8464, 8465, 960, 8537, 8538, 8539, 982
3955, 960, 8465, 8466, 961, 8539, 8540, 8541, 983
3956, 961, 8466, 8467, 962, 8541, 8542, 8543, 984
3957, 962, 8467, 8468, 963, 8543, 8544, 8545, 985
3958, 963, 8468, 8469, 964, 8545, 8546, 8547, 986
3959, 964, 8469, 8470, 965, 8547, 8548, 8549, 987
3960, 965, 8470, 8471, 966, 8549, 8550, 8551, 988
3961, 966, 8471, 8472, 967, 8551, 8552, 8553, 989
3962, 967, 8472, 8473, 968, 8553, 8554, 8555, 990
3963, 968, 8473, 8474, 969, 8555, 8556, 8557, 991
3964, 969, 8474, 8475, 970, 8557, 8558, 8559, 992
3965, 970, 8475, 8476, 971, 8559, 8560, 8561, 993
3966, 971, 8476, 8477, 972, 8561, 8562, 8563, 994
3967, 972, 8477, 8478, 973, 8563, 8564, 8565, 995
3968, 973, 8478, 8479, 974, 8565, 8566, 8567, 996
3969, 974, 8479, 946, 31, 8567, 8568, 949, 997
3970, 884, 885, 8480, 8458, 888, 8569, 8570, 8524
3971, 8458, 8480, 8481, 8459, 8570, 8571, 8572, 8526
3972, 8459, 8481, 8482, 8460, 8572, 8573, 8574, 8528
3973, 8460, 8482, 8483, 8461, 8574, 8575, 8576, 8530
3974, 8461, 8483, 8484, 8462, 8576, 8577, 8578, 8532
3975, 8462, 8484, 8485, 8463, 8578, 8579, 8580, 8534
3976, 8463, 8485, 8486, 8464, 8580, 8581, 8582, 8536
3977, 8464, 8486, 8487, 8465, 8582, 8583, 8584, 8538
3978, 8465, 8487, 8488, 8466, 8584, 8585, 8586, 8540
3979, 8466, 8488, 8489, 8467, 8586, 8587, 8588, 8542
3980, 8467, 8489, 8490, 8468, 8588, 8589, 8590, 8544
3981, 8468, 8490, 8491, 8469, 8590, 8591, 8592, 8546
3982, 8469, 8491, 8492, 8470, 8592, 8593, 8594, 8548
3983, 8470, 8492, 8493, 8471, 8594, 8595, 8596, 8550
3984, 8471, 8493, 8494, 8472, 8596, 8597, 8598, 8552
3985, 8472, 8494, 8495, 8473, 8598, 8599, 8600, 8554
3986, 8473, 8495, 8496, 8474, 8600, 8601, 8602, 8556
3987, 8474, 8496, 8497, 8475, 8602, 8603, 8604, 8558
3988, 8475, 8497, 8498, 8476, 8604, 8605, 8606, 8560
3989, 8476, 8498, 8499, 8477, 8606, 8607, 8608, 8562
3990, 8477, 8499, 8500, 8478, 8608, 8609, 8610, 8564
3991, 8478, 8500, 8501, 8479, 8610, 8611, 8612, 8566
3992, 8479, 8501, 947, 946, 8612, 8613, 950, 8568
3993, 885, 886, 8502, 8480, 889, 8614, 8615, 8569
3994, 8480, 8502, 8503, 8481, 8615, 8616, 8617, 8571
3995, 8481, 8503, 8504, 8482, 8617, 8618, 8619, 8573
3996, 8482, 8504, 8505, 8483, 8619, 8620, 8621, 8575
3997, 8483, 8505, 8506, 8484, 8621, 8622, 8623, 8577
3998, 8484, 8506, 8507, 8485, 8623, 8624, 8625, 8579
3999, 8485, 8507, 8508, 8486, 8625, 8626, 8627, 8581
4000, 8486, 8508, 8509, 8487, 8627, 8628, 8629, 8583
4001, 8487, 8509, 8510, 8488, 8629, 8630, 8631, 8585
4002, 8488, 8510, 8511, 8489, 8631, 8632, 8633, 8587
4003, 8489, 8511, 8512, 8490, 8633, 8634, 8635, 8589
4004, 8490, 8512, 8513, 8491, 8635, 8636, 8637, 8591
4005, 8491, 8513, 8514, 8492, 8637, 8638, 8639, 8593
4006, 8492, 8514, 8515, 8493, 8639, 8640, 8641, 8595
4007, 8493, 8515, 8516, 8494, 8641, 8642, 8643, 8597
4008, 8494, 8516, 8517, 8495, 8643, 8644, 8645, 8599
4009, 8495, 8517, 8518, 8496, 8645, 8646, 8647, 8601
4010, 8496, 8518, 8519, 8497, 8647, 8648, 8649, 8603
4011, 8497, 8519, 8520, 8498, 8649, 8650, 8651, 8605
4012, 8498, 8520, 8521, 8499, 8651, 8652, 8653, 8607
4013, 8499, 8521, 8522, 8500, 8653, 8654, 8655, 8609
4014, 8500, 8522, 8523, 8501, 8655, 8656, 8657, 8611
4015, 8501, 8523, 948, 947, 8657, 8658, 951, 8613
4016, 886, 28, 998, 8502, 890, 1020, 8659, 8614
4017, 8502, 998, 999, 8503, 8659, 1021, 8660, 8616
4018, 8503, 999, 1000, 8504, 8660, 1022, 8661, 8618
4019, 8504, 1000, 1001, 8505, 8661, 1023, 8662, 8620
4020, 8505, 1001, 1002, 8506, 8662, 1024, 8663, 8622
4021, 8506, 1002, 1003, 8507, 8663, 1025, 8664, 8624
4022, 8507, 1003, 1004, 8508, 8664, 1026, 8665, 8626
4023, 8508, 1004, 1005, 8509, 8665, 1027, 8666, 8628
4024, 8509, 1005, 1006, 8510, 8666, 1028, 8667, 8630
4025, 8510, 1006, 1007, 8511, 8667, 1029, 8668, 8632
4026, 8511, 1007, 1008, 8512, 8668, 1030, 8669, 8634
4027, 8512, 1008, 1009, 8513, 8669, 1031, 8670, 8636
4028, 8513, 1009, 1010, 8514, 8670, 1032, 8671, 8638
4029, 8514, 1010, 1011, 8515, 8671, 1033, 8672, 8640
4030, 8515, 1011, 1012, 8516, 8672, 1034, 8673, 8642
4031, 8516, 1012, 1013, 8517, 8673, 1035, 8674, 8644
4032, 8517, 1013, 1014, 8518, 8674, 1036, 8675, 8646
4033, 8518, 1014, 1015, 8519, 8675, 1037, 8676, 8648
4034, 8519, 1015, 1016, 8520, 8676, 1038, 8677, 8650
4035, 8520, 1016, 1017, 8521, 8677, 1039, 8678, 8652
4036, 8521, 1017, 1018, 8522, 8678, 1040, 8679, 8654
4037, 8522, 1018, 1019, 8523, 8679, 1041, 8680, 8656
4038, 8523, 1019, 32, 948, 8680, 1042, 952, 8658
*ELEMENT, type=CPS8, ELSET=Surface188
4039, 29, 1050, 8681, 905, 1072, 8747, 8748, 908
4040, 1050, 1051, 8682, 8681, 1073, 8749, 8750, 8747
4041, 1051, 1052, 8683, 8682, 1074, 8751, 8752, 8749
4042, 1052, 1053, 8684, 8683, 1075, 8753, 8754, 8751
4043, 1053, 1054, 8685, 8684, 1076, 8755, 8756, 8753
4044, 1054, 1055, 8686, 8685, 1077, 8757, 8758, 8755
4045, 1055, 1056, 8687, 8686, 1078, 8759, 8760, 8757
4046, 1056, 1057, 8688, 8687, 1079, 8761, 8762, 8759
4047, 1057, 1058, 8689, 8688, 1080, 8763, 8764, 8761
4048, 1058, 1059, 8690, 8689, 1081, 8765, 8766, 8763
4049, 1059, 1060, 8691, 8690, 1082, 8767, 8768, 8765
4050, 1060, 1061, 8692, 8691, 1083, 8769, 8770, 8767
4051, 1061, 1062, 8693, 8692, 1084, 8771, 8772, 8769
4052, 1062, 1063, 8694, 8693, 1085, 8773, 8774, 8771
4053, 1063, 1064, 8695, 8694, 1086, 8775, 8776, 8773
4054, 1064, 1065, 8696, 8695, 1087, 8777, 8778, 8775
4055, 1065, 1066, 8697, 8696, 1088, 8779, 8780, 8777
4056, 1066, 1067, 8698, 8697, 1089, 8781, 8782, 8779
4057, 1067, 1068, 8699, 8698, 1090, 8783, 8784, 8781
4058, 1068, 1069, 8700, 8699, 1091, 8785, 8786, 8783
4059, 1069, 1070, 8701, 8700, 1092, 8787, 8788, 8785
4060, 1070, 1071, 8702, 8701, 1093, 8789, 8790, 8787
4061, 1071, 33, 1043, 8702, 1094, 1046, 8791, 8789
4062, 905, 8681, 8703, 906, 8748, 8792, 8793, 909
4063, 8681, 8682, 8704, 8703, 8750, 8794, 8795, 8792
4064, 8682, 8683, 8705, 8704, 8752, 8796, 8797, 8794
4065, 8683, 8684, 8706, 8705, 8754, 8798, 8799, 8796
4066, 8684, 8685, 8707, 8706, 8756, 8800, 8801, 8798
4067, 8685, 8686, 8708, 8707, 8758, 8802, 8803, 8800
4068, 8686, 8687, 8709, 8708, 8760, 8804, 8805, 8802
4069, 8687, 8688, 8710, 8709, 8762, 8806, 8807, 8804
4070, 8688, 8689, 8711, 8710, 8764, 8808, 8809, 8806
4071, 8689, 8690, 8712, 8711, 8766, 8810, 8811, 8808
4072, 8690, 8691, 8713, 8712, 8768, 8812, 8813, 8810
4073, 8691, 8692, 8714, 8713, 8770, 8814, 8815, 8812
4074, 8692, 8693, 8715, 8714, 8772, 8816, 8817, 8814
4075, 8693, 8694, 8716, 8715, 8774, 8818, 8819, 8816
4076, 8694, 8695, 8717, 8716, 8776, 8820, 8821, 8818
4077, 8695, 8696, 8718, 8717, 8778, 8822, 8823, 8820
4078, 8696, 8697, 8719, 8718, 8780, 8824, 8825, 8822
4079, 8697, 8698, 8720, 8719, 8782, 8826, 8827, 8824
4080, 8698, 8699, 8721, 8720, 8784, 8828, 8829, 8826
4081, 8699, 8700, 8722, 8721, 8786, 8830, 8831, 8828
4082, 8700, 8701, 8723, 8722, 8788, 8832, 8833, 8830
4083, 8701, 8702, 8724, 8723, 8790, 8834, 8835, 8832
4084, 8702, 1043, 1044, 8724, 8791, 1047, 8836, 8834
4085, 906, 8703, 8725, 907, 8793, 8837, 8838, 910
4086, 8703, 8704, 8726, 8725, 8795, 8839, 8840, 8837
4087, 8704, 8705, 8727, 8726, 8797, 8841, 8842, 8839
4088, 8705, 8706, 8728, 8727, 8799, 8843, 8844, 8841
4089, 8706, 8707, 8729, 8728, 8801, 8845, 8846, 8843
4090, 8707, 8708, 8730, 8729, 8803, 8847, 8848, 8845
4091, 8708, 8709, 8731, 8730, 8805, 8849, 8850, 8847
4092, 8709, 8710, 8732, 8731, 8807, 8851, 8852, 8849
4093, 8710, 8711, 8733, 8732, 8809, 8853, 8854, 8851
4094, 8711, 8712, 8734, 8733, 8811, 8855, 8856, 8853
4095, 8712, 8713, 8735, 8734, 8813, 8857, 8858, 8855
4096, 8713, 8714, 8736, 8735, 8815, 8859, 8860, 8857
4097, 8714, 8715, 8737, 8736, 8817, 8861, 8862, 8859
4098, 8715, 8716, 8738, 8737, 8819, 8863, 8864, 8861
4099, 8716, 8717, 8739, 8738, 8821, 8865, 8866, 8863
4100, 8717, 8718, 8740, 8739, 8823, 8867, 8868, 8865
4101, 8718, 8719, 8741, 8740, 8825, 8869, 8870, 8867
4102, 8719, 8720, 8742, 8741, 8827, 8871, 8872, 8869
4103, 8720, 8721, 8743, 8742, 8829, 8873, 8874, 8871
4104, 8721, 8722, 8744, 8743, 8831, 8875, 8876, 8873
4105, 8722, 8723, 8745, 8744, 8833, 8877, 8878, 8875
4106, 8723, 8724, 8746, 8745, 8835, 8879, 8880, 8877
4107, 8724, 1044, 1045, 8746, 8836, 1048, 8881, 8879
4108, 907, 8725, 1095, 30, 8838, 8882, 1117, 911
4109, 8725, 8726, 1096, 1095, 8840, 8883, 1118, 8882
4110, 8726, 8727, 1097, 1096, 8842, 8884, 1119, 8883
4111, 8727, 8728, 1098, 1097, 8844, 8885, 1120, 8884
4112, 8728, 8729, 1099, 1098, 8846, 8886, 1121, 8885
4113, 8729, 8730, 1100, 1099, 8848, 8887, 1122, 8886
4114, 8730, 8731, 1101, 1100, 8850, 8888, 1123, 8887
4115, 8731, 8732, 1102, 1101, 8852, 8889, 1124, 8888
4116, 8732, 8733, 1103, 1102, 8854, 8890, 1125, 8889
4117, 8733, 8734, 1104, 1103, 8856, 8891, 1126, 8890
4118, 8734, 8735, 1105, 1104, 8858, 8892, 1127, 8891
4119, 8735, 8736, 1106, 1105, 8860, 8893, 1128, 8892
4120, 8736, 8737, 1107, 1106, 8862, 8894, 1129, 8893
4121, 8737, 8738, 1108, 1107, 8864, 8895, 1130, 8894
4122, 8738, 8739, 1109, 1108, 8866, 8896, 1131, 8895
4123, 8739, 8740, 1110, 1109, 8868, 8897, 1132, 8896
4124, 8740, 8741, 1111, 1110, 8870, 8898, 1133, 8897
4125, 8741, 8742, 1112, 1111, 8872, 8899, 1134, 8898
4126, 8742, 8743, 1113, 1112, 8874, 8900, 1135, 8899
4127, 8743, 8744, 1114, 1113, 8876, 8901, 1136, 8900
4128, 8744, 8745, 1115, 1114, 8878, 8902, 1137, 8901
4129, 8745, 8746, 1116, 1115, 8880, 8903, 1138, 8902
4130, 8746, 1045, 34, 1116, 8881, 1049, 1139, 8903
*ELEMENT, type=CPS8, ELSET=Surface189
4131, 31, 946, 8904, 1147, 949, 8928, 8929, 1156
4132, 1147, 8904, 8905, 1146, 8929, 8930, 8931, 1155
4133, 1146, 8905, 8906, 1145, 8931, 8932, 8933, 1154
4134, 1145, 8906, 8907, 1144, 8933, 8934, 8935, 1153
4135, 1144, 8907, 8908, 1143, 8935, 8936, 8937, 1152
4136, 1143, 8908, 8909, 1142, 8937, 8938, 8939, 1151
4137, 1142, 8909, 8910, 1141, 8939, 8940, 8941, 1150
4138, 1141, 8910, 8911, 1140, 8941, 8942, 8943, 1149
4139, 1140, 8911, 1043, 33, 8943, 8944, 1046, 1148
4140, 946, 947, 8912, 8904, 950, 8945, 8946, 8928
4141, 8904, 8912, 8913, 8905, 8946, 8947, 8948, 8930
4142, 8905, 8913, 8914, 8906, 8948, 8949, 8950, 8932
4143, 8906, 8914, 8915, 8907, 8950, 8951, 8952, 8934
4144, 8907, 8915, 8916, 8908, 8952, 8953, 8954, 8936
4145, 8908, 8916, 8917, 8909, 8954, 8955, 8956, 8938
4146, 8909, 8917, 8918, 8910, 8956, 8957, 8958, 8940
4147, 8910, 8918, 8919, 8911, 8958, 8959, 8960, 8942
4148, 8911, 8919, 1044, 1043, 8960, 8961, 1047, 8944
4149, 947, 948, 8920, 8912, 951, 8962, 8963, 8945
4150, 8912, 8920, 8921, 8913, 8963, 8964, 8965, 8947
4151, 8913, 8921, 8922, 8914, 8965, 8966, 8967, 8949
4152, 8914, 8922, 8923, 8915, 8967, 8968, 8969, 8951
4153, 8915, 8923, 8924, 8916, 8969, 8970, 8971, 8953
4154, 8916, 8924, 8925, 8917, 8971, 8972, 8973, 8955
4155, 8917, 8925, 8926, 8918, 8973, 8974, 8975, 8957
4156, 8918, 8926, 8927, 8919, 8975, 8976, 8977, 8959
4157, 8919, 8927, 1045, 1044, 8977, 8978, 1048, 8961
4158, 948, 32, 1164, 8920, 952, 1173, 8979, 8962
4159, 8920, 1164, 1163, 8921, 8979, 1172, 8980, 8964
4160, 8921, 1163, 1162, 8922, 8980, 1171, 8981, 8966
4161, 8922, 1162, 1161, 8923, 8981, 1170, 8982, 8968
4162, 8923, 1161, 1160, 8924, 8982, 1169, 8983, 8970
4163, 8924, 1160, 1159, 8925, 8983, 1168, 8984, 8972
4164, 8925, 1159, 1158, 8926, 8984, 1167, 8985, 8974
4165, 8926, 1158, 1157, 8927, 8985, 1166, 8986, 8976
4166, 8927, 1157, 34, 1045, 8986, 1165, 1049, 8978
*ELEMENT, type=CPS8, ELSET=Surface190
4167, 27, 953, 8987, 919, 975, 9163, 9164, 928
4168, 919, 8987, 8988, 918, 9164, 9165, 9166, 927
4169, 918, 8988, 8989, 917, 9166, 9167, 9168, 926
4170, 917, 8989, 8990, 916, 9168, 9169, 9170, 925
4171, 916, 8990, 8991, 915, 9170, 9171, 9172, 924
4172, 915, 8991, 8992, 914, 9172, 9173, 9174, 923
4173, 914, 8992, 8993, 913, 9174, 9175, 9176, 922
4174, 913, 8993, 8994, 912, 9176, 9177, 9178, 921
4175, 912, 8994, 1050, 29, 9178, 9179, 1072, 920
4176, 953, 954, 8995, 8987, 976, 9180, 9181, 9163
4177, 8987, 8995, 8996, 8988, 9181, 9182, 9183, 9165
4178, 8988, 8996, 8997, 8989, 9183, 9184, 9185, 9167
4179, 8989, 8997, 8998, 8990, 9185, 9186, 9187, 9169
4180, 8990, 8998, 8999, 8991, 9187, 9188, 9189, 9171
4181, 8991, 8999, 9000, 8992, 9189, 9190, 9191, 9173
4182, 8992, 9000, 9001, 8993, 9191, 9192, 9193, 9175
4183, 8993, 9001, 9002, 8994, 9193, 9194, 9195, 9177
4184, 8994, 9002, 1051, 1050, 9195, 9196, 1073, 9179
4185, 954, 955, 9003, 8995, 977, 9197, 9198, 9180
4186, 8995, 9003, 9004, 8996, 9198, 9199, 9200, 9182
4187, 8996, 9004, 9005, 8997, 9200, 9201, 9202, 9184
4188, 8997, 9005, 9006, 8998, 9202, 9203, 9204, 9186
4189, 8998, 9006, 9007, 8999, 9204, 9205, 9206, 9188
4190, 8999, 9007, 9008, 9000, 9206, 9207, 9208, 9190
4191, 9000, 9008, 9009, 9001, 9208, 9209, 9210, 9192
4192, 9001, 9009, 9010, 9002, 9210, 9211, 9212, 9194
4193, 9002, 9010, 1052, 1051, 9212, 9213, 1074, 9196
4194, 955, 956, 9011, 9003, 978, 9214, 9215, 9197
4195, 9003, 9011, 9012, 9004, 9215, 9216, 9217, 9199
4196, 9004, 9012, 9013, 9005, 9217, 9218, 9219, 9201
4197, 9005, 9013, 9014, 9006, 9219, 9220, 9221, 9203
4198, 9006, 9014, 9015, 9007, 9221, 9222, 9223, 9205
4199, 9007, 9015, 9016, 9008, 9223, 9224, 9225, 9207
4200, 9008, 9016, 9017, 9009, 9225, 9226, 9227, 9209
4201, 9009, 9017, 9018, 9010, 9227, 9228, 9229, 9211
4202, 9010, 9018, 1053, 1052, 9229, 9230, 1075, 9213
4203, 956, 957, 9019, 9011, 979, 9231, 9232, 9214
4204, 9011, 9019, 9020, 9012, 9232, 9233, 9234, 9216
4205, 9012, 9020, 9021, 9013, 9234, 9235, 9236, 9218
4206, 9013, 9021, 9022, 9014, 9236, 9237, 9238, 9220
4207, 9014, 9022, 9023, 9015, 9238, 9239, 9240, 9222
4208, 9015, 9023, 9024, 9016, 9240, 9241, 9242, 9224
4209, 9016, 9024, 9025, 9017, 9242, 9243, 9244, 9226
4210, 9017, 9025, 9026, 9018, 9244, 9245, 9246, 9228
4211, 9018, 9026, 1054, 1053, 9246, 9247, 1076, 9230
4212, 957, 958, 9027, 9019, 980, 9248, 9249, 9231
4213, 9019, 9027, 9028, 9020, 9249, 9250, 9251, 9233
4214, 9020, 9028, 9029, 9021, 9251, 9252, 9253, 9235
4215, 9021, 9029, 9030, 9022, 9253, 9254, 9255, 9237
4216, 9022, 9030, 9031, 9023, 9255, 9256, 9257, 9239
4217, 9023, 9031, 9032, 9024, 9257, 9258, 9259, 9241
4218, 9024, 9032, 9033, 9025, 9259, 9260, 9261, 9243
4219, 9025, 9033, 9034, 9026, 9261, 9262, 9263, 9245
4220, 9026, 9034, 1055, 1054, 9263, 9264, 1077, 9247
4221, 958, 959, 9035, 9027, 981, 9265, 9266, 9248
4222, 9027, 9035, 9036, 9028, 9266, 9267, 9268, 9250
4223, 9028, 9036, 9037, 9029, 9268, 9269, 9270, 9252
4224, 9029, 9037, 9038, 9030, 9270, 9271, 9272, 9254
4225, 9030, 9038, 9039, 9031, 9272, 9273, 9274, 9256
4226, 9031, 9039, 9040, 9032, 9274, 9275, 9276, 9258
4227, 9032, 9040, 9041, 9033, 9276, 9277, 9278, 9260
4228, 9033, 9041, 9042, 9034, 9278, 9279, 9280, 9262
4229, 9034, 9042, 1056, 1055, 9280, 9281, 1078, 9264
4230, 959, 960, 9043, 9035, 982, 9282, 9283, 9265
4231, 9035, 9043, 9044, 9036, 9283, 9284, 9285, 9267
4232, 9036, 9044, 9045, 9037, 9285, 9286, 9287, 9269
4233, 9037, 9045, 9046, 9038, 9287, 9288, 9289, 9271
4234, 9038, 9046, 9047, 9039, 9289, 9290, 9291, 9273
4235, 9039, 9047, 9048, 9040, 9291, 9292, 9293, 9275
4236, 9040, 9048, 9049, 9041, 9293, 9294, 9295, 9277
4237, 9041, 9049, 9050, 9042, 9295, 9296, 9297, 9279
4238, 9042, 9050, 1057, 1056, 9297, 9298, 1079, 9281
4239, 960, 961, 9051, 9043, 983, 9299, 9300, 9282
4240, 9043, 9051, 9052, 9044, 9300, 9301, 9302, 9284
4241, 9044, 9052, 9053, 9045, 9302, 9303, 9304, 9286
4242, 9045, 9053, 9054, 9046, 9304, 9305, 9306, 9288
4243, 9046, 9054, 9055, 9047, 9306, 9307, 9308, 9290
4244, 9047, 9055, 9056, 9048, 9308, 9309, 9310, 9292
4245, 9048, 9056, 9057, 9049, 9310, 9311, 9312, 9294
4246, 9049, 9057, 9058, 9050, 9312, 9313, 9314, 9296
4247, 9050, 9058, 1058, 1057, 9314, 9315, 1080, 9298
4248, 961, 962, 9059, 9051, 984, 9316, 9317, 9299
4249, 9051, 9059, 9060, 9052, 9317, 9318, 9319, 9301
4250, 9052, 9060, 9061, 9053, 9319, 9320, 9321, 9303
4251, 9053, 9061, 9062, 9054, 9321, 9322, 9323, 9305
4252, 9054, 9062, 9063, 9055, 9323, 9324, 9325, 9307
4253, 9055, 9063, 9064, 9056, 9325, 9326, 9327, 9309
4254, 9056, 9064, 9065, 9057, 9327, 9328, 9329, 9311
4255, 9057, 9065, 9066, 9058, 9329, 9330, 9331, 9313
4256, 9058, 9066, 1059, 1058, 9331, 9332, 1081, 9315
4257, 962, 963, 9067, 9059, 985, 9333, 9334, 9316
4258, 9059, 9067, 9068, 9060, 9334, 9335, 9336, 9318
4259, 9060, 9068, 9069, 9061, 9336, 9337, 9338, 9320
4260, 9061, 9069, 9070, 9062, 9338, 9339, 9340, 9322
4261, 9062, 9070, 9071, 9063, 9340, 9341, 9342, 9324
4262, 9063, 9071, 9072, 9064, 9342, 9343, 9344, 9326
4263, 9064, 9072, 9073, 9065, 9344, 9345, 9346, 9328
4264, 9065, 9073, 9074, 9066, 9346, 9347, 9348, 9330
4265, 9066, 9074, 1060, 1059, 9348, 9349, 1082, 9332
4266, 963, 964, 9075, 9067, 986, 9350, 9351, 9333
4267, 9067, 9075, 9076, 9068, 9351, 9352, 9353, 9335
4268, 9068, 9076, 9077, 9069, 9353, 9354, 9355, 9337
4269, 9069, 9077, 9078, 9070, 9355, 9356, 9357, 9339
4270, 9070, 9078, 9079, 9071, 9357, 9358, 9359, 9341
4271, 9071, 9079, 9080, 9072, 9359, 9360, 9361, 9343
4272, 9072, 9080, 9081, 9073, 9361, 9362, 9363, 9345
4273, 9073, 9081, 9082, 9074, 9363, 9364, 9365, 9347
4274, 9074, 9082, 1061, 1060, 9365, 9366, 1083, 9349
4275, 964, 965, 9083, 9075, 987, 9367, 9368, 9350
4276, 9075, 9083, 9084, 9076, 9368, 9369, 9370, 9352
4277, 9076, 9084, 9085, 9077, 9370, 9371, 9372, 9354
4278, 9077, 9085, 9086, 9078, 9372, 9373, 9374, 9356
4279, 9078, 9086, 9087, 9079, 9374, 9375, 9376, 9358
4280, 9079, 9087, 9088, 9080, 9376, 9377, 9378, 9360
4281, 9080, 9088, 9089, 9081, 9378, 9379, 9380, 9362
4282, 9081, 9089, 9090, 9082, 9380, 9381, 9382, 9364
4283, 9082, 9090, 1062, 1061, 9382, 9383, 1084, 9366
4284, 965, 966, 9091, 9083, 988, 9384, 9385, 9367
4285, 9083, 9091, 9092, 9084, 9385, 9386, 9387, 9369
4286, 9084, 9092, 9093, 9085, 9387, 9388, 9389, 9371
4287, 9085, 9093, 9094, 9086, 9389, 9390, 9391, 9373
4288, 9086, 9094, 9095, 9087, 9391, 9392, 9393, 9375
4289, 9087, 9095, 9096, 9088, 9393, 9394, 9395, 9377
4290, 9088, 9096, 9097, 9089, 9395, 9396, 9397, 9379
4291, 9089, 9097, 9098, 9090, 9397, 9398, 9399, 9381
4292, 9090, 9098, 1063, 1062, 9399, 9400, 1085, 9383
4293, 966, 967, 9099, 9091, 989, 9401, 9402, 9384
4294, 9091, 9099, 9100, 9092, 9402, 9403, 9404, 9386
4295, 9092, 9100, 9101, 9093, 9404, 9405, 9406, 9388
4296, 9093, 9101, 9102, 9094, 9406, 9407, 9408, 9390
4297, 9094, 9102, 9103, 9095, 9408, 9409, 9410, 9392
4298, 9095, 9103, 9104, 9096, 9410, 9411, 9412, 9394
4299, 9096, 9104, 9105, 9097, 9412, 9413, 9414, 9396
4300, 9097, 9105, 9106, 9098, 9414, 9415, 9416, 9398
4301, 9098, 9106, 1064, 1063, 9416, 9417, 1086, 9400
4302, 967, 968, 9107, 9099, 990, 9418, 9419, 9401
4303, 9099, 9107, 9108, 9100, 9419, 9420, 9421, 9403
4304, 9100, 9108, 9109, 9101, 9421, 9422, 9423, 9405
4305, 9101, 9109, 9110, 9102, 9423, 9424, 9425, 9407
4306, 9102, 9110, 9111, 9103, 9425, 9426, 9427, 9409
4307, 9103, 9111, 9112, 9104, 9427, 9428, 9429, 9411
4308, 9104, 9112, 9113, 9105, 9429, 9430, 9431, 9413
4309, 9105, 9113, 9114, 9106, 9431, 9432, 9433, 9415
4310, 9106, 9114, 1065, 1064, 9433, 9434, 1087, 9417
4311, 968, 969, 9115, 9107, 991, 9435, 9436, 9418
4312, 9107, 9115, 9116, 9108, 9436, 9437, 9438, 9420
4313, 9108, 9116, 9117, 9109, 9438, 9439, 9440, 9422
4314, 9109, 9117, 9118, 9110, 9440, 9441, 9442, 9424
4315, 9110, 9118, 9119, 9111, 9442, 9443, 9444, 9426
4316, 9111, 9119, 9120, 9112, 9444, 9445, 9446, 9428
4317, 9112, 9120, 9121, 9113, 9446, 9447, 9448, 9430
4318, 9113, 9121, 9122, 9114, 9448, 9449, 9450, 9432
4319, 9114, 9122, 1066, 1065, 9450, 9451, 1088, 9434
4320, 969, 970, 9123, 9115, 992, 9452, 9453, 9435
4321, 9115, 9123, 9124, 9116, 9453, 9454, 9455, 9437
4322, 9116, 9124, 9125, 9117, 9455, 9456, 9457, 9439
4323, 9117, 9125, 9126, 9118, 9457, 9458, 9459, 9441
4324, 9118, 9126, 9127, 9119, 9459, 9460, 9461, 9443
4325, 9119, 9127, 9128, 9120, 9461, 9462, 9463, 9445
4326, 9120, 9128, 9129, 9121, 9463, 9464, 9465, 9447
4327, 9121, 9129, 9130, 9122, 9465, 9466, 9467, 9449
4328, 9122, 9130, 1067, 1066, 9467, 9468, 1089, 9451
4329, 970, 971, 9131, 9123, 993, 9469, 9470, 9452
4330, 9123, 9131, 9132, 9124, 9470, 9471, 9472, 9454
4331, 9124, 9132, 9133, 9125, 9472, 9473, 9474, 9456
4332, 9125, 9133, 9134, 9126, 9474, 9475, 9476, 9458
4333, 9126, 9134, 9135, 9127, 9476, 9477, 9478, 9460
4334, 9127, 9135, 9136, 9128, 9478, 9479, 9480, 9462
4335, 9128, 9136, 9137, 9129, 9480, 9481, 9482, 9464
4336, 9129, 9137, 9138, 9130, 9482, 9483, 9484, 9466
4337, 9130, 9138, 1068, 1067, 9484, 9485, 1090, 9468
4338, 971, 972, 9139, 9131, 994, 9486, 9487, 9469
4339, 9131, 9139, 9140, 9132, 9487, 9488, 9489, 9471
4340, 9132, 9140, 9141, 9133, 9489, 9490, 9491, 9473
4341, 9133, 9141, 9142, 9134, 9491, 9492, 9493, 9475
4342, 9134, 9142, 9143, 9135, 9493, 9494, 9495, 9477
4343, 9135, 9143, 9144, 9136, 9495, 9496, 9497, 9479
4344, 9136, 9144, 9145, 9137, 9497, 9498, 9499, 9481
4345, 9137, 9145, 9146, 9138, 9499, 9500, 9501, 9483
4346, 9138, 9146, 1069, 1068, 9501, 9502, 1091, 9485
4347, 972, 973, 9147, 9139, 995, 9503, 9504, 9486
4348, 9139, 9147, 9148, 9140, 9504, 9505, 9506, 9488
4349, 9140, 9148, 9149, 9141, 9506, 9507, 9508, 9490
4350, 9141, 9149, 9150, 9142, 9508, 9509, 9510, 9492
4351, 9142, 9150, 9151, 9143, 9510, 9511, 9512, 9494
4352, 9143, 9151, 9152, 9144, 9512, 9513, 9514, 9496
4353, 9144, 9152, 9153, 9145, 9514, 9515, 9516, 9498
4354, 9145, 9153, 9154, 9146, 9516, 9517, 9518, 9500
4355, 9146, 9154, 1070, 1069, 9518, 9519, 1092, 9502
4356, 973, 974, 9155, 9147, 996, 9520, 9521, 9503
4357, 9147, 9155, 9156, 9148, 9521, 9522, 9523, 9505
4358, 9148, 9156, 9157, 9149, 9523, 9524, 9525, 9507
4359, 9149, 9157, 9158, 9150, 9525, 9526, 9527, 9509
4360, 9150, 9158, 9159, 9151, 9527, 9528, 9529, 9511
4361, 9151, 9159, 9160, 9152, 9529, 9530, 9531, 9513
4362, 9152, 9160, 9161, 9153, 9531, 9532, 9533, 9515
4363, 9153, 9161, 9162, 9154, 9533, 9534, 9535, 9517
4364, 9154, 9162, 1071, 1070, 9535, 9536, 1093, 9519
4365, 974, 31, 1147, 9155, 997, 1156, 9537, 9520
4366, 9155, 1147, 1146, 9156, 9537, 1155, 9538, 9522
4367, 9156, 1146, 1145, 9157, 9538, 1154, 9539, 9524
4368, 9157, 1145, 1144, 9158, 9539, 1153, 9540, 9526
4369, 9158, 1144, 1143, 9159, 9540, 1152, 9541, 9528
4370, 9159, 1143, 1142, 9160, 9541, 1151, 9542, 9530
4371, 9160, 1142, 1141, 9161, 9542, 1150, 9543, 9532
4372, 9161, 1141, 1140, 9162, 9543, 1149, 9544, 9534
4373, 9162, 1140, 33, 1071, 9544, 1148, 1094, 9536
*ELEMENT, type=CPS8, ELSET=Surface191
4374, 28, 936, 9545, 998, 945, 9721, 9722, 1020
4375, 936, 935, 9546, 9545, 944, 9723, 9724, 9721
4376, 935, 934, 9547, 9546, 943, 9725, 9726, 9723
4377, 934, 933, 9548, 9547, 942, 9727, 9728, 9725
4378, 933, 932, 9549, 9548, 941, 9729, 9730, 9727
4379, 932, 931, 9550, 9549, 940, 9731, 9732, 9729
4380, 931, 930, 9551, 9550, 939, 9733, 9734, 9731
4381, 930, 929, 9552, 9551, 938, 9735, 9736, 9733
4382, 929, 30, 1095, 9552, 937, 1117, 9737, 9735
4383, 998, 9545, 9553, 999, 9722, 9738, 9739, 1021
4384, 9545, 9546, 9554, 9553, 9724, 9740, 9741, 9738
4385, 9546, 9547, 9555, 9554, 9726, 9742, 9743, 9740
4386, 9547, 9548, 9556, 9555, 9728, 9744, 9745, 9742
4387, 9548, 9549, 9557, 9556, 9730, 9746, 9747, 9744
4388, 9549, 9550, 9558, 9557, 9732, 9748, 9749, 9746
4389, 9550, 9551, 9559, 9558, 9734, 9750, 9751, 9748
4390, 9551, 9552, 9560, 9559, 9736, 9752, 9753, 9750
4391, 9552, 1095, 1096, 9560, 9737, 1118, 9754, 9752
4392, 999, 9553, 9561, 1000, 9739, 9755, 9756, 1022
4393, 9553, 9554, 9562, 9561, 9741, 9757, 9758, 9755
4394, 9554, 9555, 9563, 9562, 9743, 9759, 9760, 9757
4395, 9555, 9556, 9564, 9563, 9745, 9761, 9762, 9759
4396, 9556, 9557, 9565, 9564, 9747, 9763, 9764, 9761
4397, 9557, 9558, 9566, 9565, 9749, 9765, 9766, 9763
4398, 9558, 9559, 9567, 9566, 9751, 9767, 9768, 9765
4399, 9559, 9560, 9568, 9567, 9753, 9769, 9770, 9767
4400, 9560, 1096, 1097, 9568, 9754, 1119, 9771, 9769
4401, 1000, 9561, 9569, 1001, 9756, 9772, 9773, 1023
4402, 9561, 9562, 9570, 9569, 9758, 9774, 9775, 9772
4403, 9562, 9563, 9571, 9570, 9760, 9776, 9777, 9774
4404, 9563, 9564, 9572, 9571, 9762, 9778, 9779, 9776
4405, 9564, 9565, 9573, 9572, 9764, 9780, 9781, 9778
4406, 9565, 9566, 9574, 9573, 9766, 9782, 9783, 9780
4407, 9566, 9567, 9575, 9574, 9768, 9784, 9785, 9782
4408, 9567, 9568, 9576, 9575, 9770, 9786, 9787, 9784
4409, 9568, 1097, 1098, 9576, 9771, 1120, 9788, 9786
4410, 1001, 9569, 9577, 1002, 9773, 9789, 9790, 1024
4411, 9569, 9570, 9578, 9577, 9775, 9791, 9792, 9789
4412, 9570, 9571, 9579, 9578, 9777, 9793, 9794, 9791
4413, 9571, 9572, 9580, 9579, 9779, 9795, 9796, 9793
4414, 9572, 9573, 9581, 9580, 9781, 9797, 9798, 9795
4415, 9573, 9574, 9582, 9581, 9783, 9799, 9800, 9797
4416, 9574, 9575, 9583, 9582, 9785, 9801, 9802, 9799
4417, 9575, 9576, 9584, 9583, 9787, 9803, 9804, 9801
4418, 9576, 1098, 1099, 9584, 9788, 1121, 9805, 9803
4419, 1002, 9577, 9585, 1003, 9790, 9806, 9807, 1025
4420, 9577, 9578, 9586, 9585, 9792, 9808, 9809, 9806
4421, 9578, 9579, 9587, 9586, 9794, 9810, 9811, 9808
4422, 9579, 9580, 9588, 9587, 9796, 9812, 9813, 9810
4423, 9580, 9581, 9589, 9588, 9798, 9814, 9815, 9812
4424, 9581, 9582, 9590, 9589, 9800, 9816, 9817, 9814
4425, 9582, 9583, 9591, 9590, 9802, 9818, 9819, 9816
4426, 9583, 9584, 9592, 9591, 9804, 9820, 9821, 9818
4427, 9584, 1099, 1100, 9592, 9805, 1122, 9822, 9820
4428, 1003, 9585, 9593, 1004, 9807, 9823, 9824, 1026
4429, 9585, 9586, 9594, 9593, 9809, 9825, 9826, 9823
4430, 9586, 9587, 9595, 9594, 9811, 9827, 9828, 9825
4431, 9587, 9588, 9596, 9595, 9813, 9829, 9830, 9827
4432, 9588, 9589, 9597, 9596, 9815, 9831, 9832, 9829
4433, 9589, 9590, 9598, 9597, 9817, 9833, 9834, 9831
4434, 9590, 9591, 9599, 9598, 9819, 9835, 9836, 9833
4435, 9591, 9592, 9600, 9599, 9821, 9837, 9838, 9835
4436, 9592, 1100, 1101, 9600, 9822, 1123, 9839, 9837
4437, 1004, 9593, 9601, 1005, 9824, 9840, 9841, 1027
4438, 9593, 9594, 9602, 9601, 9826, 9842, 9843, 9840
4439, 9594, 9595, 9603, 9602, 9828, 9844, 9845, 9842
4440, 9595, 9596, 9604, 9603, 9830, 9846, 9847, 9844
4441, 9596, 9597, 9605, 9604, 9832, 9848, 9849, 9846
4442, 9597, 9598, 9606, 9605, 9834, 9850, 9851, 9848
4443, 9598, 9599, 9607, 9606, 9836, 9852, 9853, 9850
4444, 9599, 9600, 9608, 9607, 9838, 9854, 9855, 9852
4445, 9600, 1101, 1102, 9608, 9839, 1124, 9856, 9854
4446, 1005, 9601, 9609, 1006, 9841, 9857, 9858, 1028
4447, 9601, 9602, 9610, 9609, 9843, 9859, 9860, 9857
4448, 9602, 9603, 9611, 9610, 9845, 9861, 9862, 9859
4449, 9603, 9604, 9612, 9611, 9847, 9863, 9864, 9861
4450, 9604, 9605, 9613, 9612, 9849, 9865, 9866, 9863
4451, 9605, 9606, 9614, 9613, 9851, 9867, 9868, 9865
4452, 9606, 9607, 9615, 9614, 9853, 9869, 9870, 9867
4453, 9607, 9608, 9616, 9615, 9855, 9871, 9872, 9869
4454, 9608, 1102, 1103, 9616, 9856, 1125, 9873, 9871
4455, 1006, 9609, 9617, 1007, 9858, 9874, 9875, 1029
4456, 9609, 9610, 9618, 9617, 9860, 9876, 9877, 9874
4457, 9610, 9611, 9619, 9618, 9862, 9878, 9879, 9876
4458, 9611, 9612, 9620, 9619, 9864, 9880, 9881, 9878
4459, 9612, 9613, 9621, 9620, 9866, 9882, 9883, 9880
4460, 9613, 9614, 9622, 9621, 9868, 9884, 9885, 9882
4461, 9614, 9615, 9623, 9622, 9870, 9886, 9887, 9884
4462, 9615, 9616, 9624, 9623, 9872, 9888, 9889, 9886
4463, 9616, 1103, 1104, 9624, 9873, 1126, 9890, 9888
4464, 1007, 9617, 9625, 1008, 9875, 9891, 9892, 1030
4465, 9617, 9618, 9626, 9625, 9877, 9893, 9894, 9891
4466, 9618, 9619, 9627, 9626, 9879, 9895, 9896, 9893
4467, 9619, 9620, 9628, 9627, 9881, 9897, 9898, 9895
4468, 9620, 9621, 9629, 9628, 9883, 9899, 9900, 9897
4469, 9621, 9622, 9630, 9629, 9885, 9901, 9902, 9899
4470, 9622, 9623, 9631, 9630, 9887, 9903, 9904, 9901
4471, 9623, 9624, 9632, 9631, 9889, 9905, 9906, 9903
4472, 9624, 1104, 1105, 9632, 9890, 1127, 9907, 9905
4473, 1008, 9625, 9633, 1009, 9892, 9908, 9909, 1031
4474, 9625, 9626, 9634, 9633, 9894, 9910, 9911, 9908
4475, 9626, 9627, 9635, 9634, 9896, 9912, 9913, 9910
4476, 9627, 9628, 9636, 9635, 9898, 9914, 9915, 9912
4477, 9628, 9629, 9637, 9636, 9900, 9916, 9917, 9914
4478, 9629, 9630, 9638, 9637, 9902, 9918, 9919, 9916
4479, 9630, 9631, 9639, 9638, 9904, 9920, 9921, 9918
4480, 9631, 9632, 9640, 9639, 9906, 9922, 9923, 9920
4481, 9632, 1105, 1106, 9640, 9907, 1128, 9924, 9922
4482, 1009, 9633, 9641, 1010, 9909, 9925, 9926, 1032
4483, 9633, 9634, 9642, 9641, 9911, 9927, 9928, 9925
4484, 9634, 9635, 9643, 9642, 9913, 9929, 9930, 9927
4485, 9635, 9636, 9644, 9643, 9915, 9931, 9932, 9929
4486, 9636, 9637, 9645, 9644, 9917, 9933, 9934, 9931
4487, 9637, 9638, 9646, 9645, 9919, 9935, 9936, 9933
4488, 9638, 9639, 9647, 9646, 9921, 9937, 9938, 9935
4489, 9639, 9640, 9648, 9647, 9923, 9939, 9940, 9937
4490, 9640, 1106, 1107, 9648, 9924, 1129, 9941, 9939
4491, 1010, 9641, 9649, 1011, 9926, 9942, 9943, 1033
4492, 9641, 9642, 9650, 9649, 9928, 9944, 9945, 9942
4493, 9642, 9643, 9651, 9650, 9930, 9946, 9947, 9944
4494, 9643, 9644, 9652, 9651, 9932, 9948, 9949, 9946
4495, 9644, 9645, 9653, 9652, 9934, 9950, 9951, 9948
4496, 9645, 9646, 9654, 9653, 9936, 9952, 9953, 9950
4497, 9646, 9647, 9655, 9654, 9938, 9954, 9955, 9952
4498, 9647, 9648, 9656, 9655, 9940, 9956, 9957, 9954
4499, 9648, 1107, 1108, 9656, 9941, 1130, 9958, 9956
4500, 1011, 9649, 9657, 1012, 9943, 9959, 9960, 1034
4501, 9649, 9650, 9658, 9657, 9945, 9961, 9962, 9959
4502, 9650, 9651, 9659, 9658, 9947, 9963, 9964, 9961
4503, 9651, 9652, 9660, 9659, 9949, 9965, 9966, 9963
4504, 9652, 9653, 9661, 9660, 9951, 9967, 9968, 9965
4505, 9653, 9654, 9662, 9661, 9953, 9969, 9970, 9967
4506, 9654, 9655, 9663, 9662, 9955, 9971, 9972, 9969
4507, 9655, 9656, 9664, 9663, 9957, 9973, 9974, 9971
4508, 9656, 1108, 1109, 9664, 9958, 1131, 9975, 9973
4509, 1012, 9657, 9665, 1013, 9960, 9976, 9977, 1035
4510, 9657, 9658, 9666, 9665, 9962, 9978, 9979, 9976
4511, 9658, 9659, 9667, 9666, 9964, 9980, 9981, 9978
4512, 9659, 9660, 9668, 9667, 9966, 9982, 9983, 9980
4513, 9660, 9661, 9669, 9668, 9968, 9984, 9985, 9982
4514, 9661, 9662, 9670, 9669, 9970, 9986, 9987, 9984
4515, 9662, 9663, 9671, 9670, 9972, 9988, 9989, 9986
4516, 9663, 9664, 9672, 9671, 9974, 9990, 9991, 9988
4517, 9664, 1109, 1110, 9672, 9975, 1132, 9992, 9990
4518, 1013, 9665, 9673, 1014, 9977, 9993, 9994, 1036
4519, 9665, 9666, 9674, 9673, 9979, 9995, 9996, 9993
4520, 9666, 9667, 9675, 9674, 9981, 9997, 9998, 9995
4521, 9667, 9668, 9676, 9675, 9983, 9999, 10000, 9997
4522, 9668, 9669, 9677, 9676, 9985, 10001, 10002, 9999
4523, 9669, 9670, 9678, 9677, 9987, 10003, 10004, 10001
4524, 9670, 9671, 9679, 9678, 9989, 10005, 10006, 10003
4525, 9671, 9672, 9680, 9679, 9991, 10007, 10008, 10005
4526, 9672, 1110, 1111, 9680, 9992, 1133, 10009, 10007
4527, 1014, 9673, 9681, 1015, 9994, 10010, 10011, 1037
4528, 9673, 9674, 9682, 9681, 9996, 10012, 10013, 10010
4529, 9674, 9675, 9683, 9682, 9998, 10014, 10015, 10012
4530, 9675, 9676, 9684, 9683, 10000, 10016, 10017, 10014
4531, 9676, 9677, 9685, 9684, 10002, 10018, 10019, 10016
4532, 9677, 9678, 9686, 9685, 10004, 10020, 10021, 10018
4533, 9678, 9679, 9687, 9686, 10006, 10022, 10023, 10020
4534, 9679, 9680, 9688, 9687, 10008, 10024, 10025, 10022
4535, 9680, 1111, 1112, 9688, 10009, 1134, 10026, 10024
4536, 1015, 9681, 9689, 1016, 10011, 10027, 10028, 1038
4537, 9681, 9682, 9690, 9689, 10013, 10029, 10030, 10027
4538, 9682, 9683, 9691, 9690, 10015, 10031, 10032, 10029
4539, 9683, 9684, 9692, 9691, 10017, 10033, 10034, 10031
4540, 9684, 9685, 9693, 9692, 10019, 10035, 10036, 10033
4541, 9685, 9686, 9694, 9693, 10021, 10037, 10038, 10035
4542, 9686, 9687, 9695, 9694, 10023, 10039, 10040, 10037
4543, 9687, 9688, 9696, 9695, 10025, 10041, 10042, 10039
4544, 9688, 1112, 1113, 9696, 10026, 1135, 10043, 10041
4545, 1016, 9689, 9697, 1017, 10028, 10044, 10045, 1039
4546, 9689, 9690, 9698, 9697, 10030, 10046, 10047, 10044
4547, 9690, 9691, 9699, 9698, 10032, 10048, 10049, 10046
4548, 9691, 9692, 9700, 9699, 10034, 10050, 10051, 10048
4549, 9692, 9693, 9701, 9700, 10036, 10052, 10053, 10050
4550, 9693, 9694, 9702, 9701, 10038, 10054, 10055, 10052
4551, 9694, 9695, 9703, 9702, 10040, 10056, 10057, 10054
4552, 9695, 9696, 9704, 9703, 10042, 10058, 10059, 10056
4553, 9696, 1113, 1114, 9704, 10043, 1136, 10060, 10058
4554, 1017, 9697, 9705, 1018, 10045, 10061, 10062, 1040
4555, 9697, 9698, 9706, 9705, 10047, 10063, 10064, 10061
4556, 9698, 9699, 9707, 9706, 10049, 10065, 10066, 10063
4557, 9699, 9700, 9708, 9707, 10051, 10067, 10068, 10065
4558, 9700, 9701, 9709, 9708, 10053, 10069, 10070, 10067
4559, 9701, 9702, 9710, 9709, 10055, 10071, 10072, 10069
4560, 9702, 9703, 9711, 9710, 10057, 10073, 10074, 10071
4561, 9703, 9704, 9712, 9711, 10059, 10075, 10076, 10073
4562, 9704, 1114, 1115, 9712, 10060, 1137, 10077, 10075
4563, 1018, 9705, 9713, 1019, 10062, 10078, 10079, 1041
4564, 9705, 9706, 9714, 9713, 10064, 10080, 10081, 10078
4565, 9706, 9707, 9715, 9714, 10066, 10082, 10083, 10080
4566, 9707, 9708, 9716, 9715, 10068, 10084, 10085, 10082
4567, 9708, 9709, 9717, 9716, 10070, 10086, 10087, 10084
4568, 9709, 9710, 9718, 9717, 10072, 10088, 10089, 10086
4569, 9710, 9711, 9719, 9718, 10074, 10090, 10091, 10088
4570, 9711, 9712, 9720, 9719, 10076, 10092, 10093, 10090
4571, 9712, 1115, 1116, 9720, 10077, 1138, 10094, 10092
4572, 1019, 9713, 1164, 32, 10079, 10095, 1173, 1042
4573, 9713, 9714, 1163, 1164, 10081, 10096, 1172, 10095
4574, 9714, 9715, 1162, 1163, 10083, 10097, 1171, 10096
4575, 9715, 9716, 1161, 1162, 10085, 10098, 1170, 10097
4576, 9716, 9717, 1160, 1161, 10087, 10099, 1169, 10098
4577, 9717, 9718, 1159, 1160, 10089, 10100, 1168, 10099
4578, 9718, 9719, 1158, 1159, 10091, 10101, 1167, 10100
4579, 9719, 9720, 1157, 1158, 10093, 10102, 1166, 10101
4580, 9720, 1116, 34, 1157, 10094, 1139, 1165, 10102
*ELEMENT, type=CPS8, ELSET=Surface192
4581, 35, 1174, 10103, 1184, 1176, 10147, 10148, 1206
4582, 1184, 10103, 10104, 1185, 10148, 10149, 10150, 1207
4583, 1185, 10104, 10105, 1186, 10150, 10151, 10152, 1208
4584, 1186, 10105, 10106, 1187, 10152, 10153, 10154, 1209
4585, 1187, 10106, 10107, 1188, 10154, 10155, 10156, 1210
4586, 1188, 10107, 10108, 1189, 10156, 10157, 10158, 1211
4587, 1189, 10108, 10109, 1190, 10158, 10159, 10160, 1212
4588, 1190, 10109, 10110, 1191, 10160, 10161, 10162, 1213
4589, 1191, 10110, 10111, 1192, 10162, 10163, 10164, 1214
4590, 1192, 10111, 10112, 1193, 10164, 10165, 10166, 1215
4591, 1193, 10112, 10113, 1194, 10166, 10167, 10168, 1216
4592, 1194, 10113, 10114, 1195, 10168, 10169, 10170, 1217
4593, 1195, 10114, 10115, 1196, 10170, 10171, 10172, 1218
4594, 1196, 10115, 10116, 1197, 10172, 10173, 10174, 1219
4595, 1197, 10116, 10117, 1198, 10174, 10175, 10176, 1220
4596, 1198, 10117, 10118, 1199, 10176, 10177, 10178, 1221
4597, 1199, 10118, 10119, 1200, 10178, 10179, 10180, 1222
4598, 1200, 10119, 10120, 1201, 10180, 10181, 10182, 1223
4599, 1201, 10120, 10121, 1202, 10182, 10183, 10184, 1224
4600, 1202, 10121, 10122, 1203, 10184, 10185, 10186, 1225
4601, 1203, 10122, 10123, 1204, 10186, 10187, 10188, 1226
4602, 1204, 10123, 10124, 1205, 10188, 10189, 10190, 1227
4603, 1205, 10124, 1179, 36, 10190, 10191, 1181, 1228
4604, 1174, 1175, 10125, 10103, 1177, 10192, 10193, 10147
4605, 10103, 10125, 10126, 10104, 10193, 10194, 10195, 10149
4606, 10104, 10126, 10127, 10105, 10195, 10196, 10197, 10151
4607, 10105, 10127, 10128, 10106, 10197, 10198, 10199, 10153
4608, 10106, 10128, 10129, 10107, 10199, 10200, 10201, 10155
4609, 10107, 10129, 10130, 10108, 10201, 10202, 10203, 10157
4610, 10108, 10130, 10131, 10109, 10203, 10204, 10205, 10159
4611, 10109, 10131, 10132, 10110, 10205, 10206, 10207, 10161
4612, 10110, 10132, 10133, 10111, 10207, 10208, 10209, 10163
4613, 10111, 10133, 10134, 10112, 10209, 10210, 10211, 10165
4614, 10112, 10134, 10135, 10113, 10211, 10212, 10213, 10167
4615, 10113, 10135, 10136, 10114, 10213, 10214, 10215, 10169
4616, 10114, 10136, 10137, 10115, 10215, 10216, 10217, 10171
4617, 10115, 10137, 10138, 10116, 10217, 10218, 10219, 10173
4618, 10116, 10138, 10139, 10117, 10219, 10220, 10221, 10175
4619, 10117, 10139, 10140, 10118, 10221, 10222, 10223, 10177
4620, 10118, 10140, 10141, 10119, 10223, 10224, 10225, 10179
4621, 10119, 10141, 10142, 10120, 10225, 10226, 10227, 10181
4622, 10120, 10142, 10143, 10121, 10227, 10228, 10229, 10183
4623, 10121, 10143, 10144, 10122, 10229, 10230, 10231, 10185
4624, 10122, 10144, 10145, 10123, 10231, 10232, 10233, 10187
4625, 10123, 10145, 10146, 10124, 10233, 10234, 10235, 10189
4626, 10124, 10146, 1180, 1179, 10235, 10236, 1182, 10191
4627, 1175, 27, 953, 10125, 1178, 975, 10237, 10192
4628, 10125, 953, 954, 10126, 10237, 976, 10238, 10194
4629, 10126, 954, 955, 10127, 10238, 977, 10239, 10196
4630, 10127, 955, 956, 10128, 10239, 978, 10240, 10198
4631, 10128, 956, 957, 10129, 10240, 979, 10241, 10200
4632, 10129, 957, 958, 10130, 10241, 980, 10242, 10202
4633, 10130, 958, 959, 10131, 10242, 981, 10243, 10204
4634, 10131, 959, 960, 10132, 10243, 982, 10244, 10206
4635, 10132, 960, 961, 10133, 10244, 983, 10245, 10208
4636, 10133, 961, 962, 10134, 10245, 984, 10246, 10210
4637, 10134, 962, 963, 10135, 10246, 985, 10247, 10212
4638, 10135, 963, 964, 10136, 10247, 986, 10248, 10214
4639, 10136, 964, 965, 10137, 10248, 987, 10249, 10216
4640, 10137, 965, 966, 10138, 10249, 988, 10250, 10218
4641, 10138, 966, 967, 10139, 10250, 989, 10251, 10220
4642, 10139, 967, 968, 10140, 10251, 990, 10252, 10222
4643, 10140, 968, 969, 10141, 10252, 991, 10253, 10224
4644, 10141, 969, 970, 10142, 10253, 992, 10254, 10226
4645, 10142, 970, 971, 10143, 10254, 993, 10255, 10228
4646, 10143, 971, 972, 10144, 10255, 994, 10256, 10230
4647, 10144, 972, 973, 10145, 10256, 995, 10257, 10232
4648, 10145, 973, 974, 10146, 10257, 996, 10258, 10234
4649, 10146, 974, 31, 1180, 10258, 997, 1183, 10236
*ELEMENT, type=CPS8, ELSET=Surface193
4650, 37, 1239, 10259, 1229, 1261, 10303, 10304, 1231
4651, 1239, 1240, 10260, 10259, 1262, 10305, 10306, 10303
4652, 1240, 1241, 10261, 10260, 1263, 10307, 10308, 10305
4653, 1241, 1242, 10262, 10261, 1264, 10309, 10310, 10307
4654, 1242, 1243, 10263, 10262, 1265, 10311, 10312, 10309
4655, 1243, 1244, 10264, 10263, 1266, 10313, 10314, 10311
4656, 1244, 1245, 10265, 10264, 1267, 10315, 10316, 10313
4657, 1245, 1246, 10266, 10265, 1268, 10317, 10318, 10315
4658, 1246, 1247, 10267, 10266, 1269, 10319, 10320, 10317
4659, 1247, 1248, 10268, 10267, 1270, 10321, 10322, 10319
4660, 1248, 1249, 10269, 10268, 1271, 10323, 10324, 10321
4661, 1249, 1250, 10270, 10269, 1272, 10325, 10326, 10323
4662, 1250, 1251, 10271, 10270, 1273, 10327, 10328, 10325
4663, 1251, 1252, 10272, 10271, 1274, 10329, 10330, 10327
4664, 1252, 1253, 10273, 10272, 1275, 10331, 10332, 10329
4665, 1253, 1254, 10274, 10273, 1276, 10333, 10334, 10331
4666, 1254, 1255, 10275, 10274, 1277, 10335, 10336, 10333
4667, 1255, 1256, 10276, 10275, 1278, 10337, 10338, 10335
4668, 1256, 1257, 10277, 10276, 1279, 10339, 10340, 10337
4669, 1257, 1258, 10278, 10277, 1280, 10341, 10342, 10339
4670, 1258, 1259, 10279, 10278, 1281, 10343, 10344, 10341
4671, 1259, 1260, 10280, 10279, 1282, 10345, 10346, 10343
4672, 1260, 38, 1234, 10280, 1283, 1236, 10347, 10345
4673, 1229, 10259, 10281, 1230, 10304, 10348, 10349, 1232
4674, 10259, 10260, 10282, 10281, 10306, 10350, 10351, 10348
4675, 10260, 10261, 10283, 10282, 10308, 10352, 10353, 10350
4676, 10261, 10262, 10284, 10283, 10310, 10354, 10355, 10352
4677, 10262, 10263, 10285, 10284, 10312, 10356, 10357, 10354
4678, 10263, 10264, 10286, 10285, 10314, 10358, 10359, 10356
4679, 10264, 10265, 10287, 10286, 10316, 10360, 10361, 10358
4680, 10265, 10266, 10288, 10287, 10318, 10362, 10363, 10360
4681, 10266, 10267, 10289, 10288, 10320, 10364, 10365, 10362
4682, 10267, 10268, 10290, 10289, 10322, 10366, 10367, 10364
4683, 10268, 10269, 10291, 10290, 10324, 10368, 10369, 10366
4684, 10269, 10270, 10292, 10291, 10326, 10370, 10371, 10368
4685, 10270, 10271, 10293, 10292, 10328, 10372, 10373, 10370
4686, 10271, 10272, 10294, 10293, 10330, 10374, 10375, 10372
4687, 10272, 10273, 10295, 10294, 10332, 10376, 10377, 10374
4688, 10273, 10274, 10296, 10295, 10334, 10378, 10379, 10376
4689, 10274, 10275, 10297, 10296, 10336, 10380, 10381, 10378
4690, 10275, 10276, 10298, 10297, 10338, 10382, 10383, 10380
4691, 10276, 10277, 10299, 10298, 10340, 10384, 10385, 10382
4692, 10277, 10278, 10300, 10299, 10342, 10386, 10387, 10384
4693, 10278, 10279, 10301, 10300, 10344, 10388, 10389, 10386
4694, 10279, 10280, 10302, 10301, 10346, 10390, 10391, 10388
4695, 10280, 1234, 1235, 10302, 10347, 1237, 10392, 10390
4696, 1230, 10281, 1050, 29, 10349, 10393, 1072, 1233
4697, 10281, 10282, 1051, 1050, 10351, 10394, 1073, 10393
4698, 10282, 10283, 1052, 1051, 10353, 10395, 1074, 10394
4699, 10283, 10284, 1053, 1052, 10355, 10396, 1075, 10395
4700, 10284, 10285, 1054, 1053, 10357, 10397, 1076, 10396
4701, 10285, 10286, 1055, 1054, 10359, 10398, 1077, 10397
4702, 10286, 10287, 1056, 1055, 10361, 10399, 1078, 10398
4703, 10287, 10288, 1057, 1056, 10363, 10400, 1079, 10399
4704, 10288, 10289, 1058, 1057, 10365, 10401, 1080, 10400
4705, 10289, 10290, 1059, 1058, 10367, 10402, 1081, 10401
4706, 10290, 10291, 1060, 1059, 10369, 10403, 1082, 10402
4707, 10291, 10292, 1061, 1060, 10371, 10404, 1083, 10403
4708, 10292, 10293, 1062, 1061, 10373, 10405, 1084, 10404
4709, 10293, 10294, 1063, 1062, 10375, 10406, 1085, 10405
4710, 10294, 10295, 1064, 1063, 10377, 10407, 1086, 10406
4711, 10295, 10296, 1065, 1064, 10379, 10408, 1087, 10407
4712, 10296, 10297, 1066, 1065, 10381, 10409, 1088, 10408
4713, 10297, 10298, 1067, 1066, 10383, 10410, 1089, 10409
4714, 10298, 10299, 1068, 1067, 10385, 10411, 1090, 10410
4715, 10299, 10300, 1069, 1068, 10387, 10412, 1091, 10411
4716, 10300, 10301, 1070, 1069, 10389, 10413, 1092, 10412
4717, 10301, 10302, 1071, 1070, 10391, 10414, 1093, 10413
4718, 10302, 1235, 33, 1071, 10392, 1238, 1094, 10414
*ELEMENT, type=CPS8, ELSET=Surface194
4719, 35, 1291, 10415, 1174, 1300, 10431, 10432, 1176
4720, 1291, 1290, 10416, 10415, 1299, 10433, 10434, 10431
4721, 1290, 1289, 10417, 10416, 1298, 10435, 10436, 10433
4722, 1289, 1288, 10418, 10417, 1297, 10437, 10438, 10435
4723, 1288, 1287, 10419, 10418, 1296, 10439, 10440, 10437
4724, 1287, 1286, 10420, 10419, 1295, 10441, 10442, 10439
4725, 1286, 1285, 10421, 10420, 1294, 10443, 10444, 10441
4726, 1285, 1284, 10422, 10421, 1293, 10445, 10446, 10443
4727, 1284, 37, 1229, 10422, 1292, 1231, 10447, 10445
4728, 1174, 10415, 10423, 1175, 10432, 10448, 10449, 1177
4729, 10415, 10416, 10424, 10423, 10434, 10450, 10451, 10448
4730, 10416, 10417, 10425, 10424, 10436, 10452, 10453, 10450
4731, 10417, 10418, 10426, 10425, 10438, 10454, 10455, 10452
4732, 10418, 10419, 10427, 10426, 10440, 10456, 10457, 10454
4733, 10419, 10420, 10428, 10427, 10442, 10458, 10459, 10456
4734, 10420, 10421, 10429, 10428, 10444, 10460, 10461, 10458
4735, 10421, 10422, 10430, 10429, 10446, 10462, 10463, 10460
4736, 10422, 1229, 1230, 10430, 10447, 1232, 10464, 10462
4737, 1175, 10423, 919, 27, 10449, 10465, 928, 1178
4738, 10423, 10424, 918, 919, 10451, 10466, 927, 10465
4739, 10424, 10425, 917, 918, 10453, 10467, 926, 10466
4740, 10425, 10426, 916, 917, 10455, 10468, 925, 10467
4741, 10426, 10427, 915, 916, 10457, 10469, 924, 10468
4742, 10427, 10428, 914, 915, 10459, 10470, 923, 10469
4743, 10428, 10429, 913, 914, 10461, 10471, 922, 10470
4744, 10429, 10430, 912, 913, 10463, 10472, 921, 10471
4745, 10430, 1230, 29, 912, 10464, 1233, 920, 10472
*ELEMENT, type=CPS8, ELSET=Surface195
4746, 36, 1179, 10473, 1308, 1181, 10489, 10490, 1317
4747, 1308, 10473, 10474, 1307, 10490, 10491, 10492, 1316
4748, 1307, 10474, 10475, 1306, 10492, 10493, 10494, 1315
4749, 1306, 10475, 10476, 1305, 10494, 10495, 10496, 1314
4750, 1305, 10476, 10477, 1304, 10496, 10497, 10498, 1313
4751, 1304, 10477, 10478, 1303, 10498, 10499, 10500, 1312
4752, 1303, 10478, 10479, 1302, 10500, 10501, 10502, 1311
4753, 1302, 10479, 10480, 1301, 10502, 10503, 10504, 1310
4754, 1301, 10480, 1234, 38, 10504, 10505, 1236, 1309
4755, 1179, 1180, 10481, 10473, 1182, 10506, 10507, 10489
4756, 10473, 10481, 10482, 10474, 10507, 10508, 10509, 10491
4757, 10474, 10482, 10483, 10475, 10509, 10510, 10511, 10493
4758, 10475, 10483, 10484, 10476, 10511, 10512, 10513, 10495
4759, 10476, 10484, 10485, 10477, 10513, 10514, 10515, 10497
4760, 10477, 10485, 10486, 10478, 10515, 10516, 10517, 10499
4761, 10478, 10486, 10487, 10479, 10517, 10518, 10519, 10501
4762, 10479, 10487, 10488, 10480, 10519, 10520, 10521, 10503
4763, 10480, 10488, 1235, 1234, 10521, 10522, 1237, 10505
4764, 1180, 31, 1147, 10481, 1183, 1156, 10523, 10506
4765, 10481, 1147, 1146, 10482, 10523, 1155, 10524, 10508
4766, 10482, 1146, 1145, 10483, 10524, 1154, 10525, 10510
4767, 10483, 1145, 1144, 10484, 10525, 1153, 10526, 10512
4768, 10484, 1144, 1143, 10485, 10526, 1152, 10527, 10514
4769, 10485, 1143, 1142, 10486, 10527, 1151, 10528, 10516
4770, 10486, 1142, 1141, 10487, 10528, 1150, 10529, 10518
4771, 10487, 1141, 1140, 10488, 10529, 1149, 10530, 10520
4772, 10488, 1140, 33, 1235, 10530, 1148, 1238, 10522
*ELEMENT, type=CPS8, ELSET=Surface196
4773, 35, 1184, 10531, 1291, 1206, 10707, 10708, 1300
4774, 1291, 10531, 10532, 1290, 10708, 10709, 10710, 1299
4775, 1290, 10532, 10533, 1289, 10710, 10711, 10712, 1298
4776, 1289, 10533, 10534, 1288, 10712, 10713, 10714, 1297
4777, 1288, 10534, 10535, 1287, 10714, 10715, 10716, 1296
4778, 1287, 10535, 10536, 1286, 10716, 10717, 10718, 1295
4779, 1286, 10536, 10537, 1285, 10718, 10719, 10720, 1294
4780, 1285, 10537, 10538, 1284, 10720, 10721, 10722, 1293
4781, 1284, 10538, 1239, 37, 10722, 10723, 1261, 1292
4782, 1184, 1185, 10539, 10531, 1207, 10724, 10725, 10707
4783, 10531, 10539, 10540, 10532, 10725, 10726, 10727, 10709
4784, 10532, 10540, 10541, 10533, 10727, 10728, 10729, 10711
4785, 10533, 10541, 10542, 10534, 10729, 10730, 10731, 10713
4786, 10534, 10542, 10543, 10535, 10731, 10732, 10733, 10715
4787, 10535, 10543, 10544, 10536, 10733, 10734, 10735, 10717
4788, 10536, 10544, 10545, 10537, 10735, 10736, 10737, 10719
4789, 10537, 10545, 10546, 10538, 10737, 10738, 10739, 10721
4790, 10538, 10546, 1240, 1239, 10739, 10740, 1262, 10723
4791, 1185, 1186, 10547, 10539, 1208, 10741, 10742, 10724
4792, 10539, 10547, 10548, 10540, 10742, 10743, 10744, 10726
4793, 10540, 10548, 10549, 10541, 10744, 10745, 10746, 10728
4794, 10541, 10549, 10550, 10542, 10746, 10747, 10748, 10730
4795, 10542, 10550, 10551, 10543, 10748, 10749, 10750, 10732
4796, 10543, 10551, 10552, 10544, 10750, 10751, 10752, 10734
4797, 10544, 10552, 10553, 10545, 10752, 10753, 10754, 10736
4798, 10545, 10553, 10554, 10546, 10754, 10755, 10756, 10738
4799, 10546, 10554, 1241, 1240, 10756, 10757, 1263, 10740
4800, 1186, 1187, 10555, 10547, 1209, 10758, 10759, 10741
4801, 10547, 10555, 10556, 10548, 10759, 10760, 10761, 10743
4802, 10548, 10556, 10557, 10549, 10761, 10762, 10763, 10745
4803, 10549, 10557, 10558, 10550, 10763, 10764, 10765, 10747
4804, 10550, 10558, 10559, 10551, 10765, 10766, 10767, 10749
4805, 10551, 10559, 10560, 10552, 10767, 10768, 10769, 10751
4806, 10552, 10560, 10561, 10553, 10769, 10770, 10771, 10753
4807, 10553, 10561, 10562, 10554, 10771, 10772, 10773, 10755
4808, 10554, 10562, 1242, 1241, 10773, 10774, 1264, 10757
4809, 1187, 1188, 10563, 10555, 1210, 10775, 10776, 10758
4810, 10555, 10563, 10564, 10556, 10776, 10777, 10778, 10760
4811, 10556, 10564, 10565, 10557, 10778, 10779, 10780, 10762
4812, 10557, 10565, 10566, 10558, 10780, 10781, 10782, 10764
4813, 10558, 10566, 10567, 10559, 10782, 10783, 10784, 10766
4814, 10559, 10567, 10568, 10560, 10784, 10785, 10786, 10768
4815, 10560, 10568, 10569, 10561, 10786, 10787, 10788, 10770
4816, 10561, 10569, 10570, 10562, 10788, 10789, 10790, 10772
4817, 10562, 10570, 1243, 1242, 10790, 10791, 1265, 10774
4818, 1188, 1189, 10571, 10563, 1211, 10792, 10793, 10775
4819, 10563, 10571, 10572, 10564, 10793, 10794, 10795, 10777
4820, 10564, 10572, 10573, 10565, 10795, 10796, 10797, 10779
4821, 10565, 10573, 10574, 10566, 10797, 10798, 10799, 10781
4822, 10566, 10574, 10575, 10567, 10799, 10800, 10801, 10783
4823, 10567, 10575, 10576, 10568, 10801, 10802, 10803, 10785
4824, 10568, 10576, 10577, 10569, 10803, 10804, 10805, 10787
4825, 10569, 10577, 10578, 10570, 10805, 10806, 10807, 10789
4826, 10570, 10578, 1244, 1243, 10807, 10808, 1266, 10791
4827, 1189, 1190, 10579, 10571, 1212, 10809, 10810, 10792
4828, 10571, 10579, 10580, 10572, 10810, 10811, 10812, 10794
4829, 10572, 10580, 10581, 10573, 10812, 10813, 10814, 10796
4830, 10573, 10581, 10582, 10574, 10814, 10815, 10816, 10798
4831, 10574, 10582, 10583, 10575, 10816, 10817, 10818, 10800
4832, 10575, 10583, 10584, 10576, 10818, 10819, 10820, 10802
4833, 10576, 10584, 10585, 10577, 10820, 10821, 10822, 10804
4834, 10577, 10585, 10586, 10578, 10822, 10823, 10824, 10806
4835, 10578, 10586, 1245, 1244, 10824, 10825, 1267, 10808
4836, 1190, 1191, 10587, 10579, 1213, 10826, 10827, 10809
4837, 10579, 10587, 10588, 10580, 10827, 10828, 10829, 10811
4838, 10580, 10588, 10589, 10581, 10829, 10830, 10831, 10813
4839, 10581, 10589, 10590, 10582, 10831, 10832, 10833, 10815
4840, 10582, 10590, 10591, 10583, 10833, 10834, 10835, 10817
4841, 10583, 10591, 10592, 10584, 10835, 10836, 10837, 10819
4842, 10584, 10592, 10593, 10585, 10837, 10838, 10839, 10821
4843, 10585, 10593, 10594, 10586, 10839, 10840, 10841, 10823
4844, 10586, 10594, 1246, 1245, 10841, 10842, 1268, 10825
4845, 1191, 1192, 10595, 10587, 1214, 10843, 10844, 10826
4846, 10587, 10595, 10596, 10588, 10844, 10845, 10846, 10828
4847, 10588, 10596, 10597, 10589, 10846, 10847, 10848, 10830
4848, 10589, 10597, 10598, 10590, 10848, 10849, 10850, 10832
4849, 10590, 10598, 10599, 10591, 10850, 10851, 10852, 10834
4850, 10591, 10599, 10600, 10592, 10852, 10853, 10854, 10836
4851, 10592, 10600, 10601, 10593, 10854, 10855, 10856, 10838
4852, 10593, 10601, 10602, 10594, 10856, 10857, 10858, 10840
4853, 10594, 10602, 1247, 1246, 10858, 10859, 1269, 10842
4854, 1192, 1193, 10603, 10595, 1215, 10860, 10861, 10843
4855, 10595, 10603, 10604, 10596, 10861, 10862, 10863, 10845
4856, 10596, 10604, 10605, 10597, 10863, 10864, 10865, 10847
4857, 10597, 10605, 10606, 10598, 10865, 10866, 10867, 10849
4858, 10598, 10606, 10607, 10599, 10867, 10868, 10869, 10851
4859, 10599, 10607, 10608, 10600, 10869, 10870, 10871, 10853
4860, 10600, 10608, 10609, 10601, 10871, 10872, 10873, 10855
4861, 10601, 10609, 10610, 10602, 10873, 10874, 10875, 10857
4862, 10602, 10610, 1248, 1247, 10875, 10876, 1270, 10859
4863, 1193, 1194, 10611, 10603, 1216, 10877, 10878, 10860
4864, 10603, 10611, 10612, 10604, 10878, 10879, 10880, 10862
4865, 10604, 10612, 10613, 10605, 10880, 10881, 10882, 10864
4866, 10605, 10613, 10614, 10606, 10882, 10883, 10884, 10866
4867, 10606, 10614, 10615, 10607, 10884, 10885, 10886, 10868
4868, 10607, 10615, 10616, 10608, 10886, 10887, 10888, 10870
4869, 10608, 10616, 10617, 10609, 10888, 10889, 10890, 10872
4870, 10609, 10617, 10618, 10610, 10890, 10891, 10892, 10874
4871, 10610, 10618, 1249, 1248, 10892, 10893, 1271, 10876
4872, 1194, 1195, 10619, 10611, 1217, 10894, 10895, 10877
4873, 10611, 10619, 10620, 10612, 10895, 10896, 10897, 10879
4874, 10612, 10620, 10621, 10613, 10897, 10898, 10899, 10881
4875, 10613, 10621, 10622, 10614, 10899, 10900, 10901, 10883
4876, 10614, 10622, 10623, 10615, 10901, 10902, 10903, 10885
4877, 10615, 10623, 10624, 10616, 10903, 10904, 10905, 10887
4878, 10616, 10624, 10625, 10617, 10905, 10906, 10907, 10889
4879, 10617, 10625, 10626, 10618, 10907, 10908, 10909, 10891
4880, 10618, 10626, 1250, 1249, 10909, 10910, 1272, 10893
4881, 1195, 1196, 10627, 10619, 1218, 10911, 10912, 10894
4882, 10619, 10627, 10628, 10620, 10912, 10913, 10914, 10896
4883, 10620, 10628, 10629, 10621, 10914, 10915, 10916, 10898
4884, 10621, 10629, 10630, 10622, 10916, 10917, 10918, 10900
4885, 10622, 10630, 10631, 10623, 10918, 10919, 10920, 10902
4886, 10623, 10631, 10632, 10624, 10920, 10921, 10922, 10904
4887, 10624, 10632, 10633, 10625, 10922, 10923, 10924, 10906
4888, 10625, 10633, 10634, 10626, 10924, 10925, 10926, 10908
4889, 10626, 10634, 1251, 1250, 10926, 10927, 1273, 10910
4890, 1196, 1197, 10635, 10627, 1219, 10928, 10929, 10911
4891, 10627, 10635, 10636, 10628, 10929, 10930, 10931, 10913
4892, 10628, 10636, 10637, 10629, 10931, 10932, 10933, 10915
4893, 10629, 10637, 10638, 10630, 10933, 10934, 10935, 10917
4894, 10630, 10638, 10639, 10631, 10935, 10936, 10937, 10919
4895, 10631, 10639, 10640, 10632, 10937, 10938, 10939, 10921
4896, 10632, 10640, 10641, 10633, 10939, 10940, 10941, 10923
4897, 10633, 10641, 10642, 10634, 10941, 10942, 10943, 10925
4898, 10634, 10642, 1252, 1251, 10943, 10944, 1274, 10927
4899, 1197, 1198, 10643, 10635, 1220, 10945, 10946, 10928
4900, 10635, 10643, 10644, 10636, 10946, 10947, 10948, 10930
4901, 10636, 10644, 10645, 10637, 10948, 10949, 10950, 10932
4902, 10637, 10645, 10646, 10638, 10950, 10951, 10952, 10934
4903, 10638, 10646, 10647, 10639, 10952, 10953, 10954, 10936
4904, 10639, 10647, 10648, 10640, 10954, 10955, 10956, 10938
4905, 10640, 10648, 10649, 10641, 10956, 10957, 10958, 10940
4906, 10641, 10649, 10650, 10642, 10958, 10959, 10960, 10942
4907, 10642, 10650, 1253, 1252, 10960, 10961, 1275, 10944
4908, 1198, 1199, 10651, 10643, 1221, 10962, 10963, 10945
4909, 10643, 10651, 10652, 10644, 10963, 10964, 10965, 10947
4910, 10644, 10652, 10653, 10645, 10965, 10966, 10967, 10949
4911, 10645, 10653, 10654, 10646, 10967, 10968, 10969, 10951
4912, 10646, 10654, 10655, 10647, 10969, 10970, 10971, 10953
4913, 10647, 10655, 10656, 10648, 10971, 10972, 10973, 10955
4914, 10648, 10656, 10657, 10649, 10973, 10974, 10975, 10957
4915, 10649, 10657, 10658, 10650, 10975, 10976, 10977, 10959
4916, 10650, 10658, 1254, 1253, 10977, 10978, 1276, 10961
4917, 1199, 1200, 10659, 10651, 1222, 10979, 10980, 10962
4918, 10651, 10659, 10660, 10652, 10980, 10981, 10982, 10964
4919, 10652, 10660, 10661, 10653, 10982, 10983, 10984, 10966
4920, 10653, 10661, 10662, 10654, 10984, 10985, 10986, 10968
4921, 10654, 10662, 10663, 10655, 10986, 10987, 10988, 10970
4922, 10655, 10663, 10664, 10656, 10988, 10989, 10990, 10972
4923, 10656, 10664, 10665, 10657, 10990, 10991, 10992, 10974
4924, 10657, 10665, 10666, 10658, 10992, 10993, 10994, 10976
4925, 10658, 10666, 1255, 1254, 10994, 10995, 1277, 10978
4926, 1200, 1201, 10667, 10659, 1223, 10996, 10997, 10979
4927, 10659, 10667, 10668, 10660, 10997, 10998, 10999, 10981
4928, 10660, 10668, 10669, 10661, 10999, 11000, 11001, 10983
4929, 10661, 10669, 10670, 10662, 11001, 11002, 11003, 10985
4930, 10662, 10670, 10671, 10663, 11003, 11004, 11005, 10987
4931, 10663, 10671, 10672, 10664, 11005, 11006, 11007, 10989
4932, 10664, 10672, 10673, 10665, 11007, 11008, 11009, 10991
4933, 10665, 10673, 10674, 10666, 11009, 11010, 11011, 10993
4934, 10666, 10674, 1256, 1255, 11011, 11012, 1278, 10995
4935, 1201, 1202, 10675, 10667, 1224, 11013, 11014, 10996
4936, 10667, 10675, 10676, 10668, 11014, 11015, 11016, 10998
4937, 10668, 10676, 10677, 10669, 11016, 11017, 11018, 11000
4938, 10669, 10677, 10678, 10670, 11018, 11019, 11020, 11002
4939, 10670, 10678, 10679, 10671, 11020, 11021, 11022, 11004
4940, 10671, 10679, 10680, 10672, 11022, 11023, 11024, 11006
4941, 10672, 10680, 10681, 10673, 11024, 11025, 11026, 11008
4942, 10673, 10681, 10682, 10674, 11026, 11027, 11028, 11010
4943, 10674, 10682, 1257, 1256, 11028, 11029, 1279, 11012
4944, 1202, 1203, 10683, 10675, 1225, 11030, 11031, 11013
4945, 10675, 10683, 10684, 10676, 11031, 11032, 11033, 11015
4946, 10676, 10684, 10685, 10677, 11033, 11034, 11035, 11017
4947, 10677, 10685, 10686, 10678, 11035, 11036, 11037, 11019
4948, 10678, 10686, 10687, 10679, 11037, 11038, 11039, 11021
4949, 10679, 10687, 10688, 10680, 11039, 11040, 11041, 11023
4950, 10680, 10688, 10689, 10681, 11041, 11042, 11043, 11025
4951, 10681, 10689, 10690, 10682, 11043, 11044, 11045, 11027
4952, 10682, 10690, 1258, 1257, 11045, 11046, 1280, 11029
4953, 1203, 1204, 10691, 10683, 1226, 11047, 11048, 11030
4954, 10683, 10691, 10692, 10684, 11048, 11049, 11050, 11032
4955, 10684, 10692, 10693, 10685, 11050, 11051, 11052, 11034
4956, 10685, 10693, 10694, 10686, 11052, 11053, 11054, 11036
4957, 10686, 10694, 10695, 10687, 11054, 11055, 11056, 11038
4958, 10687, 10695, 10696, 10688, 11056, 11057, 11058, 11040
4959, 10688, 10696, 10697, 10689, 11058, 11059, 11060, 11042
4960, 10689, 10697, 10698, 10690, 11060, 11061, 11062, 11044
4961, 10690, 10698, 1259, 1258, 11062, 11063, 1281, 11046
4962, 1204, 1205, 10699, 10691, 1227, 11064, 11065, 11047
4963, 10691, 10699, 10700, 10692, 11065, 11066, 11067, 11049
4964, 10692, 10700, 10701, 10693, 11067, 11068, 11069, 11051
4965, 10693, 10701, 10702, 10694, 11069, 11070, 11071, 11053
4966, 10694, 10702, 10703, 10695, 11071, 11072, 11073, 11055
4967, 10695, 10703, 10704, 10696, 11073, 11074, 11075, 11057
4968, 10696, 10704, 10705, 10697, 11075, 11076, 11077, 11059
4969, 10697, 10705, 10706, 10698, 11077, 11078, 11079, 11061
4970, 10698, 10706, 1260, 1259, 11079, 11080, 1282, 11063
4971, 1205, 36, 1308, 10699, 1228, 1317, 11081, 11064
4972, 10699, 1308, 1307, 10700, 11081, 1316, 11082, 11066
4973, 10700, 1307, 1306, 10701, 11082, 1315, 11083, 11068
4974, 10701, 1306, 1305, 10702, 11083, 1314, 11084, 11070
4975, 10702, 1305, 1304, 10703, 11084, 1313, 11085, 11072
4976, 10703, 1304, 1303, 10704, 11085, 1312, 11086, 11074
4977, 10704, 1303, 1302, 10705, 11086, 1311, 11087, 11076
4978, 10705, 1302, 1301, 10706, 11087, 1310, 11088, 11078
4979, 10706, 1301, 38, 1260, 11088, 1309, 1283, 11080
*ELEMENT, type=CPS8, ELSET=Surface197
4980, 36, 1179, 11089, 1318, 1181, 11091, 11092, 1319
4981, 1179, 1180, 11090, 11089, 1182, 11093, 11094, 11091
4982, 1180, 31, 1321, 11090, 1183, 1322, 11095, 11093
4983, 1318, 11089, 1324, 39, 11092, 11096, 1326, 1320
4984, 11089, 11090, 1325, 1324, 11094, 11097, 1327, 11096
4985, 11090, 1321, 40, 1325, 11095, 1323, 1328, 11097
*ELEMENT, type=CPS8, ELSET=Surface198
4986, 38, 1329, 11098, 1234, 1330, 11100, 11101, 1236
4987, 1234, 11098, 11099, 1235, 11101, 11102, 11103, 1237
4988, 1235, 11099, 1332, 33, 11103, 11104, 1333, 1238
4989, 1329, 41, 1335, 11098, 1331, 1337, 11105, 11100
4990, 11098, 1335, 1336, 11099, 11105, 1338, 11106, 11102
4991, 11099, 1336, 42, 1332, 11106, 1339, 1334, 11104
*ELEMENT, type=CPS8, ELSET=Surface199
4992, 36, 1318, 11107, 1308, 1319, 11115, 11116, 1317
4993, 1308, 11107, 11108, 1307, 11116, 11117, 11118, 1316
4994, 1307, 11108, 11109, 1306, 11118, 11119, 11120, 1315
4995, 1306, 11109, 11110, 1305, 11120, 11121, 11122, 1314
4996, 1305, 11110, 11111, 1304, 11122, 11123, 11124, 1313
4997, 1304, 11111, 11112, 1303, 11124, 11125, 11126, 1312
4998, 1303, 11112, 11113, 1302, 11126, 11127, 11128, 1311
4999, 1302, 11113, 11114, 1301, 11128, 11129, 11130, 1310
5000, 1301, 11114, 1329, 38, 11130, 11131, 1330, 1309
5001, 1318, 39, 1347, 11107, 1320, 1356, 11132, 11115
5002, 11107, 1347, 1346, 11108, 11132, 1355, 11133, 11117
5003, 11108, 1346, 1345, 11109, 11133, 1354, 11134, 11119
5004, 11109, 1345, 1344, 11110, 11134, 1353, 11135, 11121
5005, 11110, 1344, 1343, 11111, 11135, 1352, 11136, 11123
5006, 11111, 1343, 1342, 11112, 11136, 1351, 11137, 11125
5007, 11112, 1342, 1341, 11113, 11137, 1350, 11138, 11127
5008, 11113, 1341, 1340, 11114, 11138, 1349, 11139, 11129
5009, 11114, 1340, 41, 1329, 11139, 1348, 1331, 11131
*ELEMENT, type=CPS8, ELSET=Surface200
5010, 31, 1147, 11140, 1321, 1156, 11148, 11149, 1322
5011, 1147, 1146, 11141, 11140, 1155, 11150, 11151, 11148
5012, 1146, 1145, 11142, 11141, 1154, 11152, 11153, 11150
5013, 1145, 1144, 11143, 11142, 1153, 11154, 11155, 11152
5014, 1144, 1143, 11144, 11143, 1152, 11156, 11157, 11154
5015, 1143, 1142, 11145, 11144, 1151, 11158, 11159, 11156
5016, 1142, 1141, 11146, 11145, 1150, 11160, 11161, 11158
5017, 1141, 1140, 11147, 11146, 1149, 11162, 11163, 11160
5018, 1140, 33, 1332, 11147, 1148, 1333, 11164, 11162
5019, 1321, 11140, 1364, 40, 11149, 11165, 1373, 1323
5020, 11140, 11141, 1363, 1364, 11151, 11166, 1372, 11165
5021, 11141, 11142, 1362, 1363, 11153, 11167, 1371, 11166
5022, 11142, 11143, 1361, 1362, 11155, 11168, 1370, 11167
5023, 11143, 11144, 1360, 1361, 11157, 11169, 1369, 11168
5024, 11144, 11145, 1359, 1360, 11159, 11170, 1368, 11169
5025, 11145, 11146, 1358, 1359, 11161, 11171, 1367, 11170
5026, 11146, 11147, 1357, 1358, 11163, 11172, 1366, 11171
5027, 11147, 1332, 42, 1357, 11164, 1334, 1365, 11172
*ELEMENT, type=CPS8, ELSET=Surface201
5028, 39, 1324, 11173, 1347, 1326, 11189, 11190, 1356
5029, 1347, 11173, 11174, 1346, 11190, 11191, 11192, 1355
5030, 1346, 11174, 11175, 1345, 11192, 11193, 11194, 1354
5031, 1345, 11175, 11176, 1344, 11194, 11195, 11196, 1353
5032, 1344, 11176, 11177, 1343, 11196, 11197, 11198, 1352
5033, 1343, 11177, 11178, 1342, 11198, 11199, 11200, 1351
5034, 1342, 11178, 11179, 1341, 11200, 11201, 11202, 1350
5035, 1341, 11179, 11180, 1340, 11202, 11203, 11204, 1349
5036, 1340, 11180, 1335, 41, 11204, 11205, 1337, 1348
5037, 1324, 1325, 11181, 11173, 1327, 11206, 11207, 11189
5038, 11173, 11181, 11182, 11174, 11207, 11208, 11209, 11191
5039, 11174, 11182, 11183, 11175, 11209, 11210, 11211, 11193
5040, 11175, 11183, 11184, 11176, 11211, 11212, 11213, 11195
5041, 11176, 11184, 11185, 11177, 11213, 11214, 11215, 11197
5042, 11177, 11185, 11186, 11178, 11215, 11216, 11217, 11199
5043, 11178, 11186, 11187, 11179, 11217, 11218, 11219, 11201
5044, 11179, 11187, 11188, 11180, 11219, 11220, 11221, 11203
5045, 11180, 11188, 1336, 1335, 11221, 11222, 1338, 11205
5046, 1325, 40, 1364, 11181, 1328, 1373, 11223, 11206
5047, 11181, 1364, 1363, 11182, 11223, 1372, 11224, 11208
5048, 11182, 1363, 1362, 11183, 11224, 1371, 11225, 11210
5049, 11183, 1362, 1361, 11184, 11225, 1370, 11226, 11212
5050, 11184, 1361, 1360, 11185, 11226, 1369, 11227, 11214
5051, 11185, 1360, 1359, 11186, 11227, 1368, 11228, 11216
5052, 11186, 1359, 1358, 11187, 11228, 1367, 11229, 11218
5053, 11187, 1358, 1357, 11188, 11229, 1366, 11230, 11220
5054, 11188, 1357, 42, 1336, 11230, 1365, 1339, 11222
*ELEMENT, type=CPS8, ELSET=Surface202
5055, 31, 946, 11231, 1321, 949, 11234, 11235, 1322
5056, 1321, 11231, 1374, 40, 11235, 11236, 1377, 1323
5057, 946, 947, 11232, 11231, 950, 11237, 11238, 11234
5058, 11231, 11232, 1375, 1374, 11238, 11239, 1378, 11236
5059, 947, 948, 11233, 11232, 951, 11240, 11241, 11237
5060, 11232, 11233, 1376, 1375, 11241, 11242, 1379, 11239
5061, 948, 32, 1381, 11233, 952, 1382, 11243, 11240
5062, 11233, 1381, 43, 1376, 11243, 1383, 1380, 11242
*ELEMENT, type=CPS8, ELSET=Surface203
5063, 33, 1332, 11244, 1043, 1333, 11247, 11248, 1046
5064, 1332, 42, 1384, 11244, 1334, 1387, 11249, 11247
5065, 1043, 11244, 11245, 1044, 11248, 11250, 11251, 1047
5066, 11244, 1384, 1385, 11245, 11249, 1388, 11252, 11250
5067, 1044, 11245, 11246, 1045, 11251, 11253, 11254, 1048
5068, 11245, 1385, 1386, 11246, 11252, 1389, 11255, 11253
5069, 1045, 11246, 1391, 34, 11254, 11256, 1392, 1049
5070, 11246, 1386, 44, 1391, 11255, 1390, 1393, 11256
*ELEMENT, type=CPS8, ELSET=Surface204
5071, 40, 1374, 11257, 1364, 1377, 11281, 11282, 1373
5072, 1364, 11257, 11258, 1363, 11282, 11283, 11284, 1372
5073, 1363, 11258, 11259, 1362, 11284, 11285, 11286, 1371
5074, 1362, 11259, 11260, 1361, 11286, 11287, 11288, 1370
5075, 1361, 11260, 11261, 1360, 11288, 11289, 11290, 1369
5076, 1360, 11261, 11262, 1359, 11290, 11291, 11292, 1368
5077, 1359, 11262, 11263, 1358, 11292, 11293, 11294, 1367
5078, 1358, 11263, 11264, 1357, 11294, 11295, 11296, 1366
5079, 1357, 11264, 1384, 42, 11296, 11297, 1387, 1365
5080, 1374, 1375, 11265, 11257, 1378, 11298, 11299, 11281
5081, 11257, 11265, 11266, 11258, 11299, 11300, 11301, 11283
5082, 11258, 11266, 11267, 11259, 11301, 11302, 11303, 11285
5083, 11259, 11267, 11268, 11260, 11303, 11304, 11305, 11287
5084, 11260, 11268, 11269, 11261, 11305, 11306, 11307, 11289
5085, 11261, 11269, 11270, 11262, 11307, 11308, 11309, 11291
5086, 11262, 11270, 11271, 11263, 11309, 11310, 11311, 11293
5087, 11263, 11271, 11272, 11264, 11311, 11312, 11313, 11295
5088, 11264, 11272, 1385, 1384, 11313, 11314, 1388, 11297
5089, 1375, 1376, 11273, 11265, 1379, 11315, 11316, 11298
5090, 11265, 11273, 11274, 11266, 11316, 11317, 11318, 11300
5091, 11266, 11274, 11275, 11267, 11318, 11319, 11320, 11302
5092, 11267, 11275, 11276, 11268, 11320, 11321, 11322, 11304
5093, 11268, 11276, 11277, 11269, 11322, 11323, 11324, 11306
5094, 11269, 11277, 11278, 11270, 11324, 11325, 11326, 11308
5095, 11270, 11278, 11279, 11271, 11326, 11327, 11328, 11310
5096, 11271, 11279, 11280, 11272, 11328, 11329, 11330, 11312
5097, 11272, 11280, 1386, 1385, 11330, 11331, 1389, 11314
5098, 1376, 43, 1401, 11273, 1380, 1410, 11332, 11315
5099, 11273, 1401, 1400, 11274, 11332, 1409, 11333, 11317
5100, 11274, 1400, 1399, 11275, 11333, 1408, 11334, 11319
5101, 11275, 1399, 1398, 11276, 11334, 1407, 11335, 11321
5102, 11276, 1398, 1397, 11277, 11335, 1406, 11336, 11323
5103, 11277, 1397, 1396, 11278, 11336, 1405, 11337, 11325
5104, 11278, 1396, 1395, 11279, 11337, 1404, 11338, 11327
5105, 11279, 1395, 1394, 11280, 11338, 1403, 11339, 11329
5106, 11280, 1394, 44, 1386, 11339, 1402, 1390, 11331
*ELEMENT, type=CPS8, ELSET=Surface205
5107, 32, 1164, 11340, 1381, 1173, 11348, 11349, 1382
5108, 1164, 1163, 11341, 11340, 1172, 11350, 11351, 11348
5109, 1163, 1162, 11342, 11341, 1171, 11352, 11353, 11350
5110, 1162, 1161, 11343, 11342, 1170, 11354, 11355, 11352
5111, 1161, 1160, 11344, 11343, 1169, 11356, 11357, 11354
5112, 1160, 1159, 11345, 11344, 1168, 11358, 11359, 11356
5113, 1159, 1158, 11346, 11345, 1167, 11360, 11361, 11358
5114, 1158, 1157, 11347, 11346, 1166, 11362, 11363, 11360
5115, 1157, 34, 1391, 11347, 1165, 1392, 11364, 11362
5116, 1381, 11340, 1401, 43, 11349, 11365, 1410, 1383
5117, 11340, 11341, 1400, 1401, 11351, 11366, 1409, 11365
5118, 11341, 11342, 1399, 1400, 11353, 11367, 1408, 11366
5119, 11342, 11343, 1398, 1399, 11355, 11368, 1407, 11367
5120, 11343, 11344, 1397, 1398, 11357, 11369, 1406, 11368
5121, 11344, 11345, 1396, 1397, 11359, 11370, 1405, 11369
5122, 11345, 11346, 1395, 1396, 11361, 11371, 1404, 11370
5123, 11346, 11347, 1394, 1395, 11363, 11372, 1403, 11371
5124, 11347, 1391, 44, 1394, 11364, 1393, 1402, 11372
*ELEMENT, type=CPS8, ELSET=Surface206
5125, 45, 1442, 11373, 1411, 1465, 11417, 11418, 1413
5126, 1442, 1441, 11374, 11373, 1464, 11419, 11420, 11417
5127, 1441, 1440, 11375, 11374, 1463, 11421, 11422, 11419
5128, 1440, 1439, 11376, 11375, 1462, 11423, 11424, 11421
5129, 1439, 1438, 11377, 11376, 1461, 11425, 11426, 11423
5130, 1438, 1437, 11378, 11377, 1460, 11427, 11428, 11425
5131, 1437, 1436, 11379, 11378, 1459, 11429, 11430, 11427
5132, 1436, 1435, 11380, 11379, 1458, 11431, 11432, 11429
5133, 1435, 1434, 11381, 11380, 1457, 11433, 11434, 11431
5134, 1434, 1433, 11382, 11381, 1456, 11435, 11436, 11433
5135, 1433, 1432, 11383, 11382, 1455, 11437, 11438, 11435
5136, 1432, 1431, 11384, 11383, 1454, 11439, 11440, 11437
5137, 1431, 1430, 11385, 11384, 1453, 11441, 11442, 11439
5138, 1430, 1429, 11386, 11385, 1452, 11443, 11444, 11441
5139, 1429, 1428, 11387, 11386, 1451, 11445, 11446, 11443
5140, 1428, 1427, 11388, 11387, 1450, 11447, 11448, 11445
5141, 1427, 1426, 11389, 11388, 1449, 11449, 11450, 11447
5142, 1426, 1425, 11390, 11389, 1448, 11451, 11452, 11449
5143, 1425, 1424, 11391, 11390, 1447, 11453, 11454, 11451
5144, 1424, 1423, 11392, 11391, 1446, 11455, 11456, 11453
5145, 1423, 1422, 11393, 11392, 1445, 11457, 11458, 11455
5146, 1422, 1421, 11394, 11393, 1444, 11459, 11460, 11457
5147, 1421, 47, 1416, 11394, 1443, 1418, 11461, 11459
5148, 1411, 11373, 11395, 1412, 11418, 11462, 11463, 1414
5149, 11373, 11374, 11396, 11395, 11420, 11464, 11465, 11462
5150, 11374, 11375, 11397, 11396, 11422, 11466, 11467, 11464
5151, 11375, 11376, 11398, 11397, 11424, 11468, 11469, 11466
5152, 11376, 11377, 11399, 11398, 11426, 11470, 11471, 11468
5153, 11377, 11378, 11400, 11399, 11428, 11472, 11473, 11470
5154, 11378, 11379, 11401, 11400, 11430, 11474, 11475, 11472
5155, 11379, 11380, 11402, 11401, 11432, 11476, 11477, 11474
5156, 11380, 11381, 11403, 11402, 11434, 11478, 11479, 11476
5157, 11381, 11382, 11404, 11403, 11436, 11480, 11481, 11478
5158, 11382, 11383, 11405, 11404, 11438, 11482, 11483, 11480
5159, 11383, 11384, 11406, 11405, 11440, 11484, 11485, 11482
5160, 11384, 11385, 11407, 11406, 11442, 11486, 11487, 11484
5161, 11385, 11386, 11408, 11407, 11444, 11488, 11489, 11486
5162, 11386, 11387, 11409, 11408, 11446, 11490, 11491, 11488
5163, 11387, 11388, 11410, 11409, 11448, 11492, 11493, 11490
5164, 11388, 11389, 11411, 11410, 11450, 11494, 11495, 11492
5165, 11389, 11390, 11412, 11411, 11452, 11496, 11497, 11494
5166, 11390, 11391, 11413, 11412, 11454, 11498, 11499, 11496
5167, 11391, 11392, 11414, 11413, 11456, 11500, 11501, 11498
5168, 11392, 11393, 11415, 11414, 11458, 11502, 11503, 11500
5169, 11393, 11394, 11416, 11415, 11460, 11504, 11505, 11502
5170, 11394, 1416, 1417, 11416, 11461, 1419, 11506, 11504
5171, 1412, 11395, 1487, 46, 11463, 11507, 1510, 1415
5172, 11395, 11396, 1486, 1487, 11465, 11508, 1509, 11507
5173, 11396, 11397, 1485, 1486, 11467, 11509, 1508, 11508
5174, 11397, 11398, 1484, 1485, 11469, 11510, 1507, 11509
5175, 11398, 11399, 1483, 1484, 11471, 11511, 1506, 11510
5176, 11399, 11400, 1482, 1483, 11473, 11512, 1505, 11511
5177, 11400, 11401, 1481, 1482, 11475, 11513, 1504, 11512
5178, 11401, 11402, 1480, 1481, 11477, 11514, 1503, 11513
5179, 11402, 11403, 1479, 1480, 11479, 11515, 1502, 11514
5180, 11403, 11404, 1478, 1479, 11481, 11516, 1501, 11515
5181, 11404, 11405, 1477, 1478, 11483, 11517, 1500, 11516
5182, 11405, 11406, 1476, 1477, 11485, 11518, 1499, 11517
5183, 11406, 11407, 1475, 1476, 11487, 11519, 1498, 11518
5184, 11407, 11408, 1474, 1475, 11489, 11520, 1497, 11519
5185, 11408, 11409, 1473, 1474, 11491, 11521, 1496, 11520
5186, 11409, 11410, 1472, 1473, 11493, 11522, 1495, 11521
5187, 11410, 11411, 1471, 1472, 11495, 11523, 1494, 11522
5188, 11411, 11412, 1470, 1471, 11497, 11524, 1493, 11523
5189, 11412, 11413, 1469, 1470, 11499, 11525, 1492, 11524
5190, 11413, 11414, 1468, 1469, 11501, 11526, 1491, 11525
5191, 11414, 11415, 1467, 1468, 11503, 11527, 1490, 11526
5192, 11415, 11416, 1466, 1467, 11505, 11528, 1489, 11527
5193, 11416, 1417, 48, 1466, 11506, 1420, 1488, 11528
*ELEMENT, type=CPS8, ELSET=Surface207
