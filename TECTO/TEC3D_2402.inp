31320, 0, 0.22826086956522, -0.05
31321, 0, 0.30652173913043, -0.025
31322, 0, 0.2804347826087, -0.05
31323, 0, 0.35869565217391, -0.025
31324, 0, 0.33260869565217, -0.05
31325, 0, 0.41086956521739, -0.025
31326, 0, 0.38478260869565, -0.05
31327, 0, 0.46304347826087, -0.025
31328, 0, 0.43695652173913, -0.05
31329, 0, 0.51521739130435, -0.025
31330, 0, 0.48913043478261, -0.05
31331, 0, 0.56739130434783, -0.025
31332, 0, 0.54130434782609, -0.05
31333, 0, 0.6195652173913, -0.025
31334, 0, 0.59347826086956, -0.05
31335, 0, 0.67173913043478, -0.025
31336, 0, 0.64565217391304, -0.05
31337, 0, 0.72391304347826, -0.025
31338, 0, 0.69782608695652, -0.05
31339, 0, 0.77608695652174, -0.025
31340, 0, 0.75, -0.05
31341, 0, 0.82826086956522, -0.025
31342, 0, 0.80217391304348, -0.05
31343, 0, 0.88043478260869, -0.025
31344, 0, 0.85434782608696, -0.05
31345, 0, 0.93260869565217, -0.025
31346, 0, 0.90652173913043, -0.05
31347, 0, 0.98478260869565, -0.025
31348, 0, 0.95869565217391, -0.05
31349, 0, 1.0369565217391, -0.025
31350, 0, 1.0108695652174, -0.05
31351, 0, 1.0891304347826, -0.025
31352, 0, 1.0630434782609, -0.05
31353, 0, 1.1413043478261, -0.025
31354, 0, 1.1152173913043, -0.05
31355, 0, 1.1934782608696, -0.025
31356, 0, 1.1673913043478, -0.05
31357, 0, 1.245652173913, -0.025
31358, 0, 1.2195652173913, -0.05
31359, 0, 1.2978260869565, -0.025
31360, 0, 1.2717391304348, -0.05
31361, 0, 1.3239130434783, -0.05
31362, 0, 0.20217391304348, -0.075
31363, 0, 0.17608695652174, -0.1
31364, 0, 0.25434782608696, -0.075
31365, 0, 0.22826086956522, -0.1
31366, 0, 0.30652173913043, -0.075
31367, 0, 0.2804347826087, -0.1
31368, 0, 0.35869565217391, -0.075
31369, 0, 0.33260869565217, -0.1
31370, 0, 0.41086956521739, -0.075
31371, 0, 0.38478260869565, -0.1
31372, 0, 0.46304347826087, -0.075
31373, 0, 0.43695652173913, -0.1
31374, 0, 0.51521739130435, -0.075
31375, 0, 0.48913043478261, -0.1
31376, 0, 0.56739130434783, -0.075
31377, 0, 0.54130434782609, -0.1
31378, 0, 0.6195652173913, -0.075
31379, 0, 0.59347826086956, -0.1
31380, 0, 0.67173913043478, -0.075
31381, 0, 0.64565217391304, -0.1
31382, 0, 0.72391304347826, -0.075
31383, 0, 0.69782608695652, -0.1
31384, 0, 0.77608695652174, -0.075
31385, 0, 0.75, -0.1
31386, 0, 0.82826086956522, -0.075
31387, 0, 0.80217391304348, -0.1
31388, 0, 0.8804347826087, -0.075
31389, 0, 0.85434782608696, -0.1
31390, 0, 0.93260869565217, -0.075
31391, 0, 0.90652173913043, -0.1
31392, 0, 0.98478260869565, -0.075
31393, 0, 0.95869565217391, -0.1
31394, 0, 1.0369565217391, -0.075
31395, 0, 1.0108695652174, -0.1
31396, 0, 1.0891304347826, -0.075
31397, 0, 1.0630434782609, -0.1
31398, 0, 1.1413043478261, -0.075
31399, 0, 1.1152173913043, -0.1
31400, 0, 1.1934782608696, -0.075
31401, 0, 1.1673913043478, -0.1
31402, 0, 1.245652173913, -0.075
31403, 0, 1.2195652173913, -0.1
31404, 0, 1.2978260869565, -0.075
31405, 0, 1.2717391304348, -0.1
31406, 0, 1.3239130434783, -0.1
31407, 0, 0.20217391304348, -0.125
31408, 0, 0.17608695652174, -0.15
31409, 0, 0.25434782608696, -0.125
31410, 0, 0.22826086956522, -0.15
31411, 0, 0.30652173913043, -0.125
31412, 0, 0.2804347826087, -0.15
31413, 0, 0.35869565217391, -0.125
31414, 0, 0.33260869565217, -0.15
31415, 0, 0.41086956521739, -0.125
31416, 0, 0.38478260869565, -0.15
31417, 0, 0.46304347826087, -0.125
31418, 0, 0.43695652173913, -0.15
31419, 0, 0.51521739130435, -0.125
31420, 0, 0.48913043478261, -0.15
31421, 0, 0.56739130434783, -0.125
31422, 0, 0.54130434782609, -0.15
31423, 0, 0.6195652173913, -0.125
31424, 0, 0.59347826086956, -0.15
31425, 0, 0.67173913043478, -0.125
31426, 0, 0.64565217391304, -0.15
31427, 0, 0.72391304347826, -0.125
31428, 0, 0.69782608695652, -0.15
31429, 0, 0.77608695652174, -0.125
31430, 0, 0.75, -0.15
31431, 0, 0.82826086956522, -0.125
31432, 0, 0.80217391304348, -0.15
31433, 0, 0.88043478260869, -0.125
31434, 0, 0.85434782608696, -0.15
31435, 0, 0.93260869565217, -0.125
31436, 0, 0.90652173913043, -0.15
31437, 0, 0.98478260869565, -0.125
31438, 0, 0.95869565217391, -0.15
31439, 0, 1.0369565217391, -0.125
31440, 0, 1.0108695652174, -0.15
31441, 0, 1.0891304347826, -0.125
31442, 0, 1.0630434782609, -0.15
31443, 0, 1.1413043478261, -0.125
31444, 0, 1.1152173913043, -0.15
31445, 0, 1.1934782608696, -0.125
31446, 0, 1.1673913043478, -0.15
31447, 0, 1.245652173913, -0.125
31448, 0, 1.2195652173913, -0.15
31449, 0, 1.2978260869565, -0.125
31450, 0, 1.2717391304348, -0.15
31451, 0, 1.3239130434783, -0.15
31452, 0, 0.20217391304348, -0.175
31453, 0, 0.25434782608696, -0.175
31454, 0, 0.30652173913043, -0.175
31455, 0, 0.35869565217391, -0.175
31456, 0, 0.41086956521739, -0.175
31457, 0, 0.46304347826087, -0.175
31458, 0, 0.51521739130435, -0.175
31459, 0, 0.56739130434783, -0.175
31460, 0, 0.6195652173913, -0.175
31461, 0, 0.67173913043478, -0.175
31462, 0, 0.72391304347826, -0.175
31463, 0, 0.77608695652174, -0.175
31464, 0, 0.82826086956522, -0.175
31465, 0, 0.88043478260869, -0.175
31466, 0, 0.93260869565217, -0.175
31467, 0, 0.98478260869565, -0.175
31468, 0, 1.0369565217391, -0.175
31469, 0, 1.0891304347826, -0.175
31470, 0, 1.1413043478261, -0.175
31471, 0, 1.1934782608696, -0.175
31472, 0, 1.245652173913, -0.175
31473, 0, 1.2978260869565, -0.175
31474, 0.95652173913043, 0.15, -0.05
31475, 0.91304347826087, 0.15, -0.05
31476, 0.8695652173913, 0.15, -0.05
31477, 0.82608695652174, 0.15, -0.05
31478, 0.78260869565217, 0.15, -0.05
31479, 0.73913043478261, 0.15, -0.05
31480, 0.69565217391304, 0.15, -0.05
31481, 0.65217391304348, 0.15, -0.05
31482, 0.60869565217391, 0.15, -0.05
31483, 0.56521739130435, 0.15, -0.05
31484, 0.52173913043478, 0.15, -0.05
31485, 0.47826086956522, 0.15, -0.05
31486, 0.43478260869565, 0.15, -0.05
31487, 0.39130434782609, 0.15, -0.05
31488, 0.34782608695652, 0.15, -0.05
31489, 0.30434782608696, 0.15, -0.05
31490, 0.26086956521739, 0.15, -0.05
31491, 0.21739130434783, 0.15, -0.05
31492, 0.17391304347826, 0.15, -0.05
31493, 0.1304347826087, 0.15, -0.05
31494, 0.08695652173913, 0.15, -0.05
31495, 0.043478260869565, 0.15, -0.05
31496, 0.95652173913043, 0.15, -0.1
31497, 0.91304347826087, 0.15, -0.1
31498, 0.8695652173913, 0.15, -0.1
31499, 0.82608695652174, 0.15, -0.1
31500, 0.78260869565217, 0.15, -0.1
31501, 0.73913043478261, 0.15, -0.1
31502, 0.69565217391304, 0.15, -0.1
31503, 0.65217391304348, 0.15, -0.1
31504, 0.60869565217391, 0.15, -0.1
31505, 0.56521739130435, 0.15, -0.1
31506, 0.52173913043478, 0.15, -0.1
31507, 0.47826086956522, 0.15, -0.1
31508, 0.43478260869565, 0.15, -0.1
31509, 0.39130434782609, 0.15, -0.1
31510, 0.34782608695652, 0.15, -0.1
31511, 0.30434782608696, 0.15, -0.1
31512, 0.26086956521739, 0.15, -0.1
31513, 0.21739130434783, 0.15, -0.1
31514, 0.17391304347826, 0.15, -0.1
31515, 0.1304347826087, 0.15, -0.1
31516, 0.08695652173913, 0.15, -0.1
31517, 0.043478260869565, 0.15, -0.1
31518, 0.95652173913043, 0.15, -0.15
31519, 0.91304347826087, 0.15, -0.15
31520, 0.8695652173913, 0.15, -0.15
31521, 0.82608695652174, 0.15, -0.15
31522, 0.78260869565217, 0.15, -0.15
31523, 0.73913043478261, 0.15, -0.15
31524, 0.69565217391304, 0.15, -0.15
31525, 0.65217391304348, 0.15, -0.15
31526, 0.60869565217391, 0.15, -0.15
31527, 0.56521739130435, 0.15, -0.15
31528, 0.52173913043478, 0.15, -0.15
31529, 0.47826086956522, 0.15, -0.15
31530, 0.43478260869565, 0.15, -0.15
31531, 0.39130434782609, 0.15, -0.15
31532, 0.34782608695652, 0.15, -0.15
31533, 0.30434782608696, 0.15, -0.15
31534, 0.26086956521739, 0.15, -0.15
31535, 0.21739130434783, 0.15, -0.15
31536, 0.17391304347826, 0.15, -0.15
31537, 0.1304347826087, 0.15, -0.15
31538, 0.08695652173913, 0.15, -0.15
31539, 0.043478260869565, 0.15, -0.15
31540, 0.95652173913043, 0.15, -0.025
31541, 0.97826086956522, 0.15, -0.05
31542, 0.91304347826087, 0.15, -0.025
31543, 0.93478260869565, 0.15, -0.05
31544, 0.8695652173913, 0.15, -0.025
31545, 0.89130434782609, 0.15, -0.05
31546, 0.82608695652174, 0.15, -0.025
31547, 0.84782608695652, 0.15, -0.05
31548, 0.78260869565217, 0.15, -0.025
31549, 0.80434782608696, 0.15, -0.05
31550, 0.73913043478261, 0.15, -0.025
31551, 0.76086956521739, 0.15, -0.05
31552, 0.69565217391304, 0.15, -0.025
31553, 0.71739130434783, 0.15, -0.05
31554, 0.65217391304348, 0.15, -0.025
31555, 0.67391304347826, 0.15, -0.05
31556, 0.60869565217391, 0.15, -0.025
31557, 0.6304347826087, 0.15, -0.05
31558, 0.56521739130435, 0.15, -0.025
31559, 0.58695652173913, 0.15, -0.05
31560, 0.52173913043478, 0.15, -0.025
31561, 0.54347826086957, 0.15, -0.05
31562, 0.47826086956522, 0.15, -0.025
31563, 0.5, 0.15, -0.05
31564, 0.43478260869565, 0.15, -0.025
31565, 0.45652173913043, 0.15, -0.05
31566, 0.39130434782609, 0.15, -0.025
31567, 0.41304347826087, 0.15, -0.05
31568, 0.34782608695652, 0.15, -0.025
31569, 0.3695652173913, 0.15, -0.05
31570, 0.30434782608696, 0.15, -0.025
31571, 0.32608695652174, 0.15, -0.05
31572, 0.26086956521739, 0.15, -0.025
31573, 0.28260869565217, 0.15, -0.05
31574, 0.21739130434783, 0.15, -0.025
31575, 0.23913043478261, 0.15, -0.05
31576, 0.17391304347826, 0.15, -0.025
31577, 0.19565217391304, 0.15, -0.05
31578, 0.1304347826087, 0.15, -0.025
31579, 0.15217391304348, 0.15, -0.05
31580, 0.08695652173913, 0.15, -0.025
31581, 0.10869565217391, 0.15, -0.05
31582, 0.043478260869565, 0.15, -0.025
31583, 0.065217391304348, 0.15, -0.05
31584, 0.021739130434783, 0.15, -0.05
31585, 0.95652173913043, 0.15, -0.075
31586, 0.97826086956522, 0.15, -0.1
31587, 0.91304347826087, 0.15, -0.075
31588, 0.93478260869565, 0.15, -0.1
31589, 0.8695652173913, 0.15, -0.075
31590, 0.89130434782609, 0.15, -0.1
31591, 0.82608695652174, 0.15, -0.075
31592, 0.84782608695652, 0.15, -0.1
31593, 0.78260869565217, 0.15, -0.075
31594, 0.80434782608696, 0.15, -0.1
31595, 0.73913043478261, 0.15, -0.075
31596, 0.76086956521739, 0.15, -0.1
31597, 0.69565217391304, 0.15, -0.075
31598, 0.71739130434783, 0.15, -0.1
31599, 0.65217391304348, 0.15, -0.075
31600, 0.67391304347826, 0.15, -0.1
31601, 0.60869565217391, 0.15, -0.075
31602, 0.6304347826087, 0.15, -0.1
31603, 0.56521739130435, 0.15, -0.075
31604, 0.58695652173913, 0.15, -0.1
31605, 0.52173913043478, 0.15, -0.075
31606, 0.54347826086957, 0.15, -0.1
31607, 0.47826086956522, 0.15, -0.075
31608, 0.5, 0.15, -0.1
31609, 0.43478260869565, 0.15, -0.075
31610, 0.45652173913043, 0.15, -0.1
31611, 0.39130434782609, 0.15, -0.075
31612, 0.41304347826087, 0.15, -0.1
31613, 0.34782608695652, 0.15, -0.075
31614, 0.3695652173913, 0.15, -0.1
31615, 0.30434782608696, 0.15, -0.075
31616, 0.32608695652174, 0.15, -0.1
31617, 0.26086956521739, 0.15, -0.075
31618, 0.28260869565217, 0.15, -0.1
31619, 0.21739130434783, 0.15, -0.075
31620, 0.23913043478261, 0.15, -0.1
31621, 0.17391304347826, 0.15, -0.075
31622, 0.19565217391304, 0.15, -0.1
31623, 0.1304347826087, 0.15, -0.075
31624, 0.15217391304348, 0.15, -0.1
31625, 0.08695652173913, 0.15, -0.075
31626, 0.10869565217391, 0.15, -0.1
31627, 0.043478260869565, 0.15, -0.075
31628, 0.065217391304348, 0.15, -0.1
31629, 0.021739130434783, 0.15, -0.1
31630, 0.95652173913043, 0.15, -0.125
31631, 0.97826086956522, 0.15, -0.15
31632, 0.91304347826087, 0.15, -0.125
31633, 0.93478260869565, 0.15, -0.15
31634, 0.8695652173913, 0.15, -0.125
31635, 0.89130434782609, 0.15, -0.15
31636, 0.82608695652174, 0.15, -0.125
31637, 0.84782608695652, 0.15, -0.15
31638, 0.78260869565217, 0.15, -0.125
31639, 0.80434782608696, 0.15, -0.15
31640, 0.73913043478261, 0.15, -0.125
31641, 0.76086956521739, 0.15, -0.15
31642, 0.69565217391304, 0.15, -0.125
31643, 0.71739130434783, 0.15, -0.15
31644, 0.65217391304348, 0.15, -0.125
31645, 0.67391304347826, 0.15, -0.15
31646, 0.60869565217391, 0.15, -0.125
31647, 0.6304347826087, 0.15, -0.15
31648, 0.56521739130435, 0.15, -0.125
31649, 0.58695652173913, 0.15, -0.15
31650, 0.52173913043478, 0.15, -0.125
31651, 0.54347826086957, 0.15, -0.15
31652, 0.47826086956522, 0.15, -0.125
31653, 0.5, 0.15, -0.15
31654, 0.43478260869565, 0.15, -0.125
31655, 0.45652173913043, 0.15, -0.15
31656, 0.39130434782609, 0.15, -0.125
31657, 0.41304347826087, 0.15, -0.15
31658, 0.34782608695652, 0.15, -0.125
31659, 0.3695652173913, 0.15, -0.15
31660, 0.30434782608696, 0.15, -0.125
31661, 0.32608695652174, 0.15, -0.15
31662, 0.26086956521739, 0.15, -0.125
31663, 0.28260869565217, 0.15, -0.15
31664, 0.21739130434783, 0.15, -0.125
31665, 0.23913043478261, 0.15, -0.15
31666, 0.17391304347826, 0.15, -0.125
31667, 0.19565217391304, 0.15, -0.15
31668, 0.1304347826087, 0.15, -0.125
31669, 0.15217391304348, 0.15, -0.15
31670, 0.08695652173913, 0.15, -0.125
31671, 0.10869565217391, 0.15, -0.15
31672, 0.043478260869565, 0.15, -0.125
31673, 0.065217391304348, 0.15, -0.15
31674, 0.021739130434783, 0.15, -0.15
31675, 0.95652173913043, 0.15, -0.175
31676, 0.91304347826087, 0.15, -0.175
31677, 0.8695652173913, 0.15, -0.175
31678, 0.82608695652174, 0.15, -0.175
31679, 0.78260869565217, 0.15, -0.175
31680, 0.73913043478261, 0.15, -0.175
31681, 0.69565217391304, 0.15, -0.175
31682, 0.65217391304348, 0.15, -0.175
31683, 0.60869565217391, 0.15, -0.175
31684, 0.56521739130435, 0.15, -0.175
31685, 0.52173913043478, 0.15, -0.175
31686, 0.47826086956522, 0.15, -0.175
31687, 0.43478260869565, 0.15, -0.175
31688, 0.39130434782609, 0.15, -0.175
31689, 0.34782608695652, 0.15, -0.175
31690, 0.30434782608696, 0.15, -0.175
31691, 0.26086956521739, 0.15, -0.175
31692, 0.21739130434783, 0.15, -0.175
31693, 0.17391304347826, 0.15, -0.175
31694, 0.1304347826087, 0.15, -0.175
31695, 0.08695652173913, 0.15, -0.175
31696, 0.043478260869565, 0.15, -0.175
31697, 0.043478260869565, 1.35, -0.05
31698, 0.08695652173913, 1.35, -0.05
31699, 0.1304347826087, 1.35, -0.05
31700, 0.17391304347826, 1.35, -0.05
31701, 0.21739130434783, 1.35, -0.05
31702, 0.26086956521739, 1.35, -0.05
31703, 0.30434782608696, 1.35, -0.05
31704, 0.34782608695652, 1.35, -0.05
31705, 0.39130434782609, 1.35, -0.05
31706, 0.43478260869565, 1.35, -0.05
31707, 0.47826086956522, 1.35, -0.05
31708, 0.52173913043478, 1.35, -0.05
31709, 0.56521739130435, 1.35, -0.05
31710, 0.60869565217391, 1.35, -0.05
31711, 0.65217391304348, 1.35, -0.05
31712, 0.69565217391304, 1.35, -0.05
31713, 0.73913043478261, 1.35, -0.05
31714, 0.78260869565217, 1.35, -0.05
31715, 0.82608695652174, 1.35, -0.05
31716, 0.8695652173913, 1.35, -0.05
31717, 0.91304347826087, 1.35, -0.05
31718, 0.95652173913043, 1.35, -0.05
31719, 0.043478260869565, 1.35, -0.1
31720, 0.08695652173913, 1.35, -0.1
31721, 0.1304347826087, 1.35, -0.1
31722, 0.17391304347826, 1.35, -0.1
31723, 0.21739130434783, 1.35, -0.1
31724, 0.26086956521739, 1.35, -0.1
31725, 0.30434782608696, 1.35, -0.1
31726, 0.34782608695652, 1.35, -0.1
31727, 0.39130434782609, 1.35, -0.1
31728, 0.43478260869565, 1.35, -0.1
31729, 0.47826086956522, 1.35, -0.1
31730, 0.52173913043478, 1.35, -0.1
31731, 0.56521739130435, 1.35, -0.1
31732, 0.60869565217391, 1.35, -0.1
31733, 0.65217391304348, 1.35, -0.1
31734, 0.69565217391304, 1.35, -0.1
31735, 0.73913043478261, 1.35, -0.1
31736, 0.78260869565217, 1.35, -0.1
31737, 0.82608695652174, 1.35, -0.1
31738, 0.8695652173913, 1.35, -0.1
31739, 0.91304347826087, 1.35, -0.1
31740, 0.95652173913043, 1.35, -0.1
31741, 0.043478260869565, 1.35, -0.15
31742, 0.08695652173913, 1.35, -0.15
31743, 0.1304347826087, 1.35, -0.15
31744, 0.17391304347826, 1.35, -0.15
31745, 0.21739130434783, 1.35, -0.15
31746, 0.26086956521739, 1.35, -0.15
31747, 0.30434782608696, 1.35, -0.15
31748, 0.34782608695652, 1.35, -0.15
31749, 0.39130434782609, 1.35, -0.15
31750, 0.43478260869565, 1.35, -0.15
31751, 0.47826086956522, 1.35, -0.15
31752, 0.52173913043478, 1.35, -0.15
31753, 0.56521739130435, 1.35, -0.15
31754, 0.60869565217391, 1.35, -0.15
31755, 0.65217391304348, 1.35, -0.15
31756, 0.69565217391304, 1.35, -0.15
31757, 0.73913043478261, 1.35, -0.15
31758, 0.78260869565217, 1.35, -0.15
31759, 0.82608695652174, 1.35, -0.15
31760, 0.8695652173913, 1.35, -0.15
31761, 0.91304347826087, 1.35, -0.15
31762, 0.95652173913043, 1.35, -0.15
31763, 0.043478260869565, 1.35, -0.025
31764, 0.021739130434783, 1.35, -0.05
31765, 0.08695652173913, 1.35, -0.025
31766, 0.065217391304348, 1.35, -0.05
31767, 0.1304347826087, 1.35, -0.025
31768, 0.10869565217391, 1.35, -0.05
31769, 0.17391304347826, 1.35, -0.025
31770, 0.15217391304348, 1.35, -0.05
31771, 0.21739130434783, 1.35, -0.025
31772, 0.19565217391304, 1.35, -0.05
31773, 0.26086956521739, 1.35, -0.025
31774, 0.23913043478261, 1.35, -0.05
31775, 0.30434782608696, 1.35, -0.025
31776, 0.28260869565217, 1.35, -0.05
31777, 0.34782608695652, 1.35, -0.025
31778, 0.32608695652174, 1.35, -0.05
31779, 0.39130434782609, 1.35, -0.025
31780, 0.3695652173913, 1.35, -0.05
31781, 0.43478260869565, 1.35, -0.025
31782, 0.41304347826087, 1.35, -0.05
31783, 0.47826086956522, 1.35, -0.025
31784, 0.45652173913043, 1.35, -0.05
31785, 0.52173913043478, 1.35, -0.025
31786, 0.5, 1.35, -0.05
31787, 0.56521739130435, 1.35, -0.025
31788, 0.54347826086957, 1.35, -0.05
31789, 0.60869565217391, 1.35, -0.025
31790, 0.58695652173913, 1.35, -0.05
31791, 0.65217391304348, 1.35, -0.025
31792, 0.6304347826087, 1.35, -0.05
31793, 0.69565217391304, 1.35, -0.025
31794, 0.67391304347826, 1.35, -0.05
31795, 0.73913043478261, 1.35, -0.025
31796, 0.71739130434783, 1.35, -0.05
31797, 0.78260869565217, 1.35, -0.025
31798, 0.76086956521739, 1.35, -0.05
31799, 0.82608695652174, 1.35, -0.025
31800, 0.80434782608696, 1.35, -0.05
31801, 0.8695652173913, 1.35, -0.025
31802, 0.84782608695652, 1.35, -0.05
31803, 0.91304347826087, 1.35, -0.025
31804, 0.89130434782609, 1.35, -0.05
31805, 0.95652173913043, 1.35, -0.025
31806, 0.93478260869565, 1.35, -0.05
31807, 0.97826086956522, 1.35, -0.05
31808, 0.043478260869565, 1.35, -0.075
31809, 0.021739130434783, 1.35, -0.1
31810, 0.08695652173913, 1.35, -0.075
31811, 0.065217391304348, 1.35, -0.1
31812, 0.1304347826087, 1.35, -0.075
31813, 0.10869565217391, 1.35, -0.1
31814, 0.17391304347826, 1.35, -0.075
31815, 0.15217391304348, 1.35, -0.1
31816, 0.21739130434783, 1.35, -0.075
31817, 0.19565217391304, 1.35, -0.1
31818, 0.26086956521739, 1.35, -0.075
31819, 0.23913043478261, 1.35, -0.1
31820, 0.30434782608696, 1.35, -0.075
31821, 0.28260869565217, 1.35, -0.1
31822, 0.34782608695652, 1.35, -0.075
31823, 0.32608695652174, 1.35, -0.1
31824, 0.39130434782609, 1.35, -0.075
31825, 0.3695652173913, 1.35, -0.1
31826, 0.43478260869565, 1.35, -0.075
31827, 0.41304347826087, 1.35, -0.1
31828, 0.47826086956522, 1.35, -0.075
31829, 0.45652173913043, 1.35, -0.1
31830, 0.52173913043478, 1.35, -0.075
31831, 0.5, 1.35, -0.1
31832, 0.56521739130435, 1.35, -0.075
31833, 0.54347826086957, 1.35, -0.1
31834, 0.60869565217391, 1.35, -0.075
31835, 0.58695652173913, 1.35, -0.1
31836, 0.65217391304348, 1.35, -0.075
31837, 0.6304347826087, 1.35, -0.1
31838, 0.69565217391304, 1.35, -0.075
31839, 0.67391304347826, 1.35, -0.1
31840, 0.73913043478261, 1.35, -0.075
31841, 0.71739130434783, 1.35, -0.1
31842, 0.78260869565217, 1.35, -0.075
31843, 0.76086956521739, 1.35, -0.1
31844, 0.82608695652174, 1.35, -0.075
31845, 0.80434782608696, 1.35, -0.1
31846, 0.8695652173913, 1.35, -0.075
31847, 0.84782608695652, 1.35, -0.1
31848, 0.91304347826087, 1.35, -0.075
31849, 0.89130434782609, 1.35, -0.1
31850, 0.95652173913043, 1.35, -0.075
31851, 0.93478260869565, 1.35, -0.1
31852, 0.97826086956522, 1.35, -0.1
31853, 0.043478260869565, 1.35, -0.125
31854, 0.021739130434783, 1.35, -0.15
31855, 0.08695652173913, 1.35, -0.125
31856, 0.065217391304348, 1.35, -0.15
31857, 0.1304347826087, 1.35, -0.125
31858, 0.10869565217391, 1.35, -0.15
31859, 0.17391304347826, 1.35, -0.125
31860, 0.15217391304348, 1.35, -0.15
31861, 0.21739130434783, 1.35, -0.125
31862, 0.19565217391304, 1.35, -0.15
31863, 0.26086956521739, 1.35, -0.125
31864, 0.23913043478261, 1.35, -0.15
31865, 0.30434782608696, 1.35, -0.125
31866, 0.28260869565217, 1.35, -0.15
31867, 0.34782608695652, 1.35, -0.125
31868, 0.32608695652174, 1.35, -0.15
31869, 0.39130434782609, 1.35, -0.125
31870, 0.3695652173913, 1.35, -0.15
31871, 0.43478260869565, 1.35, -0.125
31872, 0.41304347826087, 1.35, -0.15
31873, 0.47826086956522, 1.35, -0.125
31874, 0.45652173913043, 1.35, -0.15
31875, 0.52173913043478, 1.35, -0.125
31876, 0.5, 1.35, -0.15
31877, 0.56521739130435, 1.35, -0.125
31878, 0.54347826086957, 1.35, -0.15
31879, 0.60869565217391, 1.35, -0.125
31880, 0.58695652173913, 1.35, -0.15
31881, 0.65217391304348, 1.35, -0.125
31882, 0.6304347826087, 1.35, -0.15
31883, 0.69565217391304, 1.35, -0.125
31884, 0.67391304347826, 1.35, -0.15
31885, 0.73913043478261, 1.35, -0.125
31886, 0.71739130434783, 1.35, -0.15
31887, 0.78260869565217, 1.35, -0.125
31888, 0.76086956521739, 1.35, -0.15
31889, 0.82608695652174, 1.35, -0.125
31890, 0.80434782608696, 1.35, -0.15
31891, 0.8695652173913, 1.35, -0.125
31892, 0.84782608695652, 1.35, -0.15
31893, 0.91304347826087, 1.35, -0.125
31894, 0.89130434782609, 1.35, -0.15
31895, 0.95652173913043, 1.35, -0.125
31896, 0.93478260869565, 1.35, -0.15
31897, 0.97826086956522, 1.35, -0.15
31898, 0.043478260869565, 1.35, -0.175
31899, 0.08695652173913, 1.35, -0.175
31900, 0.1304347826087, 1.35, -0.175
31901, 0.17391304347826, 1.35, -0.175
31902, 0.21739130434783, 1.35, -0.175
31903, 0.26086956521739, 1.35, -0.175
31904, 0.30434782608696, 1.35, -0.175
31905, 0.34782608695652, 1.35, -0.175
31906, 0.39130434782609, 1.35, -0.175
31907, 0.43478260869565, 1.35, -0.175
31908, 0.47826086956522, 1.35, -0.175
31909, 0.52173913043478, 1.35, -0.175
31910, 0.56521739130435, 1.35, -0.175
31911, 0.60869565217391, 1.35, -0.175
31912, 0.65217391304348, 1.35, -0.175
31913, 0.69565217391304, 1.35, -0.175
31914, 0.73913043478261, 1.35, -0.175
31915, 0.78260869565217, 1.35, -0.175
31916, 0.82608695652174, 1.35, -0.175
31917, 0.8695652173913, 1.35, -0.175
31918, 0.91304347826087, 1.35, -0.175
31919, 0.95652173913043, 1.35, -0.175
31920, 0.95652173913043, 0.20217391304348, -0.2
31921, 0.91304347826087, 0.20217391304348, -0.2
31922, 0.8695652173913, 0.20217391304348, -0.2
31923, 0.82608695652174, 0.20217391304348, -0.2
31924, 0.78260869565217, 0.20217391304348, -0.2
31925, 0.73913043478261, 0.20217391304348, -0.2
31926, 0.69565217391304, 0.20217391304348, -0.2
31927, 0.65217391304348, 0.20217391304348, -0.2
31928, 0.60869565217391, 0.20217391304348, -0.2
31929, 0.56521739130435, 0.20217391304348, -0.2
31930, 0.52173913043478, 0.20217391304348, -0.2
31931, 0.47826086956522, 0.20217391304348, -0.2
31932, 0.43478260869565, 0.20217391304348, -0.2
31933, 0.39130434782609, 0.20217391304348, -0.2
31934, 0.34782608695652, 0.20217391304348, -0.2
31935, 0.30434782608696, 0.20217391304348, -0.2
31936, 0.26086956521739, 0.20217391304348, -0.2
31937, 0.21739130434783, 0.20217391304348, -0.2
31938, 0.17391304347826, 0.20217391304348, -0.2
31939, 0.1304347826087, 0.20217391304348, -0.2
31940, 0.08695652173913, 0.20217391304348, -0.2
31941, 0.043478260869565, 0.20217391304348, -0.2
31942, 0.95652173913043, 0.25434782608696, -0.2
31943, 0.91304347826087, 0.25434782608696, -0.2
31944, 0.8695652173913, 0.25434782608696, -0.2
31945, 0.82608695652174, 0.25434782608696, -0.2
31946, 0.78260869565217, 0.25434782608696, -0.2
31947, 0.73913043478261, 0.25434782608696, -0.2
31948, 0.69565217391304, 0.25434782608696, -0.2
31949, 0.65217391304348, 0.25434782608696, -0.2
31950, 0.60869565217391, 0.25434782608696, -0.2
31951, 0.56521739130435, 0.25434782608696, -0.2
31952, 0.52173913043478, 0.25434782608696, -0.2
31953, 0.47826086956522, 0.25434782608696, -0.2
31954, 0.43478260869565, 0.25434782608696, -0.2
31955, 0.39130434782609, 0.25434782608696, -0.2
31956, 0.34782608695652, 0.25434782608696, -0.2
31957, 0.30434782608696, 0.25434782608696, -0.2
31958, 0.26086956521739, 0.25434782608696, -0.2
31959, 0.21739130434783, 0.25434782608696, -0.2
31960, 0.17391304347826, 0.25434782608696, -0.2
31961, 0.1304347826087, 0.25434782608696, -0.2
31962, 0.08695652173913, 0.25434782608696, -0.2
31963, 0.043478260869565, 0.25434782608696, -0.2
31964, 0.95652173913043, 0.30652173913043, -0.2
31965, 0.91304347826087, 0.30652173913043, -0.2
31966, 0.8695652173913, 0.30652173913043, -0.2
31967, 0.82608695652174, 0.30652173913043, -0.2
31968, 0.78260869565217, 0.30652173913043, -0.2
31969, 0.73913043478261, 0.30652173913043, -0.2
31970, 0.69565217391304, 0.30652173913043, -0.2
31971, 0.65217391304348, 0.30652173913043, -0.2
31972, 0.60869565217391, 0.30652173913043, -0.2
31973, 0.56521739130435, 0.30652173913043, -0.2
31974, 0.52173913043478, 0.30652173913043, -0.2
31975, 0.47826086956522, 0.30652173913043, -0.2
31976, 0.43478260869565, 0.30652173913043, -0.2
31977, 0.39130434782609, 0.30652173913043, -0.2
31978, 0.34782608695652, 0.30652173913043, -0.2
31979, 0.30434782608696, 0.30652173913043, -0.2
31980, 0.26086956521739, 0.30652173913043, -0.2
31981, 0.21739130434783, 0.30652173913043, -0.2
31982, 0.17391304347826, 0.30652173913043, -0.2
31983, 0.1304347826087, 0.30652173913043, -0.2
31984, 0.08695652173913, 0.30652173913043, -0.2
31985, 0.043478260869565, 0.30652173913043, -0.2
31986, 0.95652173913043, 0.35869565217391, -0.2
31987, 0.91304347826087, 0.35869565217391, -0.2
31988, 0.8695652173913, 0.35869565217391, -0.2
31989, 0.82608695652174, 0.35869565217391, -0.2
31990, 0.78260869565217, 0.35869565217391, -0.2
31991, 0.73913043478261, 0.35869565217391, -0.2
31992, 0.69565217391304, 0.35869565217391, -0.2
31993, 0.65217391304348, 0.35869565217391, -0.2
31994, 0.60869565217391, 0.35869565217391, -0.2
31995, 0.56521739130435, 0.35869565217391, -0.2
31996, 0.52173913043478, 0.35869565217391, -0.2
31997, 0.47826086956522, 0.35869565217391, -0.2
31998, 0.43478260869565, 0.35869565217391, -0.2
31999, 0.39130434782609, 0.35869565217391, -0.2
32000, 0.34782608695652, 0.35869565217391, -0.2
32001, 0.30434782608696, 0.35869565217391, -0.2
32002, 0.26086956521739, 0.35869565217391, -0.2
32003, 0.21739130434783, 0.35869565217391, -0.2
32004, 0.17391304347826, 0.35869565217391, -0.2
32005, 0.1304347826087, 0.35869565217391, -0.2
32006, 0.08695652173913, 0.35869565217391, -0.2
32007, 0.043478260869565, 0.35869565217391, -0.2
32008, 0.95652173913043, 0.41086956521739, -0.2
32009, 0.91304347826087, 0.41086956521739, -0.2
32010, 0.8695652173913, 0.41086956521739, -0.2
32011, 0.82608695652174, 0.41086956521739, -0.2
32012, 0.78260869565217, 0.41086956521739, -0.2
32013, 0.73913043478261, 0.41086956521739, -0.2
32014, 0.69565217391304, 0.41086956521739, -0.2
32015, 0.65217391304348, 0.41086956521739, -0.2
32016, 0.60869565217391, 0.41086956521739, -0.2
32017, 0.56521739130435, 0.41086956521739, -0.2
32018, 0.52173913043478, 0.41086956521739, -0.2
32019, 0.47826086956522, 0.41086956521739, -0.2
32020, 0.43478260869565, 0.41086956521739, -0.2
32021, 0.39130434782609, 0.41086956521739, -0.2
32022, 0.34782608695652, 0.41086956521739, -0.2
32023, 0.30434782608696, 0.41086956521739, -0.2
32024, 0.26086956521739, 0.41086956521739, -0.2
32025, 0.21739130434783, 0.41086956521739, -0.2
32026, 0.17391304347826, 0.41086956521739, -0.2
32027, 0.1304347826087, 0.41086956521739, -0.2
32028, 0.08695652173913, 0.41086956521739, -0.2
32029, 0.043478260869565, 0.41086956521739, -0.2
32030, 0.95652173913043, 0.46304347826087, -0.2
32031, 0.91304347826087, 0.46304347826087, -0.2
32032, 0.8695652173913, 0.46304347826087, -0.2
32033, 0.82608695652174, 0.46304347826087, -0.2
32034, 0.78260869565217, 0.46304347826087, -0.2
32035, 0.73913043478261, 0.46304347826087, -0.2
32036, 0.69565217391304, 0.46304347826087, -0.2
32037, 0.65217391304348, 0.46304347826087, -0.2
32038, 0.60869565217391, 0.46304347826087, -0.2
32039, 0.56521739130435, 0.46304347826087, -0.2
32040, 0.52173913043478, 0.46304347826087, -0.2
32041, 0.47826086956522, 0.46304347826087, -0.2
32042, 0.43478260869565, 0.46304347826087, -0.2
32043, 0.39130434782609, 0.46304347826087, -0.2
32044, 0.34782608695652, 0.46304347826087, -0.2
32045, 0.30434782608696, 0.46304347826087, -0.2
32046, 0.26086956521739, 0.46304347826087, -0.2
32047, 0.21739130434783, 0.46304347826087, -0.2
32048, 0.17391304347826, 0.46304347826087, -0.2
32049, 0.1304347826087, 0.46304347826087, -0.2
32050, 0.08695652173913, 0.46304347826087, -0.2
32051, 0.043478260869565, 0.46304347826087, -0.2
32052, 0.95652173913043, 0.51521739130435, -0.2
32053, 0.91304347826087, 0.51521739130435, -0.2
32054, 0.8695652173913, 0.51521739130435, -0.2
32055, 0.82608695652174, 0.51521739130435, -0.2
32056, 0.78260869565217, 0.51521739130435, -0.2
32057, 0.73913043478261, 0.51521739130435, -0.2
32058, 0.69565217391304, 0.51521739130435, -0.2
32059, 0.65217391304348, 0.51521739130435, -0.2
32060, 0.60869565217391, 0.51521739130435, -0.2
32061, 0.56521739130435, 0.51521739130435, -0.2
32062, 0.52173913043478, 0.51521739130435, -0.2
32063, 0.47826086956522, 0.51521739130435, -0.2
32064, 0.43478260869565, 0.51521739130435, -0.2
32065, 0.39130434782609, 0.51521739130435, -0.2
32066, 0.34782608695652, 0.51521739130435, -0.2
32067, 0.30434782608696, 0.51521739130435, -0.2
32068, 0.26086956521739, 0.51521739130435, -0.2
32069, 0.21739130434783, 0.51521739130435, -0.2
32070, 0.17391304347826, 0.51521739130435, -0.2
32071, 0.1304347826087, 0.51521739130435, -0.2
32072, 0.08695652173913, 0.51521739130435, -0.2
32073, 0.043478260869565, 0.51521739130435, -0.2
32074, 0.95652173913043, 0.56739130434783, -0.2
32075, 0.91304347826087, 0.56739130434783, -0.2
32076, 0.8695652173913, 0.56739130434783, -0.2
32077, 0.82608695652174, 0.56739130434783, -0.2
32078, 0.78260869565217, 0.56739130434783, -0.2
32079, 0.73913043478261, 0.56739130434783, -0.2
32080, 0.69565217391304, 0.56739130434783, -0.2
32081, 0.65217391304348, 0.56739130434783, -0.2
32082, 0.60869565217391, 0.56739130434783, -0.2
32083, 0.56521739130435, 0.56739130434783, -0.2
32084, 0.52173913043478, 0.56739130434783, -0.2
32085, 0.47826086956522, 0.56739130434783, -0.2
32086, 0.43478260869565, 0.56739130434783, -0.2
32087, 0.39130434782609, 0.56739130434783, -0.2
32088, 0.34782608695652, 0.56739130434783, -0.2
32089, 0.30434782608696, 0.56739130434783, -0.2
32090, 0.26086956521739, 0.56739130434783, -0.2
32091, 0.21739130434783, 0.56739130434783, -0.2
32092, 0.17391304347826, 0.56739130434783, -0.2
32093, 0.1304347826087, 0.56739130434783, -0.2
32094, 0.08695652173913, 0.56739130434783, -0.2
32095, 0.043478260869565, 0.56739130434783, -0.2
32096, 0.95652173913043, 0.6195652173913, -0.2
32097, 0.91304347826087, 0.6195652173913, -0.2
32098, 0.8695652173913, 0.6195652173913, -0.2
32099, 0.82608695652174, 0.6195652173913, -0.2
32100, 0.78260869565217, 0.6195652173913, -0.2
32101, 0.73913043478261, 0.6195652173913, -0.2
32102, 0.69565217391304, 0.6195652173913, -0.2
32103, 0.65217391304348, 0.6195652173913, -0.2
32104, 0.60869565217391, 0.6195652173913, -0.2
32105, 0.56521739130435, 0.6195652173913, -0.2
32106, 0.52173913043478, 0.6195652173913, -0.2
32107, 0.47826086956522, 0.6195652173913, -0.2
32108, 0.43478260869565, 0.6195652173913, -0.2
32109, 0.39130434782609, 0.6195652173913, -0.2
32110, 0.34782608695652, 0.6195652173913, -0.2
32111, 0.30434782608696, 0.6195652173913, -0.2
32112, 0.26086956521739, 0.6195652173913, -0.2
32113, 0.21739130434783, 0.6195652173913, -0.2
32114, 0.17391304347826, 0.6195652173913, -0.2
32115, 0.1304347826087, 0.6195652173913, -0.2
32116, 0.08695652173913, 0.6195652173913, -0.2
32117, 0.043478260869565, 0.6195652173913, -0.2
32118, 0.95652173913043, 0.67173913043478, -0.2
32119, 0.91304347826087, 0.67173913043478, -0.2
32120, 0.8695652173913, 0.67173913043478, -0.2
32121, 0.82608695652174, 0.67173913043478, -0.2
32122, 0.78260869565217, 0.67173913043478, -0.2
32123, 0.73913043478261, 0.67173913043478, -0.2
32124, 0.69565217391304, 0.67173913043478, -0.2
32125, 0.65217391304348, 0.67173913043478, -0.2
32126, 0.60869565217391, 0.67173913043478, -0.2
32127, 0.56521739130435, 0.67173913043478, -0.2
32128, 0.52173913043478, 0.67173913043478, -0.2
32129, 0.47826086956522, 0.67173913043478, -0.2
32130, 0.43478260869565, 0.67173913043478, -0.2
32131, 0.39130434782609, 0.67173913043478, -0.2
32132, 0.34782608695652, 0.67173913043478, -0.2
32133, 0.30434782608696, 0.67173913043478, -0.2
32134, 0.26086956521739, 0.67173913043478, -0.2
32135, 0.21739130434783, 0.67173913043478, -0.2
32136, 0.17391304347826, 0.67173913043478, -0.2
32137, 0.1304347826087, 0.67173913043478, -0.2
32138, 0.08695652173913, 0.67173913043478, -0.2
32139, 0.043478260869565, 0.67173913043478, -0.2
32140, 0.95652173913043, 0.72391304347826, -0.2
32141, 0.91304347826087, 0.72391304347826, -0.2
32142, 0.8695652173913, 0.72391304347826, -0.2
32143, 0.82608695652174, 0.72391304347826, -0.2
32144, 0.78260869565217, 0.72391304347826, -0.2
32145, 0.73913043478261, 0.72391304347826, -0.2
32146, 0.69565217391304, 0.72391304347826, -0.2
32147, 0.65217391304348, 0.72391304347826, -0.2
32148, 0.60869565217391, 0.72391304347826, -0.2
32149, 0.56521739130435, 0.72391304347826, -0.2
32150, 0.52173913043478, 0.72391304347826, -0.2
32151, 0.47826086956522, 0.72391304347826, -0.2
32152, 0.43478260869565, 0.72391304347826, -0.2
32153, 0.39130434782609, 0.72391304347826, -0.2
32154, 0.34782608695652, 0.72391304347826, -0.2
32155, 0.30434782608696, 0.72391304347826, -0.2
32156, 0.26086956521739, 0.72391304347826, -0.2
32157, 0.21739130434783, 0.72391304347826, -0.2
32158, 0.17391304347826, 0.72391304347826, -0.2
32159, 0.1304347826087, 0.72391304347826, -0.2
32160, 0.08695652173913, 0.72391304347826, -0.2
32161, 0.043478260869565, 0.72391304347826, -0.2
32162, 0.95652173913043, 0.77608695652174, -0.2
32163, 0.91304347826087, 0.77608695652174, -0.2
32164, 0.8695652173913, 0.77608695652174, -0.2
32165, 0.82608695652174, 0.77608695652174, -0.2
32166, 0.78260869565217, 0.77608695652174, -0.2
32167, 0.73913043478261, 0.77608695652174, -0.2
32168, 0.69565217391304, 0.77608695652174, -0.2
32169, 0.65217391304348, 0.77608695652174, -0.2
32170, 0.60869565217391, 0.77608695652174, -0.2
32171, 0.56521739130435, 0.77608695652174, -0.2
32172, 0.52173913043478, 0.77608695652174, -0.2
32173, 0.47826086956522, 0.77608695652174, -0.2
32174, 0.43478260869565, 0.77608695652174, -0.2
32175, 0.39130434782609, 0.77608695652174, -0.2
32176, 0.34782608695652, 0.77608695652174, -0.2
32177, 0.30434782608696, 0.77608695652174, -0.2
32178, 0.26086956521739, 0.77608695652174, -0.2
32179, 0.21739130434783, 0.77608695652174, -0.2
32180, 0.17391304347826, 0.77608695652174, -0.2
32181, 0.1304347826087, 0.77608695652174, -0.2
32182, 0.08695652173913, 0.77608695652174, -0.2
32183, 0.043478260869565, 0.77608695652174, -0.2
32184, 0.95652173913043, 0.82826086956522, -0.2
32185, 0.91304347826087, 0.82826086956522, -0.2
32186, 0.8695652173913, 0.82826086956522, -0.2
32187, 0.82608695652174, 0.82826086956522, -0.2
32188, 0.78260869565217, 0.82826086956522, -0.2
32189, 0.73913043478261, 0.82826086956522, -0.2
32190, 0.69565217391304, 0.82826086956522, -0.2
32191, 0.65217391304348, 0.82826086956522, -0.2
32192, 0.60869565217391, 0.82826086956522, -0.2
32193, 0.56521739130435, 0.82826086956522, -0.2
32194, 0.52173913043478, 0.82826086956522, -0.2
32195, 0.47826086956522, 0.82826086956522, -0.2
32196, 0.43478260869565, 0.82826086956522, -0.2
32197, 0.39130434782609, 0.82826086956522, -0.2
32198, 0.34782608695652, 0.82826086956522, -0.2
32199, 0.30434782608696, 0.82826086956522, -0.2
32200, 0.26086956521739, 0.82826086956522, -0.2
32201, 0.21739130434783, 0.82826086956522, -0.2
32202, 0.17391304347826, 0.82826086956522, -0.2
32203, 0.1304347826087, 0.82826086956522, -0.2
32204, 0.08695652173913, 0.82826086956522, -0.2
32205, 0.043478260869565, 0.82826086956522, -0.2
32206, 0.95652173913043, 0.8804347826087, -0.2
32207, 0.91304347826087, 0.8804347826087, -0.2
32208, 0.8695652173913, 0.88043478260869, -0.2
32209, 0.82608695652174, 0.8804347826087, -0.2
32210, 0.78260869565217, 0.8804347826087, -0.2
32211, 0.73913043478261, 0.8804347826087, -0.2
32212, 0.69565217391304, 0.8804347826087, -0.2
32213, 0.65217391304348, 0.8804347826087, -0.2
32214, 0.60869565217391, 0.8804347826087, -0.2
32215, 0.56521739130435, 0.8804347826087, -0.2
32216, 0.52173913043478, 0.88043478260869, -0.2
32217, 0.47826086956522, 0.8804347826087, -0.2
32218, 0.43478260869565, 0.8804347826087, -0.2
32219, 0.39130434782609, 0.88043478260869, -0.2
32220, 0.34782608695652, 0.8804347826087, -0.2
32221, 0.30434782608696, 0.8804347826087, -0.2
32222, 0.26086956521739, 0.8804347826087, -0.2
32223, 0.21739130434783, 0.8804347826087, -0.2
32224, 0.17391304347826, 0.8804347826087, -0.2
32225, 0.1304347826087, 0.8804347826087, -0.2
32226, 0.08695652173913, 0.8804347826087, -0.2
32227, 0.043478260869565, 0.8804347826087, -0.2
32228, 0.95652173913043, 0.93260869565217, -0.2
32229, 0.91304347826087, 0.93260869565217, -0.2
32230, 0.8695652173913, 0.93260869565217, -0.2
32231, 0.82608695652174, 0.93260869565217, -0.2
32232, 0.78260869565217, 0.93260869565217, -0.2
32233, 0.73913043478261, 0.93260869565217, -0.2
32234, 0.69565217391304, 0.93260869565217, -0.2
32235, 0.65217391304348, 0.93260869565217, -0.2
32236, 0.60869565217391, 0.93260869565217, -0.2
32237, 0.56521739130435, 0.93260869565217, -0.2
32238, 0.52173913043478, 0.93260869565217, -0.2
32239, 0.47826086956522, 0.93260869565217, -0.2
32240, 0.43478260869565, 0.93260869565217, -0.2
32241, 0.39130434782609, 0.93260869565217, -0.2
32242, 0.34782608695652, 0.93260869565217, -0.2
32243, 0.30434782608696, 0.93260869565217, -0.2
32244, 0.26086956521739, 0.93260869565217, -0.2
32245, 0.21739130434783, 0.93260869565217, -0.2
32246, 0.17391304347826, 0.93260869565217, -0.2
32247, 0.1304347826087, 0.93260869565217, -0.2
32248, 0.08695652173913, 0.93260869565217, -0.2
32249, 0.043478260869565, 0.93260869565217, -0.2
32250, 0.95652173913043, 0.98478260869565, -0.2
32251, 0.91304347826087, 0.98478260869565, -0.2
32252, 0.8695652173913, 0.98478260869565, -0.2
32253, 0.82608695652174, 0.98478260869565, -0.2
32254, 0.78260869565217, 0.98478260869565, -0.2
32255, 0.73913043478261, 0.98478260869565, -0.2
32256, 0.69565217391304, 0.98478260869565, -0.2
32257, 0.65217391304348, 0.98478260869565, -0.2
32258, 0.60869565217391, 0.98478260869565, -0.2
32259, 0.56521739130435, 0.98478260869565, -0.2
32260, 0.52173913043478, 0.98478260869565, -0.2
32261, 0.47826086956522, 0.98478260869565, -0.2
32262, 0.43478260869565, 0.98478260869565, -0.2
32263, 0.39130434782609, 0.98478260869565, -0.2
32264, 0.34782608695652, 0.98478260869565, -0.2
32265, 0.30434782608696, 0.98478260869565, -0.2
32266, 0.26086956521739, 0.98478260869565, -0.2
32267, 0.21739130434783, 0.98478260869565, -0.2
32268, 0.17391304347826, 0.98478260869565, -0.2
32269, 0.1304347826087, 0.98478260869565, -0.2
32270, 0.08695652173913, 0.98478260869565, -0.2
32271, 0.043478260869565, 0.98478260869565, -0.2
32272, 0.95652173913043, 1.0369565217391, -0.2
32273, 0.91304347826087, 1.0369565217391, -0.2
32274, 0.8695652173913, 1.0369565217391, -0.2
32275, 0.82608695652174, 1.0369565217391, -0.2
32276, 0.78260869565217, 1.0369565217391, -0.2
32277, 0.73913043478261, 1.0369565217391, -0.2
32278, 0.69565217391304, 1.0369565217391, -0.2
32279, 0.65217391304348, 1.0369565217391, -0.2
32280, 0.60869565217391, 1.0369565217391, -0.2
32281, 0.56521739130435, 1.0369565217391, -0.2
32282, 0.52173913043478, 1.0369565217391, -0.2
32283, 0.47826086956522, 1.0369565217391, -0.2
32284, 0.43478260869565, 1.0369565217391, -0.2
32285, 0.39130434782609, 1.0369565217391, -0.2
32286, 0.34782608695652, 1.0369565217391, -0.2
32287, 0.30434782608696, 1.0369565217391, -0.2
32288, 0.26086956521739, 1.0369565217391, -0.2
32289, 0.21739130434783, 1.0369565217391, -0.2
32290, 0.17391304347826, 1.0369565217391, -0.2
32291, 0.1304347826087, 1.0369565217391, -0.2
32292, 0.08695652173913, 1.0369565217391, -0.2
32293, 0.043478260869565, 1.0369565217391, -0.2
32294, 0.95652173913043, 1.0891304347826, -0.2
32295, 0.91304347826087, 1.0891304347826, -0.2
32296, 0.8695652173913, 1.0891304347826, -0.2
32297, 0.82608695652174, 1.0891304347826, -0.2
32298, 0.78260869565217, 1.0891304347826, -0.2
32299, 0.73913043478261, 1.0891304347826, -0.2
32300, 0.69565217391304, 1.0891304347826, -0.2
32301, 0.65217391304348, 1.0891304347826, -0.2
32302, 0.60869565217391, 1.0891304347826, -0.2
32303, 0.56521739130435, 1.0891304347826, -0.2
32304, 0.52173913043478, 1.0891304347826, -0.2
32305, 0.47826086956522, 1.0891304347826, -0.2
32306, 0.43478260869565, 1.0891304347826, -0.2
32307, 0.39130434782609, 1.0891304347826, -0.2
32308, 0.34782608695652, 1.0891304347826, -0.2
32309, 0.30434782608696, 1.0891304347826, -0.2
32310, 0.26086956521739, 1.0891304347826, -0.2
32311, 0.21739130434783, 1.0891304347826, -0.2
32312, 0.17391304347826, 1.0891304347826, -0.2
32313, 0.1304347826087, 1.0891304347826, -0.2
32314, 0.08695652173913, 1.0891304347826, -0.2
32315, 0.043478260869565, 1.0891304347826, -0.2
32316, 0.95652173913043, 1.1413043478261, -0.2
32317, 0.91304347826087, 1.1413043478261, -0.2
32318, 0.8695652173913, 1.1413043478261, -0.2
32319, 0.82608695652174, 1.1413043478261, -0.2
32320, 0.78260869565217, 1.1413043478261, -0.2
32321, 0.73913043478261, 1.1413043478261, -0.2
32322, 0.69565217391304, 1.1413043478261, -0.2
32323, 0.65217391304348, 1.1413043478261, -0.2
32324, 0.60869565217391, 1.1413043478261, -0.2
32325, 0.56521739130435, 1.1413043478261, -0.2
32326, 0.52173913043478, 1.1413043478261, -0.2
32327, 0.47826086956522, 1.1413043478261, -0.2
32328, 0.43478260869565, 1.1413043478261, -0.2
32329, 0.39130434782609, 1.1413043478261, -0.2
32330, 0.34782608695652, 1.1413043478261, -0.2
32331, 0.30434782608696, 1.1413043478261, -0.2
32332, 0.26086956521739, 1.1413043478261, -0.2
32333, 0.21739130434783, 1.1413043478261, -0.2
32334, 0.17391304347826, 1.1413043478261, -0.2
32335, 0.1304347826087, 1.1413043478261, -0.2
32336, 0.08695652173913, 1.1413043478261, -0.2
32337, 0.043478260869565, 1.1413043478261, -0.2
32338, 0.95652173913043, 1.1934782608696, -0.2
32339, 0.91304347826087, 1.1934782608696, -0.2
32340, 0.8695652173913, 1.1934782608696, -0.2
32341, 0.82608695652174, 1.1934782608696, -0.2
32342, 0.78260869565217, 1.1934782608696, -0.2
32343, 0.73913043478261, 1.1934782608696, -0.2
32344, 0.69565217391304, 1.1934782608696, -0.2
32345, 0.65217391304348, 1.1934782608696, -0.2
32346, 0.60869565217391, 1.1934782608696, -0.2
32347, 0.56521739130435, 1.1934782608696, -0.2
32348, 0.52173913043478, 1.1934782608696, -0.2
32349, 0.47826086956522, 1.1934782608696, -0.2
32350, 0.43478260869565, 1.1934782608696, -0.2
32351, 0.39130434782609, 1.1934782608696, -0.2
32352, 0.34782608695652, 1.1934782608696, -0.2
32353, 0.30434782608696, 1.1934782608696, -0.2
32354, 0.26086956521739, 1.1934782608696, -0.2
32355, 0.21739130434783, 1.1934782608696, -0.2
32356, 0.17391304347826, 1.1934782608696, -0.2
32357, 0.1304347826087, 1.1934782608696, -0.2
32358, 0.08695652173913, 1.1934782608696, -0.2
32359, 0.043478260869565, 1.1934782608696, -0.2
32360, 0.95652173913043, 1.245652173913, -0.2
32361, 0.91304347826087, 1.245652173913, -0.2
32362, 0.8695652173913, 1.245652173913, -0.2
32363, 0.82608695652174, 1.245652173913, -0.2
32364, 0.78260869565217, 1.245652173913, -0.2
32365, 0.73913043478261, 1.245652173913, -0.2
32366, 0.69565217391304, 1.245652173913, -0.2
32367, 0.65217391304348, 1.245652173913, -0.2
32368, 0.60869565217391, 1.245652173913, -0.2
32369, 0.56521739130435, 1.245652173913, -0.2
32370, 0.52173913043478, 1.245652173913, -0.2
32371, 0.47826086956522, 1.245652173913, -0.2
32372, 0.43478260869565, 1.245652173913, -0.2
32373, 0.39130434782609, 1.245652173913, -0.2
32374, 0.34782608695652, 1.245652173913, -0.2
32375, 0.30434782608696, 1.245652173913, -0.2
32376, 0.26086956521739, 1.245652173913, -0.2
32377, 0.21739130434783, 1.245652173913, -0.2
32378, 0.17391304347826, 1.245652173913, -0.2
32379, 0.1304347826087, 1.245652173913, -0.2
32380, 0.08695652173913, 1.245652173913, -0.2
32381, 0.043478260869565, 1.245652173913, -0.2
32382, 0.95652173913043, 1.2978260869565, -0.2
32383, 0.91304347826087, 1.2978260869565, -0.2
32384, 0.8695652173913, 1.2978260869565, -0.2
32385, 0.82608695652174, 1.2978260869565, -0.2
32386, 0.78260869565217, 1.2978260869565, -0.2
32387, 0.73913043478261, 1.2978260869565, -0.2
32388, 0.69565217391304, 1.2978260869565, -0.2
32389, 0.65217391304348, 1.2978260869565, -0.2
32390, 0.60869565217391, 1.2978260869565, -0.2
32391, 0.56521739130435, 1.2978260869565, -0.2
32392, 0.52173913043478, 1.2978260869565, -0.2
32393, 0.47826086956522, 1.2978260869565, -0.2
32394, 0.43478260869565, 1.2978260869565, -0.2
32395, 0.39130434782609, 1.2978260869565, -0.2
32396, 0.34782608695652, 1.2978260869565, -0.2
32397, 0.30434782608696, 1.2978260869565, -0.2
32398, 0.26086956521739, 1.2978260869565, -0.2
32399, 0.21739130434783, 1.2978260869565, -0.2
32400, 0.17391304347826, 1.2978260869565, -0.2
32401, 0.1304347826087, 1.2978260869565, -0.2
32402, 0.08695652173913, 1.2978260869565, -0.2
32403, 0.043478260869565, 1.2978260869565, -0.2
32404, 0.95652173913043, 0.17608695652174, -0.2
32405, 0.97826086956522, 0.20217391304348, -0.2
32406, 0.91304347826087, 0.17608695652174, -0.2
32407, 0.93478260869565, 0.20217391304348, -0.2
32408, 0.8695652173913, 0.17608695652174, -0.2
32409, 0.89130434782609, 0.20217391304348, -0.2
32410, 0.82608695652174, 0.17608695652174, -0.2
32411, 0.84782608695652, 0.20217391304348, -0.2
32412, 0.78260869565217, 0.17608695652174, -0.2
32413, 0.80434782608696, 0.20217391304348, -0.2
32414, 0.73913043478261, 0.17608695652174, -0.2
32415, 0.76086956521739, 0.20217391304348, -0.2
32416, 0.69565217391304, 0.17608695652174, -0.2
32417, 0.71739130434783, 0.20217391304348, -0.2
32418, 0.65217391304348, 0.17608695652174, -0.2
32419, 0.67391304347826, 0.20217391304348, -0.2
32420, 0.60869565217391, 0.17608695652174, -0.2
32421, 0.6304347826087, 0.20217391304348, -0.2
32422, 0.56521739130435, 0.17608695652174, -0.2
32423, 0.58695652173913, 0.20217391304348, -0.2
32424, 0.52173913043478, 0.17608695652174, -0.2
32425, 0.54347826086957, 0.20217391304348, -0.2
32426, 0.47826086956522, 0.17608695652174, -0.2
32427, 0.5, 0.20217391304348, -0.2
32428, 0.43478260869565, 0.17608695652174, -0.2
32429, 0.45652173913043, 0.20217391304348, -0.2
32430, 0.39130434782609, 0.17608695652174, -0.2
32431, 0.41304347826087, 0.20217391304348, -0.2
32432, 0.34782608695652, 0.17608695652174, -0.2
32433, 0.3695652173913, 0.20217391304348, -0.2
32434, 0.30434782608696, 0.17608695652174, -0.2
32435, 0.32608695652174, 0.20217391304348, -0.2
32436, 0.26086956521739, 0.17608695652174, -0.2
32437, 0.28260869565217, 0.20217391304348, -0.2
32438, 0.21739130434783, 0.17608695652174, -0.2
32439, 0.23913043478261, 0.20217391304348, -0.2
32440, 0.17391304347826, 0.17608695652174, -0.2
32441, 0.19565217391304, 0.20217391304348, -0.2
32442, 0.1304347826087, 0.17608695652174, -0.2
32443, 0.15217391304348, 0.20217391304348, -0.2
32444, 0.08695652173913, 0.17608695652174, -0.2
32445, 0.10869565217391, 0.20217391304348, -0.2
32446, 0.043478260869565, 0.17608695652174, -0.2
32447, 0.065217391304348, 0.20217391304348, -0.2
32448, 0.021739130434783, 0.20217391304348, -0.2
32449, 0.95652173913043, 0.22826086956522, -0.2
32450, 0.97826086956522, 0.25434782608696, -0.2
32451, 0.91304347826087, 0.22826086956522, -0.2
32452, 0.93478260869565, 0.25434782608696, -0.2
32453, 0.8695652173913, 0.22826086956522, -0.2
32454, 0.89130434782609, 0.25434782608696, -0.2
32455, 0.82608695652174, 0.22826086956522, -0.2
32456, 0.84782608695652, 0.25434782608696, -0.2
32457, 0.78260869565217, 0.22826086956522, -0.2
32458, 0.80434782608696, 0.25434782608696, -0.2
32459, 0.73913043478261, 0.22826086956522, -0.2
32460, 0.76086956521739, 0.25434782608696, -0.2
32461, 0.69565217391304, 0.22826086956522, -0.2
32462, 0.71739130434783, 0.25434782608696, -0.2
32463, 0.65217391304348, 0.22826086956522, -0.2
32464, 0.67391304347826, 0.25434782608696, -0.2
32465, 0.60869565217391, 0.22826086956522, -0.2
32466, 0.6304347826087, 0.25434782608696, -0.2
32467, 0.56521739130435, 0.22826086956522, -0.2
32468, 0.58695652173913, 0.25434782608696, -0.2
32469, 0.52173913043478, 0.22826086956522, -0.2
32470, 0.54347826086957, 0.25434782608696, -0.2
32471, 0.47826086956522, 0.22826086956522, -0.2
32472, 0.5, 0.25434782608696, -0.2
32473, 0.43478260869565, 0.22826086956522, -0.2
32474, 0.45652173913043, 0.25434782608696, -0.2
32475, 0.39130434782609, 0.22826086956522, -0.2
32476, 0.41304347826087, 0.25434782608696, -0.2
32477, 0.34782608695652, 0.22826086956522, -0.2
32478, 0.3695652173913, 0.25434782608696, -0.2
32479, 0.30434782608696, 0.22826086956522, -0.2
32480, 0.32608695652174, 0.25434782608696, -0.2
32481, 0.26086956521739, 0.22826086956522, -0.2
32482, 0.28260869565217, 0.25434782608696, -0.2
32483, 0.21739130434783, 0.22826086956522, -0.2
32484, 0.23913043478261, 0.25434782608696, -0.2
32485, 0.17391304347826, 0.22826086956522, -0.2
32486, 0.19565217391304, 0.25434782608696, -0.2
32487, 0.1304347826087, 0.22826086956522, -0.2
32488, 0.15217391304348, 0.25434782608696, -0.2
32489, 0.08695652173913, 0.22826086956522, -0.2
32490, 0.10869565217391, 0.25434782608696, -0.2
32491, 0.043478260869565, 0.22826086956522, -0.2
32492, 0.065217391304348, 0.25434782608696, -0.2
32493, 0.021739130434783, 0.25434782608696, -0.2
32494, 0.95652173913043, 0.2804347826087, -0.2
32495, 0.97826086956522, 0.30652173913043, -0.2
32496, 0.91304347826087, 0.2804347826087, -0.2
32497, 0.93478260869565, 0.30652173913043, -0.2
32498, 0.8695652173913, 0.2804347826087, -0.2
32499, 0.89130434782609, 0.30652173913043, -0.2
32500, 0.82608695652174, 0.2804347826087, -0.2
32501, 0.84782608695652, 0.30652173913043, -0.2
32502, 0.78260869565217, 0.2804347826087, -0.2
32503, 0.80434782608696, 0.30652173913043, -0.2
32504, 0.73913043478261, 0.2804347826087, -0.2
32505, 0.76086956521739, 0.30652173913043, -0.2
32506, 0.69565217391304, 0.2804347826087, -0.2
32507, 0.71739130434783, 0.30652173913043, -0.2
32508, 0.65217391304348, 0.2804347826087, -0.2
32509, 0.67391304347826, 0.30652173913043, -0.2
32510, 0.60869565217391, 0.2804347826087, -0.2
32511, 0.6304347826087, 0.30652173913043, -0.2
32512, 0.56521739130435, 0.2804347826087, -0.2
32513, 0.58695652173913, 0.30652173913043, -0.2
32514, 0.52173913043478, 0.2804347826087, -0.2
32515, 0.54347826086957, 0.30652173913043, -0.2
32516, 0.47826086956522, 0.2804347826087, -0.2
32517, 0.5, 0.30652173913043, -0.2
32518, 0.43478260869565, 0.2804347826087, -0.2
32519, 0.45652173913043, 0.30652173913043, -0.2
32520, 0.39130434782609, 0.2804347826087, -0.2
32521, 0.41304347826087, 0.30652173913043, -0.2
32522, 0.34782608695652, 0.2804347826087, -0.2
32523, 0.3695652173913, 0.30652173913043, -0.2
32524, 0.30434782608696, 0.2804347826087, -0.2
32525, 0.32608695652174, 0.30652173913043, -0.2
32526, 0.26086956521739, 0.2804347826087, -0.2
32527, 0.28260869565217, 0.30652173913043, -0.2
32528, 0.21739130434783, 0.2804347826087, -0.2
32529, 0.23913043478261, 0.30652173913043, -0.2
32530, 0.17391304347826, 0.2804347826087, -0.2
32531, 0.19565217391304, 0.30652173913043, -0.2
32532, 0.1304347826087, 0.2804347826087, -0.2
32533, 0.15217391304348, 0.30652173913043, -0.2
32534, 0.08695652173913, 0.2804347826087, -0.2
32535, 0.10869565217391, 0.30652173913043, -0.2
32536, 0.043478260869565, 0.2804347826087, -0.2
32537, 0.065217391304348, 0.30652173913043, -0.2
32538, 0.021739130434783, 0.30652173913043, -0.2
32539, 0.95652173913043, 0.33260869565217, -0.2
32540, 0.97826086956522, 0.35869565217391, -0.2
32541, 0.91304347826087, 0.33260869565217, -0.2
32542, 0.93478260869565, 0.35869565217391, -0.2
32543, 0.8695652173913, 0.33260869565217, -0.2
32544, 0.89130434782609, 0.35869565217391, -0.2
32545, 0.82608695652174, 0.33260869565217, -0.2
32546, 0.84782608695652, 0.35869565217391, -0.2
32547, 0.78260869565217, 0.33260869565217, -0.2
32548, 0.80434782608696, 0.35869565217391, -0.2
32549, 0.73913043478261, 0.33260869565217, -0.2
32550, 0.76086956521739, 0.35869565217391, -0.2
32551, 0.69565217391304, 0.33260869565217, -0.2
32552, 0.71739130434783, 0.35869565217391, -0.2
32553, 0.65217391304348, 0.33260869565217, -0.2
32554, 0.67391304347826, 0.35869565217391, -0.2
32555, 0.60869565217391, 0.33260869565217, -0.2
32556, 0.6304347826087, 0.35869565217391, -0.2
32557, 0.56521739130435, 0.33260869565217, -0.2
32558, 0.58695652173913, 0.35869565217391, -0.2
32559, 0.52173913043478, 0.33260869565217, -0.2
32560, 0.54347826086957, 0.35869565217391, -0.2
32561, 0.47826086956522, 0.33260869565217, -0.2
32562, 0.5, 0.35869565217391, -0.2
32563, 0.43478260869565, 0.33260869565217, -0.2
32564, 0.45652173913043, 0.35869565217391, -0.2
32565, 0.39130434782609, 0.33260869565217, -0.2
32566, 0.41304347826087, 0.35869565217391, -0.2
32567, 0.34782608695652, 0.33260869565217, -0.2
32568, 0.3695652173913, 0.35869565217391, -0.2
32569, 0.30434782608696, 0.33260869565217, -0.2
32570, 0.32608695652174, 0.35869565217391, -0.2
32571, 0.26086956521739, 0.33260869565217, -0.2
32572, 0.28260869565217, 0.35869565217391, -0.2
32573, 0.21739130434783, 0.33260869565217, -0.2
32574, 0.23913043478261, 0.35869565217391, -0.2
32575, 0.17391304347826, 0.33260869565217, -0.2
32576, 0.19565217391304, 0.35869565217391, -0.2
32577, 0.1304347826087, 0.33260869565217, -0.2
32578, 0.15217391304348, 0.35869565217391, -0.2
32579, 0.08695652173913, 0.33260869565217, -0.2
32580, 0.10869565217391, 0.35869565217391, -0.2
32581, 0.043478260869565, 0.33260869565217, -0.2
32582, 0.065217391304348, 0.35869565217391, -0.2
32583, 0.021739130434783, 0.35869565217391, -0.2
32584, 0.95652173913043, 0.38478260869565, -0.2
32585, 0.97826086956522, 0.41086956521739, -0.2
32586, 0.91304347826087, 0.38478260869565, -0.2
32587, 0.93478260869565, 0.41086956521739, -0.2
32588, 0.8695652173913, 0.38478260869565, -0.2
32589, 0.89130434782609, 0.41086956521739, -0.2
32590, 0.82608695652174, 0.38478260869565, -0.2
32591, 0.84782608695652, 0.41086956521739, -0.2
32592, 0.78260869565217, 0.38478260869565, -0.2
32593, 0.80434782608696, 0.41086956521739, -0.2
32594, 0.73913043478261, 0.38478260869565, -0.2
32595, 0.76086956521739, 0.41086956521739, -0.2
32596, 0.69565217391304, 0.38478260869565, -0.2
32597, 0.71739130434783, 0.41086956521739, -0.2
32598, 0.65217391304348, 0.38478260869565, -0.2
32599, 0.67391304347826, 0.41086956521739, -0.2
32600, 0.60869565217391, 0.38478260869565, -0.2
32601, 0.6304347826087, 0.41086956521739, -0.2
32602, 0.56521739130435, 0.38478260869565, -0.2
32603, 0.58695652173913, 0.41086956521739, -0.2
32604, 0.52173913043478, 0.38478260869565, -0.2
32605, 0.54347826086957, 0.41086956521739, -0.2
32606, 0.47826086956522, 0.38478260869565, -0.2
32607, 0.5, 0.41086956521739, -0.2
32608, 0.43478260869565, 0.38478260869565, -0.2
32609, 0.45652173913043, 0.41086956521739, -0.2
32610, 0.39130434782609, 0.38478260869565, -0.2
32611, 0.41304347826087, 0.41086956521739, -0.2
32612, 0.34782608695652, 0.38478260869565, -0.2
32613, 0.3695652173913, 0.41086956521739, -0.2
32614, 0.30434782608696, 0.38478260869565, -0.2
32615, 0.32608695652174, 0.41086956521739, -0.2
32616, 0.26086956521739, 0.38478260869565, -0.2
32617, 0.28260869565217, 0.41086956521739, -0.2
32618, 0.21739130434783, 0.38478260869565, -0.2
32619, 0.23913043478261, 0.41086956521739, -0.2
32620, 0.17391304347826, 0.38478260869565, -0.2
32621, 0.19565217391304, 0.41086956521739, -0.2
32622, 0.1304347826087, 0.38478260869565, -0.2
32623, 0.15217391304348, 0.41086956521739, -0.2
32624, 0.08695652173913, 0.38478260869565, -0.2
32625, 0.10869565217391, 0.41086956521739, -0.2
32626, 0.043478260869565, 0.38478260869565, -0.2
32627, 0.065217391304348, 0.41086956521739, -0.2
32628, 0.021739130434783, 0.41086956521739, -0.2
32629, 0.95652173913043, 0.43695652173913, -0.2
32630, 0.97826086956522, 0.46304347826087, -0.2
32631, 0.91304347826087, 0.43695652173913, -0.2
32632, 0.93478260869565, 0.46304347826087, -0.2
32633, 0.8695652173913, 0.43695652173913, -0.2
32634, 0.89130434782609, 0.46304347826087, -0.2
32635, 0.82608695652174, 0.43695652173913, -0.2
32636, 0.84782608695652, 0.46304347826087, -0.2
32637, 0.78260869565217, 0.43695652173913, -0.2
32638, 0.80434782608696, 0.46304347826087, -0.2
32639, 0.73913043478261, 0.43695652173913, -0.2
32640, 0.76086956521739, 0.46304347826087, -0.2
32641, 0.69565217391304, 0.43695652173913, -0.2
32642, 0.71739130434783, 0.46304347826087, -0.2
32643, 0.65217391304348, 0.43695652173913, -0.2
32644, 0.67391304347826, 0.46304347826087, -0.2
32645, 0.60869565217391, 0.43695652173913, -0.2
32646, 0.6304347826087, 0.46304347826087, -0.2
32647, 0.56521739130435, 0.43695652173913, -0.2
32648, 0.58695652173913, 0.46304347826087, -0.2
32649, 0.52173913043478, 0.43695652173913, -0.2
32650, 0.54347826086957, 0.46304347826087, -0.2
32651, 0.47826086956522, 0.43695652173913, -0.2
32652, 0.5, 0.46304347826087, -0.2
32653, 0.43478260869565, 0.43695652173913, -0.2
32654, 0.45652173913043, 0.46304347826087, -0.2
32655, 0.39130434782609, 0.43695652173913, -0.2
32656, 0.41304347826087, 0.46304347826087, -0.2
32657, 0.34782608695652, 0.43695652173913, -0.2
32658, 0.3695652173913, 0.46304347826087, -0.2
32659, 0.30434782608696, 0.43695652173913, -0.2
32660, 0.32608695652174, 0.46304347826087, -0.2
32661, 0.26086956521739, 0.43695652173913, -0.2
32662, 0.28260869565217, 0.46304347826087, -0.2
32663, 0.21739130434783, 0.43695652173913, -0.2
32664, 0.23913043478261, 0.46304347826087, -0.2
32665, 0.17391304347826, 0.43695652173913, -0.2
32666, 0.19565217391304, 0.46304347826087, -0.2
32667, 0.1304347826087, 0.43695652173913, -0.2
32668, 0.15217391304348, 0.46304347826087, -0.2
32669, 0.08695652173913, 0.43695652173913, -0.2
32670, 0.10869565217391, 0.46304347826087, -0.2
32671, 0.043478260869565, 0.43695652173913, -0.2
32672, 0.065217391304348, 0.46304347826087, -0.2
32673, 0.021739130434783, 0.46304347826087, -0.2
32674, 0.95652173913043, 0.48913043478261, -0.2
32675, 0.97826086956522, 0.51521739130435, -0.2
32676, 0.91304347826087, 0.48913043478261, -0.2
32677, 0.93478260869565, 0.51521739130435, -0.2
32678, 0.8695652173913, 0.48913043478261, -0.2
32679, 0.89130434782609, 0.51521739130435, -0.2
32680, 0.82608695652174, 0.48913043478261, -0.2
32681, 0.84782608695652, 0.51521739130435, -0.2
32682, 0.78260869565217, 0.48913043478261, -0.2
32683, 0.80434782608696, 0.51521739130435, -0.2
32684, 0.73913043478261, 0.48913043478261, -0.2
32685, 0.76086956521739, 0.51521739130435, -0.2
32686, 0.69565217391304, 0.48913043478261, -0.2
32687, 0.71739130434783, 0.51521739130435, -0.2
32688, 0.65217391304348, 0.48913043478261, -0.2
32689, 0.67391304347826, 0.51521739130435, -0.2
32690, 0.60869565217391, 0.48913043478261, -0.2
32691, 0.6304347826087, 0.51521739130435, -0.2
32692, 0.56521739130435, 0.48913043478261, -0.2
32693, 0.58695652173913, 0.51521739130435, -0.2
32694, 0.52173913043478, 0.48913043478261, -0.2
32695, 0.54347826086957, 0.51521739130435, -0.2
32696, 0.47826086956522, 0.48913043478261, -0.2
32697, 0.5, 0.51521739130435, -0.2
32698, 0.43478260869565, 0.48913043478261, -0.2
32699, 0.45652173913043, 0.51521739130435, -0.2
32700, 0.39130434782609, 0.48913043478261, -0.2
32701, 0.41304347826087, 0.51521739130435, -0.2
32702, 0.34782608695652, 0.48913043478261, -0.2
32703, 0.3695652173913, 0.51521739130435, -0.2
32704, 0.30434782608696, 0.48913043478261, -0.2
32705, 0.32608695652174, 0.51521739130435, -0.2
32706, 0.26086956521739, 0.48913043478261, -0.2
32707, 0.28260869565217, 0.51521739130435, -0.2
32708, 0.21739130434783, 0.48913043478261, -0.2
32709, 0.23913043478261, 0.51521739130435, -0.2
32710, 0.17391304347826, 0.48913043478261, -0.2
32711, 0.19565217391304, 0.51521739130435, -0.2
32712, 0.1304347826087, 0.48913043478261, -0.2
32713, 0.15217391304348, 0.51521739130435, -0.2
32714, 0.08695652173913, 0.48913043478261, -0.2
32715, 0.10869565217391, 0.51521739130435, -0.2
32716, 0.043478260869565, 0.48913043478261, -0.2
32717, 0.065217391304348, 0.51521739130435, -0.2
32718, 0.021739130434783, 0.51521739130435, -0.2
32719, 0.95652173913043, 0.54130434782609, -0.2
32720, 0.97826086956522, 0.56739130434783, -0.2
32721, 0.91304347826087, 0.54130434782609, -0.2
32722, 0.93478260869565, 0.56739130434783, -0.2
32723, 0.8695652173913, 0.54130434782609, -0.2
32724, 0.89130434782609, 0.56739130434783, -0.2
32725, 0.82608695652174, 0.54130434782609, -0.2
32726, 0.84782608695652, 0.56739130434783, -0.2
32727, 0.78260869565217, 0.54130434782609, -0.2
32728, 0.80434782608696, 0.56739130434783, -0.2
32729, 0.73913043478261, 0.54130434782609, -0.2
32730, 0.76086956521739, 0.56739130434783, -0.2
32731, 0.69565217391304, 0.54130434782609, -0.2
32732, 0.71739130434783, 0.56739130434783, -0.2
32733, 0.65217391304348, 0.54130434782609, -0.2
32734, 0.67391304347826, 0.56739130434783, -0.2
32735, 0.60869565217391, 0.54130434782609, -0.2
32736, 0.6304347826087, 0.56739130434783, -0.2
32737, 0.56521739130435, 0.54130434782609, -0.2
32738, 0.58695652173913, 0.56739130434783, -0.2
32739, 0.52173913043478, 0.54130434782609, -0.2
32740, 0.54347826086957, 0.56739130434783, -0.2
32741, 0.47826086956522, 0.54130434782609, -0.2
32742, 0.5, 0.56739130434783, -0.2
32743, 0.43478260869565, 0.54130434782609, -0.2
32744, 0.45652173913043, 0.56739130434783, -0.2
32745, 0.39130434782609, 0.54130434782609, -0.2
32746, 0.41304347826087, 0.56739130434783, -0.2
32747, 0.34782608695652, 0.54130434782609, -0.2
32748, 0.3695652173913, 0.56739130434783, -0.2
32749, 0.30434782608696, 0.54130434782609, -0.2
32750, 0.32608695652174, 0.56739130434783, -0.2
32751, 0.26086956521739, 0.54130434782609, -0.2
32752, 0.28260869565217, 0.56739130434783, -0.2
32753, 0.21739130434783, 0.54130434782609, -0.2
32754, 0.23913043478261, 0.56739130434783, -0.2
32755, 0.17391304347826, 0.54130434782609, -0.2
32756, 0.19565217391304, 0.56739130434783, -0.2
32757, 0.1304347826087, 0.54130434782609, -0.2
32758, 0.15217391304348, 0.56739130434783, -0.2
32759, 0.08695652173913, 0.54130434782609, -0.2
32760, 0.10869565217391, 0.56739130434783, -0.2
32761, 0.043478260869565, 0.54130434782609, -0.2
32762, 0.065217391304348, 0.56739130434783, -0.2
32763, 0.021739130434783, 0.56739130434783, -0.2
32764, 0.95652173913043, 0.59347826086956, -0.2
32765, 0.97826086956522, 0.6195652173913, -0.2
32766, 0.91304347826087, 0.59347826086956, -0.2
32767, 0.93478260869565, 0.6195652173913, -0.2
32768, 0.8695652173913, 0.59347826086956, -0.2
32769, 0.89130434782609, 0.6195652173913, -0.2
32770, 0.82608695652174, 0.59347826086956, -0.2
32771, 0.84782608695652, 0.6195652173913, -0.2
32772, 0.78260869565217, 0.59347826086956, -0.2
32773, 0.80434782608696, 0.6195652173913, -0.2
32774, 0.73913043478261, 0.59347826086956, -0.2
32775, 0.76086956521739, 0.6195652173913, -0.2
32776, 0.69565217391304, 0.59347826086956, -0.2
32777, 0.71739130434783, 0.6195652173913, -0.2
32778, 0.65217391304348, 0.59347826086956, -0.2
32779, 0.67391304347826, 0.6195652173913, -0.2
32780, 0.60869565217391, 0.59347826086956, -0.2
32781, 0.6304347826087, 0.6195652173913, -0.2
32782, 0.56521739130435, 0.59347826086956, -0.2
32783, 0.58695652173913, 0.6195652173913, -0.2
32784, 0.52173913043478, 0.59347826086956, -0.2
32785, 0.54347826086957, 0.6195652173913, -0.2
32786, 0.47826086956522, 0.59347826086956, -0.2
32787, 0.5, 0.6195652173913, -0.2
32788, 0.43478260869565, 0.59347826086956, -0.2
32789, 0.45652173913043, 0.6195652173913, -0.2
32790, 0.39130434782609, 0.59347826086956, -0.2
32791, 0.41304347826087, 0.6195652173913, -0.2
32792, 0.34782608695652, 0.59347826086956, -0.2
32793, 0.3695652173913, 0.6195652173913, -0.2
32794, 0.30434782608696, 0.59347826086956, -0.2
32795, 0.32608695652174, 0.6195652173913, -0.2
32796, 0.26086956521739, 0.59347826086956, -0.2
32797, 0.28260869565217, 0.6195652173913, -0.2
32798, 0.21739130434783, 0.59347826086956, -0.2
32799, 0.23913043478261, 0.6195652173913, -0.2
32800, 0.17391304347826, 0.59347826086956, -0.2
32801, 0.19565217391304, 0.6195652173913, -0.2
32802, 0.1304347826087, 0.59347826086956, -0.2
32803, 0.15217391304348, 0.6195652173913, -0.2
32804, 0.08695652173913, 0.59347826086956, -0.2
32805, 0.10869565217391, 0.6195652173913, -0.2
32806, 0.043478260869565, 0.59347826086956, -0.2
32807, 0.065217391304348, 0.6195652173913, -0.2
32808, 0.021739130434783, 0.6195652173913, -0.2
32809, 0.95652173913043, 0.64565217391304, -0.2
32810, 0.97826086956522, 0.67173913043478, -0.2
32811, 0.91304347826087, 0.64565217391304, -0.2
32812, 0.93478260869565, 0.67173913043478, -0.2
32813, 0.8695652173913, 0.64565217391304, -0.2
32814, 0.89130434782609, 0.67173913043478, -0.2
32815, 0.82608695652174, 0.64565217391304, -0.2
32816, 0.84782608695652, 0.67173913043478, -0.2
32817, 0.78260869565217, 0.64565217391304, -0.2
32818, 0.80434782608696, 0.67173913043478, -0.2
32819, 0.73913043478261, 0.64565217391304, -0.2
32820, 0.76086956521739, 0.67173913043478, -0.2
32821, 0.69565217391304, 0.64565217391304, -0.2
32822, 0.71739130434783, 0.67173913043478, -0.2
32823, 0.65217391304348, 0.64565217391304, -0.2
32824, 0.67391304347826, 0.67173913043478, -0.2
32825, 0.60869565217391, 0.64565217391304, -0.2
32826, 0.6304347826087, 0.67173913043478, -0.2
32827, 0.56521739130435, 0.64565217391304, -0.2
32828, 0.58695652173913, 0.67173913043478, -0.2
32829, 0.52173913043478, 0.64565217391304, -0.2
32830, 0.54347826086957, 0.67173913043478, -0.2
32831, 0.47826086956522, 0.64565217391304, -0.2
32832, 0.5, 0.67173913043478, -0.2
32833, 0.43478260869565, 0.64565217391304, -0.2
32834, 0.45652173913043, 0.67173913043478, -0.2
32835, 0.39130434782609, 0.64565217391304, -0.2
32836, 0.41304347826087, 0.67173913043478, -0.2
32837, 0.34782608695652, 0.64565217391304, -0.2
32838, 0.3695652173913, 0.67173913043478, -0.2
32839, 0.30434782608696, 0.64565217391304, -0.2
32840, 0.32608695652174, 0.67173913043478, -0.2
32841, 0.26086956521739, 0.64565217391304, -0.2
32842, 0.28260869565217, 0.67173913043478, -0.2
32843, 0.21739130434783, 0.64565217391304, -0.2
32844, 0.23913043478261, 0.67173913043478, -0.2
32845, 0.17391304347826, 0.64565217391304, -0.2
32846, 0.19565217391304, 0.67173913043478, -0.2
32847, 0.1304347826087, 0.64565217391304, -0.2
32848, 0.15217391304348, 0.67173913043478, -0.2
32849, 0.08695652173913, 0.64565217391304, -0.2
32850, 0.10869565217391, 0.67173913043478, -0.2
32851, 0.043478260869565, 0.64565217391304, -0.2
32852, 0.065217391304348, 0.67173913043478, -0.2
32853, 0.021739130434783, 0.67173913043478, -0.2
32854, 0.95652173913043, 0.69782608695652, -0.2
32855, 0.97826086956522, 0.72391304347826, -0.2
32856, 0.91304347826087, 0.69782608695652, -0.2
32857, 0.93478260869565, 0.72391304347826, -0.2
32858, 0.8695652173913, 0.69782608695652, -0.2
32859, 0.89130434782609, 0.72391304347826, -0.2
32860, 0.82608695652174, 0.69782608695652, -0.2
32861, 0.84782608695652, 0.72391304347826, -0.2
32862, 0.78260869565217, 0.69782608695652, -0.2
32863, 0.80434782608696, 0.72391304347826, -0.2
32864, 0.73913043478261, 0.69782608695652, -0.2
32865, 0.76086956521739, 0.72391304347826, -0.2
32866, 0.69565217391304, 0.69782608695652, -0.2
32867, 0.71739130434783, 0.72391304347826, -0.2
32868, 0.65217391304348, 0.69782608695652, -0.2
32869, 0.67391304347826, 0.72391304347826, -0.2
32870, 0.60869565217391, 0.69782608695652, -0.2
32871, 0.6304347826087, 0.72391304347826, -0.2
32872, 0.56521739130435, 0.69782608695652, -0.2
32873, 0.58695652173913, 0.72391304347826, -0.2
32874, 0.52173913043478, 0.69782608695652, -0.2
32875, 0.54347826086957, 0.72391304347826, -0.2
32876, 0.47826086956522, 0.69782608695652, -0.2
32877, 0.5, 0.72391304347826, -0.2
32878, 0.43478260869565, 0.69782608695652, -0.2
32879, 0.45652173913043, 0.72391304347826, -0.2
32880, 0.39130434782609, 0.69782608695652, -0.2
32881, 0.41304347826087, 0.72391304347826, -0.2
32882, 0.34782608695652, 0.69782608695652, -0.2
32883, 0.3695652173913, 0.72391304347826, -0.2
32884, 0.30434782608696, 0.69782608695652, -0.2
32885, 0.32608695652174, 0.72391304347826, -0.2
32886, 0.26086956521739, 0.69782608695652, -0.2
32887, 0.28260869565217, 0.72391304347826, -0.2
32888, 0.21739130434783, 0.69782608695652, -0.2
32889, 0.23913043478261, 0.72391304347826, -0.2
32890, 0.17391304347826, 0.69782608695652, -0.2
32891, 0.19565217391304, 0.72391304347826, -0.2
32892, 0.1304347826087, 0.69782608695652, -0.2
32893, 0.15217391304348, 0.72391304347826, -0.2
32894, 0.08695652173913, 0.69782608695652, -0.2
32895, 0.10869565217391, 0.72391304347826, -0.2
32896, 0.043478260869565, 0.69782608695652, -0.2
32897, 0.065217391304348, 0.72391304347826, -0.2
32898, 0.021739130434783, 0.72391304347826, -0.2
32899, 0.95652173913043, 0.75, -0.2
32900, 0.97826086956522, 0.77608695652174, -0.2
32901, 0.91304347826087, 0.75, -0.2
32902, 0.93478260869565, 0.77608695652174, -0.2
32903, 0.8695652173913, 0.75, -0.2
32904, 0.89130434782609, 0.77608695652174, -0.2
32905, 0.82608695652174, 0.75, -0.2
32906, 0.84782608695652, 0.77608695652174, -0.2
32907, 0.78260869565217, 0.75, -0.2
32908, 0.80434782608696, 0.77608695652174, -0.2
32909, 0.73913043478261, 0.75, -0.2
32910, 0.76086956521739, 0.77608695652174, -0.2
32911, 0.69565217391304, 0.75, -0.2
32912, 0.71739130434783, 0.77608695652174, -0.2
32913, 0.65217391304348, 0.75, -0.2
32914, 0.67391304347826, 0.77608695652174, -0.2
32915, 0.60869565217391, 0.75, -0.2
32916, 0.6304347826087, 0.77608695652174, -0.2
32917, 0.56521739130435, 0.75, -0.2
32918, 0.58695652173913, 0.77608695652174, -0.2
32919, 0.52173913043478, 0.75, -0.2
32920, 0.54347826086957, 0.77608695652174, -0.2
32921, 0.47826086956522, 0.75, -0.2
32922, 0.5, 0.77608695652174, -0.2
32923, 0.43478260869565, 0.75, -0.2
32924, 0.45652173913043, 0.77608695652174, -0.2
32925, 0.39130434782609, 0.75, -0.2
32926, 0.41304347826087, 0.77608695652174, -0.2
32927, 0.34782608695652, 0.75, -0.2
32928, 0.3695652173913, 0.77608695652174, -0.2
32929, 0.30434782608696, 0.75, -0.2
32930, 0.32608695652174, 0.77608695652174, -0.2
32931, 0.26086956521739, 0.75, -0.2
32932, 0.28260869565217, 0.77608695652174, -0.2
32933, 0.21739130434783, 0.75, -0.2
32934, 0.23913043478261, 0.77608695652174, -0.2
32935, 0.17391304347826, 0.75, -0.2
32936, 0.19565217391304, 0.77608695652174, -0.2
32937, 0.1304347826087, 0.75, -0.2
32938, 0.15217391304348, 0.77608695652174, -0.2
32939, 0.08695652173913, 0.75, -0.2
32940, 0.10869565217391, 0.77608695652174, -0.2
32941, 0.043478260869565, 0.75, -0.2
32942, 0.065217391304348, 0.77608695652174, -0.2
32943, 0.021739130434783, 0.77608695652174, -0.2
32944, 0.95652173913043, 0.80217391304348, -0.2
32945, 0.97826086956522, 0.82826086956522, -0.2
32946, 0.91304347826087, 0.80217391304348, -0.2
32947, 0.93478260869565, 0.82826086956522, -0.2
32948, 0.8695652173913, 0.80217391304348, -0.2
32949, 0.89130434782609, 0.82826086956522, -0.2
32950, 0.82608695652174, 0.80217391304348, -0.2
32951, 0.84782608695652, 0.82826086956522, -0.2
32952, 0.78260869565217, 0.80217391304348, -0.2
32953, 0.80434782608696, 0.82826086956522, -0.2
32954, 0.73913043478261, 0.80217391304348, -0.2
32955, 0.76086956521739, 0.82826086956522, -0.2
32956, 0.69565217391304, 0.80217391304348, -0.2
32957, 0.71739130434783, 0.82826086956522, -0.2
32958, 0.65217391304348, 0.80217391304348, -0.2
32959, 0.67391304347826, 0.82826086956522, -0.2
32960, 0.60869565217391, 0.80217391304348, -0.2
32961, 0.6304347826087, 0.82826086956522, -0.2
32962, 0.56521739130435, 0.80217391304348, -0.2
32963, 0.58695652173913, 0.82826086956522, -0.2
32964, 0.52173913043478, 0.80217391304348, -0.2
32965, 0.54347826086957, 0.82826086956522, -0.2
32966, 0.47826086956522, 0.80217391304348, -0.2
32967, 0.5, 0.82826086956522, -0.2
32968, 0.43478260869565, 0.80217391304348, -0.2
32969, 0.45652173913043, 0.82826086956522, -0.2
32970, 0.39130434782609, 0.80217391304348, -0.2
32971, 0.41304347826087, 0.82826086956522, -0.2
32972, 0.34782608695652, 0.80217391304348, -0.2
32973, 0.3695652173913, 0.82826086956522, -0.2
32974, 0.30434782608696, 0.80217391304348, -0.2
32975, 0.32608695652174, 0.82826086956522, -0.2
32976, 0.26086956521739, 0.80217391304348, -0.2
32977, 0.28260869565217, 0.82826086956522, -0.2
32978, 0.21739130434783, 0.80217391304348, -0.2
32979, 0.23913043478261, 0.82826086956522, -0.2
32980, 0.17391304347826, 0.80217391304348, -0.2
32981, 0.19565217391304, 0.82826086956522, -0.2
32982, 0.1304347826087, 0.80217391304348, -0.2
32983, 0.15217391304348, 0.82826086956522, -0.2
32984, 0.08695652173913, 0.80217391304348, -0.2
32985, 0.10869565217391, 0.82826086956522, -0.2
32986, 0.043478260869565, 0.80217391304348, -0.2
32987, 0.065217391304348, 0.82826086956522, -0.2
32988, 0.021739130434783, 0.82826086956522, -0.2
32989, 0.95652173913043, 0.85434782608696, -0.2
32990, 0.97826086956522, 0.8804347826087, -0.2
32991, 0.91304347826087, 0.85434782608696, -0.2
32992, 0.93478260869565, 0.8804347826087, -0.2
32993, 0.8695652173913, 0.85434782608696, -0.2
32994, 0.89130434782609, 0.8804347826087, -0.2
32995, 0.82608695652174, 0.85434782608696, -0.2
32996, 0.84782608695652, 0.8804347826087, -0.2
32997, 0.78260869565217, 0.85434782608696, -0.2
32998, 0.80434782608696, 0.8804347826087, -0.2
32999, 0.73913043478261, 0.85434782608696, -0.2
33000, 0.76086956521739, 0.8804347826087, -0.2
33001, 0.69565217391304, 0.85434782608696, -0.2
33002, 0.71739130434783, 0.8804347826087, -0.2
33003, 0.65217391304348, 0.85434782608696, -0.2
33004, 0.67391304347826, 0.8804347826087, -0.2
33005, 0.60869565217391, 0.85434782608696, -0.2
33006, 0.6304347826087, 0.8804347826087, -0.2
33007, 0.56521739130435, 0.85434782608696, -0.2
33008, 0.58695652173913, 0.8804347826087, -0.2
33009, 0.52173913043478, 0.85434782608696, -0.2
33010, 0.54347826086957, 0.88043478260869, -0.2
33011, 0.47826086956522, 0.85434782608696, -0.2
33012, 0.5, 0.88043478260869, -0.2
33013, 0.43478260869565, 0.85434782608696, -0.2
33014, 0.45652173913043, 0.8804347826087, -0.2
33015, 0.39130434782609, 0.85434782608696, -0.2
33016, 0.41304347826087, 0.88043478260869, -0.2
33017, 0.34782608695652, 0.85434782608696, -0.2
33018, 0.3695652173913, 0.8804347826087, -0.2
33019, 0.30434782608696, 0.85434782608696, -0.2
33020, 0.32608695652174, 0.8804347826087, -0.2
33021, 0.26086956521739, 0.85434782608696, -0.2
33022, 0.28260869565217, 0.8804347826087, -0.2
33023, 0.21739130434783, 0.85434782608696, -0.2
33024, 0.23913043478261, 0.8804347826087, -0.2
33025, 0.17391304347826, 0.85434782608696, -0.2
33026, 0.19565217391304, 0.8804347826087, -0.2
33027, 0.1304347826087, 0.85434782608696, -0.2
33028, 0.15217391304348, 0.8804347826087, -0.2
33029, 0.08695652173913, 0.85434782608696, -0.2
33030, 0.10869565217391, 0.8804347826087, -0.2
33031, 0.043478260869565, 0.85434782608696, -0.2
33032, 0.065217391304348, 0.8804347826087, -0.2
33033, 0.021739130434783, 0.8804347826087, -0.2
33034, 0.95652173913043, 0.90652173913043, -0.2
33035, 0.97826086956522, 0.93260869565217, -0.2
33036, 0.91304347826087, 0.90652173913043, -0.2
33037, 0.93478260869565, 0.93260869565217, -0.2
33038, 0.8695652173913, 0.90652173913043, -0.2
33039, 0.89130434782609, 0.93260869565217, -0.2
33040, 0.82608695652174, 0.90652173913043, -0.2
33041, 0.84782608695652, 0.93260869565217, -0.2
33042, 0.78260869565217, 0.90652173913043, -0.2
33043, 0.80434782608696, 0.93260869565217, -0.2
33044, 0.73913043478261, 0.90652173913043, -0.2
33045, 0.76086956521739, 0.93260869565217, -0.2
33046, 0.69565217391304, 0.90652173913043, -0.2
33047, 0.71739130434783, 0.93260869565217, -0.2
33048, 0.65217391304348, 0.90652173913043, -0.2
33049, 0.67391304347826, 0.93260869565217, -0.2
33050, 0.60869565217391, 0.90652173913043, -0.2
33051, 0.6304347826087, 0.93260869565217, -0.2
33052, 0.56521739130435, 0.90652173913043, -0.2
33053, 0.58695652173913, 0.93260869565217, -0.2
33054, 0.52173913043478, 0.90652173913043, -0.2
33055, 0.54347826086957, 0.93260869565217, -0.2
33056, 0.47826086956522, 0.90652173913043, -0.2
33057, 0.5, 0.93260869565217, -0.2
33058, 0.43478260869565, 0.90652173913043, -0.2
33059, 0.45652173913043, 0.93260869565217, -0.2
33060, 0.39130434782609, 0.90652173913043, -0.2
33061, 0.41304347826087, 0.93260869565217, -0.2
33062, 0.34782608695652, 0.90652173913043, -0.2
33063, 0.3695652173913, 0.93260869565217, -0.2
33064, 0.30434782608696, 0.90652173913043, -0.2
33065, 0.32608695652174, 0.93260869565217, -0.2
33066, 0.26086956521739, 0.90652173913043, -0.2
33067, 0.28260869565217, 0.93260869565217, -0.2
33068, 0.21739130434783, 0.90652173913043, -0.2
33069, 0.23913043478261, 0.93260869565217, -0.2
33070, 0.17391304347826, 0.90652173913043, -0.2
33071, 0.19565217391304, 0.93260869565217, -0.2
33072, 0.1304347826087, 0.90652173913043, -0.2
33073, 0.15217391304348, 0.93260869565217, -0.2
33074, 0.08695652173913, 0.90652173913043, -0.2
33075, 0.10869565217391, 0.93260869565217, -0.2
33076, 0.043478260869565, 0.90652173913043, -0.2
33077, 0.065217391304348, 0.93260869565217, -0.2
33078, 0.021739130434783, 0.93260869565217, -0.2
33079, 0.95652173913043, 0.95869565217391, -0.2
33080, 0.97826086956522, 0.98478260869565, -0.2
33081, 0.91304347826087, 0.95869565217391, -0.2
33082, 0.93478260869565, 0.98478260869565, -0.2
33083, 0.8695652173913, 0.95869565217391, -0.2
33084, 0.89130434782609, 0.98478260869565, -0.2
33085, 0.82608695652174, 0.95869565217391, -0.2
33086, 0.84782608695652, 0.98478260869565, -0.2
33087, 0.78260869565217, 0.95869565217391, -0.2
33088, 0.80434782608696, 0.98478260869565, -0.2
33089, 0.73913043478261, 0.95869565217391, -0.2
33090, 0.76086956521739, 0.98478260869565, -0.2
33091, 0.69565217391304, 0.95869565217391, -0.2
33092, 0.71739130434783, 0.98478260869565, -0.2
33093, 0.65217391304348, 0.95869565217391, -0.2
33094, 0.67391304347826, 0.98478260869565, -0.2
33095, 0.60869565217391, 0.95869565217391, -0.2
33096, 0.6304347826087, 0.98478260869565, -0.2
33097, 0.56521739130435, 0.95869565217391, -0.2
33098, 0.58695652173913, 0.98478260869565, -0.2
33099, 0.52173913043478, 0.95869565217391, -0.2
33100, 0.54347826086957, 0.98478260869565, -0.2
33101, 0.47826086956522, 0.95869565217391, -0.2
33102, 0.5, 0.98478260869565, -0.2
33103, 0.43478260869565, 0.95869565217391, -0.2
33104, 0.45652173913043, 0.98478260869565, -0.2
33105, 0.39130434782609, 0.95869565217391, -0.2
33106, 0.41304347826087, 0.98478260869565, -0.2
33107, 0.34782608695652, 0.95869565217391, -0.2
33108, 0.3695652173913, 0.98478260869565, -0.2
33109, 0.30434782608696, 0.95869565217391, -0.2
33110, 0.32608695652174, 0.98478260869565, -0.2
33111, 0.26086956521739, 0.95869565217391, -0.2
33112, 0.28260869565217, 0.98478260869565, -0.2
33113, 0.21739130434783, 0.95869565217391, -0.2
33114, 0.23913043478261, 0.98478260869565, -0.2
33115, 0.17391304347826, 0.95869565217391, -0.2
33116, 0.19565217391304, 0.98478260869565, -0.2
33117, 0.1304347826087, 0.95869565217391, -0.2
33118, 0.15217391304348, 0.98478260869565, -0.2
33119, 0.08695652173913, 0.95869565217391, -0.2
33120, 0.10869565217391, 0.98478260869565, -0.2
33121, 0.043478260869565, 0.95869565217391, -0.2
33122, 0.065217391304348, 0.98478260869565, -0.2
33123, 0.021739130434783, 0.98478260869565, -0.2
33124, 0.95652173913043, 1.0108695652174, -0.2
33125, 0.97826086956522, 1.0369565217391, -0.2
33126, 0.91304347826087, 1.0108695652174, -0.2
33127, 0.93478260869565, 1.0369565217391, -0.2
33128, 0.8695652173913, 1.0108695652174, -0.2
33129, 0.89130434782609, 1.0369565217391, -0.2
33130, 0.82608695652174, 1.0108695652174, -0.2
33131, 0.84782608695652, 1.0369565217391, -0.2
33132, 0.78260869565217, 1.0108695652174, -0.2
33133, 0.80434782608696, 1.0369565217391, -0.2
33134, 0.73913043478261, 1.0108695652174, -0.2
33135, 0.76086956521739, 1.0369565217391, -0.2
33136, 0.69565217391304, 1.0108695652174, -0.2
33137, 0.71739130434783, 1.0369565217391, -0.2
33138, 0.65217391304348, 1.0108695652174, -0.2
33139, 0.67391304347826, 1.0369565217391, -0.2
33140, 0.60869565217391, 1.0108695652174, -0.2
33141, 0.6304347826087, 1.0369565217391, -0.2
33142, 0.56521739130435, 1.0108695652174, -0.2
33143, 0.58695652173913, 1.0369565217391, -0.2
33144, 0.52173913043478, 1.0108695652174, -0.2
33145, 0.54347826086957, 1.0369565217391, -0.2
33146, 0.47826086956522, 1.0108695652174, -0.2
33147, 0.5, 1.0369565217391, -0.2
33148, 0.43478260869565, 1.0108695652174, -0.2
33149, 0.45652173913043, 1.0369565217391, -0.2
33150, 0.39130434782609, 1.0108695652174, -0.2
33151, 0.41304347826087, 1.0369565217391, -0.2
33152, 0.34782608695652, 1.0108695652174, -0.2
33153, 0.3695652173913, 1.0369565217391, -0.2
33154, 0.30434782608696, 1.0108695652174, -0.2
33155, 0.32608695652174, 1.0369565217391, -0.2
33156, 0.26086956521739, 1.0108695652174, -0.2
33157, 0.28260869565217, 1.0369565217391, -0.2
33158, 0.21739130434783, 1.0108695652174, -0.2
33159, 0.23913043478261, 1.0369565217391, -0.2
33160, 0.17391304347826, 1.0108695652174, -0.2
33161, 0.19565217391304, 1.0369565217391, -0.2
33162, 0.1304347826087, 1.0108695652174, -0.2
33163, 0.15217391304348, 1.0369565217391, -0.2
33164, 0.08695652173913, 1.0108695652174, -0.2
33165, 0.10869565217391, 1.0369565217391, -0.2
33166, 0.043478260869565, 1.0108695652174, -0.2
33167, 0.065217391304348, 1.0369565217391, -0.2
33168, 0.021739130434783, 1.0369565217391, -0.2
33169, 0.95652173913043, 1.0630434782609, -0.2
33170, 0.97826086956522, 1.0891304347826, -0.2
33171, 0.91304347826087, 1.0630434782609, -0.2
33172, 0.93478260869565, 1.0891304347826, -0.2
33173, 0.8695652173913, 1.0630434782609, -0.2
33174, 0.89130434782609, 1.0891304347826, -0.2
33175, 0.82608695652174, 1.0630434782609, -0.2
33176, 0.84782608695652, 1.0891304347826, -0.2
33177, 0.78260869565217, 1.0630434782609, -0.2
33178, 0.80434782608696, 1.0891304347826, -0.2
33179, 0.73913043478261, 1.0630434782609, -0.2
33180, 0.76086956521739, 1.0891304347826, -0.2
33181, 0.69565217391304, 1.0630434782609, -0.2
33182, 0.71739130434783, 1.0891304347826, -0.2
33183, 0.65217391304348, 1.0630434782609, -0.2
33184, 0.67391304347826, 1.0891304347826, -0.2
33185, 0.60869565217391, 1.0630434782609, -0.2
33186, 0.6304347826087, 1.0891304347826, -0.2
33187, 0.56521739130435, 1.0630434782609, -0.2
33188, 0.58695652173913, 1.0891304347826, -0.2
33189, 0.52173913043478, 1.0630434782609, -0.2
33190, 0.54347826086957, 1.0891304347826, -0.2
33191, 0.47826086956522, 1.0630434782609, -0.2
33192, 0.5, 1.0891304347826, -0.2
33193, 0.43478260869565, 1.0630434782609, -0.2
33194, 0.45652173913043, 1.0891304347826, -0.2
33195, 0.39130434782609, 1.0630434782609, -0.2
33196, 0.41304347826087, 1.0891304347826, -0.2
33197, 0.34782608695652, 1.0630434782609, -0.2
33198, 0.3695652173913, 1.0891304347826, -0.2
33199, 0.30434782608696, 1.0630434782609, -0.2
33200, 0.32608695652174, 1.0891304347826, -0.2
33201, 0.26086956521739, 1.0630434782609, -0.2
33202, 0.28260869565217, 1.0891304347826, -0.2
33203, 0.21739130434783, 1.0630434782609, -0.2
33204, 0.23913043478261, 1.0891304347826, -0.2
33205, 0.17391304347826, 1.0630434782609, -0.2
33206, 0.19565217391304, 1.0891304347826, -0.2
33207, 0.1304347826087, 1.0630434782609, -0.2
33208, 0.15217391304348, 1.0891304347826, -0.2
33209, 0.08695652173913, 1.0630434782609, -0.2
33210, 0.10869565217391, 1.0891304347826, -0.2
33211, 0.043478260869565, 1.0630434782609, -0.2
33212, 0.065217391304348, 1.0891304347826, -0.2
33213, 0.021739130434783, 1.0891304347826, -0.2
33214, 0.95652173913043, 1.1152173913043, -0.2
33215, 0.97826086956522, 1.1413043478261, -0.2
33216, 0.91304347826087, 1.1152173913043, -0.2
33217, 0.93478260869565, 1.1413043478261, -0.2
33218, 0.8695652173913, 1.1152173913043, -0.2
33219, 0.89130434782609, 1.1413043478261, -0.2
33220, 0.82608695652174, 1.1152173913043, -0.2
33221, 0.84782608695652, 1.1413043478261, -0.2
33222, 0.78260869565217, 1.1152173913043, -0.2
33223, 0.80434782608696, 1.1413043478261, -0.2
33224, 0.73913043478261, 1.1152173913043, -0.2
33225, 0.76086956521739, 1.1413043478261, -0.2
33226, 0.69565217391304, 1.1152173913043, -0.2
33227, 0.71739130434783, 1.1413043478261, -0.2
33228, 0.65217391304348, 1.1152173913043, -0.2
33229, 0.67391304347826, 1.1413043478261, -0.2
33230, 0.60869565217391, 1.1152173913043, -0.2
33231, 0.6304347826087, 1.1413043478261, -0.2
33232, 0.56521739130435, 1.1152173913043, -0.2
33233, 0.58695652173913, 1.1413043478261, -0.2
33234, 0.52173913043478, 1.1152173913043, -0.2
33235, 0.54347826086957, 1.1413043478261, -0.2
33236, 0.47826086956522, 1.1152173913043, -0.2
33237, 0.5, 1.1413043478261, -0.2
33238, 0.43478260869565, 1.1152173913043, -0.2
33239, 0.45652173913043, 1.1413043478261, -0.2
33240, 0.39130434782609, 1.1152173913043, -0.2
33241, 0.41304347826087, 1.1413043478261, -0.2
33242, 0.34782608695652, 1.1152173913043, -0.2
33243, 0.3695652173913, 1.1413043478261, -0.2
33244, 0.30434782608696, 1.1152173913043, -0.2
33245, 0.32608695652174, 1.1413043478261, -0.2
33246, 0.26086956521739, 1.1152173913043, -0.2
33247, 0.28260869565217, 1.1413043478261, -0.2
33248, 0.21739130434783, 1.1152173913043, -0.2
33249, 0.23913043478261, 1.1413043478261, -0.2
33250, 0.17391304347826, 1.1152173913043, -0.2
33251, 0.19565217391304, 1.1413043478261, -0.2
33252, 0.1304347826087, 1.1152173913043, -0.2
33253, 0.15217391304348, 1.1413043478261, -0.2
33254, 0.08695652173913, 1.1152173913043, -0.2
33255, 0.10869565217391, 1.1413043478261, -0.2
33256, 0.043478260869565, 1.1152173913043, -0.2
33257, 0.065217391304348, 1.1413043478261, -0.2
33258, 0.021739130434783, 1.1413043478261, -0.2
33259, 0.95652173913043, 1.1673913043478, -0.2
33260, 0.97826086956522, 1.1934782608696, -0.2
33261, 0.91304347826087, 1.1673913043478, -0.2
33262, 0.93478260869565, 1.1934782608696, -0.2
33263, 0.8695652173913, 1.1673913043478, -0.2
33264, 0.89130434782609, 1.1934782608696, -0.2
33265, 0.82608695652174, 1.1673913043478, -0.2
33266, 0.84782608695652, 1.1934782608696, -0.2
33267, 0.78260869565217, 1.1673913043478, -0.2
33268, 0.80434782608696, 1.1934782608696, -0.2
33269, 0.73913043478261, 1.1673913043478, -0.2
33270, 0.76086956521739, 1.1934782608696, -0.2
33271, 0.69565217391304, 1.1673913043478, -0.2
33272, 0.71739130434783, 1.1934782608696, -0.2
33273, 0.65217391304348, 1.1673913043478, -0.2
33274, 0.67391304347826, 1.1934782608696, -0.2
33275, 0.60869565217391, 1.1673913043478, -0.2
33276, 0.6304347826087, 1.1934782608696, -0.2
33277, 0.56521739130435, 1.1673913043478, -0.2
33278, 0.58695652173913, 1.1934782608696, -0.2
33279, 0.52173913043478, 1.1673913043478, -0.2
33280, 0.54347826086957, 1.1934782608696, -0.2
33281, 0.47826086956522, 1.1673913043478, -0.2
33282, 0.5, 1.1934782608696, -0.2
33283, 0.43478260869565, 1.1673913043478, -0.2
33284, 0.45652173913043, 1.1934782608696, -0.2
33285, 0.39130434782609, 1.1673913043478, -0.2
33286, 0.41304347826087, 1.1934782608696, -0.2
33287, 0.34782608695652, 1.1673913043478, -0.2
33288, 0.3695652173913, 1.1934782608696, -0.2
33289, 0.30434782608696, 1.1673913043478, -0.2
33290, 0.32608695652174, 1.1934782608696, -0.2
33291, 0.26086956521739, 1.1673913043478, -0.2
33292, 0.28260869565217, 1.1934782608696, -0.2
33293, 0.21739130434783, 1.1673913043478, -0.2
33294, 0.23913043478261, 1.1934782608696, -0.2
33295, 0.17391304347826, 1.1673913043478, -0.2
33296, 0.19565217391304, 1.1934782608696, -0.2
33297, 0.1304347826087, 1.1673913043478, -0.2
33298, 0.15217391304348, 1.1934782608696, -0.2
33299, 0.08695652173913, 1.1673913043478, -0.2
33300, 0.10869565217391, 1.1934782608696, -0.2
33301, 0.043478260869565, 1.1673913043478, -0.2
33302, 0.065217391304348, 1.1934782608696, -0.2
33303, 0.021739130434783, 1.1934782608696, -0.2
33304, 0.95652173913043, 1.2195652173913, -0.2
33305, 0.97826086956522, 1.245652173913, -0.2
33306, 0.91304347826087, 1.2195652173913, -0.2
33307, 0.93478260869565, 1.245652173913, -0.2
33308, 0.8695652173913, 1.2195652173913, -0.2
33309, 0.89130434782609, 1.245652173913, -0.2
33310, 0.82608695652174, 1.2195652173913, -0.2
33311, 0.84782608695652, 1.245652173913, -0.2
33312, 0.78260869565217, 1.2195652173913, -0.2
33313, 0.80434782608696, 1.245652173913, -0.2
33314, 0.73913043478261, 1.2195652173913, -0.2
33315, 0.76086956521739, 1.245652173913, -0.2
33316, 0.69565217391304, 1.2195652173913, -0.2
33317, 0.71739130434783, 1.245652173913, -0.2
33318, 0.65217391304348, 1.2195652173913, -0.2
33319, 0.67391304347826, 1.245652173913, -0.2
33320, 0.60869565217391, 1.2195652173913, -0.2
33321, 0.6304347826087, 1.245652173913, -0.2
33322, 0.56521739130435, 1.2195652173913, -0.2
33323, 0.58695652173913, 1.245652173913, -0.2
33324, 0.52173913043478, 1.2195652173913, -0.2
33325, 0.54347826086957, 1.245652173913, -0.2
33326, 0.47826086956522, 1.2195652173913, -0.2
33327, 0.5, 1.245652173913, -0.2
33328, 0.43478260869565, 1.2195652173913, -0.2
33329, 0.45652173913043, 1.245652173913, -0.2
33330, 0.39130434782609, 1.2195652173913, -0.2
33331, 0.41304347826087, 1.245652173913, -0.2
33332, 0.34782608695652, 1.2195652173913, -0.2
33333, 0.3695652173913, 1.245652173913, -0.2
33334, 0.30434782608696, 1.2195652173913, -0.2
33335, 0.32608695652174, 1.245652173913, -0.2
33336, 0.26086956521739, 1.2195652173913, -0.2
33337, 0.28260869565217, 1.245652173913, -0.2
33338, 0.21739130434783, 1.2195652173913, -0.2
33339, 0.23913043478261, 1.245652173913, -0.2
33340, 0.17391304347826, 1.2195652173913, -0.2
33341, 0.19565217391304, 1.245652173913, -0.2
33342, 0.1304347826087, 1.2195652173913, -0.2
33343, 0.15217391304348, 1.245652173913, -0.2
33344, 0.08695652173913, 1.2195652173913, -0.2
33345, 0.10869565217391, 1.245652173913, -0.2
33346, 0.043478260869565, 1.2195652173913, -0.2
33347, 0.065217391304348, 1.245652173913, -0.2
33348, 0.021739130434783, 1.245652173913, -0.2
33349, 0.95652173913043, 1.2717391304348, -0.2
33350, 0.97826086956522, 1.2978260869565, -0.2
33351, 0.91304347826087, 1.2717391304348, -0.2
33352, 0.93478260869565, 1.2978260869565, -0.2
33353, 0.8695652173913, 1.2717391304348, -0.2
33354, 0.89130434782609, 1.2978260869565, -0.2
33355, 0.82608695652174, 1.2717391304348, -0.2
33356, 0.84782608695652, 1.2978260869565, -0.2
33357, 0.78260869565217, 1.2717391304348, -0.2
33358, 0.80434782608696, 1.2978260869565, -0.2
33359, 0.73913043478261, 1.2717391304348, -0.2
33360, 0.76086956521739, 1.2978260869565, -0.2
33361, 0.69565217391304, 1.2717391304348, -0.2
33362, 0.71739130434783, 1.2978260869565, -0.2
33363, 0.65217391304348, 1.2717391304348, -0.2
33364, 0.67391304347826, 1.2978260869565, -0.2
33365, 0.60869565217391, 1.2717391304348, -0.2
33366, 0.6304347826087, 1.2978260869565, -0.2
33367, 0.56521739130435, 1.2717391304348, -0.2
33368, 0.58695652173913, 1.2978260869565, -0.2
33369, 0.52173913043478, 1.2717391304348, -0.2
33370, 0.54347826086957, 1.2978260869565, -0.2
33371, 0.47826086956522, 1.2717391304348, -0.2
33372, 0.5, 1.2978260869565, -0.2
33373, 0.43478260869565, 1.2717391304348, -0.2
33374, 0.45652173913043, 1.2978260869565, -0.2
33375, 0.39130434782609, 1.2717391304348, -0.2
33376, 0.41304347826087, 1.2978260869565, -0.2
33377, 0.34782608695652, 1.2717391304348, -0.2
33378, 0.3695652173913, 1.2978260869565, -0.2
33379, 0.30434782608696, 1.2717391304348, -0.2
33380, 0.32608695652174, 1.2978260869565, -0.2
33381, 0.26086956521739, 1.2717391304348, -0.2
33382, 0.28260869565217, 1.2978260869565, -0.2
33383, 0.21739130434783, 1.2717391304348, -0.2
33384, 0.23913043478261, 1.2978260869565, -0.2
33385, 0.17391304347826, 1.2717391304348, -0.2
33386, 0.19565217391304, 1.2978260869565, -0.2
33387, 0.1304347826087, 1.2717391304348, -0.2
33388, 0.15217391304348, 1.2978260869565, -0.2
33389, 0.08695652173913, 1.2717391304348, -0.2
33390, 0.10869565217391, 1.2978260869565, -0.2
33391, 0.043478260869565, 1.2717391304348, -0.2
33392, 0.065217391304348, 1.2978260869565, -0.2
33393, 0.021739130434783, 1.2978260869565, -0.2
33394, 0.95652173913043, 1.3239130434783, -0.2
33395, 0.91304347826087, 1.3239130434783, -0.2
33396, 0.8695652173913, 1.3239130434783, -0.2
33397, 0.82608695652174, 1.3239130434783, -0.2
33398, 0.78260869565217, 1.3239130434783, -0.2
33399, 0.73913043478261, 1.3239130434783, -0.2
33400, 0.69565217391304, 1.3239130434783, -0.2
33401, 0.65217391304348, 1.3239130434783, -0.2
33402, 0.60869565217391, 1.3239130434783, -0.2
33403, 0.56521739130435, 1.3239130434783, -0.2
33404, 0.52173913043478, 1.3239130434783, -0.2
33405, 0.47826086956522, 1.3239130434783, -0.2
33406, 0.43478260869565, 1.3239130434783, -0.2
33407, 0.39130434782609, 1.3239130434783, -0.2
33408, 0.34782608695652, 1.3239130434783, -0.2
33409, 0.30434782608696, 1.3239130434783, -0.2
33410, 0.26086956521739, 1.3239130434783, -0.2
33411, 0.21739130434783, 1.3239130434783, -0.2
33412, 0.17391304347826, 1.3239130434783, -0.2
33413, 0.1304347826087, 1.3239130434783, -0.2
33414, 0.08695652173913, 1.3239130434783, -0.2
33415, 0.043478260869565, 1.3239130434783, -0.2
33416, 1.2, 1.2978260869565, -0.05
33417, 1.2, 1.245652173913, -0.05
33418, 1.2, 1.1934782608696, -0.05
33419, 1.2, 1.1413043478261, -0.05
33420, 1.2, 1.0891304347826, -0.05
33421, 1.2, 1.0369565217391, -0.05
33422, 1.2, 0.98478260869565, -0.05
33423, 1.2, 0.93260869565217, -0.05
33424, 1.2, 0.8804347826087, -0.05
33425, 1.2, 0.82826086956522, -0.05
33426, 1.2, 0.77608695652174, -0.05
33427, 1.2, 0.72391304347826, -0.05
33428, 1.2, 0.67173913043478, -0.05
33429, 1.2, 0.61956521739131, -0.05
33430, 1.2, 0.56739130434783, -0.05
33431, 1.2, 0.51521739130435, -0.05
33432, 1.2, 0.46304347826087, -0.05
33433, 1.2, 0.41086956521739, -0.05
33434, 1.2, 0.35869565217391, -0.05
33435, 1.2, 0.30652173913043, -0.05
33436, 1.2, 0.25434782608696, -0.05
33437, 1.2, 0.20217391304348, -0.05
33438, 1.2, 1.2978260869565, -0.1
33439, 1.2, 1.245652173913, -0.1
33440, 1.2, 1.1934782608696, -0.1
33441, 1.2, 1.1413043478261, -0.1
33442, 1.2, 1.0891304347826, -0.1
33443, 1.2, 1.0369565217391, -0.1
33444, 1.2, 0.98478260869565, -0.1
33445, 1.2, 0.93260869565217, -0.1
33446, 1.2, 0.8804347826087, -0.1
33447, 1.2, 0.82826086956522, -0.1
33448, 1.2, 0.77608695652174, -0.1
33449, 1.2, 0.72391304347826, -0.1
33450, 1.2, 0.67173913043478, -0.1
33451, 1.2, 0.61956521739131, -0.1
33452, 1.2, 0.56739130434783, -0.1
33453, 1.2, 0.51521739130435, -0.1
33454, 1.2, 0.46304347826087, -0.1
33455, 1.2, 0.41086956521739, -0.1
33456, 1.2, 0.35869565217391, -0.1
33457, 1.2, 0.30652173913044, -0.1
33458, 1.2, 0.25434782608696, -0.1
33459, 1.2, 0.20217391304348, -0.1
33460, 1.2, 1.2978260869565, -0.15
33461, 1.2, 1.245652173913, -0.15
33462, 1.2, 1.1934782608696, -0.15
33463, 1.2, 1.1413043478261, -0.15
33464, 1.2, 1.0891304347826, -0.15
33465, 1.2, 1.0369565217391, -0.15
33466, 1.2, 0.98478260869565, -0.15
33467, 1.2, 0.93260869565217, -0.15
33468, 1.2, 0.8804347826087, -0.15
33469, 1.2, 0.82826086956522, -0.15
33470, 1.2, 0.77608695652174, -0.15
33471, 1.2, 0.72391304347826, -0.15
33472, 1.2, 0.67173913043478, -0.15
33473, 1.2, 0.61956521739131, -0.15
33474, 1.2, 0.56739130434783, -0.15
33475, 1.2, 0.51521739130435, -0.15
33476, 1.2, 0.46304347826087, -0.15
33477, 1.2, 0.41086956521739, -0.15
33478, 1.2, 0.35869565217391, -0.15
33479, 1.2, 0.30652173913044, -0.15
33480, 1.2, 0.25434782608696, -0.15
33481, 1.2, 0.20217391304348, -0.15
33482, 1.2, 1.2978260869565, -0.025
33483, 1.2, 1.3239130434783, -0.05
33484, 1.2, 1.245652173913, -0.025
33485, 1.2, 1.2717391304348, -0.05
33486, 1.2, 1.1934782608696, -0.025
33487, 1.2, 1.2195652173913, -0.05
33488, 1.2, 1.1413043478261, -0.025
33489, 1.2, 1.1673913043478, -0.05
33490, 1.2, 1.0891304347826, -0.025
33491, 1.2, 1.1152173913043, -0.05
33492, 1.2, 1.0369565217391, -0.025
33493, 1.2, 1.0630434782609, -0.05
33494, 1.2, 0.98478260869565, -0.025
33495, 1.2, 1.0108695652174, -0.05
33496, 1.2, 0.93260869565217, -0.025
33497, 1.2, 0.95869565217391, -0.05
33498, 1.2, 0.8804347826087, -0.025
33499, 1.2, 0.90652173913044, -0.05
33500, 1.2, 0.82826086956522, -0.025
33501, 1.2, 0.85434782608696, -0.05
33502, 1.2, 0.77608695652174, -0.025
33503, 1.2, 0.80217391304348, -0.05
33504, 1.2, 0.72391304347826, -0.025
33505, 1.2, 0.75, -0.05
33506, 1.2, 0.67173913043478, -0.025
33507, 1.2, 0.69782608695652, -0.05
33508, 1.2, 0.61956521739131, -0.025
33509, 1.2, 0.64565217391304, -0.05
33510, 1.2, 0.56739130434783, -0.025
33511, 1.2, 0.59347826086957, -0.05
33512, 1.2, 0.51521739130435, -0.025
33513, 1.2, 0.54130434782609, -0.05
33514, 1.2, 0.46304347826087, -0.025
33515, 1.2, 0.48913043478261, -0.05
33516, 1.2, 0.41086956521739, -0.025
33517, 1.2, 0.43695652173913, -0.05
33518, 1.2, 0.35869565217391, -0.025
33519, 1.2, 0.38478260869565, -0.05
33520, 1.2, 0.30652173913044, -0.025
33521, 1.2, 0.33260869565217, -0.05
33522, 1.2, 0.25434782608696, -0.025
33523, 1.2, 0.2804347826087, -0.05
33524, 1.2, 0.20217391304348, -0.025
33525, 1.2, 0.22826086956522, -0.05
33526, 1.2, 0.17608695652174, -0.05
33527, 1.2, 1.2978260869565, -0.075
33528, 1.2, 1.3239130434783, -0.1
33529, 1.2, 1.245652173913, -0.075
33530, 1.2, 1.2717391304348, -0.1
33531, 1.2, 1.1934782608696, -0.075
33532, 1.2, 1.2195652173913, -0.1
33533, 1.2, 1.1413043478261, -0.075
33534, 1.2, 1.1673913043478, -0.1
33535, 1.2, 1.0891304347826, -0.075
33536, 1.2, 1.1152173913043, -0.1
33537, 1.2, 1.0369565217391, -0.075
33538, 1.2, 1.0630434782609, -0.1
33539, 1.2, 0.98478260869565, -0.075
33540, 1.2, 1.0108695652174, -0.1
33541, 1.2, 0.93260869565217, -0.075
33542, 1.2, 0.95869565217391, -0.1
33543, 1.2, 0.8804347826087, -0.075
33544, 1.2, 0.90652173913044, -0.1
33545, 1.2, 0.82826086956522, -0.075
33546, 1.2, 0.85434782608696, -0.1
33547, 1.2, 0.77608695652174, -0.075
33548, 1.2, 0.80217391304348, -0.1
33549, 1.2, 0.72391304347826, -0.075
33550, 1.2, 0.75, -0.1
33551, 1.2, 0.67173913043478, -0.075
33552, 1.2, 0.69782608695652, -0.1
33553, 1.2, 0.61956521739131, -0.075
33554, 1.2, 0.64565217391304, -0.1
33555, 1.2, 0.56739130434783, -0.075
33556, 1.2, 0.59347826086957, -0.1
33557, 1.2, 0.51521739130435, -0.075
33558, 1.2, 0.54130434782609, -0.1
33559, 1.2, 0.46304347826087, -0.075
33560, 1.2, 0.48913043478261, -0.1
33561, 1.2, 0.41086956521739, -0.075
33562, 1.2, 0.43695652173913, -0.1
33563, 1.2, 0.35869565217391, -0.075
33564, 1.2, 0.38478260869565, -0.1
33565, 1.2, 0.30652173913044, -0.075
33566, 1.2, 0.33260869565217, -0.1
33567, 1.2, 0.25434782608696, -0.075
33568, 1.2, 0.2804347826087, -0.1
33569, 1.2, 0.20217391304348, -0.075
33570, 1.2, 0.22826086956522, -0.1
33571, 1.2, 0.17608695652174, -0.1
33572, 1.2, 1.2978260869565, -0.125
33573, 1.2, 1.3239130434783, -0.15
33574, 1.2, 1.245652173913, -0.125
33575, 1.2, 1.2717391304348, -0.15
33576, 1.2, 1.1934782608696, -0.125
33577, 1.2, 1.2195652173913, -0.15
33578, 1.2, 1.1413043478261, -0.125
33579, 1.2, 1.1673913043478, -0.15
33580, 1.2, 1.0891304347826, -0.125
33581, 1.2, 1.1152173913043, -0.15
33582, 1.2, 1.0369565217391, -0.125
33583, 1.2, 1.0630434782609, -0.15
33584, 1.2, 0.98478260869565, -0.125
33585, 1.2, 1.0108695652174, -0.15
33586, 1.2, 0.93260869565217, -0.125
33587, 1.2, 0.95869565217391, -0.15
33588, 1.2, 0.8804347826087, -0.125
33589, 1.2, 0.90652173913044, -0.15
33590, 1.2, 0.82826086956522, -0.125
33591, 1.2, 0.85434782608696, -0.15
33592, 1.2, 0.77608695652174, -0.125
33593, 1.2, 0.80217391304348, -0.15
33594, 1.2, 0.72391304347826, -0.125
33595, 1.2, 0.75, -0.15
33596, 1.2, 0.67173913043478, -0.125
33597, 1.2, 0.69782608695652, -0.15
33598, 1.2, 0.61956521739131, -0.125
33599, 1.2, 0.64565217391304, -0.15
33600, 1.2, 0.56739130434783, -0.125
33601, 1.2, 0.59347826086957, -0.15
33602, 1.2, 0.51521739130435, -0.125
33603, 1.2, 0.54130434782609, -0.15
33604, 1.2, 0.46304347826087, -0.125
33605, 1.2, 0.48913043478261, -0.15
33606, 1.2, 0.41086956521739, -0.125
33607, 1.2, 0.43695652173913, -0.15
33608, 1.2, 0.35869565217391, -0.125
33609, 1.2, 0.38478260869565, -0.15
33610, 1.2, 0.30652173913044, -0.125
33611, 1.2, 0.33260869565217, -0.15
33612, 1.2, 0.25434782608696, -0.125
33613, 1.2, 0.2804347826087, -0.15
33614, 1.2, 0.20217391304348, -0.125
33615, 1.2, 0.22826086956522, -0.15
33616, 1.2, 0.17608695652174, -0.15
33617, 1.2, 1.2978260869565, -0.175
33618, 1.2, 1.245652173913, -0.175
33619, 1.2, 1.1934782608696, -0.175
33620, 1.2, 1.1413043478261, -0.175
33621, 1.2, 1.0891304347826, -0.175
33622, 1.2, 1.0369565217391, -0.175
33623, 1.2, 0.98478260869565, -0.175
33624, 1.2, 0.93260869565217, -0.175
33625, 1.2, 0.8804347826087, -0.175
33626, 1.2, 0.82826086956522, -0.175
33627, 1.2, 0.77608695652174, -0.175
33628, 1.2, 0.72391304347826, -0.175
33629, 1.2, 0.67173913043478, -0.175
33630, 1.2, 0.61956521739131, -0.175
