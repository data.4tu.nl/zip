20318, 42154, 24102, 24094, 42162, 42155, 24103, 24095, 42163, 54606, 24363, 54614, 54286, 54607, 24365, 54615, 
54289, 54263, 24366, 24349, 54288
20319, 42155, 24103, 24095, 42163, 42156, 24104, 24096, 42164, 54607, 24365, 54615, 54289, 54608, 24367, 54616, 
54292, 54266, 24368, 24351, 54291
20320, 42156, 24104, 24096, 42164, 42157, 24105, 24097, 42165, 54608, 24367, 54616, 54292, 54609, 24369, 54617, 
54295, 54269, 24370, 24353, 54294
20321, 42157, 24105, 24097, 42165, 22446, 3072, 3071, 22447, 54609, 24369, 54617, 54295, 23458, 3094, 23459, 
23427, 54272, 24371, 24354, 54297
20322, 20393, 2919, 2918, 20394, 42158, 24090, 24082, 42166, 21405, 2941, 21406, 21376, 54610, 24338, 54618, 
54299, 54273, 24339, 24322, 54298
20323, 42158, 24090, 24082, 42166, 42159, 24091, 24083, 42167, 54610, 24338, 54618, 54299, 54611, 24340, 54619, 
54302, 54276, 24341, 24324, 54301
20324, 42159, 24091, 24083, 42167, 42160, 24092, 24084, 42168, 54611, 24340, 54619, 54302, 54612, 24342, 54620, 
54305, 54279, 24343, 24326, 54304
20325, 42160, 24092, 24084, 42168, 42161, 24093, 24085, 42169, 54612, 24342, 54620, 54305, 54613, 24344, 54621, 
54308, 54282, 24345, 24328, 54307
20326, 42161, 24093, 24085, 42169, 42162, 24094, 24086, 42170, 54613, 24344, 54621, 54308, 54614, 24346, 54622, 
54311, 54285, 24347, 24330, 54310
20327, 42162, 24094, 24086, 42170, 42163, 24095, 24087, 42171, 54614, 24346, 54622, 54311, 54615, 24348, 54623, 
54314, 54288, 24349, 24332, 54313
20328, 42163, 24095, 24087, 42171, 42164, 24096, 24088, 42172, 54615, 24348, 54623, 54314, 54616, 24350, 54624, 
54317, 54291, 24351, 24334, 54316
20329, 42164, 24096, 24088, 42172, 42165, 24097, 24089, 42173, 54616, 24350, 54624, 54317, 54617, 24352, 54625, 
54320, 54294, 24353, 24336, 54319
20330, 42165, 24097, 24089, 42173, 22447, 3071, 3070, 22448, 54617, 24352, 54625, 54320, 23459, 3093, 23460, 
23429, 54297, 24354, 24337, 54322
20331, 20394, 2918, 2917, 20395, 42166, 24082, 24074, 42174, 21406, 2940, 21407, 21378, 54618, 24321, 54626, 
54324, 54298, 24322, 24305, 54323
20332, 42166, 24082, 24074, 42174, 42167, 24083, 24075, 42175, 54618, 24321, 54626, 54324, 54619, 24323, 54627, 
54327, 54301, 24324, 24307, 54326
20333, 42167, 24083, 24075, 42175, 42168, 24084, 24076, 42176, 54619, 24323, 54627, 54327, 54620, 24325, 54628, 
54330, 54304, 24326, 24309, 54329
20334, 42168, 24084, 24076, 42176, 42169, 24085, 24077, 42177, 54620, 24325, 54628, 54330, 54621, 24327, 54629, 
54333, 54307, 24328, 24311, 54332
20335, 42169, 24085, 24077, 42177, 42170, 24086, 24078, 42178, 54621, 24327, 54629, 54333, 54622, 24329, 54630, 
54336, 54310, 24330, 24313, 54335
20336, 42170, 24086, 24078, 42178, 42171, 24087, 24079, 42179, 54622, 24329, 54630, 54336, 54623, 24331, 54631, 
54339, 54313, 24332, 24315, 54338
20337, 42171, 24087, 24079, 42179, 42172, 24088, 24080, 42180, 54623, 24331, 54631, 54339, 54624, 24333, 54632, 
54342, 54316, 24334, 24317, 54341
20338, 42172, 24088, 24080, 42180, 42173, 24089, 24081, 42181, 54624, 24333, 54632, 54342, 54625, 24335, 54633, 
54345, 54319, 24336, 24319, 54344
20339, 42173, 24089, 24081, 42181, 22448, 3070, 3069, 22449, 54625, 24335, 54633, 54345, 23460, 3092, 23461, 
23431, 54322, 24337, 24320, 54347
20340, 20395, 2917, 2916, 20396, 42174, 24074, 24066, 42182, 21407, 2939, 21408, 21380, 54626, 24304, 54634, 
54349, 54323, 24305, 24288, 54348
20341, 42174, 24074, 24066, 42182, 42175, 24075, 24067, 42183, 54626, 24304, 54634, 54349, 54627, 24306, 54635, 
54352, 54326, 24307, 24290, 54351
20342, 42175, 24075, 24067, 42183, 42176, 24076, 24068, 42184, 54627, 24306, 54635, 54352, 54628, 24308, 54636, 
54355, 54329, 24309, 24292, 54354
20343, 42176, 24076, 24068, 42184, 42177, 24077, 24069, 42185, 54628, 24308, 54636, 54355, 54629, 24310, 54637, 
54358, 54332, 24311, 24294, 54357
20344, 42177, 24077, 24069, 42185, 42178, 24078, 24070, 42186, 54629, 24310, 54637, 54358, 54630, 24312, 54638, 
54361, 54335, 24313, 24296, 54360
20345, 42178, 24078, 24070, 42186, 42179, 24079, 24071, 42187, 54630, 24312, 54638, 54361, 54631, 24314, 54639, 
54364, 54338, 24315, 24298, 54363
20346, 42179, 24079, 24071, 42187, 42180, 24080, 24072, 42188, 54631, 24314, 54639, 54364, 54632, 24316, 54640, 
54367, 54341, 24317, 24300, 54366
20347, 42180, 24080, 24072, 42188, 42181, 24081, 24073, 42189, 54632, 24316, 54640, 54367, 54633, 24318, 54641, 
54370, 54344, 24319, 24302, 54369
20348, 42181, 24081, 24073, 42189, 22449, 3069, 3068, 22450, 54633, 24318, 54641, 54370, 23461, 3091, 23462, 
23433, 54347, 24320, 24303, 54372
20349, 20396, 2916, 2915, 20397, 42182, 24066, 24058, 42190, 21408, 2938, 21409, 21382, 54634, 24287, 54642, 
54374, 54348, 24288, 24271, 54373
20350, 42182, 24066, 24058, 42190, 42183, 24067, 24059, 42191, 54634, 24287, 54642, 54374, 54635, 24289, 54643, 
54377, 54351, 24290, 24273, 54376
20351, 42183, 24067, 24059, 42191, 42184, 24068, 24060, 42192, 54635, 24289, 54643, 54377, 54636, 24291, 54644, 
54380, 54354, 24292, 24275, 54379
20352, 42184, 24068, 24060, 42192, 42185, 24069, 24061, 42193, 54636, 24291, 54644, 54380, 54637, 24293, 54645, 
54383, 54357, 24294, 24277, 54382
20353, 42185, 24069, 24061, 42193, 42186, 24070, 24062, 42194, 54637, 24293, 54645, 54383, 54638, 24295, 54646, 
54386, 54360, 24296, 24279, 54385
20354, 42186, 24070, 24062, 42194, 42187, 24071, 24063, 42195, 54638, 24295, 54646, 54386, 54639, 24297, 54647, 
54389, 54363, 24298, 24281, 54388
20355, 42187, 24071, 24063, 42195, 42188, 24072, 24064, 42196, 54639, 24297, 54647, 54389, 54640, 24299, 54648, 
54392, 54366, 24300, 24283, 54391
20356, 42188, 24072, 24064, 42196, 42189, 24073, 24065, 42197, 54640, 24299, 54648, 54392, 54641, 24301, 54649, 
54395, 54369, 24302, 24285, 54394
20357, 42189, 24073, 24065, 42197, 22450, 3068, 3067, 22451, 54641, 24301, 54649, 54395, 23462, 3090, 23463, 
23435, 54372, 24303, 24286, 54397
20358, 20397, 2915, 2914, 20398, 42190, 24058, 24050, 42198, 21409, 2937, 21410, 21384, 54642, 24270, 54650, 
54399, 54373, 24271, 24254, 54398
20359, 42190, 24058, 24050, 42198, 42191, 24059, 24051, 42199, 54642, 24270, 54650, 54399, 54643, 24272, 54651, 
54402, 54376, 24273, 24256, 54401
20360, 42191, 24059, 24051, 42199, 42192, 24060, 24052, 42200, 54643, 24272, 54651, 54402, 54644, 24274, 54652, 
54405, 54379, 24275, 24258, 54404
20361, 42192, 24060, 24052, 42200, 42193, 24061, 24053, 42201, 54644, 24274, 54652, 54405, 54645, 24276, 54653, 
54408, 54382, 24277, 24260, 54407
20362, 42193, 24061, 24053, 42201, 42194, 24062, 24054, 42202, 54645, 24276, 54653, 54408, 54646, 24278, 54654, 
54411, 54385, 24279, 24262, 54410
20363, 42194, 24062, 24054, 42202, 42195, 24063, 24055, 42203, 54646, 24278, 54654, 54411, 54647, 24280, 54655, 
54414, 54388, 24281, 24264, 54413
20364, 42195, 24063, 24055, 42203, 42196, 24064, 24056, 42204, 54647, 24280, 54655, 54414, 54648, 24282, 54656, 
54417, 54391, 24283, 24266, 54416
20365, 42196, 24064, 24056, 42204, 42197, 24065, 24057, 42205, 54648, 24282, 54656, 54417, 54649, 24284, 54657, 
54420, 54394, 24285, 24268, 54419
20366, 42197, 24065, 24057, 42205, 22451, 3067, 3066, 22452, 54649, 24284, 54657, 54420, 23463, 3089, 23464, 
23437, 54397, 24286, 24269, 54422
20367, 20398, 2914, 2913, 20399, 42198, 24050, 24042, 42206, 21410, 2936, 21411, 21386, 54650, 24253, 54658, 
54424, 54398, 24254, 24237, 54423
20368, 42198, 24050, 24042, 42206, 42199, 24051, 24043, 42207, 54650, 24253, 54658, 54424, 54651, 24255, 54659, 
54427, 54401, 24256, 24239, 54426
20369, 42199, 24051, 24043, 42207, 42200, 24052, 24044, 42208, 54651, 24255, 54659, 54427, 54652, 24257, 54660, 
54430, 54404, 24258, 24241, 54429
20370, 42200, 24052, 24044, 42208, 42201, 24053, 24045, 42209, 54652, 24257, 54660, 54430, 54653, 24259, 54661, 
54433, 54407, 24260, 24243, 54432
20371, 42201, 24053, 24045, 42209, 42202, 24054, 24046, 42210, 54653, 24259, 54661, 54433, 54654, 24261, 54662, 
54436, 54410, 24262, 24245, 54435
20372, 42202, 24054, 24046, 42210, 42203, 24055, 24047, 42211, 54654, 24261, 54662, 54436, 54655, 24263, 54663, 
54439, 54413, 24264, 24247, 54438
20373, 42203, 24055, 24047, 42211, 42204, 24056, 24048, 42212, 54655, 24263, 54663, 54439, 54656, 24265, 54664, 
54442, 54416, 24266, 24249, 54441
20374, 42204, 24056, 24048, 42212, 42205, 24057, 24049, 42213, 54656, 24265, 54664, 54442, 54657, 24267, 54665, 
54445, 54419, 24268, 24251, 54444
20375, 42205, 24057, 24049, 42213, 22452, 3066, 3065, 22453, 54657, 24267, 54665, 54445, 23464, 3088, 23465, 
23439, 54422, 24269, 24252, 54447
20376, 20399, 2913, 2912, 20400, 42206, 24042, 24034, 42214, 21411, 2935, 21412, 21388, 54658, 24236, 54666, 
54449, 54423, 24237, 24220, 54448
20377, 42206, 24042, 24034, 42214, 42207, 24043, 24035, 42215, 54658, 24236, 54666, 54449, 54659, 24238, 54667, 
54452, 54426, 24239, 24222, 54451
20378, 42207, 24043, 24035, 42215, 42208, 24044, 24036, 42216, 54659, 24238, 54667, 54452, 54660, 24240, 54668, 
54455, 54429, 24241, 24224, 54454
20379, 42208, 24044, 24036, 42216, 42209, 24045, 24037, 42217, 54660, 24240, 54668, 54455, 54661, 24242, 54669, 
54458, 54432, 24243, 24226, 54457
20380, 42209, 24045, 24037, 42217, 42210, 24046, 24038, 42218, 54661, 24242, 54669, 54458, 54662, 24244, 54670, 
54461, 54435, 24245, 24228, 54460
20381, 42210, 24046, 24038, 42218, 42211, 24047, 24039, 42219, 54662, 24244, 54670, 54461, 54663, 24246, 54671, 
54464, 54438, 24247, 24230, 54463
20382, 42211, 24047, 24039, 42219, 42212, 24048, 24040, 42220, 54663, 24246, 54671, 54464, 54664, 24248, 54672, 
54467, 54441, 24249, 24232, 54466
20383, 42212, 24048, 24040, 42220, 42213, 24049, 24041, 42221, 54664, 24248, 54672, 54467, 54665, 24250, 54673, 
54470, 54444, 24251, 24234, 54469
20384, 42213, 24049, 24041, 42221, 22453, 3065, 3064, 22454, 54665, 24250, 54673, 54470, 23465, 3087, 23466, 
23441, 54447, 24252, 24235, 54472
20385, 20400, 2912, 2911, 20401, 42214, 24034, 24026, 42222, 21412, 2934, 21413, 21390, 54666, 24219, 54674, 
54474, 54448, 24220, 24203, 54473
20386, 42214, 24034, 24026, 42222, 42215, 24035, 24027, 42223, 54666, 24219, 54674, 54474, 54667, 24221, 54675, 
54477, 54451, 24222, 24205, 54476
20387, 42215, 24035, 24027, 42223, 42216, 24036, 24028, 42224, 54667, 24221, 54675, 54477, 54668, 24223, 54676, 
54480, 54454, 24224, 24207, 54479
20388, 42216, 24036, 24028, 42224, 42217, 24037, 24029, 42225, 54668, 24223, 54676, 54480, 54669, 24225, 54677, 
54483, 54457, 24226, 24209, 54482
20389, 42217, 24037, 24029, 42225, 42218, 24038, 24030, 42226, 54669, 24225, 54677, 54483, 54670, 24227, 54678, 
54486, 54460, 24228, 24211, 54485
20390, 42218, 24038, 24030, 42226, 42219, 24039, 24031, 42227, 54670, 24227, 54678, 54486, 54671, 24229, 54679, 
54489, 54463, 24230, 24213, 54488
20391, 42219, 24039, 24031, 42227, 42220, 24040, 24032, 42228, 54671, 24229, 54679, 54489, 54672, 24231, 54680, 
54492, 54466, 24232, 24215, 54491
20392, 42220, 24040, 24032, 42228, 42221, 24041, 24033, 42229, 54672, 24231, 54680, 54492, 54673, 24233, 54681, 
54495, 54469, 24234, 24217, 54494
20393, 42221, 24041, 24033, 42229, 22454, 3064, 3063, 22455, 54673, 24233, 54681, 54495, 23466, 3086, 23467, 
23443, 54472, 24235, 24218, 54497
20394, 20401, 2911, 90, 2887, 42222, 24026, 3108, 23643, 21413, 2933, 2910, 21391, 54674, 24202, 24025, 
54498, 54473, 24203, 3116, 24017
20395, 42222, 24026, 3108, 23643, 42223, 24027, 3109, 23642, 54674, 24202, 24025, 54498, 54675, 24204, 24024, 
54499, 54476, 24205, 3117, 24015
20396, 42223, 24027, 3109, 23642, 42224, 24028, 3110, 23641, 54675, 24204, 24024, 54499, 54676, 24206, 24023, 
54500, 54479, 24207, 3118, 24013
20397, 42224, 24028, 3110, 23641, 42225, 24029, 3111, 23640, 54676, 24206, 24023, 54500, 54677, 24208, 24022, 
54501, 54482, 24209, 3119, 24011
20398, 42225, 24029, 3111, 23640, 42226, 24030, 3112, 23639, 54677, 24208, 24022, 54501, 54678, 24210, 24021, 
54502, 54485, 24211, 3120, 24009
20399, 42226, 24030, 3112, 23639, 42227, 24031, 3113, 23638, 54678, 24210, 24021, 54502, 54679, 24212, 24020, 
54503, 54488, 24213, 3121, 24007
20400, 42227, 24031, 3113, 23638, 42228, 24032, 3114, 23637, 54679, 24212, 24020, 54503, 54680, 24214, 24019, 
54504, 54491, 24215, 3122, 24005
20401, 42228, 24032, 3114, 23637, 42229, 24033, 3115, 23636, 54680, 24214, 24019, 54504, 54681, 24216, 24018, 
54505, 54494, 24217, 3123, 24003
20402, 42229, 24033, 3115, 23636, 22455, 3063, 92, 3039, 54681, 24216, 24018, 54505, 23467, 3085, 3062, 
23445, 54497, 24218, 3124, 24001
*ELEMENT, type=C3D20, ELSET=Volume4
20403, 67, 2008, 14764, 2035, 2062, 14860, 54682, 15176, 2009, 14787, 14786, 2058, 14875, 54859, 54860, 
15558, 2070, 14877, 54858, 15541
20404, 2062, 14860, 54682, 15176, 2063, 14859, 54683, 15177, 14875, 54859, 54860, 15558, 14873, 54862, 54863, 
15559, 2071, 14876, 54861, 15543
20405, 2063, 14859, 54683, 15177, 2064, 14858, 54684, 15178, 14873, 54862, 54863, 15559, 14871, 54865, 54866, 
15560, 2072, 14874, 54864, 15545
20406, 2064, 14858, 54684, 15178, 2065, 14857, 54685, 15179, 14871, 54865, 54866, 15560, 14869, 54868, 54869, 
15561, 2073, 14872, 54867, 15547
20407, 2065, 14857, 54685, 15179, 2066, 14856, 54686, 15180, 14869, 54868, 54869, 15561, 14867, 54871, 54872, 
15562, 2074, 14870, 54870, 15549
20408, 2066, 14856, 54686, 15180, 2067, 14855, 54687, 15181, 14867, 54871, 54872, 15562, 14865, 54874, 54875, 
15563, 2075, 14868, 54873, 15551
20409, 2067, 14855, 54687, 15181, 2068, 14854, 54688, 15182, 14865, 54874, 54875, 15563, 14863, 54877, 54878, 
15564, 2076, 14866, 54876, 15553
20410, 2068, 14854, 54688, 15182, 2069, 14853, 54689, 15183, 14863, 54877, 54878, 15564, 14861, 54880, 54881, 
15565, 2077, 14864, 54879, 15555
20411, 2069, 14853, 54689, 15183, 69, 2059, 14886, 2103, 14861, 54880, 54881, 15565, 2060, 14908, 14909, 
2126, 2078, 14862, 54882, 15557
20412, 2035, 14764, 14765, 2034, 15176, 54682, 54690, 15168, 14786, 14789, 14788, 2057, 54860, 54884, 54885, 
15542, 15541, 54858, 54883, 15524
20413, 15176, 54682, 54690, 15168, 15177, 54683, 54691, 15169, 54860, 54884, 54885, 15542, 54863, 54887, 54888, 
15544, 15543, 54861, 54886, 15526
20414, 15177, 54683, 54691, 15169, 15178, 54684, 54692, 15170, 54863, 54887, 54888, 15544, 54866, 54890, 54891, 
15546, 15545, 54864, 54889, 15528
20415, 15178, 54684, 54692, 15170, 15179, 54685, 54693, 15171, 54866, 54890, 54891, 15546, 54869, 54893, 54894, 
15548, 15547, 54867, 54892, 15530
20416, 15179, 54685, 54693, 15171, 15180, 54686, 54694, 15172, 54869, 54893, 54894, 15548, 54872, 54896, 54897, 
15550, 15549, 54870, 54895, 15532
20417, 15180, 54686, 54694, 15172, 15181, 54687, 54695, 15173, 54872, 54896, 54897, 15550, 54875, 54899, 54900, 
15552, 15551, 54873, 54898, 15534
20418, 15181, 54687, 54695, 15173, 15182, 54688, 54696, 15174, 54875, 54899, 54900, 15552, 54878, 54902, 54903, 
15554, 15553, 54876, 54901, 15536
20419, 15182, 54688, 54696, 15174, 15183, 54689, 54697, 15175, 54878, 54902, 54903, 15554, 54881, 54905, 54906, 
15556, 15555, 54879, 54904, 15538
20420, 15183, 54689, 54697, 15175, 2103, 14886, 14887, 2102, 54881, 54905, 54906, 15556, 14909, 14910, 14911, 
2125, 15557, 54882, 54907, 15540
20421, 2034, 14765, 14766, 2033, 15168, 54690, 54698, 15160, 14788, 14791, 14790, 2056, 54885, 54909, 54910, 
15525, 15524, 54883, 54908, 15507
20422, 15168, 54690, 54698, 15160, 15169, 54691, 54699, 15161, 54885, 54909, 54910, 15525, 54888, 54912, 54913, 
15527, 15526, 54886, 54911, 15509
20423, 15169, 54691, 54699, 15161, 15170, 54692, 54700, 15162, 54888, 54912, 54913, 15527, 54891, 54915, 54916, 
15529, 15528, 54889, 54914, 15511
20424, 15170, 54692, 54700, 15162, 15171, 54693, 54701, 15163, 54891, 54915, 54916, 15529, 54894, 54918, 54919, 
15531, 15530, 54892, 54917, 15513
20425, 15171, 54693, 54701, 15163, 15172, 54694, 54702, 15164, 54894, 54918, 54919, 15531, 54897, 54921, 54922, 
15533, 15532, 54895, 54920, 15515
20426, 15172, 54694, 54702, 15164, 15173, 54695, 54703, 15165, 54897, 54921, 54922, 15533, 54900, 54924, 54925, 
15535, 15534, 54898, 54923, 15517
20427, 15173, 54695, 54703, 15165, 15174, 54696, 54704, 15166, 54900, 54924, 54925, 15535, 54903, 54927, 54928, 
15537, 15536, 54901, 54926, 15519
20428, 15174, 54696, 54704, 15166, 15175, 54697, 54705, 15167, 54903, 54927, 54928, 15537, 54906, 54930, 54931, 
15539, 15538, 54904, 54929, 15521
20429, 15175, 54697, 54705, 15167, 2102, 14887, 14888, 2101, 54906, 54930, 54931, 15539, 14911, 14912, 14913, 
2124, 15540, 54907, 54932, 15523
20430, 2033, 14766, 14767, 2032, 15160, 54698, 54706, 15152, 14790, 14793, 14792, 2055, 54910, 54934, 54935, 
15508, 15507, 54908, 54933, 15490
20431, 15160, 54698, 54706, 15152, 15161, 54699, 54707, 15153, 54910, 54934, 54935, 15508, 54913, 54937, 54938, 
15510, 15509, 54911, 54936, 15492
20432, 15161, 54699, 54707, 15153, 15162, 54700, 54708, 15154, 54913, 54937, 54938, 15510, 54916, 54940, 54941, 
15512, 15511, 54914, 54939, 15494
20433, 15162, 54700, 54708, 15154, 15163, 54701, 54709, 15155, 54916, 54940, 54941, 15512, 54919, 54943, 54944, 
15514, 15513, 54917, 54942, 15496
20434, 15163, 54701, 54709, 15155, 15164, 54702, 54710, 15156, 54919, 54943, 54944, 15514, 54922, 54946, 54947, 
15516, 15515, 54920, 54945, 15498
20435, 15164, 54702, 54710, 15156, 15165, 54703, 54711, 15157, 54922, 54946, 54947, 15516, 54925, 54949, 54950, 
15518, 15517, 54923, 54948, 15500
20436, 15165, 54703, 54711, 15157, 15166, 54704, 54712, 15158, 54925, 54949, 54950, 15518, 54928, 54952, 54953, 
15520, 15519, 54926, 54951, 15502
20437, 15166, 54704, 54712, 15158, 15167, 54705, 54713, 15159, 54928, 54952, 54953, 15520, 54931, 54955, 54956, 
15522, 15521, 54929, 54954, 15504
20438, 15167, 54705, 54713, 15159, 2101, 14888, 14889, 2100, 54931, 54955, 54956, 15522, 14913, 14914, 14915, 
2123, 15523, 54932, 54957, 15506
20439, 2032, 14767, 14768, 2031, 15152, 54706, 54714, 15144, 14792, 14795, 14794, 2054, 54935, 54959, 54960, 
15491, 15490, 54933, 54958, 15473
20440, 15152, 54706, 54714, 15144, 15153, 54707, 54715, 15145, 54935, 54959, 54960, 15491, 54938, 54962, 54963, 
15493, 15492, 54936, 54961, 15475
20441, 15153, 54707, 54715, 15145, 15154, 54708, 54716, 15146, 54938, 54962, 54963, 15493, 54941, 54965, 54966, 
15495, 15494, 54939, 54964, 15477
20442, 15154, 54708, 54716, 15146, 15155, 54709, 54717, 15147, 54941, 54965, 54966, 15495, 54944, 54968, 54969, 
15497, 15496, 54942, 54967, 15479
20443, 15155, 54709, 54717, 15147, 15156, 54710, 54718, 15148, 54944, 54968, 54969, 15497, 54947, 54971, 54972, 
15499, 15498, 54945, 54970, 15481
20444, 15156, 54710, 54718, 15148, 15157, 54711, 54719, 15149, 54947, 54971, 54972, 15499, 54950, 54974, 54975, 
15501, 15500, 54948, 54973, 15483
20445, 15157, 54711, 54719, 15149, 15158, 54712, 54720, 15150, 54950, 54974, 54975, 15501, 54953, 54977, 54978, 
15503, 15502, 54951, 54976, 15485
20446, 15158, 54712, 54720, 15150, 15159, 54713, 54721, 15151, 54953, 54977, 54978, 15503, 54956, 54980, 54981, 
15505, 15504, 54954, 54979, 15487
20447, 15159, 54713, 54721, 15151, 2100, 14889, 14890, 2099, 54956, 54980, 54981, 15505, 14915, 14916, 14917, 
2122, 15506, 54957, 54982, 15489
20448, 2031, 14768, 14769, 2030, 15144, 54714, 54722, 15136, 14794, 14797, 14796, 2053, 54960, 54984, 54985, 
15474, 15473, 54958, 54983, 15456
20449, 15144, 54714, 54722, 15136, 15145, 54715, 54723, 15137, 54960, 54984, 54985, 15474, 54963, 54987, 54988, 
15476, 15475, 54961, 54986, 15458
20450, 15145, 54715, 54723, 15137, 15146, 54716, 54724, 15138, 54963, 54987, 54988, 15476, 54966, 54990, 54991, 
15478, 15477, 54964, 54989, 15460
20451, 15146, 54716, 54724, 15138, 15147, 54717, 54725, 15139, 54966, 54990, 54991, 15478, 54969, 54993, 54994, 
15480, 15479, 54967, 54992, 15462
20452, 15147, 54717, 54725, 15139, 15148, 54718, 54726, 15140, 54969, 54993, 54994, 15480, 54972, 54996, 54997, 
15482, 15481, 54970, 54995, 15464
20453, 15148, 54718, 54726, 15140, 15149, 54719, 54727, 15141, 54972, 54996, 54997, 15482, 54975, 54999, 55000, 
15484, 15483, 54973, 54998, 15466
20454, 15149, 54719, 54727, 15141, 15150, 54720, 54728, 15142, 54975, 54999, 55000, 15484, 54978, 55002, 55003, 
15486, 15485, 54976, 55001, 15468
20455, 15150, 54720, 54728, 15142, 15151, 54721, 54729, 15143, 54978, 55002, 55003, 15486, 54981, 55005, 55006, 
15488, 15487, 54979, 55004, 15470
20456, 15151, 54721, 54729, 15143, 2099, 14890, 14891, 2098, 54981, 55005, 55006, 15488, 14917, 14918, 14919, 
2121, 15489, 54982, 55007, 15472
20457, 2030, 14769, 14770, 2029, 15136, 54722, 54730, 15128, 14796, 14799, 14798, 2052, 54985, 55009, 55010, 
15457, 15456, 54983, 55008, 15439
20458, 15136, 54722, 54730, 15128, 15137, 54723, 54731, 15129, 54985, 55009, 55010, 15457, 54988, 55012, 55013, 
15459, 15458, 54986, 55011, 15441
20459, 15137, 54723, 54731, 15129, 15138, 54724, 54732, 15130, 54988, 55012, 55013, 15459, 54991, 55015, 55016, 
15461, 15460, 54989, 55014, 15443
20460, 15138, 54724, 54732, 15130, 15139, 54725, 54733, 15131, 54991, 55015, 55016, 15461, 54994, 55018, 55019, 
15463, 15462, 54992, 55017, 15445
20461, 15139, 54725, 54733, 15131, 15140, 54726, 54734, 15132, 54994, 55018, 55019, 15463, 54997, 55021, 55022, 
15465, 15464, 54995, 55020, 15447
20462, 15140, 54726, 54734, 15132, 15141, 54727, 54735, 15133, 54997, 55021, 55022, 15465, 55000, 55024, 55025, 
15467, 15466, 54998, 55023, 15449
20463, 15141, 54727, 54735, 15133, 15142, 54728, 54736, 15134, 55000, 55024, 55025, 15467, 55003, 55027, 55028, 
15469, 15468, 55001, 55026, 15451
20464, 15142, 54728, 54736, 15134, 15143, 54729, 54737, 15135, 55003, 55027, 55028, 15469, 55006, 55030, 55031, 
15471, 15470, 55004, 55029, 15453
20465, 15143, 54729, 54737, 15135, 2098, 14891, 14892, 2097, 55006, 55030, 55031, 15471, 14919, 14920, 14921, 
2120, 15472, 55007, 55032, 15455
20466, 2029, 14770, 14771, 2028, 15128, 54730, 54738, 15120, 14798, 14801, 14800, 2051, 55010, 55034, 55035, 
15440, 15439, 55008, 55033, 15422
20467, 15128, 54730, 54738, 15120, 15129, 54731, 54739, 15121, 55010, 55034, 55035, 15440, 55013, 55037, 55038, 
15442, 15441, 55011, 55036, 15424
20468, 15129, 54731, 54739, 15121, 15130, 54732, 54740, 15122, 55013, 55037, 55038, 15442, 55016, 55040, 55041, 
15444, 15443, 55014, 55039, 15426
20469, 15130, 54732, 54740, 15122, 15131, 54733, 54741, 15123, 55016, 55040, 55041, 15444, 55019, 55043, 55044, 
15446, 15445, 55017, 55042, 15428
20470, 15131, 54733, 54741, 15123, 15132, 54734, 54742, 15124, 55019, 55043, 55044, 15446, 55022, 55046, 55047, 
15448, 15447, 55020, 55045, 15430
20471, 15132, 54734, 54742, 15124, 15133, 54735, 54743, 15125, 55022, 55046, 55047, 15448, 55025, 55049, 55050, 
15450, 15449, 55023, 55048, 15432
20472, 15133, 54735, 54743, 15125, 15134, 54736, 54744, 15126, 55025, 55049, 55050, 15450, 55028, 55052, 55053, 
15452, 15451, 55026, 55051, 15434
20473, 15134, 54736, 54744, 15126, 15135, 54737, 54745, 15127, 55028, 55052, 55053, 15452, 55031, 55055, 55056, 
15454, 15453, 55029, 55054, 15436
20474, 15135, 54737, 54745, 15127, 2097, 14892, 14893, 2096, 55031, 55055, 55056, 15454, 14921, 14922, 14923, 
2119, 15455, 55032, 55057, 15438
20475, 2028, 14771, 14772, 2027, 15120, 54738, 54746, 15112, 14800, 14803, 14802, 2050, 55035, 55059, 55060, 
15423, 15422, 55033, 55058, 15405
20476, 15120, 54738, 54746, 15112, 15121, 54739, 54747, 15113, 55035, 55059, 55060, 15423, 55038, 55062, 55063, 
15425, 15424, 55036, 55061, 15407
20477, 15121, 54739, 54747, 15113, 15122, 54740, 54748, 15114, 55038, 55062, 55063, 15425, 55041, 55065, 55066, 
15427, 15426, 55039, 55064, 15409
20478, 15122, 54740, 54748, 15114, 15123, 54741, 54749, 15115, 55041, 55065, 55066, 15427, 55044, 55068, 55069, 
15429, 15428, 55042, 55067, 15411
20479, 15123, 54741, 54749, 15115, 15124, 54742, 54750, 15116, 55044, 55068, 55069, 15429, 55047, 55071, 55072, 
15431, 15430, 55045, 55070, 15413
20480, 15124, 54742, 54750, 15116, 15125, 54743, 54751, 15117, 55047, 55071, 55072, 15431, 55050, 55074, 55075, 
15433, 15432, 55048, 55073, 15415
20481, 15125, 54743, 54751, 15117, 15126, 54744, 54752, 15118, 55050, 55074, 55075, 15433, 55053, 55077, 55078, 
15435, 15434, 55051, 55076, 15417
20482, 15126, 54744, 54752, 15118, 15127, 54745, 54753, 15119, 55053, 55077, 55078, 15435, 55056, 55080, 55081, 
15437, 15436, 55054, 55079, 15419
20483, 15127, 54745, 54753, 15119, 2096, 14893, 14894, 2095, 55056, 55080, 55081, 15437, 14923, 14924, 14925, 
2118, 15438, 55057, 55082, 15421
20484, 2027, 14772, 14773, 2026, 15112, 54746, 54754, 15104, 14802, 14805, 14804, 2049, 55060, 55084, 55085, 
15406, 15405, 55058, 55083, 15388
20485, 15112, 54746, 54754, 15104, 15113, 54747, 54755, 15105, 55060, 55084, 55085, 15406, 55063, 55087, 55088, 
15408, 15407, 55061, 55086, 15390
20486, 15113, 54747, 54755, 15105, 15114, 54748, 54756, 15106, 55063, 55087, 55088, 15408, 55066, 55090, 55091, 
15410, 15409, 55064, 55089, 15392
20487, 15114, 54748, 54756, 15106, 15115, 54749, 54757, 15107, 55066, 55090, 55091, 15410, 55069, 55093, 55094, 
15412, 15411, 55067, 55092, 15394
20488, 15115, 54749, 54757, 15107, 15116, 54750, 54758, 15108, 55069, 55093, 55094, 15412, 55072, 55096, 55097, 
15414, 15413, 55070, 55095, 15396
20489, 15116, 54750, 54758, 15108, 15117, 54751, 54759, 15109, 55072, 55096, 55097, 15414, 55075, 55099, 55100, 
15416, 15415, 55073, 55098, 15398
20490, 15117, 54751, 54759, 15109, 15118, 54752, 54760, 15110, 55075, 55099, 55100, 15416, 55078, 55102, 55103, 
15418, 15417, 55076, 55101, 15400
20491, 15118, 54752, 54760, 15110, 15119, 54753, 54761, 15111, 55078, 55102, 55103, 15418, 55081, 55105, 55106, 
15420, 15419, 55079, 55104, 15402
20492, 15119, 54753, 54761, 15111, 2095, 14894, 14895, 2094, 55081, 55105, 55106, 15420, 14925, 14926, 14927, 
2117, 15421, 55082, 55107, 15404
20493, 2026, 14773, 14774, 2025, 15104, 54754, 54762, 15096, 14804, 14807, 14806, 2048, 55085, 55109, 55110, 
15389, 15388, 55083, 55108, 15371
20494, 15104, 54754, 54762, 15096, 15105, 54755, 54763, 15097, 55085, 55109, 55110, 15389, 55088, 55112, 55113, 
15391, 15390, 55086, 55111, 15373
20495, 15105, 54755, 54763, 15097, 15106, 54756, 54764, 15098, 55088, 55112, 55113, 15391, 55091, 55115, 55116, 
15393, 15392, 55089, 55114, 15375
20496, 15106, 54756, 54764, 15098, 15107, 54757, 54765, 15099, 55091, 55115, 55116, 15393, 55094, 55118, 55119, 
15395, 15394, 55092, 55117, 15377
20497, 15107, 54757, 54765, 15099, 15108, 54758, 54766, 15100, 55094, 55118, 55119, 15395, 55097, 55121, 55122, 
15397, 15396, 55095, 55120, 15379
20498, 15108, 54758, 54766, 15100, 15109, 54759, 54767, 15101, 55097, 55121, 55122, 15397, 55100, 55124, 55125, 
15399, 15398, 55098, 55123, 15381
20499, 15109, 54759, 54767, 15101, 15110, 54760, 54768, 15102, 55100, 55124, 55125, 15399, 55103, 55127, 55128, 
15401, 15400, 55101, 55126, 15383
20500, 15110, 54760, 54768, 15102, 15111, 54761, 54769, 15103, 55103, 55127, 55128, 15401, 55106, 55130, 55131, 
15403, 15402, 55104, 55129, 15385
20501, 15111, 54761, 54769, 15103, 2094, 14895, 14896, 2093, 55106, 55130, 55131, 15403, 14927, 14928, 14929, 
2116, 15404, 55107, 55132, 15387
20502, 2025, 14774, 14775, 2024, 15096, 54762, 54770, 15088, 14806, 14809, 14808, 2047, 55110, 55134, 55135, 
15372, 15371, 55108, 55133, 15354
20503, 15096, 54762, 54770, 15088, 15097, 54763, 54771, 15089, 55110, 55134, 55135, 15372, 55113, 55137, 55138, 
15374, 15373, 55111, 55136, 15356
20504, 15097, 54763, 54771, 15089, 15098, 54764, 54772, 15090, 55113, 55137, 55138, 15374, 55116, 55140, 55141, 
15376, 15375, 55114, 55139, 15358
20505, 15098, 54764, 54772, 15090, 15099, 54765, 54773, 15091, 55116, 55140, 55141, 15376, 55119, 55143, 55144, 
15378, 15377, 55117, 55142, 15360
20506, 15099, 54765, 54773, 15091, 15100, 54766, 54774, 15092, 55119, 55143, 55144, 15378, 55122, 55146, 55147, 
15380, 15379, 55120, 55145, 15362
20507, 15100, 54766, 54774, 15092, 15101, 54767, 54775, 15093, 55122, 55146, 55147, 15380, 55125, 55149, 55150, 
15382, 15381, 55123, 55148, 15364
20508, 15101, 54767, 54775, 15093, 15102, 54768, 54776, 15094, 55125, 55149, 55150, 15382, 55128, 55152, 55153, 
15384, 15383, 55126, 55151, 15366
20509, 15102, 54768, 54776, 15094, 15103, 54769, 54777, 15095, 55128, 55152, 55153, 15384, 55131, 55155, 55156, 
15386, 15385, 55129, 55154, 15368
20510, 15103, 54769, 54777, 15095, 2093, 14896, 14897, 2092, 55131, 55155, 55156, 15386, 14929, 14930, 14931, 
2115, 15387, 55132, 55157, 15370
20511, 2024, 14775, 14776, 2023, 15088, 54770, 54778, 15080, 14808, 14811, 14810, 2046, 55135, 55159, 55160, 
15355, 15354, 55133, 55158, 15337
20512, 15088, 54770, 54778, 15080, 15089, 54771, 54779, 15081, 55135, 55159, 55160, 15355, 55138, 55162, 55163, 
15357, 15356, 55136, 55161, 15339
20513, 15089, 54771, 54779, 15081, 15090, 54772, 54780, 15082, 55138, 55162, 55163, 15357, 55141, 55165, 55166, 
15359, 15358, 55139, 55164, 15341
20514, 15090, 54772, 54780, 15082, 15091, 54773, 54781, 15083, 55141, 55165, 55166, 15359, 55144, 55168, 55169, 
15361, 15360, 55142, 55167, 15343
20515, 15091, 54773, 54781, 15083, 15092, 54774, 54782, 15084, 55144, 55168, 55169, 15361, 55147, 55171, 55172, 
15363, 15362, 55145, 55170, 15345
20516, 15092, 54774, 54782, 15084, 15093, 54775, 54783, 15085, 55147, 55171, 55172, 15363, 55150, 55174, 55175, 
15365, 15364, 55148, 55173, 15347
20517, 15093, 54775, 54783, 15085, 15094, 54776, 54784, 15086, 55150, 55174, 55175, 15365, 55153, 55177, 55178, 
15367, 15366, 55151, 55176, 15349
20518, 15094, 54776, 54784, 15086, 15095, 54777, 54785, 15087, 55153, 55177, 55178, 15367, 55156, 55180, 55181, 
15369, 15368, 55154, 55179, 15351
20519, 15095, 54777, 54785, 15087, 2092, 14897, 14898, 2091, 55156, 55180, 55181, 15369, 14931, 14932, 14933, 
2114, 15370, 55157, 55182, 15353
20520, 2023, 14776, 14777, 2022, 15080, 54778, 54786, 15072, 14810, 14813, 14812, 2045, 55160, 55184, 55185, 
15338, 15337, 55158, 55183, 15320
20521, 15080, 54778, 54786, 15072, 15081, 54779, 54787, 15073, 55160, 55184, 55185, 15338, 55163, 55187, 55188, 
15340, 15339, 55161, 55186, 15322
20522, 15081, 54779, 54787, 15073, 15082, 54780, 54788, 15074, 55163, 55187, 55188, 15340, 55166, 55190, 55191, 
15342, 15341, 55164, 55189, 15324
20523, 15082, 54780, 54788, 15074, 15083, 54781, 54789, 15075, 55166, 55190, 55191, 15342, 55169, 55193, 55194, 
15344, 15343, 55167, 55192, 15326
20524, 15083, 54781, 54789, 15075, 15084, 54782, 54790, 15076, 55169, 55193, 55194, 15344, 55172, 55196, 55197, 
15346, 15345, 55170, 55195, 15328
20525, 15084, 54782, 54790, 15076, 15085, 54783, 54791, 15077, 55172, 55196, 55197, 15346, 55175, 55199, 55200, 
15348, 15347, 55173, 55198, 15330
20526, 15085, 54783, 54791, 15077, 15086, 54784, 54792, 15078, 55175, 55199, 55200, 15348, 55178, 55202, 55203, 
15350, 15349, 55176, 55201, 15332
20527, 15086, 54784, 54792, 15078, 15087, 54785, 54793, 15079, 55178, 55202, 55203, 15350, 55181, 55205, 55206, 
15352, 15351, 55179, 55204, 15334
20528, 15087, 54785, 54793, 15079, 2091, 14898, 14899, 2090, 55181, 55205, 55206, 15352, 14933, 14934, 14935, 
2113, 15353, 55182, 55207, 15336
20529, 2022, 14777, 14778, 2021, 15072, 54786, 54794, 15064, 14812, 14815, 14814, 2044, 55185, 55209, 55210, 
15321, 15320, 55183, 55208, 15303
20530, 15072, 54786, 54794, 15064, 15073, 54787, 54795, 15065, 55185, 55209, 55210, 15321, 55188, 55212, 55213, 
15323, 15322, 55186, 55211, 15305
20531, 15073, 54787, 54795, 15065, 15074, 54788, 54796, 15066, 55188, 55212, 55213, 15323, 55191, 55215, 55216, 
15325, 15324, 55189, 55214, 15307
20532, 15074, 54788, 54796, 15066, 15075, 54789, 54797, 15067, 55191, 55215, 55216, 15325, 55194, 55218, 55219, 
15327, 15326, 55192, 55217, 15309
20533, 15075, 54789, 54797, 15067, 15076, 54790, 54798, 15068, 55194, 55218, 55219, 15327, 55197, 55221, 55222, 
15329, 15328, 55195, 55220, 15311
20534, 15076, 54790, 54798, 15068, 15077, 54791, 54799, 15069, 55197, 55221, 55222, 15329, 55200, 55224, 55225, 
15331, 15330, 55198, 55223, 15313
20535, 15077, 54791, 54799, 15069, 15078, 54792, 54800, 15070, 55200, 55224, 55225, 15331, 55203, 55227, 55228, 
15333, 15332, 55201, 55226, 15315
20536, 15078, 54792, 54800, 15070, 15079, 54793, 54801, 15071, 55203, 55227, 55228, 15333, 55206, 55230, 55231, 
15335, 15334, 55204, 55229, 15317
20537, 15079, 54793, 54801, 15071, 2090, 14899, 14900, 2089, 55206, 55230, 55231, 15335, 14935, 14936, 14937, 
2112, 15336, 55207, 55232, 15319
20538, 2021, 14778, 14779, 2020, 15064, 54794, 54802, 15056, 14814, 14817, 14816, 2043, 55210, 55234, 55235, 
15304, 15303, 55208, 55233, 15286
20539, 15064, 54794, 54802, 15056, 15065, 54795, 54803, 15057, 55210, 55234, 55235, 15304, 55213, 55237, 55238, 
15306, 15305, 55211, 55236, 15288
20540, 15065, 54795, 54803, 15057, 15066, 54796, 54804, 15058, 55213, 55237, 55238, 15306, 55216, 55240, 55241, 
15308, 15307, 55214, 55239, 15290
20541, 15066, 54796, 54804, 15058, 15067, 54797, 54805, 15059, 55216, 55240, 55241, 15308, 55219, 55243, 55244, 
15310, 15309, 55217, 55242, 15292
20542, 15067, 54797, 54805, 15059, 15068, 54798, 54806, 15060, 55219, 55243, 55244, 15310, 55222, 55246, 55247, 
15312, 15311, 55220, 55245, 15294
20543, 15068, 54798, 54806, 15060, 15069, 54799, 54807, 15061, 55222, 55246, 55247, 15312, 55225, 55249, 55250, 
15314, 15313, 55223, 55248, 15296
20544, 15069, 54799, 54807, 15061, 15070, 54800, 54808, 15062, 55225, 55249, 55250, 15314, 55228, 55252, 55253, 
15316, 15315, 55226, 55251, 15298
20545, 15070, 54800, 54808, 15062, 15071, 54801, 54809, 15063, 55228, 55252, 55253, 15316, 55231, 55255, 55256, 
15318, 15317, 55229, 55254, 15300
20546, 15071, 54801, 54809, 15063, 2089, 14900, 14901, 2088, 55231, 55255, 55256, 15318, 14937, 14938, 14939, 
2111, 15319, 55232, 55257, 15302
20547, 2020, 14779, 14780, 2019, 15056, 54802, 54810, 15048, 14816, 14819, 14818, 2042, 55235, 55259, 55260, 
15287, 15286, 55233, 55258, 15269
20548, 15056, 54802, 54810, 15048, 15057, 54803, 54811, 15049, 55235, 55259, 55260, 15287, 55238, 55262, 55263, 
15289, 15288, 55236, 55261, 15271
20549, 15057, 54803, 54811, 15049, 15058, 54804, 54812, 15050, 55238, 55262, 55263, 15289, 55241, 55265, 55266, 
15291, 15290, 55239, 55264, 15273
20550, 15058, 54804, 54812, 15050, 15059, 54805, 54813, 15051, 55241, 55265, 55266, 15291, 55244, 55268, 55269, 
15293, 15292, 55242, 55267, 15275
20551, 15059, 54805, 54813, 15051, 15060, 54806, 54814, 15052, 55244, 55268, 55269, 15293, 55247, 55271, 55272, 
15295, 15294, 55245, 55270, 15277
20552, 15060, 54806, 54814, 15052, 15061, 54807, 54815, 15053, 55247, 55271, 55272, 15295, 55250, 55274, 55275, 
15297, 15296, 55248, 55273, 15279
20553, 15061, 54807, 54815, 15053, 15062, 54808, 54816, 15054, 55250, 55274, 55275, 15297, 55253, 55277, 55278, 
15299, 15298, 55251, 55276, 15281
20554, 15062, 54808, 54816, 15054, 15063, 54809, 54817, 15055, 55253, 55277, 55278, 15299, 55256, 55280, 55281, 
15301, 15300, 55254, 55279, 15283
20555, 15063, 54809, 54817, 15055, 2088, 14901, 14902, 2087, 55256, 55280, 55281, 15301, 14939, 14940, 14941, 
2110, 15302, 55257, 55282, 15285
20556, 2019, 14780, 14781, 2018, 15048, 54810, 54818, 15040, 14818, 14821, 14820, 2041, 55260, 55284, 55285, 
15270, 15269, 55258, 55283, 15252
20557, 15048, 54810, 54818, 15040, 15049, 54811, 54819, 15041, 55260, 55284, 55285, 15270, 55263, 55287, 55288, 
15272, 15271, 55261, 55286, 15254
20558, 15049, 54811, 54819, 15041, 15050, 54812, 54820, 15042, 55263, 55287, 55288, 15272, 55266, 55290, 55291, 
15274, 15273, 55264, 55289, 15256
20559, 15050, 54812, 54820, 15042, 15051, 54813, 54821, 15043, 55266, 55290, 55291, 15274, 55269, 55293, 55294, 
15276, 15275, 55267, 55292, 15258
20560, 15051, 54813, 54821, 15043, 15052, 54814, 54822, 15044, 55269, 55293, 55294, 15276, 55272, 55296, 55297, 
15278, 15277, 55270, 55295, 15260
20561, 15052, 54814, 54822, 15044, 15053, 54815, 54823, 15045, 55272, 55296, 55297, 15278, 55275, 55299, 55300, 
15280, 15279, 55273, 55298, 15262
20562, 15053, 54815, 54823, 15045, 15054, 54816, 54824, 15046, 55275, 55299, 55300, 15280, 55278, 55302, 55303, 
15282, 15281, 55276, 55301, 15264
20563, 15054, 54816, 54824, 15046, 15055, 54817, 54825, 15047, 55278, 55302, 55303, 15282, 55281, 55305, 55306, 
15284, 15283, 55279, 55304, 15266
20564, 15055, 54817, 54825, 15047, 2087, 14902, 14903, 2086, 55281, 55305, 55306, 15284, 14941, 14942, 14943, 
2109, 15285, 55282, 55307, 15268
20565, 2018, 14781, 14782, 2017, 15040, 54818, 54826, 15032, 14820, 14823, 14822, 2040, 55285, 55309, 55310, 
15253, 15252, 55283, 55308, 15235
20566, 15040, 54818, 54826, 15032, 15041, 54819, 54827, 15033, 55285, 55309, 55310, 15253, 55288, 55312, 55313, 
15255, 15254, 55286, 55311, 15237
20567, 15041, 54819, 54827, 15033, 15042, 54820, 54828, 15034, 55288, 55312, 55313, 15255, 55291, 55315, 55316, 
15257, 15256, 55289, 55314, 15239
20568, 15042, 54820, 54828, 15034, 15043, 54821, 54829, 15035, 55291, 55315, 55316, 15257, 55294, 55318, 55319, 
15259, 15258, 55292, 55317, 15241
20569, 15043, 54821, 54829, 15035, 15044, 54822, 54830, 15036, 55294, 55318, 55319, 15259, 55297, 55321, 55322, 
15261, 15260, 55295, 55320, 15243
20570, 15044, 54822, 54830, 15036, 15045, 54823, 54831, 15037, 55297, 55321, 55322, 15261, 55300, 55324, 55325, 
15263, 15262, 55298, 55323, 15245
20571, 15045, 54823, 54831, 15037, 15046, 54824, 54832, 15038, 55300, 55324, 55325, 15263, 55303, 55327, 55328, 
15265, 15264, 55301, 55326, 15247
20572, 15046, 54824, 54832, 15038, 15047, 54825, 54833, 15039, 55303, 55327, 55328, 15265, 55306, 55330, 55331, 
15267, 15266, 55304, 55329, 15249
20573, 15047, 54825, 54833, 15039, 2086, 14903, 14904, 2085, 55306, 55330, 55331, 15267, 14943, 14944, 14945, 
2108, 15268, 55307, 55332, 15251
20574, 2017, 14782, 14783, 2016, 15032, 54826, 54834, 15024, 14822, 14825, 14824, 2039, 55310, 55334, 55335, 
15236, 15235, 55308, 55333, 15218
20575, 15032, 54826, 54834, 15024, 15033, 54827, 54835, 15025, 55310, 55334, 55335, 15236, 55313, 55337, 55338, 
15238, 15237, 55311, 55336, 15220
20576, 15033, 54827, 54835, 15025, 15034, 54828, 54836, 15026, 55313, 55337, 55338, 15238, 55316, 55340, 55341, 
15240, 15239, 55314, 55339, 15222
20577, 15034, 54828, 54836, 15026, 15035, 54829, 54837, 15027, 55316, 55340, 55341, 15240, 55319, 55343, 55344, 
15242, 15241, 55317, 55342, 15224
20578, 15035, 54829, 54837, 15027, 15036, 54830, 54838, 15028, 55319, 55343, 55344, 15242, 55322, 55346, 55347, 
15244, 15243, 55320, 55345, 15226
20579, 15036, 54830, 54838, 15028, 15037, 54831, 54839, 15029, 55322, 55346, 55347, 15244, 55325, 55349, 55350, 
15246, 15245, 55323, 55348, 15228
20580, 15037, 54831, 54839, 15029, 15038, 54832, 54840, 15030, 55325, 55349, 55350, 15246, 55328, 55352, 55353, 
15248, 15247, 55326, 55351, 15230
20581, 15038, 54832, 54840, 15030, 15039, 54833, 54841, 15031, 55328, 55352, 55353, 15248, 55331, 55355, 55356, 
15250, 15249, 55329, 55354, 15232
20582, 15039, 54833, 54841, 15031, 2085, 14904, 14905, 2084, 55331, 55355, 55356, 15250, 14945, 14946, 14947, 
2107, 15251, 55332, 55357, 15234
20583, 2016, 14783, 14784, 2015, 15024, 54834, 54842, 15016, 14824, 14827, 14826, 2038, 55335, 55359, 55360, 
15219, 15218, 55333, 55358, 15201
20584, 15024, 54834, 54842, 15016, 15025, 54835, 54843, 15017, 55335, 55359, 55360, 15219, 55338, 55362, 55363, 
15221, 15220, 55336, 55361, 15203
20585, 15025, 54835, 54843, 15017, 15026, 54836, 54844, 15018, 55338, 55362, 55363, 15221, 55341, 55365, 55366, 
15223, 15222, 55339, 55364, 15205
20586, 15026, 54836, 54844, 15018, 15027, 54837, 54845, 15019, 55341, 55365, 55366, 15223, 55344, 55368, 55369, 
15225, 15224, 55342, 55367, 15207
20587, 15027, 54837, 54845, 15019, 15028, 54838, 54846, 15020, 55344, 55368, 55369, 15225, 55347, 55371, 55372, 
15227, 15226, 55345, 55370, 15209
20588, 15028, 54838, 54846, 15020, 15029, 54839, 54847, 15021, 55347, 55371, 55372, 15227, 55350, 55374, 55375, 
15229, 15228, 55348, 55373, 15211
20589, 15029, 54839, 54847, 15021, 15030, 54840, 54848, 15022, 55350, 55374, 55375, 15229, 55353, 55377, 55378, 
15231, 15230, 55351, 55376, 15213
20590, 15030, 54840, 54848, 15022, 15031, 54841, 54849, 15023, 55353, 55377, 55378, 15231, 55356, 55380, 55381, 
15233, 15232, 55354, 55379, 15215
20591, 15031, 54841, 54849, 15023, 2084, 14905, 14906, 2083, 55356, 55380, 55381, 15233, 14947, 14948, 14949, 
2106, 15234, 55357, 55382, 15217
20592, 2015, 14784, 14785, 2014, 15016, 54842, 54850, 15008, 14826, 14829, 14828, 2037, 55360, 55384, 55385, 
15202, 15201, 55358, 55383, 15184
20593, 15016, 54842, 54850, 15008, 15017, 54843, 54851, 15009, 55360, 55384, 55385, 15202, 55363, 55387, 55388, 
15204, 15203, 55361, 55386, 15186
20594, 15017, 54843, 54851, 15009, 15018, 54844, 54852, 15010, 55363, 55387, 55388, 15204, 55366, 55390, 55391, 
15206, 15205, 55364, 55389, 15188
20595, 15018, 54844, 54852, 15010, 15019, 54845, 54853, 15011, 55366, 55390, 55391, 15206, 55369, 55393, 55394, 
15208, 15207, 55367, 55392, 15190
20596, 15019, 54845, 54853, 15011, 15020, 54846, 54854, 15012, 55369, 55393, 55394, 15208, 55372, 55396, 55397, 
15210, 15209, 55370, 55395, 15192
20597, 15020, 54846, 54854, 15012, 15021, 54847, 54855, 15013, 55372, 55396, 55397, 15210, 55375, 55399, 55400, 
15212, 15211, 55373, 55398, 15194
20598, 15021, 54847, 54855, 15013, 15022, 54848, 54856, 15014, 55375, 55399, 55400, 15212, 55378, 55402, 55403, 
15214, 15213, 55376, 55401, 15196
20599, 15022, 54848, 54856, 15014, 15023, 54849, 54857, 15015, 55378, 55402, 55403, 15214, 55381, 55405, 55406, 
15216, 15215, 55379, 55404, 15198
20600, 15023, 54849, 54857, 15015, 2083, 14906, 14907, 2082, 55381, 55405, 55406, 15216, 14949, 14950, 14951, 
2105, 15217, 55382, 55407, 15200
20601, 2014, 14785, 2011, 68, 15008, 54850, 14982, 2127, 14828, 14830, 2012, 2036, 55385, 55408, 14998, 
15185, 15184, 55383, 14999, 2135
20602, 15008, 54850, 14982, 2127, 15009, 54851, 14981, 2128, 55385, 55408, 14998, 15185, 55388, 55409, 14996, 
15187, 15186, 55386, 14997, 2136
20603, 15009, 54851, 14981, 2128, 15010, 54852, 14980, 2129, 55388, 55409, 14996, 15187, 55391, 55410, 14994, 
15189, 15188, 55389, 14995, 2137
20604, 15010, 54852, 14980, 2129, 15011, 54853, 14979, 2130, 55391, 55410, 14994, 15189, 55394, 55411, 14992, 
15191, 15190, 55392, 14993, 2138
20605, 15011, 54853, 14979, 2130, 15012, 54854, 14978, 2131, 55394, 55411, 14992, 15191, 55397, 55412, 14990, 
15193, 15192, 55395, 14991, 2139
20606, 15012, 54854, 14978, 2131, 15013, 54855, 14977, 2132, 55397, 55412, 14990, 15193, 55400, 55413, 14988, 
15195, 15194, 55398, 14989, 2140
20607, 15013, 54855, 14977, 2132, 15014, 54856, 14976, 2133, 55400, 55413, 14988, 15195, 55403, 55414, 14986, 
15197, 15196, 55401, 14987, 2141
20608, 15014, 54856, 14976, 2133, 15015, 54857, 14975, 2134, 55403, 55414, 14986, 15197, 55406, 55415, 14984, 
15199, 15198, 55404, 14985, 2142
20609, 15015, 54857, 14975, 2134, 2082, 14907, 2079, 70, 55406, 55415, 14984, 15199, 14951, 14952, 2080, 
2104, 15200, 55407, 14983, 2143
20610, 2008, 45, 1442, 14764, 14860, 1516, 11969, 54682, 2010, 1465, 14831, 14787, 14885, 12351, 55416, 
54859, 14877, 1524, 12334, 54858
20611, 14860, 1516, 11969, 54682, 14859, 1517, 11970, 54683, 14885, 12351, 55416, 54859, 14884, 12352, 55417, 
54862, 14876, 1525, 12336, 54861
20612, 14859, 1517, 11970, 54683, 14858, 1518, 11971, 54684, 14884, 12352, 55417, 54862, 14883, 12353, 55418, 
54865, 14874, 1526, 12338, 54864
20613, 14858, 1518, 11971, 54684, 14857, 1519, 11972, 54685, 14883, 12353, 55418, 54865, 14882, 12354, 55419, 
54868, 14872, 1527, 12340, 54867
20614, 14857, 1519, 11972, 54685, 14856, 1520, 11973, 54686, 14882, 12354, 55419, 54868, 14881, 12355, 55420, 
54871, 14870, 1528, 12342, 54870
20615, 14856, 1520, 11973, 54686, 14855, 1521, 11974, 54687, 14881, 12355, 55420, 54871, 14880, 12356, 55421, 
54874, 14868, 1529, 12344, 54873
20616, 14855, 1521, 11974, 54687, 14854, 1522, 11975, 54688, 14880, 12356, 55421, 54874, 14879, 12357, 55422, 
54877, 14866, 1530, 12346, 54876
20617, 14854, 1522, 11975, 54688, 14853, 1523, 11976, 54689, 14879, 12357, 55422, 54877, 14878, 12358, 55423, 
54880, 14864, 1531, 12348, 54879
20618, 14853, 1523, 11976, 54689, 2059, 49, 1576, 14886, 14878, 12358, 55423, 54880, 2061, 1599, 14953, 
14908, 14862, 1532, 12350, 54882
20619, 14764, 1442, 1441, 14765, 54682, 11969, 11961, 54690, 14831, 1464, 14832, 14789, 55416, 12335, 55424, 
54884, 54858, 12334, 12317, 54883
20620, 54682, 11969, 11961, 54690, 54683, 11970, 11962, 54691, 55416, 12335, 55424, 54884, 55417, 12337, 55425, 
54887, 54861, 12336, 12319, 54886
20621, 54683, 11970, 11962, 54691, 54684, 11971, 11963, 54692, 55417, 12337, 55425, 54887, 55418, 12339, 55426, 
54890, 54864, 12338, 12321, 54889
20622, 54684, 11971, 11963, 54692, 54685, 11972, 11964, 54693, 55418, 12339, 55426, 54890, 55419, 12341, 55427, 
54893, 54867, 12340, 12323, 54892
20623, 54685, 11972, 11964, 54693, 54686, 11973, 11965, 54694, 55419, 12341, 55427, 54893, 55420, 12343, 55428, 
54896, 54870, 12342, 12325, 54895
20624, 54686, 11973, 11965, 54694, 54687, 11974, 11966, 54695, 55420, 12343, 55428, 54896, 55421, 12345, 55429, 
54899, 54873, 12344, 12327, 54898
20625, 54687, 11974, 11966, 54695, 54688, 11975, 11967, 54696, 55421, 12345, 55429, 54899, 55422, 12347, 55430, 
54902, 54876, 12346, 12329, 54901
20626, 54688, 11975, 11967, 54696, 54689, 11976, 11968, 54697, 55422, 12347, 55430, 54902, 55423, 12349, 55431, 
54905, 54879, 12348, 12331, 54904
20627, 54689, 11976, 11968, 54697, 14886, 1576, 1575, 14887, 55423, 12349, 55431, 54905, 14953, 1598, 14954, 
14910, 54882, 12350, 12333, 54907
20628, 14765, 1441, 1440, 14766, 54690, 11961, 11953, 54698, 14832, 1463, 14833, 14791, 55424, 12318, 55432, 
54909, 54883, 12317, 12300, 54908
20629, 54690, 11961, 11953, 54698, 54691, 11962, 11954, 54699, 55424, 12318, 55432, 54909, 55425, 12320, 55433, 
54912, 54886, 12319, 12302, 54911
20630, 54691, 11962, 11954, 54699, 54692, 11963, 11955, 54700, 55425, 12320, 55433, 54912, 55426, 12322, 55434, 
54915, 54889, 12321, 12304, 54914
20631, 54692, 11963, 11955, 54700, 54693, 11964, 11956, 54701, 55426, 12322, 55434, 54915, 55427, 12324, 55435, 
54918, 54892, 12323, 12306, 54917
20632, 54693, 11964, 11956, 54701, 54694, 11965, 11957, 54702, 55427, 12324, 55435, 54918, 55428, 12326, 55436, 
54921, 54895, 12325, 12308, 54920
20633, 54694, 11965, 11957, 54702, 54695, 11966, 11958, 54703, 55428, 12326, 55436, 54921, 55429, 12328, 55437, 
54924, 54898, 12327, 12310, 54923
20634, 54695, 11966, 11958, 54703, 54696, 11967, 11959, 54704, 55429, 12328, 55437, 54924, 55430, 12330, 55438, 
54927, 54901, 12329, 12312, 54926
20635, 54696, 11967, 11959, 54704, 54697, 11968, 11960, 54705, 55430, 12330, 55438, 54927, 55431, 12332, 55439, 
54930, 54904, 12331, 12314, 54929
20636, 54697, 11968, 11960, 54705, 14887, 1575, 1574, 14888, 55431, 12332, 55439, 54930, 14954, 1597, 14955, 
14912, 54907, 12333, 12316, 54932
20637, 14766, 1440, 1439, 14767, 54698, 11953, 11945, 54706, 14833, 1462, 14834, 14793, 55432, 12301, 55440, 
54934, 54908, 12300, 12283, 54933
20638, 54698, 11953, 11945, 54706, 54699, 11954, 11946, 54707, 55432, 12301, 55440, 54934, 55433, 12303, 55441, 
54937, 54911, 12302, 12285, 54936
20639, 54699, 11954, 11946, 54707, 54700, 11955, 11947, 54708, 55433, 12303, 55441, 54937, 55434, 12305, 55442, 
54940, 54914, 12304, 12287, 54939
20640, 54700, 11955, 11947, 54708, 54701, 11956, 11948, 54709, 55434, 12305, 55442, 54940, 55435, 12307, 55443, 
54943, 54917, 12306, 12289, 54942
20641, 54701, 11956, 11948, 54709, 54702, 11957, 11949, 54710, 55435, 12307, 55443, 54943, 55436, 12309, 55444, 
54946, 54920, 12308, 12291, 54945
20642, 54702, 11957, 11949, 54710, 54703, 11958, 11950, 54711, 55436, 12309, 55444, 54946, 55437, 12311, 55445, 
54949, 54923, 12310, 12293, 54948
20643, 54703, 11958, 11950, 54711, 54704, 11959, 11951, 54712, 55437, 12311, 55445, 54949, 55438, 12313, 55446, 
54952, 54926, 12312, 12295, 54951
20644, 54704, 11959, 11951, 54712, 54705, 11960, 11952, 54713, 55438, 12313, 55446, 54952, 55439, 12315, 55447, 
54955, 54929, 12314, 12297, 54954
20645, 54705, 11960, 11952, 54713, 14888, 1574, 1573, 14889, 55439, 12315, 55447, 54955, 14955, 1596, 14956, 
14914, 54932, 12316, 12299, 54957
20646, 14767, 1439, 1438, 14768, 54706, 11945, 11937, 54714, 14834, 1461, 14835, 14795, 55440, 12284, 55448, 
54959, 54933, 12283, 12266, 54958
20647, 54706, 11945, 11937, 54714, 54707, 11946, 11938, 54715, 55440, 12284, 55448, 54959, 55441, 12286, 55449, 
54962, 54936, 12285, 12268, 54961
20648, 54707, 11946, 11938, 54715, 54708, 11947, 11939, 54716, 55441, 12286, 55449, 54962, 55442, 12288, 55450, 
54965, 54939, 12287, 12270, 54964
20649, 54708, 11947, 11939, 54716, 54709, 11948, 11940, 54717, 55442, 12288, 55450, 54965, 55443, 12290, 55451, 
54968, 54942, 12289, 12272, 54967
20650, 54709, 11948, 11940, 54717, 54710, 11949, 11941, 54718, 55443, 12290, 55451, 54968, 55444, 12292, 55452, 
54971, 54945, 12291, 12274, 54970
20651, 54710, 11949, 11941, 54718, 54711, 11950, 11942, 54719, 55444, 12292, 55452, 54971, 55445, 12294, 55453, 
54974, 54948, 12293, 12276, 54973
20652, 54711, 11950, 11942, 54719, 54712, 11951, 11943, 54720, 55445, 12294, 55453, 54974, 55446, 12296, 55454, 
54977, 54951, 12295, 12278, 54976
20653, 54712, 11951, 11943, 54720, 54713, 11952, 11944, 54721, 55446, 12296, 55454, 54977, 55447, 12298, 55455, 
54980, 54954, 12297, 12280, 54979
20654, 54713, 11952, 11944, 54721, 14889, 1573, 1572, 14890, 55447, 12298, 55455, 54980, 14956, 1595, 14957, 
14916, 54957, 12299, 12282, 54982
20655, 14768, 1438, 1437, 14769, 54714, 11937, 11929, 54722, 14835, 1460, 14836, 14797, 55448, 12267, 55456, 
54984, 54958, 12266, 12249, 54983
20656, 54714, 11937, 11929, 54722, 54715, 11938, 11930, 54723, 55448, 12267, 55456, 54984, 55449, 12269, 55457, 
54987, 54961, 12268, 12251, 54986
20657, 54715, 11938, 11930, 54723, 54716, 11939, 11931, 54724, 55449, 12269, 55457, 54987, 55450, 12271, 55458, 
54990, 54964, 12270, 12253, 54989
20658, 54716, 11939, 11931, 54724, 54717, 11940, 11932, 54725, 55450, 12271, 55458, 54990, 55451, 12273, 55459, 
54993, 54967, 12272, 12255, 54992
20659, 54717, 11940, 11932, 54725, 54718, 11941, 11933, 54726, 55451, 12273, 55459, 54993, 55452, 12275, 55460, 
54996, 54970, 12274, 12257, 54995
20660, 54718, 11941, 11933, 54726, 54719, 11942, 11934, 54727, 55452, 12275, 55460, 54996, 55453, 12277, 55461, 
54999, 54973, 12276, 12259, 54998
20661, 54719, 11942, 11934, 54727, 54720, 11943, 11935, 54728, 55453, 12277, 55461, 54999, 55454, 12279, 55462, 
55002, 54976, 12278, 12261, 55001
20662, 54720, 11943, 11935, 54728, 54721, 11944, 11936, 54729, 55454, 12279, 55462, 55002, 55455, 12281, 55463, 
55005, 54979, 12280, 12263, 55004
20663, 54721, 11944, 11936, 54729, 14890, 1572, 1571, 14891, 55455, 12281, 55463, 55005, 14957, 1594, 14958, 
14918, 54982, 12282, 12265, 55007
20664, 14769, 1437, 1436, 14770, 54722, 11929, 11921, 54730, 14836, 1459, 14837, 14799, 55456, 12250, 55464, 
55009, 54983, 12249, 12232, 55008
20665, 54722, 11929, 11921, 54730, 54723, 11930, 11922, 54731, 55456, 12250, 55464, 55009, 55457, 12252, 55465, 
55012, 54986, 12251, 12234, 55011
20666, 54723, 11930, 11922, 54731, 54724, 11931, 11923, 54732, 55457, 12252, 55465, 55012, 55458, 12254, 55466, 
55015, 54989, 12253, 12236, 55014
20667, 54724, 11931, 11923, 54732, 54725, 11932, 11924, 54733, 55458, 12254, 55466, 55015, 55459, 12256, 55467, 
55018, 54992, 12255, 12238, 55017
20668, 54725, 11932, 11924, 54733, 54726, 11933, 11925, 54734, 55459, 12256, 55467, 55018, 55460, 12258, 55468, 
55021, 54995, 12257, 12240, 55020
20669, 54726, 11933, 11925, 54734, 54727, 11934, 11926, 54735, 55460, 12258, 55468, 55021, 55461, 12260, 55469, 
55024, 54998, 12259, 12242, 55023
20670, 54727, 11934, 11926, 54735, 54728, 11935, 11927, 54736, 55461, 12260, 55469, 55024, 55462, 12262, 55470, 
55027, 55001, 12261, 12244, 55026
20671, 54728, 11935, 11927, 54736, 54729, 11936, 11928, 54737, 55462, 12262, 55470, 55027, 55463, 12264, 55471, 
55030, 55004, 12263, 12246, 55029
20672, 54729, 11936, 11928, 54737, 14891, 1571, 1570, 14892, 55463, 12264, 55471, 55030, 14958, 1593, 14959, 
14920, 55007, 12265, 12248, 55032
20673, 14770, 1436, 1435, 14771, 54730, 11921, 11913, 54738, 14837, 1458, 14838, 14801, 55464, 12233, 55472, 
55034, 55008, 12232, 12215, 55033
20674, 54730, 11921, 11913, 54738, 54731, 11922, 11914, 54739, 55464, 12233, 55472, 55034, 55465, 12235, 55473, 
55037, 55011, 12234, 12217, 55036
20675, 54731, 11922, 11914, 54739, 54732, 11923, 11915, 54740, 55465, 12235, 55473, 55037, 55466, 12237, 55474, 
55040, 55014, 12236, 12219, 55039
20676, 54732, 11923, 11915, 54740, 54733, 11924, 11916, 54741, 55466, 12237, 55474, 55040, 55467, 12239, 55475, 
55043, 55017, 12238, 12221, 55042
20677, 54733, 11924, 11916, 54741, 54734, 11925, 11917, 54742, 55467, 12239, 55475, 55043, 55468, 12241, 55476, 
55046, 55020, 12240, 12223, 55045
20678, 54734, 11925, 11917, 54742, 54735, 11926, 11918, 54743, 55468, 12241, 55476, 55046, 55469, 12243, 55477, 
55049, 55023, 12242, 12225, 55048
20679, 54735, 11926, 11918, 54743, 54736, 11927, 11919, 54744, 55469, 12243, 55477, 55049, 55470, 12245, 55478, 
55052, 55026, 12244, 12227, 55051
20680, 54736, 11927, 11919, 54744, 54737, 11928, 11920, 54745, 55470, 12245, 55478, 55052, 55471, 12247, 55479, 
55055, 55029, 12246, 12229, 55054
20681, 54737, 11928, 11920, 54745, 14892, 1570, 1569, 14893, 55471, 12247, 55479, 55055, 14959, 1592, 14960, 
14922, 55032, 12248, 12231, 55057
20682, 14771, 1435, 1434, 14772, 54738, 11913, 11905, 54746, 14838, 1457, 14839, 14803, 55472, 12216, 55480, 
55059, 55033, 12215, 12198, 55058
20683, 54738, 11913, 11905, 54746, 54739, 11914, 11906, 54747, 55472, 12216, 55480, 55059, 55473, 12218, 55481, 
55062, 55036, 12217, 12200, 55061
20684, 54739, 11914, 11906, 54747, 54740, 11915, 11907, 54748, 55473, 12218, 55481, 55062, 55474, 12220, 55482, 
55065, 55039, 12219, 12202, 55064
20685, 54740, 11915, 11907, 54748, 54741, 11916, 11908, 54749, 55474, 12220, 55482, 55065, 55475, 12222, 55483, 
55068, 55042, 12221, 12204, 55067
20686, 54741, 11916, 11908, 54749, 54742, 11917, 11909, 54750, 55475, 12222, 55483, 55068, 55476, 12224, 55484, 
55071, 55045, 12223, 12206, 55070
20687, 54742, 11917, 11909, 54750, 54743, 11918, 11910, 54751, 55476, 12224, 55484, 55071, 55477, 12226, 55485, 
55074, 55048, 12225, 12208, 55073
20688, 54743, 11918, 11910, 54751, 54744, 11919, 11911, 54752, 55477, 12226, 55485, 55074, 55478, 12228, 55486, 
55077, 55051, 12227, 12210, 55076
20689, 54744, 11919, 11911, 54752, 54745, 11920, 11912, 54753, 55478, 12228, 55486, 55077, 55479, 12230, 55487, 
55080, 55054, 12229, 12212, 55079
20690, 54745, 11920, 11912, 54753, 14893, 1569, 1568, 14894, 55479, 12230, 55487, 55080, 14960, 1591, 14961, 
14924, 55057, 12231, 12214, 55082
20691, 14772, 1434, 1433, 14773, 54746, 11905, 11897, 54754, 14839, 1456, 14840, 14805, 55480, 12199, 55488, 
55084, 55058, 12198, 12181, 55083
20692, 54746, 11905, 11897, 54754, 54747, 11906, 11898, 54755, 55480, 12199, 55488, 55084, 55481, 12201, 55489, 
55087, 55061, 12200, 12183, 55086
20693, 54747, 11906, 11898, 54755, 54748, 11907, 11899, 54756, 55481, 12201, 55489, 55087, 55482, 12203, 55490, 
55090, 55064, 12202, 12185, 55089
20694, 54748, 11907, 11899, 54756, 54749, 11908, 11900, 54757, 55482, 12203, 55490, 55090, 55483, 12205, 55491, 
55093, 55067, 12204, 12187, 55092
20695, 54749, 11908, 11900, 54757, 54750, 11909, 11901, 54758, 55483, 12205, 55491, 55093, 55484, 12207, 55492, 
55096, 55070, 12206, 12189, 55095
20696, 54750, 11909, 11901, 54758, 54751, 11910, 11902, 54759, 55484, 12207, 55492, 55096, 55485, 12209, 55493, 
55099, 55073, 12208, 12191, 55098
20697, 54751, 11910, 11902, 54759, 54752, 11911, 11903, 54760, 55485, 12209, 55493, 55099, 55486, 12211, 55494, 
55102, 55076, 12210, 12193, 55101
20698, 54752, 11911, 11903, 54760, 54753, 11912, 11904, 54761, 55486, 12211, 55494, 55102, 55487, 12213, 55495, 
55105, 55079, 12212, 12195, 55104
20699, 54753, 11912, 11904, 54761, 14894, 1568, 1567, 14895, 55487, 12213, 55495, 55105, 14961, 1590, 14962, 
14926, 55082, 12214, 12197, 55107
20700, 14773, 1433, 1432, 14774, 54754, 11897, 11889, 54762, 14840, 1455, 14841, 14807, 55488, 12182, 55496, 
55109, 55083, 12181, 12164, 55108
20701, 54754, 11897, 11889, 54762, 54755, 11898, 11890, 54763, 55488, 12182, 55496, 55109, 55489, 12184, 55497, 
55112, 55086, 12183, 12166, 55111
20702, 54755, 11898, 11890, 54763, 54756, 11899, 11891, 54764, 55489, 12184, 55497, 55112, 55490, 12186, 55498, 
55115, 55089, 12185, 12168, 55114
20703, 54756, 11899, 11891, 54764, 54757, 11900, 11892, 54765, 55490, 12186, 55498, 55115, 55491, 12188, 55499, 
55118, 55092, 12187, 12170, 55117
20704, 54757, 11900, 11892, 54765, 54758, 11901, 11893, 54766, 55491, 12188, 55499, 55118, 55492, 12190, 55500, 
55121, 55095, 12189, 12172, 55120
20705, 54758, 11901, 11893, 54766, 54759, 11902, 11894, 54767, 55492, 12190, 55500, 55121, 55493, 12192, 55501, 
55124, 55098, 12191, 12174, 55123
20706, 54759, 11902, 11894, 54767, 54760, 11903, 11895, 54768, 55493, 12192, 55501, 55124, 55494, 12194, 55502, 
55127, 55101, 12193, 12176, 55126
20707, 54760, 11903, 11895, 54768, 54761, 11904, 11896, 54769, 55494, 12194, 55502, 55127, 55495, 12196, 55503, 
55130, 55104, 12195, 12178, 55129
20708, 54761, 11904, 11896, 54769, 14895, 1567, 1566, 14896, 55495, 12196, 55503, 55130, 14962, 1589, 14963, 
14928, 55107, 12197, 12180, 55132
20709, 14774, 1432, 1431, 14775, 54762, 11889, 11881, 54770, 14841, 1454, 14842, 14809, 55496, 12165, 55504, 
55134, 55108, 12164, 12147, 55133
20710, 54762, 11889, 11881, 54770, 54763, 11890, 11882, 54771, 55496, 12165, 55504, 55134, 55497, 12167, 55505, 
55137, 55111, 12166, 12149, 55136
20711, 54763, 11890, 11882, 54771, 54764, 11891, 11883, 54772, 55497, 12167, 55505, 55137, 55498, 12169, 55506, 
55140, 55114, 12168, 12151, 55139
20712, 54764, 11891, 11883, 54772, 54765, 11892, 11884, 54773, 55498, 12169, 55506, 55140, 55499, 12171, 55507, 
55143, 55117, 12170, 12153, 55142
20713, 54765, 11892, 11884, 54773, 54766, 11893, 11885, 54774, 55499, 12171, 55507, 55143, 55500, 12173, 55508, 
55146, 55120, 12172, 12155, 55145
20714, 54766, 11893, 11885, 54774, 54767, 11894, 11886, 54775, 55500, 12173, 55508, 55146, 55501, 12175, 55509, 
55149, 55123, 12174, 12157, 55148
20715, 54767, 11894, 11886, 54775, 54768, 11895, 11887, 54776, 55501, 12175, 55509, 55149, 55502, 12177, 55510, 
55152, 55126, 12176, 12159, 55151
20716, 54768, 11895, 11887, 54776, 54769, 11896, 11888, 54777, 55502, 12177, 55510, 55152, 55503, 12179, 55511, 
55155, 55129, 12178, 12161, 55154
20717, 54769, 11896, 11888, 54777, 14896, 1566, 1565, 14897, 55503, 12179, 55511, 55155, 14963, 1588, 14964, 
14930, 55132, 12180, 12163, 55157
20718, 14775, 1431, 1430, 14776, 54770, 11881, 11873, 54778, 14842, 1453, 14843, 14811, 55504, 12148, 55512, 
55159, 55133, 12147, 12130, 55158
20719, 54770, 11881, 11873, 54778, 54771, 11882, 11874, 54779, 55504, 12148, 55512, 55159, 55505, 12150, 55513, 
55162, 55136, 12149, 12132, 55161
20720, 54771, 11882, 11874, 54779, 54772, 11883, 11875, 54780, 55505, 12150, 55513, 55162, 55506, 12152, 55514, 
55165, 55139, 12151, 12134, 55164
20721, 54772, 11883, 11875, 54780, 54773, 11884, 11876, 54781, 55506, 12152, 55514, 55165, 55507, 12154, 55515, 
55168, 55142, 12153, 12136, 55167
20722, 54773, 11884, 11876, 54781, 54774, 11885, 11877, 54782, 55507, 12154, 55515, 55168, 55508, 12156, 55516, 
55171, 55145, 12155, 12138, 55170
20723, 54774, 11885, 11877, 54782, 54775, 11886, 11878, 54783, 55508, 12156, 55516, 55171, 55509, 12158, 55517, 
55174, 55148, 12157, 12140, 55173
20724, 54775, 11886, 11878, 54783, 54776, 11887, 11879, 54784, 55509, 12158, 55517, 55174, 55510, 12160, 55518, 
55177, 55151, 12159, 12142, 55176
20725, 54776, 11887, 11879, 54784, 54777, 11888, 11880, 54785, 55510, 12160, 55518, 55177, 55511, 12162, 55519, 
55180, 55154, 12161, 12144, 55179
20726, 54777, 11888, 11880, 54785, 14897, 1565, 1564, 14898, 55511, 12162, 55519, 55180, 14964, 1587, 14965, 
14932, 55157, 12163, 12146, 55182
20727, 14776, 1430, 1429, 14777, 54778, 11873, 11865, 54786, 14843, 1452, 14844, 14813, 55512, 12131, 55520, 
55184, 55158, 12130, 12113, 55183
20728, 54778, 11873, 11865, 54786, 54779, 11874, 11866, 54787, 55512, 12131, 55520, 55184, 55513, 12133, 55521, 
55187, 55161, 12132, 12115, 55186
20729, 54779, 11874, 11866, 54787, 54780, 11875, 11867, 54788, 55513, 12133, 55521, 55187, 55514, 12135, 55522, 
55190, 55164, 12134, 12117, 55189
20730, 54780, 11875, 11867, 54788, 54781, 11876, 11868, 54789, 55514, 12135, 55522, 55190, 55515, 12137, 55523, 
55193, 55167, 12136, 12119, 55192
20731, 54781, 11876, 11868, 54789, 54782, 11877, 11869, 54790, 55515, 12137, 55523, 55193, 55516, 12139, 55524, 
55196, 55170, 12138, 12121, 55195
20732, 54782, 11877, 11869, 54790, 54783, 11878, 11870, 54791, 55516, 12139, 55524, 55196, 55517, 12141, 55525, 
55199, 55173, 12140, 12123, 55198
20733, 54783, 11878, 11870, 54791, 54784, 11879, 11871, 54792, 55517, 12141, 55525, 55199, 55518, 12143, 55526, 
55202, 55176, 12142, 12125, 55201
20734, 54784, 11879, 11871, 54792, 54785, 11880, 11872, 54793, 55518, 12143, 55526, 55202, 55519, 12145, 55527, 
55205, 55179, 12144, 12127, 55204
20735, 54785, 11880, 11872, 54793, 14898, 1564, 1563, 14899, 55519, 12145, 55527, 55205, 14965, 1586, 14966, 
14934, 55182, 12146, 12129, 55207
20736, 14777, 1429, 1428, 14778, 54786, 11865, 11857, 54794, 14844, 1451, 14845, 14815, 55520, 12114, 55528, 
55209, 55183, 12113, 12096, 55208
20737, 54786, 11865, 11857, 54794, 54787, 11866, 11858, 54795, 55520, 12114, 55528, 55209, 55521, 12116, 55529, 
55212, 55186, 12115, 12098, 55211
20738, 54787, 11866, 11858, 54795, 54788, 11867, 11859, 54796, 55521, 12116, 55529, 55212, 55522, 12118, 55530, 
55215, 55189, 12117, 12100, 55214
20739, 54788, 11867, 11859, 54796, 54789, 11868, 11860, 54797, 55522, 12118, 55530, 55215, 55523, 12120, 55531, 
55218, 55192, 12119, 12102, 55217
20740, 54789, 11868, 11860, 54797, 54790, 11869, 11861, 54798, 55523, 12120, 55531, 55218, 55524, 12122, 55532, 
55221, 55195, 12121, 12104, 55220
20741, 54790, 11869, 11861, 54798, 54791, 11870, 11862, 54799, 55524, 12122, 55532, 55221, 55525, 12124, 55533, 
55224, 55198, 12123, 12106, 55223
20742, 54791, 11870, 11862, 54799, 54792, 11871, 11863, 54800, 55525, 12124, 55533, 55224, 55526, 12126, 55534, 
55227, 55201, 12125, 12108, 55226
20743, 54792, 11871, 11863, 54800, 54793, 11872, 11864, 54801, 55526, 12126, 55534, 55227, 55527, 12128, 55535, 
55230, 55204, 12127, 12110, 55229
20744, 54793, 11872, 11864, 54801, 14899, 1563, 1562, 14900, 55527, 12128, 55535, 55230, 14966, 1585, 14967, 
14936, 55207, 12129, 12112, 55232
20745, 14778, 1428, 1427, 14779, 54794, 11857, 11849, 54802, 14845, 1450, 14846, 14817, 55528, 12097, 55536, 
55234, 55208, 12096, 12079, 55233
20746, 54794, 11857, 11849, 54802, 54795, 11858, 11850, 54803, 55528, 12097, 55536, 55234, 55529, 12099, 55537, 
55237, 55211, 12098, 12081, 55236
20747, 54795, 11858, 11850, 54803, 54796, 11859, 11851, 54804, 55529, 12099, 55537, 55237, 55530, 12101, 55538, 
55240, 55214, 12100, 12083, 55239
20748, 54796, 11859, 11851, 54804, 54797, 11860, 11852, 54805, 55530, 12101, 55538, 55240, 55531, 12103, 55539, 
55243, 55217, 12102, 12085, 55242
20749, 54797, 11860, 11852, 54805, 54798, 11861, 11853, 54806, 55531, 12103, 55539, 55243, 55532, 12105, 55540, 
55246, 55220, 12104, 12087, 55245
20750, 54798, 11861, 11853, 54806, 54799, 11862, 11854, 54807, 55532, 12105, 55540, 55246, 55533, 12107, 55541, 
55249, 55223, 12106, 12089, 55248
20751, 54799, 11862, 11854, 54807, 54800, 11863, 11855, 54808, 55533, 12107, 55541, 55249, 55534, 12109, 55542, 
55252, 55226, 12108, 12091, 55251
20752, 54800, 11863, 11855, 54808, 54801, 11864, 11856, 54809, 55534, 12109, 55542, 55252, 55535, 12111, 55543, 
55255, 55229, 12110, 12093, 55254
20753, 54801, 11864, 11856, 54809, 14900, 1562, 1561, 14901, 55535, 12111, 55543, 55255, 14967, 1584, 14968, 
14938, 55232, 12112, 12095, 55257
20754, 14779, 1427, 1426, 14780, 54802, 11849, 11841, 54810, 14846, 1449, 14847, 14819, 55536, 12080, 55544, 
55259, 55233, 12079, 12062, 55258
20755, 54802, 11849, 11841, 54810, 54803, 11850, 11842, 54811, 55536, 12080, 55544, 55259, 55537, 12082, 55545, 
55262, 55236, 12081, 12064, 55261
20756, 54803, 11850, 11842, 54811, 54804, 11851, 11843, 54812, 55537, 12082, 55545, 55262, 55538, 12084, 55546, 
55265, 55239, 12083, 12066, 55264
20757, 54804, 11851, 11843, 54812, 54805, 11852, 11844, 54813, 55538, 12084, 55546, 55265, 55539, 12086, 55547, 
55268, 55242, 12085, 12068, 55267
20758, 54805, 11852, 11844, 54813, 54806, 11853, 11845, 54814, 55539, 12086, 55547, 55268, 55540, 12088, 55548, 
55271, 55245, 12087, 12070, 55270
20759, 54806, 11853, 11845, 54814, 54807, 11854, 11846, 54815, 55540, 12088, 55548, 55271, 55541, 12090, 55549, 
55274, 55248, 12089, 12072, 55273
20760, 54807, 11854, 11846, 54815, 54808, 11855, 11847, 54816, 55541, 12090, 55549, 55274, 55542, 12092, 55550, 
55277, 55251, 12091, 12074, 55276
20761, 54808, 11855, 11847, 54816, 54809, 11856, 11848, 54817, 55542, 12092, 55550, 55277, 55543, 12094, 55551, 
55280, 55254, 12093, 12076, 55279
20762, 54809, 11856, 11848, 54817, 14901, 1561, 1560, 14902, 55543, 12094, 55551, 55280, 14968, 1583, 14969, 
14940, 55257, 12095, 12078, 55282
20763, 14780, 1426, 1425, 14781, 54810, 11841, 11833, 54818, 14847, 1448, 14848, 14821, 55544, 12063, 55552, 
55284, 55258, 12062, 12045, 55283
20764, 54810, 11841, 11833, 54818, 54811, 11842, 11834, 54819, 55544, 12063, 55552, 55284, 55545, 12065, 55553, 
55287, 55261, 12064, 12047, 55286
20765, 54811, 11842, 11834, 54819, 54812, 11843, 11835, 54820, 55545, 12065, 55553, 55287, 55546, 12067, 55554, 
55290, 55264, 12066, 12049, 55289
20766, 54812, 11843, 11835, 54820, 54813, 11844, 11836, 54821, 55546, 12067, 55554, 55290, 55547, 12069, 55555, 
55293, 55267, 12068, 12051, 55292
20767, 54813, 11844, 11836, 54821, 54814, 11845, 11837, 54822, 55547, 12069, 55555, 55293, 55548, 12071, 55556, 
55296, 55270, 12070, 12053, 55295
20768, 54814, 11845, 11837, 54822, 54815, 11846, 11838, 54823, 55548, 12071, 55556, 55296, 55549, 12073, 55557, 
55299, 55273, 12072, 12055, 55298
20769, 54815, 11846, 11838, 54823, 54816, 11847, 11839, 54824, 55549, 12073, 55557, 55299, 55550, 12075, 55558, 
55302, 55276, 12074, 12057, 55301
20770, 54816, 11847, 11839, 54824, 54817, 11848, 11840, 54825, 55550, 12075, 55558, 55302, 55551, 12077, 55559, 
55305, 55279, 12076, 12059, 55304
20771, 54817, 11848, 11840, 54825, 14902, 1560, 1559, 14903, 55551, 12077, 55559, 55305, 14969, 1582, 14970, 
14942, 55282, 12078, 12061, 55307
20772, 14781, 1425, 1424, 14782, 54818, 11833, 11825, 54826, 14848, 1447, 14849, 14823, 55552, 12046, 55560, 
55309, 55283, 12045, 12028, 55308
20773, 54818, 11833, 11825, 54826, 54819, 11834, 11826, 54827, 55552, 12046, 55560, 55309, 55553, 12048, 55561, 
55312, 55286, 12047, 12030, 55311
20774, 54819, 11834, 11826, 54827, 54820, 11835, 11827, 54828, 55553, 12048, 55561, 55312, 55554, 12050, 55562, 
55315, 55289, 12049, 12032, 55314
20775, 54820, 11835, 11827, 54828, 54821, 11836, 11828, 54829, 55554, 12050, 55562, 55315, 55555, 12052, 55563, 
55318, 55292, 12051, 12034, 55317
20776, 54821, 11836, 11828, 54829, 54822, 11837, 11829, 54830, 55555, 12052, 55563, 55318, 55556, 12054, 55564, 
55321, 55295, 12053, 12036, 55320
20777, 54822, 11837, 11829, 54830, 54823, 11838, 11830, 54831, 55556, 12054, 55564, 55321, 55557, 12056, 55565, 
55324, 55298, 12055, 12038, 55323
20778, 54823, 11838, 11830, 54831, 54824, 11839, 11831, 54832, 55557, 12056, 55565, 55324, 55558, 12058, 55566, 
55327, 55301, 12057, 12040, 55326
20779, 54824, 11839, 11831, 54832, 54825, 11840, 11832, 54833, 55558, 12058, 55566, 55327, 55559, 12060, 55567, 
55330, 55304, 12059, 12042, 55329
20780, 54825, 11840, 11832, 54833, 14903, 1559, 1558, 14904, 55559, 12060, 55567, 55330, 14970, 1581, 14971, 
14944, 55307, 12061, 12044, 55332
20781, 14782, 1424, 1423, 14783, 54826, 11825, 11817, 54834, 14849, 1446, 14850, 14825, 55560, 12029, 55568, 
55334, 55308, 12028, 12011, 55333
20782, 54826, 11825, 11817, 54834, 54827, 11826, 11818, 54835, 55560, 12029, 55568, 55334, 55561, 12031, 55569, 
55337, 55311, 12030, 12013, 55336
20783, 54827, 11826, 11818, 54835, 54828, 11827, 11819, 54836, 55561, 12031, 55569, 55337, 55562, 12033, 55570, 
55340, 55314, 12032, 12015, 55339
20784, 54828, 11827, 11819, 54836, 54829, 11828, 11820, 54837, 55562, 12033, 55570, 55340, 55563, 12035, 55571, 
55343, 55317, 12034, 12017, 55342
20785, 54829, 11828, 11820, 54837, 54830, 11829, 11821, 54838, 55563, 12035, 55571, 55343, 55564, 12037, 55572, 
55346, 55320, 12036, 12019, 55345
20786, 54830, 11829, 11821, 54838, 54831, 11830, 11822, 54839, 55564, 12037, 55572, 55346, 55565, 12039, 55573, 
55349, 55323, 12038, 12021, 55348
20787, 54831, 11830, 11822, 54839, 54832, 11831, 11823, 54840, 55565, 12039, 55573, 55349, 55566, 12041, 55574, 
55352, 55326, 12040, 12023, 55351
20788, 54832, 11831, 11823, 54840, 54833, 11832, 11824, 54841, 55566, 12041, 55574, 55352, 55567, 12043, 55575, 
55355, 55329, 12042, 12025, 55354
20789, 54833, 11832, 11824, 54841, 14904, 1558, 1557, 14905, 55567, 12043, 55575, 55355, 14971, 1580, 14972, 
14946, 55332, 12044, 12027, 55357
20790, 14783, 1423, 1422, 14784, 54834, 11817, 11809, 54842, 14850, 1445, 14851, 14827, 55568, 12012, 55576, 
55359, 55333, 12011, 11994, 55358
20791, 54834, 11817, 11809, 54842, 54835, 11818, 11810, 54843, 55568, 12012, 55576, 55359, 55569, 12014, 55577, 
55362, 55336, 12013, 11996, 55361
20792, 54835, 11818, 11810, 54843, 54836, 11819, 11811, 54844, 55569, 12014, 55577, 55362, 55570, 12016, 55578, 
55365, 55339, 12015, 11998, 55364
20793, 54836, 11819, 11811, 54844, 54837, 11820, 11812, 54845, 55570, 12016, 55578, 55365, 55571, 12018, 55579, 
55368, 55342, 12017, 12000, 55367
20794, 54837, 11820, 11812, 54845, 54838, 11821, 11813, 54846, 55571, 12018, 55579, 55368, 55572, 12020, 55580, 
55371, 55345, 12019, 12002, 55370
20795, 54838, 11821, 11813, 54846, 54839, 11822, 11814, 54847, 55572, 12020, 55580, 55371, 55573, 12022, 55581, 
55374, 55348, 12021, 12004, 55373
20796, 54839, 11822, 11814, 54847, 54840, 11823, 11815, 54848, 55573, 12022, 55581, 55374, 55574, 12024, 55582, 
55377, 55351, 12023, 12006, 55376
20797, 54840, 11823, 11815, 54848, 54841, 11824, 11816, 54849, 55574, 12024, 55582, 55377, 55575, 12026, 55583, 
55380, 55354, 12025, 12008, 55379
20798, 54841, 11824, 11816, 54849, 14905, 1557, 1556, 14906, 55575, 12026, 55583, 55380, 14972, 1579, 14973, 
14948, 55357, 12027, 12010, 55382
20799, 14784, 1422, 1421, 14785, 54842, 11809, 11801, 54850, 14851, 1444, 14852, 14829, 55576, 11995, 55584, 
55384, 55358, 11994, 11977, 55383
20800, 54842, 11809, 11801, 54850, 54843, 11810, 11802, 54851, 55576, 11995, 55584, 55384, 55577, 11997, 55585, 
55387, 55361, 11996, 11979, 55386
20801, 54843, 11810, 11802, 54851, 54844, 11811, 11803, 54852, 55577, 11997, 55585, 55387, 55578, 11999, 55586, 
55390, 55364, 11998, 11981, 55389
20802, 54844, 11811, 11803, 54852, 54845, 11812, 11804, 54853, 55578, 11999, 55586, 55390, 55579, 12001, 55587, 
55393, 55367, 12000, 11983, 55392
20803, 54845, 11812, 11804, 54853, 54846, 11813, 11805, 54854, 55579, 12001, 55587, 55393, 55580, 12003, 55588, 
55396, 55370, 12002, 11985, 55395
20804, 54846, 11813, 11805, 54854, 54847, 11814, 11806, 54855, 55580, 12003, 55588, 55396, 55581, 12005, 55589, 
55399, 55373, 12004, 11987, 55398
20805, 54847, 11814, 11806, 54855, 54848, 11815, 11807, 54856, 55581, 12005, 55589, 55399, 55582, 12007, 55590, 
55402, 55376, 12006, 11989, 55401
20806, 54848, 11815, 11807, 54856, 54849, 11816, 11808, 54857, 55582, 12007, 55590, 55402, 55583, 12009, 55591, 
55405, 55379, 12008, 11991, 55404
20807, 54849, 11816, 11808, 54857, 14906, 1556, 1555, 14907, 55583, 12009, 55591, 55405, 14973, 1578, 14974, 
14950, 55382, 12010, 11993, 55407
20808, 14785, 1421, 47, 2011, 54850, 11801, 1645, 14982, 14852, 1443, 2013, 14830, 55584, 11978, 15007, 
55408, 55383, 11977, 1653, 14999
20809, 54850, 11801, 1645, 14982, 54851, 11802, 1646, 14981, 55584, 11978, 15007, 55408, 55585, 11980, 15006, 
55409, 55386, 11979, 1654, 14997
20810, 54851, 11802, 1646, 14981, 54852, 11803, 1647, 14980, 55585, 11980, 15006, 55409, 55586, 11982, 15005, 
55410, 55389, 11981, 1655, 14995
20811, 54852, 11803, 1647, 14980, 54853, 11804, 1648, 14979, 55586, 11982, 15005, 55410, 55587, 11984, 15004, 
55411, 55392, 11983, 1656, 14993
20812, 54853, 11804, 1648, 14979, 54854, 11805, 1649, 14978, 55587, 11984, 15004, 55411, 55588, 11986, 15003, 
55412, 55395, 11985, 1657, 14991
20813, 54854, 11805, 1649, 14978, 54855, 11806, 1650, 14977, 55588, 11986, 15003, 55412, 55589, 11988, 15002, 
55413, 55398, 11987, 1658, 14989
20814, 54855, 11806, 1650, 14977, 54856, 11807, 1651, 14976, 55589, 11988, 15002, 55413, 55590, 11990, 15001, 
55414, 55401, 11989, 1659, 14987
20815, 54856, 11807, 1651, 14976, 54857, 11808, 1652, 14975, 55590, 11990, 15001, 55414, 55591, 11992, 15000, 
55415, 55404, 11991, 1660, 14985
20816, 54857, 11808, 1652, 14975, 14907, 1555, 51, 2079, 55591, 11992, 15000, 55415, 14974, 1577, 2081, 
14952, 55407, 11993, 1661, 14983
*ELEMENT, type=C3D20, ELSET=Volume5
20817, 45, 1411, 11373, 1442, 1516, 11536, 55592, 11969, 1413, 11418, 11417, 1465, 11559, 55945, 55946, 
12351, 1524, 11561, 55944, 12334
20818, 1516, 11536, 55592, 11969, 1517, 11535, 55593, 11970, 11559, 55945, 55946, 12351, 11557, 55948, 55949, 
12352, 1525, 11560, 55947, 12336
20819, 1517, 11535, 55593, 11970, 1518, 11534, 55594, 11971, 11557, 55948, 55949, 12352, 11555, 55951, 55952, 
12353, 1526, 11558, 55950, 12338
20820, 1518, 11534, 55594, 11971, 1519, 11533, 55595, 11972, 11555, 55951, 55952, 12353, 11553, 55954, 55955, 
12354, 1527, 11556, 55953, 12340
20821, 1519, 11533, 55595, 11972, 1520, 11532, 55596, 11973, 11553, 55954, 55955, 12354, 11551, 55957, 55958, 
12355, 1528, 11554, 55956, 12342
20822, 1520, 11532, 55596, 11973, 1521, 11531, 55597, 11974, 11551, 55957, 55958, 12355, 11549, 55960, 55961, 
12356, 1529, 11552, 55959, 12344
20823, 1521, 11531, 55597, 11974, 1522, 11530, 55598, 11975, 11549, 55960, 55961, 12356, 11547, 55963, 55964, 
12357, 1530, 11550, 55962, 12346
20824, 1522, 11530, 55598, 11975, 1523, 11529, 55599, 11976, 11547, 55963, 55964, 12357, 11545, 55966, 55967, 
12358, 1531, 11548, 55965, 12348
20825, 1523, 11529, 55599, 11976, 49, 1511, 11587, 1576, 11545, 55966, 55967, 12358, 1513, 11631, 11632, 
1599, 1532, 11546, 55968, 12350
20826, 1442, 11373, 11374, 1441, 11969, 55592, 55600, 11961, 11417, 11420, 11419, 1464, 55946, 55970, 55971, 
12335, 12334, 55944, 55969, 12317
20827, 11969, 55592, 55600, 11961, 11970, 55593, 55601, 11962, 55946, 55970, 55971, 12335, 55949, 55973, 55974, 
12337, 12336, 55947, 55972, 12319
20828, 11970, 55593, 55601, 11962, 11971, 55594, 55602, 11963, 55949, 55973, 55974, 12337, 55952, 55976, 55977, 
12339, 12338, 55950, 55975, 12321
20829, 11971, 55594, 55602, 11963, 11972, 55595, 55603, 11964, 55952, 55976, 55977, 12339, 55955, 55979, 55980, 
12341, 12340, 55953, 55978, 12323
20830, 11972, 55595, 55603, 11964, 11973, 55596, 55604, 11965, 55955, 55979, 55980, 12341, 55958, 55982, 55983, 
12343, 12342, 55956, 55981, 12325
20831, 11973, 55596, 55604, 11965, 11974, 55597, 55605, 11966, 55958, 55982, 55983, 12343, 55961, 55985, 55986, 
12345, 12344, 55959, 55984, 12327
20832, 11974, 55597, 55605, 11966, 11975, 55598, 55606, 11967, 55961, 55985, 55986, 12345, 55964, 55988, 55989, 
12347, 12346, 55962, 55987, 12329
20833, 11975, 55598, 55606, 11967, 11976, 55599, 55607, 11968, 55964, 55988, 55989, 12347, 55967, 55991, 55992, 
12349, 12348, 55965, 55990, 12331
20834, 11976, 55599, 55607, 11968, 1576, 11587, 11588, 1575, 55967, 55991, 55992, 12349, 11632, 11633, 11634, 
1598, 12350, 55968, 55993, 12333
20835, 1441, 11374, 11375, 1440, 11961, 55600, 55608, 11953, 11419, 11422, 11421, 1463, 55971, 55995, 55996, 
12318, 12317, 55969, 55994, 12300
20836, 11961, 55600, 55608, 11953, 11962, 55601, 55609, 11954, 55971, 55995, 55996, 12318, 55974, 55998, 55999, 
12320, 12319, 55972, 55997, 12302
20837, 11962, 55601, 55609, 11954, 11963, 55602, 55610, 11955, 55974, 55998, 55999, 12320, 55977, 56001, 56002, 
12322, 12321, 55975, 56000, 12304
20838, 11963, 55602, 55610, 11955, 11964, 55603, 55611, 11956, 55977, 56001, 56002, 12322, 55980, 56004, 56005, 
12324, 12323, 55978, 56003, 12306
20839, 11964, 55603, 55611, 11956, 11965, 55604, 55612, 11957, 55980, 56004, 56005, 12324, 55983, 56007, 56008, 
12326, 12325, 55981, 56006, 12308
20840, 11965, 55604, 55612, 11957, 11966, 55605, 55613, 11958, 55983, 56007, 56008, 12326, 55986, 56010, 56011, 
12328, 12327, 55984, 56009, 12310
20841, 11966, 55605, 55613, 11958, 11967, 55606, 55614, 11959, 55986, 56010, 56011, 12328, 55989, 56013, 56014, 
12330, 12329, 55987, 56012, 12312
20842, 11967, 55606, 55614, 11959, 11968, 55607, 55615, 11960, 55989, 56013, 56014, 12330, 55992, 56016, 56017, 
12332, 12331, 55990, 56015, 12314
20843, 11968, 55607, 55615, 11960, 1575, 11588, 11589, 1574, 55992, 56016, 56017, 12332, 11634, 11635, 11636, 
1597, 12333, 55993, 56018, 12316
20844, 1440, 11375, 11376, 1439, 11953, 55608, 55616, 11945, 11421, 11424, 11423, 1462, 55996, 56020, 56021, 
12301, 12300, 55994, 56019, 12283
20845, 11953, 55608, 55616, 11945, 11954, 55609, 55617, 11946, 55996, 56020, 56021, 12301, 55999, 56023, 56024, 
12303, 12302, 55997, 56022, 12285
20846, 11954, 55609, 55617, 11946, 11955, 55610, 55618, 11947, 55999, 56023, 56024, 12303, 56002, 56026, 56027, 
12305, 12304, 56000, 56025, 12287
20847, 11955, 55610, 55618, 11947, 11956, 55611, 55619, 11948, 56002, 56026, 56027, 12305, 56005, 56029, 56030, 
12307, 12306, 56003, 56028, 12289
20848, 11956, 55611, 55619, 11948, 11957, 55612, 55620, 11949, 56005, 56029, 56030, 12307, 56008, 56032, 56033, 
12309, 12308, 56006, 56031, 12291
20849, 11957, 55612, 55620, 11949, 11958, 55613, 55621, 11950, 56008, 56032, 56033, 12309, 56011, 56035, 56036, 
12311, 12310, 56009, 56034, 12293
20850, 11958, 55613, 55621, 11950, 11959, 55614, 55622, 11951, 56011, 56035, 56036, 12311, 56014, 56038, 56039, 
12313, 12312, 56012, 56037, 12295
20851, 11959, 55614, 55622, 11951, 11960, 55615, 55623, 11952, 56014, 56038, 56039, 12313, 56017, 56041, 56042, 
12315, 12314, 56015, 56040, 12297
20852, 11960, 55615, 55623, 11952, 1574, 11589, 11590, 1573, 56017, 56041, 56042, 12315, 11636, 11637, 11638, 
1596, 12316, 56018, 56043, 12299
20853, 1439, 11376, 11377, 1438, 11945, 55616, 55624, 11937, 11423, 11426, 11425, 1461, 56021, 56045, 56046, 
12284, 12283, 56019, 56044, 12266
20854, 11945, 55616, 55624, 11937, 11946, 55617, 55625, 11938, 56021, 56045, 56046, 12284, 56024, 56048, 56049, 
12286, 12285, 56022, 56047, 12268
20855, 11946, 55617, 55625, 11938, 11947, 55618, 55626, 11939, 56024, 56048, 56049, 12286, 56027, 56051, 56052, 
12288, 12287, 56025, 56050, 12270
20856, 11947, 55618, 55626, 11939, 11948, 55619, 55627, 11940, 56027, 56051, 56052, 12288, 56030, 56054, 56055, 
12290, 12289, 56028, 56053, 12272
20857, 11948, 55619, 55627, 11940, 11949, 55620, 55628, 11941, 56030, 56054, 56055, 12290, 56033, 56057, 56058, 
12292, 12291, 56031, 56056, 12274
20858, 11949, 55620, 55628, 11941, 11950, 55621, 55629, 11942, 56033, 56057, 56058, 12292, 56036, 56060, 56061, 
12294, 12293, 56034, 56059, 12276
20859, 11950, 55621, 55629, 11942, 11951, 55622, 55630, 11943, 56036, 56060, 56061, 12294, 56039, 56063, 56064, 
12296, 12295, 56037, 56062, 12278
20860, 11951, 55622, 55630, 11943, 11952, 55623, 55631, 11944, 56039, 56063, 56064, 12296, 56042, 56066, 56067, 
12298, 12297, 56040, 56065, 12280
20861, 11952, 55623, 55631, 11944, 1573, 11590, 11591, 1572, 56042, 56066, 56067, 12298, 11638, 11639, 11640, 
1595, 12299, 56043, 56068, 12282
20862, 1438, 11377, 11378, 1437, 11937, 55624, 55632, 11929, 11425, 11428, 11427, 1460, 56046, 56070, 56071, 
12267, 12266, 56044, 56069, 12249
20863, 11937, 55624, 55632, 11929, 11938, 55625, 55633, 11930, 56046, 56070, 56071, 12267, 56049, 56073, 56074, 
12269, 12268, 56047, 56072, 12251
20864, 11938, 55625, 55633, 11930, 11939, 55626, 55634, 11931, 56049, 56073, 56074, 12269, 56052, 56076, 56077, 
12271, 12270, 56050, 56075, 12253
20865, 11939, 55626, 55634, 11931, 11940, 55627, 55635, 11932, 56052, 56076, 56077, 12271, 56055, 56079, 56080, 
12273, 12272, 56053, 56078, 12255
20866, 11940, 55627, 55635, 11932, 11941, 55628, 55636, 11933, 56055, 56079, 56080, 12273, 56058, 56082, 56083, 
12275, 12274, 56056, 56081, 12257
20867, 11941, 55628, 55636, 11933, 11942, 55629, 55637, 11934, 56058, 56082, 56083, 12275, 56061, 56085, 56086, 
12277, 12276, 56059, 56084, 12259
20868, 11942, 55629, 55637, 11934, 11943, 55630, 55638, 11935, 56061, 56085, 56086, 12277, 56064, 56088, 56089, 
12279, 12278, 56062, 56087, 12261
20869, 11943, 55630, 55638, 11935, 11944, 55631, 55639, 11936, 56064, 56088, 56089, 12279, 56067, 56091, 56092, 
12281, 12280, 56065, 56090, 12263
20870, 11944, 55631, 55639, 11936, 1572, 11591, 11592, 1571, 56067, 56091, 56092, 12281, 11640, 11641, 11642, 
1594, 12282, 56068, 56093, 12265
20871, 1437, 11378, 11379, 1436, 11929, 55632, 55640, 11921, 11427, 11430, 11429, 1459, 56071, 56095, 56096, 
12250, 12249, 56069, 56094, 12232
20872, 11929, 55632, 55640, 11921, 11930, 55633, 55641, 11922, 56071, 56095, 56096, 12250, 56074, 56098, 56099, 
12252, 12251, 56072, 56097, 12234
20873, 11930, 55633, 55641, 11922, 11931, 55634, 55642, 11923, 56074, 56098, 56099, 12252, 56077, 56101, 56102, 
12254, 12253, 56075, 56100, 12236
20874, 11931, 55634, 55642, 11923, 11932, 55635, 55643, 11924, 56077, 56101, 56102, 12254, 56080, 56104, 56105, 
12256, 12255, 56078, 56103, 12238
20875, 11932, 55635, 55643, 11924, 11933, 55636, 55644, 11925, 56080, 56104, 56105, 12256, 56083, 56107, 56108, 
12258, 12257, 56081, 56106, 12240
20876, 11933, 55636, 55644, 11925, 11934, 55637, 55645, 11926, 56083, 56107, 56108, 12258, 56086, 56110, 56111, 
12260, 12259, 56084, 56109, 12242
20877, 11934, 55637, 55645, 11926, 11935, 55638, 55646, 11927, 56086, 56110, 56111, 12260, 56089, 56113, 56114, 
12262, 12261, 56087, 56112, 12244
20878, 11935, 55638, 55646, 11927, 11936, 55639, 55647, 11928, 56089, 56113, 56114, 12262, 56092, 56116, 56117, 
12264, 12263, 56090, 56115, 12246
20879, 11936, 55639, 55647, 11928, 1571, 11592, 11593, 1570, 56092, 56116, 56117, 12264, 11642, 11643, 11644, 
1593, 12265, 56093, 56118, 12248
20880, 1436, 11379, 11380, 1435, 11921, 55640, 55648, 11913, 11429, 11432, 11431, 1458, 56096, 56120, 56121, 
12233, 12232, 56094, 56119, 12215
20881, 11921, 55640, 55648, 11913, 11922, 55641, 55649, 11914, 56096, 56120, 56121, 12233, 56099, 56123, 56124, 
12235, 12234, 56097, 56122, 12217
20882, 11922, 55641, 55649, 11914, 11923, 55642, 55650, 11915, 56099, 56123, 56124, 12235, 56102, 56126, 56127, 
12237, 12236, 56100, 56125, 12219
20883, 11923, 55642, 55650, 11915, 11924, 55643, 55651, 11916, 56102, 56126, 56127, 12237, 56105, 56129, 56130, 
12239, 12238, 56103, 56128, 12221
20884, 11924, 55643, 55651, 11916, 11925, 55644, 55652, 11917, 56105, 56129, 56130, 12239, 56108, 56132, 56133, 
12241, 12240, 56106, 56131, 12223
20885, 11925, 55644, 55652, 11917, 11926, 55645, 55653, 11918, 56108, 56132, 56133, 12241, 56111, 56135, 56136, 
12243, 12242, 56109, 56134, 12225
20886, 11926, 55645, 55653, 11918, 11927, 55646, 55654, 11919, 56111, 56135, 56136, 12243, 56114, 56138, 56139, 
12245, 12244, 56112, 56137, 12227
20887, 11927, 55646, 55654, 11919, 11928, 55647, 55655, 11920, 56114, 56138, 56139, 12245, 56117, 56141, 56142, 
12247, 12246, 56115, 56140, 12229
20888, 11928, 55647, 55655, 11920, 1570, 11593, 11594, 1569, 56117, 56141, 56142, 12247, 11644, 11645, 11646, 
1592, 12248, 56118, 56143, 12231
20889, 1435, 11380, 11381, 1434, 11913, 55648, 55656, 11905, 11431, 11434, 11433, 1457, 56121, 56145, 56146, 
12216, 12215, 56119, 56144, 12198
20890, 11913, 55648, 55656, 11905, 11914, 55649, 55657, 11906, 56121, 56145, 56146, 12216, 56124, 56148, 56149, 
12218, 12217, 56122, 56147, 12200
20891, 11914, 55649, 55657, 11906, 11915, 55650, 55658, 11907, 56124, 56148, 56149, 12218, 56127, 56151, 56152, 
12220, 12219, 56125, 56150, 12202
20892, 11915, 55650, 55658, 11907, 11916, 55651, 55659, 11908, 56127, 56151, 56152, 12220, 56130, 56154, 56155, 
12222, 12221, 56128, 56153, 12204
20893, 11916, 55651, 55659, 11908, 11917, 55652, 55660, 11909, 56130, 56154, 56155, 12222, 56133, 56157, 56158, 
12224, 12223, 56131, 56156, 12206
20894, 11917, 55652, 55660, 11909, 11918, 55653, 55661, 11910, 56133, 56157, 56158, 12224, 56136, 56160, 56161, 
12226, 12225, 56134, 56159, 12208
20895, 11918, 55653, 55661, 11910, 11919, 55654, 55662, 11911, 56136, 56160, 56161, 12226, 56139, 56163, 56164, 
12228, 12227, 56137, 56162, 12210
20896, 11919, 55654, 55662, 11911, 11920, 55655, 55663, 11912, 56139, 56163, 56164, 12228, 56142, 56166, 56167, 
12230, 12229, 56140, 56165, 12212
20897, 11920, 55655, 55663, 11912, 1569, 11594, 11595, 1568, 56142, 56166, 56167, 12230, 11646, 11647, 11648, 
1591, 12231, 56143, 56168, 12214
20898, 1434, 11381, 11382, 1433, 11905, 55656, 55664, 11897, 11433, 11436, 11435, 1456, 56146, 56170, 56171, 
12199, 12198, 56144, 56169, 12181
20899, 11905, 55656, 55664, 11897, 11906, 55657, 55665, 11898, 56146, 56170, 56171, 12199, 56149, 56173, 56174, 
12201, 12200, 56147, 56172, 12183
20900, 11906, 55657, 55665, 11898, 11907, 55658, 55666, 11899, 56149, 56173, 56174, 12201, 56152, 56176, 56177, 
12203, 12202, 56150, 56175, 12185
20901, 11907, 55658, 55666, 11899, 11908, 55659, 55667, 11900, 56152, 56176, 56177, 12203, 56155, 56179, 56180, 
12205, 12204, 56153, 56178, 12187
20902, 11908, 55659, 55667, 11900, 11909, 55660, 55668, 11901, 56155, 56179, 56180, 12205, 56158, 56182, 56183, 
12207, 12206, 56156, 56181, 12189
20903, 11909, 55660, 55668, 11901, 11910, 55661, 55669, 11902, 56158, 56182, 56183, 12207, 56161, 56185, 56186, 
12209, 12208, 56159, 56184, 12191
20904, 11910, 55661, 55669, 11902, 11911, 55662, 55670, 11903, 56161, 56185, 56186, 12209, 56164, 56188, 56189, 
12211, 12210, 56162, 56187, 12193
20905, 11911, 55662, 55670, 11903, 11912, 55663, 55671, 11904, 56164, 56188, 56189, 12211, 56167, 56191, 56192, 
12213, 12212, 56165, 56190, 12195
20906, 11912, 55663, 55671, 11904, 1568, 11595, 11596, 1567, 56167, 56191, 56192, 12213, 11648, 11649, 11650, 
1590, 12214, 56168, 56193, 12197
20907, 1433, 11382, 11383, 1432, 11897, 55664, 55672, 11889, 11435, 11438, 11437, 1455, 56171, 56195, 56196, 
12182, 12181, 56169, 56194, 12164
20908, 11897, 55664, 55672, 11889, 11898, 55665, 55673, 11890, 56171, 56195, 56196, 12182, 56174, 56198, 56199, 
12184, 12183, 56172, 56197, 12166
20909, 11898, 55665, 55673, 11890, 11899, 55666, 55674, 11891, 56174, 56198, 56199, 12184, 56177, 56201, 56202, 
12186, 12185, 56175, 56200, 12168
20910, 11899, 55666, 55674, 11891, 11900, 55667, 55675, 11892, 56177, 56201, 56202, 12186, 56180, 56204, 56205, 
12188, 12187, 56178, 56203, 12170
20911, 11900, 55667, 55675, 11892, 11901, 55668, 55676, 11893, 56180, 56204, 56205, 12188, 56183, 56207, 56208, 
12190, 12189, 56181, 56206, 12172
20912, 11901, 55668, 55676, 11893, 11902, 55669, 55677, 11894, 56183, 56207, 56208, 12190, 56186, 56210, 56211, 
12192, 12191, 56184, 56209, 12174
20913, 11902, 55669, 55677, 11894, 11903, 55670, 55678, 11895, 56186, 56210, 56211, 12192, 56189, 56213, 56214, 
12194, 12193, 56187, 56212, 12176
20914, 11903, 55670, 55678, 11895, 11904, 55671, 55679, 11896, 56189, 56213, 56214, 12194, 56192, 56216, 56217, 
12196, 12195, 56190, 56215, 12178
20915, 11904, 55671, 55679, 11896, 1567, 11596, 11597, 1566, 56192, 56216, 56217, 12196, 11650, 11651, 11652, 
1589, 12197, 56193, 56218, 12180
20916, 1432, 11383, 11384, 1431, 11889, 55672, 55680, 11881, 11437, 11440, 11439, 1454, 56196, 56220, 56221, 
12165, 12164, 56194, 56219, 12147
20917, 11889, 55672, 55680, 11881, 11890, 55673, 55681, 11882, 56196, 56220, 56221, 12165, 56199, 56223, 56224, 
12167, 12166, 56197, 56222, 12149
20918, 11890, 55673, 55681, 11882, 11891, 55674, 55682, 11883, 56199, 56223, 56224, 12167, 56202, 56226, 56227, 
12169, 12168, 56200, 56225, 12151
20919, 11891, 55674, 55682, 11883, 11892, 55675, 55683, 11884, 56202, 56226, 56227, 12169, 56205, 56229, 56230, 
12171, 12170, 56203, 56228, 12153
20920, 11892, 55675, 55683, 11884, 11893, 55676, 55684, 11885, 56205, 56229, 56230, 12171, 56208, 56232, 56233, 
12173, 12172, 56206, 56231, 12155
20921, 11893, 55676, 55684, 11885, 11894, 55677, 55685, 11886, 56208, 56232, 56233, 12173, 56211, 56235, 56236, 
12175, 12174, 56209, 56234, 12157
20922, 11894, 55677, 55685, 11886, 11895, 55678, 55686, 11887, 56211, 56235, 56236, 12175, 56214, 56238, 56239, 
12177, 12176, 56212, 56237, 12159
20923, 11895, 55678, 55686, 11887, 11896, 55679, 55687, 11888, 56214, 56238, 56239, 12177, 56217, 56241, 56242, 
12179, 12178, 56215, 56240, 12161
20924, 11896, 55679, 55687, 11888, 1566, 11597, 11598, 1565, 56217, 56241, 56242, 12179, 11652, 11653, 11654, 
1588, 12180, 56218, 56243, 12163
20925, 1431, 11384, 11385, 1430, 11881, 55680, 55688, 11873, 11439, 11442, 11441, 1453, 56221, 56245, 56246, 
12148, 12147, 56219, 56244, 12130
20926, 11881, 55680, 55688, 11873, 11882, 55681, 55689, 11874, 56221, 56245, 56246, 12148, 56224, 56248, 56249, 
12150, 12149, 56222, 56247, 12132
20927, 11882, 55681, 55689, 11874, 11883, 55682, 55690, 11875, 56224, 56248, 56249, 12150, 56227, 56251, 56252, 
12152, 12151, 56225, 56250, 12134
20928, 11883, 55682, 55690, 11875, 11884, 55683, 55691, 11876, 56227, 56251, 56252, 12152, 56230, 56254, 56255, 
12154, 12153, 56228, 56253, 12136
20929, 11884, 55683, 55691, 11876, 11885, 55684, 55692, 11877, 56230, 56254, 56255, 12154, 56233, 56257, 56258, 
12156, 12155, 56231, 56256, 12138
20930, 11885, 55684, 55692, 11877, 11886, 55685, 55693, 11878, 56233, 56257, 56258, 12156, 56236, 56260, 56261, 
12158, 12157, 56234, 56259, 12140
20931, 11886, 55685, 55693, 11878, 11887, 55686, 55694, 11879, 56236, 56260, 56261, 12158, 56239, 56263, 56264, 
12160, 12159, 56237, 56262, 12142
20932, 11887, 55686, 55694, 11879, 11888, 55687, 55695, 11880, 56239, 56263, 56264, 12160, 56242, 56266, 56267, 
12162, 12161, 56240, 56265, 12144
20933, 11888, 55687, 55695, 11880, 1565, 11598, 11599, 1564, 56242, 56266, 56267, 12162, 11654, 11655, 11656, 
1587, 12163, 56243, 56268, 12146
20934, 1430, 11385, 11386, 1429, 11873, 55688, 55696, 11865, 11441, 11444, 11443, 1452, 56246, 56270, 56271, 
12131, 12130, 56244, 56269, 12113
20935, 11873, 55688, 55696, 11865, 11874, 55689, 55697, 11866, 56246, 56270, 56271, 12131, 56249, 56273, 56274, 
12133, 12132, 56247, 56272, 12115
20936, 11874, 55689, 55697, 11866, 11875, 55690, 55698, 11867, 56249, 56273, 56274, 12133, 56252, 56276, 56277, 
12135, 12134, 56250, 56275, 12117
20937, 11875, 55690, 55698, 11867, 11876, 55691, 55699, 11868, 56252, 56276, 56277, 12135, 56255, 56279, 56280, 
12137, 12136, 56253, 56278, 12119
20938, 11876, 55691, 55699, 11868, 11877, 55692, 55700, 11869, 56255, 56279, 56280, 12137, 56258, 56282, 56283, 
12139, 12138, 56256, 56281, 12121
20939, 11877, 55692, 55700, 11869, 11878, 55693, 55701, 11870, 56258, 56282, 56283, 12139, 56261, 56285, 56286, 
12141, 12140, 56259, 56284, 12123
20940, 11878, 55693, 55701, 11870, 11879, 55694, 55702, 11871, 56261, 56285, 56286, 12141, 56264, 56288, 56289, 
12143, 12142, 56262, 56287, 12125
20941, 11879, 55694, 55702, 11871, 11880, 55695, 55703, 11872, 56264, 56288, 56289, 12143, 56267, 56291, 56292, 
12145, 12144, 56265, 56290, 12127
20942, 11880, 55695, 55703, 11872, 1564, 11599, 11600, 1563, 56267, 56291, 56292, 12145, 11656, 11657, 11658, 
1586, 12146, 56268, 56293, 12129
20943, 1429, 11386, 11387, 1428, 11865, 55696, 55704, 11857, 11443, 11446, 11445, 1451, 56271, 56295, 56296, 
12114, 12113, 56269, 56294, 12096
20944, 11865, 55696, 55704, 11857, 11866, 55697, 55705, 11858, 56271, 56295, 56296, 12114, 56274, 56298, 56299, 
12116, 12115, 56272, 56297, 12098
20945, 11866, 55697, 55705, 11858, 11867, 55698, 55706, 11859, 56274, 56298, 56299, 12116, 56277, 56301, 56302, 
12118, 12117, 56275, 56300, 12100
20946, 11867, 55698, 55706, 11859, 11868, 55699, 55707, 11860, 56277, 56301, 56302, 12118, 56280, 56304, 56305, 
12120, 12119, 56278, 56303, 12102
20947, 11868, 55699, 55707, 11860, 11869, 55700, 55708, 11861, 56280, 56304, 56305, 12120, 56283, 56307, 56308, 
12122, 12121, 56281, 56306, 12104
20948, 11869, 55700, 55708, 11861, 11870, 55701, 55709, 11862, 56283, 56307, 56308, 12122, 56286, 56310, 56311, 
12124, 12123, 56284, 56309, 12106
20949, 11870, 55701, 55709, 11862, 11871, 55702, 55710, 11863, 56286, 56310, 56311, 12124, 56289, 56313, 56314, 
12126, 12125, 56287, 56312, 12108
20950, 11871, 55702, 55710, 11863, 11872, 55703, 55711, 11864, 56289, 56313, 56314, 12126, 56292, 56316, 56317, 
12128, 12127, 56290, 56315, 12110
20951, 11872, 55703, 55711, 11864, 1563, 11600, 11601, 1562, 56292, 56316, 56317, 12128, 11658, 11659, 11660, 
1585, 12129, 56293, 56318, 12112
20952, 1428, 11387, 11388, 1427, 11857, 55704, 55712, 11849, 11445, 11448, 11447, 1450, 56296, 56320, 56321, 
12097, 12096, 56294, 56319, 12079
20953, 11857, 55704, 55712, 11849, 11858, 55705, 55713, 11850, 56296, 56320, 56321, 12097, 56299, 56323, 56324, 
12099, 12098, 56297, 56322, 12081
20954, 11858, 55705, 55713, 11850, 11859, 55706, 55714, 11851, 56299, 56323, 56324, 12099, 56302, 56326, 56327, 
12101, 12100, 56300, 56325, 12083
20955, 11859, 55706, 55714, 11851, 11860, 55707, 55715, 11852, 56302, 56326, 56327, 12101, 56305, 56329, 56330, 
12103, 12102, 56303, 56328, 12085
20956, 11860, 55707, 55715, 11852, 11861, 55708, 55716, 11853, 56305, 56329, 56330, 12103, 56308, 56332, 56333, 
12105, 12104, 56306, 56331, 12087
20957, 11861, 55708, 55716, 11853, 11862, 55709, 55717, 11854, 56308, 56332, 56333, 12105, 56311, 56335, 56336, 
12107, 12106, 56309, 56334, 12089
20958, 11862, 55709, 55717, 11854, 11863, 55710, 55718, 11855, 56311, 56335, 56336, 12107, 56314, 56338, 56339, 
12109, 12108, 56312, 56337, 12091
20959, 11863, 55710, 55718, 11855, 11864, 55711, 55719, 11856, 56314, 56338, 56339, 12109, 56317, 56341, 56342, 
12111, 12110, 56315, 56340, 12093
20960, 11864, 55711, 55719, 11856, 1562, 11601, 11602, 1561, 56317, 56341, 56342, 12111, 11660, 11661, 11662, 
1584, 12112, 56318, 56343, 12095
20961, 1427, 11388, 11389, 1426, 11849, 55712, 55720, 11841, 11447, 11450, 11449, 1449, 56321, 56345, 56346, 
12080, 12079, 56319, 56344, 12062
20962, 11849, 55712, 55720, 11841, 11850, 55713, 55721, 11842, 56321, 56345, 56346, 12080, 56324, 56348, 56349, 
12082, 12081, 56322, 56347, 12064
20963, 11850, 55713, 55721, 11842, 11851, 55714, 55722, 11843, 56324, 56348, 56349, 12082, 56327, 56351, 56352, 
12084, 12083, 56325, 56350, 12066
20964, 11851, 55714, 55722, 11843, 11852, 55715, 55723, 11844, 56327, 56351, 56352, 12084, 56330, 56354, 56355, 
12086, 12085, 56328, 56353, 12068
20965, 11852, 55715, 55723, 11844, 11853, 55716, 55724, 11845, 56330, 56354, 56355, 12086, 56333, 56357, 56358, 
12088, 12087, 56331, 56356, 12070
20966, 11853, 55716, 55724, 11845, 11854, 55717, 55725, 11846, 56333, 56357, 56358, 12088, 56336, 56360, 56361, 
12090, 12089, 56334, 56359, 12072
20967, 11854, 55717, 55725, 11846, 11855, 55718, 55726, 11847, 56336, 56360, 56361, 12090, 56339, 56363, 56364, 
12092, 12091, 56337, 56362, 12074
20968, 11855, 55718, 55726, 11847, 11856, 55719, 55727, 11848, 56339, 56363, 56364, 12092, 56342, 56366, 56367, 
12094, 12093, 56340, 56365, 12076
20969, 11856, 55719, 55727, 11848, 1561, 11602, 11603, 1560, 56342, 56366, 56367, 12094, 11662, 11663, 11664, 
1583, 12095, 56343, 56368, 12078
20970, 1426, 11389, 11390, 1425, 11841, 55720, 55728, 11833, 11449, 11452, 11451, 1448, 56346, 56370, 56371, 
12063, 12062, 56344, 56369, 12045
20971, 11841, 55720, 55728, 11833, 11842, 55721, 55729, 11834, 56346, 56370, 56371, 12063, 56349, 56373, 56374, 
12065, 12064, 56347, 56372, 12047
20972, 11842, 55721, 55729, 11834, 11843, 55722, 55730, 11835, 56349, 56373, 56374, 12065, 56352, 56376, 56377, 
12067, 12066, 56350, 56375, 12049
20973, 11843, 55722, 55730, 11835, 11844, 55723, 55731, 11836, 56352, 56376, 56377, 12067, 56355, 56379, 56380, 
12069, 12068, 56353, 56378, 12051
20974, 11844, 55723, 55731, 11836, 11845, 55724, 55732, 11837, 56355, 56379, 56380, 12069, 56358, 56382, 56383, 
12071, 12070, 56356, 56381, 12053
20975, 11845, 55724, 55732, 11837, 11846, 55725, 55733, 11838, 56358, 56382, 56383, 12071, 56361, 56385, 56386, 
12073, 12072, 56359, 56384, 12055
20976, 11846, 55725, 55733, 11838, 11847, 55726, 55734, 11839, 56361, 56385, 56386, 12073, 56364, 56388, 56389, 
12075, 12074, 56362, 56387, 12057
20977, 11847, 55726, 55734, 11839, 11848, 55727, 55735, 11840, 56364, 56388, 56389, 12075, 56367, 56391, 56392, 
12077, 12076, 56365, 56390, 12059
20978, 11848, 55727, 55735, 11840, 1560, 11603, 11604, 1559, 56367, 56391, 56392, 12077, 11664, 11665, 11666, 
1582, 12078, 56368, 56393, 12061
20979, 1425, 11390, 11391, 1424, 11833, 55728, 55736, 11825, 11451, 11454, 11453, 1447, 56371, 56395, 56396, 
12046, 12045, 56369, 56394, 12028
20980, 11833, 55728, 55736, 11825, 11834, 55729, 55737, 11826, 56371, 56395, 56396, 12046, 56374, 56398, 56399, 
12048, 12047, 56372, 56397, 12030
20981, 11834, 55729, 55737, 11826, 11835, 55730, 55738, 11827, 56374, 56398, 56399, 12048, 56377, 56401, 56402, 
12050, 12049, 56375, 56400, 12032
20982, 11835, 55730, 55738, 11827, 11836, 55731, 55739, 11828, 56377, 56401, 56402, 12050, 56380, 56404, 56405, 
12052, 12051, 56378, 56403, 12034
20983, 11836, 55731, 55739, 11828, 11837, 55732, 55740, 11829, 56380, 56404, 56405, 12052, 56383, 56407, 56408, 
12054, 12053, 56381, 56406, 12036
20984, 11837, 55732, 55740, 11829, 11838, 55733, 55741, 11830, 56383, 56407, 56408, 12054, 56386, 56410, 56411, 
12056, 12055, 56384, 56409, 12038
20985, 11838, 55733, 55741, 11830, 11839, 55734, 55742, 11831, 56386, 56410, 56411, 12056, 56389, 56413, 56414, 
12058, 12057, 56387, 56412, 12040
20986, 11839, 55734, 55742, 11831, 11840, 55735, 55743, 11832, 56389, 56413, 56414, 12058, 56392, 56416, 56417, 
12060, 12059, 56390, 56415, 12042
20987, 11840, 55735, 55743, 11832, 1559, 11604, 11605, 1558, 56392, 56416, 56417, 12060, 11666, 11667, 11668, 
1581, 12061, 56393, 56418, 12044
20988, 1424, 11391, 11392, 1423, 11825, 55736, 55744, 11817, 11453, 11456, 11455, 1446, 56396, 56420, 56421, 
12029, 12028, 56394, 56419, 12011
20989, 11825, 55736, 55744, 11817, 11826, 55737, 55745, 11818, 56396, 56420, 56421, 12029, 56399, 56423, 56424, 
12031, 12030, 56397, 56422, 12013
20990, 11826, 55737, 55745, 11818, 11827, 55738, 55746, 11819, 56399, 56423, 56424, 12031, 56402, 56426, 56427, 
12033, 12032, 56400, 56425, 12015
20991, 11827, 55738, 55746, 11819, 11828, 55739, 55747, 11820, 56402, 56426, 56427, 12033, 56405, 56429, 56430, 
12035, 12034, 56403, 56428, 12017
20992, 11828, 55739, 55747, 11820, 11829, 55740, 55748, 11821, 56405, 56429, 56430, 12035, 56408, 56432, 56433, 
12037, 12036, 56406, 56431, 12019
20993, 11829, 55740, 55748, 11821, 11830, 55741, 55749, 11822, 56408, 56432, 56433, 12037, 56411, 56435, 56436, 
12039, 12038, 56409, 56434, 12021
20994, 11830, 55741, 55749, 11822, 11831, 55742, 55750, 11823, 56411, 56435, 56436, 12039, 56414, 56438, 56439, 
12041, 12040, 56412, 56437, 12023
20995, 11831, 55742, 55750, 11823, 11832, 55743, 55751, 11824, 56414, 56438, 56439, 12041, 56417, 56441, 56442, 
12043, 12042, 56415, 56440, 12025
20996, 11832, 55743, 55751, 11824, 1558, 11605, 11606, 1557, 56417, 56441, 56442, 12043, 11668, 11669, 11670, 
1580, 12044, 56418, 56443, 12027
20997, 1423, 11392, 11393, 1422, 11817, 55744, 55752, 11809, 11455, 11458, 11457, 1445, 56421, 56445, 56446, 
12012, 12011, 56419, 56444, 11994
20998, 11817, 55744, 55752, 11809, 11818, 55745, 55753, 11810, 56421, 56445, 56446, 12012, 56424, 56448, 56449, 
12014, 12013, 56422, 56447, 11996
20999, 11818, 55745, 55753, 11810, 11819, 55746, 55754, 11811, 56424, 56448, 56449, 12014, 56427, 56451, 56452, 
12016, 12015, 56425, 56450, 11998
21000, 11819, 55746, 55754, 11811, 11820, 55747, 55755, 11812, 56427, 56451, 56452, 12016, 56430, 56454, 56455, 
12018, 12017, 56428, 56453, 12000
21001, 11820, 55747, 55755, 11812, 11821, 55748, 55756, 11813, 56430, 56454, 56455, 12018, 56433, 56457, 56458, 
12020, 12019, 56431, 56456, 12002
