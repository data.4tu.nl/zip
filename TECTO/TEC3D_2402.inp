42732, 0.08695652173913, 0.17608695652174, 0.055555555555556
42733, 0.08695652173913, 0.20217391304348, 0.083333333333333
42734, 0.10869565217391, 0.20217391304348, 0.11111111111111
42735, 0.08695652173913, 0.17608695652174, 0.11111111111111
42736, 0.08695652173913, 0.20217391304348, 0.13888888888889
42737, 0.10869565217391, 0.20217391304348, 0.16666666666667
42738, 0.08695652173913, 0.17608695652174, 0.16666666666667
42739, 0.08695652173913, 0.20217391304348, 0.19444444444444
42740, 0.10869565217391, 0.20217391304348, 0.22222222222222
42741, 0.08695652173913, 0.17608695652174, 0.22222222222222
42742, 0.08695652173913, 0.20217391304348, 0.25
42743, 0.10869565217391, 0.20217391304348, 0.27777777777778
42744, 0.08695652173913, 0.17608695652174, 0.27777777777778
42745, 0.08695652173913, 0.20217391304348, 0.30555555555556
42746, 0.10869565217391, 0.20217391304348, 0.33333333333333
42747, 0.08695652173913, 0.17608695652174, 0.33333333333333
42748, 0.08695652173913, 0.20217391304348, 0.36111111111111
42749, 0.10869565217391, 0.20217391304348, 0.38888888888889
42750, 0.08695652173913, 0.17608695652174, 0.38888888888889
42751, 0.08695652173913, 0.20217391304348, 0.41666666666667
42752, 0.10869565217391, 0.20217391304348, 0.44444444444444
42753, 0.08695652173913, 0.17608695652174, 0.44444444444444
42754, 0.08695652173913, 0.20217391304348, 0.47222222222222
42755, 0.043478260869565, 0.20217391304348, 0.027777777777778
42756, 0.065217391304348, 0.20217391304348, 0.055555555555556
42757, 0.043478260869565, 0.17608695652174, 0.055555555555556
42758, 0.043478260869565, 0.20217391304348, 0.083333333333333
42759, 0.065217391304348, 0.20217391304348, 0.11111111111111
42760, 0.043478260869565, 0.17608695652174, 0.11111111111111
42761, 0.043478260869565, 0.20217391304348, 0.13888888888889
42762, 0.065217391304348, 0.20217391304348, 0.16666666666667
42763, 0.043478260869565, 0.17608695652174, 0.16666666666667
42764, 0.043478260869565, 0.20217391304348, 0.19444444444444
42765, 0.065217391304348, 0.20217391304348, 0.22222222222222
42766, 0.043478260869565, 0.17608695652174, 0.22222222222222
42767, 0.043478260869565, 0.20217391304348, 0.25
42768, 0.065217391304348, 0.20217391304348, 0.27777777777778
42769, 0.043478260869565, 0.17608695652174, 0.27777777777778
42770, 0.043478260869565, 0.20217391304348, 0.30555555555556
42771, 0.065217391304348, 0.20217391304348, 0.33333333333333
42772, 0.043478260869565, 0.17608695652174, 0.33333333333333
42773, 0.043478260869565, 0.20217391304348, 0.36111111111111
42774, 0.065217391304348, 0.20217391304348, 0.38888888888889
42775, 0.043478260869565, 0.17608695652174, 0.38888888888889
42776, 0.043478260869565, 0.20217391304348, 0.41666666666667
42777, 0.065217391304348, 0.20217391304348, 0.44444444444444
42778, 0.043478260869565, 0.17608695652174, 0.44444444444444
42779, 0.043478260869565, 0.20217391304348, 0.47222222222222
42780, 0.021739130434783, 0.20217391304348, 0.055555555555556
42781, 0.021739130434783, 0.20217391304348, 0.11111111111111
42782, 0.021739130434783, 0.20217391304348, 0.16666666666667
42783, 0.021739130434783, 0.20217391304348, 0.22222222222222
42784, 0.021739130434783, 0.20217391304348, 0.27777777777778
42785, 0.021739130434783, 0.20217391304348, 0.33333333333333
42786, 0.021739130434783, 0.20217391304348, 0.38888888888889
42787, 0.021739130434783, 0.20217391304348, 0.44444444444444
42788, 0.95652173913043, 0.25434782608696, 0.027777777777778
42789, 0.97826086956522, 0.25434782608696, 0.055555555555556
42790, 0.95652173913043, 0.22826086956522, 0.055555555555556
42791, 0.95652173913043, 0.25434782608696, 0.083333333333333
42792, 0.97826086956522, 0.25434782608696, 0.11111111111111
42793, 0.95652173913044, 0.22826086956522, 0.11111111111111
42794, 0.95652173913044, 0.25434782608696, 0.13888888888889
42795, 0.97826086956522, 0.25434782608696, 0.16666666666667
42796, 0.95652173913044, 0.22826086956522, 0.16666666666667
42797, 0.95652173913043, 0.25434782608696, 0.19444444444444
42798, 0.97826086956522, 0.25434782608696, 0.22222222222222
42799, 0.95652173913044, 0.22826086956522, 0.22222222222222
42800, 0.95652173913043, 0.25434782608696, 0.25
42801, 0.97826086956522, 0.25434782608696, 0.27777777777778
42802, 0.95652173913043, 0.22826086956522, 0.27777777777778
42803, 0.95652173913043, 0.25434782608696, 0.30555555555556
42804, 0.97826086956522, 0.25434782608696, 0.33333333333333
42805, 0.95652173913044, 0.22826086956522, 0.33333333333333
42806, 0.95652173913043, 0.25434782608696, 0.36111111111111
42807, 0.97826086956522, 0.25434782608696, 0.38888888888889
42808, 0.95652173913043, 0.22826086956522, 0.38888888888889
42809, 0.95652173913043, 0.25434782608696, 0.41666666666667
42810, 0.97826086956522, 0.25434782608696, 0.44444444444444
42811, 0.95652173913043, 0.22826086956522, 0.44444444444444
42812, 0.95652173913043, 0.25434782608696, 0.47222222222222
42813, 0.91304347826087, 0.25434782608696, 0.027777777777778
42814, 0.93478260869565, 0.25434782608696, 0.055555555555556
42815, 0.91304347826087, 0.22826086956522, 0.055555555555556
42816, 0.91304347826087, 0.25434782608696, 0.083333333333333
42817, 0.93478260869565, 0.25434782608696, 0.11111111111111
42818, 0.91304347826087, 0.22826086956522, 0.11111111111111
42819, 0.91304347826087, 0.25434782608696, 0.13888888888889
42820, 0.93478260869565, 0.25434782608696, 0.16666666666667
42821, 0.91304347826087, 0.22826086956522, 0.16666666666667
42822, 0.91304347826087, 0.25434782608696, 0.19444444444444
42823, 0.93478260869565, 0.25434782608696, 0.22222222222222
42824, 0.91304347826087, 0.22826086956522, 0.22222222222222
42825, 0.91304347826087, 0.25434782608696, 0.25
42826, 0.93478260869565, 0.25434782608696, 0.27777777777778
42827, 0.91304347826087, 0.22826086956522, 0.27777777777778
42828, 0.91304347826087, 0.25434782608696, 0.30555555555556
42829, 0.93478260869565, 0.25434782608696, 0.33333333333333
42830, 0.91304347826087, 0.22826086956522, 0.33333333333333
42831, 0.91304347826087, 0.25434782608696, 0.36111111111111
42832, 0.93478260869565, 0.25434782608696, 0.38888888888889
42833, 0.91304347826087, 0.22826086956522, 0.38888888888889
42834, 0.91304347826087, 0.25434782608696, 0.41666666666667
42835, 0.93478260869565, 0.25434782608696, 0.44444444444444
42836, 0.91304347826087, 0.22826086956522, 0.44444444444444
42837, 0.91304347826087, 0.25434782608696, 0.47222222222222
42838, 0.8695652173913, 0.25434782608696, 0.027777777777778
42839, 0.89130434782609, 0.25434782608696, 0.055555555555556
42840, 0.8695652173913, 0.22826086956522, 0.055555555555556
42841, 0.8695652173913, 0.25434782608696, 0.083333333333333
42842, 0.89130434782609, 0.25434782608696, 0.11111111111111
42843, 0.8695652173913, 0.22826086956522, 0.11111111111111
42844, 0.8695652173913, 0.25434782608696, 0.13888888888889
42845, 0.89130434782609, 0.25434782608696, 0.16666666666667
42846, 0.8695652173913, 0.22826086956522, 0.16666666666667
42847, 0.8695652173913, 0.25434782608696, 0.19444444444444
42848, 0.89130434782609, 0.25434782608696, 0.22222222222222
42849, 0.8695652173913, 0.22826086956522, 0.22222222222222
42850, 0.8695652173913, 0.25434782608696, 0.25
42851, 0.89130434782609, 0.25434782608696, 0.27777777777778
42852, 0.8695652173913, 0.22826086956522, 0.27777777777778
42853, 0.8695652173913, 0.25434782608696, 0.30555555555556
42854, 0.89130434782609, 0.25434782608696, 0.33333333333333
42855, 0.8695652173913, 0.22826086956522, 0.33333333333333
42856, 0.8695652173913, 0.25434782608696, 0.36111111111111
42857, 0.89130434782609, 0.25434782608696, 0.38888888888889
42858, 0.8695652173913, 0.22826086956522, 0.38888888888889
42859, 0.8695652173913, 0.25434782608696, 0.41666666666667
42860, 0.89130434782609, 0.25434782608696, 0.44444444444444
42861, 0.8695652173913, 0.22826086956522, 0.44444444444444
42862, 0.8695652173913, 0.25434782608696, 0.47222222222222
42863, 0.82608695652174, 0.25434782608696, 0.027777777777778
42864, 0.84782608695652, 0.25434782608696, 0.055555555555556
42865, 0.82608695652174, 0.22826086956522, 0.055555555555556
42866, 0.82608695652174, 0.25434782608696, 0.083333333333333
42867, 0.84782608695652, 0.25434782608696, 0.11111111111111
42868, 0.82608695652174, 0.22826086956522, 0.11111111111111
42869, 0.82608695652174, 0.25434782608696, 0.13888888888889
42870, 0.84782608695652, 0.25434782608696, 0.16666666666667
42871, 0.82608695652174, 0.22826086956522, 0.16666666666667
42872, 0.82608695652174, 0.25434782608696, 0.19444444444444
42873, 0.84782608695652, 0.25434782608696, 0.22222222222222
42874, 0.82608695652174, 0.22826086956522, 0.22222222222222
42875, 0.82608695652174, 0.25434782608696, 0.25
42876, 0.84782608695652, 0.25434782608696, 0.27777777777778
42877, 0.82608695652174, 0.22826086956522, 0.27777777777778
42878, 0.82608695652174, 0.25434782608696, 0.30555555555556
42879, 0.84782608695652, 0.25434782608696, 0.33333333333333
42880, 0.82608695652174, 0.22826086956522, 0.33333333333333
42881, 0.82608695652174, 0.25434782608696, 0.36111111111111
42882, 0.84782608695652, 0.25434782608696, 0.38888888888889
42883, 0.82608695652174, 0.22826086956522, 0.38888888888889
42884, 0.82608695652174, 0.25434782608696, 0.41666666666667
42885, 0.84782608695652, 0.25434782608696, 0.44444444444444
42886, 0.82608695652174, 0.22826086956522, 0.44444444444444
42887, 0.82608695652174, 0.25434782608696, 0.47222222222222
42888, 0.78260869565217, 0.25434782608696, 0.027777777777778
42889, 0.80434782608696, 0.25434782608696, 0.055555555555556
42890, 0.78260869565217, 0.22826086956522, 0.055555555555556
42891, 0.78260869565217, 0.25434782608696, 0.083333333333333
42892, 0.80434782608696, 0.25434782608696, 0.11111111111111
42893, 0.78260869565217, 0.22826086956522, 0.11111111111111
42894, 0.78260869565217, 0.25434782608696, 0.13888888888889
42895, 0.80434782608696, 0.25434782608696, 0.16666666666667
42896, 0.78260869565217, 0.22826086956522, 0.16666666666667
42897, 0.78260869565217, 0.25434782608696, 0.19444444444444
42898, 0.80434782608696, 0.25434782608696, 0.22222222222222
42899, 0.78260869565217, 0.22826086956522, 0.22222222222222
42900, 0.78260869565217, 0.25434782608696, 0.25
42901, 0.80434782608696, 0.25434782608696, 0.27777777777778
42902, 0.78260869565217, 0.22826086956522, 0.27777777777778
42903, 0.78260869565217, 0.25434782608696, 0.30555555555556
42904, 0.80434782608696, 0.25434782608696, 0.33333333333333
42905, 0.78260869565217, 0.22826086956522, 0.33333333333333
42906, 0.78260869565217, 0.25434782608696, 0.36111111111111
42907, 0.80434782608696, 0.25434782608696, 0.38888888888889
42908, 0.78260869565217, 0.22826086956522, 0.38888888888889
42909, 0.78260869565217, 0.25434782608696, 0.41666666666667
42910, 0.80434782608696, 0.25434782608696, 0.44444444444444
42911, 0.78260869565217, 0.22826086956522, 0.44444444444444
42912, 0.78260869565217, 0.25434782608696, 0.47222222222222
42913, 0.73913043478261, 0.25434782608696, 0.027777777777778
42914, 0.76086956521739, 0.25434782608696, 0.055555555555556
42915, 0.73913043478261, 0.22826086956522, 0.055555555555556
42916, 0.73913043478261, 0.25434782608696, 0.083333333333333
42917, 0.76086956521739, 0.25434782608696, 0.11111111111111
42918, 0.73913043478261, 0.22826086956522, 0.11111111111111
42919, 0.73913043478261, 0.25434782608696, 0.13888888888889
42920, 0.76086956521739, 0.25434782608696, 0.16666666666667
42921, 0.73913043478261, 0.22826086956522, 0.16666666666667
42922, 0.73913043478261, 0.25434782608696, 0.19444444444444
42923, 0.76086956521739, 0.25434782608696, 0.22222222222222
42924, 0.73913043478261, 0.22826086956522, 0.22222222222222
42925, 0.73913043478261, 0.25434782608696, 0.25
42926, 0.76086956521739, 0.25434782608696, 0.27777777777778
42927, 0.73913043478261, 0.22826086956522, 0.27777777777778
42928, 0.73913043478261, 0.25434782608696, 0.30555555555556
42929, 0.76086956521739, 0.25434782608696, 0.33333333333333
42930, 0.73913043478261, 0.22826086956522, 0.33333333333333
42931, 0.73913043478261, 0.25434782608696, 0.36111111111111
42932, 0.76086956521739, 0.25434782608696, 0.38888888888889
42933, 0.73913043478261, 0.22826086956522, 0.38888888888889
42934, 0.73913043478261, 0.25434782608696, 0.41666666666667
42935, 0.76086956521739, 0.25434782608696, 0.44444444444444
42936, 0.73913043478261, 0.22826086956522, 0.44444444444444
42937, 0.73913043478261, 0.25434782608696, 0.47222222222222
42938, 0.69565217391304, 0.25434782608696, 0.027777777777778
42939, 0.71739130434783, 0.25434782608696, 0.055555555555556
42940, 0.69565217391304, 0.22826086956522, 0.055555555555556
42941, 0.69565217391304, 0.25434782608696, 0.083333333333333
42942, 0.71739130434783, 0.25434782608696, 0.11111111111111
42943, 0.69565217391304, 0.22826086956522, 0.11111111111111
42944, 0.69565217391304, 0.25434782608696, 0.13888888888889
42945, 0.71739130434783, 0.25434782608696, 0.16666666666667
42946, 0.69565217391304, 0.22826086956522, 0.16666666666667
42947, 0.69565217391304, 0.25434782608696, 0.19444444444444
42948, 0.71739130434783, 0.25434782608696, 0.22222222222222
42949, 0.69565217391304, 0.22826086956522, 0.22222222222222
42950, 0.69565217391304, 0.25434782608696, 0.25
42951, 0.71739130434783, 0.25434782608696, 0.27777777777778
42952, 0.69565217391304, 0.22826086956522, 0.27777777777778
42953, 0.69565217391304, 0.25434782608696, 0.30555555555556
42954, 0.71739130434783, 0.25434782608696, 0.33333333333333
42955, 0.69565217391304, 0.22826086956522, 0.33333333333333
42956, 0.69565217391304, 0.25434782608696, 0.36111111111111
42957, 0.71739130434783, 0.25434782608696, 0.38888888888889
42958, 0.69565217391304, 0.22826086956522, 0.38888888888889
42959, 0.69565217391304, 0.25434782608696, 0.41666666666667
42960, 0.71739130434783, 0.25434782608696, 0.44444444444444
42961, 0.69565217391304, 0.22826086956522, 0.44444444444444
42962, 0.69565217391304, 0.25434782608696, 0.47222222222222
42963, 0.65217391304348, 0.25434782608696, 0.027777777777778
42964, 0.67391304347826, 0.25434782608696, 0.055555555555556
42965, 0.65217391304348, 0.22826086956522, 0.055555555555556
42966, 0.65217391304348, 0.25434782608696, 0.083333333333333
42967, 0.67391304347826, 0.25434782608696, 0.11111111111111
42968, 0.65217391304348, 0.22826086956522, 0.11111111111111
42969, 0.65217391304348, 0.25434782608696, 0.13888888888889
42970, 0.67391304347826, 0.25434782608696, 0.16666666666667
42971, 0.65217391304348, 0.22826086956522, 0.16666666666667
42972, 0.65217391304348, 0.25434782608696, 0.19444444444444
42973, 0.67391304347826, 0.25434782608696, 0.22222222222222
42974, 0.65217391304348, 0.22826086956522, 0.22222222222222
42975, 0.65217391304348, 0.25434782608696, 0.25
42976, 0.67391304347826, 0.25434782608696, 0.27777777777778
42977, 0.65217391304348, 0.22826086956522, 0.27777777777778
42978, 0.65217391304348, 0.25434782608696, 0.30555555555556
42979, 0.67391304347826, 0.25434782608696, 0.33333333333333
42980, 0.65217391304348, 0.22826086956522, 0.33333333333333
42981, 0.65217391304348, 0.25434782608696, 0.36111111111111
42982, 0.67391304347826, 0.25434782608696, 0.38888888888889
42983, 0.65217391304348, 0.22826086956522, 0.38888888888889
42984, 0.65217391304348, 0.25434782608696, 0.41666666666667
42985, 0.67391304347826, 0.25434782608696, 0.44444444444444
42986, 0.65217391304348, 0.22826086956522, 0.44444444444444
42987, 0.65217391304348, 0.25434782608696, 0.47222222222222
42988, 0.60869565217391, 0.25434782608696, 0.027777777777778
42989, 0.6304347826087, 0.25434782608696, 0.055555555555556
42990, 0.60869565217391, 0.22826086956522, 0.055555555555556
42991, 0.60869565217391, 0.25434782608696, 0.083333333333333
42992, 0.6304347826087, 0.25434782608696, 0.11111111111111
42993, 0.60869565217391, 0.22826086956522, 0.11111111111111
42994, 0.60869565217391, 0.25434782608696, 0.13888888888889
42995, 0.6304347826087, 0.25434782608696, 0.16666666666667
42996, 0.60869565217391, 0.22826086956522, 0.16666666666667
42997, 0.60869565217391, 0.25434782608696, 0.19444444444444
42998, 0.6304347826087, 0.25434782608696, 0.22222222222222
42999, 0.60869565217391, 0.22826086956522, 0.22222222222222
43000, 0.60869565217391, 0.25434782608696, 0.25
43001, 0.6304347826087, 0.25434782608696, 0.27777777777778
43002, 0.60869565217391, 0.22826086956522, 0.27777777777778
43003, 0.60869565217391, 0.25434782608696, 0.30555555555556
43004, 0.6304347826087, 0.25434782608696, 0.33333333333333
43005, 0.60869565217391, 0.22826086956522, 0.33333333333333
43006, 0.60869565217391, 0.25434782608696, 0.36111111111111
43007, 0.6304347826087, 0.25434782608696, 0.38888888888889
43008, 0.60869565217391, 0.22826086956522, 0.38888888888889
43009, 0.60869565217391, 0.25434782608696, 0.41666666666667
43010, 0.6304347826087, 0.25434782608696, 0.44444444444444
43011, 0.60869565217391, 0.22826086956522, 0.44444444444444
43012, 0.60869565217391, 0.25434782608696, 0.47222222222222
43013, 0.56521739130435, 0.25434782608696, 0.027777777777778
43014, 0.58695652173913, 0.25434782608696, 0.055555555555556
43015, 0.56521739130435, 0.22826086956522, 0.055555555555556
43016, 0.56521739130435, 0.25434782608696, 0.083333333333333
43017, 0.58695652173913, 0.25434782608696, 0.11111111111111
43018, 0.56521739130435, 0.22826086956522, 0.11111111111111
43019, 0.56521739130435, 0.25434782608696, 0.13888888888889
43020, 0.58695652173913, 0.25434782608696, 0.16666666666667
43021, 0.56521739130435, 0.22826086956522, 0.16666666666667
43022, 0.56521739130435, 0.25434782608696, 0.19444444444444
43023, 0.58695652173913, 0.25434782608696, 0.22222222222222
43024, 0.56521739130435, 0.22826086956522, 0.22222222222222
43025, 0.56521739130435, 0.25434782608696, 0.25
43026, 0.58695652173913, 0.25434782608696, 0.27777777777778
43027, 0.56521739130435, 0.22826086956522, 0.27777777777778
43028, 0.56521739130435, 0.25434782608696, 0.30555555555556
43029, 0.58695652173913, 0.25434782608696, 0.33333333333333
43030, 0.56521739130435, 0.22826086956522, 0.33333333333333
43031, 0.56521739130435, 0.25434782608696, 0.36111111111111
43032, 0.58695652173913, 0.25434782608696, 0.38888888888889
43033, 0.56521739130435, 0.22826086956522, 0.38888888888889
43034, 0.56521739130435, 0.25434782608696, 0.41666666666667
43035, 0.58695652173913, 0.25434782608696, 0.44444444444444
43036, 0.56521739130435, 0.22826086956522, 0.44444444444444
43037, 0.56521739130435, 0.25434782608696, 0.47222222222222
43038, 0.52173913043478, 0.25434782608696, 0.027777777777778
43039, 0.54347826086957, 0.25434782608696, 0.055555555555556
43040, 0.52173913043478, 0.22826086956522, 0.055555555555556
43041, 0.52173913043478, 0.25434782608696, 0.083333333333333
43042, 0.54347826086957, 0.25434782608696, 0.11111111111111
43043, 0.52173913043478, 0.22826086956522, 0.11111111111111
43044, 0.52173913043478, 0.25434782608696, 0.13888888888889
43045, 0.54347826086957, 0.25434782608696, 0.16666666666667
43046, 0.52173913043478, 0.22826086956522, 0.16666666666667
43047, 0.52173913043478, 0.25434782608696, 0.19444444444444
43048, 0.54347826086956, 0.25434782608696, 0.22222222222222
43049, 0.52173913043478, 0.22826086956522, 0.22222222222222
43050, 0.52173913043478, 0.25434782608696, 0.25
43051, 0.54347826086956, 0.25434782608696, 0.27777777777778
43052, 0.52173913043478, 0.22826086956522, 0.27777777777778
43053, 0.52173913043478, 0.25434782608696, 0.30555555555556
43054, 0.54347826086956, 0.25434782608696, 0.33333333333333
43055, 0.52173913043478, 0.22826086956522, 0.33333333333333
43056, 0.52173913043478, 0.25434782608696, 0.36111111111111
43057, 0.54347826086956, 0.25434782608696, 0.38888888888889
43058, 0.52173913043478, 0.22826086956522, 0.38888888888889
43059, 0.52173913043478, 0.25434782608696, 0.41666666666667
43060, 0.54347826086956, 0.25434782608696, 0.44444444444444
43061, 0.52173913043478, 0.22826086956522, 0.44444444444444
43062, 0.52173913043478, 0.25434782608696, 0.47222222222222
43063, 0.47826086956522, 0.25434782608696, 0.027777777777778
43064, 0.5, 0.25434782608696, 0.055555555555556
43065, 0.47826086956522, 0.22826086956522, 0.055555555555556
43066, 0.47826086956522, 0.25434782608696, 0.083333333333333
43067, 0.5, 0.25434782608696, 0.11111111111111
43068, 0.47826086956522, 0.22826086956522, 0.11111111111111
43069, 0.47826086956522, 0.25434782608696, 0.13888888888889
43070, 0.5, 0.25434782608696, 0.16666666666667
43071, 0.47826086956522, 0.22826086956522, 0.16666666666667
43072, 0.47826086956522, 0.25434782608696, 0.19444444444444
43073, 0.5, 0.25434782608696, 0.22222222222222
43074, 0.47826086956522, 0.22826086956522, 0.22222222222222
43075, 0.47826086956522, 0.25434782608696, 0.25
43076, 0.5, 0.25434782608696, 0.27777777777778
43077, 0.47826086956522, 0.22826086956522, 0.27777777777778
43078, 0.47826086956522, 0.25434782608696, 0.30555555555556
43079, 0.5, 0.25434782608696, 0.33333333333333
43080, 0.47826086956522, 0.22826086956522, 0.33333333333333
43081, 0.47826086956522, 0.25434782608696, 0.36111111111111
43082, 0.5, 0.25434782608696, 0.38888888888889
43083, 0.47826086956522, 0.22826086956522, 0.38888888888889
43084, 0.47826086956522, 0.25434782608696, 0.41666666666667
43085, 0.5, 0.25434782608696, 0.44444444444444
43086, 0.47826086956522, 0.22826086956522, 0.44444444444444
43087, 0.47826086956522, 0.25434782608696, 0.47222222222222
43088, 0.43478260869565, 0.25434782608696, 0.027777777777778
43089, 0.45652173913043, 0.25434782608696, 0.055555555555556
43090, 0.43478260869565, 0.22826086956522, 0.055555555555556
43091, 0.43478260869565, 0.25434782608696, 0.083333333333333
43092, 0.45652173913044, 0.25434782608696, 0.11111111111111
43093, 0.43478260869565, 0.22826086956522, 0.11111111111111
43094, 0.43478260869565, 0.25434782608696, 0.13888888888889
43095, 0.45652173913043, 0.25434782608696, 0.16666666666667
43096, 0.43478260869565, 0.22826086956522, 0.16666666666667
43097, 0.43478260869565, 0.25434782608696, 0.19444444444444
43098, 0.45652173913043, 0.25434782608696, 0.22222222222222
43099, 0.43478260869565, 0.22826086956522, 0.22222222222222
43100, 0.43478260869565, 0.25434782608696, 0.25
43101, 0.45652173913043, 0.25434782608696, 0.27777777777778
43102, 0.43478260869565, 0.22826086956522, 0.27777777777778
43103, 0.43478260869565, 0.25434782608696, 0.30555555555556
43104, 0.45652173913043, 0.25434782608696, 0.33333333333333
43105, 0.43478260869565, 0.22826086956522, 0.33333333333333
43106, 0.43478260869565, 0.25434782608696, 0.36111111111111
43107, 0.45652173913044, 0.25434782608696, 0.38888888888889
43108, 0.43478260869565, 0.22826086956522, 0.38888888888889
43109, 0.43478260869565, 0.25434782608696, 0.41666666666667
43110, 0.45652173913043, 0.25434782608696, 0.44444444444444
43111, 0.43478260869565, 0.22826086956522, 0.44444444444444
43112, 0.43478260869565, 0.25434782608696, 0.47222222222222
43113, 0.39130434782609, 0.25434782608696, 0.027777777777778
43114, 0.41304347826087, 0.25434782608696, 0.055555555555556
43115, 0.39130434782609, 0.22826086956522, 0.055555555555556
43116, 0.39130434782609, 0.25434782608696, 0.083333333333333
43117, 0.41304347826087, 0.25434782608696, 0.11111111111111
43118, 0.39130434782609, 0.22826086956522, 0.11111111111111
43119, 0.39130434782609, 0.25434782608696, 0.13888888888889
43120, 0.41304347826087, 0.25434782608696, 0.16666666666667
43121, 0.39130434782609, 0.22826086956522, 0.16666666666667
43122, 0.39130434782609, 0.25434782608696, 0.19444444444444
43123, 0.41304347826087, 0.25434782608696, 0.22222222222222
43124, 0.39130434782609, 0.22826086956522, 0.22222222222222
43125, 0.39130434782609, 0.25434782608696, 0.25
43126, 0.41304347826087, 0.25434782608696, 0.27777777777778
43127, 0.39130434782609, 0.22826086956522, 0.27777777777778
43128, 0.39130434782609, 0.25434782608696, 0.30555555555556
43129, 0.41304347826087, 0.25434782608696, 0.33333333333333
43130, 0.39130434782609, 0.22826086956522, 0.33333333333333
43131, 0.39130434782609, 0.25434782608696, 0.36111111111111
43132, 0.41304347826087, 0.25434782608696, 0.38888888888889
43133, 0.39130434782609, 0.22826086956522, 0.38888888888889
43134, 0.39130434782609, 0.25434782608696, 0.41666666666667
43135, 0.41304347826087, 0.25434782608696, 0.44444444444444
43136, 0.39130434782609, 0.22826086956522, 0.44444444444444
43137, 0.39130434782609, 0.25434782608696, 0.47222222222222
43138, 0.34782608695652, 0.25434782608696, 0.027777777777778
43139, 0.3695652173913, 0.25434782608696, 0.055555555555556
43140, 0.34782608695652, 0.22826086956522, 0.055555555555556
43141, 0.34782608695652, 0.25434782608696, 0.083333333333333
43142, 0.3695652173913, 0.25434782608696, 0.11111111111111
43143, 0.34782608695652, 0.22826086956522, 0.11111111111111
43144, 0.34782608695652, 0.25434782608696, 0.13888888888889
43145, 0.3695652173913, 0.25434782608696, 0.16666666666667
43146, 0.34782608695652, 0.22826086956522, 0.16666666666667
43147, 0.34782608695652, 0.25434782608696, 0.19444444444444
43148, 0.3695652173913, 0.25434782608696, 0.22222222222222
43149, 0.34782608695652, 0.22826086956522, 0.22222222222222
43150, 0.34782608695652, 0.25434782608696, 0.25
43151, 0.3695652173913, 0.25434782608696, 0.27777777777778
43152, 0.34782608695652, 0.22826086956522, 0.27777777777778
43153, 0.34782608695652, 0.25434782608696, 0.30555555555556
43154, 0.3695652173913, 0.25434782608696, 0.33333333333333
43155, 0.34782608695652, 0.22826086956522, 0.33333333333333
43156, 0.34782608695652, 0.25434782608696, 0.36111111111111
43157, 0.3695652173913, 0.25434782608696, 0.38888888888889
43158, 0.34782608695652, 0.22826086956522, 0.38888888888889
43159, 0.34782608695652, 0.25434782608696, 0.41666666666667
43160, 0.3695652173913, 0.25434782608696, 0.44444444444444
43161, 0.34782608695652, 0.22826086956522, 0.44444444444444
43162, 0.34782608695652, 0.25434782608696, 0.47222222222222
43163, 0.30434782608696, 0.25434782608696, 0.027777777777778
43164, 0.32608695652174, 0.25434782608696, 0.055555555555556
43165, 0.30434782608696, 0.22826086956522, 0.055555555555556
43166, 0.30434782608696, 0.25434782608696, 0.083333333333333
43167, 0.32608695652174, 0.25434782608696, 0.11111111111111
43168, 0.30434782608696, 0.22826086956522, 0.11111111111111
43169, 0.30434782608696, 0.25434782608696, 0.13888888888889
43170, 0.32608695652174, 0.25434782608696, 0.16666666666667
43171, 0.30434782608696, 0.22826086956522, 0.16666666666667
43172, 0.30434782608696, 0.25434782608696, 0.19444444444444
43173, 0.32608695652174, 0.25434782608696, 0.22222222222222
43174, 0.30434782608696, 0.22826086956522, 0.22222222222222
43175, 0.30434782608696, 0.25434782608696, 0.25
43176, 0.32608695652174, 0.25434782608696, 0.27777777777778
43177, 0.30434782608696, 0.22826086956522, 0.27777777777778
43178, 0.30434782608696, 0.25434782608696, 0.30555555555556
43179, 0.32608695652174, 0.25434782608696, 0.33333333333333
43180, 0.30434782608696, 0.22826086956522, 0.33333333333333
43181, 0.30434782608696, 0.25434782608696, 0.36111111111111
43182, 0.32608695652174, 0.25434782608696, 0.38888888888889
43183, 0.30434782608696, 0.22826086956522, 0.38888888888889
43184, 0.30434782608696, 0.25434782608696, 0.41666666666667
43185, 0.32608695652174, 0.25434782608696, 0.44444444444444
43186, 0.30434782608696, 0.22826086956522, 0.44444444444444
43187, 0.30434782608696, 0.25434782608696, 0.47222222222222
43188, 0.26086956521739, 0.25434782608696, 0.027777777777778
43189, 0.28260869565217, 0.25434782608696, 0.055555555555556
43190, 0.26086956521739, 0.22826086956522, 0.055555555555556
43191, 0.26086956521739, 0.25434782608696, 0.083333333333333
43192, 0.28260869565217, 0.25434782608696, 0.11111111111111
43193, 0.26086956521739, 0.22826086956522, 0.11111111111111
43194, 0.26086956521739, 0.25434782608696, 0.13888888888889
43195, 0.28260869565217, 0.25434782608696, 0.16666666666667
43196, 0.26086956521739, 0.22826086956522, 0.16666666666667
43197, 0.26086956521739, 0.25434782608696, 0.19444444444444
43198, 0.28260869565217, 0.25434782608696, 0.22222222222222
43199, 0.26086956521739, 0.22826086956522, 0.22222222222222
43200, 0.26086956521739, 0.25434782608696, 0.25
43201, 0.28260869565217, 0.25434782608696, 0.27777777777778
43202, 0.26086956521739, 0.22826086956522, 0.27777777777778
43203, 0.26086956521739, 0.25434782608696, 0.30555555555556
43204, 0.28260869565217, 0.25434782608696, 0.33333333333333
43205, 0.26086956521739, 0.22826086956522, 0.33333333333333
43206, 0.26086956521739, 0.25434782608696, 0.36111111111111
43207, 0.28260869565217, 0.25434782608696, 0.38888888888889
43208, 0.26086956521739, 0.22826086956522, 0.38888888888889
43209, 0.26086956521739, 0.25434782608696, 0.41666666666667
43210, 0.28260869565217, 0.25434782608696, 0.44444444444444
43211, 0.26086956521739, 0.22826086956522, 0.44444444444444
43212, 0.26086956521739, 0.25434782608696, 0.47222222222222
43213, 0.21739130434783, 0.25434782608696, 0.027777777777778
43214, 0.23913043478261, 0.25434782608696, 0.055555555555556
43215, 0.21739130434783, 0.22826086956522, 0.055555555555556
43216, 0.21739130434783, 0.25434782608696, 0.083333333333333
43217, 0.23913043478261, 0.25434782608696, 0.11111111111111
43218, 0.21739130434783, 0.22826086956522, 0.11111111111111
43219, 0.21739130434783, 0.25434782608696, 0.13888888888889
43220, 0.23913043478261, 0.25434782608696, 0.16666666666667
43221, 0.21739130434783, 0.22826086956522, 0.16666666666667
43222, 0.21739130434783, 0.25434782608696, 0.19444444444444
43223, 0.23913043478261, 0.25434782608696, 0.22222222222222
43224, 0.21739130434783, 0.22826086956522, 0.22222222222222
43225, 0.21739130434783, 0.25434782608696, 0.25
43226, 0.23913043478261, 0.25434782608696, 0.27777777777778
43227, 0.21739130434783, 0.22826086956522, 0.27777777777778
43228, 0.21739130434783, 0.25434782608696, 0.30555555555556
43229, 0.23913043478261, 0.25434782608696, 0.33333333333333
43230, 0.21739130434783, 0.22826086956522, 0.33333333333333
43231, 0.21739130434783, 0.25434782608696, 0.36111111111111
43232, 0.23913043478261, 0.25434782608696, 0.38888888888889
43233, 0.21739130434783, 0.22826086956522, 0.38888888888889
43234, 0.21739130434783, 0.25434782608696, 0.41666666666667
43235, 0.23913043478261, 0.25434782608696, 0.44444444444444
43236, 0.21739130434783, 0.22826086956522, 0.44444444444444
43237, 0.21739130434783, 0.25434782608696, 0.47222222222222
43238, 0.17391304347826, 0.25434782608696, 0.027777777777778
43239, 0.19565217391304, 0.25434782608696, 0.055555555555556
43240, 0.17391304347826, 0.22826086956522, 0.055555555555556
43241, 0.17391304347826, 0.25434782608696, 0.083333333333333
43242, 0.19565217391304, 0.25434782608696, 0.11111111111111
43243, 0.17391304347826, 0.22826086956522, 0.11111111111111
43244, 0.17391304347826, 0.25434782608696, 0.13888888888889
43245, 0.19565217391304, 0.25434782608696, 0.16666666666667
43246, 0.17391304347826, 0.22826086956522, 0.16666666666667
43247, 0.17391304347826, 0.25434782608696, 0.19444444444444
43248, 0.19565217391304, 0.25434782608696, 0.22222222222222
43249, 0.17391304347826, 0.22826086956522, 0.22222222222222
43250, 0.17391304347826, 0.25434782608696, 0.25
43251, 0.19565217391304, 0.25434782608696, 0.27777777777778
43252, 0.17391304347826, 0.22826086956522, 0.27777777777778
43253, 0.17391304347826, 0.25434782608696, 0.30555555555556
43254, 0.19565217391304, 0.25434782608696, 0.33333333333333
43255, 0.17391304347826, 0.22826086956522, 0.33333333333333
43256, 0.17391304347826, 0.25434782608696, 0.36111111111111
43257, 0.19565217391304, 0.25434782608696, 0.38888888888889
43258, 0.17391304347826, 0.22826086956522, 0.38888888888889
43259, 0.17391304347826, 0.25434782608696, 0.41666666666667
43260, 0.19565217391304, 0.25434782608696, 0.44444444444444
43261, 0.17391304347826, 0.22826086956522, 0.44444444444444
43262, 0.17391304347826, 0.25434782608696, 0.47222222222222
43263, 0.1304347826087, 0.25434782608696, 0.027777777777778
43264, 0.15217391304348, 0.25434782608696, 0.055555555555556
43265, 0.1304347826087, 0.22826086956522, 0.055555555555556
43266, 0.1304347826087, 0.25434782608696, 0.083333333333333
43267, 0.15217391304348, 0.25434782608696, 0.11111111111111
43268, 0.1304347826087, 0.22826086956522, 0.11111111111111
43269, 0.1304347826087, 0.25434782608696, 0.13888888888889
43270, 0.15217391304348, 0.25434782608696, 0.16666666666667
43271, 0.1304347826087, 0.22826086956522, 0.16666666666667
43272, 0.1304347826087, 0.25434782608696, 0.19444444444444
43273, 0.15217391304348, 0.25434782608696, 0.22222222222222
43274, 0.1304347826087, 0.22826086956522, 0.22222222222222
43275, 0.1304347826087, 0.25434782608696, 0.25
43276, 0.15217391304348, 0.25434782608696, 0.27777777777778
43277, 0.1304347826087, 0.22826086956522, 0.27777777777778
43278, 0.1304347826087, 0.25434782608696, 0.30555555555556
43279, 0.15217391304348, 0.25434782608696, 0.33333333333333
43280, 0.1304347826087, 0.22826086956522, 0.33333333333333
43281, 0.1304347826087, 0.25434782608696, 0.36111111111111
43282, 0.15217391304348, 0.25434782608696, 0.38888888888889
43283, 0.1304347826087, 0.22826086956522, 0.38888888888889
43284, 0.1304347826087, 0.25434782608696, 0.41666666666667
43285, 0.15217391304348, 0.25434782608696, 0.44444444444444
43286, 0.1304347826087, 0.22826086956522, 0.44444444444444
43287, 0.1304347826087, 0.25434782608696, 0.47222222222222
43288, 0.08695652173913, 0.25434782608696, 0.027777777777778
43289, 0.10869565217391, 0.25434782608696, 0.055555555555556
43290, 0.08695652173913, 0.22826086956522, 0.055555555555556
43291, 0.08695652173913, 0.25434782608696, 0.083333333333333
43292, 0.10869565217391, 0.25434782608696, 0.11111111111111
43293, 0.08695652173913, 0.22826086956522, 0.11111111111111
43294, 0.08695652173913, 0.25434782608696, 0.13888888888889
43295, 0.10869565217391, 0.25434782608696, 0.16666666666667
43296, 0.08695652173913, 0.22826086956522, 0.16666666666667
43297, 0.08695652173913, 0.25434782608696, 0.19444444444444
43298, 0.10869565217391, 0.25434782608696, 0.22222222222222
43299, 0.08695652173913, 0.22826086956522, 0.22222222222222
43300, 0.08695652173913, 0.25434782608696, 0.25
43301, 0.10869565217391, 0.25434782608696, 0.27777777777778
43302, 0.08695652173913, 0.22826086956522, 0.27777777777778
43303, 0.08695652173913, 0.25434782608696, 0.30555555555556
43304, 0.10869565217391, 0.25434782608696, 0.33333333333333
43305, 0.08695652173913, 0.22826086956522, 0.33333333333333
43306, 0.08695652173913, 0.25434782608696, 0.36111111111111
43307, 0.10869565217391, 0.25434782608696, 0.38888888888889
43308, 0.08695652173913, 0.22826086956522, 0.38888888888889
43309, 0.08695652173913, 0.25434782608696, 0.41666666666667
43310, 0.10869565217391, 0.25434782608696, 0.44444444444444
43311, 0.08695652173913, 0.22826086956522, 0.44444444444444
43312, 0.08695652173913, 0.25434782608696, 0.47222222222222
43313, 0.043478260869565, 0.25434782608696, 0.027777777777778
43314, 0.065217391304348, 0.25434782608696, 0.055555555555556
43315, 0.043478260869565, 0.22826086956522, 0.055555555555556
43316, 0.043478260869565, 0.25434782608696, 0.083333333333333
43317, 0.065217391304348, 0.25434782608696, 0.11111111111111
43318, 0.043478260869565, 0.22826086956522, 0.11111111111111
43319, 0.043478260869565, 0.25434782608696, 0.13888888888889
43320, 0.065217391304348, 0.25434782608696, 0.16666666666667
43321, 0.043478260869565, 0.22826086956522, 0.16666666666667
43322, 0.043478260869565, 0.25434782608696, 0.19444444444444
43323, 0.065217391304348, 0.25434782608696, 0.22222222222222
43324, 0.043478260869565, 0.22826086956522, 0.22222222222222
43325, 0.043478260869565, 0.25434782608696, 0.25
43326, 0.065217391304348, 0.25434782608696, 0.27777777777778
43327, 0.043478260869565, 0.22826086956522, 0.27777777777778
43328, 0.043478260869565, 0.25434782608696, 0.30555555555556
43329, 0.065217391304348, 0.25434782608696, 0.33333333333333
43330, 0.043478260869565, 0.22826086956522, 0.33333333333333
43331, 0.043478260869565, 0.25434782608696, 0.36111111111111
43332, 0.065217391304348, 0.25434782608696, 0.38888888888889
43333, 0.043478260869565, 0.22826086956522, 0.38888888888889
43334, 0.043478260869565, 0.25434782608696, 0.41666666666667
43335, 0.065217391304348, 0.25434782608696, 0.44444444444444
43336, 0.043478260869565, 0.22826086956522, 0.44444444444444
43337, 0.043478260869565, 0.25434782608696, 0.47222222222222
43338, 0.021739130434783, 0.25434782608696, 0.055555555555556
43339, 0.021739130434783, 0.25434782608696, 0.11111111111111
43340, 0.021739130434783, 0.25434782608696, 0.16666666666667
43341, 0.021739130434783, 0.25434782608696, 0.22222222222222
43342, 0.021739130434783, 0.25434782608696, 0.27777777777778
43343, 0.021739130434783, 0.25434782608696, 0.33333333333333
43344, 0.021739130434783, 0.25434782608696, 0.38888888888889
43345, 0.021739130434783, 0.25434782608696, 0.44444444444444
43346, 0.95652173913044, 0.30652173913043, 0.027777777777778
43347, 0.97826086956522, 0.30652173913043, 0.055555555555556
43348, 0.95652173913043, 0.2804347826087, 0.055555555555556
43349, 0.95652173913044, 0.30652173913043, 0.083333333333333
43350, 0.97826086956522, 0.30652173913043, 0.11111111111111
43351, 0.95652173913044, 0.2804347826087, 0.11111111111111
43352, 0.95652173913044, 0.30652173913043, 0.13888888888889
43353, 0.97826086956522, 0.30652173913043, 0.16666666666667
43354, 0.95652173913044, 0.2804347826087, 0.16666666666667
43355, 0.95652173913044, 0.30652173913043, 0.19444444444444
43356, 0.97826086956522, 0.30652173913043, 0.22222222222222
43357, 0.95652173913044, 0.2804347826087, 0.22222222222222
43358, 0.95652173913044, 0.30652173913043, 0.25
43359, 0.97826086956522, 0.30652173913043, 0.27777777777778
43360, 0.95652173913044, 0.2804347826087, 0.27777777777778
43361, 0.95652173913044, 0.30652173913043, 0.30555555555556
43362, 0.97826086956522, 0.30652173913043, 0.33333333333333
43363, 0.95652173913044, 0.2804347826087, 0.33333333333333
43364, 0.95652173913044, 0.30652173913043, 0.36111111111111
43365, 0.97826086956522, 0.30652173913043, 0.38888888888889
43366, 0.95652173913043, 0.2804347826087, 0.38888888888889
43367, 0.95652173913044, 0.30652173913043, 0.41666666666667
43368, 0.97826086956522, 0.30652173913043, 0.44444444444444
43369, 0.95652173913043, 0.2804347826087, 0.44444444444444
43370, 0.95652173913044, 0.30652173913043, 0.47222222222222
43371, 0.91304347826087, 0.30652173913043, 0.027777777777778
43372, 0.93478260869565, 0.30652173913043, 0.055555555555556
43373, 0.91304347826087, 0.2804347826087, 0.055555555555556
43374, 0.91304347826087, 0.30652173913043, 0.083333333333333
43375, 0.93478260869565, 0.30652173913043, 0.11111111111111
43376, 0.91304347826087, 0.2804347826087, 0.11111111111111
43377, 0.91304347826087, 0.30652173913043, 0.13888888888889
43378, 0.93478260869565, 0.30652173913043, 0.16666666666667
43379, 0.91304347826087, 0.2804347826087, 0.16666666666667
43380, 0.91304347826087, 0.30652173913043, 0.19444444444444
43381, 0.93478260869565, 0.30652173913043, 0.22222222222222
43382, 0.91304347826087, 0.2804347826087, 0.22222222222222
43383, 0.91304347826087, 0.30652173913043, 0.25
43384, 0.93478260869565, 0.30652173913043, 0.27777777777778
43385, 0.91304347826087, 0.2804347826087, 0.27777777777778
43386, 0.91304347826087, 0.30652173913043, 0.30555555555556
43387, 0.93478260869565, 0.30652173913043, 0.33333333333333
43388, 0.91304347826087, 0.2804347826087, 0.33333333333333
43389, 0.91304347826087, 0.30652173913043, 0.36111111111111
43390, 0.93478260869565, 0.30652173913043, 0.38888888888889
43391, 0.91304347826087, 0.2804347826087, 0.38888888888889
43392, 0.91304347826087, 0.30652173913043, 0.41666666666667
43393, 0.93478260869565, 0.30652173913043, 0.44444444444444
43394, 0.91304347826087, 0.2804347826087, 0.44444444444444
43395, 0.91304347826087, 0.30652173913043, 0.47222222222222
43396, 0.8695652173913, 0.30652173913043, 0.027777777777778
43397, 0.89130434782609, 0.30652173913043, 0.055555555555556
43398, 0.8695652173913, 0.2804347826087, 0.055555555555556
43399, 0.8695652173913, 0.30652173913043, 0.083333333333333
43400, 0.89130434782609, 0.30652173913043, 0.11111111111111
43401, 0.8695652173913, 0.2804347826087, 0.11111111111111
43402, 0.8695652173913, 0.30652173913043, 0.13888888888889
43403, 0.89130434782609, 0.30652173913043, 0.16666666666667
43404, 0.8695652173913, 0.2804347826087, 0.16666666666667
43405, 0.8695652173913, 0.30652173913043, 0.19444444444444
43406, 0.89130434782609, 0.30652173913043, 0.22222222222222
43407, 0.8695652173913, 0.2804347826087, 0.22222222222222
43408, 0.8695652173913, 0.30652173913043, 0.25
43409, 0.89130434782609, 0.30652173913043, 0.27777777777778
43410, 0.8695652173913, 0.2804347826087, 0.27777777777778
43411, 0.8695652173913, 0.30652173913043, 0.30555555555556
43412, 0.89130434782609, 0.30652173913043, 0.33333333333333
43413, 0.8695652173913, 0.2804347826087, 0.33333333333333
43414, 0.8695652173913, 0.30652173913043, 0.36111111111111
43415, 0.89130434782609, 0.30652173913043, 0.38888888888889
43416, 0.8695652173913, 0.2804347826087, 0.38888888888889
43417, 0.8695652173913, 0.30652173913043, 0.41666666666667
43418, 0.89130434782609, 0.30652173913043, 0.44444444444444
43419, 0.8695652173913, 0.2804347826087, 0.44444444444444
43420, 0.8695652173913, 0.30652173913043, 0.47222222222222
43421, 0.82608695652174, 0.30652173913043, 0.027777777777778
43422, 0.84782608695652, 0.30652173913043, 0.055555555555556
43423, 0.82608695652174, 0.2804347826087, 0.055555555555556
43424, 0.82608695652174, 0.30652173913043, 0.083333333333333
43425, 0.84782608695652, 0.30652173913043, 0.11111111111111
43426, 0.82608695652174, 0.2804347826087, 0.11111111111111
43427, 0.82608695652174, 0.30652173913043, 0.13888888888889
43428, 0.84782608695652, 0.30652173913043, 0.16666666666667
43429, 0.82608695652174, 0.2804347826087, 0.16666666666667
43430, 0.82608695652174, 0.30652173913043, 0.19444444444444
43431, 0.84782608695652, 0.30652173913043, 0.22222222222222
43432, 0.82608695652174, 0.2804347826087, 0.22222222222222
43433, 0.82608695652174, 0.30652173913043, 0.25
43434, 0.84782608695652, 0.30652173913043, 0.27777777777778
43435, 0.82608695652174, 0.2804347826087, 0.27777777777778
43436, 0.82608695652174, 0.30652173913043, 0.30555555555556
43437, 0.84782608695652, 0.30652173913043, 0.33333333333333
43438, 0.82608695652174, 0.2804347826087, 0.33333333333333
43439, 0.82608695652174, 0.30652173913043, 0.36111111111111
43440, 0.84782608695652, 0.30652173913043, 0.38888888888889
43441, 0.82608695652174, 0.2804347826087, 0.38888888888889
43442, 0.82608695652174, 0.30652173913043, 0.41666666666667
43443, 0.84782608695652, 0.30652173913043, 0.44444444444444
43444, 0.82608695652174, 0.2804347826087, 0.44444444444444
43445, 0.82608695652174, 0.30652173913043, 0.47222222222222
43446, 0.78260869565217, 0.30652173913043, 0.027777777777778
43447, 0.80434782608696, 0.30652173913043, 0.055555555555556
43448, 0.78260869565217, 0.2804347826087, 0.055555555555556
43449, 0.78260869565217, 0.30652173913043, 0.083333333333333
43450, 0.80434782608696, 0.30652173913043, 0.11111111111111
43451, 0.78260869565217, 0.2804347826087, 0.11111111111111
43452, 0.78260869565217, 0.30652173913043, 0.13888888888889
43453, 0.80434782608696, 0.30652173913043, 0.16666666666667
43454, 0.78260869565217, 0.2804347826087, 0.16666666666667
43455, 0.78260869565217, 0.30652173913043, 0.19444444444444
43456, 0.80434782608696, 0.30652173913043, 0.22222222222222
43457, 0.78260869565217, 0.2804347826087, 0.22222222222222
43458, 0.78260869565217, 0.30652173913043, 0.25
43459, 0.80434782608696, 0.30652173913043, 0.27777777777778
43460, 0.78260869565217, 0.2804347826087, 0.27777777777778
43461, 0.78260869565217, 0.30652173913043, 0.30555555555556
43462, 0.80434782608696, 0.30652173913043, 0.33333333333333
43463, 0.78260869565217, 0.2804347826087, 0.33333333333333
43464, 0.78260869565217, 0.30652173913043, 0.36111111111111
43465, 0.80434782608696, 0.30652173913043, 0.38888888888889
43466, 0.78260869565217, 0.2804347826087, 0.38888888888889
43467, 0.78260869565217, 0.30652173913043, 0.41666666666667
43468, 0.80434782608696, 0.30652173913043, 0.44444444444444
43469, 0.78260869565217, 0.2804347826087, 0.44444444444444
43470, 0.78260869565217, 0.30652173913043, 0.47222222222222
43471, 0.73913043478261, 0.30652173913043, 0.027777777777778
43472, 0.76086956521739, 0.30652173913043, 0.055555555555556
43473, 0.73913043478261, 0.2804347826087, 0.055555555555556
43474, 0.73913043478261, 0.30652173913043, 0.083333333333333
43475, 0.76086956521739, 0.30652173913043, 0.11111111111111
43476, 0.73913043478261, 0.2804347826087, 0.11111111111111
43477, 0.73913043478261, 0.30652173913043, 0.13888888888889
43478, 0.76086956521739, 0.30652173913043, 0.16666666666667
43479, 0.73913043478261, 0.2804347826087, 0.16666666666667
43480, 0.73913043478261, 0.30652173913043, 0.19444444444444
43481, 0.76086956521739, 0.30652173913043, 0.22222222222222
43482, 0.73913043478261, 0.2804347826087, 0.22222222222222
43483, 0.73913043478261, 0.30652173913043, 0.25
43484, 0.76086956521739, 0.30652173913043, 0.27777777777778
43485, 0.73913043478261, 0.2804347826087, 0.27777777777778
43486, 0.73913043478261, 0.30652173913043, 0.30555555555556
43487, 0.76086956521739, 0.30652173913043, 0.33333333333333
43488, 0.73913043478261, 0.2804347826087, 0.33333333333333
43489, 0.73913043478261, 0.30652173913043, 0.36111111111111
43490, 0.76086956521739, 0.30652173913043, 0.38888888888889
43491, 0.73913043478261, 0.2804347826087, 0.38888888888889
43492, 0.73913043478261, 0.30652173913043, 0.41666666666667
43493, 0.76086956521739, 0.30652173913043, 0.44444444444444
43494, 0.73913043478261, 0.2804347826087, 0.44444444444444
43495, 0.73913043478261, 0.30652173913043, 0.47222222222222
43496, 0.69565217391304, 0.30652173913043, 0.027777777777778
43497, 0.71739130434783, 0.30652173913043, 0.055555555555556
43498, 0.69565217391304, 0.2804347826087, 0.055555555555556
43499, 0.69565217391304, 0.30652173913043, 0.083333333333333
43500, 0.71739130434783, 0.30652173913043, 0.11111111111111
43501, 0.69565217391304, 0.2804347826087, 0.11111111111111
43502, 0.69565217391304, 0.30652173913043, 0.13888888888889
43503, 0.71739130434783, 0.30652173913043, 0.16666666666667
43504, 0.69565217391304, 0.2804347826087, 0.16666666666667
43505, 0.69565217391304, 0.30652173913043, 0.19444444444444
43506, 0.71739130434783, 0.30652173913043, 0.22222222222222
43507, 0.69565217391304, 0.2804347826087, 0.22222222222222
43508, 0.69565217391304, 0.30652173913043, 0.25
43509, 0.71739130434783, 0.30652173913043, 0.27777777777778
43510, 0.69565217391304, 0.2804347826087, 0.27777777777778
43511, 0.69565217391304, 0.30652173913043, 0.30555555555556
43512, 0.71739130434783, 0.30652173913043, 0.33333333333333
43513, 0.69565217391304, 0.2804347826087, 0.33333333333333
43514, 0.69565217391304, 0.30652173913043, 0.36111111111111
43515, 0.71739130434783, 0.30652173913043, 0.38888888888889
43516, 0.69565217391304, 0.2804347826087, 0.38888888888889
43517, 0.69565217391304, 0.30652173913043, 0.41666666666667
43518, 0.71739130434783, 0.30652173913043, 0.44444444444444
43519, 0.69565217391304, 0.2804347826087, 0.44444444444444
43520, 0.69565217391304, 0.30652173913043, 0.47222222222222
43521, 0.65217391304348, 0.30652173913043, 0.027777777777778
43522, 0.67391304347826, 0.30652173913043, 0.055555555555556
43523, 0.65217391304348, 0.2804347826087, 0.055555555555556
43524, 0.65217391304348, 0.30652173913043, 0.083333333333333
43525, 0.67391304347826, 0.30652173913043, 0.11111111111111
43526, 0.65217391304348, 0.2804347826087, 0.11111111111111
43527, 0.65217391304348, 0.30652173913043, 0.13888888888889
43528, 0.67391304347826, 0.30652173913043, 0.16666666666667
43529, 0.65217391304348, 0.2804347826087, 0.16666666666667
43530, 0.65217391304348, 0.30652173913043, 0.19444444444444
43531, 0.67391304347826, 0.30652173913043, 0.22222222222222
43532, 0.65217391304348, 0.2804347826087, 0.22222222222222
43533, 0.65217391304348, 0.30652173913043, 0.25
43534, 0.67391304347826, 0.30652173913043, 0.27777777777778
43535, 0.65217391304348, 0.2804347826087, 0.27777777777778
43536, 0.65217391304348, 0.30652173913043, 0.30555555555556
43537, 0.67391304347826, 0.30652173913043, 0.33333333333333
43538, 0.65217391304348, 0.2804347826087, 0.33333333333333
43539, 0.65217391304348, 0.30652173913043, 0.36111111111111
43540, 0.67391304347826, 0.30652173913043, 0.38888888888889
43541, 0.65217391304348, 0.2804347826087, 0.38888888888889
43542, 0.65217391304348, 0.30652173913043, 0.41666666666667
43543, 0.67391304347826, 0.30652173913043, 0.44444444444444
43544, 0.65217391304348, 0.2804347826087, 0.44444444444444
43545, 0.65217391304348, 0.30652173913043, 0.47222222222222
43546, 0.60869565217391, 0.30652173913043, 0.027777777777778
43547, 0.6304347826087, 0.30652173913043, 0.055555555555556
43548, 0.60869565217391, 0.2804347826087, 0.055555555555556
43549, 0.60869565217391, 0.30652173913043, 0.083333333333333
43550, 0.6304347826087, 0.30652173913043, 0.11111111111111
43551, 0.60869565217391, 0.2804347826087, 0.11111111111111
43552, 0.60869565217391, 0.30652173913043, 0.13888888888889
43553, 0.6304347826087, 0.30652173913043, 0.16666666666667
43554, 0.60869565217391, 0.2804347826087, 0.16666666666667
43555, 0.60869565217391, 0.30652173913043, 0.19444444444444
43556, 0.6304347826087, 0.30652173913043, 0.22222222222222
43557, 0.60869565217391, 0.2804347826087, 0.22222222222222
43558, 0.60869565217391, 0.30652173913043, 0.25
43559, 0.6304347826087, 0.30652173913043, 0.27777777777778
43560, 0.60869565217391, 0.2804347826087, 0.27777777777778
43561, 0.60869565217391, 0.30652173913043, 0.30555555555556
43562, 0.6304347826087, 0.30652173913043, 0.33333333333333
43563, 0.60869565217391, 0.2804347826087, 0.33333333333333
43564, 0.60869565217391, 0.30652173913043, 0.36111111111111
43565, 0.6304347826087, 0.30652173913043, 0.38888888888889
43566, 0.60869565217391, 0.2804347826087, 0.38888888888889
43567, 0.60869565217391, 0.30652173913043, 0.41666666666667
43568, 0.6304347826087, 0.30652173913043, 0.44444444444444
43569, 0.60869565217391, 0.2804347826087, 0.44444444444444
43570, 0.60869565217391, 0.30652173913043, 0.47222222222222
43571, 0.56521739130435, 0.30652173913043, 0.027777777777778
43572, 0.58695652173913, 0.30652173913043, 0.055555555555556
43573, 0.56521739130435, 0.2804347826087, 0.055555555555556
43574, 0.56521739130435, 0.30652173913043, 0.083333333333333
43575, 0.58695652173913, 0.30652173913043, 0.11111111111111
43576, 0.56521739130435, 0.2804347826087, 0.11111111111111
43577, 0.56521739130435, 0.30652173913043, 0.13888888888889
43578, 0.58695652173913, 0.30652173913043, 0.16666666666667
43579, 0.56521739130435, 0.2804347826087, 0.16666666666667
43580, 0.56521739130435, 0.30652173913043, 0.19444444444444
43581, 0.58695652173913, 0.30652173913043, 0.22222222222222
43582, 0.56521739130435, 0.2804347826087, 0.22222222222222
43583, 0.56521739130435, 0.30652173913043, 0.25
43584, 0.58695652173913, 0.30652173913043, 0.27777777777778
43585, 0.56521739130435, 0.2804347826087, 0.27777777777778
43586, 0.56521739130435, 0.30652173913043, 0.30555555555556
43587, 0.58695652173913, 0.30652173913043, 0.33333333333333
43588, 0.56521739130435, 0.2804347826087, 0.33333333333333
43589, 0.56521739130435, 0.30652173913043, 0.36111111111111
43590, 0.58695652173913, 0.30652173913043, 0.38888888888889
43591, 0.56521739130435, 0.2804347826087, 0.38888888888889
43592, 0.56521739130435, 0.30652173913043, 0.41666666666667
43593, 0.58695652173913, 0.30652173913043, 0.44444444444444
43594, 0.56521739130435, 0.2804347826087, 0.44444444444444
43595, 0.56521739130435, 0.30652173913043, 0.47222222222222
43596, 0.52173913043478, 0.30652173913043, 0.027777777777778
43597, 0.54347826086957, 0.30652173913043, 0.055555555555556
43598, 0.52173913043478, 0.2804347826087, 0.055555555555556
43599, 0.52173913043478, 0.30652173913043, 0.083333333333333
43600, 0.54347826086957, 0.30652173913043, 0.11111111111111
43601, 0.52173913043478, 0.2804347826087, 0.11111111111111
43602, 0.52173913043478, 0.30652173913043, 0.13888888888889
43603, 0.54347826086957, 0.30652173913043, 0.16666666666667
43604, 0.52173913043478, 0.2804347826087, 0.16666666666667
43605, 0.52173913043478, 0.30652173913043, 0.19444444444444
43606, 0.54347826086956, 0.30652173913043, 0.22222222222222
43607, 0.52173913043478, 0.2804347826087, 0.22222222222222
43608, 0.52173913043478, 0.30652173913043, 0.25
43609, 0.54347826086956, 0.30652173913043, 0.27777777777778
43610, 0.52173913043478, 0.2804347826087, 0.27777777777778
43611, 0.52173913043478, 0.30652173913043, 0.30555555555556
43612, 0.54347826086956, 0.30652173913043, 0.33333333333333
43613, 0.52173913043478, 0.2804347826087, 0.33333333333333
43614, 0.52173913043478, 0.30652173913043, 0.36111111111111
43615, 0.54347826086956, 0.30652173913043, 0.38888888888889
43616, 0.52173913043478, 0.2804347826087, 0.38888888888889
43617, 0.52173913043478, 0.30652173913043, 0.41666666666667
43618, 0.54347826086956, 0.30652173913043, 0.44444444444444
43619, 0.52173913043478, 0.2804347826087, 0.44444444444444
43620, 0.52173913043478, 0.30652173913043, 0.47222222222222
43621, 0.47826086956522, 0.30652173913043, 0.027777777777778
43622, 0.5, 0.30652173913043, 0.055555555555556
43623, 0.47826086956522, 0.2804347826087, 0.055555555555556
43624, 0.47826086956522, 0.30652173913043, 0.083333333333333
43625, 0.5, 0.30652173913043, 0.11111111111111
43626, 0.47826086956522, 0.2804347826087, 0.11111111111111
43627, 0.47826086956522, 0.30652173913043, 0.13888888888889
43628, 0.5, 0.30652173913043, 0.16666666666667
43629, 0.47826086956522, 0.2804347826087, 0.16666666666667
43630, 0.47826086956522, 0.30652173913043, 0.19444444444444
43631, 0.5, 0.30652173913043, 0.22222222222222
43632, 0.47826086956522, 0.2804347826087, 0.22222222222222
43633, 0.47826086956522, 0.30652173913043, 0.25
43634, 0.5, 0.30652173913043, 0.27777777777778
43635, 0.47826086956522, 0.2804347826087, 0.27777777777778
43636, 0.47826086956522, 0.30652173913043, 0.30555555555556
43637, 0.5, 0.30652173913043, 0.33333333333333
43638, 0.47826086956522, 0.2804347826087, 0.33333333333333
43639, 0.47826086956522, 0.30652173913043, 0.36111111111111
43640, 0.5, 0.30652173913043, 0.38888888888889
43641, 0.47826086956522, 0.2804347826087, 0.38888888888889
43642, 0.47826086956522, 0.30652173913043, 0.41666666666667
43643, 0.5, 0.30652173913043, 0.44444444444444
43644, 0.47826086956522, 0.2804347826087, 0.44444444444444
43645, 0.47826086956522, 0.30652173913043, 0.47222222222222
43646, 0.43478260869565, 0.30652173913043, 0.027777777777778
43647, 0.45652173913043, 0.30652173913043, 0.055555555555556
43648, 0.43478260869565, 0.2804347826087, 0.055555555555556
43649, 0.43478260869565, 0.30652173913043, 0.083333333333333
43650, 0.45652173913043, 0.30652173913043, 0.11111111111111
43651, 0.43478260869565, 0.2804347826087, 0.11111111111111
43652, 0.43478260869565, 0.30652173913043, 0.13888888888889
43653, 0.45652173913043, 0.30652173913043, 0.16666666666667
43654, 0.43478260869565, 0.2804347826087, 0.16666666666667
43655, 0.43478260869565, 0.30652173913043, 0.19444444444444
43656, 0.45652173913043, 0.30652173913043, 0.22222222222222
43657, 0.43478260869565, 0.2804347826087, 0.22222222222222
43658, 0.43478260869565, 0.30652173913043, 0.25
43659, 0.45652173913043, 0.30652173913043, 0.27777777777778
43660, 0.43478260869565, 0.2804347826087, 0.27777777777778
43661, 0.43478260869565, 0.30652173913043, 0.30555555555556
43662, 0.45652173913043, 0.30652173913043, 0.33333333333333
43663, 0.43478260869565, 0.2804347826087, 0.33333333333333
43664, 0.43478260869565, 0.30652173913043, 0.36111111111111
43665, 0.45652173913043, 0.30652173913043, 0.38888888888889
43666, 0.43478260869565, 0.2804347826087, 0.38888888888889
43667, 0.43478260869565, 0.30652173913043, 0.41666666666667
43668, 0.45652173913043, 0.30652173913043, 0.44444444444444
43669, 0.43478260869565, 0.2804347826087, 0.44444444444444
43670, 0.43478260869565, 0.30652173913043, 0.47222222222222
43671, 0.39130434782609, 0.30652173913043, 0.027777777777778
43672, 0.41304347826087, 0.30652173913043, 0.055555555555556
43673, 0.39130434782609, 0.2804347826087, 0.055555555555556
43674, 0.39130434782609, 0.30652173913043, 0.083333333333333
43675, 0.41304347826087, 0.30652173913043, 0.11111111111111
43676, 0.39130434782609, 0.2804347826087, 0.11111111111111
43677, 0.39130434782609, 0.30652173913043, 0.13888888888889
43678, 0.41304347826087, 0.30652173913043, 0.16666666666667
43679, 0.39130434782609, 0.2804347826087, 0.16666666666667
43680, 0.39130434782609, 0.30652173913043, 0.19444444444444
43681, 0.41304347826087, 0.30652173913043, 0.22222222222222
43682, 0.39130434782609, 0.2804347826087, 0.22222222222222
43683, 0.39130434782609, 0.30652173913043, 0.25
43684, 0.41304347826087, 0.30652173913043, 0.27777777777778
43685, 0.39130434782609, 0.2804347826087, 0.27777777777778
43686, 0.39130434782609, 0.30652173913043, 0.30555555555556
43687, 0.41304347826087, 0.30652173913043, 0.33333333333333
43688, 0.39130434782609, 0.2804347826087, 0.33333333333333
43689, 0.39130434782609, 0.30652173913043, 0.36111111111111
43690, 0.41304347826087, 0.30652173913043, 0.38888888888889
43691, 0.39130434782609, 0.2804347826087, 0.38888888888889
43692, 0.39130434782609, 0.30652173913043, 0.41666666666667
43693, 0.41304347826087, 0.30652173913043, 0.44444444444444
43694, 0.39130434782609, 0.2804347826087, 0.44444444444444
43695, 0.39130434782609, 0.30652173913043, 0.47222222222222
43696, 0.34782608695652, 0.30652173913043, 0.027777777777778
43697, 0.3695652173913, 0.30652173913043, 0.055555555555556
43698, 0.34782608695652, 0.2804347826087, 0.055555555555556
43699, 0.34782608695652, 0.30652173913043, 0.083333333333333
43700, 0.3695652173913, 0.30652173913043, 0.11111111111111
43701, 0.34782608695652, 0.2804347826087, 0.11111111111111
43702, 0.34782608695652, 0.30652173913043, 0.13888888888889
43703, 0.3695652173913, 0.30652173913043, 0.16666666666667
43704, 0.34782608695652, 0.2804347826087, 0.16666666666667
43705, 0.34782608695652, 0.30652173913043, 0.19444444444444
43706, 0.3695652173913, 0.30652173913043, 0.22222222222222
43707, 0.34782608695652, 0.2804347826087, 0.22222222222222
43708, 0.34782608695652, 0.30652173913043, 0.25
43709, 0.3695652173913, 0.30652173913043, 0.27777777777778
43710, 0.34782608695652, 0.2804347826087, 0.27777777777778
43711, 0.34782608695652, 0.30652173913043, 0.30555555555556
43712, 0.3695652173913, 0.30652173913043, 0.33333333333333
43713, 0.34782608695652, 0.2804347826087, 0.33333333333333
43714, 0.34782608695652, 0.30652173913043, 0.36111111111111
43715, 0.3695652173913, 0.30652173913043, 0.38888888888889
43716, 0.34782608695652, 0.2804347826087, 0.38888888888889
43717, 0.34782608695652, 0.30652173913043, 0.41666666666667
43718, 0.3695652173913, 0.30652173913043, 0.44444444444444
43719, 0.34782608695652, 0.2804347826087, 0.44444444444444
43720, 0.34782608695652, 0.30652173913043, 0.47222222222222
43721, 0.30434782608696, 0.30652173913043, 0.027777777777778
43722, 0.32608695652174, 0.30652173913043, 0.055555555555556
43723, 0.30434782608696, 0.2804347826087, 0.055555555555556
43724, 0.30434782608696, 0.30652173913043, 0.083333333333333
43725, 0.32608695652174, 0.30652173913043, 0.11111111111111
43726, 0.30434782608696, 0.2804347826087, 0.11111111111111
43727, 0.30434782608696, 0.30652173913043, 0.13888888888889
43728, 0.32608695652174, 0.30652173913043, 0.16666666666667
43729, 0.30434782608696, 0.2804347826087, 0.16666666666667
43730, 0.30434782608696, 0.30652173913043, 0.19444444444444
43731, 0.32608695652174, 0.30652173913043, 0.22222222222222
43732, 0.30434782608696, 0.2804347826087, 0.22222222222222
43733, 0.30434782608696, 0.30652173913043, 0.25
43734, 0.32608695652174, 0.30652173913043, 0.27777777777778
43735, 0.30434782608696, 0.2804347826087, 0.27777777777778
43736, 0.30434782608696, 0.30652173913043, 0.30555555555556
43737, 0.32608695652174, 0.30652173913043, 0.33333333333333
43738, 0.30434782608696, 0.2804347826087, 0.33333333333333
43739, 0.30434782608696, 0.30652173913043, 0.36111111111111
43740, 0.32608695652174, 0.30652173913043, 0.38888888888889
43741, 0.30434782608696, 0.2804347826087, 0.38888888888889
43742, 0.30434782608696, 0.30652173913043, 0.41666666666667
43743, 0.32608695652174, 0.30652173913043, 0.44444444444444
43744, 0.30434782608696, 0.2804347826087, 0.44444444444444
43745, 0.30434782608696, 0.30652173913043, 0.47222222222222
43746, 0.26086956521739, 0.30652173913043, 0.027777777777778
43747, 0.28260869565217, 0.30652173913043, 0.055555555555556
43748, 0.26086956521739, 0.2804347826087, 0.055555555555556
43749, 0.26086956521739, 0.30652173913043, 0.083333333333333
43750, 0.28260869565217, 0.30652173913043, 0.11111111111111
43751, 0.26086956521739, 0.2804347826087, 0.11111111111111
43752, 0.26086956521739, 0.30652173913043, 0.13888888888889
43753, 0.28260869565217, 0.30652173913043, 0.16666666666667
43754, 0.26086956521739, 0.2804347826087, 0.16666666666667
43755, 0.26086956521739, 0.30652173913043, 0.19444444444444
43756, 0.28260869565217, 0.30652173913043, 0.22222222222222
43757, 0.26086956521739, 0.2804347826087, 0.22222222222222
43758, 0.26086956521739, 0.30652173913043, 0.25
43759, 0.28260869565217, 0.30652173913043, 0.27777777777778
43760, 0.26086956521739, 0.2804347826087, 0.27777777777778
43761, 0.26086956521739, 0.30652173913043, 0.30555555555556
43762, 0.28260869565217, 0.30652173913043, 0.33333333333333
43763, 0.26086956521739, 0.2804347826087, 0.33333333333333
43764, 0.26086956521739, 0.30652173913043, 0.36111111111111
43765, 0.28260869565217, 0.30652173913043, 0.38888888888889
43766, 0.26086956521739, 0.2804347826087, 0.38888888888889
43767, 0.26086956521739, 0.30652173913043, 0.41666666666667
43768, 0.28260869565217, 0.30652173913043, 0.44444444444444
43769, 0.26086956521739, 0.2804347826087, 0.44444444444444
43770, 0.26086956521739, 0.30652173913043, 0.47222222222222
43771, 0.21739130434783, 0.30652173913043, 0.027777777777778
43772, 0.23913043478261, 0.30652173913043, 0.055555555555556
43773, 0.21739130434783, 0.2804347826087, 0.055555555555556
43774, 0.21739130434783, 0.30652173913043, 0.083333333333333
43775, 0.23913043478261, 0.30652173913043, 0.11111111111111
43776, 0.21739130434783, 0.2804347826087, 0.11111111111111
43777, 0.21739130434783, 0.30652173913043, 0.13888888888889
43778, 0.23913043478261, 0.30652173913043, 0.16666666666667
43779, 0.21739130434783, 0.2804347826087, 0.16666666666667
43780, 0.21739130434783, 0.30652173913043, 0.19444444444444
43781, 0.23913043478261, 0.30652173913043, 0.22222222222222
43782, 0.21739130434783, 0.2804347826087, 0.22222222222222
43783, 0.21739130434783, 0.30652173913043, 0.25
43784, 0.23913043478261, 0.30652173913043, 0.27777777777778
43785, 0.21739130434783, 0.2804347826087, 0.27777777777778
43786, 0.21739130434783, 0.30652173913043, 0.30555555555556
43787, 0.23913043478261, 0.30652173913043, 0.33333333333333
43788, 0.21739130434783, 0.2804347826087, 0.33333333333333
43789, 0.21739130434783, 0.30652173913043, 0.36111111111111
43790, 0.23913043478261, 0.30652173913043, 0.38888888888889
43791, 0.21739130434783, 0.2804347826087, 0.38888888888889
43792, 0.21739130434783, 0.30652173913043, 0.41666666666667
43793, 0.23913043478261, 0.30652173913043, 0.44444444444444
43794, 0.21739130434783, 0.2804347826087, 0.44444444444444
43795, 0.21739130434783, 0.30652173913043, 0.47222222222222
43796, 0.17391304347826, 0.30652173913043, 0.027777777777778
43797, 0.19565217391304, 0.30652173913043, 0.055555555555556
43798, 0.17391304347826, 0.2804347826087, 0.055555555555556
43799, 0.17391304347826, 0.30652173913043, 0.083333333333333
43800, 0.19565217391304, 0.30652173913043, 0.11111111111111
43801, 0.17391304347826, 0.2804347826087, 0.11111111111111
43802, 0.17391304347826, 0.30652173913043, 0.13888888888889
43803, 0.19565217391304, 0.30652173913043, 0.16666666666667
43804, 0.17391304347826, 0.2804347826087, 0.16666666666667
43805, 0.17391304347826, 0.30652173913043, 0.19444444444444
43806, 0.19565217391304, 0.30652173913043, 0.22222222222222
43807, 0.17391304347826, 0.2804347826087, 0.22222222222222
43808, 0.17391304347826, 0.30652173913043, 0.25
43809, 0.19565217391304, 0.30652173913043, 0.27777777777778
43810, 0.17391304347826, 0.2804347826087, 0.27777777777778
43811, 0.17391304347826, 0.30652173913043, 0.30555555555556
43812, 0.19565217391304, 0.30652173913043, 0.33333333333333
43813, 0.17391304347826, 0.2804347826087, 0.33333333333333
43814, 0.17391304347826, 0.30652173913043, 0.36111111111111
43815, 0.19565217391304, 0.30652173913043, 0.38888888888889
43816, 0.17391304347826, 0.2804347826087, 0.38888888888889
43817, 0.17391304347826, 0.30652173913043, 0.41666666666667
43818, 0.19565217391304, 0.30652173913043, 0.44444444444444
43819, 0.17391304347826, 0.2804347826087, 0.44444444444444
43820, 0.17391304347826, 0.30652173913043, 0.47222222222222
43821, 0.1304347826087, 0.30652173913043, 0.027777777777778
43822, 0.15217391304348, 0.30652173913043, 0.055555555555556
43823, 0.1304347826087, 0.2804347826087, 0.055555555555556
43824, 0.1304347826087, 0.30652173913043, 0.083333333333333
43825, 0.15217391304348, 0.30652173913043, 0.11111111111111
43826, 0.1304347826087, 0.2804347826087, 0.11111111111111
43827, 0.1304347826087, 0.30652173913043, 0.13888888888889
43828, 0.15217391304348, 0.30652173913043, 0.16666666666667
43829, 0.1304347826087, 0.2804347826087, 0.16666666666667
43830, 0.1304347826087, 0.30652173913043, 0.19444444444444
43831, 0.15217391304348, 0.30652173913043, 0.22222222222222
43832, 0.1304347826087, 0.2804347826087, 0.22222222222222
43833, 0.1304347826087, 0.30652173913043, 0.25
43834, 0.15217391304348, 0.30652173913043, 0.27777777777778
43835, 0.1304347826087, 0.2804347826087, 0.27777777777778
43836, 0.1304347826087, 0.30652173913043, 0.30555555555556
43837, 0.15217391304348, 0.30652173913043, 0.33333333333333
43838, 0.1304347826087, 0.2804347826087, 0.33333333333333
43839, 0.1304347826087, 0.30652173913043, 0.36111111111111
43840, 0.15217391304348, 0.30652173913043, 0.38888888888889
43841, 0.1304347826087, 0.2804347826087, 0.38888888888889
43842, 0.1304347826087, 0.30652173913043, 0.41666666666667
43843, 0.15217391304348, 0.30652173913043, 0.44444444444444
43844, 0.1304347826087, 0.2804347826087, 0.44444444444444
43845, 0.1304347826087, 0.30652173913043, 0.47222222222222
43846, 0.08695652173913, 0.30652173913043, 0.027777777777778
43847, 0.10869565217391, 0.30652173913043, 0.055555555555556
43848, 0.08695652173913, 0.2804347826087, 0.055555555555556
43849, 0.08695652173913, 0.30652173913043, 0.083333333333333
43850, 0.10869565217391, 0.30652173913043, 0.11111111111111
43851, 0.08695652173913, 0.2804347826087, 0.11111111111111
43852, 0.08695652173913, 0.30652173913043, 0.13888888888889
43853, 0.10869565217391, 0.30652173913043, 0.16666666666667
43854, 0.08695652173913, 0.2804347826087, 0.16666666666667
43855, 0.08695652173913, 0.30652173913043, 0.19444444444444
43856, 0.10869565217391, 0.30652173913043, 0.22222222222222
43857, 0.08695652173913, 0.2804347826087, 0.22222222222222
43858, 0.08695652173913, 0.30652173913043, 0.25
43859, 0.10869565217391, 0.30652173913043, 0.27777777777778
43860, 0.08695652173913, 0.2804347826087, 0.27777777777778
43861, 0.08695652173913, 0.30652173913043, 0.30555555555556
43862, 0.10869565217391, 0.30652173913043, 0.33333333333333
43863, 0.08695652173913, 0.2804347826087, 0.33333333333333
43864, 0.08695652173913, 0.30652173913043, 0.36111111111111
43865, 0.10869565217391, 0.30652173913043, 0.38888888888889
43866, 0.08695652173913, 0.2804347826087, 0.38888888888889
43867, 0.08695652173913, 0.30652173913043, 0.41666666666667
43868, 0.10869565217391, 0.30652173913043, 0.44444444444444
43869, 0.08695652173913, 0.2804347826087, 0.44444444444444
43870, 0.08695652173913, 0.30652173913043, 0.47222222222222
43871, 0.043478260869565, 0.30652173913043, 0.027777777777778
43872, 0.065217391304348, 0.30652173913043, 0.055555555555556
43873, 0.043478260869565, 0.2804347826087, 0.055555555555556
43874, 0.043478260869565, 0.30652173913043, 0.083333333333333
43875, 0.065217391304348, 0.30652173913043, 0.11111111111111
43876, 0.043478260869565, 0.2804347826087, 0.11111111111111
43877, 0.043478260869565, 0.30652173913043, 0.13888888888889
43878, 0.065217391304348, 0.30652173913043, 0.16666666666667
43879, 0.043478260869565, 0.2804347826087, 0.16666666666667
43880, 0.043478260869565, 0.30652173913043, 0.19444444444444
43881, 0.065217391304348, 0.30652173913043, 0.22222222222222
43882, 0.043478260869565, 0.2804347826087, 0.22222222222222
43883, 0.043478260869565, 0.30652173913043, 0.25
43884, 0.065217391304348, 0.30652173913043, 0.27777777777778
43885, 0.043478260869565, 0.2804347826087, 0.27777777777778
43886, 0.043478260869565, 0.30652173913043, 0.30555555555556
43887, 0.065217391304348, 0.30652173913043, 0.33333333333333
43888, 0.043478260869565, 0.2804347826087, 0.33333333333333
43889, 0.043478260869565, 0.30652173913043, 0.36111111111111
43890, 0.065217391304348, 0.30652173913043, 0.38888888888889
43891, 0.043478260869565, 0.2804347826087, 0.38888888888889
43892, 0.043478260869565, 0.30652173913043, 0.41666666666667
43893, 0.065217391304348, 0.30652173913043, 0.44444444444444
43894, 0.043478260869565, 0.2804347826087, 0.44444444444444
43895, 0.043478260869565, 0.30652173913043, 0.47222222222222
43896, 0.021739130434783, 0.30652173913043, 0.055555555555556
43897, 0.021739130434783, 0.30652173913043, 0.11111111111111
43898, 0.021739130434783, 0.30652173913043, 0.16666666666667
43899, 0.021739130434783, 0.30652173913043, 0.22222222222222
43900, 0.021739130434783, 0.30652173913043, 0.27777777777778
43901, 0.021739130434783, 0.30652173913043, 0.33333333333333
43902, 0.021739130434783, 0.30652173913043, 0.38888888888889
43903, 0.021739130434783, 0.30652173913043, 0.44444444444444
43904, 0.95652173913043, 0.35869565217391, 0.027777777777778
43905, 0.97826086956522, 0.35869565217391, 0.055555555555556
43906, 0.95652173913044, 0.33260869565217, 0.055555555555556
43907, 0.95652173913043, 0.35869565217391, 0.083333333333333
43908, 0.97826086956522, 0.35869565217391, 0.11111111111111
43909, 0.95652173913044, 0.33260869565217, 0.11111111111111
43910, 0.95652173913044, 0.35869565217391, 0.13888888888889
43911, 0.97826086956522, 0.35869565217391, 0.16666666666667
43912, 0.95652173913044, 0.33260869565217, 0.16666666666667
43913, 0.95652173913044, 0.35869565217391, 0.19444444444444
43914, 0.97826086956522, 0.35869565217391, 0.22222222222222
43915, 0.95652173913044, 0.33260869565217, 0.22222222222222
43916, 0.95652173913044, 0.35869565217391, 0.25
43917, 0.97826086956522, 0.35869565217391, 0.27777777777778
43918, 0.95652173913044, 0.33260869565217, 0.27777777777778
43919, 0.95652173913044, 0.35869565217391, 0.30555555555556
43920, 0.97826086956522, 0.35869565217391, 0.33333333333333
43921, 0.95652173913044, 0.33260869565217, 0.33333333333333
43922, 0.95652173913043, 0.35869565217391, 0.36111111111111
43923, 0.97826086956522, 0.35869565217391, 0.38888888888889
43924, 0.95652173913044, 0.33260869565217, 0.38888888888889
43925, 0.95652173913043, 0.35869565217391, 0.41666666666667
43926, 0.97826086956522, 0.35869565217391, 0.44444444444444
43927, 0.95652173913044, 0.33260869565217, 0.44444444444444
43928, 0.95652173913043, 0.35869565217391, 0.47222222222222
43929, 0.91304347826087, 0.35869565217391, 0.027777777777778
43930, 0.93478260869565, 0.35869565217391, 0.055555555555556
43931, 0.91304347826087, 0.33260869565217, 0.055555555555556
43932, 0.91304347826087, 0.35869565217391, 0.083333333333333
43933, 0.93478260869565, 0.35869565217391, 0.11111111111111
43934, 0.91304347826087, 0.33260869565217, 0.11111111111111
43935, 0.91304347826087, 0.35869565217391, 0.13888888888889
43936, 0.93478260869565, 0.35869565217391, 0.16666666666667
43937, 0.91304347826087, 0.33260869565217, 0.16666666666667
43938, 0.91304347826087, 0.35869565217391, 0.19444444444444
43939, 0.93478260869565, 0.35869565217391, 0.22222222222222
43940, 0.91304347826087, 0.33260869565217, 0.22222222222222
43941, 0.91304347826087, 0.35869565217391, 0.25
43942, 0.93478260869565, 0.35869565217391, 0.27777777777778
43943, 0.91304347826087, 0.33260869565217, 0.27777777777778
43944, 0.91304347826087, 0.35869565217391, 0.30555555555556
43945, 0.93478260869565, 0.35869565217391, 0.33333333333333
43946, 0.91304347826087, 0.33260869565217, 0.33333333333333
43947, 0.91304347826087, 0.35869565217391, 0.36111111111111
43948, 0.93478260869565, 0.35869565217391, 0.38888888888889
43949, 0.91304347826087, 0.33260869565217, 0.38888888888889
43950, 0.91304347826087, 0.35869565217391, 0.41666666666667
43951, 0.93478260869565, 0.35869565217391, 0.44444444444444
43952, 0.91304347826087, 0.33260869565217, 0.44444444444444
43953, 0.91304347826087, 0.35869565217391, 0.47222222222222
43954, 0.8695652173913, 0.35869565217391, 0.027777777777778
43955, 0.89130434782609, 0.35869565217391, 0.055555555555556
43956, 0.8695652173913, 0.33260869565217, 0.055555555555556
43957, 0.8695652173913, 0.35869565217391, 0.083333333333333
43958, 0.89130434782609, 0.35869565217391, 0.11111111111111
43959, 0.8695652173913, 0.33260869565217, 0.11111111111111
43960, 0.8695652173913, 0.35869565217391, 0.13888888888889
43961, 0.89130434782609, 0.35869565217391, 0.16666666666667
43962, 0.8695652173913, 0.33260869565217, 0.16666666666667
43963, 0.8695652173913, 0.35869565217391, 0.19444444444444
43964, 0.89130434782609, 0.35869565217391, 0.22222222222222
43965, 0.8695652173913, 0.33260869565217, 0.22222222222222
43966, 0.8695652173913, 0.35869565217391, 0.25
43967, 0.89130434782609, 0.35869565217391, 0.27777777777778
43968, 0.8695652173913, 0.33260869565217, 0.27777777777778
43969, 0.8695652173913, 0.35869565217391, 0.30555555555556
43970, 0.89130434782609, 0.35869565217391, 0.33333333333333
43971, 0.8695652173913, 0.33260869565217, 0.33333333333333
43972, 0.8695652173913, 0.35869565217391, 0.36111111111111
43973, 0.89130434782609, 0.35869565217391, 0.38888888888889
43974, 0.8695652173913, 0.33260869565217, 0.38888888888889
43975, 0.8695652173913, 0.35869565217391, 0.41666666666667
43976, 0.89130434782609, 0.35869565217391, 0.44444444444444
43977, 0.8695652173913, 0.33260869565217, 0.44444444444444
43978, 0.8695652173913, 0.35869565217391, 0.47222222222222
43979, 0.82608695652174, 0.35869565217391, 0.027777777777778
43980, 0.84782608695652, 0.35869565217391, 0.055555555555556
43981, 0.82608695652174, 0.33260869565217, 0.055555555555556
43982, 0.82608695652174, 0.35869565217391, 0.083333333333333
43983, 0.84782608695652, 0.35869565217391, 0.11111111111111
43984, 0.82608695652174, 0.33260869565217, 0.11111111111111
43985, 0.82608695652174, 0.35869565217391, 0.13888888888889
43986, 0.84782608695652, 0.35869565217391, 0.16666666666667
43987, 0.82608695652174, 0.33260869565217, 0.16666666666667
43988, 0.82608695652174, 0.35869565217391, 0.19444444444444
43989, 0.84782608695652, 0.35869565217391, 0.22222222222222
43990, 0.82608695652174, 0.33260869565217, 0.22222222222222
43991, 0.82608695652174, 0.35869565217391, 0.25
43992, 0.84782608695652, 0.35869565217391, 0.27777777777778
43993, 0.82608695652174, 0.33260869565217, 0.27777777777778
43994, 0.82608695652174, 0.35869565217391, 0.30555555555556
43995, 0.84782608695652, 0.35869565217391, 0.33333333333333
43996, 0.82608695652174, 0.33260869565217, 0.33333333333333
43997, 0.82608695652174, 0.35869565217391, 0.36111111111111
43998, 0.84782608695652, 0.35869565217391, 0.38888888888889
43999, 0.82608695652174, 0.33260869565217, 0.38888888888889
44000, 0.82608695652174, 0.35869565217391, 0.41666666666667
44001, 0.84782608695652, 0.35869565217391, 0.44444444444444
44002, 0.82608695652174, 0.33260869565217, 0.44444444444444
44003, 0.82608695652174, 0.35869565217391, 0.47222222222222
44004, 0.78260869565217, 0.35869565217391, 0.027777777777778
44005, 0.80434782608696, 0.35869565217391, 0.055555555555556
44006, 0.78260869565217, 0.33260869565217, 0.055555555555556
44007, 0.78260869565217, 0.35869565217391, 0.083333333333333
44008, 0.80434782608696, 0.35869565217391, 0.11111111111111
44009, 0.78260869565217, 0.33260869565217, 0.11111111111111
44010, 0.78260869565217, 0.35869565217391, 0.13888888888889
44011, 0.80434782608696, 0.35869565217391, 0.16666666666667
44012, 0.78260869565217, 0.33260869565217, 0.16666666666667
44013, 0.78260869565217, 0.35869565217391, 0.19444444444444
44014, 0.80434782608696, 0.35869565217391, 0.22222222222222
44015, 0.78260869565217, 0.33260869565217, 0.22222222222222
44016, 0.78260869565217, 0.35869565217391, 0.25
44017, 0.80434782608696, 0.35869565217391, 0.27777777777778
44018, 0.78260869565217, 0.33260869565217, 0.27777777777778
44019, 0.78260869565217, 0.35869565217391, 0.30555555555556
44020, 0.80434782608696, 0.35869565217391, 0.33333333333333
44021, 0.78260869565217, 0.33260869565217, 0.33333333333333
44022, 0.78260869565217, 0.35869565217391, 0.36111111111111
44023, 0.80434782608696, 0.35869565217391, 0.38888888888889
44024, 0.78260869565217, 0.33260869565217, 0.38888888888889
44025, 0.78260869565217, 0.35869565217391, 0.41666666666667
44026, 0.80434782608696, 0.35869565217391, 0.44444444444444
44027, 0.78260869565217, 0.33260869565217, 0.44444444444444
44028, 0.78260869565217, 0.35869565217391, 0.47222222222222
44029, 0.73913043478261, 0.35869565217391, 0.027777777777778
44030, 0.76086956521739, 0.35869565217391, 0.055555555555556
44031, 0.73913043478261, 0.33260869565217, 0.055555555555556
44032, 0.73913043478261, 0.35869565217391, 0.083333333333333
44033, 0.76086956521739, 0.35869565217391, 0.11111111111111
44034, 0.73913043478261, 0.33260869565217, 0.11111111111111
44035, 0.73913043478261, 0.35869565217391, 0.13888888888889
44036, 0.76086956521739, 0.35869565217391, 0.16666666666667
44037, 0.73913043478261, 0.33260869565217, 0.16666666666667
44038, 0.73913043478261, 0.35869565217391, 0.19444444444444
44039, 0.76086956521739, 0.35869565217391, 0.22222222222222
44040, 0.73913043478261, 0.33260869565217, 0.22222222222222
44041, 0.73913043478261, 0.35869565217391, 0.25
44042, 0.76086956521739, 0.35869565217391, 0.27777777777778
44043, 0.73913043478261, 0.33260869565217, 0.27777777777778
44044, 0.73913043478261, 0.35869565217391, 0.30555555555556
44045, 0.76086956521739, 0.35869565217391, 0.33333333333333
44046, 0.73913043478261, 0.33260869565217, 0.33333333333333
44047, 0.73913043478261, 0.35869565217391, 0.36111111111111
44048, 0.76086956521739, 0.35869565217391, 0.38888888888889
44049, 0.73913043478261, 0.33260869565217, 0.38888888888889
44050, 0.73913043478261, 0.35869565217391, 0.41666666666667
44051, 0.76086956521739, 0.35869565217391, 0.44444444444444
44052, 0.73913043478261, 0.33260869565217, 0.44444444444444
44053, 0.73913043478261, 0.35869565217391, 0.47222222222222
44054, 0.69565217391304, 0.35869565217391, 0.027777777777778
44055, 0.71739130434783, 0.35869565217391, 0.055555555555556
44056, 0.69565217391304, 0.33260869565217, 0.055555555555556
44057, 0.69565217391304, 0.35869565217391, 0.083333333333333
44058, 0.71739130434783, 0.35869565217391, 0.11111111111111
44059, 0.69565217391304, 0.33260869565217, 0.11111111111111
44060, 0.69565217391304, 0.35869565217391, 0.13888888888889
44061, 0.71739130434783, 0.35869565217391, 0.16666666666667
44062, 0.69565217391304, 0.33260869565217, 0.16666666666667
44063, 0.69565217391304, 0.35869565217391, 0.19444444444444
44064, 0.71739130434783, 0.35869565217391, 0.22222222222222
44065, 0.69565217391304, 0.33260869565217, 0.22222222222222
44066, 0.69565217391304, 0.35869565217391, 0.25
44067, 0.71739130434783, 0.35869565217391, 0.27777777777778
44068, 0.69565217391304, 0.33260869565217, 0.27777777777778
44069, 0.69565217391304, 0.35869565217391, 0.30555555555556
44070, 0.71739130434783, 0.35869565217391, 0.33333333333333
44071, 0.69565217391304, 0.33260869565217, 0.33333333333333
44072, 0.69565217391304, 0.35869565217391, 0.36111111111111
44073, 0.71739130434783, 0.35869565217391, 0.38888888888889
44074, 0.69565217391304, 0.33260869565217, 0.38888888888889
44075, 0.69565217391304, 0.35869565217391, 0.41666666666667
44076, 0.71739130434783, 0.35869565217391, 0.44444444444444
44077, 0.69565217391304, 0.33260869565217, 0.44444444444444
44078, 0.69565217391304, 0.35869565217391, 0.47222222222222
44079, 0.65217391304348, 0.35869565217391, 0.027777777777778
44080, 0.67391304347826, 0.35869565217391, 0.055555555555556
44081, 0.65217391304348, 0.33260869565217, 0.055555555555556
44082, 0.65217391304348, 0.35869565217391, 0.083333333333333
44083, 0.67391304347826, 0.35869565217391, 0.11111111111111
44084, 0.65217391304348, 0.33260869565217, 0.11111111111111
44085, 0.65217391304348, 0.35869565217391, 0.13888888888889
44086, 0.67391304347826, 0.35869565217391, 0.16666666666667
44087, 0.65217391304348, 0.33260869565217, 0.16666666666667
44088, 0.65217391304348, 0.35869565217391, 0.19444444444444
44089, 0.67391304347826, 0.35869565217391, 0.22222222222222
44090, 0.65217391304348, 0.33260869565217, 0.22222222222222
44091, 0.65217391304348, 0.35869565217391, 0.25
44092, 0.67391304347826, 0.35869565217391, 0.27777777777778
44093, 0.65217391304348, 0.33260869565217, 0.27777777777778
44094, 0.65217391304348, 0.35869565217391, 0.30555555555556
44095, 0.67391304347826, 0.35869565217391, 0.33333333333333
44096, 0.65217391304348, 0.33260869565217, 0.33333333333333
44097, 0.65217391304348, 0.35869565217391, 0.36111111111111
44098, 0.67391304347826, 0.35869565217391, 0.38888888888889
44099, 0.65217391304348, 0.33260869565217, 0.38888888888889
44100, 0.65217391304348, 0.35869565217391, 0.41666666666667
44101, 0.67391304347826, 0.35869565217391, 0.44444444444444
44102, 0.65217391304348, 0.33260869565217, 0.44444444444444
44103, 0.65217391304348, 0.35869565217391, 0.47222222222222
44104, 0.60869565217391, 0.35869565217391, 0.027777777777778
44105, 0.6304347826087, 0.35869565217391, 0.055555555555556
44106, 0.60869565217391, 0.33260869565217, 0.055555555555556
44107, 0.60869565217391, 0.35869565217391, 0.083333333333333
44108, 0.6304347826087, 0.35869565217391, 0.11111111111111
44109, 0.60869565217391, 0.33260869565217, 0.11111111111111
44110, 0.60869565217391, 0.35869565217391, 0.13888888888889
44111, 0.6304347826087, 0.35869565217391, 0.16666666666667
44112, 0.60869565217391, 0.33260869565217, 0.16666666666667
44113, 0.60869565217391, 0.35869565217391, 0.19444444444444
44114, 0.6304347826087, 0.35869565217391, 0.22222222222222
44115, 0.60869565217391, 0.33260869565217, 0.22222222222222
44116, 0.60869565217391, 0.35869565217391, 0.25
44117, 0.6304347826087, 0.35869565217391, 0.27777777777778
44118, 0.60869565217391, 0.33260869565217, 0.27777777777778
44119, 0.60869565217391, 0.35869565217391, 0.30555555555556
44120, 0.6304347826087, 0.35869565217391, 0.33333333333333
44121, 0.60869565217391, 0.33260869565217, 0.33333333333333
44122, 0.60869565217391, 0.35869565217391, 0.36111111111111
44123, 0.6304347826087, 0.35869565217391, 0.38888888888889
44124, 0.60869565217391, 0.33260869565217, 0.38888888888889
44125, 0.60869565217391, 0.35869565217391, 0.41666666666667
44126, 0.6304347826087, 0.35869565217391, 0.44444444444444
44127, 0.60869565217391, 0.33260869565217, 0.44444444444444
44128, 0.60869565217391, 0.35869565217391, 0.47222222222222
44129, 0.56521739130435, 0.35869565217391, 0.027777777777778
44130, 0.58695652173913, 0.35869565217391, 0.055555555555556
44131, 0.56521739130435, 0.33260869565217, 0.055555555555556
44132, 0.56521739130435, 0.35869565217391, 0.083333333333333
44133, 0.58695652173913, 0.35869565217391, 0.11111111111111
44134, 0.56521739130435, 0.33260869565217, 0.11111111111111
44135, 0.56521739130435, 0.35869565217391, 0.13888888888889
44136, 0.58695652173913, 0.35869565217391, 0.16666666666667
44137, 0.56521739130435, 0.33260869565217, 0.16666666666667
44138, 0.56521739130435, 0.35869565217391, 0.19444444444444
44139, 0.58695652173913, 0.35869565217391, 0.22222222222222
44140, 0.56521739130435, 0.33260869565217, 0.22222222222222
44141, 0.56521739130435, 0.35869565217391, 0.25
44142, 0.58695652173913, 0.35869565217391, 0.27777777777778
44143, 0.56521739130435, 0.33260869565217, 0.27777777777778
44144, 0.56521739130435, 0.35869565217391, 0.30555555555556
44145, 0.58695652173913, 0.35869565217391, 0.33333333333333
44146, 0.56521739130435, 0.33260869565217, 0.33333333333333
44147, 0.56521739130435, 0.35869565217391, 0.36111111111111
44148, 0.58695652173913, 0.35869565217391, 0.38888888888889
44149, 0.56521739130435, 0.33260869565217, 0.38888888888889
44150, 0.56521739130435, 0.35869565217391, 0.41666666666667
44151, 0.58695652173913, 0.35869565217391, 0.44444444444444
44152, 0.56521739130435, 0.33260869565217, 0.44444444444444
44153, 0.56521739130435, 0.35869565217391, 0.47222222222222
44154, 0.52173913043478, 0.35869565217391, 0.027777777777778
44155, 0.54347826086957, 0.35869565217391, 0.055555555555556
44156, 0.52173913043478, 0.33260869565217, 0.055555555555556
44157, 0.52173913043478, 0.35869565217391, 0.083333333333333
44158, 0.54347826086957, 0.35869565217391, 0.11111111111111
44159, 0.52173913043478, 0.33260869565217, 0.11111111111111
44160, 0.52173913043478, 0.35869565217391, 0.13888888888889
44161, 0.54347826086956, 0.35869565217391, 0.16666666666667
44162, 0.52173913043478, 0.33260869565217, 0.16666666666667
44163, 0.52173913043478, 0.35869565217391, 0.19444444444444
44164, 0.54347826086956, 0.35869565217391, 0.22222222222222
44165, 0.52173913043478, 0.33260869565217, 0.22222222222222
44166, 0.52173913043478, 0.35869565217391, 0.25
44167, 0.54347826086956, 0.35869565217391, 0.27777777777778
44168, 0.52173913043478, 0.33260869565217, 0.27777777777778
44169, 0.52173913043478, 0.35869565217391, 0.30555555555556
44170, 0.54347826086956, 0.35869565217391, 0.33333333333333
44171, 0.52173913043478, 0.33260869565217, 0.33333333333333
44172, 0.52173913043478, 0.35869565217391, 0.36111111111111
44173, 0.54347826086956, 0.35869565217391, 0.38888888888889
44174, 0.52173913043478, 0.33260869565217, 0.38888888888889
44175, 0.52173913043478, 0.35869565217391, 0.41666666666667
44176, 0.54347826086956, 0.35869565217391, 0.44444444444444
44177, 0.52173913043478, 0.33260869565217, 0.44444444444444
44178, 0.52173913043478, 0.35869565217391, 0.47222222222222
44179, 0.47826086956522, 0.35869565217391, 0.027777777777778
44180, 0.5, 0.35869565217391, 0.055555555555556
44181, 0.47826086956522, 0.33260869565217, 0.055555555555556
44182, 0.47826086956522, 0.35869565217391, 0.083333333333333
44183, 0.5, 0.35869565217391, 0.11111111111111
44184, 0.47826086956522, 0.33260869565217, 0.11111111111111
44185, 0.47826086956522, 0.35869565217391, 0.13888888888889
44186, 0.5, 0.35869565217391, 0.16666666666667
44187, 0.47826086956522, 0.33260869565217, 0.16666666666667
44188, 0.47826086956522, 0.35869565217391, 0.19444444444444
44189, 0.5, 0.35869565217391, 0.22222222222222
44190, 0.47826086956522, 0.33260869565217, 0.22222222222222
44191, 0.47826086956522, 0.35869565217391, 0.25
44192, 0.5, 0.35869565217391, 0.27777777777778
44193, 0.47826086956522, 0.33260869565217, 0.27777777777778
44194, 0.47826086956522, 0.35869565217391, 0.30555555555556
44195, 0.5, 0.35869565217391, 0.33333333333333
44196, 0.47826086956522, 0.33260869565217, 0.33333333333333
44197, 0.47826086956522, 0.35869565217391, 0.36111111111111
44198, 0.5, 0.35869565217391, 0.38888888888889
44199, 0.47826086956522, 0.33260869565217, 0.38888888888889
44200, 0.47826086956522, 0.35869565217391, 0.41666666666667
44201, 0.5, 0.35869565217391, 0.44444444444444
44202, 0.47826086956522, 0.33260869565217, 0.44444444444444
44203, 0.47826086956522, 0.35869565217391, 0.47222222222222
44204, 0.43478260869565, 0.35869565217391, 0.027777777777778
44205, 0.45652173913043, 0.35869565217391, 0.055555555555556
44206, 0.43478260869565, 0.33260869565217, 0.055555555555556
44207, 0.43478260869565, 0.35869565217391, 0.083333333333333
44208, 0.45652173913043, 0.35869565217391, 0.11111111111111
44209, 0.43478260869565, 0.33260869565217, 0.11111111111111
44210, 0.43478260869565, 0.35869565217391, 0.13888888888889
44211, 0.45652173913043, 0.35869565217391, 0.16666666666667
44212, 0.43478260869565, 0.33260869565217, 0.16666666666667
44213, 0.43478260869565, 0.35869565217391, 0.19444444444444
44214, 0.45652173913043, 0.35869565217391, 0.22222222222222
44215, 0.43478260869565, 0.33260869565217, 0.22222222222222
44216, 0.43478260869565, 0.35869565217391, 0.25
44217, 0.45652173913043, 0.35869565217391, 0.27777777777778
44218, 0.43478260869565, 0.33260869565217, 0.27777777777778
44219, 0.43478260869565, 0.35869565217391, 0.30555555555556
44220, 0.45652173913043, 0.35869565217391, 0.33333333333333
44221, 0.43478260869565, 0.33260869565217, 0.33333333333333
44222, 0.43478260869565, 0.35869565217391, 0.36111111111111
44223, 0.45652173913043, 0.35869565217391, 0.38888888888889
44224, 0.43478260869565, 0.33260869565217, 0.38888888888889
44225, 0.43478260869565, 0.35869565217391, 0.41666666666667
44226, 0.45652173913043, 0.35869565217391, 0.44444444444444
44227, 0.43478260869565, 0.33260869565217, 0.44444444444444
44228, 0.43478260869565, 0.35869565217391, 0.47222222222222
44229, 0.39130434782609, 0.35869565217391, 0.027777777777778
44230, 0.41304347826087, 0.35869565217391, 0.055555555555556
44231, 0.39130434782609, 0.33260869565217, 0.055555555555556
44232, 0.39130434782609, 0.35869565217391, 0.083333333333333
44233, 0.41304347826087, 0.35869565217391, 0.11111111111111
44234, 0.39130434782609, 0.33260869565217, 0.11111111111111
44235, 0.39130434782609, 0.35869565217391, 0.13888888888889
44236, 0.41304347826087, 0.35869565217391, 0.16666666666667
44237, 0.39130434782609, 0.33260869565217, 0.16666666666667
44238, 0.39130434782609, 0.35869565217391, 0.19444444444444
44239, 0.41304347826087, 0.35869565217391, 0.22222222222222
44240, 0.39130434782609, 0.33260869565217, 0.22222222222222
44241, 0.39130434782609, 0.35869565217391, 0.25
44242, 0.41304347826087, 0.35869565217391, 0.27777777777778
44243, 0.39130434782609, 0.33260869565217, 0.27777777777778
44244, 0.39130434782609, 0.35869565217391, 0.30555555555556
44245, 0.41304347826087, 0.35869565217391, 0.33333333333333
44246, 0.39130434782609, 0.33260869565217, 0.33333333333333
44247, 0.39130434782609, 0.35869565217391, 0.36111111111111
44248, 0.41304347826087, 0.35869565217391, 0.38888888888889
44249, 0.39130434782609, 0.33260869565217, 0.38888888888889
44250, 0.39130434782609, 0.35869565217391, 0.41666666666667
44251, 0.41304347826087, 0.35869565217391, 0.44444444444444
44252, 0.39130434782609, 0.33260869565217, 0.44444444444444
44253, 0.39130434782609, 0.35869565217391, 0.47222222222222
44254, 0.34782608695652, 0.35869565217391, 0.027777777777778
44255, 0.3695652173913, 0.35869565217391, 0.055555555555556
44256, 0.34782608695652, 0.33260869565217, 0.055555555555556
44257, 0.34782608695652, 0.35869565217391, 0.083333333333333
44258, 0.3695652173913, 0.35869565217391, 0.11111111111111
44259, 0.34782608695652, 0.33260869565217, 0.11111111111111
44260, 0.34782608695652, 0.35869565217391, 0.13888888888889
44261, 0.3695652173913, 0.35869565217391, 0.16666666666667
44262, 0.34782608695652, 0.33260869565217, 0.16666666666667
44263, 0.34782608695652, 0.35869565217391, 0.19444444444444
44264, 0.3695652173913, 0.35869565217391, 0.22222222222222
44265, 0.34782608695652, 0.33260869565217, 0.22222222222222
44266, 0.34782608695652, 0.35869565217391, 0.25
44267, 0.3695652173913, 0.35869565217391, 0.27777777777778
44268, 0.34782608695652, 0.33260869565217, 0.27777777777778
44269, 0.34782608695652, 0.35869565217391, 0.30555555555556
44270, 0.3695652173913, 0.35869565217391, 0.33333333333333
44271, 0.34782608695652, 0.33260869565217, 0.33333333333333
44272, 0.34782608695652, 0.35869565217391, 0.36111111111111
44273, 0.3695652173913, 0.35869565217391, 0.38888888888889
44274, 0.34782608695652, 0.33260869565217, 0.38888888888889
44275, 0.34782608695652, 0.35869565217391, 0.41666666666667
44276, 0.3695652173913, 0.35869565217391, 0.44444444444444
44277, 0.34782608695652, 0.33260869565217, 0.44444444444444
44278, 0.34782608695652, 0.35869565217391, 0.47222222222222
44279, 0.30434782608696, 0.35869565217391, 0.027777777777778
44280, 0.32608695652174, 0.35869565217391, 0.055555555555556
44281, 0.30434782608696, 0.33260869565217, 0.055555555555556
44282, 0.30434782608696, 0.35869565217391, 0.083333333333333
44283, 0.32608695652174, 0.35869565217391, 0.11111111111111
44284, 0.30434782608696, 0.33260869565217, 0.11111111111111
44285, 0.30434782608696, 0.35869565217391, 0.13888888888889
44286, 0.32608695652174, 0.35869565217391, 0.16666666666667
44287, 0.30434782608696, 0.33260869565217, 0.16666666666667
44288, 0.30434782608696, 0.35869565217391, 0.19444444444444
44289, 0.32608695652174, 0.35869565217391, 0.22222222222222
44290, 0.30434782608696, 0.33260869565217, 0.22222222222222
44291, 0.30434782608696, 0.35869565217391, 0.25
44292, 0.32608695652174, 0.35869565217391, 0.27777777777778
44293, 0.30434782608696, 0.33260869565217, 0.27777777777778
44294, 0.30434782608696, 0.35869565217391, 0.30555555555556
44295, 0.32608695652174, 0.35869565217391, 0.33333333333333
44296, 0.30434782608696, 0.33260869565217, 0.33333333333333
44297, 0.30434782608696, 0.35869565217391, 0.36111111111111
44298, 0.32608695652174, 0.35869565217391, 0.38888888888889
44299, 0.30434782608696, 0.33260869565217, 0.38888888888889
44300, 0.30434782608696, 0.35869565217391, 0.41666666666667
44301, 0.32608695652174, 0.35869565217391, 0.44444444444444
44302, 0.30434782608696, 0.33260869565217, 0.44444444444444
44303, 0.30434782608696, 0.35869565217391, 0.47222222222222
44304, 0.26086956521739, 0.35869565217391, 0.027777777777778
44305, 0.28260869565217, 0.35869565217391, 0.055555555555556
44306, 0.26086956521739, 0.33260869565217, 0.055555555555556
44307, 0.26086956521739, 0.35869565217391, 0.083333333333333
44308, 0.28260869565217, 0.35869565217391, 0.11111111111111
44309, 0.26086956521739, 0.33260869565217, 0.11111111111111
44310, 0.26086956521739, 0.35869565217391, 0.13888888888889
44311, 0.28260869565217, 0.35869565217391, 0.16666666666667
44312, 0.26086956521739, 0.33260869565217, 0.16666666666667
44313, 0.26086956521739, 0.35869565217391, 0.19444444444444
44314, 0.28260869565217, 0.35869565217391, 0.22222222222222
44315, 0.26086956521739, 0.33260869565217, 0.22222222222222
44316, 0.26086956521739, 0.35869565217391, 0.25
44317, 0.28260869565217, 0.35869565217391, 0.27777777777778
44318, 0.26086956521739, 0.33260869565217, 0.27777777777778
44319, 0.26086956521739, 0.35869565217391, 0.30555555555556
44320, 0.28260869565217, 0.35869565217391, 0.33333333333333
44321, 0.26086956521739, 0.33260869565217, 0.33333333333333
44322, 0.26086956521739, 0.35869565217391, 0.36111111111111
44323, 0.28260869565217, 0.35869565217391, 0.38888888888889
44324, 0.26086956521739, 0.33260869565217, 0.38888888888889
44325, 0.26086956521739, 0.35869565217391, 0.41666666666667
44326, 0.28260869565217, 0.35869565217391, 0.44444444444444
44327, 0.26086956521739, 0.33260869565217, 0.44444444444444
44328, 0.26086956521739, 0.35869565217391, 0.47222222222222
44329, 0.21739130434783, 0.35869565217391, 0.027777777777778
44330, 0.23913043478261, 0.35869565217391, 0.055555555555556
44331, 0.21739130434783, 0.33260869565217, 0.055555555555556
44332, 0.21739130434783, 0.35869565217391, 0.083333333333333
44333, 0.23913043478261, 0.35869565217391, 0.11111111111111
44334, 0.21739130434783, 0.33260869565217, 0.11111111111111
44335, 0.21739130434783, 0.35869565217391, 0.13888888888889
44336, 0.23913043478261, 0.35869565217391, 0.16666666666667
44337, 0.21739130434783, 0.33260869565217, 0.16666666666667
44338, 0.21739130434783, 0.35869565217391, 0.19444444444444
44339, 0.23913043478261, 0.35869565217391, 0.22222222222222
44340, 0.21739130434783, 0.33260869565217, 0.22222222222222
44341, 0.21739130434783, 0.35869565217391, 0.25
44342, 0.23913043478261, 0.35869565217391, 0.27777777777778
44343, 0.21739130434783, 0.33260869565217, 0.27777777777778
44344, 0.21739130434783, 0.35869565217391, 0.30555555555556
44345, 0.23913043478261, 0.35869565217391, 0.33333333333333
44346, 0.21739130434783, 0.33260869565217, 0.33333333333333
44347, 0.21739130434783, 0.35869565217391, 0.36111111111111
44348, 0.23913043478261, 0.35869565217391, 0.38888888888889
44349, 0.21739130434783, 0.33260869565217, 0.38888888888889
44350, 0.21739130434783, 0.35869565217391, 0.41666666666667
44351, 0.23913043478261, 0.35869565217391, 0.44444444444444
44352, 0.21739130434783, 0.33260869565217, 0.44444444444444
44353, 0.21739130434783, 0.35869565217391, 0.47222222222222
44354, 0.17391304347826, 0.35869565217391, 0.027777777777778
44355, 0.19565217391304, 0.35869565217391, 0.055555555555556
44356, 0.17391304347826, 0.33260869565217, 0.055555555555556
44357, 0.17391304347826, 0.35869565217391, 0.083333333333333
44358, 0.19565217391304, 0.35869565217391, 0.11111111111111
44359, 0.17391304347826, 0.33260869565217, 0.11111111111111
44360, 0.17391304347826, 0.35869565217391, 0.13888888888889
44361, 0.19565217391304, 0.35869565217391, 0.16666666666667
44362, 0.17391304347826, 0.33260869565217, 0.16666666666667
44363, 0.17391304347826, 0.35869565217391, 0.19444444444444
44364, 0.19565217391304, 0.35869565217391, 0.22222222222222
44365, 0.17391304347826, 0.33260869565217, 0.22222222222222
44366, 0.17391304347826, 0.35869565217391, 0.25
44367, 0.19565217391304, 0.35869565217391, 0.27777777777778
44368, 0.17391304347826, 0.33260869565217, 0.27777777777778
44369, 0.17391304347826, 0.35869565217391, 0.30555555555556
44370, 0.19565217391304, 0.35869565217391, 0.33333333333333
44371, 0.17391304347826, 0.33260869565217, 0.33333333333333
44372, 0.17391304347826, 0.35869565217391, 0.36111111111111
44373, 0.19565217391304, 0.35869565217391, 0.38888888888889
44374, 0.17391304347826, 0.33260869565217, 0.38888888888889
44375, 0.17391304347826, 0.35869565217391, 0.41666666666667
44376, 0.19565217391304, 0.35869565217391, 0.44444444444444
44377, 0.17391304347826, 0.33260869565217, 0.44444444444444
44378, 0.17391304347826, 0.35869565217391, 0.47222222222222
44379, 0.1304347826087, 0.35869565217391, 0.027777777777778
44380, 0.15217391304348, 0.35869565217391, 0.055555555555556
44381, 0.1304347826087, 0.33260869565217, 0.055555555555556
44382, 0.1304347826087, 0.35869565217391, 0.083333333333333
44383, 0.15217391304348, 0.35869565217391, 0.11111111111111
44384, 0.1304347826087, 0.33260869565217, 0.11111111111111
44385, 0.1304347826087, 0.35869565217391, 0.13888888888889
44386, 0.15217391304348, 0.35869565217391, 0.16666666666667
44387, 0.1304347826087, 0.33260869565217, 0.16666666666667
44388, 0.1304347826087, 0.35869565217391, 0.19444444444444
44389, 0.15217391304348, 0.35869565217391, 0.22222222222222
44390, 0.1304347826087, 0.33260869565217, 0.22222222222222
44391, 0.1304347826087, 0.35869565217391, 0.25
44392, 0.15217391304348, 0.35869565217391, 0.27777777777778
44393, 0.1304347826087, 0.33260869565217, 0.27777777777778
44394, 0.1304347826087, 0.35869565217391, 0.30555555555556
44395, 0.15217391304348, 0.35869565217391, 0.33333333333333
44396, 0.1304347826087, 0.33260869565217, 0.33333333333333
44397, 0.1304347826087, 0.35869565217391, 0.36111111111111
44398, 0.15217391304348, 0.35869565217391, 0.38888888888889
44399, 0.1304347826087, 0.33260869565217, 0.38888888888889
44400, 0.1304347826087, 0.35869565217391, 0.41666666666667
44401, 0.15217391304348, 0.35869565217391, 0.44444444444444
44402, 0.1304347826087, 0.33260869565217, 0.44444444444444
44403, 0.1304347826087, 0.35869565217391, 0.47222222222222
44404, 0.08695652173913, 0.35869565217391, 0.027777777777778
44405, 0.10869565217391, 0.35869565217391, 0.055555555555556
44406, 0.08695652173913, 0.33260869565217, 0.055555555555556
44407, 0.08695652173913, 0.35869565217391, 0.083333333333333
44408, 0.10869565217391, 0.35869565217391, 0.11111111111111
44409, 0.08695652173913, 0.33260869565217, 0.11111111111111
44410, 0.08695652173913, 0.35869565217391, 0.13888888888889
44411, 0.10869565217391, 0.35869565217391, 0.16666666666667
44412, 0.08695652173913, 0.33260869565217, 0.16666666666667
44413, 0.08695652173913, 0.35869565217391, 0.19444444444444
44414, 0.10869565217391, 0.35869565217391, 0.22222222222222
44415, 0.08695652173913, 0.33260869565217, 0.22222222222222
