5194, 49, 1523, 11529, 1511, 1532, 11545, 11546, 1513
5195, 1523, 1522, 11530, 11529, 1531, 11547, 11548, 11545
5196, 1522, 1521, 11531, 11530, 1530, 11549, 11550, 11547
5197, 1521, 1520, 11532, 11531, 1529, 11551, 11552, 11549
5198, 1520, 1519, 11533, 11532, 1528, 11553, 11554, 11551
5199, 1519, 1518, 11534, 11533, 1527, 11555, 11556, 11553
5200, 1518, 1517, 11535, 11534, 1526, 11557, 11558, 11555
5201, 1517, 1516, 11536, 11535, 1525, 11559, 11560, 11557
5202, 1516, 45, 1411, 11536, 1524, 1413, 11561, 11559
5203, 1511, 11529, 11537, 1512, 11546, 11562, 11563, 1514
5204, 11529, 11530, 11538, 11537, 11548, 11564, 11565, 11562
5205, 11530, 11531, 11539, 11538, 11550, 11566, 11567, 11564
5206, 11531, 11532, 11540, 11539, 11552, 11568, 11569, 11566
5207, 11532, 11533, 11541, 11540, 11554, 11570, 11571, 11568
5208, 11533, 11534, 11542, 11541, 11556, 11572, 11573, 11570
5209, 11534, 11535, 11543, 11542, 11558, 11574, 11575, 11572
5210, 11535, 11536, 11544, 11543, 11560, 11576, 11577, 11574
5211, 11536, 1411, 1412, 11544, 11561, 1414, 11578, 11576
5212, 1512, 11537, 1540, 50, 11563, 11579, 1549, 1515
5213, 11537, 11538, 1539, 1540, 11565, 11580, 1548, 11579
5214, 11538, 11539, 1538, 1539, 11567, 11581, 1547, 11580
5215, 11539, 11540, 1537, 1538, 11569, 11582, 1546, 11581
5216, 11540, 11541, 1536, 1537, 11571, 11583, 1545, 11582
5217, 11541, 11542, 1535, 1536, 11573, 11584, 1544, 11583
5218, 11542, 11543, 1534, 1535, 11575, 11585, 1543, 11584
5219, 11543, 11544, 1533, 1534, 11577, 11586, 1542, 11585
5220, 11544, 1412, 46, 1533, 11578, 1415, 1541, 11586
*ELEMENT, type=CPS8, ELSET=Surface208
5221, 49, 1511, 11587, 1576, 1513, 11631, 11632, 1599
5222, 1576, 11587, 11588, 1575, 11632, 11633, 11634, 1598
5223, 1575, 11588, 11589, 1574, 11634, 11635, 11636, 1597
5224, 1574, 11589, 11590, 1573, 11636, 11637, 11638, 1596
5225, 1573, 11590, 11591, 1572, 11638, 11639, 11640, 1595
5226, 1572, 11591, 11592, 1571, 11640, 11641, 11642, 1594
5227, 1571, 11592, 11593, 1570, 11642, 11643, 11644, 1593
5228, 1570, 11593, 11594, 1569, 11644, 11645, 11646, 1592
5229, 1569, 11594, 11595, 1568, 11646, 11647, 11648, 1591
5230, 1568, 11595, 11596, 1567, 11648, 11649, 11650, 1590
5231, 1567, 11596, 11597, 1566, 11650, 11651, 11652, 1589
5232, 1566, 11597, 11598, 1565, 11652, 11653, 11654, 1588
5233, 1565, 11598, 11599, 1564, 11654, 11655, 11656, 1587
5234, 1564, 11599, 11600, 1563, 11656, 11657, 11658, 1586
5235, 1563, 11600, 11601, 1562, 11658, 11659, 11660, 1585
5236, 1562, 11601, 11602, 1561, 11660, 11661, 11662, 1584
5237, 1561, 11602, 11603, 1560, 11662, 11663, 11664, 1583
5238, 1560, 11603, 11604, 1559, 11664, 11665, 11666, 1582
5239, 1559, 11604, 11605, 1558, 11666, 11667, 11668, 1581
5240, 1558, 11605, 11606, 1557, 11668, 11669, 11670, 1580
5241, 1557, 11606, 11607, 1556, 11670, 11671, 11672, 1579
5242, 1556, 11607, 11608, 1555, 11672, 11673, 11674, 1578
5243, 1555, 11608, 1550, 51, 11674, 11675, 1552, 1577
5244, 1511, 1512, 11609, 11587, 1514, 11676, 11677, 11631
5245, 11587, 11609, 11610, 11588, 11677, 11678, 11679, 11633
5246, 11588, 11610, 11611, 11589, 11679, 11680, 11681, 11635
5247, 11589, 11611, 11612, 11590, 11681, 11682, 11683, 11637
5248, 11590, 11612, 11613, 11591, 11683, 11684, 11685, 11639
5249, 11591, 11613, 11614, 11592, 11685, 11686, 11687, 11641
5250, 11592, 11614, 11615, 11593, 11687, 11688, 11689, 11643
5251, 11593, 11615, 11616, 11594, 11689, 11690, 11691, 11645
5252, 11594, 11616, 11617, 11595, 11691, 11692, 11693, 11647
5253, 11595, 11617, 11618, 11596, 11693, 11694, 11695, 11649
5254, 11596, 11618, 11619, 11597, 11695, 11696, 11697, 11651
5255, 11597, 11619, 11620, 11598, 11697, 11698, 11699, 11653
5256, 11598, 11620, 11621, 11599, 11699, 11700, 11701, 11655
5257, 11599, 11621, 11622, 11600, 11701, 11702, 11703, 11657
5258, 11600, 11622, 11623, 11601, 11703, 11704, 11705, 11659
5259, 11601, 11623, 11624, 11602, 11705, 11706, 11707, 11661
5260, 11602, 11624, 11625, 11603, 11707, 11708, 11709, 11663
5261, 11603, 11625, 11626, 11604, 11709, 11710, 11711, 11665
5262, 11604, 11626, 11627, 11605, 11711, 11712, 11713, 11667
5263, 11605, 11627, 11628, 11606, 11713, 11714, 11715, 11669
5264, 11606, 11628, 11629, 11607, 11715, 11716, 11717, 11671
5265, 11607, 11629, 11630, 11608, 11717, 11718, 11719, 11673
5266, 11608, 11630, 1551, 1550, 11719, 11720, 1553, 11675
5267, 1512, 50, 1621, 11609, 1515, 1644, 11721, 11676
5268, 11609, 1621, 1620, 11610, 11721, 1643, 11722, 11678
5269, 11610, 1620, 1619, 11611, 11722, 1642, 11723, 11680
5270, 11611, 1619, 1618, 11612, 11723, 1641, 11724, 11682
5271, 11612, 1618, 1617, 11613, 11724, 1640, 11725, 11684
5272, 11613, 1617, 1616, 11614, 11725, 1639, 11726, 11686
5273, 11614, 1616, 1615, 11615, 11726, 1638, 11727, 11688
5274, 11615, 1615, 1614, 11616, 11727, 1637, 11728, 11690
5275, 11616, 1614, 1613, 11617, 11728, 1636, 11729, 11692
5276, 11617, 1613, 1612, 11618, 11729, 1635, 11730, 11694
5277, 11618, 1612, 1611, 11619, 11730, 1634, 11731, 11696
5278, 11619, 1611, 1610, 11620, 11731, 1633, 11732, 11698
5279, 11620, 1610, 1609, 11621, 11732, 1632, 11733, 11700
5280, 11621, 1609, 1608, 11622, 11733, 1631, 11734, 11702
5281, 11622, 1608, 1607, 11623, 11734, 1630, 11735, 11704
5282, 11623, 1607, 1606, 11624, 11735, 1629, 11736, 11706
5283, 11624, 1606, 1605, 11625, 11736, 1628, 11737, 11708
5284, 11625, 1605, 1604, 11626, 11737, 1627, 11738, 11710
5285, 11626, 1604, 1603, 11627, 11738, 1626, 11739, 11712
5286, 11627, 1603, 1602, 11628, 11739, 1625, 11740, 11714
5287, 11628, 1602, 1601, 11629, 11740, 1624, 11741, 11716
5288, 11629, 1601, 1600, 11630, 11741, 1623, 11742, 11718
5289, 11630, 1600, 52, 1551, 11742, 1622, 1554, 11720
*ELEMENT, type=CPS8, ELSET=Surface209
5290, 51, 1550, 11743, 1652, 1552, 11759, 11760, 1661
5291, 1652, 11743, 11744, 1651, 11760, 11761, 11762, 1660
5292, 1651, 11744, 11745, 1650, 11762, 11763, 11764, 1659
5293, 1650, 11745, 11746, 1649, 11764, 11765, 11766, 1658
5294, 1649, 11746, 11747, 1648, 11766, 11767, 11768, 1657
5295, 1648, 11747, 11748, 1647, 11768, 11769, 11770, 1656
5296, 1647, 11748, 11749, 1646, 11770, 11771, 11772, 1655
5297, 1646, 11749, 11750, 1645, 11772, 11773, 11774, 1654
5298, 1645, 11750, 1416, 47, 11774, 11775, 1418, 1653
5299, 1550, 1551, 11751, 11743, 1553, 11776, 11777, 11759
5300, 11743, 11751, 11752, 11744, 11777, 11778, 11779, 11761
5301, 11744, 11752, 11753, 11745, 11779, 11780, 11781, 11763
5302, 11745, 11753, 11754, 11746, 11781, 11782, 11783, 11765
5303, 11746, 11754, 11755, 11747, 11783, 11784, 11785, 11767
5304, 11747, 11755, 11756, 11748, 11785, 11786, 11787, 11769
5305, 11748, 11756, 11757, 11749, 11787, 11788, 11789, 11771
5306, 11749, 11757, 11758, 11750, 11789, 11790, 11791, 11773
5307, 11750, 11758, 1417, 1416, 11791, 11792, 1419, 11775
5308, 1551, 52, 1669, 11751, 1554, 1678, 11793, 11776
5309, 11751, 1669, 1668, 11752, 11793, 1677, 11794, 11778
5310, 11752, 1668, 1667, 11753, 11794, 1676, 11795, 11780
5311, 11753, 1667, 1666, 11754, 11795, 1675, 11796, 11782
5312, 11754, 1666, 1665, 11755, 11796, 1674, 11797, 11784
5313, 11755, 1665, 1664, 11756, 11797, 1673, 11798, 11786
5314, 11756, 1664, 1663, 11757, 11798, 1672, 11799, 11788
5315, 11757, 1663, 1662, 11758, 11799, 1671, 11800, 11790
5316, 11758, 1662, 48, 1417, 11800, 1670, 1420, 11792
*ELEMENT, type=CPS8, ELSET=Surface210
5317, 47, 1421, 11801, 1645, 1443, 11977, 11978, 1653
5318, 1645, 11801, 11802, 1646, 11978, 11979, 11980, 1654
5319, 1646, 11802, 11803, 1647, 11980, 11981, 11982, 1655
5320, 1647, 11803, 11804, 1648, 11982, 11983, 11984, 1656
5321, 1648, 11804, 11805, 1649, 11984, 11985, 11986, 1657
5322, 1649, 11805, 11806, 1650, 11986, 11987, 11988, 1658
5323, 1650, 11806, 11807, 1651, 11988, 11989, 11990, 1659
5324, 1651, 11807, 11808, 1652, 11990, 11991, 11992, 1660
5325, 1652, 11808, 1555, 51, 11992, 11993, 1577, 1661
5326, 1421, 1422, 11809, 11801, 1444, 11994, 11995, 11977
5327, 11801, 11809, 11810, 11802, 11995, 11996, 11997, 11979
5328, 11802, 11810, 11811, 11803, 11997, 11998, 11999, 11981
5329, 11803, 11811, 11812, 11804, 11999, 12000, 12001, 11983
5330, 11804, 11812, 11813, 11805, 12001, 12002, 12003, 11985
5331, 11805, 11813, 11814, 11806, 12003, 12004, 12005, 11987
5332, 11806, 11814, 11815, 11807, 12005, 12006, 12007, 11989
5333, 11807, 11815, 11816, 11808, 12007, 12008, 12009, 11991
5334, 11808, 11816, 1556, 1555, 12009, 12010, 1578, 11993
5335, 1422, 1423, 11817, 11809, 1445, 12011, 12012, 11994
5336, 11809, 11817, 11818, 11810, 12012, 12013, 12014, 11996
5337, 11810, 11818, 11819, 11811, 12014, 12015, 12016, 11998
5338, 11811, 11819, 11820, 11812, 12016, 12017, 12018, 12000
5339, 11812, 11820, 11821, 11813, 12018, 12019, 12020, 12002
5340, 11813, 11821, 11822, 11814, 12020, 12021, 12022, 12004
5341, 11814, 11822, 11823, 11815, 12022, 12023, 12024, 12006
5342, 11815, 11823, 11824, 11816, 12024, 12025, 12026, 12008
5343, 11816, 11824, 1557, 1556, 12026, 12027, 1579, 12010
5344, 1423, 1424, 11825, 11817, 1446, 12028, 12029, 12011
5345, 11817, 11825, 11826, 11818, 12029, 12030, 12031, 12013
5346, 11818, 11826, 11827, 11819, 12031, 12032, 12033, 12015
5347, 11819, 11827, 11828, 11820, 12033, 12034, 12035, 12017
5348, 11820, 11828, 11829, 11821, 12035, 12036, 12037, 12019
5349, 11821, 11829, 11830, 11822, 12037, 12038, 12039, 12021
5350, 11822, 11830, 11831, 11823, 12039, 12040, 12041, 12023
5351, 11823, 11831, 11832, 11824, 12041, 12042, 12043, 12025
5352, 11824, 11832, 1558, 1557, 12043, 12044, 1580, 12027
5353, 1424, 1425, 11833, 11825, 1447, 12045, 12046, 12028
5354, 11825, 11833, 11834, 11826, 12046, 12047, 12048, 12030
5355, 11826, 11834, 11835, 11827, 12048, 12049, 12050, 12032
5356, 11827, 11835, 11836, 11828, 12050, 12051, 12052, 12034
5357, 11828, 11836, 11837, 11829, 12052, 12053, 12054, 12036
5358, 11829, 11837, 11838, 11830, 12054, 12055, 12056, 12038
5359, 11830, 11838, 11839, 11831, 12056, 12057, 12058, 12040
5360, 11831, 11839, 11840, 11832, 12058, 12059, 12060, 12042
5361, 11832, 11840, 1559, 1558, 12060, 12061, 1581, 12044
5362, 1425, 1426, 11841, 11833, 1448, 12062, 12063, 12045
5363, 11833, 11841, 11842, 11834, 12063, 12064, 12065, 12047
5364, 11834, 11842, 11843, 11835, 12065, 12066, 12067, 12049
5365, 11835, 11843, 11844, 11836, 12067, 12068, 12069, 12051
5366, 11836, 11844, 11845, 11837, 12069, 12070, 12071, 12053
5367, 11837, 11845, 11846, 11838, 12071, 12072, 12073, 12055
5368, 11838, 11846, 11847, 11839, 12073, 12074, 12075, 12057
5369, 11839, 11847, 11848, 11840, 12075, 12076, 12077, 12059
5370, 11840, 11848, 1560, 1559, 12077, 12078, 1582, 12061
5371, 1426, 1427, 11849, 11841, 1449, 12079, 12080, 12062
5372, 11841, 11849, 11850, 11842, 12080, 12081, 12082, 12064
5373, 11842, 11850, 11851, 11843, 12082, 12083, 12084, 12066
5374, 11843, 11851, 11852, 11844, 12084, 12085, 12086, 12068
5375, 11844, 11852, 11853, 11845, 12086, 12087, 12088, 12070
5376, 11845, 11853, 11854, 11846, 12088, 12089, 12090, 12072
5377, 11846, 11854, 11855, 11847, 12090, 12091, 12092, 12074
5378, 11847, 11855, 11856, 11848, 12092, 12093, 12094, 12076
5379, 11848, 11856, 1561, 1560, 12094, 12095, 1583, 12078
5380, 1427, 1428, 11857, 11849, 1450, 12096, 12097, 12079
5381, 11849, 11857, 11858, 11850, 12097, 12098, 12099, 12081
5382, 11850, 11858, 11859, 11851, 12099, 12100, 12101, 12083
5383, 11851, 11859, 11860, 11852, 12101, 12102, 12103, 12085
5384, 11852, 11860, 11861, 11853, 12103, 12104, 12105, 12087
5385, 11853, 11861, 11862, 11854, 12105, 12106, 12107, 12089
5386, 11854, 11862, 11863, 11855, 12107, 12108, 12109, 12091
5387, 11855, 11863, 11864, 11856, 12109, 12110, 12111, 12093
5388, 11856, 11864, 1562, 1561, 12111, 12112, 1584, 12095
5389, 1428, 1429, 11865, 11857, 1451, 12113, 12114, 12096
5390, 11857, 11865, 11866, 11858, 12114, 12115, 12116, 12098
5391, 11858, 11866, 11867, 11859, 12116, 12117, 12118, 12100
5392, 11859, 11867, 11868, 11860, 12118, 12119, 12120, 12102
5393, 11860, 11868, 11869, 11861, 12120, 12121, 12122, 12104
5394, 11861, 11869, 11870, 11862, 12122, 12123, 12124, 12106
5395, 11862, 11870, 11871, 11863, 12124, 12125, 12126, 12108
5396, 11863, 11871, 11872, 11864, 12126, 12127, 12128, 12110
5397, 11864, 11872, 1563, 1562, 12128, 12129, 1585, 12112
5398, 1429, 1430, 11873, 11865, 1452, 12130, 12131, 12113
5399, 11865, 11873, 11874, 11866, 12131, 12132, 12133, 12115
5400, 11866, 11874, 11875, 11867, 12133, 12134, 12135, 12117
5401, 11867, 11875, 11876, 11868, 12135, 12136, 12137, 12119
5402, 11868, 11876, 11877, 11869, 12137, 12138, 12139, 12121
5403, 11869, 11877, 11878, 11870, 12139, 12140, 12141, 12123
5404, 11870, 11878, 11879, 11871, 12141, 12142, 12143, 12125
5405, 11871, 11879, 11880, 11872, 12143, 12144, 12145, 12127
5406, 11872, 11880, 1564, 1563, 12145, 12146, 1586, 12129
5407, 1430, 1431, 11881, 11873, 1453, 12147, 12148, 12130
5408, 11873, 11881, 11882, 11874, 12148, 12149, 12150, 12132
5409, 11874, 11882, 11883, 11875, 12150, 12151, 12152, 12134
5410, 11875, 11883, 11884, 11876, 12152, 12153, 12154, 12136
5411, 11876, 11884, 11885, 11877, 12154, 12155, 12156, 12138
5412, 11877, 11885, 11886, 11878, 12156, 12157, 12158, 12140
5413, 11878, 11886, 11887, 11879, 12158, 12159, 12160, 12142
5414, 11879, 11887, 11888, 11880, 12160, 12161, 12162, 12144
5415, 11880, 11888, 1565, 1564, 12162, 12163, 1587, 12146
5416, 1431, 1432, 11889, 11881, 1454, 12164, 12165, 12147
5417, 11881, 11889, 11890, 11882, 12165, 12166, 12167, 12149
5418, 11882, 11890, 11891, 11883, 12167, 12168, 12169, 12151
5419, 11883, 11891, 11892, 11884, 12169, 12170, 12171, 12153
5420, 11884, 11892, 11893, 11885, 12171, 12172, 12173, 12155
5421, 11885, 11893, 11894, 11886, 12173, 12174, 12175, 12157
5422, 11886, 11894, 11895, 11887, 12175, 12176, 12177, 12159
5423, 11887, 11895, 11896, 11888, 12177, 12178, 12179, 12161
5424, 11888, 11896, 1566, 1565, 12179, 12180, 1588, 12163
5425, 1432, 1433, 11897, 11889, 1455, 12181, 12182, 12164
5426, 11889, 11897, 11898, 11890, 12182, 12183, 12184, 12166
5427, 11890, 11898, 11899, 11891, 12184, 12185, 12186, 12168
5428, 11891, 11899, 11900, 11892, 12186, 12187, 12188, 12170
5429, 11892, 11900, 11901, 11893, 12188, 12189, 12190, 12172
5430, 11893, 11901, 11902, 11894, 12190, 12191, 12192, 12174
5431, 11894, 11902, 11903, 11895, 12192, 12193, 12194, 12176
5432, 11895, 11903, 11904, 11896, 12194, 12195, 12196, 12178
5433, 11896, 11904, 1567, 1566, 12196, 12197, 1589, 12180
5434, 1433, 1434, 11905, 11897, 1456, 12198, 12199, 12181
5435, 11897, 11905, 11906, 11898, 12199, 12200, 12201, 12183
5436, 11898, 11906, 11907, 11899, 12201, 12202, 12203, 12185
5437, 11899, 11907, 11908, 11900, 12203, 12204, 12205, 12187
5438, 11900, 11908, 11909, 11901, 12205, 12206, 12207, 12189
5439, 11901, 11909, 11910, 11902, 12207, 12208, 12209, 12191
5440, 11902, 11910, 11911, 11903, 12209, 12210, 12211, 12193
5441, 11903, 11911, 11912, 11904, 12211, 12212, 12213, 12195
5442, 11904, 11912, 1568, 1567, 12213, 12214, 1590, 12197
5443, 1434, 1435, 11913, 11905, 1457, 12215, 12216, 12198
5444, 11905, 11913, 11914, 11906, 12216, 12217, 12218, 12200
5445, 11906, 11914, 11915, 11907, 12218, 12219, 12220, 12202
5446, 11907, 11915, 11916, 11908, 12220, 12221, 12222, 12204
5447, 11908, 11916, 11917, 11909, 12222, 12223, 12224, 12206
5448, 11909, 11917, 11918, 11910, 12224, 12225, 12226, 12208
5449, 11910, 11918, 11919, 11911, 12226, 12227, 12228, 12210
5450, 11911, 11919, 11920, 11912, 12228, 12229, 12230, 12212
5451, 11912, 11920, 1569, 1568, 12230, 12231, 1591, 12214
5452, 1435, 1436, 11921, 11913, 1458, 12232, 12233, 12215
5453, 11913, 11921, 11922, 11914, 12233, 12234, 12235, 12217
5454, 11914, 11922, 11923, 11915, 12235, 12236, 12237, 12219
5455, 11915, 11923, 11924, 11916, 12237, 12238, 12239, 12221
5456, 11916, 11924, 11925, 11917, 12239, 12240, 12241, 12223
5457, 11917, 11925, 11926, 11918, 12241, 12242, 12243, 12225
5458, 11918, 11926, 11927, 11919, 12243, 12244, 12245, 12227
5459, 11919, 11927, 11928, 11920, 12245, 12246, 12247, 12229
5460, 11920, 11928, 1570, 1569, 12247, 12248, 1592, 12231
5461, 1436, 1437, 11929, 11921, 1459, 12249, 12250, 12232
5462, 11921, 11929, 11930, 11922, 12250, 12251, 12252, 12234
5463, 11922, 11930, 11931, 11923, 12252, 12253, 12254, 12236
5464, 11923, 11931, 11932, 11924, 12254, 12255, 12256, 12238
5465, 11924, 11932, 11933, 11925, 12256, 12257, 12258, 12240
5466, 11925, 11933, 11934, 11926, 12258, 12259, 12260, 12242
5467, 11926, 11934, 11935, 11927, 12260, 12261, 12262, 12244
5468, 11927, 11935, 11936, 11928, 12262, 12263, 12264, 12246
5469, 11928, 11936, 1571, 1570, 12264, 12265, 1593, 12248
5470, 1437, 1438, 11937, 11929, 1460, 12266, 12267, 12249
5471, 11929, 11937, 11938, 11930, 12267, 12268, 12269, 12251
5472, 11930, 11938, 11939, 11931, 12269, 12270, 12271, 12253
5473, 11931, 11939, 11940, 11932, 12271, 12272, 12273, 12255
5474, 11932, 11940, 11941, 11933, 12273, 12274, 12275, 12257
5475, 11933, 11941, 11942, 11934, 12275, 12276, 12277, 12259
5476, 11934, 11942, 11943, 11935, 12277, 12278, 12279, 12261
5477, 11935, 11943, 11944, 11936, 12279, 12280, 12281, 12263
5478, 11936, 11944, 1572, 1571, 12281, 12282, 1594, 12265
5479, 1438, 1439, 11945, 11937, 1461, 12283, 12284, 12266
5480, 11937, 11945, 11946, 11938, 12284, 12285, 12286, 12268
5481, 11938, 11946, 11947, 11939, 12286, 12287, 12288, 12270
5482, 11939, 11947, 11948, 11940, 12288, 12289, 12290, 12272
5483, 11940, 11948, 11949, 11941, 12290, 12291, 12292, 12274
5484, 11941, 11949, 11950, 11942, 12292, 12293, 12294, 12276
5485, 11942, 11950, 11951, 11943, 12294, 12295, 12296, 12278
5486, 11943, 11951, 11952, 11944, 12296, 12297, 12298, 12280
5487, 11944, 11952, 1573, 1572, 12298, 12299, 1595, 12282
5488, 1439, 1440, 11953, 11945, 1462, 12300, 12301, 12283
5489, 11945, 11953, 11954, 11946, 12301, 12302, 12303, 12285
5490, 11946, 11954, 11955, 11947, 12303, 12304, 12305, 12287
5491, 11947, 11955, 11956, 11948, 12305, 12306, 12307, 12289
5492, 11948, 11956, 11957, 11949, 12307, 12308, 12309, 12291
5493, 11949, 11957, 11958, 11950, 12309, 12310, 12311, 12293
5494, 11950, 11958, 11959, 11951, 12311, 12312, 12313, 12295
5495, 11951, 11959, 11960, 11952, 12313, 12314, 12315, 12297
5496, 11952, 11960, 1574, 1573, 12315, 12316, 1596, 12299
5497, 1440, 1441, 11961, 11953, 1463, 12317, 12318, 12300
5498, 11953, 11961, 11962, 11954, 12318, 12319, 12320, 12302
5499, 11954, 11962, 11963, 11955, 12320, 12321, 12322, 12304
5500, 11955, 11963, 11964, 11956, 12322, 12323, 12324, 12306
5501, 11956, 11964, 11965, 11957, 12324, 12325, 12326, 12308
5502, 11957, 11965, 11966, 11958, 12326, 12327, 12328, 12310
5503, 11958, 11966, 11967, 11959, 12328, 12329, 12330, 12312
5504, 11959, 11967, 11968, 11960, 12330, 12331, 12332, 12314
5505, 11960, 11968, 1575, 1574, 12332, 12333, 1597, 12316
5506, 1441, 1442, 11969, 11961, 1464, 12334, 12335, 12317
5507, 11961, 11969, 11970, 11962, 12335, 12336, 12337, 12319
5508, 11962, 11970, 11971, 11963, 12337, 12338, 12339, 12321
5509, 11963, 11971, 11972, 11964, 12339, 12340, 12341, 12323
5510, 11964, 11972, 11973, 11965, 12341, 12342, 12343, 12325
5511, 11965, 11973, 11974, 11966, 12343, 12344, 12345, 12327
5512, 11966, 11974, 11975, 11967, 12345, 12346, 12347, 12329
5513, 11967, 11975, 11976, 11968, 12347, 12348, 12349, 12331
5514, 11968, 11976, 1576, 1575, 12349, 12350, 1598, 12333
5515, 1442, 45, 1516, 11969, 1465, 1524, 12351, 12334
5516, 11969, 1516, 1517, 11970, 12351, 1525, 12352, 12336
5517, 11970, 1517, 1518, 11971, 12352, 1526, 12353, 12338
5518, 11971, 1518, 1519, 11972, 12353, 1527, 12354, 12340
5519, 11972, 1519, 1520, 11973, 12354, 1528, 12355, 12342
5520, 11973, 1520, 1521, 11974, 12355, 1529, 12356, 12344
5521, 11974, 1521, 1522, 11975, 12356, 1530, 12357, 12346
5522, 11975, 1522, 1523, 11976, 12357, 1531, 12358, 12348
5523, 11976, 1523, 49, 1576, 12358, 1532, 1599, 12350
*ELEMENT, type=CPS8, ELSET=Surface211
5524, 48, 1662, 12359, 1466, 1670, 12535, 12536, 1488
5525, 1662, 1663, 12360, 12359, 1671, 12537, 12538, 12535
5526, 1663, 1664, 12361, 12360, 1672, 12539, 12540, 12537
5527, 1664, 1665, 12362, 12361, 1673, 12541, 12542, 12539
5528, 1665, 1666, 12363, 12362, 1674, 12543, 12544, 12541
5529, 1666, 1667, 12364, 12363, 1675, 12545, 12546, 12543
5530, 1667, 1668, 12365, 12364, 1676, 12547, 12548, 12545
5531, 1668, 1669, 12366, 12365, 1677, 12549, 12550, 12547
5532, 1669, 52, 1600, 12366, 1678, 1622, 12551, 12549
5533, 1466, 12359, 12367, 1467, 12536, 12552, 12553, 1489
5534, 12359, 12360, 12368, 12367, 12538, 12554, 12555, 12552
5535, 12360, 12361, 12369, 12368, 12540, 12556, 12557, 12554
5536, 12361, 12362, 12370, 12369, 12542, 12558, 12559, 12556
5537, 12362, 12363, 12371, 12370, 12544, 12560, 12561, 12558
5538, 12363, 12364, 12372, 12371, 12546, 12562, 12563, 12560
5539, 12364, 12365, 12373, 12372, 12548, 12564, 12565, 12562
5540, 12365, 12366, 12374, 12373, 12550, 12566, 12567, 12564
5541, 12366, 1600, 1601, 12374, 12551, 1623, 12568, 12566
5542, 1467, 12367, 12375, 1468, 12553, 12569, 12570, 1490
5543, 12367, 12368, 12376, 12375, 12555, 12571, 12572, 12569
5544, 12368, 12369, 12377, 12376, 12557, 12573, 12574, 12571
5545, 12369, 12370, 12378, 12377, 12559, 12575, 12576, 12573
5546, 12370, 12371, 12379, 12378, 12561, 12577, 12578, 12575
5547, 12371, 12372, 12380, 12379, 12563, 12579, 12580, 12577
5548, 12372, 12373, 12381, 12380, 12565, 12581, 12582, 12579
5549, 12373, 12374, 12382, 12381, 12567, 12583, 12584, 12581
5550, 12374, 1601, 1602, 12382, 12568, 1624, 12585, 12583
5551, 1468, 12375, 12383, 1469, 12570, 12586, 12587, 1491
5552, 12375, 12376, 12384, 12383, 12572, 12588, 12589, 12586
5553, 12376, 12377, 12385, 12384, 12574, 12590, 12591, 12588
5554, 12377, 12378, 12386, 12385, 12576, 12592, 12593, 12590
5555, 12378, 12379, 12387, 12386, 12578, 12594, 12595, 12592
5556, 12379, 12380, 12388, 12387, 12580, 12596, 12597, 12594
5557, 12380, 12381, 12389, 12388, 12582, 12598, 12599, 12596
5558, 12381, 12382, 12390, 12389, 12584, 12600, 12601, 12598
5559, 12382, 1602, 1603, 12390, 12585, 1625, 12602, 12600
5560, 1469, 12383, 12391, 1470, 12587, 12603, 12604, 1492
5561, 12383, 12384, 12392, 12391, 12589, 12605, 12606, 12603
5562, 12384, 12385, 12393, 12392, 12591, 12607, 12608, 12605
5563, 12385, 12386, 12394, 12393, 12593, 12609, 12610, 12607
5564, 12386, 12387, 12395, 12394, 12595, 12611, 12612, 12609
5565, 12387, 12388, 12396, 12395, 12597, 12613, 12614, 12611
5566, 12388, 12389, 12397, 12396, 12599, 12615, 12616, 12613
5567, 12389, 12390, 12398, 12397, 12601, 12617, 12618, 12615
5568, 12390, 1603, 1604, 12398, 12602, 1626, 12619, 12617
5569, 1470, 12391, 12399, 1471, 12604, 12620, 12621, 1493
5570, 12391, 12392, 12400, 12399, 12606, 12622, 12623, 12620
5571, 12392, 12393, 12401, 12400, 12608, 12624, 12625, 12622
5572, 12393, 12394, 12402, 12401, 12610, 12626, 12627, 12624
5573, 12394, 12395, 12403, 12402, 12612, 12628, 12629, 12626
5574, 12395, 12396, 12404, 12403, 12614, 12630, 12631, 12628
5575, 12396, 12397, 12405, 12404, 12616, 12632, 12633, 12630
5576, 12397, 12398, 12406, 12405, 12618, 12634, 12635, 12632
5577, 12398, 1604, 1605, 12406, 12619, 1627, 12636, 12634
5578, 1471, 12399, 12407, 1472, 12621, 12637, 12638, 1494
5579, 12399, 12400, 12408, 12407, 12623, 12639, 12640, 12637
5580, 12400, 12401, 12409, 12408, 12625, 12641, 12642, 12639
5581, 12401, 12402, 12410, 12409, 12627, 12643, 12644, 12641
5582, 12402, 12403, 12411, 12410, 12629, 12645, 12646, 12643
5583, 12403, 12404, 12412, 12411, 12631, 12647, 12648, 12645
5584, 12404, 12405, 12413, 12412, 12633, 12649, 12650, 12647
5585, 12405, 12406, 12414, 12413, 12635, 12651, 12652, 12649
5586, 12406, 1605, 1606, 12414, 12636, 1628, 12653, 12651
5587, 1472, 12407, 12415, 1473, 12638, 12654, 12655, 1495
5588, 12407, 12408, 12416, 12415, 12640, 12656, 12657, 12654
5589, 12408, 12409, 12417, 12416, 12642, 12658, 12659, 12656
5590, 12409, 12410, 12418, 12417, 12644, 12660, 12661, 12658
5591, 12410, 12411, 12419, 12418, 12646, 12662, 12663, 12660
5592, 12411, 12412, 12420, 12419, 12648, 12664, 12665, 12662
5593, 12412, 12413, 12421, 12420, 12650, 12666, 12667, 12664
5594, 12413, 12414, 12422, 12421, 12652, 12668, 12669, 12666
5595, 12414, 1606, 1607, 12422, 12653, 1629, 12670, 12668
5596, 1473, 12415, 12423, 1474, 12655, 12671, 12672, 1496
5597, 12415, 12416, 12424, 12423, 12657, 12673, 12674, 12671
5598, 12416, 12417, 12425, 12424, 12659, 12675, 12676, 12673
5599, 12417, 12418, 12426, 12425, 12661, 12677, 12678, 12675
5600, 12418, 12419, 12427, 12426, 12663, 12679, 12680, 12677
5601, 12419, 12420, 12428, 12427, 12665, 12681, 12682, 12679
5602, 12420, 12421, 12429, 12428, 12667, 12683, 12684, 12681
5603, 12421, 12422, 12430, 12429, 12669, 12685, 12686, 12683
5604, 12422, 1607, 1608, 12430, 12670, 1630, 12687, 12685
5605, 1474, 12423, 12431, 1475, 12672, 12688, 12689, 1497
5606, 12423, 12424, 12432, 12431, 12674, 12690, 12691, 12688
5607, 12424, 12425, 12433, 12432, 12676, 12692, 12693, 12690
5608, 12425, 12426, 12434, 12433, 12678, 12694, 12695, 12692
5609, 12426, 12427, 12435, 12434, 12680, 12696, 12697, 12694
5610, 12427, 12428, 12436, 12435, 12682, 12698, 12699, 12696
5611, 12428, 12429, 12437, 12436, 12684, 12700, 12701, 12698
5612, 12429, 12430, 12438, 12437, 12686, 12702, 12703, 12700
5613, 12430, 1608, 1609, 12438, 12687, 1631, 12704, 12702
5614, 1475, 12431, 12439, 1476, 12689, 12705, 12706, 1498
5615, 12431, 12432, 12440, 12439, 12691, 12707, 12708, 12705
5616, 12432, 12433, 12441, 12440, 12693, 12709, 12710, 12707
5617, 12433, 12434, 12442, 12441, 12695, 12711, 12712, 12709
5618, 12434, 12435, 12443, 12442, 12697, 12713, 12714, 12711
5619, 12435, 12436, 12444, 12443, 12699, 12715, 12716, 12713
5620, 12436, 12437, 12445, 12444, 12701, 12717, 12718, 12715
5621, 12437, 12438, 12446, 12445, 12703, 12719, 12720, 12717
5622, 12438, 1609, 1610, 12446, 12704, 1632, 12721, 12719
5623, 1476, 12439, 12447, 1477, 12706, 12722, 12723, 1499
5624, 12439, 12440, 12448, 12447, 12708, 12724, 12725, 12722
5625, 12440, 12441, 12449, 12448, 12710, 12726, 12727, 12724
5626, 12441, 12442, 12450, 12449, 12712, 12728, 12729, 12726
5627, 12442, 12443, 12451, 12450, 12714, 12730, 12731, 12728
5628, 12443, 12444, 12452, 12451, 12716, 12732, 12733, 12730
5629, 12444, 12445, 12453, 12452, 12718, 12734, 12735, 12732
5630, 12445, 12446, 12454, 12453, 12720, 12736, 12737, 12734
5631, 12446, 1610, 1611, 12454, 12721, 1633, 12738, 12736
5632, 1477, 12447, 12455, 1478, 12723, 12739, 12740, 1500
5633, 12447, 12448, 12456, 12455, 12725, 12741, 12742, 12739
5634, 12448, 12449, 12457, 12456, 12727, 12743, 12744, 12741
5635, 12449, 12450, 12458, 12457, 12729, 12745, 12746, 12743
5636, 12450, 12451, 12459, 12458, 12731, 12747, 12748, 12745
5637, 12451, 12452, 12460, 12459, 12733, 12749, 12750, 12747
5638, 12452, 12453, 12461, 12460, 12735, 12751, 12752, 12749
5639, 12453, 12454, 12462, 12461, 12737, 12753, 12754, 12751
5640, 12454, 1611, 1612, 12462, 12738, 1634, 12755, 12753
5641, 1478, 12455, 12463, 1479, 12740, 12756, 12757, 1501
5642, 12455, 12456, 12464, 12463, 12742, 12758, 12759, 12756
5643, 12456, 12457, 12465, 12464, 12744, 12760, 12761, 12758
5644, 12457, 12458, 12466, 12465, 12746, 12762, 12763, 12760
5645, 12458, 12459, 12467, 12466, 12748, 12764, 12765, 12762
5646, 12459, 12460, 12468, 12467, 12750, 12766, 12767, 12764
5647, 12460, 12461, 12469, 12468, 12752, 12768, 12769, 12766
5648, 12461, 12462, 12470, 12469, 12754, 12770, 12771, 12768
5649, 12462, 1612, 1613, 12470, 12755, 1635, 12772, 12770
5650, 1479, 12463, 12471, 1480, 12757, 12773, 12774, 1502
5651, 12463, 12464, 12472, 12471, 12759, 12775, 12776, 12773
5652, 12464, 12465, 12473, 12472, 12761, 12777, 12778, 12775
5653, 12465, 12466, 12474, 12473, 12763, 12779, 12780, 12777
5654, 12466, 12467, 12475, 12474, 12765, 12781, 12782, 12779
5655, 12467, 12468, 12476, 12475, 12767, 12783, 12784, 12781
5656, 12468, 12469, 12477, 12476, 12769, 12785, 12786, 12783
5657, 12469, 12470, 12478, 12477, 12771, 12787, 12788, 12785
5658, 12470, 1613, 1614, 12478, 12772, 1636, 12789, 12787
5659, 1480, 12471, 12479, 1481, 12774, 12790, 12791, 1503
5660, 12471, 12472, 12480, 12479, 12776, 12792, 12793, 12790
5661, 12472, 12473, 12481, 12480, 12778, 12794, 12795, 12792
5662, 12473, 12474, 12482, 12481, 12780, 12796, 12797, 12794
5663, 12474, 12475, 12483, 12482, 12782, 12798, 12799, 12796
5664, 12475, 12476, 12484, 12483, 12784, 12800, 12801, 12798
5665, 12476, 12477, 12485, 12484, 12786, 12802, 12803, 12800
5666, 12477, 12478, 12486, 12485, 12788, 12804, 12805, 12802
5667, 12478, 1614, 1615, 12486, 12789, 1637, 12806, 12804
5668, 1481, 12479, 12487, 1482, 12791, 12807, 12808, 1504
5669, 12479, 12480, 12488, 12487, 12793, 12809, 12810, 12807
5670, 12480, 12481, 12489, 12488, 12795, 12811, 12812, 12809
5671, 12481, 12482, 12490, 12489, 12797, 12813, 12814, 12811
5672, 12482, 12483, 12491, 12490, 12799, 12815, 12816, 12813
5673, 12483, 12484, 12492, 12491, 12801, 12817, 12818, 12815
5674, 12484, 12485, 12493, 12492, 12803, 12819, 12820, 12817
5675, 12485, 12486, 12494, 12493, 12805, 12821, 12822, 12819
5676, 12486, 1615, 1616, 12494, 12806, 1638, 12823, 12821
5677, 1482, 12487, 12495, 1483, 12808, 12824, 12825, 1505
5678, 12487, 12488, 12496, 12495, 12810, 12826, 12827, 12824
5679, 12488, 12489, 12497, 12496, 12812, 12828, 12829, 12826
5680, 12489, 12490, 12498, 12497, 12814, 12830, 12831, 12828
5681, 12490, 12491, 12499, 12498, 12816, 12832, 12833, 12830
5682, 12491, 12492, 12500, 12499, 12818, 12834, 12835, 12832
5683, 12492, 12493, 12501, 12500, 12820, 12836, 12837, 12834
5684, 12493, 12494, 12502, 12501, 12822, 12838, 12839, 12836
5685, 12494, 1616, 1617, 12502, 12823, 1639, 12840, 12838
5686, 1483, 12495, 12503, 1484, 12825, 12841, 12842, 1506
5687, 12495, 12496, 12504, 12503, 12827, 12843, 12844, 12841
5688, 12496, 12497, 12505, 12504, 12829, 12845, 12846, 12843
5689, 12497, 12498, 12506, 12505, 12831, 12847, 12848, 12845
5690, 12498, 12499, 12507, 12506, 12833, 12849, 12850, 12847
5691, 12499, 12500, 12508, 12507, 12835, 12851, 12852, 12849
5692, 12500, 12501, 12509, 12508, 12837, 12853, 12854, 12851
5693, 12501, 12502, 12510, 12509, 12839, 12855, 12856, 12853
5694, 12502, 1617, 1618, 12510, 12840, 1640, 12857, 12855
5695, 1484, 12503, 12511, 1485, 12842, 12858, 12859, 1507
5696, 12503, 12504, 12512, 12511, 12844, 12860, 12861, 12858
5697, 12504, 12505, 12513, 12512, 12846, 12862, 12863, 12860
5698, 12505, 12506, 12514, 12513, 12848, 12864, 12865, 12862
5699, 12506, 12507, 12515, 12514, 12850, 12866, 12867, 12864
5700, 12507, 12508, 12516, 12515, 12852, 12868, 12869, 12866
5701, 12508, 12509, 12517, 12516, 12854, 12870, 12871, 12868
5702, 12509, 12510, 12518, 12517, 12856, 12872, 12873, 12870
5703, 12510, 1618, 1619, 12518, 12857, 1641, 12874, 12872
5704, 1485, 12511, 12519, 1486, 12859, 12875, 12876, 1508
5705, 12511, 12512, 12520, 12519, 12861, 12877, 12878, 12875
5706, 12512, 12513, 12521, 12520, 12863, 12879, 12880, 12877
5707, 12513, 12514, 12522, 12521, 12865, 12881, 12882, 12879
5708, 12514, 12515, 12523, 12522, 12867, 12883, 12884, 12881
5709, 12515, 12516, 12524, 12523, 12869, 12885, 12886, 12883
5710, 12516, 12517, 12525, 12524, 12871, 12887, 12888, 12885
5711, 12517, 12518, 12526, 12525, 12873, 12889, 12890, 12887
5712, 12518, 1619, 1620, 12526, 12874, 1642, 12891, 12889
5713, 1486, 12519, 12527, 1487, 12876, 12892, 12893, 1509
5714, 12519, 12520, 12528, 12527, 12878, 12894, 12895, 12892
5715, 12520, 12521, 12529, 12528, 12880, 12896, 12897, 12894
5716, 12521, 12522, 12530, 12529, 12882, 12898, 12899, 12896
5717, 12522, 12523, 12531, 12530, 12884, 12900, 12901, 12898
5718, 12523, 12524, 12532, 12531, 12886, 12902, 12903, 12900
5719, 12524, 12525, 12533, 12532, 12888, 12904, 12905, 12902
5720, 12525, 12526, 12534, 12533, 12890, 12906, 12907, 12904
5721, 12526, 1620, 1621, 12534, 12891, 1643, 12908, 12906
5722, 1487, 12527, 1533, 46, 12893, 12909, 1541, 1510
5723, 12527, 12528, 1534, 1533, 12895, 12910, 1542, 12909
5724, 12528, 12529, 1535, 1534, 12897, 12911, 1543, 12910
5725, 12529, 12530, 1536, 1535, 12899, 12912, 1544, 12911
5726, 12530, 12531, 1537, 1536, 12901, 12913, 1545, 12912
5727, 12531, 12532, 1538, 1537, 12903, 12914, 1546, 12913
5728, 12532, 12533, 1539, 1538, 12905, 12915, 1547, 12914
5729, 12533, 12534, 1540, 1539, 12907, 12916, 1548, 12915
5730, 12534, 1621, 50, 1540, 12908, 1644, 1549, 12916
*ELEMENT, type=CPS8, ELSET=Surface212
5731, 49, 1679, 12917, 1511, 1682, 12923, 12924, 1513
5732, 1511, 12917, 12918, 1512, 12924, 12925, 12926, 1514
5733, 1512, 12918, 1686, 50, 12926, 12927, 1689, 1515
5734, 1679, 1680, 12919, 12917, 1683, 12928, 12929, 12923
5735, 12917, 12919, 12920, 12918, 12929, 12930, 12931, 12925
5736, 12918, 12920, 1687, 1686, 12931, 12932, 1690, 12927
5737, 1680, 1681, 12921, 12919, 1684, 12933, 12934, 12928
5738, 12919, 12921, 12922, 12920, 12934, 12935, 12936, 12930
5739, 12920, 12922, 1688, 1687, 12936, 12937, 1691, 12932
5740, 1681, 53, 1693, 12921, 1685, 1695, 12938, 12933
5741, 12921, 1693, 1694, 12922, 12938, 1696, 12939, 12935
5742, 12922, 1694, 54, 1688, 12939, 1697, 1692, 12937
*ELEMENT, type=CPS8, ELSET=Surface213
5743, 45, 1411, 12940, 1698, 1413, 12946, 12947, 1701
5744, 1411, 1412, 12941, 12940, 1414, 12948, 12949, 12946
5745, 1412, 46, 1705, 12941, 1415, 1708, 12950, 12948
5746, 1698, 12940, 12942, 1699, 12947, 12951, 12952, 1702
5747, 12940, 12941, 12943, 12942, 12949, 12953, 12954, 12951
5748, 12941, 1705, 1706, 12943, 12950, 1709, 12955, 12953
5749, 1699, 12942, 12944, 1700, 12952, 12956, 12957, 1703
5750, 12942, 12943, 12945, 12944, 12954, 12958, 12959, 12956
5751, 12943, 1706, 1707, 12945, 12955, 1710, 12960, 12958
5752, 1700, 12944, 1712, 55, 12957, 12961, 1714, 1704
5753, 12944, 12945, 1713, 1712, 12959, 12962, 1715, 12961
5754, 12945, 1707, 56, 1713, 12960, 1711, 1716, 12962
*ELEMENT, type=CPS8, ELSET=Surface214
5755, 49, 1523, 12963, 1679, 1532, 12987, 12988, 1682
5756, 1523, 1522, 12964, 12963, 1531, 12989, 12990, 12987
5757, 1522, 1521, 12965, 12964, 1530, 12991, 12992, 12989
5758, 1521, 1520, 12966, 12965, 1529, 12993, 12994, 12991
5759, 1520, 1519, 12967, 12966, 1528, 12995, 12996, 12993
5760, 1519, 1518, 12968, 12967, 1527, 12997, 12998, 12995
5761, 1518, 1517, 12969, 12968, 1526, 12999, 13000, 12997
5762, 1517, 1516, 12970, 12969, 1525, 13001, 13002, 12999
5763, 1516, 45, 1698, 12970, 1524, 1701, 13003, 13001
5764, 1679, 12963, 12971, 1680, 12988, 13004, 13005, 1683
5765, 12963, 12964, 12972, 12971, 12990, 13006, 13007, 13004
5766, 12964, 12965, 12973, 12972, 12992, 13008, 13009, 13006
5767, 12965, 12966, 12974, 12973, 12994, 13010, 13011, 13008
5768, 12966, 12967, 12975, 12974, 12996, 13012, 13013, 13010
5769, 12967, 12968, 12976, 12975, 12998, 13014, 13015, 13012
5770, 12968, 12969, 12977, 12976, 13000, 13016, 13017, 13014
5771, 12969, 12970, 12978, 12977, 13002, 13018, 13019, 13016
5772, 12970, 1698, 1699, 12978, 13003, 1702, 13020, 13018
5773, 1680, 12971, 12979, 1681, 13005, 13021, 13022, 1684
5774, 12971, 12972, 12980, 12979, 13007, 13023, 13024, 13021
5775, 12972, 12973, 12981, 12980, 13009, 13025, 13026, 13023
5776, 12973, 12974, 12982, 12981, 13011, 13027, 13028, 13025
5777, 12974, 12975, 12983, 12982, 13013, 13029, 13030, 13027
5778, 12975, 12976, 12984, 12983, 13015, 13031, 13032, 13029
5779, 12976, 12977, 12985, 12984, 13017, 13033, 13034, 13031
5780, 12977, 12978, 12986, 12985, 13019, 13035, 13036, 13033
5781, 12978, 1699, 1700, 12986, 13020, 1703, 13037, 13035
5782, 1681, 12979, 1724, 53, 13022, 13038, 1733, 1685
5783, 12979, 12980, 1723, 1724, 13024, 13039, 1732, 13038
5784, 12980, 12981, 1722, 1723, 13026, 13040, 1731, 13039
5785, 12981, 12982, 1721, 1722, 13028, 13041, 1730, 13040
5786, 12982, 12983, 1720, 1721, 13030, 13042, 1729, 13041
5787, 12983, 12984, 1719, 1720, 13032, 13043, 1728, 13042
5788, 12984, 12985, 1718, 1719, 13034, 13044, 1727, 13043
5789, 12985, 12986, 1717, 1718, 13036, 13045, 1726, 13044
5790, 12986, 1700, 55, 1717, 13037, 1704, 1725, 13045
*ELEMENT, type=CPS8, ELSET=Surface215
5791, 50, 1686, 13046, 1540, 1689, 13070, 13071, 1549
5792, 1540, 13046, 13047, 1539, 13071, 13072, 13073, 1548
5793, 1539, 13047, 13048, 1538, 13073, 13074, 13075, 1547
5794, 1538, 13048, 13049, 1537, 13075, 13076, 13077, 1546
5795, 1537, 13049, 13050, 1536, 13077, 13078, 13079, 1545
5796, 1536, 13050, 13051, 1535, 13079, 13080, 13081, 1544
5797, 1535, 13051, 13052, 1534, 13081, 13082, 13083, 1543
5798, 1534, 13052, 13053, 1533, 13083, 13084, 13085, 1542
5799, 1533, 13053, 1705, 46, 13085, 13086, 1708, 1541
5800, 1686, 1687, 13054, 13046, 1690, 13087, 13088, 13070
5801, 13046, 13054, 13055, 13047, 13088, 13089, 13090, 13072
5802, 13047, 13055, 13056, 13048, 13090, 13091, 13092, 13074
5803, 13048, 13056, 13057, 13049, 13092, 13093, 13094, 13076
5804, 13049, 13057, 13058, 13050, 13094, 13095, 13096, 13078
5805, 13050, 13058, 13059, 13051, 13096, 13097, 13098, 13080
5806, 13051, 13059, 13060, 13052, 13098, 13099, 13100, 13082
5807, 13052, 13060, 13061, 13053, 13100, 13101, 13102, 13084
5808, 13053, 13061, 1706, 1705, 13102, 13103, 1709, 13086
5809, 1687, 1688, 13062, 13054, 1691, 13104, 13105, 13087
5810, 13054, 13062, 13063, 13055, 13105, 13106, 13107, 13089
5811, 13055, 13063, 13064, 13056, 13107, 13108, 13109, 13091
5812, 13056, 13064, 13065, 13057, 13109, 13110, 13111, 13093
5813, 13057, 13065, 13066, 13058, 13111, 13112, 13113, 13095
5814, 13058, 13066, 13067, 13059, 13113, 13114, 13115, 13097
5815, 13059, 13067, 13068, 13060, 13115, 13116, 13117, 13099
5816, 13060, 13068, 13069, 13061, 13117, 13118, 13119, 13101
5817, 13061, 13069, 1707, 1706, 13119, 13120, 1710, 13103
5818, 1688, 54, 1741, 13062, 1692, 1750, 13121, 13104
5819, 13062, 1741, 1740, 13063, 13121, 1749, 13122, 13106
5820, 13063, 1740, 1739, 13064, 13122, 1748, 13123, 13108
5821, 13064, 1739, 1738, 13065, 13123, 1747, 13124, 13110
5822, 13065, 1738, 1737, 13066, 13124, 1746, 13125, 13112
5823, 13066, 1737, 1736, 13067, 13125, 1745, 13126, 13114
5824, 13067, 1736, 1735, 13068, 13126, 1744, 13127, 13116
5825, 13068, 1735, 1734, 13069, 13127, 1743, 13128, 13118
5826, 13069, 1734, 56, 1707, 13128, 1742, 1711, 13120
*ELEMENT, type=CPS8, ELSET=Surface216
5827, 53, 1724, 13129, 1693, 1733, 13145, 13146, 1695
5828, 1724, 1723, 13130, 13129, 1732, 13147, 13148, 13145
5829, 1723, 1722, 13131, 13130, 1731, 13149, 13150, 13147
5830, 1722, 1721, 13132, 13131, 1730, 13151, 13152, 13149
5831, 1721, 1720, 13133, 13132, 1729, 13153, 13154, 13151
5832, 1720, 1719, 13134, 13133, 1728, 13155, 13156, 13153
5833, 1719, 1718, 13135, 13134, 1727, 13157, 13158, 13155
5834, 1718, 1717, 13136, 13135, 1726, 13159, 13160, 13157
5835, 1717, 55, 1712, 13136, 1725, 1714, 13161, 13159
5836, 1693, 13129, 13137, 1694, 13146, 13162, 13163, 1696
5837, 13129, 13130, 13138, 13137, 13148, 13164, 13165, 13162
5838, 13130, 13131, 13139, 13138, 13150, 13166, 13167, 13164
5839, 13131, 13132, 13140, 13139, 13152, 13168, 13169, 13166
5840, 13132, 13133, 13141, 13140, 13154, 13170, 13171, 13168
5841, 13133, 13134, 13142, 13141, 13156, 13172, 13173, 13170
5842, 13134, 13135, 13143, 13142, 13158, 13174, 13175, 13172
5843, 13135, 13136, 13144, 13143, 13160, 13176, 13177, 13174
5844, 13136, 1712, 1713, 13144, 13161, 1715, 13178, 13176
5845, 1694, 13137, 1741, 54, 13163, 13179, 1750, 1697
5846, 13137, 13138, 1740, 1741, 13165, 13180, 1749, 13179
5847, 13138, 13139, 1739, 1740, 13167, 13181, 1748, 13180
5848, 13139, 13140, 1738, 1739, 13169, 13182, 1747, 13181
5849, 13140, 13141, 1737, 1738, 13171, 13183, 1746, 13182
5850, 13141, 13142, 1736, 1737, 13173, 13184, 1745, 13183
5851, 13142, 13143, 1735, 1736, 13175, 13185, 1744, 13184
5852, 13143, 13144, 1734, 1735, 13177, 13186, 1743, 13185
5853, 13144, 1713, 56, 1734, 13178, 1716, 1742, 13186
*ELEMENT, type=CPS8, ELSET=Surface217
5854, 50, 1686, 13187, 1751, 1689, 13196, 13197, 1754
5855, 1686, 1687, 13188, 13187, 1690, 13198, 13199, 13196
5856, 1687, 1688, 13189, 13188, 1691, 13200, 13201, 13198
5857, 1688, 54, 1758, 13189, 1692, 1761, 13202, 13200
5858, 1751, 13187, 13190, 1752, 13197, 13203, 13204, 1755
5859, 13187, 13188, 13191, 13190, 13199, 13205, 13206, 13203
5860, 13188, 13189, 13192, 13191, 13201, 13207, 13208, 13205
5861, 13189, 1758, 1759, 13192, 13202, 1762, 13209, 13207
5862, 1752, 13190, 13193, 1753, 13204, 13210, 13211, 1756
5863, 13190, 13191, 13194, 13193, 13206, 13212, 13213, 13210
5864, 13191, 13192, 13195, 13194, 13208, 13214, 13215, 13212
5865, 13192, 1759, 1760, 13195, 13209, 1763, 13216, 13214
5866, 1753, 13193, 1765, 57, 13211, 13217, 1768, 1757
5867, 13193, 13194, 1766, 1765, 13213, 13218, 1769, 13217
5868, 13194, 13195, 1767, 1766, 13215, 13219, 1770, 13218
5869, 13195, 1760, 58, 1767, 13216, 1764, 1771, 13219
*ELEMENT, type=CPS8, ELSET=Surface218
5870, 46, 1772, 13220, 1705, 1775, 13229, 13230, 1708
5871, 1705, 13220, 13221, 1706, 13230, 13231, 13232, 1709
5872, 1706, 13221, 13222, 1707, 13232, 13233, 13234, 1710
5873, 1707, 13222, 1779, 56, 13234, 13235, 1782, 1711
5874, 1772, 1773, 13223, 13220, 1776, 13236, 13237, 13229
5875, 13220, 13223, 13224, 13221, 13237, 13238, 13239, 13231
5876, 13221, 13224, 13225, 13222, 13239, 13240, 13241, 13233
5877, 13222, 13225, 1780, 1779, 13241, 13242, 1783, 13235
5878, 1773, 1774, 13226, 13223, 1777, 13243, 13244, 13236
5879, 13223, 13226, 13227, 13224, 13244, 13245, 13246, 13238
5880, 13224, 13227, 13228, 13225, 13246, 13247, 13248, 13240
5881, 13225, 13228, 1781, 1780, 13248, 13249, 1784, 13242
5882, 1774, 59, 1786, 13226, 1778, 1789, 13250, 13243
5883, 13226, 1786, 1787, 13227, 13250, 1790, 13251, 13245
5884, 13227, 1787, 1788, 13228, 13251, 1791, 13252, 13247
5885, 13228, 1788, 60, 1781, 13252, 1792, 1785, 13249
*ELEMENT, type=CPS8, ELSET=Surface219
5886, 50, 1751, 13253, 1540, 1754, 13277, 13278, 1549
5887, 1540, 13253, 13254, 1539, 13278, 13279, 13280, 1548
5888, 1539, 13254, 13255, 1538, 13280, 13281, 13282, 1547
5889, 1538, 13255, 13256, 1537, 13282, 13283, 13284, 1546
5890, 1537, 13256, 13257, 1536, 13284, 13285, 13286, 1545
5891, 1536, 13257, 13258, 1535, 13286, 13287, 13288, 1544
5892, 1535, 13258, 13259, 1534, 13288, 13289, 13290, 1543
5893, 1534, 13259, 13260, 1533, 13290, 13291, 13292, 1542
5894, 1533, 13260, 1772, 46, 13292, 13293, 1775, 1541
5895, 1751, 1752, 13261, 13253, 1755, 13294, 13295, 13277
5896, 13253, 13261, 13262, 13254, 13295, 13296, 13297, 13279
5897, 13254, 13262, 13263, 13255, 13297, 13298, 13299, 13281
5898, 13255, 13263, 13264, 13256, 13299, 13300, 13301, 13283
5899, 13256, 13264, 13265, 13257, 13301, 13302, 13303, 13285
5900, 13257, 13265, 13266, 13258, 13303, 13304, 13305, 13287
5901, 13258, 13266, 13267, 13259, 13305, 13306, 13307, 13289
5902, 13259, 13267, 13268, 13260, 13307, 13308, 13309, 13291
5903, 13260, 13268, 1773, 1772, 13309, 13310, 1776, 13293
5904, 1752, 1753, 13269, 13261, 1756, 13311, 13312, 13294
5905, 13261, 13269, 13270, 13262, 13312, 13313, 13314, 13296
5906, 13262, 13270, 13271, 13263, 13314, 13315, 13316, 13298
5907, 13263, 13271, 13272, 13264, 13316, 13317, 13318, 13300
5908, 13264, 13272, 13273, 13265, 13318, 13319, 13320, 13302
5909, 13265, 13273, 13274, 13266, 13320, 13321, 13322, 13304
5910, 13266, 13274, 13275, 13267, 13322, 13323, 13324, 13306
5911, 13267, 13275, 13276, 13268, 13324, 13325, 13326, 13308
5912, 13268, 13276, 1774, 1773, 13326, 13327, 1777, 13310
5913, 1753, 57, 1800, 13269, 1757, 1809, 13328, 13311
5914, 13269, 1800, 1799, 13270, 13328, 1808, 13329, 13313
5915, 13270, 1799, 1798, 13271, 13329, 1807, 13330, 13315
5916, 13271, 1798, 1797, 13272, 13330, 1806, 13331, 13317
5917, 13272, 1797, 1796, 13273, 13331, 1805, 13332, 13319
5918, 13273, 1796, 1795, 13274, 13332, 1804, 13333, 13321
5919, 13274, 1795, 1794, 13275, 13333, 1803, 13334, 13323
5920, 13275, 1794, 1793, 13276, 13334, 1802, 13335, 13325
5921, 13276, 1793, 59, 1774, 13335, 1801, 1778, 13327
*ELEMENT, type=CPS8, ELSET=Surface220
5922, 54, 1741, 13336, 1758, 1750, 13360, 13361, 1761
5923, 1741, 1740, 13337, 13336, 1749, 13362, 13363, 13360
5924, 1740, 1739, 13338, 13337, 1748, 13364, 13365, 13362
5925, 1739, 1738, 13339, 13338, 1747, 13366, 13367, 13364
5926, 1738, 1737, 13340, 13339, 1746, 13368, 13369, 13366
5927, 1737, 1736, 13341, 13340, 1745, 13370, 13371, 13368
5928, 1736, 1735, 13342, 13341, 1744, 13372, 13373, 13370
5929, 1735, 1734, 13343, 13342, 1743, 13374, 13375, 13372
5930, 1734, 56, 1779, 13343, 1742, 1782, 13376, 13374
5931, 1758, 13336, 13344, 1759, 13361, 13377, 13378, 1762
5932, 13336, 13337, 13345, 13344, 13363, 13379, 13380, 13377
5933, 13337, 13338, 13346, 13345, 13365, 13381, 13382, 13379
5934, 13338, 13339, 13347, 13346, 13367, 13383, 13384, 13381
5935, 13339, 13340, 13348, 13347, 13369, 13385, 13386, 13383
5936, 13340, 13341, 13349, 13348, 13371, 13387, 13388, 13385
5937, 13341, 13342, 13350, 13349, 13373, 13389, 13390, 13387
5938, 13342, 13343, 13351, 13350, 13375, 13391, 13392, 13389
5939, 13343, 1779, 1780, 13351, 13376, 1783, 13393, 13391
5940, 1759, 13344, 13352, 1760, 13378, 13394, 13395, 1763
5941, 13344, 13345, 13353, 13352, 13380, 13396, 13397, 13394
5942, 13345, 13346, 13354, 13353, 13382, 13398, 13399, 13396
5943, 13346, 13347, 13355, 13354, 13384, 13400, 13401, 13398
5944, 13347, 13348, 13356, 13355, 13386, 13402, 13403, 13400
5945, 13348, 13349, 13357, 13356, 13388, 13404, 13405, 13402
5946, 13349, 13350, 13358, 13357, 13390, 13406, 13407, 13404
5947, 13350, 13351, 13359, 13358, 13392, 13408, 13409, 13406
5948, 13351, 1780, 1781, 13359, 13393, 1784, 13410, 13408
5949, 1760, 13352, 1817, 58, 13395, 13411, 1826, 1764
5950, 13352, 13353, 1816, 1817, 13397, 13412, 1825, 13411
5951, 13353, 13354, 1815, 1816, 13399, 13413, 1824, 13412
5952, 13354, 13355, 1814, 1815, 13401, 13414, 1823, 13413
5953, 13355, 13356, 1813, 1814, 13403, 13415, 1822, 13414
5954, 13356, 13357, 1812, 1813, 13405, 13416, 1821, 13415
5955, 13357, 13358, 1811, 1812, 13407, 13417, 1820, 13416
5956, 13358, 13359, 1810, 1811, 13409, 13418, 1819, 13417
5957, 13359, 1781, 60, 1810, 13410, 1785, 1818, 13418
*ELEMENT, type=CPS8, ELSET=Surface221
5958, 57, 1765, 13419, 1800, 1768, 13443, 13444, 1809
5959, 1800, 13419, 13420, 1799, 13444, 13445, 13446, 1808
5960, 1799, 13420, 13421, 1798, 13446, 13447, 13448, 1807
5961, 1798, 13421, 13422, 1797, 13448, 13449, 13450, 1806
5962, 1797, 13422, 13423, 1796, 13450, 13451, 13452, 1805
5963, 1796, 13423, 13424, 1795, 13452, 13453, 13454, 1804
5964, 1795, 13424, 13425, 1794, 13454, 13455, 13456, 1803
5965, 1794, 13425, 13426, 1793, 13456, 13457, 13458, 1802
5966, 1793, 13426, 1786, 59, 13458, 13459, 1789, 1801
5967, 1765, 1766, 13427, 13419, 1769, 13460, 13461, 13443
5968, 13419, 13427, 13428, 13420, 13461, 13462, 13463, 13445
5969, 13420, 13428, 13429, 13421, 13463, 13464, 13465, 13447
5970, 13421, 13429, 13430, 13422, 13465, 13466, 13467, 13449
5971, 13422, 13430, 13431, 13423, 13467, 13468, 13469, 13451
5972, 13423, 13431, 13432, 13424, 13469, 13470, 13471, 13453
5973, 13424, 13432, 13433, 13425, 13471, 13472, 13473, 13455
5974, 13425, 13433, 13434, 13426, 13473, 13474, 13475, 13457
5975, 13426, 13434, 1787, 1786, 13475, 13476, 1790, 13459
5976, 1766, 1767, 13435, 13427, 1770, 13477, 13478, 13460
5977, 13427, 13435, 13436, 13428, 13478, 13479, 13480, 13462
5978, 13428, 13436, 13437, 13429, 13480, 13481, 13482, 13464
5979, 13429, 13437, 13438, 13430, 13482, 13483, 13484, 13466
5980, 13430, 13438, 13439, 13431, 13484, 13485, 13486, 13468
5981, 13431, 13439, 13440, 13432, 13486, 13487, 13488, 13470
5982, 13432, 13440, 13441, 13433, 13488, 13489, 13490, 13472
5983, 13433, 13441, 13442, 13434, 13490, 13491, 13492, 13474
5984, 13434, 13442, 1788, 1787, 13492, 13493, 1791, 13476
5985, 1767, 58, 1817, 13435, 1771, 1826, 13494, 13477
5986, 13435, 1817, 1816, 13436, 13494, 1825, 13495, 13479
5987, 13436, 1816, 1815, 13437, 13495, 1824, 13496, 13481
5988, 13437, 1815, 1814, 13438, 13496, 1823, 13497, 13483
5989, 13438, 1814, 1813, 13439, 13497, 1822, 13498, 13485
5990, 13439, 1813, 1812, 13440, 13498, 1821, 13499, 13487
5991, 13440, 1812, 1811, 13441, 13499, 1820, 13500, 13489
5992, 13441, 1811, 1810, 13442, 13500, 1819, 13501, 13491
5993, 13442, 1810, 60, 1788, 13501, 1818, 1792, 13493
*ELEMENT, type=CPS8, ELSET=Surface222
5994, 46, 1487, 13502, 1772, 1510, 13568, 13569, 1775
5995, 1487, 1486, 13503, 13502, 1509, 13570, 13571, 13568
5996, 1486, 1485, 13504, 13503, 1508, 13572, 13573, 13570
5997, 1485, 1484, 13505, 13504, 1507, 13574, 13575, 13572
5998, 1484, 1483, 13506, 13505, 1506, 13576, 13577, 13574
5999, 1483, 1482, 13507, 13506, 1505, 13578, 13579, 13576
6000, 1482, 1481, 13508, 13507, 1504, 13580, 13581, 13578
6001, 1481, 1480, 13509, 13508, 1503, 13582, 13583, 13580
6002, 1480, 1479, 13510, 13509, 1502, 13584, 13585, 13582
6003, 1479, 1478, 13511, 13510, 1501, 13586, 13587, 13584
6004, 1478, 1477, 13512, 13511, 1500, 13588, 13589, 13586
6005, 1477, 1476, 13513, 13512, 1499, 13590, 13591, 13588
6006, 1476, 1475, 13514, 13513, 1498, 13592, 13593, 13590
6007, 1475, 1474, 13515, 13514, 1497, 13594, 13595, 13592
6008, 1474, 1473, 13516, 13515, 1496, 13596, 13597, 13594
6009, 1473, 1472, 13517, 13516, 1495, 13598, 13599, 13596
6010, 1472, 1471, 13518, 13517, 1494, 13600, 13601, 13598
6011, 1471, 1470, 13519, 13518, 1493, 13602, 13603, 13600
6012, 1470, 1469, 13520, 13519, 1492, 13604, 13605, 13602
6013, 1469, 1468, 13521, 13520, 1491, 13606, 13607, 13604
6014, 1468, 1467, 13522, 13521, 1490, 13608, 13609, 13606
6015, 1467, 1466, 13523, 13522, 1489, 13610, 13611, 13608
6016, 1466, 48, 1827, 13523, 1488, 1830, 13612, 13610
6017, 1772, 13502, 13524, 1773, 13569, 13613, 13614, 1776
6018, 13502, 13503, 13525, 13524, 13571, 13615, 13616, 13613
6019, 13503, 13504, 13526, 13525, 13573, 13617, 13618, 13615
6020, 13504, 13505, 13527, 13526, 13575, 13619, 13620, 13617
6021, 13505, 13506, 13528, 13527, 13577, 13621, 13622, 13619
6022, 13506, 13507, 13529, 13528, 13579, 13623, 13624, 13621
6023, 13507, 13508, 13530, 13529, 13581, 13625, 13626, 13623
6024, 13508, 13509, 13531, 13530, 13583, 13627, 13628, 13625
6025, 13509, 13510, 13532, 13531, 13585, 13629, 13630, 13627
6026, 13510, 13511, 13533, 13532, 13587, 13631, 13632, 13629
6027, 13511, 13512, 13534, 13533, 13589, 13633, 13634, 13631
6028, 13512, 13513, 13535, 13534, 13591, 13635, 13636, 13633
6029, 13513, 13514, 13536, 13535, 13593, 13637, 13638, 13635
6030, 13514, 13515, 13537, 13536, 13595, 13639, 13640, 13637
6031, 13515, 13516, 13538, 13537, 13597, 13641, 13642, 13639
6032, 13516, 13517, 13539, 13538, 13599, 13643, 13644, 13641
6033, 13517, 13518, 13540, 13539, 13601, 13645, 13646, 13643
6034, 13518, 13519, 13541, 13540, 13603, 13647, 13648, 13645
6035, 13519, 13520, 13542, 13541, 13605, 13649, 13650, 13647
6036, 13520, 13521, 13543, 13542, 13607, 13651, 13652, 13649
6037, 13521, 13522, 13544, 13543, 13609, 13653, 13654, 13651
6038, 13522, 13523, 13545, 13544, 13611, 13655, 13656, 13653
6039, 13523, 1827, 1828, 13545, 13612, 1831, 13657, 13655
6040, 1773, 13524, 13546, 1774, 13614, 13658, 13659, 1777
6041, 13524, 13525, 13547, 13546, 13616, 13660, 13661, 13658
6042, 13525, 13526, 13548, 13547, 13618, 13662, 13663, 13660
6043, 13526, 13527, 13549, 13548, 13620, 13664, 13665, 13662
6044, 13527, 13528, 13550, 13549, 13622, 13666, 13667, 13664
6045, 13528, 13529, 13551, 13550, 13624, 13668, 13669, 13666
6046, 13529, 13530, 13552, 13551, 13626, 13670, 13671, 13668
6047, 13530, 13531, 13553, 13552, 13628, 13672, 13673, 13670
6048, 13531, 13532, 13554, 13553, 13630, 13674, 13675, 13672
6049, 13532, 13533, 13555, 13554, 13632, 13676, 13677, 13674
6050, 13533, 13534, 13556, 13555, 13634, 13678, 13679, 13676
6051, 13534, 13535, 13557, 13556, 13636, 13680, 13681, 13678
6052, 13535, 13536, 13558, 13557, 13638, 13682, 13683, 13680
6053, 13536, 13537, 13559, 13558, 13640, 13684, 13685, 13682
6054, 13537, 13538, 13560, 13559, 13642, 13686, 13687, 13684
6055, 13538, 13539, 13561, 13560, 13644, 13688, 13689, 13686
6056, 13539, 13540, 13562, 13561, 13646, 13690, 13691, 13688
6057, 13540, 13541, 13563, 13562, 13648, 13692, 13693, 13690
6058, 13541, 13542, 13564, 13563, 13650, 13694, 13695, 13692
6059, 13542, 13543, 13565, 13564, 13652, 13696, 13697, 13694
6060, 13543, 13544, 13566, 13565, 13654, 13698, 13699, 13696
6061, 13544, 13545, 13567, 13566, 13656, 13700, 13701, 13698
6062, 13545, 1828, 1829, 13567, 13657, 1832, 13702, 13700
6063, 1774, 13546, 1855, 59, 13659, 13703, 1878, 1778
6064, 13546, 13547, 1854, 1855, 13661, 13704, 1877, 13703
6065, 13547, 13548, 1853, 1854, 13663, 13705, 1876, 13704
6066, 13548, 13549, 1852, 1853, 13665, 13706, 1875, 13705
6067, 13549, 13550, 1851, 1852, 13667, 13707, 1874, 13706
6068, 13550, 13551, 1850, 1851, 13669, 13708, 1873, 13707
6069, 13551, 13552, 1849, 1850, 13671, 13709, 1872, 13708
6070, 13552, 13553, 1848, 1849, 13673, 13710, 1871, 13709
6071, 13553, 13554, 1847, 1848, 13675, 13711, 1870, 13710
6072, 13554, 13555, 1846, 1847, 13677, 13712, 1869, 13711
6073, 13555, 13556, 1845, 1846, 13679, 13713, 1868, 13712
6074, 13556, 13557, 1844, 1845, 13681, 13714, 1867, 13713
6075, 13557, 13558, 1843, 1844, 13683, 13715, 1866, 13714
6076, 13558, 13559, 1842, 1843, 13685, 13716, 1865, 13715
6077, 13559, 13560, 1841, 1842, 13687, 13717, 1864, 13716
6078, 13560, 13561, 1840, 1841, 13689, 13718, 1863, 13717
6079, 13561, 13562, 1839, 1840, 13691, 13719, 1862, 13718
6080, 13562, 13563, 1838, 1839, 13693, 13720, 1861, 13719
6081, 13563, 13564, 1837, 1838, 13695, 13721, 1860, 13720
6082, 13564, 13565, 1836, 1837, 13697, 13722, 1859, 13721
6083, 13565, 13566, 1835, 1836, 13699, 13723, 1858, 13722
6084, 13566, 13567, 1834, 1835, 13701, 13724, 1857, 13723
6085, 13567, 1829, 61, 1834, 13702, 1833, 1856, 13724
*ELEMENT, type=CPS8, ELSET=Surface223
6086, 50, 1751, 13725, 1621, 1754, 13791, 13792, 1644
6087, 1621, 13725, 13726, 1620, 13792, 13793, 13794, 1643
6088, 1620, 13726, 13727, 1619, 13794, 13795, 13796, 1642
6089, 1619, 13727, 13728, 1618, 13796, 13797, 13798, 1641
6090, 1618, 13728, 13729, 1617, 13798, 13799, 13800, 1640
6091, 1617, 13729, 13730, 1616, 13800, 13801, 13802, 1639
6092, 1616, 13730, 13731, 1615, 13802, 13803, 13804, 1638
6093, 1615, 13731, 13732, 1614, 13804, 13805, 13806, 1637
6094, 1614, 13732, 13733, 1613, 13806, 13807, 13808, 1636
6095, 1613, 13733, 13734, 1612, 13808, 13809, 13810, 1635
6096, 1612, 13734, 13735, 1611, 13810, 13811, 13812, 1634
6097, 1611, 13735, 13736, 1610, 13812, 13813, 13814, 1633
6098, 1610, 13736, 13737, 1609, 13814, 13815, 13816, 1632
6099, 1609, 13737, 13738, 1608, 13816, 13817, 13818, 1631
6100, 1608, 13738, 13739, 1607, 13818, 13819, 13820, 1630
6101, 1607, 13739, 13740, 1606, 13820, 13821, 13822, 1629
6102, 1606, 13740, 13741, 1605, 13822, 13823, 13824, 1628
6103, 1605, 13741, 13742, 1604, 13824, 13825, 13826, 1627
6104, 1604, 13742, 13743, 1603, 13826, 13827, 13828, 1626
6105, 1603, 13743, 13744, 1602, 13828, 13829, 13830, 1625
6106, 1602, 13744, 13745, 1601, 13830, 13831, 13832, 1624
6107, 1601, 13745, 13746, 1600, 13832, 13833, 13834, 1623
6108, 1600, 13746, 1879, 52, 13834, 13835, 1882, 1622
6109, 1751, 1752, 13747, 13725, 1755, 13836, 13837, 13791
6110, 13725, 13747, 13748, 13726, 13837, 13838, 13839, 13793
6111, 13726, 13748, 13749, 13727, 13839, 13840, 13841, 13795
6112, 13727, 13749, 13750, 13728, 13841, 13842, 13843, 13797
6113, 13728, 13750, 13751, 13729, 13843, 13844, 13845, 13799
6114, 13729, 13751, 13752, 13730, 13845, 13846, 13847, 13801
6115, 13730, 13752, 13753, 13731, 13847, 13848, 13849, 13803
6116, 13731, 13753, 13754, 13732, 13849, 13850, 13851, 13805
6117, 13732, 13754, 13755, 13733, 13851, 13852, 13853, 13807
6118, 13733, 13755, 13756, 13734, 13853, 13854, 13855, 13809
6119, 13734, 13756, 13757, 13735, 13855, 13856, 13857, 13811
6120, 13735, 13757, 13758, 13736, 13857, 13858, 13859, 13813
6121, 13736, 13758, 13759, 13737, 13859, 13860, 13861, 13815
6122, 13737, 13759, 13760, 13738, 13861, 13862, 13863, 13817
6123, 13738, 13760, 13761, 13739, 13863, 13864, 13865, 13819
6124, 13739, 13761, 13762, 13740, 13865, 13866, 13867, 13821
6125, 13740, 13762, 13763, 13741, 13867, 13868, 13869, 13823
6126, 13741, 13763, 13764, 13742, 13869, 13870, 13871, 13825
6127, 13742, 13764, 13765, 13743, 13871, 13872, 13873, 13827
6128, 13743, 13765, 13766, 13744, 13873, 13874, 13875, 13829
6129, 13744, 13766, 13767, 13745, 13875, 13876, 13877, 13831
6130, 13745, 13767, 13768, 13746, 13877, 13878, 13879, 13833
6131, 13746, 13768, 1880, 1879, 13879, 13880, 1883, 13835
6132, 1752, 1753, 13769, 13747, 1756, 13881, 13882, 13836
6133, 13747, 13769, 13770, 13748, 13882, 13883, 13884, 13838
6134, 13748, 13770, 13771, 13749, 13884, 13885, 13886, 13840
6135, 13749, 13771, 13772, 13750, 13886, 13887, 13888, 13842
6136, 13750, 13772, 13773, 13751, 13888, 13889, 13890, 13844
6137, 13751, 13773, 13774, 13752, 13890, 13891, 13892, 13846
6138, 13752, 13774, 13775, 13753, 13892, 13893, 13894, 13848
6139, 13753, 13775, 13776, 13754, 13894, 13895, 13896, 13850
6140, 13754, 13776, 13777, 13755, 13896, 13897, 13898, 13852
6141, 13755, 13777, 13778, 13756, 13898, 13899, 13900, 13854
6142, 13756, 13778, 13779, 13757, 13900, 13901, 13902, 13856
6143, 13757, 13779, 13780, 13758, 13902, 13903, 13904, 13858
6144, 13758, 13780, 13781, 13759, 13904, 13905, 13906, 13860
6145, 13759, 13781, 13782, 13760, 13906, 13907, 13908, 13862
6146, 13760, 13782, 13783, 13761, 13908, 13909, 13910, 13864
6147, 13761, 13783, 13784, 13762, 13910, 13911, 13912, 13866
6148, 13762, 13784, 13785, 13763, 13912, 13913, 13914, 13868
6149, 13763, 13785, 13786, 13764, 13914, 13915, 13916, 13870
6150, 13764, 13786, 13787, 13765, 13916, 13917, 13918, 13872
6151, 13765, 13787, 13788, 13766, 13918, 13919, 13920, 13874
6152, 13766, 13788, 13789, 13767, 13920, 13921, 13922, 13876
6153, 13767, 13789, 13790, 13768, 13922, 13923, 13924, 13878
6154, 13768, 13790, 1881, 1880, 13924, 13925, 1884, 13880
6155, 1753, 57, 1907, 13769, 1757, 1930, 13926, 13881
6156, 13769, 1907, 1906, 13770, 13926, 1929, 13927, 13883
6157, 13770, 1906, 1905, 13771, 13927, 1928, 13928, 13885
6158, 13771, 1905, 1904, 13772, 13928, 1927, 13929, 13887
6159, 13772, 1904, 1903, 13773, 13929, 1926, 13930, 13889
6160, 13773, 1903, 1902, 13774, 13930, 1925, 13931, 13891
6161, 13774, 1902, 1901, 13775, 13931, 1924, 13932, 13893
6162, 13775, 1901, 1900, 13776, 13932, 1923, 13933, 13895
6163, 13776, 1900, 1899, 13777, 13933, 1922, 13934, 13897
6164, 13777, 1899, 1898, 13778, 13934, 1921, 13935, 13899
6165, 13778, 1898, 1897, 13779, 13935, 1920, 13936, 13901
6166, 13779, 1897, 1896, 13780, 13936, 1919, 13937, 13903
6167, 13780, 1896, 1895, 13781, 13937, 1918, 13938, 13905
6168, 13781, 1895, 1894, 13782, 13938, 1917, 13939, 13907
6169, 13782, 1894, 1893, 13783, 13939, 1916, 13940, 13909
6170, 13783, 1893, 1892, 13784, 13940, 1915, 13941, 13911
6171, 13784, 1892, 1891, 13785, 13941, 1914, 13942, 13913
6172, 13785, 1891, 1890, 13786, 13942, 1913, 13943, 13915
6173, 13786, 1890, 1889, 13787, 13943, 1912, 13944, 13917
6174, 13787, 1889, 1888, 13788, 13944, 1911, 13945, 13919
6175, 13788, 1888, 1887, 13789, 13945, 1910, 13946, 13921
6176, 13789, 1887, 1886, 13790, 13946, 1909, 13947, 13923
6177, 13790, 1886, 62, 1881, 13947, 1908, 1885, 13925
*ELEMENT, type=CPS8, ELSET=Surface224
6178, 52, 1879, 13948, 1669, 1882, 13972, 13973, 1678
6179, 1669, 13948, 13949, 1668, 13973, 13974, 13975, 1677
6180, 1668, 13949, 13950, 1667, 13975, 13976, 13977, 1676
6181, 1667, 13950, 13951, 1666, 13977, 13978, 13979, 1675
6182, 1666, 13951, 13952, 1665, 13979, 13980, 13981, 1674
6183, 1665, 13952, 13953, 1664, 13981, 13982, 13983, 1673
6184, 1664, 13953, 13954, 1663, 13983, 13984, 13985, 1672
6185, 1663, 13954, 13955, 1662, 13985, 13986, 13987, 1671
6186, 1662, 13955, 1827, 48, 13987, 13988, 1830, 1670
6187, 1879, 1880, 13956, 13948, 1883, 13989, 13990, 13972
6188, 13948, 13956, 13957, 13949, 13990, 13991, 13992, 13974
6189, 13949, 13957, 13958, 13950, 13992, 13993, 13994, 13976
6190, 13950, 13958, 13959, 13951, 13994, 13995, 13996, 13978
6191, 13951, 13959, 13960, 13952, 13996, 13997, 13998, 13980
6192, 13952, 13960, 13961, 13953, 13998, 13999, 14000, 13982
6193, 13953, 13961, 13962, 13954, 14000, 14001, 14002, 13984
6194, 13954, 13962, 13963, 13955, 14002, 14003, 14004, 13986
6195, 13955, 13963, 1828, 1827, 14004, 14005, 1831, 13988
6196, 1880, 1881, 13964, 13956, 1884, 14006, 14007, 13989
6197, 13956, 13964, 13965, 13957, 14007, 14008, 14009, 13991
6198, 13957, 13965, 13966, 13958, 14009, 14010, 14011, 13993
6199, 13958, 13966, 13967, 13959, 14011, 14012, 14013, 13995
6200, 13959, 13967, 13968, 13960, 14013, 14014, 14015, 13997
6201, 13960, 13968, 13969, 13961, 14015, 14016, 14017, 13999
6202, 13961, 13969, 13970, 13962, 14017, 14018, 14019, 14001
6203, 13962, 13970, 13971, 13963, 14019, 14020, 14021, 14003
6204, 13963, 13971, 1829, 1828, 14021, 14022, 1832, 14005
6205, 1881, 62, 1938, 13964, 1885, 1947, 14023, 14006
6206, 13964, 1938, 1937, 13965, 14023, 1946, 14024, 14008
6207, 13965, 1937, 1936, 13966, 14024, 1945, 14025, 14010
6208, 13966, 1936, 1935, 13967, 14025, 1944, 14026, 14012
6209, 13967, 1935, 1934, 13968, 14026, 1943, 14027, 14014
6210, 13968, 1934, 1933, 13969, 14027, 1942, 14028, 14016
6211, 13969, 1933, 1932, 13970, 14028, 1941, 14029, 14018
6212, 13970, 1932, 1931, 13971, 14029, 1940, 14030, 14020
6213, 13971, 1931, 61, 1829, 14030, 1939, 1833, 14022
*ELEMENT, type=CPS8, ELSET=Surface225
6214, 61, 1931, 14031, 1834, 1939, 14207, 14208, 1856
6215, 1931, 1932, 14032, 14031, 1940, 14209, 14210, 14207
6216, 1932, 1933, 14033, 14032, 1941, 14211, 14212, 14209
6217, 1933, 1934, 14034, 14033, 1942, 14213, 14214, 14211
6218, 1934, 1935, 14035, 14034, 1943, 14215, 14216, 14213
6219, 1935, 1936, 14036, 14035, 1944, 14217, 14218, 14215
6220, 1936, 1937, 14037, 14036, 1945, 14219, 14220, 14217
6221, 1937, 1938, 14038, 14037, 1946, 14221, 14222, 14219
6222, 1938, 62, 1886, 14038, 1947, 1908, 14223, 14221
6223, 1834, 14031, 14039, 1835, 14208, 14224, 14225, 1857
6224, 14031, 14032, 14040, 14039, 14210, 14226, 14227, 14224
6225, 14032, 14033, 14041, 14040, 14212, 14228, 14229, 14226
6226, 14033, 14034, 14042, 14041, 14214, 14230, 14231, 14228
6227, 14034, 14035, 14043, 14042, 14216, 14232, 14233, 14230
6228, 14035, 14036, 14044, 14043, 14218, 14234, 14235, 14232
6229, 14036, 14037, 14045, 14044, 14220, 14236, 14237, 14234
6230, 14037, 14038, 14046, 14045, 14222, 14238, 14239, 14236
6231, 14038, 1886, 1887, 14046, 14223, 1909, 14240, 14238
6232, 1835, 14039, 14047, 1836, 14225, 14241, 14242, 1858
6233, 14039, 14040, 14048, 14047, 14227, 14243, 14244, 14241
6234, 14040, 14041, 14049, 14048, 14229, 14245, 14246, 14243
6235, 14041, 14042, 14050, 14049, 14231, 14247, 14248, 14245
6236, 14042, 14043, 14051, 14050, 14233, 14249, 14250, 14247
6237, 14043, 14044, 14052, 14051, 14235, 14251, 14252, 14249
6238, 14044, 14045, 14053, 14052, 14237, 14253, 14254, 14251
6239, 14045, 14046, 14054, 14053, 14239, 14255, 14256, 14253
6240, 14046, 1887, 1888, 14054, 14240, 1910, 14257, 14255
6241, 1836, 14047, 14055, 1837, 14242, 14258, 14259, 1859
6242, 14047, 14048, 14056, 14055, 14244, 14260, 14261, 14258
6243, 14048, 14049, 14057, 14056, 14246, 14262, 14263, 14260
6244, 14049, 14050, 14058, 14057, 14248, 14264, 14265, 14262
6245, 14050, 14051, 14059, 14058, 14250, 14266, 14267, 14264
6246, 14051, 14052, 14060, 14059, 14252, 14268, 14269, 14266
6247, 14052, 14053, 14061, 14060, 14254, 14270, 14271, 14268
6248, 14053, 14054, 14062, 14061, 14256, 14272, 14273, 14270
6249, 14054, 1888, 1889, 14062, 14257, 1911, 14274, 14272
6250, 1837, 14055, 14063, 1838, 14259, 14275, 14276, 1860
6251, 14055, 14056, 14064, 14063, 14261, 14277, 14278, 14275
6252, 14056, 14057, 14065, 14064, 14263, 14279, 14280, 14277
6253, 14057, 14058, 14066, 14065, 14265, 14281, 14282, 14279
6254, 14058, 14059, 14067, 14066, 14267, 14283, 14284, 14281
6255, 14059, 14060, 14068, 14067, 14269, 14285, 14286, 14283
6256, 14060, 14061, 14069, 14068, 14271, 14287, 14288, 14285
6257, 14061, 14062, 14070, 14069, 14273, 14289, 14290, 14287
6258, 14062, 1889, 1890, 14070, 14274, 1912, 14291, 14289
6259, 1838, 14063, 14071, 1839, 14276, 14292, 14293, 1861
6260, 14063, 14064, 14072, 14071, 14278, 14294, 14295, 14292
6261, 14064, 14065, 14073, 14072, 14280, 14296, 14297, 14294
6262, 14065, 14066, 14074, 14073, 14282, 14298, 14299, 14296
6263, 14066, 14067, 14075, 14074, 14284, 14300, 14301, 14298
6264, 14067, 14068, 14076, 14075, 14286, 14302, 14303, 14300
6265, 14068, 14069, 14077, 14076, 14288, 14304, 14305, 14302
6266, 14069, 14070, 14078, 14077, 14290, 14306, 14307, 14304
6267, 14070, 1890, 1891, 14078, 14291, 1913, 14308, 14306
6268, 1839, 14071, 14079, 1840, 14293, 14309, 14310, 1862
6269, 14071, 14072, 14080, 14079, 14295, 14311, 14312, 14309
6270, 14072, 14073, 14081, 14080, 14297, 14313, 14314, 14311
6271, 14073, 14074, 14082, 14081, 14299, 14315, 14316, 14313
6272, 14074, 14075, 14083, 14082, 14301, 14317, 14318, 14315
6273, 14075, 14076, 14084, 14083, 14303, 14319, 14320, 14317
6274, 14076, 14077, 14085, 14084, 14305, 14321, 14322, 14319
6275, 14077, 14078, 14086, 14085, 14307, 14323, 14324, 14321
6276, 14078, 1891, 1892, 14086, 14308, 1914, 14325, 14323
6277, 1840, 14079, 14087, 1841, 14310, 14326, 14327, 1863
6278, 14079, 14080, 14088, 14087, 14312, 14328, 14329, 14326
6279, 14080, 14081, 14089, 14088, 14314, 14330, 14331, 14328
6280, 14081, 14082, 14090, 14089, 14316, 14332, 14333, 14330
6281, 14082, 14083, 14091, 14090, 14318, 14334, 14335, 14332
6282, 14083, 14084, 14092, 14091, 14320, 14336, 14337, 14334
6283, 14084, 14085, 14093, 14092, 14322, 14338, 14339, 14336
6284, 14085, 14086, 14094, 14093, 14324, 14340, 14341, 14338
6285, 14086, 1892, 1893, 14094, 14325, 1915, 14342, 14340
6286, 1841, 14087, 14095, 1842, 14327, 14343, 14344, 1864
6287, 14087, 14088, 14096, 14095, 14329, 14345, 14346, 14343
6288, 14088, 14089, 14097, 14096, 14331, 14347, 14348, 14345
6289, 14089, 14090, 14098, 14097, 14333, 14349, 14350, 14347
6290, 14090, 14091, 14099, 14098, 14335, 14351, 14352, 14349
6291, 14091, 14092, 14100, 14099, 14337, 14353, 14354, 14351
6292, 14092, 14093, 14101, 14100, 14339, 14355, 14356, 14353
6293, 14093, 14094, 14102, 14101, 14341, 14357, 14358, 14355
6294, 14094, 1893, 1894, 14102, 14342, 1916, 14359, 14357
6295, 1842, 14095, 14103, 1843, 14344, 14360, 14361, 1865
6296, 14095, 14096, 14104, 14103, 14346, 14362, 14363, 14360
6297, 14096, 14097, 14105, 14104, 14348, 14364, 14365, 14362
6298, 14097, 14098, 14106, 14105, 14350, 14366, 14367, 14364
6299, 14098, 14099, 14107, 14106, 14352, 14368, 14369, 14366
6300, 14099, 14100, 14108, 14107, 14354, 14370, 14371, 14368
6301, 14100, 14101, 14109, 14108, 14356, 14372, 14373, 14370
6302, 14101, 14102, 14110, 14109, 14358, 14374, 14375, 14372
6303, 14102, 1894, 1895, 14110, 14359, 1917, 14376, 14374
6304, 1843, 14103, 14111, 1844, 14361, 14377, 14378, 1866
6305, 14103, 14104, 14112, 14111, 14363, 14379, 14380, 14377
6306, 14104, 14105, 14113, 14112, 14365, 14381, 14382, 14379
6307, 14105, 14106, 14114, 14113, 14367, 14383, 14384, 14381
6308, 14106, 14107, 14115, 14114, 14369, 14385, 14386, 14383
6309, 14107, 14108, 14116, 14115, 14371, 14387, 14388, 14385
6310, 14108, 14109, 14117, 14116, 14373, 14389, 14390, 14387
6311, 14109, 14110, 14118, 14117, 14375, 14391, 14392, 14389
6312, 14110, 1895, 1896, 14118, 14376, 1918, 14393, 14391
6313, 1844, 14111, 14119, 1845, 14378, 14394, 14395, 1867
6314, 14111, 14112, 14120, 14119, 14380, 14396, 14397, 14394
6315, 14112, 14113, 14121, 14120, 14382, 14398, 14399, 14396
6316, 14113, 14114, 14122, 14121, 14384, 14400, 14401, 14398
6317, 14114, 14115, 14123, 14122, 14386, 14402, 14403, 14400
6318, 14115, 14116, 14124, 14123, 14388, 14404, 14405, 14402
6319, 14116, 14117, 14125, 14124, 14390, 14406, 14407, 14404
6320, 14117, 14118, 14126, 14125, 14392, 14408, 14409, 14406
6321, 14118, 1896, 1897, 14126, 14393, 1919, 14410, 14408
6322, 1845, 14119, 14127, 1846, 14395, 14411, 14412, 1868
6323, 14119, 14120, 14128, 14127, 14397, 14413, 14414, 14411
6324, 14120, 14121, 14129, 14128, 14399, 14415, 14416, 14413
6325, 14121, 14122, 14130, 14129, 14401, 14417, 14418, 14415
6326, 14122, 14123, 14131, 14130, 14403, 14419, 14420, 14417
6327, 14123, 14124, 14132, 14131, 14405, 14421, 14422, 14419
6328, 14124, 14125, 14133, 14132, 14407, 14423, 14424, 14421
6329, 14125, 14126, 14134, 14133, 14409, 14425, 14426, 14423
6330, 14126, 1897, 1898, 14134, 14410, 1920, 14427, 14425
6331, 1846, 14127, 14135, 1847, 14412, 14428, 14429, 1869
6332, 14127, 14128, 14136, 14135, 14414, 14430, 14431, 14428
6333, 14128, 14129, 14137, 14136, 14416, 14432, 14433, 14430
6334, 14129, 14130, 14138, 14137, 14418, 14434, 14435, 14432
6335, 14130, 14131, 14139, 14138, 14420, 14436, 14437, 14434
6336, 14131, 14132, 14140, 14139, 14422, 14438, 14439, 14436
6337, 14132, 14133, 14141, 14140, 14424, 14440, 14441, 14438
6338, 14133, 14134, 14142, 14141, 14426, 14442, 14443, 14440
6339, 14134, 1898, 1899, 14142, 14427, 1921, 14444, 14442
6340, 1847, 14135, 14143, 1848, 14429, 14445, 14446, 1870
6341, 14135, 14136, 14144, 14143, 14431, 14447, 14448, 14445
6342, 14136, 14137, 14145, 14144, 14433, 14449, 14450, 14447
6343, 14137, 14138, 14146, 14145, 14435, 14451, 14452, 14449
6344, 14138, 14139, 14147, 14146, 14437, 14453, 14454, 14451
6345, 14139, 14140, 14148, 14147, 14439, 14455, 14456, 14453
6346, 14140, 14141, 14149, 14148, 14441, 14457, 14458, 14455
6347, 14141, 14142, 14150, 14149, 14443, 14459, 14460, 14457
6348, 14142, 1899, 1900, 14150, 14444, 1922, 14461, 14459
6349, 1848, 14143, 14151, 1849, 14446, 14462, 14463, 1871
6350, 14143, 14144, 14152, 14151, 14448, 14464, 14465, 14462
6351, 14144, 14145, 14153, 14152, 14450, 14466, 14467, 14464
6352, 14145, 14146, 14154, 14153, 14452, 14468, 14469, 14466
6353, 14146, 14147, 14155, 14154, 14454, 14470, 14471, 14468
6354, 14147, 14148, 14156, 14155, 14456, 14472, 14473, 14470
6355, 14148, 14149, 14157, 14156, 14458, 14474, 14475, 14472
6356, 14149, 14150, 14158, 14157, 14460, 14476, 14477, 14474
6357, 14150, 1900, 1901, 14158, 14461, 1923, 14478, 14476
6358, 1849, 14151, 14159, 1850, 14463, 14479, 14480, 1872
6359, 14151, 14152, 14160, 14159, 14465, 14481, 14482, 14479
6360, 14152, 14153, 14161, 14160, 14467, 14483, 14484, 14481
6361, 14153, 14154, 14162, 14161, 14469, 14485, 14486, 14483
6362, 14154, 14155, 14163, 14162, 14471, 14487, 14488, 14485
6363, 14155, 14156, 14164, 14163, 14473, 14489, 14490, 14487
6364, 14156, 14157, 14165, 14164, 14475, 14491, 14492, 14489
6365, 14157, 14158, 14166, 14165, 14477, 14493, 14494, 14491
6366, 14158, 1901, 1902, 14166, 14478, 1924, 14495, 14493
6367, 1850, 14159, 14167, 1851, 14480, 14496, 14497, 1873
6368, 14159, 14160, 14168, 14167, 14482, 14498, 14499, 14496
6369, 14160, 14161, 14169, 14168, 14484, 14500, 14501, 14498
6370, 14161, 14162, 14170, 14169, 14486, 14502, 14503, 14500
6371, 14162, 14163, 14171, 14170, 14488, 14504, 14505, 14502
6372, 14163, 14164, 14172, 14171, 14490, 14506, 14507, 14504
6373, 14164, 14165, 14173, 14172, 14492, 14508, 14509, 14506
6374, 14165, 14166, 14174, 14173, 14494, 14510, 14511, 14508
6375, 14166, 1902, 1903, 14174, 14495, 1925, 14512, 14510
6376, 1851, 14167, 14175, 1852, 14497, 14513, 14514, 1874
6377, 14167, 14168, 14176, 14175, 14499, 14515, 14516, 14513
6378, 14168, 14169, 14177, 14176, 14501, 14517, 14518, 14515
6379, 14169, 14170, 14178, 14177, 14503, 14519, 14520, 14517
6380, 14170, 14171, 14179, 14178, 14505, 14521, 14522, 14519
6381, 14171, 14172, 14180, 14179, 14507, 14523, 14524, 14521
6382, 14172, 14173, 14181, 14180, 14509, 14525, 14526, 14523
6383, 14173, 14174, 14182, 14181, 14511, 14527, 14528, 14525
6384, 14174, 1903, 1904, 14182, 14512, 1926, 14529, 14527
6385, 1852, 14175, 14183, 1853, 14514, 14530, 14531, 1875
6386, 14175, 14176, 14184, 14183, 14516, 14532, 14533, 14530
6387, 14176, 14177, 14185, 14184, 14518, 14534, 14535, 14532
6388, 14177, 14178, 14186, 14185, 14520, 14536, 14537, 14534
6389, 14178, 14179, 14187, 14186, 14522, 14538, 14539, 14536
6390, 14179, 14180, 14188, 14187, 14524, 14540, 14541, 14538
6391, 14180, 14181, 14189, 14188, 14526, 14542, 14543, 14540
6392, 14181, 14182, 14190, 14189, 14528, 14544, 14545, 14542
6393, 14182, 1904, 1905, 14190, 14529, 1927, 14546, 14544
6394, 1853, 14183, 14191, 1854, 14531, 14547, 14548, 1876
6395, 14183, 14184, 14192, 14191, 14533, 14549, 14550, 14547
6396, 14184, 14185, 14193, 14192, 14535, 14551, 14552, 14549
6397, 14185, 14186, 14194, 14193, 14537, 14553, 14554, 14551
6398, 14186, 14187, 14195, 14194, 14539, 14555, 14556, 14553
6399, 14187, 14188, 14196, 14195, 14541, 14557, 14558, 14555
6400, 14188, 14189, 14197, 14196, 14543, 14559, 14560, 14557
6401, 14189, 14190, 14198, 14197, 14545, 14561, 14562, 14559
6402, 14190, 1905, 1906, 14198, 14546, 1928, 14563, 14561
6403, 1854, 14191, 14199, 1855, 14548, 14564, 14565, 1877
6404, 14191, 14192, 14200, 14199, 14550, 14566, 14567, 14564
6405, 14192, 14193, 14201, 14200, 14552, 14568, 14569, 14566
6406, 14193, 14194, 14202, 14201, 14554, 14570, 14571, 14568
6407, 14194, 14195, 14203, 14202, 14556, 14572, 14573, 14570
6408, 14195, 14196, 14204, 14203, 14558, 14574, 14575, 14572
6409, 14196, 14197, 14205, 14204, 14560, 14576, 14577, 14574
6410, 14197, 14198, 14206, 14205, 14562, 14578, 14579, 14576
6411, 14198, 1906, 1907, 14206, 14563, 1929, 14580, 14578
6412, 1855, 14199, 1793, 59, 14565, 14581, 1801, 1878
6413, 14199, 14200, 1794, 1793, 14567, 14582, 1802, 14581
6414, 14200, 14201, 1795, 1794, 14569, 14583, 1803, 14582
6415, 14201, 14202, 1796, 1795, 14571, 14584, 1804, 14583
6416, 14202, 14203, 1797, 1796, 14573, 14585, 1805, 14584
6417, 14203, 14204, 1798, 1797, 14575, 14586, 1806, 14585
6418, 14204, 14205, 1799, 1798, 14577, 14587, 1807, 14586
6419, 14205, 14206, 1800, 1799, 14579, 14588, 1808, 14587
6420, 14206, 1907, 57, 1800, 14580, 1930, 1809, 14588
*ELEMENT, type=CPS8, ELSET=Surface226
6421, 52, 1879, 14589, 1948, 1882, 14592, 14593, 1949
6422, 1879, 1880, 14590, 14589, 1883, 14594, 14595, 14592
6423, 1880, 1881, 14591, 14590, 1884, 14596, 14597, 14594
6424, 1881, 62, 1951, 14591, 1885, 1952, 14598, 14596
6425, 1948, 14589, 1954, 63, 14593, 14599, 1957, 1950
6426, 14589, 14590, 1955, 1954, 14595, 14600, 1958, 14599
6427, 14590, 14591, 1956, 1955, 14597, 14601, 1959, 14600
6428, 14591, 1951, 64, 1956, 14598, 1953, 1960, 14601
*ELEMENT, type=CPS8, ELSET=Surface227
6429, 48, 1961, 14602, 1827, 1962, 14605, 14606, 1830
6430, 1827, 14602, 14603, 1828, 14606, 14607, 14608, 1831
6431, 1828, 14603, 14604, 1829, 14608, 14609, 14610, 1832
6432, 1829, 14604, 1964, 61, 14610, 14611, 1965, 1833
6433, 1961, 65, 1967, 14602, 1963, 1970, 14612, 14605
6434, 14602, 1967, 1968, 14603, 14612, 1971, 14613, 14607
6435, 14603, 1968, 1969, 14604, 14613, 1972, 14614, 14609
6436, 14604, 1969, 66, 1964, 14614, 1973, 1966, 14611
*ELEMENT, type=CPS8, ELSET=Surface228
6437, 52, 1948, 14615, 1669, 1949, 14623, 14624, 1678
6438, 1669, 14615, 14616, 1668, 14624, 14625, 14626, 1677
6439, 1668, 14616, 14617, 1667, 14626, 14627, 14628, 1676
6440, 1667, 14617, 14618, 1666, 14628, 14629, 14630, 1675
6441, 1666, 14618, 14619, 1665, 14630, 14631, 14632, 1674
6442, 1665, 14619, 14620, 1664, 14632, 14633, 14634, 1673
6443, 1664, 14620, 14621, 1663, 14634, 14635, 14636, 1672
6444, 1663, 14621, 14622, 1662, 14636, 14637, 14638, 1671
6445, 1662, 14622, 1961, 48, 14638, 14639, 1962, 1670
6446, 1948, 63, 1981, 14615, 1950, 1990, 14640, 14623
6447, 14615, 1981, 1980, 14616, 14640, 1989, 14641, 14625
6448, 14616, 1980, 1979, 14617, 14641, 1988, 14642, 14627
6449, 14617, 1979, 1978, 14618, 14642, 1987, 14643, 14629
6450, 14618, 1978, 1977, 14619, 14643, 1986, 14644, 14631
6451, 14619, 1977, 1976, 14620, 14644, 1985, 14645, 14633
6452, 14620, 1976, 1975, 14621, 14645, 1984, 14646, 14635
6453, 14621, 1975, 1974, 14622, 14646, 1983, 14647, 14637
6454, 14622, 1974, 65, 1961, 14647, 1982, 1963, 14639
*ELEMENT, type=CPS8, ELSET=Surface229
6455, 62, 1938, 14648, 1951, 1947, 14656, 14657, 1952
6456, 1938, 1937, 14649, 14648, 1946, 14658, 14659, 14656
6457, 1937, 1936, 14650, 14649, 1945, 14660, 14661, 14658
6458, 1936, 1935, 14651, 14650, 1944, 14662, 14663, 14660
6459, 1935, 1934, 14652, 14651, 1943, 14664, 14665, 14662
6460, 1934, 1933, 14653, 14652, 1942, 14666, 14667, 14664
6461, 1933, 1932, 14654, 14653, 1941, 14668, 14669, 14666
6462, 1932, 1931, 14655, 14654, 1940, 14670, 14671, 14668
6463, 1931, 61, 1964, 14655, 1939, 1965, 14672, 14670
6464, 1951, 14648, 1998, 64, 14657, 14673, 2007, 1953
6465, 14648, 14649, 1997, 1998, 14659, 14674, 2006, 14673
6466, 14649, 14650, 1996, 1997, 14661, 14675, 2005, 14674
6467, 14650, 14651, 1995, 1996, 14663, 14676, 2004, 14675
6468, 14651, 14652, 1994, 1995, 14665, 14677, 2003, 14676
6469, 14652, 14653, 1993, 1994, 14667, 14678, 2002, 14677
6470, 14653, 14654, 1992, 1993, 14669, 14679, 2001, 14678
6471, 14654, 14655, 1991, 1992, 14671, 14680, 2000, 14679
6472, 14655, 1964, 66, 1991, 14672, 1966, 1999, 14680
*ELEMENT, type=CPS8, ELSET=Surface230
6473, 63, 1954, 14681, 1981, 1957, 14705, 14706, 1990
6474, 1981, 14681, 14682, 1980, 14706, 14707, 14708, 1989
6475, 1980, 14682, 14683, 1979, 14708, 14709, 14710, 1988
6476, 1979, 14683, 14684, 1978, 14710, 14711, 14712, 1987
6477, 1978, 14684, 14685, 1977, 14712, 14713, 14714, 1986
6478, 1977, 14685, 14686, 1976, 14714, 14715, 14716, 1985
6479, 1976, 14686, 14687, 1975, 14716, 14717, 14718, 1984
6480, 1975, 14687, 14688, 1974, 14718, 14719, 14720, 1983
6481, 1974, 14688, 1967, 65, 14720, 14721, 1970, 1982
6482, 1954, 1955, 14689, 14681, 1958, 14722, 14723, 14705
6483, 14681, 14689, 14690, 14682, 14723, 14724, 14725, 14707
6484, 14682, 14690, 14691, 14683, 14725, 14726, 14727, 14709
6485, 14683, 14691, 14692, 14684, 14727, 14728, 14729, 14711
6486, 14684, 14692, 14693, 14685, 14729, 14730, 14731, 14713
6487, 14685, 14693, 14694, 14686, 14731, 14732, 14733, 14715
6488, 14686, 14694, 14695, 14687, 14733, 14734, 14735, 14717
6489, 14687, 14695, 14696, 14688, 14735, 14736, 14737, 14719
6490, 14688, 14696, 1968, 1967, 14737, 14738, 1971, 14721
6491, 1955, 1956, 14697, 14689, 1959, 14739, 14740, 14722
6492, 14689, 14697, 14698, 14690, 14740, 14741, 14742, 14724
6493, 14690, 14698, 14699, 14691, 14742, 14743, 14744, 14726
6494, 14691, 14699, 14700, 14692, 14744, 14745, 14746, 14728
6495, 14692, 14700, 14701, 14693, 14746, 14747, 14748, 14730
6496, 14693, 14701, 14702, 14694, 14748, 14749, 14750, 14732
6497, 14694, 14702, 14703, 14695, 14750, 14751, 14752, 14734
6498, 14695, 14703, 14704, 14696, 14752, 14753, 14754, 14736
6499, 14696, 14704, 1969, 1968, 14754, 14755, 1972, 14738
6500, 1956, 64, 1998, 14697, 1960, 2007, 14756, 14739
6501, 14697, 1998, 1997, 14698, 14756, 2006, 14757, 14741
6502, 14698, 1997, 1996, 14699, 14757, 2005, 14758, 14743
6503, 14699, 1996, 1995, 14700, 14758, 2004, 14759, 14745
6504, 14700, 1995, 1994, 14701, 14759, 2003, 14760, 14747
6505, 14701, 1994, 1993, 14702, 14760, 2002, 14761, 14749
6506, 14702, 1993, 1992, 14703, 14761, 2001, 14762, 14751
6507, 14703, 1992, 1991, 14704, 14762, 2000, 14763, 14753
6508, 14704, 1991, 66, 1969, 14763, 1999, 1973, 14755
*ELEMENT, type=CPS8, ELSET=Surface231
6509, 67, 2035, 14764, 2008, 2058, 14786, 14787, 2009
6510, 2035, 2034, 14765, 14764, 2057, 14788, 14789, 14786
6511, 2034, 2033, 14766, 14765, 2056, 14790, 14791, 14788
6512, 2033, 2032, 14767, 14766, 2055, 14792, 14793, 14790
6513, 2032, 2031, 14768, 14767, 2054, 14794, 14795, 14792
6514, 2031, 2030, 14769, 14768, 2053, 14796, 14797, 14794
6515, 2030, 2029, 14770, 14769, 2052, 14798, 14799, 14796
6516, 2029, 2028, 14771, 14770, 2051, 14800, 14801, 14798
6517, 2028, 2027, 14772, 14771, 2050, 14802, 14803, 14800
6518, 2027, 2026, 14773, 14772, 2049, 14804, 14805, 14802
6519, 2026, 2025, 14774, 14773, 2048, 14806, 14807, 14804
6520, 2025, 2024, 14775, 14774, 2047, 14808, 14809, 14806
6521, 2024, 2023, 14776, 14775, 2046, 14810, 14811, 14808
6522, 2023, 2022, 14777, 14776, 2045, 14812, 14813, 14810
6523, 2022, 2021, 14778, 14777, 2044, 14814, 14815, 14812
6524, 2021, 2020, 14779, 14778, 2043, 14816, 14817, 14814
6525, 2020, 2019, 14780, 14779, 2042, 14818, 14819, 14816
6526, 2019, 2018, 14781, 14780, 2041, 14820, 14821, 14818
6527, 2018, 2017, 14782, 14781, 2040, 14822, 14823, 14820
6528, 2017, 2016, 14783, 14782, 2039, 14824, 14825, 14822
6529, 2016, 2015, 14784, 14783, 2038, 14826, 14827, 14824
6530, 2015, 2014, 14785, 14784, 2037, 14828, 14829, 14826
6531, 2014, 68, 2011, 14785, 2036, 2012, 14830, 14828
6532, 2008, 14764, 1442, 45, 14787, 14831, 1465, 2010
6533, 14764, 14765, 1441, 1442, 14789, 14832, 1464, 14831
6534, 14765, 14766, 1440, 1441, 14791, 14833, 1463, 14832
6535, 14766, 14767, 1439, 1440, 14793, 14834, 1462, 14833
6536, 14767, 14768, 1438, 1439, 14795, 14835, 1461, 14834
6537, 14768, 14769, 1437, 1438, 14797, 14836, 1460, 14835
6538, 14769, 14770, 1436, 1437, 14799, 14837, 1459, 14836
6539, 14770, 14771, 1435, 1436, 14801, 14838, 1458, 14837
6540, 14771, 14772, 1434, 1435, 14803, 14839, 1457, 14838
6541, 14772, 14773, 1433, 1434, 14805, 14840, 1456, 14839
6542, 14773, 14774, 1432, 1433, 14807, 14841, 1455, 14840
6543, 14774, 14775, 1431, 1432, 14809, 14842, 1454, 14841
6544, 14775, 14776, 1430, 1431, 14811, 14843, 1453, 14842
6545, 14776, 14777, 1429, 1430, 14813, 14844, 1452, 14843
6546, 14777, 14778, 1428, 1429, 14815, 14845, 1451, 14844
6547, 14778, 14779, 1427, 1428, 14817, 14846, 1450, 14845
6548, 14779, 14780, 1426, 1427, 14819, 14847, 1449, 14846
6549, 14780, 14781, 1425, 1426, 14821, 14848, 1448, 14847
6550, 14781, 14782, 1424, 1425, 14823, 14849, 1447, 14848
6551, 14782, 14783, 1423, 1424, 14825, 14850, 1446, 14849
6552, 14783, 14784, 1422, 1423, 14827, 14851, 1445, 14850
6553, 14784, 14785, 1421, 1422, 14829, 14852, 1444, 14851
6554, 14785, 2011, 47, 1421, 14830, 2013, 1443, 14852
*ELEMENT, type=CPS8, ELSET=Surface232
6555, 69, 2069, 14853, 2059, 2078, 14861, 14862, 2060
6556, 2069, 2068, 14854, 14853, 2077, 14863, 14864, 14861
6557, 2068, 2067, 14855, 14854, 2076, 14865, 14866, 14863
6558, 2067, 2066, 14856, 14855, 2075, 14867, 14868, 14865
6559, 2066, 2065, 14857, 14856, 2074, 14869, 14870, 14867
6560, 2065, 2064, 14858, 14857, 2073, 14871, 14872, 14869
6561, 2064, 2063, 14859, 14858, 2072, 14873, 14874, 14871
6562, 2063, 2062, 14860, 14859, 2071, 14875, 14876, 14873
6563, 2062, 67, 2008, 14860, 2070, 2009, 14877, 14875
6564, 2059, 14853, 1523, 49, 14862, 14878, 1532, 2061
6565, 14853, 14854, 1522, 1523, 14864, 14879, 1531, 14878
6566, 14854, 14855, 1521, 1522, 14866, 14880, 1530, 14879
6567, 14855, 14856, 1520, 1521, 14868, 14881, 1529, 14880
6568, 14856, 14857, 1519, 1520, 14870, 14882, 1528, 14881
6569, 14857, 14858, 1518, 1519, 14872, 14883, 1527, 14882
6570, 14858, 14859, 1517, 1518, 14874, 14884, 1526, 14883
6571, 14859, 14860, 1516, 1517, 14876, 14885, 1525, 14884
6572, 14860, 2008, 45, 1516, 14877, 2010, 1524, 14885
*ELEMENT, type=CPS8, ELSET=Surface233
6573, 69, 2059, 14886, 2103, 2060, 14908, 14909, 2126
6574, 2103, 14886, 14887, 2102, 14909, 14910, 14911, 2125
6575, 2102, 14887, 14888, 2101, 14911, 14912, 14913, 2124
6576, 2101, 14888, 14889, 2100, 14913, 14914, 14915, 2123
6577, 2100, 14889, 14890, 2099, 14915, 14916, 14917, 2122
6578, 2099, 14890, 14891, 2098, 14917, 14918, 14919, 2121
6579, 2098, 14891, 14892, 2097, 14919, 14920, 14921, 2120
6580, 2097, 14892, 14893, 2096, 14921, 14922, 14923, 2119
6581, 2096, 14893, 14894, 2095, 14923, 14924, 14925, 2118
6582, 2095, 14894, 14895, 2094, 14925, 14926, 14927, 2117
6583, 2094, 14895, 14896, 2093, 14927, 14928, 14929, 2116
6584, 2093, 14896, 14897, 2092, 14929, 14930, 14931, 2115
6585, 2092, 14897, 14898, 2091, 14931, 14932, 14933, 2114
6586, 2091, 14898, 14899, 2090, 14933, 14934, 14935, 2113
6587, 2090, 14899, 14900, 2089, 14935, 14936, 14937, 2112
6588, 2089, 14900, 14901, 2088, 14937, 14938, 14939, 2111
6589, 2088, 14901, 14902, 2087, 14939, 14940, 14941, 2110
6590, 2087, 14902, 14903, 2086, 14941, 14942, 14943, 2109
6591, 2086, 14903, 14904, 2085, 14943, 14944, 14945, 2108
6592, 2085, 14904, 14905, 2084, 14945, 14946, 14947, 2107
6593, 2084, 14905, 14906, 2083, 14947, 14948, 14949, 2106
6594, 2083, 14906, 14907, 2082, 14949, 14950, 14951, 2105
6595, 2082, 14907, 2079, 70, 14951, 14952, 2080, 2104
6596, 2059, 49, 1576, 14886, 2061, 1599, 14953, 14908
6597, 14886, 1576, 1575, 14887, 14953, 1598, 14954, 14910
6598, 14887, 1575, 1574, 14888, 14954, 1597, 14955, 14912
6599, 14888, 1574, 1573, 14889, 14955, 1596, 14956, 14914
6600, 14889, 1573, 1572, 14890, 14956, 1595, 14957, 14916
6601, 14890, 1572, 1571, 14891, 14957, 1594, 14958, 14918
6602, 14891, 1571, 1570, 14892, 14958, 1593, 14959, 14920
6603, 14892, 1570, 1569, 14893, 14959, 1592, 14960, 14922
6604, 14893, 1569, 1568, 14894, 14960, 1591, 14961, 14924
6605, 14894, 1568, 1567, 14895, 14961, 1590, 14962, 14926
6606, 14895, 1567, 1566, 14896, 14962, 1589, 14963, 14928
6607, 14896, 1566, 1565, 14897, 14963, 1588, 14964, 14930
6608, 14897, 1565, 1564, 14898, 14964, 1587, 14965, 14932
6609, 14898, 1564, 1563, 14899, 14965, 1586, 14966, 14934
6610, 14899, 1563, 1562, 14900, 14966, 1585, 14967, 14936
6611, 14900, 1562, 1561, 14901, 14967, 1584, 14968, 14938
6612, 14901, 1561, 1560, 14902, 14968, 1583, 14969, 14940
6613, 14902, 1560, 1559, 14903, 14969, 1582, 14970, 14942
6614, 14903, 1559, 1558, 14904, 14970, 1581, 14971, 14944
6615, 14904, 1558, 1557, 14905, 14971, 1580, 14972, 14946
6616, 14905, 1557, 1556, 14906, 14972, 1579, 14973, 14948
6617, 14906, 1556, 1555, 14907, 14973, 1578, 14974, 14950
6618, 14907, 1555, 51, 2079, 14974, 1577, 2081, 14952
*ELEMENT, type=CPS8, ELSET=Surface234
6619, 70, 2079, 14975, 2134, 2080, 14983, 14984, 2143
6620, 2134, 14975, 14976, 2133, 14984, 14985, 14986, 2142
6621, 2133, 14976, 14977, 2132, 14986, 14987, 14988, 2141
6622, 2132, 14977, 14978, 2131, 14988, 14989, 14990, 2140
6623, 2131, 14978, 14979, 2130, 14990, 14991, 14992, 2139
6624, 2130, 14979, 14980, 2129, 14992, 14993, 14994, 2138
6625, 2129, 14980, 14981, 2128, 14994, 14995, 14996, 2137
6626, 2128, 14981, 14982, 2127, 14996, 14997, 14998, 2136
6627, 2127, 14982, 2011, 68, 14998, 14999, 2012, 2135
6628, 2079, 51, 1652, 14975, 2081, 1661, 15000, 14983
6629, 14975, 1652, 1651, 14976, 15000, 1660, 15001, 14985
6630, 14976, 1651, 1650, 14977, 15001, 1659, 15002, 14987
6631, 14977, 1650, 1649, 14978, 15002, 1658, 15003, 14989
6632, 14978, 1649, 1648, 14979, 15003, 1657, 15004, 14991
6633, 14979, 1648, 1647, 14980, 15004, 1656, 15005, 14993
6634, 14980, 1647, 1646, 14981, 15005, 1655, 15006, 14995
6635, 14981, 1646, 1645, 14982, 15006, 1654, 15007, 14997
6636, 14982, 1645, 47, 2011, 15007, 1653, 2013, 14999
*ELEMENT, type=CPS8, ELSET=Surface235
6637, 68, 2014, 15008, 2127, 2036, 15184, 15185, 2135
6638, 2127, 15008, 15009, 2128, 15185, 15186, 15187, 2136
6639, 2128, 15009, 15010, 2129, 15187, 15188, 15189, 2137
6640, 2129, 15010, 15011, 2130, 15189, 15190, 15191, 2138
6641, 2130, 15011, 15012, 2131, 15191, 15192, 15193, 2139
6642, 2131, 15012, 15013, 2132, 15193, 15194, 15195, 2140
6643, 2132, 15013, 15014, 2133, 15195, 15196, 15197, 2141
6644, 2133, 15014, 15015, 2134, 15197, 15198, 15199, 2142
6645, 2134, 15015, 2082, 70, 15199, 15200, 2104, 2143
6646, 2014, 2015, 15016, 15008, 2037, 15201, 15202, 15184
6647, 15008, 15016, 15017, 15009, 15202, 15203, 15204, 15186
6648, 15009, 15017, 15018, 15010, 15204, 15205, 15206, 15188
6649, 15010, 15018, 15019, 15011, 15206, 15207, 15208, 15190
6650, 15011, 15019, 15020, 15012, 15208, 15209, 15210, 15192
6651, 15012, 15020, 15021, 15013, 15210, 15211, 15212, 15194
6652, 15013, 15021, 15022, 15014, 15212, 15213, 15214, 15196
6653, 15014, 15022, 15023, 15015, 15214, 15215, 15216, 15198
6654, 15015, 15023, 2083, 2082, 15216, 15217, 2105, 15200
6655, 2015, 2016, 15024, 15016, 2038, 15218, 15219, 15201
6656, 15016, 15024, 15025, 15017, 15219, 15220, 15221, 15203
6657, 15017, 15025, 15026, 15018, 15221, 15222, 15223, 15205
6658, 15018, 15026, 15027, 15019, 15223, 15224, 15225, 15207
6659, 15019, 15027, 15028, 15020, 15225, 15226, 15227, 15209
6660, 15020, 15028, 15029, 15021, 15227, 15228, 15229, 15211
6661, 15021, 15029, 15030, 15022, 15229, 15230, 15231, 15213
6662, 15022, 15030, 15031, 15023, 15231, 15232, 15233, 15215
6663, 15023, 15031, 2084, 2083, 15233, 15234, 2106, 15217
6664, 2016, 2017, 15032, 15024, 2039, 15235, 15236, 15218
6665, 15024, 15032, 15033, 15025, 15236, 15237, 15238, 15220
6666, 15025, 15033, 15034, 15026, 15238, 15239, 15240, 15222
6667, 15026, 15034, 15035, 15027, 15240, 15241, 15242, 15224
6668, 15027, 15035, 15036, 15028, 15242, 15243, 15244, 15226
6669, 15028, 15036, 15037, 15029, 15244, 15245, 15246, 15228
6670, 15029, 15037, 15038, 15030, 15246, 15247, 15248, 15230
6671, 15030, 15038, 15039, 15031, 15248, 15249, 15250, 15232
6672, 15031, 15039, 2085, 2084, 15250, 15251, 2107, 15234
6673, 2017, 2018, 15040, 15032, 2040, 15252, 15253, 15235
6674, 15032, 15040, 15041, 15033, 15253, 15254, 15255, 15237
6675, 15033, 15041, 15042, 15034, 15255, 15256, 15257, 15239
6676, 15034, 15042, 15043, 15035, 15257, 15258, 15259, 15241
6677, 15035, 15043, 15044, 15036, 15259, 15260, 15261, 15243
6678, 15036, 15044, 15045, 15037, 15261, 15262, 15263, 15245
6679, 15037, 15045, 15046, 15038, 15263, 15264, 15265, 15247
6680, 15038, 15046, 15047, 15039, 15265, 15266, 15267, 15249
6681, 15039, 15047, 2086, 2085, 15267, 15268, 2108, 15251
6682, 2018, 2019, 15048, 15040, 2041, 15269, 15270, 15252
6683, 15040, 15048, 15049, 15041, 15270, 15271, 15272, 15254
6684, 15041, 15049, 15050, 15042, 15272, 15273, 15274, 15256
6685, 15042, 15050, 15051, 15043, 15274, 15275, 15276, 15258
6686, 15043, 15051, 15052, 15044, 15276, 15277, 15278, 15260
6687, 15044, 15052, 15053, 15045, 15278, 15279, 15280, 15262
6688, 15045, 15053, 15054, 15046, 15280, 15281, 15282, 15264
6689, 15046, 15054, 15055, 15047, 15282, 15283, 15284, 15266
6690, 15047, 15055, 2087, 2086, 15284, 15285, 2109, 15268
6691, 2019, 2020, 15056, 15048, 2042, 15286, 15287, 15269
6692, 15048, 15056, 15057, 15049, 15287, 15288, 15289, 15271
6693, 15049, 15057, 15058, 15050, 15289, 15290, 15291, 15273
6694, 15050, 15058, 15059, 15051, 15291, 15292, 15293, 15275
6695, 15051, 15059, 15060, 15052, 15293, 15294, 15295, 15277
6696, 15052, 15060, 15061, 15053, 15295, 15296, 15297, 15279
6697, 15053, 15061, 15062, 15054, 15297, 15298, 15299, 15281
6698, 15054, 15062, 15063, 15055, 15299, 15300, 15301, 15283
6699, 15055, 15063, 2088, 2087, 15301, 15302, 2110, 15285
6700, 2020, 2021, 15064, 15056, 2043, 15303, 15304, 15286
6701, 15056, 15064, 15065, 15057, 15304, 15305, 15306, 15288
6702, 15057, 15065, 15066, 15058, 15306, 15307, 15308, 15290
6703, 15058, 15066, 15067, 15059, 15308, 15309, 15310, 15292
6704, 15059, 15067, 15068, 15060, 15310, 15311, 15312, 15294
6705, 15060, 15068, 15069, 15061, 15312, 15313, 15314, 15296
6706, 15061, 15069, 15070, 15062, 15314, 15315, 15316, 15298
6707, 15062, 15070, 15071, 15063, 15316, 15317, 15318, 15300
6708, 15063, 15071, 2089, 2088, 15318, 15319, 2111, 15302
6709, 2021, 2022, 15072, 15064, 2044, 15320, 15321, 15303
6710, 15064, 15072, 15073, 15065, 15321, 15322, 15323, 15305
6711, 15065, 15073, 15074, 15066, 15323, 15324, 15325, 15307
6712, 15066, 15074, 15075, 15067, 15325, 15326, 15327, 15309
6713, 15067, 15075, 15076, 15068, 15327, 15328, 15329, 15311
6714, 15068, 15076, 15077, 15069, 15329, 15330, 15331, 15313
6715, 15069, 15077, 15078, 15070, 15331, 15332, 15333, 15315
6716, 15070, 15078, 15079, 15071, 15333, 15334, 15335, 15317
6717, 15071, 15079, 2090, 2089, 15335, 15336, 2112, 15319
6718, 2022, 2023, 15080, 15072, 2045, 15337, 15338, 15320
6719, 15072, 15080, 15081, 15073, 15338, 15339, 15340, 15322
6720, 15073, 15081, 15082, 15074, 15340, 15341, 15342, 15324
6721, 15074, 15082, 15083, 15075, 15342, 15343, 15344, 15326
6722, 15075, 15083, 15084, 15076, 15344, 15345, 15346, 15328
6723, 15076, 15084, 15085, 15077, 15346, 15347, 15348, 15330
6724, 15077, 15085, 15086, 15078, 15348, 15349, 15350, 15332
6725, 15078, 15086, 15087, 15079, 15350, 15351, 15352, 15334
6726, 15079, 15087, 2091, 2090, 15352, 15353, 2113, 15336
6727, 2023, 2024, 15088, 15080, 2046, 15354, 15355, 15337
6728, 15080, 15088, 15089, 15081, 15355, 15356, 15357, 15339
6729, 15081, 15089, 15090, 15082, 15357, 15358, 15359, 15341
6730, 15082, 15090, 15091, 15083, 15359, 15360, 15361, 15343
6731, 15083, 15091, 15092, 15084, 15361, 15362, 15363, 15345
6732, 15084, 15092, 15093, 15085, 15363, 15364, 15365, 15347
6733, 15085, 15093, 15094, 15086, 15365, 15366, 15367, 15349
6734, 15086, 15094, 15095, 15087, 15367, 15368, 15369, 15351
6735, 15087, 15095, 2092, 2091, 15369, 15370, 2114, 15353
6736, 2024, 2025, 15096, 15088, 2047, 15371, 15372, 15354
6737, 15088, 15096, 15097, 15089, 15372, 15373, 15374, 15356
6738, 15089, 15097, 15098, 15090, 15374, 15375, 15376, 15358
6739, 15090, 15098, 15099, 15091, 15376, 15377, 15378, 15360
6740, 15091, 15099, 15100, 15092, 15378, 15379, 15380, 15362
6741, 15092, 15100, 15101, 15093, 15380, 15381, 15382, 15364
6742, 15093, 15101, 15102, 15094, 15382, 15383, 15384, 15366
6743, 15094, 15102, 15103, 15095, 15384, 15385, 15386, 15368
6744, 15095, 15103, 2093, 2092, 15386, 15387, 2115, 15370
6745, 2025, 2026, 15104, 15096, 2048, 15388, 15389, 15371
6746, 15096, 15104, 15105, 15097, 15389, 15390, 15391, 15373
6747, 15097, 15105, 15106, 15098, 15391, 15392, 15393, 15375
6748, 15098, 15106, 15107, 15099, 15393, 15394, 15395, 15377
6749, 15099, 15107, 15108, 15100, 15395, 15396, 15397, 15379
6750, 15100, 15108, 15109, 15101, 15397, 15398, 15399, 15381
6751, 15101, 15109, 15110, 15102, 15399, 15400, 15401, 15383
6752, 15102, 15110, 15111, 15103, 15401, 15402, 15403, 15385
6753, 15103, 15111, 2094, 2093, 15403, 15404, 2116, 15387
6754, 2026, 2027, 15112, 15104, 2049, 15405, 15406, 15388
6755, 15104, 15112, 15113, 15105, 15406, 15407, 15408, 15390
6756, 15105, 15113, 15114, 15106, 15408, 15409, 15410, 15392
6757, 15106, 15114, 15115, 15107, 15410, 15411, 15412, 15394
6758, 15107, 15115, 15116, 15108, 15412, 15413, 15414, 15396
6759, 15108, 15116, 15117, 15109, 15414, 15415, 15416, 15398
6760, 15109, 15117, 15118, 15110, 15416, 15417, 15418, 15400
6761, 15110, 15118, 15119, 15111, 15418, 15419, 15420, 15402
6762, 15111, 15119, 2095, 2094, 15420, 15421, 2117, 15404
6763, 2027, 2028, 15120, 15112, 2050, 15422, 15423, 15405
6764, 15112, 15120, 15121, 15113, 15423, 15424, 15425, 15407
6765, 15113, 15121, 15122, 15114, 15425, 15426, 15427, 15409
6766, 15114, 15122, 15123, 15115, 15427, 15428, 15429, 15411
6767, 15115, 15123, 15124, 15116, 15429, 15430, 15431, 15413
6768, 15116, 15124, 15125, 15117, 15431, 15432, 15433, 15415
6769, 15117, 15125, 15126, 15118, 15433, 15434, 15435, 15417
6770, 15118, 15126, 15127, 15119, 15435, 15436, 15437, 15419
6771, 15119, 15127, 2096, 2095, 15437, 15438, 2118, 15421
6772, 2028, 2029, 15128, 15120, 2051, 15439, 15440, 15422
6773, 15120, 15128, 15129, 15121, 15440, 15441, 15442, 15424
6774, 15121, 15129, 15130, 15122, 15442, 15443, 15444, 15426
6775, 15122, 15130, 15131, 15123, 15444, 15445, 15446, 15428
6776, 15123, 15131, 15132, 15124, 15446, 15447, 15448, 15430
6777, 15124, 15132, 15133, 15125, 15448, 15449, 15450, 15432
6778, 15125, 15133, 15134, 15126, 15450, 15451, 15452, 15434
6779, 15126, 15134, 15135, 15127, 15452, 15453, 15454, 15436
6780, 15127, 15135, 2097, 2096, 15454, 15455, 2119, 15438
6781, 2029, 2030, 15136, 15128, 2052, 15456, 15457, 15439
6782, 15128, 15136, 15137, 15129, 15457, 15458, 15459, 15441
6783, 15129, 15137, 15138, 15130, 15459, 15460, 15461, 15443
6784, 15130, 15138, 15139, 15131, 15461, 15462, 15463, 15445
6785, 15131, 15139, 15140, 15132, 15463, 15464, 15465, 15447
6786, 15132, 15140, 15141, 15133, 15465, 15466, 15467, 15449
6787, 15133, 15141, 15142, 15134, 15467, 15468, 15469, 15451
6788, 15134, 15142, 15143, 15135, 15469, 15470, 15471, 15453
6789, 15135, 15143, 2098, 2097, 15471, 15472, 2120, 15455
6790, 2030, 2031, 15144, 15136, 2053, 15473, 15474, 15456
6791, 15136, 15144, 15145, 15137, 15474, 15475, 15476, 15458
6792, 15137, 15145, 15146, 15138, 15476, 15477, 15478, 15460
6793, 15138, 15146, 15147, 15139, 15478, 15479, 15480, 15462
6794, 15139, 15147, 15148, 15140, 15480, 15481, 15482, 15464
6795, 15140, 15148, 15149, 15141, 15482, 15483, 15484, 15466
6796, 15141, 15149, 15150, 15142, 15484, 15485, 15486, 15468
6797, 15142, 15150, 15151, 15143, 15486, 15487, 15488, 15470
6798, 15143, 15151, 2099, 2098, 15488, 15489, 2121, 15472
6799, 2031, 2032, 15152, 15144, 2054, 15490, 15491, 15473
6800, 15144, 15152, 15153, 15145, 15491, 15492, 15493, 15475
6801, 15145, 15153, 15154, 15146, 15493, 15494, 15495, 15477
6802, 15146, 15154, 15155, 15147, 15495, 15496, 15497, 15479
6803, 15147, 15155, 15156, 15148, 15497, 15498, 15499, 15481
6804, 15148, 15156, 15157, 15149, 15499, 15500, 15501, 15483
6805, 15149, 15157, 15158, 15150, 15501, 15502, 15503, 15485
6806, 15150, 15158, 15159, 15151, 15503, 15504, 15505, 15487
6807, 15151, 15159, 2100, 2099, 15505, 15506, 2122, 15489
6808, 2032, 2033, 15160, 15152, 2055, 15507, 15508, 15490
6809, 15152, 15160, 15161, 15153, 15508, 15509, 15510, 15492
6810, 15153, 15161, 15162, 15154, 15510, 15511, 15512, 15494
6811, 15154, 15162, 15163, 15155, 15512, 15513, 15514, 15496
6812, 15155, 15163, 15164, 15156, 15514, 15515, 15516, 15498
6813, 15156, 15164, 15165, 15157, 15516, 15517, 15518, 15500
6814, 15157, 15165, 15166, 15158, 15518, 15519, 15520, 15502
6815, 15158, 15166, 15167, 15159, 15520, 15521, 15522, 15504
6816, 15159, 15167, 2101, 2100, 15522, 15523, 2123, 15506
6817, 2033, 2034, 15168, 15160, 2056, 15524, 15525, 15507
6818, 15160, 15168, 15169, 15161, 15525, 15526, 15527, 15509
6819, 15161, 15169, 15170, 15162, 15527, 15528, 15529, 15511
6820, 15162, 15170, 15171, 15163, 15529, 15530, 15531, 15513
6821, 15163, 15171, 15172, 15164, 15531, 15532, 15533, 15515
6822, 15164, 15172, 15173, 15165, 15533, 15534, 15535, 15517
6823, 15165, 15173, 15174, 15166, 15535, 15536, 15537, 15519
6824, 15166, 15174, 15175, 15167, 15537, 15538, 15539, 15521
6825, 15167, 15175, 2102, 2101, 15539, 15540, 2124, 15523
6826, 2034, 2035, 15176, 15168, 2057, 15541, 15542, 15524
6827, 15168, 15176, 15177, 15169, 15542, 15543, 15544, 15526
6828, 15169, 15177, 15178, 15170, 15544, 15545, 15546, 15528
6829, 15170, 15178, 15179, 15171, 15546, 15547, 15548, 15530
6830, 15171, 15179, 15180, 15172, 15548, 15549, 15550, 15532
6831, 15172, 15180, 15181, 15173, 15550, 15551, 15552, 15534
6832, 15173, 15181, 15182, 15174, 15552, 15553, 15554, 15536
6833, 15174, 15182, 15183, 15175, 15554, 15555, 15556, 15538
6834, 15175, 15183, 2103, 2102, 15556, 15557, 2125, 15540
6835, 2035, 67, 2062, 15176, 2058, 2070, 15558, 15541
6836, 15176, 2062, 2063, 15177, 15558, 2071, 15559, 15543
6837, 15177, 2063, 2064, 15178, 15559, 2072, 15560, 15545
6838, 15178, 2064, 2065, 15179, 15560, 2073, 15561, 15547
6839, 15179, 2065, 2066, 15180, 15561, 2074, 15562, 15549
6840, 15180, 2066, 2067, 15181, 15562, 2075, 15563, 15551
6841, 15181, 2067, 2068, 15182, 15563, 2076, 15564, 15553
6842, 15182, 2068, 2069, 15183, 15564, 2077, 15565, 15555
6843, 15183, 2069, 69, 2103, 15565, 2078, 2126, 15557
*ELEMENT, type=CPS8, ELSET=Surface236
6844, 53, 2144, 15566, 2150, 2145, 15588, 15589, 2172
6845, 2150, 15566, 15567, 2151, 15589, 15590, 15591, 2173
6846, 2151, 15567, 15568, 2152, 15591, 15592, 15593, 2174
6847, 2152, 15568, 15569, 2153, 15593, 15594, 15595, 2175
6848, 2153, 15569, 15570, 2154, 15595, 15596, 15597, 2176
6849, 2154, 15570, 15571, 2155, 15597, 15598, 15599, 2177
6850, 2155, 15571, 15572, 2156, 15599, 15600, 15601, 2178
6851, 2156, 15572, 15573, 2157, 15601, 15602, 15603, 2179
6852, 2157, 15573, 15574, 2158, 15603, 15604, 15605, 2180
6853, 2158, 15574, 15575, 2159, 15605, 15606, 15607, 2181
6854, 2159, 15575, 15576, 2160, 15607, 15608, 15609, 2182
6855, 2160, 15576, 15577, 2161, 15609, 15610, 15611, 2183
6856, 2161, 15577, 15578, 2162, 15611, 15612, 15613, 2184
6857, 2162, 15578, 15579, 2163, 15613, 15614, 15615, 2185
6858, 2163, 15579, 15580, 2164, 15615, 15616, 15617, 2186
6859, 2164, 15580, 15581, 2165, 15617, 15618, 15619, 2187
6860, 2165, 15581, 15582, 2166, 15619, 15620, 15621, 2188
6861, 2166, 15582, 15583, 2167, 15621, 15622, 15623, 2189
6862, 2167, 15583, 15584, 2168, 15623, 15624, 15625, 2190
6863, 2168, 15584, 15585, 2169, 15625, 15626, 15627, 2191
