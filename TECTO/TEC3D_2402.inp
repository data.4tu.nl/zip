27839, 77335, 77327, 10596, 10604, 77336, 77328, 10597, 10605, 77843, 77819, 10863, 77844, 77846, 77822, 10865, 
77847, 77845, 77820, 10847, 10864
27840, 77336, 77328, 10597, 10605, 77337, 77329, 10598, 10606, 77846, 77822, 10865, 77847, 77849, 77825, 10867, 
77850, 77848, 77823, 10849, 10866
27841, 77337, 77329, 10598, 10606, 77338, 77330, 10599, 10607, 77849, 77825, 10867, 77850, 77852, 77828, 10869, 
77853, 77851, 77826, 10851, 10868
27842, 77338, 77330, 10599, 10607, 77339, 77331, 10600, 10608, 77852, 77828, 10869, 77853, 77855, 77831, 10871, 
77856, 77854, 77829, 10853, 10870
27843, 77339, 77331, 10600, 10608, 77340, 77332, 10601, 10609, 77855, 77831, 10871, 77856, 77858, 77834, 10873, 
77859, 77857, 77832, 10855, 10872
27844, 77340, 77332, 10601, 10609, 77341, 77333, 10602, 10610, 77858, 77834, 10873, 77859, 77861, 77837, 10875, 
77862, 77860, 77835, 10857, 10874
27845, 77341, 77333, 10602, 10610, 10268, 10267, 1247, 1248, 77861, 77837, 10875, 77862, 10322, 10319, 1270, 
10321, 77863, 77838, 10859, 10876
27846, 10113, 10112, 1193, 1194, 77342, 77334, 10603, 10611, 10167, 10166, 1216, 10168, 77865, 77841, 10878, 
77866, 77864, 77839, 10860, 10877
27847, 77342, 77334, 10603, 10611, 77343, 77335, 10604, 10612, 77865, 77841, 10878, 77866, 77868, 77844, 10880, 
77869, 77867, 77842, 10862, 10879
27848, 77343, 77335, 10604, 10612, 77344, 77336, 10605, 10613, 77868, 77844, 10880, 77869, 77871, 77847, 10882, 
77872, 77870, 77845, 10864, 10881
27849, 77344, 77336, 10605, 10613, 77345, 77337, 10606, 10614, 77871, 77847, 10882, 77872, 77874, 77850, 10884, 
77875, 77873, 77848, 10866, 10883
27850, 77345, 77337, 10606, 10614, 77346, 77338, 10607, 10615, 77874, 77850, 10884, 77875, 77877, 77853, 10886, 
77878, 77876, 77851, 10868, 10885
27851, 77346, 77338, 10607, 10615, 77347, 77339, 10608, 10616, 77877, 77853, 10886, 77878, 77880, 77856, 10888, 
77881, 77879, 77854, 10870, 10887
27852, 77347, 77339, 10608, 10616, 77348, 77340, 10609, 10617, 77880, 77856, 10888, 77881, 77883, 77859, 10890, 
77884, 77882, 77857, 10872, 10889
27853, 77348, 77340, 10609, 10617, 77349, 77341, 10610, 10618, 77883, 77859, 10890, 77884, 77886, 77862, 10892, 
77887, 77885, 77860, 10874, 10891
27854, 77349, 77341, 10610, 10618, 10269, 10268, 1248, 1249, 77886, 77862, 10892, 77887, 10324, 10321, 1271, 
10323, 77888, 77863, 10876, 10893
27855, 10114, 10113, 1194, 1195, 77350, 77342, 10611, 10619, 10169, 10168, 1217, 10170, 77890, 77866, 10895, 
77891, 77889, 77864, 10877, 10894
27856, 77350, 77342, 10611, 10619, 77351, 77343, 10612, 10620, 77890, 77866, 10895, 77891, 77893, 77869, 10897, 
77894, 77892, 77867, 10879, 10896
27857, 77351, 77343, 10612, 10620, 77352, 77344, 10613, 10621, 77893, 77869, 10897, 77894, 77896, 77872, 10899, 
77897, 77895, 77870, 10881, 10898
27858, 77352, 77344, 10613, 10621, 77353, 77345, 10614, 10622, 77896, 77872, 10899, 77897, 77899, 77875, 10901, 
77900, 77898, 77873, 10883, 10900
27859, 77353, 77345, 10614, 10622, 77354, 77346, 10615, 10623, 77899, 77875, 10901, 77900, 77902, 77878, 10903, 
77903, 77901, 77876, 10885, 10902
27860, 77354, 77346, 10615, 10623, 77355, 77347, 10616, 10624, 77902, 77878, 10903, 77903, 77905, 77881, 10905, 
77906, 77904, 77879, 10887, 10904
27861, 77355, 77347, 10616, 10624, 77356, 77348, 10617, 10625, 77905, 77881, 10905, 77906, 77908, 77884, 10907, 
77909, 77907, 77882, 10889, 10906
27862, 77356, 77348, 10617, 10625, 77357, 77349, 10618, 10626, 77908, 77884, 10907, 77909, 77911, 77887, 10909, 
77912, 77910, 77885, 10891, 10908
27863, 77357, 77349, 10618, 10626, 10270, 10269, 1249, 1250, 77911, 77887, 10909, 77912, 10326, 10323, 1272, 
10325, 77913, 77888, 10893, 10910
27864, 10115, 10114, 1195, 1196, 77358, 77350, 10619, 10627, 10171, 10170, 1218, 10172, 77915, 77891, 10912, 
77916, 77914, 77889, 10894, 10911
27865, 77358, 77350, 10619, 10627, 77359, 77351, 10620, 10628, 77915, 77891, 10912, 77916, 77918, 77894, 10914, 
77919, 77917, 77892, 10896, 10913
27866, 77359, 77351, 10620, 10628, 77360, 77352, 10621, 10629, 77918, 77894, 10914, 77919, 77921, 77897, 10916, 
77922, 77920, 77895, 10898, 10915
27867, 77360, 77352, 10621, 10629, 77361, 77353, 10622, 10630, 77921, 77897, 10916, 77922, 77924, 77900, 10918, 
77925, 77923, 77898, 10900, 10917
27868, 77361, 77353, 10622, 10630, 77362, 77354, 10623, 10631, 77924, 77900, 10918, 77925, 77927, 77903, 10920, 
77928, 77926, 77901, 10902, 10919
27869, 77362, 77354, 10623, 10631, 77363, 77355, 10624, 10632, 77927, 77903, 10920, 77928, 77930, 77906, 10922, 
77931, 77929, 77904, 10904, 10921
27870, 77363, 77355, 10624, 10632, 77364, 77356, 10625, 10633, 77930, 77906, 10922, 77931, 77933, 77909, 10924, 
77934, 77932, 77907, 10906, 10923
27871, 77364, 77356, 10625, 10633, 77365, 77357, 10626, 10634, 77933, 77909, 10924, 77934, 77936, 77912, 10926, 
77937, 77935, 77910, 10908, 10925
27872, 77365, 77357, 10626, 10634, 10271, 10270, 1250, 1251, 77936, 77912, 10926, 77937, 10328, 10325, 1273, 
10327, 77938, 77913, 10910, 10927
27873, 10116, 10115, 1196, 1197, 77366, 77358, 10627, 10635, 10173, 10172, 1219, 10174, 77940, 77916, 10929, 
77941, 77939, 77914, 10911, 10928
27874, 77366, 77358, 10627, 10635, 77367, 77359, 10628, 10636, 77940, 77916, 10929, 77941, 77943, 77919, 10931, 
77944, 77942, 77917, 10913, 10930
27875, 77367, 77359, 10628, 10636, 77368, 77360, 10629, 10637, 77943, 77919, 10931, 77944, 77946, 77922, 10933, 
77947, 77945, 77920, 10915, 10932
27876, 77368, 77360, 10629, 10637, 77369, 77361, 10630, 10638, 77946, 77922, 10933, 77947, 77949, 77925, 10935, 
77950, 77948, 77923, 10917, 10934
27877, 77369, 77361, 10630, 10638, 77370, 77362, 10631, 10639, 77949, 77925, 10935, 77950, 77952, 77928, 10937, 
77953, 77951, 77926, 10919, 10936
27878, 77370, 77362, 10631, 10639, 77371, 77363, 10632, 10640, 77952, 77928, 10937, 77953, 77955, 77931, 10939, 
77956, 77954, 77929, 10921, 10938
27879, 77371, 77363, 10632, 10640, 77372, 77364, 10633, 10641, 77955, 77931, 10939, 77956, 77958, 77934, 10941, 
77959, 77957, 77932, 10923, 10940
27880, 77372, 77364, 10633, 10641, 77373, 77365, 10634, 10642, 77958, 77934, 10941, 77959, 77961, 77937, 10943, 
77962, 77960, 77935, 10925, 10942
27881, 77373, 77365, 10634, 10642, 10272, 10271, 1251, 1252, 77961, 77937, 10943, 77962, 10330, 10327, 1274, 
10329, 77963, 77938, 10927, 10944
27882, 10117, 10116, 1197, 1198, 77374, 77366, 10635, 10643, 10175, 10174, 1220, 10176, 77965, 77941, 10946, 
77966, 77964, 77939, 10928, 10945
27883, 77374, 77366, 10635, 10643, 77375, 77367, 10636, 10644, 77965, 77941, 10946, 77966, 77968, 77944, 10948, 
77969, 77967, 77942, 10930, 10947
27884, 77375, 77367, 10636, 10644, 77376, 77368, 10637, 10645, 77968, 77944, 10948, 77969, 77971, 77947, 10950, 
77972, 77970, 77945, 10932, 10949
27885, 77376, 77368, 10637, 10645, 77377, 77369, 10638, 10646, 77971, 77947, 10950, 77972, 77974, 77950, 10952, 
77975, 77973, 77948, 10934, 10951
27886, 77377, 77369, 10638, 10646, 77378, 77370, 10639, 10647, 77974, 77950, 10952, 77975, 77977, 77953, 10954, 
77978, 77976, 77951, 10936, 10953
27887, 77378, 77370, 10639, 10647, 77379, 77371, 10640, 10648, 77977, 77953, 10954, 77978, 77980, 77956, 10956, 
77981, 77979, 77954, 10938, 10955
27888, 77379, 77371, 10640, 10648, 77380, 77372, 10641, 10649, 77980, 77956, 10956, 77981, 77983, 77959, 10958, 
77984, 77982, 77957, 10940, 10957
27889, 77380, 77372, 10641, 10649, 77381, 77373, 10642, 10650, 77983, 77959, 10958, 77984, 77986, 77962, 10960, 
77987, 77985, 77960, 10942, 10959
27890, 77381, 77373, 10642, 10650, 10273, 10272, 1252, 1253, 77986, 77962, 10960, 77987, 10332, 10329, 1275, 
10331, 77988, 77963, 10944, 10961
27891, 10118, 10117, 1198, 1199, 77382, 77374, 10643, 10651, 10177, 10176, 1221, 10178, 77990, 77966, 10963, 
77991, 77989, 77964, 10945, 10962
27892, 77382, 77374, 10643, 10651, 77383, 77375, 10644, 10652, 77990, 77966, 10963, 77991, 77993, 77969, 10965, 
77994, 77992, 77967, 10947, 10964
27893, 77383, 77375, 10644, 10652, 77384, 77376, 10645, 10653, 77993, 77969, 10965, 77994, 77996, 77972, 10967, 
77997, 77995, 77970, 10949, 10966
27894, 77384, 77376, 10645, 10653, 77385, 77377, 10646, 10654, 77996, 77972, 10967, 77997, 77999, 77975, 10969, 
78000, 77998, 77973, 10951, 10968
27895, 77385, 77377, 10646, 10654, 77386, 77378, 10647, 10655, 77999, 77975, 10969, 78000, 78002, 77978, 10971, 
78003, 78001, 77976, 10953, 10970
27896, 77386, 77378, 10647, 10655, 77387, 77379, 10648, 10656, 78002, 77978, 10971, 78003, 78005, 77981, 10973, 
78006, 78004, 77979, 10955, 10972
27897, 77387, 77379, 10648, 10656, 77388, 77380, 10649, 10657, 78005, 77981, 10973, 78006, 78008, 77984, 10975, 
78009, 78007, 77982, 10957, 10974
27898, 77388, 77380, 10649, 10657, 77389, 77381, 10650, 10658, 78008, 77984, 10975, 78009, 78011, 77987, 10977, 
78012, 78010, 77985, 10959, 10976
27899, 77389, 77381, 10650, 10658, 10274, 10273, 1253, 1254, 78011, 77987, 10977, 78012, 10334, 10331, 1276, 
10333, 78013, 77988, 10961, 10978
27900, 10119, 10118, 1199, 1200, 77390, 77382, 10651, 10659, 10179, 10178, 1222, 10180, 78015, 77991, 10980, 
78016, 78014, 77989, 10962, 10979
27901, 77390, 77382, 10651, 10659, 77391, 77383, 10652, 10660, 78015, 77991, 10980, 78016, 78018, 77994, 10982, 
78019, 78017, 77992, 10964, 10981
27902, 77391, 77383, 10652, 10660, 77392, 77384, 10653, 10661, 78018, 77994, 10982, 78019, 78021, 77997, 10984, 
78022, 78020, 77995, 10966, 10983
27903, 77392, 77384, 10653, 10661, 77393, 77385, 10654, 10662, 78021, 77997, 10984, 78022, 78024, 78000, 10986, 
78025, 78023, 77998, 10968, 10985
27904, 77393, 77385, 10654, 10662, 77394, 77386, 10655, 10663, 78024, 78000, 10986, 78025, 78027, 78003, 10988, 
78028, 78026, 78001, 10970, 10987
27905, 77394, 77386, 10655, 10663, 77395, 77387, 10656, 10664, 78027, 78003, 10988, 78028, 78030, 78006, 10990, 
78031, 78029, 78004, 10972, 10989
27906, 77395, 77387, 10656, 10664, 77396, 77388, 10657, 10665, 78030, 78006, 10990, 78031, 78033, 78009, 10992, 
78034, 78032, 78007, 10974, 10991
27907, 77396, 77388, 10657, 10665, 77397, 77389, 10658, 10666, 78033, 78009, 10992, 78034, 78036, 78012, 10994, 
78037, 78035, 78010, 10976, 10993
27908, 77397, 77389, 10658, 10666, 10275, 10274, 1254, 1255, 78036, 78012, 10994, 78037, 10336, 10333, 1277, 
10335, 78038, 78013, 10978, 10995
27909, 10120, 10119, 1200, 1201, 77398, 77390, 10659, 10667, 10181, 10180, 1223, 10182, 78040, 78016, 10997, 
78041, 78039, 78014, 10979, 10996
27910, 77398, 77390, 10659, 10667, 77399, 77391, 10660, 10668, 78040, 78016, 10997, 78041, 78043, 78019, 10999, 
78044, 78042, 78017, 10981, 10998
27911, 77399, 77391, 10660, 10668, 77400, 77392, 10661, 10669, 78043, 78019, 10999, 78044, 78046, 78022, 11001, 
78047, 78045, 78020, 10983, 11000
27912, 77400, 77392, 10661, 10669, 77401, 77393, 10662, 10670, 78046, 78022, 11001, 78047, 78049, 78025, 11003, 
78050, 78048, 78023, 10985, 11002
27913, 77401, 77393, 10662, 10670, 77402, 77394, 10663, 10671, 78049, 78025, 11003, 78050, 78052, 78028, 11005, 
78053, 78051, 78026, 10987, 11004
27914, 77402, 77394, 10663, 10671, 77403, 77395, 10664, 10672, 78052, 78028, 11005, 78053, 78055, 78031, 11007, 
78056, 78054, 78029, 10989, 11006
27915, 77403, 77395, 10664, 10672, 77404, 77396, 10665, 10673, 78055, 78031, 11007, 78056, 78058, 78034, 11009, 
78059, 78057, 78032, 10991, 11008
27916, 77404, 77396, 10665, 10673, 77405, 77397, 10666, 10674, 78058, 78034, 11009, 78059, 78061, 78037, 11011, 
78062, 78060, 78035, 10993, 11010
27917, 77405, 77397, 10666, 10674, 10276, 10275, 1255, 1256, 78061, 78037, 11011, 78062, 10338, 10335, 1278, 
10337, 78063, 78038, 10995, 11012
27918, 10121, 10120, 1201, 1202, 77406, 77398, 10667, 10675, 10183, 10182, 1224, 10184, 78065, 78041, 11014, 
78066, 78064, 78039, 10996, 11013
27919, 77406, 77398, 10667, 10675, 77407, 77399, 10668, 10676, 78065, 78041, 11014, 78066, 78068, 78044, 11016, 
78069, 78067, 78042, 10998, 11015
27920, 77407, 77399, 10668, 10676, 77408, 77400, 10669, 10677, 78068, 78044, 11016, 78069, 78071, 78047, 11018, 
78072, 78070, 78045, 11000, 11017
27921, 77408, 77400, 10669, 10677, 77409, 77401, 10670, 10678, 78071, 78047, 11018, 78072, 78074, 78050, 11020, 
78075, 78073, 78048, 11002, 11019
27922, 77409, 77401, 10670, 10678, 77410, 77402, 10671, 10679, 78074, 78050, 11020, 78075, 78077, 78053, 11022, 
78078, 78076, 78051, 11004, 11021
27923, 77410, 77402, 10671, 10679, 77411, 77403, 10672, 10680, 78077, 78053, 11022, 78078, 78080, 78056, 11024, 
78081, 78079, 78054, 11006, 11023
27924, 77411, 77403, 10672, 10680, 77412, 77404, 10673, 10681, 78080, 78056, 11024, 78081, 78083, 78059, 11026, 
78084, 78082, 78057, 11008, 11025
27925, 77412, 77404, 10673, 10681, 77413, 77405, 10674, 10682, 78083, 78059, 11026, 78084, 78086, 78062, 11028, 
78087, 78085, 78060, 11010, 11027
27926, 77413, 77405, 10674, 10682, 10277, 10276, 1256, 1257, 78086, 78062, 11028, 78087, 10340, 10337, 1279, 
10339, 78088, 78063, 11012, 11029
27927, 10122, 10121, 1202, 1203, 77414, 77406, 10675, 10683, 10185, 10184, 1225, 10186, 78090, 78066, 11031, 
78091, 78089, 78064, 11013, 11030
27928, 77414, 77406, 10675, 10683, 77415, 77407, 10676, 10684, 78090, 78066, 11031, 78091, 78093, 78069, 11033, 
78094, 78092, 78067, 11015, 11032
27929, 77415, 77407, 10676, 10684, 77416, 77408, 10677, 10685, 78093, 78069, 11033, 78094, 78096, 78072, 11035, 
78097, 78095, 78070, 11017, 11034
27930, 77416, 77408, 10677, 10685, 77417, 77409, 10678, 10686, 78096, 78072, 11035, 78097, 78099, 78075, 11037, 
78100, 78098, 78073, 11019, 11036
27931, 77417, 77409, 10678, 10686, 77418, 77410, 10679, 10687, 78099, 78075, 11037, 78100, 78102, 78078, 11039, 
78103, 78101, 78076, 11021, 11038
27932, 77418, 77410, 10679, 10687, 77419, 77411, 10680, 10688, 78102, 78078, 11039, 78103, 78105, 78081, 11041, 
78106, 78104, 78079, 11023, 11040
27933, 77419, 77411, 10680, 10688, 77420, 77412, 10681, 10689, 78105, 78081, 11041, 78106, 78108, 78084, 11043, 
78109, 78107, 78082, 11025, 11042
27934, 77420, 77412, 10681, 10689, 77421, 77413, 10682, 10690, 78108, 78084, 11043, 78109, 78111, 78087, 11045, 
78112, 78110, 78085, 11027, 11044
27935, 77421, 77413, 10682, 10690, 10278, 10277, 1257, 1258, 78111, 78087, 11045, 78112, 10342, 10339, 1280, 
10341, 78113, 78088, 11029, 11046
27936, 10123, 10122, 1203, 1204, 77422, 77414, 10683, 10691, 10187, 10186, 1226, 10188, 78115, 78091, 11048, 
78116, 78114, 78089, 11030, 11047
27937, 77422, 77414, 10683, 10691, 77423, 77415, 10684, 10692, 78115, 78091, 11048, 78116, 78118, 78094, 11050, 
78119, 78117, 78092, 11032, 11049
27938, 77423, 77415, 10684, 10692, 77424, 77416, 10685, 10693, 78118, 78094, 11050, 78119, 78121, 78097, 11052, 
78122, 78120, 78095, 11034, 11051
27939, 77424, 77416, 10685, 10693, 77425, 77417, 10686, 10694, 78121, 78097, 11052, 78122, 78124, 78100, 11054, 
78125, 78123, 78098, 11036, 11053
27940, 77425, 77417, 10686, 10694, 77426, 77418, 10687, 10695, 78124, 78100, 11054, 78125, 78127, 78103, 11056, 
78128, 78126, 78101, 11038, 11055
27941, 77426, 77418, 10687, 10695, 77427, 77419, 10688, 10696, 78127, 78103, 11056, 78128, 78130, 78106, 11058, 
78131, 78129, 78104, 11040, 11057
27942, 77427, 77419, 10688, 10696, 77428, 77420, 10689, 10697, 78130, 78106, 11058, 78131, 78133, 78109, 11060, 
78134, 78132, 78107, 11042, 11059
27943, 77428, 77420, 10689, 10697, 77429, 77421, 10690, 10698, 78133, 78109, 11060, 78134, 78136, 78112, 11062, 
78137, 78135, 78110, 11044, 11061
27944, 77429, 77421, 10690, 10698, 10279, 10278, 1258, 1259, 78136, 78112, 11062, 78137, 10344, 10341, 1281, 
10343, 78138, 78113, 11046, 11063
27945, 10124, 10123, 1204, 1205, 77430, 77422, 10691, 10699, 10189, 10188, 1227, 10190, 78140, 78116, 11065, 
78141, 78139, 78114, 11047, 11064
27946, 77430, 77422, 10691, 10699, 77431, 77423, 10692, 10700, 78140, 78116, 11065, 78141, 78143, 78119, 11067, 
78144, 78142, 78117, 11049, 11066
27947, 77431, 77423, 10692, 10700, 77432, 77424, 10693, 10701, 78143, 78119, 11067, 78144, 78146, 78122, 11069, 
78147, 78145, 78120, 11051, 11068
27948, 77432, 77424, 10693, 10701, 77433, 77425, 10694, 10702, 78146, 78122, 11069, 78147, 78149, 78125, 11071, 
78150, 78148, 78123, 11053, 11070
27949, 77433, 77425, 10694, 10702, 77434, 77426, 10695, 10703, 78149, 78125, 11071, 78150, 78152, 78128, 11073, 
78153, 78151, 78126, 11055, 11072
27950, 77434, 77426, 10695, 10703, 77435, 77427, 10696, 10704, 78152, 78128, 11073, 78153, 78155, 78131, 11075, 
78156, 78154, 78129, 11057, 11074
27951, 77435, 77427, 10696, 10704, 77436, 77428, 10697, 10705, 78155, 78131, 11075, 78156, 78158, 78134, 11077, 
78159, 78157, 78132, 11059, 11076
27952, 77436, 77428, 10697, 10705, 77437, 77429, 10698, 10706, 78158, 78134, 11077, 78159, 78161, 78137, 11079, 
78162, 78160, 78135, 11061, 11078
27953, 77437, 77429, 10698, 10706, 10280, 10279, 1259, 1260, 78161, 78137, 11079, 78162, 10346, 10343, 1282, 
10345, 78163, 78138, 11063, 11080
27954, 1179, 10124, 1205, 36, 10473, 77430, 10699, 1308, 10191, 10190, 1228, 1181, 78164, 78141, 11081, 
10490, 10489, 78139, 11064, 1317
27955, 10473, 77430, 10699, 1308, 10474, 77431, 10700, 1307, 78164, 78141, 11081, 10490, 78165, 78144, 11082, 
10492, 10491, 78142, 11066, 1316
27956, 10474, 77431, 10700, 1307, 10475, 77432, 10701, 1306, 78165, 78144, 11082, 10492, 78166, 78147, 11083, 
10494, 10493, 78145, 11068, 1315
27957, 10475, 77432, 10701, 1306, 10476, 77433, 10702, 1305, 78166, 78147, 11083, 10494, 78167, 78150, 11084, 
10496, 10495, 78148, 11070, 1314
27958, 10476, 77433, 10702, 1305, 10477, 77434, 10703, 1304, 78167, 78150, 11084, 10496, 78168, 78153, 11085, 
10498, 10497, 78151, 11072, 1313
27959, 10477, 77434, 10703, 1304, 10478, 77435, 10704, 1303, 78168, 78153, 11085, 10498, 78169, 78156, 11086, 
10500, 10499, 78154, 11074, 1312
27960, 10478, 77435, 10704, 1303, 10479, 77436, 10705, 1302, 78169, 78156, 11086, 10500, 78170, 78159, 11087, 
10502, 10501, 78157, 11076, 1311
27961, 10479, 77436, 10705, 1302, 10480, 77437, 10706, 1301, 78170, 78159, 11087, 10502, 78171, 78162, 11088, 
10504, 10503, 78160, 11078, 1310
27962, 10480, 77437, 10706, 1301, 1234, 10280, 1260, 38, 78171, 78162, 11088, 10504, 10347, 10345, 1283, 
1236, 10505, 78163, 11080, 1309
27963, 10125, 1175, 1174, 10103, 77438, 10423, 10415, 77262, 10192, 1177, 10147, 10193, 78173, 10448, 77615, 
78174, 78172, 10449, 10432, 77614
27964, 77438, 10423, 10415, 77262, 77439, 10424, 10416, 77263, 78173, 10448, 77615, 78174, 78176, 10450, 77618, 
78177, 78175, 10451, 10434, 77617
27965, 77439, 10424, 10416, 77263, 77440, 10425, 10417, 77264, 78176, 10450, 77618, 78177, 78179, 10452, 77621, 
78180, 78178, 10453, 10436, 77620
27966, 77440, 10425, 10417, 77264, 77441, 10426, 10418, 77265, 78179, 10452, 77621, 78180, 78182, 10454, 77624, 
78183, 78181, 10455, 10438, 77623
27967, 77441, 10426, 10418, 77265, 77442, 10427, 10419, 77266, 78182, 10454, 77624, 78183, 78185, 10456, 77627, 
78186, 78184, 10457, 10440, 77626
27968, 77442, 10427, 10419, 77266, 77443, 10428, 10420, 77267, 78185, 10456, 77627, 78186, 78188, 10458, 77630, 
78189, 78187, 10459, 10442, 77629
27969, 77443, 10428, 10420, 77267, 77444, 10429, 10421, 77268, 78188, 10458, 77630, 78189, 78191, 10460, 77633, 
78192, 78190, 10461, 10444, 77632
27970, 77444, 10429, 10421, 77268, 77445, 10430, 10422, 77269, 78191, 10460, 77633, 78192, 78194, 10462, 77636, 
78195, 78193, 10463, 10446, 77635
27971, 77445, 10430, 10422, 77269, 10281, 1230, 1229, 10259, 78194, 10462, 77636, 78195, 10349, 1232, 10304, 
10348, 78196, 10464, 10447, 77638
27972, 10126, 10125, 10103, 10104, 77446, 77438, 77262, 77270, 10194, 10193, 10149, 10195, 78198, 78174, 77640, 
78199, 78197, 78172, 77614, 77639
27973, 77446, 77438, 77262, 77270, 77447, 77439, 77263, 77271, 78198, 78174, 77640, 78199, 78201, 78177, 77643, 
78202, 78200, 78175, 77617, 77642
27974, 77447, 77439, 77263, 77271, 77448, 77440, 77264, 77272, 78201, 78177, 77643, 78202, 78204, 78180, 77646, 
78205, 78203, 78178, 77620, 77645
27975, 77448, 77440, 77264, 77272, 77449, 77441, 77265, 77273, 78204, 78180, 77646, 78205, 78207, 78183, 77649, 
78208, 78206, 78181, 77623, 77648
27976, 77449, 77441, 77265, 77273, 77450, 77442, 77266, 77274, 78207, 78183, 77649, 78208, 78210, 78186, 77652, 
78211, 78209, 78184, 77626, 77651
27977, 77450, 77442, 77266, 77274, 77451, 77443, 77267, 77275, 78210, 78186, 77652, 78211, 78213, 78189, 77655, 
78214, 78212, 78187, 77629, 77654
27978, 77451, 77443, 77267, 77275, 77452, 77444, 77268, 77276, 78213, 78189, 77655, 78214, 78216, 78192, 77658, 
78217, 78215, 78190, 77632, 77657
27979, 77452, 77444, 77268, 77276, 77453, 77445, 77269, 77277, 78216, 78192, 77658, 78217, 78219, 78195, 77661, 
78220, 78218, 78193, 77635, 77660
27980, 77453, 77445, 77269, 77277, 10282, 10281, 10259, 10260, 78219, 78195, 77661, 78220, 10351, 10348, 10306, 
10350, 78221, 78196, 77638, 77663
27981, 10127, 10126, 10104, 10105, 77454, 77446, 77270, 77278, 10196, 10195, 10151, 10197, 78223, 78199, 77665, 
78224, 78222, 78197, 77639, 77664
27982, 77454, 77446, 77270, 77278, 77455, 77447, 77271, 77279, 78223, 78199, 77665, 78224, 78226, 78202, 77668, 
78227, 78225, 78200, 77642, 77667
27983, 77455, 77447, 77271, 77279, 77456, 77448, 77272, 77280, 78226, 78202, 77668, 78227, 78229, 78205, 77671, 
78230, 78228, 78203, 77645, 77670
27984, 77456, 77448, 77272, 77280, 77457, 77449, 77273, 77281, 78229, 78205, 77671, 78230, 78232, 78208, 77674, 
78233, 78231, 78206, 77648, 77673
27985, 77457, 77449, 77273, 77281, 77458, 77450, 77274, 77282, 78232, 78208, 77674, 78233, 78235, 78211, 77677, 
78236, 78234, 78209, 77651, 77676
27986, 77458, 77450, 77274, 77282, 77459, 77451, 77275, 77283, 78235, 78211, 77677, 78236, 78238, 78214, 77680, 
78239, 78237, 78212, 77654, 77679
27987, 77459, 77451, 77275, 77283, 77460, 77452, 77276, 77284, 78238, 78214, 77680, 78239, 78241, 78217, 77683, 
78242, 78240, 78215, 77657, 77682
27988, 77460, 77452, 77276, 77284, 77461, 77453, 77277, 77285, 78241, 78217, 77683, 78242, 78244, 78220, 77686, 
78245, 78243, 78218, 77660, 77685
27989, 77461, 77453, 77277, 77285, 10283, 10282, 10260, 10261, 78244, 78220, 77686, 78245, 10353, 10350, 10308, 
10352, 78246, 78221, 77663, 77688
27990, 10128, 10127, 10105, 10106, 77462, 77454, 77278, 77286, 10198, 10197, 10153, 10199, 78248, 78224, 77690, 
78249, 78247, 78222, 77664, 77689
27991, 77462, 77454, 77278, 77286, 77463, 77455, 77279, 77287, 78248, 78224, 77690, 78249, 78251, 78227, 77693, 
78252, 78250, 78225, 77667, 77692
27992, 77463, 77455, 77279, 77287, 77464, 77456, 77280, 77288, 78251, 78227, 77693, 78252, 78254, 78230, 77696, 
78255, 78253, 78228, 77670, 77695
27993, 77464, 77456, 77280, 77288, 77465, 77457, 77281, 77289, 78254, 78230, 77696, 78255, 78257, 78233, 77699, 
78258, 78256, 78231, 77673, 77698
27994, 77465, 77457, 77281, 77289, 77466, 77458, 77282, 77290, 78257, 78233, 77699, 78258, 78260, 78236, 77702, 
78261, 78259, 78234, 77676, 77701
27995, 77466, 77458, 77282, 77290, 77467, 77459, 77283, 77291, 78260, 78236, 77702, 78261, 78263, 78239, 77705, 
78264, 78262, 78237, 77679, 77704
27996, 77467, 77459, 77283, 77291, 77468, 77460, 77284, 77292, 78263, 78239, 77705, 78264, 78266, 78242, 77708, 
78267, 78265, 78240, 77682, 77707
27997, 77468, 77460, 77284, 77292, 77469, 77461, 77285, 77293, 78266, 78242, 77708, 78267, 78269, 78245, 77711, 
78270, 78268, 78243, 77685, 77710
27998, 77469, 77461, 77285, 77293, 10284, 10283, 10261, 10262, 78269, 78245, 77711, 78270, 10355, 10352, 10310, 
10354, 78271, 78246, 77688, 77713
27999, 10129, 10128, 10106, 10107, 77470, 77462, 77286, 77294, 10200, 10199, 10155, 10201, 78273, 78249, 77715, 
78274, 78272, 78247, 77689, 77714
28000, 77470, 77462, 77286, 77294, 77471, 77463, 77287, 77295, 78273, 78249, 77715, 78274, 78276, 78252, 77718, 
78277, 78275, 78250, 77692, 77717
28001, 77471, 77463, 77287, 77295, 77472, 77464, 77288, 77296, 78276, 78252, 77718, 78277, 78279, 78255, 77721, 
78280, 78278, 78253, 77695, 77720
28002, 77472, 77464, 77288, 77296, 77473, 77465, 77289, 77297, 78279, 78255, 77721, 78280, 78282, 78258, 77724, 
78283, 78281, 78256, 77698, 77723
28003, 77473, 77465, 77289, 77297, 77474, 77466, 77290, 77298, 78282, 78258, 77724, 78283, 78285, 78261, 77727, 
78286, 78284, 78259, 77701, 77726
28004, 77474, 77466, 77290, 77298, 77475, 77467, 77291, 77299, 78285, 78261, 77727, 78286, 78288, 78264, 77730, 
78289, 78287, 78262, 77704, 77729
28005, 77475, 77467, 77291, 77299, 77476, 77468, 77292, 77300, 78288, 78264, 77730, 78289, 78291, 78267, 77733, 
78292, 78290, 78265, 77707, 77732
28006, 77476, 77468, 77292, 77300, 77477, 77469, 77293, 77301, 78291, 78267, 77733, 78292, 78294, 78270, 77736, 
78295, 78293, 78268, 77710, 77735
28007, 77477, 77469, 77293, 77301, 10285, 10284, 10262, 10263, 78294, 78270, 77736, 78295, 10357, 10354, 10312, 
10356, 78296, 78271, 77713, 77738
28008, 10130, 10129, 10107, 10108, 77478, 77470, 77294, 77302, 10202, 10201, 10157, 10203, 78298, 78274, 77740, 
78299, 78297, 78272, 77714, 77739
28009, 77478, 77470, 77294, 77302, 77479, 77471, 77295, 77303, 78298, 78274, 77740, 78299, 78301, 78277, 77743, 
78302, 78300, 78275, 77717, 77742
28010, 77479, 77471, 77295, 77303, 77480, 77472, 77296, 77304, 78301, 78277, 77743, 78302, 78304, 78280, 77746, 
78305, 78303, 78278, 77720, 77745
28011, 77480, 77472, 77296, 77304, 77481, 77473, 77297, 77305, 78304, 78280, 77746, 78305, 78307, 78283, 77749, 
78308, 78306, 78281, 77723, 77748
28012, 77481, 77473, 77297, 77305, 77482, 77474, 77298, 77306, 78307, 78283, 77749, 78308, 78310, 78286, 77752, 
78311, 78309, 78284, 77726, 77751
28013, 77482, 77474, 77298, 77306, 77483, 77475, 77299, 77307, 78310, 78286, 77752, 78311, 78313, 78289, 77755, 
78314, 78312, 78287, 77729, 77754
28014, 77483, 77475, 77299, 77307, 77484, 77476, 77300, 77308, 78313, 78289, 77755, 78314, 78316, 78292, 77758, 
78317, 78315, 78290, 77732, 77757
28015, 77484, 77476, 77300, 77308, 77485, 77477, 77301, 77309, 78316, 78292, 77758, 78317, 78319, 78295, 77761, 
78320, 78318, 78293, 77735, 77760
28016, 77485, 77477, 77301, 77309, 10286, 10285, 10263, 10264, 78319, 78295, 77761, 78320, 10359, 10356, 10314, 
10358, 78321, 78296, 77738, 77763
28017, 10131, 10130, 10108, 10109, 77486, 77478, 77302, 77310, 10204, 10203, 10159, 10205, 78323, 78299, 77765, 
78324, 78322, 78297, 77739, 77764
28018, 77486, 77478, 77302, 77310, 77487, 77479, 77303, 77311, 78323, 78299, 77765, 78324, 78326, 78302, 77768, 
78327, 78325, 78300, 77742, 77767
28019, 77487, 77479, 77303, 77311, 77488, 77480, 77304, 77312, 78326, 78302, 77768, 78327, 78329, 78305, 77771, 
78330, 78328, 78303, 77745, 77770
28020, 77488, 77480, 77304, 77312, 77489, 77481, 77305, 77313, 78329, 78305, 77771, 78330, 78332, 78308, 77774, 
78333, 78331, 78306, 77748, 77773
28021, 77489, 77481, 77305, 77313, 77490, 77482, 77306, 77314, 78332, 78308, 77774, 78333, 78335, 78311, 77777, 
78336, 78334, 78309, 77751, 77776
28022, 77490, 77482, 77306, 77314, 77491, 77483, 77307, 77315, 78335, 78311, 77777, 78336, 78338, 78314, 77780, 
78339, 78337, 78312, 77754, 77779
28023, 77491, 77483, 77307, 77315, 77492, 77484, 77308, 77316, 78338, 78314, 77780, 78339, 78341, 78317, 77783, 
78342, 78340, 78315, 77757, 77782
28024, 77492, 77484, 77308, 77316, 77493, 77485, 77309, 77317, 78341, 78317, 77783, 78342, 78344, 78320, 77786, 
78345, 78343, 78318, 77760, 77785
28025, 77493, 77485, 77309, 77317, 10287, 10286, 10264, 10265, 78344, 78320, 77786, 78345, 10361, 10358, 10316, 
10360, 78346, 78321, 77763, 77788
28026, 10132, 10131, 10109, 10110, 77494, 77486, 77310, 77318, 10206, 10205, 10161, 10207, 78348, 78324, 77790, 
78349, 78347, 78322, 77764, 77789
28027, 77494, 77486, 77310, 77318, 77495, 77487, 77311, 77319, 78348, 78324, 77790, 78349, 78351, 78327, 77793, 
78352, 78350, 78325, 77767, 77792
28028, 77495, 77487, 77311, 77319, 77496, 77488, 77312, 77320, 78351, 78327, 77793, 78352, 78354, 78330, 77796, 
78355, 78353, 78328, 77770, 77795
28029, 77496, 77488, 77312, 77320, 77497, 77489, 77313, 77321, 78354, 78330, 77796, 78355, 78357, 78333, 77799, 
78358, 78356, 78331, 77773, 77798
28030, 77497, 77489, 77313, 77321, 77498, 77490, 77314, 77322, 78357, 78333, 77799, 78358, 78360, 78336, 77802, 
78361, 78359, 78334, 77776, 77801
28031, 77498, 77490, 77314, 77322, 77499, 77491, 77315, 77323, 78360, 78336, 77802, 78361, 78363, 78339, 77805, 
78364, 78362, 78337, 77779, 77804
28032, 77499, 77491, 77315, 77323, 77500, 77492, 77316, 77324, 78363, 78339, 77805, 78364, 78366, 78342, 77808, 
78367, 78365, 78340, 77782, 77807
28033, 77500, 77492, 77316, 77324, 77501, 77493, 77317, 77325, 78366, 78342, 77808, 78367, 78369, 78345, 77811, 
78370, 78368, 78343, 77785, 77810
28034, 77501, 77493, 77317, 77325, 10288, 10287, 10265, 10266, 78369, 78345, 77811, 78370, 10363, 10360, 10318, 
10362, 78371, 78346, 77788, 77813
28035, 10133, 10132, 10110, 10111, 77502, 77494, 77318, 77326, 10208, 10207, 10163, 10209, 78373, 78349, 77815, 
78374, 78372, 78347, 77789, 77814
28036, 77502, 77494, 77318, 77326, 77503, 77495, 77319, 77327, 78373, 78349, 77815, 78374, 78376, 78352, 77818, 
78377, 78375, 78350, 77792, 77817
28037, 77503, 77495, 77319, 77327, 77504, 77496, 77320, 77328, 78376, 78352, 77818, 78377, 78379, 78355, 77821, 
78380, 78378, 78353, 77795, 77820
28038, 77504, 77496, 77320, 77328, 77505, 77497, 77321, 77329, 78379, 78355, 77821, 78380, 78382, 78358, 77824, 
78383, 78381, 78356, 77798, 77823
28039, 77505, 77497, 77321, 77329, 77506, 77498, 77322, 77330, 78382, 78358, 77824, 78383, 78385, 78361, 77827, 
78386, 78384, 78359, 77801, 77826
28040, 77506, 77498, 77322, 77330, 77507, 77499, 77323, 77331, 78385, 78361, 77827, 78386, 78388, 78364, 77830, 
78389, 78387, 78362, 77804, 77829
28041, 77507, 77499, 77323, 77331, 77508, 77500, 77324, 77332, 78388, 78364, 77830, 78389, 78391, 78367, 77833, 
78392, 78390, 78365, 77807, 77832
28042, 77508, 77500, 77324, 77332, 77509, 77501, 77325, 77333, 78391, 78367, 77833, 78392, 78394, 78370, 77836, 
78395, 78393, 78368, 77810, 77835
28043, 77509, 77501, 77325, 77333, 10289, 10288, 10266, 10267, 78394, 78370, 77836, 78395, 10365, 10362, 10320, 
10364, 78396, 78371, 77813, 77838
28044, 10134, 10133, 10111, 10112, 77510, 77502, 77326, 77334, 10210, 10209, 10165, 10211, 78398, 78374, 77840, 
78399, 78397, 78372, 77814, 77839
28045, 77510, 77502, 77326, 77334, 77511, 77503, 77327, 77335, 78398, 78374, 77840, 78399, 78401, 78377, 77843, 
78402, 78400, 78375, 77817, 77842
28046, 77511, 77503, 77327, 77335, 77512, 77504, 77328, 77336, 78401, 78377, 77843, 78402, 78404, 78380, 77846, 
78405, 78403, 78378, 77820, 77845
28047, 77512, 77504, 77328, 77336, 77513, 77505, 77329, 77337, 78404, 78380, 77846, 78405, 78407, 78383, 77849, 
78408, 78406, 78381, 77823, 77848
28048, 77513, 77505, 77329, 77337, 77514, 77506, 77330, 77338, 78407, 78383, 77849, 78408, 78410, 78386, 77852, 
78411, 78409, 78384, 77826, 77851
28049, 77514, 77506, 77330, 77338, 77515, 77507, 77331, 77339, 78410, 78386, 77852, 78411, 78413, 78389, 77855, 
78414, 78412, 78387, 77829, 77854
28050, 77515, 77507, 77331, 77339, 77516, 77508, 77332, 77340, 78413, 78389, 77855, 78414, 78416, 78392, 77858, 
78417, 78415, 78390, 77832, 77857
28051, 77516, 77508, 77332, 77340, 77517, 77509, 77333, 77341, 78416, 78392, 77858, 78417, 78419, 78395, 77861, 
78420, 78418, 78393, 77835, 77860
28052, 77517, 77509, 77333, 77341, 10290, 10289, 10267, 10268, 78419, 78395, 77861, 78420, 10367, 10364, 10322, 
10366, 78421, 78396, 77838, 77863
28053, 10135, 10134, 10112, 10113, 77518, 77510, 77334, 77342, 10212, 10211, 10167, 10213, 78423, 78399, 77865, 
78424, 78422, 78397, 77839, 77864
28054, 77518, 77510, 77334, 77342, 77519, 77511, 77335, 77343, 78423, 78399, 77865, 78424, 78426, 78402, 77868, 
78427, 78425, 78400, 77842, 77867
28055, 77519, 77511, 77335, 77343, 77520, 77512, 77336, 77344, 78426, 78402, 77868, 78427, 78429, 78405, 77871, 
78430, 78428, 78403, 77845, 77870
28056, 77520, 77512, 77336, 77344, 77521, 77513, 77337, 77345, 78429, 78405, 77871, 78430, 78432, 78408, 77874, 
78433, 78431, 78406, 77848, 77873
28057, 77521, 77513, 77337, 77345, 77522, 77514, 77338, 77346, 78432, 78408, 77874, 78433, 78435, 78411, 77877, 
78436, 78434, 78409, 77851, 77876
28058, 77522, 77514, 77338, 77346, 77523, 77515, 77339, 77347, 78435, 78411, 77877, 78436, 78438, 78414, 77880, 
78439, 78437, 78412, 77854, 77879
28059, 77523, 77515, 77339, 77347, 77524, 77516, 77340, 77348, 78438, 78414, 77880, 78439, 78441, 78417, 77883, 
78442, 78440, 78415, 77857, 77882
28060, 77524, 77516, 77340, 77348, 77525, 77517, 77341, 77349, 78441, 78417, 77883, 78442, 78444, 78420, 77886, 
78445, 78443, 78418, 77860, 77885
28061, 77525, 77517, 77341, 77349, 10291, 10290, 10268, 10269, 78444, 78420, 77886, 78445, 10369, 10366, 10324, 
10368, 78446, 78421, 77863, 77888
28062, 10136, 10135, 10113, 10114, 77526, 77518, 77342, 77350, 10214, 10213, 10169, 10215, 78448, 78424, 77890, 
78449, 78447, 78422, 77864, 77889
28063, 77526, 77518, 77342, 77350, 77527, 77519, 77343, 77351, 78448, 78424, 77890, 78449, 78451, 78427, 77893, 
78452, 78450, 78425, 77867, 77892
28064, 77527, 77519, 77343, 77351, 77528, 77520, 77344, 77352, 78451, 78427, 77893, 78452, 78454, 78430, 77896, 
78455, 78453, 78428, 77870, 77895
28065, 77528, 77520, 77344, 77352, 77529, 77521, 77345, 77353, 78454, 78430, 77896, 78455, 78457, 78433, 77899, 
78458, 78456, 78431, 77873, 77898
28066, 77529, 77521, 77345, 77353, 77530, 77522, 77346, 77354, 78457, 78433, 77899, 78458, 78460, 78436, 77902, 
78461, 78459, 78434, 77876, 77901
28067, 77530, 77522, 77346, 77354, 77531, 77523, 77347, 77355, 78460, 78436, 77902, 78461, 78463, 78439, 77905, 
78464, 78462, 78437, 77879, 77904
28068, 77531, 77523, 77347, 77355, 77532, 77524, 77348, 77356, 78463, 78439, 77905, 78464, 78466, 78442, 77908, 
78467, 78465, 78440, 77882, 77907
28069, 77532, 77524, 77348, 77356, 77533, 77525, 77349, 77357, 78466, 78442, 77908, 78467, 78469, 78445, 77911, 
78470, 78468, 78443, 77885, 77910
28070, 77533, 77525, 77349, 77357, 10292, 10291, 10269, 10270, 78469, 78445, 77911, 78470, 10371, 10368, 10326, 
10370, 78471, 78446, 77888, 77913
28071, 10137, 10136, 10114, 10115, 77534, 77526, 77350, 77358, 10216, 10215, 10171, 10217, 78473, 78449, 77915, 
78474, 78472, 78447, 77889, 77914
28072, 77534, 77526, 77350, 77358, 77535, 77527, 77351, 77359, 78473, 78449, 77915, 78474, 78476, 78452, 77918, 
78477, 78475, 78450, 77892, 77917
28073, 77535, 77527, 77351, 77359, 77536, 77528, 77352, 77360, 78476, 78452, 77918, 78477, 78479, 78455, 77921, 
78480, 78478, 78453, 77895, 77920
28074, 77536, 77528, 77352, 77360, 77537, 77529, 77353, 77361, 78479, 78455, 77921, 78480, 78482, 78458, 77924, 
78483, 78481, 78456, 77898, 77923
28075, 77537, 77529, 77353, 77361, 77538, 77530, 77354, 77362, 78482, 78458, 77924, 78483, 78485, 78461, 77927, 
78486, 78484, 78459, 77901, 77926
28076, 77538, 77530, 77354, 77362, 77539, 77531, 77355, 77363, 78485, 78461, 77927, 78486, 78488, 78464, 77930, 
78489, 78487, 78462, 77904, 77929
28077, 77539, 77531, 77355, 77363, 77540, 77532, 77356, 77364, 78488, 78464, 77930, 78489, 78491, 78467, 77933, 
78492, 78490, 78465, 77907, 77932
28078, 77540, 77532, 77356, 77364, 77541, 77533, 77357, 77365, 78491, 78467, 77933, 78492, 78494, 78470, 77936, 
78495, 78493, 78468, 77910, 77935
28079, 77541, 77533, 77357, 77365, 10293, 10292, 10270, 10271, 78494, 78470, 77936, 78495, 10373, 10370, 10328, 
10372, 78496, 78471, 77913, 77938
28080, 10138, 10137, 10115, 10116, 77542, 77534, 77358, 77366, 10218, 10217, 10173, 10219, 78498, 78474, 77940, 
78499, 78497, 78472, 77914, 77939
28081, 77542, 77534, 77358, 77366, 77543, 77535, 77359, 77367, 78498, 78474, 77940, 78499, 78501, 78477, 77943, 
78502, 78500, 78475, 77917, 77942
28082, 77543, 77535, 77359, 77367, 77544, 77536, 77360, 77368, 78501, 78477, 77943, 78502, 78504, 78480, 77946, 
78505, 78503, 78478, 77920, 77945
28083, 77544, 77536, 77360, 77368, 77545, 77537, 77361, 77369, 78504, 78480, 77946, 78505, 78507, 78483, 77949, 
78508, 78506, 78481, 77923, 77948
28084, 77545, 77537, 77361, 77369, 77546, 77538, 77362, 77370, 78507, 78483, 77949, 78508, 78510, 78486, 77952, 
78511, 78509, 78484, 77926, 77951
28085, 77546, 77538, 77362, 77370, 77547, 77539, 77363, 77371, 78510, 78486, 77952, 78511, 78513, 78489, 77955, 
78514, 78512, 78487, 77929, 77954
28086, 77547, 77539, 77363, 77371, 77548, 77540, 77364, 77372, 78513, 78489, 77955, 78514, 78516, 78492, 77958, 
78517, 78515, 78490, 77932, 77957
28087, 77548, 77540, 77364, 77372, 77549, 77541, 77365, 77373, 78516, 78492, 77958, 78517, 78519, 78495, 77961, 
78520, 78518, 78493, 77935, 77960
28088, 77549, 77541, 77365, 77373, 10294, 10293, 10271, 10272, 78519, 78495, 77961, 78520, 10375, 10372, 10330, 
10374, 78521, 78496, 77938, 77963
28089, 10139, 10138, 10116, 10117, 77550, 77542, 77366, 77374, 10220, 10219, 10175, 10221, 78523, 78499, 77965, 
78524, 78522, 78497, 77939, 77964
28090, 77550, 77542, 77366, 77374, 77551, 77543, 77367, 77375, 78523, 78499, 77965, 78524, 78526, 78502, 77968, 
78527, 78525, 78500, 77942, 77967
28091, 77551, 77543, 77367, 77375, 77552, 77544, 77368, 77376, 78526, 78502, 77968, 78527, 78529, 78505, 77971, 
78530, 78528, 78503, 77945, 77970
28092, 77552, 77544, 77368, 77376, 77553, 77545, 77369, 77377, 78529, 78505, 77971, 78530, 78532, 78508, 77974, 
78533, 78531, 78506, 77948, 77973
28093, 77553, 77545, 77369, 77377, 77554, 77546, 77370, 77378, 78532, 78508, 77974, 78533, 78535, 78511, 77977, 
78536, 78534, 78509, 77951, 77976
28094, 77554, 77546, 77370, 77378, 77555, 77547, 77371, 77379, 78535, 78511, 77977, 78536, 78538, 78514, 77980, 
78539, 78537, 78512, 77954, 77979
28095, 77555, 77547, 77371, 77379, 77556, 77548, 77372, 77380, 78538, 78514, 77980, 78539, 78541, 78517, 77983, 
78542, 78540, 78515, 77957, 77982
28096, 77556, 77548, 77372, 77380, 77557, 77549, 77373, 77381, 78541, 78517, 77983, 78542, 78544, 78520, 77986, 
78545, 78543, 78518, 77960, 77985
28097, 77557, 77549, 77373, 77381, 10295, 10294, 10272, 10273, 78544, 78520, 77986, 78545, 10377, 10374, 10332, 
10376, 78546, 78521, 77963, 77988
28098, 10140, 10139, 10117, 10118, 77558, 77550, 77374, 77382, 10222, 10221, 10177, 10223, 78548, 78524, 77990, 
78549, 78547, 78522, 77964, 77989
28099, 77558, 77550, 77374, 77382, 77559, 77551, 77375, 77383, 78548, 78524, 77990, 78549, 78551, 78527, 77993, 
78552, 78550, 78525, 77967, 77992
28100, 77559, 77551, 77375, 77383, 77560, 77552, 77376, 77384, 78551, 78527, 77993, 78552, 78554, 78530, 77996, 
78555, 78553, 78528, 77970, 77995
28101, 77560, 77552, 77376, 77384, 77561, 77553, 77377, 77385, 78554, 78530, 77996, 78555, 78557, 78533, 77999, 
78558, 78556, 78531, 77973, 77998
28102, 77561, 77553, 77377, 77385, 77562, 77554, 77378, 77386, 78557, 78533, 77999, 78558, 78560, 78536, 78002, 
78561, 78559, 78534, 77976, 78001
28103, 77562, 77554, 77378, 77386, 77563, 77555, 77379, 77387, 78560, 78536, 78002, 78561, 78563, 78539, 78005, 
78564, 78562, 78537, 77979, 78004
28104, 77563, 77555, 77379, 77387, 77564, 77556, 77380, 77388, 78563, 78539, 78005, 78564, 78566, 78542, 78008, 
78567, 78565, 78540, 77982, 78007
28105, 77564, 77556, 77380, 77388, 77565, 77557, 77381, 77389, 78566, 78542, 78008, 78567, 78569, 78545, 78011, 
78570, 78568, 78543, 77985, 78010
28106, 77565, 77557, 77381, 77389, 10296, 10295, 10273, 10274, 78569, 78545, 78011, 78570, 10379, 10376, 10334, 
10378, 78571, 78546, 77988, 78013
28107, 10141, 10140, 10118, 10119, 77566, 77558, 77382, 77390, 10224, 10223, 10179, 10225, 78573, 78549, 78015, 
78574, 78572, 78547, 77989, 78014
28108, 77566, 77558, 77382, 77390, 77567, 77559, 77383, 77391, 78573, 78549, 78015, 78574, 78576, 78552, 78018, 
78577, 78575, 78550, 77992, 78017
28109, 77567, 77559, 77383, 77391, 77568, 77560, 77384, 77392, 78576, 78552, 78018, 78577, 78579, 78555, 78021, 
78580, 78578, 78553, 77995, 78020
28110, 77568, 77560, 77384, 77392, 77569, 77561, 77385, 77393, 78579, 78555, 78021, 78580, 78582, 78558, 78024, 
78583, 78581, 78556, 77998, 78023
28111, 77569, 77561, 77385, 77393, 77570, 77562, 77386, 77394, 78582, 78558, 78024, 78583, 78585, 78561, 78027, 
78586, 78584, 78559, 78001, 78026
28112, 77570, 77562, 77386, 77394, 77571, 77563, 77387, 77395, 78585, 78561, 78027, 78586, 78588, 78564, 78030, 
78589, 78587, 78562, 78004, 78029
28113, 77571, 77563, 77387, 77395, 77572, 77564, 77388, 77396, 78588, 78564, 78030, 78589, 78591, 78567, 78033, 
78592, 78590, 78565, 78007, 78032
28114, 77572, 77564, 77388, 77396, 77573, 77565, 77389, 77397, 78591, 78567, 78033, 78592, 78594, 78570, 78036, 
78595, 78593, 78568, 78010, 78035
28115, 77573, 77565, 77389, 77397, 10297, 10296, 10274, 10275, 78594, 78570, 78036, 78595, 10381, 10378, 10336, 
10380, 78596, 78571, 78013, 78038
28116, 10142, 10141, 10119, 10120, 77574, 77566, 77390, 77398, 10226, 10225, 10181, 10227, 78598, 78574, 78040, 
78599, 78597, 78572, 78014, 78039
28117, 77574, 77566, 77390, 77398, 77575, 77567, 77391, 77399, 78598, 78574, 78040, 78599, 78601, 78577, 78043, 
78602, 78600, 78575, 78017, 78042
28118, 77575, 77567, 77391, 77399, 77576, 77568, 77392, 77400, 78601, 78577, 78043, 78602, 78604, 78580, 78046, 
78605, 78603, 78578, 78020, 78045
28119, 77576, 77568, 77392, 77400, 77577, 77569, 77393, 77401, 78604, 78580, 78046, 78605, 78607, 78583, 78049, 
78608, 78606, 78581, 78023, 78048
28120, 77577, 77569, 77393, 77401, 77578, 77570, 77394, 77402, 78607, 78583, 78049, 78608, 78610, 78586, 78052, 
78611, 78609, 78584, 78026, 78051
28121, 77578, 77570, 77394, 77402, 77579, 77571, 77395, 77403, 78610, 78586, 78052, 78611, 78613, 78589, 78055, 
78614, 78612, 78587, 78029, 78054
28122, 77579, 77571, 77395, 77403, 77580, 77572, 77396, 77404, 78613, 78589, 78055, 78614, 78616, 78592, 78058, 
78617, 78615, 78590, 78032, 78057
28123, 77580, 77572, 77396, 77404, 77581, 77573, 77397, 77405, 78616, 78592, 78058, 78617, 78619, 78595, 78061, 
78620, 78618, 78593, 78035, 78060
28124, 77581, 77573, 77397, 77405, 10298, 10297, 10275, 10276, 78619, 78595, 78061, 78620, 10383, 10380, 10338, 
10382, 78621, 78596, 78038, 78063
28125, 10143, 10142, 10120, 10121, 77582, 77574, 77398, 77406, 10228, 10227, 10183, 10229, 78623, 78599, 78065, 
78624, 78622, 78597, 78039, 78064
28126, 77582, 77574, 77398, 77406, 77583, 77575, 77399, 77407, 78623, 78599, 78065, 78624, 78626, 78602, 78068, 
78627, 78625, 78600, 78042, 78067
28127, 77583, 77575, 77399, 77407, 77584, 77576, 77400, 77408, 78626, 78602, 78068, 78627, 78629, 78605, 78071, 
78630, 78628, 78603, 78045, 78070
28128, 77584, 77576, 77400, 77408, 77585, 77577, 77401, 77409, 78629, 78605, 78071, 78630, 78632, 78608, 78074, 
78633, 78631, 78606, 78048, 78073
28129, 77585, 77577, 77401, 77409, 77586, 77578, 77402, 77410, 78632, 78608, 78074, 78633, 78635, 78611, 78077, 
78636, 78634, 78609, 78051, 78076
28130, 77586, 77578, 77402, 77410, 77587, 77579, 77403, 77411, 78635, 78611, 78077, 78636, 78638, 78614, 78080, 
78639, 78637, 78612, 78054, 78079
28131, 77587, 77579, 77403, 77411, 77588, 77580, 77404, 77412, 78638, 78614, 78080, 78639, 78641, 78617, 78083, 
78642, 78640, 78615, 78057, 78082
28132, 77588, 77580, 77404, 77412, 77589, 77581, 77405, 77413, 78641, 78617, 78083, 78642, 78644, 78620, 78086, 
78645, 78643, 78618, 78060, 78085
28133, 77589, 77581, 77405, 77413, 10299, 10298, 10276, 10277, 78644, 78620, 78086, 78645, 10385, 10382, 10340, 
10384, 78646, 78621, 78063, 78088
28134, 10144, 10143, 10121, 10122, 77590, 77582, 77406, 77414, 10230, 10229, 10185, 10231, 78648, 78624, 78090, 
78649, 78647, 78622, 78064, 78089
28135, 77590, 77582, 77406, 77414, 77591, 77583, 77407, 77415, 78648, 78624, 78090, 78649, 78651, 78627, 78093, 
78652, 78650, 78625, 78067, 78092
28136, 77591, 77583, 77407, 77415, 77592, 77584, 77408, 77416, 78651, 78627, 78093, 78652, 78654, 78630, 78096, 
78655, 78653, 78628, 78070, 78095
28137, 77592, 77584, 77408, 77416, 77593, 77585, 77409, 77417, 78654, 78630, 78096, 78655, 78657, 78633, 78099, 
78658, 78656, 78631, 78073, 78098
28138, 77593, 77585, 77409, 77417, 77594, 77586, 77410, 77418, 78657, 78633, 78099, 78658, 78660, 78636, 78102, 
78661, 78659, 78634, 78076, 78101
28139, 77594, 77586, 77410, 77418, 77595, 77587, 77411, 77419, 78660, 78636, 78102, 78661, 78663, 78639, 78105, 
78664, 78662, 78637, 78079, 78104
28140, 77595, 77587, 77411, 77419, 77596, 77588, 77412, 77420, 78663, 78639, 78105, 78664, 78666, 78642, 78108, 
78667, 78665, 78640, 78082, 78107
28141, 77596, 77588, 77412, 77420, 77597, 77589, 77413, 77421, 78666, 78642, 78108, 78667, 78669, 78645, 78111, 
78670, 78668, 78643, 78085, 78110
28142, 77597, 77589, 77413, 77421, 10300, 10299, 10277, 10278, 78669, 78645, 78111, 78670, 10387, 10384, 10342, 
10386, 78671, 78646, 78088, 78113
28143, 10145, 10144, 10122, 10123, 77598, 77590, 77414, 77422, 10232, 10231, 10187, 10233, 78673, 78649, 78115, 
78674, 78672, 78647, 78089, 78114
28144, 77598, 77590, 77414, 77422, 77599, 77591, 77415, 77423, 78673, 78649, 78115, 78674, 78676, 78652, 78118, 
78677, 78675, 78650, 78092, 78117
28145, 77599, 77591, 77415, 77423, 77600, 77592, 77416, 77424, 78676, 78652, 78118, 78677, 78679, 78655, 78121, 
78680, 78678, 78653, 78095, 78120
28146, 77600, 77592, 77416, 77424, 77601, 77593, 77417, 77425, 78679, 78655, 78121, 78680, 78682, 78658, 78124, 
78683, 78681, 78656, 78098, 78123
28147, 77601, 77593, 77417, 77425, 77602, 77594, 77418, 77426, 78682, 78658, 78124, 78683, 78685, 78661, 78127, 
78686, 78684, 78659, 78101, 78126
28148, 77602, 77594, 77418, 77426, 77603, 77595, 77419, 77427, 78685, 78661, 78127, 78686, 78688, 78664, 78130, 
78689, 78687, 78662, 78104, 78129
28149, 77603, 77595, 77419, 77427, 77604, 77596, 77420, 77428, 78688, 78664, 78130, 78689, 78691, 78667, 78133, 
78692, 78690, 78665, 78107, 78132
28150, 77604, 77596, 77420, 77428, 77605, 77597, 77421, 77429, 78691, 78667, 78133, 78692, 78694, 78670, 78136, 
78695, 78693, 78668, 78110, 78135
28151, 77605, 77597, 77421, 77429, 10301, 10300, 10278, 10279, 78694, 78670, 78136, 78695, 10389, 10386, 10344, 
10388, 78696, 78671, 78113, 78138
28152, 10146, 10145, 10123, 10124, 77606, 77598, 77422, 77430, 10234, 10233, 10189, 10235, 78698, 78674, 78140, 
78699, 78697, 78672, 78114, 78139
28153, 77606, 77598, 77422, 77430, 77607, 77599, 77423, 77431, 78698, 78674, 78140, 78699, 78701, 78677, 78143, 
78702, 78700, 78675, 78117, 78142
28154, 77607, 77599, 77423, 77431, 77608, 77600, 77424, 77432, 78701, 78677, 78143, 78702, 78704, 78680, 78146, 
78705, 78703, 78678, 78120, 78145
28155, 77608, 77600, 77424, 77432, 77609, 77601, 77425, 77433, 78704, 78680, 78146, 78705, 78707, 78683, 78149, 
78708, 78706, 78681, 78123, 78148
28156, 77609, 77601, 77425, 77433, 77610, 77602, 77426, 77434, 78707, 78683, 78149, 78708, 78710, 78686, 78152, 
78711, 78709, 78684, 78126, 78151
28157, 77610, 77602, 77426, 77434, 77611, 77603, 77427, 77435, 78710, 78686, 78152, 78711, 78713, 78689, 78155, 
78714, 78712, 78687, 78129, 78154
28158, 77611, 77603, 77427, 77435, 77612, 77604, 77428, 77436, 78713, 78689, 78155, 78714, 78716, 78692, 78158, 
78717, 78715, 78690, 78132, 78157
28159, 77612, 77604, 77428, 77436, 77613, 77605, 77429, 77437, 78716, 78692, 78158, 78717, 78719, 78695, 78161, 
78720, 78718, 78693, 78135, 78160
28160, 77613, 77605, 77429, 77437, 10302, 10301, 10279, 10280, 78719, 78695, 78161, 78720, 10391, 10388, 10346, 
10390, 78721, 78696, 78138, 78163
28161, 1180, 10146, 10124, 1179, 10481, 77606, 77430, 10473, 10236, 10235, 10191, 1182, 78722, 78699, 78164, 
10507, 10506, 78697, 78139, 10489
28162, 10481, 77606, 77430, 10473, 10482, 77607, 77431, 10474, 78722, 78699, 78164, 10507, 78723, 78702, 78165, 
10509, 10508, 78700, 78142, 10491
28163, 10482, 77607, 77431, 10474, 10483, 77608, 77432, 10475, 78723, 78702, 78165, 10509, 78724, 78705, 78166, 
10511, 10510, 78703, 78145, 10493
28164, 10483, 77608, 77432, 10475, 10484, 77609, 77433, 10476, 78724, 78705, 78166, 10511, 78725, 78708, 78167, 
10513, 10512, 78706, 78148, 10495
28165, 10484, 77609, 77433, 10476, 10485, 77610, 77434, 10477, 78725, 78708, 78167, 10513, 78726, 78711, 78168, 
10515, 10514, 78709, 78151, 10497
28166, 10485, 77610, 77434, 10477, 10486, 77611, 77435, 10478, 78726, 78711, 78168, 10515, 78727, 78714, 78169, 
10517, 10516, 78712, 78154, 10499
28167, 10486, 77611, 77435, 10478, 10487, 77612, 77436, 10479, 78727, 78714, 78169, 10517, 78728, 78717, 78170, 
10519, 10518, 78715, 78157, 10501
28168, 10487, 77612, 77436, 10479, 10488, 77613, 77437, 10480, 78728, 78717, 78170, 10519, 78729, 78720, 78171, 
10521, 10520, 78718, 78160, 10503
28169, 10488, 77613, 77437, 10480, 1235, 10302, 10280, 1234, 78729, 78720, 78171, 10521, 10392, 10390, 10347, 
1237, 10522, 78721, 78163, 10505
28170, 953, 27, 1175, 10125, 8987, 919, 10423, 77438, 975, 1178, 10192, 10237, 9164, 10465, 78173, 
78730, 9163, 928, 10449, 78172
28171, 8987, 919, 10423, 77438, 8988, 918, 10424, 77439, 9164, 10465, 78173, 78730, 9166, 10466, 78176, 
78731, 9165, 927, 10451, 78175
28172, 8988, 918, 10424, 77439, 8989, 917, 10425, 77440, 9166, 10466, 78176, 78731, 9168, 10467, 78179, 
78732, 9167, 926, 10453, 78178
28173, 8989, 917, 10425, 77440, 8990, 916, 10426, 77441, 9168, 10467, 78179, 78732, 9170, 10468, 78182, 
78733, 9169, 925, 10455, 78181
28174, 8990, 916, 10426, 77441, 8991, 915, 10427, 77442, 9170, 10468, 78182, 78733, 9172, 10469, 78185, 
78734, 9171, 924, 10457, 78184
28175, 8991, 915, 10427, 77442, 8992, 914, 10428, 77443, 9172, 10469, 78185, 78734, 9174, 10470, 78188, 
78735, 9173, 923, 10459, 78187
28176, 8992, 914, 10428, 77443, 8993, 913, 10429, 77444, 9174, 10470, 78188, 78735, 9176, 10471, 78191, 
78736, 9175, 922, 10461, 78190
28177, 8993, 913, 10429, 77444, 8994, 912, 10430, 77445, 9176, 10471, 78191, 78736, 9178, 10472, 78194, 
78737, 9177, 921, 10463, 78193
28178, 8994, 912, 10430, 77445, 1050, 29, 1230, 10281, 9178, 10472, 78194, 78737, 1072, 1233, 10349, 
10393, 9179, 920, 10464, 78196
28179, 954, 953, 10125, 10126, 8995, 8987, 77438, 77446, 976, 10237, 10194, 10238, 9181, 78730, 78198, 
78738, 9180, 9163, 78172, 78197
28180, 8995, 8987, 77438, 77446, 8996, 8988, 77439, 77447, 9181, 78730, 78198, 78738, 9183, 78731, 78201, 
78739, 9182, 9165, 78175, 78200
28181, 8996, 8988, 77439, 77447, 8997, 8989, 77440, 77448, 9183, 78731, 78201, 78739, 9185, 78732, 78204, 
78740, 9184, 9167, 78178, 78203
28182, 8997, 8989, 77440, 77448, 8998, 8990, 77441, 77449, 9185, 78732, 78204, 78740, 9187, 78733, 78207, 
78741, 9186, 9169, 78181, 78206
28183, 8998, 8990, 77441, 77449, 8999, 8991, 77442, 77450, 9187, 78733, 78207, 78741, 9189, 78734, 78210, 
78742, 9188, 9171, 78184, 78209
28184, 8999, 8991, 77442, 77450, 9000, 8992, 77443, 77451, 9189, 78734, 78210, 78742, 9191, 78735, 78213, 
78743, 9190, 9173, 78187, 78212
28185, 9000, 8992, 77443, 77451, 9001, 8993, 77444, 77452, 9191, 78735, 78213, 78743, 9193, 78736, 78216, 
78744, 9192, 9175, 78190, 78215
28186, 9001, 8993, 77444, 77452, 9002, 8994, 77445, 77453, 9193, 78736, 78216, 78744, 9195, 78737, 78219, 
78745, 9194, 9177, 78193, 78218
28187, 9002, 8994, 77445, 77453, 1051, 1050, 10281, 10282, 9195, 78737, 78219, 78745, 1073, 10393, 10351, 
10394, 9196, 9179, 78196, 78221
28188, 955, 954, 10126, 10127, 9003, 8995, 77446, 77454, 977, 10238, 10196, 10239, 9198, 78738, 78223, 
78746, 9197, 9180, 78197, 78222
28189, 9003, 8995, 77446, 77454, 9004, 8996, 77447, 77455, 9198, 78738, 78223, 78746, 9200, 78739, 78226, 
78747, 9199, 9182, 78200, 78225
28190, 9004, 8996, 77447, 77455, 9005, 8997, 77448, 77456, 9200, 78739, 78226, 78747, 9202, 78740, 78229, 
78748, 9201, 9184, 78203, 78228
28191, 9005, 8997, 77448, 77456, 9006, 8998, 77449, 77457, 9202, 78740, 78229, 78748, 9204, 78741, 78232, 
78749, 9203, 9186, 78206, 78231
28192, 9006, 8998, 77449, 77457, 9007, 8999, 77450, 77458, 9204, 78741, 78232, 78749, 9206, 78742, 78235, 
78750, 9205, 9188, 78209, 78234
28193, 9007, 8999, 77450, 77458, 9008, 9000, 77451, 77459, 9206, 78742, 78235, 78750, 9208, 78743, 78238, 
78751, 9207, 9190, 78212, 78237
28194, 9008, 9000, 77451, 77459, 9009, 9001, 77452, 77460, 9208, 78743, 78238, 78751, 9210, 78744, 78241, 
78752, 9209, 9192, 78215, 78240
28195, 9009, 9001, 77452, 77460, 9010, 9002, 77453, 77461, 9210, 78744, 78241, 78752, 9212, 78745, 78244, 
78753, 9211, 9194, 78218, 78243
28196, 9010, 9002, 77453, 77461, 1052, 1051, 10282, 10283, 9212, 78745, 78244, 78753, 1074, 10394, 10353, 
10395, 9213, 9196, 78221, 78246
28197, 956, 955, 10127, 10128, 9011, 9003, 77454, 77462, 978, 10239, 10198, 10240, 9215, 78746, 78248, 
78754, 9214, 9197, 78222, 78247
28198, 9011, 9003, 77454, 77462, 9012, 9004, 77455, 77463, 9215, 78746, 78248, 78754, 9217, 78747, 78251, 
78755, 9216, 9199, 78225, 78250
28199, 9012, 9004, 77455, 77463, 9013, 9005, 77456, 77464, 9217, 78747, 78251, 78755, 9219, 78748, 78254, 
78756, 9218, 9201, 78228, 78253
28200, 9013, 9005, 77456, 77464, 9014, 9006, 77457, 77465, 9219, 78748, 78254, 78756, 9221, 78749, 78257, 
78757, 9220, 9203, 78231, 78256
28201, 9014, 9006, 77457, 77465, 9015, 9007, 77458, 77466, 9221, 78749, 78257, 78757, 9223, 78750, 78260, 
78758, 9222, 9205, 78234, 78259
28202, 9015, 9007, 77458, 77466, 9016, 9008, 77459, 77467, 9223, 78750, 78260, 78758, 9225, 78751, 78263, 
78759, 9224, 9207, 78237, 78262
28203, 9016, 9008, 77459, 77467, 9017, 9009, 77460, 77468, 9225, 78751, 78263, 78759, 9227, 78752, 78266, 
78760, 9226, 9209, 78240, 78265
28204, 9017, 9009, 77460, 77468, 9018, 9010, 77461, 77469, 9227, 78752, 78266, 78760, 9229, 78753, 78269, 
78761, 9228, 9211, 78243, 78268
28205, 9018, 9010, 77461, 77469, 1053, 1052, 10283, 10284, 9229, 78753, 78269, 78761, 1075, 10395, 10355, 
10396, 9230, 9213, 78246, 78271
28206, 957, 956, 10128, 10129, 9019, 9011, 77462, 77470, 979, 10240, 10200, 10241, 9232, 78754, 78273, 
78762, 9231, 9214, 78247, 78272
28207, 9019, 9011, 77462, 77470, 9020, 9012, 77463, 77471, 9232, 78754, 78273, 78762, 9234, 78755, 78276, 
78763, 9233, 9216, 78250, 78275
28208, 9020, 9012, 77463, 77471, 9021, 9013, 77464, 77472, 9234, 78755, 78276, 78763, 9236, 78756, 78279, 
78764, 9235, 9218, 78253, 78278
28209, 9021, 9013, 77464, 77472, 9022, 9014, 77465, 77473, 9236, 78756, 78279, 78764, 9238, 78757, 78282, 
78765, 9237, 9220, 78256, 78281
28210, 9022, 9014, 77465, 77473, 9023, 9015, 77466, 77474, 9238, 78757, 78282, 78765, 9240, 78758, 78285, 
78766, 9239, 9222, 78259, 78284
28211, 9023, 9015, 77466, 77474, 9024, 9016, 77467, 77475, 9240, 78758, 78285, 78766, 9242, 78759, 78288, 
78767, 9241, 9224, 78262, 78287
28212, 9024, 9016, 77467, 77475, 9025, 9017, 77468, 77476, 9242, 78759, 78288, 78767, 9244, 78760, 78291, 
78768, 9243, 9226, 78265, 78290
28213, 9025, 9017, 77468, 77476, 9026, 9018, 77469, 77477, 9244, 78760, 78291, 78768, 9246, 78761, 78294, 
78769, 9245, 9228, 78268, 78293
28214, 9026, 9018, 77469, 77477, 1054, 1053, 10284, 10285, 9246, 78761, 78294, 78769, 1076, 10396, 10357, 
10397, 9247, 9230, 78271, 78296
28215, 958, 957, 10129, 10130, 9027, 9019, 77470, 77478, 980, 10241, 10202, 10242, 9249, 78762, 78298, 
78770, 9248, 9231, 78272, 78297
28216, 9027, 9019, 77470, 77478, 9028, 9020, 77471, 77479, 9249, 78762, 78298, 78770, 9251, 78763, 78301, 
78771, 9250, 9233, 78275, 78300
28217, 9028, 9020, 77471, 77479, 9029, 9021, 77472, 77480, 9251, 78763, 78301, 78771, 9253, 78764, 78304, 
78772, 9252, 9235, 78278, 78303
28218, 9029, 9021, 77472, 77480, 9030, 9022, 77473, 77481, 9253, 78764, 78304, 78772, 9255, 78765, 78307, 
78773, 9254, 9237, 78281, 78306
28219, 9030, 9022, 77473, 77481, 9031, 9023, 77474, 77482, 9255, 78765, 78307, 78773, 9257, 78766, 78310, 
78774, 9256, 9239, 78284, 78309
28220, 9031, 9023, 77474, 77482, 9032, 9024, 77475, 77483, 9257, 78766, 78310, 78774, 9259, 78767, 78313, 
78775, 9258, 9241, 78287, 78312
28221, 9032, 9024, 77475, 77483, 9033, 9025, 77476, 77484, 9259, 78767, 78313, 78775, 9261, 78768, 78316, 
78776, 9260, 9243, 78290, 78315
28222, 9033, 9025, 77476, 77484, 9034, 9026, 77477, 77485, 9261, 78768, 78316, 78776, 9263, 78769, 78319, 
78777, 9262, 9245, 78293, 78318
28223, 9034, 9026, 77477, 77485, 1055, 1054, 10285, 10286, 9263, 78769, 78319, 78777, 1077, 10397, 10359, 
10398, 9264, 9247, 78296, 78321
28224, 959, 958, 10130, 10131, 9035, 9027, 77478, 77486, 981, 10242, 10204, 10243, 9266, 78770, 78323, 
78778, 9265, 9248, 78297, 78322
28225, 9035, 9027, 77478, 77486, 9036, 9028, 77479, 77487, 9266, 78770, 78323, 78778, 9268, 78771, 78326, 
78779, 9267, 9250, 78300, 78325
28226, 9036, 9028, 77479, 77487, 9037, 9029, 77480, 77488, 9268, 78771, 78326, 78779, 9270, 78772, 78329, 
78780, 9269, 9252, 78303, 78328
28227, 9037, 9029, 77480, 77488, 9038, 9030, 77481, 77489, 9270, 78772, 78329, 78780, 9272, 78773, 78332, 
78781, 9271, 9254, 78306, 78331
28228, 9038, 9030, 77481, 77489, 9039, 9031, 77482, 77490, 9272, 78773, 78332, 78781, 9274, 78774, 78335, 
78782, 9273, 9256, 78309, 78334
28229, 9039, 9031, 77482, 77490, 9040, 9032, 77483, 77491, 9274, 78774, 78335, 78782, 9276, 78775, 78338, 
78783, 9275, 9258, 78312, 78337
28230, 9040, 9032, 77483, 77491, 9041, 9033, 77484, 77492, 9276, 78775, 78338, 78783, 9278, 78776, 78341, 
78784, 9277, 9260, 78315, 78340
28231, 9041, 9033, 77484, 77492, 9042, 9034, 77485, 77493, 9278, 78776, 78341, 78784, 9280, 78777, 78344, 
78785, 9279, 9262, 78318, 78343
28232, 9042, 9034, 77485, 77493, 1056, 1055, 10286, 10287, 9280, 78777, 78344, 78785, 1078, 10398, 10361, 
10399, 9281, 9264, 78321, 78346
28233, 960, 959, 10131, 10132, 9043, 9035, 77486, 77494, 982, 10243, 10206, 10244, 9283, 78778, 78348, 
78786, 9282, 9265, 78322, 78347
28234, 9043, 9035, 77486, 77494, 9044, 9036, 77487, 77495, 9283, 78778, 78348, 78786, 9285, 78779, 78351, 
78787, 9284, 9267, 78325, 78350
28235, 9044, 9036, 77487, 77495, 9045, 9037, 77488, 77496, 9285, 78779, 78351, 78787, 9287, 78780, 78354, 
78788, 9286, 9269, 78328, 78353
28236, 9045, 9037, 77488, 77496, 9046, 9038, 77489, 77497, 9287, 78780, 78354, 78788, 9289, 78781, 78357, 
78789, 9288, 9271, 78331, 78356
28237, 9046, 9038, 77489, 77497, 9047, 9039, 77490, 77498, 9289, 78781, 78357, 78789, 9291, 78782, 78360, 
78790, 9290, 9273, 78334, 78359
28238, 9047, 9039, 77490, 77498, 9048, 9040, 77491, 77499, 9291, 78782, 78360, 78790, 9293, 78783, 78363, 
78791, 9292, 9275, 78337, 78362
28239, 9048, 9040, 77491, 77499, 9049, 9041, 77492, 77500, 9293, 78783, 78363, 78791, 9295, 78784, 78366, 
78792, 9294, 9277, 78340, 78365
28240, 9049, 9041, 77492, 77500, 9050, 9042, 77493, 77501, 9295, 78784, 78366, 78792, 9297, 78785, 78369, 
78793, 9296, 9279, 78343, 78368
28241, 9050, 9042, 77493, 77501, 1057, 1056, 10287, 10288, 9297, 78785, 78369, 78793, 1079, 10399, 10363, 
10400, 9298, 9281, 78346, 78371
28242, 961, 960, 10132, 10133, 9051, 9043, 77494, 77502, 983, 10244, 10208, 10245, 9300, 78786, 78373, 
78794, 9299, 9282, 78347, 78372
28243, 9051, 9043, 77494, 77502, 9052, 9044, 77495, 77503, 9300, 78786, 78373, 78794, 9302, 78787, 78376, 
78795, 9301, 9284, 78350, 78375
28244, 9052, 9044, 77495, 77503, 9053, 9045, 77496, 77504, 9302, 78787, 78376, 78795, 9304, 78788, 78379, 
78796, 9303, 9286, 78353, 78378
28245, 9053, 9045, 77496, 77504, 9054, 9046, 77497, 77505, 9304, 78788, 78379, 78796, 9306, 78789, 78382, 
78797, 9305, 9288, 78356, 78381
28246, 9054, 9046, 77497, 77505, 9055, 9047, 77498, 77506, 9306, 78789, 78382, 78797, 9308, 78790, 78385, 
78798, 9307, 9290, 78359, 78384
28247, 9055, 9047, 77498, 77506, 9056, 9048, 77499, 77507, 9308, 78790, 78385, 78798, 9310, 78791, 78388, 
78799, 9309, 9292, 78362, 78387
28248, 9056, 9048, 77499, 77507, 9057, 9049, 77500, 77508, 9310, 78791, 78388, 78799, 9312, 78792, 78391, 
78800, 9311, 9294, 78365, 78390
28249, 9057, 9049, 77500, 77508, 9058, 9050, 77501, 77509, 9312, 78792, 78391, 78800, 9314, 78793, 78394, 
78801, 9313, 9296, 78368, 78393
28250, 9058, 9050, 77501, 77509, 1058, 1057, 10288, 10289, 9314, 78793, 78394, 78801, 1080, 10400, 10365, 
10401, 9315, 9298, 78371, 78396
28251, 962, 961, 10133, 10134, 9059, 9051, 77502, 77510, 984, 10245, 10210, 10246, 9317, 78794, 78398, 
78802, 9316, 9299, 78372, 78397
28252, 9059, 9051, 77502, 77510, 9060, 9052, 77503, 77511, 9317, 78794, 78398, 78802, 9319, 78795, 78401, 
78803, 9318, 9301, 78375, 78400
28253, 9060, 9052, 77503, 77511, 9061, 9053, 77504, 77512, 9319, 78795, 78401, 78803, 9321, 78796, 78404, 
78804, 9320, 9303, 78378, 78403
28254, 9061, 9053, 77504, 77512, 9062, 9054, 77505, 77513, 9321, 78796, 78404, 78804, 9323, 78797, 78407, 
78805, 9322, 9305, 78381, 78406
28255, 9062, 9054, 77505, 77513, 9063, 9055, 77506, 77514, 9323, 78797, 78407, 78805, 9325, 78798, 78410, 
78806, 9324, 9307, 78384, 78409
28256, 9063, 9055, 77506, 77514, 9064, 9056, 77507, 77515, 9325, 78798, 78410, 78806, 9327, 78799, 78413, 
78807, 9326, 9309, 78387, 78412
28257, 9064, 9056, 77507, 77515, 9065, 9057, 77508, 77516, 9327, 78799, 78413, 78807, 9329, 78800, 78416, 
78808, 9328, 9311, 78390, 78415
28258, 9065, 9057, 77508, 77516, 9066, 9058, 77509, 77517, 9329, 78800, 78416, 78808, 9331, 78801, 78419, 
78809, 9330, 9313, 78393, 78418
28259, 9066, 9058, 77509, 77517, 1059, 1058, 10289, 10290, 9331, 78801, 78419, 78809, 1081, 10401, 10367, 
10402, 9332, 9315, 78396, 78421
28260, 963, 962, 10134, 10135, 9067, 9059, 77510, 77518, 985, 10246, 10212, 10247, 9334, 78802, 78423, 
78810, 9333, 9316, 78397, 78422
28261, 9067, 9059, 77510, 77518, 9068, 9060, 77511, 77519, 9334, 78802, 78423, 78810, 9336, 78803, 78426, 
78811, 9335, 9318, 78400, 78425
28262, 9068, 9060, 77511, 77519, 9069, 9061, 77512, 77520, 9336, 78803, 78426, 78811, 9338, 78804, 78429, 
78812, 9337, 9320, 78403, 78428
28263, 9069, 9061, 77512, 77520, 9070, 9062, 77513, 77521, 9338, 78804, 78429, 78812, 9340, 78805, 78432, 
78813, 9339, 9322, 78406, 78431
28264, 9070, 9062, 77513, 77521, 9071, 9063, 77514, 77522, 9340, 78805, 78432, 78813, 9342, 78806, 78435, 
78814, 9341, 9324, 78409, 78434
28265, 9071, 9063, 77514, 77522, 9072, 9064, 77515, 77523, 9342, 78806, 78435, 78814, 9344, 78807, 78438, 
78815, 9343, 9326, 78412, 78437
28266, 9072, 9064, 77515, 77523, 9073, 9065, 77516, 77524, 9344, 78807, 78438, 78815, 9346, 78808, 78441, 
78816, 9345, 9328, 78415, 78440
28267, 9073, 9065, 77516, 77524, 9074, 9066, 77517, 77525, 9346, 78808, 78441, 78816, 9348, 78809, 78444, 
78817, 9347, 9330, 78418, 78443
28268, 9074, 9066, 77517, 77525, 1060, 1059, 10290, 10291, 9348, 78809, 78444, 78817, 1082, 10402, 10369, 
10403, 9349, 9332, 78421, 78446
28269, 964, 963, 10135, 10136, 9075, 9067, 77518, 77526, 986, 10247, 10214, 10248, 9351, 78810, 78448, 
78818, 9350, 9333, 78422, 78447
28270, 9075, 9067, 77518, 77526, 9076, 9068, 77519, 77527, 9351, 78810, 78448, 78818, 9353, 78811, 78451, 
78819, 9352, 9335, 78425, 78450
28271, 9076, 9068, 77519, 77527, 9077, 9069, 77520, 77528, 9353, 78811, 78451, 78819, 9355, 78812, 78454, 
78820, 9354, 9337, 78428, 78453
28272, 9077, 9069, 77520, 77528, 9078, 9070, 77521, 77529, 9355, 78812, 78454, 78820, 9357, 78813, 78457, 
78821, 9356, 9339, 78431, 78456
28273, 9078, 9070, 77521, 77529, 9079, 9071, 77522, 77530, 9357, 78813, 78457, 78821, 9359, 78814, 78460, 
78822, 9358, 9341, 78434, 78459
28274, 9079, 9071, 77522, 77530, 9080, 9072, 77523, 77531, 9359, 78814, 78460, 78822, 9361, 78815, 78463, 
78823, 9360, 9343, 78437, 78462
28275, 9080, 9072, 77523, 77531, 9081, 9073, 77524, 77532, 9361, 78815, 78463, 78823, 9363, 78816, 78466, 
78824, 9362, 9345, 78440, 78465
28276, 9081, 9073, 77524, 77532, 9082, 9074, 77525, 77533, 9363, 78816, 78466, 78824, 9365, 78817, 78469, 
78825, 9364, 9347, 78443, 78468
28277, 9082, 9074, 77525, 77533, 1061, 1060, 10291, 10292, 9365, 78817, 78469, 78825, 1083, 10403, 10371, 
10404, 9366, 9349, 78446, 78471
28278, 965, 964, 10136, 10137, 9083, 9075, 77526, 77534, 987, 10248, 10216, 10249, 9368, 78818, 78473, 
78826, 9367, 9350, 78447, 78472
28279, 9083, 9075, 77526, 77534, 9084, 9076, 77527, 77535, 9368, 78818, 78473, 78826, 9370, 78819, 78476, 
78827, 9369, 9352, 78450, 78475
28280, 9084, 9076, 77527, 77535, 9085, 9077, 77528, 77536, 9370, 78819, 78476, 78827, 9372, 78820, 78479, 
78828, 9371, 9354, 78453, 78478
28281, 9085, 9077, 77528, 77536, 9086, 9078, 77529, 77537, 9372, 78820, 78479, 78828, 9374, 78821, 78482, 
78829, 9373, 9356, 78456, 78481
28282, 9086, 9078, 77529, 77537, 9087, 9079, 77530, 77538, 9374, 78821, 78482, 78829, 9376, 78822, 78485, 
78830, 9375, 9358, 78459, 78484
28283, 9087, 9079, 77530, 77538, 9088, 9080, 77531, 77539, 9376, 78822, 78485, 78830, 9378, 78823, 78488, 
78831, 9377, 9360, 78462, 78487
28284, 9088, 9080, 77531, 77539, 9089, 9081, 77532, 77540, 9378, 78823, 78488, 78831, 9380, 78824, 78491, 
78832, 9379, 9362, 78465, 78490
28285, 9089, 9081, 77532, 77540, 9090, 9082, 77533, 77541, 9380, 78824, 78491, 78832, 9382, 78825, 78494, 
78833, 9381, 9364, 78468, 78493
28286, 9090, 9082, 77533, 77541, 1062, 1061, 10292, 10293, 9382, 78825, 78494, 78833, 1084, 10404, 10373, 
10405, 9383, 9366, 78471, 78496
28287, 966, 965, 10137, 10138, 9091, 9083, 77534, 77542, 988, 10249, 10218, 10250, 9385, 78826, 78498, 
78834, 9384, 9367, 78472, 78497
28288, 9091, 9083, 77534, 77542, 9092, 9084, 77535, 77543, 9385, 78826, 78498, 78834, 9387, 78827, 78501, 
78835, 9386, 9369, 78475, 78500
28289, 9092, 9084, 77535, 77543, 9093, 9085, 77536, 77544, 9387, 78827, 78501, 78835, 9389, 78828, 78504, 
78836, 9388, 9371, 78478, 78503
28290, 9093, 9085, 77536, 77544, 9094, 9086, 77537, 77545, 9389, 78828, 78504, 78836, 9391, 78829, 78507, 
78837, 9390, 9373, 78481, 78506
28291, 9094, 9086, 77537, 77545, 9095, 9087, 77538, 77546, 9391, 78829, 78507, 78837, 9393, 78830, 78510, 
78838, 9392, 9375, 78484, 78509
28292, 9095, 9087, 77538, 77546, 9096, 9088, 77539, 77547, 9393, 78830, 78510, 78838, 9395, 78831, 78513, 
78839, 9394, 9377, 78487, 78512
28293, 9096, 9088, 77539, 77547, 9097, 9089, 77540, 77548, 9395, 78831, 78513, 78839, 9397, 78832, 78516, 
78840, 9396, 9379, 78490, 78515
28294, 9097, 9089, 77540, 77548, 9098, 9090, 77541, 77549, 9397, 78832, 78516, 78840, 9399, 78833, 78519, 
78841, 9398, 9381, 78493, 78518
28295, 9098, 9090, 77541, 77549, 1063, 1062, 10293, 10294, 9399, 78833, 78519, 78841, 1085, 10405, 10375, 
10406, 9400, 9383, 78496, 78521
28296, 967, 966, 10138, 10139, 9099, 9091, 77542, 77550, 989, 10250, 10220, 10251, 9402, 78834, 78523, 
78842, 9401, 9384, 78497, 78522
28297, 9099, 9091, 77542, 77550, 9100, 9092, 77543, 77551, 9402, 78834, 78523, 78842, 9404, 78835, 78526, 
78843, 9403, 9386, 78500, 78525
28298, 9100, 9092, 77543, 77551, 9101, 9093, 77544, 77552, 9404, 78835, 78526, 78843, 9406, 78836, 78529, 
78844, 9405, 9388, 78503, 78528
28299, 9101, 9093, 77544, 77552, 9102, 9094, 77545, 77553, 9406, 78836, 78529, 78844, 9408, 78837, 78532, 
78845, 9407, 9390, 78506, 78531
28300, 9102, 9094, 77545, 77553, 9103, 9095, 77546, 77554, 9408, 78837, 78532, 78845, 9410, 78838, 78535, 
78846, 9409, 9392, 78509, 78534
28301, 9103, 9095, 77546, 77554, 9104, 9096, 77547, 77555, 9410, 78838, 78535, 78846, 9412, 78839, 78538, 
78847, 9411, 9394, 78512, 78537
28302, 9104, 9096, 77547, 77555, 9105, 9097, 77548, 77556, 9412, 78839, 78538, 78847, 9414, 78840, 78541, 
78848, 9413, 9396, 78515, 78540
28303, 9105, 9097, 77548, 77556, 9106, 9098, 77549, 77557, 9414, 78840, 78541, 78848, 9416, 78841, 78544, 
78849, 9415, 9398, 78518, 78543
28304, 9106, 9098, 77549, 77557, 1064, 1063, 10294, 10295, 9416, 78841, 78544, 78849, 1086, 10406, 10377, 
10407, 9417, 9400, 78521, 78546
28305, 968, 967, 10139, 10140, 9107, 9099, 77550, 77558, 990, 10251, 10222, 10252, 9419, 78842, 78548, 
78850, 9418, 9401, 78522, 78547
28306, 9107, 9099, 77550, 77558, 9108, 9100, 77551, 77559, 9419, 78842, 78548, 78850, 9421, 78843, 78551, 
78851, 9420, 9403, 78525, 78550
28307, 9108, 9100, 77551, 77559, 9109, 9101, 77552, 77560, 9421, 78843, 78551, 78851, 9423, 78844, 78554, 
78852, 9422, 9405, 78528, 78553
28308, 9109, 9101, 77552, 77560, 9110, 9102, 77553, 77561, 9423, 78844, 78554, 78852, 9425, 78845, 78557, 
78853, 9424, 9407, 78531, 78556
28309, 9110, 9102, 77553, 77561, 9111, 9103, 77554, 77562, 9425, 78845, 78557, 78853, 9427, 78846, 78560, 
78854, 9426, 9409, 78534, 78559
28310, 9111, 9103, 77554, 77562, 9112, 9104, 77555, 77563, 9427, 78846, 78560, 78854, 9429, 78847, 78563, 
78855, 9428, 9411, 78537, 78562
28311, 9112, 9104, 77555, 77563, 9113, 9105, 77556, 77564, 9429, 78847, 78563, 78855, 9431, 78848, 78566, 
78856, 9430, 9413, 78540, 78565
28312, 9113, 9105, 77556, 77564, 9114, 9106, 77557, 77565, 9431, 78848, 78566, 78856, 9433, 78849, 78569, 
78857, 9432, 9415, 78543, 78568
28313, 9114, 9106, 77557, 77565, 1065, 1064, 10295, 10296, 9433, 78849, 78569, 78857, 1087, 10407, 10379, 
10408, 9434, 9417, 78546, 78571
28314, 969, 968, 10140, 10141, 9115, 9107, 77558, 77566, 991, 10252, 10224, 10253, 9436, 78850, 78573, 
78858, 9435, 9418, 78547, 78572
28315, 9115, 9107, 77558, 77566, 9116, 9108, 77559, 77567, 9436, 78850, 78573, 78858, 9438, 78851, 78576, 
78859, 9437, 9420, 78550, 78575
28316, 9116, 9108, 77559, 77567, 9117, 9109, 77560, 77568, 9438, 78851, 78576, 78859, 9440, 78852, 78579, 
78860, 9439, 9422, 78553, 78578
28317, 9117, 9109, 77560, 77568, 9118, 9110, 77561, 77569, 9440, 78852, 78579, 78860, 9442, 78853, 78582, 
78861, 9441, 9424, 78556, 78581
28318, 9118, 9110, 77561, 77569, 9119, 9111, 77562, 77570, 9442, 78853, 78582, 78861, 9444, 78854, 78585, 
78862, 9443, 9426, 78559, 78584
28319, 9119, 9111, 77562, 77570, 9120, 9112, 77563, 77571, 9444, 78854, 78585, 78862, 9446, 78855, 78588, 
78863, 9445, 9428, 78562, 78587
28320, 9120, 9112, 77563, 77571, 9121, 9113, 77564, 77572, 9446, 78855, 78588, 78863, 9448, 78856, 78591, 
78864, 9447, 9430, 78565, 78590
28321, 9121, 9113, 77564, 77572, 9122, 9114, 77565, 77573, 9448, 78856, 78591, 78864, 9450, 78857, 78594, 
78865, 9449, 9432, 78568, 78593
28322, 9122, 9114, 77565, 77573, 1066, 1065, 10296, 10297, 9450, 78857, 78594, 78865, 1088, 10408, 10381, 
10409, 9451, 9434, 78571, 78596
28323, 970, 969, 10141, 10142, 9123, 9115, 77566, 77574, 992, 10253, 10226, 10254, 9453, 78858, 78598, 
78866, 9452, 9435, 78572, 78597
28324, 9123, 9115, 77566, 77574, 9124, 9116, 77567, 77575, 9453, 78858, 78598, 78866, 9455, 78859, 78601, 
78867, 9454, 9437, 78575, 78600
28325, 9124, 9116, 77567, 77575, 9125, 9117, 77568, 77576, 9455, 78859, 78601, 78867, 9457, 78860, 78604, 
78868, 9456, 9439, 78578, 78603
28326, 9125, 9117, 77568, 77576, 9126, 9118, 77569, 77577, 9457, 78860, 78604, 78868, 9459, 78861, 78607, 
78869, 9458, 9441, 78581, 78606
28327, 9126, 9118, 77569, 77577, 9127, 9119, 77570, 77578, 9459, 78861, 78607, 78869, 9461, 78862, 78610, 
78870, 9460, 9443, 78584, 78609
28328, 9127, 9119, 77570, 77578, 9128, 9120, 77571, 77579, 9461, 78862, 78610, 78870, 9463, 78863, 78613, 
78871, 9462, 9445, 78587, 78612
28329, 9128, 9120, 77571, 77579, 9129, 9121, 77572, 77580, 9463, 78863, 78613, 78871, 9465, 78864, 78616, 
78872, 9464, 9447, 78590, 78615
28330, 9129, 9121, 77572, 77580, 9130, 9122, 77573, 77581, 9465, 78864, 78616, 78872, 9467, 78865, 78619, 
78873, 9466, 9449, 78593, 78618
28331, 9130, 9122, 77573, 77581, 1067, 1066, 10297, 10298, 9467, 78865, 78619, 78873, 1089, 10409, 10383, 
10410, 9468, 9451, 78596, 78621
28332, 971, 970, 10142, 10143, 9131, 9123, 77574, 77582, 993, 10254, 10228, 10255, 9470, 78866, 78623, 
78874, 9469, 9452, 78597, 78622
28333, 9131, 9123, 77574, 77582, 9132, 9124, 77575, 77583, 9470, 78866, 78623, 78874, 9472, 78867, 78626, 
78875, 9471, 9454, 78600, 78625
28334, 9132, 9124, 77575, 77583, 9133, 9125, 77576, 77584, 9472, 78867, 78626, 78875, 9474, 78868, 78629, 
78876, 9473, 9456, 78603, 78628
28335, 9133, 9125, 77576, 77584, 9134, 9126, 77577, 77585, 9474, 78868, 78629, 78876, 9476, 78869, 78632, 
78877, 9475, 9458, 78606, 78631
28336, 9134, 9126, 77577, 77585, 9135, 9127, 77578, 77586, 9476, 78869, 78632, 78877, 9478, 78870, 78635, 
78878, 9477, 9460, 78609, 78634
28337, 9135, 9127, 77578, 77586, 9136, 9128, 77579, 77587, 9478, 78870, 78635, 78878, 9480, 78871, 78638, 
78879, 9479, 9462, 78612, 78637
28338, 9136, 9128, 77579, 77587, 9137, 9129, 77580, 77588, 9480, 78871, 78638, 78879, 9482, 78872, 78641, 
78880, 9481, 9464, 78615, 78640
28339, 9137, 9129, 77580, 77588, 9138, 9130, 77581, 77589, 9482, 78872, 78641, 78880, 9484, 78873, 78644, 
78881, 9483, 9466, 78618, 78643
28340, 9138, 9130, 77581, 77589, 1068, 1067, 10298, 10299, 9484, 78873, 78644, 78881, 1090, 10410, 10385, 
10411, 9485, 9468, 78621, 78646
28341, 972, 971, 10143, 10144, 9139, 9131, 77582, 77590, 994, 10255, 10230, 10256, 9487, 78874, 78648, 
78882, 9486, 9469, 78622, 78647
28342, 9139, 9131, 77582, 77590, 9140, 9132, 77583, 77591, 9487, 78874, 78648, 78882, 9489, 78875, 78651, 
78883, 9488, 9471, 78625, 78650
28343, 9140, 9132, 77583, 77591, 9141, 9133, 77584, 77592, 9489, 78875, 78651, 78883, 9491, 78876, 78654, 
78884, 9490, 9473, 78628, 78653
28344, 9141, 9133, 77584, 77592, 9142, 9134, 77585, 77593, 9491, 78876, 78654, 78884, 9493, 78877, 78657, 
78885, 9492, 9475, 78631, 78656
28345, 9142, 9134, 77585, 77593, 9143, 9135, 77586, 77594, 9493, 78877, 78657, 78885, 9495, 78878, 78660, 
78886, 9494, 9477, 78634, 78659
28346, 9143, 9135, 77586, 77594, 9144, 9136, 77587, 77595, 9495, 78878, 78660, 78886, 9497, 78879, 78663, 
78887, 9496, 9479, 78637, 78662
28347, 9144, 9136, 77587, 77595, 9145, 9137, 77588, 77596, 9497, 78879, 78663, 78887, 9499, 78880, 78666, 
78888, 9498, 9481, 78640, 78665
28348, 9145, 9137, 77588, 77596, 9146, 9138, 77589, 77597, 9499, 78880, 78666, 78888, 9501, 78881, 78669, 
78889, 9500, 9483, 78643, 78668
28349, 9146, 9138, 77589, 77597, 1069, 1068, 10299, 10300, 9501, 78881, 78669, 78889, 1091, 10411, 10387, 
10412, 9502, 9485, 78646, 78671
28350, 973, 972, 10144, 10145, 9147, 9139, 77590, 77598, 995, 10256, 10232, 10257, 9504, 78882, 78673, 
78890, 9503, 9486, 78647, 78672
28351, 9147, 9139, 77590, 77598, 9148, 9140, 77591, 77599, 9504, 78882, 78673, 78890, 9506, 78883, 78676, 
78891, 9505, 9488, 78650, 78675
28352, 9148, 9140, 77591, 77599, 9149, 9141, 77592, 77600, 9506, 78883, 78676, 78891, 9508, 78884, 78679, 
78892, 9507, 9490, 78653, 78678
28353, 9149, 9141, 77592, 77600, 9150, 9142, 77593, 77601, 9508, 78884, 78679, 78892, 9510, 78885, 78682, 
78893, 9509, 9492, 78656, 78681
28354, 9150, 9142, 77593, 77601, 9151, 9143, 77594, 77602, 9510, 78885, 78682, 78893, 9512, 78886, 78685, 
78894, 9511, 9494, 78659, 78684
28355, 9151, 9143, 77594, 77602, 9152, 9144, 77595, 77603, 9512, 78886, 78685, 78894, 9514, 78887, 78688, 
78895, 9513, 9496, 78662, 78687
28356, 9152, 9144, 77595, 77603, 9153, 9145, 77596, 77604, 9514, 78887, 78688, 78895, 9516, 78888, 78691, 
78896, 9515, 9498, 78665, 78690
28357, 9153, 9145, 77596, 77604, 9154, 9146, 77597, 77605, 9516, 78888, 78691, 78896, 9518, 78889, 78694, 
78897, 9517, 9500, 78668, 78693
28358, 9154, 9146, 77597, 77605, 1070, 1069, 10300, 10301, 9518, 78889, 78694, 78897, 1092, 10412, 10389, 
10413, 9519, 9502, 78671, 78696
28359, 974, 973, 10145, 10146, 9155, 9147, 77598, 77606, 996, 10257, 10234, 10258, 9521, 78890, 78698, 
78898, 9520, 9503, 78672, 78697
28360, 9155, 9147, 77598, 77606, 9156, 9148, 77599, 77607, 9521, 78890, 78698, 78898, 9523, 78891, 78701, 
78899, 9522, 9505, 78675, 78700
28361, 9156, 9148, 77599, 77607, 9157, 9149, 77600, 77608, 9523, 78891, 78701, 78899, 9525, 78892, 78704, 
78900, 9524, 9507, 78678, 78703
28362, 9157, 9149, 77600, 77608, 9158, 9150, 77601, 77609, 9525, 78892, 78704, 78900, 9527, 78893, 78707, 
78901, 9526, 9509, 78681, 78706
28363, 9158, 9150, 77601, 77609, 9159, 9151, 77602, 77610, 9527, 78893, 78707, 78901, 9529, 78894, 78710, 
78902, 9528, 9511, 78684, 78709
28364, 9159, 9151, 77602, 77610, 9160, 9152, 77603, 77611, 9529, 78894, 78710, 78902, 9531, 78895, 78713, 
78903, 9530, 9513, 78687, 78712
28365, 9160, 9152, 77603, 77611, 9161, 9153, 77604, 77612, 9531, 78895, 78713, 78903, 9533, 78896, 78716, 
78904, 9532, 9515, 78690, 78715
28366, 9161, 9153, 77604, 77612, 9162, 9154, 77605, 77613, 9533, 78896, 78716, 78904, 9535, 78897, 78719, 
78905, 9534, 9517, 78693, 78718
28367, 9162, 9154, 77605, 77613, 1071, 1070, 10301, 10302, 9535, 78897, 78719, 78905, 1093, 10413, 10391, 
10414, 9536, 9519, 78696, 78721
28368, 31, 974, 10146, 1180, 1147, 9155, 77606, 10481, 997, 10258, 10236, 1183, 9537, 78898, 78722, 
10523, 1156, 9520, 78697, 10506
28369, 1147, 9155, 77606, 10481, 1146, 9156, 77607, 10482, 9537, 78898, 78722, 10523, 9538, 78899, 78723, 
10524, 1155, 9522, 78700, 10508
28370, 1146, 9156, 77607, 10482, 1145, 9157, 77608, 10483, 9538, 78899, 78723, 10524, 9539, 78900, 78724, 
10525, 1154, 9524, 78703, 10510
28371, 1145, 9157, 77608, 10483, 1144, 9158, 77609, 10484, 9539, 78900, 78724, 10525, 9540, 78901, 78725, 
10526, 1153, 9526, 78706, 10512
28372, 1144, 9158, 77609, 10484, 1143, 9159, 77610, 10485, 9540, 78901, 78725, 10526, 9541, 78902, 78726, 
10527, 1152, 9528, 78709, 10514
28373, 1143, 9159, 77610, 10485, 1142, 9160, 77611, 10486, 9541, 78902, 78726, 10527, 9542, 78903, 78727, 
10528, 1151, 9530, 78712, 10516
28374, 1142, 9160, 77611, 10486, 1141, 9161, 77612, 10487, 9542, 78903, 78727, 10528, 9543, 78904, 78728, 
10529, 1150, 9532, 78715, 10518
28375, 1141, 9161, 77612, 10487, 1140, 9162, 77613, 10488, 9543, 78904, 78728, 10529, 9544, 78905, 78729, 
10530, 1149, 9534, 78718, 10520
28376, 1140, 9162, 77613, 10488, 33, 1071, 10302, 1235, 9544, 78905, 78729, 10530, 1094, 10414, 10392, 
1238, 1148, 9536, 78721, 10522
*ELEMENT, type=C3D20, ELSET=Volume12
28377, 36, 1318, 11089, 1179, 1308, 11107, 78906, 10473, 1319, 11092, 11091, 1181, 11116, 78923, 78924, 
10490, 1317, 11115, 78922, 10489
28378, 1308, 11107, 78906, 10473, 1307, 11108, 78907, 10474, 11116, 78923, 78924, 10490, 11118, 78926, 78927, 
10492, 1316, 11117, 78925, 10491
28379, 1307, 11108, 78907, 10474, 1306, 11109, 78908, 10475, 11118, 78926, 78927, 10492, 11120, 78929, 78930, 
10494, 1315, 11119, 78928, 10493
28380, 1306, 11109, 78908, 10475, 1305, 11110, 78909, 10476, 11120, 78929, 78930, 10494, 11122, 78932, 78933, 
10496, 1314, 11121, 78931, 10495
28381, 1305, 11110, 78909, 10476, 1304, 11111, 78910, 10477, 11122, 78932, 78933, 10496, 11124, 78935, 78936, 
10498, 1313, 11123, 78934, 10497
28382, 1304, 11111, 78910, 10477, 1303, 11112, 78911, 10478, 11124, 78935, 78936, 10498, 11126, 78938, 78939, 
10500, 1312, 11125, 78937, 10499
28383, 1303, 11112, 78911, 10478, 1302, 11113, 78912, 10479, 11126, 78938, 78939, 10500, 11128, 78941, 78942, 
10502, 1311, 11127, 78940, 10501
28384, 1302, 11113, 78912, 10479, 1301, 11114, 78913, 10480, 11128, 78941, 78942, 10502, 11130, 78944, 78945, 
10504, 1310, 11129, 78943, 10503
28385, 1301, 11114, 78913, 10480, 38, 1329, 11098, 1234, 11130, 78944, 78945, 10504, 1330, 11100, 11101, 
1236, 1309, 11131, 78946, 10505
28386, 1179, 11089, 11090, 1180, 10473, 78906, 78914, 10481, 11091, 11094, 11093, 1182, 78924, 78948, 78949, 
10507, 10489, 78922, 78947, 10506
28387, 10473, 78906, 78914, 10481, 10474, 78907, 78915, 10482, 78924, 78948, 78949, 10507, 78927, 78951, 78952, 
10509, 10491, 78925, 78950, 10508
28388, 10474, 78907, 78915, 10482, 10475, 78908, 78916, 10483, 78927, 78951, 78952, 10509, 78930, 78954, 78955, 
10511, 10493, 78928, 78953, 10510
28389, 10475, 78908, 78916, 10483, 10476, 78909, 78917, 10484, 78930, 78954, 78955, 10511, 78933, 78957, 78958, 
10513, 10495, 78931, 78956, 10512
28390, 10476, 78909, 78917, 10484, 10477, 78910, 78918, 10485, 78933, 78957, 78958, 10513, 78936, 78960, 78961, 
10515, 10497, 78934, 78959, 10514
28391, 10477, 78910, 78918, 10485, 10478, 78911, 78919, 10486, 78936, 78960, 78961, 10515, 78939, 78963, 78964, 
10517, 10499, 78937, 78962, 10516
28392, 10478, 78911, 78919, 10486, 10479, 78912, 78920, 10487, 78939, 78963, 78964, 10517, 78942, 78966, 78967, 
10519, 10501, 78940, 78965, 10518
28393, 10479, 78912, 78920, 10487, 10480, 78913, 78921, 10488, 78942, 78966, 78967, 10519, 78945, 78969, 78970, 
10521, 10503, 78943, 78968, 10520
28394, 10480, 78913, 78921, 10488, 1234, 11098, 11099, 1235, 78945, 78969, 78970, 10521, 11101, 11102, 11103, 
1237, 10505, 78946, 78971, 10522
28395, 1180, 11090, 1321, 31, 10481, 78914, 11140, 1147, 11093, 11095, 1322, 1183, 78949, 78972, 11148, 
10523, 10506, 78947, 11149, 1156
28396, 10481, 78914, 11140, 1147, 10482, 78915, 11141, 1146, 78949, 78972, 11148, 10523, 78952, 78973, 11150, 
10524, 10508, 78950, 11151, 1155
28397, 10482, 78915, 11141, 1146, 10483, 78916, 11142, 1145, 78952, 78973, 11150, 10524, 78955, 78974, 11152, 
10525, 10510, 78953, 11153, 1154
28398, 10483, 78916, 11142, 1145, 10484, 78917, 11143, 1144, 78955, 78974, 11152, 10525, 78958, 78975, 11154, 
10526, 10512, 78956, 11155, 1153
28399, 10484, 78917, 11143, 1144, 10485, 78918, 11144, 1143, 78958, 78975, 11154, 10526, 78961, 78976, 11156, 
10527, 10514, 78959, 11157, 1152
28400, 10485, 78918, 11144, 1143, 10486, 78919, 11145, 1142, 78961, 78976, 11156, 10527, 78964, 78977, 11158, 
10528, 10516, 78962, 11159, 1151
28401, 10486, 78919, 11145, 1142, 10487, 78920, 11146, 1141, 78964, 78977, 11158, 10528, 78967, 78978, 11160, 
10529, 10518, 78965, 11161, 1150
28402, 10487, 78920, 11146, 1141, 10488, 78921, 11147, 1140, 78967, 78978, 11160, 10529, 78970, 78979, 11162, 
10530, 10520, 78968, 11163, 1149
28403, 10488, 78921, 11147, 1140, 1235, 11099, 1332, 33, 78970, 78979, 11162, 10530, 11103, 11104, 1333, 
1238, 10522, 78971, 11164, 1148
28404, 1318, 39, 1324, 11089, 11107, 1347, 11173, 78906, 1320, 1326, 11096, 11092, 11132, 11190, 78980, 
78923, 11115, 1356, 11189, 78922
28405, 11107, 1347, 11173, 78906, 11108, 1346, 11174, 78907, 11132, 11190, 78980, 78923, 11133, 11192, 78981, 
78926, 11117, 1355, 11191, 78925
28406, 11108, 1346, 11174, 78907, 11109, 1345, 11175, 78908, 11133, 11192, 78981, 78926, 11134, 11194, 78982, 
78929, 11119, 1354, 11193, 78928
28407, 11109, 1345, 11175, 78908, 11110, 1344, 11176, 78909, 11134, 11194, 78982, 78929, 11135, 11196, 78983, 
78932, 11121, 1353, 11195, 78931
28408, 11110, 1344, 11176, 78909, 11111, 1343, 11177, 78910, 11135, 11196, 78983, 78932, 11136, 11198, 78984, 
78935, 11123, 1352, 11197, 78934
28409, 11111, 1343, 11177, 78910, 11112, 1342, 11178, 78911, 11136, 11198, 78984, 78935, 11137, 11200, 78985, 
78938, 11125, 1351, 11199, 78937
28410, 11112, 1342, 11178, 78911, 11113, 1341, 11179, 78912, 11137, 11200, 78985, 78938, 11138, 11202, 78986, 
78941, 11127, 1350, 11201, 78940
28411, 11113, 1341, 11179, 78912, 11114, 1340, 11180, 78913, 11138, 11202, 78986, 78941, 11139, 11204, 78987, 
78944, 11129, 1349, 11203, 78943
28412, 11114, 1340, 11180, 78913, 1329, 41, 1335, 11098, 11139, 11204, 78987, 78944, 1331, 1337, 11105, 
11100, 11131, 1348, 11205, 78946
28413, 11089, 1324, 1325, 11090, 78906, 11173, 11181, 78914, 11096, 1327, 11097, 11094, 78980, 11207, 78988, 
78948, 78922, 11189, 11206, 78947
28414, 78906, 11173, 11181, 78914, 78907, 11174, 11182, 78915, 78980, 11207, 78988, 78948, 78981, 11209, 78989, 
78951, 78925, 11191, 11208, 78950
28415, 78907, 11174, 11182, 78915, 78908, 11175, 11183, 78916, 78981, 11209, 78989, 78951, 78982, 11211, 78990, 
78954, 78928, 11193, 11210, 78953
28416, 78908, 11175, 11183, 78916, 78909, 11176, 11184, 78917, 78982, 11211, 78990, 78954, 78983, 11213, 78991, 
78957, 78931, 11195, 11212, 78956
28417, 78909, 11176, 11184, 78917, 78910, 11177, 11185, 78918, 78983, 11213, 78991, 78957, 78984, 11215, 78992, 
78960, 78934, 11197, 11214, 78959
28418, 78910, 11177, 11185, 78918, 78911, 11178, 11186, 78919, 78984, 11215, 78992, 78960, 78985, 11217, 78993, 
78963, 78937, 11199, 11216, 78962
28419, 78911, 11178, 11186, 78919, 78912, 11179, 11187, 78920, 78985, 11217, 78993, 78963, 78986, 11219, 78994, 
78966, 78940, 11201, 11218, 78965
28420, 78912, 11179, 11187, 78920, 78913, 11180, 11188, 78921, 78986, 11219, 78994, 78966, 78987, 11221, 78995, 
78969, 78943, 11203, 11220, 78968
28421, 78913, 11180, 11188, 78921, 11098, 1335, 1336, 11099, 78987, 11221, 78995, 78969, 11105, 1338, 11106, 
11102, 78946, 11205, 11222, 78971
28422, 11090, 1325, 40, 1321, 78914, 11181, 1364, 11140, 11097, 1328, 1323, 11095, 78988, 11223, 11165, 
78972, 78947, 11206, 1373, 11149
28423, 78914, 11181, 1364, 11140, 78915, 11182, 1363, 11141, 78988, 11223, 11165, 78972, 78989, 11224, 11166, 
78973, 78950, 11208, 1372, 11151
28424, 78915, 11182, 1363, 11141, 78916, 11183, 1362, 11142, 78989, 11224, 11166, 78973, 78990, 11225, 11167, 
78974, 78953, 11210, 1371, 11153
28425, 78916, 11183, 1362, 11142, 78917, 11184, 1361, 11143, 78990, 11225, 11167, 78974, 78991, 11226, 11168, 
78975, 78956, 11212, 1370, 11155
28426, 78917, 11184, 1361, 11143, 78918, 11185, 1360, 11144, 78991, 11226, 11168, 78975, 78992, 11227, 11169, 
78976, 78959, 11214, 1369, 11157
28427, 78918, 11185, 1360, 11144, 78919, 11186, 1359, 11145, 78992, 11227, 11169, 78976, 78993, 11228, 11170, 
78977, 78962, 11216, 1368, 11159
28428, 78919, 11186, 1359, 11145, 78920, 11187, 1358, 11146, 78993, 11228, 11170, 78977, 78994, 11229, 11171, 
78978, 78965, 11218, 1367, 11161
28429, 78920, 11187, 1358, 11146, 78921, 11188, 1357, 11147, 78994, 11229, 11171, 78978, 78995, 11230, 11172, 
78979, 78968, 11220, 1366, 11163
28430, 78921, 11188, 1357, 11147, 11099, 1336, 42, 1332, 78995, 11230, 11172, 78979, 11106, 1339, 1334, 
11104, 78971, 11222, 1365, 11164
*ELEMENT, type=C3D20, ELSET=Volume13
28431, 5154, 360, 11, 383, 78996, 5146, 363, 5243, 5162, 361, 392, 5163, 79013, 5150, 5285, 
79014, 79012, 5151, 365, 5281
28432, 78996, 5146, 363, 5243, 78997, 5145, 364, 5244, 79013, 5150, 5285, 79014, 79016, 5148, 5286, 
79017, 79015, 5149, 366, 5283
28433, 78997, 5145, 364, 5244, 5187, 357, 9, 420, 79016, 5148, 5286, 79017, 5196, 358, 429, 
5195, 79018, 5147, 367, 5284
28434, 5155, 5154, 383, 382, 78998, 78996, 5243, 5241, 5164, 5163, 391, 5165, 79020, 79014, 5280, 
79021, 79019, 79012, 5281, 5276
28435, 78998, 78996, 5243, 5241, 78999, 78997, 5244, 5242, 79020, 79014, 5280, 79021, 79023, 79017, 5282, 
79024, 79022, 79015, 5283, 5278
28436, 78999, 78997, 5244, 5242, 5188, 5187, 420, 419, 79023, 79017, 5282, 79024, 5198, 5195, 428, 
5197, 79025, 79018, 5284, 5279
28437, 5156, 5155, 382, 381, 79000, 78998, 5241, 5239, 5166, 5165, 390, 5167, 79027, 79021, 5275, 
79028, 79026, 79019, 5276, 5271
28438, 79000, 78998, 5241, 5239, 79001, 78999, 5242, 5240, 79027, 79021, 5275, 79028, 79030, 79024, 5277, 
79031, 79029, 79022, 5278, 5273
28439, 79001, 78999, 5242, 5240, 5189, 5188, 419, 418, 79030, 79024, 5277, 79031, 5200, 5197, 427, 
5199, 79032, 79025, 5279, 5274
28440, 5157, 5156, 381, 380, 79002, 79000, 5239, 5237, 5168, 5167, 389, 5169, 79034, 79028, 5270, 
79035, 79033, 79026, 5271, 5266
28441, 79002, 79000, 5239, 5237, 79003, 79001, 5240, 5238, 79034, 79028, 5270, 79035, 79037, 79031, 5272, 
79038, 79036, 79029, 5273, 5268
28442, 79003, 79001, 5240, 5238, 5190, 5189, 418, 417, 79037, 79031, 5272, 79038, 5202, 5199, 426, 
5201, 79039, 79032, 5274, 5269
28443, 5158, 5157, 380, 379, 79004, 79002, 5237, 5235, 5170, 5169, 388, 5171, 79041, 79035, 5265, 
79042, 79040, 79033, 5266, 5261
28444, 79004, 79002, 5237, 5235, 79005, 79003, 5238, 5236, 79041, 79035, 5265, 79042, 79044, 79038, 5267, 
79045, 79043, 79036, 5268, 5263
28445, 79005, 79003, 5238, 5236, 5191, 5190, 417, 416, 79044, 79038, 5267, 79045, 5204, 5201, 425, 
5203, 79046, 79039, 5269, 5264
28446, 5159, 5158, 379, 378, 79006, 79004, 5235, 5233, 5172, 5171, 387, 5173, 79048, 79042, 5260, 
79049, 79047, 79040, 5261, 5256
28447, 79006, 79004, 5235, 5233, 79007, 79005, 5236, 5234, 79048, 79042, 5260, 79049, 79051, 79045, 5262, 
79052, 79050, 79043, 5263, 5258
28448, 79007, 79005, 5236, 5234, 5192, 5191, 416, 415, 79051, 79045, 5262, 79052, 5206, 5203, 424, 
5205, 79053, 79046, 5264, 5259
28449, 5160, 5159, 378, 377, 79008, 79006, 5233, 5231, 5174, 5173, 386, 5175, 79055, 79049, 5255, 
79056, 79054, 79047, 5256, 5251
28450, 79008, 79006, 5233, 5231, 79009, 79007, 5234, 5232, 79055, 79049, 5255, 79056, 79058, 79052, 5257, 
79059, 79057, 79050, 5258, 5253
28451, 79009, 79007, 5234, 5232, 5193, 5192, 415, 414, 79058, 79052, 5257, 79059, 5208, 5205, 423, 
5207, 79060, 79053, 5259, 5254
28452, 5161, 5160, 377, 376, 79010, 79008, 5231, 5229, 5176, 5175, 385, 5177, 79062, 79056, 5250, 
79063, 79061, 79054, 5251, 5246
28453, 79010, 79008, 5231, 5229, 79011, 79009, 5232, 5230, 79062, 79056, 5250, 79063, 79065, 79059, 5252, 
79066, 79064, 79057, 5253, 5248
28454, 79011, 79009, 5232, 5230, 5194, 5193, 414, 413, 79065, 79059, 5252, 79066, 5210, 5207, 422, 
5209, 79067, 79060, 5254, 5249
28455, 373, 5161, 376, 13, 5221, 79010, 5229, 447, 5178, 5177, 384, 374, 79068, 79063, 5245, 
5224, 5226, 79061, 5246, 449
28456, 5221, 79010, 5229, 447, 5220, 79011, 5230, 448, 79068, 79063, 5245, 5224, 79069, 79066, 5247, 
5222, 5225, 79064, 5248, 450
28457, 5220, 79011, 5230, 448, 410, 5194, 413, 15, 79069, 79066, 5247, 5222, 5211, 5209, 421, 
411, 5223, 79067, 5249, 451
28458, 400, 12, 360, 5154, 5301, 368, 5146, 78996, 409, 362, 5162, 5179, 5343, 5153, 79013, 
79070, 5338, 370, 5151, 79012
28459, 5301, 368, 5146, 78996, 5302, 369, 5145, 78997, 5343, 5153, 79013, 79070, 5344, 5152, 79016, 
79071, 5340, 371, 5149, 79015
28460, 5302, 369, 5145, 78997, 437, 10, 357, 5187, 5344, 5152, 79016, 79071, 446, 359, 5196, 
5212, 5342, 372, 5147, 79018
28461, 399, 400, 5154, 5155, 5299, 5301, 78996, 78998, 408, 5179, 5164, 5180, 5339, 79070, 79020, 
79072, 5333, 5338, 79012, 79019
28462, 5299, 5301, 78996, 78998, 5300, 5302, 78997, 78999, 5339, 79070, 79020, 79072, 5341, 79071, 79023, 
79073, 5335, 5340, 79015, 79022
28463, 5300, 5302, 78997, 78999, 436, 437, 5187, 5188, 5341, 79071, 79023, 79073, 445, 5212, 5198, 
5213, 5337, 5342, 79018, 79025
28464, 398, 399, 5155, 5156, 5297, 5299, 78998, 79000, 407, 5180, 5166, 5181, 5334, 79072, 79027, 
79074, 5328, 5333, 79019, 79026
28465, 5297, 5299, 78998, 79000, 5298, 5300, 78999, 79001, 5334, 79072, 79027, 79074, 5336, 79073, 79030, 
79075, 5330, 5335, 79022, 79029
28466, 5298, 5300, 78999, 79001, 435, 436, 5188, 5189, 5336, 79073, 79030, 79075, 444, 5213, 5200, 
5214, 5332, 5337, 79025, 79032
28467, 397, 398, 5156, 5157, 5295, 5297, 79000, 79002, 406, 5181, 5168, 5182, 5329, 79074, 79034, 
79076, 5323, 5328, 79026, 79033
28468, 5295, 5297, 79000, 79002, 5296, 5298, 79001, 79003, 5329, 79074, 79034, 79076, 5331, 79075, 79037, 
79077, 5325, 5330, 79029, 79036
28469, 5296, 5298, 79001, 79003, 434, 435, 5189, 5190, 5331, 79075, 79037, 79077, 443, 5214, 5202, 
5215, 5327, 5332, 79032, 79039
28470, 396, 397, 5157, 5158, 5293, 5295, 79002, 79004, 405, 5182, 5170, 5183, 5324, 79076, 79041, 
79078, 5318, 5323, 79033, 79040
28471, 5293, 5295, 79002, 79004, 5294, 5296, 79003, 79005, 5324, 79076, 79041, 79078, 5326, 79077, 79044, 
79079, 5320, 5325, 79036, 79043
28472, 5294, 5296, 79003, 79005, 433, 434, 5190, 5191, 5326, 79077, 79044, 79079, 442, 5215, 5204, 
5216, 5322, 5327, 79039, 79046
28473, 395, 396, 5158, 5159, 5291, 5293, 79004, 79006, 404, 5183, 5172, 5184, 5319, 79078, 79048, 
79080, 5313, 5318, 79040, 79047
28474, 5291, 5293, 79004, 79006, 5292, 5294, 79005, 79007, 5319, 79078, 79048, 79080, 5321, 79079, 79051, 
79081, 5315, 5320, 79043, 79050
28475, 5292, 5294, 79005, 79007, 432, 433, 5191, 5192, 5321, 79079, 79051, 79081, 441, 5216, 5206, 
5217, 5317, 5322, 79046, 79053
28476, 394, 395, 5159, 5160, 5289, 5291, 79006, 79008, 403, 5184, 5174, 5185, 5314, 79080, 79055, 
79082, 5308, 5313, 79047, 79054
28477, 5289, 5291, 79006, 79008, 5290, 5292, 79007, 79009, 5314, 79080, 79055, 79082, 5316, 79081, 79058, 
79083, 5310, 5315, 79050, 79057
28478, 5290, 5292, 79007, 79009, 431, 432, 5192, 5193, 5316, 79081, 79058, 79083, 440, 5217, 5208, 
5218, 5312, 5317, 79053, 79060
28479, 393, 394, 5160, 5161, 5287, 5289, 79008, 79010, 402, 5185, 5176, 5186, 5309, 79082, 79062, 
79084, 5303, 5308, 79054, 79061
28480, 5287, 5289, 79008, 79010, 5288, 5290, 79009, 79011, 5309, 79082, 79062, 79084, 5311, 79083, 79065, 
79085, 5305, 5310, 79057, 79064
28481, 5288, 5290, 79009, 79011, 430, 431, 5193, 5194, 5311, 79083, 79065, 79085, 439, 5218, 5210, 
5219, 5307, 5312, 79060, 79067
28482, 14, 393, 5161, 373, 452, 5287, 79010, 5221, 401, 5186, 5178, 375, 5304, 79084, 79068, 
5228, 454, 5303, 79061, 5226
28483, 452, 5287, 79010, 5221, 453, 5288, 79011, 5220, 5304, 79084, 79068, 5228, 5306, 79085, 79069, 
5227, 455, 5305, 79064, 5225
28484, 453, 5288, 79011, 5220, 16, 430, 5194, 410, 5306, 79085, 79069, 5227, 438, 5219, 5211, 
412, 456, 5307, 79067, 5223
*ELEMENT, type=C3D20, ELSET=Volume20
28485, 46, 1772, 13502, 1487, 1533, 13260, 79086, 12527, 1775, 13569, 13568, 1510, 13292, 79615, 79616, 
12909, 1541, 13293, 79614, 12893
28486, 1533, 13260, 79086, 12527, 1534, 13259, 79087, 12528, 13292, 79615, 79616, 12909, 13290, 79618, 79619, 
12910, 1542, 13291, 79617, 12895
28487, 1534, 13259, 79087, 12528, 1535, 13258, 79088, 12529, 13290, 79618, 79619, 12910, 13288, 79621, 79622, 
12911, 1543, 13289, 79620, 12897
28488, 1535, 13258, 79088, 12529, 1536, 13257, 79089, 12530, 13288, 79621, 79622, 12911, 13286, 79624, 79625, 
12912, 1544, 13287, 79623, 12899
28489, 1536, 13257, 79089, 12530, 1537, 13256, 79090, 12531, 13286, 79624, 79625, 12912, 13284, 79627, 79628, 
12913, 1545, 13285, 79626, 12901
28490, 1537, 13256, 79090, 12531, 1538, 13255, 79091, 12532, 13284, 79627, 79628, 12913, 13282, 79630, 79631, 
12914, 1546, 13283, 79629, 12903
28491, 1538, 13255, 79091, 12532, 1539, 13254, 79092, 12533, 13282, 79630, 79631, 12914, 13280, 79633, 79634, 
12915, 1547, 13281, 79632, 12905
28492, 1539, 13254, 79092, 12533, 1540, 13253, 79093, 12534, 13280, 79633, 79634, 12915, 13278, 79636, 79637, 
12916, 1548, 13279, 79635, 12907
28493, 1540, 13253, 79093, 12534, 50, 1751, 13725, 1621, 13278, 79636, 79637, 12916, 1754, 13791, 13792, 
1644, 1549, 13277, 79638, 12908
28494, 1487, 13502, 13503, 1486, 12527, 79086, 79094, 12519, 13568, 13571, 13570, 1509, 79616, 79640, 79641, 
12892, 12893, 79614, 79639, 12876
28495, 12527, 79086, 79094, 12519, 12528, 79087, 79095, 12520, 79616, 79640, 79641, 12892, 79619, 79643, 79644, 
12894, 12895, 79617, 79642, 12878
28496, 12528, 79087, 79095, 12520, 12529, 79088, 79096, 12521, 79619, 79643, 79644, 12894, 79622, 79646, 79647, 
12896, 12897, 79620, 79645, 12880
28497, 12529, 79088, 79096, 12521, 12530, 79089, 79097, 12522, 79622, 79646, 79647, 12896, 79625, 79649, 79650, 
12898, 12899, 79623, 79648, 12882
28498, 12530, 79089, 79097, 12522, 12531, 79090, 79098, 12523, 79625, 79649, 79650, 12898, 79628, 79652, 79653, 
12900, 12901, 79626, 79651, 12884
28499, 12531, 79090, 79098, 12523, 12532, 79091, 79099, 12524, 79628, 79652, 79653, 12900, 79631, 79655, 79656, 
12902, 12903, 79629, 79654, 12886
28500, 12532, 79091, 79099, 12524, 12533, 79092, 79100, 12525, 79631, 79655, 79656, 12902, 79634, 79658, 79659, 
12904, 12905, 79632, 79657, 12888
28501, 12533, 79092, 79100, 12525, 12534, 79093, 79101, 12526, 79634, 79658, 79659, 12904, 79637, 79661, 79662, 
12906, 12907, 79635, 79660, 12890
28502, 12534, 79093, 79101, 12526, 1621, 13725, 13726, 1620, 79637, 79661, 79662, 12906, 13792, 13793, 13794, 
1643, 12908, 79638, 79663, 12891
28503, 1486, 13503, 13504, 1485, 12519, 79094, 79102, 12511, 13570, 13573, 13572, 1508, 79641, 79665, 79666, 
12875, 12876, 79639, 79664, 12859
28504, 12519, 79094, 79102, 12511, 12520, 79095, 79103, 12512, 79641, 79665, 79666, 12875, 79644, 79668, 79669, 
12877, 12878, 79642, 79667, 12861
28505, 12520, 79095, 79103, 12512, 12521, 79096, 79104, 12513, 79644, 79668, 79669, 12877, 79647, 79671, 79672, 
12879, 12880, 79645, 79670, 12863
28506, 12521, 79096, 79104, 12513, 12522, 79097, 79105, 12514, 79647, 79671, 79672, 12879, 79650, 79674, 79675, 
12881, 12882, 79648, 79673, 12865
28507, 12522, 79097, 79105, 12514, 12523, 79098, 79106, 12515, 79650, 79674, 79675, 12881, 79653, 79677, 79678, 
12883, 12884, 79651, 79676, 12867
28508, 12523, 79098, 79106, 12515, 12524, 79099, 79107, 12516, 79653, 79677, 79678, 12883, 79656, 79680, 79681, 
12885, 12886, 79654, 79679, 12869
28509, 12524, 79099, 79107, 12516, 12525, 79100, 79108, 12517, 79656, 79680, 79681, 12885, 79659, 79683, 79684, 
12887, 12888, 79657, 79682, 12871
28510, 12525, 79100, 79108, 12517, 12526, 79101, 79109, 12518, 79659, 79683, 79684, 12887, 79662, 79686, 79687, 
12889, 12890, 79660, 79685, 12873
28511, 12526, 79101, 79109, 12518, 1620, 13726, 13727, 1619, 79662, 79686, 79687, 12889, 13794, 13795, 13796, 
1642, 12891, 79663, 79688, 12874
28512, 1485, 13504, 13505, 1484, 12511, 79102, 79110, 12503, 13572, 13575, 13574, 1507, 79666, 79690, 79691, 
12858, 12859, 79664, 79689, 12842
28513, 12511, 79102, 79110, 12503, 12512, 79103, 79111, 12504, 79666, 79690, 79691, 12858, 79669, 79693, 79694, 
12860, 12861, 79667, 79692, 12844
28514, 12512, 79103, 79111, 12504, 12513, 79104, 79112, 12505, 79669, 79693, 79694, 12860, 79672, 79696, 79697, 
12862, 12863, 79670, 79695, 12846
28515, 12513, 79104, 79112, 12505, 12514, 79105, 79113, 12506, 79672, 79696, 79697, 12862, 79675, 79699, 79700, 
12864, 12865, 79673, 79698, 12848
28516, 12514, 79105, 79113, 12506, 12515, 79106, 79114, 12507, 79675, 79699, 79700, 12864, 79678, 79702, 79703, 
12866, 12867, 79676, 79701, 12850
28517, 12515, 79106, 79114, 12507, 12516, 79107, 79115, 12508, 79678, 79702, 79703, 12866, 79681, 79705, 79706, 
12868, 12869, 79679, 79704, 12852
28518, 12516, 79107, 79115, 12508, 12517, 79108, 79116, 12509, 79681, 79705, 79706, 12868, 79684, 79708, 79709, 
12870, 12871, 79682, 79707, 12854
28519, 12517, 79108, 79116, 12509, 12518, 79109, 79117, 12510, 79684, 79708, 79709, 12870, 79687, 79711, 79712, 
12872, 12873, 79685, 79710, 12856
28520, 12518, 79109, 79117, 12510, 1619, 13727, 13728, 1618, 79687, 79711, 79712, 12872, 13796, 13797, 13798, 
1641, 12874, 79688, 79713, 12857
28521, 1484, 13505, 13506, 1483, 12503, 79110, 79118, 12495, 13574, 13577, 13576, 1506, 79691, 79715, 79716, 
12841, 12842, 79689, 79714, 12825
28522, 12503, 79110, 79118, 12495, 12504, 79111, 79119, 12496, 79691, 79715, 79716, 12841, 79694, 79718, 79719, 
12843, 12844, 79692, 79717, 12827
28523, 12504, 79111, 79119, 12496, 12505, 79112, 79120, 12497, 79694, 79718, 79719, 12843, 79697, 79721, 79722, 
12845, 12846, 79695, 79720, 12829
28524, 12505, 79112, 79120, 12497, 12506, 79113, 79121, 12498, 79697, 79721, 79722, 12845, 79700, 79724, 79725, 
12847, 12848, 79698, 79723, 12831
28525, 12506, 79113, 79121, 12498, 12507, 79114, 79122, 12499, 79700, 79724, 79725, 12847, 79703, 79727, 79728, 
12849, 12850, 79701, 79726, 12833
28526, 12507, 79114, 79122, 12499, 12508, 79115, 79123, 12500, 79703, 79727, 79728, 12849, 79706, 79730, 79731, 
12851, 12852, 79704, 79729, 12835
28527, 12508, 79115, 79123, 12500, 12509, 79116, 79124, 12501, 79706, 79730, 79731, 12851, 79709, 79733, 79734, 
12853, 12854, 79707, 79732, 12837
28528, 12509, 79116, 79124, 12501, 12510, 79117, 79125, 12502, 79709, 79733, 79734, 12853, 79712, 79736, 79737, 
12855, 12856, 79710, 79735, 12839
28529, 12510, 79117, 79125, 12502, 1618, 13728, 13729, 1617, 79712, 79736, 79737, 12855, 13798, 13799, 13800, 
1640, 12857, 79713, 79738, 12840
28530, 1483, 13506, 13507, 1482, 12495, 79118, 79126, 12487, 13576, 13579, 13578, 1505, 79716, 79740, 79741, 
12824, 12825, 79714, 79739, 12808
28531, 12495, 79118, 79126, 12487, 12496, 79119, 79127, 12488, 79716, 79740, 79741, 12824, 79719, 79743, 79744, 
12826, 12827, 79717, 79742, 12810
28532, 12496, 79119, 79127, 12488, 12497, 79120, 79128, 12489, 79719, 79743, 79744, 12826, 79722, 79746, 79747, 
12828, 12829, 79720, 79745, 12812
28533, 12497, 79120, 79128, 12489, 12498, 79121, 79129, 12490, 79722, 79746, 79747, 12828, 79725, 79749, 79750, 
12830, 12831, 79723, 79748, 12814
28534, 12498, 79121, 79129, 12490, 12499, 79122, 79130, 12491, 79725, 79749, 79750, 12830, 79728, 79752, 79753, 
12832, 12833, 79726, 79751, 12816
28535, 12499, 79122, 79130, 12491, 12500, 79123, 79131, 12492, 79728, 79752, 79753, 12832, 79731, 79755, 79756, 
12834, 12835, 79729, 79754, 12818
28536, 12500, 79123, 79131, 12492, 12501, 79124, 79132, 12493, 79731, 79755, 79756, 12834, 79734, 79758, 79759, 
12836, 12837, 79732, 79757, 12820
28537, 12501, 79124, 79132, 12493, 12502, 79125, 79133, 12494, 79734, 79758, 79759, 12836, 79737, 79761, 79762, 
12838, 12839, 79735, 79760, 12822
