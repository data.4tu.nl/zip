90084, 1.3739130434783, 0.075, 0.083333333333333
90085, 1.3521739130435, 0.075, 0.055555555555556
90086, 1.3739130434783, 0.0625, 0.055555555555556
90087, 1.3739130434783, 0.075, 0.027777777777778
90088, 1.4173913043478, 0.075, 0.47222222222222
90089, 1.395652173913, 0.075, 0.44444444444444
90090, 1.4173913043478, 0.0625, 0.44444444444444
90091, 1.4173913043478, 0.075, 0.41666666666667
90092, 1.395652173913, 0.075, 0.38888888888889
90093, 1.4173913043478, 0.0625, 0.38888888888889
90094, 1.4173913043478, 0.075, 0.36111111111111
90095, 1.395652173913, 0.075, 0.33333333333333
90096, 1.4173913043478, 0.0625, 0.33333333333333
90097, 1.4173913043478, 0.075, 0.30555555555556
90098, 1.395652173913, 0.075, 0.27777777777778
90099, 1.4173913043478, 0.0625, 0.27777777777778
90100, 1.4173913043478, 0.075, 0.25
90101, 1.395652173913, 0.075, 0.22222222222222
90102, 1.4173913043478, 0.0625, 0.22222222222222
90103, 1.4173913043478, 0.075, 0.19444444444444
90104, 1.395652173913, 0.075, 0.16666666666667
90105, 1.4173913043478, 0.0625, 0.16666666666667
90106, 1.4173913043478, 0.075, 0.13888888888889
90107, 1.395652173913, 0.075, 0.11111111111111
90108, 1.4173913043478, 0.0625, 0.11111111111111
90109, 1.4173913043478, 0.075, 0.083333333333333
90110, 1.395652173913, 0.075, 0.055555555555556
90111, 1.4173913043478, 0.0625, 0.055555555555556
90112, 1.4173913043478, 0.075, 0.027777777777778
90113, 1.4608695652174, 0.075, 0.47222222222222
90114, 1.4391304347826, 0.075, 0.44444444444444
90115, 1.4608695652174, 0.0625, 0.44444444444444
90116, 1.4608695652174, 0.075, 0.41666666666667
90117, 1.4391304347826, 0.075, 0.38888888888889
90118, 1.4608695652174, 0.0625, 0.38888888888889
90119, 1.4608695652174, 0.075, 0.36111111111111
90120, 1.4391304347826, 0.075, 0.33333333333333
90121, 1.4608695652174, 0.0625, 0.33333333333333
90122, 1.4608695652174, 0.075, 0.30555555555556
90123, 1.4391304347826, 0.075, 0.27777777777778
90124, 1.4608695652174, 0.0625, 0.27777777777778
90125, 1.4608695652174, 0.075, 0.25
90126, 1.4391304347826, 0.075, 0.22222222222222
90127, 1.4608695652174, 0.0625, 0.22222222222222
90128, 1.4608695652174, 0.075, 0.19444444444444
90129, 1.4391304347826, 0.075, 0.16666666666667
90130, 1.4608695652174, 0.0625, 0.16666666666667
90131, 1.4608695652174, 0.075, 0.13888888888889
90132, 1.4391304347826, 0.075, 0.11111111111111
90133, 1.4608695652174, 0.0625, 0.11111111111111
90134, 1.4608695652174, 0.075, 0.083333333333333
90135, 1.4391304347826, 0.075, 0.055555555555556
90136, 1.4608695652174, 0.0625, 0.055555555555556
90137, 1.4608695652174, 0.075, 0.027777777777778
90138, 1.504347826087, 0.075, 0.47222222222222
90139, 1.4826086956522, 0.075, 0.44444444444444
90140, 1.504347826087, 0.0625, 0.44444444444444
90141, 1.504347826087, 0.075, 0.41666666666667
90142, 1.4826086956522, 0.075, 0.38888888888889
90143, 1.504347826087, 0.0625, 0.38888888888889
90144, 1.504347826087, 0.075, 0.36111111111111
90145, 1.4826086956522, 0.075, 0.33333333333333
90146, 1.504347826087, 0.0625, 0.33333333333333
90147, 1.504347826087, 0.075, 0.30555555555556
90148, 1.4826086956522, 0.075, 0.27777777777778
90149, 1.504347826087, 0.0625, 0.27777777777778
90150, 1.504347826087, 0.075, 0.25
90151, 1.4826086956522, 0.075, 0.22222222222222
90152, 1.504347826087, 0.0625, 0.22222222222222
90153, 1.504347826087, 0.075, 0.19444444444444
90154, 1.4826086956522, 0.075, 0.16666666666667
90155, 1.504347826087, 0.0625, 0.16666666666667
90156, 1.504347826087, 0.075, 0.13888888888889
90157, 1.4826086956522, 0.075, 0.11111111111111
90158, 1.504347826087, 0.0625, 0.11111111111111
90159, 1.504347826087, 0.075, 0.083333333333333
90160, 1.4826086956522, 0.075, 0.055555555555556
90161, 1.504347826087, 0.0625, 0.055555555555556
90162, 1.504347826087, 0.075, 0.027777777777778
90163, 1.5478260869565, 0.075, 0.47222222222222
90164, 1.5260869565217, 0.075, 0.44444444444444
90165, 1.5478260869565, 0.0625, 0.44444444444444
90166, 1.5478260869565, 0.075, 0.41666666666667
90167, 1.5260869565217, 0.075, 0.38888888888889
90168, 1.5478260869565, 0.0625, 0.38888888888889
90169, 1.5478260869565, 0.075, 0.36111111111111
90170, 1.5260869565217, 0.075, 0.33333333333333
90171, 1.5478260869565, 0.0625, 0.33333333333333
90172, 1.5478260869565, 0.075, 0.30555555555556
90173, 1.5260869565217, 0.075, 0.27777777777778
90174, 1.5478260869565, 0.0625, 0.27777777777778
90175, 1.5478260869565, 0.075, 0.25
90176, 1.5260869565217, 0.075, 0.22222222222222
90177, 1.5478260869565, 0.0625, 0.22222222222222
90178, 1.5478260869565, 0.075, 0.19444444444444
90179, 1.5260869565217, 0.075, 0.16666666666667
90180, 1.5478260869565, 0.0625, 0.16666666666667
90181, 1.5478260869565, 0.075, 0.13888888888889
90182, 1.5260869565217, 0.075, 0.11111111111111
90183, 1.5478260869565, 0.0625, 0.11111111111111
90184, 1.5478260869565, 0.075, 0.083333333333333
90185, 1.5260869565217, 0.075, 0.055555555555556
90186, 1.5478260869565, 0.0625, 0.055555555555556
90187, 1.5478260869565, 0.075, 0.027777777777778
90188, 1.5913043478261, 0.075, 0.47222222222222
90189, 1.5695652173913, 0.075, 0.44444444444444
90190, 1.5913043478261, 0.0625, 0.44444444444444
90191, 1.5913043478261, 0.075, 0.41666666666667
90192, 1.5695652173913, 0.075, 0.38888888888889
90193, 1.5913043478261, 0.0625, 0.38888888888889
90194, 1.5913043478261, 0.075, 0.36111111111111
90195, 1.5695652173913, 0.075, 0.33333333333333
90196, 1.5913043478261, 0.0625, 0.33333333333333
90197, 1.5913043478261, 0.075, 0.30555555555556
90198, 1.5695652173913, 0.075, 0.27777777777778
90199, 1.5913043478261, 0.0625, 0.27777777777778
90200, 1.5913043478261, 0.075, 0.25
90201, 1.5695652173913, 0.075, 0.22222222222222
90202, 1.5913043478261, 0.0625, 0.22222222222222
90203, 1.5913043478261, 0.075, 0.19444444444444
90204, 1.5695652173913, 0.075, 0.16666666666667
90205, 1.5913043478261, 0.0625, 0.16666666666667
90206, 1.5913043478261, 0.075, 0.13888888888889
90207, 1.5695652173913, 0.075, 0.11111111111111
90208, 1.5913043478261, 0.0625, 0.11111111111111
90209, 1.5913043478261, 0.075, 0.083333333333333
90210, 1.5695652173913, 0.075, 0.055555555555556
90211, 1.5913043478261, 0.0625, 0.055555555555556
90212, 1.5913043478261, 0.075, 0.027777777777778
90213, 1.6347826086957, 0.075, 0.47222222222222
90214, 1.6130434782609, 0.075, 0.44444444444444
90215, 1.6347826086957, 0.0625, 0.44444444444444
90216, 1.6347826086957, 0.075, 0.41666666666667
90217, 1.6130434782609, 0.075, 0.38888888888889
90218, 1.6347826086957, 0.0625, 0.38888888888889
90219, 1.6347826086957, 0.075, 0.36111111111111
90220, 1.6130434782609, 0.075, 0.33333333333333
90221, 1.6347826086957, 0.0625, 0.33333333333333
90222, 1.6347826086957, 0.075, 0.30555555555556
90223, 1.6130434782609, 0.075, 0.27777777777778
90224, 1.6347826086957, 0.0625, 0.27777777777778
90225, 1.6347826086957, 0.075, 0.25
90226, 1.6130434782609, 0.075, 0.22222222222222
90227, 1.6347826086957, 0.0625, 0.22222222222222
90228, 1.6347826086957, 0.075, 0.19444444444444
90229, 1.6130434782609, 0.075, 0.16666666666667
90230, 1.6347826086957, 0.0625, 0.16666666666667
90231, 1.6347826086957, 0.075, 0.13888888888889
90232, 1.6130434782609, 0.075, 0.11111111111111
90233, 1.6347826086957, 0.0625, 0.11111111111111
90234, 1.6347826086957, 0.075, 0.083333333333333
90235, 1.6130434782609, 0.075, 0.055555555555556
90236, 1.6347826086957, 0.0625, 0.055555555555556
90237, 1.6347826086957, 0.075, 0.027777777777778
90238, 1.6782608695652, 0.075, 0.47222222222222
90239, 1.6565217391304, 0.075, 0.44444444444444
90240, 1.6782608695652, 0.0625, 0.44444444444444
90241, 1.6782608695652, 0.075, 0.41666666666667
90242, 1.6565217391304, 0.075, 0.38888888888889
90243, 1.6782608695652, 0.0625, 0.38888888888889
90244, 1.6782608695652, 0.075, 0.36111111111111
90245, 1.6565217391304, 0.075, 0.33333333333333
90246, 1.6782608695652, 0.0625, 0.33333333333333
90247, 1.6782608695652, 0.075, 0.30555555555556
90248, 1.6565217391304, 0.075, 0.27777777777778
90249, 1.6782608695652, 0.0625, 0.27777777777778
90250, 1.6782608695652, 0.075, 0.25
90251, 1.6565217391304, 0.075, 0.22222222222222
90252, 1.6782608695652, 0.0625, 0.22222222222222
90253, 1.6782608695652, 0.075, 0.19444444444444
90254, 1.6565217391304, 0.075, 0.16666666666667
90255, 1.6782608695652, 0.0625, 0.16666666666667
90256, 1.6782608695652, 0.075, 0.13888888888889
90257, 1.6565217391304, 0.075, 0.11111111111111
90258, 1.6782608695652, 0.0625, 0.11111111111111
90259, 1.6782608695652, 0.075, 0.083333333333333
90260, 1.6565217391304, 0.075, 0.055555555555556
90261, 1.6782608695652, 0.0625, 0.055555555555556
90262, 1.6782608695652, 0.075, 0.027777777777778
90263, 1.7217391304348, 0.075, 0.47222222222222
90264, 1.7, 0.075, 0.44444444444444
90265, 1.7217391304348, 0.0625, 0.44444444444444
90266, 1.7217391304348, 0.075, 0.41666666666667
90267, 1.7, 0.075, 0.38888888888889
90268, 1.7217391304348, 0.0625, 0.38888888888889
90269, 1.7217391304348, 0.075, 0.36111111111111
90270, 1.7, 0.075, 0.33333333333333
90271, 1.7217391304348, 0.0625, 0.33333333333333
90272, 1.7217391304348, 0.075, 0.30555555555556
90273, 1.7, 0.075, 0.27777777777778
90274, 1.7217391304348, 0.0625, 0.27777777777778
90275, 1.7217391304348, 0.075, 0.25
90276, 1.7, 0.075, 0.22222222222222
90277, 1.7217391304348, 0.0625, 0.22222222222222
90278, 1.7217391304348, 0.075, 0.19444444444444
90279, 1.7, 0.075, 0.16666666666667
90280, 1.7217391304348, 0.0625, 0.16666666666667
90281, 1.7217391304348, 0.075, 0.13888888888889
90282, 1.7, 0.075, 0.11111111111111
90283, 1.7217391304348, 0.0625, 0.11111111111111
90284, 1.7217391304348, 0.075, 0.083333333333333
90285, 1.7, 0.075, 0.055555555555556
90286, 1.7217391304348, 0.0625, 0.055555555555556
90287, 1.7217391304348, 0.075, 0.027777777777778
90288, 1.7652173913043, 0.075, 0.47222222222222
90289, 1.7434782608696, 0.075, 0.44444444444444
90290, 1.7652173913043, 0.0625, 0.44444444444444
90291, 1.7652173913043, 0.075, 0.41666666666667
90292, 1.7434782608696, 0.075, 0.38888888888889
90293, 1.7652173913043, 0.0625, 0.38888888888889
90294, 1.7652173913043, 0.075, 0.36111111111111
90295, 1.7434782608696, 0.075, 0.33333333333333
90296, 1.7652173913043, 0.0625, 0.33333333333333
90297, 1.7652173913043, 0.075, 0.30555555555556
90298, 1.7434782608696, 0.075, 0.27777777777778
90299, 1.7652173913043, 0.0625, 0.27777777777778
90300, 1.7652173913043, 0.075, 0.25
90301, 1.7434782608696, 0.075, 0.22222222222222
90302, 1.7652173913043, 0.0625, 0.22222222222222
90303, 1.7652173913043, 0.075, 0.19444444444444
90304, 1.7434782608696, 0.075, 0.16666666666667
90305, 1.7652173913043, 0.0625, 0.16666666666667
90306, 1.7652173913043, 0.075, 0.13888888888889
90307, 1.7434782608696, 0.075, 0.11111111111111
90308, 1.7652173913043, 0.0625, 0.11111111111111
90309, 1.7652173913043, 0.075, 0.083333333333333
90310, 1.7434782608696, 0.075, 0.055555555555556
90311, 1.7652173913043, 0.0625, 0.055555555555556
90312, 1.7652173913043, 0.075, 0.027777777777778
90313, 1.8086956521739, 0.075, 0.47222222222222
90314, 1.7869565217391, 0.075, 0.44444444444444
90315, 1.8086956521739, 0.0625, 0.44444444444444
90316, 1.8086956521739, 0.075, 0.41666666666667
90317, 1.7869565217391, 0.075, 0.38888888888889
90318, 1.8086956521739, 0.0625, 0.38888888888889
90319, 1.8086956521739, 0.075, 0.36111111111111
90320, 1.7869565217391, 0.075, 0.33333333333333
90321, 1.8086956521739, 0.0625, 0.33333333333333
90322, 1.8086956521739, 0.075, 0.30555555555556
90323, 1.7869565217391, 0.075, 0.27777777777778
90324, 1.8086956521739, 0.0625, 0.27777777777778
90325, 1.8086956521739, 0.075, 0.25
90326, 1.7869565217391, 0.075, 0.22222222222222
90327, 1.8086956521739, 0.0625, 0.22222222222222
90328, 1.8086956521739, 0.075, 0.19444444444444
90329, 1.7869565217391, 0.075, 0.16666666666667
90330, 1.8086956521739, 0.0625, 0.16666666666667
90331, 1.8086956521739, 0.075, 0.13888888888889
90332, 1.7869565217391, 0.075, 0.11111111111111
90333, 1.8086956521739, 0.0625, 0.11111111111111
90334, 1.8086956521739, 0.075, 0.083333333333333
90335, 1.7869565217391, 0.075, 0.055555555555556
90336, 1.8086956521739, 0.0625, 0.055555555555556
90337, 1.8086956521739, 0.075, 0.027777777777778
90338, 1.8521739130435, 0.075, 0.47222222222222
90339, 1.8304347826087, 0.075, 0.44444444444444
90340, 1.8521739130435, 0.0625, 0.44444444444444
90341, 1.8521739130435, 0.075, 0.41666666666667
90342, 1.8304347826087, 0.075, 0.38888888888889
90343, 1.8521739130435, 0.0625, 0.38888888888889
90344, 1.8521739130435, 0.075, 0.36111111111111
90345, 1.8304347826087, 0.075, 0.33333333333333
90346, 1.8521739130435, 0.0625, 0.33333333333333
90347, 1.8521739130435, 0.075, 0.30555555555556
90348, 1.8304347826087, 0.075, 0.27777777777778
90349, 1.8521739130435, 0.0625, 0.27777777777778
90350, 1.8521739130435, 0.075, 0.25
90351, 1.8304347826087, 0.075, 0.22222222222222
90352, 1.8521739130435, 0.0625, 0.22222222222222
90353, 1.8521739130435, 0.075, 0.19444444444444
90354, 1.8304347826087, 0.075, 0.16666666666667
90355, 1.8521739130435, 0.0625, 0.16666666666667
90356, 1.8521739130435, 0.075, 0.13888888888889
90357, 1.8304347826087, 0.075, 0.11111111111111
90358, 1.8521739130435, 0.0625, 0.11111111111111
90359, 1.8521739130435, 0.075, 0.083333333333333
90360, 1.8304347826087, 0.075, 0.055555555555556
90361, 1.8521739130435, 0.0625, 0.055555555555556
90362, 1.8521739130435, 0.075, 0.027777777777778
90363, 1.895652173913, 0.075, 0.47222222222222
90364, 1.8739130434783, 0.075, 0.44444444444444
90365, 1.895652173913, 0.0625, 0.44444444444444
90366, 1.895652173913, 0.075, 0.41666666666667
90367, 1.8739130434783, 0.075, 0.38888888888889
90368, 1.895652173913, 0.0625, 0.38888888888889
90369, 1.895652173913, 0.075, 0.36111111111111
90370, 1.8739130434783, 0.075, 0.33333333333333
90371, 1.895652173913, 0.0625, 0.33333333333333
90372, 1.895652173913, 0.075, 0.30555555555556
90373, 1.8739130434783, 0.075, 0.27777777777778
90374, 1.895652173913, 0.0625, 0.27777777777778
90375, 1.895652173913, 0.075, 0.25
90376, 1.8739130434783, 0.075, 0.22222222222222
90377, 1.895652173913, 0.0625, 0.22222222222222
90378, 1.895652173913, 0.075, 0.19444444444444
90379, 1.8739130434783, 0.075, 0.16666666666667
90380, 1.895652173913, 0.0625, 0.16666666666667
90381, 1.895652173913, 0.075, 0.13888888888889
90382, 1.8739130434783, 0.075, 0.11111111111111
90383, 1.895652173913, 0.0625, 0.11111111111111
90384, 1.895652173913, 0.075, 0.083333333333333
90385, 1.8739130434783, 0.075, 0.055555555555556
90386, 1.895652173913, 0.0625, 0.055555555555556
90387, 1.895652173913, 0.075, 0.027777777777778
90388, 1.9391304347826, 0.075, 0.47222222222222
90389, 1.9173913043478, 0.075, 0.44444444444444
90390, 1.9391304347826, 0.0625, 0.44444444444444
90391, 1.9391304347826, 0.075, 0.41666666666667
90392, 1.9173913043478, 0.075, 0.38888888888889
90393, 1.9391304347826, 0.0625, 0.38888888888889
90394, 1.9391304347826, 0.075, 0.36111111111111
90395, 1.9173913043478, 0.075, 0.33333333333333
90396, 1.9391304347826, 0.0625, 0.33333333333333
90397, 1.9391304347826, 0.075, 0.30555555555556
90398, 1.9173913043478, 0.075, 0.27777777777778
90399, 1.9391304347826, 0.0625, 0.27777777777778
90400, 1.9391304347826, 0.075, 0.25
90401, 1.9173913043478, 0.075, 0.22222222222222
90402, 1.9391304347826, 0.0625, 0.22222222222222
90403, 1.9391304347826, 0.075, 0.19444444444444
90404, 1.9173913043478, 0.075, 0.16666666666667
90405, 1.9391304347826, 0.0625, 0.16666666666667
90406, 1.9391304347826, 0.075, 0.13888888888889
90407, 1.9173913043478, 0.075, 0.11111111111111
90408, 1.9391304347826, 0.0625, 0.11111111111111
90409, 1.9391304347826, 0.075, 0.083333333333333
90410, 1.9173913043478, 0.075, 0.055555555555556
90411, 1.9391304347826, 0.0625, 0.055555555555556
90412, 1.9391304347826, 0.075, 0.027777777777778
90413, 1.9826086956522, 0.075, 0.47222222222222
90414, 1.9608695652174, 0.075, 0.44444444444444
90415, 1.9826086956522, 0.0625, 0.44444444444444
90416, 1.9826086956522, 0.075, 0.41666666666667
90417, 1.9608695652174, 0.075, 0.38888888888889
90418, 1.9826086956522, 0.0625, 0.38888888888889
90419, 1.9826086956522, 0.075, 0.36111111111111
90420, 1.9608695652174, 0.075, 0.33333333333333
90421, 1.9826086956522, 0.0625, 0.33333333333333
90422, 1.9826086956522, 0.075, 0.30555555555556
90423, 1.9608695652174, 0.075, 0.27777777777778
90424, 1.9826086956522, 0.0625, 0.27777777777778
90425, 1.9826086956522, 0.075, 0.25
90426, 1.9608695652174, 0.075, 0.22222222222222
90427, 1.9826086956522, 0.0625, 0.22222222222222
90428, 1.9826086956522, 0.075, 0.19444444444444
90429, 1.9608695652174, 0.075, 0.16666666666667
90430, 1.9826086956522, 0.0625, 0.16666666666667
90431, 1.9826086956522, 0.075, 0.13888888888889
90432, 1.9608695652174, 0.075, 0.11111111111111
90433, 1.9826086956522, 0.0625, 0.11111111111111
90434, 1.9826086956522, 0.075, 0.083333333333333
90435, 1.9608695652174, 0.075, 0.055555555555556
90436, 1.9826086956522, 0.0625, 0.055555555555556
90437, 1.9826086956522, 0.075, 0.027777777777778
90438, 2.0260869565217, 0.075, 0.47222222222222
90439, 2.004347826087, 0.075, 0.44444444444444
90440, 2.0260869565217, 0.0625, 0.44444444444444
90441, 2.0260869565217, 0.075, 0.41666666666667
90442, 2.004347826087, 0.075, 0.38888888888889
90443, 2.0260869565217, 0.0625, 0.38888888888889
90444, 2.0260869565217, 0.075, 0.36111111111111
90445, 2.004347826087, 0.075, 0.33333333333333
90446, 2.0260869565217, 0.0625, 0.33333333333333
90447, 2.0260869565217, 0.075, 0.30555555555556
90448, 2.004347826087, 0.075, 0.27777777777778
90449, 2.0260869565217, 0.0625, 0.27777777777778
90450, 2.0260869565217, 0.075, 0.25
90451, 2.004347826087, 0.075, 0.22222222222222
90452, 2.0260869565217, 0.0625, 0.22222222222222
90453, 2.0260869565217, 0.075, 0.19444444444444
90454, 2.004347826087, 0.075, 0.16666666666667
90455, 2.0260869565217, 0.0625, 0.16666666666667
90456, 2.0260869565217, 0.075, 0.13888888888889
90457, 2.004347826087, 0.075, 0.11111111111111
90458, 2.0260869565217, 0.0625, 0.11111111111111
90459, 2.0260869565217, 0.075, 0.083333333333333
90460, 2.004347826087, 0.075, 0.055555555555556
90461, 2.0260869565217, 0.0625, 0.055555555555556
90462, 2.0260869565217, 0.075, 0.027777777777778
90463, 2.0695652173913, 0.075, 0.47222222222222
90464, 2.0478260869565, 0.075, 0.44444444444444
90465, 2.0695652173913, 0.0625, 0.44444444444444
90466, 2.0695652173913, 0.075, 0.41666666666667
90467, 2.0478260869565, 0.075, 0.38888888888889
90468, 2.0695652173913, 0.0625, 0.38888888888889
90469, 2.0695652173913, 0.075, 0.36111111111111
90470, 2.0478260869565, 0.075, 0.33333333333333
90471, 2.0695652173913, 0.0625, 0.33333333333333
90472, 2.0695652173913, 0.075, 0.30555555555556
90473, 2.0478260869565, 0.075, 0.27777777777778
90474, 2.0695652173913, 0.0625, 0.27777777777778
90475, 2.0695652173913, 0.075, 0.25
90476, 2.0478260869565, 0.075, 0.22222222222222
90477, 2.0695652173913, 0.0625, 0.22222222222222
90478, 2.0695652173913, 0.075, 0.19444444444444
90479, 2.0478260869565, 0.075, 0.16666666666667
90480, 2.0695652173913, 0.0625, 0.16666666666667
90481, 2.0695652173913, 0.075, 0.13888888888889
90482, 2.0478260869565, 0.075, 0.11111111111111
90483, 2.0695652173913, 0.0625, 0.11111111111111
90484, 2.0695652173913, 0.075, 0.083333333333333
90485, 2.0478260869565, 0.075, 0.055555555555556
90486, 2.0695652173913, 0.0625, 0.055555555555556
90487, 2.0695652173913, 0.075, 0.027777777777778
90488, 2.1130434782609, 0.075, 0.47222222222222
90489, 2.0913043478261, 0.075, 0.44444444444444
90490, 2.1130434782609, 0.0625, 0.44444444444444
90491, 2.1130434782609, 0.075, 0.41666666666667
90492, 2.0913043478261, 0.075, 0.38888888888889
90493, 2.1130434782609, 0.0625, 0.38888888888889
90494, 2.1130434782609, 0.075, 0.36111111111111
90495, 2.0913043478261, 0.075, 0.33333333333333
90496, 2.1130434782609, 0.0625, 0.33333333333333
90497, 2.1130434782609, 0.075, 0.30555555555556
90498, 2.0913043478261, 0.075, 0.27777777777778
90499, 2.1130434782609, 0.0625, 0.27777777777778
90500, 2.1130434782609, 0.075, 0.25
90501, 2.0913043478261, 0.075, 0.22222222222222
90502, 2.1130434782609, 0.0625, 0.22222222222222
90503, 2.1130434782609, 0.075, 0.19444444444444
90504, 2.0913043478261, 0.075, 0.16666666666667
90505, 2.1130434782609, 0.0625, 0.16666666666667
90506, 2.1130434782609, 0.075, 0.13888888888889
90507, 2.0913043478261, 0.075, 0.11111111111111
90508, 2.1130434782609, 0.0625, 0.11111111111111
90509, 2.1130434782609, 0.075, 0.083333333333333
90510, 2.0913043478261, 0.075, 0.055555555555556
90511, 2.1130434782609, 0.0625, 0.055555555555556
90512, 2.1130434782609, 0.075, 0.027777777777778
90513, 2.1565217391304, 0.075, 0.47222222222222
90514, 2.1347826086957, 0.075, 0.44444444444444
90515, 2.1565217391304, 0.0625, 0.44444444444444
90516, 2.1565217391304, 0.075, 0.41666666666667
90517, 2.1347826086957, 0.075, 0.38888888888889
90518, 2.1565217391304, 0.0625, 0.38888888888889
90519, 2.1565217391304, 0.075, 0.36111111111111
90520, 2.1347826086957, 0.075, 0.33333333333333
90521, 2.1565217391304, 0.0625, 0.33333333333333
90522, 2.1565217391304, 0.075, 0.30555555555556
90523, 2.1347826086957, 0.075, 0.27777777777778
90524, 2.1565217391304, 0.0625, 0.27777777777778
90525, 2.1565217391304, 0.075, 0.25
90526, 2.1347826086957, 0.075, 0.22222222222222
90527, 2.1565217391304, 0.0625, 0.22222222222222
90528, 2.1565217391304, 0.075, 0.19444444444444
90529, 2.1347826086957, 0.075, 0.16666666666667
90530, 2.1565217391304, 0.0625, 0.16666666666667
90531, 2.1565217391304, 0.075, 0.13888888888889
90532, 2.1347826086957, 0.075, 0.11111111111111
90533, 2.1565217391304, 0.0625, 0.11111111111111
90534, 2.1565217391304, 0.075, 0.083333333333333
90535, 2.1347826086957, 0.075, 0.055555555555556
90536, 2.1565217391304, 0.0625, 0.055555555555556
90537, 2.1565217391304, 0.075, 0.027777777777778
90538, 2.1782608695652, 0.075, 0.44444444444444
90539, 2.1782608695652, 0.075, 0.38888888888889
90540, 2.1782608695652, 0.075, 0.33333333333333
90541, 2.1782608695652, 0.075, 0.27777777777778
90542, 2.1782608695652, 0.075, 0.22222222222222
90543, 2.1782608695652, 0.075, 0.16666666666667
90544, 2.1782608695652, 0.075, 0.11111111111111
90545, 2.1782608695652, 0.075, 0.055555555555556
90546, 1.2434782608696, 0.0875, 0.44444444444444
90547, 1.2434782608696, 0.0875, 0.38888888888889
90548, 1.2434782608696, 0.0875, 0.33333333333333
90549, 1.2434782608696, 0.0875, 0.27777777777778
90550, 1.2434782608696, 0.0875, 0.22222222222222
90551, 1.2434782608696, 0.0875, 0.16666666666667
90552, 1.2434782608696, 0.0875, 0.11111111111111
90553, 1.2434782608696, 0.0875, 0.055555555555556
90554, 1.2869565217391, 0.0875, 0.44444444444444
90555, 1.2869565217391, 0.0875, 0.38888888888889
90556, 1.2869565217391, 0.0875, 0.33333333333333
90557, 1.2869565217391, 0.0875, 0.27777777777778
90558, 1.2869565217391, 0.0875, 0.22222222222222
90559, 1.2869565217391, 0.0875, 0.16666666666667
90560, 1.2869565217391, 0.0875, 0.11111111111111
90561, 1.2869565217391, 0.0875, 0.055555555555556
90562, 1.3304347826087, 0.0875, 0.44444444444444
90563, 1.3304347826087, 0.0875, 0.38888888888889
90564, 1.3304347826087, 0.0875, 0.33333333333333
90565, 1.3304347826087, 0.0875, 0.27777777777778
90566, 1.3304347826087, 0.0875, 0.22222222222222
90567, 1.3304347826087, 0.0875, 0.16666666666667
90568, 1.3304347826087, 0.0875, 0.11111111111111
90569, 1.3304347826087, 0.0875, 0.055555555555556
90570, 1.3739130434783, 0.0875, 0.44444444444444
90571, 1.3739130434783, 0.0875, 0.38888888888889
90572, 1.3739130434783, 0.0875, 0.33333333333333
90573, 1.3739130434783, 0.0875, 0.27777777777778
90574, 1.3739130434783, 0.0875, 0.22222222222222
90575, 1.3739130434783, 0.0875, 0.16666666666667
90576, 1.3739130434783, 0.0875, 0.11111111111111
90577, 1.3739130434783, 0.0875, 0.055555555555556
90578, 1.4173913043478, 0.0875, 0.44444444444444
90579, 1.4173913043478, 0.0875, 0.38888888888889
90580, 1.4173913043478, 0.0875, 0.33333333333333
90581, 1.4173913043478, 0.0875, 0.27777777777778
90582, 1.4173913043478, 0.0875, 0.22222222222222
90583, 1.4173913043478, 0.0875, 0.16666666666667
90584, 1.4173913043478, 0.0875, 0.11111111111111
90585, 1.4173913043478, 0.0875, 0.055555555555556
90586, 1.4608695652174, 0.0875, 0.44444444444444
90587, 1.4608695652174, 0.0875, 0.38888888888889
90588, 1.4608695652174, 0.0875, 0.33333333333333
90589, 1.4608695652174, 0.0875, 0.27777777777778
90590, 1.4608695652174, 0.0875, 0.22222222222222
90591, 1.4608695652174, 0.0875, 0.16666666666667
90592, 1.4608695652174, 0.0875, 0.11111111111111
90593, 1.4608695652174, 0.0875, 0.055555555555556
90594, 1.504347826087, 0.0875, 0.44444444444444
90595, 1.504347826087, 0.0875, 0.38888888888889
90596, 1.504347826087, 0.0875, 0.33333333333333
90597, 1.504347826087, 0.0875, 0.27777777777778
90598, 1.504347826087, 0.0875, 0.22222222222222
90599, 1.504347826087, 0.0875, 0.16666666666667
90600, 1.504347826087, 0.0875, 0.11111111111111
90601, 1.504347826087, 0.0875, 0.055555555555556
90602, 1.5478260869565, 0.0875, 0.44444444444444
90603, 1.5478260869565, 0.0875, 0.38888888888889
90604, 1.5478260869565, 0.0875, 0.33333333333333
90605, 1.5478260869565, 0.0875, 0.27777777777778
90606, 1.5478260869565, 0.0875, 0.22222222222222
90607, 1.5478260869565, 0.0875, 0.16666666666667
90608, 1.5478260869565, 0.0875, 0.11111111111111
90609, 1.5478260869565, 0.0875, 0.055555555555556
90610, 1.5913043478261, 0.0875, 0.44444444444444
90611, 1.5913043478261, 0.0875, 0.38888888888889
90612, 1.5913043478261, 0.0875, 0.33333333333333
90613, 1.5913043478261, 0.0875, 0.27777777777778
90614, 1.5913043478261, 0.0875, 0.22222222222222
90615, 1.5913043478261, 0.0875, 0.16666666666667
90616, 1.5913043478261, 0.0875, 0.11111111111111
90617, 1.5913043478261, 0.0875, 0.055555555555556
90618, 1.6347826086957, 0.0875, 0.44444444444444
90619, 1.6347826086957, 0.0875, 0.38888888888889
90620, 1.6347826086957, 0.0875, 0.33333333333333
90621, 1.6347826086957, 0.0875, 0.27777777777778
90622, 1.6347826086957, 0.0875, 0.22222222222222
90623, 1.6347826086957, 0.0875, 0.16666666666667
90624, 1.6347826086957, 0.0875, 0.11111111111111
90625, 1.6347826086957, 0.0875, 0.055555555555556
90626, 1.6782608695652, 0.0875, 0.44444444444444
90627, 1.6782608695652, 0.0875, 0.38888888888889
90628, 1.6782608695652, 0.0875, 0.33333333333333
90629, 1.6782608695652, 0.0875, 0.27777777777778
90630, 1.6782608695652, 0.0875, 0.22222222222222
90631, 1.6782608695652, 0.0875, 0.16666666666667
90632, 1.6782608695652, 0.0875, 0.11111111111111
90633, 1.6782608695652, 0.0875, 0.055555555555556
90634, 1.7217391304348, 0.0875, 0.44444444444444
90635, 1.7217391304348, 0.0875, 0.38888888888889
90636, 1.7217391304348, 0.0875, 0.33333333333333
90637, 1.7217391304348, 0.0875, 0.27777777777778
90638, 1.7217391304348, 0.0875, 0.22222222222222
90639, 1.7217391304348, 0.0875, 0.16666666666667
90640, 1.7217391304348, 0.0875, 0.11111111111111
90641, 1.7217391304348, 0.0875, 0.055555555555556
90642, 1.7652173913043, 0.0875, 0.44444444444444
90643, 1.7652173913043, 0.0875, 0.38888888888889
90644, 1.7652173913043, 0.0875, 0.33333333333333
90645, 1.7652173913043, 0.0875, 0.27777777777778
90646, 1.7652173913043, 0.0875, 0.22222222222222
90647, 1.7652173913043, 0.0875, 0.16666666666667
90648, 1.7652173913043, 0.0875, 0.11111111111111
90649, 1.7652173913043, 0.0875, 0.055555555555556
90650, 1.8086956521739, 0.0875, 0.44444444444444
90651, 1.8086956521739, 0.0875, 0.38888888888889
90652, 1.8086956521739, 0.0875, 0.33333333333333
90653, 1.8086956521739, 0.0875, 0.27777777777778
90654, 1.8086956521739, 0.0875, 0.22222222222222
90655, 1.8086956521739, 0.0875, 0.16666666666667
90656, 1.8086956521739, 0.0875, 0.11111111111111
90657, 1.8086956521739, 0.0875, 0.055555555555556
90658, 1.8521739130435, 0.0875, 0.44444444444444
90659, 1.8521739130435, 0.0875, 0.38888888888889
90660, 1.8521739130435, 0.0875, 0.33333333333333
90661, 1.8521739130435, 0.0875, 0.27777777777778
90662, 1.8521739130435, 0.0875, 0.22222222222222
90663, 1.8521739130435, 0.0875, 0.16666666666667
90664, 1.8521739130435, 0.0875, 0.11111111111111
90665, 1.8521739130435, 0.0875, 0.055555555555556
90666, 1.895652173913, 0.0875, 0.44444444444444
90667, 1.895652173913, 0.0875, 0.38888888888889
90668, 1.895652173913, 0.0875, 0.33333333333333
90669, 1.895652173913, 0.0875, 0.27777777777778
90670, 1.895652173913, 0.0875, 0.22222222222222
90671, 1.895652173913, 0.0875, 0.16666666666667
90672, 1.895652173913, 0.0875, 0.11111111111111
90673, 1.895652173913, 0.0875, 0.055555555555556
90674, 1.9391304347826, 0.0875, 0.44444444444444
90675, 1.9391304347826, 0.0875, 0.38888888888889
90676, 1.9391304347826, 0.0875, 0.33333333333333
90677, 1.9391304347826, 0.0875, 0.27777777777778
90678, 1.9391304347826, 0.0875, 0.22222222222222
90679, 1.9391304347826, 0.0875, 0.16666666666667
90680, 1.9391304347826, 0.0875, 0.11111111111111
90681, 1.9391304347826, 0.0875, 0.055555555555556
90682, 1.9826086956522, 0.0875, 0.44444444444444
90683, 1.9826086956522, 0.0875, 0.38888888888889
90684, 1.9826086956522, 0.0875, 0.33333333333333
90685, 1.9826086956522, 0.0875, 0.27777777777778
90686, 1.9826086956522, 0.0875, 0.22222222222222
90687, 1.9826086956522, 0.0875, 0.16666666666667
90688, 1.9826086956522, 0.0875, 0.11111111111111
90689, 1.9826086956522, 0.0875, 0.055555555555556
90690, 2.0260869565217, 0.0875, 0.44444444444444
90691, 2.0260869565217, 0.0875, 0.38888888888889
90692, 2.0260869565217, 0.0875, 0.33333333333333
90693, 2.0260869565217, 0.0875, 0.27777777777778
90694, 2.0260869565217, 0.0875, 0.22222222222222
90695, 2.0260869565217, 0.0875, 0.16666666666667
90696, 2.0260869565217, 0.0875, 0.11111111111111
90697, 2.0260869565217, 0.0875, 0.055555555555556
90698, 2.0695652173913, 0.0875, 0.44444444444444
90699, 2.0695652173913, 0.0875, 0.38888888888889
90700, 2.0695652173913, 0.0875, 0.33333333333333
90701, 2.0695652173913, 0.0875, 0.27777777777778
90702, 2.0695652173913, 0.0875, 0.22222222222222
90703, 2.0695652173913, 0.0875, 0.16666666666667
90704, 2.0695652173913, 0.0875, 0.11111111111111
90705, 2.0695652173913, 0.0875, 0.055555555555556
90706, 2.1130434782609, 0.0875, 0.44444444444444
90707, 2.1130434782609, 0.0875, 0.38888888888889
90708, 2.1130434782609, 0.0875, 0.33333333333333
90709, 2.1130434782609, 0.0875, 0.27777777777778
90710, 2.1130434782609, 0.0875, 0.22222222222222
90711, 2.1130434782609, 0.0875, 0.16666666666667
90712, 2.1130434782609, 0.0875, 0.11111111111111
90713, 2.1130434782609, 0.0875, 0.055555555555556
90714, 2.1565217391304, 0.0875, 0.44444444444444
90715, 2.1565217391304, 0.0875, 0.38888888888889
90716, 2.1565217391304, 0.0875, 0.33333333333333
90717, 2.1565217391304, 0.0875, 0.27777777777778
90718, 2.1565217391304, 0.0875, 0.22222222222222
90719, 2.1565217391304, 0.0875, 0.16666666666667
90720, 2.1565217391304, 0.0875, 0.11111111111111
90721, 2.1565217391304, 0.0875, 0.055555555555556
90722, 0.95652173913043, 0.075, 0.055555555555556
90723, 0.95652173913044, 0.075, 0.11111111111111
90724, 0.95652173913043, 0.075, 0.16666666666667
90725, 0.95652173913044, 0.075, 0.22222222222222
90726, 0.95652173913044, 0.075, 0.27777777777778
90727, 0.95652173913044, 0.075, 0.33333333333333
90728, 0.95652173913044, 0.075, 0.38888888888889
90729, 0.95652173913044, 0.075, 0.44444444444444
90730, 0.91304347826087, 0.075, 0.055555555555556
90731, 0.91304347826087, 0.075, 0.11111111111111
90732, 0.91304347826087, 0.075, 0.16666666666667
90733, 0.91304347826087, 0.075, 0.22222222222222
90734, 0.91304347826087, 0.075, 0.27777777777778
90735, 0.91304347826087, 0.075, 0.33333333333333
90736, 0.91304347826087, 0.075, 0.38888888888889
90737, 0.91304347826087, 0.075, 0.44444444444444
90738, 0.8695652173913, 0.075, 0.055555555555556
90739, 0.8695652173913, 0.075, 0.11111111111111
90740, 0.8695652173913, 0.075, 0.16666666666667
90741, 0.8695652173913, 0.075, 0.22222222222222
90742, 0.8695652173913, 0.075, 0.27777777777778
90743, 0.8695652173913, 0.075, 0.33333333333333
90744, 0.8695652173913, 0.075, 0.38888888888889
90745, 0.8695652173913, 0.075, 0.44444444444444
90746, 0.82608695652174, 0.075, 0.055555555555556
90747, 0.82608695652174, 0.075, 0.11111111111111
90748, 0.82608695652174, 0.075, 0.16666666666667
90749, 0.82608695652174, 0.075, 0.22222222222222
90750, 0.82608695652174, 0.075, 0.27777777777778
90751, 0.82608695652174, 0.075, 0.33333333333333
90752, 0.82608695652174, 0.075, 0.38888888888889
90753, 0.82608695652174, 0.075, 0.44444444444444
90754, 0.78260869565217, 0.075, 0.055555555555556
90755, 0.78260869565217, 0.075, 0.11111111111111
90756, 0.78260869565217, 0.075, 0.16666666666667
90757, 0.78260869565217, 0.075, 0.22222222222222
90758, 0.78260869565217, 0.075, 0.27777777777778
90759, 0.78260869565217, 0.075, 0.33333333333333
90760, 0.78260869565217, 0.075, 0.38888888888889
90761, 0.78260869565217, 0.075, 0.44444444444444
90762, 0.73913043478261, 0.075, 0.055555555555556
90763, 0.73913043478261, 0.075, 0.11111111111111
90764, 0.73913043478261, 0.075, 0.16666666666667
90765, 0.73913043478261, 0.075, 0.22222222222222
90766, 0.73913043478261, 0.075, 0.27777777777778
90767, 0.73913043478261, 0.075, 0.33333333333333
90768, 0.73913043478261, 0.075, 0.38888888888889
90769, 0.73913043478261, 0.075, 0.44444444444444
90770, 0.69565217391304, 0.075, 0.055555555555556
90771, 0.69565217391304, 0.075, 0.11111111111111
90772, 0.69565217391304, 0.075, 0.16666666666667
90773, 0.69565217391304, 0.075, 0.22222222222222
90774, 0.69565217391304, 0.075, 0.27777777777778
90775, 0.69565217391304, 0.075, 0.33333333333333
90776, 0.69565217391304, 0.075, 0.38888888888889
90777, 0.69565217391304, 0.075, 0.44444444444444
90778, 0.65217391304348, 0.075, 0.055555555555556
90779, 0.65217391304348, 0.075, 0.11111111111111
90780, 0.65217391304348, 0.075, 0.16666666666667
90781, 0.65217391304348, 0.075, 0.22222222222222
90782, 0.65217391304348, 0.075, 0.27777777777778
90783, 0.65217391304348, 0.075, 0.33333333333333
90784, 0.65217391304348, 0.075, 0.38888888888889
90785, 0.65217391304348, 0.075, 0.44444444444444
90786, 0.60869565217391, 0.075, 0.055555555555556
90787, 0.60869565217391, 0.075, 0.11111111111111
90788, 0.60869565217391, 0.075, 0.16666666666667
90789, 0.60869565217391, 0.075, 0.22222222222222
90790, 0.60869565217391, 0.075, 0.27777777777778
90791, 0.60869565217391, 0.075, 0.33333333333333
90792, 0.60869565217391, 0.075, 0.38888888888889
90793, 0.60869565217391, 0.075, 0.44444444444444
90794, 0.56521739130435, 0.075, 0.055555555555556
90795, 0.56521739130435, 0.075, 0.11111111111111
90796, 0.56521739130435, 0.075, 0.16666666666667
90797, 0.56521739130435, 0.075, 0.22222222222222
90798, 0.56521739130435, 0.075, 0.27777777777778
90799, 0.56521739130435, 0.075, 0.33333333333333
90800, 0.56521739130435, 0.075, 0.38888888888889
90801, 0.56521739130435, 0.075, 0.44444444444444
90802, 0.52173913043478, 0.075, 0.055555555555556
90803, 0.52173913043478, 0.075, 0.11111111111111
90804, 0.52173913043478, 0.075, 0.16666666666667
90805, 0.52173913043478, 0.075, 0.22222222222222
90806, 0.52173913043478, 0.075, 0.27777777777778
90807, 0.52173913043478, 0.075, 0.33333333333333
90808, 0.52173913043478, 0.075, 0.38888888888889
90809, 0.52173913043478, 0.075, 0.44444444444444
90810, 0.47826086956522, 0.075, 0.055555555555556
90811, 0.47826086956522, 0.075, 0.11111111111111
90812, 0.47826086956522, 0.075, 0.16666666666667
90813, 0.47826086956522, 0.075, 0.22222222222222
90814, 0.47826086956522, 0.075, 0.27777777777778
90815, 0.47826086956522, 0.075, 0.33333333333333
90816, 0.47826086956522, 0.075, 0.38888888888889
90817, 0.47826086956522, 0.075, 0.44444444444444
90818, 0.43478260869565, 0.075, 0.055555555555556
90819, 0.43478260869565, 0.075, 0.11111111111111
90820, 0.43478260869565, 0.075, 0.16666666666667
90821, 0.43478260869565, 0.075, 0.22222222222222
90822, 0.43478260869565, 0.075, 0.27777777777778
90823, 0.43478260869565, 0.075, 0.33333333333333
90824, 0.43478260869565, 0.075, 0.38888888888889
90825, 0.43478260869565, 0.075, 0.44444444444444
90826, 0.39130434782609, 0.075, 0.055555555555556
90827, 0.39130434782609, 0.075, 0.11111111111111
90828, 0.39130434782609, 0.075, 0.16666666666667
90829, 0.39130434782609, 0.075, 0.22222222222222
90830, 0.39130434782609, 0.075, 0.27777777777778
90831, 0.39130434782609, 0.075, 0.33333333333333
90832, 0.39130434782609, 0.075, 0.38888888888889
90833, 0.39130434782609, 0.075, 0.44444444444444
90834, 0.34782608695652, 0.075, 0.055555555555556
90835, 0.34782608695652, 0.075, 0.11111111111111
90836, 0.34782608695652, 0.075, 0.16666666666667
90837, 0.34782608695652, 0.075, 0.22222222222222
90838, 0.34782608695652, 0.075, 0.27777777777778
90839, 0.34782608695652, 0.075, 0.33333333333333
90840, 0.34782608695652, 0.075, 0.38888888888889
90841, 0.34782608695652, 0.075, 0.44444444444444
90842, 0.30434782608696, 0.075, 0.055555555555556
90843, 0.30434782608696, 0.075, 0.11111111111111
90844, 0.30434782608696, 0.075, 0.16666666666667
90845, 0.30434782608696, 0.075, 0.22222222222222
90846, 0.30434782608696, 0.075, 0.27777777777778
90847, 0.30434782608696, 0.075, 0.33333333333333
90848, 0.30434782608696, 0.075, 0.38888888888889
90849, 0.30434782608696, 0.075, 0.44444444444444
90850, 0.26086956521739, 0.075, 0.055555555555556
90851, 0.26086956521739, 0.075, 0.11111111111111
90852, 0.26086956521739, 0.075, 0.16666666666667
90853, 0.26086956521739, 0.075, 0.22222222222222
90854, 0.26086956521739, 0.075, 0.27777777777778
90855, 0.26086956521739, 0.075, 0.33333333333333
90856, 0.26086956521739, 0.075, 0.38888888888889
90857, 0.26086956521739, 0.075, 0.44444444444444
90858, 0.21739130434783, 0.075, 0.055555555555556
90859, 0.21739130434783, 0.075, 0.11111111111111
90860, 0.21739130434783, 0.075, 0.16666666666667
90861, 0.21739130434783, 0.075, 0.22222222222222
90862, 0.21739130434783, 0.075, 0.27777777777778
90863, 0.21739130434783, 0.075, 0.33333333333333
90864, 0.21739130434783, 0.075, 0.38888888888889
90865, 0.21739130434783, 0.075, 0.44444444444444
90866, 0.17391304347826, 0.075, 0.055555555555556
90867, 0.17391304347826, 0.075, 0.11111111111111
90868, 0.17391304347826, 0.075, 0.16666666666667
90869, 0.17391304347826, 0.075, 0.22222222222222
90870, 0.17391304347826, 0.075, 0.27777777777778
90871, 0.17391304347826, 0.075, 0.33333333333333
90872, 0.17391304347826, 0.075, 0.38888888888889
90873, 0.17391304347826, 0.075, 0.44444444444444
90874, 0.1304347826087, 0.075, 0.055555555555556
90875, 0.1304347826087, 0.075, 0.11111111111111
90876, 0.1304347826087, 0.075, 0.16666666666667
90877, 0.1304347826087, 0.075, 0.22222222222222
90878, 0.1304347826087, 0.075, 0.27777777777778
90879, 0.1304347826087, 0.075, 0.33333333333333
90880, 0.1304347826087, 0.075, 0.38888888888889
90881, 0.1304347826087, 0.075, 0.44444444444444
90882, 0.08695652173913, 0.075, 0.055555555555556
90883, 0.08695652173913, 0.075, 0.11111111111111
90884, 0.08695652173913, 0.075, 0.16666666666667
90885, 0.08695652173913, 0.075, 0.22222222222222
90886, 0.08695652173913, 0.075, 0.27777777777778
90887, 0.08695652173913, 0.075, 0.33333333333333
90888, 0.08695652173913, 0.075, 0.38888888888889
90889, 0.08695652173913, 0.075, 0.44444444444444
90890, 0.043478260869565, 0.075, 0.055555555555556
90891, 0.043478260869565, 0.075, 0.11111111111111
90892, 0.043478260869565, 0.075, 0.16666666666667
90893, 0.043478260869565, 0.075, 0.22222222222222
90894, 0.043478260869565, 0.075, 0.27777777777778
90895, 0.043478260869565, 0.075, 0.33333333333333
90896, 0.043478260869565, 0.075, 0.38888888888889
90897, 0.043478260869565, 0.075, 0.44444444444444
90898, 0.95652173913043, 0.075, 0.027777777777778
90899, 0.97826086956522, 0.075, 0.055555555555556
90900, 0.95652173913043, 0.0625, 0.055555555555556
90901, 0.95652173913043, 0.075, 0.083333333333333
90902, 0.97826086956522, 0.075, 0.11111111111111
90903, 0.95652173913043, 0.0625, 0.11111111111111
90904, 0.95652173913044, 0.075, 0.13888888888889
90905, 0.97826086956522, 0.075, 0.16666666666667
90906, 0.95652173913043, 0.0625, 0.16666666666667
90907, 0.95652173913044, 0.075, 0.19444444444444
90908, 0.97826086956522, 0.075, 0.22222222222222
90909, 0.95652173913044, 0.0625, 0.22222222222222
90910, 0.95652173913044, 0.075, 0.25
90911, 0.97826086956522, 0.075, 0.27777777777778
90912, 0.95652173913043, 0.0625, 0.27777777777778
90913, 0.95652173913044, 0.075, 0.30555555555556
90914, 0.97826086956522, 0.075, 0.33333333333333
90915, 0.95652173913043, 0.0625, 0.33333333333333
90916, 0.95652173913044, 0.075, 0.36111111111111
90917, 0.97826086956522, 0.075, 0.38888888888889
90918, 0.95652173913043, 0.0625, 0.38888888888889
90919, 0.95652173913044, 0.075, 0.41666666666667
90920, 0.97826086956522, 0.075, 0.44444444444444
90921, 0.95652173913043, 0.0625, 0.44444444444444
90922, 0.95652173913043, 0.075, 0.47222222222222
90923, 0.91304347826087, 0.075, 0.027777777777778
90924, 0.93478260869565, 0.075, 0.055555555555556
90925, 0.91304347826087, 0.0625, 0.055555555555556
90926, 0.91304347826087, 0.075, 0.083333333333333
90927, 0.93478260869565, 0.075, 0.11111111111111
90928, 0.91304347826087, 0.0625, 0.11111111111111
90929, 0.91304347826087, 0.075, 0.13888888888889
90930, 0.93478260869565, 0.075, 0.16666666666667
90931, 0.91304347826087, 0.0625, 0.16666666666667
90932, 0.91304347826087, 0.075, 0.19444444444444
90933, 0.93478260869565, 0.075, 0.22222222222222
90934, 0.91304347826087, 0.0625, 0.22222222222222
90935, 0.91304347826087, 0.075, 0.25
90936, 0.93478260869565, 0.075, 0.27777777777778
90937, 0.91304347826087, 0.0625, 0.27777777777778
90938, 0.91304347826087, 0.075, 0.30555555555556
90939, 0.93478260869565, 0.075, 0.33333333333333
90940, 0.91304347826087, 0.0625, 0.33333333333333
90941, 0.91304347826087, 0.075, 0.36111111111111
90942, 0.93478260869565, 0.075, 0.38888888888889
90943, 0.91304347826087, 0.0625, 0.38888888888889
90944, 0.91304347826087, 0.075, 0.41666666666667
90945, 0.93478260869565, 0.075, 0.44444444444444
90946, 0.91304347826087, 0.0625, 0.44444444444444
90947, 0.91304347826087, 0.075, 0.47222222222222
90948, 0.8695652173913, 0.075, 0.027777777777778
90949, 0.89130434782609, 0.075, 0.055555555555556
90950, 0.8695652173913, 0.0625, 0.055555555555556
90951, 0.8695652173913, 0.075, 0.083333333333333
90952, 0.89130434782609, 0.075, 0.11111111111111
90953, 0.8695652173913, 0.0625, 0.11111111111111
90954, 0.8695652173913, 0.075, 0.13888888888889
90955, 0.89130434782609, 0.075, 0.16666666666667
90956, 0.8695652173913, 0.0625, 0.16666666666667
90957, 0.8695652173913, 0.075, 0.19444444444444
90958, 0.89130434782609, 0.075, 0.22222222222222
90959, 0.8695652173913, 0.0625, 0.22222222222222
90960, 0.8695652173913, 0.075, 0.25
90961, 0.89130434782609, 0.075, 0.27777777777778
90962, 0.8695652173913, 0.0625, 0.27777777777778
90963, 0.8695652173913, 0.075, 0.30555555555556
90964, 0.89130434782609, 0.075, 0.33333333333333
90965, 0.8695652173913, 0.0625, 0.33333333333333
90966, 0.8695652173913, 0.075, 0.36111111111111
90967, 0.89130434782609, 0.075, 0.38888888888889
90968, 0.8695652173913, 0.0625, 0.38888888888889
90969, 0.8695652173913, 0.075, 0.41666666666667
90970, 0.89130434782609, 0.075, 0.44444444444444
90971, 0.8695652173913, 0.0625, 0.44444444444444
90972, 0.8695652173913, 0.075, 0.47222222222222
90973, 0.82608695652174, 0.075, 0.027777777777778
90974, 0.84782608695652, 0.075, 0.055555555555556
90975, 0.82608695652174, 0.0625, 0.055555555555556
90976, 0.82608695652174, 0.075, 0.083333333333333
90977, 0.84782608695652, 0.075, 0.11111111111111
90978, 0.82608695652174, 0.0625, 0.11111111111111
90979, 0.82608695652174, 0.075, 0.13888888888889
90980, 0.84782608695652, 0.075, 0.16666666666667
90981, 0.82608695652174, 0.0625, 0.16666666666667
90982, 0.82608695652174, 0.075, 0.19444444444444
90983, 0.84782608695652, 0.075, 0.22222222222222
90984, 0.82608695652174, 0.0625, 0.22222222222222
90985, 0.82608695652174, 0.075, 0.25
90986, 0.84782608695652, 0.075, 0.27777777777778
90987, 0.82608695652174, 0.0625, 0.27777777777778
90988, 0.82608695652174, 0.075, 0.30555555555556
90989, 0.84782608695652, 0.075, 0.33333333333333
90990, 0.82608695652174, 0.0625, 0.33333333333333
90991, 0.82608695652174, 0.075, 0.36111111111111
90992, 0.84782608695652, 0.075, 0.38888888888889
90993, 0.82608695652174, 0.0625, 0.38888888888889
90994, 0.82608695652174, 0.075, 0.41666666666667
90995, 0.84782608695652, 0.075, 0.44444444444444
90996, 0.82608695652174, 0.0625, 0.44444444444444
90997, 0.82608695652174, 0.075, 0.47222222222222
90998, 0.78260869565217, 0.075, 0.027777777777778
90999, 0.80434782608696, 0.075, 0.055555555555556
91000, 0.78260869565217, 0.0625, 0.055555555555556
91001, 0.78260869565217, 0.075, 0.083333333333333
91002, 0.80434782608696, 0.075, 0.11111111111111
91003, 0.78260869565217, 0.0625, 0.11111111111111
91004, 0.78260869565217, 0.075, 0.13888888888889
91005, 0.80434782608696, 0.075, 0.16666666666667
91006, 0.78260869565217, 0.0625, 0.16666666666667
91007, 0.78260869565217, 0.075, 0.19444444444444
91008, 0.80434782608696, 0.075, 0.22222222222222
91009, 0.78260869565217, 0.0625, 0.22222222222222
91010, 0.78260869565217, 0.075, 0.25
91011, 0.80434782608696, 0.075, 0.27777777777778
91012, 0.78260869565217, 0.0625, 0.27777777777778
91013, 0.78260869565217, 0.075, 0.30555555555556
91014, 0.80434782608696, 0.075, 0.33333333333333
91015, 0.78260869565217, 0.0625, 0.33333333333333
91016, 0.78260869565217, 0.075, 0.36111111111111
91017, 0.80434782608696, 0.075, 0.38888888888889
91018, 0.78260869565217, 0.0625, 0.38888888888889
91019, 0.78260869565217, 0.075, 0.41666666666667
91020, 0.80434782608696, 0.075, 0.44444444444444
91021, 0.78260869565217, 0.0625, 0.44444444444444
91022, 0.78260869565217, 0.075, 0.47222222222222
91023, 0.73913043478261, 0.075, 0.027777777777778
91024, 0.76086956521739, 0.075, 0.055555555555556
91025, 0.73913043478261, 0.0625, 0.055555555555556
91026, 0.73913043478261, 0.075, 0.083333333333333
91027, 0.76086956521739, 0.075, 0.11111111111111
91028, 0.73913043478261, 0.0625, 0.11111111111111
91029, 0.73913043478261, 0.075, 0.13888888888889
91030, 0.76086956521739, 0.075, 0.16666666666667
91031, 0.73913043478261, 0.0625, 0.16666666666667
91032, 0.73913043478261, 0.075, 0.19444444444444
91033, 0.76086956521739, 0.075, 0.22222222222222
91034, 0.73913043478261, 0.0625, 0.22222222222222
91035, 0.73913043478261, 0.075, 0.25
91036, 0.76086956521739, 0.075, 0.27777777777778
91037, 0.73913043478261, 0.0625, 0.27777777777778
91038, 0.73913043478261, 0.075, 0.30555555555556
91039, 0.76086956521739, 0.075, 0.33333333333333
91040, 0.73913043478261, 0.0625, 0.33333333333333
91041, 0.73913043478261, 0.075, 0.36111111111111
91042, 0.76086956521739, 0.075, 0.38888888888889
91043, 0.73913043478261, 0.0625, 0.38888888888889
91044, 0.73913043478261, 0.075, 0.41666666666667
91045, 0.76086956521739, 0.075, 0.44444444444444
91046, 0.73913043478261, 0.0625, 0.44444444444444
91047, 0.73913043478261, 0.075, 0.47222222222222
91048, 0.69565217391304, 0.075, 0.027777777777778
91049, 0.71739130434783, 0.075, 0.055555555555556
91050, 0.69565217391304, 0.0625, 0.055555555555556
91051, 0.69565217391304, 0.075, 0.083333333333333
91052, 0.71739130434783, 0.075, 0.11111111111111
91053, 0.69565217391304, 0.0625, 0.11111111111111
91054, 0.69565217391304, 0.075, 0.13888888888889
91055, 0.71739130434783, 0.075, 0.16666666666667
91056, 0.69565217391304, 0.0625, 0.16666666666667
91057, 0.69565217391304, 0.075, 0.19444444444444
91058, 0.71739130434783, 0.075, 0.22222222222222
91059, 0.69565217391304, 0.0625, 0.22222222222222
91060, 0.69565217391304, 0.075, 0.25
91061, 0.71739130434783, 0.075, 0.27777777777778
91062, 0.69565217391304, 0.0625, 0.27777777777778
91063, 0.69565217391304, 0.075, 0.30555555555556
91064, 0.71739130434783, 0.075, 0.33333333333333
91065, 0.69565217391304, 0.0625, 0.33333333333333
91066, 0.69565217391304, 0.075, 0.36111111111111
91067, 0.71739130434783, 0.075, 0.38888888888889
91068, 0.69565217391304, 0.0625, 0.38888888888889
91069, 0.69565217391304, 0.075, 0.41666666666667
91070, 0.71739130434783, 0.075, 0.44444444444444
91071, 0.69565217391304, 0.0625, 0.44444444444444
91072, 0.69565217391304, 0.075, 0.47222222222222
91073, 0.65217391304348, 0.075, 0.027777777777778
91074, 0.67391304347826, 0.075, 0.055555555555556
91075, 0.65217391304348, 0.0625, 0.055555555555556
91076, 0.65217391304348, 0.075, 0.083333333333333
91077, 0.67391304347826, 0.075, 0.11111111111111
91078, 0.65217391304348, 0.0625, 0.11111111111111
91079, 0.65217391304348, 0.075, 0.13888888888889
91080, 0.67391304347826, 0.075, 0.16666666666667
91081, 0.65217391304348, 0.0625, 0.16666666666667
91082, 0.65217391304348, 0.075, 0.19444444444444
91083, 0.67391304347826, 0.075, 0.22222222222222
91084, 0.65217391304348, 0.0625, 0.22222222222222
91085, 0.65217391304348, 0.075, 0.25
91086, 0.67391304347826, 0.075, 0.27777777777778
91087, 0.65217391304348, 0.0625, 0.27777777777778
91088, 0.65217391304348, 0.075, 0.30555555555556
91089, 0.67391304347826, 0.075, 0.33333333333333
91090, 0.65217391304348, 0.0625, 0.33333333333333
91091, 0.65217391304348, 0.075, 0.36111111111111
91092, 0.67391304347826, 0.075, 0.38888888888889
91093, 0.65217391304348, 0.0625, 0.38888888888889
91094, 0.65217391304348, 0.075, 0.41666666666667
91095, 0.67391304347826, 0.075, 0.44444444444444
91096, 0.65217391304348, 0.0625, 0.44444444444444
91097, 0.65217391304348, 0.075, 0.47222222222222
91098, 0.60869565217391, 0.075, 0.027777777777778
91099, 0.6304347826087, 0.075, 0.055555555555556
91100, 0.60869565217391, 0.0625, 0.055555555555556
91101, 0.60869565217391, 0.075, 0.083333333333333
91102, 0.6304347826087, 0.075, 0.11111111111111
91103, 0.60869565217391, 0.0625, 0.11111111111111
91104, 0.60869565217391, 0.075, 0.13888888888889
91105, 0.6304347826087, 0.075, 0.16666666666667
91106, 0.60869565217391, 0.0625, 0.16666666666667
91107, 0.60869565217391, 0.075, 0.19444444444444
91108, 0.6304347826087, 0.075, 0.22222222222222
91109, 0.60869565217391, 0.0625, 0.22222222222222
91110, 0.60869565217391, 0.075, 0.25
91111, 0.6304347826087, 0.075, 0.27777777777778
91112, 0.60869565217391, 0.0625, 0.27777777777778
91113, 0.60869565217391, 0.075, 0.30555555555556
91114, 0.6304347826087, 0.075, 0.33333333333333
91115, 0.60869565217391, 0.0625, 0.33333333333333
91116, 0.60869565217391, 0.075, 0.36111111111111
91117, 0.6304347826087, 0.075, 0.38888888888889
91118, 0.60869565217391, 0.0625, 0.38888888888889
91119, 0.60869565217391, 0.075, 0.41666666666667
91120, 0.6304347826087, 0.075, 0.44444444444444
91121, 0.60869565217391, 0.0625, 0.44444444444444
91122, 0.60869565217391, 0.075, 0.47222222222222
91123, 0.56521739130435, 0.075, 0.027777777777778
91124, 0.58695652173913, 0.075, 0.055555555555556
91125, 0.56521739130435, 0.0625, 0.055555555555556
91126, 0.56521739130435, 0.075, 0.083333333333333
91127, 0.58695652173913, 0.075, 0.11111111111111
91128, 0.56521739130435, 0.0625, 0.11111111111111
91129, 0.56521739130435, 0.075, 0.13888888888889
91130, 0.58695652173913, 0.075, 0.16666666666667
91131, 0.56521739130435, 0.0625, 0.16666666666667
91132, 0.56521739130435, 0.075, 0.19444444444444
91133, 0.58695652173913, 0.075, 0.22222222222222
91134, 0.56521739130435, 0.0625, 0.22222222222222
91135, 0.56521739130435, 0.075, 0.25
91136, 0.58695652173913, 0.075, 0.27777777777778
91137, 0.56521739130435, 0.0625, 0.27777777777778
91138, 0.56521739130435, 0.075, 0.30555555555556
91139, 0.58695652173913, 0.075, 0.33333333333333
91140, 0.56521739130435, 0.0625, 0.33333333333333
91141, 0.56521739130435, 0.075, 0.36111111111111
91142, 0.58695652173913, 0.075, 0.38888888888889
91143, 0.56521739130435, 0.0625, 0.38888888888889
91144, 0.56521739130435, 0.075, 0.41666666666667
91145, 0.58695652173913, 0.075, 0.44444444444444
91146, 0.56521739130435, 0.0625, 0.44444444444444
91147, 0.56521739130435, 0.075, 0.47222222222222
91148, 0.52173913043478, 0.075, 0.027777777777778
91149, 0.54347826086957, 0.075, 0.055555555555556
91150, 0.52173913043478, 0.0625, 0.055555555555556
91151, 0.52173913043478, 0.075, 0.083333333333333
91152, 0.54347826086957, 0.075, 0.11111111111111
91153, 0.52173913043478, 0.0625, 0.11111111111111
91154, 0.52173913043478, 0.075, 0.13888888888889
91155, 0.54347826086957, 0.075, 0.16666666666667
91156, 0.52173913043478, 0.0625, 0.16666666666667
91157, 0.52173913043478, 0.075, 0.19444444444444
91158, 0.54347826086956, 0.075, 0.22222222222222
91159, 0.52173913043478, 0.0625, 0.22222222222222
91160, 0.52173913043478, 0.075, 0.25
91161, 0.54347826086956, 0.075, 0.27777777777778
91162, 0.52173913043478, 0.0625, 0.27777777777778
91163, 0.52173913043478, 0.075, 0.30555555555556
91164, 0.54347826086956, 0.075, 0.33333333333333
91165, 0.52173913043478, 0.0625, 0.33333333333333
91166, 0.52173913043478, 0.075, 0.36111111111111
91167, 0.54347826086956, 0.075, 0.38888888888889
91168, 0.52173913043478, 0.0625, 0.38888888888889
91169, 0.52173913043478, 0.075, 0.41666666666667
91170, 0.54347826086956, 0.075, 0.44444444444444
91171, 0.52173913043478, 0.0625, 0.44444444444444
91172, 0.52173913043478, 0.075, 0.47222222222222
91173, 0.47826086956522, 0.075, 0.027777777777778
91174, 0.5, 0.075, 0.055555555555556
91175, 0.47826086956522, 0.0625, 0.055555555555556
91176, 0.47826086956522, 0.075, 0.083333333333333
91177, 0.5, 0.075, 0.11111111111111
91178, 0.47826086956522, 0.0625, 0.11111111111111
91179, 0.47826086956522, 0.075, 0.13888888888889
91180, 0.5, 0.075, 0.16666666666667
91181, 0.47826086956522, 0.0625, 0.16666666666667
91182, 0.47826086956522, 0.075, 0.19444444444444
91183, 0.5, 0.075, 0.22222222222222
91184, 0.47826086956522, 0.0625, 0.22222222222222
91185, 0.47826086956522, 0.075, 0.25
91186, 0.5, 0.075, 0.27777777777778
91187, 0.47826086956522, 0.0625, 0.27777777777778
91188, 0.47826086956522, 0.075, 0.30555555555556
91189, 0.5, 0.075, 0.33333333333333
91190, 0.47826086956522, 0.0625, 0.33333333333333
91191, 0.47826086956522, 0.075, 0.36111111111111
91192, 0.5, 0.075, 0.38888888888889
91193, 0.47826086956522, 0.0625, 0.38888888888889
91194, 0.47826086956522, 0.075, 0.41666666666667
91195, 0.5, 0.075, 0.44444444444444
91196, 0.47826086956522, 0.0625, 0.44444444444444
91197, 0.47826086956522, 0.075, 0.47222222222222
91198, 0.43478260869565, 0.075, 0.027777777777778
91199, 0.45652173913043, 0.075, 0.055555555555556
91200, 0.43478260869565, 0.0625, 0.055555555555556
91201, 0.43478260869565, 0.075, 0.083333333333333
91202, 0.45652173913043, 0.075, 0.11111111111111
91203, 0.43478260869565, 0.0625, 0.11111111111111
91204, 0.43478260869565, 0.075, 0.13888888888889
91205, 0.45652173913043, 0.075, 0.16666666666667
91206, 0.43478260869565, 0.0625, 0.16666666666667
91207, 0.43478260869565, 0.075, 0.19444444444444
91208, 0.45652173913043, 0.075, 0.22222222222222
91209, 0.43478260869565, 0.0625, 0.22222222222222
91210, 0.43478260869565, 0.075, 0.25
91211, 0.45652173913043, 0.075, 0.27777777777778
91212, 0.43478260869565, 0.0625, 0.27777777777778
91213, 0.43478260869565, 0.075, 0.30555555555556
91214, 0.45652173913043, 0.075, 0.33333333333333
91215, 0.43478260869565, 0.0625, 0.33333333333333
91216, 0.43478260869565, 0.075, 0.36111111111111
91217, 0.45652173913044, 0.075, 0.38888888888889
91218, 0.43478260869565, 0.0625, 0.38888888888889
91219, 0.43478260869565, 0.075, 0.41666666666667
91220, 0.45652173913043, 0.075, 0.44444444444444
91221, 0.43478260869565, 0.0625, 0.44444444444444
91222, 0.43478260869565, 0.075, 0.47222222222222
91223, 0.39130434782609, 0.075, 0.027777777777778
91224, 0.41304347826087, 0.075, 0.055555555555556
91225, 0.39130434782609, 0.0625, 0.055555555555556
91226, 0.39130434782609, 0.075, 0.083333333333333
91227, 0.41304347826087, 0.075, 0.11111111111111
91228, 0.39130434782609, 0.0625, 0.11111111111111
91229, 0.39130434782609, 0.075, 0.13888888888889
91230, 0.41304347826087, 0.075, 0.16666666666667
91231, 0.39130434782609, 0.0625, 0.16666666666667
91232, 0.39130434782609, 0.075, 0.19444444444444
91233, 0.41304347826087, 0.075, 0.22222222222222
91234, 0.39130434782609, 0.0625, 0.22222222222222
91235, 0.39130434782609, 0.075, 0.25
91236, 0.41304347826087, 0.075, 0.27777777777778
91237, 0.39130434782609, 0.0625, 0.27777777777778
91238, 0.39130434782609, 0.075, 0.30555555555556
91239, 0.41304347826087, 0.075, 0.33333333333333
91240, 0.39130434782609, 0.0625, 0.33333333333333
91241, 0.39130434782609, 0.075, 0.36111111111111
91242, 0.41304347826087, 0.075, 0.38888888888889
91243, 0.39130434782609, 0.0625, 0.38888888888889
91244, 0.39130434782609, 0.075, 0.41666666666667
91245, 0.41304347826087, 0.075, 0.44444444444444
91246, 0.39130434782609, 0.0625, 0.44444444444444
91247, 0.39130434782609, 0.075, 0.47222222222222
91248, 0.34782608695652, 0.075, 0.027777777777778
91249, 0.3695652173913, 0.075, 0.055555555555556
91250, 0.34782608695652, 0.0625, 0.055555555555556
91251, 0.34782608695652, 0.075, 0.083333333333333
91252, 0.3695652173913, 0.075, 0.11111111111111
91253, 0.34782608695652, 0.0625, 0.11111111111111
91254, 0.34782608695652, 0.075, 0.13888888888889
91255, 0.3695652173913, 0.075, 0.16666666666667
91256, 0.34782608695652, 0.0625, 0.16666666666667
91257, 0.34782608695652, 0.075, 0.19444444444444
91258, 0.3695652173913, 0.075, 0.22222222222222
91259, 0.34782608695652, 0.0625, 0.22222222222222
91260, 0.34782608695652, 0.075, 0.25
91261, 0.3695652173913, 0.075, 0.27777777777778
91262, 0.34782608695652, 0.0625, 0.27777777777778
91263, 0.34782608695652, 0.075, 0.30555555555556
91264, 0.3695652173913, 0.075, 0.33333333333333
91265, 0.34782608695652, 0.0625, 0.33333333333333
91266, 0.34782608695652, 0.075, 0.36111111111111
91267, 0.3695652173913, 0.075, 0.38888888888889
91268, 0.34782608695652, 0.0625, 0.38888888888889
91269, 0.34782608695652, 0.075, 0.41666666666667
91270, 0.3695652173913, 0.075, 0.44444444444444
91271, 0.34782608695652, 0.0625, 0.44444444444444
91272, 0.34782608695652, 0.075, 0.47222222222222
91273, 0.30434782608696, 0.075, 0.027777777777778
91274, 0.32608695652174, 0.075, 0.055555555555556
91275, 0.30434782608696, 0.0625, 0.055555555555556
91276, 0.30434782608696, 0.075, 0.083333333333333
91277, 0.32608695652174, 0.075, 0.11111111111111
91278, 0.30434782608696, 0.0625, 0.11111111111111
91279, 0.30434782608696, 0.075, 0.13888888888889
91280, 0.32608695652174, 0.075, 0.16666666666667
91281, 0.30434782608696, 0.0625, 0.16666666666667
91282, 0.30434782608696, 0.075, 0.19444444444444
91283, 0.32608695652174, 0.075, 0.22222222222222
91284, 0.30434782608696, 0.0625, 0.22222222222222
91285, 0.30434782608696, 0.075, 0.25
91286, 0.32608695652174, 0.075, 0.27777777777778
91287, 0.30434782608696, 0.0625, 0.27777777777778
91288, 0.30434782608696, 0.075, 0.30555555555556
91289, 0.32608695652174, 0.075, 0.33333333333333
91290, 0.30434782608696, 0.0625, 0.33333333333333
91291, 0.30434782608696, 0.075, 0.36111111111111
91292, 0.32608695652174, 0.075, 0.38888888888889
91293, 0.30434782608696, 0.0625, 0.38888888888889
91294, 0.30434782608696, 0.075, 0.41666666666667
91295, 0.32608695652174, 0.075, 0.44444444444444
91296, 0.30434782608696, 0.0625, 0.44444444444444
91297, 0.30434782608696, 0.075, 0.47222222222222
91298, 0.26086956521739, 0.075, 0.027777777777778
91299, 0.28260869565217, 0.075, 0.055555555555556
91300, 0.26086956521739, 0.0625, 0.055555555555556
91301, 0.26086956521739, 0.075, 0.083333333333333
91302, 0.28260869565217, 0.075, 0.11111111111111
91303, 0.26086956521739, 0.0625, 0.11111111111111
91304, 0.26086956521739, 0.075, 0.13888888888889
91305, 0.28260869565217, 0.075, 0.16666666666667
91306, 0.26086956521739, 0.0625, 0.16666666666667
91307, 0.26086956521739, 0.075, 0.19444444444444
91308, 0.28260869565217, 0.075, 0.22222222222222
91309, 0.26086956521739, 0.0625, 0.22222222222222
91310, 0.26086956521739, 0.075, 0.25
91311, 0.28260869565217, 0.075, 0.27777777777778
91312, 0.26086956521739, 0.0625, 0.27777777777778
91313, 0.26086956521739, 0.075, 0.30555555555556
91314, 0.28260869565217, 0.075, 0.33333333333333
91315, 0.26086956521739, 0.0625, 0.33333333333333
91316, 0.26086956521739, 0.075, 0.36111111111111
91317, 0.28260869565217, 0.075, 0.38888888888889
91318, 0.26086956521739, 0.0625, 0.38888888888889
91319, 0.26086956521739, 0.075, 0.41666666666667
91320, 0.28260869565217, 0.075, 0.44444444444444
91321, 0.26086956521739, 0.0625, 0.44444444444444
91322, 0.26086956521739, 0.075, 0.47222222222222
91323, 0.21739130434783, 0.075, 0.027777777777778
91324, 0.23913043478261, 0.075, 0.055555555555556
91325, 0.21739130434783, 0.0625, 0.055555555555556
91326, 0.21739130434783, 0.075, 0.083333333333333
91327, 0.23913043478261, 0.075, 0.11111111111111
91328, 0.21739130434783, 0.0625, 0.11111111111111
91329, 0.21739130434783, 0.075, 0.13888888888889
91330, 0.23913043478261, 0.075, 0.16666666666667
91331, 0.21739130434783, 0.0625, 0.16666666666667
91332, 0.21739130434783, 0.075, 0.19444444444444
91333, 0.23913043478261, 0.075, 0.22222222222222
91334, 0.21739130434783, 0.0625, 0.22222222222222
91335, 0.21739130434783, 0.075, 0.25
91336, 0.23913043478261, 0.075, 0.27777777777778
91337, 0.21739130434783, 0.0625, 0.27777777777778
91338, 0.21739130434783, 0.075, 0.30555555555556
91339, 0.23913043478261, 0.075, 0.33333333333333
91340, 0.21739130434783, 0.0625, 0.33333333333333
91341, 0.21739130434783, 0.075, 0.36111111111111
91342, 0.23913043478261, 0.075, 0.38888888888889
91343, 0.21739130434783, 0.0625, 0.38888888888889
91344, 0.21739130434783, 0.075, 0.41666666666667
91345, 0.23913043478261, 0.075, 0.44444444444444
91346, 0.21739130434783, 0.0625, 0.44444444444444
91347, 0.21739130434783, 0.075, 0.47222222222222
91348, 0.17391304347826, 0.075, 0.027777777777778
91349, 0.19565217391304, 0.075, 0.055555555555556
91350, 0.17391304347826, 0.0625, 0.055555555555556
91351, 0.17391304347826, 0.075, 0.083333333333333
91352, 0.19565217391304, 0.075, 0.11111111111111
91353, 0.17391304347826, 0.0625, 0.11111111111111
91354, 0.17391304347826, 0.075, 0.13888888888889
91355, 0.19565217391304, 0.075, 0.16666666666667
91356, 0.17391304347826, 0.0625, 0.16666666666667
91357, 0.17391304347826, 0.075, 0.19444444444444
91358, 0.19565217391304, 0.075, 0.22222222222222
91359, 0.17391304347826, 0.0625, 0.22222222222222
91360, 0.17391304347826, 0.075, 0.25
91361, 0.19565217391304, 0.075, 0.27777777777778
91362, 0.17391304347826, 0.0625, 0.27777777777778
91363, 0.17391304347826, 0.075, 0.30555555555556
91364, 0.19565217391304, 0.075, 0.33333333333333
91365, 0.17391304347826, 0.0625, 0.33333333333333
91366, 0.17391304347826, 0.075, 0.36111111111111
91367, 0.19565217391304, 0.075, 0.38888888888889
91368, 0.17391304347826, 0.0625, 0.38888888888889
91369, 0.17391304347826, 0.075, 0.41666666666667
91370, 0.19565217391304, 0.075, 0.44444444444444
91371, 0.17391304347826, 0.0625, 0.44444444444444
91372, 0.17391304347826, 0.075, 0.47222222222222
91373, 0.1304347826087, 0.075, 0.027777777777778
91374, 0.15217391304348, 0.075, 0.055555555555556
91375, 0.1304347826087, 0.0625, 0.055555555555556
91376, 0.1304347826087, 0.075, 0.083333333333333
91377, 0.15217391304348, 0.075, 0.11111111111111
91378, 0.1304347826087, 0.0625, 0.11111111111111
91379, 0.1304347826087, 0.075, 0.13888888888889
91380, 0.15217391304348, 0.075, 0.16666666666667
91381, 0.1304347826087, 0.0625, 0.16666666666667
91382, 0.1304347826087, 0.075, 0.19444444444444
91383, 0.15217391304348, 0.075, 0.22222222222222
91384, 0.1304347826087, 0.0625, 0.22222222222222
91385, 0.1304347826087, 0.075, 0.25
91386, 0.15217391304348, 0.075, 0.27777777777778
91387, 0.1304347826087, 0.0625, 0.27777777777778
91388, 0.1304347826087, 0.075, 0.30555555555556
91389, 0.15217391304348, 0.075, 0.33333333333333
91390, 0.1304347826087, 0.0625, 0.33333333333333
91391, 0.1304347826087, 0.075, 0.36111111111111
91392, 0.15217391304348, 0.075, 0.38888888888889
91393, 0.1304347826087, 0.0625, 0.38888888888889
91394, 0.1304347826087, 0.075, 0.41666666666667
91395, 0.15217391304348, 0.075, 0.44444444444444
91396, 0.1304347826087, 0.0625, 0.44444444444444
91397, 0.1304347826087, 0.075, 0.47222222222222
91398, 0.08695652173913, 0.075, 0.027777777777778
91399, 0.10869565217391, 0.075, 0.055555555555556
91400, 0.08695652173913, 0.0625, 0.055555555555556
91401, 0.08695652173913, 0.075, 0.083333333333333
91402, 0.10869565217391, 0.075, 0.11111111111111
91403, 0.08695652173913, 0.0625, 0.11111111111111
91404, 0.08695652173913, 0.075, 0.13888888888889
91405, 0.10869565217391, 0.075, 0.16666666666667
91406, 0.08695652173913, 0.0625, 0.16666666666667
91407, 0.08695652173913, 0.075, 0.19444444444444
91408, 0.10869565217391, 0.075, 0.22222222222222
91409, 0.08695652173913, 0.0625, 0.22222222222222
91410, 0.08695652173913, 0.075, 0.25
91411, 0.10869565217391, 0.075, 0.27777777777778
91412, 0.08695652173913, 0.0625, 0.27777777777778
91413, 0.08695652173913, 0.075, 0.30555555555556
91414, 0.10869565217391, 0.075, 0.33333333333333
91415, 0.08695652173913, 0.0625, 0.33333333333333
91416, 0.08695652173913, 0.075, 0.36111111111111
91417, 0.10869565217391, 0.075, 0.38888888888889
91418, 0.08695652173913, 0.0625, 0.38888888888889
91419, 0.08695652173913, 0.075, 0.41666666666667
91420, 0.10869565217391, 0.075, 0.44444444444444
91421, 0.08695652173913, 0.0625, 0.44444444444444
91422, 0.08695652173913, 0.075, 0.47222222222222
91423, 0.043478260869565, 0.075, 0.027777777777778
91424, 0.065217391304348, 0.075, 0.055555555555556
91425, 0.043478260869565, 0.0625, 0.055555555555556
91426, 0.043478260869565, 0.075, 0.083333333333333
91427, 0.065217391304348, 0.075, 0.11111111111111
91428, 0.043478260869565, 0.0625, 0.11111111111111
91429, 0.043478260869565, 0.075, 0.13888888888889
91430, 0.065217391304348, 0.075, 0.16666666666667
91431, 0.043478260869565, 0.0625, 0.16666666666667
91432, 0.043478260869565, 0.075, 0.19444444444444
91433, 0.065217391304348, 0.075, 0.22222222222222
91434, 0.043478260869565, 0.0625, 0.22222222222222
91435, 0.043478260869565, 0.075, 0.25
91436, 0.065217391304348, 0.075, 0.27777777777778
91437, 0.043478260869565, 0.0625, 0.27777777777778
91438, 0.043478260869565, 0.075, 0.30555555555556
91439, 0.065217391304348, 0.075, 0.33333333333333
91440, 0.043478260869565, 0.0625, 0.33333333333333
91441, 0.043478260869565, 0.075, 0.36111111111111
91442, 0.065217391304348, 0.075, 0.38888888888889
91443, 0.043478260869565, 0.0625, 0.38888888888889
91444, 0.043478260869565, 0.075, 0.41666666666667
91445, 0.065217391304348, 0.075, 0.44444444444444
91446, 0.043478260869565, 0.0625, 0.44444444444444
91447, 0.043478260869565, 0.075, 0.47222222222222
91448, 0.021739130434783, 0.075, 0.055555555555556
91449, 0.021739130434783, 0.075, 0.11111111111111
91450, 0.021739130434783, 0.075, 0.16666666666667
91451, 0.021739130434783, 0.075, 0.22222222222222
91452, 0.021739130434783, 0.075, 0.27777777777778
91453, 0.021739130434783, 0.075, 0.33333333333333
91454, 0.021739130434783, 0.075, 0.38888888888889
91455, 0.021739130434783, 0.075, 0.44444444444444
91456, 0.95652173913043, 0.0875, 0.055555555555556
91457, 0.95652173913043, 0.0875, 0.11111111111111
91458, 0.95652173913043, 0.0875, 0.16666666666667
91459, 0.95652173913044, 0.0875, 0.22222222222222
91460, 0.95652173913043, 0.0875, 0.27777777777778
91461, 0.95652173913043, 0.0875, 0.33333333333333
91462, 0.95652173913043, 0.0875, 0.38888888888889
91463, 0.95652173913043, 0.0875, 0.44444444444444
91464, 0.91304347826087, 0.0875, 0.055555555555556
91465, 0.91304347826087, 0.0875, 0.11111111111111
91466, 0.91304347826087, 0.0875, 0.16666666666667
91467, 0.91304347826087, 0.0875, 0.22222222222222
91468, 0.91304347826087, 0.0875, 0.27777777777778
91469, 0.91304347826087, 0.0875, 0.33333333333333
91470, 0.91304347826087, 0.0875, 0.38888888888889
91471, 0.91304347826087, 0.0875, 0.44444444444444
91472, 0.8695652173913, 0.0875, 0.055555555555556
91473, 0.8695652173913, 0.0875, 0.11111111111111
91474, 0.8695652173913, 0.0875, 0.16666666666667
91475, 0.8695652173913, 0.0875, 0.22222222222222
91476, 0.8695652173913, 0.0875, 0.27777777777778
91477, 0.8695652173913, 0.0875, 0.33333333333333
91478, 0.8695652173913, 0.0875, 0.38888888888889
91479, 0.8695652173913, 0.0875, 0.44444444444444
91480, 0.82608695652174, 0.0875, 0.055555555555556
91481, 0.82608695652174, 0.0875, 0.11111111111111
91482, 0.82608695652174, 0.0875, 0.16666666666667
91483, 0.82608695652174, 0.0875, 0.22222222222222
91484, 0.82608695652174, 0.0875, 0.27777777777778
91485, 0.82608695652174, 0.0875, 0.33333333333333
91486, 0.82608695652174, 0.0875, 0.38888888888889
91487, 0.82608695652174, 0.0875, 0.44444444444444
91488, 0.78260869565217, 0.0875, 0.055555555555556
91489, 0.78260869565217, 0.0875, 0.11111111111111
91490, 0.78260869565217, 0.0875, 0.16666666666667
91491, 0.78260869565217, 0.0875, 0.22222222222222
91492, 0.78260869565217, 0.0875, 0.27777777777778
91493, 0.78260869565217, 0.0875, 0.33333333333333
91494, 0.78260869565217, 0.0875, 0.38888888888889
91495, 0.78260869565217, 0.0875, 0.44444444444444
91496, 0.73913043478261, 0.0875, 0.055555555555556
91497, 0.73913043478261, 0.0875, 0.11111111111111
91498, 0.73913043478261, 0.0875, 0.16666666666667
91499, 0.73913043478261, 0.0875, 0.22222222222222
91500, 0.73913043478261, 0.0875, 0.27777777777778
91501, 0.73913043478261, 0.0875, 0.33333333333333
91502, 0.73913043478261, 0.0875, 0.38888888888889
91503, 0.73913043478261, 0.0875, 0.44444444444444
91504, 0.69565217391304, 0.0875, 0.055555555555556
91505, 0.69565217391304, 0.0875, 0.11111111111111
91506, 0.69565217391304, 0.0875, 0.16666666666667
91507, 0.69565217391304, 0.0875, 0.22222222222222
91508, 0.69565217391304, 0.0875, 0.27777777777778
91509, 0.69565217391304, 0.0875, 0.33333333333333
91510, 0.69565217391304, 0.0875, 0.38888888888889
91511, 0.69565217391304, 0.0875, 0.44444444444444
91512, 0.65217391304348, 0.0875, 0.055555555555556
91513, 0.65217391304348, 0.0875, 0.11111111111111
91514, 0.65217391304348, 0.0875, 0.16666666666667
91515, 0.65217391304348, 0.0875, 0.22222222222222
91516, 0.65217391304348, 0.0875, 0.27777777777778
91517, 0.65217391304348, 0.0875, 0.33333333333333
91518, 0.65217391304348, 0.0875, 0.38888888888889
91519, 0.65217391304348, 0.0875, 0.44444444444444
91520, 0.60869565217391, 0.0875, 0.055555555555556
91521, 0.60869565217391, 0.0875, 0.11111111111111
91522, 0.60869565217391, 0.0875, 0.16666666666667
91523, 0.60869565217391, 0.0875, 0.22222222222222
91524, 0.60869565217391, 0.0875, 0.27777777777778
91525, 0.60869565217391, 0.0875, 0.33333333333333
91526, 0.60869565217391, 0.0875, 0.38888888888889
91527, 0.60869565217391, 0.0875, 0.44444444444444
91528, 0.56521739130435, 0.0875, 0.055555555555556
91529, 0.56521739130435, 0.0875, 0.11111111111111
91530, 0.56521739130435, 0.0875, 0.16666666666667
91531, 0.56521739130435, 0.0875, 0.22222222222222
91532, 0.56521739130435, 0.0875, 0.27777777777778
91533, 0.56521739130435, 0.0875, 0.33333333333333
91534, 0.56521739130435, 0.0875, 0.38888888888889
91535, 0.56521739130435, 0.0875, 0.44444444444444
91536, 0.52173913043478, 0.0875, 0.055555555555556
91537, 0.52173913043478, 0.0875, 0.11111111111111
91538, 0.52173913043478, 0.0875, 0.16666666666667
91539, 0.52173913043478, 0.0875, 0.22222222222222
91540, 0.52173913043478, 0.0875, 0.27777777777778
91541, 0.52173913043478, 0.0875, 0.33333333333333
91542, 0.52173913043478, 0.0875, 0.38888888888889
91543, 0.52173913043478, 0.0875, 0.44444444444444
91544, 0.47826086956522, 0.0875, 0.055555555555556
91545, 0.47826086956522, 0.0875, 0.11111111111111
91546, 0.47826086956522, 0.0875, 0.16666666666667
91547, 0.47826086956522, 0.0875, 0.22222222222222
91548, 0.47826086956522, 0.0875, 0.27777777777778
91549, 0.47826086956522, 0.0875, 0.33333333333333
91550, 0.47826086956522, 0.0875, 0.38888888888889
91551, 0.47826086956522, 0.0875, 0.44444444444444
91552, 0.43478260869565, 0.0875, 0.055555555555556
91553, 0.43478260869565, 0.0875, 0.11111111111111
91554, 0.43478260869565, 0.0875, 0.16666666666667
91555, 0.43478260869565, 0.0875, 0.22222222222222
91556, 0.43478260869565, 0.0875, 0.27777777777778
91557, 0.43478260869565, 0.0875, 0.33333333333333
91558, 0.43478260869565, 0.0875, 0.38888888888889
91559, 0.43478260869565, 0.0875, 0.44444444444444
91560, 0.39130434782609, 0.0875, 0.055555555555556
91561, 0.39130434782609, 0.0875, 0.11111111111111
91562, 0.39130434782609, 0.0875, 0.16666666666667
91563, 0.39130434782609, 0.0875, 0.22222222222222
91564, 0.39130434782609, 0.0875, 0.27777777777778
91565, 0.39130434782609, 0.0875, 0.33333333333333
91566, 0.39130434782609, 0.0875, 0.38888888888889
91567, 0.39130434782609, 0.0875, 0.44444444444444
91568, 0.34782608695652, 0.0875, 0.055555555555556
91569, 0.34782608695652, 0.0875, 0.11111111111111
91570, 0.34782608695652, 0.0875, 0.16666666666667
91571, 0.34782608695652, 0.0875, 0.22222222222222
91572, 0.34782608695652, 0.0875, 0.27777777777778
91573, 0.34782608695652, 0.0875, 0.33333333333333
91574, 0.34782608695652, 0.0875, 0.38888888888889
91575, 0.34782608695652, 0.0875, 0.44444444444444
91576, 0.30434782608696, 0.0875, 0.055555555555556
91577, 0.30434782608696, 0.0875, 0.11111111111111
91578, 0.30434782608696, 0.0875, 0.16666666666667
91579, 0.30434782608696, 0.0875, 0.22222222222222
91580, 0.30434782608696, 0.0875, 0.27777777777778
91581, 0.30434782608696, 0.0875, 0.33333333333333
91582, 0.30434782608696, 0.0875, 0.38888888888889
91583, 0.30434782608696, 0.0875, 0.44444444444444
91584, 0.26086956521739, 0.0875, 0.055555555555556
91585, 0.26086956521739, 0.0875, 0.11111111111111
91586, 0.26086956521739, 0.0875, 0.16666666666667
91587, 0.26086956521739, 0.0875, 0.22222222222222
91588, 0.26086956521739, 0.0875, 0.27777777777778
91589, 0.26086956521739, 0.0875, 0.33333333333333
91590, 0.26086956521739, 0.0875, 0.38888888888889
91591, 0.26086956521739, 0.0875, 0.44444444444444
91592, 0.21739130434783, 0.0875, 0.055555555555556
91593, 0.21739130434783, 0.0875, 0.11111111111111
91594, 0.21739130434783, 0.0875, 0.16666666666667
91595, 0.21739130434783, 0.0875, 0.22222222222222
91596, 0.21739130434783, 0.0875, 0.27777777777778
91597, 0.21739130434783, 0.0875, 0.33333333333333
91598, 0.21739130434783, 0.0875, 0.38888888888889
91599, 0.21739130434783, 0.0875, 0.44444444444444
91600, 0.17391304347826, 0.0875, 0.055555555555556
91601, 0.17391304347826, 0.0875, 0.11111111111111
91602, 0.17391304347826, 0.0875, 0.16666666666667
91603, 0.17391304347826, 0.0875, 0.22222222222222
91604, 0.17391304347826, 0.0875, 0.27777777777778
91605, 0.17391304347826, 0.0875, 0.33333333333333
91606, 0.17391304347826, 0.0875, 0.38888888888889
91607, 0.17391304347826, 0.0875, 0.44444444444444
91608, 0.1304347826087, 0.0875, 0.055555555555556
91609, 0.1304347826087, 0.0875, 0.11111111111111
91610, 0.1304347826087, 0.0875, 0.16666666666667
91611, 0.1304347826087, 0.0875, 0.22222222222222
91612, 0.1304347826087, 0.0875, 0.27777777777778
91613, 0.1304347826087, 0.0875, 0.33333333333333
91614, 0.1304347826087, 0.0875, 0.38888888888889
91615, 0.1304347826087, 0.0875, 0.44444444444444
91616, 0.08695652173913, 0.0875, 0.055555555555556
91617, 0.08695652173913, 0.0875, 0.11111111111111
91618, 0.08695652173913, 0.0875, 0.16666666666667
91619, 0.08695652173913, 0.0875, 0.22222222222222
91620, 0.08695652173913, 0.0875, 0.27777777777778
91621, 0.08695652173913, 0.0875, 0.33333333333333
91622, 0.08695652173913, 0.0875, 0.38888888888889
91623, 0.08695652173913, 0.0875, 0.44444444444444
91624, 0.043478260869565, 0.0875, 0.055555555555556
91625, 0.043478260869565, 0.0875, 0.11111111111111
91626, 0.043478260869565, 0.0875, 0.16666666666667
91627, 0.043478260869565, 0.0875, 0.22222222222222
91628, 0.043478260869565, 0.0875, 0.27777777777778
91629, 0.043478260869565, 0.0875, 0.33333333333333
91630, 0.043478260869565, 0.0875, 0.38888888888889
91631, 0.043478260869565, 0.0875, 0.44444444444444
91632, 0.95652173913043, 1.375, 0.055555555555556
91633, 0.95652173913044, 1.375, 0.11111111111111
91634, 0.95652173913044, 1.375, 0.16666666666667
91635, 0.95652173913044, 1.375, 0.22222222222222
91636, 0.95652173913044, 1.375, 0.27777777777778
91637, 0.95652173913044, 1.375, 0.33333333333333
91638, 0.95652173913044, 1.375, 0.38888888888889
91639, 0.95652173913044, 1.375, 0.44444444444444
91640, 0.91304347826087, 1.375, 0.055555555555556
91641, 0.91304347826087, 1.375, 0.11111111111111
91642, 0.91304347826087, 1.375, 0.16666666666667
91643, 0.91304347826087, 1.375, 0.22222222222222
91644, 0.91304347826087, 1.375, 0.27777777777778
91645, 0.91304347826087, 1.375, 0.33333333333333
91646, 0.91304347826087, 1.375, 0.38888888888889
91647, 0.91304347826087, 1.375, 0.44444444444444
91648, 0.8695652173913, 1.375, 0.055555555555556
91649, 0.8695652173913, 1.375, 0.11111111111111
91650, 0.8695652173913, 1.375, 0.16666666666667
91651, 0.8695652173913, 1.375, 0.22222222222222
91652, 0.8695652173913, 1.375, 0.27777777777778
91653, 0.8695652173913, 1.375, 0.33333333333333
91654, 0.8695652173913, 1.375, 0.38888888888889
91655, 0.8695652173913, 1.375, 0.44444444444444
91656, 0.82608695652174, 1.375, 0.055555555555556
91657, 0.82608695652174, 1.375, 0.11111111111111
91658, 0.82608695652174, 1.375, 0.16666666666667
91659, 0.82608695652174, 1.375, 0.22222222222222
91660, 0.82608695652174, 1.375, 0.27777777777778
91661, 0.82608695652174, 1.375, 0.33333333333333
91662, 0.82608695652174, 1.375, 0.38888888888889
91663, 0.82608695652174, 1.375, 0.44444444444444
91664, 0.78260869565217, 1.375, 0.055555555555556
91665, 0.78260869565217, 1.375, 0.11111111111111
91666, 0.78260869565217, 1.375, 0.16666666666667
91667, 0.78260869565217, 1.375, 0.22222222222222
91668, 0.78260869565217, 1.375, 0.27777777777778
91669, 0.78260869565217, 1.375, 0.33333333333333
91670, 0.78260869565217, 1.375, 0.38888888888889
91671, 0.78260869565217, 1.375, 0.44444444444444
91672, 0.73913043478261, 1.375, 0.055555555555556
91673, 0.73913043478261, 1.375, 0.11111111111111
91674, 0.73913043478261, 1.375, 0.16666666666667
91675, 0.73913043478261, 1.375, 0.22222222222222
91676, 0.73913043478261, 1.375, 0.27777777777778
91677, 0.73913043478261, 1.375, 0.33333333333333
91678, 0.73913043478261, 1.375, 0.38888888888889
91679, 0.73913043478261, 1.375, 0.44444444444444
91680, 0.69565217391304, 1.375, 0.055555555555556
91681, 0.69565217391304, 1.375, 0.11111111111111
91682, 0.69565217391304, 1.375, 0.16666666666667
91683, 0.69565217391304, 1.375, 0.22222222222222
91684, 0.69565217391304, 1.375, 0.27777777777778
91685, 0.69565217391304, 1.375, 0.33333333333333
91686, 0.69565217391304, 1.375, 0.38888888888889
91687, 0.69565217391304, 1.375, 0.44444444444444
91688, 0.65217391304348, 1.375, 0.055555555555556
91689, 0.65217391304348, 1.375, 0.11111111111111
91690, 0.65217391304348, 1.375, 0.16666666666667
91691, 0.65217391304348, 1.375, 0.22222222222222
91692, 0.65217391304348, 1.375, 0.27777777777778
91693, 0.65217391304348, 1.375, 0.33333333333333
91694, 0.65217391304348, 1.375, 0.38888888888889
91695, 0.65217391304348, 1.375, 0.44444444444444
91696, 0.60869565217391, 1.375, 0.055555555555556
91697, 0.60869565217391, 1.375, 0.11111111111111
91698, 0.60869565217391, 1.375, 0.16666666666667
91699, 0.60869565217391, 1.375, 0.22222222222222
91700, 0.60869565217391, 1.375, 0.27777777777778
91701, 0.60869565217391, 1.375, 0.33333333333333
91702, 0.60869565217391, 1.375, 0.38888888888889
91703, 0.60869565217391, 1.375, 0.44444444444444
91704, 0.56521739130435, 1.375, 0.055555555555556
91705, 0.56521739130435, 1.375, 0.11111111111111
91706, 0.56521739130435, 1.375, 0.16666666666667
91707, 0.56521739130435, 1.375, 0.22222222222222
91708, 0.56521739130435, 1.375, 0.27777777777778
91709, 0.56521739130435, 1.375, 0.33333333333333
91710, 0.56521739130435, 1.375, 0.38888888888889
91711, 0.56521739130435, 1.375, 0.44444444444444
91712, 0.52173913043478, 1.375, 0.055555555555556
91713, 0.52173913043478, 1.375, 0.11111111111111
91714, 0.52173913043478, 1.375, 0.16666666666667
91715, 0.52173913043478, 1.375, 0.22222222222222
91716, 0.52173913043478, 1.375, 0.27777777777778
91717, 0.52173913043478, 1.375, 0.33333333333333
91718, 0.52173913043478, 1.375, 0.38888888888889
91719, 0.52173913043478, 1.375, 0.44444444444444
91720, 0.47826086956522, 1.375, 0.055555555555556
91721, 0.47826086956522, 1.375, 0.11111111111111
91722, 0.47826086956522, 1.375, 0.16666666666667
91723, 0.47826086956522, 1.375, 0.22222222222222
91724, 0.47826086956522, 1.375, 0.27777777777778
91725, 0.47826086956522, 1.375, 0.33333333333333
91726, 0.47826086956522, 1.375, 0.38888888888889
91727, 0.47826086956522, 1.375, 0.44444444444444
91728, 0.43478260869565, 1.375, 0.055555555555556
91729, 0.43478260869565, 1.375, 0.11111111111111
91730, 0.43478260869565, 1.375, 0.16666666666667
91731, 0.43478260869565, 1.375, 0.22222222222222
91732, 0.43478260869565, 1.375, 0.27777777777778
91733, 0.43478260869565, 1.375, 0.33333333333333
91734, 0.43478260869565, 1.375, 0.38888888888889
91735, 0.43478260869565, 1.375, 0.44444444444444
91736, 0.39130434782609, 1.375, 0.055555555555556
91737, 0.39130434782609, 1.375, 0.11111111111111
91738, 0.39130434782609, 1.375, 0.16666666666667
91739, 0.39130434782609, 1.375, 0.22222222222222
91740, 0.39130434782609, 1.375, 0.27777777777778
91741, 0.39130434782609, 1.375, 0.33333333333333
91742, 0.39130434782609, 1.375, 0.38888888888889
91743, 0.39130434782609, 1.375, 0.44444444444444
91744, 0.34782608695652, 1.375, 0.055555555555556
91745, 0.34782608695652, 1.375, 0.11111111111111
91746, 0.34782608695652, 1.375, 0.16666666666667
91747, 0.34782608695652, 1.375, 0.22222222222222
91748, 0.34782608695652, 1.375, 0.27777777777778
91749, 0.34782608695652, 1.375, 0.33333333333333
91750, 0.34782608695652, 1.375, 0.38888888888889
91751, 0.34782608695652, 1.375, 0.44444444444444
91752, 0.30434782608696, 1.375, 0.055555555555556
91753, 0.30434782608696, 1.375, 0.11111111111111
91754, 0.30434782608696, 1.375, 0.16666666666667
91755, 0.30434782608696, 1.375, 0.22222222222222
91756, 0.30434782608696, 1.375, 0.27777777777778
91757, 0.30434782608696, 1.375, 0.33333333333333
91758, 0.30434782608696, 1.375, 0.38888888888889
91759, 0.30434782608696, 1.375, 0.44444444444444
91760, 0.26086956521739, 1.375, 0.055555555555556
91761, 0.26086956521739, 1.375, 0.11111111111111
91762, 0.26086956521739, 1.375, 0.16666666666667
91763, 0.26086956521739, 1.375, 0.22222222222222
91764, 0.26086956521739, 1.375, 0.27777777777778
91765, 0.26086956521739, 1.375, 0.33333333333333
91766, 0.26086956521739, 1.375, 0.38888888888889
91767, 0.26086956521739, 1.375, 0.44444444444444
91768, 0.21739130434783, 1.375, 0.055555555555556
91769, 0.21739130434783, 1.375, 0.11111111111111
91770, 0.21739130434783, 1.375, 0.16666666666667
91771, 0.21739130434783, 1.375, 0.22222222222222
91772, 0.21739130434783, 1.375, 0.27777777777778
91773, 0.21739130434783, 1.375, 0.33333333333333
91774, 0.21739130434783, 1.375, 0.38888888888889
91775, 0.21739130434783, 1.375, 0.44444444444444
91776, 0.17391304347826, 1.375, 0.055555555555556
91777, 0.17391304347826, 1.375, 0.11111111111111
91778, 0.17391304347826, 1.375, 0.16666666666667
91779, 0.17391304347826, 1.375, 0.22222222222222
91780, 0.17391304347826, 1.375, 0.27777777777778
91781, 0.17391304347826, 1.375, 0.33333333333333
91782, 0.17391304347826, 1.375, 0.38888888888889
91783, 0.17391304347826, 1.375, 0.44444444444444
91784, 0.1304347826087, 1.375, 0.055555555555556
91785, 0.1304347826087, 1.375, 0.11111111111111
91786, 0.1304347826087, 1.375, 0.16666666666667
91787, 0.1304347826087, 1.375, 0.22222222222222
91788, 0.1304347826087, 1.375, 0.27777777777778
91789, 0.1304347826087, 1.375, 0.33333333333333
91790, 0.1304347826087, 1.375, 0.38888888888889
91791, 0.1304347826087, 1.375, 0.44444444444444
91792, 0.08695652173913, 1.375, 0.055555555555556
91793, 0.08695652173913, 1.375, 0.11111111111111
91794, 0.08695652173913, 1.375, 0.16666666666667
91795, 0.08695652173913, 1.375, 0.22222222222222
91796, 0.08695652173913, 1.375, 0.27777777777778
91797, 0.08695652173913, 1.375, 0.33333333333333
91798, 0.08695652173913, 1.375, 0.38888888888889
91799, 0.08695652173913, 1.375, 0.44444444444444
91800, 0.043478260869565, 1.375, 0.055555555555556
91801, 0.043478260869565, 1.375, 0.11111111111111
91802, 0.043478260869565, 1.375, 0.16666666666667
91803, 0.043478260869565, 1.375, 0.22222222222222
91804, 0.043478260869565, 1.375, 0.27777777777778
91805, 0.043478260869565, 1.375, 0.33333333333333
91806, 0.043478260869565, 1.375, 0.38888888888889
91807, 0.043478260869565, 1.375, 0.44444444444444
91808, 0.95652173913043, 1.375, 0.027777777777778
91809, 0.97826086956522, 1.375, 0.055555555555556
91810, 0.95652173913043, 1.3875, 0.055555555555556
91811, 0.95652173913043, 1.375, 0.083333333333333
91812, 0.97826086956522, 1.375, 0.11111111111111
91813, 0.95652173913044, 1.3875, 0.11111111111111
91814, 0.95652173913044, 1.375, 0.13888888888889
91815, 0.97826086956522, 1.375, 0.16666666666667
91816, 0.95652173913044, 1.3875, 0.16666666666667
91817, 0.95652173913044, 1.375, 0.19444444444444
91818, 0.97826086956522, 1.375, 0.22222222222222
91819, 0.95652173913043, 1.3875, 0.22222222222222
91820, 0.95652173913044, 1.375, 0.25
91821, 0.97826086956522, 1.375, 0.27777777777778
91822, 0.95652173913043, 1.3875, 0.27777777777778
91823, 0.95652173913044, 1.375, 0.30555555555556
91824, 0.97826086956522, 1.375, 0.33333333333333
91825, 0.95652173913043, 1.3875, 0.33333333333333
91826, 0.95652173913044, 1.375, 0.36111111111111
91827, 0.97826086956522, 1.375, 0.38888888888889
91828, 0.95652173913043, 1.3875, 0.38888888888889
91829, 0.95652173913044, 1.375, 0.41666666666667
91830, 0.97826086956522, 1.375, 0.44444444444444
91831, 0.95652173913043, 1.3875, 0.44444444444444
91832, 0.95652173913043, 1.375, 0.47222222222222
91833, 0.91304347826087, 1.375, 0.027777777777778
91834, 0.93478260869565, 1.375, 0.055555555555556
91835, 0.91304347826087, 1.3875, 0.055555555555556
91836, 0.91304347826087, 1.375, 0.083333333333333
91837, 0.93478260869565, 1.375, 0.11111111111111
91838, 0.91304347826087, 1.3875, 0.11111111111111
91839, 0.91304347826087, 1.375, 0.13888888888889
91840, 0.93478260869565, 1.375, 0.16666666666667
91841, 0.91304347826087, 1.3875, 0.16666666666667
91842, 0.91304347826087, 1.375, 0.19444444444444
91843, 0.93478260869565, 1.375, 0.22222222222222
91844, 0.91304347826087, 1.3875, 0.22222222222222
91845, 0.91304347826087, 1.375, 0.25
91846, 0.93478260869565, 1.375, 0.27777777777778
91847, 0.91304347826087, 1.3875, 0.27777777777778
91848, 0.91304347826087, 1.375, 0.30555555555556
91849, 0.93478260869565, 1.375, 0.33333333333333
91850, 0.91304347826087, 1.3875, 0.33333333333333
91851, 0.91304347826087, 1.375, 0.36111111111111
91852, 0.93478260869565, 1.375, 0.38888888888889
91853, 0.91304347826087, 1.3875, 0.38888888888889
91854, 0.91304347826087, 1.375, 0.41666666666667
91855, 0.93478260869565, 1.375, 0.44444444444444
91856, 0.91304347826087, 1.3875, 0.44444444444444
91857, 0.91304347826087, 1.375, 0.47222222222222
91858, 0.8695652173913, 1.375, 0.027777777777778
91859, 0.89130434782609, 1.375, 0.055555555555556
91860, 0.8695652173913, 1.3875, 0.055555555555556
91861, 0.8695652173913, 1.375, 0.083333333333333
91862, 0.89130434782609, 1.375, 0.11111111111111
91863, 0.8695652173913, 1.3875, 0.11111111111111
91864, 0.8695652173913, 1.375, 0.13888888888889
91865, 0.89130434782609, 1.375, 0.16666666666667
91866, 0.8695652173913, 1.3875, 0.16666666666667
91867, 0.8695652173913, 1.375, 0.19444444444444
91868, 0.89130434782609, 1.375, 0.22222222222222
91869, 0.8695652173913, 1.3875, 0.22222222222222
91870, 0.8695652173913, 1.375, 0.25
91871, 0.89130434782609, 1.375, 0.27777777777778
91872, 0.8695652173913, 1.3875, 0.27777777777778
91873, 0.8695652173913, 1.375, 0.30555555555556
91874, 0.89130434782609, 1.375, 0.33333333333333
91875, 0.8695652173913, 1.3875, 0.33333333333333
91876, 0.8695652173913, 1.375, 0.36111111111111
91877, 0.89130434782609, 1.375, 0.38888888888889
91878, 0.8695652173913, 1.3875, 0.38888888888889
91879, 0.8695652173913, 1.375, 0.41666666666667
91880, 0.89130434782609, 1.375, 0.44444444444444
91881, 0.8695652173913, 1.3875, 0.44444444444444
91882, 0.8695652173913, 1.375, 0.47222222222222
91883, 0.82608695652174, 1.375, 0.027777777777778
91884, 0.84782608695652, 1.375, 0.055555555555556
91885, 0.82608695652174, 1.3875, 0.055555555555556
91886, 0.82608695652174, 1.375, 0.083333333333333
91887, 0.84782608695652, 1.375, 0.11111111111111
91888, 0.82608695652174, 1.3875, 0.11111111111111
91889, 0.82608695652174, 1.375, 0.13888888888889
91890, 0.84782608695652, 1.375, 0.16666666666667
91891, 0.82608695652174, 1.3875, 0.16666666666667
91892, 0.82608695652174, 1.375, 0.19444444444444
91893, 0.84782608695652, 1.375, 0.22222222222222
91894, 0.82608695652174, 1.3875, 0.22222222222222
91895, 0.82608695652174, 1.375, 0.25
91896, 0.84782608695652, 1.375, 0.27777777777778
91897, 0.82608695652174, 1.3875, 0.27777777777778
91898, 0.82608695652174, 1.375, 0.30555555555556
91899, 0.84782608695652, 1.375, 0.33333333333333
91900, 0.82608695652174, 1.3875, 0.33333333333333
91901, 0.82608695652174, 1.375, 0.36111111111111
91902, 0.84782608695652, 1.375, 0.38888888888889
91903, 0.82608695652174, 1.3875, 0.38888888888889
91904, 0.82608695652174, 1.375, 0.41666666666667
91905, 0.84782608695652, 1.375, 0.44444444444444
91906, 0.82608695652174, 1.3875, 0.44444444444444
91907, 0.82608695652174, 1.375, 0.47222222222222
91908, 0.78260869565217, 1.375, 0.027777777777778
91909, 0.80434782608696, 1.375, 0.055555555555556
91910, 0.78260869565217, 1.3875, 0.055555555555556
91911, 0.78260869565217, 1.375, 0.083333333333333
91912, 0.80434782608696, 1.375, 0.11111111111111
91913, 0.78260869565217, 1.3875, 0.11111111111111
91914, 0.78260869565217, 1.375, 0.13888888888889
91915, 0.80434782608696, 1.375, 0.16666666666667
91916, 0.78260869565217, 1.3875, 0.16666666666667
91917, 0.78260869565217, 1.375, 0.19444444444444
91918, 0.80434782608696, 1.375, 0.22222222222222
91919, 0.78260869565217, 1.3875, 0.22222222222222
91920, 0.78260869565217, 1.375, 0.25
91921, 0.80434782608696, 1.375, 0.27777777777778
91922, 0.78260869565217, 1.3875, 0.27777777777778
91923, 0.78260869565217, 1.375, 0.30555555555556
91924, 0.80434782608696, 1.375, 0.33333333333333
91925, 0.78260869565217, 1.3875, 0.33333333333333
91926, 0.78260869565217, 1.375, 0.36111111111111
91927, 0.80434782608696, 1.375, 0.38888888888889
91928, 0.78260869565217, 1.3875, 0.38888888888889
91929, 0.78260869565217, 1.375, 0.41666666666667
91930, 0.80434782608696, 1.375, 0.44444444444444
91931, 0.78260869565217, 1.3875, 0.44444444444444
91932, 0.78260869565217, 1.375, 0.47222222222222
91933, 0.73913043478261, 1.375, 0.027777777777778
91934, 0.76086956521739, 1.375, 0.055555555555556
91935, 0.73913043478261, 1.3875, 0.055555555555556
91936, 0.73913043478261, 1.375, 0.083333333333333
91937, 0.76086956521739, 1.375, 0.11111111111111
91938, 0.73913043478261, 1.3875, 0.11111111111111
91939, 0.73913043478261, 1.375, 0.13888888888889
91940, 0.76086956521739, 1.375, 0.16666666666667
91941, 0.73913043478261, 1.3875, 0.16666666666667
91942, 0.73913043478261, 1.375, 0.19444444444444
91943, 0.76086956521739, 1.375, 0.22222222222222
91944, 0.73913043478261, 1.3875, 0.22222222222222
91945, 0.73913043478261, 1.375, 0.25
91946, 0.76086956521739, 1.375, 0.27777777777778
91947, 0.73913043478261, 1.3875, 0.27777777777778
91948, 0.73913043478261, 1.375, 0.30555555555556
91949, 0.76086956521739, 1.375, 0.33333333333333
91950, 0.73913043478261, 1.3875, 0.33333333333333
91951, 0.73913043478261, 1.375, 0.36111111111111
91952, 0.76086956521739, 1.375, 0.38888888888889
91953, 0.73913043478261, 1.3875, 0.38888888888889
91954, 0.73913043478261, 1.375, 0.41666666666667
91955, 0.76086956521739, 1.375, 0.44444444444444
91956, 0.73913043478261, 1.3875, 0.44444444444444
91957, 0.73913043478261, 1.375, 0.47222222222222
91958, 0.69565217391304, 1.375, 0.027777777777778
91959, 0.71739130434783, 1.375, 0.055555555555556
91960, 0.69565217391304, 1.3875, 0.055555555555556
91961, 0.69565217391304, 1.375, 0.083333333333333
91962, 0.71739130434783, 1.375, 0.11111111111111
91963, 0.69565217391304, 1.3875, 0.11111111111111
91964, 0.69565217391304, 1.375, 0.13888888888889
91965, 0.71739130434783, 1.375, 0.16666666666667
91966, 0.69565217391304, 1.3875, 0.16666666666667
91967, 0.69565217391304, 1.375, 0.19444444444444
91968, 0.71739130434783, 1.375, 0.22222222222222
91969, 0.69565217391304, 1.3875, 0.22222222222222
91970, 0.69565217391304, 1.375, 0.25
91971, 0.71739130434783, 1.375, 0.27777777777778
91972, 0.69565217391304, 1.3875, 0.27777777777778
91973, 0.69565217391304, 1.375, 0.30555555555556
91974, 0.71739130434783, 1.375, 0.33333333333333
91975, 0.69565217391304, 1.3875, 0.33333333333333
91976, 0.69565217391304, 1.375, 0.36111111111111
91977, 0.71739130434783, 1.375, 0.38888888888889
91978, 0.69565217391304, 1.3875, 0.38888888888889
91979, 0.69565217391304, 1.375, 0.41666666666667
91980, 0.71739130434783, 1.375, 0.44444444444444
91981, 0.69565217391304, 1.3875, 0.44444444444444
91982, 0.69565217391304, 1.375, 0.47222222222222
91983, 0.65217391304348, 1.375, 0.027777777777778
91984, 0.67391304347826, 1.375, 0.055555555555556
91985, 0.65217391304348, 1.3875, 0.055555555555556
91986, 0.65217391304348, 1.375, 0.083333333333333
91987, 0.67391304347826, 1.375, 0.11111111111111
91988, 0.65217391304348, 1.3875, 0.11111111111111
91989, 0.65217391304348, 1.375, 0.13888888888889
91990, 0.67391304347826, 1.375, 0.16666666666667
91991, 0.65217391304348, 1.3875, 0.16666666666667
91992, 0.65217391304348, 1.375, 0.19444444444444
91993, 0.67391304347826, 1.375, 0.22222222222222
91994, 0.65217391304348, 1.3875, 0.22222222222222
91995, 0.65217391304348, 1.375, 0.25
91996, 0.67391304347826, 1.375, 0.27777777777778
91997, 0.65217391304348, 1.3875, 0.27777777777778
91998, 0.65217391304348, 1.375, 0.30555555555556
91999, 0.67391304347826, 1.375, 0.33333333333333
92000, 0.65217391304348, 1.3875, 0.33333333333333
92001, 0.65217391304348, 1.375, 0.36111111111111
92002, 0.67391304347826, 1.375, 0.38888888888889
92003, 0.65217391304348, 1.3875, 0.38888888888889
92004, 0.65217391304348, 1.375, 0.41666666666667
92005, 0.67391304347826, 1.375, 0.44444444444444
92006, 0.65217391304348, 1.3875, 0.44444444444444
92007, 0.65217391304348, 1.375, 0.47222222222222
92008, 0.60869565217391, 1.375, 0.027777777777778
92009, 0.6304347826087, 1.375, 0.055555555555556
92010, 0.60869565217391, 1.3875, 0.055555555555556
92011, 0.60869565217391, 1.375, 0.083333333333333
92012, 0.6304347826087, 1.375, 0.11111111111111
92013, 0.60869565217391, 1.3875, 0.11111111111111
92014, 0.60869565217391, 1.375, 0.13888888888889
92015, 0.6304347826087, 1.375, 0.16666666666667
92016, 0.60869565217391, 1.3875, 0.16666666666667
92017, 0.60869565217391, 1.375, 0.19444444444444
92018, 0.6304347826087, 1.375, 0.22222222222222
92019, 0.60869565217391, 1.3875, 0.22222222222222
92020, 0.60869565217391, 1.375, 0.25
92021, 0.6304347826087, 1.375, 0.27777777777778
92022, 0.60869565217391, 1.3875, 0.27777777777778
92023, 0.60869565217391, 1.375, 0.30555555555556
92024, 0.6304347826087, 1.375, 0.33333333333333
92025, 0.60869565217391, 1.3875, 0.33333333333333
92026, 0.60869565217391, 1.375, 0.36111111111111
92027, 0.6304347826087, 1.375, 0.38888888888889
92028, 0.60869565217391, 1.3875, 0.38888888888889
92029, 0.60869565217391, 1.375, 0.41666666666667
92030, 0.6304347826087, 1.375, 0.44444444444444
92031, 0.60869565217391, 1.3875, 0.44444444444444
92032, 0.60869565217391, 1.375, 0.47222222222222
92033, 0.56521739130435, 1.375, 0.027777777777778
92034, 0.58695652173913, 1.375, 0.055555555555556
92035, 0.56521739130435, 1.3875, 0.055555555555556
92036, 0.56521739130435, 1.375, 0.083333333333333
92037, 0.58695652173913, 1.375, 0.11111111111111
92038, 0.56521739130435, 1.3875, 0.11111111111111
92039, 0.56521739130435, 1.375, 0.13888888888889
92040, 0.58695652173913, 1.375, 0.16666666666667
92041, 0.56521739130435, 1.3875, 0.16666666666667
92042, 0.56521739130435, 1.375, 0.19444444444444
92043, 0.58695652173913, 1.375, 0.22222222222222
92044, 0.56521739130435, 1.3875, 0.22222222222222
92045, 0.56521739130435, 1.375, 0.25
92046, 0.58695652173913, 1.375, 0.27777777777778
92047, 0.56521739130435, 1.3875, 0.27777777777778
92048, 0.56521739130435, 1.375, 0.30555555555556
92049, 0.58695652173913, 1.375, 0.33333333333333
92050, 0.56521739130435, 1.3875, 0.33333333333333
92051, 0.56521739130435, 1.375, 0.36111111111111
92052, 0.58695652173913, 1.375, 0.38888888888889
92053, 0.56521739130435, 1.3875, 0.38888888888889
92054, 0.56521739130435, 1.375, 0.41666666666667
92055, 0.58695652173913, 1.375, 0.44444444444444
92056, 0.56521739130435, 1.3875, 0.44444444444444
92057, 0.56521739130435, 1.375, 0.47222222222222
92058, 0.52173913043478, 1.375, 0.027777777777778
92059, 0.54347826086957, 1.375, 0.055555555555556
92060, 0.52173913043478, 1.3875, 0.055555555555556
92061, 0.52173913043478, 1.375, 0.083333333333333
92062, 0.54347826086957, 1.375, 0.11111111111111
92063, 0.52173913043478, 1.3875, 0.11111111111111
92064, 0.52173913043478, 1.375, 0.13888888888889
92065, 0.54347826086957, 1.375, 0.16666666666667
92066, 0.52173913043478, 1.3875, 0.16666666666667
92067, 0.52173913043478, 1.375, 0.19444444444444
92068, 0.54347826086956, 1.375, 0.22222222222222
92069, 0.52173913043478, 1.3875, 0.22222222222222
92070, 0.52173913043478, 1.375, 0.25
92071, 0.54347826086956, 1.375, 0.27777777777778
92072, 0.52173913043478, 1.3875, 0.27777777777778
92073, 0.52173913043478, 1.375, 0.30555555555556
92074, 0.54347826086956, 1.375, 0.33333333333333
92075, 0.52173913043478, 1.3875, 0.33333333333333
92076, 0.52173913043478, 1.375, 0.36111111111111
92077, 0.54347826086956, 1.375, 0.38888888888889
92078, 0.52173913043478, 1.3875, 0.38888888888889
92079, 0.52173913043478, 1.375, 0.41666666666667
92080, 0.54347826086956, 1.375, 0.44444444444444
92081, 0.52173913043478, 1.3875, 0.44444444444444
92082, 0.52173913043478, 1.375, 0.47222222222222
92083, 0.47826086956522, 1.375, 0.027777777777778
92084, 0.5, 1.375, 0.055555555555556
92085, 0.47826086956522, 1.3875, 0.055555555555556
92086, 0.47826086956522, 1.375, 0.083333333333333
92087, 0.5, 1.375, 0.11111111111111
92088, 0.47826086956522, 1.3875, 0.11111111111111
92089, 0.47826086956522, 1.375, 0.13888888888889
92090, 0.5, 1.375, 0.16666666666667
92091, 0.47826086956522, 1.3875, 0.16666666666667
92092, 0.47826086956522, 1.375, 0.19444444444444
92093, 0.5, 1.375, 0.22222222222222
92094, 0.47826086956522, 1.3875, 0.22222222222222
92095, 0.47826086956522, 1.375, 0.25
92096, 0.5, 1.375, 0.27777777777778
92097, 0.47826086956522, 1.3875, 0.27777777777778
92098, 0.47826086956522, 1.375, 0.30555555555556
92099, 0.5, 1.375, 0.33333333333333
92100, 0.47826086956522, 1.3875, 0.33333333333333
92101, 0.47826086956522, 1.375, 0.36111111111111
92102, 0.5, 1.375, 0.38888888888889
92103, 0.47826086956522, 1.3875, 0.38888888888889
92104, 0.47826086956522, 1.375, 0.41666666666667
92105, 0.5, 1.375, 0.44444444444444
92106, 0.47826086956522, 1.3875, 0.44444444444444
92107, 0.47826086956522, 1.375, 0.47222222222222
92108, 0.43478260869565, 1.375, 0.027777777777778
92109, 0.45652173913043, 1.375, 0.055555555555556
92110, 0.43478260869565, 1.3875, 0.055555555555556
92111, 0.43478260869565, 1.375, 0.083333333333333
92112, 0.45652173913043, 1.375, 0.11111111111111
92113, 0.43478260869565, 1.3875, 0.11111111111111
92114, 0.43478260869565, 1.375, 0.13888888888889
92115, 0.45652173913043, 1.375, 0.16666666666667
92116, 0.43478260869565, 1.3875, 0.16666666666667
92117, 0.43478260869565, 1.375, 0.19444444444444
92118, 0.45652173913043, 1.375, 0.22222222222222
92119, 0.43478260869565, 1.3875, 0.22222222222222
92120, 0.43478260869565, 1.375, 0.25
92121, 0.45652173913043, 1.375, 0.27777777777778
92122, 0.43478260869565, 1.3875, 0.27777777777778
92123, 0.43478260869565, 1.375, 0.30555555555556
92124, 0.45652173913043, 1.375, 0.33333333333333
92125, 0.43478260869565, 1.3875, 0.33333333333333
92126, 0.43478260869565, 1.375, 0.36111111111111
92127, 0.45652173913044, 1.375, 0.38888888888889
92128, 0.43478260869565, 1.3875, 0.38888888888889
92129, 0.43478260869565, 1.375, 0.41666666666667
92130, 0.45652173913043, 1.375, 0.44444444444444
92131, 0.43478260869565, 1.3875, 0.44444444444444
92132, 0.43478260869565, 1.375, 0.47222222222222
92133, 0.39130434782609, 1.375, 0.027777777777778
92134, 0.41304347826087, 1.375, 0.055555555555556
92135, 0.39130434782609, 1.3875, 0.055555555555556
92136, 0.39130434782609, 1.375, 0.083333333333333
