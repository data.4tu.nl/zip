8066, 0.78260869565217, -0.25, 0.47222222222222
8067, 0.82608695652174, -0.25, 0.027777777777778
8068, 0.80434782608696, -0.25, 0.055555555555556
8069, 0.82608695652174, -0.25, 0.083333333333333
8070, 0.80434782608696, -0.25, 0.11111111111111
8071, 0.82608695652174, -0.25, 0.13888888888889
8072, 0.80434782608696, -0.25, 0.16666666666667
8073, 0.82608695652174, -0.25, 0.19444444444444
8074, 0.80434782608696, -0.25, 0.22222222222222
8075, 0.82608695652174, -0.25, 0.25
8076, 0.80434782608696, -0.25, 0.27777777777778
8077, 0.82608695652174, -0.25, 0.30555555555556
8078, 0.80434782608696, -0.25, 0.33333333333333
8079, 0.82608695652174, -0.25, 0.36111111111111
8080, 0.80434782608696, -0.25, 0.38888888888889
8081, 0.82608695652174, -0.25, 0.41666666666667
8082, 0.80434782608696, -0.25, 0.44444444444444
8083, 0.82608695652174, -0.25, 0.47222222222222
8084, 0.8695652173913, -0.25, 0.027777777777778
8085, 0.84782608695652, -0.25, 0.055555555555556
8086, 0.8695652173913, -0.25, 0.083333333333333
8087, 0.84782608695652, -0.25, 0.11111111111111
8088, 0.8695652173913, -0.25, 0.13888888888889
8089, 0.84782608695652, -0.25, 0.16666666666667
8090, 0.8695652173913, -0.25, 0.19444444444444
8091, 0.84782608695652, -0.25, 0.22222222222222
8092, 0.8695652173913, -0.25, 0.25
8093, 0.84782608695652, -0.25, 0.27777777777778
8094, 0.8695652173913, -0.25, 0.30555555555556
8095, 0.84782608695652, -0.25, 0.33333333333333
8096, 0.8695652173913, -0.25, 0.36111111111111
8097, 0.84782608695652, -0.25, 0.38888888888889
8098, 0.8695652173913, -0.25, 0.41666666666667
8099, 0.84782608695652, -0.25, 0.44444444444444
8100, 0.8695652173913, -0.25, 0.47222222222222
8101, 0.91304347826087, -0.25, 0.027777777777778
8102, 0.89130434782609, -0.25, 0.055555555555556
8103, 0.91304347826087, -0.25, 0.083333333333333
8104, 0.89130434782609, -0.25, 0.11111111111111
8105, 0.91304347826087, -0.25, 0.13888888888889
8106, 0.89130434782609, -0.25, 0.16666666666667
8107, 0.91304347826087, -0.25, 0.19444444444444
8108, 0.89130434782609, -0.25, 0.22222222222222
8109, 0.91304347826087, -0.25, 0.25
8110, 0.89130434782609, -0.25, 0.27777777777778
8111, 0.91304347826087, -0.25, 0.30555555555556
8112, 0.89130434782609, -0.25, 0.33333333333333
8113, 0.91304347826087, -0.25, 0.36111111111111
8114, 0.89130434782609, -0.25, 0.38888888888889
8115, 0.91304347826087, -0.25, 0.41666666666667
8116, 0.89130434782609, -0.25, 0.44444444444444
8117, 0.91304347826087, -0.25, 0.47222222222222
8118, 0.95652173913043, -0.25, 0.027777777777778
8119, 0.93478260869565, -0.25, 0.055555555555556
8120, 0.95652173913043, -0.25, 0.083333333333333
8121, 0.93478260869565, -0.25, 0.11111111111111
8122, 0.95652173913043, -0.25, 0.13888888888889
8123, 0.93478260869565, -0.25, 0.16666666666667
8124, 0.95652173913043, -0.25, 0.19444444444444
8125, 0.93478260869565, -0.25, 0.22222222222222
8126, 0.95652173913043, -0.25, 0.25
8127, 0.93478260869565, -0.25, 0.27777777777778
8128, 0.95652173913043, -0.25, 0.30555555555556
8129, 0.93478260869565, -0.25, 0.33333333333333
8130, 0.95652173913043, -0.25, 0.36111111111111
8131, 0.93478260869565, -0.25, 0.38888888888889
8132, 0.95652173913043, -0.25, 0.41666666666667
8133, 0.93478260869565, -0.25, 0.44444444444444
8134, 0.95652173913043, -0.25, 0.47222222222222
8135, 0.97826086956522, -0.25, 0.055555555555556
8136, 0.97826086956522, -0.25, 0.11111111111111
8137, 0.97826086956522, -0.25, 0.16666666666667
8138, 0.97826086956522, -0.25, 0.22222222222222
8139, 0.97826086956522, -0.25, 0.27777777777778
8140, 0.97826086956522, -0.25, 0.33333333333333
8141, 0.97826086956522, -0.25, 0.38888888888889
8142, 0.97826086956522, -0.25, 0.44444444444444
8143, 1.05, -0.1, 0.5
8144, 1.05, -0.15, 0.5
8145, 1.05, -0.2, 0.5
8146, 1.1, -0.1, 0.5
8147, 1.1, -0.15, 0.5
8148, 1.1, -0.2, 0.5
8149, 1.15, -0.1, 0.5
8150, 1.15, -0.15, 0.5
8151, 1.15, -0.2, 0.5
8152, 1.025, -0.1, 0.5
8153, 1.05, -0.075, 0.5
8154, 1.025, -0.15, 0.5
8155, 1.05, -0.125, 0.5
8156, 1.025, -0.2, 0.5
8157, 1.05, -0.175, 0.5
8158, 1.05, -0.225, 0.5
8159, 1.075, -0.1, 0.5
8160, 1.1, -0.075, 0.5
8161, 1.075, -0.15, 0.5
8162, 1.1, -0.125, 0.5
8163, 1.075, -0.2, 0.5
8164, 1.1, -0.175, 0.5
8165, 1.1, -0.225, 0.5
8166, 1.125, -0.1, 0.5
8167, 1.15, -0.075, 0.5
8168, 1.125, -0.15, 0.5
8169, 1.15, -0.125, 0.5
8170, 1.125, -0.2, 0.5
8171, 1.15, -0.175, 0.5
8172, 1.15, -0.225, 0.5
8173, 1.175, -0.1, 0.5
8174, 1.175, -0.15, 0.5
8175, 1.175, -0.2, 0.5
8176, 1.05, -0.1, 0
8177, 1.05, -0.15, 0
8178, 1.05, -0.2, 0
8179, 1.1, -0.1, 0
8180, 1.1, -0.15, 0
8181, 1.1, -0.2, 0
8182, 1.15, -0.1, 0
8183, 1.15, -0.15, 0
8184, 1.15, -0.2, 0
8185, 1.05, -0.075, 0
8186, 1.025, -0.1, 0
8187, 1.05, -0.125, 0
8188, 1.025, -0.15, 0
8189, 1.05, -0.175, 0
8190, 1.025, -0.2, 0
8191, 1.05, -0.225, 0
8192, 1.1, -0.075, 0
8193, 1.075, -0.1, 0
8194, 1.1, -0.125, 0
8195, 1.075, -0.15, 0
8196, 1.1, -0.175, 0
8197, 1.075, -0.2, 0
8198, 1.1, -0.225, 0
8199, 1.15, -0.075, 0
8200, 1.125, -0.1, 0
8201, 1.15, -0.125, 0
8202, 1.125, -0.15, 0
8203, 1.15, -0.175, 0
8204, 1.125, -0.2, 0
8205, 1.15, -0.225, 0
8206, 1.175, -0.1, 0
8207, 1.175, -0.15, 0
8208, 1.175, -0.2, 0
8209, 1.05, -0.05, 0.44444444444444
8210, 1.05, -0.05, 0.38888888888889
8211, 1.05, -0.05, 0.33333333333333
8212, 1.05, -0.05, 0.27777777777778
8213, 1.05, -0.05, 0.22222222222222
8214, 1.05, -0.05, 0.16666666666667
8215, 1.05, -0.05, 0.11111111111111
8216, 1.05, -0.05, 0.055555555555556
8217, 1.1, -0.05, 0.44444444444444
8218, 1.1, -0.05, 0.38888888888889
8219, 1.1, -0.05, 0.33333333333333
8220, 1.1, -0.05, 0.27777777777778
8221, 1.1, -0.05, 0.22222222222222
8222, 1.1, -0.05, 0.16666666666667
8223, 1.1, -0.05, 0.11111111111111
8224, 1.1, -0.05, 0.055555555555556
8225, 1.15, -0.05, 0.44444444444444
8226, 1.15, -0.05, 0.38888888888889
8227, 1.15, -0.05, 0.33333333333333
8228, 1.15, -0.05, 0.27777777777778
8229, 1.15, -0.05, 0.22222222222222
8230, 1.15, -0.05, 0.16666666666667
8231, 1.15, -0.05, 0.11111111111111
8232, 1.15, -0.05, 0.055555555555556
8233, 1.05, -0.05, 0.47222222222222
8234, 1.025, -0.05, 0.44444444444444
8235, 1.05, -0.05, 0.41666666666667
8236, 1.025, -0.05, 0.38888888888889
8237, 1.05, -0.05, 0.36111111111111
8238, 1.025, -0.05, 0.33333333333333
8239, 1.05, -0.05, 0.30555555555556
8240, 1.025, -0.05, 0.27777777777778
8241, 1.05, -0.05, 0.25
8242, 1.025, -0.05, 0.22222222222222
8243, 1.05, -0.05, 0.19444444444444
8244, 1.025, -0.05, 0.16666666666667
8245, 1.05, -0.05, 0.13888888888889
8246, 1.025, -0.05, 0.11111111111111
8247, 1.05, -0.05, 0.083333333333333
8248, 1.025, -0.05, 0.055555555555556
8249, 1.05, -0.05, 0.027777777777778
8250, 1.1, -0.05, 0.47222222222222
8251, 1.075, -0.05, 0.44444444444444
8252, 1.1, -0.05, 0.41666666666667
8253, 1.075, -0.05, 0.38888888888889
8254, 1.1, -0.05, 0.36111111111111
8255, 1.075, -0.05, 0.33333333333333
8256, 1.1, -0.05, 0.30555555555556
8257, 1.075, -0.05, 0.27777777777778
8258, 1.1, -0.05, 0.25
8259, 1.075, -0.05, 0.22222222222222
8260, 1.1, -0.05, 0.19444444444444
8261, 1.075, -0.05, 0.16666666666667
8262, 1.1, -0.05, 0.13888888888889
8263, 1.075, -0.05, 0.11111111111111
8264, 1.1, -0.05, 0.083333333333333
8265, 1.075, -0.05, 0.055555555555556
8266, 1.1, -0.05, 0.027777777777778
8267, 1.15, -0.05, 0.47222222222222
8268, 1.125, -0.05, 0.44444444444444
8269, 1.15, -0.05, 0.41666666666667
8270, 1.125, -0.05, 0.38888888888889
8271, 1.15, -0.05, 0.36111111111111
8272, 1.125, -0.05, 0.33333333333333
8273, 1.15, -0.05, 0.30555555555556
8274, 1.125, -0.05, 0.27777777777778
8275, 1.15, -0.05, 0.25
8276, 1.125, -0.05, 0.22222222222222
8277, 1.15, -0.05, 0.19444444444444
8278, 1.125, -0.05, 0.16666666666667
8279, 1.15, -0.05, 0.13888888888889
8280, 1.125, -0.05, 0.11111111111111
8281, 1.15, -0.05, 0.083333333333333
8282, 1.125, -0.05, 0.055555555555556
8283, 1.15, -0.05, 0.027777777777778
8284, 1.175, -0.05, 0.44444444444444
8285, 1.175, -0.05, 0.38888888888889
8286, 1.175, -0.05, 0.33333333333333
8287, 1.175, -0.05, 0.27777777777778
8288, 1.175, -0.05, 0.22222222222222
8289, 1.175, -0.05, 0.16666666666667
8290, 1.175, -0.05, 0.11111111111111
8291, 1.175, -0.05, 0.055555555555556
8292, 1.05, -0.25, 0.44444444444444
8293, 1.05, -0.25, 0.38888888888889
8294, 1.05, -0.25, 0.33333333333333
8295, 1.05, -0.25, 0.27777777777778
8296, 1.05, -0.25, 0.22222222222222
8297, 1.05, -0.25, 0.16666666666667
8298, 1.05, -0.25, 0.11111111111111
8299, 1.05, -0.25, 0.055555555555556
8300, 1.1, -0.25, 0.44444444444444
8301, 1.1, -0.25, 0.38888888888889
8302, 1.1, -0.25, 0.33333333333333
8303, 1.1, -0.25, 0.27777777777778
8304, 1.1, -0.25, 0.22222222222222
8305, 1.1, -0.25, 0.16666666666667
8306, 1.1, -0.25, 0.11111111111111
8307, 1.1, -0.25, 0.055555555555556
8308, 1.15, -0.25, 0.44444444444444
8309, 1.15, -0.25, 0.38888888888889
8310, 1.15, -0.25, 0.33333333333333
8311, 1.15, -0.25, 0.27777777777778
8312, 1.15, -0.25, 0.22222222222222
8313, 1.15, -0.25, 0.16666666666667
8314, 1.15, -0.25, 0.11111111111111
8315, 1.15, -0.25, 0.055555555555556
8316, 1.025, -0.25, 0.44444444444444
8317, 1.05, -0.25, 0.47222222222222
8318, 1.025, -0.25, 0.38888888888889
8319, 1.05, -0.25, 0.41666666666667
8320, 1.025, -0.25, 0.33333333333333
8321, 1.05, -0.25, 0.36111111111111
8322, 1.025, -0.25, 0.27777777777778
8323, 1.05, -0.25, 0.30555555555556
8324, 1.025, -0.25, 0.22222222222222
8325, 1.05, -0.25, 0.25
8326, 1.025, -0.25, 0.16666666666667
8327, 1.05, -0.25, 0.19444444444444
8328, 1.025, -0.25, 0.11111111111111
8329, 1.05, -0.25, 0.13888888888889
8330, 1.025, -0.25, 0.055555555555556
8331, 1.05, -0.25, 0.083333333333333
8332, 1.05, -0.25, 0.027777777777778
8333, 1.075, -0.25, 0.44444444444444
8334, 1.1, -0.25, 0.47222222222222
8335, 1.075, -0.25, 0.38888888888889
8336, 1.1, -0.25, 0.41666666666667
8337, 1.075, -0.25, 0.33333333333333
8338, 1.1, -0.25, 0.36111111111111
8339, 1.075, -0.25, 0.27777777777778
8340, 1.1, -0.25, 0.30555555555556
8341, 1.075, -0.25, 0.22222222222222
8342, 1.1, -0.25, 0.25
8343, 1.075, -0.25, 0.16666666666667
8344, 1.1, -0.25, 0.19444444444444
8345, 1.075, -0.25, 0.11111111111111
8346, 1.1, -0.25, 0.13888888888889
8347, 1.075, -0.25, 0.055555555555556
8348, 1.1, -0.25, 0.083333333333333
8349, 1.1, -0.25, 0.027777777777778
8350, 1.125, -0.25, 0.44444444444444
8351, 1.15, -0.25, 0.47222222222222
8352, 1.125, -0.25, 0.38888888888889
8353, 1.15, -0.25, 0.41666666666667
8354, 1.125, -0.25, 0.33333333333333
8355, 1.15, -0.25, 0.36111111111111
8356, 1.125, -0.25, 0.27777777777778
8357, 1.15, -0.25, 0.30555555555556
8358, 1.125, -0.25, 0.22222222222222
8359, 1.15, -0.25, 0.25
8360, 1.125, -0.25, 0.16666666666667
8361, 1.15, -0.25, 0.19444444444444
8362, 1.125, -0.25, 0.11111111111111
8363, 1.15, -0.25, 0.13888888888889
8364, 1.125, -0.25, 0.055555555555556
8365, 1.15, -0.25, 0.083333333333333
8366, 1.15, -0.25, 0.027777777777778
8367, 1.175, -0.25, 0.44444444444444
8368, 1.175, -0.25, 0.38888888888889
8369, 1.175, -0.25, 0.33333333333333
8370, 1.175, -0.25, 0.27777777777778
8371, 1.175, -0.25, 0.22222222222222
8372, 1.175, -0.25, 0.16666666666667
8373, 1.175, -0.25, 0.11111111111111
8374, 1.175, -0.25, 0.055555555555556
8375, 1.2, -0.1, 0.44444444444444
8376, 1.2, -0.1, 0.38888888888889
8377, 1.2, -0.1, 0.33333333333333
8378, 1.2, -0.1, 0.27777777777778
8379, 1.2, -0.1, 0.22222222222222
8380, 1.2, -0.1, 0.16666666666667
8381, 1.2, -0.1, 0.11111111111111
8382, 1.2, -0.1, 0.055555555555556
8383, 1.2, -0.15, 0.44444444444444
8384, 1.2, -0.15, 0.38888888888889
8385, 1.2, -0.15, 0.33333333333333
8386, 1.2, -0.15, 0.27777777777778
8387, 1.2, -0.15, 0.22222222222222
8388, 1.2, -0.15, 0.16666666666667
8389, 1.2, -0.15, 0.11111111111111
8390, 1.2, -0.15, 0.055555555555556
8391, 1.2, -0.2, 0.44444444444444
8392, 1.2, -0.2, 0.38888888888889
8393, 1.2, -0.2, 0.33333333333333
8394, 1.2, -0.2, 0.27777777777778
8395, 1.2, -0.2, 0.22222222222222
8396, 1.2, -0.2, 0.16666666666667
8397, 1.2, -0.2, 0.11111111111111
8398, 1.2, -0.2, 0.055555555555556
8399, 1.2, -0.1, 0.47222222222222
8400, 1.2, -0.075, 0.44444444444444
8401, 1.2, -0.1, 0.41666666666667
8402, 1.2, -0.075, 0.38888888888889
8403, 1.2, -0.1, 0.36111111111111
8404, 1.2, -0.075, 0.33333333333333
8405, 1.2, -0.1, 0.30555555555556
8406, 1.2, -0.075, 0.27777777777778
8407, 1.2, -0.1, 0.25
8408, 1.2, -0.075, 0.22222222222222
8409, 1.2, -0.1, 0.19444444444444
8410, 1.2, -0.075, 0.16666666666667
8411, 1.2, -0.1, 0.13888888888889
8412, 1.2, -0.075, 0.11111111111111
8413, 1.2, -0.1, 0.083333333333333
8414, 1.2, -0.075, 0.055555555555556
8415, 1.2, -0.1, 0.027777777777778
8416, 1.2, -0.15, 0.47222222222222
8417, 1.2, -0.125, 0.44444444444444
8418, 1.2, -0.15, 0.41666666666667
8419, 1.2, -0.125, 0.38888888888889
8420, 1.2, -0.15, 0.36111111111111
8421, 1.2, -0.125, 0.33333333333333
8422, 1.2, -0.15, 0.30555555555556
8423, 1.2, -0.125, 0.27777777777778
8424, 1.2, -0.15, 0.25
8425, 1.2, -0.125, 0.22222222222222
8426, 1.2, -0.15, 0.19444444444444
8427, 1.2, -0.125, 0.16666666666667
8428, 1.2, -0.15, 0.13888888888889
8429, 1.2, -0.125, 0.11111111111111
8430, 1.2, -0.15, 0.083333333333333
8431, 1.2, -0.125, 0.055555555555556
8432, 1.2, -0.15, 0.027777777777778
8433, 1.2, -0.2, 0.47222222222222
8434, 1.2, -0.175, 0.44444444444444
8435, 1.2, -0.2, 0.41666666666667
8436, 1.2, -0.175, 0.38888888888889
8437, 1.2, -0.2, 0.36111111111111
8438, 1.2, -0.175, 0.33333333333333
8439, 1.2, -0.2, 0.30555555555556
8440, 1.2, -0.175, 0.27777777777778
8441, 1.2, -0.2, 0.25
8442, 1.2, -0.175, 0.22222222222222
8443, 1.2, -0.2, 0.19444444444444
8444, 1.2, -0.175, 0.16666666666667
8445, 1.2, -0.2, 0.13888888888889
8446, 1.2, -0.175, 0.11111111111111
8447, 1.2, -0.2, 0.083333333333333
8448, 1.2, -0.175, 0.055555555555556
8449, 1.2, -0.2, 0.027777777777778
8450, 1.2, -0.225, 0.44444444444444
8451, 1.2, -0.225, 0.38888888888889
8452, 1.2, -0.225, 0.33333333333333
8453, 1.2, -0.225, 0.27777777777778
8454, 1.2, -0.225, 0.22222222222222
8455, 1.2, -0.225, 0.16666666666667
8456, 1.2, -0.225, 0.11111111111111
8457, 1.2, -0.225, 0.055555555555556
8458, 1.2434782608696, -0.1, 0.5
8459, 1.2869565217391, -0.1, 0.5
8460, 1.3304347826087, -0.1, 0.5
8461, 1.3739130434783, -0.1, 0.5
8462, 1.4173913043478, -0.1, 0.5
8463, 1.4608695652174, -0.1, 0.5
8464, 1.504347826087, -0.1, 0.5
8465, 1.5478260869565, -0.1, 0.5
8466, 1.5913043478261, -0.1, 0.5
8467, 1.6347826086957, -0.1, 0.5
8468, 1.6782608695652, -0.1, 0.5
8469, 1.7217391304348, -0.1, 0.5
8470, 1.7652173913043, -0.1, 0.5
8471, 1.8086956521739, -0.1, 0.5
8472, 1.8521739130435, -0.1, 0.5
8473, 1.895652173913, -0.1, 0.5
8474, 1.9391304347826, -0.1, 0.5
8475, 1.9826086956522, -0.1, 0.5
8476, 2.0260869565217, -0.1, 0.5
8477, 2.0695652173913, -0.1, 0.5
8478, 2.1130434782609, -0.1, 0.5
8479, 2.1565217391304, -0.1, 0.5
8480, 1.2434782608696, -0.15, 0.5
8481, 1.2869565217391, -0.15, 0.5
8482, 1.3304347826087, -0.15, 0.5
8483, 1.3739130434783, -0.15, 0.5
8484, 1.4173913043478, -0.15, 0.5
8485, 1.4608695652174, -0.15, 0.5
8486, 1.504347826087, -0.15, 0.5
8487, 1.5478260869565, -0.15, 0.5
8488, 1.5913043478261, -0.15, 0.5
8489, 1.6347826086957, -0.15, 0.5
8490, 1.6782608695652, -0.15, 0.5
8491, 1.7217391304348, -0.15, 0.5
8492, 1.7652173913043, -0.15, 0.5
8493, 1.8086956521739, -0.15, 0.5
8494, 1.8521739130435, -0.15, 0.5
8495, 1.895652173913, -0.15, 0.5
8496, 1.9391304347826, -0.15, 0.5
8497, 1.9826086956522, -0.15, 0.5
8498, 2.0260869565217, -0.15, 0.5
8499, 2.0695652173913, -0.15, 0.5
8500, 2.1130434782609, -0.15, 0.5
8501, 2.1565217391304, -0.15, 0.5
8502, 1.2434782608696, -0.2, 0.5
8503, 1.2869565217391, -0.2, 0.5
8504, 1.3304347826087, -0.2, 0.5
8505, 1.3739130434783, -0.2, 0.5
8506, 1.4173913043478, -0.2, 0.5
8507, 1.4608695652174, -0.2, 0.5
8508, 1.504347826087, -0.2, 0.5
8509, 1.5478260869565, -0.2, 0.5
8510, 1.5913043478261, -0.2, 0.5
8511, 1.6347826086957, -0.2, 0.5
8512, 1.6782608695652, -0.2, 0.5
8513, 1.7217391304348, -0.2, 0.5
8514, 1.7652173913043, -0.2, 0.5
8515, 1.8086956521739, -0.2, 0.5
8516, 1.8521739130435, -0.2, 0.5
8517, 1.895652173913, -0.2, 0.5
8518, 1.9391304347826, -0.2, 0.5
8519, 1.9826086956522, -0.2, 0.5
8520, 2.0260869565217, -0.2, 0.5
8521, 2.0695652173913, -0.2, 0.5
8522, 2.1130434782609, -0.2, 0.5
8523, 2.1565217391304, -0.2, 0.5
8524, 1.2217391304348, -0.1, 0.5
8525, 1.2434782608696, -0.075, 0.5
8526, 1.2652173913043, -0.1, 0.5
8527, 1.2869565217391, -0.075, 0.5
8528, 1.3086956521739, -0.1, 0.5
8529, 1.3304347826087, -0.075, 0.5
8530, 1.3521739130435, -0.1, 0.5
8531, 1.3739130434783, -0.075, 0.5
8532, 1.395652173913, -0.1, 0.5
8533, 1.4173913043478, -0.075, 0.5
8534, 1.4391304347826, -0.1, 0.5
8535, 1.4608695652174, -0.075, 0.5
8536, 1.4826086956522, -0.1, 0.5
8537, 1.504347826087, -0.075, 0.5
8538, 1.5260869565217, -0.1, 0.5
8539, 1.5478260869565, -0.075, 0.5
8540, 1.5695652173913, -0.1, 0.5
8541, 1.5913043478261, -0.075, 0.5
8542, 1.6130434782609, -0.1, 0.5
8543, 1.6347826086957, -0.075, 0.5
8544, 1.6565217391304, -0.1, 0.5
8545, 1.6782608695652, -0.075, 0.5
8546, 1.7, -0.1, 0.5
8547, 1.7217391304348, -0.075, 0.5
8548, 1.7434782608696, -0.1, 0.5
8549, 1.7652173913043, -0.075, 0.5
8550, 1.7869565217391, -0.1, 0.5
8551, 1.8086956521739, -0.075, 0.5
8552, 1.8304347826087, -0.1, 0.5
8553, 1.8521739130435, -0.075, 0.5
8554, 1.8739130434783, -0.1, 0.5
8555, 1.895652173913, -0.075, 0.5
8556, 1.9173913043478, -0.1, 0.5
8557, 1.9391304347826, -0.075, 0.5
8558, 1.9608695652174, -0.1, 0.5
8559, 1.9826086956522, -0.075, 0.5
8560, 2.004347826087, -0.1, 0.5
8561, 2.0260869565217, -0.075, 0.5
8562, 2.0478260869565, -0.1, 0.5
8563, 2.0695652173913, -0.075, 0.5
8564, 2.0913043478261, -0.1, 0.5
8565, 2.1130434782609, -0.075, 0.5
8566, 2.1347826086957, -0.1, 0.5
8567, 2.1565217391304, -0.075, 0.5
8568, 2.1782608695652, -0.1, 0.5
8569, 1.2217391304348, -0.15, 0.5
8570, 1.2434782608696, -0.125, 0.5
8571, 1.2652173913043, -0.15, 0.5
8572, 1.2869565217391, -0.125, 0.5
8573, 1.3086956521739, -0.15, 0.5
8574, 1.3304347826087, -0.125, 0.5
8575, 1.3521739130435, -0.15, 0.5
8576, 1.3739130434783, -0.125, 0.5
8577, 1.395652173913, -0.15, 0.5
8578, 1.4173913043478, -0.125, 0.5
8579, 1.4391304347826, -0.15, 0.5
8580, 1.4608695652174, -0.125, 0.5
8581, 1.4826086956522, -0.15, 0.5
8582, 1.504347826087, -0.125, 0.5
8583, 1.5260869565217, -0.15, 0.5
8584, 1.5478260869565, -0.125, 0.5
8585, 1.5695652173913, -0.15, 0.5
8586, 1.5913043478261, -0.125, 0.5
8587, 1.6130434782609, -0.15, 0.5
8588, 1.6347826086957, -0.125, 0.5
8589, 1.6565217391304, -0.15, 0.5
8590, 1.6782608695652, -0.125, 0.5
8591, 1.7, -0.15, 0.5
8592, 1.7217391304348, -0.125, 0.5
8593, 1.7434782608696, -0.15, 0.5
8594, 1.7652173913043, -0.125, 0.5
8595, 1.7869565217391, -0.15, 0.5
8596, 1.8086956521739, -0.125, 0.5
8597, 1.8304347826087, -0.15, 0.5
8598, 1.8521739130435, -0.125, 0.5
8599, 1.8739130434783, -0.15, 0.5
8600, 1.895652173913, -0.125, 0.5
8601, 1.9173913043478, -0.15, 0.5
8602, 1.9391304347826, -0.125, 0.5
8603, 1.9608695652174, -0.15, 0.5
8604, 1.9826086956522, -0.125, 0.5
8605, 2.004347826087, -0.15, 0.5
8606, 2.0260869565217, -0.125, 0.5
8607, 2.0478260869565, -0.15, 0.5
8608, 2.0695652173913, -0.125, 0.5
8609, 2.0913043478261, -0.15, 0.5
8610, 2.1130434782609, -0.125, 0.5
8611, 2.1347826086957, -0.15, 0.5
8612, 2.1565217391304, -0.125, 0.5
8613, 2.1782608695652, -0.15, 0.5
8614, 1.2217391304348, -0.2, 0.5
8615, 1.2434782608696, -0.175, 0.5
8616, 1.2652173913043, -0.2, 0.5
8617, 1.2869565217391, -0.175, 0.5
8618, 1.3086956521739, -0.2, 0.5
8619, 1.3304347826087, -0.175, 0.5
8620, 1.3521739130435, -0.2, 0.5
8621, 1.3739130434783, -0.175, 0.5
8622, 1.395652173913, -0.2, 0.5
8623, 1.4173913043478, -0.175, 0.5
8624, 1.4391304347826, -0.2, 0.5
8625, 1.4608695652174, -0.175, 0.5
8626, 1.4826086956522, -0.2, 0.5
8627, 1.504347826087, -0.175, 0.5
8628, 1.5260869565217, -0.2, 0.5
8629, 1.5478260869565, -0.175, 0.5
8630, 1.5695652173913, -0.2, 0.5
8631, 1.5913043478261, -0.175, 0.5
8632, 1.6130434782609, -0.2, 0.5
8633, 1.6347826086957, -0.175, 0.5
8634, 1.6565217391304, -0.2, 0.5
8635, 1.6782608695652, -0.175, 0.5
8636, 1.7, -0.2, 0.5
8637, 1.7217391304348, -0.175, 0.5
8638, 1.7434782608696, -0.2, 0.5
8639, 1.7652173913043, -0.175, 0.5
8640, 1.7869565217391, -0.2, 0.5
8641, 1.8086956521739, -0.175, 0.5
8642, 1.8304347826087, -0.2, 0.5
8643, 1.8521739130435, -0.175, 0.5
8644, 1.8739130434783, -0.2, 0.5
8645, 1.895652173913, -0.175, 0.5
8646, 1.9173913043478, -0.2, 0.5
8647, 1.9391304347826, -0.175, 0.5
8648, 1.9608695652174, -0.2, 0.5
8649, 1.9826086956522, -0.175, 0.5
8650, 2.004347826087, -0.2, 0.5
8651, 2.0260869565217, -0.175, 0.5
8652, 2.0478260869565, -0.2, 0.5
8653, 2.0695652173913, -0.175, 0.5
8654, 2.0913043478261, -0.2, 0.5
8655, 2.1130434782609, -0.175, 0.5
8656, 2.1347826086957, -0.2, 0.5
8657, 2.1565217391304, -0.175, 0.5
8658, 2.1782608695652, -0.2, 0.5
8659, 1.2434782608696, -0.225, 0.5
8660, 1.2869565217391, -0.225, 0.5
8661, 1.3304347826087, -0.225, 0.5
8662, 1.3739130434783, -0.225, 0.5
8663, 1.4173913043478, -0.225, 0.5
8664, 1.4608695652174, -0.225, 0.5
8665, 1.504347826087, -0.225, 0.5
8666, 1.5478260869565, -0.225, 0.5
8667, 1.5913043478261, -0.225, 0.5
8668, 1.6347826086957, -0.225, 0.5
8669, 1.6782608695652, -0.225, 0.5
8670, 1.7217391304348, -0.225, 0.5
8671, 1.7652173913043, -0.225, 0.5
8672, 1.8086956521739, -0.225, 0.5
8673, 1.8521739130435, -0.225, 0.5
8674, 1.895652173913, -0.225, 0.5
8675, 1.9391304347826, -0.225, 0.5
8676, 1.9826086956522, -0.225, 0.5
8677, 2.0260869565217, -0.225, 0.5
8678, 2.0695652173913, -0.225, 0.5
8679, 2.1130434782609, -0.225, 0.5
8680, 2.1565217391304, -0.225, 0.5
8681, 1.2434782608696, -0.1, 0
8682, 1.2869565217391, -0.1, 0
8683, 1.3304347826087, -0.1, 0
8684, 1.3739130434783, -0.1, 0
8685, 1.4173913043478, -0.1, 0
8686, 1.4608695652174, -0.1, 0
8687, 1.504347826087, -0.1, 0
8688, 1.5478260869565, -0.1, 0
8689, 1.5913043478261, -0.1, 0
8690, 1.6347826086957, -0.1, 0
8691, 1.6782608695652, -0.1, 0
8692, 1.7217391304348, -0.1, 0
8693, 1.7652173913043, -0.1, 0
8694, 1.8086956521739, -0.1, 0
8695, 1.8521739130435, -0.1, 0
8696, 1.895652173913, -0.1, 0
8697, 1.9391304347826, -0.1, 0
8698, 1.9826086956522, -0.1, 0
8699, 2.0260869565217, -0.1, 0
8700, 2.0695652173913, -0.1, 0
8701, 2.1130434782609, -0.1, 0
8702, 2.1565217391304, -0.1, 0
8703, 1.2434782608696, -0.15, 0
8704, 1.2869565217391, -0.15, 0
8705, 1.3304347826087, -0.15, 0
8706, 1.3739130434783, -0.15, 0
8707, 1.4173913043478, -0.15, 0
8708, 1.4608695652174, -0.15, 0
8709, 1.504347826087, -0.15, 0
8710, 1.5478260869565, -0.15, 0
8711, 1.5913043478261, -0.15, 0
8712, 1.6347826086957, -0.15, 0
8713, 1.6782608695652, -0.15, 0
8714, 1.7217391304348, -0.15, 0
8715, 1.7652173913043, -0.15, 0
8716, 1.8086956521739, -0.15, 0
8717, 1.8521739130435, -0.15, 0
8718, 1.895652173913, -0.15, 0
8719, 1.9391304347826, -0.15, 0
8720, 1.9826086956522, -0.15, 0
8721, 2.0260869565217, -0.15, 0
8722, 2.0695652173913, -0.15, 0
8723, 2.1130434782609, -0.15, 0
8724, 2.1565217391304, -0.15, 0
8725, 1.2434782608696, -0.2, 0
8726, 1.2869565217391, -0.2, 0
8727, 1.3304347826087, -0.2, 0
8728, 1.3739130434783, -0.2, 0
8729, 1.4173913043478, -0.2, 0
8730, 1.4608695652174, -0.2, 0
8731, 1.504347826087, -0.2, 0
8732, 1.5478260869565, -0.2, 0
8733, 1.5913043478261, -0.2, 0
8734, 1.6347826086957, -0.2, 0
8735, 1.6782608695652, -0.2, 0
8736, 1.7217391304348, -0.2, 0
8737, 1.7652173913043, -0.2, 0
8738, 1.8086956521739, -0.2, 0
8739, 1.8521739130435, -0.2, 0
8740, 1.895652173913, -0.2, 0
8741, 1.9391304347826, -0.2, 0
8742, 1.9826086956522, -0.2, 0
8743, 2.0260869565217, -0.2, 0
8744, 2.0695652173913, -0.2, 0
8745, 2.1130434782609, -0.2, 0
8746, 2.1565217391304, -0.2, 0
8747, 1.2434782608696, -0.075, 0
8748, 1.2217391304348, -0.1, 0
8749, 1.2869565217391, -0.075, 0
8750, 1.2652173913043, -0.1, 0
8751, 1.3304347826087, -0.075, 0
8752, 1.3086956521739, -0.1, 0
8753, 1.3739130434783, -0.075, 0
8754, 1.3521739130435, -0.1, 0
8755, 1.4173913043478, -0.075, 0
8756, 1.395652173913, -0.1, 0
8757, 1.4608695652174, -0.075, 0
8758, 1.4391304347826, -0.1, 0
8759, 1.504347826087, -0.075, 0
8760, 1.4826086956522, -0.1, 0
8761, 1.5478260869565, -0.075, 0
8762, 1.5260869565217, -0.1, 0
8763, 1.5913043478261, -0.075, 0
8764, 1.5695652173913, -0.1, 0
8765, 1.6347826086957, -0.075, 0
8766, 1.6130434782609, -0.1, 0
8767, 1.6782608695652, -0.075, 0
8768, 1.6565217391304, -0.1, 0
8769, 1.7217391304348, -0.075, 0
8770, 1.7, -0.1, 0
8771, 1.7652173913043, -0.075, 0
8772, 1.7434782608696, -0.1, 0
8773, 1.8086956521739, -0.075, 0
8774, 1.7869565217391, -0.1, 0
8775, 1.8521739130435, -0.075, 0
8776, 1.8304347826087, -0.1, 0
8777, 1.895652173913, -0.075, 0
8778, 1.8739130434783, -0.1, 0
8779, 1.9391304347826, -0.075, 0
8780, 1.9173913043478, -0.1, 0
8781, 1.9826086956522, -0.075, 0
8782, 1.9608695652174, -0.1, 0
8783, 2.0260869565217, -0.075, 0
8784, 2.004347826087, -0.1, 0
8785, 2.0695652173913, -0.075, 0
8786, 2.0478260869565, -0.1, 0
8787, 2.1130434782609, -0.075, 0
8788, 2.0913043478261, -0.1, 0
8789, 2.1565217391304, -0.075, 0
8790, 2.1347826086957, -0.1, 0
8791, 2.1782608695652, -0.1, 0
8792, 1.2434782608696, -0.125, 0
8793, 1.2217391304348, -0.15, 0
8794, 1.2869565217391, -0.125, 0
8795, 1.2652173913043, -0.15, 0
8796, 1.3304347826087, -0.125, 0
8797, 1.3086956521739, -0.15, 0
8798, 1.3739130434783, -0.125, 0
8799, 1.3521739130435, -0.15, 0
8800, 1.4173913043478, -0.125, 0
8801, 1.395652173913, -0.15, 0
8802, 1.4608695652174, -0.125, 0
8803, 1.4391304347826, -0.15, 0
8804, 1.504347826087, -0.125, 0
8805, 1.4826086956522, -0.15, 0
8806, 1.5478260869565, -0.125, 0
8807, 1.5260869565217, -0.15, 0
8808, 1.5913043478261, -0.125, 0
8809, 1.5695652173913, -0.15, 0
8810, 1.6347826086957, -0.125, 0
8811, 1.6130434782609, -0.15, 0
8812, 1.6782608695652, -0.125, 0
8813, 1.6565217391304, -0.15, 0
8814, 1.7217391304348, -0.125, 0
8815, 1.7, -0.15, 0
8816, 1.7652173913043, -0.125, 0
8817, 1.7434782608696, -0.15, 0
8818, 1.8086956521739, -0.125, 0
8819, 1.7869565217391, -0.15, 0
8820, 1.8521739130435, -0.125, 0
8821, 1.8304347826087, -0.15, 0
8822, 1.895652173913, -0.125, 0
8823, 1.8739130434783, -0.15, 0
8824, 1.9391304347826, -0.125, 0
8825, 1.9173913043478, -0.15, 0
8826, 1.9826086956522, -0.125, 0
8827, 1.9608695652174, -0.15, 0
8828, 2.0260869565217, -0.125, 0
8829, 2.004347826087, -0.15, 0
8830, 2.0695652173913, -0.125, 0
8831, 2.0478260869565, -0.15, 0
8832, 2.1130434782609, -0.125, 0
8833, 2.0913043478261, -0.15, 0
8834, 2.1565217391304, -0.125, 0
8835, 2.1347826086957, -0.15, 0
8836, 2.1782608695652, -0.15, 0
8837, 1.2434782608696, -0.175, 0
8838, 1.2217391304348, -0.2, 0
8839, 1.2869565217391, -0.175, 0
8840, 1.2652173913043, -0.2, 0
8841, 1.3304347826087, -0.175, 0
8842, 1.3086956521739, -0.2, 0
8843, 1.3739130434783, -0.175, 0
8844, 1.3521739130435, -0.2, 0
8845, 1.4173913043478, -0.175, 0
8846, 1.395652173913, -0.2, 0
8847, 1.4608695652174, -0.175, 0
8848, 1.4391304347826, -0.2, 0
8849, 1.504347826087, -0.175, 0
8850, 1.4826086956522, -0.2, 0
8851, 1.5478260869565, -0.175, 0
8852, 1.5260869565217, -0.2, 0
8853, 1.5913043478261, -0.175, 0
8854, 1.5695652173913, -0.2, 0
8855, 1.6347826086957, -0.175, 0
8856, 1.6130434782609, -0.2, 0
8857, 1.6782608695652, -0.175, 0
8858, 1.6565217391304, -0.2, 0
8859, 1.7217391304348, -0.175, 0
8860, 1.7, -0.2, 0
8861, 1.7652173913043, -0.175, 0
8862, 1.7434782608696, -0.2, 0
8863, 1.8086956521739, -0.175, 0
8864, 1.7869565217391, -0.2, 0
8865, 1.8521739130435, -0.175, 0
8866, 1.8304347826087, -0.2, 0
8867, 1.895652173913, -0.175, 0
8868, 1.8739130434783, -0.2, 0
8869, 1.9391304347826, -0.175, 0
8870, 1.9173913043478, -0.2, 0
8871, 1.9826086956522, -0.175, 0
8872, 1.9608695652174, -0.2, 0
8873, 2.0260869565217, -0.175, 0
8874, 2.004347826087, -0.2, 0
8875, 2.0695652173913, -0.175, 0
8876, 2.0478260869565, -0.2, 0
8877, 2.1130434782609, -0.175, 0
8878, 2.0913043478261, -0.2, 0
8879, 2.1565217391304, -0.175, 0
8880, 2.1347826086957, -0.2, 0
8881, 2.1782608695652, -0.2, 0
8882, 1.2434782608696, -0.225, 0
8883, 1.2869565217391, -0.225, 0
8884, 1.3304347826087, -0.225, 0
8885, 1.3739130434783, -0.225, 0
8886, 1.4173913043478, -0.225, 0
8887, 1.4608695652174, -0.225, 0
8888, 1.504347826087, -0.225, 0
8889, 1.5478260869565, -0.225, 0
8890, 1.5913043478261, -0.225, 0
8891, 1.6347826086957, -0.225, 0
8892, 1.6782608695652, -0.225, 0
8893, 1.7217391304348, -0.225, 0
8894, 1.7652173913043, -0.225, 0
8895, 1.8086956521739, -0.225, 0
8896, 1.8521739130435, -0.225, 0
8897, 1.895652173913, -0.225, 0
8898, 1.9391304347826, -0.225, 0
8899, 1.9826086956522, -0.225, 0
8900, 2.0260869565217, -0.225, 0
8901, 2.0695652173913, -0.225, 0
8902, 2.1130434782609, -0.225, 0
8903, 2.1565217391304, -0.225, 0
8904, 2.2, -0.1, 0.44444444444444
8905, 2.2, -0.1, 0.38888888888889
8906, 2.2, -0.1, 0.33333333333333
8907, 2.2, -0.1, 0.27777777777778
8908, 2.2, -0.1, 0.22222222222222
8909, 2.2, -0.1, 0.16666666666667
8910, 2.2, -0.1, 0.11111111111111
8911, 2.2, -0.1, 0.055555555555556
8912, 2.2, -0.15, 0.44444444444444
8913, 2.2, -0.15, 0.38888888888889
8914, 2.2, -0.15, 0.33333333333333
8915, 2.2, -0.15, 0.27777777777778
8916, 2.2, -0.15, 0.22222222222222
8917, 2.2, -0.15, 0.16666666666667
8918, 2.2, -0.15, 0.11111111111111
8919, 2.2, -0.15, 0.055555555555556
8920, 2.2, -0.2, 0.44444444444444
8921, 2.2, -0.2, 0.38888888888889
8922, 2.2, -0.2, 0.33333333333333
8923, 2.2, -0.2, 0.27777777777778
8924, 2.2, -0.2, 0.22222222222222
8925, 2.2, -0.2, 0.16666666666667
8926, 2.2, -0.2, 0.11111111111111
8927, 2.2, -0.2, 0.055555555555556
8928, 2.2, -0.1, 0.47222222222222
8929, 2.2, -0.075, 0.44444444444444
8930, 2.2, -0.1, 0.41666666666667
8931, 2.2, -0.075, 0.38888888888889
8932, 2.2, -0.1, 0.36111111111111
8933, 2.2, -0.075, 0.33333333333333
8934, 2.2, -0.1, 0.30555555555556
8935, 2.2, -0.075, 0.27777777777778
8936, 2.2, -0.1, 0.25
8937, 2.2, -0.075, 0.22222222222222
8938, 2.2, -0.1, 0.19444444444444
8939, 2.2, -0.075, 0.16666666666667
8940, 2.2, -0.1, 0.13888888888889
8941, 2.2, -0.075, 0.11111111111111
8942, 2.2, -0.1, 0.083333333333333
8943, 2.2, -0.075, 0.055555555555556
8944, 2.2, -0.1, 0.027777777777778
8945, 2.2, -0.15, 0.47222222222222
8946, 2.2, -0.125, 0.44444444444444
8947, 2.2, -0.15, 0.41666666666667
8948, 2.2, -0.125, 0.38888888888889
8949, 2.2, -0.15, 0.36111111111111
8950, 2.2, -0.125, 0.33333333333333
8951, 2.2, -0.15, 0.30555555555556
8952, 2.2, -0.125, 0.27777777777778
8953, 2.2, -0.15, 0.25
8954, 2.2, -0.125, 0.22222222222222
8955, 2.2, -0.15, 0.19444444444444
8956, 2.2, -0.125, 0.16666666666667
8957, 2.2, -0.15, 0.13888888888889
8958, 2.2, -0.125, 0.11111111111111
8959, 2.2, -0.15, 0.083333333333333
8960, 2.2, -0.125, 0.055555555555556
8961, 2.2, -0.15, 0.027777777777778
8962, 2.2, -0.2, 0.47222222222222
8963, 2.2, -0.175, 0.44444444444444
8964, 2.2, -0.2, 0.41666666666667
8965, 2.2, -0.175, 0.38888888888889
8966, 2.2, -0.2, 0.36111111111111
8967, 2.2, -0.175, 0.33333333333333
8968, 2.2, -0.2, 0.30555555555556
8969, 2.2, -0.175, 0.27777777777778
8970, 2.2, -0.2, 0.25
8971, 2.2, -0.175, 0.22222222222222
8972, 2.2, -0.2, 0.19444444444444
8973, 2.2, -0.175, 0.16666666666667
8974, 2.2, -0.2, 0.13888888888889
8975, 2.2, -0.175, 0.11111111111111
8976, 2.2, -0.2, 0.083333333333333
8977, 2.2, -0.175, 0.055555555555556
8978, 2.2, -0.2, 0.027777777777778
8979, 2.2, -0.225, 0.44444444444444
8980, 2.2, -0.225, 0.38888888888889
8981, 2.2, -0.225, 0.33333333333333
8982, 2.2, -0.225, 0.27777777777778
8983, 2.2, -0.225, 0.22222222222222
8984, 2.2, -0.225, 0.16666666666667
8985, 2.2, -0.225, 0.11111111111111
8986, 2.2, -0.225, 0.055555555555556
8987, 1.2434782608696, -0.05, 0.44444444444444
8988, 1.2434782608696, -0.05, 0.38888888888889
8989, 1.2434782608696, -0.05, 0.33333333333333
8990, 1.2434782608696, -0.05, 0.27777777777778
8991, 1.2434782608696, -0.05, 0.22222222222222
8992, 1.2434782608696, -0.05, 0.16666666666667
8993, 1.2434782608696, -0.05, 0.11111111111111
8994, 1.2434782608696, -0.05, 0.055555555555556
8995, 1.2869565217391, -0.05, 0.44444444444444
8996, 1.2869565217391, -0.05, 0.38888888888889
8997, 1.2869565217391, -0.05, 0.33333333333333
8998, 1.2869565217391, -0.05, 0.27777777777778
8999, 1.2869565217391, -0.05, 0.22222222222222
9000, 1.2869565217391, -0.05, 0.16666666666667
9001, 1.2869565217391, -0.05, 0.11111111111111
9002, 1.2869565217391, -0.05, 0.055555555555556
9003, 1.3304347826087, -0.05, 0.44444444444444
9004, 1.3304347826087, -0.05, 0.38888888888889
9005, 1.3304347826087, -0.05, 0.33333333333333
9006, 1.3304347826087, -0.05, 0.27777777777778
9007, 1.3304347826087, -0.05, 0.22222222222222
9008, 1.3304347826087, -0.05, 0.16666666666667
9009, 1.3304347826087, -0.05, 0.11111111111111
9010, 1.3304347826087, -0.05, 0.055555555555556
9011, 1.3739130434783, -0.05, 0.44444444444444
9012, 1.3739130434783, -0.05, 0.38888888888889
9013, 1.3739130434783, -0.05, 0.33333333333333
9014, 1.3739130434783, -0.05, 0.27777777777778
9015, 1.3739130434783, -0.05, 0.22222222222222
9016, 1.3739130434783, -0.05, 0.16666666666667
9017, 1.3739130434783, -0.05, 0.11111111111111
9018, 1.3739130434783, -0.05, 0.055555555555556
9019, 1.4173913043478, -0.05, 0.44444444444444
9020, 1.4173913043478, -0.05, 0.38888888888889
9021, 1.4173913043478, -0.05, 0.33333333333333
9022, 1.4173913043478, -0.05, 0.27777777777778
9023, 1.4173913043478, -0.05, 0.22222222222222
9024, 1.4173913043478, -0.05, 0.16666666666667
9025, 1.4173913043478, -0.05, 0.11111111111111
9026, 1.4173913043478, -0.05, 0.055555555555556
9027, 1.4608695652174, -0.05, 0.44444444444444
9028, 1.4608695652174, -0.05, 0.38888888888889
9029, 1.4608695652174, -0.05, 0.33333333333333
9030, 1.4608695652174, -0.05, 0.27777777777778
9031, 1.4608695652174, -0.05, 0.22222222222222
9032, 1.4608695652174, -0.05, 0.16666666666667
9033, 1.4608695652174, -0.05, 0.11111111111111
9034, 1.4608695652174, -0.05, 0.055555555555556
9035, 1.504347826087, -0.05, 0.44444444444444
9036, 1.504347826087, -0.05, 0.38888888888889
9037, 1.504347826087, -0.05, 0.33333333333333
9038, 1.504347826087, -0.05, 0.27777777777778
9039, 1.504347826087, -0.05, 0.22222222222222
9040, 1.504347826087, -0.05, 0.16666666666667
9041, 1.504347826087, -0.05, 0.11111111111111
9042, 1.504347826087, -0.05, 0.055555555555556
9043, 1.5478260869565, -0.05, 0.44444444444444
9044, 1.5478260869565, -0.05, 0.38888888888889
9045, 1.5478260869565, -0.05, 0.33333333333333
9046, 1.5478260869565, -0.05, 0.27777777777778
9047, 1.5478260869565, -0.05, 0.22222222222222
9048, 1.5478260869565, -0.05, 0.16666666666667
9049, 1.5478260869565, -0.05, 0.11111111111111
9050, 1.5478260869565, -0.05, 0.055555555555556
9051, 1.5913043478261, -0.05, 0.44444444444444
9052, 1.5913043478261, -0.05, 0.38888888888889
9053, 1.5913043478261, -0.05, 0.33333333333333
9054, 1.5913043478261, -0.05, 0.27777777777778
9055, 1.5913043478261, -0.05, 0.22222222222222
9056, 1.5913043478261, -0.05, 0.16666666666667
9057, 1.5913043478261, -0.05, 0.11111111111111
9058, 1.5913043478261, -0.05, 0.055555555555556
9059, 1.6347826086957, -0.05, 0.44444444444444
9060, 1.6347826086957, -0.05, 0.38888888888889
9061, 1.6347826086957, -0.05, 0.33333333333333
9062, 1.6347826086957, -0.05, 0.27777777777778
9063, 1.6347826086957, -0.05, 0.22222222222222
9064, 1.6347826086957, -0.05, 0.16666666666667
9065, 1.6347826086957, -0.05, 0.11111111111111
9066, 1.6347826086957, -0.05, 0.055555555555556
9067, 1.6782608695652, -0.05, 0.44444444444444
9068, 1.6782608695652, -0.05, 0.38888888888889
9069, 1.6782608695652, -0.05, 0.33333333333333
9070, 1.6782608695652, -0.05, 0.27777777777778
9071, 1.6782608695652, -0.05, 0.22222222222222
9072, 1.6782608695652, -0.05, 0.16666666666667
9073, 1.6782608695652, -0.05, 0.11111111111111
9074, 1.6782608695652, -0.05, 0.055555555555556
9075, 1.7217391304348, -0.05, 0.44444444444444
9076, 1.7217391304348, -0.05, 0.38888888888889
9077, 1.7217391304348, -0.05, 0.33333333333333
9078, 1.7217391304348, -0.05, 0.27777777777778
9079, 1.7217391304348, -0.05, 0.22222222222222
9080, 1.7217391304348, -0.05, 0.16666666666667
9081, 1.7217391304348, -0.05, 0.11111111111111
9082, 1.7217391304348, -0.05, 0.055555555555556
9083, 1.7652173913043, -0.05, 0.44444444444444
9084, 1.7652173913043, -0.05, 0.38888888888889
9085, 1.7652173913043, -0.05, 0.33333333333333
9086, 1.7652173913043, -0.05, 0.27777777777778
9087, 1.7652173913043, -0.05, 0.22222222222222
9088, 1.7652173913043, -0.05, 0.16666666666667
9089, 1.7652173913043, -0.05, 0.11111111111111
9090, 1.7652173913043, -0.05, 0.055555555555556
9091, 1.8086956521739, -0.05, 0.44444444444444
9092, 1.8086956521739, -0.05, 0.38888888888889
9093, 1.8086956521739, -0.05, 0.33333333333333
9094, 1.8086956521739, -0.05, 0.27777777777778
9095, 1.8086956521739, -0.05, 0.22222222222222
9096, 1.8086956521739, -0.05, 0.16666666666667
9097, 1.8086956521739, -0.05, 0.11111111111111
9098, 1.8086956521739, -0.05, 0.055555555555556
9099, 1.8521739130435, -0.05, 0.44444444444444
9100, 1.8521739130435, -0.05, 0.38888888888889
9101, 1.8521739130435, -0.05, 0.33333333333333
9102, 1.8521739130435, -0.05, 0.27777777777778
9103, 1.8521739130435, -0.05, 0.22222222222222
9104, 1.8521739130435, -0.05, 0.16666666666667
9105, 1.8521739130435, -0.05, 0.11111111111111
9106, 1.8521739130435, -0.05, 0.055555555555556
9107, 1.895652173913, -0.05, 0.44444444444444
9108, 1.895652173913, -0.05, 0.38888888888889
9109, 1.895652173913, -0.05, 0.33333333333333
9110, 1.895652173913, -0.05, 0.27777777777778
9111, 1.895652173913, -0.05, 0.22222222222222
9112, 1.895652173913, -0.05, 0.16666666666667
9113, 1.895652173913, -0.05, 0.11111111111111
9114, 1.895652173913, -0.05, 0.055555555555556
9115, 1.9391304347826, -0.05, 0.44444444444444
9116, 1.9391304347826, -0.05, 0.38888888888889
9117, 1.9391304347826, -0.05, 0.33333333333333
9118, 1.9391304347826, -0.05, 0.27777777777778
9119, 1.9391304347826, -0.05, 0.22222222222222
9120, 1.9391304347826, -0.05, 0.16666666666667
9121, 1.9391304347826, -0.05, 0.11111111111111
9122, 1.9391304347826, -0.05, 0.055555555555556
9123, 1.9826086956522, -0.05, 0.44444444444444
9124, 1.9826086956522, -0.05, 0.38888888888889
9125, 1.9826086956522, -0.05, 0.33333333333333
9126, 1.9826086956522, -0.05, 0.27777777777778
9127, 1.9826086956522, -0.05, 0.22222222222222
9128, 1.9826086956522, -0.05, 0.16666666666667
9129, 1.9826086956522, -0.05, 0.11111111111111
9130, 1.9826086956522, -0.05, 0.055555555555556
9131, 2.0260869565217, -0.05, 0.44444444444444
9132, 2.0260869565217, -0.05, 0.38888888888889
9133, 2.0260869565217, -0.05, 0.33333333333333
9134, 2.0260869565217, -0.05, 0.27777777777778
9135, 2.0260869565217, -0.05, 0.22222222222222
9136, 2.0260869565217, -0.05, 0.16666666666667
9137, 2.0260869565217, -0.05, 0.11111111111111
9138, 2.0260869565217, -0.05, 0.055555555555556
9139, 2.0695652173913, -0.05, 0.44444444444444
9140, 2.0695652173913, -0.05, 0.38888888888889
9141, 2.0695652173913, -0.05, 0.33333333333333
9142, 2.0695652173913, -0.05, 0.27777777777778
9143, 2.0695652173913, -0.05, 0.22222222222222
9144, 2.0695652173913, -0.05, 0.16666666666667
9145, 2.0695652173913, -0.05, 0.11111111111111
9146, 2.0695652173913, -0.05, 0.055555555555556
9147, 2.1130434782609, -0.05, 0.44444444444444
9148, 2.1130434782609, -0.05, 0.38888888888889
9149, 2.1130434782609, -0.05, 0.33333333333333
9150, 2.1130434782609, -0.05, 0.27777777777778
9151, 2.1130434782609, -0.05, 0.22222222222222
9152, 2.1130434782609, -0.05, 0.16666666666667
9153, 2.1130434782609, -0.05, 0.11111111111111
9154, 2.1130434782609, -0.05, 0.055555555555556
9155, 2.1565217391304, -0.05, 0.44444444444444
9156, 2.1565217391304, -0.05, 0.38888888888889
9157, 2.1565217391304, -0.05, 0.33333333333333
9158, 2.1565217391304, -0.05, 0.27777777777778
9159, 2.1565217391304, -0.05, 0.22222222222222
9160, 2.1565217391304, -0.05, 0.16666666666667
9161, 2.1565217391304, -0.05, 0.11111111111111
9162, 2.1565217391304, -0.05, 0.055555555555556
9163, 1.2434782608696, -0.05, 0.47222222222222
9164, 1.2217391304348, -0.05, 0.44444444444444
9165, 1.2434782608696, -0.05, 0.41666666666667
9166, 1.2217391304348, -0.05, 0.38888888888889
9167, 1.2434782608696, -0.05, 0.36111111111111
9168, 1.2217391304348, -0.05, 0.33333333333333
9169, 1.2434782608696, -0.05, 0.30555555555556
9170, 1.2217391304348, -0.05, 0.27777777777778
9171, 1.2434782608696, -0.05, 0.25
9172, 1.2217391304348, -0.05, 0.22222222222222
9173, 1.2434782608696, -0.05, 0.19444444444444
9174, 1.2217391304348, -0.05, 0.16666666666667
9175, 1.2434782608696, -0.05, 0.13888888888889
9176, 1.2217391304348, -0.05, 0.11111111111111
9177, 1.2434782608696, -0.05, 0.083333333333333
9178, 1.2217391304348, -0.05, 0.055555555555556
9179, 1.2434782608696, -0.05, 0.027777777777778
9180, 1.2869565217391, -0.05, 0.47222222222222
9181, 1.2652173913043, -0.05, 0.44444444444444
9182, 1.2869565217391, -0.05, 0.41666666666667
9183, 1.2652173913043, -0.05, 0.38888888888889
9184, 1.2869565217391, -0.05, 0.36111111111111
9185, 1.2652173913043, -0.05, 0.33333333333333
9186, 1.2869565217391, -0.05, 0.30555555555556
9187, 1.2652173913043, -0.05, 0.27777777777778
9188, 1.2869565217391, -0.05, 0.25
9189, 1.2652173913043, -0.05, 0.22222222222222
9190, 1.2869565217391, -0.05, 0.19444444444444
9191, 1.2652173913043, -0.05, 0.16666666666667
9192, 1.2869565217391, -0.05, 0.13888888888889
9193, 1.2652173913043, -0.05, 0.11111111111111
9194, 1.2869565217391, -0.05, 0.083333333333333
9195, 1.2652173913043, -0.05, 0.055555555555556
9196, 1.2869565217391, -0.05, 0.027777777777778
9197, 1.3304347826087, -0.05, 0.47222222222222
9198, 1.3086956521739, -0.05, 0.44444444444444
9199, 1.3304347826087, -0.05, 0.41666666666667
9200, 1.3086956521739, -0.05, 0.38888888888889
9201, 1.3304347826087, -0.05, 0.36111111111111
9202, 1.3086956521739, -0.05, 0.33333333333333
9203, 1.3304347826087, -0.05, 0.30555555555556
9204, 1.3086956521739, -0.05, 0.27777777777778
9205, 1.3304347826087, -0.05, 0.25
9206, 1.3086956521739, -0.05, 0.22222222222222
9207, 1.3304347826087, -0.05, 0.19444444444444
9208, 1.3086956521739, -0.05, 0.16666666666667
9209, 1.3304347826087, -0.05, 0.13888888888889
9210, 1.3086956521739, -0.05, 0.11111111111111
9211, 1.3304347826087, -0.05, 0.083333333333333
9212, 1.3086956521739, -0.05, 0.055555555555556
9213, 1.3304347826087, -0.05, 0.027777777777778
9214, 1.3739130434783, -0.05, 0.47222222222222
9215, 1.3521739130435, -0.05, 0.44444444444444
9216, 1.3739130434783, -0.05, 0.41666666666667
9217, 1.3521739130435, -0.05, 0.38888888888889
9218, 1.3739130434783, -0.05, 0.36111111111111
9219, 1.3521739130435, -0.05, 0.33333333333333
9220, 1.3739130434783, -0.05, 0.30555555555556
9221, 1.3521739130435, -0.05, 0.27777777777778
9222, 1.3739130434783, -0.05, 0.25
9223, 1.3521739130435, -0.05, 0.22222222222222
9224, 1.3739130434783, -0.05, 0.19444444444444
9225, 1.3521739130435, -0.05, 0.16666666666667
9226, 1.3739130434783, -0.05, 0.13888888888889
9227, 1.3521739130435, -0.05, 0.11111111111111
9228, 1.3739130434783, -0.05, 0.083333333333333
9229, 1.3521739130435, -0.05, 0.055555555555556
9230, 1.3739130434783, -0.05, 0.027777777777778
9231, 1.4173913043478, -0.05, 0.47222222222222
9232, 1.395652173913, -0.05, 0.44444444444444
9233, 1.4173913043478, -0.05, 0.41666666666667
9234, 1.395652173913, -0.05, 0.38888888888889
9235, 1.4173913043478, -0.05, 0.36111111111111
9236, 1.395652173913, -0.05, 0.33333333333333
9237, 1.4173913043478, -0.05, 0.30555555555556
9238, 1.395652173913, -0.05, 0.27777777777778
9239, 1.4173913043478, -0.05, 0.25
9240, 1.395652173913, -0.05, 0.22222222222222
9241, 1.4173913043478, -0.05, 0.19444444444444
9242, 1.395652173913, -0.05, 0.16666666666667
9243, 1.4173913043478, -0.05, 0.13888888888889
9244, 1.395652173913, -0.05, 0.11111111111111
9245, 1.4173913043478, -0.05, 0.083333333333333
9246, 1.395652173913, -0.05, 0.055555555555556
9247, 1.4173913043478, -0.05, 0.027777777777778
9248, 1.4608695652174, -0.05, 0.47222222222222
9249, 1.4391304347826, -0.05, 0.44444444444444
9250, 1.4608695652174, -0.05, 0.41666666666667
9251, 1.4391304347826, -0.05, 0.38888888888889
9252, 1.4608695652174, -0.05, 0.36111111111111
9253, 1.4391304347826, -0.05, 0.33333333333333
9254, 1.4608695652174, -0.05, 0.30555555555556
9255, 1.4391304347826, -0.05, 0.27777777777778
9256, 1.4608695652174, -0.05, 0.25
9257, 1.4391304347826, -0.05, 0.22222222222222
9258, 1.4608695652174, -0.05, 0.19444444444444
9259, 1.4391304347826, -0.05, 0.16666666666667
9260, 1.4608695652174, -0.05, 0.13888888888889
9261, 1.4391304347826, -0.05, 0.11111111111111
9262, 1.4608695652174, -0.05, 0.083333333333333
9263, 1.4391304347826, -0.05, 0.055555555555556
9264, 1.4608695652174, -0.05, 0.027777777777778
9265, 1.504347826087, -0.05, 0.47222222222222
9266, 1.4826086956522, -0.05, 0.44444444444444
9267, 1.504347826087, -0.05, 0.41666666666667
9268, 1.4826086956522, -0.05, 0.38888888888889
9269, 1.504347826087, -0.05, 0.36111111111111
9270, 1.4826086956522, -0.05, 0.33333333333333
9271, 1.504347826087, -0.05, 0.30555555555556
9272, 1.4826086956522, -0.05, 0.27777777777778
9273, 1.504347826087, -0.05, 0.25
9274, 1.4826086956522, -0.05, 0.22222222222222
9275, 1.504347826087, -0.05, 0.19444444444444
9276, 1.4826086956522, -0.05, 0.16666666666667
9277, 1.504347826087, -0.05, 0.13888888888889
9278, 1.4826086956522, -0.05, 0.11111111111111
9279, 1.504347826087, -0.05, 0.083333333333333
9280, 1.4826086956522, -0.05, 0.055555555555556
9281, 1.504347826087, -0.05, 0.027777777777778
9282, 1.5478260869565, -0.05, 0.47222222222222
9283, 1.5260869565217, -0.05, 0.44444444444444
9284, 1.5478260869565, -0.05, 0.41666666666667
9285, 1.5260869565217, -0.05, 0.38888888888889
9286, 1.5478260869565, -0.05, 0.36111111111111
9287, 1.5260869565217, -0.05, 0.33333333333333
9288, 1.5478260869565, -0.05, 0.30555555555556
9289, 1.5260869565217, -0.05, 0.27777777777778
9290, 1.5478260869565, -0.05, 0.25
9291, 1.5260869565217, -0.05, 0.22222222222222
9292, 1.5478260869565, -0.05, 0.19444444444444
9293, 1.5260869565217, -0.05, 0.16666666666667
9294, 1.5478260869565, -0.05, 0.13888888888889
9295, 1.5260869565217, -0.05, 0.11111111111111
9296, 1.5478260869565, -0.05, 0.083333333333333
9297, 1.5260869565217, -0.05, 0.055555555555556
9298, 1.5478260869565, -0.05, 0.027777777777778
9299, 1.5913043478261, -0.05, 0.47222222222222
9300, 1.5695652173913, -0.05, 0.44444444444444
9301, 1.5913043478261, -0.05, 0.41666666666667
9302, 1.5695652173913, -0.05, 0.38888888888889
9303, 1.5913043478261, -0.05, 0.36111111111111
9304, 1.5695652173913, -0.05, 0.33333333333333
9305, 1.5913043478261, -0.05, 0.30555555555556
9306, 1.5695652173913, -0.05, 0.27777777777778
9307, 1.5913043478261, -0.05, 0.25
9308, 1.5695652173913, -0.05, 0.22222222222222
9309, 1.5913043478261, -0.05, 0.19444444444444
9310, 1.5695652173913, -0.05, 0.16666666666667
9311, 1.5913043478261, -0.05, 0.13888888888889
9312, 1.5695652173913, -0.05, 0.11111111111111
9313, 1.5913043478261, -0.05, 0.083333333333333
9314, 1.5695652173913, -0.05, 0.055555555555556
9315, 1.5913043478261, -0.05, 0.027777777777778
9316, 1.6347826086957, -0.05, 0.47222222222222
9317, 1.6130434782609, -0.05, 0.44444444444444
9318, 1.6347826086957, -0.05, 0.41666666666667
9319, 1.6130434782609, -0.05, 0.38888888888889
9320, 1.6347826086957, -0.05, 0.36111111111111
9321, 1.6130434782609, -0.05, 0.33333333333333
9322, 1.6347826086957, -0.05, 0.30555555555556
9323, 1.6130434782609, -0.05, 0.27777777777778
9324, 1.6347826086957, -0.05, 0.25
9325, 1.6130434782609, -0.05, 0.22222222222222
9326, 1.6347826086957, -0.05, 0.19444444444444
9327, 1.6130434782609, -0.05, 0.16666666666667
9328, 1.6347826086957, -0.05, 0.13888888888889
9329, 1.6130434782609, -0.05, 0.11111111111111
9330, 1.6347826086957, -0.05, 0.083333333333333
9331, 1.6130434782609, -0.05, 0.055555555555556
9332, 1.6347826086957, -0.05, 0.027777777777778
9333, 1.6782608695652, -0.05, 0.47222222222222
9334, 1.6565217391304, -0.05, 0.44444444444444
9335, 1.6782608695652, -0.05, 0.41666666666667
9336, 1.6565217391304, -0.05, 0.38888888888889
9337, 1.6782608695652, -0.05, 0.36111111111111
9338, 1.6565217391304, -0.05, 0.33333333333333
9339, 1.6782608695652, -0.05, 0.30555555555556
9340, 1.6565217391304, -0.05, 0.27777777777778
9341, 1.6782608695652, -0.05, 0.25
9342, 1.6565217391304, -0.05, 0.22222222222222
9343, 1.6782608695652, -0.05, 0.19444444444444
9344, 1.6565217391304, -0.05, 0.16666666666667
9345, 1.6782608695652, -0.05, 0.13888888888889
9346, 1.6565217391304, -0.05, 0.11111111111111
9347, 1.6782608695652, -0.05, 0.083333333333333
9348, 1.6565217391304, -0.05, 0.055555555555556
9349, 1.6782608695652, -0.05, 0.027777777777778
9350, 1.7217391304348, -0.05, 0.47222222222222
9351, 1.7, -0.05, 0.44444444444444
9352, 1.7217391304348, -0.05, 0.41666666666667
9353, 1.7, -0.05, 0.38888888888889
9354, 1.7217391304348, -0.05, 0.36111111111111
9355, 1.7, -0.05, 0.33333333333333
9356, 1.7217391304348, -0.05, 0.30555555555556
9357, 1.7, -0.05, 0.27777777777778
9358, 1.7217391304348, -0.05, 0.25
9359, 1.7, -0.05, 0.22222222222222
9360, 1.7217391304348, -0.05, 0.19444444444444
9361, 1.7, -0.05, 0.16666666666667
9362, 1.7217391304348, -0.05, 0.13888888888889
9363, 1.7, -0.05, 0.11111111111111
9364, 1.7217391304348, -0.05, 0.083333333333333
9365, 1.7, -0.05, 0.055555555555556
9366, 1.7217391304348, -0.05, 0.027777777777778
9367, 1.7652173913043, -0.05, 0.47222222222222
9368, 1.7434782608696, -0.05, 0.44444444444444
9369, 1.7652173913043, -0.05, 0.41666666666667
9370, 1.7434782608696, -0.05, 0.38888888888889
9371, 1.7652173913043, -0.05, 0.36111111111111
9372, 1.7434782608696, -0.05, 0.33333333333333
9373, 1.7652173913043, -0.05, 0.30555555555556
9374, 1.7434782608696, -0.05, 0.27777777777778
9375, 1.7652173913043, -0.05, 0.25
9376, 1.7434782608696, -0.05, 0.22222222222222
9377, 1.7652173913043, -0.05, 0.19444444444444
9378, 1.7434782608696, -0.05, 0.16666666666667
9379, 1.7652173913043, -0.05, 0.13888888888889
9380, 1.7434782608696, -0.05, 0.11111111111111
9381, 1.7652173913043, -0.05, 0.083333333333333
9382, 1.7434782608696, -0.05, 0.055555555555556
9383, 1.7652173913043, -0.05, 0.027777777777778
9384, 1.8086956521739, -0.05, 0.47222222222222
9385, 1.7869565217391, -0.05, 0.44444444444444
9386, 1.8086956521739, -0.05, 0.41666666666667
9387, 1.7869565217391, -0.05, 0.38888888888889
9388, 1.8086956521739, -0.05, 0.36111111111111
9389, 1.7869565217391, -0.05, 0.33333333333333
9390, 1.8086956521739, -0.05, 0.30555555555556
9391, 1.7869565217391, -0.05, 0.27777777777778
9392, 1.8086956521739, -0.05, 0.25
9393, 1.7869565217391, -0.05, 0.22222222222222
9394, 1.8086956521739, -0.05, 0.19444444444444
9395, 1.7869565217391, -0.05, 0.16666666666667
9396, 1.8086956521739, -0.05, 0.13888888888889
9397, 1.7869565217391, -0.05, 0.11111111111111
9398, 1.8086956521739, -0.05, 0.083333333333333
9399, 1.7869565217391, -0.05, 0.055555555555556
9400, 1.8086956521739, -0.05, 0.027777777777778
9401, 1.8521739130435, -0.05, 0.47222222222222
9402, 1.8304347826087, -0.05, 0.44444444444444
9403, 1.8521739130435, -0.05, 0.41666666666667
9404, 1.8304347826087, -0.05, 0.38888888888889
9405, 1.8521739130435, -0.05, 0.36111111111111
9406, 1.8304347826087, -0.05, 0.33333333333333
9407, 1.8521739130435, -0.05, 0.30555555555556
9408, 1.8304347826087, -0.05, 0.27777777777778
9409, 1.8521739130435, -0.05, 0.25
9410, 1.8304347826087, -0.05, 0.22222222222222
9411, 1.8521739130435, -0.05, 0.19444444444444
9412, 1.8304347826087, -0.05, 0.16666666666667
9413, 1.8521739130435, -0.05, 0.13888888888889
9414, 1.8304347826087, -0.05, 0.11111111111111
9415, 1.8521739130435, -0.05, 0.083333333333333
9416, 1.8304347826087, -0.05, 0.055555555555556
9417, 1.8521739130435, -0.05, 0.027777777777778
9418, 1.895652173913, -0.05, 0.47222222222222
9419, 1.8739130434783, -0.05, 0.44444444444444
9420, 1.895652173913, -0.05, 0.41666666666667
9421, 1.8739130434783, -0.05, 0.38888888888889
9422, 1.895652173913, -0.05, 0.36111111111111
9423, 1.8739130434783, -0.05, 0.33333333333333
9424, 1.895652173913, -0.05, 0.30555555555556
9425, 1.8739130434783, -0.05, 0.27777777777778
9426, 1.895652173913, -0.05, 0.25
9427, 1.8739130434783, -0.05, 0.22222222222222
9428, 1.895652173913, -0.05, 0.19444444444444
9429, 1.8739130434783, -0.05, 0.16666666666667
9430, 1.895652173913, -0.05, 0.13888888888889
9431, 1.8739130434783, -0.05, 0.11111111111111
9432, 1.895652173913, -0.05, 0.083333333333333
9433, 1.8739130434783, -0.05, 0.055555555555556
9434, 1.895652173913, -0.05, 0.027777777777778
9435, 1.9391304347826, -0.05, 0.47222222222222
9436, 1.9173913043478, -0.05, 0.44444444444444
9437, 1.9391304347826, -0.05, 0.41666666666667
9438, 1.9173913043478, -0.05, 0.38888888888889
9439, 1.9391304347826, -0.05, 0.36111111111111
9440, 1.9173913043478, -0.05, 0.33333333333333
9441, 1.9391304347826, -0.05, 0.30555555555556
9442, 1.9173913043478, -0.05, 0.27777777777778
9443, 1.9391304347826, -0.05, 0.25
9444, 1.9173913043478, -0.05, 0.22222222222222
9445, 1.9391304347826, -0.05, 0.19444444444444
9446, 1.9173913043478, -0.05, 0.16666666666667
9447, 1.9391304347826, -0.05, 0.13888888888889
9448, 1.9173913043478, -0.05, 0.11111111111111
9449, 1.9391304347826, -0.05, 0.083333333333333
9450, 1.9173913043478, -0.05, 0.055555555555556
9451, 1.9391304347826, -0.05, 0.027777777777778
9452, 1.9826086956522, -0.05, 0.47222222222222
9453, 1.9608695652174, -0.05, 0.44444444444444
9454, 1.9826086956522, -0.05, 0.41666666666667
9455, 1.9608695652174, -0.05, 0.38888888888889
9456, 1.9826086956522, -0.05, 0.36111111111111
9457, 1.9608695652174, -0.05, 0.33333333333333
9458, 1.9826086956522, -0.05, 0.30555555555556
9459, 1.9608695652174, -0.05, 0.27777777777778
9460, 1.9826086956522, -0.05, 0.25
9461, 1.9608695652174, -0.05, 0.22222222222222
9462, 1.9826086956522, -0.05, 0.19444444444444
9463, 1.9608695652174, -0.05, 0.16666666666667
9464, 1.9826086956522, -0.05, 0.13888888888889
9465, 1.9608695652174, -0.05, 0.11111111111111
9466, 1.9826086956522, -0.05, 0.083333333333333
9467, 1.9608695652174, -0.05, 0.055555555555556
9468, 1.9826086956522, -0.05, 0.027777777777778
9469, 2.0260869565217, -0.05, 0.47222222222222
9470, 2.004347826087, -0.05, 0.44444444444444
9471, 2.0260869565217, -0.05, 0.41666666666667
9472, 2.004347826087, -0.05, 0.38888888888889
9473, 2.0260869565217, -0.05, 0.36111111111111
9474, 2.004347826087, -0.05, 0.33333333333333
9475, 2.0260869565217, -0.05, 0.30555555555556
9476, 2.004347826087, -0.05, 0.27777777777778
9477, 2.0260869565217, -0.05, 0.25
9478, 2.004347826087, -0.05, 0.22222222222222
9479, 2.0260869565217, -0.05, 0.19444444444444
9480, 2.004347826087, -0.05, 0.16666666666667
9481, 2.0260869565217, -0.05, 0.13888888888889
9482, 2.004347826087, -0.05, 0.11111111111111
9483, 2.0260869565217, -0.05, 0.083333333333333
9484, 2.004347826087, -0.05, 0.055555555555556
9485, 2.0260869565217, -0.05, 0.027777777777778
9486, 2.0695652173913, -0.05, 0.47222222222222
9487, 2.0478260869565, -0.05, 0.44444444444444
9488, 2.0695652173913, -0.05, 0.41666666666667
9489, 2.0478260869565, -0.05, 0.38888888888889
9490, 2.0695652173913, -0.05, 0.36111111111111
9491, 2.0478260869565, -0.05, 0.33333333333333
9492, 2.0695652173913, -0.05, 0.30555555555556
9493, 2.0478260869565, -0.05, 0.27777777777778
9494, 2.0695652173913, -0.05, 0.25
9495, 2.0478260869565, -0.05, 0.22222222222222
9496, 2.0695652173913, -0.05, 0.19444444444444
9497, 2.0478260869565, -0.05, 0.16666666666667
9498, 2.0695652173913, -0.05, 0.13888888888889
9499, 2.0478260869565, -0.05, 0.11111111111111
9500, 2.0695652173913, -0.05, 0.083333333333333
9501, 2.0478260869565, -0.05, 0.055555555555556
9502, 2.0695652173913, -0.05, 0.027777777777778
9503, 2.1130434782609, -0.05, 0.47222222222222
9504, 2.0913043478261, -0.05, 0.44444444444444
9505, 2.1130434782609, -0.05, 0.41666666666667
9506, 2.0913043478261, -0.05, 0.38888888888889
9507, 2.1130434782609, -0.05, 0.36111111111111
9508, 2.0913043478261, -0.05, 0.33333333333333
9509, 2.1130434782609, -0.05, 0.30555555555556
9510, 2.0913043478261, -0.05, 0.27777777777778
9511, 2.1130434782609, -0.05, 0.25
9512, 2.0913043478261, -0.05, 0.22222222222222
9513, 2.1130434782609, -0.05, 0.19444444444444
9514, 2.0913043478261, -0.05, 0.16666666666667
9515, 2.1130434782609, -0.05, 0.13888888888889
9516, 2.0913043478261, -0.05, 0.11111111111111
9517, 2.1130434782609, -0.05, 0.083333333333333
9518, 2.0913043478261, -0.05, 0.055555555555556
9519, 2.1130434782609, -0.05, 0.027777777777778
9520, 2.1565217391304, -0.05, 0.47222222222222
9521, 2.1347826086957, -0.05, 0.44444444444444
9522, 2.1565217391304, -0.05, 0.41666666666667
9523, 2.1347826086957, -0.05, 0.38888888888889
9524, 2.1565217391304, -0.05, 0.36111111111111
9525, 2.1347826086957, -0.05, 0.33333333333333
9526, 2.1565217391304, -0.05, 0.30555555555556
9527, 2.1347826086957, -0.05, 0.27777777777778
9528, 2.1565217391304, -0.05, 0.25
9529, 2.1347826086957, -0.05, 0.22222222222222
9530, 2.1565217391304, -0.05, 0.19444444444444
9531, 2.1347826086957, -0.05, 0.16666666666667
9532, 2.1565217391304, -0.05, 0.13888888888889
9533, 2.1347826086957, -0.05, 0.11111111111111
9534, 2.1565217391304, -0.05, 0.083333333333333
9535, 2.1347826086957, -0.05, 0.055555555555556
9536, 2.1565217391304, -0.05, 0.027777777777778
9537, 2.1782608695652, -0.05, 0.44444444444444
9538, 2.1782608695652, -0.05, 0.38888888888889
9539, 2.1782608695652, -0.05, 0.33333333333333
9540, 2.1782608695652, -0.05, 0.27777777777778
9541, 2.1782608695652, -0.05, 0.22222222222222
9542, 2.1782608695652, -0.05, 0.16666666666667
9543, 2.1782608695652, -0.05, 0.11111111111111
9544, 2.1782608695652, -0.05, 0.055555555555556
9545, 1.2434782608696, -0.25, 0.44444444444444
9546, 1.2434782608696, -0.25, 0.38888888888889
9547, 1.2434782608696, -0.25, 0.33333333333333
9548, 1.2434782608696, -0.25, 0.27777777777778
9549, 1.2434782608696, -0.25, 0.22222222222222
9550, 1.2434782608696, -0.25, 0.16666666666667
9551, 1.2434782608696, -0.25, 0.11111111111111
9552, 1.2434782608696, -0.25, 0.055555555555556
9553, 1.2869565217391, -0.25, 0.44444444444444
9554, 1.2869565217391, -0.25, 0.38888888888889
9555, 1.2869565217391, -0.25, 0.33333333333333
9556, 1.2869565217391, -0.25, 0.27777777777778
9557, 1.2869565217391, -0.25, 0.22222222222222
9558, 1.2869565217391, -0.25, 0.16666666666667
9559, 1.2869565217391, -0.25, 0.11111111111111
9560, 1.2869565217391, -0.25, 0.055555555555556
9561, 1.3304347826087, -0.25, 0.44444444444444
9562, 1.3304347826087, -0.25, 0.38888888888889
9563, 1.3304347826087, -0.25, 0.33333333333333
9564, 1.3304347826087, -0.25, 0.27777777777778
9565, 1.3304347826087, -0.25, 0.22222222222222
9566, 1.3304347826087, -0.25, 0.16666666666667
9567, 1.3304347826087, -0.25, 0.11111111111111
9568, 1.3304347826087, -0.25, 0.055555555555556
9569, 1.3739130434783, -0.25, 0.44444444444444
9570, 1.3739130434783, -0.25, 0.38888888888889
9571, 1.3739130434783, -0.25, 0.33333333333333
9572, 1.3739130434783, -0.25, 0.27777777777778
9573, 1.3739130434783, -0.25, 0.22222222222222
9574, 1.3739130434783, -0.25, 0.16666666666667
9575, 1.3739130434783, -0.25, 0.11111111111111
9576, 1.3739130434783, -0.25, 0.055555555555556
9577, 1.4173913043478, -0.25, 0.44444444444444
9578, 1.4173913043478, -0.25, 0.38888888888889
9579, 1.4173913043478, -0.25, 0.33333333333333
9580, 1.4173913043478, -0.25, 0.27777777777778
9581, 1.4173913043478, -0.25, 0.22222222222222
9582, 1.4173913043478, -0.25, 0.16666666666667
9583, 1.4173913043478, -0.25, 0.11111111111111
9584, 1.4173913043478, -0.25, 0.055555555555556
9585, 1.4608695652174, -0.25, 0.44444444444444
9586, 1.4608695652174, -0.25, 0.38888888888889
9587, 1.4608695652174, -0.25, 0.33333333333333
9588, 1.4608695652174, -0.25, 0.27777777777778
9589, 1.4608695652174, -0.25, 0.22222222222222
9590, 1.4608695652174, -0.25, 0.16666666666667
9591, 1.4608695652174, -0.25, 0.11111111111111
9592, 1.4608695652174, -0.25, 0.055555555555556
9593, 1.504347826087, -0.25, 0.44444444444444
9594, 1.504347826087, -0.25, 0.38888888888889
9595, 1.504347826087, -0.25, 0.33333333333333
9596, 1.504347826087, -0.25, 0.27777777777778
9597, 1.504347826087, -0.25, 0.22222222222222
9598, 1.504347826087, -0.25, 0.16666666666667
9599, 1.504347826087, -0.25, 0.11111111111111
9600, 1.504347826087, -0.25, 0.055555555555556
9601, 1.5478260869565, -0.25, 0.44444444444444
9602, 1.5478260869565, -0.25, 0.38888888888889
9603, 1.5478260869565, -0.25, 0.33333333333333
9604, 1.5478260869565, -0.25, 0.27777777777778
9605, 1.5478260869565, -0.25, 0.22222222222222
9606, 1.5478260869565, -0.25, 0.16666666666667
9607, 1.5478260869565, -0.25, 0.11111111111111
9608, 1.5478260869565, -0.25, 0.055555555555556
9609, 1.5913043478261, -0.25, 0.44444444444444
9610, 1.5913043478261, -0.25, 0.38888888888889
9611, 1.5913043478261, -0.25, 0.33333333333333
9612, 1.5913043478261, -0.25, 0.27777777777778
9613, 1.5913043478261, -0.25, 0.22222222222222
9614, 1.5913043478261, -0.25, 0.16666666666667
9615, 1.5913043478261, -0.25, 0.11111111111111
9616, 1.5913043478261, -0.25, 0.055555555555556
9617, 1.6347826086957, -0.25, 0.44444444444444
9618, 1.6347826086957, -0.25, 0.38888888888889
9619, 1.6347826086957, -0.25, 0.33333333333333
9620, 1.6347826086957, -0.25, 0.27777777777778
9621, 1.6347826086957, -0.25, 0.22222222222222
9622, 1.6347826086957, -0.25, 0.16666666666667
9623, 1.6347826086957, -0.25, 0.11111111111111
9624, 1.6347826086957, -0.25, 0.055555555555556
9625, 1.6782608695652, -0.25, 0.44444444444444
9626, 1.6782608695652, -0.25, 0.38888888888889
9627, 1.6782608695652, -0.25, 0.33333333333333
9628, 1.6782608695652, -0.25, 0.27777777777778
9629, 1.6782608695652, -0.25, 0.22222222222222
9630, 1.6782608695652, -0.25, 0.16666666666667
9631, 1.6782608695652, -0.25, 0.11111111111111
9632, 1.6782608695652, -0.25, 0.055555555555556
9633, 1.7217391304348, -0.25, 0.44444444444444
9634, 1.7217391304348, -0.25, 0.38888888888889
9635, 1.7217391304348, -0.25, 0.33333333333333
9636, 1.7217391304348, -0.25, 0.27777777777778
9637, 1.7217391304348, -0.25, 0.22222222222222
9638, 1.7217391304348, -0.25, 0.16666666666667
9639, 1.7217391304348, -0.25, 0.11111111111111
9640, 1.7217391304348, -0.25, 0.055555555555556
9641, 1.7652173913043, -0.25, 0.44444444444444
9642, 1.7652173913043, -0.25, 0.38888888888889
9643, 1.7652173913043, -0.25, 0.33333333333333
9644, 1.7652173913043, -0.25, 0.27777777777778
9645, 1.7652173913043, -0.25, 0.22222222222222
9646, 1.7652173913043, -0.25, 0.16666666666667
9647, 1.7652173913043, -0.25, 0.11111111111111
9648, 1.7652173913043, -0.25, 0.055555555555556
9649, 1.8086956521739, -0.25, 0.44444444444444
9650, 1.8086956521739, -0.25, 0.38888888888889
9651, 1.8086956521739, -0.25, 0.33333333333333
9652, 1.8086956521739, -0.25, 0.27777777777778
9653, 1.8086956521739, -0.25, 0.22222222222222
9654, 1.8086956521739, -0.25, 0.16666666666667
9655, 1.8086956521739, -0.25, 0.11111111111111
9656, 1.8086956521739, -0.25, 0.055555555555556
9657, 1.8521739130435, -0.25, 0.44444444444444
9658, 1.8521739130435, -0.25, 0.38888888888889
9659, 1.8521739130435, -0.25, 0.33333333333333
9660, 1.8521739130435, -0.25, 0.27777777777778
9661, 1.8521739130435, -0.25, 0.22222222222222
9662, 1.8521739130435, -0.25, 0.16666666666667
9663, 1.8521739130435, -0.25, 0.11111111111111
9664, 1.8521739130435, -0.25, 0.055555555555556
9665, 1.895652173913, -0.25, 0.44444444444444
9666, 1.895652173913, -0.25, 0.38888888888889
9667, 1.895652173913, -0.25, 0.33333333333333
9668, 1.895652173913, -0.25, 0.27777777777778
9669, 1.895652173913, -0.25, 0.22222222222222
9670, 1.895652173913, -0.25, 0.16666666666667
9671, 1.895652173913, -0.25, 0.11111111111111
9672, 1.895652173913, -0.25, 0.055555555555556
9673, 1.9391304347826, -0.25, 0.44444444444444
9674, 1.9391304347826, -0.25, 0.38888888888889
9675, 1.9391304347826, -0.25, 0.33333333333333
9676, 1.9391304347826, -0.25, 0.27777777777778
9677, 1.9391304347826, -0.25, 0.22222222222222
9678, 1.9391304347826, -0.25, 0.16666666666667
9679, 1.9391304347826, -0.25, 0.11111111111111
9680, 1.9391304347826, -0.25, 0.055555555555556
9681, 1.9826086956522, -0.25, 0.44444444444444
9682, 1.9826086956522, -0.25, 0.38888888888889
9683, 1.9826086956522, -0.25, 0.33333333333333
9684, 1.9826086956522, -0.25, 0.27777777777778
9685, 1.9826086956522, -0.25, 0.22222222222222
9686, 1.9826086956522, -0.25, 0.16666666666667
9687, 1.9826086956522, -0.25, 0.11111111111111
9688, 1.9826086956522, -0.25, 0.055555555555556
9689, 2.0260869565217, -0.25, 0.44444444444444
9690, 2.0260869565217, -0.25, 0.38888888888889
9691, 2.0260869565217, -0.25, 0.33333333333333
9692, 2.0260869565217, -0.25, 0.27777777777778
9693, 2.0260869565217, -0.25, 0.22222222222222
9694, 2.0260869565217, -0.25, 0.16666666666667
9695, 2.0260869565217, -0.25, 0.11111111111111
9696, 2.0260869565217, -0.25, 0.055555555555556
9697, 2.0695652173913, -0.25, 0.44444444444444
9698, 2.0695652173913, -0.25, 0.38888888888889
9699, 2.0695652173913, -0.25, 0.33333333333333
9700, 2.0695652173913, -0.25, 0.27777777777778
9701, 2.0695652173913, -0.25, 0.22222222222222
9702, 2.0695652173913, -0.25, 0.16666666666667
9703, 2.0695652173913, -0.25, 0.11111111111111
9704, 2.0695652173913, -0.25, 0.055555555555556
9705, 2.1130434782609, -0.25, 0.44444444444444
9706, 2.1130434782609, -0.25, 0.38888888888889
9707, 2.1130434782609, -0.25, 0.33333333333333
9708, 2.1130434782609, -0.25, 0.27777777777778
9709, 2.1130434782609, -0.25, 0.22222222222222
9710, 2.1130434782609, -0.25, 0.16666666666667
9711, 2.1130434782609, -0.25, 0.11111111111111
9712, 2.1130434782609, -0.25, 0.055555555555556
9713, 2.1565217391304, -0.25, 0.44444444444444
9714, 2.1565217391304, -0.25, 0.38888888888889
9715, 2.1565217391304, -0.25, 0.33333333333333
9716, 2.1565217391304, -0.25, 0.27777777777778
9717, 2.1565217391304, -0.25, 0.22222222222222
9718, 2.1565217391304, -0.25, 0.16666666666667
9719, 2.1565217391304, -0.25, 0.11111111111111
9720, 2.1565217391304, -0.25, 0.055555555555556
9721, 1.2217391304348, -0.25, 0.44444444444444
9722, 1.2434782608696, -0.25, 0.47222222222222
9723, 1.2217391304348, -0.25, 0.38888888888889
9724, 1.2434782608696, -0.25, 0.41666666666667
9725, 1.2217391304348, -0.25, 0.33333333333333
9726, 1.2434782608696, -0.25, 0.36111111111111
9727, 1.2217391304348, -0.25, 0.27777777777778
9728, 1.2434782608696, -0.25, 0.30555555555556
9729, 1.2217391304348, -0.25, 0.22222222222222
9730, 1.2434782608696, -0.25, 0.25
9731, 1.2217391304348, -0.25, 0.16666666666667
9732, 1.2434782608696, -0.25, 0.19444444444444
9733, 1.2217391304348, -0.25, 0.11111111111111
9734, 1.2434782608696, -0.25, 0.13888888888889
9735, 1.2217391304348, -0.25, 0.055555555555556
9736, 1.2434782608696, -0.25, 0.083333333333333
9737, 1.2434782608696, -0.25, 0.027777777777778
9738, 1.2652173913043, -0.25, 0.44444444444444
9739, 1.2869565217391, -0.25, 0.47222222222222
9740, 1.2652173913043, -0.25, 0.38888888888889
9741, 1.2869565217391, -0.25, 0.41666666666667
9742, 1.2652173913043, -0.25, 0.33333333333333
9743, 1.2869565217391, -0.25, 0.36111111111111
9744, 1.2652173913043, -0.25, 0.27777777777778
9745, 1.2869565217391, -0.25, 0.30555555555556
9746, 1.2652173913043, -0.25, 0.22222222222222
9747, 1.2869565217391, -0.25, 0.25
9748, 1.2652173913043, -0.25, 0.16666666666667
9749, 1.2869565217391, -0.25, 0.19444444444444
9750, 1.2652173913043, -0.25, 0.11111111111111
9751, 1.2869565217391, -0.25, 0.13888888888889
9752, 1.2652173913043, -0.25, 0.055555555555556
9753, 1.2869565217391, -0.25, 0.083333333333333
9754, 1.2869565217391, -0.25, 0.027777777777778
9755, 1.3086956521739, -0.25, 0.44444444444444
9756, 1.3304347826087, -0.25, 0.47222222222222
9757, 1.3086956521739, -0.25, 0.38888888888889
9758, 1.3304347826087, -0.25, 0.41666666666667
9759, 1.3086956521739, -0.25, 0.33333333333333
9760, 1.3304347826087, -0.25, 0.36111111111111
9761, 1.3086956521739, -0.25, 0.27777777777778
9762, 1.3304347826087, -0.25, 0.30555555555556
9763, 1.3086956521739, -0.25, 0.22222222222222
9764, 1.3304347826087, -0.25, 0.25
9765, 1.3086956521739, -0.25, 0.16666666666667
9766, 1.3304347826087, -0.25, 0.19444444444444
9767, 1.3086956521739, -0.25, 0.11111111111111
9768, 1.3304347826087, -0.25, 0.13888888888889
9769, 1.3086956521739, -0.25, 0.055555555555556
9770, 1.3304347826087, -0.25, 0.083333333333333
9771, 1.3304347826087, -0.25, 0.027777777777778
9772, 1.3521739130435, -0.25, 0.44444444444444
9773, 1.3739130434783, -0.25, 0.47222222222222
9774, 1.3521739130435, -0.25, 0.38888888888889
9775, 1.3739130434783, -0.25, 0.41666666666667
9776, 1.3521739130435, -0.25, 0.33333333333333
9777, 1.3739130434783, -0.25, 0.36111111111111
9778, 1.3521739130435, -0.25, 0.27777777777778
9779, 1.3739130434783, -0.25, 0.30555555555556
9780, 1.3521739130435, -0.25, 0.22222222222222
9781, 1.3739130434783, -0.25, 0.25
9782, 1.3521739130435, -0.25, 0.16666666666667
9783, 1.3739130434783, -0.25, 0.19444444444444
9784, 1.3521739130435, -0.25, 0.11111111111111
9785, 1.3739130434783, -0.25, 0.13888888888889
9786, 1.3521739130435, -0.25, 0.055555555555556
9787, 1.3739130434783, -0.25, 0.083333333333333
9788, 1.3739130434783, -0.25, 0.027777777777778
9789, 1.395652173913, -0.25, 0.44444444444444
9790, 1.4173913043478, -0.25, 0.47222222222222
9791, 1.395652173913, -0.25, 0.38888888888889
9792, 1.4173913043478, -0.25, 0.41666666666667
9793, 1.395652173913, -0.25, 0.33333333333333
9794, 1.4173913043478, -0.25, 0.36111111111111
9795, 1.395652173913, -0.25, 0.27777777777778
9796, 1.4173913043478, -0.25, 0.30555555555556
9797, 1.395652173913, -0.25, 0.22222222222222
9798, 1.4173913043478, -0.25, 0.25
9799, 1.395652173913, -0.25, 0.16666666666667
9800, 1.4173913043478, -0.25, 0.19444444444444
9801, 1.395652173913, -0.25, 0.11111111111111
9802, 1.4173913043478, -0.25, 0.13888888888889
9803, 1.395652173913, -0.25, 0.055555555555556
9804, 1.4173913043478, -0.25, 0.083333333333333
9805, 1.4173913043478, -0.25, 0.027777777777778
9806, 1.4391304347826, -0.25, 0.44444444444444
9807, 1.4608695652174, -0.25, 0.47222222222222
9808, 1.4391304347826, -0.25, 0.38888888888889
9809, 1.4608695652174, -0.25, 0.41666666666667
9810, 1.4391304347826, -0.25, 0.33333333333333
9811, 1.4608695652174, -0.25, 0.36111111111111
9812, 1.4391304347826, -0.25, 0.27777777777778
9813, 1.4608695652174, -0.25, 0.30555555555556
9814, 1.4391304347826, -0.25, 0.22222222222222
9815, 1.4608695652174, -0.25, 0.25
9816, 1.4391304347826, -0.25, 0.16666666666667
9817, 1.4608695652174, -0.25, 0.19444444444444
9818, 1.4391304347826, -0.25, 0.11111111111111
9819, 1.4608695652174, -0.25, 0.13888888888889
9820, 1.4391304347826, -0.25, 0.055555555555556
9821, 1.4608695652174, -0.25, 0.083333333333333
9822, 1.4608695652174, -0.25, 0.027777777777778
9823, 1.4826086956522, -0.25, 0.44444444444444
9824, 1.504347826087, -0.25, 0.47222222222222
9825, 1.4826086956522, -0.25, 0.38888888888889
9826, 1.504347826087, -0.25, 0.41666666666667
9827, 1.4826086956522, -0.25, 0.33333333333333
9828, 1.504347826087, -0.25, 0.36111111111111
9829, 1.4826086956522, -0.25, 0.27777777777778
9830, 1.504347826087, -0.25, 0.30555555555556
9831, 1.4826086956522, -0.25, 0.22222222222222
9832, 1.504347826087, -0.25, 0.25
9833, 1.4826086956522, -0.25, 0.16666666666667
9834, 1.504347826087, -0.25, 0.19444444444444
9835, 1.4826086956522, -0.25, 0.11111111111111
9836, 1.504347826087, -0.25, 0.13888888888889
9837, 1.4826086956522, -0.25, 0.055555555555556
9838, 1.504347826087, -0.25, 0.083333333333333
9839, 1.504347826087, -0.25, 0.027777777777778
9840, 1.5260869565217, -0.25, 0.44444444444444
9841, 1.5478260869565, -0.25, 0.47222222222222
9842, 1.5260869565217, -0.25, 0.38888888888889
9843, 1.5478260869565, -0.25, 0.41666666666667
9844, 1.5260869565217, -0.25, 0.33333333333333
9845, 1.5478260869565, -0.25, 0.36111111111111
9846, 1.5260869565217, -0.25, 0.27777777777778
9847, 1.5478260869565, -0.25, 0.30555555555556
9848, 1.5260869565217, -0.25, 0.22222222222222
9849, 1.5478260869565, -0.25, 0.25
9850, 1.5260869565217, -0.25, 0.16666666666667
9851, 1.5478260869565, -0.25, 0.19444444444444
9852, 1.5260869565217, -0.25, 0.11111111111111
9853, 1.5478260869565, -0.25, 0.13888888888889
9854, 1.5260869565217, -0.25, 0.055555555555556
9855, 1.5478260869565, -0.25, 0.083333333333333
9856, 1.5478260869565, -0.25, 0.027777777777778
9857, 1.5695652173913, -0.25, 0.44444444444444
9858, 1.5913043478261, -0.25, 0.47222222222222
9859, 1.5695652173913, -0.25, 0.38888888888889
9860, 1.5913043478261, -0.25, 0.41666666666667
9861, 1.5695652173913, -0.25, 0.33333333333333
9862, 1.5913043478261, -0.25, 0.36111111111111
9863, 1.5695652173913, -0.25, 0.27777777777778
9864, 1.5913043478261, -0.25, 0.30555555555556
9865, 1.5695652173913, -0.25, 0.22222222222222
9866, 1.5913043478261, -0.25, 0.25
9867, 1.5695652173913, -0.25, 0.16666666666667
9868, 1.5913043478261, -0.25, 0.19444444444444
9869, 1.5695652173913, -0.25, 0.11111111111111
9870, 1.5913043478261, -0.25, 0.13888888888889
9871, 1.5695652173913, -0.25, 0.055555555555556
9872, 1.5913043478261, -0.25, 0.083333333333333
9873, 1.5913043478261, -0.25, 0.027777777777778
9874, 1.6130434782609, -0.25, 0.44444444444444
9875, 1.6347826086957, -0.25, 0.47222222222222
9876, 1.6130434782609, -0.25, 0.38888888888889
9877, 1.6347826086957, -0.25, 0.41666666666667
9878, 1.6130434782609, -0.25, 0.33333333333333
9879, 1.6347826086957, -0.25, 0.36111111111111
9880, 1.6130434782609, -0.25, 0.27777777777778
9881, 1.6347826086957, -0.25, 0.30555555555556
9882, 1.6130434782609, -0.25, 0.22222222222222
9883, 1.6347826086957, -0.25, 0.25
9884, 1.6130434782609, -0.25, 0.16666666666667
9885, 1.6347826086957, -0.25, 0.19444444444444
9886, 1.6130434782609, -0.25, 0.11111111111111
9887, 1.6347826086957, -0.25, 0.13888888888889
9888, 1.6130434782609, -0.25, 0.055555555555556
9889, 1.6347826086957, -0.25, 0.083333333333333
9890, 1.6347826086957, -0.25, 0.027777777777778
9891, 1.6565217391304, -0.25, 0.44444444444444
9892, 1.6782608695652, -0.25, 0.47222222222222
9893, 1.6565217391304, -0.25, 0.38888888888889
9894, 1.6782608695652, -0.25, 0.41666666666667
9895, 1.6565217391304, -0.25, 0.33333333333333
9896, 1.6782608695652, -0.25, 0.36111111111111
9897, 1.6565217391304, -0.25, 0.27777777777778
9898, 1.6782608695652, -0.25, 0.30555555555556
9899, 1.6565217391304, -0.25, 0.22222222222222
9900, 1.6782608695652, -0.25, 0.25
9901, 1.6565217391304, -0.25, 0.16666666666667
9902, 1.6782608695652, -0.25, 0.19444444444444
9903, 1.6565217391304, -0.25, 0.11111111111111
9904, 1.6782608695652, -0.25, 0.13888888888889
9905, 1.6565217391304, -0.25, 0.055555555555556
9906, 1.6782608695652, -0.25, 0.083333333333333
9907, 1.6782608695652, -0.25, 0.027777777777778
9908, 1.7, -0.25, 0.44444444444444
9909, 1.7217391304348, -0.25, 0.47222222222222
9910, 1.7, -0.25, 0.38888888888889
9911, 1.7217391304348, -0.25, 0.41666666666667
9912, 1.7, -0.25, 0.33333333333333
9913, 1.7217391304348, -0.25, 0.36111111111111
9914, 1.7, -0.25, 0.27777777777778
9915, 1.7217391304348, -0.25, 0.30555555555556
9916, 1.7, -0.25, 0.22222222222222
9917, 1.7217391304348, -0.25, 0.25
9918, 1.7, -0.25, 0.16666666666667
9919, 1.7217391304348, -0.25, 0.19444444444444
9920, 1.7, -0.25, 0.11111111111111
9921, 1.7217391304348, -0.25, 0.13888888888889
9922, 1.7, -0.25, 0.055555555555556
9923, 1.7217391304348, -0.25, 0.083333333333333
9924, 1.7217391304348, -0.25, 0.027777777777778
9925, 1.7434782608696, -0.25, 0.44444444444444
9926, 1.7652173913043, -0.25, 0.47222222222222
9927, 1.7434782608696, -0.25, 0.38888888888889
9928, 1.7652173913043, -0.25, 0.41666666666667
9929, 1.7434782608696, -0.25, 0.33333333333333
9930, 1.7652173913043, -0.25, 0.36111111111111
9931, 1.7434782608696, -0.25, 0.27777777777778
9932, 1.7652173913043, -0.25, 0.30555555555556
9933, 1.7434782608696, -0.25, 0.22222222222222
9934, 1.7652173913043, -0.25, 0.25
9935, 1.7434782608696, -0.25, 0.16666666666667
9936, 1.7652173913043, -0.25, 0.19444444444444
9937, 1.7434782608696, -0.25, 0.11111111111111
9938, 1.7652173913043, -0.25, 0.13888888888889
9939, 1.7434782608696, -0.25, 0.055555555555556
9940, 1.7652173913043, -0.25, 0.083333333333333
9941, 1.7652173913043, -0.25, 0.027777777777778
9942, 1.7869565217391, -0.25, 0.44444444444444
9943, 1.8086956521739, -0.25, 0.47222222222222
9944, 1.7869565217391, -0.25, 0.38888888888889
9945, 1.8086956521739, -0.25, 0.41666666666667
9946, 1.7869565217391, -0.25, 0.33333333333333
9947, 1.8086956521739, -0.25, 0.36111111111111
9948, 1.7869565217391, -0.25, 0.27777777777778
9949, 1.8086956521739, -0.25, 0.30555555555556
9950, 1.7869565217391, -0.25, 0.22222222222222
9951, 1.8086956521739, -0.25, 0.25
9952, 1.7869565217391, -0.25, 0.16666666666667
9953, 1.8086956521739, -0.25, 0.19444444444444
9954, 1.7869565217391, -0.25, 0.11111111111111
9955, 1.8086956521739, -0.25, 0.13888888888889
9956, 1.7869565217391, -0.25, 0.055555555555556
9957, 1.8086956521739, -0.25, 0.083333333333333
9958, 1.8086956521739, -0.25, 0.027777777777778
9959, 1.8304347826087, -0.25, 0.44444444444444
9960, 1.8521739130435, -0.25, 0.47222222222222
9961, 1.8304347826087, -0.25, 0.38888888888889
9962, 1.8521739130435, -0.25, 0.41666666666667
9963, 1.8304347826087, -0.25, 0.33333333333333
9964, 1.8521739130435, -0.25, 0.36111111111111
9965, 1.8304347826087, -0.25, 0.27777777777778
9966, 1.8521739130435, -0.25, 0.30555555555556
9967, 1.8304347826087, -0.25, 0.22222222222222
9968, 1.8521739130435, -0.25, 0.25
9969, 1.8304347826087, -0.25, 0.16666666666667
9970, 1.8521739130435, -0.25, 0.19444444444444
9971, 1.8304347826087, -0.25, 0.11111111111111
9972, 1.8521739130435, -0.25, 0.13888888888889
9973, 1.8304347826087, -0.25, 0.055555555555556
9974, 1.8521739130435, -0.25, 0.083333333333333
9975, 1.8521739130435, -0.25, 0.027777777777778
9976, 1.8739130434783, -0.25, 0.44444444444444
9977, 1.895652173913, -0.25, 0.47222222222222
9978, 1.8739130434783, -0.25, 0.38888888888889
9979, 1.895652173913, -0.25, 0.41666666666667
9980, 1.8739130434783, -0.25, 0.33333333333333
9981, 1.895652173913, -0.25, 0.36111111111111
9982, 1.8739130434783, -0.25, 0.27777777777778
9983, 1.895652173913, -0.25, 0.30555555555556
9984, 1.8739130434783, -0.25, 0.22222222222222
9985, 1.895652173913, -0.25, 0.25
9986, 1.8739130434783, -0.25, 0.16666666666667
9987, 1.895652173913, -0.25, 0.19444444444444
9988, 1.8739130434783, -0.25, 0.11111111111111
9989, 1.895652173913, -0.25, 0.13888888888889
9990, 1.8739130434783, -0.25, 0.055555555555556
9991, 1.895652173913, -0.25, 0.083333333333333
9992, 1.895652173913, -0.25, 0.027777777777778
9993, 1.9173913043478, -0.25, 0.44444444444444
9994, 1.9391304347826, -0.25, 0.47222222222222
9995, 1.9173913043478, -0.25, 0.38888888888889
9996, 1.9391304347826, -0.25, 0.41666666666667
9997, 1.9173913043478, -0.25, 0.33333333333333
9998, 1.9391304347826, -0.25, 0.36111111111111
9999, 1.9173913043478, -0.25, 0.27777777777778
10000, 1.9391304347826, -0.25, 0.30555555555556
10001, 1.9173913043478, -0.25, 0.22222222222222
10002, 1.9391304347826, -0.25, 0.25
10003, 1.9173913043478, -0.25, 0.16666666666667
10004, 1.9391304347826, -0.25, 0.19444444444444
10005, 1.9173913043478, -0.25, 0.11111111111111
10006, 1.9391304347826, -0.25, 0.13888888888889
10007, 1.9173913043478, -0.25, 0.055555555555556
10008, 1.9391304347826, -0.25, 0.083333333333333
10009, 1.9391304347826, -0.25, 0.027777777777778
10010, 1.9608695652174, -0.25, 0.44444444444444
10011, 1.9826086956522, -0.25, 0.47222222222222
10012, 1.9608695652174, -0.25, 0.38888888888889
10013, 1.9826086956522, -0.25, 0.41666666666667
10014, 1.9608695652174, -0.25, 0.33333333333333
10015, 1.9826086956522, -0.25, 0.36111111111111
10016, 1.9608695652174, -0.25, 0.27777777777778
10017, 1.9826086956522, -0.25, 0.30555555555556
10018, 1.9608695652174, -0.25, 0.22222222222222
10019, 1.9826086956522, -0.25, 0.25
10020, 1.9608695652174, -0.25, 0.16666666666667
10021, 1.9826086956522, -0.25, 0.19444444444444
10022, 1.9608695652174, -0.25, 0.11111111111111
10023, 1.9826086956522, -0.25, 0.13888888888889
10024, 1.9608695652174, -0.25, 0.055555555555556
10025, 1.9826086956522, -0.25, 0.083333333333333
10026, 1.9826086956522, -0.25, 0.027777777777778
10027, 2.004347826087, -0.25, 0.44444444444444
10028, 2.0260869565217, -0.25, 0.47222222222222
10029, 2.004347826087, -0.25, 0.38888888888889
10030, 2.0260869565217, -0.25, 0.41666666666667
10031, 2.004347826087, -0.25, 0.33333333333333
10032, 2.0260869565217, -0.25, 0.36111111111111
10033, 2.004347826087, -0.25, 0.27777777777778
10034, 2.0260869565217, -0.25, 0.30555555555556
10035, 2.004347826087, -0.25, 0.22222222222222
10036, 2.0260869565217, -0.25, 0.25
10037, 2.004347826087, -0.25, 0.16666666666667
10038, 2.0260869565217, -0.25, 0.19444444444444
10039, 2.004347826087, -0.25, 0.11111111111111
10040, 2.0260869565217, -0.25, 0.13888888888889
10041, 2.004347826087, -0.25, 0.055555555555556
10042, 2.0260869565217, -0.25, 0.083333333333333
10043, 2.0260869565217, -0.25, 0.027777777777778
10044, 2.0478260869565, -0.25, 0.44444444444444
10045, 2.0695652173913, -0.25, 0.47222222222222
10046, 2.0478260869565, -0.25, 0.38888888888889
10047, 2.0695652173913, -0.25, 0.41666666666667
10048, 2.0478260869565, -0.25, 0.33333333333333
10049, 2.0695652173913, -0.25, 0.36111111111111
10050, 2.0478260869565, -0.25, 0.27777777777778
10051, 2.0695652173913, -0.25, 0.30555555555556
10052, 2.0478260869565, -0.25, 0.22222222222222
10053, 2.0695652173913, -0.25, 0.25
10054, 2.0478260869565, -0.25, 0.16666666666667
10055, 2.0695652173913, -0.25, 0.19444444444444
10056, 2.0478260869565, -0.25, 0.11111111111111
10057, 2.0695652173913, -0.25, 0.13888888888889
10058, 2.0478260869565, -0.25, 0.055555555555556
10059, 2.0695652173913, -0.25, 0.083333333333333
10060, 2.0695652173913, -0.25, 0.027777777777778
10061, 2.0913043478261, -0.25, 0.44444444444444
10062, 2.1130434782609, -0.25, 0.47222222222222
10063, 2.0913043478261, -0.25, 0.38888888888889
10064, 2.1130434782609, -0.25, 0.41666666666667
10065, 2.0913043478261, -0.25, 0.33333333333333
10066, 2.1130434782609, -0.25, 0.36111111111111
10067, 2.0913043478261, -0.25, 0.27777777777778
10068, 2.1130434782609, -0.25, 0.30555555555556
10069, 2.0913043478261, -0.25, 0.22222222222222
10070, 2.1130434782609, -0.25, 0.25
10071, 2.0913043478261, -0.25, 0.16666666666667
10072, 2.1130434782609, -0.25, 0.19444444444444
10073, 2.0913043478261, -0.25, 0.11111111111111
10074, 2.1130434782609, -0.25, 0.13888888888889
10075, 2.0913043478261, -0.25, 0.055555555555556
10076, 2.1130434782609, -0.25, 0.083333333333333
10077, 2.1130434782609, -0.25, 0.027777777777778
10078, 2.1347826086957, -0.25, 0.44444444444444
10079, 2.1565217391304, -0.25, 0.47222222222222
10080, 2.1347826086957, -0.25, 0.38888888888889
10081, 2.1565217391304, -0.25, 0.41666666666667
10082, 2.1347826086957, -0.25, 0.33333333333333
10083, 2.1565217391304, -0.25, 0.36111111111111
10084, 2.1347826086957, -0.25, 0.27777777777778
10085, 2.1565217391304, -0.25, 0.30555555555556
10086, 2.1347826086957, -0.25, 0.22222222222222
10087, 2.1565217391304, -0.25, 0.25
10088, 2.1347826086957, -0.25, 0.16666666666667
10089, 2.1565217391304, -0.25, 0.19444444444444
10090, 2.1347826086957, -0.25, 0.11111111111111
10091, 2.1565217391304, -0.25, 0.13888888888889
10092, 2.1347826086957, -0.25, 0.055555555555556
10093, 2.1565217391304, -0.25, 0.083333333333333
10094, 2.1565217391304, -0.25, 0.027777777777778
10095, 2.1782608695652, -0.25, 0.44444444444444
10096, 2.1782608695652, -0.25, 0.38888888888889
10097, 2.1782608695652, -0.25, 0.33333333333333
10098, 2.1782608695652, -0.25, 0.27777777777778
10099, 2.1782608695652, -0.25, 0.22222222222222
10100, 2.1782608695652, -0.25, 0.16666666666667
10101, 2.1782608695652, -0.25, 0.11111111111111
10102, 2.1782608695652, -0.25, 0.055555555555556
10103, 1.2434782608696, 0.016666666666667, 0.5
10104, 1.2869565217391, 0.016666666666667, 0.5
10105, 1.3304347826087, 0.016666666666667, 0.5
10106, 1.3739130434783, 0.016666666666667, 0.5
10107, 1.4173913043478, 0.016666666666667, 0.5
10108, 1.4608695652174, 0.016666666666667, 0.5
10109, 1.504347826087, 0.016666666666667, 0.5
10110, 1.5478260869565, 0.016666666666667, 0.5
10111, 1.5913043478261, 0.016666666666667, 0.5
10112, 1.6347826086957, 0.016666666666667, 0.5
10113, 1.6782608695652, 0.016666666666667, 0.5
10114, 1.7217391304348, 0.016666666666667, 0.5
10115, 1.7652173913043, 0.016666666666667, 0.5
10116, 1.8086956521739, 0.016666666666667, 0.5
10117, 1.8521739130435, 0.016666666666667, 0.5
10118, 1.895652173913, 0.016666666666667, 0.5
10119, 1.9391304347826, 0.016666666666667, 0.5
10120, 1.9826086956522, 0.016666666666667, 0.5
10121, 2.0260869565217, 0.016666666666667, 0.5
10122, 2.0695652173913, 0.016666666666667, 0.5
10123, 2.1130434782609, 0.016666666666667, 0.5
10124, 2.1565217391304, 0.016666666666667, 0.5
10125, 1.2434782608696, -0.016666666666667, 0.5
10126, 1.2869565217391, -0.016666666666667, 0.5
10127, 1.3304347826087, -0.016666666666667, 0.5
10128, 1.3739130434783, -0.016666666666667, 0.5
10129, 1.4173913043478, -0.016666666666667, 0.5
10130, 1.4608695652174, -0.016666666666667, 0.5
10131, 1.504347826087, -0.016666666666667, 0.5
10132, 1.5478260869565, -0.016666666666667, 0.5
10133, 1.5913043478261, -0.016666666666667, 0.5
10134, 1.6347826086957, -0.016666666666667, 0.5
10135, 1.6782608695652, -0.016666666666667, 0.5
10136, 1.7217391304348, -0.016666666666667, 0.5
10137, 1.7652173913043, -0.016666666666667, 0.5
10138, 1.8086956521739, -0.016666666666667, 0.5
10139, 1.8521739130435, -0.016666666666667, 0.5
10140, 1.895652173913, -0.016666666666667, 0.5
10141, 1.9391304347826, -0.016666666666667, 0.5
10142, 1.9826086956522, -0.016666666666667, 0.5
10143, 2.0260869565217, -0.016666666666667, 0.5
10144, 2.0695652173913, -0.016666666666667, 0.5
10145, 2.1130434782609, -0.016666666666667, 0.5
10146, 2.1565217391304, -0.016666666666667, 0.5
10147, 1.2217391304348, 0.016666666666667, 0.5
10148, 1.2434782608696, 0.033333333333333, 0.5
10149, 1.2652173913043, 0.016666666666667, 0.5
10150, 1.2869565217391, 0.033333333333333, 0.5
10151, 1.3086956521739, 0.016666666666667, 0.5
10152, 1.3304347826087, 0.033333333333333, 0.5
10153, 1.3521739130435, 0.016666666666667, 0.5
10154, 1.3739130434783, 0.033333333333333, 0.5
10155, 1.395652173913, 0.016666666666667, 0.5
10156, 1.4173913043478, 0.033333333333333, 0.5
10157, 1.4391304347826, 0.016666666666667, 0.5
10158, 1.4608695652174, 0.033333333333333, 0.5
10159, 1.4826086956522, 0.016666666666667, 0.5
10160, 1.504347826087, 0.033333333333333, 0.5
10161, 1.5260869565217, 0.016666666666667, 0.5
10162, 1.5478260869565, 0.033333333333333, 0.5
10163, 1.5695652173913, 0.016666666666667, 0.5
10164, 1.5913043478261, 0.033333333333333, 0.5
10165, 1.6130434782609, 0.016666666666667, 0.5
10166, 1.6347826086957, 0.033333333333333, 0.5
10167, 1.6565217391304, 0.016666666666667, 0.5
10168, 1.6782608695652, 0.033333333333333, 0.5
10169, 1.7, 0.016666666666667, 0.5
10170, 1.7217391304348, 0.033333333333333, 0.5
10171, 1.7434782608696, 0.016666666666667, 0.5
10172, 1.7652173913043, 0.033333333333333, 0.5
10173, 1.7869565217391, 0.016666666666667, 0.5
10174, 1.8086956521739, 0.033333333333333, 0.5
10175, 1.8304347826087, 0.016666666666667, 0.5
10176, 1.8521739130435, 0.033333333333333, 0.5
10177, 1.8739130434783, 0.016666666666667, 0.5
10178, 1.895652173913, 0.033333333333333, 0.5
10179, 1.9173913043478, 0.016666666666667, 0.5
10180, 1.9391304347826, 0.033333333333333, 0.5
10181, 1.9608695652174, 0.016666666666667, 0.5
10182, 1.9826086956522, 0.033333333333333, 0.5
10183, 2.004347826087, 0.016666666666667, 0.5
10184, 2.0260869565217, 0.033333333333333, 0.5
10185, 2.0478260869565, 0.016666666666667, 0.5
10186, 2.0695652173913, 0.033333333333333, 0.5
10187, 2.0913043478261, 0.016666666666667, 0.5
10188, 2.1130434782609, 0.033333333333333, 0.5
10189, 2.1347826086957, 0.016666666666667, 0.5
10190, 2.1565217391304, 0.033333333333333, 0.5
10191, 2.1782608695652, 0.016666666666667, 0.5
10192, 1.2217391304348, -0.016666666666667, 0.5
10193, 1.2434782608696, -4.1633363423443e-17, 0.5
10194, 1.2652173913043, -0.016666666666667, 0.5
10195, 1.2869565217391, -2.7755575615629e-17, 0.5
10196, 1.3086956521739, -0.016666666666667, 0.5
10197, 1.3304347826087, -2.7755575615629e-17, 0.5
10198, 1.3521739130435, -0.016666666666667, 0.5
10199, 1.3739130434783, -4.1633363423443e-17, 0.5
10200, 1.395652173913, -0.016666666666667, 0.5
10201, 1.4173913043478, -2.7755575615629e-17, 0.5
10202, 1.4391304347826, -0.016666666666667, 0.5
10203, 1.4608695652174, -2.7755575615629e-17, 0.5
10204, 1.4826086956522, -0.016666666666667, 0.5
10205, 1.504347826087, -2.7755575615629e-17, 0.5
10206, 1.5260869565217, -0.016666666666667, 0.5
10207, 1.5478260869565, -4.8572257327351e-17, 0.5
10208, 1.5695652173913, -0.016666666666667, 0.5
10209, 1.5913043478261, -4.1633363423443e-17, 0.5
10210, 1.6130434782609, -0.016666666666667, 0.5
10211, 1.6347826086957, -5.5511151231258e-17, 0.5
10212, 1.6565217391304, -0.016666666666667, 0.5
10213, 1.6782608695652, -5.5511151231258e-17, 0.5
10214, 1.7, -0.016666666666667, 0.5
10215, 1.7217391304348, -4.8572257327351e-17, 0.5
10216, 1.7434782608696, -0.016666666666667, 0.5
10217, 1.7652173913043, -4.1633363423443e-17, 0.5
10218, 1.7869565217391, -0.016666666666667, 0.5
10219, 1.8086956521739, -2.7755575615629e-17, 0.5
10220, 1.8304347826087, -0.016666666666667, 0.5
10221, 1.8521739130435, -4.1633363423443e-17, 0.5
10222, 1.8739130434783, -0.016666666666667, 0.5
10223, 1.895652173913, -4.8572257327351e-17, 0.5
10224, 1.9173913043478, -0.016666666666667, 0.5
10225, 1.9391304347826, -2.7755575615629e-17, 0.5
10226, 1.9608695652174, -0.016666666666667, 0.5
10227, 1.9826086956522, -4.1633363423443e-17, 0.5
10228, 2.004347826087, -0.016666666666667, 0.5
10229, 2.0260869565217, -2.7755575615629e-17, 0.5
10230, 2.0478260869565, -0.016666666666667, 0.5
10231, 2.0695652173913, -4.1633363423443e-17, 0.5
10232, 2.0913043478261, -0.016666666666667, 0.5
10233, 2.1130434782609, -4.1633363423443e-17, 0.5
10234, 2.1347826086957, -0.016666666666667, 0.5
10235, 2.1565217391304, -4.1633363423443e-17, 0.5
10236, 2.1782608695652, -0.016666666666667, 0.5
10237, 1.2434782608696, -0.033333333333333, 0.5
10238, 1.2869565217391, -0.033333333333333, 0.5
10239, 1.3304347826087, -0.033333333333333, 0.5
10240, 1.3739130434783, -0.033333333333333, 0.5
10241, 1.4173913043478, -0.033333333333333, 0.5
10242, 1.4608695652174, -0.033333333333333, 0.5
10243, 1.504347826087, -0.033333333333333, 0.5
10244, 1.5478260869565, -0.033333333333333, 0.5
10245, 1.5913043478261, -0.033333333333333, 0.5
10246, 1.6347826086957, -0.033333333333333, 0.5
10247, 1.6782608695652, -0.033333333333333, 0.5
10248, 1.7217391304348, -0.033333333333333, 0.5
10249, 1.7652173913043, -0.033333333333333, 0.5
10250, 1.8086956521739, -0.033333333333333, 0.5
10251, 1.8521739130435, -0.033333333333333, 0.5
10252, 1.895652173913, -0.033333333333333, 0.5
10253, 1.9391304347826, -0.033333333333333, 0.5
10254, 1.9826086956522, -0.033333333333333, 0.5
10255, 2.0260869565217, -0.033333333333333, 0.5
10256, 2.0695652173913, -0.033333333333333, 0.5
10257, 2.1130434782609, -0.033333333333333, 0.5
10258, 2.1565217391304, -0.033333333333333, 0.5
10259, 1.2434782608696, 0.016666666666667, 0
10260, 1.2869565217391, 0.016666666666667, 0
10261, 1.3304347826087, 0.016666666666667, 0
10262, 1.3739130434783, 0.016666666666667, 0
10263, 1.4173913043478, 0.016666666666667, 0
10264, 1.4608695652174, 0.016666666666667, 0
10265, 1.504347826087, 0.016666666666667, 0
10266, 1.5478260869565, 0.016666666666667, 0
10267, 1.5913043478261, 0.016666666666667, 0
10268, 1.6347826086957, 0.016666666666667, 0
10269, 1.6782608695652, 0.016666666666667, 0
10270, 1.7217391304348, 0.016666666666667, 0
10271, 1.7652173913043, 0.016666666666667, 0
10272, 1.8086956521739, 0.016666666666667, 0
10273, 1.8521739130435, 0.016666666666667, 0
10274, 1.895652173913, 0.016666666666667, 0
10275, 1.9391304347826, 0.016666666666667, 0
10276, 1.9826086956522, 0.016666666666667, 0
10277, 2.0260869565217, 0.016666666666667, 0
10278, 2.0695652173913, 0.016666666666667, 0
10279, 2.1130434782609, 0.016666666666667, 0
10280, 2.1565217391304, 0.016666666666667, 0
10281, 1.2434782608696, -0.016666666666667, 0
10282, 1.2869565217391, -0.016666666666667, 0
10283, 1.3304347826087, -0.016666666666667, 0
10284, 1.3739130434783, -0.016666666666667, 0
10285, 1.4173913043478, -0.016666666666667, 0
10286, 1.4608695652174, -0.016666666666667, 0
10287, 1.504347826087, -0.016666666666667, 0
10288, 1.5478260869565, -0.016666666666667, 0
10289, 1.5913043478261, -0.016666666666667, 0
10290, 1.6347826086957, -0.016666666666667, 0
10291, 1.6782608695652, -0.016666666666667, 0
10292, 1.7217391304348, -0.016666666666667, 0
10293, 1.7652173913043, -0.016666666666667, 0
10294, 1.8086956521739, -0.016666666666667, 0
10295, 1.8521739130435, -0.016666666666667, 0
10296, 1.895652173913, -0.016666666666667, 0
10297, 1.9391304347826, -0.016666666666667, 0
10298, 1.9826086956522, -0.016666666666667, 0
10299, 2.0260869565217, -0.016666666666667, 0
10300, 2.0695652173913, -0.016666666666667, 0
10301, 2.1130434782609, -0.016666666666667, 0
10302, 2.1565217391304, -0.016666666666667, 0
10303, 1.2434782608696, 0.033333333333333, 0
10304, 1.2217391304348, 0.016666666666667, 0
10305, 1.2869565217391, 0.033333333333333, 0
10306, 1.2652173913043, 0.016666666666667, 0
10307, 1.3304347826087, 0.033333333333333, 0
10308, 1.3086956521739, 0.016666666666667, 0
10309, 1.3739130434783, 0.033333333333333, 0
10310, 1.3521739130435, 0.016666666666667, 0
10311, 1.4173913043478, 0.033333333333333, 0
10312, 1.395652173913, 0.016666666666667, 0
10313, 1.4608695652174, 0.033333333333333, 0
10314, 1.4391304347826, 0.016666666666667, 0
10315, 1.504347826087, 0.033333333333333, 0
10316, 1.4826086956522, 0.016666666666667, 0
10317, 1.5478260869565, 0.033333333333333, 0
10318, 1.5260869565217, 0.016666666666667, 0
10319, 1.5913043478261, 0.033333333333333, 0
10320, 1.5695652173913, 0.016666666666667, 0
10321, 1.6347826086957, 0.033333333333333, 0
10322, 1.6130434782609, 0.016666666666667, 0
10323, 1.6782608695652, 0.033333333333333, 0
10324, 1.6565217391304, 0.016666666666667, 0
10325, 1.7217391304348, 0.033333333333333, 0
10326, 1.7, 0.016666666666667, 0
10327, 1.7652173913043, 0.033333333333333, 0
10328, 1.7434782608696, 0.016666666666667, 0
10329, 1.8086956521739, 0.033333333333333, 0
10330, 1.7869565217391, 0.016666666666667, 0
10331, 1.8521739130435, 0.033333333333333, 0
10332, 1.8304347826087, 0.016666666666667, 0
10333, 1.895652173913, 0.033333333333333, 0
10334, 1.8739130434783, 0.016666666666667, 0
10335, 1.9391304347826, 0.033333333333333, 0
10336, 1.9173913043478, 0.016666666666667, 0
10337, 1.9826086956522, 0.033333333333333, 0
10338, 1.9608695652174, 0.016666666666667, 0
10339, 2.0260869565217, 0.033333333333333, 0
10340, 2.004347826087, 0.016666666666667, 0
10341, 2.0695652173913, 0.033333333333333, 0
10342, 2.0478260869565, 0.016666666666667, 0
10343, 2.1130434782609, 0.033333333333333, 0
10344, 2.0913043478261, 0.016666666666667, 0
10345, 2.1565217391304, 0.033333333333333, 0
10346, 2.1347826086957, 0.016666666666667, 0
10347, 2.1782608695652, 0.016666666666667, 0
10348, 1.2434782608696, -4.1633363423443e-17, 0
10349, 1.2217391304348, -0.016666666666667, 0
10350, 1.2869565217391, -2.7755575615629e-17, 0
10351, 1.2652173913043, -0.016666666666667, 0
10352, 1.3304347826087, -2.7755575615629e-17, 0
10353, 1.3086956521739, -0.016666666666667, 0
10354, 1.3739130434783, -4.1633363423443e-17, 0
10355, 1.3521739130435, -0.016666666666667, 0
10356, 1.4173913043478, -2.7755575615629e-17, 0
10357, 1.395652173913, -0.016666666666667, 0
10358, 1.4608695652174, -2.7755575615629e-17, 0
10359, 1.4391304347826, -0.016666666666667, 0
10360, 1.504347826087, -2.7755575615629e-17, 0
10361, 1.4826086956522, -0.016666666666667, 0
10362, 1.5478260869565, -4.8572257327351e-17, 0
10363, 1.5260869565217, -0.016666666666667, 0
10364, 1.5913043478261, -4.1633363423443e-17, 0
10365, 1.5695652173913, -0.016666666666667, 0
10366, 1.6347826086957, -5.5511151231258e-17, 0
10367, 1.6130434782609, -0.016666666666667, 0
10368, 1.6782608695652, -5.5511151231258e-17, 0
10369, 1.6565217391304, -0.016666666666667, 0
10370, 1.7217391304348, -4.8572257327351e-17, 0
10371, 1.7, -0.016666666666667, 0
10372, 1.7652173913043, -4.1633363423443e-17, 0
10373, 1.7434782608696, -0.016666666666667, 0
10374, 1.8086956521739, -2.7755575615629e-17, 0
10375, 1.7869565217391, -0.016666666666667, 0
10376, 1.8521739130435, -4.1633363423443e-17, 0
10377, 1.8304347826087, -0.016666666666667, 0
10378, 1.895652173913, -4.8572257327351e-17, 0
10379, 1.8739130434783, -0.016666666666667, 0
10380, 1.9391304347826, -2.7755575615629e-17, 0
10381, 1.9173913043478, -0.016666666666667, 0
10382, 1.9826086956522, -4.1633363423443e-17, 0
10383, 1.9608695652174, -0.016666666666667, 0
10384, 2.0260869565217, -2.7755575615629e-17, 0
10385, 2.004347826087, -0.016666666666667, 0
10386, 2.0695652173913, -4.1633363423443e-17, 0
10387, 2.0478260869565, -0.016666666666667, 0
10388, 2.1130434782609, -4.1633363423443e-17, 0
10389, 2.0913043478261, -0.016666666666667, 0
10390, 2.1565217391304, -4.1633363423443e-17, 0
10391, 2.1347826086957, -0.016666666666667, 0
10392, 2.1782608695652, -0.016666666666667, 0
10393, 1.2434782608696, -0.033333333333333, 0
10394, 1.2869565217391, -0.033333333333333, 0
10395, 1.3304347826087, -0.033333333333333, 0
10396, 1.3739130434783, -0.033333333333333, 0
10397, 1.4173913043478, -0.033333333333333, 0
10398, 1.4608695652174, -0.033333333333333, 0
10399, 1.504347826087, -0.033333333333333, 0
10400, 1.5478260869565, -0.033333333333333, 0
10401, 1.5913043478261, -0.033333333333333, 0
10402, 1.6347826086957, -0.033333333333333, 0
10403, 1.6782608695652, -0.033333333333333, 0
10404, 1.7217391304348, -0.033333333333333, 0
10405, 1.7652173913043, -0.033333333333333, 0
10406, 1.8086956521739, -0.033333333333333, 0
10407, 1.8521739130435, -0.033333333333333, 0
10408, 1.895652173913, -0.033333333333333, 0
10409, 1.9391304347826, -0.033333333333333, 0
10410, 1.9826086956522, -0.033333333333333, 0
10411, 2.0260869565217, -0.033333333333333, 0
10412, 2.0695652173913, -0.033333333333333, 0
10413, 2.1130434782609, -0.033333333333333, 0
10414, 2.1565217391304, -0.033333333333333, 0
10415, 1.2, 0.016666666666667, 0.44444444444444
10416, 1.2, 0.016666666666667, 0.38888888888889
10417, 1.2, 0.016666666666667, 0.33333333333333
10418, 1.2, 0.016666666666667, 0.27777777777778
10419, 1.2, 0.016666666666667, 0.22222222222222
10420, 1.2, 0.016666666666667, 0.16666666666667
10421, 1.2, 0.016666666666667, 0.11111111111111
10422, 1.2, 0.016666666666667, 0.055555555555556
10423, 1.2, -0.016666666666667, 0.44444444444444
10424, 1.2, -0.016666666666667, 0.38888888888889
10425, 1.2, -0.016666666666667, 0.33333333333333
10426, 1.2, -0.016666666666667, 0.27777777777778
10427, 1.2, -0.016666666666667, 0.22222222222222
10428, 1.2, -0.016666666666667, 0.16666666666667
10429, 1.2, -0.016666666666667, 0.11111111111111
10430, 1.2, -0.016666666666667, 0.055555555555556
10431, 1.2, 0.033333333333333, 0.44444444444444
10432, 1.2, 0.016666666666667, 0.47222222222222
10433, 1.2, 0.033333333333333, 0.38888888888889
10434, 1.2, 0.016666666666667, 0.41666666666667
10435, 1.2, 0.033333333333333, 0.33333333333333
10436, 1.2, 0.016666666666667, 0.36111111111111
10437, 1.2, 0.033333333333333, 0.27777777777778
10438, 1.2, 0.016666666666667, 0.30555555555556
10439, 1.2, 0.033333333333333, 0.22222222222222
10440, 1.2, 0.016666666666667, 0.25
10441, 1.2, 0.033333333333333, 0.16666666666667
10442, 1.2, 0.016666666666667, 0.19444444444444
10443, 1.2, 0.033333333333333, 0.11111111111111
10444, 1.2, 0.016666666666667, 0.13888888888889
10445, 1.2, 0.033333333333333, 0.055555555555556
10446, 1.2, 0.016666666666667, 0.083333333333333
10447, 1.2, 0.016666666666667, 0.027777777777778
10448, 1.2, -1.0408340855861e-16, 0.44444444444444
10449, 1.2, -0.016666666666667, 0.47222222222222
10450, 1.2, -9.7144514654701e-17, 0.38888888888889
10451, 1.2, -0.016666666666667, 0.41666666666667
10452, 1.2, -1.0408340855861e-16, 0.33333333333333
10453, 1.2, -0.016666666666667, 0.36111111111111
10454, 1.2, -1.0408340855861e-16, 0.27777777777778
10455, 1.2, -0.016666666666667, 0.30555555555556
10456, 1.2, -1.0408340855861e-16, 0.22222222222222
10457, 1.2, -0.016666666666667, 0.25
