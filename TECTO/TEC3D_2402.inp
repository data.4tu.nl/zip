96264, 0.69565217391304, 1.245652173913, -0.025
96265, 0.67391304347826, 1.245652173913, -0.05
96266, 0.65217391304348, 1.2195652173913, -0.05
96267, 0.65217391304348, 1.245652173913, -0.025
96268, 0.6304347826087, 1.245652173913, -0.05
96269, 0.60869565217391, 1.2195652173913, -0.05
96270, 0.60869565217391, 1.245652173913, -0.025
96271, 0.58695652173913, 1.245652173913, -0.05
96272, 0.56521739130435, 1.2195652173913, -0.05
96273, 0.56521739130435, 1.245652173913, -0.025
96274, 0.54347826086956, 1.245652173913, -0.05
96275, 0.52173913043478, 1.2195652173913, -0.05
96276, 0.52173913043478, 1.245652173913, -0.025
96277, 0.5, 1.245652173913, -0.05
96278, 0.47826086956522, 1.2195652173913, -0.05
96279, 0.47826086956522, 1.245652173913, -0.025
96280, 0.45652173913043, 1.245652173913, -0.05
96281, 0.43478260869565, 1.2195652173913, -0.05
96282, 0.43478260869565, 1.245652173913, -0.025
96283, 0.41304347826087, 1.245652173913, -0.05
96284, 0.39130434782609, 1.2195652173913, -0.05
96285, 0.39130434782609, 1.245652173913, -0.025
96286, 0.3695652173913, 1.245652173913, -0.05
96287, 0.34782608695652, 1.2195652173913, -0.05
96288, 0.34782608695652, 1.245652173913, -0.025
96289, 0.32608695652174, 1.245652173913, -0.05
96290, 0.30434782608696, 1.2195652173913, -0.05
96291, 0.30434782608696, 1.245652173913, -0.025
96292, 0.28260869565217, 1.245652173913, -0.05
96293, 0.26086956521739, 1.2195652173913, -0.05
96294, 0.26086956521739, 1.245652173913, -0.025
96295, 0.23913043478261, 1.245652173913, -0.05
96296, 0.21739130434783, 1.2195652173913, -0.05
96297, 0.21739130434783, 1.245652173913, -0.025
96298, 0.19565217391304, 1.245652173913, -0.05
96299, 0.17391304347826, 1.2195652173913, -0.05
96300, 0.17391304347826, 1.245652173913, -0.025
96301, 0.15217391304348, 1.245652173913, -0.05
96302, 0.1304347826087, 1.2195652173913, -0.05
96303, 0.1304347826087, 1.245652173913, -0.025
96304, 0.10869565217391, 1.245652173913, -0.05
96305, 0.08695652173913, 1.2195652173913, -0.05
96306, 0.08695652173913, 1.245652173913, -0.025
96307, 0.065217391304348, 1.245652173913, -0.05
96308, 0.043478260869565, 1.2195652173913, -0.05
96309, 0.043478260869565, 1.245652173913, -0.025
96310, 0.021739130434783, 1.245652173913, -0.05
96311, 0.97826086956522, 1.2978260869565, -0.05
96312, 0.95652173913044, 1.2717391304348, -0.05
96313, 0.95652173913043, 1.2978260869565, -0.025
96314, 0.93478260869565, 1.2978260869565, -0.05
96315, 0.91304347826087, 1.2717391304348, -0.05
96316, 0.91304347826087, 1.2978260869565, -0.025
96317, 0.89130434782609, 1.2978260869565, -0.05
96318, 0.8695652173913, 1.2717391304348, -0.05
96319, 0.8695652173913, 1.2978260869565, -0.025
96320, 0.84782608695652, 1.2978260869565, -0.05
96321, 0.82608695652174, 1.2717391304348, -0.05
96322, 0.82608695652174, 1.2978260869565, -0.025
96323, 0.80434782608696, 1.2978260869565, -0.05
96324, 0.78260869565217, 1.2717391304348, -0.05
96325, 0.78260869565217, 1.2978260869565, -0.025
96326, 0.76086956521739, 1.2978260869565, -0.05
96327, 0.73913043478261, 1.2717391304348, -0.05
96328, 0.73913043478261, 1.2978260869565, -0.025
96329, 0.71739130434783, 1.2978260869565, -0.05
96330, 0.69565217391304, 1.2717391304348, -0.05
96331, 0.69565217391304, 1.2978260869565, -0.025
96332, 0.67391304347826, 1.2978260869565, -0.05
96333, 0.65217391304348, 1.2717391304348, -0.05
96334, 0.65217391304348, 1.2978260869565, -0.025
96335, 0.6304347826087, 1.2978260869565, -0.05
96336, 0.60869565217391, 1.2717391304348, -0.05
96337, 0.60869565217391, 1.2978260869565, -0.025
96338, 0.58695652173913, 1.2978260869565, -0.05
96339, 0.56521739130435, 1.2717391304348, -0.05
96340, 0.56521739130435, 1.2978260869565, -0.025
96341, 0.54347826086957, 1.2978260869565, -0.05
96342, 0.52173913043478, 1.2717391304348, -0.05
96343, 0.52173913043478, 1.2978260869565, -0.025
96344, 0.5, 1.2978260869565, -0.05
96345, 0.47826086956522, 1.2717391304348, -0.05
96346, 0.47826086956522, 1.2978260869565, -0.025
96347, 0.45652173913043, 1.2978260869565, -0.05
96348, 0.43478260869565, 1.2717391304348, -0.05
96349, 0.43478260869565, 1.2978260869565, -0.025
96350, 0.41304347826087, 1.2978260869565, -0.05
96351, 0.39130434782609, 1.2717391304348, -0.05
96352, 0.39130434782609, 1.2978260869565, -0.025
96353, 0.3695652173913, 1.2978260869565, -0.05
96354, 0.34782608695652, 1.2717391304348, -0.05
96355, 0.34782608695652, 1.2978260869565, -0.025
96356, 0.32608695652174, 1.2978260869565, -0.05
96357, 0.30434782608696, 1.2717391304348, -0.05
96358, 0.30434782608696, 1.2978260869565, -0.025
96359, 0.28260869565217, 1.2978260869565, -0.05
96360, 0.26086956521739, 1.2717391304348, -0.05
96361, 0.26086956521739, 1.2978260869565, -0.025
96362, 0.23913043478261, 1.2978260869565, -0.05
96363, 0.21739130434783, 1.2717391304348, -0.05
96364, 0.21739130434783, 1.2978260869565, -0.025
96365, 0.19565217391304, 1.2978260869565, -0.05
96366, 0.17391304347826, 1.2717391304348, -0.05
96367, 0.17391304347826, 1.2978260869565, -0.025
96368, 0.15217391304348, 1.2978260869565, -0.05
96369, 0.1304347826087, 1.2717391304348, -0.05
96370, 0.1304347826087, 1.2978260869565, -0.025
96371, 0.10869565217391, 1.2978260869565, -0.05
96372, 0.08695652173913, 1.2717391304348, -0.05
96373, 0.08695652173913, 1.2978260869565, -0.025
96374, 0.065217391304348, 1.2978260869565, -0.05
96375, 0.043478260869565, 1.2717391304348, -0.05
96376, 0.043478260869565, 1.2978260869565, -0.025
96377, 0.021739130434783, 1.2978260869565, -0.05
96378, 0.95652173913043, 1.3239130434783, -0.05
96379, 0.91304347826087, 1.3239130434783, -0.05
96380, 0.8695652173913, 1.3239130434783, -0.05
96381, 0.82608695652174, 1.3239130434783, -0.05
96382, 0.78260869565217, 1.3239130434783, -0.05
96383, 0.73913043478261, 1.3239130434783, -0.05
96384, 0.69565217391304, 1.3239130434783, -0.05
96385, 0.65217391304348, 1.3239130434783, -0.05
96386, 0.60869565217391, 1.3239130434783, -0.05
96387, 0.56521739130435, 1.3239130434783, -0.05
96388, 0.52173913043478, 1.3239130434783, -0.05
96389, 0.47826086956522, 1.3239130434783, -0.05
96390, 0.43478260869565, 1.3239130434783, -0.05
96391, 0.39130434782609, 1.3239130434783, -0.05
96392, 0.34782608695652, 1.3239130434783, -0.05
96393, 0.30434782608696, 1.3239130434783, -0.05
96394, 0.26086956521739, 1.3239130434783, -0.05
96395, 0.21739130434783, 1.3239130434783, -0.05
96396, 0.17391304347826, 1.3239130434783, -0.05
96397, 0.1304347826087, 1.3239130434783, -0.05
96398, 0.08695652173913, 1.3239130434783, -0.05
96399, 0.043478260869565, 1.3239130434783, -0.05
96400, 0.97826086956522, 0.20217391304348, -0.1
96401, 0.95652173913043, 0.17608695652174, -0.1
96402, 0.95652173913044, 0.20217391304348, -0.075
96403, 0.93478260869565, 0.20217391304348, -0.1
96404, 0.91304347826087, 0.17608695652174, -0.1
96405, 0.91304347826087, 0.20217391304348, -0.075
96406, 0.89130434782609, 0.20217391304348, -0.1
96407, 0.8695652173913, 0.17608695652174, -0.1
96408, 0.8695652173913, 0.20217391304348, -0.075
96409, 0.84782608695652, 0.20217391304348, -0.1
96410, 0.82608695652174, 0.17608695652174, -0.1
96411, 0.82608695652174, 0.20217391304348, -0.075
96412, 0.80434782608696, 0.20217391304348, -0.1
96413, 0.78260869565217, 0.17608695652174, -0.1
96414, 0.78260869565217, 0.20217391304348, -0.075
96415, 0.76086956521739, 0.20217391304348, -0.1
96416, 0.73913043478261, 0.17608695652174, -0.1
96417, 0.73913043478261, 0.20217391304348, -0.075
96418, 0.71739130434783, 0.20217391304348, -0.1
96419, 0.69565217391304, 0.17608695652174, -0.1
96420, 0.69565217391304, 0.20217391304348, -0.075
96421, 0.67391304347826, 0.20217391304348, -0.1
96422, 0.65217391304348, 0.17608695652174, -0.1
96423, 0.65217391304348, 0.20217391304348, -0.075
96424, 0.6304347826087, 0.20217391304348, -0.1
96425, 0.60869565217391, 0.17608695652174, -0.1
96426, 0.60869565217391, 0.20217391304348, -0.075
96427, 0.58695652173913, 0.20217391304348, -0.1
96428, 0.56521739130435, 0.17608695652174, -0.1
96429, 0.56521739130435, 0.20217391304348, -0.075
96430, 0.54347826086957, 0.20217391304348, -0.1
96431, 0.52173913043478, 0.17608695652174, -0.1
96432, 0.52173913043478, 0.20217391304348, -0.075
96433, 0.5, 0.20217391304348, -0.1
96434, 0.47826086956522, 0.17608695652174, -0.1
96435, 0.47826086956522, 0.20217391304348, -0.075
96436, 0.45652173913043, 0.20217391304348, -0.1
96437, 0.43478260869565, 0.17608695652174, -0.1
96438, 0.43478260869565, 0.20217391304348, -0.075
96439, 0.41304347826087, 0.20217391304348, -0.1
96440, 0.39130434782609, 0.17608695652174, -0.1
96441, 0.39130434782609, 0.20217391304348, -0.075
96442, 0.3695652173913, 0.20217391304348, -0.1
96443, 0.34782608695652, 0.17608695652174, -0.1
96444, 0.34782608695652, 0.20217391304348, -0.075
96445, 0.32608695652174, 0.20217391304348, -0.1
96446, 0.30434782608696, 0.17608695652174, -0.1
96447, 0.30434782608696, 0.20217391304348, -0.075
96448, 0.28260869565217, 0.20217391304348, -0.1
96449, 0.26086956521739, 0.17608695652174, -0.1
96450, 0.26086956521739, 0.20217391304348, -0.075
96451, 0.23913043478261, 0.20217391304348, -0.1
96452, 0.21739130434783, 0.17608695652174, -0.1
96453, 0.21739130434783, 0.20217391304348, -0.075
96454, 0.19565217391304, 0.20217391304348, -0.1
96455, 0.17391304347826, 0.17608695652174, -0.1
96456, 0.17391304347826, 0.20217391304348, -0.075
96457, 0.15217391304348, 0.20217391304348, -0.1
96458, 0.1304347826087, 0.17608695652174, -0.1
96459, 0.1304347826087, 0.20217391304348, -0.075
96460, 0.10869565217391, 0.20217391304348, -0.1
96461, 0.08695652173913, 0.17608695652174, -0.1
96462, 0.08695652173913, 0.20217391304348, -0.075
96463, 0.065217391304348, 0.20217391304348, -0.1
96464, 0.043478260869565, 0.17608695652174, -0.1
96465, 0.043478260869565, 0.20217391304348, -0.075
96466, 0.021739130434783, 0.20217391304348, -0.1
96467, 0.97826086956522, 0.25434782608696, -0.1
96468, 0.95652173913044, 0.22826086956522, -0.1
96469, 0.95652173913043, 0.25434782608696, -0.075
96470, 0.93478260869565, 0.25434782608696, -0.1
96471, 0.91304347826087, 0.22826086956522, -0.1
96472, 0.91304347826087, 0.25434782608696, -0.075
96473, 0.89130434782609, 0.25434782608696, -0.1
96474, 0.8695652173913, 0.22826086956522, -0.1
96475, 0.8695652173913, 0.25434782608696, -0.075
96476, 0.84782608695652, 0.25434782608696, -0.1
96477, 0.82608695652174, 0.22826086956522, -0.1
96478, 0.82608695652174, 0.25434782608696, -0.075
96479, 0.80434782608696, 0.25434782608696, -0.1
96480, 0.78260869565217, 0.22826086956522, -0.1
96481, 0.78260869565217, 0.25434782608696, -0.075
96482, 0.76086956521739, 0.25434782608696, -0.1
96483, 0.73913043478261, 0.22826086956522, -0.1
96484, 0.73913043478261, 0.25434782608696, -0.075
96485, 0.71739130434783, 0.25434782608696, -0.1
96486, 0.69565217391304, 0.22826086956522, -0.1
96487, 0.69565217391304, 0.25434782608696, -0.075
96488, 0.67391304347826, 0.25434782608696, -0.1
96489, 0.65217391304348, 0.22826086956522, -0.1
96490, 0.65217391304348, 0.25434782608696, -0.075
96491, 0.6304347826087, 0.25434782608696, -0.1
96492, 0.60869565217391, 0.22826086956522, -0.1
96493, 0.60869565217391, 0.25434782608696, -0.075
96494, 0.58695652173913, 0.25434782608696, -0.1
96495, 0.56521739130435, 0.22826086956522, -0.1
96496, 0.56521739130435, 0.25434782608696, -0.075
96497, 0.54347826086956, 0.25434782608696, -0.1
96498, 0.52173913043478, 0.22826086956522, -0.1
96499, 0.52173913043478, 0.25434782608696, -0.075
96500, 0.5, 0.25434782608696, -0.1
96501, 0.47826086956522, 0.22826086956522, -0.1
96502, 0.47826086956522, 0.25434782608696, -0.075
96503, 0.45652173913044, 0.25434782608696, -0.1
96504, 0.43478260869565, 0.22826086956522, -0.1
96505, 0.43478260869565, 0.25434782608696, -0.075
96506, 0.41304347826087, 0.25434782608696, -0.1
96507, 0.39130434782609, 0.22826086956522, -0.1
96508, 0.39130434782609, 0.25434782608696, -0.075
96509, 0.3695652173913, 0.25434782608696, -0.1
96510, 0.34782608695652, 0.22826086956522, -0.1
96511, 0.34782608695652, 0.25434782608696, -0.075
96512, 0.32608695652174, 0.25434782608696, -0.1
96513, 0.30434782608696, 0.22826086956522, -0.1
96514, 0.30434782608696, 0.25434782608696, -0.075
96515, 0.28260869565217, 0.25434782608696, -0.1
96516, 0.26086956521739, 0.22826086956522, -0.1
96517, 0.26086956521739, 0.25434782608696, -0.075
96518, 0.23913043478261, 0.25434782608696, -0.1
96519, 0.21739130434783, 0.22826086956522, -0.1
96520, 0.21739130434783, 0.25434782608696, -0.075
96521, 0.19565217391304, 0.25434782608696, -0.1
96522, 0.17391304347826, 0.22826086956522, -0.1
96523, 0.17391304347826, 0.25434782608696, -0.075
96524, 0.15217391304348, 0.25434782608696, -0.1
96525, 0.1304347826087, 0.22826086956522, -0.1
96526, 0.1304347826087, 0.25434782608696, -0.075
96527, 0.10869565217391, 0.25434782608696, -0.1
96528, 0.08695652173913, 0.22826086956522, -0.1
96529, 0.08695652173913, 0.25434782608696, -0.075
96530, 0.065217391304348, 0.25434782608696, -0.1
96531, 0.043478260869565, 0.22826086956522, -0.1
96532, 0.043478260869565, 0.25434782608696, -0.075
96533, 0.021739130434783, 0.25434782608696, -0.1
96534, 0.97826086956522, 0.30652173913043, -0.1
96535, 0.95652173913044, 0.2804347826087, -0.1
96536, 0.95652173913044, 0.30652173913043, -0.075
96537, 0.93478260869565, 0.30652173913043, -0.1
96538, 0.91304347826087, 0.2804347826087, -0.1
96539, 0.91304347826087, 0.30652173913043, -0.075
96540, 0.89130434782609, 0.30652173913043, -0.1
96541, 0.8695652173913, 0.2804347826087, -0.1
96542, 0.8695652173913, 0.30652173913043, -0.075
96543, 0.84782608695652, 0.30652173913043, -0.1
96544, 0.82608695652174, 0.2804347826087, -0.1
96545, 0.82608695652174, 0.30652173913043, -0.075
96546, 0.80434782608696, 0.30652173913043, -0.1
96547, 0.78260869565217, 0.2804347826087, -0.1
96548, 0.78260869565217, 0.30652173913043, -0.075
96549, 0.76086956521739, 0.30652173913043, -0.1
96550, 0.73913043478261, 0.2804347826087, -0.1
96551, 0.73913043478261, 0.30652173913043, -0.075
96552, 0.71739130434783, 0.30652173913043, -0.1
96553, 0.69565217391304, 0.2804347826087, -0.1
96554, 0.69565217391304, 0.30652173913043, -0.075
96555, 0.67391304347826, 0.30652173913043, -0.1
96556, 0.65217391304348, 0.2804347826087, -0.1
96557, 0.65217391304348, 0.30652173913043, -0.075
96558, 0.6304347826087, 0.30652173913043, -0.1
96559, 0.60869565217391, 0.2804347826087, -0.1
96560, 0.60869565217391, 0.30652173913043, -0.075
96561, 0.58695652173913, 0.30652173913043, -0.1
96562, 0.56521739130435, 0.2804347826087, -0.1
96563, 0.56521739130435, 0.30652173913043, -0.075
96564, 0.54347826086957, 0.30652173913043, -0.1
96565, 0.52173913043478, 0.2804347826087, -0.1
96566, 0.52173913043478, 0.30652173913043, -0.075
96567, 0.5, 0.30652173913043, -0.1
96568, 0.47826086956522, 0.2804347826087, -0.1
96569, 0.47826086956522, 0.30652173913043, -0.075
96570, 0.45652173913043, 0.30652173913043, -0.1
96571, 0.43478260869565, 0.2804347826087, -0.1
96572, 0.43478260869565, 0.30652173913043, -0.075
96573, 0.41304347826087, 0.30652173913043, -0.1
96574, 0.39130434782609, 0.2804347826087, -0.1
96575, 0.39130434782609, 0.30652173913043, -0.075
96576, 0.3695652173913, 0.30652173913043, -0.1
96577, 0.34782608695652, 0.2804347826087, -0.1
96578, 0.34782608695652, 0.30652173913043, -0.075
96579, 0.32608695652174, 0.30652173913043, -0.1
96580, 0.30434782608696, 0.2804347826087, -0.1
96581, 0.30434782608696, 0.30652173913043, -0.075
96582, 0.28260869565217, 0.30652173913043, -0.1
96583, 0.26086956521739, 0.2804347826087, -0.1
96584, 0.26086956521739, 0.30652173913043, -0.075
96585, 0.23913043478261, 0.30652173913043, -0.1
96586, 0.21739130434783, 0.2804347826087, -0.1
96587, 0.21739130434783, 0.30652173913043, -0.075
96588, 0.19565217391304, 0.30652173913043, -0.1
96589, 0.17391304347826, 0.2804347826087, -0.1
96590, 0.17391304347826, 0.30652173913043, -0.075
96591, 0.15217391304348, 0.30652173913043, -0.1
96592, 0.1304347826087, 0.2804347826087, -0.1
96593, 0.1304347826087, 0.30652173913043, -0.075
96594, 0.10869565217391, 0.30652173913043, -0.1
96595, 0.08695652173913, 0.2804347826087, -0.1
96596, 0.08695652173913, 0.30652173913043, -0.075
96597, 0.065217391304348, 0.30652173913043, -0.1
96598, 0.043478260869565, 0.2804347826087, -0.1
96599, 0.043478260869565, 0.30652173913043, -0.075
96600, 0.021739130434783, 0.30652173913043, -0.1
96601, 0.97826086956522, 0.35869565217391, -0.1
96602, 0.95652173913044, 0.33260869565217, -0.1
96603, 0.95652173913043, 0.35869565217391, -0.075
96604, 0.93478260869565, 0.35869565217391, -0.1
96605, 0.91304347826087, 0.33260869565217, -0.1
96606, 0.91304347826087, 0.35869565217391, -0.075
96607, 0.89130434782609, 0.35869565217391, -0.1
96608, 0.8695652173913, 0.33260869565217, -0.1
96609, 0.8695652173913, 0.35869565217391, -0.075
96610, 0.84782608695652, 0.35869565217391, -0.1
96611, 0.82608695652174, 0.33260869565217, -0.1
96612, 0.82608695652174, 0.35869565217391, -0.075
96613, 0.80434782608696, 0.35869565217391, -0.1
96614, 0.78260869565217, 0.33260869565217, -0.1
96615, 0.78260869565217, 0.35869565217391, -0.075
96616, 0.76086956521739, 0.35869565217391, -0.1
96617, 0.73913043478261, 0.33260869565217, -0.1
96618, 0.73913043478261, 0.35869565217391, -0.075
96619, 0.71739130434783, 0.35869565217391, -0.1
96620, 0.69565217391304, 0.33260869565217, -0.1
96621, 0.69565217391304, 0.35869565217391, -0.075
96622, 0.67391304347826, 0.35869565217391, -0.1
96623, 0.65217391304348, 0.33260869565217, -0.1
96624, 0.65217391304348, 0.35869565217391, -0.075
96625, 0.6304347826087, 0.35869565217391, -0.1
96626, 0.60869565217391, 0.33260869565217, -0.1
96627, 0.60869565217391, 0.35869565217391, -0.075
96628, 0.58695652173913, 0.35869565217391, -0.1
96629, 0.56521739130435, 0.33260869565217, -0.1
96630, 0.56521739130435, 0.35869565217391, -0.075
96631, 0.54347826086957, 0.35869565217391, -0.1
96632, 0.52173913043478, 0.33260869565217, -0.1
96633, 0.52173913043478, 0.35869565217391, -0.075
96634, 0.5, 0.35869565217391, -0.1
96635, 0.47826086956522, 0.33260869565217, -0.1
96636, 0.47826086956522, 0.35869565217391, -0.075
96637, 0.45652173913043, 0.35869565217391, -0.1
96638, 0.43478260869565, 0.33260869565217, -0.1
96639, 0.43478260869565, 0.35869565217391, -0.075
96640, 0.41304347826087, 0.35869565217391, -0.1
96641, 0.39130434782609, 0.33260869565217, -0.1
96642, 0.39130434782609, 0.35869565217391, -0.075
96643, 0.3695652173913, 0.35869565217391, -0.1
96644, 0.34782608695652, 0.33260869565217, -0.1
96645, 0.34782608695652, 0.35869565217391, -0.075
96646, 0.32608695652174, 0.35869565217391, -0.1
96647, 0.30434782608696, 0.33260869565217, -0.1
96648, 0.30434782608696, 0.35869565217391, -0.075
96649, 0.28260869565217, 0.35869565217391, -0.1
96650, 0.26086956521739, 0.33260869565217, -0.1
96651, 0.26086956521739, 0.35869565217391, -0.075
96652, 0.23913043478261, 0.35869565217391, -0.1
96653, 0.21739130434783, 0.33260869565217, -0.1
96654, 0.21739130434783, 0.35869565217391, -0.075
96655, 0.19565217391304, 0.35869565217391, -0.1
96656, 0.17391304347826, 0.33260869565217, -0.1
96657, 0.17391304347826, 0.35869565217391, -0.075
96658, 0.15217391304348, 0.35869565217391, -0.1
96659, 0.1304347826087, 0.33260869565217, -0.1
96660, 0.1304347826087, 0.35869565217391, -0.075
96661, 0.10869565217391, 0.35869565217391, -0.1
96662, 0.08695652173913, 0.33260869565217, -0.1
96663, 0.08695652173913, 0.35869565217391, -0.075
96664, 0.065217391304348, 0.35869565217391, -0.1
96665, 0.043478260869565, 0.33260869565217, -0.1
96666, 0.043478260869565, 0.35869565217391, -0.075
96667, 0.021739130434783, 0.35869565217391, -0.1
96668, 0.97826086956522, 0.41086956521739, -0.1
96669, 0.95652173913044, 0.38478260869565, -0.1
96670, 0.95652173913043, 0.41086956521739, -0.075
96671, 0.93478260869565, 0.41086956521739, -0.1
96672, 0.91304347826087, 0.38478260869565, -0.1
96673, 0.91304347826087, 0.41086956521739, -0.075
96674, 0.89130434782609, 0.41086956521739, -0.1
96675, 0.8695652173913, 0.38478260869565, -0.1
96676, 0.8695652173913, 0.41086956521739, -0.075
96677, 0.84782608695652, 0.41086956521739, -0.1
96678, 0.82608695652174, 0.38478260869565, -0.1
96679, 0.82608695652174, 0.41086956521739, -0.075
96680, 0.80434782608696, 0.41086956521739, -0.1
96681, 0.78260869565217, 0.38478260869565, -0.1
96682, 0.78260869565217, 0.41086956521739, -0.075
96683, 0.76086956521739, 0.41086956521739, -0.1
96684, 0.73913043478261, 0.38478260869565, -0.1
96685, 0.73913043478261, 0.41086956521739, -0.075
96686, 0.71739130434783, 0.41086956521739, -0.1
96687, 0.69565217391304, 0.38478260869565, -0.1
96688, 0.69565217391304, 0.41086956521739, -0.075
96689, 0.67391304347826, 0.41086956521739, -0.1
96690, 0.65217391304348, 0.38478260869565, -0.1
96691, 0.65217391304348, 0.41086956521739, -0.075
96692, 0.6304347826087, 0.41086956521739, -0.1
96693, 0.60869565217391, 0.38478260869565, -0.1
96694, 0.60869565217391, 0.41086956521739, -0.075
96695, 0.58695652173913, 0.41086956521739, -0.1
96696, 0.56521739130435, 0.38478260869565, -0.1
96697, 0.56521739130435, 0.41086956521739, -0.075
96698, 0.54347826086957, 0.41086956521739, -0.1
96699, 0.52173913043478, 0.38478260869565, -0.1
96700, 0.52173913043478, 0.41086956521739, -0.075
96701, 0.5, 0.41086956521739, -0.1
96702, 0.47826086956522, 0.38478260869565, -0.1
96703, 0.47826086956522, 0.41086956521739, -0.075
96704, 0.45652173913043, 0.41086956521739, -0.1
96705, 0.43478260869565, 0.38478260869565, -0.1
96706, 0.43478260869565, 0.41086956521739, -0.075
96707, 0.41304347826087, 0.41086956521739, -0.1
96708, 0.39130434782609, 0.38478260869565, -0.1
96709, 0.39130434782609, 0.41086956521739, -0.075
96710, 0.3695652173913, 0.41086956521739, -0.1
96711, 0.34782608695652, 0.38478260869565, -0.1
96712, 0.34782608695652, 0.41086956521739, -0.075
96713, 0.32608695652174, 0.41086956521739, -0.1
96714, 0.30434782608696, 0.38478260869565, -0.1
96715, 0.30434782608696, 0.41086956521739, -0.075
96716, 0.28260869565217, 0.41086956521739, -0.1
96717, 0.26086956521739, 0.38478260869565, -0.1
96718, 0.26086956521739, 0.41086956521739, -0.075
96719, 0.23913043478261, 0.41086956521739, -0.1
96720, 0.21739130434783, 0.38478260869565, -0.1
96721, 0.21739130434783, 0.41086956521739, -0.075
96722, 0.19565217391304, 0.41086956521739, -0.1
96723, 0.17391304347826, 0.38478260869565, -0.1
96724, 0.17391304347826, 0.41086956521739, -0.075
96725, 0.15217391304348, 0.41086956521739, -0.1
96726, 0.1304347826087, 0.38478260869565, -0.1
96727, 0.1304347826087, 0.41086956521739, -0.075
96728, 0.10869565217391, 0.41086956521739, -0.1
96729, 0.08695652173913, 0.38478260869565, -0.1
96730, 0.08695652173913, 0.41086956521739, -0.075
96731, 0.065217391304348, 0.41086956521739, -0.1
96732, 0.043478260869565, 0.38478260869565, -0.1
96733, 0.043478260869565, 0.41086956521739, -0.075
96734, 0.021739130434783, 0.41086956521739, -0.1
96735, 0.97826086956522, 0.46304347826087, -0.1
96736, 0.95652173913044, 0.43695652173913, -0.1
96737, 0.95652173913043, 0.46304347826087, -0.075
96738, 0.93478260869565, 0.46304347826087, -0.1
96739, 0.91304347826087, 0.43695652173913, -0.1
96740, 0.91304347826087, 0.46304347826087, -0.075
96741, 0.89130434782609, 0.46304347826087, -0.1
96742, 0.8695652173913, 0.43695652173913, -0.1
96743, 0.8695652173913, 0.46304347826087, -0.075
96744, 0.84782608695652, 0.46304347826087, -0.1
96745, 0.82608695652174, 0.43695652173913, -0.1
96746, 0.82608695652174, 0.46304347826087, -0.075
96747, 0.80434782608696, 0.46304347826087, -0.1
96748, 0.78260869565217, 0.43695652173913, -0.1
96749, 0.78260869565217, 0.46304347826087, -0.075
96750, 0.76086956521739, 0.46304347826087, -0.1
96751, 0.73913043478261, 0.43695652173913, -0.1
96752, 0.73913043478261, 0.46304347826087, -0.075
96753, 0.71739130434783, 0.46304347826087, -0.1
96754, 0.69565217391304, 0.43695652173913, -0.1
96755, 0.69565217391304, 0.46304347826087, -0.075
96756, 0.67391304347826, 0.46304347826087, -0.1
96757, 0.65217391304348, 0.43695652173913, -0.1
96758, 0.65217391304348, 0.46304347826087, -0.075
96759, 0.6304347826087, 0.46304347826087, -0.1
96760, 0.60869565217391, 0.43695652173913, -0.1
96761, 0.60869565217391, 0.46304347826087, -0.075
96762, 0.58695652173913, 0.46304347826087, -0.1
96763, 0.56521739130435, 0.43695652173913, -0.1
96764, 0.56521739130435, 0.46304347826087, -0.075
96765, 0.54347826086957, 0.46304347826087, -0.1
96766, 0.52173913043478, 0.43695652173913, -0.1
96767, 0.52173913043478, 0.46304347826087, -0.075
96768, 0.5, 0.46304347826087, -0.1
96769, 0.47826086956522, 0.43695652173913, -0.1
96770, 0.47826086956522, 0.46304347826087, -0.075
96771, 0.45652173913043, 0.46304347826087, -0.1
96772, 0.43478260869565, 0.43695652173913, -0.1
96773, 0.43478260869565, 0.46304347826087, -0.075
96774, 0.41304347826087, 0.46304347826087, -0.1
96775, 0.39130434782609, 0.43695652173913, -0.1
96776, 0.39130434782609, 0.46304347826087, -0.075
96777, 0.3695652173913, 0.46304347826087, -0.1
96778, 0.34782608695652, 0.43695652173913, -0.1
96779, 0.34782608695652, 0.46304347826087, -0.075
96780, 0.32608695652174, 0.46304347826087, -0.1
96781, 0.30434782608696, 0.43695652173913, -0.1
96782, 0.30434782608696, 0.46304347826087, -0.075
96783, 0.28260869565217, 0.46304347826087, -0.1
96784, 0.26086956521739, 0.43695652173913, -0.1
96785, 0.26086956521739, 0.46304347826087, -0.075
96786, 0.23913043478261, 0.46304347826087, -0.1
96787, 0.21739130434783, 0.43695652173913, -0.1
96788, 0.21739130434783, 0.46304347826087, -0.075
96789, 0.19565217391304, 0.46304347826087, -0.1
96790, 0.17391304347826, 0.43695652173913, -0.1
96791, 0.17391304347826, 0.46304347826087, -0.075
96792, 0.15217391304348, 0.46304347826087, -0.1
96793, 0.1304347826087, 0.43695652173913, -0.1
96794, 0.1304347826087, 0.46304347826087, -0.075
96795, 0.10869565217391, 0.46304347826087, -0.1
96796, 0.08695652173913, 0.43695652173913, -0.1
96797, 0.08695652173913, 0.46304347826087, -0.075
96798, 0.065217391304348, 0.46304347826087, -0.1
96799, 0.043478260869565, 0.43695652173913, -0.1
96800, 0.043478260869565, 0.46304347826087, -0.075
96801, 0.021739130434783, 0.46304347826087, -0.1
96802, 0.97826086956522, 0.51521739130435, -0.1
96803, 0.95652173913044, 0.48913043478261, -0.1
96804, 0.95652173913043, 0.51521739130435, -0.075
96805, 0.93478260869565, 0.51521739130435, -0.1
96806, 0.91304347826087, 0.48913043478261, -0.1
96807, 0.91304347826087, 0.51521739130435, -0.075
96808, 0.89130434782609, 0.51521739130435, -0.1
96809, 0.8695652173913, 0.48913043478261, -0.1
96810, 0.8695652173913, 0.51521739130435, -0.075
96811, 0.84782608695652, 0.51521739130435, -0.1
96812, 0.82608695652174, 0.48913043478261, -0.1
96813, 0.82608695652174, 0.51521739130435, -0.075
96814, 0.80434782608696, 0.51521739130435, -0.1
96815, 0.78260869565217, 0.48913043478261, -0.1
96816, 0.78260869565217, 0.51521739130435, -0.075
96817, 0.76086956521739, 0.51521739130435, -0.1
96818, 0.73913043478261, 0.48913043478261, -0.1
96819, 0.73913043478261, 0.51521739130435, -0.075
96820, 0.71739130434783, 0.51521739130435, -0.1
96821, 0.69565217391304, 0.48913043478261, -0.1
96822, 0.69565217391304, 0.51521739130435, -0.075
96823, 0.67391304347826, 0.51521739130435, -0.1
96824, 0.65217391304348, 0.48913043478261, -0.1
96825, 0.65217391304348, 0.51521739130435, -0.075
96826, 0.6304347826087, 0.51521739130435, -0.1
96827, 0.60869565217391, 0.48913043478261, -0.1
96828, 0.60869565217391, 0.51521739130435, -0.075
96829, 0.58695652173913, 0.51521739130435, -0.1
96830, 0.56521739130435, 0.48913043478261, -0.1
96831, 0.56521739130435, 0.51521739130435, -0.075
96832, 0.54347826086956, 0.51521739130435, -0.1
96833, 0.52173913043478, 0.48913043478261, -0.1
96834, 0.52173913043478, 0.51521739130435, -0.075
96835, 0.5, 0.51521739130435, -0.1
96836, 0.47826086956522, 0.48913043478261, -0.1
96837, 0.47826086956522, 0.51521739130435, -0.075
96838, 0.45652173913044, 0.51521739130435, -0.1
96839, 0.43478260869565, 0.48913043478261, -0.1
96840, 0.43478260869565, 0.51521739130435, -0.075
96841, 0.41304347826087, 0.51521739130435, -0.1
96842, 0.39130434782609, 0.48913043478261, -0.1
96843, 0.39130434782609, 0.51521739130435, -0.075
96844, 0.3695652173913, 0.51521739130435, -0.1
96845, 0.34782608695652, 0.48913043478261, -0.1
96846, 0.34782608695652, 0.51521739130435, -0.075
96847, 0.32608695652174, 0.51521739130435, -0.1
96848, 0.30434782608696, 0.48913043478261, -0.1
96849, 0.30434782608696, 0.51521739130435, -0.075
96850, 0.28260869565217, 0.51521739130435, -0.1
96851, 0.26086956521739, 0.48913043478261, -0.1
96852, 0.26086956521739, 0.51521739130435, -0.075
96853, 0.23913043478261, 0.51521739130435, -0.1
96854, 0.21739130434783, 0.48913043478261, -0.1
96855, 0.21739130434783, 0.51521739130435, -0.075
96856, 0.19565217391304, 0.51521739130435, -0.1
96857, 0.17391304347826, 0.48913043478261, -0.1
96858, 0.17391304347826, 0.51521739130435, -0.075
96859, 0.15217391304348, 0.51521739130435, -0.1
96860, 0.1304347826087, 0.48913043478261, -0.1
96861, 0.1304347826087, 0.51521739130435, -0.075
96862, 0.10869565217391, 0.51521739130435, -0.1
96863, 0.08695652173913, 0.48913043478261, -0.1
96864, 0.08695652173913, 0.51521739130435, -0.075
96865, 0.065217391304348, 0.51521739130435, -0.1
96866, 0.043478260869565, 0.48913043478261, -0.1
96867, 0.043478260869565, 0.51521739130435, -0.075
96868, 0.021739130434783, 0.51521739130435, -0.1
96869, 0.97826086956522, 0.56739130434783, -0.1
96870, 0.95652173913044, 0.54130434782609, -0.1
96871, 0.95652173913043, 0.56739130434783, -0.075
96872, 0.93478260869565, 0.56739130434783, -0.1
96873, 0.91304347826087, 0.54130434782609, -0.1
96874, 0.91304347826087, 0.56739130434783, -0.075
96875, 0.89130434782609, 0.56739130434783, -0.1
96876, 0.8695652173913, 0.54130434782609, -0.1
96877, 0.8695652173913, 0.56739130434783, -0.075
96878, 0.84782608695652, 0.56739130434783, -0.1
96879, 0.82608695652174, 0.54130434782609, -0.1
96880, 0.82608695652174, 0.56739130434783, -0.075
96881, 0.80434782608696, 0.56739130434783, -0.1
96882, 0.78260869565217, 0.54130434782609, -0.1
96883, 0.78260869565217, 0.56739130434783, -0.075
96884, 0.76086956521739, 0.56739130434783, -0.1
96885, 0.73913043478261, 0.54130434782609, -0.1
96886, 0.73913043478261, 0.56739130434783, -0.075
96887, 0.71739130434783, 0.56739130434783, -0.1
96888, 0.69565217391304, 0.54130434782609, -0.1
96889, 0.69565217391304, 0.56739130434783, -0.075
96890, 0.67391304347826, 0.56739130434783, -0.1
96891, 0.65217391304348, 0.54130434782609, -0.1
96892, 0.65217391304348, 0.56739130434783, -0.075
96893, 0.6304347826087, 0.56739130434783, -0.1
96894, 0.60869565217391, 0.54130434782609, -0.1
96895, 0.60869565217391, 0.56739130434783, -0.075
96896, 0.58695652173913, 0.56739130434783, -0.1
96897, 0.56521739130435, 0.54130434782609, -0.1
96898, 0.56521739130435, 0.56739130434783, -0.075
96899, 0.54347826086957, 0.56739130434783, -0.1
96900, 0.52173913043478, 0.54130434782609, -0.1
96901, 0.52173913043478, 0.56739130434783, -0.075
96902, 0.5, 0.56739130434783, -0.1
96903, 0.47826086956522, 0.54130434782609, -0.1
96904, 0.47826086956522, 0.56739130434783, -0.075
96905, 0.45652173913043, 0.56739130434783, -0.1
96906, 0.43478260869565, 0.54130434782609, -0.1
96907, 0.43478260869565, 0.56739130434783, -0.075
96908, 0.41304347826087, 0.56739130434783, -0.1
96909, 0.39130434782609, 0.54130434782609, -0.1
96910, 0.39130434782609, 0.56739130434783, -0.075
96911, 0.3695652173913, 0.56739130434783, -0.1
96912, 0.34782608695652, 0.54130434782609, -0.1
96913, 0.34782608695652, 0.56739130434783, -0.075
96914, 0.32608695652174, 0.56739130434783, -0.1
96915, 0.30434782608696, 0.54130434782609, -0.1
96916, 0.30434782608696, 0.56739130434783, -0.075
96917, 0.28260869565217, 0.56739130434783, -0.1
96918, 0.26086956521739, 0.54130434782609, -0.1
96919, 0.26086956521739, 0.56739130434783, -0.075
96920, 0.23913043478261, 0.56739130434783, -0.1
96921, 0.21739130434783, 0.54130434782609, -0.1
96922, 0.21739130434783, 0.56739130434783, -0.075
96923, 0.19565217391304, 0.56739130434783, -0.1
96924, 0.17391304347826, 0.54130434782609, -0.1
96925, 0.17391304347826, 0.56739130434783, -0.075
96926, 0.15217391304348, 0.56739130434783, -0.1
96927, 0.1304347826087, 0.54130434782609, -0.1
96928, 0.1304347826087, 0.56739130434783, -0.075
96929, 0.10869565217391, 0.56739130434783, -0.1
96930, 0.08695652173913, 0.54130434782609, -0.1
96931, 0.08695652173913, 0.56739130434783, -0.075
96932, 0.065217391304348, 0.56739130434783, -0.1
96933, 0.043478260869565, 0.54130434782609, -0.1
96934, 0.043478260869565, 0.56739130434783, -0.075
96935, 0.021739130434783, 0.56739130434783, -0.1
96936, 0.97826086956522, 0.6195652173913, -0.1
96937, 0.95652173913044, 0.59347826086956, -0.1
96938, 0.95652173913043, 0.6195652173913, -0.075
96939, 0.93478260869565, 0.6195652173913, -0.1
96940, 0.91304347826087, 0.59347826086956, -0.1
96941, 0.91304347826087, 0.6195652173913, -0.075
96942, 0.89130434782609, 0.6195652173913, -0.1
96943, 0.8695652173913, 0.59347826086956, -0.1
96944, 0.8695652173913, 0.6195652173913, -0.075
96945, 0.84782608695652, 0.6195652173913, -0.1
96946, 0.82608695652174, 0.59347826086956, -0.1
96947, 0.82608695652174, 0.6195652173913, -0.075
96948, 0.80434782608696, 0.6195652173913, -0.1
96949, 0.78260869565217, 0.59347826086956, -0.1
96950, 0.78260869565217, 0.6195652173913, -0.075
96951, 0.76086956521739, 0.6195652173913, -0.1
96952, 0.73913043478261, 0.59347826086956, -0.1
96953, 0.73913043478261, 0.6195652173913, -0.075
96954, 0.71739130434783, 0.6195652173913, -0.1
96955, 0.69565217391304, 0.59347826086956, -0.1
96956, 0.69565217391304, 0.6195652173913, -0.075
96957, 0.67391304347826, 0.6195652173913, -0.1
96958, 0.65217391304348, 0.59347826086956, -0.1
96959, 0.65217391304348, 0.6195652173913, -0.075
96960, 0.6304347826087, 0.6195652173913, -0.1
96961, 0.60869565217391, 0.59347826086956, -0.1
96962, 0.60869565217391, 0.6195652173913, -0.075
96963, 0.58695652173913, 0.6195652173913, -0.1
96964, 0.56521739130435, 0.59347826086956, -0.1
96965, 0.56521739130435, 0.6195652173913, -0.075
96966, 0.54347826086957, 0.6195652173913, -0.1
96967, 0.52173913043478, 0.59347826086956, -0.1
96968, 0.52173913043478, 0.6195652173913, -0.075
96969, 0.5, 0.6195652173913, -0.1
96970, 0.47826086956522, 0.59347826086956, -0.1
96971, 0.47826086956522, 0.6195652173913, -0.075
96972, 0.45652173913043, 0.6195652173913, -0.1
96973, 0.43478260869565, 0.59347826086956, -0.1
96974, 0.43478260869565, 0.6195652173913, -0.075
96975, 0.41304347826087, 0.6195652173913, -0.1
96976, 0.39130434782609, 0.59347826086956, -0.1
96977, 0.39130434782609, 0.6195652173913, -0.075
96978, 0.3695652173913, 0.6195652173913, -0.1
96979, 0.34782608695652, 0.59347826086956, -0.1
96980, 0.34782608695652, 0.6195652173913, -0.075
96981, 0.32608695652174, 0.6195652173913, -0.1
96982, 0.30434782608696, 0.59347826086956, -0.1
96983, 0.30434782608696, 0.6195652173913, -0.075
96984, 0.28260869565217, 0.6195652173913, -0.1
96985, 0.26086956521739, 0.59347826086956, -0.1
96986, 0.26086956521739, 0.6195652173913, -0.075
96987, 0.23913043478261, 0.6195652173913, -0.1
96988, 0.21739130434783, 0.59347826086956, -0.1
96989, 0.21739130434783, 0.6195652173913, -0.075
96990, 0.19565217391304, 0.6195652173913, -0.1
96991, 0.17391304347826, 0.59347826086956, -0.1
96992, 0.17391304347826, 0.6195652173913, -0.075
96993, 0.15217391304348, 0.6195652173913, -0.1
96994, 0.1304347826087, 0.59347826086956, -0.1
96995, 0.1304347826087, 0.6195652173913, -0.075
96996, 0.10869565217391, 0.6195652173913, -0.1
96997, 0.08695652173913, 0.59347826086956, -0.1
96998, 0.08695652173913, 0.6195652173913, -0.075
96999, 0.065217391304348, 0.6195652173913, -0.1
97000, 0.043478260869565, 0.59347826086956, -0.1
97001, 0.043478260869565, 0.6195652173913, -0.075
97002, 0.021739130434783, 0.6195652173913, -0.1
97003, 0.97826086956522, 0.67173913043478, -0.1
97004, 0.95652173913044, 0.64565217391304, -0.1
97005, 0.95652173913044, 0.67173913043478, -0.075
97006, 0.93478260869565, 0.67173913043478, -0.1
97007, 0.91304347826087, 0.64565217391304, -0.1
97008, 0.91304347826087, 0.67173913043478, -0.075
97009, 0.89130434782609, 0.67173913043478, -0.1
97010, 0.8695652173913, 0.64565217391304, -0.1
97011, 0.8695652173913, 0.67173913043478, -0.075
97012, 0.84782608695652, 0.67173913043478, -0.1
97013, 0.82608695652174, 0.64565217391304, -0.1
97014, 0.82608695652174, 0.67173913043478, -0.075
97015, 0.80434782608696, 0.67173913043478, -0.1
97016, 0.78260869565217, 0.64565217391304, -0.1
97017, 0.78260869565217, 0.67173913043478, -0.075
97018, 0.76086956521739, 0.67173913043478, -0.1
97019, 0.73913043478261, 0.64565217391304, -0.1
97020, 0.73913043478261, 0.67173913043478, -0.075
97021, 0.71739130434783, 0.67173913043478, -0.1
97022, 0.69565217391304, 0.64565217391304, -0.1
97023, 0.69565217391304, 0.67173913043478, -0.075
97024, 0.67391304347826, 0.67173913043478, -0.1
97025, 0.65217391304348, 0.64565217391304, -0.1
97026, 0.65217391304348, 0.67173913043478, -0.075
97027, 0.6304347826087, 0.67173913043478, -0.1
97028, 0.60869565217391, 0.64565217391304, -0.1
97029, 0.60869565217391, 0.67173913043478, -0.075
97030, 0.58695652173913, 0.67173913043478, -0.1
97031, 0.56521739130435, 0.64565217391304, -0.1
97032, 0.56521739130435, 0.67173913043478, -0.075
97033, 0.54347826086957, 0.67173913043478, -0.1
97034, 0.52173913043478, 0.64565217391304, -0.1
97035, 0.52173913043478, 0.67173913043478, -0.075
97036, 0.5, 0.67173913043478, -0.1
97037, 0.47826086956522, 0.64565217391304, -0.1
97038, 0.47826086956522, 0.67173913043478, -0.075
97039, 0.45652173913043, 0.67173913043478, -0.1
97040, 0.43478260869565, 0.64565217391304, -0.1
97041, 0.43478260869565, 0.67173913043478, -0.075
97042, 0.41304347826087, 0.67173913043478, -0.1
97043, 0.39130434782609, 0.64565217391304, -0.1
97044, 0.39130434782609, 0.67173913043478, -0.075
97045, 0.3695652173913, 0.67173913043478, -0.1
97046, 0.34782608695652, 0.64565217391304, -0.1
97047, 0.34782608695652, 0.67173913043478, -0.075
97048, 0.32608695652174, 0.67173913043478, -0.1
97049, 0.30434782608696, 0.64565217391304, -0.1
97050, 0.30434782608696, 0.67173913043478, -0.075
97051, 0.28260869565217, 0.67173913043478, -0.1
97052, 0.26086956521739, 0.64565217391304, -0.1
97053, 0.26086956521739, 0.67173913043478, -0.075
97054, 0.23913043478261, 0.67173913043478, -0.1
97055, 0.21739130434783, 0.64565217391304, -0.1
97056, 0.21739130434783, 0.67173913043478, -0.075
97057, 0.19565217391304, 0.67173913043478, -0.1
97058, 0.17391304347826, 0.64565217391304, -0.1
97059, 0.17391304347826, 0.67173913043478, -0.075
97060, 0.15217391304348, 0.67173913043478, -0.1
97061, 0.1304347826087, 0.64565217391304, -0.1
97062, 0.1304347826087, 0.67173913043478, -0.075
97063, 0.10869565217391, 0.67173913043478, -0.1
97064, 0.08695652173913, 0.64565217391304, -0.1
97065, 0.08695652173913, 0.67173913043478, -0.075
97066, 0.065217391304348, 0.67173913043478, -0.1
97067, 0.043478260869565, 0.64565217391304, -0.1
97068, 0.043478260869565, 0.67173913043478, -0.075
97069, 0.021739130434783, 0.67173913043478, -0.1
97070, 0.97826086956522, 0.72391304347826, -0.1
97071, 0.95652173913044, 0.69782608695652, -0.1
97072, 0.95652173913044, 0.72391304347826, -0.075
97073, 0.93478260869565, 0.72391304347826, -0.1
97074, 0.91304347826087, 0.69782608695652, -0.1
97075, 0.91304347826087, 0.72391304347826, -0.075
97076, 0.89130434782609, 0.72391304347826, -0.1
97077, 0.8695652173913, 0.69782608695652, -0.1
97078, 0.8695652173913, 0.72391304347826, -0.075
97079, 0.84782608695652, 0.72391304347826, -0.1
97080, 0.82608695652174, 0.69782608695652, -0.1
97081, 0.82608695652174, 0.72391304347826, -0.075
97082, 0.80434782608696, 0.72391304347826, -0.1
97083, 0.78260869565217, 0.69782608695652, -0.1
97084, 0.78260869565217, 0.72391304347826, -0.075
97085, 0.76086956521739, 0.72391304347826, -0.1
97086, 0.73913043478261, 0.69782608695652, -0.1
97087, 0.73913043478261, 0.72391304347826, -0.075
97088, 0.71739130434783, 0.72391304347826, -0.1
97089, 0.69565217391304, 0.69782608695652, -0.1
97090, 0.69565217391304, 0.72391304347826, -0.075
97091, 0.67391304347826, 0.72391304347826, -0.1
97092, 0.65217391304348, 0.69782608695652, -0.1
97093, 0.65217391304348, 0.72391304347826, -0.075
97094, 0.6304347826087, 0.72391304347826, -0.1
97095, 0.60869565217391, 0.69782608695652, -0.1
97096, 0.60869565217391, 0.72391304347826, -0.075
97097, 0.58695652173913, 0.72391304347826, -0.1
97098, 0.56521739130435, 0.69782608695652, -0.1
97099, 0.56521739130435, 0.72391304347826, -0.075
97100, 0.54347826086957, 0.72391304347826, -0.1
97101, 0.52173913043478, 0.69782608695652, -0.1
97102, 0.52173913043478, 0.72391304347826, -0.075
97103, 0.5, 0.72391304347826, -0.1
97104, 0.47826086956522, 0.69782608695652, -0.1
97105, 0.47826086956522, 0.72391304347826, -0.075
97106, 0.45652173913043, 0.72391304347826, -0.1
97107, 0.43478260869565, 0.69782608695652, -0.1
97108, 0.43478260869565, 0.72391304347826, -0.075
97109, 0.41304347826087, 0.72391304347826, -0.1
97110, 0.39130434782609, 0.69782608695652, -0.1
97111, 0.39130434782609, 0.72391304347826, -0.075
97112, 0.3695652173913, 0.72391304347826, -0.1
97113, 0.34782608695652, 0.69782608695652, -0.1
97114, 0.34782608695652, 0.72391304347826, -0.075
97115, 0.32608695652174, 0.72391304347826, -0.1
97116, 0.30434782608696, 0.69782608695652, -0.1
97117, 0.30434782608696, 0.72391304347826, -0.075
97118, 0.28260869565217, 0.72391304347826, -0.1
97119, 0.26086956521739, 0.69782608695652, -0.1
97120, 0.26086956521739, 0.72391304347826, -0.075
97121, 0.23913043478261, 0.72391304347826, -0.1
97122, 0.21739130434783, 0.69782608695652, -0.1
97123, 0.21739130434783, 0.72391304347826, -0.075
97124, 0.19565217391304, 0.72391304347826, -0.1
97125, 0.17391304347826, 0.69782608695652, -0.1
97126, 0.17391304347826, 0.72391304347826, -0.075
97127, 0.15217391304348, 0.72391304347826, -0.1
97128, 0.1304347826087, 0.69782608695652, -0.1
97129, 0.1304347826087, 0.72391304347826, -0.075
97130, 0.10869565217391, 0.72391304347826, -0.1
97131, 0.08695652173913, 0.69782608695652, -0.1
97132, 0.08695652173913, 0.72391304347826, -0.075
97133, 0.065217391304348, 0.72391304347826, -0.1
97134, 0.043478260869565, 0.69782608695652, -0.1
97135, 0.043478260869565, 0.72391304347826, -0.075
97136, 0.021739130434783, 0.72391304347826, -0.1
97137, 0.97826086956522, 0.77608695652174, -0.1
97138, 0.95652173913044, 0.75, -0.1
97139, 0.95652173913043, 0.77608695652174, -0.075
97140, 0.93478260869565, 0.77608695652174, -0.1
97141, 0.91304347826087, 0.75, -0.1
97142, 0.91304347826087, 0.77608695652174, -0.075
97143, 0.89130434782609, 0.77608695652174, -0.1
97144, 0.8695652173913, 0.75, -0.1
97145, 0.8695652173913, 0.77608695652174, -0.075
97146, 0.84782608695652, 0.77608695652174, -0.1
97147, 0.82608695652174, 0.75, -0.1
97148, 0.82608695652174, 0.77608695652174, -0.075
97149, 0.80434782608696, 0.77608695652174, -0.1
97150, 0.78260869565217, 0.75, -0.1
97151, 0.78260869565217, 0.77608695652174, -0.075
97152, 0.76086956521739, 0.77608695652174, -0.1
97153, 0.73913043478261, 0.75, -0.1
97154, 0.73913043478261, 0.77608695652174, -0.075
97155, 0.71739130434783, 0.77608695652174, -0.1
97156, 0.69565217391304, 0.75, -0.1
97157, 0.69565217391304, 0.77608695652174, -0.075
97158, 0.67391304347826, 0.77608695652174, -0.1
97159, 0.65217391304348, 0.75, -0.1
97160, 0.65217391304348, 0.77608695652174, -0.075
97161, 0.6304347826087, 0.77608695652174, -0.1
97162, 0.60869565217391, 0.75, -0.1
97163, 0.60869565217391, 0.77608695652174, -0.075
97164, 0.58695652173913, 0.77608695652174, -0.1
97165, 0.56521739130435, 0.75, -0.1
97166, 0.56521739130435, 0.77608695652174, -0.075
97167, 0.54347826086957, 0.77608695652174, -0.1
97168, 0.52173913043478, 0.75, -0.1
97169, 0.52173913043478, 0.77608695652174, -0.075
97170, 0.5, 0.77608695652174, -0.1
97171, 0.47826086956522, 0.75, -0.1
97172, 0.47826086956522, 0.77608695652174, -0.075
97173, 0.45652173913043, 0.77608695652174, -0.1
97174, 0.43478260869565, 0.75, -0.1
97175, 0.43478260869565, 0.77608695652174, -0.075
97176, 0.41304347826087, 0.77608695652174, -0.1
97177, 0.39130434782609, 0.75, -0.1
97178, 0.39130434782609, 0.77608695652174, -0.075
97179, 0.3695652173913, 0.77608695652174, -0.1
97180, 0.34782608695652, 0.75, -0.1
97181, 0.34782608695652, 0.77608695652174, -0.075
97182, 0.32608695652174, 0.77608695652174, -0.1
97183, 0.30434782608696, 0.75, -0.1
97184, 0.30434782608696, 0.77608695652174, -0.075
97185, 0.28260869565217, 0.77608695652174, -0.1
97186, 0.26086956521739, 0.75, -0.1
97187, 0.26086956521739, 0.77608695652174, -0.075
97188, 0.23913043478261, 0.77608695652174, -0.1
97189, 0.21739130434783, 0.75, -0.1
97190, 0.21739130434783, 0.77608695652174, -0.075
97191, 0.19565217391304, 0.77608695652174, -0.1
97192, 0.17391304347826, 0.75, -0.1
97193, 0.17391304347826, 0.77608695652174, -0.075
97194, 0.15217391304348, 0.77608695652174, -0.1
97195, 0.1304347826087, 0.75, -0.1
97196, 0.1304347826087, 0.77608695652174, -0.075
97197, 0.10869565217391, 0.77608695652174, -0.1
97198, 0.08695652173913, 0.75, -0.1
97199, 0.08695652173913, 0.77608695652174, -0.075
97200, 0.065217391304348, 0.77608695652174, -0.1
97201, 0.043478260869565, 0.75, -0.1
97202, 0.043478260869565, 0.77608695652174, -0.075
97203, 0.021739130434783, 0.77608695652174, -0.1
97204, 0.97826086956522, 0.82826086956522, -0.1
97205, 0.95652173913044, 0.80217391304348, -0.1
97206, 0.95652173913044, 0.82826086956522, -0.075
97207, 0.93478260869565, 0.82826086956522, -0.1
97208, 0.91304347826087, 0.80217391304348, -0.1
97209, 0.91304347826087, 0.82826086956522, -0.075
97210, 0.89130434782609, 0.82826086956522, -0.1
97211, 0.8695652173913, 0.80217391304348, -0.1
97212, 0.8695652173913, 0.82826086956522, -0.075
97213, 0.84782608695652, 0.82826086956522, -0.1
97214, 0.82608695652174, 0.80217391304348, -0.1
97215, 0.82608695652174, 0.82826086956522, -0.075
97216, 0.80434782608696, 0.82826086956522, -0.1
97217, 0.78260869565217, 0.80217391304348, -0.1
97218, 0.78260869565217, 0.82826086956522, -0.075
97219, 0.76086956521739, 0.82826086956522, -0.1
97220, 0.73913043478261, 0.80217391304348, -0.1
97221, 0.73913043478261, 0.82826086956522, -0.075
97222, 0.71739130434783, 0.82826086956522, -0.1
97223, 0.69565217391304, 0.80217391304348, -0.1
97224, 0.69565217391304, 0.82826086956522, -0.075
97225, 0.67391304347826, 0.82826086956522, -0.1
97226, 0.65217391304348, 0.80217391304348, -0.1
97227, 0.65217391304348, 0.82826086956522, -0.075
97228, 0.6304347826087, 0.82826086956522, -0.1
97229, 0.60869565217391, 0.80217391304348, -0.1
97230, 0.60869565217391, 0.82826086956522, -0.075
97231, 0.58695652173913, 0.82826086956522, -0.1
97232, 0.56521739130435, 0.80217391304348, -0.1
97233, 0.56521739130435, 0.82826086956522, -0.075
97234, 0.54347826086957, 0.82826086956522, -0.1
97235, 0.52173913043478, 0.80217391304348, -0.1
97236, 0.52173913043478, 0.82826086956522, -0.075
97237, 0.5, 0.82826086956522, -0.1
97238, 0.47826086956522, 0.80217391304348, -0.1
97239, 0.47826086956522, 0.82826086956522, -0.075
97240, 0.45652173913043, 0.82826086956522, -0.1
97241, 0.43478260869565, 0.80217391304348, -0.1
97242, 0.43478260869565, 0.82826086956522, -0.075
97243, 0.41304347826087, 0.82826086956522, -0.1
97244, 0.39130434782609, 0.80217391304348, -0.1
97245, 0.39130434782609, 0.82826086956522, -0.075
97246, 0.3695652173913, 0.82826086956522, -0.1
97247, 0.34782608695652, 0.80217391304348, -0.1
97248, 0.34782608695652, 0.82826086956522, -0.075
97249, 0.32608695652174, 0.82826086956522, -0.1
97250, 0.30434782608696, 0.80217391304348, -0.1
97251, 0.30434782608696, 0.82826086956522, -0.075
97252, 0.28260869565217, 0.82826086956522, -0.1
97253, 0.26086956521739, 0.80217391304348, -0.1
97254, 0.26086956521739, 0.82826086956522, -0.075
97255, 0.23913043478261, 0.82826086956522, -0.1
97256, 0.21739130434783, 0.80217391304348, -0.1
97257, 0.21739130434783, 0.82826086956522, -0.075
97258, 0.19565217391304, 0.82826086956522, -0.1
97259, 0.17391304347826, 0.80217391304348, -0.1
97260, 0.17391304347826, 0.82826086956522, -0.075
97261, 0.15217391304348, 0.82826086956522, -0.1
97262, 0.1304347826087, 0.80217391304348, -0.1
97263, 0.1304347826087, 0.82826086956522, -0.075
97264, 0.10869565217391, 0.82826086956522, -0.1
97265, 0.08695652173913, 0.80217391304348, -0.1
97266, 0.08695652173913, 0.82826086956522, -0.075
97267, 0.065217391304348, 0.82826086956522, -0.1
97268, 0.043478260869565, 0.80217391304348, -0.1
97269, 0.043478260869565, 0.82826086956522, -0.075
97270, 0.021739130434783, 0.82826086956522, -0.1
97271, 0.97826086956522, 0.8804347826087, -0.1
97272, 0.95652173913044, 0.85434782608696, -0.1
97273, 0.95652173913044, 0.88043478260869, -0.075
97274, 0.93478260869565, 0.8804347826087, -0.1
97275, 0.91304347826087, 0.85434782608696, -0.1
97276, 0.91304347826087, 0.8804347826087, -0.075
97277, 0.89130434782609, 0.8804347826087, -0.1
97278, 0.8695652173913, 0.85434782608696, -0.1
97279, 0.8695652173913, 0.8804347826087, -0.075
97280, 0.84782608695652, 0.8804347826087, -0.1
97281, 0.82608695652174, 0.85434782608696, -0.1
97282, 0.82608695652174, 0.8804347826087, -0.075
97283, 0.80434782608696, 0.8804347826087, -0.1
97284, 0.78260869565217, 0.85434782608696, -0.1
97285, 0.78260869565217, 0.8804347826087, -0.075
97286, 0.76086956521739, 0.8804347826087, -0.1
97287, 0.73913043478261, 0.85434782608696, -0.1
97288, 0.73913043478261, 0.88043478260869, -0.075
97289, 0.71739130434783, 0.8804347826087, -0.1
97290, 0.69565217391304, 0.85434782608696, -0.1
97291, 0.69565217391304, 0.8804347826087, -0.075
97292, 0.67391304347826, 0.8804347826087, -0.1
97293, 0.65217391304348, 0.85434782608696, -0.1
97294, 0.65217391304348, 0.8804347826087, -0.075
97295, 0.6304347826087, 0.8804347826087, -0.1
97296, 0.60869565217391, 0.85434782608696, -0.1
97297, 0.60869565217391, 0.8804347826087, -0.075
97298, 0.58695652173913, 0.8804347826087, -0.1
97299, 0.56521739130435, 0.85434782608696, -0.1
97300, 0.56521739130435, 0.88043478260869, -0.075
97301, 0.54347826086957, 0.88043478260869, -0.1
97302, 0.52173913043478, 0.85434782608696, -0.1
97303, 0.52173913043478, 0.8804347826087, -0.075
97304, 0.5, 0.88043478260869, -0.1
97305, 0.47826086956522, 0.85434782608696, -0.1
97306, 0.47826086956522, 0.8804347826087, -0.075
97307, 0.45652173913043, 0.88043478260869, -0.1
97308, 0.43478260869565, 0.85434782608696, -0.1
97309, 0.43478260869565, 0.88043478260869, -0.075
97310, 0.41304347826087, 0.8804347826087, -0.1
97311, 0.39130434782609, 0.85434782608696, -0.1
97312, 0.39130434782609, 0.8804347826087, -0.075
97313, 0.3695652173913, 0.8804347826087, -0.1
97314, 0.34782608695652, 0.85434782608696, -0.1
97315, 0.34782608695652, 0.8804347826087, -0.075
97316, 0.32608695652174, 0.8804347826087, -0.1
97317, 0.30434782608696, 0.85434782608696, -0.1
97318, 0.30434782608696, 0.88043478260869, -0.075
97319, 0.28260869565217, 0.8804347826087, -0.1
97320, 0.26086956521739, 0.85434782608696, -0.1
97321, 0.26086956521739, 0.8804347826087, -0.075
97322, 0.23913043478261, 0.8804347826087, -0.1
97323, 0.21739130434783, 0.85434782608696, -0.1
97324, 0.21739130434783, 0.88043478260869, -0.075
97325, 0.19565217391304, 0.8804347826087, -0.1
97326, 0.17391304347826, 0.85434782608696, -0.1
97327, 0.17391304347826, 0.8804347826087, -0.075
97328, 0.15217391304348, 0.8804347826087, -0.1
97329, 0.1304347826087, 0.85434782608696, -0.1
97330, 0.1304347826087, 0.8804347826087, -0.075
97331, 0.10869565217391, 0.8804347826087, -0.1
97332, 0.08695652173913, 0.85434782608696, -0.1
97333, 0.08695652173913, 0.8804347826087, -0.075
97334, 0.065217391304348, 0.8804347826087, -0.1
97335, 0.043478260869565, 0.85434782608696, -0.1
97336, 0.043478260869565, 0.88043478260869, -0.075
97337, 0.021739130434783, 0.88043478260869, -0.1
97338, 0.97826086956522, 0.93260869565217, -0.1
97339, 0.95652173913044, 0.90652173913043, -0.1
97340, 0.95652173913043, 0.93260869565217, -0.075
97341, 0.93478260869565, 0.93260869565217, -0.1
97342, 0.91304347826087, 0.90652173913043, -0.1
97343, 0.91304347826087, 0.93260869565217, -0.075
97344, 0.89130434782609, 0.93260869565217, -0.1
97345, 0.8695652173913, 0.90652173913043, -0.1
97346, 0.8695652173913, 0.93260869565217, -0.075
97347, 0.84782608695652, 0.93260869565217, -0.1
97348, 0.82608695652174, 0.90652173913043, -0.1
97349, 0.82608695652174, 0.93260869565217, -0.075
97350, 0.80434782608696, 0.93260869565217, -0.1
97351, 0.78260869565217, 0.90652173913043, -0.1
97352, 0.78260869565217, 0.93260869565217, -0.075
97353, 0.76086956521739, 0.93260869565217, -0.1
97354, 0.73913043478261, 0.90652173913043, -0.1
97355, 0.73913043478261, 0.93260869565217, -0.075
97356, 0.71739130434783, 0.93260869565217, -0.1
97357, 0.69565217391304, 0.90652173913043, -0.1
97358, 0.69565217391304, 0.93260869565217, -0.075
97359, 0.67391304347826, 0.93260869565217, -0.1
97360, 0.65217391304348, 0.90652173913043, -0.1
97361, 0.65217391304348, 0.93260869565217, -0.075
97362, 0.6304347826087, 0.93260869565217, -0.1
97363, 0.60869565217391, 0.90652173913043, -0.1
97364, 0.60869565217391, 0.93260869565217, -0.075
97365, 0.58695652173913, 0.93260869565217, -0.1
97366, 0.56521739130435, 0.90652173913043, -0.1
97367, 0.56521739130435, 0.93260869565217, -0.075
97368, 0.54347826086957, 0.93260869565217, -0.1
97369, 0.52173913043478, 0.90652173913043, -0.1
97370, 0.52173913043478, 0.93260869565217, -0.075
97371, 0.5, 0.93260869565217, -0.1
97372, 0.47826086956522, 0.90652173913043, -0.1
97373, 0.47826086956522, 0.93260869565217, -0.075
97374, 0.45652173913043, 0.93260869565217, -0.1
97375, 0.43478260869565, 0.90652173913043, -0.1
97376, 0.43478260869565, 0.93260869565217, -0.075
97377, 0.41304347826087, 0.93260869565217, -0.1
97378, 0.39130434782609, 0.90652173913043, -0.1
97379, 0.39130434782609, 0.93260869565217, -0.075
97380, 0.3695652173913, 0.93260869565217, -0.1
97381, 0.34782608695652, 0.90652173913043, -0.1
97382, 0.34782608695652, 0.93260869565217, -0.075
97383, 0.32608695652174, 0.93260869565217, -0.1
97384, 0.30434782608696, 0.90652173913043, -0.1
97385, 0.30434782608696, 0.93260869565217, -0.075
97386, 0.28260869565217, 0.93260869565217, -0.1
97387, 0.26086956521739, 0.90652173913043, -0.1
97388, 0.26086956521739, 0.93260869565217, -0.075
97389, 0.23913043478261, 0.93260869565217, -0.1
97390, 0.21739130434783, 0.90652173913043, -0.1
97391, 0.21739130434783, 0.93260869565217, -0.075
97392, 0.19565217391304, 0.93260869565217, -0.1
97393, 0.17391304347826, 0.90652173913043, -0.1
97394, 0.17391304347826, 0.93260869565217, -0.075
97395, 0.15217391304348, 0.93260869565217, -0.1
97396, 0.1304347826087, 0.90652173913043, -0.1
97397, 0.1304347826087, 0.93260869565217, -0.075
97398, 0.10869565217391, 0.93260869565217, -0.1
97399, 0.08695652173913, 0.90652173913043, -0.1
97400, 0.08695652173913, 0.93260869565217, -0.075
97401, 0.065217391304348, 0.93260869565217, -0.1
97402, 0.043478260869565, 0.90652173913043, -0.1
97403, 0.043478260869565, 0.93260869565217, -0.075
97404, 0.021739130434783, 0.93260869565217, -0.1
97405, 0.97826086956522, 0.98478260869565, -0.1
97406, 0.95652173913044, 0.95869565217391, -0.1
97407, 0.95652173913044, 0.98478260869565, -0.075
97408, 0.93478260869565, 0.98478260869565, -0.1
97409, 0.91304347826087, 0.95869565217391, -0.1
97410, 0.91304347826087, 0.98478260869565, -0.075
97411, 0.89130434782609, 0.98478260869565, -0.1
97412, 0.8695652173913, 0.95869565217391, -0.1
97413, 0.8695652173913, 0.98478260869565, -0.075
97414, 0.84782608695652, 0.98478260869565, -0.1
97415, 0.82608695652174, 0.95869565217391, -0.1
97416, 0.82608695652174, 0.98478260869565, -0.075
97417, 0.80434782608696, 0.98478260869565, -0.1
97418, 0.78260869565217, 0.95869565217391, -0.1
97419, 0.78260869565217, 0.98478260869565, -0.075
97420, 0.76086956521739, 0.98478260869565, -0.1
97421, 0.73913043478261, 0.95869565217391, -0.1
97422, 0.73913043478261, 0.98478260869565, -0.075
97423, 0.71739130434783, 0.98478260869565, -0.1
97424, 0.69565217391304, 0.95869565217391, -0.1
97425, 0.69565217391304, 0.98478260869565, -0.075
97426, 0.67391304347826, 0.98478260869565, -0.1
97427, 0.65217391304348, 0.95869565217391, -0.1
97428, 0.65217391304348, 0.98478260869565, -0.075
97429, 0.6304347826087, 0.98478260869565, -0.1
97430, 0.60869565217391, 0.95869565217391, -0.1
97431, 0.60869565217391, 0.98478260869565, -0.075
97432, 0.58695652173913, 0.98478260869565, -0.1
97433, 0.56521739130435, 0.95869565217391, -0.1
97434, 0.56521739130435, 0.98478260869565, -0.075
97435, 0.54347826086957, 0.98478260869565, -0.1
97436, 0.52173913043478, 0.95869565217391, -0.1
97437, 0.52173913043478, 0.98478260869565, -0.075
97438, 0.5, 0.98478260869565, -0.1
97439, 0.47826086956522, 0.95869565217391, -0.1
97440, 0.47826086956522, 0.98478260869565, -0.075
97441, 0.45652173913043, 0.98478260869565, -0.1
97442, 0.43478260869565, 0.95869565217391, -0.1
97443, 0.43478260869565, 0.98478260869565, -0.075
97444, 0.41304347826087, 0.98478260869565, -0.1
97445, 0.39130434782609, 0.95869565217391, -0.1
97446, 0.39130434782609, 0.98478260869565, -0.075
97447, 0.3695652173913, 0.98478260869565, -0.1
97448, 0.34782608695652, 0.95869565217391, -0.1
97449, 0.34782608695652, 0.98478260869565, -0.075
97450, 0.32608695652174, 0.98478260869565, -0.1
97451, 0.30434782608696, 0.95869565217391, -0.1
97452, 0.30434782608696, 0.98478260869565, -0.075
97453, 0.28260869565217, 0.98478260869565, -0.1
97454, 0.26086956521739, 0.95869565217391, -0.1
97455, 0.26086956521739, 0.98478260869565, -0.075
97456, 0.23913043478261, 0.98478260869565, -0.1
97457, 0.21739130434783, 0.95869565217391, -0.1
97458, 0.21739130434783, 0.98478260869565, -0.075
97459, 0.19565217391304, 0.98478260869565, -0.1
97460, 0.17391304347826, 0.95869565217391, -0.1
97461, 0.17391304347826, 0.98478260869565, -0.075
97462, 0.15217391304348, 0.98478260869565, -0.1
97463, 0.1304347826087, 0.95869565217391, -0.1
97464, 0.1304347826087, 0.98478260869565, -0.075
97465, 0.10869565217391, 0.98478260869565, -0.1
97466, 0.08695652173913, 0.95869565217391, -0.1
97467, 0.08695652173913, 0.98478260869565, -0.075
97468, 0.065217391304348, 0.98478260869565, -0.1
97469, 0.043478260869565, 0.95869565217391, -0.1
97470, 0.043478260869565, 0.98478260869565, -0.075
97471, 0.021739130434783, 0.98478260869565, -0.1
97472, 0.97826086956522, 1.0369565217391, -0.1
97473, 0.95652173913044, 1.0108695652174, -0.1
97474, 0.95652173913043, 1.0369565217391, -0.075
97475, 0.93478260869565, 1.0369565217391, -0.1
97476, 0.91304347826087, 1.0108695652174, -0.1
97477, 0.91304347826087, 1.0369565217391, -0.075
97478, 0.89130434782609, 1.0369565217391, -0.1
97479, 0.8695652173913, 1.0108695652174, -0.1
97480, 0.8695652173913, 1.0369565217391, -0.075
97481, 0.84782608695652, 1.0369565217391, -0.1
97482, 0.82608695652174, 1.0108695652174, -0.1
97483, 0.82608695652174, 1.0369565217391, -0.075
97484, 0.80434782608696, 1.0369565217391, -0.1
97485, 0.78260869565217, 1.0108695652174, -0.1
97486, 0.78260869565217, 1.0369565217391, -0.075
97487, 0.76086956521739, 1.0369565217391, -0.1
97488, 0.73913043478261, 1.0108695652174, -0.1
97489, 0.73913043478261, 1.0369565217391, -0.075
97490, 0.71739130434783, 1.0369565217391, -0.1
97491, 0.69565217391304, 1.0108695652174, -0.1
97492, 0.69565217391304, 1.0369565217391, -0.075
97493, 0.67391304347826, 1.0369565217391, -0.1
97494, 0.65217391304348, 1.0108695652174, -0.1
97495, 0.65217391304348, 1.0369565217391, -0.075
97496, 0.6304347826087, 1.0369565217391, -0.1
97497, 0.60869565217391, 1.0108695652174, -0.1
97498, 0.60869565217391, 1.0369565217391, -0.075
97499, 0.58695652173913, 1.0369565217391, -0.1
97500, 0.56521739130435, 1.0108695652174, -0.1
97501, 0.56521739130435, 1.0369565217391, -0.075
97502, 0.54347826086957, 1.0369565217391, -0.1
97503, 0.52173913043478, 1.0108695652174, -0.1
97504, 0.52173913043478, 1.0369565217391, -0.075
97505, 0.5, 1.0369565217391, -0.1
97506, 0.47826086956522, 1.0108695652174, -0.1
97507, 0.47826086956522, 1.0369565217391, -0.075
97508, 0.45652173913043, 1.0369565217391, -0.1
97509, 0.43478260869565, 1.0108695652174, -0.1
97510, 0.43478260869565, 1.0369565217391, -0.075
97511, 0.41304347826087, 1.0369565217391, -0.1
97512, 0.39130434782609, 1.0108695652174, -0.1
97513, 0.39130434782609, 1.0369565217391, -0.075
97514, 0.3695652173913, 1.0369565217391, -0.1
97515, 0.34782608695652, 1.0108695652174, -0.1
97516, 0.34782608695652, 1.0369565217391, -0.075
97517, 0.32608695652174, 1.0369565217391, -0.1
97518, 0.30434782608696, 1.0108695652174, -0.1
97519, 0.30434782608696, 1.0369565217391, -0.075
97520, 0.28260869565217, 1.0369565217391, -0.1
97521, 0.26086956521739, 1.0108695652174, -0.1
97522, 0.26086956521739, 1.0369565217391, -0.075
97523, 0.23913043478261, 1.0369565217391, -0.1
97524, 0.21739130434783, 1.0108695652174, -0.1
97525, 0.21739130434783, 1.0369565217391, -0.075
97526, 0.19565217391304, 1.0369565217391, -0.1
97527, 0.17391304347826, 1.0108695652174, -0.1
97528, 0.17391304347826, 1.0369565217391, -0.075
97529, 0.15217391304348, 1.0369565217391, -0.1
97530, 0.1304347826087, 1.0108695652174, -0.1
97531, 0.1304347826087, 1.0369565217391, -0.075
97532, 0.10869565217391, 1.0369565217391, -0.1
97533, 0.08695652173913, 1.0108695652174, -0.1
97534, 0.08695652173913, 1.0369565217391, -0.075
97535, 0.065217391304348, 1.0369565217391, -0.1
97536, 0.043478260869565, 1.0108695652174, -0.1
97537, 0.043478260869565, 1.0369565217391, -0.075
97538, 0.021739130434783, 1.0369565217391, -0.1
97539, 0.97826086956522, 1.0891304347826, -0.1
97540, 0.95652173913044, 1.0630434782609, -0.1
97541, 0.95652173913043, 1.0891304347826, -0.075
97542, 0.93478260869565, 1.0891304347826, -0.1
97543, 0.91304347826087, 1.0630434782609, -0.1
97544, 0.91304347826087, 1.0891304347826, -0.075
97545, 0.89130434782609, 1.0891304347826, -0.1
97546, 0.8695652173913, 1.0630434782609, -0.1
97547, 0.8695652173913, 1.0891304347826, -0.075
97548, 0.84782608695652, 1.0891304347826, -0.1
97549, 0.82608695652174, 1.0630434782609, -0.1
97550, 0.82608695652174, 1.0891304347826, -0.075
97551, 0.80434782608696, 1.0891304347826, -0.1
97552, 0.78260869565217, 1.0630434782609, -0.1
97553, 0.78260869565217, 1.0891304347826, -0.075
97554, 0.76086956521739, 1.0891304347826, -0.1
97555, 0.73913043478261, 1.0630434782609, -0.1
97556, 0.73913043478261, 1.0891304347826, -0.075
97557, 0.71739130434783, 1.0891304347826, -0.1
97558, 0.69565217391304, 1.0630434782609, -0.1
97559, 0.69565217391304, 1.0891304347826, -0.075
97560, 0.67391304347826, 1.0891304347826, -0.1
97561, 0.65217391304348, 1.0630434782609, -0.1
97562, 0.65217391304348, 1.0891304347826, -0.075
97563, 0.6304347826087, 1.0891304347826, -0.1
97564, 0.60869565217391, 1.0630434782609, -0.1
97565, 0.60869565217391, 1.0891304347826, -0.075
97566, 0.58695652173913, 1.0891304347826, -0.1
97567, 0.56521739130435, 1.0630434782609, -0.1
97568, 0.56521739130435, 1.0891304347826, -0.075
97569, 0.54347826086956, 1.0891304347826, -0.1
97570, 0.52173913043478, 1.0630434782609, -0.1
97571, 0.52173913043478, 1.0891304347826, -0.075
97572, 0.5, 1.0891304347826, -0.1
97573, 0.47826086956522, 1.0630434782609, -0.1
97574, 0.47826086956522, 1.0891304347826, -0.075
97575, 0.45652173913043, 1.0891304347826, -0.1
97576, 0.43478260869565, 1.0630434782609, -0.1
97577, 0.43478260869565, 1.0891304347826, -0.075
97578, 0.41304347826087, 1.0891304347826, -0.1
97579, 0.39130434782609, 1.0630434782609, -0.1
97580, 0.39130434782609, 1.0891304347826, -0.075
97581, 0.3695652173913, 1.0891304347826, -0.1
97582, 0.34782608695652, 1.0630434782609, -0.1
97583, 0.34782608695652, 1.0891304347826, -0.075
97584, 0.32608695652174, 1.0891304347826, -0.1
97585, 0.30434782608696, 1.0630434782609, -0.1
97586, 0.30434782608696, 1.0891304347826, -0.075
97587, 0.28260869565217, 1.0891304347826, -0.1
97588, 0.26086956521739, 1.0630434782609, -0.1
97589, 0.26086956521739, 1.0891304347826, -0.075
97590, 0.23913043478261, 1.0891304347826, -0.1
97591, 0.21739130434783, 1.0630434782609, -0.1
97592, 0.21739130434783, 1.0891304347826, -0.075
97593, 0.19565217391304, 1.0891304347826, -0.1
97594, 0.17391304347826, 1.0630434782609, -0.1
97595, 0.17391304347826, 1.0891304347826, -0.075
97596, 0.15217391304348, 1.0891304347826, -0.1
97597, 0.1304347826087, 1.0630434782609, -0.1
97598, 0.1304347826087, 1.0891304347826, -0.075
97599, 0.10869565217391, 1.0891304347826, -0.1
97600, 0.08695652173913, 1.0630434782609, -0.1
97601, 0.08695652173913, 1.0891304347826, -0.075
97602, 0.065217391304348, 1.0891304347826, -0.1
97603, 0.043478260869565, 1.0630434782609, -0.1
97604, 0.043478260869565, 1.0891304347826, -0.075
97605, 0.021739130434783, 1.0891304347826, -0.1
97606, 0.97826086956522, 1.1413043478261, -0.1
97607, 0.95652173913044, 1.1152173913043, -0.1
97608, 0.95652173913043, 1.1413043478261, -0.075
97609, 0.93478260869565, 1.1413043478261, -0.1
97610, 0.91304347826087, 1.1152173913043, -0.1
97611, 0.91304347826087, 1.1413043478261, -0.075
97612, 0.89130434782609, 1.1413043478261, -0.1
97613, 0.8695652173913, 1.1152173913043, -0.1
97614, 0.8695652173913, 1.1413043478261, -0.075
97615, 0.84782608695652, 1.1413043478261, -0.1
97616, 0.82608695652174, 1.1152173913043, -0.1
97617, 0.82608695652174, 1.1413043478261, -0.075
97618, 0.80434782608696, 1.1413043478261, -0.1
97619, 0.78260869565217, 1.1152173913043, -0.1
97620, 0.78260869565217, 1.1413043478261, -0.075
97621, 0.76086956521739, 1.1413043478261, -0.1
97622, 0.73913043478261, 1.1152173913043, -0.1
97623, 0.73913043478261, 1.1413043478261, -0.075
97624, 0.71739130434783, 1.1413043478261, -0.1
97625, 0.69565217391304, 1.1152173913043, -0.1
97626, 0.69565217391304, 1.1413043478261, -0.075
97627, 0.67391304347826, 1.1413043478261, -0.1
97628, 0.65217391304348, 1.1152173913043, -0.1
97629, 0.65217391304348, 1.1413043478261, -0.075
97630, 0.6304347826087, 1.1413043478261, -0.1
97631, 0.60869565217391, 1.1152173913043, -0.1
97632, 0.60869565217391, 1.1413043478261, -0.075
97633, 0.58695652173913, 1.1413043478261, -0.1
97634, 0.56521739130435, 1.1152173913043, -0.1
97635, 0.56521739130435, 1.1413043478261, -0.075
97636, 0.54347826086957, 1.1413043478261, -0.1
97637, 0.52173913043478, 1.1152173913043, -0.1
97638, 0.52173913043478, 1.1413043478261, -0.075
97639, 0.5, 1.1413043478261, -0.1
97640, 0.47826086956522, 1.1152173913043, -0.1
97641, 0.47826086956522, 1.1413043478261, -0.075
97642, 0.45652173913043, 1.1413043478261, -0.1
97643, 0.43478260869565, 1.1152173913043, -0.1
97644, 0.43478260869565, 1.1413043478261, -0.075
97645, 0.41304347826087, 1.1413043478261, -0.1
97646, 0.39130434782609, 1.1152173913043, -0.1
97647, 0.39130434782609, 1.1413043478261, -0.075
97648, 0.3695652173913, 1.1413043478261, -0.1
97649, 0.34782608695652, 1.1152173913043, -0.1
97650, 0.34782608695652, 1.1413043478261, -0.075
97651, 0.32608695652174, 1.1413043478261, -0.1
97652, 0.30434782608696, 1.1152173913043, -0.1
97653, 0.30434782608696, 1.1413043478261, -0.075
97654, 0.28260869565217, 1.1413043478261, -0.1
97655, 0.26086956521739, 1.1152173913043, -0.1
97656, 0.26086956521739, 1.1413043478261, -0.075
97657, 0.23913043478261, 1.1413043478261, -0.1
97658, 0.21739130434783, 1.1152173913043, -0.1
97659, 0.21739130434783, 1.1413043478261, -0.075
97660, 0.19565217391304, 1.1413043478261, -0.1
97661, 0.17391304347826, 1.1152173913043, -0.1
97662, 0.17391304347826, 1.1413043478261, -0.075
97663, 0.15217391304348, 1.1413043478261, -0.1
97664, 0.1304347826087, 1.1152173913043, -0.1
97665, 0.1304347826087, 1.1413043478261, -0.075
97666, 0.10869565217391, 1.1413043478261, -0.1
97667, 0.08695652173913, 1.1152173913043, -0.1
97668, 0.08695652173913, 1.1413043478261, -0.075
97669, 0.065217391304348, 1.1413043478261, -0.1
97670, 0.043478260869565, 1.1152173913043, -0.1
97671, 0.043478260869565, 1.1413043478261, -0.075
97672, 0.021739130434783, 1.1413043478261, -0.1
97673, 0.97826086956522, 1.1934782608696, -0.1
97674, 0.95652173913044, 1.1673913043478, -0.1
97675, 0.95652173913043, 1.1934782608696, -0.075
97676, 0.93478260869565, 1.1934782608696, -0.1
97677, 0.91304347826087, 1.1673913043478, -0.1
97678, 0.91304347826087, 1.1934782608696, -0.075
97679, 0.89130434782609, 1.1934782608696, -0.1
97680, 0.8695652173913, 1.1673913043478, -0.1
97681, 0.8695652173913, 1.1934782608696, -0.075
97682, 0.84782608695652, 1.1934782608696, -0.1
97683, 0.82608695652174, 1.1673913043478, -0.1
97684, 0.82608695652174, 1.1934782608696, -0.075
97685, 0.80434782608696, 1.1934782608696, -0.1
97686, 0.78260869565217, 1.1673913043478, -0.1
97687, 0.78260869565217, 1.1934782608696, -0.075
97688, 0.76086956521739, 1.1934782608696, -0.1
97689, 0.73913043478261, 1.1673913043478, -0.1
97690, 0.73913043478261, 1.1934782608696, -0.075
97691, 0.71739130434783, 1.1934782608696, -0.1
97692, 0.69565217391304, 1.1673913043478, -0.1
97693, 0.69565217391304, 1.1934782608696, -0.075
97694, 0.67391304347826, 1.1934782608696, -0.1
97695, 0.65217391304348, 1.1673913043478, -0.1
97696, 0.65217391304348, 1.1934782608696, -0.075
97697, 0.6304347826087, 1.1934782608696, -0.1
97698, 0.60869565217391, 1.1673913043478, -0.1
97699, 0.60869565217391, 1.1934782608696, -0.075
97700, 0.58695652173913, 1.1934782608696, -0.1
97701, 0.56521739130435, 1.1673913043478, -0.1
97702, 0.56521739130435, 1.1934782608696, -0.075
97703, 0.54347826086957, 1.1934782608696, -0.1
97704, 0.52173913043478, 1.1673913043478, -0.1
97705, 0.52173913043478, 1.1934782608696, -0.075
97706, 0.5, 1.1934782608696, -0.1
97707, 0.47826086956522, 1.1673913043478, -0.1
97708, 0.47826086956522, 1.1934782608696, -0.075
97709, 0.45652173913043, 1.1934782608696, -0.1
97710, 0.43478260869565, 1.1673913043478, -0.1
97711, 0.43478260869565, 1.1934782608696, -0.075
97712, 0.41304347826087, 1.1934782608696, -0.1
97713, 0.39130434782609, 1.1673913043478, -0.1
97714, 0.39130434782609, 1.1934782608696, -0.075
97715, 0.3695652173913, 1.1934782608696, -0.1
97716, 0.34782608695652, 1.1673913043478, -0.1
97717, 0.34782608695652, 1.1934782608696, -0.075
97718, 0.32608695652174, 1.1934782608696, -0.1
97719, 0.30434782608696, 1.1673913043478, -0.1
97720, 0.30434782608696, 1.1934782608696, -0.075
97721, 0.28260869565217, 1.1934782608696, -0.1
97722, 0.26086956521739, 1.1673913043478, -0.1
97723, 0.26086956521739, 1.1934782608696, -0.075
97724, 0.23913043478261, 1.1934782608696, -0.1
97725, 0.21739130434783, 1.1673913043478, -0.1
97726, 0.21739130434783, 1.1934782608696, -0.075
97727, 0.19565217391304, 1.1934782608696, -0.1
97728, 0.17391304347826, 1.1673913043478, -0.1
97729, 0.17391304347826, 1.1934782608696, -0.075
97730, 0.15217391304348, 1.1934782608696, -0.1
97731, 0.1304347826087, 1.1673913043478, -0.1
97732, 0.1304347826087, 1.1934782608696, -0.075
97733, 0.10869565217391, 1.1934782608696, -0.1
97734, 0.08695652173913, 1.1673913043478, -0.1
97735, 0.08695652173913, 1.1934782608696, -0.075
97736, 0.065217391304348, 1.1934782608696, -0.1
97737, 0.043478260869565, 1.1673913043478, -0.1
97738, 0.043478260869565, 1.1934782608696, -0.075
97739, 0.021739130434783, 1.1934782608696, -0.1
97740, 0.97826086956522, 1.245652173913, -0.1
97741, 0.95652173913044, 1.2195652173913, -0.1
97742, 0.95652173913044, 1.245652173913, -0.075
97743, 0.93478260869565, 1.245652173913, -0.1
97744, 0.91304347826087, 1.2195652173913, -0.1
97745, 0.91304347826087, 1.245652173913, -0.075
97746, 0.89130434782609, 1.245652173913, -0.1
97747, 0.8695652173913, 1.2195652173913, -0.1
97748, 0.8695652173913, 1.245652173913, -0.075
97749, 0.84782608695652, 1.245652173913, -0.1
97750, 0.82608695652174, 1.2195652173913, -0.1
97751, 0.82608695652174, 1.245652173913, -0.075
97752, 0.80434782608696, 1.245652173913, -0.1
97753, 0.78260869565217, 1.2195652173913, -0.1
97754, 0.78260869565217, 1.245652173913, -0.075
97755, 0.76086956521739, 1.245652173913, -0.1
97756, 0.73913043478261, 1.2195652173913, -0.1
97757, 0.73913043478261, 1.245652173913, -0.075
97758, 0.71739130434783, 1.245652173913, -0.1
97759, 0.69565217391304, 1.2195652173913, -0.1
97760, 0.69565217391304, 1.245652173913, -0.075
97761, 0.67391304347826, 1.245652173913, -0.1
97762, 0.65217391304348, 1.2195652173913, -0.1
97763, 0.65217391304348, 1.245652173913, -0.075
97764, 0.6304347826087, 1.245652173913, -0.1
97765, 0.60869565217391, 1.2195652173913, -0.1
97766, 0.60869565217391, 1.245652173913, -0.075
97767, 0.58695652173913, 1.245652173913, -0.1
97768, 0.56521739130435, 1.2195652173913, -0.1
97769, 0.56521739130435, 1.245652173913, -0.075
97770, 0.54347826086957, 1.245652173913, -0.1
97771, 0.52173913043478, 1.2195652173913, -0.1
97772, 0.52173913043478, 1.245652173913, -0.075
97773, 0.5, 1.245652173913, -0.1
97774, 0.47826086956522, 1.2195652173913, -0.1
97775, 0.47826086956522, 1.245652173913, -0.075
97776, 0.45652173913043, 1.245652173913, -0.1
97777, 0.43478260869565, 1.2195652173913, -0.1
97778, 0.43478260869565, 1.245652173913, -0.075
97779, 0.41304347826087, 1.245652173913, -0.1
97780, 0.39130434782609, 1.2195652173913, -0.1
97781, 0.39130434782609, 1.245652173913, -0.075
97782, 0.3695652173913, 1.245652173913, -0.1
97783, 0.34782608695652, 1.2195652173913, -0.1
97784, 0.34782608695652, 1.245652173913, -0.075
97785, 0.32608695652174, 1.245652173913, -0.1
97786, 0.30434782608696, 1.2195652173913, -0.1
97787, 0.30434782608696, 1.245652173913, -0.075
97788, 0.28260869565217, 1.245652173913, -0.1
97789, 0.26086956521739, 1.2195652173913, -0.1
97790, 0.26086956521739, 1.245652173913, -0.075
97791, 0.23913043478261, 1.245652173913, -0.1
97792, 0.21739130434783, 1.2195652173913, -0.1
97793, 0.21739130434783, 1.245652173913, -0.075
97794, 0.19565217391304, 1.245652173913, -0.1
97795, 0.17391304347826, 1.2195652173913, -0.1
97796, 0.17391304347826, 1.245652173913, -0.075
97797, 0.15217391304348, 1.245652173913, -0.1
97798, 0.1304347826087, 1.2195652173913, -0.1
97799, 0.1304347826087, 1.245652173913, -0.075
97800, 0.10869565217391, 1.245652173913, -0.1
97801, 0.08695652173913, 1.2195652173913, -0.1
97802, 0.08695652173913, 1.245652173913, -0.075
97803, 0.065217391304348, 1.245652173913, -0.1
97804, 0.043478260869565, 1.2195652173913, -0.1
97805, 0.043478260869565, 1.245652173913, -0.075
97806, 0.021739130434783, 1.245652173913, -0.1
97807, 0.97826086956522, 1.2978260869565, -0.1
97808, 0.95652173913044, 1.2717391304348, -0.1
97809, 0.95652173913044, 1.2978260869565, -0.075
97810, 0.93478260869565, 1.2978260869565, -0.1
97811, 0.91304347826087, 1.2717391304348, -0.1
97812, 0.91304347826087, 1.2978260869565, -0.075
97813, 0.89130434782609, 1.2978260869565, -0.1
97814, 0.8695652173913, 1.2717391304348, -0.1
97815, 0.8695652173913, 1.2978260869565, -0.075
97816, 0.84782608695652, 1.2978260869565, -0.1
97817, 0.82608695652174, 1.2717391304348, -0.1
97818, 0.82608695652174, 1.2978260869565, -0.075
97819, 0.80434782608696, 1.2978260869565, -0.1
97820, 0.78260869565217, 1.2717391304348, -0.1
97821, 0.78260869565217, 1.2978260869565, -0.075
97822, 0.76086956521739, 1.2978260869565, -0.1
97823, 0.73913043478261, 1.2717391304348, -0.1
97824, 0.73913043478261, 1.2978260869565, -0.075
97825, 0.71739130434783, 1.2978260869565, -0.1
97826, 0.69565217391304, 1.2717391304348, -0.1
97827, 0.69565217391304, 1.2978260869565, -0.075
97828, 0.67391304347826, 1.2978260869565, -0.1
97829, 0.65217391304348, 1.2717391304348, -0.1
97830, 0.65217391304348, 1.2978260869565, -0.075
97831, 0.6304347826087, 1.2978260869565, -0.1
97832, 0.60869565217391, 1.2717391304348, -0.1
97833, 0.60869565217391, 1.2978260869565, -0.075
97834, 0.58695652173913, 1.2978260869565, -0.1
97835, 0.56521739130435, 1.2717391304348, -0.1
97836, 0.56521739130435, 1.2978260869565, -0.075
97837, 0.54347826086957, 1.2978260869565, -0.1
97838, 0.52173913043478, 1.2717391304348, -0.1
97839, 0.52173913043478, 1.2978260869565, -0.075
97840, 0.5, 1.2978260869565, -0.1
97841, 0.47826086956522, 1.2717391304348, -0.1
97842, 0.47826086956522, 1.2978260869565, -0.075
97843, 0.45652173913043, 1.2978260869565, -0.1
97844, 0.43478260869565, 1.2717391304348, -0.1
97845, 0.43478260869565, 1.2978260869565, -0.075
97846, 0.41304347826087, 1.2978260869565, -0.1
97847, 0.39130434782609, 1.2717391304348, -0.1
97848, 0.39130434782609, 1.2978260869565, -0.075
97849, 0.3695652173913, 1.2978260869565, -0.1
97850, 0.34782608695652, 1.2717391304348, -0.1
97851, 0.34782608695652, 1.2978260869565, -0.075
97852, 0.32608695652174, 1.2978260869565, -0.1
97853, 0.30434782608696, 1.2717391304348, -0.1
97854, 0.30434782608696, 1.2978260869565, -0.075
97855, 0.28260869565217, 1.2978260869565, -0.1
97856, 0.26086956521739, 1.2717391304348, -0.1
97857, 0.26086956521739, 1.2978260869565, -0.075
97858, 0.23913043478261, 1.2978260869565, -0.1
97859, 0.21739130434783, 1.2717391304348, -0.1
97860, 0.21739130434783, 1.2978260869565, -0.075
97861, 0.19565217391304, 1.2978260869565, -0.1
97862, 0.17391304347826, 1.2717391304348, -0.1
97863, 0.17391304347826, 1.2978260869565, -0.075
97864, 0.15217391304348, 1.2978260869565, -0.1
97865, 0.1304347826087, 1.2717391304348, -0.1
97866, 0.1304347826087, 1.2978260869565, -0.075
97867, 0.10869565217391, 1.2978260869565, -0.1
97868, 0.08695652173913, 1.2717391304348, -0.1
97869, 0.08695652173913, 1.2978260869565, -0.075
97870, 0.065217391304348, 1.2978260869565, -0.1
97871, 0.043478260869565, 1.2717391304348, -0.1
97872, 0.043478260869565, 1.2978260869565, -0.075
97873, 0.021739130434783, 1.2978260869565, -0.1
97874, 0.95652173913043, 1.3239130434783, -0.1
97875, 0.91304347826087, 1.3239130434783, -0.1
97876, 0.8695652173913, 1.3239130434783, -0.1
97877, 0.82608695652174, 1.3239130434783, -0.1
97878, 0.78260869565217, 1.3239130434783, -0.1
97879, 0.73913043478261, 1.3239130434783, -0.1
97880, 0.69565217391304, 1.3239130434783, -0.1
97881, 0.65217391304348, 1.3239130434783, -0.1
97882, 0.60869565217391, 1.3239130434783, -0.1
97883, 0.56521739130435, 1.3239130434783, -0.1
97884, 0.52173913043478, 1.3239130434783, -0.1
97885, 0.47826086956522, 1.3239130434783, -0.1
97886, 0.43478260869565, 1.3239130434783, -0.1
97887, 0.39130434782609, 1.3239130434783, -0.1
97888, 0.34782608695652, 1.3239130434783, -0.1
97889, 0.30434782608696, 1.3239130434783, -0.1
97890, 0.26086956521739, 1.3239130434783, -0.1
97891, 0.21739130434783, 1.3239130434783, -0.1
97892, 0.17391304347826, 1.3239130434783, -0.1
97893, 0.1304347826087, 1.3239130434783, -0.1
97894, 0.08695652173913, 1.3239130434783, -0.1
97895, 0.043478260869565, 1.3239130434783, -0.1
97896, 0.97826086956522, 0.20217391304348, -0.15
97897, 0.95652173913043, 0.17608695652174, -0.15
97898, 0.95652173913044, 0.20217391304348, -0.125
97899, 0.93478260869565, 0.20217391304348, -0.15
97900, 0.91304347826087, 0.17608695652174, -0.15
97901, 0.91304347826087, 0.20217391304348, -0.125
97902, 0.89130434782609, 0.20217391304348, -0.15
97903, 0.8695652173913, 0.17608695652174, -0.15
97904, 0.8695652173913, 0.20217391304348, -0.125
97905, 0.84782608695652, 0.20217391304348, -0.15
97906, 0.82608695652174, 0.17608695652174, -0.15
97907, 0.82608695652174, 0.20217391304348, -0.125
97908, 0.80434782608696, 0.20217391304348, -0.15
97909, 0.78260869565217, 0.17608695652174, -0.15
97910, 0.78260869565217, 0.20217391304348, -0.125
97911, 0.76086956521739, 0.20217391304348, -0.15
97912, 0.73913043478261, 0.17608695652174, -0.15
97913, 0.73913043478261, 0.20217391304348, -0.125
97914, 0.71739130434783, 0.20217391304348, -0.15
97915, 0.69565217391304, 0.17608695652174, -0.15
97916, 0.69565217391304, 0.20217391304348, -0.125
97917, 0.67391304347826, 0.20217391304348, -0.15
97918, 0.65217391304348, 0.17608695652174, -0.15
97919, 0.65217391304348, 0.20217391304348, -0.125
97920, 0.6304347826087, 0.20217391304348, -0.15
97921, 0.60869565217391, 0.17608695652174, -0.15
97922, 0.60869565217391, 0.20217391304348, -0.125
97923, 0.58695652173913, 0.20217391304348, -0.15
97924, 0.56521739130435, 0.17608695652174, -0.15
97925, 0.56521739130435, 0.20217391304348, -0.125
97926, 0.54347826086957, 0.20217391304348, -0.15
97927, 0.52173913043478, 0.17608695652174, -0.15
97928, 0.52173913043478, 0.20217391304348, -0.125
97929, 0.5, 0.20217391304348, -0.15
97930, 0.47826086956522, 0.17608695652174, -0.15
97931, 0.47826086956522, 0.20217391304348, -0.125
97932, 0.45652173913043, 0.20217391304348, -0.15
97933, 0.43478260869565, 0.17608695652174, -0.15
97934, 0.43478260869565, 0.20217391304348, -0.125
97935, 0.41304347826087, 0.20217391304348, -0.15
97936, 0.39130434782609, 0.17608695652174, -0.15
97937, 0.39130434782609, 0.20217391304348, -0.125
97938, 0.3695652173913, 0.20217391304348, -0.15
97939, 0.34782608695652, 0.17608695652174, -0.15
97940, 0.34782608695652, 0.20217391304348, -0.125
97941, 0.32608695652174, 0.20217391304348, -0.15
97942, 0.30434782608696, 0.17608695652174, -0.15
97943, 0.30434782608696, 0.20217391304348, -0.125
97944, 0.28260869565217, 0.20217391304348, -0.15
97945, 0.26086956521739, 0.17608695652174, -0.15
97946, 0.26086956521739, 0.20217391304348, -0.125
97947, 0.23913043478261, 0.20217391304348, -0.15
97948, 0.21739130434783, 0.17608695652174, -0.15
97949, 0.21739130434783, 0.20217391304348, -0.125
97950, 0.19565217391304, 0.20217391304348, -0.15
97951, 0.17391304347826, 0.17608695652174, -0.15
97952, 0.17391304347826, 0.20217391304348, -0.125
97953, 0.15217391304348, 0.20217391304348, -0.15
97954, 0.1304347826087, 0.17608695652174, -0.15
97955, 0.1304347826087, 0.20217391304348, -0.125
97956, 0.10869565217391, 0.20217391304348, -0.15
97957, 0.08695652173913, 0.17608695652174, -0.15
97958, 0.08695652173913, 0.20217391304348, -0.125
97959, 0.065217391304348, 0.20217391304348, -0.15
97960, 0.043478260869565, 0.17608695652174, -0.15
97961, 0.043478260869565, 0.20217391304348, -0.125
97962, 0.021739130434783, 0.20217391304348, -0.15
97963, 0.97826086956522, 0.25434782608696, -0.15
97964, 0.95652173913044, 0.22826086956522, -0.15
97965, 0.95652173913044, 0.25434782608696, -0.125
97966, 0.93478260869565, 0.25434782608696, -0.15
97967, 0.91304347826087, 0.22826086956522, -0.15
97968, 0.91304347826087, 0.25434782608696, -0.125
97969, 0.89130434782609, 0.25434782608696, -0.15
97970, 0.8695652173913, 0.22826086956522, -0.15
97971, 0.8695652173913, 0.25434782608696, -0.125
97972, 0.84782608695652, 0.25434782608696, -0.15
97973, 0.82608695652174, 0.22826086956522, -0.15
97974, 0.82608695652174, 0.25434782608696, -0.125
97975, 0.80434782608696, 0.25434782608696, -0.15
97976, 0.78260869565217, 0.22826086956522, -0.15
97977, 0.78260869565217, 0.25434782608696, -0.125
97978, 0.76086956521739, 0.25434782608696, -0.15
97979, 0.73913043478261, 0.22826086956522, -0.15
97980, 0.73913043478261, 0.25434782608696, -0.125
97981, 0.71739130434783, 0.25434782608696, -0.15
97982, 0.69565217391304, 0.22826086956522, -0.15
97983, 0.69565217391304, 0.25434782608696, -0.125
97984, 0.67391304347826, 0.25434782608696, -0.15
97985, 0.65217391304348, 0.22826086956522, -0.15
97986, 0.65217391304348, 0.25434782608696, -0.125
97987, 0.6304347826087, 0.25434782608696, -0.15
97988, 0.60869565217391, 0.22826086956522, -0.15
97989, 0.60869565217391, 0.25434782608696, -0.125
97990, 0.58695652173913, 0.25434782608696, -0.15
97991, 0.56521739130435, 0.22826086956522, -0.15
97992, 0.56521739130435, 0.25434782608696, -0.125
97993, 0.54347826086957, 0.25434782608696, -0.15
97994, 0.52173913043478, 0.22826086956522, -0.15
97995, 0.52173913043478, 0.25434782608696, -0.125
97996, 0.5, 0.25434782608696, -0.15
97997, 0.47826086956522, 0.22826086956522, -0.15
97998, 0.47826086956522, 0.25434782608696, -0.125
97999, 0.45652173913044, 0.25434782608696, -0.15
98000, 0.43478260869565, 0.22826086956522, -0.15
98001, 0.43478260869565, 0.25434782608696, -0.125
98002, 0.41304347826087, 0.25434782608696, -0.15
98003, 0.39130434782609, 0.22826086956522, -0.15
98004, 0.39130434782609, 0.25434782608696, -0.125
98005, 0.3695652173913, 0.25434782608696, -0.15
98006, 0.34782608695652, 0.22826086956522, -0.15
98007, 0.34782608695652, 0.25434782608696, -0.125
98008, 0.32608695652174, 0.25434782608696, -0.15
98009, 0.30434782608696, 0.22826086956522, -0.15
98010, 0.30434782608696, 0.25434782608696, -0.125
98011, 0.28260869565217, 0.25434782608696, -0.15
98012, 0.26086956521739, 0.22826086956522, -0.15
98013, 0.26086956521739, 0.25434782608696, -0.125
98014, 0.23913043478261, 0.25434782608696, -0.15
98015, 0.21739130434783, 0.22826086956522, -0.15
98016, 0.21739130434783, 0.25434782608696, -0.125
98017, 0.19565217391304, 0.25434782608696, -0.15
98018, 0.17391304347826, 0.22826086956522, -0.15
98019, 0.17391304347826, 0.25434782608696, -0.125
98020, 0.15217391304348, 0.25434782608696, -0.15
98021, 0.1304347826087, 0.22826086956522, -0.15
98022, 0.1304347826087, 0.25434782608696, -0.125
98023, 0.10869565217391, 0.25434782608696, -0.15
98024, 0.08695652173913, 0.22826086956522, -0.15
98025, 0.08695652173913, 0.25434782608696, -0.125
98026, 0.065217391304348, 0.25434782608696, -0.15
98027, 0.043478260869565, 0.22826086956522, -0.15
98028, 0.043478260869565, 0.25434782608696, -0.125
98029, 0.021739130434783, 0.25434782608696, -0.15
98030, 0.97826086956522, 0.30652173913043, -0.15
98031, 0.95652173913044, 0.2804347826087, -0.15
98032, 0.95652173913044, 0.30652173913043, -0.125
98033, 0.93478260869565, 0.30652173913043, -0.15
98034, 0.91304347826087, 0.2804347826087, -0.15
98035, 0.91304347826087, 0.30652173913043, -0.125
98036, 0.89130434782609, 0.30652173913043, -0.15
98037, 0.8695652173913, 0.2804347826087, -0.15
98038, 0.8695652173913, 0.30652173913043, -0.125
98039, 0.84782608695652, 0.30652173913043, -0.15
98040, 0.82608695652174, 0.2804347826087, -0.15
98041, 0.82608695652174, 0.30652173913043, -0.125
98042, 0.80434782608696, 0.30652173913043, -0.15
98043, 0.78260869565217, 0.2804347826087, -0.15
98044, 0.78260869565217, 0.30652173913043, -0.125
98045, 0.76086956521739, 0.30652173913043, -0.15
98046, 0.73913043478261, 0.2804347826087, -0.15
98047, 0.73913043478261, 0.30652173913043, -0.125
98048, 0.71739130434783, 0.30652173913043, -0.15
98049, 0.69565217391304, 0.2804347826087, -0.15
98050, 0.69565217391304, 0.30652173913043, -0.125
98051, 0.67391304347826, 0.30652173913043, -0.15
98052, 0.65217391304348, 0.2804347826087, -0.15
98053, 0.65217391304348, 0.30652173913043, -0.125
98054, 0.6304347826087, 0.30652173913043, -0.15
98055, 0.60869565217391, 0.2804347826087, -0.15
98056, 0.60869565217391, 0.30652173913043, -0.125
98057, 0.58695652173913, 0.30652173913043, -0.15
98058, 0.56521739130435, 0.2804347826087, -0.15
98059, 0.56521739130435, 0.30652173913043, -0.125
98060, 0.54347826086957, 0.30652173913043, -0.15
98061, 0.52173913043478, 0.2804347826087, -0.15
98062, 0.52173913043478, 0.30652173913043, -0.125
98063, 0.5, 0.30652173913043, -0.15
98064, 0.47826086956522, 0.2804347826087, -0.15
98065, 0.47826086956522, 0.30652173913043, -0.125
98066, 0.45652173913043, 0.30652173913043, -0.15
98067, 0.43478260869565, 0.2804347826087, -0.15
98068, 0.43478260869565, 0.30652173913043, -0.125
98069, 0.41304347826087, 0.30652173913043, -0.15
98070, 0.39130434782609, 0.2804347826087, -0.15
98071, 0.39130434782609, 0.30652173913043, -0.125
98072, 0.3695652173913, 0.30652173913043, -0.15
98073, 0.34782608695652, 0.2804347826087, -0.15
98074, 0.34782608695652, 0.30652173913043, -0.125
98075, 0.32608695652174, 0.30652173913043, -0.15
98076, 0.30434782608696, 0.2804347826087, -0.15
98077, 0.30434782608696, 0.30652173913043, -0.125
98078, 0.28260869565217, 0.30652173913043, -0.15
98079, 0.26086956521739, 0.2804347826087, -0.15
98080, 0.26086956521739, 0.30652173913043, -0.125
98081, 0.23913043478261, 0.30652173913043, -0.15
98082, 0.21739130434783, 0.2804347826087, -0.15
98083, 0.21739130434783, 0.30652173913043, -0.125
98084, 0.19565217391304, 0.30652173913043, -0.15
98085, 0.17391304347826, 0.2804347826087, -0.15
98086, 0.17391304347826, 0.30652173913043, -0.125
98087, 0.15217391304348, 0.30652173913043, -0.15
98088, 0.1304347826087, 0.2804347826087, -0.15
98089, 0.1304347826087, 0.30652173913043, -0.125
98090, 0.10869565217391, 0.30652173913043, -0.15
98091, 0.08695652173913, 0.2804347826087, -0.15
98092, 0.08695652173913, 0.30652173913043, -0.125
98093, 0.065217391304348, 0.30652173913043, -0.15
98094, 0.043478260869565, 0.2804347826087, -0.15
98095, 0.043478260869565, 0.30652173913043, -0.125
98096, 0.021739130434783, 0.30652173913043, -0.15
98097, 0.97826086956522, 0.35869565217391, -0.15
98098, 0.95652173913044, 0.33260869565217, -0.15
98099, 0.95652173913044, 0.35869565217391, -0.125
98100, 0.93478260869565, 0.35869565217391, -0.15
98101, 0.91304347826087, 0.33260869565217, -0.15
98102, 0.91304347826087, 0.35869565217391, -0.125
98103, 0.89130434782609, 0.35869565217391, -0.15
98104, 0.8695652173913, 0.33260869565217, -0.15
98105, 0.8695652173913, 0.35869565217391, -0.125
98106, 0.84782608695652, 0.35869565217391, -0.15
98107, 0.82608695652174, 0.33260869565217, -0.15
98108, 0.82608695652174, 0.35869565217391, -0.125
98109, 0.80434782608696, 0.35869565217391, -0.15
98110, 0.78260869565217, 0.33260869565217, -0.15
98111, 0.78260869565217, 0.35869565217391, -0.125
98112, 0.76086956521739, 0.35869565217391, -0.15
98113, 0.73913043478261, 0.33260869565217, -0.15
98114, 0.73913043478261, 0.35869565217391, -0.125
98115, 0.71739130434783, 0.35869565217391, -0.15
98116, 0.69565217391304, 0.33260869565217, -0.15
98117, 0.69565217391304, 0.35869565217391, -0.125
98118, 0.67391304347826, 0.35869565217391, -0.15
98119, 0.65217391304348, 0.33260869565217, -0.15
98120, 0.65217391304348, 0.35869565217391, -0.125
98121, 0.6304347826087, 0.35869565217391, -0.15
98122, 0.60869565217391, 0.33260869565217, -0.15
98123, 0.60869565217391, 0.35869565217391, -0.125
98124, 0.58695652173913, 0.35869565217391, -0.15
98125, 0.56521739130435, 0.33260869565217, -0.15
98126, 0.56521739130435, 0.35869565217391, -0.125
98127, 0.54347826086956, 0.35869565217391, -0.15
98128, 0.52173913043478, 0.33260869565217, -0.15
98129, 0.52173913043478, 0.35869565217391, -0.125
98130, 0.5, 0.35869565217391, -0.15
98131, 0.47826086956522, 0.33260869565217, -0.15
98132, 0.47826086956522, 0.35869565217391, -0.125
98133, 0.45652173913043, 0.35869565217391, -0.15
98134, 0.43478260869565, 0.33260869565217, -0.15
98135, 0.43478260869565, 0.35869565217391, -0.125
98136, 0.41304347826087, 0.35869565217391, -0.15
98137, 0.39130434782609, 0.33260869565217, -0.15
98138, 0.39130434782609, 0.35869565217391, -0.125
98139, 0.3695652173913, 0.35869565217391, -0.15
98140, 0.34782608695652, 0.33260869565217, -0.15
98141, 0.34782608695652, 0.35869565217391, -0.125
98142, 0.32608695652174, 0.35869565217391, -0.15
98143, 0.30434782608696, 0.33260869565217, -0.15
98144, 0.30434782608696, 0.35869565217391, -0.125
98145, 0.28260869565217, 0.35869565217391, -0.15
98146, 0.26086956521739, 0.33260869565217, -0.15
98147, 0.26086956521739, 0.35869565217391, -0.125
98148, 0.23913043478261, 0.35869565217391, -0.15
98149, 0.21739130434783, 0.33260869565217, -0.15
98150, 0.21739130434783, 0.35869565217391, -0.125
98151, 0.19565217391304, 0.35869565217391, -0.15
98152, 0.17391304347826, 0.33260869565217, -0.15
98153, 0.17391304347826, 0.35869565217391, -0.125
98154, 0.15217391304348, 0.35869565217391, -0.15
98155, 0.1304347826087, 0.33260869565217, -0.15
98156, 0.1304347826087, 0.35869565217391, -0.125
98157, 0.10869565217391, 0.35869565217391, -0.15
98158, 0.08695652173913, 0.33260869565217, -0.15
98159, 0.08695652173913, 0.35869565217391, -0.125
98160, 0.065217391304348, 0.35869565217391, -0.15
98161, 0.043478260869565, 0.33260869565217, -0.15
98162, 0.043478260869565, 0.35869565217391, -0.125
98163, 0.021739130434783, 0.35869565217391, -0.15
98164, 0.97826086956522, 0.41086956521739, -0.15
98165, 0.95652173913043, 0.38478260869565, -0.15
98166, 0.95652173913044, 0.41086956521739, -0.125
98167, 0.93478260869565, 0.41086956521739, -0.15
98168, 0.91304347826087, 0.38478260869565, -0.15
98169, 0.91304347826087, 0.41086956521739, -0.125
98170, 0.89130434782609, 0.41086956521739, -0.15
98171, 0.8695652173913, 0.38478260869565, -0.15
98172, 0.8695652173913, 0.41086956521739, -0.125
98173, 0.84782608695652, 0.41086956521739, -0.15
98174, 0.82608695652174, 0.38478260869565, -0.15
98175, 0.82608695652174, 0.41086956521739, -0.125
98176, 0.80434782608696, 0.41086956521739, -0.15
98177, 0.78260869565217, 0.38478260869565, -0.15
98178, 0.78260869565217, 0.41086956521739, -0.125
98179, 0.76086956521739, 0.41086956521739, -0.15
98180, 0.73913043478261, 0.38478260869565, -0.15
98181, 0.73913043478261, 0.41086956521739, -0.125
98182, 0.71739130434783, 0.41086956521739, -0.15
98183, 0.69565217391304, 0.38478260869565, -0.15
98184, 0.69565217391304, 0.41086956521739, -0.125
98185, 0.67391304347826, 0.41086956521739, -0.15
98186, 0.65217391304348, 0.38478260869565, -0.15
98187, 0.65217391304348, 0.41086956521739, -0.125
98188, 0.6304347826087, 0.41086956521739, -0.15
98189, 0.60869565217391, 0.38478260869565, -0.15
98190, 0.60869565217391, 0.41086956521739, -0.125
98191, 0.58695652173913, 0.41086956521739, -0.15
98192, 0.56521739130435, 0.38478260869565, -0.15
98193, 0.56521739130435, 0.41086956521739, -0.125
98194, 0.54347826086956, 0.41086956521739, -0.15
98195, 0.52173913043478, 0.38478260869565, -0.15
98196, 0.52173913043478, 0.41086956521739, -0.125
98197, 0.5, 0.41086956521739, -0.15
98198, 0.47826086956522, 0.38478260869565, -0.15
98199, 0.47826086956522, 0.41086956521739, -0.125
98200, 0.45652173913043, 0.41086956521739, -0.15
98201, 0.43478260869565, 0.38478260869565, -0.15
98202, 0.43478260869565, 0.41086956521739, -0.125
98203, 0.41304347826087, 0.41086956521739, -0.15
98204, 0.39130434782609, 0.38478260869565, -0.15
98205, 0.39130434782609, 0.41086956521739, -0.125
98206, 0.3695652173913, 0.41086956521739, -0.15
98207, 0.34782608695652, 0.38478260869565, -0.15
98208, 0.34782608695652, 0.41086956521739, -0.125
98209, 0.32608695652174, 0.41086956521739, -0.15
98210, 0.30434782608696, 0.38478260869565, -0.15
98211, 0.30434782608696, 0.41086956521739, -0.125
98212, 0.28260869565217, 0.41086956521739, -0.15
98213, 0.26086956521739, 0.38478260869565, -0.15
98214, 0.26086956521739, 0.41086956521739, -0.125
98215, 0.23913043478261, 0.41086956521739, -0.15
98216, 0.21739130434783, 0.38478260869565, -0.15
98217, 0.21739130434783, 0.41086956521739, -0.125
98218, 0.19565217391304, 0.41086956521739, -0.15
98219, 0.17391304347826, 0.38478260869565, -0.15
98220, 0.17391304347826, 0.41086956521739, -0.125
98221, 0.15217391304348, 0.41086956521739, -0.15
98222, 0.1304347826087, 0.38478260869565, -0.15
98223, 0.1304347826087, 0.41086956521739, -0.125
98224, 0.10869565217391, 0.41086956521739, -0.15
98225, 0.08695652173913, 0.38478260869565, -0.15
98226, 0.08695652173913, 0.41086956521739, -0.125
98227, 0.065217391304348, 0.41086956521739, -0.15
98228, 0.043478260869565, 0.38478260869565, -0.15
98229, 0.043478260869565, 0.41086956521739, -0.125
98230, 0.021739130434783, 0.41086956521739, -0.15
98231, 0.97826086956522, 0.46304347826087, -0.15
98232, 0.95652173913043, 0.43695652173913, -0.15
98233, 0.95652173913044, 0.46304347826087, -0.125
98234, 0.93478260869565, 0.46304347826087, -0.15
98235, 0.91304347826087, 0.43695652173913, -0.15
98236, 0.91304347826087, 0.46304347826087, -0.125
98237, 0.89130434782609, 0.46304347826087, -0.15
98238, 0.8695652173913, 0.43695652173913, -0.15
98239, 0.8695652173913, 0.46304347826087, -0.125
98240, 0.84782608695652, 0.46304347826087, -0.15
98241, 0.82608695652174, 0.43695652173913, -0.15
98242, 0.82608695652174, 0.46304347826087, -0.125
98243, 0.80434782608696, 0.46304347826087, -0.15
98244, 0.78260869565217, 0.43695652173913, -0.15
98245, 0.78260869565217, 0.46304347826087, -0.125
98246, 0.76086956521739, 0.46304347826087, -0.15
98247, 0.73913043478261, 0.43695652173913, -0.15
98248, 0.73913043478261, 0.46304347826087, -0.125
98249, 0.71739130434783, 0.46304347826087, -0.15
98250, 0.69565217391304, 0.43695652173913, -0.15
98251, 0.69565217391304, 0.46304347826087, -0.125
98252, 0.67391304347826, 0.46304347826087, -0.15
98253, 0.65217391304348, 0.43695652173913, -0.15
98254, 0.65217391304348, 0.46304347826087, -0.125
98255, 0.6304347826087, 0.46304347826087, -0.15
98256, 0.60869565217391, 0.43695652173913, -0.15
98257, 0.60869565217391, 0.46304347826087, -0.125
98258, 0.58695652173913, 0.46304347826087, -0.15
98259, 0.56521739130435, 0.43695652173913, -0.15
98260, 0.56521739130435, 0.46304347826087, -0.125
98261, 0.54347826086957, 0.46304347826087, -0.15
98262, 0.52173913043478, 0.43695652173913, -0.15
98263, 0.52173913043478, 0.46304347826087, -0.125
98264, 0.5, 0.46304347826087, -0.15
98265, 0.47826086956522, 0.43695652173913, -0.15
98266, 0.47826086956522, 0.46304347826087, -0.125
98267, 0.45652173913043, 0.46304347826087, -0.15
98268, 0.43478260869565, 0.43695652173913, -0.15
98269, 0.43478260869565, 0.46304347826087, -0.125
98270, 0.41304347826087, 0.46304347826087, -0.15
98271, 0.39130434782609, 0.43695652173913, -0.15
98272, 0.39130434782609, 0.46304347826087, -0.125
98273, 0.3695652173913, 0.46304347826087, -0.15
98274, 0.34782608695652, 0.43695652173913, -0.15
98275, 0.34782608695652, 0.46304347826087, -0.125
98276, 0.32608695652174, 0.46304347826087, -0.15
98277, 0.30434782608696, 0.43695652173913, -0.15
98278, 0.30434782608696, 0.46304347826087, -0.125
98279, 0.28260869565217, 0.46304347826087, -0.15
98280, 0.26086956521739, 0.43695652173913, -0.15
98281, 0.26086956521739, 0.46304347826087, -0.125
98282, 0.23913043478261, 0.46304347826087, -0.15
98283, 0.21739130434783, 0.43695652173913, -0.15
98284, 0.21739130434783, 0.46304347826087, -0.125
98285, 0.19565217391304, 0.46304347826087, -0.15
98286, 0.17391304347826, 0.43695652173913, -0.15
98287, 0.17391304347826, 0.46304347826087, -0.125
98288, 0.15217391304348, 0.46304347826087, -0.15
98289, 0.1304347826087, 0.43695652173913, -0.15
98290, 0.1304347826087, 0.46304347826087, -0.125
98291, 0.10869565217391, 0.46304347826087, -0.15
98292, 0.08695652173913, 0.43695652173913, -0.15
98293, 0.08695652173913, 0.46304347826087, -0.125
98294, 0.065217391304348, 0.46304347826087, -0.15
98295, 0.043478260869565, 0.43695652173913, -0.15
98296, 0.043478260869565, 0.46304347826087, -0.125
98297, 0.021739130434783, 0.46304347826087, -0.15
98298, 0.97826086956522, 0.51521739130435, -0.15
98299, 0.95652173913043, 0.48913043478261, -0.15
98300, 0.95652173913043, 0.51521739130435, -0.125
98301, 0.93478260869565, 0.51521739130435, -0.15
98302, 0.91304347826087, 0.48913043478261, -0.15
98303, 0.91304347826087, 0.51521739130435, -0.125
98304, 0.89130434782609, 0.51521739130435, -0.15
98305, 0.8695652173913, 0.48913043478261, -0.15
98306, 0.8695652173913, 0.51521739130435, -0.125
98307, 0.84782608695652, 0.51521739130435, -0.15
98308, 0.82608695652174, 0.48913043478261, -0.15
98309, 0.82608695652174, 0.51521739130435, -0.125
98310, 0.80434782608696, 0.51521739130435, -0.15
98311, 0.78260869565217, 0.48913043478261, -0.15
98312, 0.78260869565217, 0.51521739130435, -0.125
98313, 0.76086956521739, 0.51521739130435, -0.15
98314, 0.73913043478261, 0.48913043478261, -0.15
98315, 0.73913043478261, 0.51521739130435, -0.125
98316, 0.71739130434783, 0.51521739130435, -0.15
98317, 0.69565217391304, 0.48913043478261, -0.15
98318, 0.69565217391304, 0.51521739130435, -0.125
98319, 0.67391304347826, 0.51521739130435, -0.15
98320, 0.65217391304348, 0.48913043478261, -0.15
98321, 0.65217391304348, 0.51521739130435, -0.125
98322, 0.6304347826087, 0.51521739130435, -0.15
98323, 0.60869565217391, 0.48913043478261, -0.15
98324, 0.60869565217391, 0.51521739130435, -0.125
98325, 0.58695652173913, 0.51521739130435, -0.15
98326, 0.56521739130435, 0.48913043478261, -0.15
98327, 0.56521739130435, 0.51521739130435, -0.125
98328, 0.54347826086956, 0.51521739130435, -0.15
98329, 0.52173913043478, 0.48913043478261, -0.15
98330, 0.52173913043478, 0.51521739130435, -0.125
98331, 0.5, 0.51521739130435, -0.15
98332, 0.47826086956522, 0.48913043478261, -0.15
98333, 0.47826086956522, 0.51521739130435, -0.125
98334, 0.45652173913043, 0.51521739130435, -0.15
98335, 0.43478260869565, 0.48913043478261, -0.15
98336, 0.43478260869565, 0.51521739130435, -0.125
98337, 0.41304347826087, 0.51521739130435, -0.15
98338, 0.39130434782609, 0.48913043478261, -0.15
98339, 0.39130434782609, 0.51521739130435, -0.125
98340, 0.3695652173913, 0.51521739130435, -0.15
98341, 0.34782608695652, 0.48913043478261, -0.15
