98342, 0.34782608695652, 0.51521739130435, -0.125
98343, 0.32608695652174, 0.51521739130435, -0.15
98344, 0.30434782608696, 0.48913043478261, -0.15
98345, 0.30434782608696, 0.51521739130435, -0.125
98346, 0.28260869565217, 0.51521739130435, -0.15
98347, 0.26086956521739, 0.48913043478261, -0.15
98348, 0.26086956521739, 0.51521739130435, -0.125
98349, 0.23913043478261, 0.51521739130435, -0.15
98350, 0.21739130434783, 0.48913043478261, -0.15
98351, 0.21739130434783, 0.51521739130435, -0.125
98352, 0.19565217391304, 0.51521739130435, -0.15
98353, 0.17391304347826, 0.48913043478261, -0.15
98354, 0.17391304347826, 0.51521739130435, -0.125
98355, 0.15217391304348, 0.51521739130435, -0.15
98356, 0.1304347826087, 0.48913043478261, -0.15
98357, 0.1304347826087, 0.51521739130435, -0.125
98358, 0.10869565217391, 0.51521739130435, -0.15
98359, 0.08695652173913, 0.48913043478261, -0.15
98360, 0.08695652173913, 0.51521739130435, -0.125
98361, 0.065217391304348, 0.51521739130435, -0.15
98362, 0.043478260869565, 0.48913043478261, -0.15
98363, 0.043478260869565, 0.51521739130435, -0.125
98364, 0.021739130434783, 0.51521739130435, -0.15
98365, 0.97826086956522, 0.56739130434783, -0.15
98366, 0.95652173913043, 0.54130434782609, -0.15
98367, 0.95652173913044, 0.56739130434783, -0.125
98368, 0.93478260869565, 0.56739130434783, -0.15
98369, 0.91304347826087, 0.54130434782609, -0.15
98370, 0.91304347826087, 0.56739130434783, -0.125
98371, 0.89130434782609, 0.56739130434783, -0.15
98372, 0.8695652173913, 0.54130434782609, -0.15
98373, 0.8695652173913, 0.56739130434783, -0.125
98374, 0.84782608695652, 0.56739130434783, -0.15
98375, 0.82608695652174, 0.54130434782609, -0.15
98376, 0.82608695652174, 0.56739130434783, -0.125
98377, 0.80434782608696, 0.56739130434783, -0.15
98378, 0.78260869565217, 0.54130434782609, -0.15
98379, 0.78260869565217, 0.56739130434783, -0.125
98380, 0.76086956521739, 0.56739130434783, -0.15
98381, 0.73913043478261, 0.54130434782609, -0.15
98382, 0.73913043478261, 0.56739130434783, -0.125
98383, 0.71739130434783, 0.56739130434783, -0.15
98384, 0.69565217391304, 0.54130434782609, -0.15
98385, 0.69565217391304, 0.56739130434783, -0.125
98386, 0.67391304347826, 0.56739130434783, -0.15
98387, 0.65217391304348, 0.54130434782609, -0.15
98388, 0.65217391304348, 0.56739130434783, -0.125
98389, 0.6304347826087, 0.56739130434783, -0.15
98390, 0.60869565217391, 0.54130434782609, -0.15
98391, 0.60869565217391, 0.56739130434783, -0.125
98392, 0.58695652173913, 0.56739130434783, -0.15
98393, 0.56521739130435, 0.54130434782609, -0.15
98394, 0.56521739130435, 0.56739130434783, -0.125
98395, 0.54347826086957, 0.56739130434783, -0.15
98396, 0.52173913043478, 0.54130434782609, -0.15
98397, 0.52173913043478, 0.56739130434783, -0.125
98398, 0.5, 0.56739130434783, -0.15
98399, 0.47826086956522, 0.54130434782609, -0.15
98400, 0.47826086956522, 0.56739130434783, -0.125
98401, 0.45652173913043, 0.56739130434783, -0.15
98402, 0.43478260869565, 0.54130434782609, -0.15
98403, 0.43478260869565, 0.56739130434783, -0.125
98404, 0.41304347826087, 0.56739130434783, -0.15
98405, 0.39130434782609, 0.54130434782609, -0.15
98406, 0.39130434782609, 0.56739130434783, -0.125
98407, 0.3695652173913, 0.56739130434783, -0.15
98408, 0.34782608695652, 0.54130434782609, -0.15
98409, 0.34782608695652, 0.56739130434783, -0.125
98410, 0.32608695652174, 0.56739130434783, -0.15
98411, 0.30434782608696, 0.54130434782609, -0.15
98412, 0.30434782608696, 0.56739130434783, -0.125
98413, 0.28260869565217, 0.56739130434783, -0.15
98414, 0.26086956521739, 0.54130434782609, -0.15
98415, 0.26086956521739, 0.56739130434783, -0.125
98416, 0.23913043478261, 0.56739130434783, -0.15
98417, 0.21739130434783, 0.54130434782609, -0.15
98418, 0.21739130434783, 0.56739130434783, -0.125
98419, 0.19565217391304, 0.56739130434783, -0.15
98420, 0.17391304347826, 0.54130434782609, -0.15
98421, 0.17391304347826, 0.56739130434783, -0.125
98422, 0.15217391304348, 0.56739130434783, -0.15
98423, 0.1304347826087, 0.54130434782609, -0.15
98424, 0.1304347826087, 0.56739130434783, -0.125
98425, 0.10869565217391, 0.56739130434783, -0.15
98426, 0.08695652173913, 0.54130434782609, -0.15
98427, 0.08695652173913, 0.56739130434783, -0.125
98428, 0.065217391304348, 0.56739130434783, -0.15
98429, 0.043478260869565, 0.54130434782609, -0.15
98430, 0.043478260869565, 0.56739130434783, -0.125
98431, 0.021739130434783, 0.56739130434783, -0.15
98432, 0.97826086956522, 0.6195652173913, -0.15
98433, 0.95652173913044, 0.59347826086956, -0.15
98434, 0.95652173913044, 0.6195652173913, -0.125
98435, 0.93478260869565, 0.6195652173913, -0.15
98436, 0.91304347826087, 0.59347826086956, -0.15
98437, 0.91304347826087, 0.6195652173913, -0.125
98438, 0.89130434782609, 0.6195652173913, -0.15
98439, 0.8695652173913, 0.59347826086956, -0.15
98440, 0.8695652173913, 0.6195652173913, -0.125
98441, 0.84782608695652, 0.6195652173913, -0.15
98442, 0.82608695652174, 0.59347826086956, -0.15
98443, 0.82608695652174, 0.6195652173913, -0.125
98444, 0.80434782608696, 0.6195652173913, -0.15
98445, 0.78260869565217, 0.59347826086956, -0.15
98446, 0.78260869565217, 0.6195652173913, -0.125
98447, 0.76086956521739, 0.6195652173913, -0.15
98448, 0.73913043478261, 0.59347826086956, -0.15
98449, 0.73913043478261, 0.6195652173913, -0.125
98450, 0.71739130434783, 0.6195652173913, -0.15
98451, 0.69565217391304, 0.59347826086956, -0.15
98452, 0.69565217391304, 0.6195652173913, -0.125
98453, 0.67391304347826, 0.6195652173913, -0.15
98454, 0.65217391304348, 0.59347826086956, -0.15
98455, 0.65217391304348, 0.6195652173913, -0.125
98456, 0.6304347826087, 0.6195652173913, -0.15
98457, 0.60869565217391, 0.59347826086956, -0.15
98458, 0.60869565217391, 0.6195652173913, -0.125
98459, 0.58695652173913, 0.6195652173913, -0.15
98460, 0.56521739130435, 0.59347826086956, -0.15
98461, 0.56521739130435, 0.6195652173913, -0.125
98462, 0.54347826086957, 0.6195652173913, -0.15
98463, 0.52173913043478, 0.59347826086956, -0.15
98464, 0.52173913043478, 0.6195652173913, -0.125
98465, 0.5, 0.6195652173913, -0.15
98466, 0.47826086956522, 0.59347826086956, -0.15
98467, 0.47826086956522, 0.6195652173913, -0.125
98468, 0.45652173913043, 0.6195652173913, -0.15
98469, 0.43478260869565, 0.59347826086956, -0.15
98470, 0.43478260869565, 0.6195652173913, -0.125
98471, 0.41304347826087, 0.6195652173913, -0.15
98472, 0.39130434782609, 0.59347826086956, -0.15
98473, 0.39130434782609, 0.6195652173913, -0.125
98474, 0.3695652173913, 0.6195652173913, -0.15
98475, 0.34782608695652, 0.59347826086956, -0.15
98476, 0.34782608695652, 0.6195652173913, -0.125
98477, 0.32608695652174, 0.6195652173913, -0.15
98478, 0.30434782608696, 0.59347826086956, -0.15
98479, 0.30434782608696, 0.6195652173913, -0.125
98480, 0.28260869565217, 0.6195652173913, -0.15
98481, 0.26086956521739, 0.59347826086956, -0.15
98482, 0.26086956521739, 0.6195652173913, -0.125
98483, 0.23913043478261, 0.6195652173913, -0.15
98484, 0.21739130434783, 0.59347826086956, -0.15
98485, 0.21739130434783, 0.6195652173913, -0.125
98486, 0.19565217391304, 0.6195652173913, -0.15
98487, 0.17391304347826, 0.59347826086956, -0.15
98488, 0.17391304347826, 0.6195652173913, -0.125
98489, 0.15217391304348, 0.6195652173913, -0.15
98490, 0.1304347826087, 0.59347826086956, -0.15
98491, 0.1304347826087, 0.6195652173913, -0.125
98492, 0.10869565217391, 0.6195652173913, -0.15
98493, 0.08695652173913, 0.59347826086956, -0.15
98494, 0.08695652173913, 0.6195652173913, -0.125
98495, 0.065217391304348, 0.6195652173913, -0.15
98496, 0.043478260869565, 0.59347826086956, -0.15
98497, 0.043478260869565, 0.6195652173913, -0.125
98498, 0.021739130434783, 0.6195652173913, -0.15
98499, 0.97826086956522, 0.67173913043478, -0.15
98500, 0.95652173913044, 0.64565217391304, -0.15
98501, 0.95652173913044, 0.67173913043478, -0.125
98502, 0.93478260869565, 0.67173913043478, -0.15
98503, 0.91304347826087, 0.64565217391304, -0.15
98504, 0.91304347826087, 0.67173913043478, -0.125
98505, 0.89130434782609, 0.67173913043478, -0.15
98506, 0.8695652173913, 0.64565217391304, -0.15
98507, 0.8695652173913, 0.67173913043478, -0.125
98508, 0.84782608695652, 0.67173913043478, -0.15
98509, 0.82608695652174, 0.64565217391304, -0.15
98510, 0.82608695652174, 0.67173913043478, -0.125
98511, 0.80434782608696, 0.67173913043478, -0.15
98512, 0.78260869565217, 0.64565217391304, -0.15
98513, 0.78260869565217, 0.67173913043478, -0.125
98514, 0.76086956521739, 0.67173913043478, -0.15
98515, 0.73913043478261, 0.64565217391304, -0.15
98516, 0.73913043478261, 0.67173913043478, -0.125
98517, 0.71739130434783, 0.67173913043478, -0.15
98518, 0.69565217391304, 0.64565217391304, -0.15
98519, 0.69565217391304, 0.67173913043478, -0.125
98520, 0.67391304347826, 0.67173913043478, -0.15
98521, 0.65217391304348, 0.64565217391304, -0.15
98522, 0.65217391304348, 0.67173913043478, -0.125
98523, 0.6304347826087, 0.67173913043478, -0.15
98524, 0.60869565217391, 0.64565217391304, -0.15
98525, 0.60869565217391, 0.67173913043478, -0.125
98526, 0.58695652173913, 0.67173913043478, -0.15
98527, 0.56521739130435, 0.64565217391304, -0.15
98528, 0.56521739130435, 0.67173913043478, -0.125
98529, 0.54347826086956, 0.67173913043478, -0.15
98530, 0.52173913043478, 0.64565217391304, -0.15
98531, 0.52173913043478, 0.67173913043478, -0.125
98532, 0.5, 0.67173913043478, -0.15
98533, 0.47826086956522, 0.64565217391304, -0.15
98534, 0.47826086956522, 0.67173913043478, -0.125
98535, 0.45652173913043, 0.67173913043478, -0.15
98536, 0.43478260869565, 0.64565217391304, -0.15
98537, 0.43478260869565, 0.67173913043478, -0.125
98538, 0.41304347826087, 0.67173913043478, -0.15
98539, 0.39130434782609, 0.64565217391304, -0.15
98540, 0.39130434782609, 0.67173913043478, -0.125
98541, 0.3695652173913, 0.67173913043478, -0.15
98542, 0.34782608695652, 0.64565217391304, -0.15
98543, 0.34782608695652, 0.67173913043478, -0.125
98544, 0.32608695652174, 0.67173913043478, -0.15
98545, 0.30434782608696, 0.64565217391304, -0.15
98546, 0.30434782608696, 0.67173913043478, -0.125
98547, 0.28260869565217, 0.67173913043478, -0.15
98548, 0.26086956521739, 0.64565217391304, -0.15
98549, 0.26086956521739, 0.67173913043478, -0.125
98550, 0.23913043478261, 0.67173913043478, -0.15
98551, 0.21739130434783, 0.64565217391304, -0.15
98552, 0.21739130434783, 0.67173913043478, -0.125
98553, 0.19565217391304, 0.67173913043478, -0.15
98554, 0.17391304347826, 0.64565217391304, -0.15
98555, 0.17391304347826, 0.67173913043478, -0.125
98556, 0.15217391304348, 0.67173913043478, -0.15
98557, 0.1304347826087, 0.64565217391304, -0.15
98558, 0.1304347826087, 0.67173913043478, -0.125
98559, 0.10869565217391, 0.67173913043478, -0.15
98560, 0.08695652173913, 0.64565217391304, -0.15
98561, 0.08695652173913, 0.67173913043478, -0.125
98562, 0.065217391304348, 0.67173913043478, -0.15
98563, 0.043478260869565, 0.64565217391304, -0.15
98564, 0.043478260869565, 0.67173913043478, -0.125
98565, 0.021739130434783, 0.67173913043478, -0.15
98566, 0.97826086956522, 0.72391304347826, -0.15
98567, 0.95652173913044, 0.69782608695652, -0.15
98568, 0.95652173913044, 0.72391304347826, -0.125
98569, 0.93478260869565, 0.72391304347826, -0.15
98570, 0.91304347826087, 0.69782608695652, -0.15
98571, 0.91304347826087, 0.72391304347826, -0.125
98572, 0.89130434782609, 0.72391304347826, -0.15
98573, 0.8695652173913, 0.69782608695652, -0.15
98574, 0.8695652173913, 0.72391304347826, -0.125
98575, 0.84782608695652, 0.72391304347826, -0.15
98576, 0.82608695652174, 0.69782608695652, -0.15
98577, 0.82608695652174, 0.72391304347826, -0.125
98578, 0.80434782608696, 0.72391304347826, -0.15
98579, 0.78260869565217, 0.69782608695652, -0.15
98580, 0.78260869565217, 0.72391304347826, -0.125
98581, 0.76086956521739, 0.72391304347826, -0.15
98582, 0.73913043478261, 0.69782608695652, -0.15
98583, 0.73913043478261, 0.72391304347826, -0.125
98584, 0.71739130434783, 0.72391304347826, -0.15
98585, 0.69565217391304, 0.69782608695652, -0.15
98586, 0.69565217391304, 0.72391304347826, -0.125
98587, 0.67391304347826, 0.72391304347826, -0.15
98588, 0.65217391304348, 0.69782608695652, -0.15
98589, 0.65217391304348, 0.72391304347826, -0.125
98590, 0.6304347826087, 0.72391304347826, -0.15
98591, 0.60869565217391, 0.69782608695652, -0.15
98592, 0.60869565217391, 0.72391304347826, -0.125
98593, 0.58695652173913, 0.72391304347826, -0.15
98594, 0.56521739130435, 0.69782608695652, -0.15
98595, 0.56521739130435, 0.72391304347826, -0.125
98596, 0.54347826086957, 0.72391304347826, -0.15
98597, 0.52173913043478, 0.69782608695652, -0.15
98598, 0.52173913043478, 0.72391304347826, -0.125
98599, 0.5, 0.72391304347826, -0.15
98600, 0.47826086956522, 0.69782608695652, -0.15
98601, 0.47826086956522, 0.72391304347826, -0.125
98602, 0.45652173913043, 0.72391304347826, -0.15
98603, 0.43478260869565, 0.69782608695652, -0.15
98604, 0.43478260869565, 0.72391304347826, -0.125
98605, 0.41304347826087, 0.72391304347826, -0.15
98606, 0.39130434782609, 0.69782608695652, -0.15
98607, 0.39130434782609, 0.72391304347826, -0.125
98608, 0.3695652173913, 0.72391304347826, -0.15
98609, 0.34782608695652, 0.69782608695652, -0.15
98610, 0.34782608695652, 0.72391304347826, -0.125
98611, 0.32608695652174, 0.72391304347826, -0.15
98612, 0.30434782608696, 0.69782608695652, -0.15
98613, 0.30434782608696, 0.72391304347826, -0.125
98614, 0.28260869565217, 0.72391304347826, -0.15
98615, 0.26086956521739, 0.69782608695652, -0.15
98616, 0.26086956521739, 0.72391304347826, -0.125
98617, 0.23913043478261, 0.72391304347826, -0.15
98618, 0.21739130434783, 0.69782608695652, -0.15
98619, 0.21739130434783, 0.72391304347826, -0.125
98620, 0.19565217391304, 0.72391304347826, -0.15
98621, 0.17391304347826, 0.69782608695652, -0.15
98622, 0.17391304347826, 0.72391304347826, -0.125
98623, 0.15217391304348, 0.72391304347826, -0.15
98624, 0.1304347826087, 0.69782608695652, -0.15
98625, 0.1304347826087, 0.72391304347826, -0.125
98626, 0.10869565217391, 0.72391304347826, -0.15
98627, 0.08695652173913, 0.69782608695652, -0.15
98628, 0.08695652173913, 0.72391304347826, -0.125
98629, 0.065217391304348, 0.72391304347826, -0.15
98630, 0.043478260869565, 0.69782608695652, -0.15
98631, 0.043478260869565, 0.72391304347826, -0.125
98632, 0.021739130434783, 0.72391304347826, -0.15
98633, 0.97826086956522, 0.77608695652174, -0.15
98634, 0.95652173913044, 0.75, -0.15
98635, 0.95652173913044, 0.77608695652174, -0.125
98636, 0.93478260869565, 0.77608695652174, -0.15
98637, 0.91304347826087, 0.75, -0.15
98638, 0.91304347826087, 0.77608695652174, -0.125
98639, 0.89130434782609, 0.77608695652174, -0.15
98640, 0.8695652173913, 0.75, -0.15
98641, 0.8695652173913, 0.77608695652174, -0.125
98642, 0.84782608695652, 0.77608695652174, -0.15
98643, 0.82608695652174, 0.75, -0.15
98644, 0.82608695652174, 0.77608695652174, -0.125
98645, 0.80434782608696, 0.77608695652174, -0.15
98646, 0.78260869565217, 0.75, -0.15
98647, 0.78260869565217, 0.77608695652174, -0.125
98648, 0.76086956521739, 0.77608695652174, -0.15
98649, 0.73913043478261, 0.75, -0.15
98650, 0.73913043478261, 0.77608695652174, -0.125
98651, 0.71739130434783, 0.77608695652174, -0.15
98652, 0.69565217391304, 0.75, -0.15
98653, 0.69565217391304, 0.77608695652174, -0.125
98654, 0.67391304347826, 0.77608695652174, -0.15
98655, 0.65217391304348, 0.75, -0.15
98656, 0.65217391304348, 0.77608695652174, -0.125
98657, 0.6304347826087, 0.77608695652174, -0.15
98658, 0.60869565217391, 0.75, -0.15
98659, 0.60869565217391, 0.77608695652174, -0.125
98660, 0.58695652173913, 0.77608695652174, -0.15
98661, 0.56521739130435, 0.75, -0.15
98662, 0.56521739130435, 0.77608695652174, -0.125
98663, 0.54347826086956, 0.77608695652174, -0.15
98664, 0.52173913043478, 0.75, -0.15
98665, 0.52173913043478, 0.77608695652174, -0.125
98666, 0.5, 0.77608695652174, -0.15
98667, 0.47826086956522, 0.75, -0.15
98668, 0.47826086956522, 0.77608695652174, -0.125
98669, 0.45652173913043, 0.77608695652174, -0.15
98670, 0.43478260869565, 0.75, -0.15
98671, 0.43478260869565, 0.77608695652174, -0.125
98672, 0.41304347826087, 0.77608695652174, -0.15
98673, 0.39130434782609, 0.75, -0.15
98674, 0.39130434782609, 0.77608695652174, -0.125
98675, 0.3695652173913, 0.77608695652174, -0.15
98676, 0.34782608695652, 0.75, -0.15
98677, 0.34782608695652, 0.77608695652174, -0.125
98678, 0.32608695652174, 0.77608695652174, -0.15
98679, 0.30434782608696, 0.75, -0.15
98680, 0.30434782608696, 0.77608695652174, -0.125
98681, 0.28260869565217, 0.77608695652174, -0.15
98682, 0.26086956521739, 0.75, -0.15
98683, 0.26086956521739, 0.77608695652174, -0.125
98684, 0.23913043478261, 0.77608695652174, -0.15
98685, 0.21739130434783, 0.75, -0.15
98686, 0.21739130434783, 0.77608695652174, -0.125
98687, 0.19565217391304, 0.77608695652174, -0.15
98688, 0.17391304347826, 0.75, -0.15
98689, 0.17391304347826, 0.77608695652174, -0.125
98690, 0.15217391304348, 0.77608695652174, -0.15
98691, 0.1304347826087, 0.75, -0.15
98692, 0.1304347826087, 0.77608695652174, -0.125
98693, 0.10869565217391, 0.77608695652174, -0.15
98694, 0.08695652173913, 0.75, -0.15
98695, 0.08695652173913, 0.77608695652174, -0.125
98696, 0.065217391304348, 0.77608695652174, -0.15
98697, 0.043478260869565, 0.75, -0.15
98698, 0.043478260869565, 0.77608695652174, -0.125
98699, 0.021739130434783, 0.77608695652174, -0.15
98700, 0.97826086956522, 0.82826086956522, -0.15
98701, 0.95652173913044, 0.80217391304348, -0.15
98702, 0.95652173913044, 0.82826086956522, -0.125
98703, 0.93478260869565, 0.82826086956522, -0.15
98704, 0.91304347826087, 0.80217391304348, -0.15
98705, 0.91304347826087, 0.82826086956522, -0.125
98706, 0.89130434782609, 0.82826086956522, -0.15
98707, 0.8695652173913, 0.80217391304348, -0.15
98708, 0.8695652173913, 0.82826086956522, -0.125
98709, 0.84782608695652, 0.82826086956522, -0.15
98710, 0.82608695652174, 0.80217391304348, -0.15
98711, 0.82608695652174, 0.82826086956522, -0.125
98712, 0.80434782608696, 0.82826086956522, -0.15
98713, 0.78260869565217, 0.80217391304348, -0.15
98714, 0.78260869565217, 0.82826086956522, -0.125
98715, 0.76086956521739, 0.82826086956522, -0.15
98716, 0.73913043478261, 0.80217391304348, -0.15
98717, 0.73913043478261, 0.82826086956522, -0.125
98718, 0.71739130434783, 0.82826086956522, -0.15
98719, 0.69565217391304, 0.80217391304348, -0.15
98720, 0.69565217391304, 0.82826086956522, -0.125
98721, 0.67391304347826, 0.82826086956522, -0.15
98722, 0.65217391304348, 0.80217391304348, -0.15
98723, 0.65217391304348, 0.82826086956522, -0.125
98724, 0.6304347826087, 0.82826086956522, -0.15
98725, 0.60869565217391, 0.80217391304348, -0.15
98726, 0.60869565217391, 0.82826086956522, -0.125
98727, 0.58695652173913, 0.82826086956522, -0.15
98728, 0.56521739130435, 0.80217391304348, -0.15
98729, 0.56521739130435, 0.82826086956522, -0.125
98730, 0.54347826086957, 0.82826086956522, -0.15
98731, 0.52173913043478, 0.80217391304348, -0.15
98732, 0.52173913043478, 0.82826086956522, -0.125
98733, 0.5, 0.82826086956522, -0.15
98734, 0.47826086956522, 0.80217391304348, -0.15
98735, 0.47826086956522, 0.82826086956522, -0.125
98736, 0.45652173913043, 0.82826086956522, -0.15
98737, 0.43478260869565, 0.80217391304348, -0.15
98738, 0.43478260869565, 0.82826086956522, -0.125
98739, 0.41304347826087, 0.82826086956522, -0.15
98740, 0.39130434782609, 0.80217391304348, -0.15
98741, 0.39130434782609, 0.82826086956522, -0.125
98742, 0.3695652173913, 0.82826086956522, -0.15
98743, 0.34782608695652, 0.80217391304348, -0.15
98744, 0.34782608695652, 0.82826086956522, -0.125
98745, 0.32608695652174, 0.82826086956522, -0.15
98746, 0.30434782608696, 0.80217391304348, -0.15
98747, 0.30434782608696, 0.82826086956522, -0.125
98748, 0.28260869565217, 0.82826086956522, -0.15
98749, 0.26086956521739, 0.80217391304348, -0.15
98750, 0.26086956521739, 0.82826086956522, -0.125
98751, 0.23913043478261, 0.82826086956522, -0.15
98752, 0.21739130434783, 0.80217391304348, -0.15
98753, 0.21739130434783, 0.82826086956522, -0.125
98754, 0.19565217391304, 0.82826086956522, -0.15
98755, 0.17391304347826, 0.80217391304348, -0.15
98756, 0.17391304347826, 0.82826086956522, -0.125
98757, 0.15217391304348, 0.82826086956522, -0.15
98758, 0.1304347826087, 0.80217391304348, -0.15
98759, 0.1304347826087, 0.82826086956522, -0.125
98760, 0.10869565217391, 0.82826086956522, -0.15
98761, 0.08695652173913, 0.80217391304348, -0.15
98762, 0.08695652173913, 0.82826086956522, -0.125
98763, 0.065217391304348, 0.82826086956522, -0.15
98764, 0.043478260869565, 0.80217391304348, -0.15
98765, 0.043478260869565, 0.82826086956522, -0.125
98766, 0.021739130434783, 0.82826086956522, -0.15
98767, 0.97826086956522, 0.88043478260869, -0.15
98768, 0.95652173913044, 0.85434782608696, -0.15
98769, 0.95652173913044, 0.88043478260869, -0.125
98770, 0.93478260869565, 0.88043478260869, -0.15
98771, 0.91304347826087, 0.85434782608696, -0.15
98772, 0.91304347826087, 0.88043478260869, -0.125
98773, 0.89130434782609, 0.88043478260869, -0.15
98774, 0.8695652173913, 0.85434782608696, -0.15
98775, 0.8695652173913, 0.88043478260869, -0.125
98776, 0.84782608695652, 0.88043478260869, -0.15
98777, 0.82608695652174, 0.85434782608696, -0.15
98778, 0.82608695652174, 0.8804347826087, -0.125
98779, 0.80434782608696, 0.8804347826087, -0.15
98780, 0.78260869565217, 0.85434782608696, -0.15
98781, 0.78260869565217, 0.8804347826087, -0.125
98782, 0.76086956521739, 0.88043478260869, -0.15
98783, 0.73913043478261, 0.85434782608696, -0.15
98784, 0.73913043478261, 0.88043478260869, -0.125
98785, 0.71739130434783, 0.88043478260869, -0.15
98786, 0.69565217391304, 0.85434782608696, -0.15
98787, 0.69565217391304, 0.8804347826087, -0.125
98788, 0.67391304347826, 0.8804347826087, -0.15
98789, 0.65217391304348, 0.85434782608696, -0.15
98790, 0.65217391304348, 0.8804347826087, -0.125
98791, 0.6304347826087, 0.88043478260869, -0.15
98792, 0.60869565217391, 0.85434782608696, -0.15
98793, 0.60869565217391, 0.8804347826087, -0.125
98794, 0.58695652173913, 0.88043478260869, -0.15
98795, 0.56521739130435, 0.85434782608696, -0.15
98796, 0.56521739130435, 0.88043478260869, -0.125
98797, 0.54347826086957, 0.88043478260869, -0.15
98798, 0.52173913043478, 0.85434782608696, -0.15
98799, 0.52173913043478, 0.88043478260869, -0.125
98800, 0.5, 0.88043478260869, -0.15
98801, 0.47826086956522, 0.85434782608696, -0.15
98802, 0.47826086956522, 0.88043478260869, -0.125
98803, 0.45652173913043, 0.88043478260869, -0.15
98804, 0.43478260869565, 0.85434782608696, -0.15
98805, 0.43478260869565, 0.88043478260869, -0.125
98806, 0.41304347826087, 0.88043478260869, -0.15
98807, 0.39130434782609, 0.85434782608696, -0.15
98808, 0.39130434782609, 0.88043478260869, -0.125
98809, 0.3695652173913, 0.88043478260869, -0.15
98810, 0.34782608695652, 0.85434782608696, -0.15
98811, 0.34782608695652, 0.8804347826087, -0.125
98812, 0.32608695652174, 0.8804347826087, -0.15
98813, 0.30434782608696, 0.85434782608696, -0.15
98814, 0.30434782608696, 0.88043478260869, -0.125
98815, 0.28260869565217, 0.88043478260869, -0.15
98816, 0.26086956521739, 0.85434782608696, -0.15
98817, 0.26086956521739, 0.88043478260869, -0.125
98818, 0.23913043478261, 0.88043478260869, -0.15
98819, 0.21739130434783, 0.85434782608696, -0.15
98820, 0.21739130434783, 0.88043478260869, -0.125
98821, 0.19565217391304, 0.88043478260869, -0.15
98822, 0.17391304347826, 0.85434782608696, -0.15
98823, 0.17391304347826, 0.88043478260869, -0.125
98824, 0.15217391304348, 0.88043478260869, -0.15
98825, 0.1304347826087, 0.85434782608696, -0.15
98826, 0.1304347826087, 0.88043478260869, -0.125
98827, 0.10869565217391, 0.88043478260869, -0.15
98828, 0.08695652173913, 0.85434782608696, -0.15
98829, 0.08695652173913, 0.8804347826087, -0.125
98830, 0.065217391304348, 0.88043478260869, -0.15
98831, 0.043478260869565, 0.85434782608696, -0.15
98832, 0.043478260869565, 0.88043478260869, -0.125
98833, 0.021739130434783, 0.88043478260869, -0.15
98834, 0.97826086956522, 0.93260869565217, -0.15
98835, 0.95652173913044, 0.90652173913043, -0.15
98836, 0.95652173913044, 0.93260869565217, -0.125
98837, 0.93478260869565, 0.93260869565217, -0.15
98838, 0.91304347826087, 0.90652173913043, -0.15
98839, 0.91304347826087, 0.93260869565217, -0.125
98840, 0.89130434782609, 0.93260869565217, -0.15
98841, 0.8695652173913, 0.90652173913043, -0.15
98842, 0.8695652173913, 0.93260869565217, -0.125
98843, 0.84782608695652, 0.93260869565217, -0.15
98844, 0.82608695652174, 0.90652173913043, -0.15
98845, 0.82608695652174, 0.93260869565217, -0.125
98846, 0.80434782608696, 0.93260869565217, -0.15
98847, 0.78260869565217, 0.90652173913043, -0.15
98848, 0.78260869565217, 0.93260869565217, -0.125
98849, 0.76086956521739, 0.93260869565217, -0.15
98850, 0.73913043478261, 0.90652173913043, -0.15
98851, 0.73913043478261, 0.93260869565217, -0.125
98852, 0.71739130434783, 0.93260869565217, -0.15
98853, 0.69565217391304, 0.90652173913043, -0.15
98854, 0.69565217391304, 0.93260869565217, -0.125
98855, 0.67391304347826, 0.93260869565217, -0.15
98856, 0.65217391304348, 0.90652173913043, -0.15
98857, 0.65217391304348, 0.93260869565217, -0.125
98858, 0.6304347826087, 0.93260869565217, -0.15
98859, 0.60869565217391, 0.90652173913043, -0.15
98860, 0.60869565217391, 0.93260869565217, -0.125
98861, 0.58695652173913, 0.93260869565217, -0.15
98862, 0.56521739130435, 0.90652173913043, -0.15
98863, 0.56521739130435, 0.93260869565217, -0.125
98864, 0.54347826086957, 0.93260869565217, -0.15
98865, 0.52173913043478, 0.90652173913043, -0.15
98866, 0.52173913043478, 0.93260869565217, -0.125
98867, 0.5, 0.93260869565217, -0.15
98868, 0.47826086956522, 0.90652173913043, -0.15
98869, 0.47826086956522, 0.93260869565217, -0.125
98870, 0.45652173913043, 0.93260869565217, -0.15
98871, 0.43478260869565, 0.90652173913043, -0.15
98872, 0.43478260869565, 0.93260869565217, -0.125
98873, 0.41304347826087, 0.93260869565217, -0.15
98874, 0.39130434782609, 0.90652173913043, -0.15
98875, 0.39130434782609, 0.93260869565217, -0.125
98876, 0.3695652173913, 0.93260869565217, -0.15
98877, 0.34782608695652, 0.90652173913043, -0.15
98878, 0.34782608695652, 0.93260869565217, -0.125
98879, 0.32608695652174, 0.93260869565217, -0.15
98880, 0.30434782608696, 0.90652173913043, -0.15
98881, 0.30434782608696, 0.93260869565217, -0.125
98882, 0.28260869565217, 0.93260869565217, -0.15
98883, 0.26086956521739, 0.90652173913043, -0.15
98884, 0.26086956521739, 0.93260869565217, -0.125
98885, 0.23913043478261, 0.93260869565217, -0.15
98886, 0.21739130434783, 0.90652173913043, -0.15
98887, 0.21739130434783, 0.93260869565217, -0.125
98888, 0.19565217391304, 0.93260869565217, -0.15
98889, 0.17391304347826, 0.90652173913043, -0.15
98890, 0.17391304347826, 0.93260869565217, -0.125
98891, 0.15217391304348, 0.93260869565217, -0.15
98892, 0.1304347826087, 0.90652173913043, -0.15
98893, 0.1304347826087, 0.93260869565217, -0.125
98894, 0.10869565217391, 0.93260869565217, -0.15
98895, 0.08695652173913, 0.90652173913043, -0.15
98896, 0.08695652173913, 0.93260869565217, -0.125
98897, 0.065217391304348, 0.93260869565217, -0.15
98898, 0.043478260869565, 0.90652173913043, -0.15
98899, 0.043478260869565, 0.93260869565217, -0.125
98900, 0.021739130434783, 0.93260869565217, -0.15
98901, 0.97826086956522, 0.98478260869565, -0.15
98902, 0.95652173913044, 0.95869565217391, -0.15
98903, 0.95652173913044, 0.98478260869565, -0.125
98904, 0.93478260869565, 0.98478260869565, -0.15
98905, 0.91304347826087, 0.95869565217391, -0.15
98906, 0.91304347826087, 0.98478260869565, -0.125
98907, 0.89130434782609, 0.98478260869565, -0.15
98908, 0.8695652173913, 0.95869565217391, -0.15
98909, 0.8695652173913, 0.98478260869565, -0.125
98910, 0.84782608695652, 0.98478260869565, -0.15
98911, 0.82608695652174, 0.95869565217391, -0.15
98912, 0.82608695652174, 0.98478260869565, -0.125
98913, 0.80434782608696, 0.98478260869565, -0.15
98914, 0.78260869565217, 0.95869565217391, -0.15
98915, 0.78260869565217, 0.98478260869565, -0.125
98916, 0.76086956521739, 0.98478260869565, -0.15
98917, 0.73913043478261, 0.95869565217391, -0.15
98918, 0.73913043478261, 0.98478260869565, -0.125
98919, 0.71739130434783, 0.98478260869565, -0.15
98920, 0.69565217391304, 0.95869565217391, -0.15
98921, 0.69565217391304, 0.98478260869565, -0.125
98922, 0.67391304347826, 0.98478260869565, -0.15
98923, 0.65217391304348, 0.95869565217391, -0.15
98924, 0.65217391304348, 0.98478260869565, -0.125
98925, 0.6304347826087, 0.98478260869565, -0.15
98926, 0.60869565217391, 0.95869565217391, -0.15
98927, 0.60869565217391, 0.98478260869565, -0.125
98928, 0.58695652173913, 0.98478260869565, -0.15
98929, 0.56521739130435, 0.95869565217391, -0.15
98930, 0.56521739130435, 0.98478260869565, -0.125
98931, 0.54347826086957, 0.98478260869565, -0.15
98932, 0.52173913043478, 0.95869565217391, -0.15
98933, 0.52173913043478, 0.98478260869565, -0.125
98934, 0.5, 0.98478260869565, -0.15
98935, 0.47826086956522, 0.95869565217391, -0.15
98936, 0.47826086956522, 0.98478260869565, -0.125
98937, 0.45652173913043, 0.98478260869565, -0.15
98938, 0.43478260869565, 0.95869565217391, -0.15
98939, 0.43478260869565, 0.98478260869565, -0.125
98940, 0.41304347826087, 0.98478260869565, -0.15
98941, 0.39130434782609, 0.95869565217391, -0.15
98942, 0.39130434782609, 0.98478260869565, -0.125
98943, 0.3695652173913, 0.98478260869565, -0.15
98944, 0.34782608695652, 0.95869565217391, -0.15
98945, 0.34782608695652, 0.98478260869565, -0.125
98946, 0.32608695652174, 0.98478260869565, -0.15
98947, 0.30434782608696, 0.95869565217391, -0.15
98948, 0.30434782608696, 0.98478260869565, -0.125
98949, 0.28260869565217, 0.98478260869565, -0.15
98950, 0.26086956521739, 0.95869565217391, -0.15
98951, 0.26086956521739, 0.98478260869565, -0.125
98952, 0.23913043478261, 0.98478260869565, -0.15
98953, 0.21739130434783, 0.95869565217391, -0.15
98954, 0.21739130434783, 0.98478260869565, -0.125
98955, 0.19565217391304, 0.98478260869565, -0.15
98956, 0.17391304347826, 0.95869565217391, -0.15
98957, 0.17391304347826, 0.98478260869565, -0.125
98958, 0.15217391304348, 0.98478260869565, -0.15
98959, 0.1304347826087, 0.95869565217391, -0.15
98960, 0.1304347826087, 0.98478260869565, -0.125
98961, 0.10869565217391, 0.98478260869565, -0.15
98962, 0.08695652173913, 0.95869565217391, -0.15
98963, 0.08695652173913, 0.98478260869565, -0.125
98964, 0.065217391304348, 0.98478260869565, -0.15
98965, 0.043478260869565, 0.95869565217391, -0.15
98966, 0.043478260869565, 0.98478260869565, -0.125
98967, 0.021739130434783, 0.98478260869565, -0.15
98968, 0.97826086956522, 1.0369565217391, -0.15
98969, 0.95652173913044, 1.0108695652174, -0.15
98970, 0.95652173913044, 1.0369565217391, -0.125
98971, 0.93478260869565, 1.0369565217391, -0.15
98972, 0.91304347826087, 1.0108695652174, -0.15
98973, 0.91304347826087, 1.0369565217391, -0.125
98974, 0.89130434782609, 1.0369565217391, -0.15
98975, 0.8695652173913, 1.0108695652174, -0.15
98976, 0.8695652173913, 1.0369565217391, -0.125
98977, 0.84782608695652, 1.0369565217391, -0.15
98978, 0.82608695652174, 1.0108695652174, -0.15
98979, 0.82608695652174, 1.0369565217391, -0.125
98980, 0.80434782608696, 1.0369565217391, -0.15
98981, 0.78260869565217, 1.0108695652174, -0.15
98982, 0.78260869565217, 1.0369565217391, -0.125
98983, 0.76086956521739, 1.0369565217391, -0.15
98984, 0.73913043478261, 1.0108695652174, -0.15
98985, 0.73913043478261, 1.0369565217391, -0.125
98986, 0.71739130434783, 1.0369565217391, -0.15
98987, 0.69565217391304, 1.0108695652174, -0.15
98988, 0.69565217391304, 1.0369565217391, -0.125
98989, 0.67391304347826, 1.0369565217391, -0.15
98990, 0.65217391304348, 1.0108695652174, -0.15
98991, 0.65217391304348, 1.0369565217391, -0.125
98992, 0.6304347826087, 1.0369565217391, -0.15
98993, 0.60869565217391, 1.0108695652174, -0.15
98994, 0.60869565217391, 1.0369565217391, -0.125
98995, 0.58695652173913, 1.0369565217391, -0.15
98996, 0.56521739130435, 1.0108695652174, -0.15
98997, 0.56521739130435, 1.0369565217391, -0.125
98998, 0.54347826086957, 1.0369565217391, -0.15
98999, 0.52173913043478, 1.0108695652174, -0.15
99000, 0.52173913043478, 1.0369565217391, -0.125
99001, 0.5, 1.0369565217391, -0.15
99002, 0.47826086956522, 1.0108695652174, -0.15
99003, 0.47826086956522, 1.0369565217391, -0.125
99004, 0.45652173913043, 1.0369565217391, -0.15
99005, 0.43478260869565, 1.0108695652174, -0.15
99006, 0.43478260869565, 1.0369565217391, -0.125
99007, 0.41304347826087, 1.0369565217391, -0.15
99008, 0.39130434782609, 1.0108695652174, -0.15
99009, 0.39130434782609, 1.0369565217391, -0.125
99010, 0.3695652173913, 1.0369565217391, -0.15
99011, 0.34782608695652, 1.0108695652174, -0.15
99012, 0.34782608695652, 1.0369565217391, -0.125
99013, 0.32608695652174, 1.0369565217391, -0.15
99014, 0.30434782608696, 1.0108695652174, -0.15
99015, 0.30434782608696, 1.0369565217391, -0.125
99016, 0.28260869565217, 1.0369565217391, -0.15
99017, 0.26086956521739, 1.0108695652174, -0.15
99018, 0.26086956521739, 1.0369565217391, -0.125
99019, 0.23913043478261, 1.0369565217391, -0.15
99020, 0.21739130434783, 1.0108695652174, -0.15
99021, 0.21739130434783, 1.0369565217391, -0.125
99022, 0.19565217391304, 1.0369565217391, -0.15
99023, 0.17391304347826, 1.0108695652174, -0.15
99024, 0.17391304347826, 1.0369565217391, -0.125
99025, 0.15217391304348, 1.0369565217391, -0.15
99026, 0.1304347826087, 1.0108695652174, -0.15
99027, 0.1304347826087, 1.0369565217391, -0.125
99028, 0.10869565217391, 1.0369565217391, -0.15
99029, 0.08695652173913, 1.0108695652174, -0.15
99030, 0.08695652173913, 1.0369565217391, -0.125
99031, 0.065217391304348, 1.0369565217391, -0.15
99032, 0.043478260869565, 1.0108695652174, -0.15
99033, 0.043478260869565, 1.0369565217391, -0.125
99034, 0.021739130434783, 1.0369565217391, -0.15
99035, 0.97826086956522, 1.0891304347826, -0.15
99036, 0.95652173913044, 1.0630434782609, -0.15
99037, 0.95652173913044, 1.0891304347826, -0.125
99038, 0.93478260869565, 1.0891304347826, -0.15
99039, 0.91304347826087, 1.0630434782609, -0.15
99040, 0.91304347826087, 1.0891304347826, -0.125
99041, 0.89130434782609, 1.0891304347826, -0.15
99042, 0.8695652173913, 1.0630434782609, -0.15
99043, 0.8695652173913, 1.0891304347826, -0.125
99044, 0.84782608695652, 1.0891304347826, -0.15
99045, 0.82608695652174, 1.0630434782609, -0.15
99046, 0.82608695652174, 1.0891304347826, -0.125
99047, 0.80434782608696, 1.0891304347826, -0.15
99048, 0.78260869565217, 1.0630434782609, -0.15
99049, 0.78260869565217, 1.0891304347826, -0.125
99050, 0.76086956521739, 1.0891304347826, -0.15
99051, 0.73913043478261, 1.0630434782609, -0.15
99052, 0.73913043478261, 1.0891304347826, -0.125
99053, 0.71739130434783, 1.0891304347826, -0.15
99054, 0.69565217391304, 1.0630434782609, -0.15
99055, 0.69565217391304, 1.0891304347826, -0.125
99056, 0.67391304347826, 1.0891304347826, -0.15
99057, 0.65217391304348, 1.0630434782609, -0.15
99058, 0.65217391304348, 1.0891304347826, -0.125
99059, 0.6304347826087, 1.0891304347826, -0.15
99060, 0.60869565217391, 1.0630434782609, -0.15
99061, 0.60869565217391, 1.0891304347826, -0.125
99062, 0.58695652173913, 1.0891304347826, -0.15
99063, 0.56521739130435, 1.0630434782609, -0.15
99064, 0.56521739130435, 1.0891304347826, -0.125
99065, 0.54347826086956, 1.0891304347826, -0.15
99066, 0.52173913043478, 1.0630434782609, -0.15
99067, 0.52173913043478, 1.0891304347826, -0.125
99068, 0.5, 1.0891304347826, -0.15
99069, 0.47826086956522, 1.0630434782609, -0.15
99070, 0.47826086956522, 1.0891304347826, -0.125
99071, 0.45652173913043, 1.0891304347826, -0.15
99072, 0.43478260869565, 1.0630434782609, -0.15
99073, 0.43478260869565, 1.0891304347826, -0.125
99074, 0.41304347826087, 1.0891304347826, -0.15
99075, 0.39130434782609, 1.0630434782609, -0.15
99076, 0.39130434782609, 1.0891304347826, -0.125
99077, 0.3695652173913, 1.0891304347826, -0.15
99078, 0.34782608695652, 1.0630434782609, -0.15
99079, 0.34782608695652, 1.0891304347826, -0.125
99080, 0.32608695652174, 1.0891304347826, -0.15
99081, 0.30434782608696, 1.0630434782609, -0.15
99082, 0.30434782608696, 1.0891304347826, -0.125
99083, 0.28260869565217, 1.0891304347826, -0.15
99084, 0.26086956521739, 1.0630434782609, -0.15
99085, 0.26086956521739, 1.0891304347826, -0.125
99086, 0.23913043478261, 1.0891304347826, -0.15
99087, 0.21739130434783, 1.0630434782609, -0.15
99088, 0.21739130434783, 1.0891304347826, -0.125
99089, 0.19565217391304, 1.0891304347826, -0.15
99090, 0.17391304347826, 1.0630434782609, -0.15
99091, 0.17391304347826, 1.0891304347826, -0.125
99092, 0.15217391304348, 1.0891304347826, -0.15
99093, 0.1304347826087, 1.0630434782609, -0.15
99094, 0.1304347826087, 1.0891304347826, -0.125
99095, 0.10869565217391, 1.0891304347826, -0.15
99096, 0.08695652173913, 1.0630434782609, -0.15
99097, 0.08695652173913, 1.0891304347826, -0.125
99098, 0.065217391304348, 1.0891304347826, -0.15
99099, 0.043478260869565, 1.0630434782609, -0.15
99100, 0.043478260869565, 1.0891304347826, -0.125
99101, 0.021739130434783, 1.0891304347826, -0.15
99102, 0.97826086956522, 1.1413043478261, -0.15
99103, 0.95652173913044, 1.1152173913043, -0.15
99104, 0.95652173913044, 1.1413043478261, -0.125
99105, 0.93478260869565, 1.1413043478261, -0.15
99106, 0.91304347826087, 1.1152173913043, -0.15
99107, 0.91304347826087, 1.1413043478261, -0.125
99108, 0.89130434782609, 1.1413043478261, -0.15
99109, 0.8695652173913, 1.1152173913043, -0.15
99110, 0.8695652173913, 1.1413043478261, -0.125
99111, 0.84782608695652, 1.1413043478261, -0.15
99112, 0.82608695652174, 1.1152173913043, -0.15
99113, 0.82608695652174, 1.1413043478261, -0.125
99114, 0.80434782608696, 1.1413043478261, -0.15
99115, 0.78260869565217, 1.1152173913043, -0.15
99116, 0.78260869565217, 1.1413043478261, -0.125
99117, 0.76086956521739, 1.1413043478261, -0.15
99118, 0.73913043478261, 1.1152173913043, -0.15
99119, 0.73913043478261, 1.1413043478261, -0.125
99120, 0.71739130434783, 1.1413043478261, -0.15
99121, 0.69565217391304, 1.1152173913043, -0.15
99122, 0.69565217391304, 1.1413043478261, -0.125
99123, 0.67391304347826, 1.1413043478261, -0.15
99124, 0.65217391304348, 1.1152173913043, -0.15
99125, 0.65217391304348, 1.1413043478261, -0.125
99126, 0.6304347826087, 1.1413043478261, -0.15
99127, 0.60869565217391, 1.1152173913043, -0.15
99128, 0.60869565217391, 1.1413043478261, -0.125
99129, 0.58695652173913, 1.1413043478261, -0.15
99130, 0.56521739130435, 1.1152173913043, -0.15
99131, 0.56521739130435, 1.1413043478261, -0.125
99132, 0.54347826086957, 1.1413043478261, -0.15
99133, 0.52173913043478, 1.1152173913043, -0.15
99134, 0.52173913043478, 1.1413043478261, -0.125
99135, 0.5, 1.1413043478261, -0.15
99136, 0.47826086956522, 1.1152173913043, -0.15
99137, 0.47826086956522, 1.1413043478261, -0.125
99138, 0.45652173913043, 1.1413043478261, -0.15
99139, 0.43478260869565, 1.1152173913043, -0.15
99140, 0.43478260869565, 1.1413043478261, -0.125
99141, 0.41304347826087, 1.1413043478261, -0.15
99142, 0.39130434782609, 1.1152173913043, -0.15
99143, 0.39130434782609, 1.1413043478261, -0.125
99144, 0.3695652173913, 1.1413043478261, -0.15
99145, 0.34782608695652, 1.1152173913043, -0.15
99146, 0.34782608695652, 1.1413043478261, -0.125
99147, 0.32608695652174, 1.1413043478261, -0.15
99148, 0.30434782608696, 1.1152173913043, -0.15
99149, 0.30434782608696, 1.1413043478261, -0.125
99150, 0.28260869565217, 1.1413043478261, -0.15
99151, 0.26086956521739, 1.1152173913043, -0.15
99152, 0.26086956521739, 1.1413043478261, -0.125
99153, 0.23913043478261, 1.1413043478261, -0.15
99154, 0.21739130434783, 1.1152173913043, -0.15
99155, 0.21739130434783, 1.1413043478261, -0.125
99156, 0.19565217391304, 1.1413043478261, -0.15
99157, 0.17391304347826, 1.1152173913043, -0.15
99158, 0.17391304347826, 1.1413043478261, -0.125
99159, 0.15217391304348, 1.1413043478261, -0.15
99160, 0.1304347826087, 1.1152173913043, -0.15
99161, 0.1304347826087, 1.1413043478261, -0.125
99162, 0.10869565217391, 1.1413043478261, -0.15
99163, 0.08695652173913, 1.1152173913043, -0.15
99164, 0.08695652173913, 1.1413043478261, -0.125
99165, 0.065217391304348, 1.1413043478261, -0.15
99166, 0.043478260869565, 1.1152173913043, -0.15
99167, 0.043478260869565, 1.1413043478261, -0.125
99168, 0.021739130434783, 1.1413043478261, -0.15
99169, 0.97826086956522, 1.1934782608696, -0.15
99170, 0.95652173913044, 1.1673913043478, -0.15
99171, 0.95652173913044, 1.1934782608696, -0.125
99172, 0.93478260869565, 1.1934782608696, -0.15
99173, 0.91304347826087, 1.1673913043478, -0.15
99174, 0.91304347826087, 1.1934782608696, -0.125
99175, 0.89130434782609, 1.1934782608696, -0.15
99176, 0.8695652173913, 1.1673913043478, -0.15
99177, 0.8695652173913, 1.1934782608696, -0.125
99178, 0.84782608695652, 1.1934782608696, -0.15
99179, 0.82608695652174, 1.1673913043478, -0.15
99180, 0.82608695652174, 1.1934782608696, -0.125
99181, 0.80434782608696, 1.1934782608696, -0.15
99182, 0.78260869565217, 1.1673913043478, -0.15
99183, 0.78260869565217, 1.1934782608696, -0.125
99184, 0.76086956521739, 1.1934782608696, -0.15
99185, 0.73913043478261, 1.1673913043478, -0.15
99186, 0.73913043478261, 1.1934782608696, -0.125
99187, 0.71739130434783, 1.1934782608696, -0.15
99188, 0.69565217391304, 1.1673913043478, -0.15
99189, 0.69565217391304, 1.1934782608696, -0.125
99190, 0.67391304347826, 1.1934782608696, -0.15
99191, 0.65217391304348, 1.1673913043478, -0.15
99192, 0.65217391304348, 1.1934782608696, -0.125
99193, 0.6304347826087, 1.1934782608696, -0.15
99194, 0.60869565217391, 1.1673913043478, -0.15
99195, 0.60869565217391, 1.1934782608696, -0.125
99196, 0.58695652173913, 1.1934782608696, -0.15
99197, 0.56521739130435, 1.1673913043478, -0.15
99198, 0.56521739130435, 1.1934782608696, -0.125
99199, 0.54347826086957, 1.1934782608696, -0.15
99200, 0.52173913043478, 1.1673913043478, -0.15
99201, 0.52173913043478, 1.1934782608696, -0.125
99202, 0.5, 1.1934782608696, -0.15
99203, 0.47826086956522, 1.1673913043478, -0.15
99204, 0.47826086956522, 1.1934782608696, -0.125
99205, 0.45652173913043, 1.1934782608696, -0.15
99206, 0.43478260869565, 1.1673913043478, -0.15
99207, 0.43478260869565, 1.1934782608696, -0.125
99208, 0.41304347826087, 1.1934782608696, -0.15
99209, 0.39130434782609, 1.1673913043478, -0.15
99210, 0.39130434782609, 1.1934782608696, -0.125
99211, 0.3695652173913, 1.1934782608696, -0.15
99212, 0.34782608695652, 1.1673913043478, -0.15
99213, 0.34782608695652, 1.1934782608696, -0.125
99214, 0.32608695652174, 1.1934782608696, -0.15
99215, 0.30434782608696, 1.1673913043478, -0.15
99216, 0.30434782608696, 1.1934782608696, -0.125
99217, 0.28260869565217, 1.1934782608696, -0.15
99218, 0.26086956521739, 1.1673913043478, -0.15
99219, 0.26086956521739, 1.1934782608696, -0.125
99220, 0.23913043478261, 1.1934782608696, -0.15
99221, 0.21739130434783, 1.1673913043478, -0.15
99222, 0.21739130434783, 1.1934782608696, -0.125
99223, 0.19565217391304, 1.1934782608696, -0.15
99224, 0.17391304347826, 1.1673913043478, -0.15
99225, 0.17391304347826, 1.1934782608696, -0.125
99226, 0.15217391304348, 1.1934782608696, -0.15
99227, 0.1304347826087, 1.1673913043478, -0.15
99228, 0.1304347826087, 1.1934782608696, -0.125
99229, 0.10869565217391, 1.1934782608696, -0.15
99230, 0.08695652173913, 1.1673913043478, -0.15
99231, 0.08695652173913, 1.1934782608696, -0.125
99232, 0.065217391304348, 1.1934782608696, -0.15
99233, 0.043478260869565, 1.1673913043478, -0.15
99234, 0.043478260869565, 1.1934782608696, -0.125
99235, 0.021739130434783, 1.1934782608696, -0.15
99236, 0.97826086956522, 1.245652173913, -0.15
99237, 0.95652173913044, 1.2195652173913, -0.15
99238, 0.95652173913044, 1.245652173913, -0.125
99239, 0.93478260869565, 1.245652173913, -0.15
99240, 0.91304347826087, 1.2195652173913, -0.15
99241, 0.91304347826087, 1.245652173913, -0.125
99242, 0.89130434782609, 1.245652173913, -0.15
99243, 0.8695652173913, 1.2195652173913, -0.15
99244, 0.8695652173913, 1.245652173913, -0.125
99245, 0.84782608695652, 1.245652173913, -0.15
99246, 0.82608695652174, 1.2195652173913, -0.15
99247, 0.82608695652174, 1.245652173913, -0.125
99248, 0.80434782608696, 1.245652173913, -0.15
99249, 0.78260869565217, 1.2195652173913, -0.15
99250, 0.78260869565217, 1.245652173913, -0.125
99251, 0.76086956521739, 1.245652173913, -0.15
99252, 0.73913043478261, 1.2195652173913, -0.15
99253, 0.73913043478261, 1.245652173913, -0.125
99254, 0.71739130434783, 1.245652173913, -0.15
99255, 0.69565217391304, 1.2195652173913, -0.15
99256, 0.69565217391304, 1.245652173913, -0.125
99257, 0.67391304347826, 1.245652173913, -0.15
99258, 0.65217391304348, 1.2195652173913, -0.15
99259, 0.65217391304348, 1.245652173913, -0.125
99260, 0.6304347826087, 1.245652173913, -0.15
99261, 0.60869565217391, 1.2195652173913, -0.15
99262, 0.60869565217391, 1.245652173913, -0.125
99263, 0.58695652173913, 1.245652173913, -0.15
99264, 0.56521739130435, 1.2195652173913, -0.15
99265, 0.56521739130435, 1.245652173913, -0.125
99266, 0.54347826086957, 1.245652173913, -0.15
99267, 0.52173913043478, 1.2195652173913, -0.15
99268, 0.52173913043478, 1.245652173913, -0.125
99269, 0.5, 1.245652173913, -0.15
99270, 0.47826086956522, 1.2195652173913, -0.15
99271, 0.47826086956522, 1.245652173913, -0.125
99272, 0.45652173913043, 1.245652173913, -0.15
99273, 0.43478260869565, 1.2195652173913, -0.15
99274, 0.43478260869565, 1.245652173913, -0.125
99275, 0.41304347826087, 1.245652173913, -0.15
99276, 0.39130434782609, 1.2195652173913, -0.15
99277, 0.39130434782609, 1.245652173913, -0.125
99278, 0.3695652173913, 1.245652173913, -0.15
99279, 0.34782608695652, 1.2195652173913, -0.15
99280, 0.34782608695652, 1.245652173913, -0.125
99281, 0.32608695652174, 1.245652173913, -0.15
99282, 0.30434782608696, 1.2195652173913, -0.15
99283, 0.30434782608696, 1.245652173913, -0.125
99284, 0.28260869565217, 1.245652173913, -0.15
99285, 0.26086956521739, 1.2195652173913, -0.15
99286, 0.26086956521739, 1.245652173913, -0.125
99287, 0.23913043478261, 1.245652173913, -0.15
99288, 0.21739130434783, 1.2195652173913, -0.15
99289, 0.21739130434783, 1.245652173913, -0.125
99290, 0.19565217391304, 1.245652173913, -0.15
99291, 0.17391304347826, 1.2195652173913, -0.15
99292, 0.17391304347826, 1.245652173913, -0.125
99293, 0.15217391304348, 1.245652173913, -0.15
99294, 0.1304347826087, 1.2195652173913, -0.15
99295, 0.1304347826087, 1.245652173913, -0.125
99296, 0.10869565217391, 1.245652173913, -0.15
99297, 0.08695652173913, 1.2195652173913, -0.15
99298, 0.08695652173913, 1.245652173913, -0.125
99299, 0.065217391304348, 1.245652173913, -0.15
99300, 0.043478260869565, 1.2195652173913, -0.15
99301, 0.043478260869565, 1.245652173913, -0.125
99302, 0.021739130434783, 1.245652173913, -0.15
99303, 0.97826086956522, 1.2978260869565, -0.15
99304, 0.95652173913044, 1.2717391304348, -0.15
99305, 0.95652173913044, 1.2978260869565, -0.125
99306, 0.93478260869565, 1.2978260869565, -0.15
99307, 0.91304347826087, 1.2717391304348, -0.15
99308, 0.91304347826087, 1.2978260869565, -0.125
99309, 0.89130434782609, 1.2978260869565, -0.15
99310, 0.8695652173913, 1.2717391304348, -0.15
99311, 0.8695652173913, 1.2978260869565, -0.125
99312, 0.84782608695652, 1.2978260869565, -0.15
99313, 0.82608695652174, 1.2717391304348, -0.15
99314, 0.82608695652174, 1.2978260869565, -0.125
99315, 0.80434782608696, 1.2978260869565, -0.15
99316, 0.78260869565217, 1.2717391304348, -0.15
99317, 0.78260869565217, 1.2978260869565, -0.125
99318, 0.76086956521739, 1.2978260869565, -0.15
99319, 0.73913043478261, 1.2717391304348, -0.15
99320, 0.73913043478261, 1.2978260869565, -0.125
99321, 0.71739130434783, 1.2978260869565, -0.15
99322, 0.69565217391304, 1.2717391304348, -0.15
99323, 0.69565217391304, 1.2978260869565, -0.125
99324, 0.67391304347826, 1.2978260869565, -0.15
99325, 0.65217391304348, 1.2717391304348, -0.15
99326, 0.65217391304348, 1.2978260869565, -0.125
99327, 0.6304347826087, 1.2978260869565, -0.15
99328, 0.60869565217391, 1.2717391304348, -0.15
99329, 0.60869565217391, 1.2978260869565, -0.125
99330, 0.58695652173913, 1.2978260869565, -0.15
99331, 0.56521739130435, 1.2717391304348, -0.15
99332, 0.56521739130435, 1.2978260869565, -0.125
99333, 0.54347826086957, 1.2978260869565, -0.15
99334, 0.52173913043478, 1.2717391304348, -0.15
99335, 0.52173913043478, 1.2978260869565, -0.125
99336, 0.5, 1.2978260869565, -0.15
99337, 0.47826086956522, 1.2717391304348, -0.15
99338, 0.47826086956522, 1.2978260869565, -0.125
99339, 0.45652173913043, 1.2978260869565, -0.15
99340, 0.43478260869565, 1.2717391304348, -0.15
99341, 0.43478260869565, 1.2978260869565, -0.125
99342, 0.41304347826087, 1.2978260869565, -0.15
99343, 0.39130434782609, 1.2717391304348, -0.15
99344, 0.39130434782609, 1.2978260869565, -0.125
99345, 0.3695652173913, 1.2978260869565, -0.15
99346, 0.34782608695652, 1.2717391304348, -0.15
99347, 0.34782608695652, 1.2978260869565, -0.125
99348, 0.32608695652174, 1.2978260869565, -0.15
99349, 0.30434782608696, 1.2717391304348, -0.15
99350, 0.30434782608696, 1.2978260869565, -0.125
99351, 0.28260869565217, 1.2978260869565, -0.15
99352, 0.26086956521739, 1.2717391304348, -0.15
99353, 0.26086956521739, 1.2978260869565, -0.125
99354, 0.23913043478261, 1.2978260869565, -0.15
99355, 0.21739130434783, 1.2717391304348, -0.15
99356, 0.21739130434783, 1.2978260869565, -0.125
99357, 0.19565217391304, 1.2978260869565, -0.15
99358, 0.17391304347826, 1.2717391304348, -0.15
99359, 0.17391304347826, 1.2978260869565, -0.125
99360, 0.15217391304348, 1.2978260869565, -0.15
99361, 0.1304347826087, 1.2717391304348, -0.15
99362, 0.1304347826087, 1.2978260869565, -0.125
99363, 0.10869565217391, 1.2978260869565, -0.15
99364, 0.08695652173913, 1.2717391304348, -0.15
99365, 0.08695652173913, 1.2978260869565, -0.125
99366, 0.065217391304348, 1.2978260869565, -0.15
99367, 0.043478260869565, 1.2717391304348, -0.15
99368, 0.043478260869565, 1.2978260869565, -0.125
99369, 0.021739130434783, 1.2978260869565, -0.15
99370, 0.95652173913043, 1.3239130434783, -0.15
99371, 0.91304347826087, 1.3239130434783, -0.15
99372, 0.8695652173913, 1.3239130434783, -0.15
99373, 0.82608695652174, 1.3239130434783, -0.15
99374, 0.78260869565217, 1.3239130434783, -0.15
99375, 0.73913043478261, 1.3239130434783, -0.15
99376, 0.69565217391304, 1.3239130434783, -0.15
99377, 0.65217391304348, 1.3239130434783, -0.15
99378, 0.60869565217391, 1.3239130434783, -0.15
99379, 0.56521739130435, 1.3239130434783, -0.15
99380, 0.52173913043478, 1.3239130434783, -0.15
99381, 0.47826086956522, 1.3239130434783, -0.15
99382, 0.43478260869565, 1.3239130434783, -0.15
99383, 0.39130434782609, 1.3239130434783, -0.15
99384, 0.34782608695652, 1.3239130434783, -0.15
99385, 0.30434782608696, 1.3239130434783, -0.15
99386, 0.26086956521739, 1.3239130434783, -0.15
99387, 0.21739130434783, 1.3239130434783, -0.15
99388, 0.17391304347826, 1.3239130434783, -0.15
99389, 0.1304347826087, 1.3239130434783, -0.15
99390, 0.08695652173913, 1.3239130434783, -0.15
99391, 0.043478260869565, 1.3239130434783, -0.15
99392, 0.95652173913043, 0.20217391304348, -0.175
99393, 0.91304347826087, 0.20217391304348, -0.175
99394, 0.8695652173913, 0.20217391304348, -0.175
99395, 0.82608695652174, 0.20217391304348, -0.175
99396, 0.78260869565217, 0.20217391304348, -0.175
99397, 0.73913043478261, 0.20217391304348, -0.175
99398, 0.69565217391304, 0.20217391304348, -0.175
99399, 0.65217391304348, 0.20217391304348, -0.175
99400, 0.60869565217391, 0.20217391304348, -0.175
99401, 0.56521739130435, 0.20217391304348, -0.175
99402, 0.52173913043478, 0.20217391304348, -0.175
99403, 0.47826086956522, 0.20217391304348, -0.175
99404, 0.43478260869565, 0.20217391304348, -0.175
99405, 0.39130434782609, 0.20217391304348, -0.175
99406, 0.34782608695652, 0.20217391304348, -0.175
99407, 0.30434782608696, 0.20217391304348, -0.175
99408, 0.26086956521739, 0.20217391304348, -0.175
99409, 0.21739130434783, 0.20217391304348, -0.175
99410, 0.17391304347826, 0.20217391304348, -0.175
99411, 0.1304347826087, 0.20217391304348, -0.175
99412, 0.08695652173913, 0.20217391304348, -0.175
99413, 0.043478260869565, 0.20217391304348, -0.175
99414, 0.95652173913043, 0.25434782608696, -0.175
99415, 0.91304347826087, 0.25434782608696, -0.175
99416, 0.8695652173913, 0.25434782608696, -0.175
99417, 0.82608695652174, 0.25434782608696, -0.175
99418, 0.78260869565217, 0.25434782608696, -0.175
99419, 0.73913043478261, 0.25434782608696, -0.175
99420, 0.69565217391304, 0.25434782608696, -0.175
99421, 0.65217391304348, 0.25434782608696, -0.175
99422, 0.60869565217391, 0.25434782608696, -0.175
99423, 0.56521739130435, 0.25434782608696, -0.175
99424, 0.52173913043478, 0.25434782608696, -0.175
99425, 0.47826086956522, 0.25434782608696, -0.175
99426, 0.43478260869565, 0.25434782608696, -0.175
99427, 0.39130434782609, 0.25434782608696, -0.175
99428, 0.34782608695652, 0.25434782608696, -0.175
99429, 0.30434782608696, 0.25434782608696, -0.175
99430, 0.26086956521739, 0.25434782608696, -0.175
99431, 0.21739130434783, 0.25434782608696, -0.175
99432, 0.17391304347826, 0.25434782608696, -0.175
99433, 0.1304347826087, 0.25434782608696, -0.175
99434, 0.08695652173913, 0.25434782608696, -0.175
99435, 0.043478260869565, 0.25434782608696, -0.175
99436, 0.95652173913044, 0.30652173913043, -0.175
99437, 0.91304347826087, 0.30652173913043, -0.175
99438, 0.8695652173913, 0.30652173913043, -0.175
99439, 0.82608695652174, 0.30652173913043, -0.175
99440, 0.78260869565217, 0.30652173913043, -0.175
99441, 0.73913043478261, 0.30652173913043, -0.175
99442, 0.69565217391304, 0.30652173913043, -0.175
99443, 0.65217391304348, 0.30652173913043, -0.175
99444, 0.60869565217391, 0.30652173913043, -0.175
99445, 0.56521739130435, 0.30652173913043, -0.175
99446, 0.52173913043478, 0.30652173913043, -0.175
99447, 0.47826086956522, 0.30652173913043, -0.175
99448, 0.43478260869565, 0.30652173913043, -0.175
99449, 0.39130434782609, 0.30652173913043, -0.175
99450, 0.34782608695652, 0.30652173913043, -0.175
99451, 0.30434782608696, 0.30652173913043, -0.175
99452, 0.26086956521739, 0.30652173913043, -0.175
99453, 0.21739130434783, 0.30652173913043, -0.175
99454, 0.17391304347826, 0.30652173913043, -0.175
99455, 0.1304347826087, 0.30652173913043, -0.175
99456, 0.08695652173913, 0.30652173913043, -0.175
99457, 0.043478260869565, 0.30652173913043, -0.175
99458, 0.95652173913043, 0.35869565217391, -0.175
99459, 0.91304347826087, 0.35869565217391, -0.175
99460, 0.8695652173913, 0.35869565217391, -0.175
99461, 0.82608695652174, 0.35869565217391, -0.175
99462, 0.78260869565217, 0.35869565217391, -0.175
99463, 0.73913043478261, 0.35869565217391, -0.175
99464, 0.69565217391304, 0.35869565217391, -0.175
99465, 0.65217391304348, 0.35869565217391, -0.175
99466, 0.60869565217391, 0.35869565217391, -0.175
99467, 0.56521739130435, 0.35869565217391, -0.175
99468, 0.52173913043478, 0.35869565217391, -0.175
99469, 0.47826086956522, 0.35869565217391, -0.175
99470, 0.43478260869565, 0.35869565217391, -0.175
99471, 0.39130434782609, 0.35869565217391, -0.175
99472, 0.34782608695652, 0.35869565217391, -0.175
99473, 0.30434782608696, 0.35869565217391, -0.175
99474, 0.26086956521739, 0.35869565217391, -0.175
99475, 0.21739130434783, 0.35869565217391, -0.175
99476, 0.17391304347826, 0.35869565217391, -0.175
99477, 0.1304347826087, 0.35869565217391, -0.175
99478, 0.08695652173913, 0.35869565217391, -0.175
99479, 0.043478260869565, 0.35869565217391, -0.175
99480, 0.95652173913043, 0.41086956521739, -0.175
99481, 0.91304347826087, 0.41086956521739, -0.175
99482, 0.8695652173913, 0.41086956521739, -0.175
99483, 0.82608695652174, 0.41086956521739, -0.175
99484, 0.78260869565217, 0.41086956521739, -0.175
99485, 0.73913043478261, 0.41086956521739, -0.175
99486, 0.69565217391304, 0.41086956521739, -0.175
99487, 0.65217391304348, 0.41086956521739, -0.175
99488, 0.60869565217391, 0.41086956521739, -0.175
99489, 0.56521739130435, 0.41086956521739, -0.175
99490, 0.52173913043478, 0.41086956521739, -0.175
99491, 0.47826086956522, 0.41086956521739, -0.175
99492, 0.43478260869565, 0.41086956521739, -0.175
99493, 0.39130434782609, 0.41086956521739, -0.175
99494, 0.34782608695652, 0.41086956521739, -0.175
99495, 0.30434782608696, 0.41086956521739, -0.175
99496, 0.26086956521739, 0.41086956521739, -0.175
99497, 0.21739130434783, 0.41086956521739, -0.175
99498, 0.17391304347826, 0.41086956521739, -0.175
99499, 0.1304347826087, 0.41086956521739, -0.175
99500, 0.08695652173913, 0.41086956521739, -0.175
99501, 0.043478260869565, 0.41086956521739, -0.175
99502, 0.95652173913043, 0.46304347826087, -0.175
99503, 0.91304347826087, 0.46304347826087, -0.175
99504, 0.8695652173913, 0.46304347826087, -0.175
99505, 0.82608695652174, 0.46304347826087, -0.175
99506, 0.78260869565217, 0.46304347826087, -0.175
99507, 0.73913043478261, 0.46304347826087, -0.175
99508, 0.69565217391304, 0.46304347826087, -0.175
99509, 0.65217391304348, 0.46304347826087, -0.175
99510, 0.60869565217391, 0.46304347826087, -0.175
99511, 0.56521739130435, 0.46304347826087, -0.175
99512, 0.52173913043478, 0.46304347826087, -0.175
99513, 0.47826086956522, 0.46304347826087, -0.175
99514, 0.43478260869565, 0.46304347826087, -0.175
99515, 0.39130434782609, 0.46304347826087, -0.175
99516, 0.34782608695652, 0.46304347826087, -0.175
99517, 0.30434782608696, 0.46304347826087, -0.175
99518, 0.26086956521739, 0.46304347826087, -0.175
99519, 0.21739130434783, 0.46304347826087, -0.175
99520, 0.17391304347826, 0.46304347826087, -0.175
99521, 0.1304347826087, 0.46304347826087, -0.175
99522, 0.08695652173913, 0.46304347826087, -0.175
99523, 0.043478260869565, 0.46304347826087, -0.175
99524, 0.95652173913043, 0.51521739130435, -0.175
99525, 0.91304347826087, 0.51521739130435, -0.175
99526, 0.8695652173913, 0.51521739130435, -0.175
99527, 0.82608695652174, 0.51521739130435, -0.175
99528, 0.78260869565217, 0.51521739130435, -0.175
99529, 0.73913043478261, 0.51521739130435, -0.175
99530, 0.69565217391304, 0.51521739130435, -0.175
99531, 0.65217391304348, 0.51521739130435, -0.175
99532, 0.60869565217391, 0.51521739130435, -0.175
99533, 0.56521739130435, 0.51521739130435, -0.175
99534, 0.52173913043478, 0.51521739130435, -0.175
99535, 0.47826086956522, 0.51521739130435, -0.175
99536, 0.43478260869565, 0.51521739130435, -0.175
99537, 0.39130434782609, 0.51521739130435, -0.175
99538, 0.34782608695652, 0.51521739130435, -0.175
99539, 0.30434782608696, 0.51521739130435, -0.175
99540, 0.26086956521739, 0.51521739130435, -0.175
99541, 0.21739130434783, 0.51521739130435, -0.175
99542, 0.17391304347826, 0.51521739130435, -0.175
99543, 0.1304347826087, 0.51521739130435, -0.175
99544, 0.08695652173913, 0.51521739130435, -0.175
99545, 0.043478260869565, 0.51521739130435, -0.175
99546, 0.95652173913043, 0.56739130434783, -0.175
99547, 0.91304347826087, 0.56739130434783, -0.175
99548, 0.8695652173913, 0.56739130434783, -0.175
99549, 0.82608695652174, 0.56739130434783, -0.175
99550, 0.78260869565217, 0.56739130434783, -0.175
99551, 0.73913043478261, 0.56739130434783, -0.175
99552, 0.69565217391304, 0.56739130434783, -0.175
99553, 0.65217391304348, 0.56739130434783, -0.175
99554, 0.60869565217391, 0.56739130434783, -0.175
99555, 0.56521739130435, 0.56739130434783, -0.175
99556, 0.52173913043478, 0.56739130434783, -0.175
99557, 0.47826086956522, 0.56739130434783, -0.175
99558, 0.43478260869565, 0.56739130434783, -0.175
99559, 0.39130434782609, 0.56739130434783, -0.175
99560, 0.34782608695652, 0.56739130434783, -0.175
99561, 0.30434782608696, 0.56739130434783, -0.175
99562, 0.26086956521739, 0.56739130434783, -0.175
99563, 0.21739130434783, 0.56739130434783, -0.175
99564, 0.17391304347826, 0.56739130434783, -0.175
99565, 0.1304347826087, 0.56739130434783, -0.175
99566, 0.08695652173913, 0.56739130434783, -0.175
99567, 0.043478260869565, 0.56739130434783, -0.175
99568, 0.95652173913043, 0.6195652173913, -0.175
99569, 0.91304347826087, 0.6195652173913, -0.175
99570, 0.8695652173913, 0.6195652173913, -0.175
99571, 0.82608695652174, 0.6195652173913, -0.175
99572, 0.78260869565217, 0.6195652173913, -0.175
99573, 0.73913043478261, 0.6195652173913, -0.175
99574, 0.69565217391304, 0.6195652173913, -0.175
99575, 0.65217391304348, 0.6195652173913, -0.175
99576, 0.60869565217391, 0.6195652173913, -0.175
99577, 0.56521739130435, 0.6195652173913, -0.175
99578, 0.52173913043478, 0.6195652173913, -0.175
99579, 0.47826086956522, 0.6195652173913, -0.175
99580, 0.43478260869565, 0.6195652173913, -0.175
99581, 0.39130434782609, 0.6195652173913, -0.175
99582, 0.34782608695652, 0.6195652173913, -0.175
99583, 0.30434782608696, 0.6195652173913, -0.175
99584, 0.26086956521739, 0.6195652173913, -0.175
99585, 0.21739130434783, 0.6195652173913, -0.175
99586, 0.17391304347826, 0.6195652173913, -0.175
99587, 0.1304347826087, 0.6195652173913, -0.175
99588, 0.08695652173913, 0.6195652173913, -0.175
99589, 0.043478260869565, 0.6195652173913, -0.175
99590, 0.95652173913043, 0.67173913043478, -0.175
99591, 0.91304347826087, 0.67173913043478, -0.175
99592, 0.8695652173913, 0.67173913043478, -0.175
99593, 0.82608695652174, 0.67173913043478, -0.175
99594, 0.78260869565217, 0.67173913043478, -0.175
99595, 0.73913043478261, 0.67173913043478, -0.175
99596, 0.69565217391304, 0.67173913043478, -0.175
99597, 0.65217391304348, 0.67173913043478, -0.175
99598, 0.60869565217391, 0.67173913043478, -0.175
99599, 0.56521739130435, 0.67173913043478, -0.175
99600, 0.52173913043478, 0.67173913043478, -0.175
99601, 0.47826086956522, 0.67173913043478, -0.175
99602, 0.43478260869565, 0.67173913043478, -0.175
99603, 0.39130434782609, 0.67173913043478, -0.175
99604, 0.34782608695652, 0.67173913043478, -0.175
99605, 0.30434782608696, 0.67173913043478, -0.175
99606, 0.26086956521739, 0.67173913043478, -0.175
99607, 0.21739130434783, 0.67173913043478, -0.175
99608, 0.17391304347826, 0.67173913043478, -0.175
99609, 0.1304347826087, 0.67173913043478, -0.175
99610, 0.08695652173913, 0.67173913043478, -0.175
99611, 0.043478260869565, 0.67173913043478, -0.175
99612, 0.95652173913043, 0.72391304347826, -0.175
99613, 0.91304347826087, 0.72391304347826, -0.175
99614, 0.8695652173913, 0.72391304347826, -0.175
99615, 0.82608695652174, 0.72391304347826, -0.175
99616, 0.78260869565217, 0.72391304347826, -0.175
99617, 0.73913043478261, 0.72391304347826, -0.175
99618, 0.69565217391304, 0.72391304347826, -0.175
99619, 0.65217391304348, 0.72391304347826, -0.175
99620, 0.60869565217391, 0.72391304347826, -0.175
99621, 0.56521739130435, 0.72391304347826, -0.175
99622, 0.52173913043478, 0.72391304347826, -0.175
99623, 0.47826086956522, 0.72391304347826, -0.175
99624, 0.43478260869565, 0.72391304347826, -0.175
99625, 0.39130434782609, 0.72391304347826, -0.175
99626, 0.34782608695652, 0.72391304347826, -0.175
99627, 0.30434782608696, 0.72391304347826, -0.175
99628, 0.26086956521739, 0.72391304347826, -0.175
99629, 0.21739130434783, 0.72391304347826, -0.175
99630, 0.17391304347826, 0.72391304347826, -0.175
99631, 0.1304347826087, 0.72391304347826, -0.175
99632, 0.08695652173913, 0.72391304347826, -0.175
99633, 0.043478260869565, 0.72391304347826, -0.175
99634, 0.95652173913043, 0.77608695652174, -0.175
99635, 0.91304347826087, 0.77608695652174, -0.175
99636, 0.8695652173913, 0.77608695652174, -0.175
99637, 0.82608695652174, 0.77608695652174, -0.175
99638, 0.78260869565217, 0.77608695652174, -0.175
99639, 0.73913043478261, 0.77608695652174, -0.175
99640, 0.69565217391304, 0.77608695652174, -0.175
99641, 0.65217391304348, 0.77608695652174, -0.175
99642, 0.60869565217391, 0.77608695652174, -0.175
99643, 0.56521739130435, 0.77608695652174, -0.175
99644, 0.52173913043478, 0.77608695652174, -0.175
99645, 0.47826086956522, 0.77608695652174, -0.175
99646, 0.43478260869565, 0.77608695652174, -0.175
99647, 0.39130434782609, 0.77608695652174, -0.175
99648, 0.34782608695652, 0.77608695652174, -0.175
99649, 0.30434782608696, 0.77608695652174, -0.175
99650, 0.26086956521739, 0.77608695652174, -0.175
99651, 0.21739130434783, 0.77608695652174, -0.175
99652, 0.17391304347826, 0.77608695652174, -0.175
99653, 0.1304347826087, 0.77608695652174, -0.175
99654, 0.08695652173913, 0.77608695652174, -0.175
99655, 0.043478260869565, 0.77608695652174, -0.175
99656, 0.95652173913043, 0.82826086956522, -0.175
99657, 0.91304347826087, 0.82826086956522, -0.175
99658, 0.8695652173913, 0.82826086956522, -0.175
99659, 0.82608695652174, 0.82826086956522, -0.175
99660, 0.78260869565217, 0.82826086956522, -0.175
99661, 0.73913043478261, 0.82826086956522, -0.175
99662, 0.69565217391304, 0.82826086956522, -0.175
99663, 0.65217391304348, 0.82826086956522, -0.175
99664, 0.60869565217391, 0.82826086956522, -0.175
99665, 0.56521739130435, 0.82826086956522, -0.175
99666, 0.52173913043478, 0.82826086956522, -0.175
99667, 0.47826086956522, 0.82826086956522, -0.175
99668, 0.43478260869565, 0.82826086956522, -0.175
99669, 0.39130434782609, 0.82826086956522, -0.175
99670, 0.34782608695652, 0.82826086956522, -0.175
99671, 0.30434782608696, 0.82826086956522, -0.175
99672, 0.26086956521739, 0.82826086956522, -0.175
99673, 0.21739130434783, 0.82826086956522, -0.175
99674, 0.17391304347826, 0.82826086956522, -0.175
99675, 0.1304347826087, 0.82826086956522, -0.175
99676, 0.08695652173913, 0.82826086956522, -0.175
99677, 0.043478260869565, 0.82826086956522, -0.175
99678, 0.95652173913043, 0.88043478260869, -0.175
99679, 0.91304347826087, 0.88043478260869, -0.175
99680, 0.8695652173913, 0.88043478260869, -0.175
99681, 0.82608695652174, 0.8804347826087, -0.175
99682, 0.78260869565217, 0.8804347826087, -0.175
99683, 0.73913043478261, 0.88043478260869, -0.175
99684, 0.69565217391304, 0.88043478260869, -0.175
99685, 0.65217391304348, 0.8804347826087, -0.175
99686, 0.60869565217391, 0.88043478260869, -0.175
99687, 0.56521739130435, 0.88043478260869, -0.175
99688, 0.52173913043478, 0.88043478260869, -0.175
99689, 0.47826086956522, 0.88043478260869, -0.175
99690, 0.43478260869565, 0.88043478260869, -0.175
99691, 0.39130434782609, 0.88043478260869, -0.175
99692, 0.34782608695652, 0.8804347826087, -0.175
99693, 0.30434782608696, 0.8804347826087, -0.175
99694, 0.26086956521739, 0.88043478260869, -0.175
99695, 0.21739130434783, 0.88043478260869, -0.175
99696, 0.17391304347826, 0.88043478260869, -0.175
99697, 0.1304347826087, 0.88043478260869, -0.175
99698, 0.08695652173913, 0.8804347826087, -0.175
99699, 0.043478260869565, 0.88043478260869, -0.175
99700, 0.95652173913043, 0.93260869565217, -0.175
99701, 0.91304347826087, 0.93260869565217, -0.175
99702, 0.8695652173913, 0.93260869565217, -0.175
99703, 0.82608695652174, 0.93260869565217, -0.175
99704, 0.78260869565217, 0.93260869565217, -0.175
99705, 0.73913043478261, 0.93260869565217, -0.175
99706, 0.69565217391304, 0.93260869565217, -0.175
99707, 0.65217391304348, 0.93260869565217, -0.175
99708, 0.60869565217391, 0.93260869565217, -0.175
99709, 0.56521739130435, 0.93260869565217, -0.175
99710, 0.52173913043478, 0.93260869565217, -0.175
99711, 0.47826086956522, 0.93260869565217, -0.175
99712, 0.43478260869565, 0.93260869565217, -0.175
99713, 0.39130434782609, 0.93260869565217, -0.175
99714, 0.34782608695652, 0.93260869565217, -0.175
99715, 0.30434782608696, 0.93260869565217, -0.175
99716, 0.26086956521739, 0.93260869565217, -0.175
99717, 0.21739130434783, 0.93260869565217, -0.175
99718, 0.17391304347826, 0.93260869565217, -0.175
99719, 0.1304347826087, 0.93260869565217, -0.175
99720, 0.08695652173913, 0.93260869565217, -0.175
99721, 0.043478260869565, 0.93260869565217, -0.175
99722, 0.95652173913043, 0.98478260869565, -0.175
99723, 0.91304347826087, 0.98478260869565, -0.175
99724, 0.8695652173913, 0.98478260869565, -0.175
99725, 0.82608695652174, 0.98478260869565, -0.175
99726, 0.78260869565217, 0.98478260869565, -0.175
99727, 0.73913043478261, 0.98478260869565, -0.175
99728, 0.69565217391304, 0.98478260869565, -0.175
99729, 0.65217391304348, 0.98478260869565, -0.175
99730, 0.60869565217391, 0.98478260869565, -0.175
99731, 0.56521739130435, 0.98478260869565, -0.175
99732, 0.52173913043478, 0.98478260869565, -0.175
99733, 0.47826086956522, 0.98478260869565, -0.175
99734, 0.43478260869565, 0.98478260869565, -0.175
99735, 0.39130434782609, 0.98478260869565, -0.175
99736, 0.34782608695652, 0.98478260869565, -0.175
99737, 0.30434782608696, 0.98478260869565, -0.175
99738, 0.26086956521739, 0.98478260869565, -0.175
99739, 0.21739130434783, 0.98478260869565, -0.175
99740, 0.17391304347826, 0.98478260869565, -0.175
99741, 0.1304347826087, 0.98478260869565, -0.175
99742, 0.08695652173913, 0.98478260869565, -0.175
99743, 0.043478260869565, 0.98478260869565, -0.175
99744, 0.95652173913043, 1.0369565217391, -0.175
99745, 0.91304347826087, 1.0369565217391, -0.175
99746, 0.8695652173913, 1.0369565217391, -0.175
99747, 0.82608695652174, 1.0369565217391, -0.175
99748, 0.78260869565217, 1.0369565217391, -0.175
99749, 0.73913043478261, 1.0369565217391, -0.175
99750, 0.69565217391304, 1.0369565217391, -0.175
99751, 0.65217391304348, 1.0369565217391, -0.175
99752, 0.60869565217391, 1.0369565217391, -0.175
99753, 0.56521739130435, 1.0369565217391, -0.175
99754, 0.52173913043478, 1.0369565217391, -0.175
99755, 0.47826086956522, 1.0369565217391, -0.175
99756, 0.43478260869565, 1.0369565217391, -0.175
99757, 0.39130434782609, 1.0369565217391, -0.175
99758, 0.34782608695652, 1.0369565217391, -0.175
99759, 0.30434782608696, 1.0369565217391, -0.175
99760, 0.26086956521739, 1.0369565217391, -0.175
99761, 0.21739130434783, 1.0369565217391, -0.175
99762, 0.17391304347826, 1.0369565217391, -0.175
99763, 0.1304347826087, 1.0369565217391, -0.175
99764, 0.08695652173913, 1.0369565217391, -0.175
99765, 0.043478260869565, 1.0369565217391, -0.175
99766, 0.95652173913043, 1.0891304347826, -0.175
99767, 0.91304347826087, 1.0891304347826, -0.175
99768, 0.8695652173913, 1.0891304347826, -0.175
99769, 0.82608695652174, 1.0891304347826, -0.175
99770, 0.78260869565217, 1.0891304347826, -0.175
99771, 0.73913043478261, 1.0891304347826, -0.175
99772, 0.69565217391304, 1.0891304347826, -0.175
99773, 0.65217391304348, 1.0891304347826, -0.175
99774, 0.60869565217391, 1.0891304347826, -0.175
99775, 0.56521739130435, 1.0891304347826, -0.175
99776, 0.52173913043478, 1.0891304347826, -0.175
99777, 0.47826086956522, 1.0891304347826, -0.175
99778, 0.43478260869565, 1.0891304347826, -0.175
99779, 0.39130434782609, 1.0891304347826, -0.175
99780, 0.34782608695652, 1.0891304347826, -0.175
99781, 0.30434782608696, 1.0891304347826, -0.175
99782, 0.26086956521739, 1.0891304347826, -0.175
99783, 0.21739130434783, 1.0891304347826, -0.175
99784, 0.17391304347826, 1.0891304347826, -0.175
99785, 0.1304347826087, 1.0891304347826, -0.175
99786, 0.08695652173913, 1.0891304347826, -0.175
99787, 0.043478260869565, 1.0891304347826, -0.175
99788, 0.95652173913043, 1.1413043478261, -0.175
99789, 0.91304347826087, 1.1413043478261, -0.175
99790, 0.8695652173913, 1.1413043478261, -0.175
99791, 0.82608695652174, 1.1413043478261, -0.175
99792, 0.78260869565217, 1.1413043478261, -0.175
99793, 0.73913043478261, 1.1413043478261, -0.175
99794, 0.69565217391304, 1.1413043478261, -0.175
99795, 0.65217391304348, 1.1413043478261, -0.175
99796, 0.60869565217391, 1.1413043478261, -0.175
99797, 0.56521739130435, 1.1413043478261, -0.175
99798, 0.52173913043478, 1.1413043478261, -0.175
99799, 0.47826086956522, 1.1413043478261, -0.175
99800, 0.43478260869565, 1.1413043478261, -0.175
99801, 0.39130434782609, 1.1413043478261, -0.175
99802, 0.34782608695652, 1.1413043478261, -0.175
99803, 0.30434782608696, 1.1413043478261, -0.175
99804, 0.26086956521739, 1.1413043478261, -0.175
99805, 0.21739130434783, 1.1413043478261, -0.175
99806, 0.17391304347826, 1.1413043478261, -0.175
99807, 0.1304347826087, 1.1413043478261, -0.175
99808, 0.08695652173913, 1.1413043478261, -0.175
99809, 0.043478260869565, 1.1413043478261, -0.175
99810, 0.95652173913043, 1.1934782608696, -0.175
99811, 0.91304347826087, 1.1934782608696, -0.175
99812, 0.8695652173913, 1.1934782608696, -0.175
99813, 0.82608695652174, 1.1934782608696, -0.175
99814, 0.78260869565217, 1.1934782608696, -0.175
99815, 0.73913043478261, 1.1934782608696, -0.175
99816, 0.69565217391304, 1.1934782608696, -0.175
99817, 0.65217391304348, 1.1934782608696, -0.175
99818, 0.60869565217391, 1.1934782608696, -0.175
99819, 0.56521739130435, 1.1934782608696, -0.175
99820, 0.52173913043478, 1.1934782608696, -0.175
99821, 0.47826086956522, 1.1934782608696, -0.175
99822, 0.43478260869565, 1.1934782608696, -0.175
99823, 0.39130434782609, 1.1934782608696, -0.175
99824, 0.34782608695652, 1.1934782608696, -0.175
99825, 0.30434782608696, 1.1934782608696, -0.175
99826, 0.26086956521739, 1.1934782608696, -0.175
99827, 0.21739130434783, 1.1934782608696, -0.175
99828, 0.17391304347826, 1.1934782608696, -0.175
99829, 0.1304347826087, 1.1934782608696, -0.175
99830, 0.08695652173913, 1.1934782608696, -0.175
99831, 0.043478260869565, 1.1934782608696, -0.175
99832, 0.95652173913044, 1.245652173913, -0.175
99833, 0.91304347826087, 1.245652173913, -0.175
99834, 0.8695652173913, 1.245652173913, -0.175
99835, 0.82608695652174, 1.245652173913, -0.175
99836, 0.78260869565217, 1.245652173913, -0.175
99837, 0.73913043478261, 1.245652173913, -0.175
99838, 0.69565217391304, 1.245652173913, -0.175
99839, 0.65217391304348, 1.245652173913, -0.175
99840, 0.60869565217391, 1.245652173913, -0.175
99841, 0.56521739130435, 1.245652173913, -0.175
99842, 0.52173913043478, 1.245652173913, -0.175
99843, 0.47826086956522, 1.245652173913, -0.175
99844, 0.43478260869565, 1.245652173913, -0.175
99845, 0.39130434782609, 1.245652173913, -0.175
99846, 0.34782608695652, 1.245652173913, -0.175
99847, 0.30434782608696, 1.245652173913, -0.175
99848, 0.26086956521739, 1.245652173913, -0.175
99849, 0.21739130434783, 1.245652173913, -0.175
99850, 0.17391304347826, 1.245652173913, -0.175
99851, 0.1304347826087, 1.245652173913, -0.175
99852, 0.08695652173913, 1.245652173913, -0.175
99853, 0.043478260869565, 1.245652173913, -0.175
99854, 0.95652173913043, 1.2978260869565, -0.175
99855, 0.91304347826087, 1.2978260869565, -0.175
99856, 0.8695652173913, 1.2978260869565, -0.175
99857, 0.82608695652174, 1.2978260869565, -0.175
99858, 0.78260869565217, 1.2978260869565, -0.175
99859, 0.73913043478261, 1.2978260869565, -0.175
99860, 0.69565217391304, 1.2978260869565, -0.175
99861, 0.65217391304348, 1.2978260869565, -0.175
99862, 0.60869565217391, 1.2978260869565, -0.175
99863, 0.56521739130435, 1.2978260869565, -0.175
99864, 0.52173913043478, 1.2978260869565, -0.175
99865, 0.47826086956522, 1.2978260869565, -0.175
99866, 0.43478260869565, 1.2978260869565, -0.175
99867, 0.39130434782609, 1.2978260869565, -0.175
99868, 0.34782608695652, 1.2978260869565, -0.175
99869, 0.30434782608696, 1.2978260869565, -0.175
99870, 0.26086956521739, 1.2978260869565, -0.175
99871, 0.21739130434783, 1.2978260869565, -0.175
99872, 0.17391304347826, 1.2978260869565, -0.175
99873, 0.1304347826087, 1.2978260869565, -0.175
99874, 0.08695652173913, 1.2978260869565, -0.175
99875, 0.043478260869565, 1.2978260869565, -0.175
99876, 1.2434782608696, 1.2978260869565, -0.05
99877, 1.2869565217391, 1.2978260869565, -0.05
99878, 1.3304347826087, 1.2978260869565, -0.05
99879, 1.3739130434783, 1.2978260869565, -0.05
99880, 1.4173913043478, 1.2978260869565, -0.05
99881, 1.4608695652174, 1.2978260869565, -0.05
99882, 1.504347826087, 1.2978260869565, -0.05
99883, 1.5478260869565, 1.2978260869565, -0.05
99884, 1.5913043478261, 1.2978260869565, -0.05
99885, 1.6347826086957, 1.2978260869565, -0.05
99886, 1.6782608695652, 1.2978260869565, -0.05
99887, 1.7217391304348, 1.2978260869565, -0.05
99888, 1.7652173913043, 1.2978260869565, -0.05
99889, 1.8086956521739, 1.2978260869565, -0.05
99890, 1.8521739130435, 1.2978260869565, -0.05
99891, 1.895652173913, 1.2978260869565, -0.05
99892, 1.9391304347826, 1.2978260869565, -0.05
99893, 1.9826086956522, 1.2978260869565, -0.05
99894, 2.0260869565217, 1.2978260869565, -0.05
99895, 2.0695652173913, 1.2978260869565, -0.05
99896, 2.1130434782609, 1.2978260869565, -0.05
99897, 2.1565217391304, 1.2978260869565, -0.05
99898, 1.2434782608696, 1.245652173913, -0.05
99899, 1.2869565217391, 1.245652173913, -0.05
99900, 1.3304347826087, 1.245652173913, -0.05
99901, 1.3739130434783, 1.245652173913, -0.05
99902, 1.4173913043478, 1.245652173913, -0.05
99903, 1.4608695652174, 1.245652173913, -0.05
99904, 1.504347826087, 1.245652173913, -0.05
99905, 1.5478260869565, 1.245652173913, -0.05
99906, 1.5913043478261, 1.245652173913, -0.05
99907, 1.6347826086957, 1.245652173913, -0.05
99908, 1.6782608695652, 1.245652173913, -0.05
99909, 1.7217391304348, 1.245652173913, -0.05
99910, 1.7652173913043, 1.245652173913, -0.05
99911, 1.8086956521739, 1.245652173913, -0.05
99912, 1.8521739130435, 1.245652173913, -0.05
99913, 1.895652173913, 1.245652173913, -0.05
99914, 1.9391304347826, 1.245652173913, -0.05
99915, 1.9826086956522, 1.245652173913, -0.05
99916, 2.0260869565217, 1.245652173913, -0.05
99917, 2.0695652173913, 1.245652173913, -0.05
99918, 2.1130434782609, 1.245652173913, -0.05
99919, 2.1565217391304, 1.245652173913, -0.05
99920, 1.2434782608696, 1.1934782608696, -0.05
99921, 1.2869565217391, 1.1934782608696, -0.05
99922, 1.3304347826087, 1.1934782608696, -0.05
99923, 1.3739130434783, 1.1934782608696, -0.05
99924, 1.4173913043478, 1.1934782608696, -0.05
99925, 1.4608695652174, 1.1934782608696, -0.05
99926, 1.504347826087, 1.1934782608696, -0.05
99927, 1.5478260869565, 1.1934782608696, -0.05
99928, 1.5913043478261, 1.1934782608696, -0.05
99929, 1.6347826086957, 1.1934782608696, -0.05
99930, 1.6782608695652, 1.1934782608696, -0.05
99931, 1.7217391304348, 1.1934782608696, -0.05
99932, 1.7652173913043, 1.1934782608696, -0.05
99933, 1.8086956521739, 1.1934782608696, -0.05
99934, 1.8521739130435, 1.1934782608696, -0.05
99935, 1.895652173913, 1.1934782608696, -0.05
99936, 1.9391304347826, 1.1934782608696, -0.05
99937, 1.9826086956522, 1.1934782608696, -0.05
99938, 2.0260869565217, 1.1934782608696, -0.05
99939, 2.0695652173913, 1.1934782608696, -0.05
99940, 2.1130434782609, 1.1934782608696, -0.05
99941, 2.1565217391304, 1.1934782608696, -0.05
99942, 1.2434782608696, 1.1413043478261, -0.05
99943, 1.2869565217391, 1.1413043478261, -0.05
99944, 1.3304347826087, 1.1413043478261, -0.05
99945, 1.3739130434783, 1.1413043478261, -0.05
99946, 1.4173913043478, 1.1413043478261, -0.05
99947, 1.4608695652174, 1.1413043478261, -0.05
99948, 1.504347826087, 1.1413043478261, -0.05
99949, 1.5478260869565, 1.1413043478261, -0.05
99950, 1.5913043478261, 1.1413043478261, -0.05
99951, 1.6347826086957, 1.1413043478261, -0.05
99952, 1.6782608695652, 1.1413043478261, -0.05
99953, 1.7217391304348, 1.1413043478261, -0.05
99954, 1.7652173913043, 1.1413043478261, -0.05
99955, 1.8086956521739, 1.1413043478261, -0.05
99956, 1.8521739130435, 1.1413043478261, -0.05
99957, 1.895652173913, 1.1413043478261, -0.05
99958, 1.9391304347826, 1.1413043478261, -0.05
99959, 1.9826086956522, 1.1413043478261, -0.05
99960, 2.0260869565217, 1.1413043478261, -0.05
99961, 2.0695652173913, 1.1413043478261, -0.05
99962, 2.1130434782609, 1.1413043478261, -0.05
99963, 2.1565217391304, 1.1413043478261, -0.05
99964, 1.2434782608696, 1.0891304347826, -0.05
99965, 1.2869565217391, 1.0891304347826, -0.05
99966, 1.3304347826087, 1.0891304347826, -0.05
99967, 1.3739130434783, 1.0891304347826, -0.05
99968, 1.4173913043478, 1.0891304347826, -0.05
99969, 1.4608695652174, 1.0891304347826, -0.05
99970, 1.504347826087, 1.0891304347826, -0.05
99971, 1.5478260869565, 1.0891304347826, -0.05
99972, 1.5913043478261, 1.0891304347826, -0.05
99973, 1.6347826086957, 1.0891304347826, -0.05
99974, 1.6782608695652, 1.0891304347826, -0.05
99975, 1.7217391304348, 1.0891304347826, -0.05
99976, 1.7652173913043, 1.0891304347826, -0.05
99977, 1.8086956521739, 1.0891304347826, -0.05
99978, 1.8521739130435, 1.0891304347826, -0.05
99979, 1.895652173913, 1.0891304347826, -0.05
99980, 1.9391304347826, 1.0891304347826, -0.05
99981, 1.9826086956522, 1.0891304347826, -0.05
99982, 2.0260869565217, 1.0891304347826, -0.05
99983, 2.0695652173913, 1.0891304347826, -0.05
99984, 2.1130434782609, 1.0891304347826, -0.05
99985, 2.1565217391304, 1.0891304347826, -0.05
99986, 1.2434782608696, 1.0369565217391, -0.05
99987, 1.2869565217391, 1.0369565217391, -0.05
99988, 1.3304347826087, 1.0369565217391, -0.05
99989, 1.3739130434783, 1.0369565217391, -0.05
99990, 1.4173913043478, 1.0369565217391, -0.05
99991, 1.4608695652174, 1.0369565217391, -0.05
99992, 1.504347826087, 1.0369565217391, -0.05
99993, 1.5478260869565, 1.0369565217391, -0.05
99994, 1.5913043478261, 1.0369565217391, -0.05
99995, 1.6347826086957, 1.0369565217391, -0.05
99996, 1.6782608695652, 1.0369565217391, -0.05
99997, 1.7217391304348, 1.0369565217391, -0.05
99998, 1.7652173913043, 1.0369565217391, -0.05
99999, 1.8086956521739, 1.0369565217391, -0.05
100000, 1.8521739130435, 1.0369565217391, -0.05
100001, 1.895652173913, 1.0369565217391, -0.05
100002, 1.9391304347826, 1.0369565217391, -0.05
100003, 1.9826086956522, 1.0369565217391, -0.05
100004, 2.0260869565217, 1.0369565217391, -0.05
100005, 2.0695652173913, 1.0369565217391, -0.05
100006, 2.1130434782609, 1.0369565217391, -0.05
100007, 2.1565217391304, 1.0369565217391, -0.05
100008, 1.2434782608696, 0.98478260869565, -0.05
100009, 1.2869565217391, 0.98478260869565, -0.05
100010, 1.3304347826087, 0.98478260869565, -0.05
100011, 1.3739130434783, 0.98478260869565, -0.05
100012, 1.4173913043478, 0.98478260869565, -0.05
100013, 1.4608695652174, 0.98478260869565, -0.05
100014, 1.504347826087, 0.98478260869565, -0.05
100015, 1.5478260869565, 0.98478260869565, -0.05
100016, 1.5913043478261, 0.98478260869565, -0.05
100017, 1.6347826086957, 0.98478260869565, -0.05
100018, 1.6782608695652, 0.98478260869565, -0.05
100019, 1.7217391304348, 0.98478260869565, -0.05
100020, 1.7652173913043, 0.98478260869565, -0.05
100021, 1.8086956521739, 0.98478260869565, -0.05
100022, 1.8521739130435, 0.98478260869565, -0.05
100023, 1.895652173913, 0.98478260869565, -0.05
100024, 1.9391304347826, 0.98478260869565, -0.05
100025, 1.9826086956522, 0.98478260869565, -0.05
100026, 2.0260869565217, 0.98478260869565, -0.05
100027, 2.0695652173913, 0.98478260869565, -0.05
100028, 2.1130434782609, 0.98478260869565, -0.05
100029, 2.1565217391304, 0.98478260869565, -0.05
100030, 1.2434782608696, 0.93260869565217, -0.05
100031, 1.2869565217391, 0.93260869565217, -0.05
100032, 1.3304347826087, 0.93260869565217, -0.05
100033, 1.3739130434783, 0.93260869565217, -0.05
100034, 1.4173913043478, 0.93260869565217, -0.05
100035, 1.4608695652174, 0.93260869565217, -0.05
100036, 1.504347826087, 0.93260869565217, -0.05
100037, 1.5478260869565, 0.93260869565217, -0.05
100038, 1.5913043478261, 0.93260869565217, -0.05
100039, 1.6347826086957, 0.93260869565217, -0.05
100040, 1.6782608695652, 0.93260869565217, -0.05
100041, 1.7217391304348, 0.93260869565217, -0.05
100042, 1.7652173913043, 0.93260869565217, -0.05
100043, 1.8086956521739, 0.93260869565217, -0.05
100044, 1.8521739130435, 0.93260869565218, -0.05
100045, 1.895652173913, 0.93260869565217, -0.05
100046, 1.9391304347826, 0.93260869565217, -0.05
100047, 1.9826086956522, 0.93260869565217, -0.05
100048, 2.0260869565217, 0.93260869565217, -0.05
100049, 2.0695652173913, 0.93260869565217, -0.05
100050, 2.1130434782609, 0.93260869565217, -0.05
100051, 2.1565217391304, 0.93260869565217, -0.05
100052, 1.2434782608696, 0.8804347826087, -0.05
100053, 1.2869565217391, 0.8804347826087, -0.05
100054, 1.3304347826087, 0.8804347826087, -0.05
100055, 1.3739130434783, 0.8804347826087, -0.05
100056, 1.4173913043478, 0.8804347826087, -0.05
100057, 1.4608695652174, 0.8804347826087, -0.05
100058, 1.504347826087, 0.8804347826087, -0.05
100059, 1.5478260869565, 0.8804347826087, -0.05
100060, 1.5913043478261, 0.8804347826087, -0.05
100061, 1.6347826086957, 0.8804347826087, -0.05
100062, 1.6782608695652, 0.8804347826087, -0.05
100063, 1.7217391304348, 0.8804347826087, -0.05
100064, 1.7652173913043, 0.8804347826087, -0.05
100065, 1.8086956521739, 0.8804347826087, -0.05
100066, 1.8521739130435, 0.8804347826087, -0.05
100067, 1.895652173913, 0.8804347826087, -0.05
100068, 1.9391304347826, 0.8804347826087, -0.05
100069, 1.9826086956522, 0.8804347826087, -0.05
100070, 2.0260869565217, 0.8804347826087, -0.05
100071, 2.0695652173913, 0.8804347826087, -0.05
100072, 2.1130434782609, 0.8804347826087, -0.05
100073, 2.1565217391304, 0.8804347826087, -0.05
100074, 1.2434782608696, 0.82826086956522, -0.05
100075, 1.2869565217391, 0.82826086956522, -0.05
100076, 1.3304347826087, 0.82826086956522, -0.05
100077, 1.3739130434783, 0.82826086956522, -0.05
100078, 1.4173913043478, 0.82826086956522, -0.05
100079, 1.4608695652174, 0.82826086956522, -0.05
100080, 1.504347826087, 0.82826086956522, -0.05
100081, 1.5478260869565, 0.82826086956522, -0.05
100082, 1.5913043478261, 0.82826086956522, -0.05
100083, 1.6347826086957, 0.82826086956522, -0.05
100084, 1.6782608695652, 0.82826086956522, -0.05
100085, 1.7217391304348, 0.82826086956522, -0.05
100086, 1.7652173913043, 0.82826086956522, -0.05
100087, 1.8086956521739, 0.82826086956522, -0.05
100088, 1.8521739130435, 0.82826086956522, -0.05
100089, 1.895652173913, 0.82826086956522, -0.05
100090, 1.9391304347826, 0.82826086956522, -0.05
100091, 1.9826086956522, 0.82826086956522, -0.05
100092, 2.0260869565217, 0.82826086956522, -0.05
100093, 2.0695652173913, 0.82826086956522, -0.05
100094, 2.1130434782609, 0.82826086956522, -0.05
100095, 2.1565217391304, 0.82826086956522, -0.05
100096, 1.2434782608696, 0.77608695652174, -0.05
100097, 1.2869565217391, 0.77608695652174, -0.05
100098, 1.3304347826087, 0.77608695652174, -0.05
100099, 1.3739130434783, 0.77608695652174, -0.05
100100, 1.4173913043478, 0.77608695652174, -0.05
100101, 1.4608695652174, 0.77608695652174, -0.05
100102, 1.504347826087, 0.77608695652174, -0.05
100103, 1.5478260869565, 0.77608695652174, -0.05
100104, 1.5913043478261, 0.77608695652174, -0.05
100105, 1.6347826086957, 0.77608695652174, -0.05
100106, 1.6782608695652, 0.77608695652174, -0.05
100107, 1.7217391304348, 0.77608695652174, -0.05
100108, 1.7652173913043, 0.77608695652174, -0.05
100109, 1.8086956521739, 0.77608695652174, -0.05
100110, 1.8521739130435, 0.77608695652174, -0.05
100111, 1.895652173913, 0.77608695652174, -0.05
100112, 1.9391304347826, 0.77608695652174, -0.05
100113, 1.9826086956522, 0.77608695652174, -0.05
100114, 2.0260869565217, 0.77608695652174, -0.05
100115, 2.0695652173913, 0.77608695652174, -0.05
100116, 2.1130434782609, 0.77608695652174, -0.05
100117, 2.1565217391304, 0.77608695652174, -0.05
100118, 1.2434782608696, 0.72391304347826, -0.05
100119, 1.2869565217391, 0.72391304347826, -0.05
100120, 1.3304347826087, 0.72391304347826, -0.05
100121, 1.3739130434783, 0.72391304347826, -0.05
100122, 1.4173913043478, 0.72391304347826, -0.05
100123, 1.4608695652174, 0.72391304347826, -0.05
100124, 1.504347826087, 0.72391304347826, -0.05
100125, 1.5478260869565, 0.72391304347826, -0.05
100126, 1.5913043478261, 0.72391304347826, -0.05
100127, 1.6347826086957, 0.72391304347826, -0.05
100128, 1.6782608695652, 0.72391304347826, -0.05
100129, 1.7217391304348, 0.72391304347826, -0.05
100130, 1.7652173913043, 0.72391304347826, -0.05
100131, 1.8086956521739, 0.72391304347826, -0.05
100132, 1.8521739130435, 0.72391304347826, -0.05
100133, 1.895652173913, 0.72391304347826, -0.05
100134, 1.9391304347826, 0.72391304347826, -0.05
100135, 1.9826086956522, 0.72391304347826, -0.05
100136, 2.0260869565217, 0.72391304347826, -0.05
100137, 2.0695652173913, 0.72391304347826, -0.05
100138, 2.1130434782609, 0.72391304347826, -0.05
100139, 2.1565217391304, 0.72391304347826, -0.05
100140, 1.2434782608696, 0.67173913043478, -0.05
100141, 1.2869565217391, 0.67173913043478, -0.05
100142, 1.3304347826087, 0.67173913043478, -0.05
100143, 1.3739130434783, 0.67173913043478, -0.05
100144, 1.4173913043478, 0.67173913043478, -0.05
100145, 1.4608695652174, 0.67173913043478, -0.05
100146, 1.504347826087, 0.67173913043478, -0.05
100147, 1.5478260869565, 0.67173913043478, -0.05
100148, 1.5913043478261, 0.67173913043478, -0.05
100149, 1.6347826086957, 0.67173913043478, -0.05
100150, 1.6782608695652, 0.67173913043478, -0.05
100151, 1.7217391304348, 0.67173913043478, -0.05
100152, 1.7652173913043, 0.67173913043478, -0.05
100153, 1.8086956521739, 0.67173913043478, -0.05
100154, 1.8521739130435, 0.67173913043478, -0.05
100155, 1.895652173913, 0.67173913043478, -0.05
100156, 1.9391304347826, 0.67173913043478, -0.05
100157, 1.9826086956522, 0.67173913043478, -0.05
100158, 2.0260869565217, 0.67173913043478, -0.05
100159, 2.0695652173913, 0.67173913043478, -0.05
100160, 2.1130434782609, 0.67173913043478, -0.05
100161, 2.1565217391304, 0.67173913043478, -0.05
100162, 1.2434782608696, 0.6195652173913, -0.05
100163, 1.2869565217391, 0.61956521739131, -0.05
100164, 1.3304347826087, 0.61956521739131, -0.05
100165, 1.3739130434783, 0.61956521739131, -0.05
100166, 1.4173913043478, 0.61956521739131, -0.05
100167, 1.4608695652174, 0.61956521739131, -0.05
100168, 1.504347826087, 0.6195652173913, -0.05
100169, 1.5478260869565, 0.61956521739131, -0.05
100170, 1.5913043478261, 0.6195652173913, -0.05
100171, 1.6347826086957, 0.61956521739131, -0.05
100172, 1.6782608695652, 0.61956521739131, -0.05
100173, 1.7217391304348, 0.61956521739131, -0.05
100174, 1.7652173913043, 0.61956521739131, -0.05
100175, 1.8086956521739, 0.61956521739131, -0.05
100176, 1.8521739130435, 0.6195652173913, -0.05
100177, 1.895652173913, 0.61956521739131, -0.05
100178, 1.9391304347826, 0.6195652173913, -0.05
100179, 1.9826086956522, 0.61956521739131, -0.05
100180, 2.0260869565217, 0.6195652173913, -0.05
100181, 2.0695652173913, 0.61956521739131, -0.05
100182, 2.1130434782609, 0.61956521739131, -0.05
100183, 2.1565217391304, 0.61956521739131, -0.05
100184, 1.2434782608696, 0.56739130434783, -0.05
100185, 1.2869565217391, 0.56739130434783, -0.05
100186, 1.3304347826087, 0.56739130434783, -0.05
100187, 1.3739130434783, 0.56739130434783, -0.05
100188, 1.4173913043478, 0.56739130434783, -0.05
100189, 1.4608695652174, 0.56739130434783, -0.05
100190, 1.504347826087, 0.56739130434783, -0.05
100191, 1.5478260869565, 0.56739130434783, -0.05
100192, 1.5913043478261, 0.56739130434783, -0.05
100193, 1.6347826086957, 0.56739130434783, -0.05
100194, 1.6782608695652, 0.56739130434783, -0.05
100195, 1.7217391304348, 0.56739130434783, -0.05
100196, 1.7652173913043, 0.56739130434783, -0.05
100197, 1.8086956521739, 0.56739130434783, -0.05
100198, 1.8521739130435, 0.56739130434783, -0.05
100199, 1.895652173913, 0.56739130434783, -0.05
100200, 1.9391304347826, 0.56739130434783, -0.05
100201, 1.9826086956522, 0.56739130434783, -0.05
100202, 2.0260869565217, 0.56739130434783, -0.05
100203, 2.0695652173913, 0.56739130434783, -0.05
100204, 2.1130434782609, 0.56739130434783, -0.05
100205, 2.1565217391304, 0.56739130434783, -0.05
100206, 1.2434782608696, 0.51521739130435, -0.05
100207, 1.2869565217391, 0.51521739130435, -0.05
100208, 1.3304347826087, 0.51521739130435, -0.05
100209, 1.3739130434783, 0.51521739130435, -0.05
100210, 1.4173913043478, 0.51521739130435, -0.05
100211, 1.4608695652174, 0.51521739130435, -0.05
100212, 1.504347826087, 0.51521739130435, -0.05
100213, 1.5478260869565, 0.51521739130435, -0.05
100214, 1.5913043478261, 0.51521739130435, -0.05
100215, 1.6347826086957, 0.51521739130435, -0.05
100216, 1.6782608695652, 0.51521739130435, -0.05
100217, 1.7217391304348, 0.51521739130435, -0.05
100218, 1.7652173913043, 0.51521739130435, -0.05
100219, 1.8086956521739, 0.51521739130435, -0.05
100220, 1.8521739130435, 0.51521739130435, -0.05
100221, 1.895652173913, 0.51521739130435, -0.05
100222, 1.9391304347826, 0.51521739130435, -0.05
100223, 1.9826086956522, 0.51521739130435, -0.05
100224, 2.0260869565217, 0.51521739130435, -0.05
100225, 2.0695652173913, 0.51521739130435, -0.05
100226, 2.1130434782609, 0.51521739130435, -0.05
100227, 2.1565217391304, 0.51521739130435, -0.05
100228, 1.2434782608696, 0.46304347826087, -0.05
100229, 1.2869565217391, 0.46304347826087, -0.05
100230, 1.3304347826087, 0.46304347826087, -0.05
100231, 1.3739130434783, 0.46304347826087, -0.05
100232, 1.4173913043478, 0.46304347826087, -0.05
100233, 1.4608695652174, 0.46304347826087, -0.05
100234, 1.504347826087, 0.46304347826087, -0.05
100235, 1.5478260869565, 0.46304347826087, -0.05
100236, 1.5913043478261, 0.46304347826087, -0.05
100237, 1.6347826086957, 0.46304347826087, -0.05
100238, 1.6782608695652, 0.46304347826087, -0.05
100239, 1.7217391304348, 0.46304347826087, -0.05
100240, 1.7652173913043, 0.46304347826087, -0.05
100241, 1.8086956521739, 0.46304347826087, -0.05
100242, 1.8521739130435, 0.46304347826087, -0.05
100243, 1.895652173913, 0.46304347826087, -0.05
100244, 1.9391304347826, 0.46304347826087, -0.05
100245, 1.9826086956522, 0.46304347826087, -0.05
100246, 2.0260869565217, 0.46304347826087, -0.05
100247, 2.0695652173913, 0.46304347826087, -0.05
100248, 2.1130434782609, 0.46304347826087, -0.05
100249, 2.1565217391304, 0.46304347826087, -0.05
100250, 1.2434782608696, 0.41086956521739, -0.05
100251, 1.2869565217391, 0.41086956521739, -0.05
100252, 1.3304347826087, 0.41086956521739, -0.05
100253, 1.3739130434783, 0.41086956521739, -0.05
100254, 1.4173913043478, 0.41086956521739, -0.05
100255, 1.4608695652174, 0.41086956521739, -0.05
100256, 1.504347826087, 0.41086956521739, -0.05
100257, 1.5478260869565, 0.41086956521739, -0.05
100258, 1.5913043478261, 0.41086956521739, -0.05
100259, 1.6347826086957, 0.41086956521739, -0.05
100260, 1.6782608695652, 0.41086956521739, -0.05
100261, 1.7217391304348, 0.41086956521739, -0.05
100262, 1.7652173913043, 0.41086956521739, -0.05
100263, 1.8086956521739, 0.41086956521739, -0.05
100264, 1.8521739130435, 0.41086956521739, -0.05
100265, 1.895652173913, 0.41086956521739, -0.05
100266, 1.9391304347826, 0.41086956521739, -0.05
100267, 1.9826086956522, 0.41086956521739, -0.05
100268, 2.0260869565217, 0.41086956521739, -0.05
100269, 2.0695652173913, 0.41086956521739, -0.05
100270, 2.1130434782609, 0.41086956521739, -0.05
100271, 2.1565217391304, 0.41086956521739, -0.05
100272, 1.2434782608696, 0.35869565217391, -0.05
100273, 1.2869565217391, 0.35869565217391, -0.05
100274, 1.3304347826087, 0.35869565217391, -0.05
100275, 1.3739130434783, 0.35869565217391, -0.05
100276, 1.4173913043478, 0.35869565217391, -0.05
100277, 1.4608695652174, 0.35869565217391, -0.05
100278, 1.504347826087, 0.35869565217391, -0.05
100279, 1.5478260869565, 0.35869565217391, -0.05
100280, 1.5913043478261, 0.35869565217391, -0.05
100281, 1.6347826086957, 0.35869565217391, -0.05
100282, 1.6782608695652, 0.35869565217391, -0.05
100283, 1.7217391304348, 0.35869565217391, -0.05
100284, 1.7652173913043, 0.35869565217391, -0.05
100285, 1.8086956521739, 0.35869565217391, -0.05
100286, 1.8521739130435, 0.35869565217391, -0.05
100287, 1.895652173913, 0.35869565217391, -0.05
100288, 1.9391304347826, 0.35869565217391, -0.05
100289, 1.9826086956522, 0.35869565217391, -0.05
100290, 2.0260869565217, 0.35869565217391, -0.05
100291, 2.0695652173913, 0.35869565217391, -0.05
100292, 2.1130434782609, 0.35869565217391, -0.05
100293, 2.1565217391304, 0.35869565217391, -0.05
100294, 1.2434782608696, 0.30652173913044, -0.05
100295, 1.2869565217391, 0.30652173913043, -0.05
100296, 1.3304347826087, 0.30652173913043, -0.05
100297, 1.3739130434783, 0.30652173913044, -0.05
100298, 1.4173913043478, 0.30652173913043, -0.05
100299, 1.4608695652174, 0.30652173913043, -0.05
100300, 1.504347826087, 0.30652173913044, -0.05
100301, 1.5478260869565, 0.30652173913044, -0.05
100302, 1.5913043478261, 0.30652173913043, -0.05
100303, 1.6347826086957, 0.30652173913043, -0.05
100304, 1.6782608695652, 0.30652173913043, -0.05
100305, 1.7217391304348, 0.30652173913043, -0.05
100306, 1.7652173913043, 0.30652173913043, -0.05
100307, 1.8086956521739, 0.30652173913044, -0.05
100308, 1.8521739130435, 0.30652173913043, -0.05
100309, 1.895652173913, 0.30652173913043, -0.05
100310, 1.9391304347826, 0.30652173913043, -0.05
100311, 1.9826086956522, 0.30652173913044, -0.05
100312, 2.0260869565217, 0.30652173913044, -0.05
100313, 2.0695652173913, 0.30652173913043, -0.05
100314, 2.1130434782609, 0.30652173913043, -0.05
100315, 2.1565217391304, 0.30652173913043, -0.05
100316, 1.2434782608696, 0.25434782608696, -0.05
100317, 1.2869565217391, 0.25434782608696, -0.05
100318, 1.3304347826087, 0.25434782608696, -0.05
100319, 1.3739130434783, 0.25434782608696, -0.05
100320, 1.4173913043478, 0.25434782608696, -0.05
100321, 1.4608695652174, 0.25434782608696, -0.05
100322, 1.504347826087, 0.25434782608696, -0.05
100323, 1.5478260869565, 0.25434782608696, -0.05
100324, 1.5913043478261, 0.25434782608696, -0.05
100325, 1.6347826086957, 0.25434782608696, -0.05
100326, 1.6782608695652, 0.25434782608696, -0.05
100327, 1.7217391304348, 0.25434782608696, -0.05
100328, 1.7652173913043, 0.25434782608696, -0.05
100329, 1.8086956521739, 0.25434782608696, -0.05
100330, 1.8521739130435, 0.25434782608696, -0.05
100331, 1.895652173913, 0.25434782608696, -0.05
100332, 1.9391304347826, 0.25434782608696, -0.05
100333, 1.9826086956522, 0.25434782608696, -0.05
100334, 2.0260869565217, 0.25434782608696, -0.05
100335, 2.0695652173913, 0.25434782608696, -0.05
100336, 2.1130434782609, 0.25434782608696, -0.05
100337, 2.1565217391304, 0.25434782608696, -0.05
100338, 1.2434782608696, 0.20217391304348, -0.05
100339, 1.2869565217391, 0.20217391304348, -0.05
100340, 1.3304347826087, 0.20217391304348, -0.05
100341, 1.3739130434783, 0.20217391304348, -0.05
100342, 1.4173913043478, 0.20217391304348, -0.05
100343, 1.4608695652174, 0.20217391304348, -0.05
100344, 1.504347826087, 0.20217391304348, -0.05
100345, 1.5478260869565, 0.20217391304348, -0.05
100346, 1.5913043478261, 0.20217391304348, -0.05
100347, 1.6347826086957, 0.20217391304348, -0.05
100348, 1.6782608695652, 0.20217391304348, -0.05
100349, 1.7217391304348, 0.20217391304348, -0.05
100350, 1.7652173913043, 0.20217391304348, -0.05
100351, 1.8086956521739, 0.20217391304348, -0.05
100352, 1.8521739130435, 0.20217391304348, -0.05
100353, 1.895652173913, 0.20217391304348, -0.05
100354, 1.9391304347826, 0.20217391304348, -0.05
100355, 1.9826086956522, 0.20217391304348, -0.05
100356, 2.0260869565217, 0.20217391304348, -0.05
100357, 2.0695652173913, 0.20217391304348, -0.05
100358, 2.1130434782609, 0.20217391304348, -0.05
100359, 2.1565217391304, 0.20217391304348, -0.05
100360, 1.2434782608696, 1.2978260869565, -0.1
100361, 1.2869565217391, 1.2978260869565, -0.1
100362, 1.3304347826087, 1.2978260869565, -0.1
100363, 1.3739130434783, 1.2978260869565, -0.1
100364, 1.4173913043478, 1.2978260869565, -0.1
100365, 1.4608695652174, 1.2978260869565, -0.1
100366, 1.504347826087, 1.2978260869565, -0.1
100367, 1.5478260869565, 1.2978260869565, -0.1
100368, 1.5913043478261, 1.2978260869565, -0.1
100369, 1.6347826086957, 1.2978260869565, -0.1
100370, 1.6782608695652, 1.2978260869565, -0.1
100371, 1.7217391304348, 1.2978260869565, -0.1
100372, 1.7652173913043, 1.2978260869565, -0.1
100373, 1.8086956521739, 1.2978260869565, -0.1
100374, 1.8521739130435, 1.2978260869565, -0.1
100375, 1.895652173913, 1.2978260869565, -0.1
100376, 1.9391304347826, 1.2978260869565, -0.1
100377, 1.9826086956522, 1.2978260869565, -0.1
100378, 2.0260869565217, 1.2978260869565, -0.1
100379, 2.0695652173913, 1.2978260869565, -0.1
100380, 2.1130434782609, 1.2978260869565, -0.1
100381, 2.1565217391304, 1.2978260869565, -0.1
100382, 1.2434782608696, 1.245652173913, -0.1
100383, 1.2869565217391, 1.245652173913, -0.1
100384, 1.3304347826087, 1.245652173913, -0.1
100385, 1.3739130434783, 1.245652173913, -0.1
100386, 1.4173913043478, 1.245652173913, -0.1
100387, 1.4608695652174, 1.245652173913, -0.1
100388, 1.504347826087, 1.245652173913, -0.1
100389, 1.5478260869565, 1.245652173913, -0.1
100390, 1.5913043478261, 1.245652173913, -0.1
100391, 1.6347826086957, 1.245652173913, -0.1
100392, 1.6782608695652, 1.245652173913, -0.1
100393, 1.7217391304348, 1.245652173913, -0.1
100394, 1.7652173913043, 1.245652173913, -0.1
100395, 1.8086956521739, 1.245652173913, -0.1
100396, 1.8521739130435, 1.245652173913, -0.1
100397, 1.895652173913, 1.245652173913, -0.1
100398, 1.9391304347826, 1.245652173913, -0.1
100399, 1.9826086956522, 1.245652173913, -0.1
