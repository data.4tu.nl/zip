12672, 0.39130434782609, 1.55, 0.027777777777778
12673, 0.3695652173913, 1.55, 0.11111111111111
12674, 0.39130434782609, 1.55, 0.083333333333333
12675, 0.3695652173913, 1.55, 0.16666666666667
12676, 0.39130434782609, 1.55, 0.13888888888889
12677, 0.3695652173913, 1.55, 0.22222222222222
12678, 0.39130434782609, 1.55, 0.19444444444444
12679, 0.3695652173913, 1.55, 0.27777777777778
12680, 0.39130434782609, 1.55, 0.25
12681, 0.3695652173913, 1.55, 0.33333333333333
12682, 0.39130434782609, 1.55, 0.30555555555556
12683, 0.3695652173913, 1.55, 0.38888888888889
12684, 0.39130434782609, 1.55, 0.36111111111111
12685, 0.3695652173913, 1.55, 0.44444444444444
12686, 0.39130434782609, 1.55, 0.41666666666667
12687, 0.39130434782609, 1.55, 0.47222222222222
12688, 0.41304347826087, 1.55, 0.055555555555556
12689, 0.43478260869565, 1.55, 0.027777777777778
12690, 0.41304347826087, 1.55, 0.11111111111111
12691, 0.43478260869565, 1.55, 0.083333333333333
12692, 0.41304347826087, 1.55, 0.16666666666667
12693, 0.43478260869565, 1.55, 0.13888888888889
12694, 0.41304347826087, 1.55, 0.22222222222222
12695, 0.43478260869565, 1.55, 0.19444444444444
12696, 0.41304347826087, 1.55, 0.27777777777778
12697, 0.43478260869565, 1.55, 0.25
12698, 0.41304347826087, 1.55, 0.33333333333333
12699, 0.43478260869565, 1.55, 0.30555555555556
12700, 0.41304347826087, 1.55, 0.38888888888889
12701, 0.43478260869565, 1.55, 0.36111111111111
12702, 0.41304347826087, 1.55, 0.44444444444444
12703, 0.43478260869565, 1.55, 0.41666666666667
12704, 0.43478260869565, 1.55, 0.47222222222222
12705, 0.45652173913043, 1.55, 0.055555555555556
12706, 0.47826086956522, 1.55, 0.027777777777778
12707, 0.45652173913043, 1.55, 0.11111111111111
12708, 0.47826086956522, 1.55, 0.083333333333333
12709, 0.45652173913043, 1.55, 0.16666666666667
12710, 0.47826086956522, 1.55, 0.13888888888889
12711, 0.45652173913043, 1.55, 0.22222222222222
12712, 0.47826086956522, 1.55, 0.19444444444444
12713, 0.45652173913043, 1.55, 0.27777777777778
12714, 0.47826086956522, 1.55, 0.25
12715, 0.45652173913043, 1.55, 0.33333333333333
12716, 0.47826086956522, 1.55, 0.30555555555556
12717, 0.45652173913043, 1.55, 0.38888888888889
12718, 0.47826086956522, 1.55, 0.36111111111111
12719, 0.45652173913043, 1.55, 0.44444444444444
12720, 0.47826086956522, 1.55, 0.41666666666667
12721, 0.47826086956522, 1.55, 0.47222222222222
12722, 0.5, 1.55, 0.055555555555556
12723, 0.52173913043478, 1.55, 0.027777777777778
12724, 0.5, 1.55, 0.11111111111111
12725, 0.52173913043478, 1.55, 0.083333333333333
12726, 0.5, 1.55, 0.16666666666667
12727, 0.52173913043478, 1.55, 0.13888888888889
12728, 0.5, 1.55, 0.22222222222222
12729, 0.52173913043478, 1.55, 0.19444444444444
12730, 0.5, 1.55, 0.27777777777778
12731, 0.52173913043478, 1.55, 0.25
12732, 0.5, 1.55, 0.33333333333333
12733, 0.52173913043478, 1.55, 0.30555555555556
12734, 0.5, 1.55, 0.38888888888889
12735, 0.52173913043478, 1.55, 0.36111111111111
12736, 0.5, 1.55, 0.44444444444444
12737, 0.52173913043478, 1.55, 0.41666666666667
12738, 0.52173913043478, 1.55, 0.47222222222222
12739, 0.54347826086957, 1.55, 0.055555555555556
12740, 0.56521739130435, 1.55, 0.027777777777778
12741, 0.54347826086957, 1.55, 0.11111111111111
12742, 0.56521739130435, 1.55, 0.083333333333333
12743, 0.54347826086957, 1.55, 0.16666666666667
12744, 0.56521739130435, 1.55, 0.13888888888889
12745, 0.54347826086957, 1.55, 0.22222222222222
12746, 0.56521739130435, 1.55, 0.19444444444444
12747, 0.54347826086957, 1.55, 0.27777777777778
12748, 0.56521739130435, 1.55, 0.25
12749, 0.54347826086957, 1.55, 0.33333333333333
12750, 0.56521739130435, 1.55, 0.30555555555556
12751, 0.54347826086957, 1.55, 0.38888888888889
12752, 0.56521739130435, 1.55, 0.36111111111111
12753, 0.54347826086957, 1.55, 0.44444444444444
12754, 0.56521739130435, 1.55, 0.41666666666667
12755, 0.56521739130435, 1.55, 0.47222222222222
12756, 0.58695652173913, 1.55, 0.055555555555556
12757, 0.60869565217391, 1.55, 0.027777777777778
12758, 0.58695652173913, 1.55, 0.11111111111111
12759, 0.60869565217391, 1.55, 0.083333333333333
12760, 0.58695652173913, 1.55, 0.16666666666667
12761, 0.60869565217391, 1.55, 0.13888888888889
12762, 0.58695652173913, 1.55, 0.22222222222222
12763, 0.60869565217391, 1.55, 0.19444444444444
12764, 0.58695652173913, 1.55, 0.27777777777778
12765, 0.60869565217391, 1.55, 0.25
12766, 0.58695652173913, 1.55, 0.33333333333333
12767, 0.60869565217391, 1.55, 0.30555555555556
12768, 0.58695652173913, 1.55, 0.38888888888889
12769, 0.60869565217391, 1.55, 0.36111111111111
12770, 0.58695652173913, 1.55, 0.44444444444444
12771, 0.60869565217391, 1.55, 0.41666666666667
12772, 0.60869565217391, 1.55, 0.47222222222222
12773, 0.6304347826087, 1.55, 0.055555555555556
12774, 0.65217391304348, 1.55, 0.027777777777778
12775, 0.6304347826087, 1.55, 0.11111111111111
12776, 0.65217391304348, 1.55, 0.083333333333333
12777, 0.6304347826087, 1.55, 0.16666666666667
12778, 0.65217391304348, 1.55, 0.13888888888889
12779, 0.6304347826087, 1.55, 0.22222222222222
12780, 0.65217391304348, 1.55, 0.19444444444444
12781, 0.6304347826087, 1.55, 0.27777777777778
12782, 0.65217391304348, 1.55, 0.25
12783, 0.6304347826087, 1.55, 0.33333333333333
12784, 0.65217391304348, 1.55, 0.30555555555556
12785, 0.6304347826087, 1.55, 0.38888888888889
12786, 0.65217391304348, 1.55, 0.36111111111111
12787, 0.6304347826087, 1.55, 0.44444444444444
12788, 0.65217391304348, 1.55, 0.41666666666667
12789, 0.65217391304348, 1.55, 0.47222222222222
12790, 0.67391304347826, 1.55, 0.055555555555556
12791, 0.69565217391304, 1.55, 0.027777777777778
12792, 0.67391304347826, 1.55, 0.11111111111111
12793, 0.69565217391304, 1.55, 0.083333333333333
12794, 0.67391304347826, 1.55, 0.16666666666667
12795, 0.69565217391304, 1.55, 0.13888888888889
12796, 0.67391304347826, 1.55, 0.22222222222222
12797, 0.69565217391304, 1.55, 0.19444444444444
12798, 0.67391304347826, 1.55, 0.27777777777778
12799, 0.69565217391304, 1.55, 0.25
12800, 0.67391304347826, 1.55, 0.33333333333333
12801, 0.69565217391304, 1.55, 0.30555555555556
12802, 0.67391304347826, 1.55, 0.38888888888889
12803, 0.69565217391304, 1.55, 0.36111111111111
12804, 0.67391304347826, 1.55, 0.44444444444444
12805, 0.69565217391304, 1.55, 0.41666666666667
12806, 0.69565217391304, 1.55, 0.47222222222222
12807, 0.71739130434783, 1.55, 0.055555555555556
12808, 0.73913043478261, 1.55, 0.027777777777778
12809, 0.71739130434783, 1.55, 0.11111111111111
12810, 0.73913043478261, 1.55, 0.083333333333333
12811, 0.71739130434783, 1.55, 0.16666666666667
12812, 0.73913043478261, 1.55, 0.13888888888889
12813, 0.71739130434783, 1.55, 0.22222222222222
12814, 0.73913043478261, 1.55, 0.19444444444444
12815, 0.71739130434783, 1.55, 0.27777777777778
12816, 0.73913043478261, 1.55, 0.25
12817, 0.71739130434783, 1.55, 0.33333333333333
12818, 0.73913043478261, 1.55, 0.30555555555556
12819, 0.71739130434783, 1.55, 0.38888888888889
12820, 0.73913043478261, 1.55, 0.36111111111111
12821, 0.71739130434783, 1.55, 0.44444444444444
12822, 0.73913043478261, 1.55, 0.41666666666667
12823, 0.73913043478261, 1.55, 0.47222222222222
12824, 0.76086956521739, 1.55, 0.055555555555556
12825, 0.78260869565217, 1.55, 0.027777777777778
12826, 0.76086956521739, 1.55, 0.11111111111111
12827, 0.78260869565217, 1.55, 0.083333333333333
12828, 0.76086956521739, 1.55, 0.16666666666667
12829, 0.78260869565217, 1.55, 0.13888888888889
12830, 0.76086956521739, 1.55, 0.22222222222222
12831, 0.78260869565217, 1.55, 0.19444444444444
12832, 0.76086956521739, 1.55, 0.27777777777778
12833, 0.78260869565217, 1.55, 0.25
12834, 0.76086956521739, 1.55, 0.33333333333333
12835, 0.78260869565217, 1.55, 0.30555555555556
12836, 0.76086956521739, 1.55, 0.38888888888889
12837, 0.78260869565217, 1.55, 0.36111111111111
12838, 0.76086956521739, 1.55, 0.44444444444444
12839, 0.78260869565217, 1.55, 0.41666666666667
12840, 0.78260869565217, 1.55, 0.47222222222222
12841, 0.80434782608696, 1.55, 0.055555555555556
12842, 0.82608695652174, 1.55, 0.027777777777778
12843, 0.80434782608696, 1.55, 0.11111111111111
12844, 0.82608695652174, 1.55, 0.083333333333333
12845, 0.80434782608696, 1.55, 0.16666666666667
12846, 0.82608695652174, 1.55, 0.13888888888889
12847, 0.80434782608696, 1.55, 0.22222222222222
12848, 0.82608695652174, 1.55, 0.19444444444444
12849, 0.80434782608696, 1.55, 0.27777777777778
12850, 0.82608695652174, 1.55, 0.25
12851, 0.80434782608696, 1.55, 0.33333333333333
12852, 0.82608695652174, 1.55, 0.30555555555556
12853, 0.80434782608696, 1.55, 0.38888888888889
12854, 0.82608695652174, 1.55, 0.36111111111111
12855, 0.80434782608696, 1.55, 0.44444444444444
12856, 0.82608695652174, 1.55, 0.41666666666667
12857, 0.82608695652174, 1.55, 0.47222222222222
12858, 0.84782608695652, 1.55, 0.055555555555556
12859, 0.8695652173913, 1.55, 0.027777777777778
12860, 0.84782608695652, 1.55, 0.11111111111111
12861, 0.8695652173913, 1.55, 0.083333333333333
12862, 0.84782608695652, 1.55, 0.16666666666667
12863, 0.8695652173913, 1.55, 0.13888888888889
12864, 0.84782608695652, 1.55, 0.22222222222222
12865, 0.8695652173913, 1.55, 0.19444444444444
12866, 0.84782608695652, 1.55, 0.27777777777778
12867, 0.8695652173913, 1.55, 0.25
12868, 0.84782608695652, 1.55, 0.33333333333333
12869, 0.8695652173913, 1.55, 0.30555555555556
12870, 0.84782608695652, 1.55, 0.38888888888889
12871, 0.8695652173913, 1.55, 0.36111111111111
12872, 0.84782608695652, 1.55, 0.44444444444444
12873, 0.8695652173913, 1.55, 0.41666666666667
12874, 0.8695652173913, 1.55, 0.47222222222222
12875, 0.89130434782609, 1.55, 0.055555555555556
12876, 0.91304347826087, 1.55, 0.027777777777778
12877, 0.89130434782609, 1.55, 0.11111111111111
12878, 0.91304347826087, 1.55, 0.083333333333333
12879, 0.89130434782609, 1.55, 0.16666666666667
12880, 0.91304347826087, 1.55, 0.13888888888889
12881, 0.89130434782609, 1.55, 0.22222222222222
12882, 0.91304347826087, 1.55, 0.19444444444444
12883, 0.89130434782609, 1.55, 0.27777777777778
12884, 0.91304347826087, 1.55, 0.25
12885, 0.89130434782609, 1.55, 0.33333333333333
12886, 0.91304347826087, 1.55, 0.30555555555556
12887, 0.89130434782609, 1.55, 0.38888888888889
12888, 0.91304347826087, 1.55, 0.36111111111111
12889, 0.89130434782609, 1.55, 0.44444444444444
12890, 0.91304347826087, 1.55, 0.41666666666667
12891, 0.91304347826087, 1.55, 0.47222222222222
12892, 0.93478260869565, 1.55, 0.055555555555556
12893, 0.95652173913043, 1.55, 0.027777777777778
12894, 0.93478260869565, 1.55, 0.11111111111111
12895, 0.95652173913043, 1.55, 0.083333333333333
12896, 0.93478260869565, 1.55, 0.16666666666667
12897, 0.95652173913043, 1.55, 0.13888888888889
12898, 0.93478260869565, 1.55, 0.22222222222222
12899, 0.95652173913043, 1.55, 0.19444444444444
12900, 0.93478260869565, 1.55, 0.27777777777778
12901, 0.95652173913043, 1.55, 0.25
12902, 0.93478260869565, 1.55, 0.33333333333333
12903, 0.95652173913043, 1.55, 0.30555555555556
12904, 0.93478260869565, 1.55, 0.38888888888889
12905, 0.95652173913043, 1.55, 0.36111111111111
12906, 0.93478260869565, 1.55, 0.44444444444444
12907, 0.95652173913043, 1.55, 0.41666666666667
12908, 0.95652173913043, 1.55, 0.47222222222222
12909, 0.97826086956522, 1.55, 0.055555555555556
12910, 0.97826086956522, 1.55, 0.11111111111111
12911, 0.97826086956522, 1.55, 0.16666666666667
12912, 0.97826086956522, 1.55, 0.22222222222222
12913, 0.97826086956522, 1.55, 0.27777777777778
12914, 0.97826086956522, 1.55, 0.33333333333333
12915, 0.97826086956522, 1.55, 0.38888888888889
12916, 0.97826086956522, 1.55, 0.44444444444444
12917, 1.05, 1.4833333333333, 0.5
12918, 1.05, 1.5166666666667, 0.5
12919, 1.1, 1.4833333333333, 0.5
12920, 1.1, 1.5166666666667, 0.5
12921, 1.15, 1.4833333333333, 0.5
12922, 1.15, 1.5166666666667, 0.5
12923, 1.05, 1.4666666666667, 0.5
12924, 1.025, 1.4833333333333, 0.5
12925, 1.05, 1.5, 0.5
12926, 1.025, 1.5166666666667, 0.5
12927, 1.05, 1.5333333333333, 0.5
12928, 1.1, 1.4666666666667, 0.5
12929, 1.075, 1.4833333333333, 0.5
12930, 1.1, 1.5, 0.5
12931, 1.075, 1.5166666666667, 0.5
12932, 1.1, 1.5333333333333, 0.5
12933, 1.15, 1.4666666666667, 0.5
12934, 1.125, 1.4833333333333, 0.5
12935, 1.15, 1.5, 0.5
12936, 1.125, 1.5166666666667, 0.5
12937, 1.15, 1.5333333333333, 0.5
12938, 1.175, 1.4833333333333, 0.5
12939, 1.175, 1.5166666666667, 0.5
12940, 1.05, 1.4833333333333, 0
12941, 1.05, 1.5166666666667, 0
12942, 1.1, 1.4833333333333, 0
12943, 1.1, 1.5166666666667, 0
12944, 1.15, 1.4833333333333, 0
12945, 1.15, 1.5166666666667, 0
12946, 1.025, 1.4833333333333, 0
12947, 1.05, 1.4666666666667, 0
12948, 1.025, 1.5166666666667, 0
12949, 1.05, 1.5, 0
12950, 1.05, 1.5333333333333, 0
12951, 1.075, 1.4833333333333, 0
12952, 1.1, 1.4666666666667, 0
12953, 1.075, 1.5166666666667, 0
12954, 1.1, 1.5, 0
12955, 1.1, 1.5333333333333, 0
12956, 1.125, 1.4833333333333, 0
12957, 1.15, 1.4666666666667, 0
12958, 1.125, 1.5166666666667, 0
12959, 1.15, 1.5, 0
12960, 1.15, 1.5333333333333, 0
12961, 1.175, 1.4833333333333, 0
12962, 1.175, 1.5166666666667, 0
12963, 1.05, 1.45, 0.44444444444444
12964, 1.05, 1.45, 0.38888888888889
12965, 1.05, 1.45, 0.33333333333333
12966, 1.05, 1.45, 0.27777777777778
12967, 1.05, 1.45, 0.22222222222222
12968, 1.05, 1.45, 0.16666666666667
12969, 1.05, 1.45, 0.11111111111111
12970, 1.05, 1.45, 0.055555555555556
12971, 1.1, 1.45, 0.44444444444444
12972, 1.1, 1.45, 0.38888888888889
12973, 1.1, 1.45, 0.33333333333333
12974, 1.1, 1.45, 0.27777777777778
12975, 1.1, 1.45, 0.22222222222222
12976, 1.1, 1.45, 0.16666666666667
12977, 1.1, 1.45, 0.11111111111111
12978, 1.1, 1.45, 0.055555555555556
12979, 1.15, 1.45, 0.44444444444444
12980, 1.15, 1.45, 0.38888888888889
12981, 1.15, 1.45, 0.33333333333333
12982, 1.15, 1.45, 0.27777777777778
12983, 1.15, 1.45, 0.22222222222222
12984, 1.15, 1.45, 0.16666666666667
12985, 1.15, 1.45, 0.11111111111111
12986, 1.15, 1.45, 0.055555555555556
12987, 1.025, 1.45, 0.44444444444444
12988, 1.05, 1.45, 0.47222222222222
12989, 1.025, 1.45, 0.38888888888889
12990, 1.05, 1.45, 0.41666666666667
12991, 1.025, 1.45, 0.33333333333333
12992, 1.05, 1.45, 0.36111111111111
12993, 1.025, 1.45, 0.27777777777778
12994, 1.05, 1.45, 0.30555555555556
12995, 1.025, 1.45, 0.22222222222222
12996, 1.05, 1.45, 0.25
12997, 1.025, 1.45, 0.16666666666667
12998, 1.05, 1.45, 0.19444444444444
12999, 1.025, 1.45, 0.11111111111111
13000, 1.05, 1.45, 0.13888888888889
13001, 1.025, 1.45, 0.055555555555556
13002, 1.05, 1.45, 0.083333333333333
13003, 1.05, 1.45, 0.027777777777778
13004, 1.075, 1.45, 0.44444444444444
13005, 1.1, 1.45, 0.47222222222222
13006, 1.075, 1.45, 0.38888888888889
13007, 1.1, 1.45, 0.41666666666667
13008, 1.075, 1.45, 0.33333333333333
13009, 1.1, 1.45, 0.36111111111111
13010, 1.075, 1.45, 0.27777777777778
13011, 1.1, 1.45, 0.30555555555556
13012, 1.075, 1.45, 0.22222222222222
13013, 1.1, 1.45, 0.25
13014, 1.075, 1.45, 0.16666666666667
13015, 1.1, 1.45, 0.19444444444444
13016, 1.075, 1.45, 0.11111111111111
13017, 1.1, 1.45, 0.13888888888889
13018, 1.075, 1.45, 0.055555555555556
13019, 1.1, 1.45, 0.083333333333333
13020, 1.1, 1.45, 0.027777777777778
13021, 1.125, 1.45, 0.44444444444444
13022, 1.15, 1.45, 0.47222222222222
13023, 1.125, 1.45, 0.38888888888889
13024, 1.15, 1.45, 0.41666666666667
13025, 1.125, 1.45, 0.33333333333333
13026, 1.15, 1.45, 0.36111111111111
13027, 1.125, 1.45, 0.27777777777778
13028, 1.15, 1.45, 0.30555555555556
13029, 1.125, 1.45, 0.22222222222222
13030, 1.15, 1.45, 0.25
13031, 1.125, 1.45, 0.16666666666667
13032, 1.15, 1.45, 0.19444444444444
13033, 1.125, 1.45, 0.11111111111111
13034, 1.15, 1.45, 0.13888888888889
13035, 1.125, 1.45, 0.055555555555556
13036, 1.15, 1.45, 0.083333333333333
13037, 1.15, 1.45, 0.027777777777778
13038, 1.175, 1.45, 0.44444444444444
13039, 1.175, 1.45, 0.38888888888889
13040, 1.175, 1.45, 0.33333333333333
13041, 1.175, 1.45, 0.27777777777778
13042, 1.175, 1.45, 0.22222222222222
13043, 1.175, 1.45, 0.16666666666667
13044, 1.175, 1.45, 0.11111111111111
13045, 1.175, 1.45, 0.055555555555556
13046, 1.05, 1.55, 0.44444444444444
13047, 1.05, 1.55, 0.38888888888889
13048, 1.05, 1.55, 0.33333333333333
13049, 1.05, 1.55, 0.27777777777778
13050, 1.05, 1.55, 0.22222222222222
13051, 1.05, 1.55, 0.16666666666667
13052, 1.05, 1.55, 0.11111111111111
13053, 1.05, 1.55, 0.055555555555556
13054, 1.1, 1.55, 0.44444444444444
13055, 1.1, 1.55, 0.38888888888889
13056, 1.1, 1.55, 0.33333333333333
13057, 1.1, 1.55, 0.27777777777778
13058, 1.1, 1.55, 0.22222222222222
13059, 1.1, 1.55, 0.16666666666667
13060, 1.1, 1.55, 0.11111111111111
13061, 1.1, 1.55, 0.055555555555556
13062, 1.15, 1.55, 0.44444444444444
13063, 1.15, 1.55, 0.38888888888889
13064, 1.15, 1.55, 0.33333333333333
13065, 1.15, 1.55, 0.27777777777778
13066, 1.15, 1.55, 0.22222222222222
13067, 1.15, 1.55, 0.16666666666667
13068, 1.15, 1.55, 0.11111111111111
13069, 1.15, 1.55, 0.055555555555556
13070, 1.05, 1.55, 0.47222222222222
13071, 1.025, 1.55, 0.44444444444444
13072, 1.05, 1.55, 0.41666666666667
13073, 1.025, 1.55, 0.38888888888889
13074, 1.05, 1.55, 0.36111111111111
13075, 1.025, 1.55, 0.33333333333333
13076, 1.05, 1.55, 0.30555555555556
13077, 1.025, 1.55, 0.27777777777778
13078, 1.05, 1.55, 0.25
13079, 1.025, 1.55, 0.22222222222222
13080, 1.05, 1.55, 0.19444444444444
13081, 1.025, 1.55, 0.16666666666667
13082, 1.05, 1.55, 0.13888888888889
13083, 1.025, 1.55, 0.11111111111111
13084, 1.05, 1.55, 0.083333333333333
13085, 1.025, 1.55, 0.055555555555556
13086, 1.05, 1.55, 0.027777777777778
13087, 1.1, 1.55, 0.47222222222222
13088, 1.075, 1.55, 0.44444444444444
13089, 1.1, 1.55, 0.41666666666667
13090, 1.075, 1.55, 0.38888888888889
13091, 1.1, 1.55, 0.36111111111111
13092, 1.075, 1.55, 0.33333333333333
13093, 1.1, 1.55, 0.30555555555556
13094, 1.075, 1.55, 0.27777777777778
13095, 1.1, 1.55, 0.25
13096, 1.075, 1.55, 0.22222222222222
13097, 1.1, 1.55, 0.19444444444444
13098, 1.075, 1.55, 0.16666666666667
13099, 1.1, 1.55, 0.13888888888889
13100, 1.075, 1.55, 0.11111111111111
13101, 1.1, 1.55, 0.083333333333333
13102, 1.075, 1.55, 0.055555555555556
13103, 1.1, 1.55, 0.027777777777778
13104, 1.15, 1.55, 0.47222222222222
13105, 1.125, 1.55, 0.44444444444444
13106, 1.15, 1.55, 0.41666666666667
13107, 1.125, 1.55, 0.38888888888889
13108, 1.15, 1.55, 0.36111111111111
13109, 1.125, 1.55, 0.33333333333333
13110, 1.15, 1.55, 0.30555555555556
13111, 1.125, 1.55, 0.27777777777778
13112, 1.15, 1.55, 0.25
13113, 1.125, 1.55, 0.22222222222222
13114, 1.15, 1.55, 0.19444444444444
13115, 1.125, 1.55, 0.16666666666667
13116, 1.15, 1.55, 0.13888888888889
13117, 1.125, 1.55, 0.11111111111111
13118, 1.15, 1.55, 0.083333333333333
13119, 1.125, 1.55, 0.055555555555556
13120, 1.15, 1.55, 0.027777777777778
13121, 1.175, 1.55, 0.44444444444444
13122, 1.175, 1.55, 0.38888888888889
13123, 1.175, 1.55, 0.33333333333333
13124, 1.175, 1.55, 0.27777777777778
13125, 1.175, 1.55, 0.22222222222222
13126, 1.175, 1.55, 0.16666666666667
13127, 1.175, 1.55, 0.11111111111111
13128, 1.175, 1.55, 0.055555555555556
13129, 1.2, 1.4833333333333, 0.44444444444444
13130, 1.2, 1.4833333333333, 0.38888888888889
13131, 1.2, 1.4833333333333, 0.33333333333333
13132, 1.2, 1.4833333333333, 0.27777777777778
13133, 1.2, 1.4833333333333, 0.22222222222222
13134, 1.2, 1.4833333333333, 0.16666666666667
13135, 1.2, 1.4833333333333, 0.11111111111111
13136, 1.2, 1.4833333333333, 0.055555555555556
13137, 1.2, 1.5166666666667, 0.44444444444444
13138, 1.2, 1.5166666666667, 0.38888888888889
13139, 1.2, 1.5166666666667, 0.33333333333333
13140, 1.2, 1.5166666666667, 0.27777777777778
13141, 1.2, 1.5166666666667, 0.22222222222222
13142, 1.2, 1.5166666666667, 0.16666666666667
13143, 1.2, 1.5166666666667, 0.11111111111111
13144, 1.2, 1.5166666666667, 0.055555555555556
13145, 1.2, 1.4666666666667, 0.44444444444444
13146, 1.2, 1.4833333333333, 0.47222222222222
13147, 1.2, 1.4666666666667, 0.38888888888889
13148, 1.2, 1.4833333333333, 0.41666666666667
13149, 1.2, 1.4666666666667, 0.33333333333333
13150, 1.2, 1.4833333333333, 0.36111111111111
13151, 1.2, 1.4666666666667, 0.27777777777778
13152, 1.2, 1.4833333333333, 0.30555555555556
13153, 1.2, 1.4666666666667, 0.22222222222222
13154, 1.2, 1.4833333333333, 0.25
13155, 1.2, 1.4666666666667, 0.16666666666667
13156, 1.2, 1.4833333333333, 0.19444444444444
13157, 1.2, 1.4666666666667, 0.11111111111111
13158, 1.2, 1.4833333333333, 0.13888888888889
13159, 1.2, 1.4666666666667, 0.055555555555556
13160, 1.2, 1.4833333333333, 0.083333333333333
13161, 1.2, 1.4833333333333, 0.027777777777778
13162, 1.2, 1.5, 0.44444444444444
13163, 1.2, 1.5166666666667, 0.47222222222222
13164, 1.2, 1.5, 0.38888888888889
13165, 1.2, 1.5166666666667, 0.41666666666667
13166, 1.2, 1.5, 0.33333333333333
13167, 1.2, 1.5166666666667, 0.36111111111111
13168, 1.2, 1.5, 0.27777777777778
13169, 1.2, 1.5166666666667, 0.30555555555556
13170, 1.2, 1.5, 0.22222222222222
13171, 1.2, 1.5166666666667, 0.25
13172, 1.2, 1.5, 0.16666666666667
13173, 1.2, 1.5166666666667, 0.19444444444444
13174, 1.2, 1.5, 0.11111111111111
13175, 1.2, 1.5166666666667, 0.13888888888889
13176, 1.2, 1.5, 0.055555555555556
13177, 1.2, 1.5166666666667, 0.083333333333333
13178, 1.2, 1.5166666666667, 0.027777777777778
13179, 1.2, 1.5333333333333, 0.44444444444444
13180, 1.2, 1.5333333333333, 0.38888888888889
13181, 1.2, 1.5333333333333, 0.33333333333333
13182, 1.2, 1.5333333333333, 0.27777777777778
13183, 1.2, 1.5333333333333, 0.22222222222222
13184, 1.2, 1.5333333333333, 0.16666666666667
13185, 1.2, 1.5333333333333, 0.11111111111111
13186, 1.2, 1.5333333333333, 0.055555555555556
13187, 1.05, 1.6, 0.5
13188, 1.1, 1.6, 0.5
13189, 1.15, 1.6, 0.5
13190, 1.05, 1.65, 0.5
13191, 1.1, 1.65, 0.5
13192, 1.15, 1.65, 0.5
13193, 1.05, 1.7, 0.5
13194, 1.1, 1.7, 0.5
13195, 1.15, 1.7, 0.5
13196, 1.05, 1.575, 0.5
13197, 1.025, 1.6, 0.5
13198, 1.1, 1.575, 0.5
13199, 1.075, 1.6, 0.5
13200, 1.15, 1.575, 0.5
13201, 1.125, 1.6, 0.5
13202, 1.175, 1.6, 0.5
13203, 1.05, 1.625, 0.5
13204, 1.025, 1.65, 0.5
13205, 1.1, 1.625, 0.5
13206, 1.075, 1.65, 0.5
13207, 1.15, 1.625, 0.5
13208, 1.125, 1.65, 0.5
13209, 1.175, 1.65, 0.5
13210, 1.05, 1.675, 0.5
13211, 1.025, 1.7, 0.5
13212, 1.1, 1.675, 0.5
13213, 1.075, 1.7, 0.5
13214, 1.15, 1.675, 0.5
13215, 1.125, 1.7, 0.5
13216, 1.175, 1.7, 0.5
13217, 1.05, 1.725, 0.5
13218, 1.1, 1.725, 0.5
13219, 1.15, 1.725, 0.5
13220, 1.05, 1.6, 0
13221, 1.1, 1.6, 0
13222, 1.15, 1.6, 0
13223, 1.05, 1.65, 0
13224, 1.1, 1.65, 0
13225, 1.15, 1.65, 0
13226, 1.05, 1.7, 0
13227, 1.1, 1.7, 0
13228, 1.15, 1.7, 0
13229, 1.025, 1.6, 0
13230, 1.05, 1.575, 0
13231, 1.075, 1.6, 0
13232, 1.1, 1.575, 0
13233, 1.125, 1.6, 0
13234, 1.15, 1.575, 0
13235, 1.175, 1.6, 0
13236, 1.025, 1.65, 0
13237, 1.05, 1.625, 0
13238, 1.075, 1.65, 0
13239, 1.1, 1.625, 0
13240, 1.125, 1.65, 0
13241, 1.15, 1.625, 0
13242, 1.175, 1.65, 0
13243, 1.025, 1.7, 0
13244, 1.05, 1.675, 0
13245, 1.075, 1.7, 0
13246, 1.1, 1.675, 0
13247, 1.125, 1.7, 0
13248, 1.15, 1.675, 0
13249, 1.175, 1.7, 0
13250, 1.05, 1.725, 0
13251, 1.1, 1.725, 0
13252, 1.15, 1.725, 0
13253, 1, 1.6, 0.44444444444444
13254, 1, 1.6, 0.38888888888889
13255, 1, 1.6, 0.33333333333333
13256, 1, 1.6, 0.27777777777778
13257, 1, 1.6, 0.22222222222222
13258, 1, 1.6, 0.16666666666667
13259, 1, 1.6, 0.11111111111111
13260, 1, 1.6, 0.055555555555556
13261, 1, 1.65, 0.44444444444444
13262, 1, 1.65, 0.38888888888889
13263, 1, 1.65, 0.33333333333333
13264, 1, 1.65, 0.27777777777778
13265, 1, 1.65, 0.22222222222222
13266, 1, 1.65, 0.16666666666667
13267, 1, 1.65, 0.11111111111111
13268, 1, 1.65, 0.055555555555556
13269, 1, 1.7, 0.44444444444444
13270, 1, 1.7, 0.38888888888889
13271, 1, 1.7, 0.33333333333333
13272, 1, 1.7, 0.27777777777778
13273, 1, 1.7, 0.22222222222222
13274, 1, 1.7, 0.16666666666667
13275, 1, 1.7, 0.11111111111111
13276, 1, 1.7, 0.055555555555556
13277, 1, 1.6, 0.47222222222222
13278, 1, 1.575, 0.44444444444444
13279, 1, 1.6, 0.41666666666667
13280, 1, 1.575, 0.38888888888889
13281, 1, 1.6, 0.36111111111111
13282, 1, 1.575, 0.33333333333333
13283, 1, 1.6, 0.30555555555556
13284, 1, 1.575, 0.27777777777778
13285, 1, 1.6, 0.25
13286, 1, 1.575, 0.22222222222222
13287, 1, 1.6, 0.19444444444444
13288, 1, 1.575, 0.16666666666667
13289, 1, 1.6, 0.13888888888889
13290, 1, 1.575, 0.11111111111111
13291, 1, 1.6, 0.083333333333333
13292, 1, 1.575, 0.055555555555556
13293, 1, 1.6, 0.027777777777778
13294, 1, 1.65, 0.47222222222222
13295, 1, 1.625, 0.44444444444444
13296, 1, 1.65, 0.41666666666667
13297, 1, 1.625, 0.38888888888889
13298, 1, 1.65, 0.36111111111111
13299, 1, 1.625, 0.33333333333333
13300, 1, 1.65, 0.30555555555556
13301, 1, 1.625, 0.27777777777778
13302, 1, 1.65, 0.25
13303, 1, 1.625, 0.22222222222222
13304, 1, 1.65, 0.19444444444444
13305, 1, 1.625, 0.16666666666667
13306, 1, 1.65, 0.13888888888889
13307, 1, 1.625, 0.11111111111111
13308, 1, 1.65, 0.083333333333333
13309, 1, 1.625, 0.055555555555556
13310, 1, 1.65, 0.027777777777778
13311, 1, 1.7, 0.47222222222222
13312, 1, 1.675, 0.44444444444444
13313, 1, 1.7, 0.41666666666667
13314, 1, 1.675, 0.38888888888889
13315, 1, 1.7, 0.36111111111111
13316, 1, 1.675, 0.33333333333333
13317, 1, 1.7, 0.30555555555556
13318, 1, 1.675, 0.27777777777778
13319, 1, 1.7, 0.25
13320, 1, 1.675, 0.22222222222222
13321, 1, 1.7, 0.19444444444444
13322, 1, 1.675, 0.16666666666667
13323, 1, 1.7, 0.13888888888889
13324, 1, 1.675, 0.11111111111111
13325, 1, 1.7, 0.083333333333333
13326, 1, 1.675, 0.055555555555556
13327, 1, 1.7, 0.027777777777778
13328, 1, 1.725, 0.44444444444444
13329, 1, 1.725, 0.38888888888889
13330, 1, 1.725, 0.33333333333333
13331, 1, 1.725, 0.27777777777778
13332, 1, 1.725, 0.22222222222222
13333, 1, 1.725, 0.16666666666667
13334, 1, 1.725, 0.11111111111111
13335, 1, 1.725, 0.055555555555556
13336, 1.2, 1.6, 0.44444444444444
13337, 1.2, 1.6, 0.38888888888889
13338, 1.2, 1.6, 0.33333333333333
13339, 1.2, 1.6, 0.27777777777778
13340, 1.2, 1.6, 0.22222222222222
13341, 1.2, 1.6, 0.16666666666667
13342, 1.2, 1.6, 0.11111111111111
13343, 1.2, 1.6, 0.055555555555556
13344, 1.2, 1.65, 0.44444444444444
13345, 1.2, 1.65, 0.38888888888889
13346, 1.2, 1.65, 0.33333333333333
13347, 1.2, 1.65, 0.27777777777778
13348, 1.2, 1.65, 0.22222222222222
13349, 1.2, 1.65, 0.16666666666667
13350, 1.2, 1.65, 0.11111111111111
13351, 1.2, 1.65, 0.055555555555556
13352, 1.2, 1.7, 0.44444444444444
13353, 1.2, 1.7, 0.38888888888889
13354, 1.2, 1.7, 0.33333333333333
13355, 1.2, 1.7, 0.27777777777778
13356, 1.2, 1.7, 0.22222222222222
13357, 1.2, 1.7, 0.16666666666667
13358, 1.2, 1.7, 0.11111111111111
13359, 1.2, 1.7, 0.055555555555556
13360, 1.2, 1.575, 0.44444444444444
13361, 1.2, 1.6, 0.47222222222222
13362, 1.2, 1.575, 0.38888888888889
13363, 1.2, 1.6, 0.41666666666667
13364, 1.2, 1.575, 0.33333333333333
13365, 1.2, 1.6, 0.36111111111111
13366, 1.2, 1.575, 0.27777777777778
13367, 1.2, 1.6, 0.30555555555556
13368, 1.2, 1.575, 0.22222222222222
13369, 1.2, 1.6, 0.25
13370, 1.2, 1.575, 0.16666666666667
13371, 1.2, 1.6, 0.19444444444444
13372, 1.2, 1.575, 0.11111111111111
13373, 1.2, 1.6, 0.13888888888889
13374, 1.2, 1.575, 0.055555555555556
13375, 1.2, 1.6, 0.083333333333333
13376, 1.2, 1.6, 0.027777777777778
13377, 1.2, 1.625, 0.44444444444444
13378, 1.2, 1.65, 0.47222222222222
13379, 1.2, 1.625, 0.38888888888889
13380, 1.2, 1.65, 0.41666666666667
13381, 1.2, 1.625, 0.33333333333333
13382, 1.2, 1.65, 0.36111111111111
13383, 1.2, 1.625, 0.27777777777778
13384, 1.2, 1.65, 0.30555555555556
13385, 1.2, 1.625, 0.22222222222222
13386, 1.2, 1.65, 0.25
13387, 1.2, 1.625, 0.16666666666667
13388, 1.2, 1.65, 0.19444444444444
13389, 1.2, 1.625, 0.11111111111111
13390, 1.2, 1.65, 0.13888888888889
13391, 1.2, 1.625, 0.055555555555556
13392, 1.2, 1.65, 0.083333333333333
13393, 1.2, 1.65, 0.027777777777778
13394, 1.2, 1.675, 0.44444444444444
13395, 1.2, 1.7, 0.47222222222222
13396, 1.2, 1.675, 0.38888888888889
13397, 1.2, 1.7, 0.41666666666667
13398, 1.2, 1.675, 0.33333333333333
13399, 1.2, 1.7, 0.36111111111111
13400, 1.2, 1.675, 0.27777777777778
13401, 1.2, 1.7, 0.30555555555556
13402, 1.2, 1.675, 0.22222222222222
13403, 1.2, 1.7, 0.25
13404, 1.2, 1.675, 0.16666666666667
13405, 1.2, 1.7, 0.19444444444444
13406, 1.2, 1.675, 0.11111111111111
13407, 1.2, 1.7, 0.13888888888889
13408, 1.2, 1.675, 0.055555555555556
13409, 1.2, 1.7, 0.083333333333333
13410, 1.2, 1.7, 0.027777777777778
13411, 1.2, 1.725, 0.44444444444444
13412, 1.2, 1.725, 0.38888888888889
13413, 1.2, 1.725, 0.33333333333333
13414, 1.2, 1.725, 0.27777777777778
13415, 1.2, 1.725, 0.22222222222222
13416, 1.2, 1.725, 0.16666666666667
13417, 1.2, 1.725, 0.11111111111111
13418, 1.2, 1.725, 0.055555555555556
13419, 1.05, 1.75, 0.44444444444444
13420, 1.05, 1.75, 0.38888888888889
13421, 1.05, 1.75, 0.33333333333333
13422, 1.05, 1.75, 0.27777777777778
13423, 1.05, 1.75, 0.22222222222222
13424, 1.05, 1.75, 0.16666666666667
13425, 1.05, 1.75, 0.11111111111111
13426, 1.05, 1.75, 0.055555555555556
13427, 1.1, 1.75, 0.44444444444444
13428, 1.1, 1.75, 0.38888888888889
13429, 1.1, 1.75, 0.33333333333333
13430, 1.1, 1.75, 0.27777777777778
13431, 1.1, 1.75, 0.22222222222222
13432, 1.1, 1.75, 0.16666666666667
13433, 1.1, 1.75, 0.11111111111111
13434, 1.1, 1.75, 0.055555555555556
13435, 1.15, 1.75, 0.44444444444444
13436, 1.15, 1.75, 0.38888888888889
13437, 1.15, 1.75, 0.33333333333333
13438, 1.15, 1.75, 0.27777777777778
13439, 1.15, 1.75, 0.22222222222222
13440, 1.15, 1.75, 0.16666666666667
13441, 1.15, 1.75, 0.11111111111111
13442, 1.15, 1.75, 0.055555555555556
13443, 1.05, 1.75, 0.47222222222222
13444, 1.025, 1.75, 0.44444444444444
13445, 1.05, 1.75, 0.41666666666667
13446, 1.025, 1.75, 0.38888888888889
13447, 1.05, 1.75, 0.36111111111111
13448, 1.025, 1.75, 0.33333333333333
13449, 1.05, 1.75, 0.30555555555556
13450, 1.025, 1.75, 0.27777777777778
13451, 1.05, 1.75, 0.25
13452, 1.025, 1.75, 0.22222222222222
13453, 1.05, 1.75, 0.19444444444444
13454, 1.025, 1.75, 0.16666666666667
13455, 1.05, 1.75, 0.13888888888889
13456, 1.025, 1.75, 0.11111111111111
13457, 1.05, 1.75, 0.083333333333333
13458, 1.025, 1.75, 0.055555555555556
13459, 1.05, 1.75, 0.027777777777778
13460, 1.1, 1.75, 0.47222222222222
13461, 1.075, 1.75, 0.44444444444444
13462, 1.1, 1.75, 0.41666666666667
13463, 1.075, 1.75, 0.38888888888889
13464, 1.1, 1.75, 0.36111111111111
13465, 1.075, 1.75, 0.33333333333333
13466, 1.1, 1.75, 0.30555555555556
13467, 1.075, 1.75, 0.27777777777778
13468, 1.1, 1.75, 0.25
13469, 1.075, 1.75, 0.22222222222222
13470, 1.1, 1.75, 0.19444444444444
13471, 1.075, 1.75, 0.16666666666667
13472, 1.1, 1.75, 0.13888888888889
13473, 1.075, 1.75, 0.11111111111111
13474, 1.1, 1.75, 0.083333333333333
13475, 1.075, 1.75, 0.055555555555556
13476, 1.1, 1.75, 0.027777777777778
13477, 1.15, 1.75, 0.47222222222222
13478, 1.125, 1.75, 0.44444444444444
13479, 1.15, 1.75, 0.41666666666667
13480, 1.125, 1.75, 0.38888888888889
13481, 1.15, 1.75, 0.36111111111111
13482, 1.125, 1.75, 0.33333333333333
13483, 1.15, 1.75, 0.30555555555556
13484, 1.125, 1.75, 0.27777777777778
13485, 1.15, 1.75, 0.25
13486, 1.125, 1.75, 0.22222222222222
13487, 1.15, 1.75, 0.19444444444444
13488, 1.125, 1.75, 0.16666666666667
13489, 1.15, 1.75, 0.13888888888889
13490, 1.125, 1.75, 0.11111111111111
13491, 1.15, 1.75, 0.083333333333333
13492, 1.125, 1.75, 0.055555555555556
13493, 1.15, 1.75, 0.027777777777778
13494, 1.175, 1.75, 0.44444444444444
13495, 1.175, 1.75, 0.38888888888889
13496, 1.175, 1.75, 0.33333333333333
13497, 1.175, 1.75, 0.27777777777778
13498, 1.175, 1.75, 0.22222222222222
13499, 1.175, 1.75, 0.16666666666667
13500, 1.175, 1.75, 0.11111111111111
13501, 1.175, 1.75, 0.055555555555556
13502, 0.95652173913043, 1.6, 0
13503, 0.91304347826087, 1.6, 0
13504, 0.8695652173913, 1.6, 0
13505, 0.82608695652174, 1.6, 0
13506, 0.78260869565217, 1.6, 0
13507, 0.73913043478261, 1.6, 0
13508, 0.69565217391304, 1.6, 0
13509, 0.65217391304348, 1.6, 0
13510, 0.60869565217391, 1.6, 0
13511, 0.56521739130435, 1.6, 0
13512, 0.52173913043478, 1.6, 0
13513, 0.47826086956522, 1.6, 0
13514, 0.43478260869565, 1.6, 0
13515, 0.39130434782609, 1.6, 0
13516, 0.34782608695652, 1.6, 0
13517, 0.30434782608696, 1.6, 0
13518, 0.26086956521739, 1.6, 0
13519, 0.21739130434783, 1.6, 0
13520, 0.17391304347826, 1.6, 0
13521, 0.1304347826087, 1.6, 0
13522, 0.08695652173913, 1.6, 0
13523, 0.043478260869565, 1.6, 0
13524, 0.95652173913043, 1.65, 0
13525, 0.91304347826087, 1.65, 0
13526, 0.8695652173913, 1.65, 0
13527, 0.82608695652174, 1.65, 0
13528, 0.78260869565217, 1.65, 0
13529, 0.73913043478261, 1.65, 0
13530, 0.69565217391304, 1.65, 0
13531, 0.65217391304348, 1.65, 0
13532, 0.60869565217391, 1.65, 0
13533, 0.56521739130435, 1.65, 0
13534, 0.52173913043478, 1.65, 0
13535, 0.47826086956522, 1.65, 0
13536, 0.43478260869565, 1.65, 0
13537, 0.39130434782609, 1.65, 0
13538, 0.34782608695652, 1.65, 0
13539, 0.30434782608696, 1.65, 0
13540, 0.26086956521739, 1.65, 0
13541, 0.21739130434783, 1.65, 0
13542, 0.17391304347826, 1.65, 0
13543, 0.1304347826087, 1.65, 0
13544, 0.08695652173913, 1.65, 0
13545, 0.043478260869565, 1.65, 0
13546, 0.95652173913043, 1.7, 0
13547, 0.91304347826087, 1.7, 0
13548, 0.8695652173913, 1.7, 0
13549, 0.82608695652174, 1.7, 0
13550, 0.78260869565217, 1.7, 0
13551, 0.73913043478261, 1.7, 0
13552, 0.69565217391304, 1.7, 0
13553, 0.65217391304348, 1.7, 0
13554, 0.60869565217391, 1.7, 0
13555, 0.56521739130435, 1.7, 0
13556, 0.52173913043478, 1.7, 0
13557, 0.47826086956522, 1.7, 0
13558, 0.43478260869565, 1.7, 0
13559, 0.39130434782609, 1.7, 0
13560, 0.34782608695652, 1.7, 0
13561, 0.30434782608696, 1.7, 0
13562, 0.26086956521739, 1.7, 0
13563, 0.21739130434783, 1.7, 0
13564, 0.17391304347826, 1.7, 0
13565, 0.1304347826087, 1.7, 0
13566, 0.08695652173913, 1.7, 0
13567, 0.043478260869565, 1.7, 0
13568, 0.95652173913043, 1.575, 0
13569, 0.97826086956522, 1.6, 0
13570, 0.91304347826087, 1.575, 0
13571, 0.93478260869565, 1.6, 0
13572, 0.8695652173913, 1.575, 0
13573, 0.89130434782609, 1.6, 0
13574, 0.82608695652174, 1.575, 0
13575, 0.84782608695652, 1.6, 0
13576, 0.78260869565217, 1.575, 0
13577, 0.80434782608696, 1.6, 0
13578, 0.73913043478261, 1.575, 0
13579, 0.76086956521739, 1.6, 0
13580, 0.69565217391304, 1.575, 0
13581, 0.71739130434783, 1.6, 0
13582, 0.65217391304348, 1.575, 0
13583, 0.67391304347826, 1.6, 0
13584, 0.60869565217391, 1.575, 0
13585, 0.6304347826087, 1.6, 0
13586, 0.56521739130435, 1.575, 0
13587, 0.58695652173913, 1.6, 0
13588, 0.52173913043478, 1.575, 0
13589, 0.54347826086957, 1.6, 0
13590, 0.47826086956522, 1.575, 0
13591, 0.5, 1.6, 0
13592, 0.43478260869565, 1.575, 0
13593, 0.45652173913043, 1.6, 0
13594, 0.39130434782609, 1.575, 0
13595, 0.41304347826087, 1.6, 0
13596, 0.34782608695652, 1.575, 0
13597, 0.3695652173913, 1.6, 0
13598, 0.30434782608696, 1.575, 0
13599, 0.32608695652174, 1.6, 0
13600, 0.26086956521739, 1.575, 0
13601, 0.28260869565217, 1.6, 0
13602, 0.21739130434783, 1.575, 0
13603, 0.23913043478261, 1.6, 0
13604, 0.17391304347826, 1.575, 0
13605, 0.19565217391304, 1.6, 0
13606, 0.1304347826087, 1.575, 0
13607, 0.15217391304348, 1.6, 0
13608, 0.08695652173913, 1.575, 0
13609, 0.10869565217391, 1.6, 0
13610, 0.043478260869565, 1.575, 0
13611, 0.065217391304348, 1.6, 0
13612, 0.021739130434783, 1.6, 0
13613, 0.95652173913043, 1.625, 0
13614, 0.97826086956522, 1.65, 0
13615, 0.91304347826087, 1.625, 0
13616, 0.93478260869565, 1.65, 0
13617, 0.8695652173913, 1.625, 0
13618, 0.89130434782609, 1.65, 0
13619, 0.82608695652174, 1.625, 0
13620, 0.84782608695652, 1.65, 0
13621, 0.78260869565217, 1.625, 0
13622, 0.80434782608696, 1.65, 0
13623, 0.73913043478261, 1.625, 0
13624, 0.76086956521739, 1.65, 0
13625, 0.69565217391304, 1.625, 0
13626, 0.71739130434783, 1.65, 0
13627, 0.65217391304348, 1.625, 0
13628, 0.67391304347826, 1.65, 0
13629, 0.60869565217391, 1.625, 0
13630, 0.6304347826087, 1.65, 0
13631, 0.56521739130435, 1.625, 0
13632, 0.58695652173913, 1.65, 0
13633, 0.52173913043478, 1.625, 0
13634, 0.54347826086957, 1.65, 0
13635, 0.47826086956522, 1.625, 0
13636, 0.5, 1.65, 0
13637, 0.43478260869565, 1.625, 0
13638, 0.45652173913043, 1.65, 0
13639, 0.39130434782609, 1.625, 0
13640, 0.41304347826087, 1.65, 0
13641, 0.34782608695652, 1.625, 0
13642, 0.3695652173913, 1.65, 0
13643, 0.30434782608696, 1.625, 0
13644, 0.32608695652174, 1.65, 0
13645, 0.26086956521739, 1.625, 0
13646, 0.28260869565217, 1.65, 0
13647, 0.21739130434783, 1.625, 0
13648, 0.23913043478261, 1.65, 0
13649, 0.17391304347826, 1.625, 0
13650, 0.19565217391304, 1.65, 0
13651, 0.1304347826087, 1.625, 0
13652, 0.15217391304348, 1.65, 0
13653, 0.08695652173913, 1.625, 0
13654, 0.10869565217391, 1.65, 0
13655, 0.043478260869565, 1.625, 0
13656, 0.065217391304348, 1.65, 0
13657, 0.021739130434783, 1.65, 0
13658, 0.95652173913043, 1.675, 0
13659, 0.97826086956522, 1.7, 0
13660, 0.91304347826087, 1.675, 0
13661, 0.93478260869565, 1.7, 0
13662, 0.8695652173913, 1.675, 0
13663, 0.89130434782609, 1.7, 0
13664, 0.82608695652174, 1.675, 0
13665, 0.84782608695652, 1.7, 0
13666, 0.78260869565217, 1.675, 0
13667, 0.80434782608696, 1.7, 0
13668, 0.73913043478261, 1.675, 0
13669, 0.76086956521739, 1.7, 0
13670, 0.69565217391304, 1.675, 0
13671, 0.71739130434783, 1.7, 0
13672, 0.65217391304348, 1.675, 0
13673, 0.67391304347826, 1.7, 0
13674, 0.60869565217391, 1.675, 0
13675, 0.6304347826087, 1.7, 0
13676, 0.56521739130435, 1.675, 0
13677, 0.58695652173913, 1.7, 0
13678, 0.52173913043478, 1.675, 0
13679, 0.54347826086957, 1.7, 0
13680, 0.47826086956522, 1.675, 0
13681, 0.5, 1.7, 0
13682, 0.43478260869565, 1.675, 0
13683, 0.45652173913043, 1.7, 0
13684, 0.39130434782609, 1.675, 0
13685, 0.41304347826087, 1.7, 0
13686, 0.34782608695652, 1.675, 0
13687, 0.3695652173913, 1.7, 0
13688, 0.30434782608696, 1.675, 0
13689, 0.32608695652174, 1.7, 0
13690, 0.26086956521739, 1.675, 0
13691, 0.28260869565217, 1.7, 0
13692, 0.21739130434783, 1.675, 0
13693, 0.23913043478261, 1.7, 0
13694, 0.17391304347826, 1.675, 0
13695, 0.19565217391304, 1.7, 0
13696, 0.1304347826087, 1.675, 0
13697, 0.15217391304348, 1.7, 0
13698, 0.08695652173913, 1.675, 0
13699, 0.10869565217391, 1.7, 0
13700, 0.043478260869565, 1.675, 0
13701, 0.065217391304348, 1.7, 0
13702, 0.021739130434783, 1.7, 0
13703, 0.95652173913043, 1.725, 0
13704, 0.91304347826087, 1.725, 0
13705, 0.8695652173913, 1.725, 0
13706, 0.82608695652174, 1.725, 0
13707, 0.78260869565217, 1.725, 0
13708, 0.73913043478261, 1.725, 0
13709, 0.69565217391304, 1.725, 0
13710, 0.65217391304348, 1.725, 0
13711, 0.60869565217391, 1.725, 0
13712, 0.56521739130435, 1.725, 0
13713, 0.52173913043478, 1.725, 0
13714, 0.47826086956522, 1.725, 0
13715, 0.43478260869565, 1.725, 0
13716, 0.39130434782609, 1.725, 0
13717, 0.34782608695652, 1.725, 0
13718, 0.30434782608696, 1.725, 0
13719, 0.26086956521739, 1.725, 0
13720, 0.21739130434783, 1.725, 0
13721, 0.17391304347826, 1.725, 0
13722, 0.1304347826087, 1.725, 0
13723, 0.08695652173913, 1.725, 0
13724, 0.043478260869565, 1.725, 0
13725, 0.95652173913043, 1.6, 0.5
13726, 0.91304347826087, 1.6, 0.5
13727, 0.8695652173913, 1.6, 0.5
13728, 0.82608695652174, 1.6, 0.5
13729, 0.78260869565217, 1.6, 0.5
13730, 0.73913043478261, 1.6, 0.5
13731, 0.69565217391304, 1.6, 0.5
13732, 0.65217391304348, 1.6, 0.5
13733, 0.60869565217391, 1.6, 0.5
13734, 0.56521739130435, 1.6, 0.5
13735, 0.52173913043478, 1.6, 0.5
13736, 0.47826086956522, 1.6, 0.5
13737, 0.43478260869565, 1.6, 0.5
13738, 0.39130434782609, 1.6, 0.5
13739, 0.34782608695652, 1.6, 0.5
13740, 0.30434782608696, 1.6, 0.5
13741, 0.26086956521739, 1.6, 0.5
13742, 0.21739130434783, 1.6, 0.5
13743, 0.17391304347826, 1.6, 0.5
13744, 0.1304347826087, 1.6, 0.5
13745, 0.08695652173913, 1.6, 0.5
13746, 0.043478260869565, 1.6, 0.5
13747, 0.95652173913043, 1.65, 0.5
13748, 0.91304347826087, 1.65, 0.5
13749, 0.8695652173913, 1.65, 0.5
13750, 0.82608695652174, 1.65, 0.5
13751, 0.78260869565217, 1.65, 0.5
13752, 0.73913043478261, 1.65, 0.5
13753, 0.69565217391304, 1.65, 0.5
13754, 0.65217391304348, 1.65, 0.5
13755, 0.60869565217391, 1.65, 0.5
13756, 0.56521739130435, 1.65, 0.5
13757, 0.52173913043478, 1.65, 0.5
13758, 0.47826086956522, 1.65, 0.5
13759, 0.43478260869565, 1.65, 0.5
13760, 0.39130434782609, 1.65, 0.5
13761, 0.34782608695652, 1.65, 0.5
13762, 0.30434782608696, 1.65, 0.5
13763, 0.26086956521739, 1.65, 0.5
13764, 0.21739130434783, 1.65, 0.5
13765, 0.17391304347826, 1.65, 0.5
13766, 0.1304347826087, 1.65, 0.5
13767, 0.08695652173913, 1.65, 0.5
13768, 0.043478260869565, 1.65, 0.5
13769, 0.95652173913043, 1.7, 0.5
13770, 0.91304347826087, 1.7, 0.5
13771, 0.8695652173913, 1.7, 0.5
13772, 0.82608695652174, 1.7, 0.5
13773, 0.78260869565217, 1.7, 0.5
13774, 0.73913043478261, 1.7, 0.5
13775, 0.69565217391304, 1.7, 0.5
13776, 0.65217391304348, 1.7, 0.5
13777, 0.60869565217391, 1.7, 0.5
13778, 0.56521739130435, 1.7, 0.5
13779, 0.52173913043478, 1.7, 0.5
13780, 0.47826086956522, 1.7, 0.5
13781, 0.43478260869565, 1.7, 0.5
13782, 0.39130434782609, 1.7, 0.5
13783, 0.34782608695652, 1.7, 0.5
13784, 0.30434782608696, 1.7, 0.5
13785, 0.26086956521739, 1.7, 0.5
13786, 0.21739130434783, 1.7, 0.5
13787, 0.17391304347826, 1.7, 0.5
13788, 0.1304347826087, 1.7, 0.5
13789, 0.08695652173913, 1.7, 0.5
13790, 0.043478260869565, 1.7, 0.5
13791, 0.97826086956522, 1.6, 0.5
13792, 0.95652173913043, 1.575, 0.5
13793, 0.93478260869565, 1.6, 0.5
13794, 0.91304347826087, 1.575, 0.5
13795, 0.89130434782609, 1.6, 0.5
13796, 0.8695652173913, 1.575, 0.5
13797, 0.84782608695652, 1.6, 0.5
13798, 0.82608695652174, 1.575, 0.5
13799, 0.80434782608696, 1.6, 0.5
13800, 0.78260869565217, 1.575, 0.5
13801, 0.76086956521739, 1.6, 0.5
13802, 0.73913043478261, 1.575, 0.5
13803, 0.71739130434783, 1.6, 0.5
13804, 0.69565217391304, 1.575, 0.5
13805, 0.67391304347826, 1.6, 0.5
13806, 0.65217391304348, 1.575, 0.5
13807, 0.6304347826087, 1.6, 0.5
13808, 0.60869565217391, 1.575, 0.5
13809, 0.58695652173913, 1.6, 0.5
13810, 0.56521739130435, 1.575, 0.5
13811, 0.54347826086957, 1.6, 0.5
13812, 0.52173913043478, 1.575, 0.5
13813, 0.5, 1.6, 0.5
13814, 0.47826086956522, 1.575, 0.5
13815, 0.45652173913043, 1.6, 0.5
13816, 0.43478260869565, 1.575, 0.5
13817, 0.41304347826087, 1.6, 0.5
13818, 0.39130434782609, 1.575, 0.5
13819, 0.3695652173913, 1.6, 0.5
13820, 0.34782608695652, 1.575, 0.5
13821, 0.32608695652174, 1.6, 0.5
13822, 0.30434782608696, 1.575, 0.5
13823, 0.28260869565217, 1.6, 0.5
13824, 0.26086956521739, 1.575, 0.5
13825, 0.23913043478261, 1.6, 0.5
13826, 0.21739130434783, 1.575, 0.5
13827, 0.19565217391304, 1.6, 0.5
13828, 0.17391304347826, 1.575, 0.5
13829, 0.15217391304348, 1.6, 0.5
13830, 0.1304347826087, 1.575, 0.5
13831, 0.10869565217391, 1.6, 0.5
13832, 0.08695652173913, 1.575, 0.5
13833, 0.065217391304348, 1.6, 0.5
13834, 0.043478260869565, 1.575, 0.5
13835, 0.021739130434783, 1.6, 0.5
13836, 0.97826086956522, 1.65, 0.5
13837, 0.95652173913043, 1.625, 0.5
13838, 0.93478260869565, 1.65, 0.5
13839, 0.91304347826087, 1.625, 0.5
13840, 0.89130434782609, 1.65, 0.5
13841, 0.8695652173913, 1.625, 0.5
13842, 0.84782608695652, 1.65, 0.5
13843, 0.82608695652174, 1.625, 0.5
13844, 0.80434782608696, 1.65, 0.5
13845, 0.78260869565217, 1.625, 0.5
13846, 0.76086956521739, 1.65, 0.5
13847, 0.73913043478261, 1.625, 0.5
13848, 0.71739130434783, 1.65, 0.5
13849, 0.69565217391304, 1.625, 0.5
13850, 0.67391304347826, 1.65, 0.5
13851, 0.65217391304348, 1.625, 0.5
13852, 0.6304347826087, 1.65, 0.5
13853, 0.60869565217391, 1.625, 0.5
13854, 0.58695652173913, 1.65, 0.5
13855, 0.56521739130435, 1.625, 0.5
13856, 0.54347826086957, 1.65, 0.5
13857, 0.52173913043478, 1.625, 0.5
13858, 0.5, 1.65, 0.5
13859, 0.47826086956522, 1.625, 0.5
13860, 0.45652173913043, 1.65, 0.5
13861, 0.43478260869565, 1.625, 0.5
13862, 0.41304347826087, 1.65, 0.5
13863, 0.39130434782609, 1.625, 0.5
13864, 0.3695652173913, 1.65, 0.5
13865, 0.34782608695652, 1.625, 0.5
13866, 0.32608695652174, 1.65, 0.5
13867, 0.30434782608696, 1.625, 0.5
13868, 0.28260869565217, 1.65, 0.5
13869, 0.26086956521739, 1.625, 0.5
13870, 0.23913043478261, 1.65, 0.5
13871, 0.21739130434783, 1.625, 0.5
13872, 0.19565217391304, 1.65, 0.5
13873, 0.17391304347826, 1.625, 0.5
13874, 0.15217391304348, 1.65, 0.5
13875, 0.1304347826087, 1.625, 0.5
13876, 0.10869565217391, 1.65, 0.5
13877, 0.08695652173913, 1.625, 0.5
13878, 0.065217391304348, 1.65, 0.5
13879, 0.043478260869565, 1.625, 0.5
13880, 0.021739130434783, 1.65, 0.5
13881, 0.97826086956522, 1.7, 0.5
13882, 0.95652173913043, 1.675, 0.5
13883, 0.93478260869565, 1.7, 0.5
13884, 0.91304347826087, 1.675, 0.5
13885, 0.89130434782609, 1.7, 0.5
13886, 0.8695652173913, 1.675, 0.5
13887, 0.84782608695652, 1.7, 0.5
13888, 0.82608695652174, 1.675, 0.5
13889, 0.80434782608696, 1.7, 0.5
13890, 0.78260869565217, 1.675, 0.5
13891, 0.76086956521739, 1.7, 0.5
13892, 0.73913043478261, 1.675, 0.5
13893, 0.71739130434783, 1.7, 0.5
13894, 0.69565217391304, 1.675, 0.5
13895, 0.67391304347826, 1.7, 0.5
13896, 0.65217391304348, 1.675, 0.5
13897, 0.6304347826087, 1.7, 0.5
13898, 0.60869565217391, 1.675, 0.5
13899, 0.58695652173913, 1.7, 0.5
13900, 0.56521739130435, 1.675, 0.5
13901, 0.54347826086957, 1.7, 0.5
13902, 0.52173913043478, 1.675, 0.5
13903, 0.5, 1.7, 0.5
13904, 0.47826086956522, 1.675, 0.5
13905, 0.45652173913043, 1.7, 0.5
13906, 0.43478260869565, 1.675, 0.5
13907, 0.41304347826087, 1.7, 0.5
13908, 0.39130434782609, 1.675, 0.5
13909, 0.3695652173913, 1.7, 0.5
13910, 0.34782608695652, 1.675, 0.5
13911, 0.32608695652174, 1.7, 0.5
13912, 0.30434782608696, 1.675, 0.5
13913, 0.28260869565217, 1.7, 0.5
13914, 0.26086956521739, 1.675, 0.5
13915, 0.23913043478261, 1.7, 0.5
13916, 0.21739130434783, 1.675, 0.5
13917, 0.19565217391304, 1.7, 0.5
13918, 0.17391304347826, 1.675, 0.5
13919, 0.15217391304348, 1.7, 0.5
13920, 0.1304347826087, 1.675, 0.5
13921, 0.10869565217391, 1.7, 0.5
13922, 0.08695652173913, 1.675, 0.5
13923, 0.065217391304348, 1.7, 0.5
13924, 0.043478260869565, 1.675, 0.5
13925, 0.021739130434783, 1.7, 0.5
13926, 0.95652173913043, 1.725, 0.5
13927, 0.91304347826087, 1.725, 0.5
13928, 0.8695652173913, 1.725, 0.5
13929, 0.82608695652174, 1.725, 0.5
13930, 0.78260869565217, 1.725, 0.5
13931, 0.73913043478261, 1.725, 0.5
13932, 0.69565217391304, 1.725, 0.5
13933, 0.65217391304348, 1.725, 0.5
13934, 0.60869565217391, 1.725, 0.5
13935, 0.56521739130435, 1.725, 0.5
13936, 0.52173913043478, 1.725, 0.5
13937, 0.47826086956522, 1.725, 0.5
13938, 0.43478260869565, 1.725, 0.5
13939, 0.39130434782609, 1.725, 0.5
13940, 0.34782608695652, 1.725, 0.5
13941, 0.30434782608696, 1.725, 0.5
13942, 0.26086956521739, 1.725, 0.5
13943, 0.21739130434783, 1.725, 0.5
13944, 0.17391304347826, 1.725, 0.5
13945, 0.1304347826087, 1.725, 0.5
13946, 0.08695652173913, 1.725, 0.5
13947, 0.043478260869565, 1.725, 0.5
13948, 0, 1.6, 0.44444444444444
13949, 0, 1.6, 0.38888888888889
13950, 0, 1.6, 0.33333333333333
13951, 0, 1.6, 0.27777777777778
13952, 0, 1.6, 0.22222222222222
13953, 0, 1.6, 0.16666666666667
13954, 0, 1.6, 0.11111111111111
13955, 0, 1.6, 0.055555555555556
13956, 0, 1.65, 0.44444444444444
13957, 0, 1.65, 0.38888888888889
13958, 0, 1.65, 0.33333333333333
13959, 0, 1.65, 0.27777777777778
13960, 0, 1.65, 0.22222222222222
13961, 0, 1.65, 0.16666666666667
13962, 0, 1.65, 0.11111111111111
13963, 0, 1.65, 0.055555555555556
13964, 0, 1.7, 0.44444444444444
13965, 0, 1.7, 0.38888888888889
13966, 0, 1.7, 0.33333333333333
13967, 0, 1.7, 0.27777777777778
13968, 0, 1.7, 0.22222222222222
13969, 0, 1.7, 0.16666666666667
13970, 0, 1.7, 0.11111111111111
13971, 0, 1.7, 0.055555555555556
13972, 0, 1.6, 0.47222222222222
13973, 0, 1.575, 0.44444444444444
13974, 0, 1.6, 0.41666666666667
13975, 0, 1.575, 0.38888888888889
13976, 0, 1.6, 0.36111111111111
13977, 0, 1.575, 0.33333333333333
13978, 0, 1.6, 0.30555555555556
13979, 0, 1.575, 0.27777777777778
13980, 0, 1.6, 0.25
13981, 0, 1.575, 0.22222222222222
13982, 0, 1.6, 0.19444444444444
13983, 0, 1.575, 0.16666666666667
13984, 0, 1.6, 0.13888888888889
13985, 0, 1.575, 0.11111111111111
13986, 0, 1.6, 0.083333333333333
13987, 0, 1.575, 0.055555555555556
13988, 0, 1.6, 0.027777777777778
13989, 0, 1.65, 0.47222222222222
13990, 0, 1.625, 0.44444444444444
13991, 0, 1.65, 0.41666666666667
13992, 0, 1.625, 0.38888888888889
13993, 0, 1.65, 0.36111111111111
13994, 0, 1.625, 0.33333333333333
13995, 0, 1.65, 0.30555555555556
13996, 0, 1.625, 0.27777777777778
13997, 0, 1.65, 0.25
13998, 0, 1.625, 0.22222222222222
13999, 0, 1.65, 0.19444444444444
14000, 0, 1.625, 0.16666666666667
14001, 0, 1.65, 0.13888888888889
14002, 0, 1.625, 0.11111111111111
14003, 0, 1.65, 0.083333333333333
14004, 0, 1.625, 0.055555555555556
14005, 0, 1.65, 0.027777777777778
14006, 0, 1.7, 0.47222222222222
14007, 0, 1.675, 0.44444444444444
14008, 0, 1.7, 0.41666666666667
14009, 0, 1.675, 0.38888888888889
14010, 0, 1.7, 0.36111111111111
14011, 0, 1.675, 0.33333333333333
14012, 0, 1.7, 0.30555555555556
14013, 0, 1.675, 0.27777777777778
14014, 0, 1.7, 0.25
14015, 0, 1.675, 0.22222222222222
14016, 0, 1.7, 0.19444444444444
14017, 0, 1.675, 0.16666666666667
14018, 0, 1.7, 0.13888888888889
14019, 0, 1.675, 0.11111111111111
14020, 0, 1.7, 0.083333333333333
14021, 0, 1.675, 0.055555555555556
14022, 0, 1.7, 0.027777777777778
14023, 0, 1.725, 0.44444444444444
14024, 0, 1.725, 0.38888888888889
14025, 0, 1.725, 0.33333333333333
14026, 0, 1.725, 0.27777777777778
14027, 0, 1.725, 0.22222222222222
14028, 0, 1.725, 0.16666666666667
14029, 0, 1.725, 0.11111111111111
14030, 0, 1.725, 0.055555555555556
14031, 0.043478260869565, 1.75, 0.055555555555556
14032, 0.043478260869565, 1.75, 0.11111111111111
14033, 0.043478260869565, 1.75, 0.16666666666667
14034, 0.043478260869565, 1.75, 0.22222222222222
14035, 0.043478260869565, 1.75, 0.27777777777778
14036, 0.043478260869565, 1.75, 0.33333333333333
14037, 0.043478260869565, 1.75, 0.38888888888889
14038, 0.043478260869565, 1.75, 0.44444444444444
14039, 0.08695652173913, 1.75, 0.055555555555556
14040, 0.08695652173913, 1.75, 0.11111111111111
14041, 0.08695652173913, 1.75, 0.16666666666667
14042, 0.08695652173913, 1.75, 0.22222222222222
14043, 0.08695652173913, 1.75, 0.27777777777778
14044, 0.08695652173913, 1.75, 0.33333333333333
14045, 0.08695652173913, 1.75, 0.38888888888889
14046, 0.08695652173913, 1.75, 0.44444444444444
14047, 0.1304347826087, 1.75, 0.055555555555556
14048, 0.1304347826087, 1.75, 0.11111111111111
14049, 0.1304347826087, 1.75, 0.16666666666667
14050, 0.1304347826087, 1.75, 0.22222222222222
14051, 0.1304347826087, 1.75, 0.27777777777778
14052, 0.1304347826087, 1.75, 0.33333333333333
14053, 0.1304347826087, 1.75, 0.38888888888889
14054, 0.1304347826087, 1.75, 0.44444444444444
14055, 0.17391304347826, 1.75, 0.055555555555556
14056, 0.17391304347826, 1.75, 0.11111111111111
14057, 0.17391304347826, 1.75, 0.16666666666667
14058, 0.17391304347826, 1.75, 0.22222222222222
14059, 0.17391304347826, 1.75, 0.27777777777778
14060, 0.17391304347826, 1.75, 0.33333333333333
14061, 0.17391304347826, 1.75, 0.38888888888889
14062, 0.17391304347826, 1.75, 0.44444444444444
14063, 0.21739130434783, 1.75, 0.055555555555556
14064, 0.21739130434783, 1.75, 0.11111111111111
14065, 0.21739130434783, 1.75, 0.16666666666667
14066, 0.21739130434783, 1.75, 0.22222222222222
14067, 0.21739130434783, 1.75, 0.27777777777778
14068, 0.21739130434783, 1.75, 0.33333333333333
14069, 0.21739130434783, 1.75, 0.38888888888889
14070, 0.21739130434783, 1.75, 0.44444444444444
14071, 0.26086956521739, 1.75, 0.055555555555556
14072, 0.26086956521739, 1.75, 0.11111111111111
14073, 0.26086956521739, 1.75, 0.16666666666667
14074, 0.26086956521739, 1.75, 0.22222222222222
14075, 0.26086956521739, 1.75, 0.27777777777778
14076, 0.26086956521739, 1.75, 0.33333333333333
14077, 0.26086956521739, 1.75, 0.38888888888889
14078, 0.26086956521739, 1.75, 0.44444444444444
14079, 0.30434782608696, 1.75, 0.055555555555556
14080, 0.30434782608696, 1.75, 0.11111111111111
14081, 0.30434782608696, 1.75, 0.16666666666667
14082, 0.30434782608696, 1.75, 0.22222222222222
14083, 0.30434782608696, 1.75, 0.27777777777778
14084, 0.30434782608696, 1.75, 0.33333333333333
14085, 0.30434782608696, 1.75, 0.38888888888889
14086, 0.30434782608696, 1.75, 0.44444444444444
14087, 0.34782608695652, 1.75, 0.055555555555556
14088, 0.34782608695652, 1.75, 0.11111111111111
14089, 0.34782608695652, 1.75, 0.16666666666667
14090, 0.34782608695652, 1.75, 0.22222222222222
14091, 0.34782608695652, 1.75, 0.27777777777778
14092, 0.34782608695652, 1.75, 0.33333333333333
14093, 0.34782608695652, 1.75, 0.38888888888889
14094, 0.34782608695652, 1.75, 0.44444444444444
14095, 0.39130434782609, 1.75, 0.055555555555556
14096, 0.39130434782609, 1.75, 0.11111111111111
14097, 0.39130434782609, 1.75, 0.16666666666667
14098, 0.39130434782609, 1.75, 0.22222222222222
14099, 0.39130434782609, 1.75, 0.27777777777778
14100, 0.39130434782609, 1.75, 0.33333333333333
14101, 0.39130434782609, 1.75, 0.38888888888889
14102, 0.39130434782609, 1.75, 0.44444444444444
14103, 0.43478260869565, 1.75, 0.055555555555556
14104, 0.43478260869565, 1.75, 0.11111111111111
14105, 0.43478260869565, 1.75, 0.16666666666667
14106, 0.43478260869565, 1.75, 0.22222222222222
14107, 0.43478260869565, 1.75, 0.27777777777778
14108, 0.43478260869565, 1.75, 0.33333333333333
14109, 0.43478260869565, 1.75, 0.38888888888889
14110, 0.43478260869565, 1.75, 0.44444444444444
14111, 0.47826086956522, 1.75, 0.055555555555556
14112, 0.47826086956522, 1.75, 0.11111111111111
14113, 0.47826086956522, 1.75, 0.16666666666667
14114, 0.47826086956522, 1.75, 0.22222222222222
14115, 0.47826086956522, 1.75, 0.27777777777778
14116, 0.47826086956522, 1.75, 0.33333333333333
14117, 0.47826086956522, 1.75, 0.38888888888889
14118, 0.47826086956522, 1.75, 0.44444444444444
14119, 0.52173913043478, 1.75, 0.055555555555556
14120, 0.52173913043478, 1.75, 0.11111111111111
14121, 0.52173913043478, 1.75, 0.16666666666667
14122, 0.52173913043478, 1.75, 0.22222222222222
14123, 0.52173913043478, 1.75, 0.27777777777778
14124, 0.52173913043478, 1.75, 0.33333333333333
14125, 0.52173913043478, 1.75, 0.38888888888889
14126, 0.52173913043478, 1.75, 0.44444444444444
14127, 0.56521739130435, 1.75, 0.055555555555556
14128, 0.56521739130435, 1.75, 0.11111111111111
14129, 0.56521739130435, 1.75, 0.16666666666667
14130, 0.56521739130435, 1.75, 0.22222222222222
14131, 0.56521739130435, 1.75, 0.27777777777778
14132, 0.56521739130435, 1.75, 0.33333333333333
14133, 0.56521739130435, 1.75, 0.38888888888889
14134, 0.56521739130435, 1.75, 0.44444444444444
14135, 0.60869565217391, 1.75, 0.055555555555556
14136, 0.60869565217391, 1.75, 0.11111111111111
14137, 0.60869565217391, 1.75, 0.16666666666667
14138, 0.60869565217391, 1.75, 0.22222222222222
14139, 0.60869565217391, 1.75, 0.27777777777778
14140, 0.60869565217391, 1.75, 0.33333333333333
14141, 0.60869565217391, 1.75, 0.38888888888889
14142, 0.60869565217391, 1.75, 0.44444444444444
14143, 0.65217391304348, 1.75, 0.055555555555556
14144, 0.65217391304348, 1.75, 0.11111111111111
14145, 0.65217391304348, 1.75, 0.16666666666667
14146, 0.65217391304348, 1.75, 0.22222222222222
14147, 0.65217391304348, 1.75, 0.27777777777778
14148, 0.65217391304348, 1.75, 0.33333333333333
14149, 0.65217391304348, 1.75, 0.38888888888889
14150, 0.65217391304348, 1.75, 0.44444444444444
14151, 0.69565217391304, 1.75, 0.055555555555556
14152, 0.69565217391304, 1.75, 0.11111111111111
14153, 0.69565217391304, 1.75, 0.16666666666667
14154, 0.69565217391304, 1.75, 0.22222222222222
14155, 0.69565217391304, 1.75, 0.27777777777778
14156, 0.69565217391304, 1.75, 0.33333333333333
14157, 0.69565217391304, 1.75, 0.38888888888889
14158, 0.69565217391304, 1.75, 0.44444444444444
14159, 0.73913043478261, 1.75, 0.055555555555556
14160, 0.73913043478261, 1.75, 0.11111111111111
14161, 0.73913043478261, 1.75, 0.16666666666667
14162, 0.73913043478261, 1.75, 0.22222222222222
14163, 0.73913043478261, 1.75, 0.27777777777778
14164, 0.73913043478261, 1.75, 0.33333333333333
14165, 0.73913043478261, 1.75, 0.38888888888889
14166, 0.73913043478261, 1.75, 0.44444444444444
14167, 0.78260869565217, 1.75, 0.055555555555556
14168, 0.78260869565217, 1.75, 0.11111111111111
14169, 0.78260869565217, 1.75, 0.16666666666667
14170, 0.78260869565217, 1.75, 0.22222222222222
14171, 0.78260869565217, 1.75, 0.27777777777778
14172, 0.78260869565217, 1.75, 0.33333333333333
14173, 0.78260869565217, 1.75, 0.38888888888889
14174, 0.78260869565217, 1.75, 0.44444444444444
14175, 0.82608695652174, 1.75, 0.055555555555556
14176, 0.82608695652174, 1.75, 0.11111111111111
14177, 0.82608695652174, 1.75, 0.16666666666667
14178, 0.82608695652174, 1.75, 0.22222222222222
14179, 0.82608695652174, 1.75, 0.27777777777778
14180, 0.82608695652174, 1.75, 0.33333333333333
14181, 0.82608695652174, 1.75, 0.38888888888889
14182, 0.82608695652174, 1.75, 0.44444444444444
14183, 0.8695652173913, 1.75, 0.055555555555556
14184, 0.8695652173913, 1.75, 0.11111111111111
14185, 0.8695652173913, 1.75, 0.16666666666667
14186, 0.8695652173913, 1.75, 0.22222222222222
14187, 0.8695652173913, 1.75, 0.27777777777778
14188, 0.8695652173913, 1.75, 0.33333333333333
14189, 0.8695652173913, 1.75, 0.38888888888889
14190, 0.8695652173913, 1.75, 0.44444444444444
14191, 0.91304347826087, 1.75, 0.055555555555556
14192, 0.91304347826087, 1.75, 0.11111111111111
14193, 0.91304347826087, 1.75, 0.16666666666667
14194, 0.91304347826087, 1.75, 0.22222222222222
14195, 0.91304347826087, 1.75, 0.27777777777778
14196, 0.91304347826087, 1.75, 0.33333333333333
14197, 0.91304347826087, 1.75, 0.38888888888889
14198, 0.91304347826087, 1.75, 0.44444444444444
14199, 0.95652173913043, 1.75, 0.055555555555556
14200, 0.95652173913043, 1.75, 0.11111111111111
14201, 0.95652173913043, 1.75, 0.16666666666667
14202, 0.95652173913043, 1.75, 0.22222222222222
14203, 0.95652173913043, 1.75, 0.27777777777778
14204, 0.95652173913043, 1.75, 0.33333333333333
14205, 0.95652173913043, 1.75, 0.38888888888889
14206, 0.95652173913043, 1.75, 0.44444444444444
14207, 0.021739130434783, 1.75, 0.055555555555556
14208, 0.043478260869565, 1.75, 0.027777777777778
14209, 0.021739130434783, 1.75, 0.11111111111111
14210, 0.043478260869565, 1.75, 0.083333333333333
14211, 0.021739130434783, 1.75, 0.16666666666667
14212, 0.043478260869565, 1.75, 0.13888888888889
14213, 0.021739130434783, 1.75, 0.22222222222222
14214, 0.043478260869565, 1.75, 0.19444444444444
14215, 0.021739130434783, 1.75, 0.27777777777778
14216, 0.043478260869565, 1.75, 0.25
14217, 0.021739130434783, 1.75, 0.33333333333333
14218, 0.043478260869565, 1.75, 0.30555555555556
14219, 0.021739130434783, 1.75, 0.38888888888889
14220, 0.043478260869565, 1.75, 0.36111111111111
14221, 0.021739130434783, 1.75, 0.44444444444444
14222, 0.043478260869565, 1.75, 0.41666666666667
14223, 0.043478260869565, 1.75, 0.47222222222222
14224, 0.065217391304348, 1.75, 0.055555555555556
14225, 0.08695652173913, 1.75, 0.027777777777778
14226, 0.065217391304348, 1.75, 0.11111111111111
14227, 0.08695652173913, 1.75, 0.083333333333333
14228, 0.065217391304348, 1.75, 0.16666666666667
14229, 0.08695652173913, 1.75, 0.13888888888889
14230, 0.065217391304348, 1.75, 0.22222222222222
14231, 0.08695652173913, 1.75, 0.19444444444444
14232, 0.065217391304348, 1.75, 0.27777777777778
14233, 0.08695652173913, 1.75, 0.25
14234, 0.065217391304348, 1.75, 0.33333333333333
14235, 0.08695652173913, 1.75, 0.30555555555556
14236, 0.065217391304348, 1.75, 0.38888888888889
14237, 0.08695652173913, 1.75, 0.36111111111111
14238, 0.065217391304348, 1.75, 0.44444444444444
14239, 0.08695652173913, 1.75, 0.41666666666667
14240, 0.08695652173913, 1.75, 0.47222222222222
14241, 0.10869565217391, 1.75, 0.055555555555556
14242, 0.1304347826087, 1.75, 0.027777777777778
14243, 0.10869565217391, 1.75, 0.11111111111111
14244, 0.1304347826087, 1.75, 0.083333333333333
14245, 0.10869565217391, 1.75, 0.16666666666667
14246, 0.1304347826087, 1.75, 0.13888888888889
14247, 0.10869565217391, 1.75, 0.22222222222222
14248, 0.1304347826087, 1.75, 0.19444444444444
14249, 0.10869565217391, 1.75, 0.27777777777778
14250, 0.1304347826087, 1.75, 0.25
14251, 0.10869565217391, 1.75, 0.33333333333333
14252, 0.1304347826087, 1.75, 0.30555555555556
14253, 0.10869565217391, 1.75, 0.38888888888889
14254, 0.1304347826087, 1.75, 0.36111111111111
14255, 0.10869565217391, 1.75, 0.44444444444444
14256, 0.1304347826087, 1.75, 0.41666666666667
14257, 0.1304347826087, 1.75, 0.47222222222222
14258, 0.15217391304348, 1.75, 0.055555555555556
14259, 0.17391304347826, 1.75, 0.027777777777778
14260, 0.15217391304348, 1.75, 0.11111111111111
14261, 0.17391304347826, 1.75, 0.083333333333333
14262, 0.15217391304348, 1.75, 0.16666666666667
14263, 0.17391304347826, 1.75, 0.13888888888889
14264, 0.15217391304348, 1.75, 0.22222222222222
14265, 0.17391304347826, 1.75, 0.19444444444444
14266, 0.15217391304348, 1.75, 0.27777777777778
14267, 0.17391304347826, 1.75, 0.25
14268, 0.15217391304348, 1.75, 0.33333333333333
14269, 0.17391304347826, 1.75, 0.30555555555556
14270, 0.15217391304348, 1.75, 0.38888888888889
14271, 0.17391304347826, 1.75, 0.36111111111111
14272, 0.15217391304348, 1.75, 0.44444444444444
14273, 0.17391304347826, 1.75, 0.41666666666667
14274, 0.17391304347826, 1.75, 0.47222222222222
14275, 0.19565217391304, 1.75, 0.055555555555556
14276, 0.21739130434783, 1.75, 0.027777777777778
14277, 0.19565217391304, 1.75, 0.11111111111111
14278, 0.21739130434783, 1.75, 0.083333333333333
14279, 0.19565217391304, 1.75, 0.16666666666667
14280, 0.21739130434783, 1.75, 0.13888888888889
14281, 0.19565217391304, 1.75, 0.22222222222222
14282, 0.21739130434783, 1.75, 0.19444444444444
14283, 0.19565217391304, 1.75, 0.27777777777778
14284, 0.21739130434783, 1.75, 0.25
14285, 0.19565217391304, 1.75, 0.33333333333333
14286, 0.21739130434783, 1.75, 0.30555555555556
14287, 0.19565217391304, 1.75, 0.38888888888889
14288, 0.21739130434783, 1.75, 0.36111111111111
14289, 0.19565217391304, 1.75, 0.44444444444444
14290, 0.21739130434783, 1.75, 0.41666666666667
14291, 0.21739130434783, 1.75, 0.47222222222222
14292, 0.23913043478261, 1.75, 0.055555555555556
14293, 0.26086956521739, 1.75, 0.027777777777778
14294, 0.23913043478261, 1.75, 0.11111111111111
14295, 0.26086956521739, 1.75, 0.083333333333333
14296, 0.23913043478261, 1.75, 0.16666666666667
14297, 0.26086956521739, 1.75, 0.13888888888889
14298, 0.23913043478261, 1.75, 0.22222222222222
14299, 0.26086956521739, 1.75, 0.19444444444444
14300, 0.23913043478261, 1.75, 0.27777777777778
14301, 0.26086956521739, 1.75, 0.25
14302, 0.23913043478261, 1.75, 0.33333333333333
14303, 0.26086956521739, 1.75, 0.30555555555556
14304, 0.23913043478261, 1.75, 0.38888888888889
14305, 0.26086956521739, 1.75, 0.36111111111111
14306, 0.23913043478261, 1.75, 0.44444444444444
14307, 0.26086956521739, 1.75, 0.41666666666667
14308, 0.26086956521739, 1.75, 0.47222222222222
14309, 0.28260869565217, 1.75, 0.055555555555556
14310, 0.30434782608696, 1.75, 0.027777777777778
14311, 0.28260869565217, 1.75, 0.11111111111111
14312, 0.30434782608696, 1.75, 0.083333333333333
14313, 0.28260869565217, 1.75, 0.16666666666667
14314, 0.30434782608696, 1.75, 0.13888888888889
14315, 0.28260869565217, 1.75, 0.22222222222222
14316, 0.30434782608696, 1.75, 0.19444444444444
14317, 0.28260869565217, 1.75, 0.27777777777778
14318, 0.30434782608696, 1.75, 0.25
14319, 0.28260869565217, 1.75, 0.33333333333333
14320, 0.30434782608696, 1.75, 0.30555555555556
14321, 0.28260869565217, 1.75, 0.38888888888889
14322, 0.30434782608696, 1.75, 0.36111111111111
14323, 0.28260869565217, 1.75, 0.44444444444444
14324, 0.30434782608696, 1.75, 0.41666666666667
14325, 0.30434782608696, 1.75, 0.47222222222222
14326, 0.32608695652174, 1.75, 0.055555555555556
14327, 0.34782608695652, 1.75, 0.027777777777778
14328, 0.32608695652174, 1.75, 0.11111111111111
14329, 0.34782608695652, 1.75, 0.083333333333333
14330, 0.32608695652174, 1.75, 0.16666666666667
14331, 0.34782608695652, 1.75, 0.13888888888889
14332, 0.32608695652174, 1.75, 0.22222222222222
14333, 0.34782608695652, 1.75, 0.19444444444444
14334, 0.32608695652174, 1.75, 0.27777777777778
14335, 0.34782608695652, 1.75, 0.25
14336, 0.32608695652174, 1.75, 0.33333333333333
14337, 0.34782608695652, 1.75, 0.30555555555556
14338, 0.32608695652174, 1.75, 0.38888888888889
14339, 0.34782608695652, 1.75, 0.36111111111111
14340, 0.32608695652174, 1.75, 0.44444444444444
14341, 0.34782608695652, 1.75, 0.41666666666667
14342, 0.34782608695652, 1.75, 0.47222222222222
14343, 0.3695652173913, 1.75, 0.055555555555556
14344, 0.39130434782609, 1.75, 0.027777777777778
14345, 0.3695652173913, 1.75, 0.11111111111111
14346, 0.39130434782609, 1.75, 0.083333333333333
14347, 0.3695652173913, 1.75, 0.16666666666667
14348, 0.39130434782609, 1.75, 0.13888888888889
14349, 0.3695652173913, 1.75, 0.22222222222222
14350, 0.39130434782609, 1.75, 0.19444444444444
14351, 0.3695652173913, 1.75, 0.27777777777778
14352, 0.39130434782609, 1.75, 0.25
14353, 0.3695652173913, 1.75, 0.33333333333333
14354, 0.39130434782609, 1.75, 0.30555555555556
14355, 0.3695652173913, 1.75, 0.38888888888889
14356, 0.39130434782609, 1.75, 0.36111111111111
14357, 0.3695652173913, 1.75, 0.44444444444444
14358, 0.39130434782609, 1.75, 0.41666666666667
14359, 0.39130434782609, 1.75, 0.47222222222222
14360, 0.41304347826087, 1.75, 0.055555555555556
14361, 0.43478260869565, 1.75, 0.027777777777778
14362, 0.41304347826087, 1.75, 0.11111111111111
14363, 0.43478260869565, 1.75, 0.083333333333333
14364, 0.41304347826087, 1.75, 0.16666666666667
14365, 0.43478260869565, 1.75, 0.13888888888889
14366, 0.41304347826087, 1.75, 0.22222222222222
14367, 0.43478260869565, 1.75, 0.19444444444444
14368, 0.41304347826087, 1.75, 0.27777777777778
14369, 0.43478260869565, 1.75, 0.25
14370, 0.41304347826087, 1.75, 0.33333333333333
14371, 0.43478260869565, 1.75, 0.30555555555556
14372, 0.41304347826087, 1.75, 0.38888888888889
14373, 0.43478260869565, 1.75, 0.36111111111111
14374, 0.41304347826087, 1.75, 0.44444444444444
14375, 0.43478260869565, 1.75, 0.41666666666667
14376, 0.43478260869565, 1.75, 0.47222222222222
14377, 0.45652173913043, 1.75, 0.055555555555556
14378, 0.47826086956522, 1.75, 0.027777777777778
14379, 0.45652173913043, 1.75, 0.11111111111111
14380, 0.47826086956522, 1.75, 0.083333333333333
14381, 0.45652173913043, 1.75, 0.16666666666667
14382, 0.47826086956522, 1.75, 0.13888888888889
14383, 0.45652173913043, 1.75, 0.22222222222222
14384, 0.47826086956522, 1.75, 0.19444444444444
14385, 0.45652173913043, 1.75, 0.27777777777778
14386, 0.47826086956522, 1.75, 0.25
14387, 0.45652173913043, 1.75, 0.33333333333333
14388, 0.47826086956522, 1.75, 0.30555555555556
14389, 0.45652173913043, 1.75, 0.38888888888889
14390, 0.47826086956522, 1.75, 0.36111111111111
14391, 0.45652173913043, 1.75, 0.44444444444444
14392, 0.47826086956522, 1.75, 0.41666666666667
14393, 0.47826086956522, 1.75, 0.47222222222222
14394, 0.5, 1.75, 0.055555555555556
14395, 0.52173913043478, 1.75, 0.027777777777778
14396, 0.5, 1.75, 0.11111111111111
14397, 0.52173913043478, 1.75, 0.083333333333333
14398, 0.5, 1.75, 0.16666666666667
14399, 0.52173913043478, 1.75, 0.13888888888889
14400, 0.5, 1.75, 0.22222222222222
14401, 0.52173913043478, 1.75, 0.19444444444444
14402, 0.5, 1.75, 0.27777777777778
14403, 0.52173913043478, 1.75, 0.25
14404, 0.5, 1.75, 0.33333333333333
14405, 0.52173913043478, 1.75, 0.30555555555556
14406, 0.5, 1.75, 0.38888888888889
14407, 0.52173913043478, 1.75, 0.36111111111111
14408, 0.5, 1.75, 0.44444444444444
14409, 0.52173913043478, 1.75, 0.41666666666667
14410, 0.52173913043478, 1.75, 0.47222222222222
14411, 0.54347826086957, 1.75, 0.055555555555556
14412, 0.56521739130435, 1.75, 0.027777777777778
14413, 0.54347826086957, 1.75, 0.11111111111111
14414, 0.56521739130435, 1.75, 0.083333333333333
14415, 0.54347826086957, 1.75, 0.16666666666667
14416, 0.56521739130435, 1.75, 0.13888888888889
14417, 0.54347826086957, 1.75, 0.22222222222222
14418, 0.56521739130435, 1.75, 0.19444444444444
14419, 0.54347826086957, 1.75, 0.27777777777778
14420, 0.56521739130435, 1.75, 0.25
14421, 0.54347826086957, 1.75, 0.33333333333333
14422, 0.56521739130435, 1.75, 0.30555555555556
14423, 0.54347826086957, 1.75, 0.38888888888889
14424, 0.56521739130435, 1.75, 0.36111111111111
14425, 0.54347826086957, 1.75, 0.44444444444444
14426, 0.56521739130435, 1.75, 0.41666666666667
14427, 0.56521739130435, 1.75, 0.47222222222222
14428, 0.58695652173913, 1.75, 0.055555555555556
14429, 0.60869565217391, 1.75, 0.027777777777778
14430, 0.58695652173913, 1.75, 0.11111111111111
14431, 0.60869565217391, 1.75, 0.083333333333333
14432, 0.58695652173913, 1.75, 0.16666666666667
14433, 0.60869565217391, 1.75, 0.13888888888889
14434, 0.58695652173913, 1.75, 0.22222222222222
14435, 0.60869565217391, 1.75, 0.19444444444444
14436, 0.58695652173913, 1.75, 0.27777777777778
14437, 0.60869565217391, 1.75, 0.25
14438, 0.58695652173913, 1.75, 0.33333333333333
14439, 0.60869565217391, 1.75, 0.30555555555556
14440, 0.58695652173913, 1.75, 0.38888888888889
14441, 0.60869565217391, 1.75, 0.36111111111111
14442, 0.58695652173913, 1.75, 0.44444444444444
14443, 0.60869565217391, 1.75, 0.41666666666667
14444, 0.60869565217391, 1.75, 0.47222222222222
14445, 0.6304347826087, 1.75, 0.055555555555556
14446, 0.65217391304348, 1.75, 0.027777777777778
14447, 0.6304347826087, 1.75, 0.11111111111111
14448, 0.65217391304348, 1.75, 0.083333333333333
14449, 0.6304347826087, 1.75, 0.16666666666667
14450, 0.65217391304348, 1.75, 0.13888888888889
14451, 0.6304347826087, 1.75, 0.22222222222222
14452, 0.65217391304348, 1.75, 0.19444444444444
14453, 0.6304347826087, 1.75, 0.27777777777778
14454, 0.65217391304348, 1.75, 0.25
14455, 0.6304347826087, 1.75, 0.33333333333333
14456, 0.65217391304348, 1.75, 0.30555555555556
14457, 0.6304347826087, 1.75, 0.38888888888889
14458, 0.65217391304348, 1.75, 0.36111111111111
14459, 0.6304347826087, 1.75, 0.44444444444444
14460, 0.65217391304348, 1.75, 0.41666666666667
14461, 0.65217391304348, 1.75, 0.47222222222222
14462, 0.67391304347826, 1.75, 0.055555555555556
14463, 0.69565217391304, 1.75, 0.027777777777778
14464, 0.67391304347826, 1.75, 0.11111111111111
14465, 0.69565217391304, 1.75, 0.083333333333333
14466, 0.67391304347826, 1.75, 0.16666666666667
14467, 0.69565217391304, 1.75, 0.13888888888889
14468, 0.67391304347826, 1.75, 0.22222222222222
14469, 0.69565217391304, 1.75, 0.19444444444444
14470, 0.67391304347826, 1.75, 0.27777777777778
14471, 0.69565217391304, 1.75, 0.25
14472, 0.67391304347826, 1.75, 0.33333333333333
14473, 0.69565217391304, 1.75, 0.30555555555556
14474, 0.67391304347826, 1.75, 0.38888888888889
14475, 0.69565217391304, 1.75, 0.36111111111111
14476, 0.67391304347826, 1.75, 0.44444444444444
14477, 0.69565217391304, 1.75, 0.41666666666667
14478, 0.69565217391304, 1.75, 0.47222222222222
14479, 0.71739130434783, 1.75, 0.055555555555556
14480, 0.73913043478261, 1.75, 0.027777777777778
14481, 0.71739130434783, 1.75, 0.11111111111111
14482, 0.73913043478261, 1.75, 0.083333333333333
14483, 0.71739130434783, 1.75, 0.16666666666667
14484, 0.73913043478261, 1.75, 0.13888888888889
14485, 0.71739130434783, 1.75, 0.22222222222222
14486, 0.73913043478261, 1.75, 0.19444444444444
14487, 0.71739130434783, 1.75, 0.27777777777778
14488, 0.73913043478261, 1.75, 0.25
14489, 0.71739130434783, 1.75, 0.33333333333333
14490, 0.73913043478261, 1.75, 0.30555555555556
14491, 0.71739130434783, 1.75, 0.38888888888889
14492, 0.73913043478261, 1.75, 0.36111111111111
14493, 0.71739130434783, 1.75, 0.44444444444444
14494, 0.73913043478261, 1.75, 0.41666666666667
14495, 0.73913043478261, 1.75, 0.47222222222222
14496, 0.76086956521739, 1.75, 0.055555555555556
14497, 0.78260869565217, 1.75, 0.027777777777778
14498, 0.76086956521739, 1.75, 0.11111111111111
14499, 0.78260869565217, 1.75, 0.083333333333333
14500, 0.76086956521739, 1.75, 0.16666666666667
14501, 0.78260869565217, 1.75, 0.13888888888889
14502, 0.76086956521739, 1.75, 0.22222222222222
14503, 0.78260869565217, 1.75, 0.19444444444444
14504, 0.76086956521739, 1.75, 0.27777777777778
14505, 0.78260869565217, 1.75, 0.25
14506, 0.76086956521739, 1.75, 0.33333333333333
14507, 0.78260869565217, 1.75, 0.30555555555556
14508, 0.76086956521739, 1.75, 0.38888888888889
14509, 0.78260869565217, 1.75, 0.36111111111111
14510, 0.76086956521739, 1.75, 0.44444444444444
14511, 0.78260869565217, 1.75, 0.41666666666667
14512, 0.78260869565217, 1.75, 0.47222222222222
14513, 0.80434782608696, 1.75, 0.055555555555556
14514, 0.82608695652174, 1.75, 0.027777777777778
14515, 0.80434782608696, 1.75, 0.11111111111111
14516, 0.82608695652174, 1.75, 0.083333333333333
14517, 0.80434782608696, 1.75, 0.16666666666667
14518, 0.82608695652174, 1.75, 0.13888888888889
14519, 0.80434782608696, 1.75, 0.22222222222222
14520, 0.82608695652174, 1.75, 0.19444444444444
14521, 0.80434782608696, 1.75, 0.27777777777778
14522, 0.82608695652174, 1.75, 0.25
14523, 0.80434782608696, 1.75, 0.33333333333333
14524, 0.82608695652174, 1.75, 0.30555555555556
14525, 0.80434782608696, 1.75, 0.38888888888889
14526, 0.82608695652174, 1.75, 0.36111111111111
14527, 0.80434782608696, 1.75, 0.44444444444444
14528, 0.82608695652174, 1.75, 0.41666666666667
14529, 0.82608695652174, 1.75, 0.47222222222222
14530, 0.84782608695652, 1.75, 0.055555555555556
14531, 0.8695652173913, 1.75, 0.027777777777778
14532, 0.84782608695652, 1.75, 0.11111111111111
14533, 0.8695652173913, 1.75, 0.083333333333333
14534, 0.84782608695652, 1.75, 0.16666666666667
14535, 0.8695652173913, 1.75, 0.13888888888889
14536, 0.84782608695652, 1.75, 0.22222222222222
14537, 0.8695652173913, 1.75, 0.19444444444444
14538, 0.84782608695652, 1.75, 0.27777777777778
14539, 0.8695652173913, 1.75, 0.25
14540, 0.84782608695652, 1.75, 0.33333333333333
14541, 0.8695652173913, 1.75, 0.30555555555556
14542, 0.84782608695652, 1.75, 0.38888888888889
14543, 0.8695652173913, 1.75, 0.36111111111111
14544, 0.84782608695652, 1.75, 0.44444444444444
14545, 0.8695652173913, 1.75, 0.41666666666667
14546, 0.8695652173913, 1.75, 0.47222222222222
14547, 0.89130434782609, 1.75, 0.055555555555556
14548, 0.91304347826087, 1.75, 0.027777777777778
14549, 0.89130434782609, 1.75, 0.11111111111111
14550, 0.91304347826087, 1.75, 0.083333333333333
14551, 0.89130434782609, 1.75, 0.16666666666667
14552, 0.91304347826087, 1.75, 0.13888888888889
14553, 0.89130434782609, 1.75, 0.22222222222222
14554, 0.91304347826087, 1.75, 0.19444444444444
14555, 0.89130434782609, 1.75, 0.27777777777778
14556, 0.91304347826087, 1.75, 0.25
14557, 0.89130434782609, 1.75, 0.33333333333333
14558, 0.91304347826087, 1.75, 0.30555555555556
14559, 0.89130434782609, 1.75, 0.38888888888889
14560, 0.91304347826087, 1.75, 0.36111111111111
14561, 0.89130434782609, 1.75, 0.44444444444444
14562, 0.91304347826087, 1.75, 0.41666666666667
14563, 0.91304347826087, 1.75, 0.47222222222222
14564, 0.93478260869565, 1.75, 0.055555555555556
14565, 0.95652173913043, 1.75, 0.027777777777778
14566, 0.93478260869565, 1.75, 0.11111111111111
14567, 0.95652173913043, 1.75, 0.083333333333333
14568, 0.93478260869565, 1.75, 0.16666666666667
14569, 0.95652173913043, 1.75, 0.13888888888889
14570, 0.93478260869565, 1.75, 0.22222222222222
14571, 0.95652173913043, 1.75, 0.19444444444444
14572, 0.93478260869565, 1.75, 0.27777777777778
14573, 0.95652173913043, 1.75, 0.25
14574, 0.93478260869565, 1.75, 0.33333333333333
14575, 0.95652173913043, 1.75, 0.30555555555556
14576, 0.93478260869565, 1.75, 0.38888888888889
14577, 0.95652173913043, 1.75, 0.36111111111111
14578, 0.93478260869565, 1.75, 0.44444444444444
14579, 0.95652173913043, 1.75, 0.41666666666667
14580, 0.95652173913043, 1.75, 0.47222222222222
14581, 0.97826086956522, 1.75, 0.055555555555556
14582, 0.97826086956522, 1.75, 0.11111111111111
14583, 0.97826086956522, 1.75, 0.16666666666667
14584, 0.97826086956522, 1.75, 0.22222222222222
14585, 0.97826086956522, 1.75, 0.27777777777778
14586, 0.97826086956522, 1.75, 0.33333333333333
14587, 0.97826086956522, 1.75, 0.38888888888889
14588, 0.97826086956522, 1.75, 0.44444444444444
14589, -0.05, 1.6, 0.5
14590, -0.05, 1.65, 0.5
14591, -0.05, 1.7, 0.5
14592, -0.025, 1.6, 0.5
14593, -0.05, 1.575, 0.5
14594, -0.025, 1.65, 0.5
14595, -0.05, 1.625, 0.5
14596, -0.025, 1.7, 0.5
14597, -0.05, 1.675, 0.5
14598, -0.05, 1.725, 0.5
14599, -0.075, 1.6, 0.5
14600, -0.075, 1.65, 0.5
14601, -0.075, 1.7, 0.5
14602, -0.05, 1.6, 0
14603, -0.05, 1.65, 0
14604, -0.05, 1.7, 0
14605, -0.05, 1.575, 0
14606, -0.025, 1.6, 0
14607, -0.05, 1.625, 0
14608, -0.025, 1.65, 0
14609, -0.05, 1.675, 0
14610, -0.025, 1.7, 0
14611, -0.05, 1.725, 0
14612, -0.075, 1.6, 0
14613, -0.075, 1.65, 0
14614, -0.075, 1.7, 0
14615, -0.05, 1.55, 0.44444444444444
14616, -0.05, 1.55, 0.38888888888889
14617, -0.05, 1.55, 0.33333333333333
14618, -0.05, 1.55, 0.27777777777778
14619, -0.05, 1.55, 0.22222222222222
14620, -0.05, 1.55, 0.16666666666667
14621, -0.05, 1.55, 0.11111111111111
14622, -0.05, 1.55, 0.055555555555556
14623, -0.05, 1.55, 0.47222222222222
14624, -0.025, 1.55, 0.44444444444444
14625, -0.05, 1.55, 0.41666666666667
14626, -0.025, 1.55, 0.38888888888889
14627, -0.05, 1.55, 0.36111111111111
14628, -0.025, 1.55, 0.33333333333333
14629, -0.05, 1.55, 0.30555555555556
14630, -0.025, 1.55, 0.27777777777778
14631, -0.05, 1.55, 0.25
14632, -0.025, 1.55, 0.22222222222222
14633, -0.05, 1.55, 0.19444444444444
14634, -0.025, 1.55, 0.16666666666667
14635, -0.05, 1.55, 0.13888888888889
14636, -0.025, 1.55, 0.11111111111111
14637, -0.05, 1.55, 0.083333333333333
14638, -0.025, 1.55, 0.055555555555556
14639, -0.05, 1.55, 0.027777777777778
14640, -0.075, 1.55, 0.44444444444444
14641, -0.075, 1.55, 0.38888888888889
14642, -0.075, 1.55, 0.33333333333333
14643, -0.075, 1.55, 0.27777777777778
14644, -0.075, 1.55, 0.22222222222222
14645, -0.075, 1.55, 0.16666666666667
14646, -0.075, 1.55, 0.11111111111111
14647, -0.075, 1.55, 0.055555555555556
14648, -0.05, 1.75, 0.44444444444444
14649, -0.05, 1.75, 0.38888888888889
14650, -0.05, 1.75, 0.33333333333333
14651, -0.05, 1.75, 0.27777777777778
14652, -0.05, 1.75, 0.22222222222222
14653, -0.05, 1.75, 0.16666666666667
14654, -0.05, 1.75, 0.11111111111111
14655, -0.05, 1.75, 0.055555555555556
14656, -0.025, 1.75, 0.44444444444444
14657, -0.05, 1.75, 0.47222222222222
14658, -0.025, 1.75, 0.38888888888889
14659, -0.05, 1.75, 0.41666666666667
14660, -0.025, 1.75, 0.33333333333333
14661, -0.05, 1.75, 0.36111111111111
14662, -0.025, 1.75, 0.27777777777778
14663, -0.05, 1.75, 0.30555555555556
14664, -0.025, 1.75, 0.22222222222222
14665, -0.05, 1.75, 0.25
14666, -0.025, 1.75, 0.16666666666667
14667, -0.05, 1.75, 0.19444444444444
14668, -0.025, 1.75, 0.11111111111111
14669, -0.05, 1.75, 0.13888888888889
14670, -0.025, 1.75, 0.055555555555556
14671, -0.05, 1.75, 0.083333333333333
14672, -0.05, 1.75, 0.027777777777778
14673, -0.075, 1.75, 0.44444444444444
14674, -0.075, 1.75, 0.38888888888889
14675, -0.075, 1.75, 0.33333333333333
14676, -0.075, 1.75, 0.27777777777778
14677, -0.075, 1.75, 0.22222222222222
14678, -0.075, 1.75, 0.16666666666667
14679, -0.075, 1.75, 0.11111111111111
14680, -0.075, 1.75, 0.055555555555556
14681, -0.1, 1.6, 0.44444444444444
14682, -0.1, 1.6, 0.38888888888889
14683, -0.1, 1.6, 0.33333333333333
14684, -0.1, 1.6, 0.27777777777778
14685, -0.1, 1.6, 0.22222222222222
14686, -0.1, 1.6, 0.16666666666667
14687, -0.1, 1.6, 0.11111111111111
14688, -0.1, 1.6, 0.055555555555556
14689, -0.1, 1.65, 0.44444444444444
14690, -0.1, 1.65, 0.38888888888889
14691, -0.1, 1.65, 0.33333333333333
14692, -0.1, 1.65, 0.27777777777778
14693, -0.1, 1.65, 0.22222222222222
14694, -0.1, 1.65, 0.16666666666667
14695, -0.1, 1.65, 0.11111111111111
14696, -0.1, 1.65, 0.055555555555556
14697, -0.1, 1.7, 0.44444444444444
14698, -0.1, 1.7, 0.38888888888889
14699, -0.1, 1.7, 0.33333333333333
14700, -0.1, 1.7, 0.27777777777778
14701, -0.1, 1.7, 0.22222222222222
14702, -0.1, 1.7, 0.16666666666667
14703, -0.1, 1.7, 0.11111111111111
14704, -0.1, 1.7, 0.055555555555556
14705, -0.1, 1.6, 0.47222222222222
14706, -0.1, 1.575, 0.44444444444444
14707, -0.1, 1.6, 0.41666666666667
14708, -0.1, 1.575, 0.38888888888889
14709, -0.1, 1.6, 0.36111111111111
14710, -0.1, 1.575, 0.33333333333333
14711, -0.1, 1.6, 0.30555555555556
14712, -0.1, 1.575, 0.27777777777778
14713, -0.1, 1.6, 0.25
14714, -0.1, 1.575, 0.22222222222222
14715, -0.1, 1.6, 0.19444444444444
14716, -0.1, 1.575, 0.16666666666667
14717, -0.1, 1.6, 0.13888888888889
14718, -0.1, 1.575, 0.11111111111111
14719, -0.1, 1.6, 0.083333333333333
14720, -0.1, 1.575, 0.055555555555556
14721, -0.1, 1.6, 0.027777777777778
14722, -0.1, 1.65, 0.47222222222222
14723, -0.1, 1.625, 0.44444444444444
14724, -0.1, 1.65, 0.41666666666667
14725, -0.1, 1.625, 0.38888888888889
14726, -0.1, 1.65, 0.36111111111111
14727, -0.1, 1.625, 0.33333333333333
14728, -0.1, 1.65, 0.30555555555556
14729, -0.1, 1.625, 0.27777777777778
14730, -0.1, 1.65, 0.25
14731, -0.1, 1.625, 0.22222222222222
14732, -0.1, 1.65, 0.19444444444444
14733, -0.1, 1.625, 0.16666666666667
14734, -0.1, 1.65, 0.13888888888889
14735, -0.1, 1.625, 0.11111111111111
14736, -0.1, 1.65, 0.083333333333333
14737, -0.1, 1.625, 0.055555555555556
14738, -0.1, 1.65, 0.027777777777778
14739, -0.1, 1.7, 0.47222222222222
14740, -0.1, 1.675, 0.44444444444444
14741, -0.1, 1.7, 0.41666666666667
14742, -0.1, 1.675, 0.38888888888889
14743, -0.1, 1.7, 0.36111111111111
14744, -0.1, 1.675, 0.33333333333333
14745, -0.1, 1.7, 0.30555555555556
14746, -0.1, 1.675, 0.27777777777778
14747, -0.1, 1.7, 0.25
14748, -0.1, 1.675, 0.22222222222222
14749, -0.1, 1.7, 0.19444444444444
14750, -0.1, 1.675, 0.16666666666667
14751, -0.1, 1.7, 0.13888888888889
14752, -0.1, 1.675, 0.11111111111111
14753, -0.1, 1.7, 0.083333333333333
14754, -0.1, 1.675, 0.055555555555556
14755, -0.1, 1.7, 0.027777777777778
14756, -0.1, 1.725, 0.44444444444444
14757, -0.1, 1.725, 0.38888888888889
14758, -0.1, 1.725, 0.33333333333333
14759, -0.1, 1.725, 0.27777777777778
14760, -0.1, 1.725, 0.22222222222222
14761, -0.1, 1.725, 0.16666666666667
14762, -0.1, 1.725, 0.11111111111111
14763, -0.1, 1.725, 0.055555555555556
14764, 0.95652173913043, 1.425, 0
14765, 0.91304347826087, 1.425, 0
14766, 0.8695652173913, 1.425, 0
14767, 0.82608695652174, 1.425, 0
14768, 0.78260869565217, 1.425, 0
14769, 0.73913043478261, 1.425, 0
14770, 0.69565217391304, 1.425, 0
14771, 0.65217391304348, 1.425, 0
14772, 0.60869565217391, 1.425, 0
14773, 0.56521739130435, 1.425, 0
14774, 0.52173913043478, 1.425, 0
14775, 0.47826086956522, 1.425, 0
14776, 0.43478260869565, 1.425, 0
14777, 0.39130434782609, 1.425, 0
14778, 0.34782608695652, 1.425, 0
14779, 0.30434782608696, 1.425, 0
14780, 0.26086956521739, 1.425, 0
14781, 0.21739130434783, 1.425, 0
14782, 0.17391304347826, 1.425, 0
14783, 0.1304347826087, 1.425, 0
14784, 0.08695652173913, 1.425, 0
14785, 0.043478260869565, 1.425, 0
14786, 0.95652173913043, 1.4125, 0
14787, 0.97826086956522, 1.425, 0
14788, 0.91304347826087, 1.4125, 0
14789, 0.93478260869565, 1.425, 0
14790, 0.8695652173913, 1.4125, 0
14791, 0.89130434782609, 1.425, 0
14792, 0.82608695652174, 1.4125, 0
14793, 0.84782608695652, 1.425, 0
14794, 0.78260869565217, 1.4125, 0
14795, 0.80434782608696, 1.425, 0
14796, 0.73913043478261, 1.4125, 0
14797, 0.76086956521739, 1.425, 0
14798, 0.69565217391304, 1.4125, 0
14799, 0.71739130434783, 1.425, 0
14800, 0.65217391304348, 1.4125, 0
14801, 0.67391304347826, 1.425, 0
14802, 0.60869565217391, 1.4125, 0
14803, 0.6304347826087, 1.425, 0
14804, 0.56521739130435, 1.4125, 0
14805, 0.58695652173913, 1.425, 0
14806, 0.52173913043478, 1.4125, 0
14807, 0.54347826086957, 1.425, 0
14808, 0.47826086956522, 1.4125, 0
14809, 0.5, 1.425, 0
14810, 0.43478260869565, 1.4125, 0
14811, 0.45652173913043, 1.425, 0
14812, 0.39130434782609, 1.4125, 0
14813, 0.41304347826087, 1.425, 0
14814, 0.34782608695652, 1.4125, 0
14815, 0.3695652173913, 1.425, 0
14816, 0.30434782608696, 1.4125, 0
14817, 0.32608695652174, 1.425, 0
14818, 0.26086956521739, 1.4125, 0
14819, 0.28260869565217, 1.425, 0
14820, 0.21739130434783, 1.4125, 0
14821, 0.23913043478261, 1.425, 0
14822, 0.17391304347826, 1.4125, 0
14823, 0.19565217391304, 1.425, 0
14824, 0.1304347826087, 1.4125, 0
14825, 0.15217391304348, 1.425, 0
14826, 0.08695652173913, 1.4125, 0
14827, 0.10869565217391, 1.425, 0
14828, 0.043478260869565, 1.4125, 0
14829, 0.065217391304348, 1.425, 0
14830, 0.021739130434783, 1.425, 0
14831, 0.95652173913043, 1.4375, 0
14832, 0.91304347826087, 1.4375, 0
14833, 0.8695652173913, 1.4375, 0
14834, 0.82608695652174, 1.4375, 0
14835, 0.78260869565217, 1.4375, 0
14836, 0.73913043478261, 1.4375, 0
14837, 0.69565217391304, 1.4375, 0
14838, 0.65217391304348, 1.4375, 0
14839, 0.60869565217391, 1.4375, 0
14840, 0.56521739130435, 1.4375, 0
14841, 0.52173913043478, 1.4375, 0
14842, 0.47826086956522, 1.4375, 0
14843, 0.43478260869565, 1.4375, 0
14844, 0.39130434782609, 1.4375, 0
14845, 0.34782608695652, 1.4375, 0
14846, 0.30434782608696, 1.4375, 0
14847, 0.26086956521739, 1.4375, 0
14848, 0.21739130434783, 1.4375, 0
14849, 0.17391304347826, 1.4375, 0
14850, 0.1304347826087, 1.4375, 0
14851, 0.08695652173913, 1.4375, 0
14852, 0.043478260869565, 1.4375, 0
14853, 1, 1.425, 0.44444444444444
14854, 1, 1.425, 0.38888888888889
14855, 1, 1.425, 0.33333333333333
14856, 1, 1.425, 0.27777777777778
14857, 1, 1.425, 0.22222222222222
14858, 1, 1.425, 0.16666666666667
14859, 1, 1.425, 0.11111111111111
14860, 1, 1.425, 0.055555555555556
14861, 1, 1.4125, 0.44444444444444
14862, 1, 1.425, 0.47222222222222
14863, 1, 1.4125, 0.38888888888889
14864, 1, 1.425, 0.41666666666667
14865, 1, 1.4125, 0.33333333333333
14866, 1, 1.425, 0.36111111111111
14867, 1, 1.4125, 0.27777777777778
14868, 1, 1.425, 0.30555555555556
14869, 1, 1.4125, 0.22222222222222
14870, 1, 1.425, 0.25
14871, 1, 1.4125, 0.16666666666667
14872, 1, 1.425, 0.19444444444444
14873, 1, 1.4125, 0.11111111111111
14874, 1, 1.425, 0.13888888888889
14875, 1, 1.4125, 0.055555555555556
14876, 1, 1.425, 0.083333333333333
14877, 1, 1.425, 0.027777777777778
14878, 1, 1.4375, 0.44444444444444
14879, 1, 1.4375, 0.38888888888889
14880, 1, 1.4375, 0.33333333333333
14881, 1, 1.4375, 0.27777777777778
14882, 1, 1.4375, 0.22222222222222
14883, 1, 1.4375, 0.16666666666667
14884, 1, 1.4375, 0.11111111111111
14885, 1, 1.4375, 0.055555555555556
14886, 0.95652173913043, 1.425, 0.5
14887, 0.91304347826087, 1.425, 0.5
14888, 0.8695652173913, 1.425, 0.5
14889, 0.82608695652174, 1.425, 0.5
14890, 0.78260869565217, 1.425, 0.5
14891, 0.73913043478261, 1.425, 0.5
14892, 0.69565217391304, 1.425, 0.5
14893, 0.65217391304348, 1.425, 0.5
14894, 0.60869565217391, 1.425, 0.5
14895, 0.56521739130435, 1.425, 0.5
14896, 0.52173913043478, 1.425, 0.5
14897, 0.47826086956522, 1.425, 0.5
14898, 0.43478260869565, 1.425, 0.5
14899, 0.39130434782609, 1.425, 0.5
14900, 0.34782608695652, 1.425, 0.5
14901, 0.30434782608696, 1.425, 0.5
14902, 0.26086956521739, 1.425, 0.5
14903, 0.21739130434783, 1.425, 0.5
14904, 0.17391304347826, 1.425, 0.5
14905, 0.1304347826087, 1.425, 0.5
14906, 0.08695652173913, 1.425, 0.5
14907, 0.043478260869565, 1.425, 0.5
14908, 0.97826086956522, 1.425, 0.5
14909, 0.95652173913043, 1.4125, 0.5
14910, 0.93478260869565, 1.425, 0.5
14911, 0.91304347826087, 1.4125, 0.5
14912, 0.89130434782609, 1.425, 0.5
14913, 0.8695652173913, 1.4125, 0.5
14914, 0.84782608695652, 1.425, 0.5
14915, 0.82608695652174, 1.4125, 0.5
14916, 0.80434782608696, 1.425, 0.5
14917, 0.78260869565217, 1.4125, 0.5
14918, 0.76086956521739, 1.425, 0.5
14919, 0.73913043478261, 1.4125, 0.5
14920, 0.71739130434783, 1.425, 0.5
14921, 0.69565217391304, 1.4125, 0.5
14922, 0.67391304347826, 1.425, 0.5
14923, 0.65217391304348, 1.4125, 0.5
14924, 0.6304347826087, 1.425, 0.5
14925, 0.60869565217391, 1.4125, 0.5
14926, 0.58695652173913, 1.425, 0.5
14927, 0.56521739130435, 1.4125, 0.5
14928, 0.54347826086957, 1.425, 0.5
14929, 0.52173913043478, 1.4125, 0.5
14930, 0.5, 1.425, 0.5
14931, 0.47826086956522, 1.4125, 0.5
14932, 0.45652173913043, 1.425, 0.5
14933, 0.43478260869565, 1.4125, 0.5
14934, 0.41304347826087, 1.425, 0.5
14935, 0.39130434782609, 1.4125, 0.5
14936, 0.3695652173913, 1.425, 0.5
14937, 0.34782608695652, 1.4125, 0.5
14938, 0.32608695652174, 1.425, 0.5
14939, 0.30434782608696, 1.4125, 0.5
14940, 0.28260869565217, 1.425, 0.5
14941, 0.26086956521739, 1.4125, 0.5
14942, 0.23913043478261, 1.425, 0.5
14943, 0.21739130434783, 1.4125, 0.5
14944, 0.19565217391304, 1.425, 0.5
14945, 0.17391304347826, 1.4125, 0.5
14946, 0.15217391304348, 1.425, 0.5
14947, 0.1304347826087, 1.4125, 0.5
14948, 0.10869565217391, 1.425, 0.5
14949, 0.08695652173913, 1.4125, 0.5
14950, 0.065217391304348, 1.425, 0.5
14951, 0.043478260869565, 1.4125, 0.5
14952, 0.021739130434783, 1.425, 0.5
14953, 0.95652173913043, 1.4375, 0.5
14954, 0.91304347826087, 1.4375, 0.5
14955, 0.8695652173913, 1.4375, 0.5
14956, 0.82608695652174, 1.4375, 0.5
14957, 0.78260869565217, 1.4375, 0.5
14958, 0.73913043478261, 1.4375, 0.5
14959, 0.69565217391304, 1.4375, 0.5
14960, 0.65217391304348, 1.4375, 0.5
14961, 0.60869565217391, 1.4375, 0.5
14962, 0.56521739130435, 1.4375, 0.5
14963, 0.52173913043478, 1.4375, 0.5
14964, 0.47826086956522, 1.4375, 0.5
14965, 0.43478260869565, 1.4375, 0.5
14966, 0.39130434782609, 1.4375, 0.5
14967, 0.34782608695652, 1.4375, 0.5
14968, 0.30434782608696, 1.4375, 0.5
14969, 0.26086956521739, 1.4375, 0.5
14970, 0.21739130434783, 1.4375, 0.5
14971, 0.17391304347826, 1.4375, 0.5
14972, 0.1304347826087, 1.4375, 0.5
14973, 0.08695652173913, 1.4375, 0.5
14974, 0.043478260869565, 1.4375, 0.5
14975, 0, 1.425, 0.44444444444444
14976, 0, 1.425, 0.38888888888889
14977, 0, 1.425, 0.33333333333333
14978, 0, 1.425, 0.27777777777778
14979, 0, 1.425, 0.22222222222222
14980, 0, 1.425, 0.16666666666667
14981, 0, 1.425, 0.11111111111111
14982, 0, 1.425, 0.055555555555556
14983, 0, 1.425, 0.47222222222222
14984, 0, 1.4125, 0.44444444444444
14985, 0, 1.425, 0.41666666666667
14986, 0, 1.4125, 0.38888888888889
14987, 0, 1.425, 0.36111111111111
14988, 0, 1.4125, 0.33333333333333
14989, 0, 1.425, 0.30555555555556
14990, 0, 1.4125, 0.27777777777778
14991, 0, 1.425, 0.25
14992, 0, 1.4125, 0.22222222222222
14993, 0, 1.425, 0.19444444444444
14994, 0, 1.4125, 0.16666666666667
14995, 0, 1.425, 0.13888888888889
14996, 0, 1.4125, 0.11111111111111
14997, 0, 1.425, 0.083333333333333
14998, 0, 1.4125, 0.055555555555556
14999, 0, 1.425, 0.027777777777778
15000, 0, 1.4375, 0.44444444444444
15001, 0, 1.4375, 0.38888888888889
15002, 0, 1.4375, 0.33333333333333
15003, 0, 1.4375, 0.27777777777778
15004, 0, 1.4375, 0.22222222222222
15005, 0, 1.4375, 0.16666666666667
15006, 0, 1.4375, 0.11111111111111
15007, 0, 1.4375, 0.055555555555556
15008, 0.043478260869565, 1.4, 0.055555555555556
15009, 0.043478260869565, 1.4, 0.11111111111111
15010, 0.043478260869565, 1.4, 0.16666666666667
15011, 0.043478260869565, 1.4, 0.22222222222222
15012, 0.043478260869565, 1.4, 0.27777777777778
15013, 0.043478260869565, 1.4, 0.33333333333333
15014, 0.043478260869565, 1.4, 0.38888888888889
15015, 0.043478260869565, 1.4, 0.44444444444444
15016, 0.08695652173913, 1.4, 0.055555555555556
15017, 0.08695652173913, 1.4, 0.11111111111111
15018, 0.08695652173913, 1.4, 0.16666666666667
15019, 0.08695652173913, 1.4, 0.22222222222222
15020, 0.08695652173913, 1.4, 0.27777777777778
15021, 0.08695652173913, 1.4, 0.33333333333333
15022, 0.08695652173913, 1.4, 0.38888888888889
15023, 0.08695652173913, 1.4, 0.44444444444444
15024, 0.1304347826087, 1.4, 0.055555555555556
15025, 0.1304347826087, 1.4, 0.11111111111111
15026, 0.1304347826087, 1.4, 0.16666666666667
15027, 0.1304347826087, 1.4, 0.22222222222222
15028, 0.1304347826087, 1.4, 0.27777777777778
15029, 0.1304347826087, 1.4, 0.33333333333333
15030, 0.1304347826087, 1.4, 0.38888888888889
15031, 0.1304347826087, 1.4, 0.44444444444444
15032, 0.17391304347826, 1.4, 0.055555555555556
15033, 0.17391304347826, 1.4, 0.11111111111111
15034, 0.17391304347826, 1.4, 0.16666666666667
15035, 0.17391304347826, 1.4, 0.22222222222222
15036, 0.17391304347826, 1.4, 0.27777777777778
15037, 0.17391304347826, 1.4, 0.33333333333333
15038, 0.17391304347826, 1.4, 0.38888888888889
15039, 0.17391304347826, 1.4, 0.44444444444444
15040, 0.21739130434783, 1.4, 0.055555555555556
15041, 0.21739130434783, 1.4, 0.11111111111111
15042, 0.21739130434783, 1.4, 0.16666666666667
15043, 0.21739130434783, 1.4, 0.22222222222222
15044, 0.21739130434783, 1.4, 0.27777777777778
15045, 0.21739130434783, 1.4, 0.33333333333333
15046, 0.21739130434783, 1.4, 0.38888888888889
15047, 0.21739130434783, 1.4, 0.44444444444444
15048, 0.26086956521739, 1.4, 0.055555555555556
15049, 0.26086956521739, 1.4, 0.11111111111111
15050, 0.26086956521739, 1.4, 0.16666666666667
15051, 0.26086956521739, 1.4, 0.22222222222222
15052, 0.26086956521739, 1.4, 0.27777777777778
15053, 0.26086956521739, 1.4, 0.33333333333333
15054, 0.26086956521739, 1.4, 0.38888888888889
15055, 0.26086956521739, 1.4, 0.44444444444444
15056, 0.30434782608696, 1.4, 0.055555555555556
15057, 0.30434782608696, 1.4, 0.11111111111111
15058, 0.30434782608696, 1.4, 0.16666666666667
15059, 0.30434782608696, 1.4, 0.22222222222222
15060, 0.30434782608696, 1.4, 0.27777777777778
15061, 0.30434782608696, 1.4, 0.33333333333333
15062, 0.30434782608696, 1.4, 0.38888888888889
15063, 0.30434782608696, 1.4, 0.44444444444444
15064, 0.34782608695652, 1.4, 0.055555555555556
15065, 0.34782608695652, 1.4, 0.11111111111111
15066, 0.34782608695652, 1.4, 0.16666666666667
15067, 0.34782608695652, 1.4, 0.22222222222222
15068, 0.34782608695652, 1.4, 0.27777777777778
15069, 0.34782608695652, 1.4, 0.33333333333333
15070, 0.34782608695652, 1.4, 0.38888888888889
15071, 0.34782608695652, 1.4, 0.44444444444444
15072, 0.39130434782609, 1.4, 0.055555555555556
15073, 0.39130434782609, 1.4, 0.11111111111111
15074, 0.39130434782609, 1.4, 0.16666666666667
15075, 0.39130434782609, 1.4, 0.22222222222222
15076, 0.39130434782609, 1.4, 0.27777777777778
15077, 0.39130434782609, 1.4, 0.33333333333333
15078, 0.39130434782609, 1.4, 0.38888888888889
15079, 0.39130434782609, 1.4, 0.44444444444444
15080, 0.43478260869565, 1.4, 0.055555555555556
15081, 0.43478260869565, 1.4, 0.11111111111111
15082, 0.43478260869565, 1.4, 0.16666666666667
15083, 0.43478260869565, 1.4, 0.22222222222222
15084, 0.43478260869565, 1.4, 0.27777777777778
15085, 0.43478260869565, 1.4, 0.33333333333333
15086, 0.43478260869565, 1.4, 0.38888888888889
15087, 0.43478260869565, 1.4, 0.44444444444444
15088, 0.47826086956522, 1.4, 0.055555555555556
15089, 0.47826086956522, 1.4, 0.11111111111111
15090, 0.47826086956522, 1.4, 0.16666666666667
15091, 0.47826086956522, 1.4, 0.22222222222222
15092, 0.47826086956522, 1.4, 0.27777777777778
15093, 0.47826086956522, 1.4, 0.33333333333333
15094, 0.47826086956522, 1.4, 0.38888888888889
15095, 0.47826086956522, 1.4, 0.44444444444444
15096, 0.52173913043478, 1.4, 0.055555555555556
15097, 0.52173913043478, 1.4, 0.11111111111111
15098, 0.52173913043478, 1.4, 0.16666666666667
15099, 0.52173913043478, 1.4, 0.22222222222222
15100, 0.52173913043478, 1.4, 0.27777777777778
15101, 0.52173913043478, 1.4, 0.33333333333333
15102, 0.52173913043478, 1.4, 0.38888888888889
15103, 0.52173913043478, 1.4, 0.44444444444444
15104, 0.56521739130435, 1.4, 0.055555555555556
15105, 0.56521739130435, 1.4, 0.11111111111111
15106, 0.56521739130435, 1.4, 0.16666666666667
15107, 0.56521739130435, 1.4, 0.22222222222222
15108, 0.56521739130435, 1.4, 0.27777777777778
15109, 0.56521739130435, 1.4, 0.33333333333333
15110, 0.56521739130435, 1.4, 0.38888888888889
15111, 0.56521739130435, 1.4, 0.44444444444444
15112, 0.60869565217391, 1.4, 0.055555555555556
15113, 0.60869565217391, 1.4, 0.11111111111111
15114, 0.60869565217391, 1.4, 0.16666666666667
15115, 0.60869565217391, 1.4, 0.22222222222222
15116, 0.60869565217391, 1.4, 0.27777777777778
15117, 0.60869565217391, 1.4, 0.33333333333333
15118, 0.60869565217391, 1.4, 0.38888888888889
15119, 0.60869565217391, 1.4, 0.44444444444444
15120, 0.65217391304348, 1.4, 0.055555555555556
15121, 0.65217391304348, 1.4, 0.11111111111111
15122, 0.65217391304348, 1.4, 0.16666666666667
15123, 0.65217391304348, 1.4, 0.22222222222222
15124, 0.65217391304348, 1.4, 0.27777777777778
15125, 0.65217391304348, 1.4, 0.33333333333333
15126, 0.65217391304348, 1.4, 0.38888888888889
15127, 0.65217391304348, 1.4, 0.44444444444444
15128, 0.69565217391304, 1.4, 0.055555555555556
15129, 0.69565217391304, 1.4, 0.11111111111111
15130, 0.69565217391304, 1.4, 0.16666666666667
15131, 0.69565217391304, 1.4, 0.22222222222222
15132, 0.69565217391304, 1.4, 0.27777777777778
15133, 0.69565217391304, 1.4, 0.33333333333333
15134, 0.69565217391304, 1.4, 0.38888888888889
15135, 0.69565217391304, 1.4, 0.44444444444444
15136, 0.73913043478261, 1.4, 0.055555555555556
15137, 0.73913043478261, 1.4, 0.11111111111111
15138, 0.73913043478261, 1.4, 0.16666666666667
15139, 0.73913043478261, 1.4, 0.22222222222222
15140, 0.73913043478261, 1.4, 0.27777777777778
15141, 0.73913043478261, 1.4, 0.33333333333333
15142, 0.73913043478261, 1.4, 0.38888888888889
15143, 0.73913043478261, 1.4, 0.44444444444444
15144, 0.78260869565217, 1.4, 0.055555555555556
15145, 0.78260869565217, 1.4, 0.11111111111111
15146, 0.78260869565217, 1.4, 0.16666666666667
15147, 0.78260869565217, 1.4, 0.22222222222222
15148, 0.78260869565217, 1.4, 0.27777777777778
15149, 0.78260869565217, 1.4, 0.33333333333333
15150, 0.78260869565217, 1.4, 0.38888888888889
15151, 0.78260869565217, 1.4, 0.44444444444444
15152, 0.82608695652174, 1.4, 0.055555555555556
15153, 0.82608695652174, 1.4, 0.11111111111111
15154, 0.82608695652174, 1.4, 0.16666666666667
15155, 0.82608695652174, 1.4, 0.22222222222222
15156, 0.82608695652174, 1.4, 0.27777777777778
15157, 0.82608695652174, 1.4, 0.33333333333333
15158, 0.82608695652174, 1.4, 0.38888888888889
15159, 0.82608695652174, 1.4, 0.44444444444444
15160, 0.8695652173913, 1.4, 0.055555555555556
15161, 0.8695652173913, 1.4, 0.11111111111111
15162, 0.8695652173913, 1.4, 0.16666666666667
15163, 0.8695652173913, 1.4, 0.22222222222222
15164, 0.8695652173913, 1.4, 0.27777777777778
15165, 0.8695652173913, 1.4, 0.33333333333333
15166, 0.8695652173913, 1.4, 0.38888888888889
15167, 0.8695652173913, 1.4, 0.44444444444444
15168, 0.91304347826087, 1.4, 0.055555555555556
15169, 0.91304347826087, 1.4, 0.11111111111111
15170, 0.91304347826087, 1.4, 0.16666666666667
15171, 0.91304347826087, 1.4, 0.22222222222222
15172, 0.91304347826087, 1.4, 0.27777777777778
15173, 0.91304347826087, 1.4, 0.33333333333333
15174, 0.91304347826087, 1.4, 0.38888888888889
15175, 0.91304347826087, 1.4, 0.44444444444444
15176, 0.95652173913043, 1.4, 0.055555555555556
15177, 0.95652173913043, 1.4, 0.11111111111111
15178, 0.95652173913043, 1.4, 0.16666666666667
15179, 0.95652173913043, 1.4, 0.22222222222222
15180, 0.95652173913043, 1.4, 0.27777777777778
15181, 0.95652173913043, 1.4, 0.33333333333333
15182, 0.95652173913043, 1.4, 0.38888888888889
15183, 0.95652173913043, 1.4, 0.44444444444444
15184, 0.043478260869565, 1.4, 0.027777777777778
15185, 0.021739130434783, 1.4, 0.055555555555556
15186, 0.043478260869565, 1.4, 0.083333333333333
15187, 0.021739130434783, 1.4, 0.11111111111111
15188, 0.043478260869565, 1.4, 0.13888888888889
15189, 0.021739130434783, 1.4, 0.16666666666667
15190, 0.043478260869565, 1.4, 0.19444444444444
15191, 0.021739130434783, 1.4, 0.22222222222222
15192, 0.043478260869565, 1.4, 0.25
15193, 0.021739130434783, 1.4, 0.27777777777778
15194, 0.043478260869565, 1.4, 0.30555555555556
15195, 0.021739130434783, 1.4, 0.33333333333333
15196, 0.043478260869565, 1.4, 0.36111111111111
15197, 0.021739130434783, 1.4, 0.38888888888889
15198, 0.043478260869565, 1.4, 0.41666666666667
15199, 0.021739130434783, 1.4, 0.44444444444444
15200, 0.043478260869565, 1.4, 0.47222222222222
15201, 0.08695652173913, 1.4, 0.027777777777778
15202, 0.065217391304348, 1.4, 0.055555555555556
15203, 0.08695652173913, 1.4, 0.083333333333333
15204, 0.065217391304348, 1.4, 0.11111111111111
15205, 0.08695652173913, 1.4, 0.13888888888889
15206, 0.065217391304348, 1.4, 0.16666666666667
15207, 0.08695652173913, 1.4, 0.19444444444444
15208, 0.065217391304348, 1.4, 0.22222222222222
15209, 0.08695652173913, 1.4, 0.25
15210, 0.065217391304348, 1.4, 0.27777777777778
15211, 0.08695652173913, 1.4, 0.30555555555556
