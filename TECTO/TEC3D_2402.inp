739, 1302, 1311, 1303
740, 1303, 1312, 1304
741, 1304, 1313, 1305
742, 1305, 1314, 1306
743, 1306, 1315, 1307
744, 1307, 1316, 1308
745, 1308, 1317, 36
*ELEMENT, type=T3D3, ELSET=Line306
746, 36, 1319, 1318
747, 1318, 1320, 39
*ELEMENT, type=T3D3, ELSET=Line307
748, 31, 1322, 1321
749, 1321, 1323, 40
*ELEMENT, type=T3D3, ELSET=Line308
750, 39, 1326, 1324
751, 1324, 1327, 1325
752, 1325, 1328, 40
*ELEMENT, type=T3D3, ELSET=Line309
753, 38, 1330, 1329
754, 1329, 1331, 41
*ELEMENT, type=T3D3, ELSET=Line310
755, 33, 1333, 1332
756, 1332, 1334, 42
*ELEMENT, type=T3D3, ELSET=Line311
757, 41, 1337, 1335
758, 1335, 1338, 1336
759, 1336, 1339, 42
*ELEMENT, type=T3D3, ELSET=Line312
760, 41, 1348, 1340
761, 1340, 1349, 1341
762, 1341, 1350, 1342
763, 1342, 1351, 1343
764, 1343, 1352, 1344
765, 1344, 1353, 1345
766, 1345, 1354, 1346
767, 1346, 1355, 1347
768, 1347, 1356, 39
*ELEMENT, type=T3D3, ELSET=Line313
769, 42, 1365, 1357
770, 1357, 1366, 1358
771, 1358, 1367, 1359
772, 1359, 1368, 1360
773, 1360, 1369, 1361
774, 1361, 1370, 1362
775, 1362, 1371, 1363
776, 1363, 1372, 1364
777, 1364, 1373, 40
*ELEMENT, type=T3D3, ELSET=Line314
778, 40, 1377, 1374
779, 1374, 1378, 1375
780, 1375, 1379, 1376
781, 1376, 1380, 43
*ELEMENT, type=T3D3, ELSET=Line315
782, 32, 1382, 1381
783, 1381, 1383, 43
*ELEMENT, type=T3D3, ELSET=Line316
784, 42, 1387, 1384
785, 1384, 1388, 1385
786, 1385, 1389, 1386
787, 1386, 1390, 44
*ELEMENT, type=T3D3, ELSET=Line317
788, 34, 1392, 1391
789, 1391, 1393, 44
*ELEMENT, type=T3D3, ELSET=Line318
790, 44, 1402, 1394
791, 1394, 1403, 1395
792, 1395, 1404, 1396
793, 1396, 1405, 1397
794, 1397, 1406, 1398
795, 1398, 1407, 1399
796, 1399, 1408, 1400
797, 1400, 1409, 1401
798, 1401, 1410, 43
*ELEMENT, type=T3D3, ELSET=Line319
799, 45, 1413, 1411
800, 1411, 1414, 1412
801, 1412, 1415, 46
*ELEMENT, type=T3D3, ELSET=Line320
802, 47, 1418, 1416
803, 1416, 1419, 1417
804, 1417, 1420, 48
*ELEMENT, type=T3D3, ELSET=Line321
805, 47, 1443, 1421
806, 1421, 1444, 1422
807, 1422, 1445, 1423
808, 1423, 1446, 1424
809, 1424, 1447, 1425
810, 1425, 1448, 1426
811, 1426, 1449, 1427
812, 1427, 1450, 1428
813, 1428, 1451, 1429
814, 1429, 1452, 1430
815, 1430, 1453, 1431
816, 1431, 1454, 1432
817, 1432, 1455, 1433
818, 1433, 1456, 1434
819, 1434, 1457, 1435
820, 1435, 1458, 1436
821, 1436, 1459, 1437
822, 1437, 1460, 1438
823, 1438, 1461, 1439
824, 1439, 1462, 1440
825, 1440, 1463, 1441
826, 1441, 1464, 1442
827, 1442, 1465, 45
*ELEMENT, type=T3D3, ELSET=Line322
828, 48, 1488, 1466
829, 1466, 1489, 1467
830, 1467, 1490, 1468
831, 1468, 1491, 1469
832, 1469, 1492, 1470
833, 1470, 1493, 1471
834, 1471, 1494, 1472
835, 1472, 1495, 1473
836, 1473, 1496, 1474
837, 1474, 1497, 1475
838, 1475, 1498, 1476
839, 1476, 1499, 1477
840, 1477, 1500, 1478
841, 1478, 1501, 1479
842, 1479, 1502, 1480
843, 1480, 1503, 1481
844, 1481, 1504, 1482
845, 1482, 1505, 1483
846, 1483, 1506, 1484
847, 1484, 1507, 1485
848, 1485, 1508, 1486
849, 1486, 1509, 1487
850, 1487, 1510, 46
*ELEMENT, type=T3D3, ELSET=Line323
851, 49, 1513, 1511
852, 1511, 1514, 1512
853, 1512, 1515, 50
*ELEMENT, type=T3D3, ELSET=Line324
854, 45, 1524, 1516
855, 1516, 1525, 1517
856, 1517, 1526, 1518
857, 1518, 1527, 1519
858, 1519, 1528, 1520
859, 1520, 1529, 1521
860, 1521, 1530, 1522
861, 1522, 1531, 1523
862, 1523, 1532, 49
*ELEMENT, type=T3D3, ELSET=Line325
863, 46, 1541, 1533
864, 1533, 1542, 1534
865, 1534, 1543, 1535
866, 1535, 1544, 1536
867, 1536, 1545, 1537
868, 1537, 1546, 1538
869, 1538, 1547, 1539
870, 1539, 1548, 1540
871, 1540, 1549, 50
*ELEMENT, type=T3D3, ELSET=Line326
872, 51, 1552, 1550
873, 1550, 1553, 1551
874, 1551, 1554, 52
*ELEMENT, type=T3D3, ELSET=Line327
875, 51, 1577, 1555
876, 1555, 1578, 1556
877, 1556, 1579, 1557
878, 1557, 1580, 1558
879, 1558, 1581, 1559
880, 1559, 1582, 1560
881, 1560, 1583, 1561
882, 1561, 1584, 1562
883, 1562, 1585, 1563
884, 1563, 1586, 1564
885, 1564, 1587, 1565
886, 1565, 1588, 1566
887, 1566, 1589, 1567
888, 1567, 1590, 1568
889, 1568, 1591, 1569
890, 1569, 1592, 1570
891, 1570, 1593, 1571
892, 1571, 1594, 1572
893, 1572, 1595, 1573
894, 1573, 1596, 1574
895, 1574, 1597, 1575
896, 1575, 1598, 1576
897, 1576, 1599, 49
*ELEMENT, type=T3D3, ELSET=Line328
898, 52, 1622, 1600
899, 1600, 1623, 1601
900, 1601, 1624, 1602
901, 1602, 1625, 1603
902, 1603, 1626, 1604
903, 1604, 1627, 1605
904, 1605, 1628, 1606
905, 1606, 1629, 1607
906, 1607, 1630, 1608
907, 1608, 1631, 1609
908, 1609, 1632, 1610
909, 1610, 1633, 1611
910, 1611, 1634, 1612
911, 1612, 1635, 1613
912, 1613, 1636, 1614
913, 1614, 1637, 1615
914, 1615, 1638, 1616
915, 1616, 1639, 1617
916, 1617, 1640, 1618
917, 1618, 1641, 1619
918, 1619, 1642, 1620
919, 1620, 1643, 1621
920, 1621, 1644, 50
*ELEMENT, type=T3D3, ELSET=Line329
921, 47, 1653, 1645
922, 1645, 1654, 1646
923, 1646, 1655, 1647
924, 1647, 1656, 1648
925, 1648, 1657, 1649
926, 1649, 1658, 1650
927, 1650, 1659, 1651
928, 1651, 1660, 1652
929, 1652, 1661, 51
*ELEMENT, type=T3D3, ELSET=Line330
930, 48, 1670, 1662
931, 1662, 1671, 1663
932, 1663, 1672, 1664
933, 1664, 1673, 1665
934, 1665, 1674, 1666
935, 1666, 1675, 1667
936, 1667, 1676, 1668
937, 1668, 1677, 1669
938, 1669, 1678, 52
*ELEMENT, type=T3D3, ELSET=Line331
939, 49, 1682, 1679
940, 1679, 1683, 1680
941, 1680, 1684, 1681
942, 1681, 1685, 53
*ELEMENT, type=T3D3, ELSET=Line332
943, 50, 1689, 1686
944, 1686, 1690, 1687
945, 1687, 1691, 1688
946, 1688, 1692, 54
*ELEMENT, type=T3D3, ELSET=Line333
947, 53, 1695, 1693
948, 1693, 1696, 1694
949, 1694, 1697, 54
*ELEMENT, type=T3D3, ELSET=Line334
950, 45, 1701, 1698
951, 1698, 1702, 1699
952, 1699, 1703, 1700
953, 1700, 1704, 55
*ELEMENT, type=T3D3, ELSET=Line335
954, 46, 1708, 1705
955, 1705, 1709, 1706
956, 1706, 1710, 1707
957, 1707, 1711, 56
*ELEMENT, type=T3D3, ELSET=Line336
958, 55, 1714, 1712
959, 1712, 1715, 1713
960, 1713, 1716, 56
*ELEMENT, type=T3D3, ELSET=Line337
961, 55, 1725, 1717
962, 1717, 1726, 1718
963, 1718, 1727, 1719
964, 1719, 1728, 1720
965, 1720, 1729, 1721
966, 1721, 1730, 1722
967, 1722, 1731, 1723
968, 1723, 1732, 1724
969, 1724, 1733, 53
*ELEMENT, type=T3D3, ELSET=Line338
970, 56, 1742, 1734
971, 1734, 1743, 1735
972, 1735, 1744, 1736
973, 1736, 1745, 1737
974, 1737, 1746, 1738
975, 1738, 1747, 1739
976, 1739, 1748, 1740
977, 1740, 1749, 1741
978, 1741, 1750, 54
*ELEMENT, type=T3D3, ELSET=Line339
979, 50, 1754, 1751
980, 1751, 1755, 1752
981, 1752, 1756, 1753
982, 1753, 1757, 57
*ELEMENT, type=T3D3, ELSET=Line340
983, 54, 1761, 1758
984, 1758, 1762, 1759
985, 1759, 1763, 1760
986, 1760, 1764, 58
*ELEMENT, type=T3D3, ELSET=Line341
987, 57, 1768, 1765
988, 1765, 1769, 1766
989, 1766, 1770, 1767
990, 1767, 1771, 58
*ELEMENT, type=T3D3, ELSET=Line342
991, 46, 1775, 1772
992, 1772, 1776, 1773
993, 1773, 1777, 1774
994, 1774, 1778, 59
*ELEMENT, type=T3D3, ELSET=Line343
995, 56, 1782, 1779
996, 1779, 1783, 1780
997, 1780, 1784, 1781
998, 1781, 1785, 60
*ELEMENT, type=T3D3, ELSET=Line344
999, 59, 1789, 1786
1000, 1786, 1790, 1787
1001, 1787, 1791, 1788
1002, 1788, 1792, 60
*ELEMENT, type=T3D3, ELSET=Line345
1003, 59, 1801, 1793
1004, 1793, 1802, 1794
1005, 1794, 1803, 1795
1006, 1795, 1804, 1796
1007, 1796, 1805, 1797
1008, 1797, 1806, 1798
1009, 1798, 1807, 1799
1010, 1799, 1808, 1800
1011, 1800, 1809, 57
*ELEMENT, type=T3D3, ELSET=Line346
1012, 60, 1818, 1810
1013, 1810, 1819, 1811
1014, 1811, 1820, 1812
1015, 1812, 1821, 1813
1016, 1813, 1822, 1814
1017, 1814, 1823, 1815
1018, 1815, 1824, 1816
1019, 1816, 1825, 1817
1020, 1817, 1826, 58
*ELEMENT, type=T3D3, ELSET=Line347
1021, 48, 1830, 1827
1022, 1827, 1831, 1828
1023, 1828, 1832, 1829
1024, 1829, 1833, 61
*ELEMENT, type=T3D3, ELSET=Line348
1025, 61, 1856, 1834
1026, 1834, 1857, 1835
1027, 1835, 1858, 1836
1028, 1836, 1859, 1837
1029, 1837, 1860, 1838
1030, 1838, 1861, 1839
1031, 1839, 1862, 1840
1032, 1840, 1863, 1841
1033, 1841, 1864, 1842
1034, 1842, 1865, 1843
1035, 1843, 1866, 1844
1036, 1844, 1867, 1845
1037, 1845, 1868, 1846
1038, 1846, 1869, 1847
1039, 1847, 1870, 1848
1040, 1848, 1871, 1849
1041, 1849, 1872, 1850
1042, 1850, 1873, 1851
1043, 1851, 1874, 1852
1044, 1852, 1875, 1853
1045, 1853, 1876, 1854
1046, 1854, 1877, 1855
1047, 1855, 1878, 59
*ELEMENT, type=T3D3, ELSET=Line349
1048, 52, 1882, 1879
1049, 1879, 1883, 1880
1050, 1880, 1884, 1881
1051, 1881, 1885, 62
*ELEMENT, type=T3D3, ELSET=Line350
1052, 62, 1908, 1886
1053, 1886, 1909, 1887
1054, 1887, 1910, 1888
1055, 1888, 1911, 1889
1056, 1889, 1912, 1890
1057, 1890, 1913, 1891
1058, 1891, 1914, 1892
1059, 1892, 1915, 1893
1060, 1893, 1916, 1894
1061, 1894, 1917, 1895
1062, 1895, 1918, 1896
1063, 1896, 1919, 1897
1064, 1897, 1920, 1898
1065, 1898, 1921, 1899
1066, 1899, 1922, 1900
1067, 1900, 1923, 1901
1068, 1901, 1924, 1902
1069, 1902, 1925, 1903
1070, 1903, 1926, 1904
1071, 1904, 1927, 1905
1072, 1905, 1928, 1906
1073, 1906, 1929, 1907
1074, 1907, 1930, 57
*ELEMENT, type=T3D3, ELSET=Line351
1075, 61, 1939, 1931
1076, 1931, 1940, 1932
1077, 1932, 1941, 1933
1078, 1933, 1942, 1934
1079, 1934, 1943, 1935
1080, 1935, 1944, 1936
1081, 1936, 1945, 1937
1082, 1937, 1946, 1938
1083, 1938, 1947, 62
*ELEMENT, type=T3D3, ELSET=Line352
1084, 52, 1949, 1948
1085, 1948, 1950, 63
*ELEMENT, type=T3D3, ELSET=Line353
1086, 62, 1952, 1951
1087, 1951, 1953, 64
*ELEMENT, type=T3D3, ELSET=Line354
1088, 63, 1957, 1954
1089, 1954, 1958, 1955
1090, 1955, 1959, 1956
1091, 1956, 1960, 64
*ELEMENT, type=T3D3, ELSET=Line355
1092, 48, 1962, 1961
1093, 1961, 1963, 65
*ELEMENT, type=T3D3, ELSET=Line356
1094, 61, 1965, 1964
1095, 1964, 1966, 66
*ELEMENT, type=T3D3, ELSET=Line357
1096, 65, 1970, 1967
1097, 1967, 1971, 1968
1098, 1968, 1972, 1969
1099, 1969, 1973, 66
*ELEMENT, type=T3D3, ELSET=Line358
1100, 65, 1982, 1974
1101, 1974, 1983, 1975
1102, 1975, 1984, 1976
1103, 1976, 1985, 1977
1104, 1977, 1986, 1978
1105, 1978, 1987, 1979
1106, 1979, 1988, 1980
1107, 1980, 1989, 1981
1108, 1981, 1990, 63
*ELEMENT, type=T3D3, ELSET=Line359
1109, 66, 1999, 1991
1110, 1991, 2000, 1992
1111, 1992, 2001, 1993
1112, 1993, 2002, 1994
1113, 1994, 2003, 1995
1114, 1995, 2004, 1996
1115, 1996, 2005, 1997
1116, 1997, 2006, 1998
1117, 1998, 2007, 64
*ELEMENT, type=T3D3, ELSET=Line360
1118, 67, 2009, 2008
1119, 2008, 2010, 45
*ELEMENT, type=T3D3, ELSET=Line361
1120, 68, 2012, 2011
1121, 2011, 2013, 47
*ELEMENT, type=T3D3, ELSET=Line362
1122, 68, 2036, 2014
1123, 2014, 2037, 2015
1124, 2015, 2038, 2016
1125, 2016, 2039, 2017
1126, 2017, 2040, 2018
1127, 2018, 2041, 2019
1128, 2019, 2042, 2020
1129, 2020, 2043, 2021
1130, 2021, 2044, 2022
1131, 2022, 2045, 2023
1132, 2023, 2046, 2024
1133, 2024, 2047, 2025
1134, 2025, 2048, 2026
1135, 2026, 2049, 2027
1136, 2027, 2050, 2028
1137, 2028, 2051, 2029
1138, 2029, 2052, 2030
1139, 2030, 2053, 2031
1140, 2031, 2054, 2032
1141, 2032, 2055, 2033
1142, 2033, 2056, 2034
1143, 2034, 2057, 2035
1144, 2035, 2058, 67
*ELEMENT, type=T3D3, ELSET=Line363
1145, 69, 2060, 2059
1146, 2059, 2061, 49
*ELEMENT, type=T3D3, ELSET=Line364
1147, 67, 2070, 2062
1148, 2062, 2071, 2063
1149, 2063, 2072, 2064
1150, 2064, 2073, 2065
1151, 2065, 2074, 2066
1152, 2066, 2075, 2067
1153, 2067, 2076, 2068
1154, 2068, 2077, 2069
1155, 2069, 2078, 69
*ELEMENT, type=T3D3, ELSET=Line365
1156, 70, 2080, 2079
1157, 2079, 2081, 51
*ELEMENT, type=T3D3, ELSET=Line366
1158, 70, 2104, 2082
1159, 2082, 2105, 2083
1160, 2083, 2106, 2084
1161, 2084, 2107, 2085
1162, 2085, 2108, 2086
1163, 2086, 2109, 2087
1164, 2087, 2110, 2088
1165, 2088, 2111, 2089
1166, 2089, 2112, 2090
1167, 2090, 2113, 2091
1168, 2091, 2114, 2092
1169, 2092, 2115, 2093
1170, 2093, 2116, 2094
1171, 2094, 2117, 2095
1172, 2095, 2118, 2096
1173, 2096, 2119, 2097
1174, 2097, 2120, 2098
1175, 2098, 2121, 2099
1176, 2099, 2122, 2100
1177, 2100, 2123, 2101
1178, 2101, 2124, 2102
1179, 2102, 2125, 2103
1180, 2103, 2126, 69
*ELEMENT, type=T3D3, ELSET=Line367
1181, 68, 2135, 2127
1182, 2127, 2136, 2128
1183, 2128, 2137, 2129
1184, 2129, 2138, 2130
1185, 2130, 2139, 2131
1186, 2131, 2140, 2132
1187, 2132, 2141, 2133
1188, 2133, 2142, 2134
1189, 2134, 2143, 70
*ELEMENT, type=T3D3, ELSET=Line368
1190, 53, 2145, 2144
1191, 2144, 2146, 71
*ELEMENT, type=T3D3, ELSET=Line369
1192, 72, 2148, 2147
1193, 2147, 2149, 73
*ELEMENT, type=T3D3, ELSET=Line370
1194, 53, 2172, 2150
1195, 2150, 2173, 2151
1196, 2151, 2174, 2152
1197, 2152, 2175, 2153
1198, 2153, 2176, 2154
1199, 2154, 2177, 2155
1200, 2155, 2178, 2156
1201, 2156, 2179, 2157
1202, 2157, 2180, 2158
1203, 2158, 2181, 2159
1204, 2159, 2182, 2160
1205, 2160, 2183, 2161
1206, 2161, 2184, 2162
1207, 2162, 2185, 2163
1208, 2163, 2186, 2164
1209, 2164, 2187, 2165
1210, 2165, 2188, 2166
1211, 2166, 2189, 2167
1212, 2167, 2190, 2168
1213, 2168, 2191, 2169
1214, 2169, 2192, 2170
1215, 2170, 2193, 2171
1216, 2171, 2194, 72
*ELEMENT, type=T3D3, ELSET=Line371
1217, 71, 2217, 2195
1218, 2195, 2218, 2196
1219, 2196, 2219, 2197
1220, 2197, 2220, 2198
1221, 2198, 2221, 2199
1222, 2199, 2222, 2200
1223, 2200, 2223, 2201
1224, 2201, 2224, 2202
1225, 2202, 2225, 2203
1226, 2203, 2226, 2204
1227, 2204, 2227, 2205
1228, 2205, 2228, 2206
1229, 2206, 2229, 2207
1230, 2207, 2230, 2208
1231, 2208, 2231, 2209
1232, 2209, 2232, 2210
1233, 2210, 2233, 2211
1234, 2211, 2234, 2212
1235, 2212, 2235, 2213
1236, 2213, 2236, 2214
1237, 2214, 2237, 2215
1238, 2215, 2238, 2216
1239, 2216, 2239, 73
*ELEMENT, type=T3D3, ELSET=Line372
1240, 55, 2241, 2240
1241, 2240, 2242, 74
*ELEMENT, type=T3D3, ELSET=Line373
1242, 75, 2244, 2243
1243, 2243, 2245, 76
*ELEMENT, type=T3D3, ELSET=Line374
1244, 55, 2268, 2246
1245, 2246, 2269, 2247
1246, 2247, 2270, 2248
1247, 2248, 2271, 2249
1248, 2249, 2272, 2250
1249, 2250, 2273, 2251
1250, 2251, 2274, 2252
1251, 2252, 2275, 2253
1252, 2253, 2276, 2254
1253, 2254, 2277, 2255
1254, 2255, 2278, 2256
1255, 2256, 2279, 2257
1256, 2257, 2280, 2258
1257, 2258, 2281, 2259
1258, 2259, 2282, 2260
1259, 2260, 2283, 2261
1260, 2261, 2284, 2262
1261, 2262, 2285, 2263
1262, 2263, 2286, 2264
1263, 2264, 2287, 2265
1264, 2265, 2288, 2266
1265, 2266, 2289, 2267
1266, 2267, 2290, 75
*ELEMENT, type=T3D3, ELSET=Line375
1267, 74, 2313, 2291
1268, 2291, 2314, 2292
1269, 2292, 2315, 2293
1270, 2293, 2316, 2294
1271, 2294, 2317, 2295
1272, 2295, 2318, 2296
1273, 2296, 2319, 2297
1274, 2297, 2320, 2298
1275, 2298, 2321, 2299
1276, 2299, 2322, 2300
1277, 2300, 2323, 2301
1278, 2301, 2324, 2302
1279, 2302, 2325, 2303
1280, 2303, 2326, 2304
1281, 2304, 2327, 2305
1282, 2305, 2328, 2306
1283, 2306, 2329, 2307
1284, 2307, 2330, 2308
1285, 2308, 2331, 2309
1286, 2309, 2332, 2310
1287, 2310, 2333, 2311
1288, 2311, 2334, 2312
1289, 2312, 2335, 76
*ELEMENT, type=T3D3, ELSET=Line376
1290, 74, 2344, 2336
1291, 2336, 2345, 2337
1292, 2337, 2346, 2338
1293, 2338, 2347, 2339
1294, 2339, 2348, 2340
1295, 2340, 2349, 2341
1296, 2341, 2350, 2342
1297, 2342, 2351, 2343
1298, 2343, 2352, 71
*ELEMENT, type=T3D3, ELSET=Line377
1299, 75, 2361, 2353
1300, 2353, 2362, 2354
1301, 2354, 2363, 2355
1302, 2355, 2364, 2356
1303, 2356, 2365, 2357
1304, 2357, 2366, 2358
1305, 2358, 2367, 2359
1306, 2359, 2368, 2360
1307, 2360, 2369, 72
*ELEMENT, type=T3D3, ELSET=Line378
1308, 76, 2378, 2370
1309, 2370, 2379, 2371
1310, 2371, 2380, 2372
1311, 2372, 2381, 2373
1312, 2373, 2382, 2374
1313, 2374, 2383, 2375
1314, 2375, 2384, 2376
1315, 2376, 2385, 2377
1316, 2377, 2386, 73
*ELEMENT, type=T3D3, ELSET=Line379
1317, 54, 2409, 2387
1318, 2387, 2410, 2388
1319, 2388, 2411, 2389
1320, 2389, 2412, 2390
1321, 2390, 2413, 2391
1322, 2391, 2414, 2392
1323, 2392, 2415, 2393
1324, 2393, 2416, 2394
1325, 2394, 2417, 2395
1326, 2395, 2418, 2396
1327, 2396, 2419, 2397
1328, 2397, 2420, 2398
1329, 2398, 2421, 2399
1330, 2399, 2422, 2400
1331, 2400, 2423, 2401
1332, 2401, 2424, 2402
1333, 2402, 2425, 2403
1334, 2403, 2426, 2404
1335, 2404, 2427, 2405
1336, 2405, 2428, 2406
1337, 2406, 2429, 2407
1338, 2407, 2430, 2408
1339, 2408, 2431, 77
*ELEMENT, type=T3D3, ELSET=Line380
1340, 72, 2434, 2432
1341, 2432, 2435, 2433
1342, 2433, 2436, 77
*ELEMENT, type=T3D3, ELSET=Line381
1343, 56, 2459, 2437
1344, 2437, 2460, 2438
1345, 2438, 2461, 2439
1346, 2439, 2462, 2440
1347, 2440, 2463, 2441
1348, 2441, 2464, 2442
1349, 2442, 2465, 2443
1350, 2443, 2466, 2444
1351, 2444, 2467, 2445
1352, 2445, 2468, 2446
1353, 2446, 2469, 2447
1354, 2447, 2470, 2448
1355, 2448, 2471, 2449
1356, 2449, 2472, 2450
1357, 2450, 2473, 2451
1358, 2451, 2474, 2452
1359, 2452, 2475, 2453
1360, 2453, 2476, 2454
1361, 2454, 2477, 2455
1362, 2455, 2478, 2456
1363, 2456, 2479, 2457
1364, 2457, 2480, 2458
1365, 2458, 2481, 78
*ELEMENT, type=T3D3, ELSET=Line382
1366, 75, 2484, 2482
1367, 2482, 2485, 2483
1368, 2483, 2486, 78
*ELEMENT, type=T3D3, ELSET=Line383
1369, 78, 2495, 2487
1370, 2487, 2496, 2488
1371, 2488, 2497, 2489
1372, 2489, 2498, 2490
1373, 2490, 2499, 2491
1374, 2491, 2500, 2492
1375, 2492, 2501, 2493
1376, 2493, 2502, 2494
1377, 2494, 2503, 77
*ELEMENT, type=T3D3, ELSET=Line384
1378, 77, 2507, 2504
1379, 2504, 2508, 2505
1380, 2505, 2509, 2506
1381, 2506, 2510, 79
*ELEMENT, type=T3D3, ELSET=Line385
1382, 58, 2533, 2511
1383, 2511, 2534, 2512
1384, 2512, 2535, 2513
1385, 2513, 2536, 2514
1386, 2514, 2537, 2515
1387, 2515, 2538, 2516
1388, 2516, 2539, 2517
1389, 2517, 2540, 2518
1390, 2518, 2541, 2519
1391, 2519, 2542, 2520
1392, 2520, 2543, 2521
1393, 2521, 2544, 2522
1394, 2522, 2545, 2523
1395, 2523, 2546, 2524
1396, 2524, 2547, 2525
1397, 2525, 2548, 2526
1398, 2526, 2549, 2527
1399, 2527, 2550, 2528
1400, 2528, 2551, 2529
1401, 2529, 2552, 2530
1402, 2530, 2553, 2531
1403, 2531, 2554, 2532
1404, 2532, 2555, 79
*ELEMENT, type=T3D3, ELSET=Line386
1405, 78, 2559, 2556
1406, 2556, 2560, 2557
1407, 2557, 2561, 2558
1408, 2558, 2562, 80
*ELEMENT, type=T3D3, ELSET=Line387
1409, 60, 2585, 2563
1410, 2563, 2586, 2564
1411, 2564, 2587, 2565
1412, 2565, 2588, 2566
1413, 2566, 2589, 2567
1414, 2567, 2590, 2568
1415, 2568, 2591, 2569
1416, 2569, 2592, 2570
1417, 2570, 2593, 2571
1418, 2571, 2594, 2572
1419, 2572, 2595, 2573
1420, 2573, 2596, 2574
1421, 2574, 2597, 2575
1422, 2575, 2598, 2576
1423, 2576, 2599, 2577
1424, 2577, 2600, 2578
1425, 2578, 2601, 2579
1426, 2579, 2602, 2580
1427, 2580, 2603, 2581
1428, 2581, 2604, 2582
1429, 2582, 2605, 2583
1430, 2583, 2606, 2584
1431, 2584, 2607, 80
*ELEMENT, type=T3D3, ELSET=Line388
1432, 80, 2616, 2608
1433, 2608, 2617, 2609
1434, 2609, 2618, 2610
1435, 2610, 2619, 2611
1436, 2611, 2620, 2612
1437, 2612, 2621, 2613
1438, 2613, 2622, 2614
1439, 2614, 2623, 2615
1440, 2615, 2624, 79
*ELEMENT, type=T3D3, ELSET=Line389
1441, 77, 2626, 2625
1442, 2625, 2627, 81
*ELEMENT, type=T3D3, ELSET=Line390
1443, 79, 2629, 2628
1444, 2628, 2630, 82
*ELEMENT, type=T3D3, ELSET=Line391
1445, 81, 2634, 2631
1446, 2631, 2635, 2632
1447, 2632, 2636, 2633
1448, 2633, 2637, 82
*ELEMENT, type=T3D3, ELSET=Line392
1449, 78, 2639, 2638
1450, 2638, 2640, 83
*ELEMENT, type=T3D3, ELSET=Line393
1451, 80, 2642, 2641
1452, 2641, 2643, 84
*ELEMENT, type=T3D3, ELSET=Line394
1453, 83, 2647, 2644
1454, 2644, 2648, 2645
1455, 2645, 2649, 2646
1456, 2646, 2650, 84
*ELEMENT, type=T3D3, ELSET=Line395
1457, 83, 2659, 2651
1458, 2651, 2660, 2652
1459, 2652, 2661, 2653
1460, 2653, 2662, 2654
1461, 2654, 2663, 2655
1462, 2655, 2664, 2656
1463, 2656, 2665, 2657
1464, 2657, 2666, 2658
1465, 2658, 2667, 81
*ELEMENT, type=T3D3, ELSET=Line396
1466, 84, 2676, 2668
1467, 2668, 2677, 2669
1468, 2669, 2678, 2670
1469, 2670, 2679, 2671
1470, 2671, 2680, 2672
1471, 2672, 2681, 2673
1472, 2673, 2682, 2674
1473, 2674, 2683, 2675
1474, 2675, 2684, 82
*ELEMENT, type=T3D3, ELSET=Line397
1475, 85, 2686, 2685
1476, 2685, 2687, 1
*ELEMENT, type=T3D3, ELSET=Line398
1477, 86, 2689, 2688
1478, 2688, 2690, 2
*ELEMENT, type=T3D3, ELSET=Line399
1479, 86, 2713, 2691
1480, 2691, 2714, 2692
1481, 2692, 2715, 2693
1482, 2693, 2716, 2694
1483, 2694, 2717, 2695
1484, 2695, 2718, 2696
1485, 2696, 2719, 2697
1486, 2697, 2720, 2698
1487, 2698, 2721, 2699
1488, 2699, 2722, 2700
1489, 2700, 2723, 2701
1490, 2701, 2724, 2702
1491, 2702, 2725, 2703
1492, 2703, 2726, 2704
1493, 2704, 2727, 2705
1494, 2705, 2728, 2706
1495, 2706, 2729, 2707
1496, 2707, 2730, 2708
1497, 2708, 2731, 2709
1498, 2709, 2732, 2710
1499, 2710, 2733, 2711
1500, 2711, 2734, 2712
1501, 2712, 2735, 85
*ELEMENT, type=T3D3, ELSET=Line400
1502, 87, 2737, 2736
1503, 2736, 2738, 3
*ELEMENT, type=T3D3, ELSET=Line401
1504, 85, 2747, 2739
1505, 2739, 2748, 2740
1506, 2740, 2749, 2741
1507, 2741, 2750, 2742
1508, 2742, 2751, 2743
1509, 2743, 2752, 2744
1510, 2744, 2753, 2745
1511, 2745, 2754, 2746
1512, 2746, 2755, 87
*ELEMENT, type=T3D3, ELSET=Line402
1513, 88, 2757, 2756
1514, 2756, 2758, 4
*ELEMENT, type=T3D3, ELSET=Line403
1515, 88, 2781, 2759
1516, 2759, 2782, 2760
1517, 2760, 2783, 2761
1518, 2761, 2784, 2762
1519, 2762, 2785, 2763
1520, 2763, 2786, 2764
1521, 2764, 2787, 2765
1522, 2765, 2788, 2766
1523, 2766, 2789, 2767
1524, 2767, 2790, 2768
1525, 2768, 2791, 2769
1526, 2769, 2792, 2770
1527, 2770, 2793, 2771
1528, 2771, 2794, 2772
1529, 2772, 2795, 2773
1530, 2773, 2796, 2774
1531, 2774, 2797, 2775
1532, 2775, 2798, 2776
1533, 2776, 2799, 2777
1534, 2777, 2800, 2778
1535, 2778, 2801, 2779
1536, 2779, 2802, 2780
1537, 2780, 2803, 87
*ELEMENT, type=T3D3, ELSET=Line404
1538, 86, 2812, 2804
1539, 2804, 2813, 2805
1540, 2805, 2814, 2806
1541, 2806, 2815, 2807
1542, 2807, 2816, 2808
1543, 2808, 2817, 2809
1544, 2809, 2818, 2810
1545, 2810, 2819, 2811
1546, 2811, 2820, 88
*ELEMENT, type=T3D3, ELSET=Line405
1547, 1, 2843, 2821
1548, 2821, 2844, 2822
1549, 2822, 2845, 2823
1550, 2823, 2846, 2824
1551, 2824, 2847, 2825
1552, 2825, 2848, 2826
1553, 2826, 2849, 2827
1554, 2827, 2850, 2828
1555, 2828, 2851, 2829
1556, 2829, 2852, 2830
1557, 2830, 2853, 2831
1558, 2831, 2854, 2832
1559, 2832, 2855, 2833
1560, 2833, 2856, 2834
1561, 2834, 2857, 2835
1562, 2835, 2858, 2836
1563, 2836, 2859, 2837
1564, 2837, 2860, 2838
1565, 2838, 2861, 2839
1566, 2839, 2862, 2840
1567, 2840, 2863, 2841
1568, 2841, 2864, 2842
1569, 2842, 2865, 89
*ELEMENT, type=T3D3, ELSET=Line406
1570, 2, 2888, 2866
1571, 2866, 2889, 2867
1572, 2867, 2890, 2868
1573, 2868, 2891, 2869
1574, 2869, 2892, 2870
1575, 2870, 2893, 2871
1576, 2871, 2894, 2872
1577, 2872, 2895, 2873
1578, 2873, 2896, 2874
1579, 2874, 2897, 2875
1580, 2875, 2898, 2876
1581, 2876, 2899, 2877
1582, 2877, 2900, 2878
1583, 2878, 2901, 2879
1584, 2879, 2902, 2880
1585, 2880, 2903, 2881
1586, 2881, 2904, 2882
1587, 2882, 2905, 2883
1588, 2883, 2906, 2884
1589, 2884, 2907, 2885
1590, 2885, 2908, 2886
1591, 2886, 2909, 2887
1592, 2887, 2910, 90
*ELEMENT, type=T3D3, ELSET=Line407
1593, 90, 2933, 2911
1594, 2911, 2934, 2912
1595, 2912, 2935, 2913
1596, 2913, 2936, 2914
1597, 2914, 2937, 2915
1598, 2915, 2938, 2916
1599, 2916, 2939, 2917
1600, 2917, 2940, 2918
1601, 2918, 2941, 2919
1602, 2919, 2942, 2920
1603, 2920, 2943, 2921
1604, 2921, 2944, 2922
1605, 2922, 2945, 2923
1606, 2923, 2946, 2924
1607, 2924, 2947, 2925
1608, 2925, 2948, 2926
1609, 2926, 2949, 2927
1610, 2927, 2950, 2928
1611, 2928, 2951, 2929
1612, 2929, 2952, 2930
1613, 2930, 2953, 2931
1614, 2931, 2954, 2932
1615, 2932, 2955, 89
*ELEMENT, type=T3D3, ELSET=Line408
1616, 3, 2978, 2956
1617, 2956, 2979, 2957
1618, 2957, 2980, 2958
1619, 2958, 2981, 2959
1620, 2959, 2982, 2960
1621, 2960, 2983, 2961
1622, 2961, 2984, 2962
1623, 2962, 2985, 2963
1624, 2963, 2986, 2964
1625, 2964, 2987, 2965
1626, 2965, 2988, 2966
1627, 2966, 2989, 2967
1628, 2967, 2990, 2968
1629, 2968, 2991, 2969
1630, 2969, 2992, 2970
1631, 2970, 2993, 2971
1632, 2971, 2994, 2972
1633, 2972, 2995, 2973
1634, 2973, 2996, 2974
1635, 2974, 2997, 2975
1636, 2975, 2998, 2976
1637, 2976, 2999, 2977
1638, 2977, 3000, 91
*ELEMENT, type=T3D3, ELSET=Line409
1639, 89, 3009, 3001
1640, 3001, 3010, 3002
1641, 3002, 3011, 3003
1642, 3003, 3012, 3004
1643, 3004, 3013, 3005
1644, 3005, 3014, 3006
1645, 3006, 3015, 3007
1646, 3007, 3016, 3008
1647, 3008, 3017, 91
*ELEMENT, type=T3D3, ELSET=Line410
1648, 4, 3040, 3018
1649, 3018, 3041, 3019
1650, 3019, 3042, 3020
1651, 3020, 3043, 3021
1652, 3021, 3044, 3022
1653, 3022, 3045, 3023
1654, 3023, 3046, 3024
1655, 3024, 3047, 3025
1656, 3025, 3048, 3026
1657, 3026, 3049, 3027
1658, 3027, 3050, 3028
1659, 3028, 3051, 3029
1660, 3029, 3052, 3030
1661, 3030, 3053, 3031
1662, 3031, 3054, 3032
1663, 3032, 3055, 3033
1664, 3033, 3056, 3034
1665, 3034, 3057, 3035
1666, 3035, 3058, 3036
1667, 3036, 3059, 3037
1668, 3037, 3060, 3038
1669, 3038, 3061, 3039
1670, 3039, 3062, 92
*ELEMENT, type=T3D3, ELSET=Line411
1671, 92, 3085, 3063
1672, 3063, 3086, 3064
1673, 3064, 3087, 3065
1674, 3065, 3088, 3066
1675, 3066, 3089, 3067
1676, 3067, 3090, 3068
1677, 3068, 3091, 3069
1678, 3069, 3092, 3070
1679, 3070, 3093, 3071
1680, 3071, 3094, 3072
1681, 3072, 3095, 3073
1682, 3073, 3096, 3074
1683, 3074, 3097, 3075
1684, 3075, 3098, 3076
1685, 3076, 3099, 3077
1686, 3077, 3100, 3078
1687, 3078, 3101, 3079
1688, 3079, 3102, 3080
1689, 3080, 3103, 3081
1690, 3081, 3104, 3082
1691, 3082, 3105, 3083
1692, 3083, 3106, 3084
1693, 3084, 3107, 91
*ELEMENT, type=T3D3, ELSET=Line412
1694, 90, 3116, 3108
1695, 3108, 3117, 3109
1696, 3109, 3118, 3110
1697, 3110, 3119, 3111
1698, 3111, 3120, 3112
1699, 3112, 3121, 3113
1700, 3113, 3122, 3114
1701, 3114, 3123, 3115
1702, 3115, 3124, 92
*ELEMENT, type=T3D3, ELSET=Line413
1703, 93, 3147, 3125
1704, 3125, 3148, 3126
1705, 3126, 3149, 3127
1706, 3127, 3150, 3128
1707, 3128, 3151, 3129
1708, 3129, 3152, 3130
1709, 3130, 3153, 3131
1710, 3131, 3154, 3132
1711, 3132, 3155, 3133
1712, 3133, 3156, 3134
1713, 3134, 3157, 3135
1714, 3135, 3158, 3136
1715, 3136, 3159, 3137
1716, 3137, 3160, 3138
1717, 3138, 3161, 3139
1718, 3139, 3162, 3140
1719, 3140, 3163, 3141
1720, 3141, 3164, 3142
1721, 3142, 3165, 3143
1722, 3143, 3166, 3144
1723, 3144, 3167, 3145
1724, 3145, 3168, 3146
1725, 3146, 3169, 5
*ELEMENT, type=T3D3, ELSET=Line414
1726, 94, 3192, 3170
1727, 3170, 3193, 3171
1728, 3171, 3194, 3172
1729, 3172, 3195, 3173
1730, 3173, 3196, 3174
1731, 3174, 3197, 3175
1732, 3175, 3198, 3176
1733, 3176, 3199, 3177
1734, 3177, 3200, 3178
1735, 3178, 3201, 3179
1736, 3179, 3202, 3180
1737, 3180, 3203, 3181
1738, 3181, 3204, 3182
1739, 3182, 3205, 3183
1740, 3183, 3206, 3184
1741, 3184, 3207, 3185
1742, 3185, 3208, 3186
1743, 3186, 3209, 3187
1744, 3187, 3210, 3188
1745, 3188, 3211, 3189
1746, 3189, 3212, 3190
1747, 3190, 3213, 3191
1748, 3191, 3214, 6
*ELEMENT, type=T3D3, ELSET=Line415
1749, 93, 3237, 3215
1750, 3215, 3238, 3216
1751, 3216, 3239, 3217
1752, 3217, 3240, 3218
1753, 3218, 3241, 3219
1754, 3219, 3242, 3220
1755, 3220, 3243, 3221
1756, 3221, 3244, 3222
1757, 3222, 3245, 3223
1758, 3223, 3246, 3224
1759, 3224, 3247, 3225
1760, 3225, 3248, 3226
1761, 3226, 3249, 3227
1762, 3227, 3250, 3228
1763, 3228, 3251, 3229
1764, 3229, 3252, 3230
1765, 3230, 3253, 3231
1766, 3231, 3254, 3232
1767, 3232, 3255, 3233
1768, 3233, 3256, 3234
1769, 3234, 3257, 3235
1770, 3235, 3258, 3236
1771, 3236, 3259, 94
*ELEMENT, type=T3D3, ELSET=Line416
1772, 95, 3282, 3260
1773, 3260, 3283, 3261
1774, 3261, 3284, 3262
1775, 3262, 3285, 3263
1776, 3263, 3286, 3264
1777, 3264, 3287, 3265
1778, 3265, 3288, 3266
1779, 3266, 3289, 3267
1780, 3267, 3290, 3268
1781, 3268, 3291, 3269
1782, 3269, 3292, 3270
1783, 3270, 3293, 3271
1784, 3271, 3294, 3272
1785, 3272, 3295, 3273
1786, 3273, 3296, 3274
1787, 3274, 3297, 3275
1788, 3275, 3298, 3276
1789, 3276, 3299, 3277
1790, 3277, 3300, 3278
1791, 3278, 3301, 3279
1792, 3279, 3302, 3280
1793, 3280, 3303, 3281
1794, 3281, 3304, 7
*ELEMENT, type=T3D3, ELSET=Line417
1795, 96, 3327, 3305
1796, 3305, 3328, 3306
1797, 3306, 3329, 3307
1798, 3307, 3330, 3308
1799, 3308, 3331, 3309
1800, 3309, 3332, 3310
1801, 3310, 3333, 3311
1802, 3311, 3334, 3312
1803, 3312, 3335, 3313
1804, 3313, 3336, 3314
1805, 3314, 3337, 3315
1806, 3315, 3338, 3316
1807, 3316, 3339, 3317
1808, 3317, 3340, 3318
1809, 3318, 3341, 3319
1810, 3319, 3342, 3320
1811, 3320, 3343, 3321
1812, 3321, 3344, 3322
1813, 3322, 3345, 3323
1814, 3323, 3346, 3324
1815, 3324, 3347, 3325
1816, 3325, 3348, 3326
1817, 3326, 3349, 8
*ELEMENT, type=T3D3, ELSET=Line418
1818, 95, 3372, 3350
1819, 3350, 3373, 3351
1820, 3351, 3374, 3352
1821, 3352, 3375, 3353
1822, 3353, 3376, 3354
1823, 3354, 3377, 3355
1824, 3355, 3378, 3356
1825, 3356, 3379, 3357
1826, 3357, 3380, 3358
1827, 3358, 3381, 3359
1828, 3359, 3382, 3360
1829, 3360, 3383, 3361
1830, 3361, 3384, 3362
1831, 3362, 3385, 3363
1832, 3363, 3386, 3364
1833, 3364, 3387, 3365
1834, 3365, 3388, 3366
1835, 3366, 3389, 3367
1836, 3367, 3390, 3368
1837, 3368, 3391, 3369
1838, 3369, 3392, 3370
1839, 3370, 3393, 3371
1840, 3371, 3394, 96
*ELEMENT, type=T3D3, ELSET=Line419
1841, 95, 3403, 3395
1842, 3395, 3404, 3396
1843, 3396, 3405, 3397
1844, 3397, 3406, 3398
1845, 3398, 3407, 3399
1846, 3399, 3408, 3400
1847, 3400, 3409, 3401
1848, 3401, 3410, 3402
1849, 3402, 3411, 93
*ELEMENT, type=T3D3, ELSET=Line420
1850, 96, 3420, 3412
1851, 3412, 3421, 3413
1852, 3413, 3422, 3414
1853, 3414, 3423, 3415
1854, 3415, 3424, 3416
1855, 3416, 3425, 3417
1856, 3417, 3426, 3418
1857, 3418, 3427, 3419
1858, 3419, 3428, 94
*ELEMENT, type=T3D3, ELSET=Line421
1859, 5, 3430, 3429
1860, 3429, 3431, 97
*ELEMENT, type=T3D3, ELSET=Line422
1861, 6, 3433, 3432
1862, 3432, 3434, 98
*ELEMENT, type=T3D3, ELSET=Line423
1863, 97, 3457, 3435
1864, 3435, 3458, 3436
1865, 3436, 3459, 3437
1866, 3437, 3460, 3438
1867, 3438, 3461, 3439
1868, 3439, 3462, 3440
1869, 3440, 3463, 3441
1870, 3441, 3464, 3442
1871, 3442, 3465, 3443
1872, 3443, 3466, 3444
1873, 3444, 3467, 3445
1874, 3445, 3468, 3446
1875, 3446, 3469, 3447
1876, 3447, 3470, 3448
1877, 3448, 3471, 3449
1878, 3449, 3472, 3450
1879, 3450, 3473, 3451
1880, 3451, 3474, 3452
1881, 3452, 3475, 3453
1882, 3453, 3476, 3454
1883, 3454, 3477, 3455
1884, 3455, 3478, 3456
1885, 3456, 3479, 98
*ELEMENT, type=T3D3, ELSET=Line424
1886, 7, 3481, 3480
1887, 3480, 3482, 99
*ELEMENT, type=T3D3, ELSET=Line425
1888, 8, 3484, 3483
1889, 3483, 3485, 100
*ELEMENT, type=T3D3, ELSET=Line426
1890, 99, 3508, 3486
1891, 3486, 3509, 3487
1892, 3487, 3510, 3488
1893, 3488, 3511, 3489
1894, 3489, 3512, 3490
1895, 3490, 3513, 3491
1896, 3491, 3514, 3492
1897, 3492, 3515, 3493
1898, 3493, 3516, 3494
1899, 3494, 3517, 3495
1900, 3495, 3518, 3496
1901, 3496, 3519, 3497
1902, 3497, 3520, 3498
1903, 3498, 3521, 3499
1904, 3499, 3522, 3500
1905, 3500, 3523, 3501
1906, 3501, 3524, 3502
1907, 3502, 3525, 3503
1908, 3503, 3526, 3504
1909, 3504, 3527, 3505
1910, 3505, 3528, 3506
1911, 3506, 3529, 3507
1912, 3507, 3530, 100
*ELEMENT, type=T3D3, ELSET=Line427
1913, 99, 3539, 3531
1914, 3531, 3540, 3532
1915, 3532, 3541, 3533
1916, 3533, 3542, 3534
1917, 3534, 3543, 3535
1918, 3535, 3544, 3536
1919, 3536, 3545, 3537
1920, 3537, 3546, 3538
1921, 3538, 3547, 97
*ELEMENT, type=T3D3, ELSET=Line428
1922, 100, 3556, 3548
1923, 3548, 3557, 3549
1924, 3549, 3558, 3550
1925, 3550, 3559, 3551
1926, 3551, 3560, 3552
1927, 3552, 3561, 3553
1928, 3553, 3562, 3554
1929, 3554, 3563, 3555
1930, 3555, 3564, 98
*ELEMENT, type=T3D3, ELSET=Line429
1931, 35, 3566, 3565
1932, 3565, 3567, 97
*ELEMENT, type=T3D3, ELSET=Line430
1933, 36, 3569, 3568
1934, 3568, 3570, 98
*ELEMENT, type=T3D3, ELSET=Line431
1935, 37, 3572, 3571
1936, 3571, 3573, 99
*ELEMENT, type=T3D3, ELSET=Line432
1937, 38, 3575, 3574
1938, 3574, 3576, 100
*ELEMENT, type=T3D3, ELSET=Line433
1939, 24, 3578, 3577
1940, 3577, 3579, 85
*ELEMENT, type=T3D3, ELSET=Line434
1941, 15, 3581, 3580
1942, 3580, 3582, 86
*ELEMENT, type=T3D3, ELSET=Line435
1943, 23, 3584, 3583
1944, 3583, 3585, 87
*ELEMENT, type=T3D3, ELSET=Line436
1945, 9, 3587, 3586
1946, 3586, 3588, 88
*ELEMENT, type=T3D3, ELSET=Line453
1947, 67, 3590, 3589
1948, 3589, 3591, 89
*ELEMENT, type=T3D3, ELSET=Line454
1949, 68, 3593, 3592
1950, 3592, 3594, 90
*ELEMENT, type=T3D3, ELSET=Line455
1951, 69, 3596, 3595
1952, 3595, 3597, 91
*ELEMENT, type=T3D3, ELSET=Line456
1953, 70, 3599, 3598
1954, 3598, 3600, 92
*ELEMENT, type=T3D3, ELSET=Line457
1955, 71, 3602, 3601
1956, 3601, 3603, 93
*ELEMENT, type=T3D3, ELSET=Line458
1957, 73, 3605, 3604
1958, 3604, 3606, 94
*ELEMENT, type=T3D3, ELSET=Line459
1959, 74, 3608, 3607
1960, 3607, 3609, 95
*ELEMENT, type=T3D3, ELSET=Line460
1961, 76, 3611, 3610
1962, 3610, 3612, 96
*ELEMENT, type=T3D3, ELSET=Line461
1963, 1, 3616, 3613
1964, 3613, 3617, 3614
1965, 3614, 3618, 3615
1966, 3615, 3619, 101
*ELEMENT, type=T3D3, ELSET=Line462
1967, 89, 3623, 3620
1968, 3620, 3624, 3621
1969, 3621, 3625, 3622
1970, 3622, 3626, 102
*ELEMENT, type=T3D3, ELSET=Line463
1971, 101, 3649, 3627
1972, 3627, 3650, 3628
1973, 3628, 3651, 3629
1974, 3629, 3652, 3630
1975, 3630, 3653, 3631
1976, 3631, 3654, 3632
1977, 3632, 3655, 3633
1978, 3633, 3656, 3634
1979, 3634, 3657, 3635
1980, 3635, 3658, 3636
1981, 3636, 3659, 3637
1982, 3637, 3660, 3638
1983, 3638, 3661, 3639
1984, 3639, 3662, 3640
1985, 3640, 3663, 3641
1986, 3641, 3664, 3642
1987, 3642, 3665, 3643
1988, 3643, 3666, 3644
1989, 3644, 3667, 3645
1990, 3645, 3668, 3646
1991, 3646, 3669, 3647
1992, 3647, 3670, 3648
1993, 3648, 3671, 102
*ELEMENT, type=T3D3, ELSET=Line464
1994, 2, 3675, 3672
1995, 3672, 3676, 3673
1996, 3673, 3677, 3674
1997, 3674, 3678, 103
*ELEMENT, type=T3D3, ELSET=Line465
1998, 90, 3682, 3679
1999, 3679, 3683, 3680
2000, 3680, 3684, 3681
2001, 3681, 3685, 104
*ELEMENT, type=T3D3, ELSET=Line466
2002, 103, 3708, 3686
2003, 3686, 3709, 3687
2004, 3687, 3710, 3688
2005, 3688, 3711, 3689
2006, 3689, 3712, 3690
2007, 3690, 3713, 3691
2008, 3691, 3714, 3692
2009, 3692, 3715, 3693
2010, 3693, 3716, 3694
2011, 3694, 3717, 3695
2012, 3695, 3718, 3696
2013, 3696, 3719, 3697
2014, 3697, 3720, 3698
2015, 3698, 3721, 3699
2016, 3699, 3722, 3700
2017, 3700, 3723, 3701
2018, 3701, 3724, 3702
2019, 3702, 3725, 3703
2020, 3703, 3726, 3704
2021, 3704, 3727, 3705
2022, 3705, 3728, 3706
2023, 3706, 3729, 3707
2024, 3707, 3730, 104
*ELEMENT, type=T3D3, ELSET=Line467
2025, 103, 3753, 3731
2026, 3731, 3754, 3732
2027, 3732, 3755, 3733
2028, 3733, 3756, 3734
2029, 3734, 3757, 3735
2030, 3735, 3758, 3736
2031, 3736, 3759, 3737
2032, 3737, 3760, 3738
2033, 3738, 3761, 3739
2034, 3739, 3762, 3740
2035, 3740, 3763, 3741
2036, 3741, 3764, 3742
2037, 3742, 3765, 3743
2038, 3743, 3766, 3744
2039, 3744, 3767, 3745
2040, 3745, 3768, 3746
2041, 3746, 3769, 3747
2042, 3747, 3770, 3748
2043, 3748, 3771, 3749
2044, 3749, 3772, 3750
2045, 3750, 3773, 3751
2046, 3751, 3774, 3752
2047, 3752, 3775, 101
*ELEMENT, type=T3D3, ELSET=Line468
2048, 104, 3798, 3776
2049, 3776, 3799, 3777
2050, 3777, 3800, 3778
2051, 3778, 3801, 3779
2052, 3779, 3802, 3780
2053, 3780, 3803, 3781
2054, 3781, 3804, 3782
2055, 3782, 3805, 3783
2056, 3783, 3806, 3784
2057, 3784, 3807, 3785
2058, 3785, 3808, 3786
2059, 3786, 3809, 3787
2060, 3787, 3810, 3788
2061, 3788, 3811, 3789
2062, 3789, 3812, 3790
2063, 3790, 3813, 3791
2064, 3791, 3814, 3792
2065, 3792, 3815, 3793
2066, 3793, 3816, 3794
2067, 3794, 3817, 3795
2068, 3795, 3818, 3796
2069, 3796, 3819, 3797
2070, 3797, 3820, 102
*ELEMENT, type=T3D3, ELSET=Line474
2071, 95, 3824, 3821
2072, 3821, 3825, 3822
2073, 3822, 3826, 3823
2074, 3823, 3827, 105
*ELEMENT, type=T3D3, ELSET=Line477
2075, 7, 3831, 3828
2076, 3828, 3832, 3829
2077, 3829, 3833, 3830
2078, 3830, 3834, 106
*ELEMENT, type=T3D3, ELSET=Line480
2079, 105, 3857, 3835
2080, 3835, 3858, 3836
2081, 3836, 3859, 3837
2082, 3837, 3860, 3838
2083, 3838, 3861, 3839
2084, 3839, 3862, 3840
2085, 3840, 3863, 3841
2086, 3841, 3864, 3842
2087, 3842, 3865, 3843
2088, 3843, 3866, 3844
2089, 3844, 3867, 3845
2090, 3845, 3868, 3846
2091, 3846, 3869, 3847
2092, 3847, 3870, 3848
2093, 3848, 3871, 3849
2094, 3849, 3872, 3850
2095, 3850, 3873, 3851
2096, 3851, 3874, 3852
2097, 3852, 3875, 3853
2098, 3853, 3876, 3854
2099, 3854, 3877, 3855
2100, 3855, 3878, 3856
2101, 3856, 3879, 106
*ELEMENT, type=T3D3, ELSET=Line482
2102, 96, 3883, 3880
2103, 3880, 3884, 3881
2104, 3881, 3885, 3882
2105, 3882, 3886, 107
*ELEMENT, type=T3D3, ELSET=Line483
2106, 8, 3890, 3887
2107, 3887, 3891, 3888
2108, 3888, 3892, 3889
2109, 3889, 3893, 108
*ELEMENT, type=T3D3, ELSET=Line484
2110, 107, 3916, 3894
2111, 3894, 3917, 3895
2112, 3895, 3918, 3896
2113, 3896, 3919, 3897
2114, 3897, 3920, 3898
2115, 3898, 3921, 3899
2116, 3899, 3922, 3900
2117, 3900, 3923, 3901
2118, 3901, 3924, 3902
2119, 3902, 3925, 3903
2120, 3903, 3926, 3904
2121, 3904, 3927, 3905
2122, 3905, 3928, 3906
2123, 3906, 3929, 3907
2124, 3907, 3930, 3908
2125, 3908, 3931, 3909
2126, 3909, 3932, 3910
2127, 3910, 3933, 3911
2128, 3911, 3934, 3912
2129, 3912, 3935, 3913
2130, 3913, 3936, 3914
2131, 3914, 3937, 3915
2132, 3915, 3938, 108
*ELEMENT, type=T3D3, ELSET=Line485
2133, 105, 3961, 3939
2134, 3939, 3962, 3940
2135, 3940, 3963, 3941
2136, 3941, 3964, 3942
2137, 3942, 3965, 3943
2138, 3943, 3966, 3944
2139, 3944, 3967, 3945
2140, 3945, 3968, 3946
2141, 3946, 3969, 3947
2142, 3947, 3970, 3948
2143, 3948, 3971, 3949
2144, 3949, 3972, 3950
2145, 3950, 3973, 3951
2146, 3951, 3974, 3952
2147, 3952, 3975, 3953
2148, 3953, 3976, 3954
2149, 3954, 3977, 3955
2150, 3955, 3978, 3956
2151, 3956, 3979, 3957
2152, 3957, 3980, 3958
2153, 3958, 3981, 3959
2154, 3959, 3982, 3960
2155, 3960, 3983, 107
*ELEMENT, type=T3D3, ELSET=Line486
2156, 106, 4006, 3984
2157, 3984, 4007, 3985
2158, 3985, 4008, 3986
2159, 3986, 4009, 3987
2160, 3987, 4010, 3988
2161, 3988, 4011, 3989
2162, 3989, 4012, 3990
2163, 3990, 4013, 3991
2164, 3991, 4014, 3992
2165, 3992, 4015, 3993
2166, 3993, 4016, 3994
2167, 3994, 4017, 3995
2168, 3995, 4018, 3996
2169, 3996, 4019, 3997
2170, 3997, 4020, 3998
2171, 3998, 4021, 3999
2172, 3999, 4022, 4000
2173, 4000, 4023, 4001
2174, 4001, 4024, 4002
2175, 4002, 4025, 4003
2176, 4003, 4026, 4004
2177, 4004, 4027, 4005
2178, 4005, 4028, 108
*ELEMENT, type=CPS8, ELSET=Surface11
2179, 2, 216, 4029, 109, 224, 4205, 4206, 131
2180, 216, 217, 4030, 4029, 225, 4207, 4208, 4205
2181, 217, 218, 4031, 4030, 226, 4209, 4210, 4207
2182, 218, 219, 4032, 4031, 227, 4211, 4212, 4209
2183, 219, 220, 4033, 4032, 228, 4213, 4214, 4211
2184, 220, 221, 4034, 4033, 229, 4215, 4216, 4213
2185, 221, 222, 4035, 4034, 230, 4217, 4218, 4215
2186, 222, 223, 4036, 4035, 231, 4219, 4220, 4217
2187, 223, 4, 171, 4036, 232, 193, 4221, 4219
2188, 109, 4029, 4037, 110, 4206, 4222, 4223, 132
2189, 4029, 4030, 4038, 4037, 4208, 4224, 4225, 4222
2190, 4030, 4031, 4039, 4038, 4210, 4226, 4227, 4224
2191, 4031, 4032, 4040, 4039, 4212, 4228, 4229, 4226
2192, 4032, 4033, 4041, 4040, 4214, 4230, 4231, 4228
2193, 4033, 4034, 4042, 4041, 4216, 4232, 4233, 4230
2194, 4034, 4035, 4043, 4042, 4218, 4234, 4235, 4232
2195, 4035, 4036, 4044, 4043, 4220, 4236, 4237, 4234
2196, 4036, 171, 172, 4044, 4221, 194, 4238, 4236
2197, 110, 4037, 4045, 111, 4223, 4239, 4240, 133
2198, 4037, 4038, 4046, 4045, 4225, 4241, 4242, 4239
2199, 4038, 4039, 4047, 4046, 4227, 4243, 4244, 4241
2200, 4039, 4040, 4048, 4047, 4229, 4245, 4246, 4243
2201, 4040, 4041, 4049, 4048, 4231, 4247, 4248, 4245
2202, 4041, 4042, 4050, 4049, 4233, 4249, 4250, 4247
2203, 4042, 4043, 4051, 4050, 4235, 4251, 4252, 4249
2204, 4043, 4044, 4052, 4051, 4237, 4253, 4254, 4251
2205, 4044, 172, 173, 4052, 4238, 195, 4255, 4253
2206, 111, 4045, 4053, 112, 4240, 4256, 4257, 134
2207, 4045, 4046, 4054, 4053, 4242, 4258, 4259, 4256
2208, 4046, 4047, 4055, 4054, 4244, 4260, 4261, 4258
2209, 4047, 4048, 4056, 4055, 4246, 4262, 4263, 4260
2210, 4048, 4049, 4057, 4056, 4248, 4264, 4265, 4262
2211, 4049, 4050, 4058, 4057, 4250, 4266, 4267, 4264
2212, 4050, 4051, 4059, 4058, 4252, 4268, 4269, 4266
2213, 4051, 4052, 4060, 4059, 4254, 4270, 4271, 4268
2214, 4052, 173, 174, 4060, 4255, 196, 4272, 4270
2215, 112, 4053, 4061, 113, 4257, 4273, 4274, 135
2216, 4053, 4054, 4062, 4061, 4259, 4275, 4276, 4273
2217, 4054, 4055, 4063, 4062, 4261, 4277, 4278, 4275
2218, 4055, 4056, 4064, 4063, 4263, 4279, 4280, 4277
2219, 4056, 4057, 4065, 4064, 4265, 4281, 4282, 4279
2220, 4057, 4058, 4066, 4065, 4267, 4283, 4284, 4281
2221, 4058, 4059, 4067, 4066, 4269, 4285, 4286, 4283
2222, 4059, 4060, 4068, 4067, 4271, 4287, 4288, 4285
2223, 4060, 174, 175, 4068, 4272, 197, 4289, 4287
2224, 113, 4061, 4069, 114, 4274, 4290, 4291, 136
2225, 4061, 4062, 4070, 4069, 4276, 4292, 4293, 4290
2226, 4062, 4063, 4071, 4070, 4278, 4294, 4295, 4292
2227, 4063, 4064, 4072, 4071, 4280, 4296, 4297, 4294
2228, 4064, 4065, 4073, 4072, 4282, 4298, 4299, 4296
2229, 4065, 4066, 4074, 4073, 4284, 4300, 4301, 4298
2230, 4066, 4067, 4075, 4074, 4286, 4302, 4303, 4300
2231, 4067, 4068, 4076, 4075, 4288, 4304, 4305, 4302
2232, 4068, 175, 176, 4076, 4289, 198, 4306, 4304
2233, 114, 4069, 4077, 115, 4291, 4307, 4308, 137
2234, 4069, 4070, 4078, 4077, 4293, 4309, 4310, 4307
2235, 4070, 4071, 4079, 4078, 4295, 4311, 4312, 4309
2236, 4071, 4072, 4080, 4079, 4297, 4313, 4314, 4311
2237, 4072, 4073, 4081, 4080, 4299, 4315, 4316, 4313
2238, 4073, 4074, 4082, 4081, 4301, 4317, 4318, 4315
2239, 4074, 4075, 4083, 4082, 4303, 4319, 4320, 4317
2240, 4075, 4076, 4084, 4083, 4305, 4321, 4322, 4319
2241, 4076, 176, 177, 4084, 4306, 199, 4323, 4321
2242, 115, 4077, 4085, 116, 4308, 4324, 4325, 138
2243, 4077, 4078, 4086, 4085, 4310, 4326, 4327, 4324
2244, 4078, 4079, 4087, 4086, 4312, 4328, 4329, 4326
2245, 4079, 4080, 4088, 4087, 4314, 4330, 4331, 4328
2246, 4080, 4081, 4089, 4088, 4316, 4332, 4333, 4330
2247, 4081, 4082, 4090, 4089, 4318, 4334, 4335, 4332
2248, 4082, 4083, 4091, 4090, 4320, 4336, 4337, 4334
2249, 4083, 4084, 4092, 4091, 4322, 4338, 4339, 4336
2250, 4084, 177, 178, 4092, 4323, 200, 4340, 4338
2251, 116, 4085, 4093, 117, 4325, 4341, 4342, 139
2252, 4085, 4086, 4094, 4093, 4327, 4343, 4344, 4341
2253, 4086, 4087, 4095, 4094, 4329, 4345, 4346, 4343
2254, 4087, 4088, 4096, 4095, 4331, 4347, 4348, 4345
2255, 4088, 4089, 4097, 4096, 4333, 4349, 4350, 4347
2256, 4089, 4090, 4098, 4097, 4335, 4351, 4352, 4349
2257, 4090, 4091, 4099, 4098, 4337, 4353, 4354, 4351
2258, 4091, 4092, 4100, 4099, 4339, 4355, 4356, 4353
2259, 4092, 178, 179, 4100, 4340, 201, 4357, 4355
2260, 117, 4093, 4101, 118, 4342, 4358, 4359, 140
2261, 4093, 4094, 4102, 4101, 4344, 4360, 4361, 4358
2262, 4094, 4095, 4103, 4102, 4346, 4362, 4363, 4360
2263, 4095, 4096, 4104, 4103, 4348, 4364, 4365, 4362
2264, 4096, 4097, 4105, 4104, 4350, 4366, 4367, 4364
2265, 4097, 4098, 4106, 4105, 4352, 4368, 4369, 4366
2266, 4098, 4099, 4107, 4106, 4354, 4370, 4371, 4368
2267, 4099, 4100, 4108, 4107, 4356, 4372, 4373, 4370
2268, 4100, 179, 180, 4108, 4357, 202, 4374, 4372
2269, 118, 4101, 4109, 119, 4359, 4375, 4376, 141
2270, 4101, 4102, 4110, 4109, 4361, 4377, 4378, 4375
2271, 4102, 4103, 4111, 4110, 4363, 4379, 4380, 4377
2272, 4103, 4104, 4112, 4111, 4365, 4381, 4382, 4379
2273, 4104, 4105, 4113, 4112, 4367, 4383, 4384, 4381
2274, 4105, 4106, 4114, 4113, 4369, 4385, 4386, 4383
2275, 4106, 4107, 4115, 4114, 4371, 4387, 4388, 4385
2276, 4107, 4108, 4116, 4115, 4373, 4389, 4390, 4387
2277, 4108, 180, 181, 4116, 4374, 203, 4391, 4389
2278, 119, 4109, 4117, 120, 4376, 4392, 4393, 142
2279, 4109, 4110, 4118, 4117, 4378, 4394, 4395, 4392
2280, 4110, 4111, 4119, 4118, 4380, 4396, 4397, 4394
2281, 4111, 4112, 4120, 4119, 4382, 4398, 4399, 4396
2282, 4112, 4113, 4121, 4120, 4384, 4400, 4401, 4398
2283, 4113, 4114, 4122, 4121, 4386, 4402, 4403, 4400
2284, 4114, 4115, 4123, 4122, 4388, 4404, 4405, 4402
2285, 4115, 4116, 4124, 4123, 4390, 4406, 4407, 4404
2286, 4116, 181, 182, 4124, 4391, 204, 4408, 4406
2287, 120, 4117, 4125, 121, 4393, 4409, 4410, 143
2288, 4117, 4118, 4126, 4125, 4395, 4411, 4412, 4409
2289, 4118, 4119, 4127, 4126, 4397, 4413, 4414, 4411
2290, 4119, 4120, 4128, 4127, 4399, 4415, 4416, 4413
2291, 4120, 4121, 4129, 4128, 4401, 4417, 4418, 4415
2292, 4121, 4122, 4130, 4129, 4403, 4419, 4420, 4417
2293, 4122, 4123, 4131, 4130, 4405, 4421, 4422, 4419
2294, 4123, 4124, 4132, 4131, 4407, 4423, 4424, 4421
2295, 4124, 182, 183, 4132, 4408, 205, 4425, 4423
2296, 121, 4125, 4133, 122, 4410, 4426, 4427, 144
2297, 4125, 4126, 4134, 4133, 4412, 4428, 4429, 4426
2298, 4126, 4127, 4135, 4134, 4414, 4430, 4431, 4428
2299, 4127, 4128, 4136, 4135, 4416, 4432, 4433, 4430
2300, 4128, 4129, 4137, 4136, 4418, 4434, 4435, 4432
2301, 4129, 4130, 4138, 4137, 4420, 4436, 4437, 4434
2302, 4130, 4131, 4139, 4138, 4422, 4438, 4439, 4436
2303, 4131, 4132, 4140, 4139, 4424, 4440, 4441, 4438
2304, 4132, 183, 184, 4140, 4425, 206, 4442, 4440
2305, 122, 4133, 4141, 123, 4427, 4443, 4444, 145
2306, 4133, 4134, 4142, 4141, 4429, 4445, 4446, 4443
2307, 4134, 4135, 4143, 4142, 4431, 4447, 4448, 4445
2308, 4135, 4136, 4144, 4143, 4433, 4449, 4450, 4447
2309, 4136, 4137, 4145, 4144, 4435, 4451, 4452, 4449
2310, 4137, 4138, 4146, 4145, 4437, 4453, 4454, 4451
2311, 4138, 4139, 4147, 4146, 4439, 4455, 4456, 4453
2312, 4139, 4140, 4148, 4147, 4441, 4457, 4458, 4455
2313, 4140, 184, 185, 4148, 4442, 207, 4459, 4457
2314, 123, 4141, 4149, 124, 4444, 4460, 4461, 146
2315, 4141, 4142, 4150, 4149, 4446, 4462, 4463, 4460
2316, 4142, 4143, 4151, 4150, 4448, 4464, 4465, 4462
2317, 4143, 4144, 4152, 4151, 4450, 4466, 4467, 4464
2318, 4144, 4145, 4153, 4152, 4452, 4468, 4469, 4466
2319, 4145, 4146, 4154, 4153, 4454, 4470, 4471, 4468
2320, 4146, 4147, 4155, 4154, 4456, 4472, 4473, 4470
2321, 4147, 4148, 4156, 4155, 4458, 4474, 4475, 4472
2322, 4148, 185, 186, 4156, 4459, 208, 4476, 4474
2323, 124, 4149, 4157, 125, 4461, 4477, 4478, 147
2324, 4149, 4150, 4158, 4157, 4463, 4479, 4480, 4477
2325, 4150, 4151, 4159, 4158, 4465, 4481, 4482, 4479
2326, 4151, 4152, 4160, 4159, 4467, 4483, 4484, 4481
2327, 4152, 4153, 4161, 4160, 4469, 4485, 4486, 4483
2328, 4153, 4154, 4162, 4161, 4471, 4487, 4488, 4485
2329, 4154, 4155, 4163, 4162, 4473, 4489, 4490, 4487
2330, 4155, 4156, 4164, 4163, 4475, 4491, 4492, 4489
2331, 4156, 186, 187, 4164, 4476, 209, 4493, 4491
2332, 125, 4157, 4165, 126, 4478, 4494, 4495, 148
2333, 4157, 4158, 4166, 4165, 4480, 4496, 4497, 4494
2334, 4158, 4159, 4167, 4166, 4482, 4498, 4499, 4496
2335, 4159, 4160, 4168, 4167, 4484, 4500, 4501, 4498
2336, 4160, 4161, 4169, 4168, 4486, 4502, 4503, 4500
2337, 4161, 4162, 4170, 4169, 4488, 4504, 4505, 4502
2338, 4162, 4163, 4171, 4170, 4490, 4506, 4507, 4504
2339, 4163, 4164, 4172, 4171, 4492, 4508, 4509, 4506
2340, 4164, 187, 188, 4172, 4493, 210, 4510, 4508
2341, 126, 4165, 4173, 127, 4495, 4511, 4512, 149
2342, 4165, 4166, 4174, 4173, 4497, 4513, 4514, 4511
2343, 4166, 4167, 4175, 4174, 4499, 4515, 4516, 4513
2344, 4167, 4168, 4176, 4175, 4501, 4517, 4518, 4515
2345, 4168, 4169, 4177, 4176, 4503, 4519, 4520, 4517
2346, 4169, 4170, 4178, 4177, 4505, 4521, 4522, 4519
2347, 4170, 4171, 4179, 4178, 4507, 4523, 4524, 4521
2348, 4171, 4172, 4180, 4179, 4509, 4525, 4526, 4523
2349, 4172, 188, 189, 4180, 4510, 211, 4527, 4525
2350, 127, 4173, 4181, 128, 4512, 4528, 4529, 150
2351, 4173, 4174, 4182, 4181, 4514, 4530, 4531, 4528
2352, 4174, 4175, 4183, 4182, 4516, 4532, 4533, 4530
2353, 4175, 4176, 4184, 4183, 4518, 4534, 4535, 4532
2354, 4176, 4177, 4185, 4184, 4520, 4536, 4537, 4534
2355, 4177, 4178, 4186, 4185, 4522, 4538, 4539, 4536
2356, 4178, 4179, 4187, 4186, 4524, 4540, 4541, 4538
2357, 4179, 4180, 4188, 4187, 4526, 4542, 4543, 4540
2358, 4180, 189, 190, 4188, 4527, 212, 4544, 4542
2359, 128, 4181, 4189, 129, 4529, 4545, 4546, 151
2360, 4181, 4182, 4190, 4189, 4531, 4547, 4548, 4545
2361, 4182, 4183, 4191, 4190, 4533, 4549, 4550, 4547
2362, 4183, 4184, 4192, 4191, 4535, 4551, 4552, 4549
2363, 4184, 4185, 4193, 4192, 4537, 4553, 4554, 4551
2364, 4185, 4186, 4194, 4193, 4539, 4555, 4556, 4553
2365, 4186, 4187, 4195, 4194, 4541, 4557, 4558, 4555
2366, 4187, 4188, 4196, 4195, 4543, 4559, 4560, 4557
2367, 4188, 190, 191, 4196, 4544, 213, 4561, 4559
2368, 129, 4189, 4197, 130, 4546, 4562, 4563, 152
2369, 4189, 4190, 4198, 4197, 4548, 4564, 4565, 4562
2370, 4190, 4191, 4199, 4198, 4550, 4566, 4567, 4564
2371, 4191, 4192, 4200, 4199, 4552, 4568, 4569, 4566
2372, 4192, 4193, 4201, 4200, 4554, 4570, 4571, 4568
2373, 4193, 4194, 4202, 4201, 4556, 4572, 4573, 4570
2374, 4194, 4195, 4203, 4202, 4558, 4574, 4575, 4572
2375, 4195, 4196, 4204, 4203, 4560, 4576, 4577, 4574
2376, 4196, 191, 192, 4204, 4561, 214, 4578, 4576
2377, 130, 4197, 154, 1, 4563, 4579, 162, 153
2378, 4197, 4198, 155, 154, 4565, 4580, 163, 4579
2379, 4198, 4199, 156, 155, 4567, 4581, 164, 4580
2380, 4199, 4200, 157, 156, 4569, 4582, 165, 4581
2381, 4200, 4201, 158, 157, 4571, 4583, 166, 4582
2382, 4201, 4202, 159, 158, 4573, 4584, 167, 4583
2383, 4202, 4203, 160, 159, 4575, 4585, 168, 4584
2384, 4203, 4204, 161, 160, 4577, 4586, 169, 4585
2385, 4204, 192, 3, 161, 4578, 215, 170, 4586
*ELEMENT, type=CPS8, ELSET=Surface46
2386, 5, 330, 4587, 233, 339, 4763, 4764, 255
2387, 330, 329, 4588, 4587, 338, 4765, 4766, 4763
2388, 329, 328, 4589, 4588, 337, 4767, 4768, 4765
2389, 328, 327, 4590, 4589, 336, 4769, 4770, 4767
2390, 327, 326, 4591, 4590, 335, 4771, 4772, 4769
2391, 326, 325, 4592, 4591, 334, 4773, 4774, 4771
2392, 325, 324, 4593, 4592, 333, 4775, 4776, 4773
2393, 324, 323, 4594, 4593, 332, 4777, 4778, 4775
2394, 323, 7, 278, 4594, 331, 300, 4779, 4777
2395, 233, 4587, 4595, 234, 4764, 4780, 4781, 256
2396, 4587, 4588, 4596, 4595, 4766, 4782, 4783, 4780
2397, 4588, 4589, 4597, 4596, 4768, 4784, 4785, 4782
2398, 4589, 4590, 4598, 4597, 4770, 4786, 4787, 4784
2399, 4590, 4591, 4599, 4598, 4772, 4788, 4789, 4786
2400, 4591, 4592, 4600, 4599, 4774, 4790, 4791, 4788
2401, 4592, 4593, 4601, 4600, 4776, 4792, 4793, 4790
2402, 4593, 4594, 4602, 4601, 4778, 4794, 4795, 4792
2403, 4594, 278, 279, 4602, 4779, 301, 4796, 4794
2404, 234, 4595, 4603, 235, 4781, 4797, 4798, 257
2405, 4595, 4596, 4604, 4603, 4783, 4799, 4800, 4797
2406, 4596, 4597, 4605, 4604, 4785, 4801, 4802, 4799
2407, 4597, 4598, 4606, 4605, 4787, 4803, 4804, 4801
2408, 4598, 4599, 4607, 4606, 4789, 4805, 4806, 4803
2409, 4599, 4600, 4608, 4607, 4791, 4807, 4808, 4805
2410, 4600, 4601, 4609, 4608, 4793, 4809, 4810, 4807
2411, 4601, 4602, 4610, 4609, 4795, 4811, 4812, 4809
2412, 4602, 279, 280, 4610, 4796, 302, 4813, 4811
2413, 235, 4603, 4611, 236, 4798, 4814, 4815, 258
2414, 4603, 4604, 4612, 4611, 4800, 4816, 4817, 4814
2415, 4604, 4605, 4613, 4612, 4802, 4818, 4819, 4816
2416, 4605, 4606, 4614, 4613, 4804, 4820, 4821, 4818
2417, 4606, 4607, 4615, 4614, 4806, 4822, 4823, 4820
2418, 4607, 4608, 4616, 4615, 4808, 4824, 4825, 4822
2419, 4608, 4609, 4617, 4616, 4810, 4826, 4827, 4824
2420, 4609, 4610, 4618, 4617, 4812, 4828, 4829, 4826
2421, 4610, 280, 281, 4618, 4813, 303, 4830, 4828
2422, 236, 4611, 4619, 237, 4815, 4831, 4832, 259
2423, 4611, 4612, 4620, 4619, 4817, 4833, 4834, 4831
2424, 4612, 4613, 4621, 4620, 4819, 4835, 4836, 4833
2425, 4613, 4614, 4622, 4621, 4821, 4837, 4838, 4835
2426, 4614, 4615, 4623, 4622, 4823, 4839, 4840, 4837
2427, 4615, 4616, 4624, 4623, 4825, 4841, 4842, 4839
2428, 4616, 4617, 4625, 4624, 4827, 4843, 4844, 4841
2429, 4617, 4618, 4626, 4625, 4829, 4845, 4846, 4843
2430, 4618, 281, 282, 4626, 4830, 304, 4847, 4845
2431, 237, 4619, 4627, 238, 4832, 4848, 4849, 260
2432, 4619, 4620, 4628, 4627, 4834, 4850, 4851, 4848
2433, 4620, 4621, 4629, 4628, 4836, 4852, 4853, 4850
2434, 4621, 4622, 4630, 4629, 4838, 4854, 4855, 4852
2435, 4622, 4623, 4631, 4630, 4840, 4856, 4857, 4854
2436, 4623, 4624, 4632, 4631, 4842, 4858, 4859, 4856
2437, 4624, 4625, 4633, 4632, 4844, 4860, 4861, 4858
2438, 4625, 4626, 4634, 4633, 4846, 4862, 4863, 4860
2439, 4626, 282, 283, 4634, 4847, 305, 4864, 4862
2440, 238, 4627, 4635, 239, 4849, 4865, 4866, 261
2441, 4627, 4628, 4636, 4635, 4851, 4867, 4868, 4865
2442, 4628, 4629, 4637, 4636, 4853, 4869, 4870, 4867
2443, 4629, 4630, 4638, 4637, 4855, 4871, 4872, 4869
2444, 4630, 4631, 4639, 4638, 4857, 4873, 4874, 4871
2445, 4631, 4632, 4640, 4639, 4859, 4875, 4876, 4873
2446, 4632, 4633, 4641, 4640, 4861, 4877, 4878, 4875
2447, 4633, 4634, 4642, 4641, 4863, 4879, 4880, 4877
2448, 4634, 283, 284, 4642, 4864, 306, 4881, 4879
2449, 239, 4635, 4643, 240, 4866, 4882, 4883, 262
2450, 4635, 4636, 4644, 4643, 4868, 4884, 4885, 4882
2451, 4636, 4637, 4645, 4644, 4870, 4886, 4887, 4884
2452, 4637, 4638, 4646, 4645, 4872, 4888, 4889, 4886
2453, 4638, 4639, 4647, 4646, 4874, 4890, 4891, 4888
2454, 4639, 4640, 4648, 4647, 4876, 4892, 4893, 4890
2455, 4640, 4641, 4649, 4648, 4878, 4894, 4895, 4892
2456, 4641, 4642, 4650, 4649, 4880, 4896, 4897, 4894
2457, 4642, 284, 285, 4650, 4881, 307, 4898, 4896
2458, 240, 4643, 4651, 241, 4883, 4899, 4900, 263
2459, 4643, 4644, 4652, 4651, 4885, 4901, 4902, 4899
2460, 4644, 4645, 4653, 4652, 4887, 4903, 4904, 4901
2461, 4645, 4646, 4654, 4653, 4889, 4905, 4906, 4903
2462, 4646, 4647, 4655, 4654, 4891, 4907, 4908, 4905
2463, 4647, 4648, 4656, 4655, 4893, 4909, 4910, 4907
2464, 4648, 4649, 4657, 4656, 4895, 4911, 4912, 4909
2465, 4649, 4650, 4658, 4657, 4897, 4913, 4914, 4911
2466, 4650, 285, 286, 4658, 4898, 308, 4915, 4913
2467, 241, 4651, 4659, 242, 4900, 4916, 4917, 264
2468, 4651, 4652, 4660, 4659, 4902, 4918, 4919, 4916
2469, 4652, 4653, 4661, 4660, 4904, 4920, 4921, 4918
2470, 4653, 4654, 4662, 4661, 4906, 4922, 4923, 4920
2471, 4654, 4655, 4663, 4662, 4908, 4924, 4925, 4922
2472, 4655, 4656, 4664, 4663, 4910, 4926, 4927, 4924
2473, 4656, 4657, 4665, 4664, 4912, 4928, 4929, 4926
2474, 4657, 4658, 4666, 4665, 4914, 4930, 4931, 4928
2475, 4658, 286, 287, 4666, 4915, 309, 4932, 4930
2476, 242, 4659, 4667, 243, 4917, 4933, 4934, 265
2477, 4659, 4660, 4668, 4667, 4919, 4935, 4936, 4933
2478, 4660, 4661, 4669, 4668, 4921, 4937, 4938, 4935
2479, 4661, 4662, 4670, 4669, 4923, 4939, 4940, 4937
2480, 4662, 4663, 4671, 4670, 4925, 4941, 4942, 4939
2481, 4663, 4664, 4672, 4671, 4927, 4943, 4944, 4941
2482, 4664, 4665, 4673, 4672, 4929, 4945, 4946, 4943
2483, 4665, 4666, 4674, 4673, 4931, 4947, 4948, 4945
2484, 4666, 287, 288, 4674, 4932, 310, 4949, 4947
2485, 243, 4667, 4675, 244, 4934, 4950, 4951, 266
2486, 4667, 4668, 4676, 4675, 4936, 4952, 4953, 4950
2487, 4668, 4669, 4677, 4676, 4938, 4954, 4955, 4952
2488, 4669, 4670, 4678, 4677, 4940, 4956, 4957, 4954
2489, 4670, 4671, 4679, 4678, 4942, 4958, 4959, 4956
2490, 4671, 4672, 4680, 4679, 4944, 4960, 4961, 4958
2491, 4672, 4673, 4681, 4680, 4946, 4962, 4963, 4960
2492, 4673, 4674, 4682, 4681, 4948, 4964, 4965, 4962
2493, 4674, 288, 289, 4682, 4949, 311, 4966, 4964
2494, 244, 4675, 4683, 245, 4951, 4967, 4968, 267
2495, 4675, 4676, 4684, 4683, 4953, 4969, 4970, 4967
2496, 4676, 4677, 4685, 4684, 4955, 4971, 4972, 4969
2497, 4677, 4678, 4686, 4685, 4957, 4973, 4974, 4971
2498, 4678, 4679, 4687, 4686, 4959, 4975, 4976, 4973
2499, 4679, 4680, 4688, 4687, 4961, 4977, 4978, 4975
2500, 4680, 4681, 4689, 4688, 4963, 4979, 4980, 4977
2501, 4681, 4682, 4690, 4689, 4965, 4981, 4982, 4979
2502, 4682, 289, 290, 4690, 4966, 312, 4983, 4981
2503, 245, 4683, 4691, 246, 4968, 4984, 4985, 268
2504, 4683, 4684, 4692, 4691, 4970, 4986, 4987, 4984
2505, 4684, 4685, 4693, 4692, 4972, 4988, 4989, 4986
2506, 4685, 4686, 4694, 4693, 4974, 4990, 4991, 4988
2507, 4686, 4687, 4695, 4694, 4976, 4992, 4993, 4990
2508, 4687, 4688, 4696, 4695, 4978, 4994, 4995, 4992
2509, 4688, 4689, 4697, 4696, 4980, 4996, 4997, 4994
2510, 4689, 4690, 4698, 4697, 4982, 4998, 4999, 4996
2511, 4690, 290, 291, 4698, 4983, 313, 5000, 4998
2512, 246, 4691, 4699, 247, 4985, 5001, 5002, 269
2513, 4691, 4692, 4700, 4699, 4987, 5003, 5004, 5001
2514, 4692, 4693, 4701, 4700, 4989, 5005, 5006, 5003
2515, 4693, 4694, 4702, 4701, 4991, 5007, 5008, 5005
2516, 4694, 4695, 4703, 4702, 4993, 5009, 5010, 5007
2517, 4695, 4696, 4704, 4703, 4995, 5011, 5012, 5009
2518, 4696, 4697, 4705, 4704, 4997, 5013, 5014, 5011
2519, 4697, 4698, 4706, 4705, 4999, 5015, 5016, 5013
2520, 4698, 291, 292, 4706, 5000, 314, 5017, 5015
2521, 247, 4699, 4707, 248, 5002, 5018, 5019, 270
2522, 4699, 4700, 4708, 4707, 5004, 5020, 5021, 5018
2523, 4700, 4701, 4709, 4708, 5006, 5022, 5023, 5020
2524, 4701, 4702, 4710, 4709, 5008, 5024, 5025, 5022
2525, 4702, 4703, 4711, 4710, 5010, 5026, 5027, 5024
2526, 4703, 4704, 4712, 4711, 5012, 5028, 5029, 5026
2527, 4704, 4705, 4713, 4712, 5014, 5030, 5031, 5028
2528, 4705, 4706, 4714, 4713, 5016, 5032, 5033, 5030
2529, 4706, 292, 293, 4714, 5017, 315, 5034, 5032
2530, 248, 4707, 4715, 249, 5019, 5035, 5036, 271
2531, 4707, 4708, 4716, 4715, 5021, 5037, 5038, 5035
2532, 4708, 4709, 4717, 4716, 5023, 5039, 5040, 5037
2533, 4709, 4710, 4718, 4717, 5025, 5041, 5042, 5039
2534, 4710, 4711, 4719, 4718, 5027, 5043, 5044, 5041
2535, 4711, 4712, 4720, 4719, 5029, 5045, 5046, 5043
2536, 4712, 4713, 4721, 4720, 5031, 5047, 5048, 5045
2537, 4713, 4714, 4722, 4721, 5033, 5049, 5050, 5047
2538, 4714, 293, 294, 4722, 5034, 316, 5051, 5049
2539, 249, 4715, 4723, 250, 5036, 5052, 5053, 272
2540, 4715, 4716, 4724, 4723, 5038, 5054, 5055, 5052
2541, 4716, 4717, 4725, 4724, 5040, 5056, 5057, 5054
2542, 4717, 4718, 4726, 4725, 5042, 5058, 5059, 5056
2543, 4718, 4719, 4727, 4726, 5044, 5060, 5061, 5058
2544, 4719, 4720, 4728, 4727, 5046, 5062, 5063, 5060
2545, 4720, 4721, 4729, 4728, 5048, 5064, 5065, 5062
2546, 4721, 4722, 4730, 4729, 5050, 5066, 5067, 5064
2547, 4722, 294, 295, 4730, 5051, 317, 5068, 5066
2548, 250, 4723, 4731, 251, 5053, 5069, 5070, 273
2549, 4723, 4724, 4732, 4731, 5055, 5071, 5072, 5069
2550, 4724, 4725, 4733, 4732, 5057, 5073, 5074, 5071
2551, 4725, 4726, 4734, 4733, 5059, 5075, 5076, 5073
2552, 4726, 4727, 4735, 4734, 5061, 5077, 5078, 5075
2553, 4727, 4728, 4736, 4735, 5063, 5079, 5080, 5077
2554, 4728, 4729, 4737, 4736, 5065, 5081, 5082, 5079
2555, 4729, 4730, 4738, 4737, 5067, 5083, 5084, 5081
2556, 4730, 295, 296, 4738, 5068, 318, 5085, 5083
2557, 251, 4731, 4739, 252, 5070, 5086, 5087, 274
2558, 4731, 4732, 4740, 4739, 5072, 5088, 5089, 5086
2559, 4732, 4733, 4741, 4740, 5074, 5090, 5091, 5088
2560, 4733, 4734, 4742, 4741, 5076, 5092, 5093, 5090
2561, 4734, 4735, 4743, 4742, 5078, 5094, 5095, 5092
2562, 4735, 4736, 4744, 4743, 5080, 5096, 5097, 5094
2563, 4736, 4737, 4745, 4744, 5082, 5098, 5099, 5096
2564, 4737, 4738, 4746, 4745, 5084, 5100, 5101, 5098
2565, 4738, 296, 297, 4746, 5085, 319, 5102, 5100
2566, 252, 4739, 4747, 253, 5087, 5103, 5104, 275
2567, 4739, 4740, 4748, 4747, 5089, 5105, 5106, 5103
2568, 4740, 4741, 4749, 4748, 5091, 5107, 5108, 5105
2569, 4741, 4742, 4750, 4749, 5093, 5109, 5110, 5107
2570, 4742, 4743, 4751, 4750, 5095, 5111, 5112, 5109
2571, 4743, 4744, 4752, 4751, 5097, 5113, 5114, 5111
2572, 4744, 4745, 4753, 4752, 5099, 5115, 5116, 5113
2573, 4745, 4746, 4754, 4753, 5101, 5117, 5118, 5115
2574, 4746, 297, 298, 4754, 5102, 320, 5119, 5117
2575, 253, 4747, 4755, 254, 5104, 5120, 5121, 276
2576, 4747, 4748, 4756, 4755, 5106, 5122, 5123, 5120
2577, 4748, 4749, 4757, 4756, 5108, 5124, 5125, 5122
2578, 4749, 4750, 4758, 4757, 5110, 5126, 5127, 5124
2579, 4750, 4751, 4759, 4758, 5112, 5128, 5129, 5126
2580, 4751, 4752, 4760, 4759, 5114, 5130, 5131, 5128
2581, 4752, 4753, 4761, 4760, 5116, 5132, 5133, 5130
2582, 4753, 4754, 4762, 4761, 5118, 5134, 5135, 5132
2583, 4754, 298, 299, 4762, 5119, 321, 5136, 5134
2584, 254, 4755, 347, 6, 5121, 5137, 356, 277
2585, 4755, 4756, 346, 347, 5123, 5138, 355, 5137
2586, 4756, 4757, 345, 346, 5125, 5139, 354, 5138
2587, 4757, 4758, 344, 345, 5127, 5140, 353, 5139
2588, 4758, 4759, 343, 344, 5129, 5141, 352, 5140
2589, 4759, 4760, 342, 343, 5131, 5142, 351, 5141
2590, 4760, 4761, 341, 342, 5133, 5143, 350, 5142
2591, 4761, 4762, 340, 341, 5135, 5144, 349, 5143
2592, 4762, 299, 8, 340, 5136, 322, 348, 5144
*ELEMENT, type=CPS8, ELSET=Surface63
2593, 9, 357, 5145, 364, 358, 5147, 5148, 367
2594, 364, 5145, 5146, 363, 5148, 5149, 5150, 366
2595, 363, 5146, 360, 11, 5150, 5151, 361, 365
2596, 357, 10, 369, 5145, 359, 372, 5152, 5147
2597, 5145, 369, 368, 5146, 5152, 371, 5153, 5149
2598, 5146, 368, 12, 360, 5153, 370, 362, 5151
*ELEMENT, type=CPS8, ELSET=Surface163
2599, 11, 360, 5154, 383, 361, 5162, 5163, 392
2600, 383, 5154, 5155, 382, 5163, 5164, 5165, 391
2601, 382, 5155, 5156, 381, 5165, 5166, 5167, 390
2602, 381, 5156, 5157, 380, 5167, 5168, 5169, 389
2603, 380, 5157, 5158, 379, 5169, 5170, 5171, 388
2604, 379, 5158, 5159, 378, 5171, 5172, 5173, 387
2605, 378, 5159, 5160, 377, 5173, 5174, 5175, 386
2606, 377, 5160, 5161, 376, 5175, 5176, 5177, 385
2607, 376, 5161, 373, 13, 5177, 5178, 374, 384
2608, 360, 12, 400, 5154, 362, 409, 5179, 5162
2609, 5154, 400, 399, 5155, 5179, 408, 5180, 5164
2610, 5155, 399, 398, 5156, 5180, 407, 5181, 5166
2611, 5156, 398, 397, 5157, 5181, 406, 5182, 5168
2612, 5157, 397, 396, 5158, 5182, 405, 5183, 5170
2613, 5158, 396, 395, 5159, 5183, 404, 5184, 5172
2614, 5159, 395, 394, 5160, 5184, 403, 5185, 5174
2615, 5160, 394, 393, 5161, 5185, 402, 5186, 5176
2616, 5161, 393, 14, 373, 5186, 401, 375, 5178
*ELEMENT, type=CPS8, ELSET=Surface164
2617, 9, 420, 5187, 357, 429, 5195, 5196, 358
2618, 420, 419, 5188, 5187, 428, 5197, 5198, 5195
2619, 419, 418, 5189, 5188, 427, 5199, 5200, 5197
2620, 418, 417, 5190, 5189, 426, 5201, 5202, 5199
2621, 417, 416, 5191, 5190, 425, 5203, 5204, 5201
2622, 416, 415, 5192, 5191, 424, 5205, 5206, 5203
2623, 415, 414, 5193, 5192, 423, 5207, 5208, 5205
2624, 414, 413, 5194, 5193, 422, 5209, 5210, 5207
2625, 413, 15, 410, 5194, 421, 411, 5211, 5209
2626, 357, 5187, 437, 10, 5196, 5212, 446, 359
2627, 5187, 5188, 436, 437, 5198, 5213, 445, 5212
2628, 5188, 5189, 435, 436, 5200, 5214, 444, 5213
2629, 5189, 5190, 434, 435, 5202, 5215, 443, 5214
2630, 5190, 5191, 433, 434, 5204, 5216, 442, 5215
2631, 5191, 5192, 432, 433, 5206, 5217, 441, 5216
2632, 5192, 5193, 431, 432, 5208, 5218, 440, 5217
2633, 5193, 5194, 430, 431, 5210, 5219, 439, 5218
2634, 5194, 410, 16, 430, 5211, 412, 438, 5219
*ELEMENT, type=CPS8, ELSET=Surface165
2635, 15, 448, 5220, 410, 451, 5222, 5223, 411
2636, 448, 447, 5221, 5220, 450, 5224, 5225, 5222
2637, 447, 13, 373, 5221, 449, 374, 5226, 5224
2638, 410, 5220, 453, 16, 5223, 5227, 456, 412
2639, 5220, 5221, 452, 453, 5225, 5228, 455, 5227
2640, 5221, 373, 14, 452, 5226, 375, 454, 5228
*ELEMENT, type=CPS8, ELSET=Surface166
2641, 13, 447, 5229, 376, 449, 5245, 5246, 384
2642, 447, 448, 5230, 5229, 450, 5247, 5248, 5245
2643, 448, 15, 413, 5230, 451, 421, 5249, 5247
2644, 376, 5229, 5231, 377, 5246, 5250, 5251, 385
2645, 5229, 5230, 5232, 5231, 5248, 5252, 5253, 5250
2646, 5230, 413, 414, 5232, 5249, 422, 5254, 5252
2647, 377, 5231, 5233, 378, 5251, 5255, 5256, 386
2648, 5231, 5232, 5234, 5233, 5253, 5257, 5258, 5255
2649, 5232, 414, 415, 5234, 5254, 423, 5259, 5257
2650, 378, 5233, 5235, 379, 5256, 5260, 5261, 387
2651, 5233, 5234, 5236, 5235, 5258, 5262, 5263, 5260
2652, 5234, 415, 416, 5236, 5259, 424, 5264, 5262
2653, 379, 5235, 5237, 380, 5261, 5265, 5266, 388
2654, 5235, 5236, 5238, 5237, 5263, 5267, 5268, 5265
2655, 5236, 416, 417, 5238, 5264, 425, 5269, 5267
2656, 380, 5237, 5239, 381, 5266, 5270, 5271, 389
2657, 5237, 5238, 5240, 5239, 5268, 5272, 5273, 5270
2658, 5238, 417, 418, 5240, 5269, 426, 5274, 5272
2659, 381, 5239, 5241, 382, 5271, 5275, 5276, 390
2660, 5239, 5240, 5242, 5241, 5273, 5277, 5278, 5275
2661, 5240, 418, 419, 5242, 5274, 427, 5279, 5277
2662, 382, 5241, 5243, 383, 5276, 5280, 5281, 391
2663, 5241, 5242, 5244, 5243, 5278, 5282, 5283, 5280
2664, 5242, 419, 420, 5244, 5279, 428, 5284, 5282
2665, 383, 5243, 363, 11, 5281, 5285, 365, 392
2666, 5243, 5244, 364, 363, 5283, 5286, 366, 5285
2667, 5244, 420, 9, 364, 5284, 429, 367, 5286
*ELEMENT, type=CPS8, ELSET=Surface167
2668, 14, 393, 5287, 452, 401, 5303, 5304, 454
2669, 452, 5287, 5288, 453, 5304, 5305, 5306, 455
2670, 453, 5288, 430, 16, 5306, 5307, 438, 456
2671, 393, 394, 5289, 5287, 402, 5308, 5309, 5303
2672, 5287, 5289, 5290, 5288, 5309, 5310, 5311, 5305
2673, 5288, 5290, 431, 430, 5311, 5312, 439, 5307
2674, 394, 395, 5291, 5289, 403, 5313, 5314, 5308
2675, 5289, 5291, 5292, 5290, 5314, 5315, 5316, 5310
2676, 5290, 5292, 432, 431, 5316, 5317, 440, 5312
2677, 395, 396, 5293, 5291, 404, 5318, 5319, 5313
2678, 5291, 5293, 5294, 5292, 5319, 5320, 5321, 5315
2679, 5292, 5294, 433, 432, 5321, 5322, 441, 5317
2680, 396, 397, 5295, 5293, 405, 5323, 5324, 5318
2681, 5293, 5295, 5296, 5294, 5324, 5325, 5326, 5320
2682, 5294, 5296, 434, 433, 5326, 5327, 442, 5322
2683, 397, 398, 5297, 5295, 406, 5328, 5329, 5323
2684, 5295, 5297, 5298, 5296, 5329, 5330, 5331, 5325
2685, 5296, 5298, 435, 434, 5331, 5332, 443, 5327
2686, 398, 399, 5299, 5297, 407, 5333, 5334, 5328
2687, 5297, 5299, 5300, 5298, 5334, 5335, 5336, 5330
2688, 5298, 5300, 436, 435, 5336, 5337, 444, 5332
2689, 399, 400, 5301, 5299, 408, 5338, 5339, 5333
2690, 5299, 5301, 5302, 5300, 5339, 5340, 5341, 5335
2691, 5300, 5302, 437, 436, 5341, 5342, 445, 5337
2692, 400, 12, 368, 5301, 409, 370, 5343, 5338
2693, 5301, 368, 369, 5302, 5343, 371, 5344, 5340
2694, 5302, 369, 10, 437, 5344, 372, 446, 5342
*ELEMENT, type=CPS8, ELSET=Surface168
2695, 11, 360, 5345, 457, 361, 5348, 5349, 460
2696, 360, 12, 464, 5345, 362, 467, 5350, 5348
2697, 457, 5345, 5346, 458, 5349, 5351, 5352, 461
2698, 5345, 464, 465, 5346, 5350, 468, 5353, 5351
2699, 458, 5346, 5347, 459, 5352, 5354, 5355, 462
2700, 5346, 465, 466, 5347, 5353, 469, 5356, 5354
2701, 459, 5347, 471, 17, 5355, 5357, 472, 463
2702, 5347, 466, 18, 471, 5356, 470, 473, 5357
*ELEMENT, type=CPS8, ELSET=Surface169
2703, 13, 474, 5358, 373, 477, 5361, 5362, 374
2704, 373, 5358, 481, 14, 5362, 5363, 484, 375
2705, 474, 475, 5359, 5358, 478, 5364, 5365, 5361
2706, 5358, 5359, 482, 481, 5365, 5366, 485, 5363
2707, 475, 476, 5360, 5359, 479, 5367, 5368, 5364
2708, 5359, 5360, 483, 482, 5368, 5369, 486, 5366
2709, 476, 19, 488, 5360, 480, 489, 5370, 5367
2710, 5360, 488, 20, 483, 5370, 490, 487, 5369
*ELEMENT, type=CPS8, ELSET=Surface170
2711, 11, 457, 5371, 383, 460, 5395, 5396, 392
2712, 383, 5371, 5372, 382, 5396, 5397, 5398, 391
2713, 382, 5372, 5373, 381, 5398, 5399, 5400, 390
2714, 381, 5373, 5374, 380, 5400, 5401, 5402, 389
2715, 380, 5374, 5375, 379, 5402, 5403, 5404, 388
2716, 379, 5375, 5376, 378, 5404, 5405, 5406, 387
2717, 378, 5376, 5377, 377, 5406, 5407, 5408, 386
2718, 377, 5377, 5378, 376, 5408, 5409, 5410, 385
2719, 376, 5378, 474, 13, 5410, 5411, 477, 384
2720, 457, 458, 5379, 5371, 461, 5412, 5413, 5395
2721, 5371, 5379, 5380, 5372, 5413, 5414, 5415, 5397
2722, 5372, 5380, 5381, 5373, 5415, 5416, 5417, 5399
2723, 5373, 5381, 5382, 5374, 5417, 5418, 5419, 5401
2724, 5374, 5382, 5383, 5375, 5419, 5420, 5421, 5403
2725, 5375, 5383, 5384, 5376, 5421, 5422, 5423, 5405
2726, 5376, 5384, 5385, 5377, 5423, 5424, 5425, 5407
2727, 5377, 5385, 5386, 5378, 5425, 5426, 5427, 5409
2728, 5378, 5386, 475, 474, 5427, 5428, 478, 5411
2729, 458, 459, 5387, 5379, 462, 5429, 5430, 5412
2730, 5379, 5387, 5388, 5380, 5430, 5431, 5432, 5414
2731, 5380, 5388, 5389, 5381, 5432, 5433, 5434, 5416
2732, 5381, 5389, 5390, 5382, 5434, 5435, 5436, 5418
2733, 5382, 5390, 5391, 5383, 5436, 5437, 5438, 5420
2734, 5383, 5391, 5392, 5384, 5438, 5439, 5440, 5422
2735, 5384, 5392, 5393, 5385, 5440, 5441, 5442, 5424
2736, 5385, 5393, 5394, 5386, 5442, 5443, 5444, 5426
2737, 5386, 5394, 476, 475, 5444, 5445, 479, 5428
2738, 459, 17, 498, 5387, 463, 507, 5446, 5429
2739, 5387, 498, 497, 5388, 5446, 506, 5447, 5431
2740, 5388, 497, 496, 5389, 5447, 505, 5448, 5433
2741, 5389, 496, 495, 5390, 5448, 504, 5449, 5435
2742, 5390, 495, 494, 5391, 5449, 503, 5450, 5437
2743, 5391, 494, 493, 5392, 5450, 502, 5451, 5439
2744, 5392, 493, 492, 5393, 5451, 501, 5452, 5441
2745, 5393, 492, 491, 5394, 5452, 500, 5453, 5443
2746, 5394, 491, 19, 476, 5453, 499, 480, 5445
*ELEMENT, type=CPS8, ELSET=Surface171
2747, 12, 400, 5454, 464, 409, 5478, 5479, 467
2748, 400, 399, 5455, 5454, 408, 5480, 5481, 5478
2749, 399, 398, 5456, 5455, 407, 5482, 5483, 5480
2750, 398, 397, 5457, 5456, 406, 5484, 5485, 5482
2751, 397, 396, 5458, 5457, 405, 5486, 5487, 5484
2752, 396, 395, 5459, 5458, 404, 5488, 5489, 5486
2753, 395, 394, 5460, 5459, 403, 5490, 5491, 5488
2754, 394, 393, 5461, 5460, 402, 5492, 5493, 5490
2755, 393, 14, 481, 5461, 401, 484, 5494, 5492
2756, 464, 5454, 5462, 465, 5479, 5495, 5496, 468
2757, 5454, 5455, 5463, 5462, 5481, 5497, 5498, 5495
2758, 5455, 5456, 5464, 5463, 5483, 5499, 5500, 5497
2759, 5456, 5457, 5465, 5464, 5485, 5501, 5502, 5499
2760, 5457, 5458, 5466, 5465, 5487, 5503, 5504, 5501
2761, 5458, 5459, 5467, 5466, 5489, 5505, 5506, 5503
2762, 5459, 5460, 5468, 5467, 5491, 5507, 5508, 5505
2763, 5460, 5461, 5469, 5468, 5493, 5509, 5510, 5507
2764, 5461, 481, 482, 5469, 5494, 485, 5511, 5509
2765, 465, 5462, 5470, 466, 5496, 5512, 5513, 469
2766, 5462, 5463, 5471, 5470, 5498, 5514, 5515, 5512
2767, 5463, 5464, 5472, 5471, 5500, 5516, 5517, 5514
2768, 5464, 5465, 5473, 5472, 5502, 5518, 5519, 5516
2769, 5465, 5466, 5474, 5473, 5504, 5520, 5521, 5518
2770, 5466, 5467, 5475, 5474, 5506, 5522, 5523, 5520
2771, 5467, 5468, 5476, 5475, 5508, 5524, 5525, 5522
2772, 5468, 5469, 5477, 5476, 5510, 5526, 5527, 5524
2773, 5469, 482, 483, 5477, 5511, 486, 5528, 5526
2774, 466, 5470, 515, 18, 5513, 5529, 524, 470
2775, 5470, 5471, 514, 515, 5515, 5530, 523, 5529
2776, 5471, 5472, 513, 514, 5517, 5531, 522, 5530
2777, 5472, 5473, 512, 513, 5519, 5532, 521, 5531
2778, 5473, 5474, 511, 512, 5521, 5533, 520, 5532
2779, 5474, 5475, 510, 511, 5523, 5534, 519, 5533
2780, 5475, 5476, 509, 510, 5525, 5535, 518, 5534
2781, 5476, 5477, 508, 509, 5527, 5536, 517, 5535
2782, 5477, 483, 20, 508, 5528, 487, 516, 5536
*ELEMENT, type=CPS8, ELSET=Surface172
2783, 17, 471, 5537, 498, 472, 5545, 5546, 507
2784, 498, 5537, 5538, 497, 5546, 5547, 5548, 506
2785, 497, 5538, 5539, 496, 5548, 5549, 5550, 505
2786, 496, 5539, 5540, 495, 5550, 5551, 5552, 504
2787, 495, 5540, 5541, 494, 5552, 5553, 5554, 503
2788, 494, 5541, 5542, 493, 5554, 5555, 5556, 502
2789, 493, 5542, 5543, 492, 5556, 5557, 5558, 501
2790, 492, 5543, 5544, 491, 5558, 5559, 5560, 500
2791, 491, 5544, 488, 19, 5560, 5561, 489, 499
2792, 471, 18, 515, 5537, 473, 524, 5562, 5545
2793, 5537, 515, 514, 5538, 5562, 523, 5563, 5547
2794, 5538, 514, 513, 5539, 5563, 522, 5564, 5549
2795, 5539, 513, 512, 5540, 5564, 521, 5565, 5551
2796, 5540, 512, 511, 5541, 5565, 520, 5566, 5553
2797, 5541, 511, 510, 5542, 5566, 519, 5567, 5555
2798, 5542, 510, 509, 5543, 5567, 518, 5568, 5557
2799, 5543, 509, 508, 5544, 5568, 517, 5569, 5559
2800, 5544, 508, 20, 488, 5569, 516, 490, 5561
*ELEMENT, type=CPS8, ELSET=Surface173
2801, 22, 564, 5570, 525, 566, 5586, 5587, 533
2802, 564, 565, 5571, 5570, 567, 5588, 5589, 5586
2803, 565, 24, 547, 5571, 568, 555, 5590, 5588
2804, 525, 5570, 5572, 526, 5587, 5591, 5592, 534
2805, 5570, 5571, 5573, 5572, 5589, 5593, 5594, 5591
2806, 5571, 547, 548, 5573, 5590, 556, 5595, 5593
2807, 526, 5572, 5574, 527, 5592, 5596, 5597, 535
2808, 5572, 5573, 5575, 5574, 5594, 5598, 5599, 5596
2809, 5573, 548, 549, 5575, 5595, 557, 5600, 5598
2810, 527, 5574, 5576, 528, 5597, 5601, 5602, 536
2811, 5574, 5575, 5577, 5576, 5599, 5603, 5604, 5601
2812, 5575, 549, 550, 5577, 5600, 558, 5605, 5603
2813, 528, 5576, 5578, 529, 5602, 5606, 5607, 537
2814, 5576, 5577, 5579, 5578, 5604, 5608, 5609, 5606
2815, 5577, 550, 551, 5579, 5605, 559, 5610, 5608
2816, 529, 5578, 5580, 530, 5607, 5611, 5612, 538
2817, 5578, 5579, 5581, 5580, 5609, 5613, 5614, 5611
2818, 5579, 551, 552, 5581, 5610, 560, 5615, 5613
2819, 530, 5580, 5582, 531, 5612, 5616, 5617, 539
2820, 5580, 5581, 5583, 5582, 5614, 5618, 5619, 5616
2821, 5581, 552, 553, 5583, 5615, 561, 5620, 5618
2822, 531, 5582, 5584, 532, 5617, 5621, 5622, 540
2823, 5582, 5583, 5585, 5584, 5619, 5623, 5624, 5621
2824, 5583, 553, 554, 5585, 5620, 562, 5625, 5623
2825, 532, 5584, 542, 21, 5622, 5626, 544, 541
2826, 5584, 5585, 543, 542, 5624, 5627, 545, 5626
2827, 5585, 554, 23, 543, 5625, 563, 546, 5627
*ELEMENT, type=CPS8, ELSET=Surface174
2828, 13, 569, 5628, 376, 591, 5804, 5805, 384
2829, 376, 5628, 5629, 377, 5805, 5806, 5807, 385
2830, 377, 5629, 5630, 378, 5807, 5808, 5809, 386
2831, 378, 5630, 5631, 379, 5809, 5810, 5811, 387
2832, 379, 5631, 5632, 380, 5811, 5812, 5813, 388
2833, 380, 5632, 5633, 381, 5813, 5814, 5815, 389
2834, 381, 5633, 5634, 382, 5815, 5816, 5817, 390
2835, 382, 5634, 5635, 383, 5817, 5818, 5819, 391
2836, 383, 5635, 614, 11, 5819, 5820, 636, 392
2837, 569, 570, 5636, 5628, 592, 5821, 5822, 5804
2838, 5628, 5636, 5637, 5629, 5822, 5823, 5824, 5806
2839, 5629, 5637, 5638, 5630, 5824, 5825, 5826, 5808
2840, 5630, 5638, 5639, 5631, 5826, 5827, 5828, 5810
2841, 5631, 5639, 5640, 5632, 5828, 5829, 5830, 5812
2842, 5632, 5640, 5641, 5633, 5830, 5831, 5832, 5814
2843, 5633, 5641, 5642, 5634, 5832, 5833, 5834, 5816
2844, 5634, 5642, 5643, 5635, 5834, 5835, 5836, 5818
2845, 5635, 5643, 615, 614, 5836, 5837, 637, 5820
2846, 570, 571, 5644, 5636, 593, 5838, 5839, 5821
2847, 5636, 5644, 5645, 5637, 5839, 5840, 5841, 5823
2848, 5637, 5645, 5646, 5638, 5841, 5842, 5843, 5825
2849, 5638, 5646, 5647, 5639, 5843, 5844, 5845, 5827
2850, 5639, 5647, 5648, 5640, 5845, 5846, 5847, 5829
2851, 5640, 5648, 5649, 5641, 5847, 5848, 5849, 5831
2852, 5641, 5649, 5650, 5642, 5849, 5850, 5851, 5833
2853, 5642, 5650, 5651, 5643, 5851, 5852, 5853, 5835
2854, 5643, 5651, 616, 615, 5853, 5854, 638, 5837
2855, 571, 572, 5652, 5644, 594, 5855, 5856, 5838
2856, 5644, 5652, 5653, 5645, 5856, 5857, 5858, 5840
2857, 5645, 5653, 5654, 5646, 5858, 5859, 5860, 5842
2858, 5646, 5654, 5655, 5647, 5860, 5861, 5862, 5844
2859, 5647, 5655, 5656, 5648, 5862, 5863, 5864, 5846
2860, 5648, 5656, 5657, 5649, 5864, 5865, 5866, 5848
2861, 5649, 5657, 5658, 5650, 5866, 5867, 5868, 5850
2862, 5650, 5658, 5659, 5651, 5868, 5869, 5870, 5852
2863, 5651, 5659, 617, 616, 5870, 5871, 639, 5854
2864, 572, 573, 5660, 5652, 595, 5872, 5873, 5855
2865, 5652, 5660, 5661, 5653, 5873, 5874, 5875, 5857
2866, 5653, 5661, 5662, 5654, 5875, 5876, 5877, 5859
2867, 5654, 5662, 5663, 5655, 5877, 5878, 5879, 5861
2868, 5655, 5663, 5664, 5656, 5879, 5880, 5881, 5863
2869, 5656, 5664, 5665, 5657, 5881, 5882, 5883, 5865
2870, 5657, 5665, 5666, 5658, 5883, 5884, 5885, 5867
2871, 5658, 5666, 5667, 5659, 5885, 5886, 5887, 5869
2872, 5659, 5667, 618, 617, 5887, 5888, 640, 5871
2873, 573, 574, 5668, 5660, 596, 5889, 5890, 5872
2874, 5660, 5668, 5669, 5661, 5890, 5891, 5892, 5874
2875, 5661, 5669, 5670, 5662, 5892, 5893, 5894, 5876
2876, 5662, 5670, 5671, 5663, 5894, 5895, 5896, 5878
2877, 5663, 5671, 5672, 5664, 5896, 5897, 5898, 5880
2878, 5664, 5672, 5673, 5665, 5898, 5899, 5900, 5882
2879, 5665, 5673, 5674, 5666, 5900, 5901, 5902, 5884
2880, 5666, 5674, 5675, 5667, 5902, 5903, 5904, 5886
2881, 5667, 5675, 619, 618, 5904, 5905, 641, 5888
2882, 574, 575, 5676, 5668, 597, 5906, 5907, 5889
2883, 5668, 5676, 5677, 5669, 5907, 5908, 5909, 5891
2884, 5669, 5677, 5678, 5670, 5909, 5910, 5911, 5893
2885, 5670, 5678, 5679, 5671, 5911, 5912, 5913, 5895
2886, 5671, 5679, 5680, 5672, 5913, 5914, 5915, 5897
2887, 5672, 5680, 5681, 5673, 5915, 5916, 5917, 5899
2888, 5673, 5681, 5682, 5674, 5917, 5918, 5919, 5901
2889, 5674, 5682, 5683, 5675, 5919, 5920, 5921, 5903
2890, 5675, 5683, 620, 619, 5921, 5922, 642, 5905
2891, 575, 576, 5684, 5676, 598, 5923, 5924, 5906
2892, 5676, 5684, 5685, 5677, 5924, 5925, 5926, 5908
2893, 5677, 5685, 5686, 5678, 5926, 5927, 5928, 5910
2894, 5678, 5686, 5687, 5679, 5928, 5929, 5930, 5912
2895, 5679, 5687, 5688, 5680, 5930, 5931, 5932, 5914
2896, 5680, 5688, 5689, 5681, 5932, 5933, 5934, 5916
2897, 5681, 5689, 5690, 5682, 5934, 5935, 5936, 5918
2898, 5682, 5690, 5691, 5683, 5936, 5937, 5938, 5920
2899, 5683, 5691, 621, 620, 5938, 5939, 643, 5922
2900, 576, 577, 5692, 5684, 599, 5940, 5941, 5923
2901, 5684, 5692, 5693, 5685, 5941, 5942, 5943, 5925
2902, 5685, 5693, 5694, 5686, 5943, 5944, 5945, 5927
2903, 5686, 5694, 5695, 5687, 5945, 5946, 5947, 5929
2904, 5687, 5695, 5696, 5688, 5947, 5948, 5949, 5931
2905, 5688, 5696, 5697, 5689, 5949, 5950, 5951, 5933
2906, 5689, 5697, 5698, 5690, 5951, 5952, 5953, 5935
2907, 5690, 5698, 5699, 5691, 5953, 5954, 5955, 5937
2908, 5691, 5699, 622, 621, 5955, 5956, 644, 5939
2909, 577, 578, 5700, 5692, 600, 5957, 5958, 5940
2910, 5692, 5700, 5701, 5693, 5958, 5959, 5960, 5942
2911, 5693, 5701, 5702, 5694, 5960, 5961, 5962, 5944
2912, 5694, 5702, 5703, 5695, 5962, 5963, 5964, 5946
2913, 5695, 5703, 5704, 5696, 5964, 5965, 5966, 5948
2914, 5696, 5704, 5705, 5697, 5966, 5967, 5968, 5950
2915, 5697, 5705, 5706, 5698, 5968, 5969, 5970, 5952
2916, 5698, 5706, 5707, 5699, 5970, 5971, 5972, 5954
2917, 5699, 5707, 623, 622, 5972, 5973, 645, 5956
2918, 578, 579, 5708, 5700, 601, 5974, 5975, 5957
2919, 5700, 5708, 5709, 5701, 5975, 5976, 5977, 5959
2920, 5701, 5709, 5710, 5702, 5977, 5978, 5979, 5961
2921, 5702, 5710, 5711, 5703, 5979, 5980, 5981, 5963
2922, 5703, 5711, 5712, 5704, 5981, 5982, 5983, 5965
2923, 5704, 5712, 5713, 5705, 5983, 5984, 5985, 5967
2924, 5705, 5713, 5714, 5706, 5985, 5986, 5987, 5969
2925, 5706, 5714, 5715, 5707, 5987, 5988, 5989, 5971
2926, 5707, 5715, 624, 623, 5989, 5990, 646, 5973
2927, 579, 580, 5716, 5708, 602, 5991, 5992, 5974
2928, 5708, 5716, 5717, 5709, 5992, 5993, 5994, 5976
2929, 5709, 5717, 5718, 5710, 5994, 5995, 5996, 5978
2930, 5710, 5718, 5719, 5711, 5996, 5997, 5998, 5980
2931, 5711, 5719, 5720, 5712, 5998, 5999, 6000, 5982
2932, 5712, 5720, 5721, 5713, 6000, 6001, 6002, 5984
2933, 5713, 5721, 5722, 5714, 6002, 6003, 6004, 5986
2934, 5714, 5722, 5723, 5715, 6004, 6005, 6006, 5988
2935, 5715, 5723, 625, 624, 6006, 6007, 647, 5990
2936, 580, 581, 5724, 5716, 603, 6008, 6009, 5991
2937, 5716, 5724, 5725, 5717, 6009, 6010, 6011, 5993
2938, 5717, 5725, 5726, 5718, 6011, 6012, 6013, 5995
2939, 5718, 5726, 5727, 5719, 6013, 6014, 6015, 5997
2940, 5719, 5727, 5728, 5720, 6015, 6016, 6017, 5999
2941, 5720, 5728, 5729, 5721, 6017, 6018, 6019, 6001
2942, 5721, 5729, 5730, 5722, 6019, 6020, 6021, 6003
2943, 5722, 5730, 5731, 5723, 6021, 6022, 6023, 6005
2944, 5723, 5731, 626, 625, 6023, 6024, 648, 6007
2945, 581, 582, 5732, 5724, 604, 6025, 6026, 6008
2946, 5724, 5732, 5733, 5725, 6026, 6027, 6028, 6010
2947, 5725, 5733, 5734, 5726, 6028, 6029, 6030, 6012
2948, 5726, 5734, 5735, 5727, 6030, 6031, 6032, 6014
2949, 5727, 5735, 5736, 5728, 6032, 6033, 6034, 6016
2950, 5728, 5736, 5737, 5729, 6034, 6035, 6036, 6018
2951, 5729, 5737, 5738, 5730, 6036, 6037, 6038, 6020
2952, 5730, 5738, 5739, 5731, 6038, 6039, 6040, 6022
2953, 5731, 5739, 627, 626, 6040, 6041, 649, 6024
2954, 582, 583, 5740, 5732, 605, 6042, 6043, 6025
2955, 5732, 5740, 5741, 5733, 6043, 6044, 6045, 6027
2956, 5733, 5741, 5742, 5734, 6045, 6046, 6047, 6029
2957, 5734, 5742, 5743, 5735, 6047, 6048, 6049, 6031
2958, 5735, 5743, 5744, 5736, 6049, 6050, 6051, 6033
2959, 5736, 5744, 5745, 5737, 6051, 6052, 6053, 6035
2960, 5737, 5745, 5746, 5738, 6053, 6054, 6055, 6037
2961, 5738, 5746, 5747, 5739, 6055, 6056, 6057, 6039
2962, 5739, 5747, 628, 627, 6057, 6058, 650, 6041
2963, 583, 584, 5748, 5740, 606, 6059, 6060, 6042
2964, 5740, 5748, 5749, 5741, 6060, 6061, 6062, 6044
2965, 5741, 5749, 5750, 5742, 6062, 6063, 6064, 6046
2966, 5742, 5750, 5751, 5743, 6064, 6065, 6066, 6048
2967, 5743, 5751, 5752, 5744, 6066, 6067, 6068, 6050
2968, 5744, 5752, 5753, 5745, 6068, 6069, 6070, 6052
2969, 5745, 5753, 5754, 5746, 6070, 6071, 6072, 6054
2970, 5746, 5754, 5755, 5747, 6072, 6073, 6074, 6056
2971, 5747, 5755, 629, 628, 6074, 6075, 651, 6058
2972, 584, 585, 5756, 5748, 607, 6076, 6077, 6059
2973, 5748, 5756, 5757, 5749, 6077, 6078, 6079, 6061
2974, 5749, 5757, 5758, 5750, 6079, 6080, 6081, 6063
2975, 5750, 5758, 5759, 5751, 6081, 6082, 6083, 6065
2976, 5751, 5759, 5760, 5752, 6083, 6084, 6085, 6067
2977, 5752, 5760, 5761, 5753, 6085, 6086, 6087, 6069
2978, 5753, 5761, 5762, 5754, 6087, 6088, 6089, 6071
2979, 5754, 5762, 5763, 5755, 6089, 6090, 6091, 6073
2980, 5755, 5763, 630, 629, 6091, 6092, 652, 6075
2981, 585, 586, 5764, 5756, 608, 6093, 6094, 6076
2982, 5756, 5764, 5765, 5757, 6094, 6095, 6096, 6078
2983, 5757, 5765, 5766, 5758, 6096, 6097, 6098, 6080
2984, 5758, 5766, 5767, 5759, 6098, 6099, 6100, 6082
2985, 5759, 5767, 5768, 5760, 6100, 6101, 6102, 6084
2986, 5760, 5768, 5769, 5761, 6102, 6103, 6104, 6086
2987, 5761, 5769, 5770, 5762, 6104, 6105, 6106, 6088
2988, 5762, 5770, 5771, 5763, 6106, 6107, 6108, 6090
2989, 5763, 5771, 631, 630, 6108, 6109, 653, 6092
2990, 586, 587, 5772, 5764, 609, 6110, 6111, 6093
2991, 5764, 5772, 5773, 5765, 6111, 6112, 6113, 6095
2992, 5765, 5773, 5774, 5766, 6113, 6114, 6115, 6097
2993, 5766, 5774, 5775, 5767, 6115, 6116, 6117, 6099
2994, 5767, 5775, 5776, 5768, 6117, 6118, 6119, 6101
2995, 5768, 5776, 5777, 5769, 6119, 6120, 6121, 6103
2996, 5769, 5777, 5778, 5770, 6121, 6122, 6123, 6105
2997, 5770, 5778, 5779, 5771, 6123, 6124, 6125, 6107
2998, 5771, 5779, 632, 631, 6125, 6126, 654, 6109
2999, 587, 588, 5780, 5772, 610, 6127, 6128, 6110
3000, 5772, 5780, 5781, 5773, 6128, 6129, 6130, 6112
3001, 5773, 5781, 5782, 5774, 6130, 6131, 6132, 6114
3002, 5774, 5782, 5783, 5775, 6132, 6133, 6134, 6116
3003, 5775, 5783, 5784, 5776, 6134, 6135, 6136, 6118
3004, 5776, 5784, 5785, 5777, 6136, 6137, 6138, 6120
3005, 5777, 5785, 5786, 5778, 6138, 6139, 6140, 6122
3006, 5778, 5786, 5787, 5779, 6140, 6141, 6142, 6124
3007, 5779, 5787, 633, 632, 6142, 6143, 655, 6126
3008, 588, 589, 5788, 5780, 611, 6144, 6145, 6127
3009, 5780, 5788, 5789, 5781, 6145, 6146, 6147, 6129
3010, 5781, 5789, 5790, 5782, 6147, 6148, 6149, 6131
3011, 5782, 5790, 5791, 5783, 6149, 6150, 6151, 6133
3012, 5783, 5791, 5792, 5784, 6151, 6152, 6153, 6135
3013, 5784, 5792, 5793, 5785, 6153, 6154, 6155, 6137
3014, 5785, 5793, 5794, 5786, 6155, 6156, 6157, 6139
3015, 5786, 5794, 5795, 5787, 6157, 6158, 6159, 6141
3016, 5787, 5795, 634, 633, 6159, 6160, 656, 6143
3017, 589, 590, 5796, 5788, 612, 6161, 6162, 6144
3018, 5788, 5796, 5797, 5789, 6162, 6163, 6164, 6146
3019, 5789, 5797, 5798, 5790, 6164, 6165, 6166, 6148
3020, 5790, 5798, 5799, 5791, 6166, 6167, 6168, 6150
3021, 5791, 5799, 5800, 5792, 6168, 6169, 6170, 6152
3022, 5792, 5800, 5801, 5793, 6170, 6171, 6172, 6154
3023, 5793, 5801, 5802, 5794, 6172, 6173, 6174, 6156
3024, 5794, 5802, 5803, 5795, 6174, 6175, 6176, 6158
3025, 5795, 5803, 635, 634, 6176, 6177, 657, 6160
3026, 590, 22, 525, 5796, 613, 533, 6178, 6161
3027, 5796, 525, 526, 5797, 6178, 534, 6179, 6163
3028, 5797, 526, 527, 5798, 6179, 535, 6180, 6165
3029, 5798, 527, 528, 5799, 6180, 536, 6181, 6167
3030, 5799, 528, 529, 5800, 6181, 537, 6182, 6169
3031, 5800, 529, 530, 5801, 6182, 538, 6183, 6171
3032, 5801, 530, 531, 5802, 6183, 539, 6184, 6173
3033, 5802, 531, 532, 5803, 6184, 540, 6185, 6175
3034, 5803, 532, 21, 635, 6185, 541, 658, 6177
*ELEMENT, type=CPS8, ELSET=Surface175
3035, 15, 413, 6186, 659, 421, 6362, 6363, 681
3036, 413, 414, 6187, 6186, 422, 6364, 6365, 6362
3037, 414, 415, 6188, 6187, 423, 6366, 6367, 6364
3038, 415, 416, 6189, 6188, 424, 6368, 6369, 6366
3039, 416, 417, 6190, 6189, 425, 6370, 6371, 6368
3040, 417, 418, 6191, 6190, 426, 6372, 6373, 6370
3041, 418, 419, 6192, 6191, 427, 6374, 6375, 6372
3042, 419, 420, 6193, 6192, 428, 6376, 6377, 6374
3043, 420, 9, 704, 6193, 429, 726, 6378, 6376
3044, 659, 6186, 6194, 660, 6363, 6379, 6380, 682
3045, 6186, 6187, 6195, 6194, 6365, 6381, 6382, 6379
3046, 6187, 6188, 6196, 6195, 6367, 6383, 6384, 6381
3047, 6188, 6189, 6197, 6196, 6369, 6385, 6386, 6383
3048, 6189, 6190, 6198, 6197, 6371, 6387, 6388, 6385
3049, 6190, 6191, 6199, 6198, 6373, 6389, 6390, 6387
3050, 6191, 6192, 6200, 6199, 6375, 6391, 6392, 6389
3051, 6192, 6193, 6201, 6200, 6377, 6393, 6394, 6391
3052, 6193, 704, 705, 6201, 6378, 727, 6395, 6393
3053, 660, 6194, 6202, 661, 6380, 6396, 6397, 683
3054, 6194, 6195, 6203, 6202, 6382, 6398, 6399, 6396
3055, 6195, 6196, 6204, 6203, 6384, 6400, 6401, 6398
3056, 6196, 6197, 6205, 6204, 6386, 6402, 6403, 6400
3057, 6197, 6198, 6206, 6205, 6388, 6404, 6405, 6402
3058, 6198, 6199, 6207, 6206, 6390, 6406, 6407, 6404
3059, 6199, 6200, 6208, 6207, 6392, 6408, 6409, 6406
3060, 6200, 6201, 6209, 6208, 6394, 6410, 6411, 6408
3061, 6201, 705, 706, 6209, 6395, 728, 6412, 6410
3062, 661, 6202, 6210, 662, 6397, 6413, 6414, 684
3063, 6202, 6203, 6211, 6210, 6399, 6415, 6416, 6413
3064, 6203, 6204, 6212, 6211, 6401, 6417, 6418, 6415
3065, 6204, 6205, 6213, 6212, 6403, 6419, 6420, 6417
3066, 6205, 6206, 6214, 6213, 6405, 6421, 6422, 6419
3067, 6206, 6207, 6215, 6214, 6407, 6423, 6424, 6421
3068, 6207, 6208, 6216, 6215, 6409, 6425, 6426, 6423
3069, 6208, 6209, 6217, 6216, 6411, 6427, 6428, 6425
3070, 6209, 706, 707, 6217, 6412, 729, 6429, 6427
3071, 662, 6210, 6218, 663, 6414, 6430, 6431, 685
3072, 6210, 6211, 6219, 6218, 6416, 6432, 6433, 6430
3073, 6211, 6212, 6220, 6219, 6418, 6434, 6435, 6432
3074, 6212, 6213, 6221, 6220, 6420, 6436, 6437, 6434
3075, 6213, 6214, 6222, 6221, 6422, 6438, 6439, 6436
3076, 6214, 6215, 6223, 6222, 6424, 6440, 6441, 6438
3077, 6215, 6216, 6224, 6223, 6426, 6442, 6443, 6440
3078, 6216, 6217, 6225, 6224, 6428, 6444, 6445, 6442
3079, 6217, 707, 708, 6225, 6429, 730, 6446, 6444
3080, 663, 6218, 6226, 664, 6431, 6447, 6448, 686
3081, 6218, 6219, 6227, 6226, 6433, 6449, 6450, 6447
3082, 6219, 6220, 6228, 6227, 6435, 6451, 6452, 6449
3083, 6220, 6221, 6229, 6228, 6437, 6453, 6454, 6451
3084, 6221, 6222, 6230, 6229, 6439, 6455, 6456, 6453
3085, 6222, 6223, 6231, 6230, 6441, 6457, 6458, 6455
3086, 6223, 6224, 6232, 6231, 6443, 6459, 6460, 6457
3087, 6224, 6225, 6233, 6232, 6445, 6461, 6462, 6459
3088, 6225, 708, 709, 6233, 6446, 731, 6463, 6461
3089, 664, 6226, 6234, 665, 6448, 6464, 6465, 687
3090, 6226, 6227, 6235, 6234, 6450, 6466, 6467, 6464
3091, 6227, 6228, 6236, 6235, 6452, 6468, 6469, 6466
3092, 6228, 6229, 6237, 6236, 6454, 6470, 6471, 6468
3093, 6229, 6230, 6238, 6237, 6456, 6472, 6473, 6470
3094, 6230, 6231, 6239, 6238, 6458, 6474, 6475, 6472
3095, 6231, 6232, 6240, 6239, 6460, 6476, 6477, 6474
3096, 6232, 6233, 6241, 6240, 6462, 6478, 6479, 6476
3097, 6233, 709, 710, 6241, 6463, 732, 6480, 6478
3098, 665, 6234, 6242, 666, 6465, 6481, 6482, 688
3099, 6234, 6235, 6243, 6242, 6467, 6483, 6484, 6481
3100, 6235, 6236, 6244, 6243, 6469, 6485, 6486, 6483
3101, 6236, 6237, 6245, 6244, 6471, 6487, 6488, 6485
3102, 6237, 6238, 6246, 6245, 6473, 6489, 6490, 6487
3103, 6238, 6239, 6247, 6246, 6475, 6491, 6492, 6489
3104, 6239, 6240, 6248, 6247, 6477, 6493, 6494, 6491
3105, 6240, 6241, 6249, 6248, 6479, 6495, 6496, 6493
3106, 6241, 710, 711, 6249, 6480, 733, 6497, 6495
3107, 666, 6242, 6250, 667, 6482, 6498, 6499, 689
3108, 6242, 6243, 6251, 6250, 6484, 6500, 6501, 6498
3109, 6243, 6244, 6252, 6251, 6486, 6502, 6503, 6500
3110, 6244, 6245, 6253, 6252, 6488, 6504, 6505, 6502
3111, 6245, 6246, 6254, 6253, 6490, 6506, 6507, 6504
3112, 6246, 6247, 6255, 6254, 6492, 6508, 6509, 6506
3113, 6247, 6248, 6256, 6255, 6494, 6510, 6511, 6508
3114, 6248, 6249, 6257, 6256, 6496, 6512, 6513, 6510
3115, 6249, 711, 712, 6257, 6497, 734, 6514, 6512
3116, 667, 6250, 6258, 668, 6499, 6515, 6516, 690
3117, 6250, 6251, 6259, 6258, 6501, 6517, 6518, 6515
3118, 6251, 6252, 6260, 6259, 6503, 6519, 6520, 6517
3119, 6252, 6253, 6261, 6260, 6505, 6521, 6522, 6519
3120, 6253, 6254, 6262, 6261, 6507, 6523, 6524, 6521
3121, 6254, 6255, 6263, 6262, 6509, 6525, 6526, 6523
3122, 6255, 6256, 6264, 6263, 6511, 6527, 6528, 6525
3123, 6256, 6257, 6265, 6264, 6513, 6529, 6530, 6527
3124, 6257, 712, 713, 6265, 6514, 735, 6531, 6529
3125, 668, 6258, 6266, 669, 6516, 6532, 6533, 691
3126, 6258, 6259, 6267, 6266, 6518, 6534, 6535, 6532
3127, 6259, 6260, 6268, 6267, 6520, 6536, 6537, 6534
3128, 6260, 6261, 6269, 6268, 6522, 6538, 6539, 6536
3129, 6261, 6262, 6270, 6269, 6524, 6540, 6541, 6538
3130, 6262, 6263, 6271, 6270, 6526, 6542, 6543, 6540
3131, 6263, 6264, 6272, 6271, 6528, 6544, 6545, 6542
3132, 6264, 6265, 6273, 6272, 6530, 6546, 6547, 6544
3133, 6265, 713, 714, 6273, 6531, 736, 6548, 6546
3134, 669, 6266, 6274, 670, 6533, 6549, 6550, 692
3135, 6266, 6267, 6275, 6274, 6535, 6551, 6552, 6549
3136, 6267, 6268, 6276, 6275, 6537, 6553, 6554, 6551
3137, 6268, 6269, 6277, 6276, 6539, 6555, 6556, 6553
3138, 6269, 6270, 6278, 6277, 6541, 6557, 6558, 6555
3139, 6270, 6271, 6279, 6278, 6543, 6559, 6560, 6557
3140, 6271, 6272, 6280, 6279, 6545, 6561, 6562, 6559
3141, 6272, 6273, 6281, 6280, 6547, 6563, 6564, 6561
3142, 6273, 714, 715, 6281, 6548, 737, 6565, 6563
3143, 670, 6274, 6282, 671, 6550, 6566, 6567, 693
3144, 6274, 6275, 6283, 6282, 6552, 6568, 6569, 6566
3145, 6275, 6276, 6284, 6283, 6554, 6570, 6571, 6568
3146, 6276, 6277, 6285, 6284, 6556, 6572, 6573, 6570
3147, 6277, 6278, 6286, 6285, 6558, 6574, 6575, 6572
3148, 6278, 6279, 6287, 6286, 6560, 6576, 6577, 6574
3149, 6279, 6280, 6288, 6287, 6562, 6578, 6579, 6576
3150, 6280, 6281, 6289, 6288, 6564, 6580, 6581, 6578
3151, 6281, 715, 716, 6289, 6565, 738, 6582, 6580
3152, 671, 6282, 6290, 672, 6567, 6583, 6584, 694
3153, 6282, 6283, 6291, 6290, 6569, 6585, 6586, 6583
3154, 6283, 6284, 6292, 6291, 6571, 6587, 6588, 6585
3155, 6284, 6285, 6293, 6292, 6573, 6589, 6590, 6587
3156, 6285, 6286, 6294, 6293, 6575, 6591, 6592, 6589
3157, 6286, 6287, 6295, 6294, 6577, 6593, 6594, 6591
3158, 6287, 6288, 6296, 6295, 6579, 6595, 6596, 6593
3159, 6288, 6289, 6297, 6296, 6581, 6597, 6598, 6595
3160, 6289, 716, 717, 6297, 6582, 739, 6599, 6597
3161, 672, 6290, 6298, 673, 6584, 6600, 6601, 695
3162, 6290, 6291, 6299, 6298, 6586, 6602, 6603, 6600
3163, 6291, 6292, 6300, 6299, 6588, 6604, 6605, 6602
3164, 6292, 6293, 6301, 6300, 6590, 6606, 6607, 6604
3165, 6293, 6294, 6302, 6301, 6592, 6608, 6609, 6606
3166, 6294, 6295, 6303, 6302, 6594, 6610, 6611, 6608
3167, 6295, 6296, 6304, 6303, 6596, 6612, 6613, 6610
3168, 6296, 6297, 6305, 6304, 6598, 6614, 6615, 6612
3169, 6297, 717, 718, 6305, 6599, 740, 6616, 6614
3170, 673, 6298, 6306, 674, 6601, 6617, 6618, 696
3171, 6298, 6299, 6307, 6306, 6603, 6619, 6620, 6617
3172, 6299, 6300, 6308, 6307, 6605, 6621, 6622, 6619
3173, 6300, 6301, 6309, 6308, 6607, 6623, 6624, 6621
3174, 6301, 6302, 6310, 6309, 6609, 6625, 6626, 6623
3175, 6302, 6303, 6311, 6310, 6611, 6627, 6628, 6625
3176, 6303, 6304, 6312, 6311, 6613, 6629, 6630, 6627
3177, 6304, 6305, 6313, 6312, 6615, 6631, 6632, 6629
3178, 6305, 718, 719, 6313, 6616, 741, 6633, 6631
3179, 674, 6306, 6314, 675, 6618, 6634, 6635, 697
3180, 6306, 6307, 6315, 6314, 6620, 6636, 6637, 6634
3181, 6307, 6308, 6316, 6315, 6622, 6638, 6639, 6636
3182, 6308, 6309, 6317, 6316, 6624, 6640, 6641, 6638
3183, 6309, 6310, 6318, 6317, 6626, 6642, 6643, 6640
3184, 6310, 6311, 6319, 6318, 6628, 6644, 6645, 6642
3185, 6311, 6312, 6320, 6319, 6630, 6646, 6647, 6644
3186, 6312, 6313, 6321, 6320, 6632, 6648, 6649, 6646
3187, 6313, 719, 720, 6321, 6633, 742, 6650, 6648
3188, 675, 6314, 6322, 676, 6635, 6651, 6652, 698
3189, 6314, 6315, 6323, 6322, 6637, 6653, 6654, 6651
3190, 6315, 6316, 6324, 6323, 6639, 6655, 6656, 6653
3191, 6316, 6317, 6325, 6324, 6641, 6657, 6658, 6655
3192, 6317, 6318, 6326, 6325, 6643, 6659, 6660, 6657
3193, 6318, 6319, 6327, 6326, 6645, 6661, 6662, 6659
3194, 6319, 6320, 6328, 6327, 6647, 6663, 6664, 6661
3195, 6320, 6321, 6329, 6328, 6649, 6665, 6666, 6663
3196, 6321, 720, 721, 6329, 6650, 743, 6667, 6665
3197, 676, 6322, 6330, 677, 6652, 6668, 6669, 699
3198, 6322, 6323, 6331, 6330, 6654, 6670, 6671, 6668
3199, 6323, 6324, 6332, 6331, 6656, 6672, 6673, 6670
3200, 6324, 6325, 6333, 6332, 6658, 6674, 6675, 6672
3201, 6325, 6326, 6334, 6333, 6660, 6676, 6677, 6674
3202, 6326, 6327, 6335, 6334, 6662, 6678, 6679, 6676
3203, 6327, 6328, 6336, 6335, 6664, 6680, 6681, 6678
3204, 6328, 6329, 6337, 6336, 6666, 6682, 6683, 6680
3205, 6329, 721, 722, 6337, 6667, 744, 6684, 6682
3206, 677, 6330, 6338, 678, 6669, 6685, 6686, 700
3207, 6330, 6331, 6339, 6338, 6671, 6687, 6688, 6685
3208, 6331, 6332, 6340, 6339, 6673, 6689, 6690, 6687
3209, 6332, 6333, 6341, 6340, 6675, 6691, 6692, 6689
3210, 6333, 6334, 6342, 6341, 6677, 6693, 6694, 6691
3211, 6334, 6335, 6343, 6342, 6679, 6695, 6696, 6693
3212, 6335, 6336, 6344, 6343, 6681, 6697, 6698, 6695
3213, 6336, 6337, 6345, 6344, 6683, 6699, 6700, 6697
3214, 6337, 722, 723, 6345, 6684, 745, 6701, 6699
3215, 678, 6338, 6346, 679, 6686, 6702, 6703, 701
3216, 6338, 6339, 6347, 6346, 6688, 6704, 6705, 6702
3217, 6339, 6340, 6348, 6347, 6690, 6706, 6707, 6704
3218, 6340, 6341, 6349, 6348, 6692, 6708, 6709, 6706
3219, 6341, 6342, 6350, 6349, 6694, 6710, 6711, 6708
3220, 6342, 6343, 6351, 6350, 6696, 6712, 6713, 6710
3221, 6343, 6344, 6352, 6351, 6698, 6714, 6715, 6712
3222, 6344, 6345, 6353, 6352, 6700, 6716, 6717, 6714
3223, 6345, 723, 724, 6353, 6701, 746, 6718, 6716
3224, 679, 6346, 6354, 680, 6703, 6719, 6720, 702
3225, 6346, 6347, 6355, 6354, 6705, 6721, 6722, 6719
3226, 6347, 6348, 6356, 6355, 6707, 6723, 6724, 6721
3227, 6348, 6349, 6357, 6356, 6709, 6725, 6726, 6723
3228, 6349, 6350, 6358, 6357, 6711, 6727, 6728, 6725
3229, 6350, 6351, 6359, 6358, 6713, 6729, 6730, 6727
3230, 6351, 6352, 6360, 6359, 6715, 6731, 6732, 6729
3231, 6352, 6353, 6361, 6360, 6717, 6733, 6734, 6731
3232, 6353, 724, 725, 6361, 6718, 747, 6735, 6733
3233, 680, 6354, 547, 24, 6720, 6736, 555, 703
3234, 6354, 6355, 548, 547, 6722, 6737, 556, 6736
3235, 6355, 6356, 549, 548, 6724, 6738, 557, 6737
3236, 6356, 6357, 550, 549, 6726, 6739, 558, 6738
3237, 6357, 6358, 551, 550, 6728, 6740, 559, 6739
3238, 6358, 6359, 552, 551, 6730, 6741, 560, 6740
3239, 6359, 6360, 553, 552, 6732, 6742, 561, 6741
3240, 6360, 6361, 554, 553, 6734, 6743, 562, 6742
3241, 6361, 725, 23, 554, 6735, 748, 563, 6743
*ELEMENT, type=CPS8, ELSET=Surface176
3242, 13, 447, 6744, 569, 449, 6788, 6789, 591
3243, 569, 6744, 6745, 570, 6789, 6790, 6791, 592
3244, 570, 6745, 6746, 571, 6791, 6792, 6793, 593
3245, 571, 6746, 6747, 572, 6793, 6794, 6795, 594
3246, 572, 6747, 6748, 573, 6795, 6796, 6797, 595
3247, 573, 6748, 6749, 574, 6797, 6798, 6799, 596
3248, 574, 6749, 6750, 575, 6799, 6800, 6801, 597
3249, 575, 6750, 6751, 576, 6801, 6802, 6803, 598
3250, 576, 6751, 6752, 577, 6803, 6804, 6805, 599
3251, 577, 6752, 6753, 578, 6805, 6806, 6807, 600
3252, 578, 6753, 6754, 579, 6807, 6808, 6809, 601
3253, 579, 6754, 6755, 580, 6809, 6810, 6811, 602
3254, 580, 6755, 6756, 581, 6811, 6812, 6813, 603
3255, 581, 6756, 6757, 582, 6813, 6814, 6815, 604
3256, 582, 6757, 6758, 583, 6815, 6816, 6817, 605
3257, 583, 6758, 6759, 584, 6817, 6818, 6819, 606
3258, 584, 6759, 6760, 585, 6819, 6820, 6821, 607
3259, 585, 6760, 6761, 586, 6821, 6822, 6823, 608
3260, 586, 6761, 6762, 587, 6823, 6824, 6825, 609
3261, 587, 6762, 6763, 588, 6825, 6826, 6827, 610
3262, 588, 6763, 6764, 589, 6827, 6828, 6829, 611
3263, 589, 6764, 6765, 590, 6829, 6830, 6831, 612
3264, 590, 6765, 564, 22, 6831, 6832, 566, 613
3265, 447, 448, 6766, 6744, 450, 6833, 6834, 6788
3266, 6744, 6766, 6767, 6745, 6834, 6835, 6836, 6790
3267, 6745, 6767, 6768, 6746, 6836, 6837, 6838, 6792
3268, 6746, 6768, 6769, 6747, 6838, 6839, 6840, 6794
3269, 6747, 6769, 6770, 6748, 6840, 6841, 6842, 6796
3270, 6748, 6770, 6771, 6749, 6842, 6843, 6844, 6798
3271, 6749, 6771, 6772, 6750, 6844, 6845, 6846, 6800
3272, 6750, 6772, 6773, 6751, 6846, 6847, 6848, 6802
3273, 6751, 6773, 6774, 6752, 6848, 6849, 6850, 6804
3274, 6752, 6774, 6775, 6753, 6850, 6851, 6852, 6806
3275, 6753, 6775, 6776, 6754, 6852, 6853, 6854, 6808
3276, 6754, 6776, 6777, 6755, 6854, 6855, 6856, 6810
3277, 6755, 6777, 6778, 6756, 6856, 6857, 6858, 6812
3278, 6756, 6778, 6779, 6757, 6858, 6859, 6860, 6814
3279, 6757, 6779, 6780, 6758, 6860, 6861, 6862, 6816
3280, 6758, 6780, 6781, 6759, 6862, 6863, 6864, 6818
3281, 6759, 6781, 6782, 6760, 6864, 6865, 6866, 6820
3282, 6760, 6782, 6783, 6761, 6866, 6867, 6868, 6822
3283, 6761, 6783, 6784, 6762, 6868, 6869, 6870, 6824
3284, 6762, 6784, 6785, 6763, 6870, 6871, 6872, 6826
3285, 6763, 6785, 6786, 6764, 6872, 6873, 6874, 6828
3286, 6764, 6786, 6787, 6765, 6874, 6875, 6876, 6830
3287, 6765, 6787, 565, 564, 6876, 6877, 567, 6832
3288, 448, 15, 659, 6766, 451, 681, 6878, 6833
3289, 6766, 659, 660, 6767, 6878, 682, 6879, 6835
3290, 6767, 660, 661, 6768, 6879, 683, 6880, 6837
3291, 6768, 661, 662, 6769, 6880, 684, 6881, 6839
3292, 6769, 662, 663, 6770, 6881, 685, 6882, 6841
3293, 6770, 663, 664, 6771, 6882, 686, 6883, 6843
3294, 6771, 664, 665, 6772, 6883, 687, 6884, 6845
3295, 6772, 665, 666, 6773, 6884, 688, 6885, 6847
3296, 6773, 666, 667, 6774, 6885, 689, 6886, 6849
3297, 6774, 667, 668, 6775, 6886, 690, 6887, 6851
3298, 6775, 668, 669, 6776, 6887, 691, 6888, 6853
3299, 6776, 669, 670, 6777, 6888, 692, 6889, 6855
3300, 6777, 670, 671, 6778, 6889, 693, 6890, 6857
3301, 6778, 671, 672, 6779, 6890, 694, 6891, 6859
3302, 6779, 672, 673, 6780, 6891, 695, 6892, 6861
3303, 6780, 673, 674, 6781, 6892, 696, 6893, 6863
3304, 6781, 674, 675, 6782, 6893, 697, 6894, 6865
3305, 6782, 675, 676, 6783, 6894, 698, 6895, 6867
3306, 6783, 676, 677, 6784, 6895, 699, 6896, 6869
3307, 6784, 677, 678, 6785, 6896, 700, 6897, 6871
3308, 6785, 678, 679, 6786, 6897, 701, 6898, 6873
3309, 6786, 679, 680, 6787, 6898, 702, 6899, 6875
3310, 6787, 680, 24, 565, 6899, 703, 568, 6877
*ELEMENT, type=CPS8, ELSET=Surface177
3311, 11, 614, 6900, 363, 636, 6944, 6945, 365
3312, 614, 615, 6901, 6900, 637, 6946, 6947, 6944
3313, 615, 616, 6902, 6901, 638, 6948, 6949, 6946
3314, 616, 617, 6903, 6902, 639, 6950, 6951, 6948
3315, 617, 618, 6904, 6903, 640, 6952, 6953, 6950
3316, 618, 619, 6905, 6904, 641, 6954, 6955, 6952
3317, 619, 620, 6906, 6905, 642, 6956, 6957, 6954
3318, 620, 621, 6907, 6906, 643, 6958, 6959, 6956
3319, 621, 622, 6908, 6907, 644, 6960, 6961, 6958
3320, 622, 623, 6909, 6908, 645, 6962, 6963, 6960
3321, 623, 624, 6910, 6909, 646, 6964, 6965, 6962
3322, 624, 625, 6911, 6910, 647, 6966, 6967, 6964
3323, 625, 626, 6912, 6911, 648, 6968, 6969, 6966
3324, 626, 627, 6913, 6912, 649, 6970, 6971, 6968
3325, 627, 628, 6914, 6913, 650, 6972, 6973, 6970
3326, 628, 629, 6915, 6914, 651, 6974, 6975, 6972
3327, 629, 630, 6916, 6915, 652, 6976, 6977, 6974
3328, 630, 631, 6917, 6916, 653, 6978, 6979, 6976
3329, 631, 632, 6918, 6917, 654, 6980, 6981, 6978
3330, 632, 633, 6919, 6918, 655, 6982, 6983, 6980
3331, 633, 634, 6920, 6919, 656, 6984, 6985, 6982
3332, 634, 635, 6921, 6920, 657, 6986, 6987, 6984
3333, 635, 21, 542, 6921, 658, 544, 6988, 6986
3334, 363, 6900, 6922, 364, 6945, 6989, 6990, 366
3335, 6900, 6901, 6923, 6922, 6947, 6991, 6992, 6989
3336, 6901, 6902, 6924, 6923, 6949, 6993, 6994, 6991
3337, 6902, 6903, 6925, 6924, 6951, 6995, 6996, 6993
3338, 6903, 6904, 6926, 6925, 6953, 6997, 6998, 6995
3339, 6904, 6905, 6927, 6926, 6955, 6999, 7000, 6997
3340, 6905, 6906, 6928, 6927, 6957, 7001, 7002, 6999
3341, 6906, 6907, 6929, 6928, 6959, 7003, 7004, 7001
3342, 6907, 6908, 6930, 6929, 6961, 7005, 7006, 7003
3343, 6908, 6909, 6931, 6930, 6963, 7007, 7008, 7005
3344, 6909, 6910, 6932, 6931, 6965, 7009, 7010, 7007
3345, 6910, 6911, 6933, 6932, 6967, 7011, 7012, 7009
3346, 6911, 6912, 6934, 6933, 6969, 7013, 7014, 7011
3347, 6912, 6913, 6935, 6934, 6971, 7015, 7016, 7013
3348, 6913, 6914, 6936, 6935, 6973, 7017, 7018, 7015
3349, 6914, 6915, 6937, 6936, 6975, 7019, 7020, 7017
3350, 6915, 6916, 6938, 6937, 6977, 7021, 7022, 7019
3351, 6916, 6917, 6939, 6938, 6979, 7023, 7024, 7021
3352, 6917, 6918, 6940, 6939, 6981, 7025, 7026, 7023
3353, 6918, 6919, 6941, 6940, 6983, 7027, 7028, 7025
3354, 6919, 6920, 6942, 6941, 6985, 7029, 7030, 7027
3355, 6920, 6921, 6943, 6942, 6987, 7031, 7032, 7029
3356, 6921, 542, 543, 6943, 6988, 545, 7033, 7031
3357, 364, 6922, 704, 9, 6990, 7034, 726, 367
3358, 6922, 6923, 705, 704, 6992, 7035, 727, 7034
3359, 6923, 6924, 706, 705, 6994, 7036, 728, 7035
3360, 6924, 6925, 707, 706, 6996, 7037, 729, 7036
3361, 6925, 6926, 708, 707, 6998, 7038, 730, 7037
3362, 6926, 6927, 709, 708, 7000, 7039, 731, 7038
3363, 6927, 6928, 710, 709, 7002, 7040, 732, 7039
3364, 6928, 6929, 711, 710, 7004, 7041, 733, 7040
3365, 6929, 6930, 712, 711, 7006, 7042, 734, 7041
3366, 6930, 6931, 713, 712, 7008, 7043, 735, 7042
3367, 6931, 6932, 714, 713, 7010, 7044, 736, 7043
3368, 6932, 6933, 715, 714, 7012, 7045, 737, 7044
3369, 6933, 6934, 716, 715, 7014, 7046, 738, 7045
3370, 6934, 6935, 717, 716, 7016, 7047, 739, 7046
3371, 6935, 6936, 718, 717, 7018, 7048, 740, 7047
3372, 6936, 6937, 719, 718, 7020, 7049, 741, 7048
3373, 6937, 6938, 720, 719, 7022, 7050, 742, 7049
3374, 6938, 6939, 721, 720, 7024, 7051, 743, 7050
