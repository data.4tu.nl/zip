5785, 0.8695652173913, -0.05, 0.33333333333333
5786, 0.8695652173913, -0.05, 0.38888888888889
5787, 0.8695652173913, -0.05, 0.44444444444444
5788, 0.91304347826087, -0.05, 0.055555555555556
5789, 0.91304347826087, -0.05, 0.11111111111111
5790, 0.91304347826087, -0.05, 0.16666666666667
5791, 0.91304347826087, -0.05, 0.22222222222222
5792, 0.91304347826087, -0.05, 0.27777777777778
5793, 0.91304347826087, -0.05, 0.33333333333333
5794, 0.91304347826087, -0.05, 0.38888888888889
5795, 0.91304347826087, -0.05, 0.44444444444444
5796, 0.95652173913043, -0.05, 0.055555555555556
5797, 0.95652173913043, -0.05, 0.11111111111111
5798, 0.95652173913043, -0.05, 0.16666666666667
5799, 0.95652173913043, -0.05, 0.22222222222222
5800, 0.95652173913043, -0.05, 0.27777777777778
5801, 0.95652173913043, -0.05, 0.33333333333333
5802, 0.95652173913043, -0.05, 0.38888888888889
5803, 0.95652173913043, -0.05, 0.44444444444444
5804, 0.043478260869565, -0.05, 0.027777777777778
5805, 0.021739130434783, -0.05, 0.055555555555556
5806, 0.043478260869565, -0.05, 0.083333333333333
5807, 0.021739130434783, -0.05, 0.11111111111111
5808, 0.043478260869565, -0.05, 0.13888888888889
5809, 0.021739130434783, -0.05, 0.16666666666667
5810, 0.043478260869565, -0.05, 0.19444444444444
5811, 0.021739130434783, -0.05, 0.22222222222222
5812, 0.043478260869565, -0.05, 0.25
5813, 0.021739130434783, -0.05, 0.27777777777778
5814, 0.043478260869565, -0.05, 0.30555555555556
5815, 0.021739130434783, -0.05, 0.33333333333333
5816, 0.043478260869565, -0.05, 0.36111111111111
5817, 0.021739130434783, -0.05, 0.38888888888889
5818, 0.043478260869565, -0.05, 0.41666666666667
5819, 0.021739130434783, -0.05, 0.44444444444444
5820, 0.043478260869565, -0.05, 0.47222222222222
5821, 0.08695652173913, -0.05, 0.027777777777778
5822, 0.065217391304348, -0.05, 0.055555555555556
5823, 0.08695652173913, -0.05, 0.083333333333333
5824, 0.065217391304348, -0.05, 0.11111111111111
5825, 0.08695652173913, -0.05, 0.13888888888889
5826, 0.065217391304348, -0.05, 0.16666666666667
5827, 0.08695652173913, -0.05, 0.19444444444444
5828, 0.065217391304348, -0.05, 0.22222222222222
5829, 0.08695652173913, -0.05, 0.25
5830, 0.065217391304348, -0.05, 0.27777777777778
5831, 0.08695652173913, -0.05, 0.30555555555556
5832, 0.065217391304348, -0.05, 0.33333333333333
5833, 0.08695652173913, -0.05, 0.36111111111111
5834, 0.065217391304348, -0.05, 0.38888888888889
5835, 0.08695652173913, -0.05, 0.41666666666667
5836, 0.065217391304348, -0.05, 0.44444444444444
5837, 0.08695652173913, -0.05, 0.47222222222222
5838, 0.1304347826087, -0.05, 0.027777777777778
5839, 0.10869565217391, -0.05, 0.055555555555556
5840, 0.1304347826087, -0.05, 0.083333333333333
5841, 0.10869565217391, -0.05, 0.11111111111111
5842, 0.1304347826087, -0.05, 0.13888888888889
5843, 0.10869565217391, -0.05, 0.16666666666667
5844, 0.1304347826087, -0.05, 0.19444444444444
5845, 0.10869565217391, -0.05, 0.22222222222222
5846, 0.1304347826087, -0.05, 0.25
5847, 0.10869565217391, -0.05, 0.27777777777778
5848, 0.1304347826087, -0.05, 0.30555555555556
5849, 0.10869565217391, -0.05, 0.33333333333333
5850, 0.1304347826087, -0.05, 0.36111111111111
5851, 0.10869565217391, -0.05, 0.38888888888889
5852, 0.1304347826087, -0.05, 0.41666666666667
5853, 0.10869565217391, -0.05, 0.44444444444444
5854, 0.1304347826087, -0.05, 0.47222222222222
5855, 0.17391304347826, -0.05, 0.027777777777778
5856, 0.15217391304348, -0.05, 0.055555555555556
5857, 0.17391304347826, -0.05, 0.083333333333333
5858, 0.15217391304348, -0.05, 0.11111111111111
5859, 0.17391304347826, -0.05, 0.13888888888889
5860, 0.15217391304348, -0.05, 0.16666666666667
5861, 0.17391304347826, -0.05, 0.19444444444444
5862, 0.15217391304348, -0.05, 0.22222222222222
5863, 0.17391304347826, -0.05, 0.25
5864, 0.15217391304348, -0.05, 0.27777777777778
5865, 0.17391304347826, -0.05, 0.30555555555556
5866, 0.15217391304348, -0.05, 0.33333333333333
5867, 0.17391304347826, -0.05, 0.36111111111111
5868, 0.15217391304348, -0.05, 0.38888888888889
5869, 0.17391304347826, -0.05, 0.41666666666667
5870, 0.15217391304348, -0.05, 0.44444444444444
5871, 0.17391304347826, -0.05, 0.47222222222222
5872, 0.21739130434783, -0.05, 0.027777777777778
5873, 0.19565217391304, -0.05, 0.055555555555556
5874, 0.21739130434783, -0.05, 0.083333333333333
5875, 0.19565217391304, -0.05, 0.11111111111111
5876, 0.21739130434783, -0.05, 0.13888888888889
5877, 0.19565217391304, -0.05, 0.16666666666667
5878, 0.21739130434783, -0.05, 0.19444444444444
5879, 0.19565217391304, -0.05, 0.22222222222222
5880, 0.21739130434783, -0.05, 0.25
5881, 0.19565217391304, -0.05, 0.27777777777778
5882, 0.21739130434783, -0.05, 0.30555555555556
5883, 0.19565217391304, -0.05, 0.33333333333333
5884, 0.21739130434783, -0.05, 0.36111111111111
5885, 0.19565217391304, -0.05, 0.38888888888889
5886, 0.21739130434783, -0.05, 0.41666666666667
5887, 0.19565217391304, -0.05, 0.44444444444444
5888, 0.21739130434783, -0.05, 0.47222222222222
5889, 0.26086956521739, -0.05, 0.027777777777778
5890, 0.23913043478261, -0.05, 0.055555555555556
5891, 0.26086956521739, -0.05, 0.083333333333333
5892, 0.23913043478261, -0.05, 0.11111111111111
5893, 0.26086956521739, -0.05, 0.13888888888889
5894, 0.23913043478261, -0.05, 0.16666666666667
5895, 0.26086956521739, -0.05, 0.19444444444444
5896, 0.23913043478261, -0.05, 0.22222222222222
5897, 0.26086956521739, -0.05, 0.25
5898, 0.23913043478261, -0.05, 0.27777777777778
5899, 0.26086956521739, -0.05, 0.30555555555556
5900, 0.23913043478261, -0.05, 0.33333333333333
5901, 0.26086956521739, -0.05, 0.36111111111111
5902, 0.23913043478261, -0.05, 0.38888888888889
5903, 0.26086956521739, -0.05, 0.41666666666667
5904, 0.23913043478261, -0.05, 0.44444444444444
5905, 0.26086956521739, -0.05, 0.47222222222222
5906, 0.30434782608696, -0.05, 0.027777777777778
5907, 0.28260869565217, -0.05, 0.055555555555556
5908, 0.30434782608696, -0.05, 0.083333333333333
5909, 0.28260869565217, -0.05, 0.11111111111111
5910, 0.30434782608696, -0.05, 0.13888888888889
5911, 0.28260869565217, -0.05, 0.16666666666667
5912, 0.30434782608696, -0.05, 0.19444444444444
5913, 0.28260869565217, -0.05, 0.22222222222222
5914, 0.30434782608696, -0.05, 0.25
5915, 0.28260869565217, -0.05, 0.27777777777778
5916, 0.30434782608696, -0.05, 0.30555555555556
5917, 0.28260869565217, -0.05, 0.33333333333333
5918, 0.30434782608696, -0.05, 0.36111111111111
5919, 0.28260869565217, -0.05, 0.38888888888889
5920, 0.30434782608696, -0.05, 0.41666666666667
5921, 0.28260869565217, -0.05, 0.44444444444444
5922, 0.30434782608696, -0.05, 0.47222222222222
5923, 0.34782608695652, -0.05, 0.027777777777778
5924, 0.32608695652174, -0.05, 0.055555555555556
5925, 0.34782608695652, -0.05, 0.083333333333333
5926, 0.32608695652174, -0.05, 0.11111111111111
5927, 0.34782608695652, -0.05, 0.13888888888889
5928, 0.32608695652174, -0.05, 0.16666666666667
5929, 0.34782608695652, -0.05, 0.19444444444444
5930, 0.32608695652174, -0.05, 0.22222222222222
5931, 0.34782608695652, -0.05, 0.25
5932, 0.32608695652174, -0.05, 0.27777777777778
5933, 0.34782608695652, -0.05, 0.30555555555556
5934, 0.32608695652174, -0.05, 0.33333333333333
5935, 0.34782608695652, -0.05, 0.36111111111111
5936, 0.32608695652174, -0.05, 0.38888888888889
5937, 0.34782608695652, -0.05, 0.41666666666667
5938, 0.32608695652174, -0.05, 0.44444444444444
5939, 0.34782608695652, -0.05, 0.47222222222222
5940, 0.39130434782609, -0.05, 0.027777777777778
5941, 0.3695652173913, -0.05, 0.055555555555556
5942, 0.39130434782609, -0.05, 0.083333333333333
5943, 0.3695652173913, -0.05, 0.11111111111111
5944, 0.39130434782609, -0.05, 0.13888888888889
5945, 0.3695652173913, -0.05, 0.16666666666667
5946, 0.39130434782609, -0.05, 0.19444444444444
5947, 0.3695652173913, -0.05, 0.22222222222222
5948, 0.39130434782609, -0.05, 0.25
5949, 0.3695652173913, -0.05, 0.27777777777778
5950, 0.39130434782609, -0.05, 0.30555555555556
5951, 0.3695652173913, -0.05, 0.33333333333333
5952, 0.39130434782609, -0.05, 0.36111111111111
5953, 0.3695652173913, -0.05, 0.38888888888889
5954, 0.39130434782609, -0.05, 0.41666666666667
5955, 0.3695652173913, -0.05, 0.44444444444444
5956, 0.39130434782609, -0.05, 0.47222222222222
5957, 0.43478260869565, -0.05, 0.027777777777778
5958, 0.41304347826087, -0.05, 0.055555555555556
5959, 0.43478260869565, -0.05, 0.083333333333333
5960, 0.41304347826087, -0.05, 0.11111111111111
5961, 0.43478260869565, -0.05, 0.13888888888889
5962, 0.41304347826087, -0.05, 0.16666666666667
5963, 0.43478260869565, -0.05, 0.19444444444444
5964, 0.41304347826087, -0.05, 0.22222222222222
5965, 0.43478260869565, -0.05, 0.25
5966, 0.41304347826087, -0.05, 0.27777777777778
5967, 0.43478260869565, -0.05, 0.30555555555556
5968, 0.41304347826087, -0.05, 0.33333333333333
5969, 0.43478260869565, -0.05, 0.36111111111111
5970, 0.41304347826087, -0.05, 0.38888888888889
5971, 0.43478260869565, -0.05, 0.41666666666667
5972, 0.41304347826087, -0.05, 0.44444444444444
5973, 0.43478260869565, -0.05, 0.47222222222222
5974, 0.47826086956522, -0.05, 0.027777777777778
5975, 0.45652173913043, -0.05, 0.055555555555556
5976, 0.47826086956522, -0.05, 0.083333333333333
5977, 0.45652173913043, -0.05, 0.11111111111111
5978, 0.47826086956522, -0.05, 0.13888888888889
5979, 0.45652173913043, -0.05, 0.16666666666667
5980, 0.47826086956522, -0.05, 0.19444444444444
5981, 0.45652173913043, -0.05, 0.22222222222222
5982, 0.47826086956522, -0.05, 0.25
5983, 0.45652173913043, -0.05, 0.27777777777778
5984, 0.47826086956522, -0.05, 0.30555555555556
5985, 0.45652173913043, -0.05, 0.33333333333333
5986, 0.47826086956522, -0.05, 0.36111111111111
5987, 0.45652173913043, -0.05, 0.38888888888889
5988, 0.47826086956522, -0.05, 0.41666666666667
5989, 0.45652173913043, -0.05, 0.44444444444444
5990, 0.47826086956522, -0.05, 0.47222222222222
5991, 0.52173913043478, -0.05, 0.027777777777778
5992, 0.5, -0.05, 0.055555555555556
5993, 0.52173913043478, -0.05, 0.083333333333333
5994, 0.5, -0.05, 0.11111111111111
5995, 0.52173913043478, -0.05, 0.13888888888889
5996, 0.5, -0.05, 0.16666666666667
5997, 0.52173913043478, -0.05, 0.19444444444444
5998, 0.5, -0.05, 0.22222222222222
5999, 0.52173913043478, -0.05, 0.25
6000, 0.5, -0.05, 0.27777777777778
6001, 0.52173913043478, -0.05, 0.30555555555556
6002, 0.5, -0.05, 0.33333333333333
6003, 0.52173913043478, -0.05, 0.36111111111111
6004, 0.5, -0.05, 0.38888888888889
6005, 0.52173913043478, -0.05, 0.41666666666667
6006, 0.5, -0.05, 0.44444444444444
6007, 0.52173913043478, -0.05, 0.47222222222222
6008, 0.56521739130435, -0.05, 0.027777777777778
6009, 0.54347826086957, -0.05, 0.055555555555556
6010, 0.56521739130435, -0.05, 0.083333333333333
6011, 0.54347826086957, -0.05, 0.11111111111111
6012, 0.56521739130435, -0.05, 0.13888888888889
6013, 0.54347826086957, -0.05, 0.16666666666667
6014, 0.56521739130435, -0.05, 0.19444444444444
6015, 0.54347826086957, -0.05, 0.22222222222222
6016, 0.56521739130435, -0.05, 0.25
6017, 0.54347826086957, -0.05, 0.27777777777778
6018, 0.56521739130435, -0.05, 0.30555555555556
6019, 0.54347826086957, -0.05, 0.33333333333333
6020, 0.56521739130435, -0.05, 0.36111111111111
6021, 0.54347826086957, -0.05, 0.38888888888889
6022, 0.56521739130435, -0.05, 0.41666666666667
6023, 0.54347826086957, -0.05, 0.44444444444444
6024, 0.56521739130435, -0.05, 0.47222222222222
6025, 0.60869565217391, -0.05, 0.027777777777778
6026, 0.58695652173913, -0.05, 0.055555555555556
6027, 0.60869565217391, -0.05, 0.083333333333333
6028, 0.58695652173913, -0.05, 0.11111111111111
6029, 0.60869565217391, -0.05, 0.13888888888889
6030, 0.58695652173913, -0.05, 0.16666666666667
6031, 0.60869565217391, -0.05, 0.19444444444444
6032, 0.58695652173913, -0.05, 0.22222222222222
6033, 0.60869565217391, -0.05, 0.25
6034, 0.58695652173913, -0.05, 0.27777777777778
6035, 0.60869565217391, -0.05, 0.30555555555556
6036, 0.58695652173913, -0.05, 0.33333333333333
6037, 0.60869565217391, -0.05, 0.36111111111111
6038, 0.58695652173913, -0.05, 0.38888888888889
6039, 0.60869565217391, -0.05, 0.41666666666667
6040, 0.58695652173913, -0.05, 0.44444444444444
6041, 0.60869565217391, -0.05, 0.47222222222222
6042, 0.65217391304348, -0.05, 0.027777777777778
6043, 0.6304347826087, -0.05, 0.055555555555556
6044, 0.65217391304348, -0.05, 0.083333333333333
6045, 0.6304347826087, -0.05, 0.11111111111111
6046, 0.65217391304348, -0.05, 0.13888888888889
6047, 0.6304347826087, -0.05, 0.16666666666667
6048, 0.65217391304348, -0.05, 0.19444444444444
6049, 0.6304347826087, -0.05, 0.22222222222222
6050, 0.65217391304348, -0.05, 0.25
6051, 0.6304347826087, -0.05, 0.27777777777778
6052, 0.65217391304348, -0.05, 0.30555555555556
6053, 0.6304347826087, -0.05, 0.33333333333333
6054, 0.65217391304348, -0.05, 0.36111111111111
6055, 0.6304347826087, -0.05, 0.38888888888889
6056, 0.65217391304348, -0.05, 0.41666666666667
6057, 0.6304347826087, -0.05, 0.44444444444444
6058, 0.65217391304348, -0.05, 0.47222222222222
6059, 0.69565217391304, -0.05, 0.027777777777778
6060, 0.67391304347826, -0.05, 0.055555555555556
6061, 0.69565217391304, -0.05, 0.083333333333333
6062, 0.67391304347826, -0.05, 0.11111111111111
6063, 0.69565217391304, -0.05, 0.13888888888889
6064, 0.67391304347826, -0.05, 0.16666666666667
6065, 0.69565217391304, -0.05, 0.19444444444444
6066, 0.67391304347826, -0.05, 0.22222222222222
6067, 0.69565217391304, -0.05, 0.25
6068, 0.67391304347826, -0.05, 0.27777777777778
6069, 0.69565217391304, -0.05, 0.30555555555556
6070, 0.67391304347826, -0.05, 0.33333333333333
6071, 0.69565217391304, -0.05, 0.36111111111111
6072, 0.67391304347826, -0.05, 0.38888888888889
6073, 0.69565217391304, -0.05, 0.41666666666667
6074, 0.67391304347826, -0.05, 0.44444444444444
6075, 0.69565217391304, -0.05, 0.47222222222222
6076, 0.73913043478261, -0.05, 0.027777777777778
6077, 0.71739130434783, -0.05, 0.055555555555556
6078, 0.73913043478261, -0.05, 0.083333333333333
6079, 0.71739130434783, -0.05, 0.11111111111111
6080, 0.73913043478261, -0.05, 0.13888888888889
6081, 0.71739130434783, -0.05, 0.16666666666667
6082, 0.73913043478261, -0.05, 0.19444444444444
6083, 0.71739130434783, -0.05, 0.22222222222222
6084, 0.73913043478261, -0.05, 0.25
6085, 0.71739130434783, -0.05, 0.27777777777778
6086, 0.73913043478261, -0.05, 0.30555555555556
6087, 0.71739130434783, -0.05, 0.33333333333333
6088, 0.73913043478261, -0.05, 0.36111111111111
6089, 0.71739130434783, -0.05, 0.38888888888889
6090, 0.73913043478261, -0.05, 0.41666666666667
6091, 0.71739130434783, -0.05, 0.44444444444444
6092, 0.73913043478261, -0.05, 0.47222222222222
6093, 0.78260869565217, -0.05, 0.027777777777778
6094, 0.76086956521739, -0.05, 0.055555555555556
6095, 0.78260869565217, -0.05, 0.083333333333333
6096, 0.76086956521739, -0.05, 0.11111111111111
6097, 0.78260869565217, -0.05, 0.13888888888889
6098, 0.76086956521739, -0.05, 0.16666666666667
6099, 0.78260869565217, -0.05, 0.19444444444444
6100, 0.76086956521739, -0.05, 0.22222222222222
6101, 0.78260869565217, -0.05, 0.25
6102, 0.76086956521739, -0.05, 0.27777777777778
6103, 0.78260869565217, -0.05, 0.30555555555556
6104, 0.76086956521739, -0.05, 0.33333333333333
6105, 0.78260869565217, -0.05, 0.36111111111111
6106, 0.76086956521739, -0.05, 0.38888888888889
6107, 0.78260869565217, -0.05, 0.41666666666667
6108, 0.76086956521739, -0.05, 0.44444444444444
6109, 0.78260869565217, -0.05, 0.47222222222222
6110, 0.82608695652174, -0.05, 0.027777777777778
6111, 0.80434782608696, -0.05, 0.055555555555556
6112, 0.82608695652174, -0.05, 0.083333333333333
6113, 0.80434782608696, -0.05, 0.11111111111111
6114, 0.82608695652174, -0.05, 0.13888888888889
6115, 0.80434782608696, -0.05, 0.16666666666667
6116, 0.82608695652174, -0.05, 0.19444444444444
6117, 0.80434782608696, -0.05, 0.22222222222222
6118, 0.82608695652174, -0.05, 0.25
6119, 0.80434782608696, -0.05, 0.27777777777778
6120, 0.82608695652174, -0.05, 0.30555555555556
6121, 0.80434782608696, -0.05, 0.33333333333333
6122, 0.82608695652174, -0.05, 0.36111111111111
6123, 0.80434782608696, -0.05, 0.38888888888889
6124, 0.82608695652174, -0.05, 0.41666666666667
6125, 0.80434782608696, -0.05, 0.44444444444444
6126, 0.82608695652174, -0.05, 0.47222222222222
6127, 0.8695652173913, -0.05, 0.027777777777778
6128, 0.84782608695652, -0.05, 0.055555555555556
6129, 0.8695652173913, -0.05, 0.083333333333333
6130, 0.84782608695652, -0.05, 0.11111111111111
6131, 0.8695652173913, -0.05, 0.13888888888889
6132, 0.84782608695652, -0.05, 0.16666666666667
6133, 0.8695652173913, -0.05, 0.19444444444444
6134, 0.84782608695652, -0.05, 0.22222222222222
6135, 0.8695652173913, -0.05, 0.25
6136, 0.84782608695652, -0.05, 0.27777777777778
6137, 0.8695652173913, -0.05, 0.30555555555556
6138, 0.84782608695652, -0.05, 0.33333333333333
6139, 0.8695652173913, -0.05, 0.36111111111111
6140, 0.84782608695652, -0.05, 0.38888888888889
6141, 0.8695652173913, -0.05, 0.41666666666667
6142, 0.84782608695652, -0.05, 0.44444444444444
6143, 0.8695652173913, -0.05, 0.47222222222222
6144, 0.91304347826087, -0.05, 0.027777777777778
6145, 0.89130434782609, -0.05, 0.055555555555556
6146, 0.91304347826087, -0.05, 0.083333333333333
6147, 0.89130434782609, -0.05, 0.11111111111111
6148, 0.91304347826087, -0.05, 0.13888888888889
6149, 0.89130434782609, -0.05, 0.16666666666667
6150, 0.91304347826087, -0.05, 0.19444444444444
6151, 0.89130434782609, -0.05, 0.22222222222222
6152, 0.91304347826087, -0.05, 0.25
6153, 0.89130434782609, -0.05, 0.27777777777778
6154, 0.91304347826087, -0.05, 0.30555555555556
6155, 0.89130434782609, -0.05, 0.33333333333333
6156, 0.91304347826087, -0.05, 0.36111111111111
6157, 0.89130434782609, -0.05, 0.38888888888889
6158, 0.91304347826087, -0.05, 0.41666666666667
6159, 0.89130434782609, -0.05, 0.44444444444444
6160, 0.91304347826087, -0.05, 0.47222222222222
6161, 0.95652173913043, -0.05, 0.027777777777778
6162, 0.93478260869565, -0.05, 0.055555555555556
6163, 0.95652173913043, -0.05, 0.083333333333333
6164, 0.93478260869565, -0.05, 0.11111111111111
6165, 0.95652173913043, -0.05, 0.13888888888889
6166, 0.93478260869565, -0.05, 0.16666666666667
6167, 0.95652173913043, -0.05, 0.19444444444444
6168, 0.93478260869565, -0.05, 0.22222222222222
6169, 0.95652173913043, -0.05, 0.25
6170, 0.93478260869565, -0.05, 0.27777777777778
6171, 0.95652173913043, -0.05, 0.30555555555556
6172, 0.93478260869565, -0.05, 0.33333333333333
6173, 0.95652173913043, -0.05, 0.36111111111111
6174, 0.93478260869565, -0.05, 0.38888888888889
6175, 0.95652173913043, -0.05, 0.41666666666667
6176, 0.93478260869565, -0.05, 0.44444444444444
6177, 0.95652173913043, -0.05, 0.47222222222222
6178, 0.97826086956522, -0.05, 0.055555555555556
6179, 0.97826086956522, -0.05, 0.11111111111111
6180, 0.97826086956522, -0.05, 0.16666666666667
6181, 0.97826086956522, -0.05, 0.22222222222222
6182, 0.97826086956522, -0.05, 0.27777777777778
6183, 0.97826086956522, -0.05, 0.33333333333333
6184, 0.97826086956522, -0.05, 0.38888888888889
6185, 0.97826086956522, -0.05, 0.44444444444444
6186, 0.043478260869565, 0.05, 0.055555555555556
6187, 0.043478260869565, 0.05, 0.11111111111111
6188, 0.043478260869565, 0.05, 0.16666666666667
6189, 0.043478260869565, 0.05, 0.22222222222222
6190, 0.043478260869565, 0.05, 0.27777777777778
6191, 0.043478260869565, 0.05, 0.33333333333333
6192, 0.043478260869565, 0.05, 0.38888888888889
6193, 0.043478260869565, 0.05, 0.44444444444444
6194, 0.08695652173913, 0.05, 0.055555555555556
6195, 0.08695652173913, 0.05, 0.11111111111111
6196, 0.08695652173913, 0.05, 0.16666666666667
6197, 0.08695652173913, 0.05, 0.22222222222222
6198, 0.08695652173913, 0.05, 0.27777777777778
6199, 0.08695652173913, 0.05, 0.33333333333333
6200, 0.08695652173913, 0.05, 0.38888888888889
6201, 0.08695652173913, 0.05, 0.44444444444444
6202, 0.1304347826087, 0.05, 0.055555555555556
6203, 0.1304347826087, 0.05, 0.11111111111111
6204, 0.1304347826087, 0.05, 0.16666666666667
6205, 0.1304347826087, 0.05, 0.22222222222222
6206, 0.1304347826087, 0.05, 0.27777777777778
6207, 0.1304347826087, 0.05, 0.33333333333333
6208, 0.1304347826087, 0.05, 0.38888888888889
6209, 0.1304347826087, 0.05, 0.44444444444444
6210, 0.17391304347826, 0.05, 0.055555555555556
6211, 0.17391304347826, 0.05, 0.11111111111111
6212, 0.17391304347826, 0.05, 0.16666666666667
6213, 0.17391304347826, 0.05, 0.22222222222222
6214, 0.17391304347826, 0.05, 0.27777777777778
6215, 0.17391304347826, 0.05, 0.33333333333333
6216, 0.17391304347826, 0.05, 0.38888888888889
6217, 0.17391304347826, 0.05, 0.44444444444444
6218, 0.21739130434783, 0.05, 0.055555555555556
6219, 0.21739130434783, 0.05, 0.11111111111111
6220, 0.21739130434783, 0.05, 0.16666666666667
6221, 0.21739130434783, 0.05, 0.22222222222222
6222, 0.21739130434783, 0.05, 0.27777777777778
6223, 0.21739130434783, 0.05, 0.33333333333333
6224, 0.21739130434783, 0.05, 0.38888888888889
6225, 0.21739130434783, 0.05, 0.44444444444444
6226, 0.26086956521739, 0.05, 0.055555555555556
6227, 0.26086956521739, 0.05, 0.11111111111111
6228, 0.26086956521739, 0.05, 0.16666666666667
6229, 0.26086956521739, 0.05, 0.22222222222222
6230, 0.26086956521739, 0.05, 0.27777777777778
6231, 0.26086956521739, 0.05, 0.33333333333333
6232, 0.26086956521739, 0.05, 0.38888888888889
6233, 0.26086956521739, 0.05, 0.44444444444444
6234, 0.30434782608696, 0.05, 0.055555555555556
6235, 0.30434782608696, 0.05, 0.11111111111111
6236, 0.30434782608696, 0.05, 0.16666666666667
6237, 0.30434782608696, 0.05, 0.22222222222222
6238, 0.30434782608696, 0.05, 0.27777777777778
6239, 0.30434782608696, 0.05, 0.33333333333333
6240, 0.30434782608696, 0.05, 0.38888888888889
6241, 0.30434782608696, 0.05, 0.44444444444444
6242, 0.34782608695652, 0.05, 0.055555555555556
6243, 0.34782608695652, 0.05, 0.11111111111111
6244, 0.34782608695652, 0.05, 0.16666666666667
6245, 0.34782608695652, 0.05, 0.22222222222222
6246, 0.34782608695652, 0.05, 0.27777777777778
6247, 0.34782608695652, 0.05, 0.33333333333333
6248, 0.34782608695652, 0.05, 0.38888888888889
6249, 0.34782608695652, 0.05, 0.44444444444444
6250, 0.39130434782609, 0.05, 0.055555555555556
6251, 0.39130434782609, 0.05, 0.11111111111111
6252, 0.39130434782609, 0.05, 0.16666666666667
6253, 0.39130434782609, 0.05, 0.22222222222222
6254, 0.39130434782609, 0.05, 0.27777777777778
6255, 0.39130434782609, 0.05, 0.33333333333333
6256, 0.39130434782609, 0.05, 0.38888888888889
6257, 0.39130434782609, 0.05, 0.44444444444444
6258, 0.43478260869565, 0.05, 0.055555555555556
6259, 0.43478260869565, 0.05, 0.11111111111111
6260, 0.43478260869565, 0.05, 0.16666666666667
6261, 0.43478260869565, 0.05, 0.22222222222222
6262, 0.43478260869565, 0.05, 0.27777777777778
6263, 0.43478260869565, 0.05, 0.33333333333333
6264, 0.43478260869565, 0.05, 0.38888888888889
6265, 0.43478260869565, 0.05, 0.44444444444444
6266, 0.47826086956522, 0.05, 0.055555555555556
6267, 0.47826086956522, 0.05, 0.11111111111111
6268, 0.47826086956522, 0.05, 0.16666666666667
6269, 0.47826086956522, 0.05, 0.22222222222222
6270, 0.47826086956522, 0.05, 0.27777777777778
6271, 0.47826086956522, 0.05, 0.33333333333333
6272, 0.47826086956522, 0.05, 0.38888888888889
6273, 0.47826086956522, 0.05, 0.44444444444444
6274, 0.52173913043478, 0.05, 0.055555555555556
6275, 0.52173913043478, 0.05, 0.11111111111111
6276, 0.52173913043478, 0.05, 0.16666666666667
6277, 0.52173913043478, 0.05, 0.22222222222222
6278, 0.52173913043478, 0.05, 0.27777777777778
6279, 0.52173913043478, 0.05, 0.33333333333333
6280, 0.52173913043478, 0.05, 0.38888888888889
6281, 0.52173913043478, 0.05, 0.44444444444444
6282, 0.56521739130435, 0.05, 0.055555555555556
6283, 0.56521739130435, 0.05, 0.11111111111111
6284, 0.56521739130435, 0.05, 0.16666666666667
6285, 0.56521739130435, 0.05, 0.22222222222222
6286, 0.56521739130435, 0.05, 0.27777777777778
6287, 0.56521739130435, 0.05, 0.33333333333333
6288, 0.56521739130435, 0.05, 0.38888888888889
6289, 0.56521739130435, 0.05, 0.44444444444444
6290, 0.60869565217391, 0.05, 0.055555555555556
6291, 0.60869565217391, 0.05, 0.11111111111111
6292, 0.60869565217391, 0.05, 0.16666666666667
6293, 0.60869565217391, 0.05, 0.22222222222222
6294, 0.60869565217391, 0.05, 0.27777777777778
6295, 0.60869565217391, 0.05, 0.33333333333333
6296, 0.60869565217391, 0.05, 0.38888888888889
6297, 0.60869565217391, 0.05, 0.44444444444444
6298, 0.65217391304348, 0.05, 0.055555555555556
6299, 0.65217391304348, 0.05, 0.11111111111111
6300, 0.65217391304348, 0.05, 0.16666666666667
6301, 0.65217391304348, 0.05, 0.22222222222222
6302, 0.65217391304348, 0.05, 0.27777777777778
6303, 0.65217391304348, 0.05, 0.33333333333333
6304, 0.65217391304348, 0.05, 0.38888888888889
6305, 0.65217391304348, 0.05, 0.44444444444444
6306, 0.69565217391304, 0.05, 0.055555555555556
6307, 0.69565217391304, 0.05, 0.11111111111111
6308, 0.69565217391304, 0.05, 0.16666666666667
6309, 0.69565217391304, 0.05, 0.22222222222222
6310, 0.69565217391304, 0.05, 0.27777777777778
6311, 0.69565217391304, 0.05, 0.33333333333333
6312, 0.69565217391304, 0.05, 0.38888888888889
6313, 0.69565217391304, 0.05, 0.44444444444444
6314, 0.73913043478261, 0.05, 0.055555555555556
6315, 0.73913043478261, 0.05, 0.11111111111111
6316, 0.73913043478261, 0.05, 0.16666666666667
6317, 0.73913043478261, 0.05, 0.22222222222222
6318, 0.73913043478261, 0.05, 0.27777777777778
6319, 0.73913043478261, 0.05, 0.33333333333333
6320, 0.73913043478261, 0.05, 0.38888888888889
6321, 0.73913043478261, 0.05, 0.44444444444444
6322, 0.78260869565217, 0.05, 0.055555555555556
6323, 0.78260869565217, 0.05, 0.11111111111111
6324, 0.78260869565217, 0.05, 0.16666666666667
6325, 0.78260869565217, 0.05, 0.22222222222222
6326, 0.78260869565217, 0.05, 0.27777777777778
6327, 0.78260869565217, 0.05, 0.33333333333333
6328, 0.78260869565217, 0.05, 0.38888888888889
6329, 0.78260869565217, 0.05, 0.44444444444444
6330, 0.82608695652174, 0.05, 0.055555555555556
6331, 0.82608695652174, 0.05, 0.11111111111111
6332, 0.82608695652174, 0.05, 0.16666666666667
6333, 0.82608695652174, 0.05, 0.22222222222222
6334, 0.82608695652174, 0.05, 0.27777777777778
6335, 0.82608695652174, 0.05, 0.33333333333333
6336, 0.82608695652174, 0.05, 0.38888888888889
6337, 0.82608695652174, 0.05, 0.44444444444444
6338, 0.8695652173913, 0.05, 0.055555555555556
6339, 0.8695652173913, 0.05, 0.11111111111111
6340, 0.8695652173913, 0.05, 0.16666666666667
6341, 0.8695652173913, 0.05, 0.22222222222222
6342, 0.8695652173913, 0.05, 0.27777777777778
6343, 0.8695652173913, 0.05, 0.33333333333333
6344, 0.8695652173913, 0.05, 0.38888888888889
6345, 0.8695652173913, 0.05, 0.44444444444444
6346, 0.91304347826087, 0.05, 0.055555555555556
6347, 0.91304347826087, 0.05, 0.11111111111111
6348, 0.91304347826087, 0.05, 0.16666666666667
6349, 0.91304347826087, 0.05, 0.22222222222222
6350, 0.91304347826087, 0.05, 0.27777777777778
6351, 0.91304347826087, 0.05, 0.33333333333333
6352, 0.91304347826087, 0.05, 0.38888888888889
6353, 0.91304347826087, 0.05, 0.44444444444444
6354, 0.95652173913043, 0.05, 0.055555555555556
6355, 0.95652173913043, 0.05, 0.11111111111111
6356, 0.95652173913043, 0.05, 0.16666666666667
6357, 0.95652173913043, 0.05, 0.22222222222222
6358, 0.95652173913043, 0.05, 0.27777777777778
6359, 0.95652173913043, 0.05, 0.33333333333333
6360, 0.95652173913043, 0.05, 0.38888888888889
6361, 0.95652173913043, 0.05, 0.44444444444444
6362, 0.021739130434783, 0.05, 0.055555555555556
6363, 0.043478260869565, 0.05, 0.027777777777778
6364, 0.021739130434783, 0.05, 0.11111111111111
6365, 0.043478260869565, 0.05, 0.083333333333333
6366, 0.021739130434783, 0.05, 0.16666666666667
6367, 0.043478260869565, 0.05, 0.13888888888889
6368, 0.021739130434783, 0.05, 0.22222222222222
6369, 0.043478260869565, 0.05, 0.19444444444444
6370, 0.021739130434783, 0.05, 0.27777777777778
6371, 0.043478260869565, 0.05, 0.25
6372, 0.021739130434783, 0.05, 0.33333333333333
6373, 0.043478260869565, 0.05, 0.30555555555556
6374, 0.021739130434783, 0.05, 0.38888888888889
6375, 0.043478260869565, 0.05, 0.36111111111111
6376, 0.021739130434783, 0.05, 0.44444444444444
6377, 0.043478260869565, 0.05, 0.41666666666667
6378, 0.043478260869565, 0.05, 0.47222222222222
6379, 0.065217391304348, 0.05, 0.055555555555556
6380, 0.08695652173913, 0.05, 0.027777777777778
6381, 0.065217391304348, 0.05, 0.11111111111111
6382, 0.08695652173913, 0.05, 0.083333333333333
6383, 0.065217391304348, 0.05, 0.16666666666667
6384, 0.08695652173913, 0.05, 0.13888888888889
6385, 0.065217391304348, 0.05, 0.22222222222222
6386, 0.08695652173913, 0.05, 0.19444444444444
6387, 0.065217391304348, 0.05, 0.27777777777778
6388, 0.08695652173913, 0.05, 0.25
6389, 0.065217391304348, 0.05, 0.33333333333333
6390, 0.08695652173913, 0.05, 0.30555555555556
6391, 0.065217391304348, 0.05, 0.38888888888889
6392, 0.08695652173913, 0.05, 0.36111111111111
6393, 0.065217391304348, 0.05, 0.44444444444444
6394, 0.08695652173913, 0.05, 0.41666666666667
6395, 0.08695652173913, 0.05, 0.47222222222222
6396, 0.10869565217391, 0.05, 0.055555555555556
6397, 0.1304347826087, 0.05, 0.027777777777778
6398, 0.10869565217391, 0.05, 0.11111111111111
6399, 0.1304347826087, 0.05, 0.083333333333333
6400, 0.10869565217391, 0.05, 0.16666666666667
6401, 0.1304347826087, 0.05, 0.13888888888889
6402, 0.10869565217391, 0.05, 0.22222222222222
6403, 0.1304347826087, 0.05, 0.19444444444444
6404, 0.10869565217391, 0.05, 0.27777777777778
6405, 0.1304347826087, 0.05, 0.25
6406, 0.10869565217391, 0.05, 0.33333333333333
6407, 0.1304347826087, 0.05, 0.30555555555556
6408, 0.10869565217391, 0.05, 0.38888888888889
6409, 0.1304347826087, 0.05, 0.36111111111111
6410, 0.10869565217391, 0.05, 0.44444444444444
6411, 0.1304347826087, 0.05, 0.41666666666667
6412, 0.1304347826087, 0.05, 0.47222222222222
6413, 0.15217391304348, 0.05, 0.055555555555556
6414, 0.17391304347826, 0.05, 0.027777777777778
6415, 0.15217391304348, 0.05, 0.11111111111111
6416, 0.17391304347826, 0.05, 0.083333333333333
6417, 0.15217391304348, 0.05, 0.16666666666667
6418, 0.17391304347826, 0.05, 0.13888888888889
6419, 0.15217391304348, 0.05, 0.22222222222222
6420, 0.17391304347826, 0.05, 0.19444444444444
6421, 0.15217391304348, 0.05, 0.27777777777778
6422, 0.17391304347826, 0.05, 0.25
6423, 0.15217391304348, 0.05, 0.33333333333333
6424, 0.17391304347826, 0.05, 0.30555555555556
6425, 0.15217391304348, 0.05, 0.38888888888889
6426, 0.17391304347826, 0.05, 0.36111111111111
6427, 0.15217391304348, 0.05, 0.44444444444444
6428, 0.17391304347826, 0.05, 0.41666666666667
6429, 0.17391304347826, 0.05, 0.47222222222222
6430, 0.19565217391304, 0.05, 0.055555555555556
6431, 0.21739130434783, 0.05, 0.027777777777778
6432, 0.19565217391304, 0.05, 0.11111111111111
6433, 0.21739130434783, 0.05, 0.083333333333333
6434, 0.19565217391304, 0.05, 0.16666666666667
6435, 0.21739130434783, 0.05, 0.13888888888889
6436, 0.19565217391304, 0.05, 0.22222222222222
6437, 0.21739130434783, 0.05, 0.19444444444444
6438, 0.19565217391304, 0.05, 0.27777777777778
6439, 0.21739130434783, 0.05, 0.25
6440, 0.19565217391304, 0.05, 0.33333333333333
6441, 0.21739130434783, 0.05, 0.30555555555556
6442, 0.19565217391304, 0.05, 0.38888888888889
6443, 0.21739130434783, 0.05, 0.36111111111111
6444, 0.19565217391304, 0.05, 0.44444444444444
6445, 0.21739130434783, 0.05, 0.41666666666667
6446, 0.21739130434783, 0.05, 0.47222222222222
6447, 0.23913043478261, 0.05, 0.055555555555556
6448, 0.26086956521739, 0.05, 0.027777777777778
6449, 0.23913043478261, 0.05, 0.11111111111111
6450, 0.26086956521739, 0.05, 0.083333333333333
6451, 0.23913043478261, 0.05, 0.16666666666667
6452, 0.26086956521739, 0.05, 0.13888888888889
6453, 0.23913043478261, 0.05, 0.22222222222222
6454, 0.26086956521739, 0.05, 0.19444444444444
6455, 0.23913043478261, 0.05, 0.27777777777778
6456, 0.26086956521739, 0.05, 0.25
6457, 0.23913043478261, 0.05, 0.33333333333333
6458, 0.26086956521739, 0.05, 0.30555555555556
6459, 0.23913043478261, 0.05, 0.38888888888889
6460, 0.26086956521739, 0.05, 0.36111111111111
6461, 0.23913043478261, 0.05, 0.44444444444444
6462, 0.26086956521739, 0.05, 0.41666666666667
6463, 0.26086956521739, 0.05, 0.47222222222222
6464, 0.28260869565217, 0.05, 0.055555555555556
6465, 0.30434782608696, 0.05, 0.027777777777778
6466, 0.28260869565217, 0.05, 0.11111111111111
6467, 0.30434782608696, 0.05, 0.083333333333333
6468, 0.28260869565217, 0.05, 0.16666666666667
6469, 0.30434782608696, 0.05, 0.13888888888889
6470, 0.28260869565217, 0.05, 0.22222222222222
6471, 0.30434782608696, 0.05, 0.19444444444444
6472, 0.28260869565217, 0.05, 0.27777777777778
6473, 0.30434782608696, 0.05, 0.25
6474, 0.28260869565217, 0.05, 0.33333333333333
6475, 0.30434782608696, 0.05, 0.30555555555556
6476, 0.28260869565217, 0.05, 0.38888888888889
6477, 0.30434782608696, 0.05, 0.36111111111111
6478, 0.28260869565217, 0.05, 0.44444444444444
6479, 0.30434782608696, 0.05, 0.41666666666667
6480, 0.30434782608696, 0.05, 0.47222222222222
6481, 0.32608695652174, 0.05, 0.055555555555556
6482, 0.34782608695652, 0.05, 0.027777777777778
6483, 0.32608695652174, 0.05, 0.11111111111111
6484, 0.34782608695652, 0.05, 0.083333333333333
6485, 0.32608695652174, 0.05, 0.16666666666667
6486, 0.34782608695652, 0.05, 0.13888888888889
6487, 0.32608695652174, 0.05, 0.22222222222222
6488, 0.34782608695652, 0.05, 0.19444444444444
6489, 0.32608695652174, 0.05, 0.27777777777778
6490, 0.34782608695652, 0.05, 0.25
6491, 0.32608695652174, 0.05, 0.33333333333333
6492, 0.34782608695652, 0.05, 0.30555555555556
6493, 0.32608695652174, 0.05, 0.38888888888889
6494, 0.34782608695652, 0.05, 0.36111111111111
6495, 0.32608695652174, 0.05, 0.44444444444444
6496, 0.34782608695652, 0.05, 0.41666666666667
6497, 0.34782608695652, 0.05, 0.47222222222222
6498, 0.3695652173913, 0.05, 0.055555555555556
6499, 0.39130434782609, 0.05, 0.027777777777778
6500, 0.3695652173913, 0.05, 0.11111111111111
6501, 0.39130434782609, 0.05, 0.083333333333333
6502, 0.3695652173913, 0.05, 0.16666666666667
6503, 0.39130434782609, 0.05, 0.13888888888889
6504, 0.3695652173913, 0.05, 0.22222222222222
6505, 0.39130434782609, 0.05, 0.19444444444444
6506, 0.3695652173913, 0.05, 0.27777777777778
6507, 0.39130434782609, 0.05, 0.25
6508, 0.3695652173913, 0.05, 0.33333333333333
6509, 0.39130434782609, 0.05, 0.30555555555556
6510, 0.3695652173913, 0.05, 0.38888888888889
6511, 0.39130434782609, 0.05, 0.36111111111111
6512, 0.3695652173913, 0.05, 0.44444444444444
6513, 0.39130434782609, 0.05, 0.41666666666667
6514, 0.39130434782609, 0.05, 0.47222222222222
6515, 0.41304347826087, 0.05, 0.055555555555556
6516, 0.43478260869565, 0.05, 0.027777777777778
6517, 0.41304347826087, 0.05, 0.11111111111111
6518, 0.43478260869565, 0.05, 0.083333333333333
6519, 0.41304347826087, 0.05, 0.16666666666667
6520, 0.43478260869565, 0.05, 0.13888888888889
6521, 0.41304347826087, 0.05, 0.22222222222222
6522, 0.43478260869565, 0.05, 0.19444444444444
6523, 0.41304347826087, 0.05, 0.27777777777778
6524, 0.43478260869565, 0.05, 0.25
6525, 0.41304347826087, 0.05, 0.33333333333333
6526, 0.43478260869565, 0.05, 0.30555555555556
6527, 0.41304347826087, 0.05, 0.38888888888889
6528, 0.43478260869565, 0.05, 0.36111111111111
6529, 0.41304347826087, 0.05, 0.44444444444444
6530, 0.43478260869565, 0.05, 0.41666666666667
6531, 0.43478260869565, 0.05, 0.47222222222222
6532, 0.45652173913043, 0.05, 0.055555555555556
6533, 0.47826086956522, 0.05, 0.027777777777778
6534, 0.45652173913043, 0.05, 0.11111111111111
6535, 0.47826086956522, 0.05, 0.083333333333333
6536, 0.45652173913043, 0.05, 0.16666666666667
6537, 0.47826086956522, 0.05, 0.13888888888889
6538, 0.45652173913043, 0.05, 0.22222222222222
6539, 0.47826086956522, 0.05, 0.19444444444444
6540, 0.45652173913043, 0.05, 0.27777777777778
6541, 0.47826086956522, 0.05, 0.25
6542, 0.45652173913043, 0.05, 0.33333333333333
6543, 0.47826086956522, 0.05, 0.30555555555556
6544, 0.45652173913043, 0.05, 0.38888888888889
6545, 0.47826086956522, 0.05, 0.36111111111111
6546, 0.45652173913043, 0.05, 0.44444444444444
6547, 0.47826086956522, 0.05, 0.41666666666667
6548, 0.47826086956522, 0.05, 0.47222222222222
6549, 0.5, 0.05, 0.055555555555556
6550, 0.52173913043478, 0.05, 0.027777777777778
6551, 0.5, 0.05, 0.11111111111111
6552, 0.52173913043478, 0.05, 0.083333333333333
6553, 0.5, 0.05, 0.16666666666667
6554, 0.52173913043478, 0.05, 0.13888888888889
6555, 0.5, 0.05, 0.22222222222222
6556, 0.52173913043478, 0.05, 0.19444444444444
6557, 0.5, 0.05, 0.27777777777778
6558, 0.52173913043478, 0.05, 0.25
6559, 0.5, 0.05, 0.33333333333333
6560, 0.52173913043478, 0.05, 0.30555555555556
6561, 0.5, 0.05, 0.38888888888889
6562, 0.52173913043478, 0.05, 0.36111111111111
6563, 0.5, 0.05, 0.44444444444444
6564, 0.52173913043478, 0.05, 0.41666666666667
6565, 0.52173913043478, 0.05, 0.47222222222222
6566, 0.54347826086957, 0.05, 0.055555555555556
6567, 0.56521739130435, 0.05, 0.027777777777778
6568, 0.54347826086957, 0.05, 0.11111111111111
6569, 0.56521739130435, 0.05, 0.083333333333333
6570, 0.54347826086957, 0.05, 0.16666666666667
6571, 0.56521739130435, 0.05, 0.13888888888889
6572, 0.54347826086957, 0.05, 0.22222222222222
6573, 0.56521739130435, 0.05, 0.19444444444444
6574, 0.54347826086957, 0.05, 0.27777777777778
6575, 0.56521739130435, 0.05, 0.25
6576, 0.54347826086957, 0.05, 0.33333333333333
6577, 0.56521739130435, 0.05, 0.30555555555556
6578, 0.54347826086957, 0.05, 0.38888888888889
6579, 0.56521739130435, 0.05, 0.36111111111111
6580, 0.54347826086957, 0.05, 0.44444444444444
6581, 0.56521739130435, 0.05, 0.41666666666667
6582, 0.56521739130435, 0.05, 0.47222222222222
6583, 0.58695652173913, 0.05, 0.055555555555556
6584, 0.60869565217391, 0.05, 0.027777777777778
6585, 0.58695652173913, 0.05, 0.11111111111111
6586, 0.60869565217391, 0.05, 0.083333333333333
6587, 0.58695652173913, 0.05, 0.16666666666667
6588, 0.60869565217391, 0.05, 0.13888888888889
6589, 0.58695652173913, 0.05, 0.22222222222222
6590, 0.60869565217391, 0.05, 0.19444444444444
6591, 0.58695652173913, 0.05, 0.27777777777778
6592, 0.60869565217391, 0.05, 0.25
6593, 0.58695652173913, 0.05, 0.33333333333333
6594, 0.60869565217391, 0.05, 0.30555555555556
6595, 0.58695652173913, 0.05, 0.38888888888889
6596, 0.60869565217391, 0.05, 0.36111111111111
6597, 0.58695652173913, 0.05, 0.44444444444444
6598, 0.60869565217391, 0.05, 0.41666666666667
6599, 0.60869565217391, 0.05, 0.47222222222222
6600, 0.6304347826087, 0.05, 0.055555555555556
6601, 0.65217391304348, 0.05, 0.027777777777778
6602, 0.6304347826087, 0.05, 0.11111111111111
6603, 0.65217391304348, 0.05, 0.083333333333333
6604, 0.6304347826087, 0.05, 0.16666666666667
6605, 0.65217391304348, 0.05, 0.13888888888889
6606, 0.6304347826087, 0.05, 0.22222222222222
6607, 0.65217391304348, 0.05, 0.19444444444444
6608, 0.6304347826087, 0.05, 0.27777777777778
6609, 0.65217391304348, 0.05, 0.25
6610, 0.6304347826087, 0.05, 0.33333333333333
6611, 0.65217391304348, 0.05, 0.30555555555556
6612, 0.6304347826087, 0.05, 0.38888888888889
6613, 0.65217391304348, 0.05, 0.36111111111111
6614, 0.6304347826087, 0.05, 0.44444444444444
6615, 0.65217391304348, 0.05, 0.41666666666667
6616, 0.65217391304348, 0.05, 0.47222222222222
6617, 0.67391304347826, 0.05, 0.055555555555556
6618, 0.69565217391304, 0.05, 0.027777777777778
6619, 0.67391304347826, 0.05, 0.11111111111111
6620, 0.69565217391304, 0.05, 0.083333333333333
6621, 0.67391304347826, 0.05, 0.16666666666667
6622, 0.69565217391304, 0.05, 0.13888888888889
6623, 0.67391304347826, 0.05, 0.22222222222222
6624, 0.69565217391304, 0.05, 0.19444444444444
6625, 0.67391304347826, 0.05, 0.27777777777778
6626, 0.69565217391304, 0.05, 0.25
6627, 0.67391304347826, 0.05, 0.33333333333333
6628, 0.69565217391304, 0.05, 0.30555555555556
6629, 0.67391304347826, 0.05, 0.38888888888889
6630, 0.69565217391304, 0.05, 0.36111111111111
6631, 0.67391304347826, 0.05, 0.44444444444444
6632, 0.69565217391304, 0.05, 0.41666666666667
6633, 0.69565217391304, 0.05, 0.47222222222222
6634, 0.71739130434783, 0.05, 0.055555555555556
6635, 0.73913043478261, 0.05, 0.027777777777778
6636, 0.71739130434783, 0.05, 0.11111111111111
6637, 0.73913043478261, 0.05, 0.083333333333333
6638, 0.71739130434783, 0.05, 0.16666666666667
6639, 0.73913043478261, 0.05, 0.13888888888889
6640, 0.71739130434783, 0.05, 0.22222222222222
6641, 0.73913043478261, 0.05, 0.19444444444444
6642, 0.71739130434783, 0.05, 0.27777777777778
6643, 0.73913043478261, 0.05, 0.25
6644, 0.71739130434783, 0.05, 0.33333333333333
6645, 0.73913043478261, 0.05, 0.30555555555556
6646, 0.71739130434783, 0.05, 0.38888888888889
6647, 0.73913043478261, 0.05, 0.36111111111111
6648, 0.71739130434783, 0.05, 0.44444444444444
6649, 0.73913043478261, 0.05, 0.41666666666667
6650, 0.73913043478261, 0.05, 0.47222222222222
6651, 0.76086956521739, 0.05, 0.055555555555556
6652, 0.78260869565217, 0.05, 0.027777777777778
6653, 0.76086956521739, 0.05, 0.11111111111111
6654, 0.78260869565217, 0.05, 0.083333333333333
6655, 0.76086956521739, 0.05, 0.16666666666667
6656, 0.78260869565217, 0.05, 0.13888888888889
6657, 0.76086956521739, 0.05, 0.22222222222222
6658, 0.78260869565217, 0.05, 0.19444444444444
6659, 0.76086956521739, 0.05, 0.27777777777778
6660, 0.78260869565217, 0.05, 0.25
6661, 0.76086956521739, 0.05, 0.33333333333333
6662, 0.78260869565217, 0.05, 0.30555555555556
6663, 0.76086956521739, 0.05, 0.38888888888889
6664, 0.78260869565217, 0.05, 0.36111111111111
6665, 0.76086956521739, 0.05, 0.44444444444444
6666, 0.78260869565217, 0.05, 0.41666666666667
6667, 0.78260869565217, 0.05, 0.47222222222222
6668, 0.80434782608696, 0.05, 0.055555555555556
6669, 0.82608695652174, 0.05, 0.027777777777778
6670, 0.80434782608696, 0.05, 0.11111111111111
6671, 0.82608695652174, 0.05, 0.083333333333333
6672, 0.80434782608696, 0.05, 0.16666666666667
6673, 0.82608695652174, 0.05, 0.13888888888889
6674, 0.80434782608696, 0.05, 0.22222222222222
6675, 0.82608695652174, 0.05, 0.19444444444444
6676, 0.80434782608696, 0.05, 0.27777777777778
6677, 0.82608695652174, 0.05, 0.25
6678, 0.80434782608696, 0.05, 0.33333333333333
6679, 0.82608695652174, 0.05, 0.30555555555556
6680, 0.80434782608696, 0.05, 0.38888888888889
6681, 0.82608695652174, 0.05, 0.36111111111111
6682, 0.80434782608696, 0.05, 0.44444444444444
6683, 0.82608695652174, 0.05, 0.41666666666667
6684, 0.82608695652174, 0.05, 0.47222222222222
6685, 0.84782608695652, 0.05, 0.055555555555556
6686, 0.8695652173913, 0.05, 0.027777777777778
6687, 0.84782608695652, 0.05, 0.11111111111111
6688, 0.8695652173913, 0.05, 0.083333333333333
6689, 0.84782608695652, 0.05, 0.16666666666667
6690, 0.8695652173913, 0.05, 0.13888888888889
6691, 0.84782608695652, 0.05, 0.22222222222222
6692, 0.8695652173913, 0.05, 0.19444444444444
6693, 0.84782608695652, 0.05, 0.27777777777778
6694, 0.8695652173913, 0.05, 0.25
6695, 0.84782608695652, 0.05, 0.33333333333333
6696, 0.8695652173913, 0.05, 0.30555555555556
6697, 0.84782608695652, 0.05, 0.38888888888889
6698, 0.8695652173913, 0.05, 0.36111111111111
6699, 0.84782608695652, 0.05, 0.44444444444444
6700, 0.8695652173913, 0.05, 0.41666666666667
6701, 0.8695652173913, 0.05, 0.47222222222222
6702, 0.89130434782609, 0.05, 0.055555555555556
6703, 0.91304347826087, 0.05, 0.027777777777778
6704, 0.89130434782609, 0.05, 0.11111111111111
6705, 0.91304347826087, 0.05, 0.083333333333333
6706, 0.89130434782609, 0.05, 0.16666666666667
6707, 0.91304347826087, 0.05, 0.13888888888889
6708, 0.89130434782609, 0.05, 0.22222222222222
6709, 0.91304347826087, 0.05, 0.19444444444444
6710, 0.89130434782609, 0.05, 0.27777777777778
6711, 0.91304347826087, 0.05, 0.25
6712, 0.89130434782609, 0.05, 0.33333333333333
6713, 0.91304347826087, 0.05, 0.30555555555556
6714, 0.89130434782609, 0.05, 0.38888888888889
6715, 0.91304347826087, 0.05, 0.36111111111111
6716, 0.89130434782609, 0.05, 0.44444444444444
6717, 0.91304347826087, 0.05, 0.41666666666667
6718, 0.91304347826087, 0.05, 0.47222222222222
6719, 0.93478260869565, 0.05, 0.055555555555556
6720, 0.95652173913043, 0.05, 0.027777777777778
6721, 0.93478260869565, 0.05, 0.11111111111111
6722, 0.95652173913043, 0.05, 0.083333333333333
6723, 0.93478260869565, 0.05, 0.16666666666667
6724, 0.95652173913043, 0.05, 0.13888888888889
6725, 0.93478260869565, 0.05, 0.22222222222222
6726, 0.95652173913043, 0.05, 0.19444444444444
6727, 0.93478260869565, 0.05, 0.27777777777778
6728, 0.95652173913043, 0.05, 0.25
6729, 0.93478260869565, 0.05, 0.33333333333333
6730, 0.95652173913043, 0.05, 0.30555555555556
6731, 0.93478260869565, 0.05, 0.38888888888889
6732, 0.95652173913043, 0.05, 0.36111111111111
6733, 0.93478260869565, 0.05, 0.44444444444444
6734, 0.95652173913043, 0.05, 0.41666666666667
6735, 0.95652173913043, 0.05, 0.47222222222222
6736, 0.97826086956522, 0.05, 0.055555555555556
6737, 0.97826086956522, 0.05, 0.11111111111111
6738, 0.97826086956522, 0.05, 0.16666666666667
6739, 0.97826086956522, 0.05, 0.22222222222222
6740, 0.97826086956522, 0.05, 0.27777777777778
6741, 0.97826086956522, 0.05, 0.33333333333333
6742, 0.97826086956522, 0.05, 0.38888888888889
6743, 0.97826086956522, 0.05, 0.44444444444444
6744, 0.043478260869565, -0.016666666666667, 0
6745, 0.08695652173913, -0.016666666666667, 0
6746, 0.1304347826087, -0.016666666666667, 0
6747, 0.17391304347826, -0.016666666666667, 0
6748, 0.21739130434783, -0.016666666666667, 0
6749, 0.26086956521739, -0.016666666666667, 0
6750, 0.30434782608696, -0.016666666666667, 0
6751, 0.34782608695652, -0.016666666666667, 0
6752, 0.39130434782609, -0.016666666666667, 0
6753, 0.43478260869565, -0.016666666666667, 0
6754, 0.47826086956522, -0.016666666666667, 0
6755, 0.52173913043478, -0.016666666666667, 0
6756, 0.56521739130435, -0.016666666666667, 0
6757, 0.60869565217391, -0.016666666666667, 0
6758, 0.65217391304348, -0.016666666666667, 0
6759, 0.69565217391304, -0.016666666666667, 0
6760, 0.73913043478261, -0.016666666666667, 0
6761, 0.78260869565217, -0.016666666666667, 0
6762, 0.82608695652174, -0.016666666666667, 0
6763, 0.8695652173913, -0.016666666666667, 0
6764, 0.91304347826087, -0.016666666666667, 0
6765, 0.95652173913043, -0.016666666666667, 0
6766, 0.043478260869565, 0.016666666666667, 0
6767, 0.08695652173913, 0.016666666666667, 0
6768, 0.1304347826087, 0.016666666666667, 0
6769, 0.17391304347826, 0.016666666666667, 0
6770, 0.21739130434783, 0.016666666666667, 0
6771, 0.26086956521739, 0.016666666666667, 0
6772, 0.30434782608696, 0.016666666666667, 0
6773, 0.34782608695652, 0.016666666666667, 0
6774, 0.39130434782609, 0.016666666666667, 0
6775, 0.43478260869565, 0.016666666666667, 0
6776, 0.47826086956522, 0.016666666666667, 0
6777, 0.52173913043478, 0.016666666666667, 0
6778, 0.56521739130435, 0.016666666666667, 0
6779, 0.60869565217391, 0.016666666666667, 0
6780, 0.65217391304348, 0.016666666666667, 0
6781, 0.69565217391304, 0.016666666666667, 0
6782, 0.73913043478261, 0.016666666666667, 0
6783, 0.78260869565217, 0.016666666666667, 0
6784, 0.82608695652174, 0.016666666666667, 0
6785, 0.8695652173913, 0.016666666666667, 0
6786, 0.91304347826087, 0.016666666666667, 0
6787, 0.95652173913043, 0.016666666666667, 0
6788, 0.021739130434783, -0.016666666666667, 0
6789, 0.043478260869565, -0.033333333333333, 0
6790, 0.065217391304348, -0.016666666666667, 0
6791, 0.08695652173913, -0.033333333333333, 0
6792, 0.10869565217391, -0.016666666666667, 0
6793, 0.1304347826087, -0.033333333333333, 0
6794, 0.15217391304348, -0.016666666666667, 0
6795, 0.17391304347826, -0.033333333333333, 0
6796, 0.19565217391304, -0.016666666666667, 0
6797, 0.21739130434783, -0.033333333333333, 0
6798, 0.23913043478261, -0.016666666666667, 0
6799, 0.26086956521739, -0.033333333333333, 0
6800, 0.28260869565217, -0.016666666666667, 0
6801, 0.30434782608696, -0.033333333333333, 0
6802, 0.32608695652174, -0.016666666666667, 0
6803, 0.34782608695652, -0.033333333333333, 0
6804, 0.3695652173913, -0.016666666666667, 0
6805, 0.39130434782609, -0.033333333333333, 0
6806, 0.41304347826087, -0.016666666666667, 0
6807, 0.43478260869565, -0.033333333333333, 0
6808, 0.45652173913043, -0.016666666666667, 0
6809, 0.47826086956522, -0.033333333333333, 0
6810, 0.5, -0.016666666666667, 0
6811, 0.52173913043478, -0.033333333333333, 0
6812, 0.54347826086957, -0.016666666666667, 0
6813, 0.56521739130435, -0.033333333333333, 0
6814, 0.58695652173913, -0.016666666666667, 0
6815, 0.60869565217391, -0.033333333333333, 0
6816, 0.6304347826087, -0.016666666666667, 0
6817, 0.65217391304348, -0.033333333333333, 0
6818, 0.67391304347826, -0.016666666666667, 0
6819, 0.69565217391304, -0.033333333333333, 0
6820, 0.71739130434783, -0.016666666666667, 0
6821, 0.73913043478261, -0.033333333333333, 0
6822, 0.76086956521739, -0.016666666666667, 0
6823, 0.78260869565217, -0.033333333333333, 0
6824, 0.80434782608696, -0.016666666666667, 0
6825, 0.82608695652174, -0.033333333333333, 0
6826, 0.84782608695652, -0.016666666666667, 0
6827, 0.8695652173913, -0.033333333333333, 0
6828, 0.89130434782609, -0.016666666666667, 0
6829, 0.91304347826087, -0.033333333333333, 0
6830, 0.93478260869565, -0.016666666666667, 0
6831, 0.95652173913043, -0.033333333333333, 0
6832, 0.97826086956522, -0.016666666666667, 0
6833, 0.021739130434783, 0.016666666666667, 0
6834, 0.043478260869565, 5.5511151231258e-17, 0
6835, 0.065217391304348, 0.016666666666667, 0
6836, 0.08695652173913, 5.5511151231258e-17, 0
6837, 0.10869565217391, 0.016666666666667, 0
6838, 0.1304347826087, 5.5511151231258e-17, 0
6839, 0.15217391304348, 0.016666666666667, 0
6840, 0.17391304347826, 5.5511151231258e-17, 0
6841, 0.19565217391304, 0.016666666666667, 0
6842, 0.21739130434783, 5.5511151231258e-17, 0
6843, 0.23913043478261, 0.016666666666667, 0
6844, 0.26086956521739, 5.5511151231258e-17, 0
6845, 0.28260869565217, 0.016666666666667, 0
6846, 0.30434782608696, 5.5511151231258e-17, 0
6847, 0.32608695652174, 0.016666666666667, 0
6848, 0.34782608695652, 5.5511151231258e-17, 0
6849, 0.3695652173913, 0.016666666666667, 0
6850, 0.39130434782609, 5.5511151231258e-17, 0
6851, 0.41304347826087, 0.016666666666667, 0
6852, 0.43478260869565, 4.8572257327351e-17, 0
6853, 0.45652173913043, 0.016666666666667, 0
6854, 0.47826086956522, 5.5511151231258e-17, 0
6855, 0.5, 0.016666666666667, 0
6856, 0.52173913043478, 5.5511151231258e-17, 0
6857, 0.54347826086957, 0.016666666666667, 0
6858, 0.56521739130435, 5.5511151231258e-17, 0
6859, 0.58695652173913, 0.016666666666667, 0
6860, 0.60869565217391, 5.5511151231258e-17, 0
6861, 0.6304347826087, 0.016666666666667, 0
6862, 0.65217391304348, 5.5511151231258e-17, 0
6863, 0.67391304347826, 0.016666666666667, 0
6864, 0.69565217391304, 5.5511151231258e-17, 0
6865, 0.71739130434783, 0.016666666666667, 0
6866, 0.73913043478261, 5.5511151231258e-17, 0
6867, 0.76086956521739, 0.016666666666667, 0
6868, 0.78260869565217, 5.5511151231258e-17, 0
6869, 0.80434782608696, 0.016666666666667, 0
6870, 0.82608695652174, 5.5511151231258e-17, 0
6871, 0.84782608695652, 0.016666666666667, 0
6872, 0.8695652173913, 5.5511151231258e-17, 0
6873, 0.89130434782609, 0.016666666666667, 0
6874, 0.91304347826087, 5.5511151231258e-17, 0
6875, 0.93478260869565, 0.016666666666667, 0
6876, 0.95652173913043, 5.5511151231258e-17, 0
6877, 0.97826086956522, 0.016666666666667, 0
6878, 0.043478260869565, 0.033333333333333, 0
6879, 0.08695652173913, 0.033333333333333, 0
6880, 0.1304347826087, 0.033333333333333, 0
6881, 0.17391304347826, 0.033333333333333, 0
6882, 0.21739130434783, 0.033333333333333, 0
6883, 0.26086956521739, 0.033333333333333, 0
6884, 0.30434782608696, 0.033333333333333, 0
6885, 0.34782608695652, 0.033333333333333, 0
6886, 0.39130434782609, 0.033333333333333, 0
6887, 0.43478260869565, 0.033333333333333, 0
6888, 0.47826086956522, 0.033333333333333, 0
6889, 0.52173913043478, 0.033333333333333, 0
6890, 0.56521739130435, 0.033333333333333, 0
6891, 0.60869565217391, 0.033333333333333, 0
6892, 0.65217391304348, 0.033333333333333, 0
6893, 0.69565217391304, 0.033333333333333, 0
6894, 0.73913043478261, 0.033333333333333, 0
6895, 0.78260869565217, 0.033333333333333, 0
6896, 0.82608695652174, 0.033333333333333, 0
6897, 0.8695652173913, 0.033333333333333, 0
6898, 0.91304347826087, 0.033333333333333, 0
6899, 0.95652173913043, 0.033333333333333, 0
6900, 0.043478260869565, -0.016666666666667, 0.5
6901, 0.08695652173913, -0.016666666666667, 0.5
6902, 0.1304347826087, -0.016666666666667, 0.5
6903, 0.17391304347826, -0.016666666666667, 0.5
6904, 0.21739130434783, -0.016666666666667, 0.5
6905, 0.26086956521739, -0.016666666666667, 0.5
6906, 0.30434782608696, -0.016666666666667, 0.5
6907, 0.34782608695652, -0.016666666666667, 0.5
6908, 0.39130434782609, -0.016666666666667, 0.5
6909, 0.43478260869565, -0.016666666666667, 0.5
6910, 0.47826086956522, -0.016666666666667, 0.5
6911, 0.52173913043478, -0.016666666666667, 0.5
6912, 0.56521739130435, -0.016666666666667, 0.5
6913, 0.60869565217391, -0.016666666666667, 0.5
6914, 0.65217391304348, -0.016666666666667, 0.5
6915, 0.69565217391304, -0.016666666666667, 0.5
6916, 0.73913043478261, -0.016666666666667, 0.5
6917, 0.78260869565217, -0.016666666666667, 0.5
6918, 0.82608695652174, -0.016666666666667, 0.5
6919, 0.8695652173913, -0.016666666666667, 0.5
6920, 0.91304347826087, -0.016666666666667, 0.5
6921, 0.95652173913043, -0.016666666666667, 0.5
6922, 0.043478260869565, 0.016666666666667, 0.5
6923, 0.08695652173913, 0.016666666666667, 0.5
6924, 0.1304347826087, 0.016666666666667, 0.5
6925, 0.17391304347826, 0.016666666666667, 0.5
6926, 0.21739130434783, 0.016666666666667, 0.5
6927, 0.26086956521739, 0.016666666666667, 0.5
6928, 0.30434782608696, 0.016666666666667, 0.5
6929, 0.34782608695652, 0.016666666666667, 0.5
6930, 0.39130434782609, 0.016666666666667, 0.5
6931, 0.43478260869565, 0.016666666666667, 0.5
6932, 0.47826086956522, 0.016666666666667, 0.5
6933, 0.52173913043478, 0.016666666666667, 0.5
6934, 0.56521739130435, 0.016666666666667, 0.5
6935, 0.60869565217391, 0.016666666666667, 0.5
6936, 0.65217391304348, 0.016666666666667, 0.5
6937, 0.69565217391304, 0.016666666666667, 0.5
6938, 0.73913043478261, 0.016666666666667, 0.5
6939, 0.78260869565217, 0.016666666666667, 0.5
6940, 0.82608695652174, 0.016666666666667, 0.5
6941, 0.8695652173913, 0.016666666666667, 0.5
6942, 0.91304347826087, 0.016666666666667, 0.5
6943, 0.95652173913043, 0.016666666666667, 0.5
6944, 0.043478260869565, -0.033333333333333, 0.5
6945, 0.021739130434783, -0.016666666666667, 0.5
6946, 0.08695652173913, -0.033333333333333, 0.5
6947, 0.065217391304348, -0.016666666666667, 0.5
6948, 0.1304347826087, -0.033333333333333, 0.5
6949, 0.10869565217391, -0.016666666666667, 0.5
6950, 0.17391304347826, -0.033333333333333, 0.5
6951, 0.15217391304348, -0.016666666666667, 0.5
6952, 0.21739130434783, -0.033333333333333, 0.5
6953, 0.19565217391304, -0.016666666666667, 0.5
6954, 0.26086956521739, -0.033333333333333, 0.5
6955, 0.23913043478261, -0.016666666666667, 0.5
6956, 0.30434782608696, -0.033333333333333, 0.5
6957, 0.28260869565217, -0.016666666666667, 0.5
6958, 0.34782608695652, -0.033333333333333, 0.5
6959, 0.32608695652174, -0.016666666666667, 0.5
6960, 0.39130434782609, -0.033333333333333, 0.5
6961, 0.3695652173913, -0.016666666666667, 0.5
6962, 0.43478260869565, -0.033333333333333, 0.5
6963, 0.41304347826087, -0.016666666666667, 0.5
6964, 0.47826086956522, -0.033333333333333, 0.5
6965, 0.45652173913043, -0.016666666666667, 0.5
6966, 0.52173913043478, -0.033333333333333, 0.5
6967, 0.5, -0.016666666666667, 0.5
6968, 0.56521739130435, -0.033333333333333, 0.5
6969, 0.54347826086957, -0.016666666666667, 0.5
6970, 0.60869565217391, -0.033333333333333, 0.5
6971, 0.58695652173913, -0.016666666666667, 0.5
6972, 0.65217391304348, -0.033333333333333, 0.5
6973, 0.6304347826087, -0.016666666666667, 0.5
6974, 0.69565217391304, -0.033333333333333, 0.5
6975, 0.67391304347826, -0.016666666666667, 0.5
6976, 0.73913043478261, -0.033333333333333, 0.5
6977, 0.71739130434783, -0.016666666666667, 0.5
6978, 0.78260869565217, -0.033333333333333, 0.5
6979, 0.76086956521739, -0.016666666666667, 0.5
6980, 0.82608695652174, -0.033333333333333, 0.5
6981, 0.80434782608696, -0.016666666666667, 0.5
6982, 0.8695652173913, -0.033333333333333, 0.5
6983, 0.84782608695652, -0.016666666666667, 0.5
6984, 0.91304347826087, -0.033333333333333, 0.5
6985, 0.89130434782609, -0.016666666666667, 0.5
6986, 0.95652173913043, -0.033333333333333, 0.5
6987, 0.93478260869565, -0.016666666666667, 0.5
6988, 0.97826086956522, -0.016666666666667, 0.5
6989, 0.043478260869565, 5.5511151231258e-17, 0.5
6990, 0.021739130434783, 0.016666666666667, 0.5
6991, 0.08695652173913, 5.5511151231258e-17, 0.5
6992, 0.065217391304348, 0.016666666666667, 0.5
6993, 0.1304347826087, 5.5511151231258e-17, 0.5
6994, 0.10869565217391, 0.016666666666667, 0.5
6995, 0.17391304347826, 5.5511151231258e-17, 0.5
6996, 0.15217391304348, 0.016666666666667, 0.5
6997, 0.21739130434783, 5.5511151231258e-17, 0.5
6998, 0.19565217391304, 0.016666666666667, 0.5
6999, 0.26086956521739, 5.5511151231258e-17, 0.5
7000, 0.23913043478261, 0.016666666666667, 0.5
7001, 0.30434782608696, 5.5511151231258e-17, 0.5
7002, 0.28260869565217, 0.016666666666667, 0.5
7003, 0.34782608695652, 5.5511151231258e-17, 0.5
7004, 0.32608695652174, 0.016666666666667, 0.5
7005, 0.39130434782609, 5.5511151231258e-17, 0.5
7006, 0.3695652173913, 0.016666666666667, 0.5
7007, 0.43478260869565, 4.8572257327351e-17, 0.5
7008, 0.41304347826087, 0.016666666666667, 0.5
7009, 0.47826086956522, 5.5511151231258e-17, 0.5
7010, 0.45652173913043, 0.016666666666667, 0.5
7011, 0.52173913043478, 5.5511151231258e-17, 0.5
7012, 0.5, 0.016666666666667, 0.5
7013, 0.56521739130435, 5.5511151231258e-17, 0.5
7014, 0.54347826086957, 0.016666666666667, 0.5
7015, 0.60869565217391, 5.5511151231258e-17, 0.5
7016, 0.58695652173913, 0.016666666666667, 0.5
7017, 0.65217391304348, 5.5511151231258e-17, 0.5
7018, 0.6304347826087, 0.016666666666667, 0.5
7019, 0.69565217391304, 5.5511151231258e-17, 0.5
7020, 0.67391304347826, 0.016666666666667, 0.5
7021, 0.73913043478261, 5.5511151231258e-17, 0.5
7022, 0.71739130434783, 0.016666666666667, 0.5
7023, 0.78260869565217, 5.5511151231258e-17, 0.5
7024, 0.76086956521739, 0.016666666666667, 0.5
7025, 0.82608695652174, 5.5511151231258e-17, 0.5
7026, 0.80434782608696, 0.016666666666667, 0.5
7027, 0.8695652173913, 5.5511151231258e-17, 0.5
7028, 0.84782608695652, 0.016666666666667, 0.5
7029, 0.91304347826087, 5.5511151231258e-17, 0.5
7030, 0.89130434782609, 0.016666666666667, 0.5
7031, 0.95652173913043, 5.5511151231258e-17, 0.5
7032, 0.93478260869565, 0.016666666666667, 0.5
7033, 0.97826086956522, 0.016666666666667, 0.5
7034, 0.043478260869565, 0.033333333333333, 0.5
7035, 0.08695652173913, 0.033333333333333, 0.5
7036, 0.1304347826087, 0.033333333333333, 0.5
7037, 0.17391304347826, 0.033333333333333, 0.5
7038, 0.21739130434783, 0.033333333333333, 0.5
7039, 0.26086956521739, 0.033333333333333, 0.5
7040, 0.30434782608696, 0.033333333333333, 0.5
7041, 0.34782608695652, 0.033333333333333, 0.5
7042, 0.39130434782609, 0.033333333333333, 0.5
7043, 0.43478260869565, 0.033333333333333, 0.5
7044, 0.47826086956522, 0.033333333333333, 0.5
7045, 0.52173913043478, 0.033333333333333, 0.5
7046, 0.56521739130435, 0.033333333333333, 0.5
7047, 0.60869565217391, 0.033333333333333, 0.5
7048, 0.65217391304348, 0.033333333333333, 0.5
7049, 0.69565217391304, 0.033333333333333, 0.5
7050, 0.73913043478261, 0.033333333333333, 0.5
7051, 0.78260869565217, 0.033333333333333, 0.5
7052, 0.82608695652174, 0.033333333333333, 0.5
7053, 0.8695652173913, 0.033333333333333, 0.5
7054, 0.91304347826087, 0.033333333333333, 0.5
7055, 0.95652173913043, 0.033333333333333, 0.5
7056, 0.95652173913043, -0.1, 0
7057, 0.91304347826087, -0.1, 0
7058, 0.8695652173913, -0.1, 0
7059, 0.82608695652174, -0.1, 0
7060, 0.78260869565217, -0.1, 0
7061, 0.73913043478261, -0.1, 0
7062, 0.69565217391304, -0.1, 0
7063, 0.65217391304348, -0.1, 0
7064, 0.60869565217391, -0.1, 0
7065, 0.56521739130435, -0.1, 0
7066, 0.52173913043478, -0.1, 0
7067, 0.47826086956522, -0.1, 0
7068, 0.43478260869565, -0.1, 0
7069, 0.39130434782609, -0.1, 0
7070, 0.34782608695652, -0.1, 0
7071, 0.30434782608696, -0.1, 0
7072, 0.26086956521739, -0.1, 0
7073, 0.21739130434783, -0.1, 0
7074, 0.17391304347826, -0.1, 0
7075, 0.1304347826087, -0.1, 0
7076, 0.08695652173913, -0.1, 0
7077, 0.043478260869565, -0.1, 0
7078, 0.95652173913043, -0.15, 0
7079, 0.91304347826087, -0.15, 0
7080, 0.8695652173913, -0.15, 0
7081, 0.82608695652174, -0.15, 0
7082, 0.78260869565217, -0.15, 0
7083, 0.73913043478261, -0.15, 0
7084, 0.69565217391304, -0.15, 0
7085, 0.65217391304348, -0.15, 0
7086, 0.60869565217391, -0.15, 0
7087, 0.56521739130435, -0.15, 0
7088, 0.52173913043478, -0.15, 0
7089, 0.47826086956522, -0.15, 0
7090, 0.43478260869565, -0.15, 0
7091, 0.39130434782609, -0.15, 0
7092, 0.34782608695652, -0.15, 0
7093, 0.30434782608696, -0.15, 0
7094, 0.26086956521739, -0.15, 0
7095, 0.21739130434783, -0.15, 0
7096, 0.17391304347826, -0.15, 0
7097, 0.1304347826087, -0.15, 0
7098, 0.08695652173913, -0.15, 0
7099, 0.043478260869565, -0.15, 0
7100, 0.95652173913043, -0.2, 0
7101, 0.91304347826087, -0.2, 0
7102, 0.8695652173913, -0.2, 0
7103, 0.82608695652174, -0.2, 0
7104, 0.78260869565217, -0.2, 0
7105, 0.73913043478261, -0.2, 0
7106, 0.69565217391304, -0.2, 0
7107, 0.65217391304348, -0.2, 0
7108, 0.60869565217391, -0.2, 0
7109, 0.56521739130435, -0.2, 0
7110, 0.52173913043478, -0.2, 0
7111, 0.47826086956522, -0.2, 0
7112, 0.43478260869565, -0.2, 0
7113, 0.39130434782609, -0.2, 0
7114, 0.34782608695652, -0.2, 0
7115, 0.30434782608696, -0.2, 0
7116, 0.26086956521739, -0.2, 0
7117, 0.21739130434783, -0.2, 0
7118, 0.17391304347826, -0.2, 0
7119, 0.1304347826087, -0.2, 0
7120, 0.08695652173913, -0.2, 0
7121, 0.043478260869565, -0.2, 0
7122, 0.97826086956522, -0.1, 0
7123, 0.95652173913043, -0.075, 0
7124, 0.93478260869565, -0.1, 0
7125, 0.91304347826087, -0.075, 0
7126, 0.89130434782609, -0.1, 0
7127, 0.8695652173913, -0.075, 0
7128, 0.84782608695652, -0.1, 0
7129, 0.82608695652174, -0.075, 0
7130, 0.80434782608696, -0.1, 0
7131, 0.78260869565217, -0.075, 0
7132, 0.76086956521739, -0.1, 0
7133, 0.73913043478261, -0.075, 0
7134, 0.71739130434783, -0.1, 0
7135, 0.69565217391304, -0.075, 0
7136, 0.67391304347826, -0.1, 0
7137, 0.65217391304348, -0.075, 0
7138, 0.6304347826087, -0.1, 0
7139, 0.60869565217391, -0.075, 0
7140, 0.58695652173913, -0.1, 0
7141, 0.56521739130435, -0.075, 0
7142, 0.54347826086957, -0.1, 0
7143, 0.52173913043478, -0.075, 0
7144, 0.5, -0.1, 0
7145, 0.47826086956522, -0.075, 0
7146, 0.45652173913043, -0.1, 0
7147, 0.43478260869565, -0.075, 0
7148, 0.41304347826087, -0.1, 0
7149, 0.39130434782609, -0.075, 0
7150, 0.3695652173913, -0.1, 0
7151, 0.34782608695652, -0.075, 0
7152, 0.32608695652174, -0.1, 0
7153, 0.30434782608696, -0.075, 0
7154, 0.28260869565217, -0.1, 0
7155, 0.26086956521739, -0.075, 0
7156, 0.23913043478261, -0.1, 0
7157, 0.21739130434783, -0.075, 0
7158, 0.19565217391304, -0.1, 0
7159, 0.17391304347826, -0.075, 0
7160, 0.15217391304348, -0.1, 0
7161, 0.1304347826087, -0.075, 0
7162, 0.10869565217391, -0.1, 0
7163, 0.08695652173913, -0.075, 0
7164, 0.065217391304348, -0.1, 0
7165, 0.043478260869565, -0.075, 0
7166, 0.021739130434783, -0.1, 0
7167, 0.97826086956522, -0.15, 0
7168, 0.95652173913043, -0.125, 0
7169, 0.93478260869565, -0.15, 0
7170, 0.91304347826087, -0.125, 0
7171, 0.89130434782609, -0.15, 0
7172, 0.8695652173913, -0.125, 0
7173, 0.84782608695652, -0.15, 0
7174, 0.82608695652174, -0.125, 0
7175, 0.80434782608696, -0.15, 0
7176, 0.78260869565217, -0.125, 0
7177, 0.76086956521739, -0.15, 0
7178, 0.73913043478261, -0.125, 0
7179, 0.71739130434783, -0.15, 0
7180, 0.69565217391304, -0.125, 0
7181, 0.67391304347826, -0.15, 0
7182, 0.65217391304348, -0.125, 0
7183, 0.6304347826087, -0.15, 0
7184, 0.60869565217391, -0.125, 0
7185, 0.58695652173913, -0.15, 0
7186, 0.56521739130435, -0.125, 0
7187, 0.54347826086957, -0.15, 0
7188, 0.52173913043478, -0.125, 0
7189, 0.5, -0.15, 0
7190, 0.47826086956522, -0.125, 0
7191, 0.45652173913043, -0.15, 0
7192, 0.43478260869565, -0.125, 0
7193, 0.41304347826087, -0.15, 0
7194, 0.39130434782609, -0.125, 0
7195, 0.3695652173913, -0.15, 0
7196, 0.34782608695652, -0.125, 0
7197, 0.32608695652174, -0.15, 0
7198, 0.30434782608696, -0.125, 0
7199, 0.28260869565217, -0.15, 0
7200, 0.26086956521739, -0.125, 0
7201, 0.23913043478261, -0.15, 0
7202, 0.21739130434783, -0.125, 0
7203, 0.19565217391304, -0.15, 0
7204, 0.17391304347826, -0.125, 0
7205, 0.15217391304348, -0.15, 0
7206, 0.1304347826087, -0.125, 0
7207, 0.10869565217391, -0.15, 0
7208, 0.08695652173913, -0.125, 0
7209, 0.065217391304348, -0.15, 0
7210, 0.043478260869565, -0.125, 0
7211, 0.021739130434783, -0.15, 0
7212, 0.97826086956522, -0.2, 0
7213, 0.95652173913043, -0.175, 0
7214, 0.93478260869565, -0.2, 0
7215, 0.91304347826087, -0.175, 0
7216, 0.89130434782609, -0.2, 0
7217, 0.8695652173913, -0.175, 0
7218, 0.84782608695652, -0.2, 0
7219, 0.82608695652174, -0.175, 0
7220, 0.80434782608696, -0.2, 0
7221, 0.78260869565217, -0.175, 0
7222, 0.76086956521739, -0.2, 0
7223, 0.73913043478261, -0.175, 0
7224, 0.71739130434783, -0.2, 0
7225, 0.69565217391304, -0.175, 0
7226, 0.67391304347826, -0.2, 0
7227, 0.65217391304348, -0.175, 0
7228, 0.6304347826087, -0.2, 0
7229, 0.60869565217391, -0.175, 0
7230, 0.58695652173913, -0.2, 0
7231, 0.56521739130435, -0.175, 0
7232, 0.54347826086957, -0.2, 0
7233, 0.52173913043478, -0.175, 0
7234, 0.5, -0.2, 0
7235, 0.47826086956522, -0.175, 0
7236, 0.45652173913043, -0.2, 0
7237, 0.43478260869565, -0.175, 0
7238, 0.41304347826087, -0.2, 0
7239, 0.39130434782609, -0.175, 0
7240, 0.3695652173913, -0.2, 0
7241, 0.34782608695652, -0.175, 0
7242, 0.32608695652174, -0.2, 0
7243, 0.30434782608696, -0.175, 0
7244, 0.28260869565217, -0.2, 0
7245, 0.26086956521739, -0.175, 0
7246, 0.23913043478261, -0.2, 0
7247, 0.21739130434783, -0.175, 0
7248, 0.19565217391304, -0.2, 0
7249, 0.17391304347826, -0.175, 0
7250, 0.15217391304348, -0.2, 0
7251, 0.1304347826087, -0.175, 0
7252, 0.10869565217391, -0.2, 0
7253, 0.08695652173913, -0.175, 0
7254, 0.065217391304348, -0.2, 0
7255, 0.043478260869565, -0.175, 0
7256, 0.021739130434783, -0.2, 0
7257, 0.95652173913043, -0.225, 0
7258, 0.91304347826087, -0.225, 0
7259, 0.8695652173913, -0.225, 0
7260, 0.82608695652174, -0.225, 0
7261, 0.78260869565217, -0.225, 0
7262, 0.73913043478261, -0.225, 0
7263, 0.69565217391304, -0.225, 0
7264, 0.65217391304348, -0.225, 0
7265, 0.60869565217391, -0.225, 0
7266, 0.56521739130435, -0.225, 0
7267, 0.52173913043478, -0.225, 0
7268, 0.47826086956522, -0.225, 0
7269, 0.43478260869565, -0.225, 0
7270, 0.39130434782609, -0.225, 0
7271, 0.34782608695652, -0.225, 0
7272, 0.30434782608696, -0.225, 0
7273, 0.26086956521739, -0.225, 0
7274, 0.21739130434783, -0.225, 0
7275, 0.17391304347826, -0.225, 0
7276, 0.1304347826087, -0.225, 0
7277, 0.08695652173913, -0.225, 0
7278, 0.043478260869565, -0.225, 0
7279, 1, -0.1, 0.44444444444444
7280, 1, -0.1, 0.38888888888889
7281, 1, -0.1, 0.33333333333333
7282, 1, -0.1, 0.27777777777778
7283, 1, -0.1, 0.22222222222222
7284, 1, -0.1, 0.16666666666667
7285, 1, -0.1, 0.11111111111111
7286, 1, -0.1, 0.055555555555556
7287, 1, -0.15, 0.44444444444444
7288, 1, -0.15, 0.38888888888889
7289, 1, -0.15, 0.33333333333333
7290, 1, -0.15, 0.27777777777778
7291, 1, -0.15, 0.22222222222222
7292, 1, -0.15, 0.16666666666667
7293, 1, -0.15, 0.11111111111111
7294, 1, -0.15, 0.055555555555556
7295, 1, -0.2, 0.44444444444444
7296, 1, -0.2, 0.38888888888889
7297, 1, -0.2, 0.33333333333333
7298, 1, -0.2, 0.27777777777778
7299, 1, -0.2, 0.22222222222222
7300, 1, -0.2, 0.16666666666667
7301, 1, -0.2, 0.11111111111111
7302, 1, -0.2, 0.055555555555556
7303, 1, -0.1, 0.47222222222222
7304, 1, -0.075, 0.44444444444444
7305, 1, -0.1, 0.41666666666667
7306, 1, -0.075, 0.38888888888889
7307, 1, -0.1, 0.36111111111111
7308, 1, -0.075, 0.33333333333333
7309, 1, -0.1, 0.30555555555556
7310, 1, -0.075, 0.27777777777778
7311, 1, -0.1, 0.25
7312, 1, -0.075, 0.22222222222222
7313, 1, -0.1, 0.19444444444444
7314, 1, -0.075, 0.16666666666667
7315, 1, -0.1, 0.13888888888889
7316, 1, -0.075, 0.11111111111111
7317, 1, -0.1, 0.083333333333333
7318, 1, -0.075, 0.055555555555556
7319, 1, -0.1, 0.027777777777778
7320, 1, -0.15, 0.47222222222222
7321, 1, -0.125, 0.44444444444444
7322, 1, -0.15, 0.41666666666667
7323, 1, -0.125, 0.38888888888889
7324, 1, -0.15, 0.36111111111111
7325, 1, -0.125, 0.33333333333333
7326, 1, -0.15, 0.30555555555556
7327, 1, -0.125, 0.27777777777778
7328, 1, -0.15, 0.25
7329, 1, -0.125, 0.22222222222222
7330, 1, -0.15, 0.19444444444444
7331, 1, -0.125, 0.16666666666667
7332, 1, -0.15, 0.13888888888889
7333, 1, -0.125, 0.11111111111111
7334, 1, -0.15, 0.083333333333333
7335, 1, -0.125, 0.055555555555556
7336, 1, -0.15, 0.027777777777778
7337, 1, -0.2, 0.47222222222222
7338, 1, -0.175, 0.44444444444444
7339, 1, -0.2, 0.41666666666667
7340, 1, -0.175, 0.38888888888889
7341, 1, -0.2, 0.36111111111111
7342, 1, -0.175, 0.33333333333333
7343, 1, -0.2, 0.30555555555556
7344, 1, -0.175, 0.27777777777778
7345, 1, -0.2, 0.25
7346, 1, -0.175, 0.22222222222222
7347, 1, -0.2, 0.19444444444444
7348, 1, -0.175, 0.16666666666667
7349, 1, -0.2, 0.13888888888889
7350, 1, -0.175, 0.11111111111111
7351, 1, -0.2, 0.083333333333333
7352, 1, -0.175, 0.055555555555556
7353, 1, -0.2, 0.027777777777778
7354, 1, -0.225, 0.44444444444444
7355, 1, -0.225, 0.38888888888889
7356, 1, -0.225, 0.33333333333333
7357, 1, -0.225, 0.27777777777778
7358, 1, -0.225, 0.22222222222222
7359, 1, -0.225, 0.16666666666667
7360, 1, -0.225, 0.11111111111111
7361, 1, -0.225, 0.055555555555556
7362, 0.95652173913043, -0.1, 0.5
7363, 0.91304347826087, -0.1, 0.5
7364, 0.8695652173913, -0.1, 0.5
7365, 0.82608695652174, -0.1, 0.5
7366, 0.78260869565217, -0.1, 0.5
7367, 0.73913043478261, -0.1, 0.5
7368, 0.69565217391304, -0.1, 0.5
7369, 0.65217391304348, -0.1, 0.5
7370, 0.60869565217391, -0.1, 0.5
7371, 0.56521739130435, -0.1, 0.5
7372, 0.52173913043478, -0.1, 0.5
7373, 0.47826086956522, -0.1, 0.5
7374, 0.43478260869565, -0.1, 0.5
7375, 0.39130434782609, -0.1, 0.5
7376, 0.34782608695652, -0.1, 0.5
7377, 0.30434782608696, -0.1, 0.5
7378, 0.26086956521739, -0.1, 0.5
7379, 0.21739130434783, -0.1, 0.5
7380, 0.17391304347826, -0.1, 0.5
7381, 0.1304347826087, -0.1, 0.5
7382, 0.08695652173913, -0.1, 0.5
7383, 0.043478260869565, -0.1, 0.5
7384, 0.95652173913043, -0.15, 0.5
7385, 0.91304347826087, -0.15, 0.5
7386, 0.8695652173913, -0.15, 0.5
7387, 0.82608695652174, -0.15, 0.5
7388, 0.78260869565217, -0.15, 0.5
7389, 0.73913043478261, -0.15, 0.5
7390, 0.69565217391304, -0.15, 0.5
7391, 0.65217391304348, -0.15, 0.5
7392, 0.60869565217391, -0.15, 0.5
7393, 0.56521739130435, -0.15, 0.5
7394, 0.52173913043478, -0.15, 0.5
7395, 0.47826086956522, -0.15, 0.5
7396, 0.43478260869565, -0.15, 0.5
7397, 0.39130434782609, -0.15, 0.5
7398, 0.34782608695652, -0.15, 0.5
7399, 0.30434782608696, -0.15, 0.5
7400, 0.26086956521739, -0.15, 0.5
7401, 0.21739130434783, -0.15, 0.5
7402, 0.17391304347826, -0.15, 0.5
7403, 0.1304347826087, -0.15, 0.5
7404, 0.08695652173913, -0.15, 0.5
7405, 0.043478260869565, -0.15, 0.5
7406, 0.95652173913043, -0.2, 0.5
7407, 0.91304347826087, -0.2, 0.5
7408, 0.8695652173913, -0.2, 0.5
7409, 0.82608695652174, -0.2, 0.5
7410, 0.78260869565217, -0.2, 0.5
7411, 0.73913043478261, -0.2, 0.5
7412, 0.69565217391304, -0.2, 0.5
7413, 0.65217391304348, -0.2, 0.5
7414, 0.60869565217391, -0.2, 0.5
7415, 0.56521739130435, -0.2, 0.5
7416, 0.52173913043478, -0.2, 0.5
7417, 0.47826086956522, -0.2, 0.5
7418, 0.43478260869565, -0.2, 0.5
7419, 0.39130434782609, -0.2, 0.5
7420, 0.34782608695652, -0.2, 0.5
7421, 0.30434782608696, -0.2, 0.5
7422, 0.26086956521739, -0.2, 0.5
7423, 0.21739130434783, -0.2, 0.5
7424, 0.17391304347826, -0.2, 0.5
7425, 0.1304347826087, -0.2, 0.5
7426, 0.08695652173913, -0.2, 0.5
7427, 0.043478260869565, -0.2, 0.5
7428, 0.95652173913043, -0.075, 0.5
7429, 0.97826086956522, -0.1, 0.5
7430, 0.91304347826087, -0.075, 0.5
7431, 0.93478260869565, -0.1, 0.5
7432, 0.8695652173913, -0.075, 0.5
7433, 0.89130434782609, -0.1, 0.5
7434, 0.82608695652174, -0.075, 0.5
7435, 0.84782608695652, -0.1, 0.5
7436, 0.78260869565217, -0.075, 0.5
7437, 0.80434782608696, -0.1, 0.5
7438, 0.73913043478261, -0.075, 0.5
7439, 0.76086956521739, -0.1, 0.5
7440, 0.69565217391304, -0.075, 0.5
7441, 0.71739130434783, -0.1, 0.5
7442, 0.65217391304348, -0.075, 0.5
7443, 0.67391304347826, -0.1, 0.5
7444, 0.60869565217391, -0.075, 0.5
7445, 0.6304347826087, -0.1, 0.5
7446, 0.56521739130435, -0.075, 0.5
7447, 0.58695652173913, -0.1, 0.5
7448, 0.52173913043478, -0.075, 0.5
7449, 0.54347826086957, -0.1, 0.5
7450, 0.47826086956522, -0.075, 0.5
7451, 0.5, -0.1, 0.5
7452, 0.43478260869565, -0.075, 0.5
7453, 0.45652173913043, -0.1, 0.5
7454, 0.39130434782609, -0.075, 0.5
7455, 0.41304347826087, -0.1, 0.5
7456, 0.34782608695652, -0.075, 0.5
7457, 0.3695652173913, -0.1, 0.5
7458, 0.30434782608696, -0.075, 0.5
7459, 0.32608695652174, -0.1, 0.5
7460, 0.26086956521739, -0.075, 0.5
7461, 0.28260869565217, -0.1, 0.5
7462, 0.21739130434783, -0.075, 0.5
7463, 0.23913043478261, -0.1, 0.5
7464, 0.17391304347826, -0.075, 0.5
7465, 0.19565217391304, -0.1, 0.5
7466, 0.1304347826087, -0.075, 0.5
7467, 0.15217391304348, -0.1, 0.5
7468, 0.08695652173913, -0.075, 0.5
7469, 0.10869565217391, -0.1, 0.5
7470, 0.043478260869565, -0.075, 0.5
7471, 0.065217391304348, -0.1, 0.5
7472, 0.021739130434783, -0.1, 0.5
7473, 0.95652173913043, -0.125, 0.5
7474, 0.97826086956522, -0.15, 0.5
7475, 0.91304347826087, -0.125, 0.5
7476, 0.93478260869565, -0.15, 0.5
7477, 0.8695652173913, -0.125, 0.5
7478, 0.89130434782609, -0.15, 0.5
7479, 0.82608695652174, -0.125, 0.5
7480, 0.84782608695652, -0.15, 0.5
7481, 0.78260869565217, -0.125, 0.5
7482, 0.80434782608696, -0.15, 0.5
7483, 0.73913043478261, -0.125, 0.5
7484, 0.76086956521739, -0.15, 0.5
7485, 0.69565217391304, -0.125, 0.5
7486, 0.71739130434783, -0.15, 0.5
7487, 0.65217391304348, -0.125, 0.5
7488, 0.67391304347826, -0.15, 0.5
7489, 0.60869565217391, -0.125, 0.5
7490, 0.6304347826087, -0.15, 0.5
7491, 0.56521739130435, -0.125, 0.5
7492, 0.58695652173913, -0.15, 0.5
7493, 0.52173913043478, -0.125, 0.5
7494, 0.54347826086957, -0.15, 0.5
7495, 0.47826086956522, -0.125, 0.5
7496, 0.5, -0.15, 0.5
7497, 0.43478260869565, -0.125, 0.5
7498, 0.45652173913043, -0.15, 0.5
7499, 0.39130434782609, -0.125, 0.5
7500, 0.41304347826087, -0.15, 0.5
7501, 0.34782608695652, -0.125, 0.5
7502, 0.3695652173913, -0.15, 0.5
7503, 0.30434782608696, -0.125, 0.5
7504, 0.32608695652174, -0.15, 0.5
7505, 0.26086956521739, -0.125, 0.5
7506, 0.28260869565217, -0.15, 0.5
7507, 0.21739130434783, -0.125, 0.5
7508, 0.23913043478261, -0.15, 0.5
7509, 0.17391304347826, -0.125, 0.5
7510, 0.19565217391304, -0.15, 0.5
7511, 0.1304347826087, -0.125, 0.5
7512, 0.15217391304348, -0.15, 0.5
7513, 0.08695652173913, -0.125, 0.5
7514, 0.10869565217391, -0.15, 0.5
7515, 0.043478260869565, -0.125, 0.5
7516, 0.065217391304348, -0.15, 0.5
7517, 0.021739130434783, -0.15, 0.5
7518, 0.95652173913043, -0.175, 0.5
7519, 0.97826086956522, -0.2, 0.5
7520, 0.91304347826087, -0.175, 0.5
7521, 0.93478260869565, -0.2, 0.5
7522, 0.8695652173913, -0.175, 0.5
7523, 0.89130434782609, -0.2, 0.5
7524, 0.82608695652174, -0.175, 0.5
7525, 0.84782608695652, -0.2, 0.5
7526, 0.78260869565217, -0.175, 0.5
7527, 0.80434782608696, -0.2, 0.5
7528, 0.73913043478261, -0.175, 0.5
7529, 0.76086956521739, -0.2, 0.5
7530, 0.69565217391304, -0.175, 0.5
7531, 0.71739130434783, -0.2, 0.5
7532, 0.65217391304348, -0.175, 0.5
7533, 0.67391304347826, -0.2, 0.5
7534, 0.60869565217391, -0.175, 0.5
7535, 0.6304347826087, -0.2, 0.5
7536, 0.56521739130435, -0.175, 0.5
7537, 0.58695652173913, -0.2, 0.5
7538, 0.52173913043478, -0.175, 0.5
7539, 0.54347826086957, -0.2, 0.5
7540, 0.47826086956522, -0.175, 0.5
7541, 0.5, -0.2, 0.5
7542, 0.43478260869565, -0.175, 0.5
7543, 0.45652173913043, -0.2, 0.5
7544, 0.39130434782609, -0.175, 0.5
7545, 0.41304347826087, -0.2, 0.5
7546, 0.34782608695652, -0.175, 0.5
7547, 0.3695652173913, -0.2, 0.5
7548, 0.30434782608696, -0.175, 0.5
7549, 0.32608695652174, -0.2, 0.5
7550, 0.26086956521739, -0.175, 0.5
7551, 0.28260869565217, -0.2, 0.5
7552, 0.21739130434783, -0.175, 0.5
7553, 0.23913043478261, -0.2, 0.5
7554, 0.17391304347826, -0.175, 0.5
7555, 0.19565217391304, -0.2, 0.5
7556, 0.1304347826087, -0.175, 0.5
7557, 0.15217391304348, -0.2, 0.5
7558, 0.08695652173913, -0.175, 0.5
7559, 0.10869565217391, -0.2, 0.5
7560, 0.043478260869565, -0.175, 0.5
7561, 0.065217391304348, -0.2, 0.5
7562, 0.021739130434783, -0.2, 0.5
7563, 0.95652173913043, -0.225, 0.5
7564, 0.91304347826087, -0.225, 0.5
7565, 0.8695652173913, -0.225, 0.5
7566, 0.82608695652174, -0.225, 0.5
7567, 0.78260869565217, -0.225, 0.5
7568, 0.73913043478261, -0.225, 0.5
7569, 0.69565217391304, -0.225, 0.5
7570, 0.65217391304348, -0.225, 0.5
7571, 0.60869565217391, -0.225, 0.5
7572, 0.56521739130435, -0.225, 0.5
7573, 0.52173913043478, -0.225, 0.5
7574, 0.47826086956522, -0.225, 0.5
7575, 0.43478260869565, -0.225, 0.5
7576, 0.39130434782609, -0.225, 0.5
7577, 0.34782608695652, -0.225, 0.5
7578, 0.30434782608696, -0.225, 0.5
7579, 0.26086956521739, -0.225, 0.5
7580, 0.21739130434783, -0.225, 0.5
7581, 0.17391304347826, -0.225, 0.5
7582, 0.1304347826087, -0.225, 0.5
7583, 0.08695652173913, -0.225, 0.5
7584, 0.043478260869565, -0.225, 0.5
7585, 0.043478260869565, -0.25, 0.055555555555556
7586, 0.043478260869565, -0.25, 0.11111111111111
7587, 0.043478260869565, -0.25, 0.16666666666667
7588, 0.043478260869565, -0.25, 0.22222222222222
7589, 0.043478260869565, -0.25, 0.27777777777778
7590, 0.043478260869565, -0.25, 0.33333333333333
7591, 0.043478260869565, -0.25, 0.38888888888889
7592, 0.043478260869565, -0.25, 0.44444444444444
7593, 0.08695652173913, -0.25, 0.055555555555556
7594, 0.08695652173913, -0.25, 0.11111111111111
7595, 0.08695652173913, -0.25, 0.16666666666667
7596, 0.08695652173913, -0.25, 0.22222222222222
7597, 0.08695652173913, -0.25, 0.27777777777778
7598, 0.08695652173913, -0.25, 0.33333333333333
7599, 0.08695652173913, -0.25, 0.38888888888889
7600, 0.08695652173913, -0.25, 0.44444444444444
7601, 0.1304347826087, -0.25, 0.055555555555556
7602, 0.1304347826087, -0.25, 0.11111111111111
7603, 0.1304347826087, -0.25, 0.16666666666667
7604, 0.1304347826087, -0.25, 0.22222222222222
7605, 0.1304347826087, -0.25, 0.27777777777778
7606, 0.1304347826087, -0.25, 0.33333333333333
7607, 0.1304347826087, -0.25, 0.38888888888889
7608, 0.1304347826087, -0.25, 0.44444444444444
7609, 0.17391304347826, -0.25, 0.055555555555556
7610, 0.17391304347826, -0.25, 0.11111111111111
7611, 0.17391304347826, -0.25, 0.16666666666667
7612, 0.17391304347826, -0.25, 0.22222222222222
7613, 0.17391304347826, -0.25, 0.27777777777778
7614, 0.17391304347826, -0.25, 0.33333333333333
7615, 0.17391304347826, -0.25, 0.38888888888889
7616, 0.17391304347826, -0.25, 0.44444444444444
7617, 0.21739130434783, -0.25, 0.055555555555556
7618, 0.21739130434783, -0.25, 0.11111111111111
7619, 0.21739130434783, -0.25, 0.16666666666667
7620, 0.21739130434783, -0.25, 0.22222222222222
7621, 0.21739130434783, -0.25, 0.27777777777778
7622, 0.21739130434783, -0.25, 0.33333333333333
7623, 0.21739130434783, -0.25, 0.38888888888889
7624, 0.21739130434783, -0.25, 0.44444444444444
7625, 0.26086956521739, -0.25, 0.055555555555556
7626, 0.26086956521739, -0.25, 0.11111111111111
7627, 0.26086956521739, -0.25, 0.16666666666667
7628, 0.26086956521739, -0.25, 0.22222222222222
7629, 0.26086956521739, -0.25, 0.27777777777778
7630, 0.26086956521739, -0.25, 0.33333333333333
7631, 0.26086956521739, -0.25, 0.38888888888889
7632, 0.26086956521739, -0.25, 0.44444444444444
7633, 0.30434782608696, -0.25, 0.055555555555556
7634, 0.30434782608696, -0.25, 0.11111111111111
7635, 0.30434782608696, -0.25, 0.16666666666667
7636, 0.30434782608696, -0.25, 0.22222222222222
7637, 0.30434782608696, -0.25, 0.27777777777778
7638, 0.30434782608696, -0.25, 0.33333333333333
7639, 0.30434782608696, -0.25, 0.38888888888889
7640, 0.30434782608696, -0.25, 0.44444444444444
7641, 0.34782608695652, -0.25, 0.055555555555556
7642, 0.34782608695652, -0.25, 0.11111111111111
7643, 0.34782608695652, -0.25, 0.16666666666667
7644, 0.34782608695652, -0.25, 0.22222222222222
7645, 0.34782608695652, -0.25, 0.27777777777778
7646, 0.34782608695652, -0.25, 0.33333333333333
7647, 0.34782608695652, -0.25, 0.38888888888889
7648, 0.34782608695652, -0.25, 0.44444444444444
7649, 0.39130434782609, -0.25, 0.055555555555556
7650, 0.39130434782609, -0.25, 0.11111111111111
7651, 0.39130434782609, -0.25, 0.16666666666667
7652, 0.39130434782609, -0.25, 0.22222222222222
7653, 0.39130434782609, -0.25, 0.27777777777778
7654, 0.39130434782609, -0.25, 0.33333333333333
7655, 0.39130434782609, -0.25, 0.38888888888889
7656, 0.39130434782609, -0.25, 0.44444444444444
7657, 0.43478260869565, -0.25, 0.055555555555556
7658, 0.43478260869565, -0.25, 0.11111111111111
7659, 0.43478260869565, -0.25, 0.16666666666667
7660, 0.43478260869565, -0.25, 0.22222222222222
7661, 0.43478260869565, -0.25, 0.27777777777778
7662, 0.43478260869565, -0.25, 0.33333333333333
7663, 0.43478260869565, -0.25, 0.38888888888889
7664, 0.43478260869565, -0.25, 0.44444444444444
7665, 0.47826086956522, -0.25, 0.055555555555556
7666, 0.47826086956522, -0.25, 0.11111111111111
7667, 0.47826086956522, -0.25, 0.16666666666667
7668, 0.47826086956522, -0.25, 0.22222222222222
7669, 0.47826086956522, -0.25, 0.27777777777778
7670, 0.47826086956522, -0.25, 0.33333333333333
7671, 0.47826086956522, -0.25, 0.38888888888889
7672, 0.47826086956522, -0.25, 0.44444444444444
7673, 0.52173913043478, -0.25, 0.055555555555556
7674, 0.52173913043478, -0.25, 0.11111111111111
7675, 0.52173913043478, -0.25, 0.16666666666667
7676, 0.52173913043478, -0.25, 0.22222222222222
7677, 0.52173913043478, -0.25, 0.27777777777778
7678, 0.52173913043478, -0.25, 0.33333333333333
7679, 0.52173913043478, -0.25, 0.38888888888889
7680, 0.52173913043478, -0.25, 0.44444444444444
7681, 0.56521739130435, -0.25, 0.055555555555556
7682, 0.56521739130435, -0.25, 0.11111111111111
7683, 0.56521739130435, -0.25, 0.16666666666667
7684, 0.56521739130435, -0.25, 0.22222222222222
7685, 0.56521739130435, -0.25, 0.27777777777778
7686, 0.56521739130435, -0.25, 0.33333333333333
7687, 0.56521739130435, -0.25, 0.38888888888889
7688, 0.56521739130435, -0.25, 0.44444444444444
7689, 0.60869565217391, -0.25, 0.055555555555556
7690, 0.60869565217391, -0.25, 0.11111111111111
7691, 0.60869565217391, -0.25, 0.16666666666667
7692, 0.60869565217391, -0.25, 0.22222222222222
7693, 0.60869565217391, -0.25, 0.27777777777778
7694, 0.60869565217391, -0.25, 0.33333333333333
7695, 0.60869565217391, -0.25, 0.38888888888889
7696, 0.60869565217391, -0.25, 0.44444444444444
7697, 0.65217391304348, -0.25, 0.055555555555556
7698, 0.65217391304348, -0.25, 0.11111111111111
7699, 0.65217391304348, -0.25, 0.16666666666667
7700, 0.65217391304348, -0.25, 0.22222222222222
7701, 0.65217391304348, -0.25, 0.27777777777778
7702, 0.65217391304348, -0.25, 0.33333333333333
7703, 0.65217391304348, -0.25, 0.38888888888889
7704, 0.65217391304348, -0.25, 0.44444444444444
7705, 0.69565217391304, -0.25, 0.055555555555556
7706, 0.69565217391304, -0.25, 0.11111111111111
7707, 0.69565217391304, -0.25, 0.16666666666667
7708, 0.69565217391304, -0.25, 0.22222222222222
7709, 0.69565217391304, -0.25, 0.27777777777778
7710, 0.69565217391304, -0.25, 0.33333333333333
7711, 0.69565217391304, -0.25, 0.38888888888889
7712, 0.69565217391304, -0.25, 0.44444444444444
7713, 0.73913043478261, -0.25, 0.055555555555556
7714, 0.73913043478261, -0.25, 0.11111111111111
7715, 0.73913043478261, -0.25, 0.16666666666667
7716, 0.73913043478261, -0.25, 0.22222222222222
7717, 0.73913043478261, -0.25, 0.27777777777778
7718, 0.73913043478261, -0.25, 0.33333333333333
7719, 0.73913043478261, -0.25, 0.38888888888889
7720, 0.73913043478261, -0.25, 0.44444444444444
7721, 0.78260869565217, -0.25, 0.055555555555556
7722, 0.78260869565217, -0.25, 0.11111111111111
7723, 0.78260869565217, -0.25, 0.16666666666667
7724, 0.78260869565217, -0.25, 0.22222222222222
7725, 0.78260869565217, -0.25, 0.27777777777778
7726, 0.78260869565217, -0.25, 0.33333333333333
7727, 0.78260869565217, -0.25, 0.38888888888889
7728, 0.78260869565217, -0.25, 0.44444444444444
7729, 0.82608695652174, -0.25, 0.055555555555556
7730, 0.82608695652174, -0.25, 0.11111111111111
7731, 0.82608695652174, -0.25, 0.16666666666667
7732, 0.82608695652174, -0.25, 0.22222222222222
7733, 0.82608695652174, -0.25, 0.27777777777778
7734, 0.82608695652174, -0.25, 0.33333333333333
7735, 0.82608695652174, -0.25, 0.38888888888889
7736, 0.82608695652174, -0.25, 0.44444444444444
7737, 0.8695652173913, -0.25, 0.055555555555556
7738, 0.8695652173913, -0.25, 0.11111111111111
7739, 0.8695652173913, -0.25, 0.16666666666667
7740, 0.8695652173913, -0.25, 0.22222222222222
7741, 0.8695652173913, -0.25, 0.27777777777778
7742, 0.8695652173913, -0.25, 0.33333333333333
7743, 0.8695652173913, -0.25, 0.38888888888889
7744, 0.8695652173913, -0.25, 0.44444444444444
7745, 0.91304347826087, -0.25, 0.055555555555556
7746, 0.91304347826087, -0.25, 0.11111111111111
7747, 0.91304347826087, -0.25, 0.16666666666667
7748, 0.91304347826087, -0.25, 0.22222222222222
7749, 0.91304347826087, -0.25, 0.27777777777778
7750, 0.91304347826087, -0.25, 0.33333333333333
7751, 0.91304347826087, -0.25, 0.38888888888889
7752, 0.91304347826087, -0.25, 0.44444444444444
7753, 0.95652173913043, -0.25, 0.055555555555556
7754, 0.95652173913043, -0.25, 0.11111111111111
7755, 0.95652173913043, -0.25, 0.16666666666667
7756, 0.95652173913043, -0.25, 0.22222222222222
7757, 0.95652173913043, -0.25, 0.27777777777778
7758, 0.95652173913043, -0.25, 0.33333333333333
7759, 0.95652173913043, -0.25, 0.38888888888889
7760, 0.95652173913043, -0.25, 0.44444444444444
7761, 0.043478260869565, -0.25, 0.027777777777778
7762, 0.021739130434783, -0.25, 0.055555555555556
7763, 0.043478260869565, -0.25, 0.083333333333333
7764, 0.021739130434783, -0.25, 0.11111111111111
7765, 0.043478260869565, -0.25, 0.13888888888889
7766, 0.021739130434783, -0.25, 0.16666666666667
7767, 0.043478260869565, -0.25, 0.19444444444444
7768, 0.021739130434783, -0.25, 0.22222222222222
7769, 0.043478260869565, -0.25, 0.25
7770, 0.021739130434783, -0.25, 0.27777777777778
7771, 0.043478260869565, -0.25, 0.30555555555556
7772, 0.021739130434783, -0.25, 0.33333333333333
7773, 0.043478260869565, -0.25, 0.36111111111111
7774, 0.021739130434783, -0.25, 0.38888888888889
7775, 0.043478260869565, -0.25, 0.41666666666667
7776, 0.021739130434783, -0.25, 0.44444444444444
7777, 0.043478260869565, -0.25, 0.47222222222222
7778, 0.08695652173913, -0.25, 0.027777777777778
7779, 0.065217391304348, -0.25, 0.055555555555556
7780, 0.08695652173913, -0.25, 0.083333333333333
7781, 0.065217391304348, -0.25, 0.11111111111111
7782, 0.08695652173913, -0.25, 0.13888888888889
7783, 0.065217391304348, -0.25, 0.16666666666667
7784, 0.08695652173913, -0.25, 0.19444444444444
7785, 0.065217391304348, -0.25, 0.22222222222222
7786, 0.08695652173913, -0.25, 0.25
7787, 0.065217391304348, -0.25, 0.27777777777778
7788, 0.08695652173913, -0.25, 0.30555555555556
7789, 0.065217391304348, -0.25, 0.33333333333333
7790, 0.08695652173913, -0.25, 0.36111111111111
7791, 0.065217391304348, -0.25, 0.38888888888889
7792, 0.08695652173913, -0.25, 0.41666666666667
7793, 0.065217391304348, -0.25, 0.44444444444444
7794, 0.08695652173913, -0.25, 0.47222222222222
7795, 0.1304347826087, -0.25, 0.027777777777778
7796, 0.10869565217391, -0.25, 0.055555555555556
7797, 0.1304347826087, -0.25, 0.083333333333333
7798, 0.10869565217391, -0.25, 0.11111111111111
7799, 0.1304347826087, -0.25, 0.13888888888889
7800, 0.10869565217391, -0.25, 0.16666666666667
7801, 0.1304347826087, -0.25, 0.19444444444444
7802, 0.10869565217391, -0.25, 0.22222222222222
7803, 0.1304347826087, -0.25, 0.25
7804, 0.10869565217391, -0.25, 0.27777777777778
7805, 0.1304347826087, -0.25, 0.30555555555556
7806, 0.10869565217391, -0.25, 0.33333333333333
7807, 0.1304347826087, -0.25, 0.36111111111111
7808, 0.10869565217391, -0.25, 0.38888888888889
7809, 0.1304347826087, -0.25, 0.41666666666667
7810, 0.10869565217391, -0.25, 0.44444444444444
7811, 0.1304347826087, -0.25, 0.47222222222222
7812, 0.17391304347826, -0.25, 0.027777777777778
7813, 0.15217391304348, -0.25, 0.055555555555556
7814, 0.17391304347826, -0.25, 0.083333333333333
7815, 0.15217391304348, -0.25, 0.11111111111111
7816, 0.17391304347826, -0.25, 0.13888888888889
7817, 0.15217391304348, -0.25, 0.16666666666667
7818, 0.17391304347826, -0.25, 0.19444444444444
7819, 0.15217391304348, -0.25, 0.22222222222222
7820, 0.17391304347826, -0.25, 0.25
7821, 0.15217391304348, -0.25, 0.27777777777778
7822, 0.17391304347826, -0.25, 0.30555555555556
7823, 0.15217391304348, -0.25, 0.33333333333333
7824, 0.17391304347826, -0.25, 0.36111111111111
7825, 0.15217391304348, -0.25, 0.38888888888889
7826, 0.17391304347826, -0.25, 0.41666666666667
7827, 0.15217391304348, -0.25, 0.44444444444444
7828, 0.17391304347826, -0.25, 0.47222222222222
7829, 0.21739130434783, -0.25, 0.027777777777778
7830, 0.19565217391304, -0.25, 0.055555555555556
7831, 0.21739130434783, -0.25, 0.083333333333333
7832, 0.19565217391304, -0.25, 0.11111111111111
7833, 0.21739130434783, -0.25, 0.13888888888889
7834, 0.19565217391304, -0.25, 0.16666666666667
7835, 0.21739130434783, -0.25, 0.19444444444444
7836, 0.19565217391304, -0.25, 0.22222222222222
7837, 0.21739130434783, -0.25, 0.25
7838, 0.19565217391304, -0.25, 0.27777777777778
7839, 0.21739130434783, -0.25, 0.30555555555556
7840, 0.19565217391304, -0.25, 0.33333333333333
7841, 0.21739130434783, -0.25, 0.36111111111111
7842, 0.19565217391304, -0.25, 0.38888888888889
7843, 0.21739130434783, -0.25, 0.41666666666667
7844, 0.19565217391304, -0.25, 0.44444444444444
7845, 0.21739130434783, -0.25, 0.47222222222222
7846, 0.26086956521739, -0.25, 0.027777777777778
7847, 0.23913043478261, -0.25, 0.055555555555556
7848, 0.26086956521739, -0.25, 0.083333333333333
7849, 0.23913043478261, -0.25, 0.11111111111111
7850, 0.26086956521739, -0.25, 0.13888888888889
7851, 0.23913043478261, -0.25, 0.16666666666667
7852, 0.26086956521739, -0.25, 0.19444444444444
7853, 0.23913043478261, -0.25, 0.22222222222222
7854, 0.26086956521739, -0.25, 0.25
7855, 0.23913043478261, -0.25, 0.27777777777778
7856, 0.26086956521739, -0.25, 0.30555555555556
7857, 0.23913043478261, -0.25, 0.33333333333333
7858, 0.26086956521739, -0.25, 0.36111111111111
7859, 0.23913043478261, -0.25, 0.38888888888889
7860, 0.26086956521739, -0.25, 0.41666666666667
7861, 0.23913043478261, -0.25, 0.44444444444444
7862, 0.26086956521739, -0.25, 0.47222222222222
7863, 0.30434782608696, -0.25, 0.027777777777778
7864, 0.28260869565217, -0.25, 0.055555555555556
7865, 0.30434782608696, -0.25, 0.083333333333333
7866, 0.28260869565217, -0.25, 0.11111111111111
7867, 0.30434782608696, -0.25, 0.13888888888889
7868, 0.28260869565217, -0.25, 0.16666666666667
7869, 0.30434782608696, -0.25, 0.19444444444444
7870, 0.28260869565217, -0.25, 0.22222222222222
7871, 0.30434782608696, -0.25, 0.25
7872, 0.28260869565217, -0.25, 0.27777777777778
7873, 0.30434782608696, -0.25, 0.30555555555556
7874, 0.28260869565217, -0.25, 0.33333333333333
7875, 0.30434782608696, -0.25, 0.36111111111111
7876, 0.28260869565217, -0.25, 0.38888888888889
7877, 0.30434782608696, -0.25, 0.41666666666667
7878, 0.28260869565217, -0.25, 0.44444444444444
7879, 0.30434782608696, -0.25, 0.47222222222222
7880, 0.34782608695652, -0.25, 0.027777777777778
7881, 0.32608695652174, -0.25, 0.055555555555556
7882, 0.34782608695652, -0.25, 0.083333333333333
7883, 0.32608695652174, -0.25, 0.11111111111111
7884, 0.34782608695652, -0.25, 0.13888888888889
7885, 0.32608695652174, -0.25, 0.16666666666667
7886, 0.34782608695652, -0.25, 0.19444444444444
7887, 0.32608695652174, -0.25, 0.22222222222222
7888, 0.34782608695652, -0.25, 0.25
7889, 0.32608695652174, -0.25, 0.27777777777778
7890, 0.34782608695652, -0.25, 0.30555555555556
7891, 0.32608695652174, -0.25, 0.33333333333333
7892, 0.34782608695652, -0.25, 0.36111111111111
7893, 0.32608695652174, -0.25, 0.38888888888889
7894, 0.34782608695652, -0.25, 0.41666666666667
7895, 0.32608695652174, -0.25, 0.44444444444444
7896, 0.34782608695652, -0.25, 0.47222222222222
7897, 0.39130434782609, -0.25, 0.027777777777778
7898, 0.3695652173913, -0.25, 0.055555555555556
7899, 0.39130434782609, -0.25, 0.083333333333333
7900, 0.3695652173913, -0.25, 0.11111111111111
7901, 0.39130434782609, -0.25, 0.13888888888889
7902, 0.3695652173913, -0.25, 0.16666666666667
7903, 0.39130434782609, -0.25, 0.19444444444444
7904, 0.3695652173913, -0.25, 0.22222222222222
7905, 0.39130434782609, -0.25, 0.25
7906, 0.3695652173913, -0.25, 0.27777777777778
7907, 0.39130434782609, -0.25, 0.30555555555556
7908, 0.3695652173913, -0.25, 0.33333333333333
7909, 0.39130434782609, -0.25, 0.36111111111111
7910, 0.3695652173913, -0.25, 0.38888888888889
7911, 0.39130434782609, -0.25, 0.41666666666667
7912, 0.3695652173913, -0.25, 0.44444444444444
7913, 0.39130434782609, -0.25, 0.47222222222222
7914, 0.43478260869565, -0.25, 0.027777777777778
7915, 0.41304347826087, -0.25, 0.055555555555556
7916, 0.43478260869565, -0.25, 0.083333333333333
7917, 0.41304347826087, -0.25, 0.11111111111111
7918, 0.43478260869565, -0.25, 0.13888888888889
7919, 0.41304347826087, -0.25, 0.16666666666667
7920, 0.43478260869565, -0.25, 0.19444444444444
7921, 0.41304347826087, -0.25, 0.22222222222222
7922, 0.43478260869565, -0.25, 0.25
7923, 0.41304347826087, -0.25, 0.27777777777778
7924, 0.43478260869565, -0.25, 0.30555555555556
7925, 0.41304347826087, -0.25, 0.33333333333333
7926, 0.43478260869565, -0.25, 0.36111111111111
7927, 0.41304347826087, -0.25, 0.38888888888889
7928, 0.43478260869565, -0.25, 0.41666666666667
7929, 0.41304347826087, -0.25, 0.44444444444444
7930, 0.43478260869565, -0.25, 0.47222222222222
7931, 0.47826086956522, -0.25, 0.027777777777778
7932, 0.45652173913043, -0.25, 0.055555555555556
7933, 0.47826086956522, -0.25, 0.083333333333333
7934, 0.45652173913043, -0.25, 0.11111111111111
7935, 0.47826086956522, -0.25, 0.13888888888889
7936, 0.45652173913043, -0.25, 0.16666666666667
7937, 0.47826086956522, -0.25, 0.19444444444444
7938, 0.45652173913043, -0.25, 0.22222222222222
7939, 0.47826086956522, -0.25, 0.25
7940, 0.45652173913043, -0.25, 0.27777777777778
7941, 0.47826086956522, -0.25, 0.30555555555556
7942, 0.45652173913043, -0.25, 0.33333333333333
7943, 0.47826086956522, -0.25, 0.36111111111111
7944, 0.45652173913043, -0.25, 0.38888888888889
7945, 0.47826086956522, -0.25, 0.41666666666667
7946, 0.45652173913043, -0.25, 0.44444444444444
7947, 0.47826086956522, -0.25, 0.47222222222222
7948, 0.52173913043478, -0.25, 0.027777777777778
7949, 0.5, -0.25, 0.055555555555556
7950, 0.52173913043478, -0.25, 0.083333333333333
7951, 0.5, -0.25, 0.11111111111111
7952, 0.52173913043478, -0.25, 0.13888888888889
7953, 0.5, -0.25, 0.16666666666667
7954, 0.52173913043478, -0.25, 0.19444444444444
7955, 0.5, -0.25, 0.22222222222222
7956, 0.52173913043478, -0.25, 0.25
7957, 0.5, -0.25, 0.27777777777778
7958, 0.52173913043478, -0.25, 0.30555555555556
7959, 0.5, -0.25, 0.33333333333333
7960, 0.52173913043478, -0.25, 0.36111111111111
7961, 0.5, -0.25, 0.38888888888889
7962, 0.52173913043478, -0.25, 0.41666666666667
7963, 0.5, -0.25, 0.44444444444444
7964, 0.52173913043478, -0.25, 0.47222222222222
7965, 0.56521739130435, -0.25, 0.027777777777778
7966, 0.54347826086957, -0.25, 0.055555555555556
7967, 0.56521739130435, -0.25, 0.083333333333333
7968, 0.54347826086957, -0.25, 0.11111111111111
7969, 0.56521739130435, -0.25, 0.13888888888889
7970, 0.54347826086957, -0.25, 0.16666666666667
7971, 0.56521739130435, -0.25, 0.19444444444444
7972, 0.54347826086957, -0.25, 0.22222222222222
7973, 0.56521739130435, -0.25, 0.25
7974, 0.54347826086957, -0.25, 0.27777777777778
7975, 0.56521739130435, -0.25, 0.30555555555556
7976, 0.54347826086957, -0.25, 0.33333333333333
7977, 0.56521739130435, -0.25, 0.36111111111111
7978, 0.54347826086957, -0.25, 0.38888888888889
7979, 0.56521739130435, -0.25, 0.41666666666667
7980, 0.54347826086957, -0.25, 0.44444444444444
7981, 0.56521739130435, -0.25, 0.47222222222222
7982, 0.60869565217391, -0.25, 0.027777777777778
7983, 0.58695652173913, -0.25, 0.055555555555556
7984, 0.60869565217391, -0.25, 0.083333333333333
7985, 0.58695652173913, -0.25, 0.11111111111111
7986, 0.60869565217391, -0.25, 0.13888888888889
7987, 0.58695652173913, -0.25, 0.16666666666667
7988, 0.60869565217391, -0.25, 0.19444444444444
7989, 0.58695652173913, -0.25, 0.22222222222222
7990, 0.60869565217391, -0.25, 0.25
7991, 0.58695652173913, -0.25, 0.27777777777778
7992, 0.60869565217391, -0.25, 0.30555555555556
7993, 0.58695652173913, -0.25, 0.33333333333333
7994, 0.60869565217391, -0.25, 0.36111111111111
7995, 0.58695652173913, -0.25, 0.38888888888889
7996, 0.60869565217391, -0.25, 0.41666666666667
7997, 0.58695652173913, -0.25, 0.44444444444444
7998, 0.60869565217391, -0.25, 0.47222222222222
7999, 0.65217391304348, -0.25, 0.027777777777778
8000, 0.6304347826087, -0.25, 0.055555555555556
8001, 0.65217391304348, -0.25, 0.083333333333333
8002, 0.6304347826087, -0.25, 0.11111111111111
8003, 0.65217391304348, -0.25, 0.13888888888889
8004, 0.6304347826087, -0.25, 0.16666666666667
8005, 0.65217391304348, -0.25, 0.19444444444444
8006, 0.6304347826087, -0.25, 0.22222222222222
8007, 0.65217391304348, -0.25, 0.25
8008, 0.6304347826087, -0.25, 0.27777777777778
8009, 0.65217391304348, -0.25, 0.30555555555556
8010, 0.6304347826087, -0.25, 0.33333333333333
8011, 0.65217391304348, -0.25, 0.36111111111111
8012, 0.6304347826087, -0.25, 0.38888888888889
8013, 0.65217391304348, -0.25, 0.41666666666667
8014, 0.6304347826087, -0.25, 0.44444444444444
8015, 0.65217391304348, -0.25, 0.47222222222222
8016, 0.69565217391304, -0.25, 0.027777777777778
8017, 0.67391304347826, -0.25, 0.055555555555556
8018, 0.69565217391304, -0.25, 0.083333333333333
8019, 0.67391304347826, -0.25, 0.11111111111111
8020, 0.69565217391304, -0.25, 0.13888888888889
8021, 0.67391304347826, -0.25, 0.16666666666667
8022, 0.69565217391304, -0.25, 0.19444444444444
8023, 0.67391304347826, -0.25, 0.22222222222222
8024, 0.69565217391304, -0.25, 0.25
8025, 0.67391304347826, -0.25, 0.27777777777778
8026, 0.69565217391304, -0.25, 0.30555555555556
8027, 0.67391304347826, -0.25, 0.33333333333333
8028, 0.69565217391304, -0.25, 0.36111111111111
8029, 0.67391304347826, -0.25, 0.38888888888889
8030, 0.69565217391304, -0.25, 0.41666666666667
8031, 0.67391304347826, -0.25, 0.44444444444444
8032, 0.69565217391304, -0.25, 0.47222222222222
8033, 0.73913043478261, -0.25, 0.027777777777778
8034, 0.71739130434783, -0.25, 0.055555555555556
8035, 0.73913043478261, -0.25, 0.083333333333333
8036, 0.71739130434783, -0.25, 0.11111111111111
8037, 0.73913043478261, -0.25, 0.13888888888889
8038, 0.71739130434783, -0.25, 0.16666666666667
8039, 0.73913043478261, -0.25, 0.19444444444444
8040, 0.71739130434783, -0.25, 0.22222222222222
8041, 0.73913043478261, -0.25, 0.25
8042, 0.71739130434783, -0.25, 0.27777777777778
8043, 0.73913043478261, -0.25, 0.30555555555556
8044, 0.71739130434783, -0.25, 0.33333333333333
8045, 0.73913043478261, -0.25, 0.36111111111111
8046, 0.71739130434783, -0.25, 0.38888888888889
8047, 0.73913043478261, -0.25, 0.41666666666667
8048, 0.71739130434783, -0.25, 0.44444444444444
8049, 0.73913043478261, -0.25, 0.47222222222222
8050, 0.78260869565217, -0.25, 0.027777777777778
8051, 0.76086956521739, -0.25, 0.055555555555556
8052, 0.78260869565217, -0.25, 0.083333333333333
8053, 0.76086956521739, -0.25, 0.11111111111111
8054, 0.78260869565217, -0.25, 0.13888888888889
8055, 0.76086956521739, -0.25, 0.16666666666667
8056, 0.78260869565217, -0.25, 0.19444444444444
8057, 0.76086956521739, -0.25, 0.22222222222222
8058, 0.78260869565217, -0.25, 0.25
8059, 0.76086956521739, -0.25, 0.27777777777778
8060, 0.78260869565217, -0.25, 0.30555555555556
8061, 0.76086956521739, -0.25, 0.33333333333333
8062, 0.78260869565217, -0.25, 0.36111111111111
8063, 0.76086956521739, -0.25, 0.38888888888889
8064, 0.78260869565217, -0.25, 0.41666666666667
8065, 0.76086956521739, -0.25, 0.44444444444444
