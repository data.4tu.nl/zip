72261, 2.1565217391304, 0.56739130434783, 0.027777777777778
72262, 2.1782608695652, 0.56739130434783, 0.44444444444444
72263, 2.1782608695652, 0.56739130434783, 0.38888888888889
72264, 2.1782608695652, 0.56739130434783, 0.33333333333333
72265, 2.1782608695652, 0.56739130434783, 0.27777777777778
72266, 2.1782608695652, 0.56739130434783, 0.22222222222222
72267, 2.1782608695652, 0.56739130434783, 0.16666666666667
72268, 2.1782608695652, 0.56739130434783, 0.11111111111111
72269, 2.1782608695652, 0.56739130434783, 0.055555555555556
72270, 1.2434782608696, 0.51521739130435, 0.47222222222222
72271, 1.2217391304348, 0.51521739130435, 0.44444444444444
72272, 1.2434782608696, 0.54130434782609, 0.44444444444444
72273, 1.2434782608696, 0.51521739130435, 0.41666666666667
72274, 1.2217391304348, 0.51521739130435, 0.38888888888889
72275, 1.2434782608696, 0.54130434782609, 0.38888888888889
72276, 1.2434782608696, 0.51521739130435, 0.36111111111111
72277, 1.2217391304348, 0.51521739130435, 0.33333333333333
72278, 1.2434782608696, 0.54130434782609, 0.33333333333333
72279, 1.2434782608696, 0.51521739130435, 0.30555555555556
72280, 1.2217391304348, 0.51521739130435, 0.27777777777778
72281, 1.2434782608696, 0.54130434782609, 0.27777777777778
72282, 1.2434782608696, 0.51521739130435, 0.25
72283, 1.2217391304348, 0.51521739130435, 0.22222222222222
72284, 1.2434782608696, 0.54130434782609, 0.22222222222222
72285, 1.2434782608696, 0.51521739130435, 0.19444444444444
72286, 1.2217391304348, 0.51521739130435, 0.16666666666667
72287, 1.2434782608696, 0.54130434782609, 0.16666666666667
72288, 1.2434782608696, 0.51521739130435, 0.13888888888889
72289, 1.2217391304348, 0.51521739130435, 0.11111111111111
72290, 1.2434782608696, 0.54130434782609, 0.11111111111111
72291, 1.2434782608696, 0.51521739130435, 0.083333333333333
72292, 1.2217391304348, 0.51521739130435, 0.055555555555556
72293, 1.2434782608696, 0.54130434782609, 0.055555555555556
72294, 1.2434782608696, 0.51521739130435, 0.027777777777778
72295, 1.2869565217391, 0.51521739130435, 0.47222222222222
72296, 1.2652173913043, 0.51521739130435, 0.44444444444444
72297, 1.2869565217391, 0.54130434782609, 0.44444444444444
72298, 1.2869565217391, 0.51521739130435, 0.41666666666667
72299, 1.2652173913043, 0.51521739130435, 0.38888888888889
72300, 1.2869565217391, 0.54130434782609, 0.38888888888889
72301, 1.2869565217391, 0.51521739130435, 0.36111111111111
72302, 1.2652173913043, 0.51521739130435, 0.33333333333333
72303, 1.2869565217391, 0.54130434782609, 0.33333333333333
72304, 1.2869565217391, 0.51521739130435, 0.30555555555556
72305, 1.2652173913043, 0.51521739130435, 0.27777777777778
72306, 1.2869565217391, 0.54130434782609, 0.27777777777778
72307, 1.2869565217391, 0.51521739130435, 0.25
72308, 1.2652173913043, 0.51521739130435, 0.22222222222222
72309, 1.2869565217391, 0.54130434782609, 0.22222222222222
72310, 1.2869565217391, 0.51521739130435, 0.19444444444444
72311, 1.2652173913043, 0.51521739130435, 0.16666666666667
72312, 1.2869565217391, 0.54130434782609, 0.16666666666667
72313, 1.2869565217391, 0.51521739130435, 0.13888888888889
72314, 1.2652173913043, 0.51521739130435, 0.11111111111111
72315, 1.2869565217391, 0.54130434782609, 0.11111111111111
72316, 1.2869565217391, 0.51521739130435, 0.083333333333333
72317, 1.2652173913043, 0.51521739130435, 0.055555555555556
72318, 1.2869565217391, 0.54130434782609, 0.055555555555556
72319, 1.2869565217391, 0.51521739130435, 0.027777777777778
72320, 1.3304347826087, 0.51521739130435, 0.47222222222222
72321, 1.3086956521739, 0.51521739130435, 0.44444444444444
72322, 1.3304347826087, 0.54130434782609, 0.44444444444444
72323, 1.3304347826087, 0.51521739130435, 0.41666666666667
72324, 1.3086956521739, 0.51521739130435, 0.38888888888889
72325, 1.3304347826087, 0.54130434782609, 0.38888888888889
72326, 1.3304347826087, 0.51521739130435, 0.36111111111111
72327, 1.3086956521739, 0.51521739130435, 0.33333333333333
72328, 1.3304347826087, 0.54130434782609, 0.33333333333333
72329, 1.3304347826087, 0.51521739130435, 0.30555555555556
72330, 1.3086956521739, 0.51521739130435, 0.27777777777778
72331, 1.3304347826087, 0.54130434782609, 0.27777777777778
72332, 1.3304347826087, 0.51521739130435, 0.25
72333, 1.3086956521739, 0.51521739130435, 0.22222222222222
72334, 1.3304347826087, 0.54130434782609, 0.22222222222222
72335, 1.3304347826087, 0.51521739130435, 0.19444444444444
72336, 1.3086956521739, 0.51521739130435, 0.16666666666667
72337, 1.3304347826087, 0.54130434782609, 0.16666666666667
72338, 1.3304347826087, 0.51521739130435, 0.13888888888889
72339, 1.3086956521739, 0.51521739130435, 0.11111111111111
72340, 1.3304347826087, 0.54130434782609, 0.11111111111111
72341, 1.3304347826087, 0.51521739130435, 0.083333333333333
72342, 1.3086956521739, 0.51521739130435, 0.055555555555556
72343, 1.3304347826087, 0.54130434782609, 0.055555555555556
72344, 1.3304347826087, 0.51521739130435, 0.027777777777778
72345, 1.3739130434783, 0.51521739130435, 0.47222222222222
72346, 1.3521739130435, 0.51521739130435, 0.44444444444444
72347, 1.3739130434783, 0.54130434782609, 0.44444444444444
72348, 1.3739130434783, 0.51521739130435, 0.41666666666667
72349, 1.3521739130435, 0.51521739130435, 0.38888888888889
72350, 1.3739130434783, 0.54130434782609, 0.38888888888889
72351, 1.3739130434783, 0.51521739130435, 0.36111111111111
72352, 1.3521739130435, 0.51521739130435, 0.33333333333333
72353, 1.3739130434783, 0.54130434782609, 0.33333333333333
72354, 1.3739130434783, 0.51521739130435, 0.30555555555556
72355, 1.3521739130435, 0.51521739130435, 0.27777777777778
72356, 1.3739130434783, 0.54130434782609, 0.27777777777778
72357, 1.3739130434783, 0.51521739130435, 0.25
72358, 1.3521739130435, 0.51521739130435, 0.22222222222222
72359, 1.3739130434783, 0.54130434782609, 0.22222222222222
72360, 1.3739130434783, 0.51521739130435, 0.19444444444444
72361, 1.3521739130435, 0.51521739130435, 0.16666666666667
72362, 1.3739130434783, 0.54130434782609, 0.16666666666667
72363, 1.3739130434783, 0.51521739130435, 0.13888888888889
72364, 1.3521739130435, 0.51521739130435, 0.11111111111111
72365, 1.3739130434783, 0.54130434782609, 0.11111111111111
72366, 1.3739130434783, 0.51521739130435, 0.083333333333333
72367, 1.3521739130435, 0.51521739130435, 0.055555555555556
72368, 1.3739130434783, 0.54130434782609, 0.055555555555556
72369, 1.3739130434783, 0.51521739130435, 0.027777777777778
72370, 1.4173913043478, 0.51521739130435, 0.47222222222222
72371, 1.395652173913, 0.51521739130435, 0.44444444444444
72372, 1.4173913043478, 0.54130434782609, 0.44444444444444
72373, 1.4173913043478, 0.51521739130435, 0.41666666666667
72374, 1.395652173913, 0.51521739130435, 0.38888888888889
72375, 1.4173913043478, 0.54130434782609, 0.38888888888889
72376, 1.4173913043478, 0.51521739130435, 0.36111111111111
72377, 1.395652173913, 0.51521739130435, 0.33333333333333
72378, 1.4173913043478, 0.54130434782609, 0.33333333333333
72379, 1.4173913043478, 0.51521739130435, 0.30555555555556
72380, 1.395652173913, 0.51521739130435, 0.27777777777778
72381, 1.4173913043478, 0.54130434782609, 0.27777777777778
72382, 1.4173913043478, 0.51521739130435, 0.25
72383, 1.395652173913, 0.51521739130435, 0.22222222222222
72384, 1.4173913043478, 0.54130434782609, 0.22222222222222
72385, 1.4173913043478, 0.51521739130435, 0.19444444444444
72386, 1.395652173913, 0.51521739130435, 0.16666666666667
72387, 1.4173913043478, 0.54130434782609, 0.16666666666667
72388, 1.4173913043478, 0.51521739130435, 0.13888888888889
72389, 1.395652173913, 0.51521739130435, 0.11111111111111
72390, 1.4173913043478, 0.54130434782609, 0.11111111111111
72391, 1.4173913043478, 0.51521739130435, 0.083333333333333
72392, 1.395652173913, 0.51521739130435, 0.055555555555556
72393, 1.4173913043478, 0.54130434782609, 0.055555555555556
72394, 1.4173913043478, 0.51521739130435, 0.027777777777778
72395, 1.4608695652174, 0.51521739130435, 0.47222222222222
72396, 1.4391304347826, 0.51521739130435, 0.44444444444444
72397, 1.4608695652174, 0.54130434782609, 0.44444444444444
72398, 1.4608695652174, 0.51521739130435, 0.41666666666667
72399, 1.4391304347826, 0.51521739130435, 0.38888888888889
72400, 1.4608695652174, 0.54130434782609, 0.38888888888889
72401, 1.4608695652174, 0.51521739130435, 0.36111111111111
72402, 1.4391304347826, 0.51521739130435, 0.33333333333333
72403, 1.4608695652174, 0.54130434782609, 0.33333333333333
72404, 1.4608695652174, 0.51521739130435, 0.30555555555556
72405, 1.4391304347826, 0.51521739130435, 0.27777777777778
72406, 1.4608695652174, 0.54130434782609, 0.27777777777778
72407, 1.4608695652174, 0.51521739130435, 0.25
72408, 1.4391304347826, 0.51521739130435, 0.22222222222222
72409, 1.4608695652174, 0.54130434782609, 0.22222222222222
72410, 1.4608695652174, 0.51521739130435, 0.19444444444444
72411, 1.4391304347826, 0.51521739130435, 0.16666666666667
72412, 1.4608695652174, 0.54130434782609, 0.16666666666667
72413, 1.4608695652174, 0.51521739130435, 0.13888888888889
72414, 1.4391304347826, 0.51521739130435, 0.11111111111111
72415, 1.4608695652174, 0.54130434782609, 0.11111111111111
72416, 1.4608695652174, 0.51521739130435, 0.083333333333333
72417, 1.4391304347826, 0.51521739130435, 0.055555555555556
72418, 1.4608695652174, 0.54130434782609, 0.055555555555556
72419, 1.4608695652174, 0.51521739130435, 0.027777777777778
72420, 1.504347826087, 0.51521739130435, 0.47222222222222
72421, 1.4826086956522, 0.51521739130435, 0.44444444444444
72422, 1.504347826087, 0.54130434782609, 0.44444444444444
72423, 1.504347826087, 0.51521739130435, 0.41666666666667
72424, 1.4826086956522, 0.51521739130435, 0.38888888888889
72425, 1.504347826087, 0.54130434782609, 0.38888888888889
72426, 1.504347826087, 0.51521739130435, 0.36111111111111
72427, 1.4826086956522, 0.51521739130435, 0.33333333333333
72428, 1.504347826087, 0.54130434782609, 0.33333333333333
72429, 1.504347826087, 0.51521739130435, 0.30555555555556
72430, 1.4826086956522, 0.51521739130435, 0.27777777777778
72431, 1.504347826087, 0.54130434782609, 0.27777777777778
72432, 1.504347826087, 0.51521739130435, 0.25
72433, 1.4826086956522, 0.51521739130435, 0.22222222222222
72434, 1.504347826087, 0.54130434782609, 0.22222222222222
72435, 1.504347826087, 0.51521739130435, 0.19444444444444
72436, 1.4826086956522, 0.51521739130435, 0.16666666666667
72437, 1.504347826087, 0.54130434782609, 0.16666666666667
72438, 1.504347826087, 0.51521739130435, 0.13888888888889
72439, 1.4826086956522, 0.51521739130435, 0.11111111111111
72440, 1.504347826087, 0.54130434782609, 0.11111111111111
72441, 1.504347826087, 0.51521739130435, 0.083333333333333
72442, 1.4826086956522, 0.51521739130435, 0.055555555555556
72443, 1.504347826087, 0.54130434782609, 0.055555555555556
72444, 1.504347826087, 0.51521739130435, 0.027777777777778
72445, 1.5478260869565, 0.51521739130435, 0.47222222222222
72446, 1.5260869565217, 0.51521739130435, 0.44444444444444
72447, 1.5478260869565, 0.54130434782609, 0.44444444444444
72448, 1.5478260869565, 0.51521739130435, 0.41666666666667
72449, 1.5260869565217, 0.51521739130435, 0.38888888888889
72450, 1.5478260869565, 0.54130434782609, 0.38888888888889
72451, 1.5478260869565, 0.51521739130435, 0.36111111111111
72452, 1.5260869565217, 0.51521739130435, 0.33333333333333
72453, 1.5478260869565, 0.54130434782609, 0.33333333333333
72454, 1.5478260869565, 0.51521739130435, 0.30555555555556
72455, 1.5260869565217, 0.51521739130435, 0.27777777777778
72456, 1.5478260869565, 0.54130434782609, 0.27777777777778
72457, 1.5478260869565, 0.51521739130435, 0.25
72458, 1.5260869565217, 0.51521739130435, 0.22222222222222
72459, 1.5478260869565, 0.54130434782609, 0.22222222222222
72460, 1.5478260869565, 0.51521739130435, 0.19444444444444
72461, 1.5260869565217, 0.51521739130435, 0.16666666666667
72462, 1.5478260869565, 0.54130434782609, 0.16666666666667
72463, 1.5478260869565, 0.51521739130435, 0.13888888888889
72464, 1.5260869565217, 0.51521739130435, 0.11111111111111
72465, 1.5478260869565, 0.54130434782609, 0.11111111111111
72466, 1.5478260869565, 0.51521739130435, 0.083333333333333
72467, 1.5260869565217, 0.51521739130435, 0.055555555555556
72468, 1.5478260869565, 0.54130434782609, 0.055555555555556
72469, 1.5478260869565, 0.51521739130435, 0.027777777777778
72470, 1.5913043478261, 0.51521739130435, 0.47222222222222
72471, 1.5695652173913, 0.51521739130435, 0.44444444444444
72472, 1.5913043478261, 0.54130434782609, 0.44444444444444
72473, 1.5913043478261, 0.51521739130435, 0.41666666666667
72474, 1.5695652173913, 0.51521739130435, 0.38888888888889
72475, 1.5913043478261, 0.54130434782609, 0.38888888888889
72476, 1.5913043478261, 0.51521739130435, 0.36111111111111
72477, 1.5695652173913, 0.51521739130435, 0.33333333333333
72478, 1.5913043478261, 0.54130434782609, 0.33333333333333
72479, 1.5913043478261, 0.51521739130435, 0.30555555555556
72480, 1.5695652173913, 0.51521739130435, 0.27777777777778
72481, 1.5913043478261, 0.54130434782609, 0.27777777777778
72482, 1.5913043478261, 0.51521739130435, 0.25
72483, 1.5695652173913, 0.51521739130435, 0.22222222222222
72484, 1.5913043478261, 0.54130434782609, 0.22222222222222
72485, 1.5913043478261, 0.51521739130435, 0.19444444444444
72486, 1.5695652173913, 0.51521739130435, 0.16666666666667
72487, 1.5913043478261, 0.54130434782609, 0.16666666666667
72488, 1.5913043478261, 0.51521739130435, 0.13888888888889
72489, 1.5695652173913, 0.51521739130435, 0.11111111111111
72490, 1.5913043478261, 0.54130434782609, 0.11111111111111
72491, 1.5913043478261, 0.51521739130435, 0.083333333333333
72492, 1.5695652173913, 0.51521739130435, 0.055555555555556
72493, 1.5913043478261, 0.54130434782609, 0.055555555555556
72494, 1.5913043478261, 0.51521739130435, 0.027777777777778
72495, 1.6347826086957, 0.51521739130435, 0.47222222222222
72496, 1.6130434782609, 0.51521739130435, 0.44444444444444
72497, 1.6347826086957, 0.54130434782609, 0.44444444444444
72498, 1.6347826086957, 0.51521739130435, 0.41666666666667
72499, 1.6130434782609, 0.51521739130435, 0.38888888888889
72500, 1.6347826086957, 0.54130434782609, 0.38888888888889
72501, 1.6347826086957, 0.51521739130435, 0.36111111111111
72502, 1.6130434782609, 0.51521739130435, 0.33333333333333
72503, 1.6347826086957, 0.54130434782609, 0.33333333333333
72504, 1.6347826086957, 0.51521739130435, 0.30555555555556
72505, 1.6130434782609, 0.51521739130435, 0.27777777777778
72506, 1.6347826086957, 0.54130434782609, 0.27777777777778
72507, 1.6347826086957, 0.51521739130435, 0.25
72508, 1.6130434782609, 0.51521739130435, 0.22222222222222
72509, 1.6347826086957, 0.54130434782609, 0.22222222222222
72510, 1.6347826086957, 0.51521739130435, 0.19444444444444
72511, 1.6130434782609, 0.51521739130435, 0.16666666666667
72512, 1.6347826086957, 0.54130434782609, 0.16666666666667
72513, 1.6347826086957, 0.51521739130435, 0.13888888888889
72514, 1.6130434782609, 0.51521739130435, 0.11111111111111
72515, 1.6347826086957, 0.54130434782609, 0.11111111111111
72516, 1.6347826086957, 0.51521739130435, 0.083333333333333
72517, 1.6130434782609, 0.51521739130435, 0.055555555555556
72518, 1.6347826086957, 0.54130434782609, 0.055555555555556
72519, 1.6347826086957, 0.51521739130435, 0.027777777777778
72520, 1.6782608695652, 0.51521739130435, 0.47222222222222
72521, 1.6565217391304, 0.51521739130435, 0.44444444444444
72522, 1.6782608695652, 0.54130434782609, 0.44444444444444
72523, 1.6782608695652, 0.51521739130435, 0.41666666666667
72524, 1.6565217391304, 0.51521739130435, 0.38888888888889
72525, 1.6782608695652, 0.54130434782609, 0.38888888888889
72526, 1.6782608695652, 0.51521739130435, 0.36111111111111
72527, 1.6565217391304, 0.51521739130435, 0.33333333333333
72528, 1.6782608695652, 0.54130434782609, 0.33333333333333
72529, 1.6782608695652, 0.51521739130435, 0.30555555555556
72530, 1.6565217391304, 0.51521739130435, 0.27777777777778
72531, 1.6782608695652, 0.54130434782609, 0.27777777777778
72532, 1.6782608695652, 0.51521739130435, 0.25
72533, 1.6565217391304, 0.51521739130435, 0.22222222222222
72534, 1.6782608695652, 0.54130434782609, 0.22222222222222
72535, 1.6782608695652, 0.51521739130435, 0.19444444444444
72536, 1.6565217391304, 0.51521739130435, 0.16666666666667
72537, 1.6782608695652, 0.54130434782609, 0.16666666666667
72538, 1.6782608695652, 0.51521739130435, 0.13888888888889
72539, 1.6565217391304, 0.51521739130435, 0.11111111111111
72540, 1.6782608695652, 0.54130434782609, 0.11111111111111
72541, 1.6782608695652, 0.51521739130435, 0.083333333333333
72542, 1.6565217391304, 0.51521739130435, 0.055555555555556
72543, 1.6782608695652, 0.54130434782609, 0.055555555555556
72544, 1.6782608695652, 0.51521739130435, 0.027777777777778
72545, 1.7217391304348, 0.51521739130435, 0.47222222222222
72546, 1.7, 0.51521739130435, 0.44444444444444
72547, 1.7217391304348, 0.54130434782609, 0.44444444444444
72548, 1.7217391304348, 0.51521739130435, 0.41666666666667
72549, 1.7, 0.51521739130435, 0.38888888888889
72550, 1.7217391304348, 0.54130434782609, 0.38888888888889
72551, 1.7217391304348, 0.51521739130435, 0.36111111111111
72552, 1.7, 0.51521739130435, 0.33333333333333
72553, 1.7217391304348, 0.54130434782609, 0.33333333333333
72554, 1.7217391304348, 0.51521739130435, 0.30555555555556
72555, 1.7, 0.51521739130435, 0.27777777777778
72556, 1.7217391304348, 0.54130434782609, 0.27777777777778
72557, 1.7217391304348, 0.51521739130435, 0.25
72558, 1.7, 0.51521739130435, 0.22222222222222
72559, 1.7217391304348, 0.54130434782609, 0.22222222222222
72560, 1.7217391304348, 0.51521739130435, 0.19444444444444
72561, 1.7, 0.51521739130435, 0.16666666666667
72562, 1.7217391304348, 0.54130434782609, 0.16666666666667
72563, 1.7217391304348, 0.51521739130435, 0.13888888888889
72564, 1.7, 0.51521739130435, 0.11111111111111
72565, 1.7217391304348, 0.54130434782609, 0.11111111111111
72566, 1.7217391304348, 0.51521739130435, 0.083333333333333
72567, 1.7, 0.51521739130435, 0.055555555555556
72568, 1.7217391304348, 0.54130434782609, 0.055555555555556
72569, 1.7217391304348, 0.51521739130435, 0.027777777777778
72570, 1.7652173913043, 0.51521739130435, 0.47222222222222
72571, 1.7434782608696, 0.51521739130435, 0.44444444444444
72572, 1.7652173913043, 0.54130434782609, 0.44444444444444
72573, 1.7652173913043, 0.51521739130435, 0.41666666666667
72574, 1.7434782608696, 0.51521739130435, 0.38888888888889
72575, 1.7652173913043, 0.54130434782609, 0.38888888888889
72576, 1.7652173913043, 0.51521739130435, 0.36111111111111
72577, 1.7434782608696, 0.51521739130435, 0.33333333333333
72578, 1.7652173913043, 0.54130434782609, 0.33333333333333
72579, 1.7652173913043, 0.51521739130435, 0.30555555555556
72580, 1.7434782608696, 0.51521739130435, 0.27777777777778
72581, 1.7652173913043, 0.54130434782609, 0.27777777777778
72582, 1.7652173913043, 0.51521739130435, 0.25
72583, 1.7434782608696, 0.51521739130435, 0.22222222222222
72584, 1.7652173913043, 0.54130434782609, 0.22222222222222
72585, 1.7652173913043, 0.51521739130435, 0.19444444444444
72586, 1.7434782608696, 0.51521739130435, 0.16666666666667
72587, 1.7652173913043, 0.54130434782609, 0.16666666666667
72588, 1.7652173913043, 0.51521739130435, 0.13888888888889
72589, 1.7434782608696, 0.51521739130435, 0.11111111111111
72590, 1.7652173913043, 0.54130434782609, 0.11111111111111
72591, 1.7652173913043, 0.51521739130435, 0.083333333333333
72592, 1.7434782608696, 0.51521739130435, 0.055555555555556
72593, 1.7652173913043, 0.54130434782609, 0.055555555555556
72594, 1.7652173913043, 0.51521739130435, 0.027777777777778
72595, 1.8086956521739, 0.51521739130435, 0.47222222222222
72596, 1.7869565217391, 0.51521739130435, 0.44444444444444
72597, 1.8086956521739, 0.54130434782609, 0.44444444444444
72598, 1.8086956521739, 0.51521739130435, 0.41666666666667
72599, 1.7869565217391, 0.51521739130435, 0.38888888888889
72600, 1.8086956521739, 0.54130434782609, 0.38888888888889
72601, 1.8086956521739, 0.51521739130435, 0.36111111111111
72602, 1.7869565217391, 0.51521739130435, 0.33333333333333
72603, 1.8086956521739, 0.54130434782609, 0.33333333333333
72604, 1.8086956521739, 0.51521739130435, 0.30555555555556
72605, 1.7869565217391, 0.51521739130435, 0.27777777777778
72606, 1.8086956521739, 0.54130434782609, 0.27777777777778
72607, 1.8086956521739, 0.51521739130435, 0.25
72608, 1.7869565217391, 0.51521739130435, 0.22222222222222
72609, 1.8086956521739, 0.54130434782609, 0.22222222222222
72610, 1.8086956521739, 0.51521739130435, 0.19444444444444
72611, 1.7869565217391, 0.51521739130435, 0.16666666666667
72612, 1.8086956521739, 0.54130434782609, 0.16666666666667
72613, 1.8086956521739, 0.51521739130435, 0.13888888888889
72614, 1.7869565217391, 0.51521739130435, 0.11111111111111
72615, 1.8086956521739, 0.54130434782609, 0.11111111111111
72616, 1.8086956521739, 0.51521739130435, 0.083333333333333
72617, 1.7869565217391, 0.51521739130435, 0.055555555555556
72618, 1.8086956521739, 0.54130434782609, 0.055555555555556
72619, 1.8086956521739, 0.51521739130435, 0.027777777777778
72620, 1.8521739130435, 0.51521739130435, 0.47222222222222
72621, 1.8304347826087, 0.51521739130435, 0.44444444444444
72622, 1.8521739130435, 0.54130434782609, 0.44444444444444
72623, 1.8521739130435, 0.51521739130435, 0.41666666666667
72624, 1.8304347826087, 0.51521739130435, 0.38888888888889
72625, 1.8521739130435, 0.54130434782609, 0.38888888888889
72626, 1.8521739130435, 0.51521739130435, 0.36111111111111
72627, 1.8304347826087, 0.51521739130435, 0.33333333333333
72628, 1.8521739130435, 0.54130434782609, 0.33333333333333
72629, 1.8521739130435, 0.51521739130435, 0.30555555555556
72630, 1.8304347826087, 0.51521739130435, 0.27777777777778
72631, 1.8521739130435, 0.54130434782609, 0.27777777777778
72632, 1.8521739130435, 0.51521739130435, 0.25
72633, 1.8304347826087, 0.51521739130435, 0.22222222222222
72634, 1.8521739130435, 0.54130434782609, 0.22222222222222
72635, 1.8521739130435, 0.51521739130435, 0.19444444444444
72636, 1.8304347826087, 0.51521739130435, 0.16666666666667
72637, 1.8521739130435, 0.54130434782609, 0.16666666666667
72638, 1.8521739130435, 0.51521739130435, 0.13888888888889
72639, 1.8304347826087, 0.51521739130435, 0.11111111111111
72640, 1.8521739130435, 0.54130434782609, 0.11111111111111
72641, 1.8521739130435, 0.51521739130435, 0.083333333333333
72642, 1.8304347826087, 0.51521739130435, 0.055555555555556
72643, 1.8521739130435, 0.54130434782609, 0.055555555555556
72644, 1.8521739130435, 0.51521739130435, 0.027777777777778
72645, 1.895652173913, 0.51521739130435, 0.47222222222222
72646, 1.8739130434783, 0.51521739130435, 0.44444444444444
72647, 1.895652173913, 0.54130434782609, 0.44444444444444
72648, 1.895652173913, 0.51521739130435, 0.41666666666667
72649, 1.8739130434783, 0.51521739130435, 0.38888888888889
72650, 1.895652173913, 0.54130434782609, 0.38888888888889
72651, 1.895652173913, 0.51521739130435, 0.36111111111111
72652, 1.8739130434783, 0.51521739130435, 0.33333333333333
72653, 1.895652173913, 0.54130434782609, 0.33333333333333
72654, 1.895652173913, 0.51521739130435, 0.30555555555556
72655, 1.8739130434783, 0.51521739130435, 0.27777777777778
72656, 1.895652173913, 0.54130434782609, 0.27777777777778
72657, 1.895652173913, 0.51521739130435, 0.25
72658, 1.8739130434783, 0.51521739130435, 0.22222222222222
72659, 1.895652173913, 0.54130434782609, 0.22222222222222
72660, 1.895652173913, 0.51521739130435, 0.19444444444444
72661, 1.8739130434783, 0.51521739130435, 0.16666666666667
72662, 1.895652173913, 0.54130434782609, 0.16666666666667
72663, 1.895652173913, 0.51521739130435, 0.13888888888889
72664, 1.8739130434783, 0.51521739130435, 0.11111111111111
72665, 1.895652173913, 0.54130434782609, 0.11111111111111
72666, 1.895652173913, 0.51521739130435, 0.083333333333333
72667, 1.8739130434783, 0.51521739130435, 0.055555555555556
72668, 1.895652173913, 0.54130434782609, 0.055555555555556
72669, 1.895652173913, 0.51521739130435, 0.027777777777778
72670, 1.9391304347826, 0.51521739130435, 0.47222222222222
72671, 1.9173913043478, 0.51521739130435, 0.44444444444444
72672, 1.9391304347826, 0.54130434782609, 0.44444444444444
72673, 1.9391304347826, 0.51521739130435, 0.41666666666667
72674, 1.9173913043478, 0.51521739130435, 0.38888888888889
72675, 1.9391304347826, 0.54130434782609, 0.38888888888889
72676, 1.9391304347826, 0.51521739130435, 0.36111111111111
72677, 1.9173913043478, 0.51521739130435, 0.33333333333333
72678, 1.9391304347826, 0.54130434782609, 0.33333333333333
72679, 1.9391304347826, 0.51521739130435, 0.30555555555556
72680, 1.9173913043478, 0.51521739130435, 0.27777777777778
72681, 1.9391304347826, 0.54130434782609, 0.27777777777778
72682, 1.9391304347826, 0.51521739130435, 0.25
72683, 1.9173913043478, 0.51521739130435, 0.22222222222222
72684, 1.9391304347826, 0.54130434782609, 0.22222222222222
72685, 1.9391304347826, 0.51521739130435, 0.19444444444444
72686, 1.9173913043478, 0.51521739130435, 0.16666666666667
72687, 1.9391304347826, 0.54130434782609, 0.16666666666667
72688, 1.9391304347826, 0.51521739130435, 0.13888888888889
72689, 1.9173913043478, 0.51521739130435, 0.11111111111111
72690, 1.9391304347826, 0.54130434782609, 0.11111111111111
72691, 1.9391304347826, 0.51521739130435, 0.083333333333333
72692, 1.9173913043478, 0.51521739130435, 0.055555555555556
72693, 1.9391304347826, 0.54130434782609, 0.055555555555556
72694, 1.9391304347826, 0.51521739130435, 0.027777777777778
72695, 1.9826086956522, 0.51521739130435, 0.47222222222222
72696, 1.9608695652174, 0.51521739130435, 0.44444444444444
72697, 1.9826086956522, 0.54130434782609, 0.44444444444444
72698, 1.9826086956522, 0.51521739130435, 0.41666666666667
72699, 1.9608695652174, 0.51521739130435, 0.38888888888889
72700, 1.9826086956522, 0.54130434782609, 0.38888888888889
72701, 1.9826086956522, 0.51521739130435, 0.36111111111111
72702, 1.9608695652174, 0.51521739130435, 0.33333333333333
72703, 1.9826086956522, 0.54130434782609, 0.33333333333333
72704, 1.9826086956522, 0.51521739130435, 0.30555555555556
72705, 1.9608695652174, 0.51521739130435, 0.27777777777778
72706, 1.9826086956522, 0.54130434782609, 0.27777777777778
72707, 1.9826086956522, 0.51521739130435, 0.25
72708, 1.9608695652174, 0.51521739130435, 0.22222222222222
72709, 1.9826086956522, 0.54130434782609, 0.22222222222222
72710, 1.9826086956522, 0.51521739130435, 0.19444444444444
72711, 1.9608695652174, 0.51521739130435, 0.16666666666667
72712, 1.9826086956522, 0.54130434782609, 0.16666666666667
72713, 1.9826086956522, 0.51521739130435, 0.13888888888889
72714, 1.9608695652174, 0.51521739130435, 0.11111111111111
72715, 1.9826086956522, 0.54130434782609, 0.11111111111111
72716, 1.9826086956522, 0.51521739130435, 0.083333333333333
72717, 1.9608695652174, 0.51521739130435, 0.055555555555556
72718, 1.9826086956522, 0.54130434782609, 0.055555555555556
72719, 1.9826086956522, 0.51521739130435, 0.027777777777778
72720, 2.0260869565217, 0.51521739130435, 0.47222222222222
72721, 2.004347826087, 0.51521739130435, 0.44444444444444
72722, 2.0260869565217, 0.54130434782609, 0.44444444444444
72723, 2.0260869565217, 0.51521739130435, 0.41666666666667
72724, 2.004347826087, 0.51521739130435, 0.38888888888889
72725, 2.0260869565217, 0.54130434782609, 0.38888888888889
72726, 2.0260869565217, 0.51521739130435, 0.36111111111111
72727, 2.004347826087, 0.51521739130435, 0.33333333333333
72728, 2.0260869565217, 0.54130434782609, 0.33333333333333
72729, 2.0260869565217, 0.51521739130435, 0.30555555555556
72730, 2.004347826087, 0.51521739130435, 0.27777777777778
72731, 2.0260869565217, 0.54130434782609, 0.27777777777778
72732, 2.0260869565217, 0.51521739130435, 0.25
72733, 2.004347826087, 0.51521739130435, 0.22222222222222
72734, 2.0260869565217, 0.54130434782609, 0.22222222222222
72735, 2.0260869565217, 0.51521739130435, 0.19444444444444
72736, 2.004347826087, 0.51521739130435, 0.16666666666667
72737, 2.0260869565217, 0.54130434782609, 0.16666666666667
72738, 2.0260869565217, 0.51521739130435, 0.13888888888889
72739, 2.004347826087, 0.51521739130435, 0.11111111111111
72740, 2.0260869565217, 0.54130434782609, 0.11111111111111
72741, 2.0260869565217, 0.51521739130435, 0.083333333333333
72742, 2.004347826087, 0.51521739130435, 0.055555555555556
72743, 2.0260869565217, 0.54130434782609, 0.055555555555556
72744, 2.0260869565217, 0.51521739130435, 0.027777777777778
72745, 2.0695652173913, 0.51521739130435, 0.47222222222222
72746, 2.0478260869565, 0.51521739130435, 0.44444444444444
72747, 2.0695652173913, 0.54130434782609, 0.44444444444444
72748, 2.0695652173913, 0.51521739130435, 0.41666666666667
72749, 2.0478260869565, 0.51521739130435, 0.38888888888889
72750, 2.0695652173913, 0.54130434782609, 0.38888888888889
72751, 2.0695652173913, 0.51521739130435, 0.36111111111111
72752, 2.0478260869565, 0.51521739130435, 0.33333333333333
72753, 2.0695652173913, 0.54130434782609, 0.33333333333333
72754, 2.0695652173913, 0.51521739130435, 0.30555555555556
72755, 2.0478260869565, 0.51521739130435, 0.27777777777778
72756, 2.0695652173913, 0.54130434782609, 0.27777777777778
72757, 2.0695652173913, 0.51521739130435, 0.25
72758, 2.0478260869565, 0.51521739130435, 0.22222222222222
72759, 2.0695652173913, 0.54130434782609, 0.22222222222222
72760, 2.0695652173913, 0.51521739130435, 0.19444444444444
72761, 2.0478260869565, 0.51521739130435, 0.16666666666667
72762, 2.0695652173913, 0.54130434782609, 0.16666666666667
72763, 2.0695652173913, 0.51521739130435, 0.13888888888889
72764, 2.0478260869565, 0.51521739130435, 0.11111111111111
72765, 2.0695652173913, 0.54130434782609, 0.11111111111111
72766, 2.0695652173913, 0.51521739130435, 0.083333333333333
72767, 2.0478260869565, 0.51521739130435, 0.055555555555556
72768, 2.0695652173913, 0.54130434782609, 0.055555555555556
72769, 2.0695652173913, 0.51521739130435, 0.027777777777778
72770, 2.1130434782609, 0.51521739130435, 0.47222222222222
72771, 2.0913043478261, 0.51521739130435, 0.44444444444444
72772, 2.1130434782609, 0.54130434782609, 0.44444444444444
72773, 2.1130434782609, 0.51521739130435, 0.41666666666667
72774, 2.0913043478261, 0.51521739130435, 0.38888888888889
72775, 2.1130434782609, 0.54130434782609, 0.38888888888889
72776, 2.1130434782609, 0.51521739130435, 0.36111111111111
72777, 2.0913043478261, 0.51521739130435, 0.33333333333333
72778, 2.1130434782609, 0.54130434782609, 0.33333333333333
72779, 2.1130434782609, 0.51521739130435, 0.30555555555556
72780, 2.0913043478261, 0.51521739130435, 0.27777777777778
72781, 2.1130434782609, 0.54130434782609, 0.27777777777778
72782, 2.1130434782609, 0.51521739130435, 0.25
72783, 2.0913043478261, 0.51521739130435, 0.22222222222222
72784, 2.1130434782609, 0.54130434782609, 0.22222222222222
72785, 2.1130434782609, 0.51521739130435, 0.19444444444444
72786, 2.0913043478261, 0.51521739130435, 0.16666666666667
72787, 2.1130434782609, 0.54130434782609, 0.16666666666667
72788, 2.1130434782609, 0.51521739130435, 0.13888888888889
72789, 2.0913043478261, 0.51521739130435, 0.11111111111111
72790, 2.1130434782609, 0.54130434782609, 0.11111111111111
72791, 2.1130434782609, 0.51521739130435, 0.083333333333333
72792, 2.0913043478261, 0.51521739130435, 0.055555555555556
72793, 2.1130434782609, 0.54130434782609, 0.055555555555556
72794, 2.1130434782609, 0.51521739130435, 0.027777777777778
72795, 2.1565217391304, 0.51521739130435, 0.47222222222222
72796, 2.1347826086957, 0.51521739130435, 0.44444444444444
72797, 2.1565217391304, 0.54130434782609, 0.44444444444444
72798, 2.1565217391304, 0.51521739130435, 0.41666666666667
72799, 2.1347826086957, 0.51521739130435, 0.38888888888889
72800, 2.1565217391304, 0.54130434782609, 0.38888888888889
72801, 2.1565217391304, 0.51521739130435, 0.36111111111111
72802, 2.1347826086957, 0.51521739130435, 0.33333333333333
72803, 2.1565217391304, 0.54130434782609, 0.33333333333333
72804, 2.1565217391304, 0.51521739130435, 0.30555555555556
72805, 2.1347826086957, 0.51521739130435, 0.27777777777778
72806, 2.1565217391304, 0.54130434782609, 0.27777777777778
72807, 2.1565217391304, 0.51521739130435, 0.25
72808, 2.1347826086957, 0.51521739130435, 0.22222222222222
72809, 2.1565217391304, 0.54130434782609, 0.22222222222222
72810, 2.1565217391304, 0.51521739130435, 0.19444444444444
72811, 2.1347826086957, 0.51521739130435, 0.16666666666667
72812, 2.1565217391304, 0.54130434782609, 0.16666666666667
72813, 2.1565217391304, 0.51521739130435, 0.13888888888889
72814, 2.1347826086957, 0.51521739130435, 0.11111111111111
72815, 2.1565217391304, 0.54130434782609, 0.11111111111111
72816, 2.1565217391304, 0.51521739130435, 0.083333333333333
72817, 2.1347826086957, 0.51521739130435, 0.055555555555556
72818, 2.1565217391304, 0.54130434782609, 0.055555555555556
72819, 2.1565217391304, 0.51521739130435, 0.027777777777778
72820, 2.1782608695652, 0.51521739130435, 0.44444444444444
72821, 2.1782608695652, 0.51521739130435, 0.38888888888889
72822, 2.1782608695652, 0.51521739130435, 0.33333333333333
72823, 2.1782608695652, 0.51521739130435, 0.27777777777778
72824, 2.1782608695652, 0.51521739130435, 0.22222222222222
72825, 2.1782608695652, 0.51521739130435, 0.16666666666667
72826, 2.1782608695652, 0.51521739130435, 0.11111111111111
72827, 2.1782608695652, 0.51521739130435, 0.055555555555556
72828, 1.2434782608696, 0.46304347826087, 0.47222222222222
72829, 1.2217391304348, 0.46304347826087, 0.44444444444444
72830, 1.2434782608696, 0.48913043478261, 0.44444444444444
72831, 1.2434782608696, 0.46304347826087, 0.41666666666667
72832, 1.2217391304348, 0.46304347826087, 0.38888888888889
72833, 1.2434782608696, 0.48913043478261, 0.38888888888889
72834, 1.2434782608696, 0.46304347826087, 0.36111111111111
72835, 1.2217391304348, 0.46304347826087, 0.33333333333333
72836, 1.2434782608696, 0.48913043478261, 0.33333333333333
72837, 1.2434782608696, 0.46304347826087, 0.30555555555556
72838, 1.2217391304348, 0.46304347826087, 0.27777777777778
72839, 1.2434782608696, 0.48913043478261, 0.27777777777778
72840, 1.2434782608696, 0.46304347826087, 0.25
72841, 1.2217391304348, 0.46304347826087, 0.22222222222222
72842, 1.2434782608696, 0.48913043478261, 0.22222222222222
72843, 1.2434782608696, 0.46304347826087, 0.19444444444444
72844, 1.2217391304348, 0.46304347826087, 0.16666666666667
72845, 1.2434782608696, 0.48913043478261, 0.16666666666667
72846, 1.2434782608696, 0.46304347826087, 0.13888888888889
72847, 1.2217391304348, 0.46304347826087, 0.11111111111111
72848, 1.2434782608696, 0.48913043478261, 0.11111111111111
72849, 1.2434782608696, 0.46304347826087, 0.083333333333333
72850, 1.2217391304348, 0.46304347826087, 0.055555555555556
72851, 1.2434782608696, 0.48913043478261, 0.055555555555556
72852, 1.2434782608696, 0.46304347826087, 0.027777777777778
72853, 1.2869565217391, 0.46304347826087, 0.47222222222222
72854, 1.2652173913043, 0.46304347826087, 0.44444444444444
72855, 1.2869565217391, 0.48913043478261, 0.44444444444444
72856, 1.2869565217391, 0.46304347826087, 0.41666666666667
72857, 1.2652173913043, 0.46304347826087, 0.38888888888889
72858, 1.2869565217391, 0.48913043478261, 0.38888888888889
72859, 1.2869565217391, 0.46304347826087, 0.36111111111111
72860, 1.2652173913043, 0.46304347826087, 0.33333333333333
72861, 1.2869565217391, 0.48913043478261, 0.33333333333333
72862, 1.2869565217391, 0.46304347826087, 0.30555555555556
72863, 1.2652173913043, 0.46304347826087, 0.27777777777778
72864, 1.2869565217391, 0.48913043478261, 0.27777777777778
72865, 1.2869565217391, 0.46304347826087, 0.25
72866, 1.2652173913043, 0.46304347826087, 0.22222222222222
72867, 1.2869565217391, 0.48913043478261, 0.22222222222222
72868, 1.2869565217391, 0.46304347826087, 0.19444444444444
72869, 1.2652173913043, 0.46304347826087, 0.16666666666667
72870, 1.2869565217391, 0.48913043478261, 0.16666666666667
72871, 1.2869565217391, 0.46304347826087, 0.13888888888889
72872, 1.2652173913043, 0.46304347826087, 0.11111111111111
72873, 1.2869565217391, 0.48913043478261, 0.11111111111111
72874, 1.2869565217391, 0.46304347826087, 0.083333333333333
72875, 1.2652173913043, 0.46304347826087, 0.055555555555556
72876, 1.2869565217391, 0.48913043478261, 0.055555555555556
72877, 1.2869565217391, 0.46304347826087, 0.027777777777778
72878, 1.3304347826087, 0.46304347826087, 0.47222222222222
72879, 1.3086956521739, 0.46304347826087, 0.44444444444444
72880, 1.3304347826087, 0.48913043478261, 0.44444444444444
72881, 1.3304347826087, 0.46304347826087, 0.41666666666667
72882, 1.3086956521739, 0.46304347826087, 0.38888888888889
72883, 1.3304347826087, 0.48913043478261, 0.38888888888889
72884, 1.3304347826087, 0.46304347826087, 0.36111111111111
72885, 1.3086956521739, 0.46304347826087, 0.33333333333333
72886, 1.3304347826087, 0.48913043478261, 0.33333333333333
72887, 1.3304347826087, 0.46304347826087, 0.30555555555556
72888, 1.3086956521739, 0.46304347826087, 0.27777777777778
72889, 1.3304347826087, 0.48913043478261, 0.27777777777778
72890, 1.3304347826087, 0.46304347826087, 0.25
72891, 1.3086956521739, 0.46304347826087, 0.22222222222222
72892, 1.3304347826087, 0.48913043478261, 0.22222222222222
72893, 1.3304347826087, 0.46304347826087, 0.19444444444444
72894, 1.3086956521739, 0.46304347826087, 0.16666666666667
72895, 1.3304347826087, 0.48913043478261, 0.16666666666667
72896, 1.3304347826087, 0.46304347826087, 0.13888888888889
72897, 1.3086956521739, 0.46304347826087, 0.11111111111111
72898, 1.3304347826087, 0.48913043478261, 0.11111111111111
72899, 1.3304347826087, 0.46304347826087, 0.083333333333333
72900, 1.3086956521739, 0.46304347826087, 0.055555555555556
72901, 1.3304347826087, 0.48913043478261, 0.055555555555556
72902, 1.3304347826087, 0.46304347826087, 0.027777777777778
72903, 1.3739130434783, 0.46304347826087, 0.47222222222222
72904, 1.3521739130435, 0.46304347826087, 0.44444444444444
72905, 1.3739130434783, 0.48913043478261, 0.44444444444444
72906, 1.3739130434783, 0.46304347826087, 0.41666666666667
72907, 1.3521739130435, 0.46304347826087, 0.38888888888889
72908, 1.3739130434783, 0.48913043478261, 0.38888888888889
72909, 1.3739130434783, 0.46304347826087, 0.36111111111111
72910, 1.3521739130435, 0.46304347826087, 0.33333333333333
72911, 1.3739130434783, 0.48913043478261, 0.33333333333333
72912, 1.3739130434783, 0.46304347826087, 0.30555555555556
72913, 1.3521739130435, 0.46304347826087, 0.27777777777778
72914, 1.3739130434783, 0.48913043478261, 0.27777777777778
72915, 1.3739130434783, 0.46304347826087, 0.25
72916, 1.3521739130435, 0.46304347826087, 0.22222222222222
72917, 1.3739130434783, 0.48913043478261, 0.22222222222222
72918, 1.3739130434783, 0.46304347826087, 0.19444444444444
72919, 1.3521739130435, 0.46304347826087, 0.16666666666667
72920, 1.3739130434783, 0.48913043478261, 0.16666666666667
72921, 1.3739130434783, 0.46304347826087, 0.13888888888889
72922, 1.3521739130435, 0.46304347826087, 0.11111111111111
72923, 1.3739130434783, 0.48913043478261, 0.11111111111111
72924, 1.3739130434783, 0.46304347826087, 0.083333333333333
72925, 1.3521739130435, 0.46304347826087, 0.055555555555556
72926, 1.3739130434783, 0.48913043478261, 0.055555555555556
72927, 1.3739130434783, 0.46304347826087, 0.027777777777778
72928, 1.4173913043478, 0.46304347826087, 0.47222222222222
72929, 1.395652173913, 0.46304347826087, 0.44444444444444
72930, 1.4173913043478, 0.48913043478261, 0.44444444444444
72931, 1.4173913043478, 0.46304347826087, 0.41666666666667
72932, 1.395652173913, 0.46304347826087, 0.38888888888889
72933, 1.4173913043478, 0.48913043478261, 0.38888888888889
72934, 1.4173913043478, 0.46304347826087, 0.36111111111111
72935, 1.395652173913, 0.46304347826087, 0.33333333333333
72936, 1.4173913043478, 0.48913043478261, 0.33333333333333
72937, 1.4173913043478, 0.46304347826087, 0.30555555555556
72938, 1.395652173913, 0.46304347826087, 0.27777777777778
72939, 1.4173913043478, 0.48913043478261, 0.27777777777778
72940, 1.4173913043478, 0.46304347826087, 0.25
72941, 1.395652173913, 0.46304347826087, 0.22222222222222
72942, 1.4173913043478, 0.48913043478261, 0.22222222222222
72943, 1.4173913043478, 0.46304347826087, 0.19444444444444
72944, 1.395652173913, 0.46304347826087, 0.16666666666667
72945, 1.4173913043478, 0.48913043478261, 0.16666666666667
72946, 1.4173913043478, 0.46304347826087, 0.13888888888889
72947, 1.395652173913, 0.46304347826087, 0.11111111111111
72948, 1.4173913043478, 0.48913043478261, 0.11111111111111
72949, 1.4173913043478, 0.46304347826087, 0.083333333333333
72950, 1.395652173913, 0.46304347826087, 0.055555555555556
72951, 1.4173913043478, 0.48913043478261, 0.055555555555556
72952, 1.4173913043478, 0.46304347826087, 0.027777777777778
72953, 1.4608695652174, 0.46304347826087, 0.47222222222222
72954, 1.4391304347826, 0.46304347826087, 0.44444444444444
72955, 1.4608695652174, 0.48913043478261, 0.44444444444444
72956, 1.4608695652174, 0.46304347826087, 0.41666666666667
72957, 1.4391304347826, 0.46304347826087, 0.38888888888889
72958, 1.4608695652174, 0.48913043478261, 0.38888888888889
72959, 1.4608695652174, 0.46304347826087, 0.36111111111111
72960, 1.4391304347826, 0.46304347826087, 0.33333333333333
72961, 1.4608695652174, 0.48913043478261, 0.33333333333333
72962, 1.4608695652174, 0.46304347826087, 0.30555555555556
72963, 1.4391304347826, 0.46304347826087, 0.27777777777778
72964, 1.4608695652174, 0.48913043478261, 0.27777777777778
72965, 1.4608695652174, 0.46304347826087, 0.25
72966, 1.4391304347826, 0.46304347826087, 0.22222222222222
72967, 1.4608695652174, 0.48913043478261, 0.22222222222222
72968, 1.4608695652174, 0.46304347826087, 0.19444444444444
72969, 1.4391304347826, 0.46304347826087, 0.16666666666667
72970, 1.4608695652174, 0.48913043478261, 0.16666666666667
72971, 1.4608695652174, 0.46304347826087, 0.13888888888889
72972, 1.4391304347826, 0.46304347826087, 0.11111111111111
72973, 1.4608695652174, 0.48913043478261, 0.11111111111111
72974, 1.4608695652174, 0.46304347826087, 0.083333333333333
72975, 1.4391304347826, 0.46304347826087, 0.055555555555556
72976, 1.4608695652174, 0.48913043478261, 0.055555555555556
72977, 1.4608695652174, 0.46304347826087, 0.027777777777778
72978, 1.504347826087, 0.46304347826087, 0.47222222222222
72979, 1.4826086956522, 0.46304347826087, 0.44444444444444
72980, 1.504347826087, 0.48913043478261, 0.44444444444444
72981, 1.504347826087, 0.46304347826087, 0.41666666666667
72982, 1.4826086956522, 0.46304347826087, 0.38888888888889
72983, 1.504347826087, 0.48913043478261, 0.38888888888889
72984, 1.504347826087, 0.46304347826087, 0.36111111111111
72985, 1.4826086956522, 0.46304347826087, 0.33333333333333
72986, 1.504347826087, 0.48913043478261, 0.33333333333333
72987, 1.504347826087, 0.46304347826087, 0.30555555555556
72988, 1.4826086956522, 0.46304347826087, 0.27777777777778
72989, 1.504347826087, 0.48913043478261, 0.27777777777778
72990, 1.504347826087, 0.46304347826087, 0.25
72991, 1.4826086956522, 0.46304347826087, 0.22222222222222
72992, 1.504347826087, 0.48913043478261, 0.22222222222222
72993, 1.504347826087, 0.46304347826087, 0.19444444444444
72994, 1.4826086956522, 0.46304347826087, 0.16666666666667
72995, 1.504347826087, 0.48913043478261, 0.16666666666667
72996, 1.504347826087, 0.46304347826087, 0.13888888888889
72997, 1.4826086956522, 0.46304347826087, 0.11111111111111
72998, 1.504347826087, 0.48913043478261, 0.11111111111111
72999, 1.504347826087, 0.46304347826087, 0.083333333333333
73000, 1.4826086956522, 0.46304347826087, 0.055555555555556
73001, 1.504347826087, 0.48913043478261, 0.055555555555556
73002, 1.504347826087, 0.46304347826087, 0.027777777777778
73003, 1.5478260869565, 0.46304347826087, 0.47222222222222
73004, 1.5260869565217, 0.46304347826087, 0.44444444444444
73005, 1.5478260869565, 0.48913043478261, 0.44444444444444
73006, 1.5478260869565, 0.46304347826087, 0.41666666666667
73007, 1.5260869565217, 0.46304347826087, 0.38888888888889
73008, 1.5478260869565, 0.48913043478261, 0.38888888888889
73009, 1.5478260869565, 0.46304347826087, 0.36111111111111
73010, 1.5260869565217, 0.46304347826087, 0.33333333333333
73011, 1.5478260869565, 0.48913043478261, 0.33333333333333
73012, 1.5478260869565, 0.46304347826087, 0.30555555555556
73013, 1.5260869565217, 0.46304347826087, 0.27777777777778
73014, 1.5478260869565, 0.48913043478261, 0.27777777777778
73015, 1.5478260869565, 0.46304347826087, 0.25
73016, 1.5260869565217, 0.46304347826087, 0.22222222222222
73017, 1.5478260869565, 0.48913043478261, 0.22222222222222
73018, 1.5478260869565, 0.46304347826087, 0.19444444444444
73019, 1.5260869565217, 0.46304347826087, 0.16666666666667
73020, 1.5478260869565, 0.48913043478261, 0.16666666666667
73021, 1.5478260869565, 0.46304347826087, 0.13888888888889
73022, 1.5260869565217, 0.46304347826087, 0.11111111111111
73023, 1.5478260869565, 0.48913043478261, 0.11111111111111
73024, 1.5478260869565, 0.46304347826087, 0.083333333333333
73025, 1.5260869565217, 0.46304347826087, 0.055555555555556
73026, 1.5478260869565, 0.48913043478261, 0.055555555555556
73027, 1.5478260869565, 0.46304347826087, 0.027777777777778
73028, 1.5913043478261, 0.46304347826087, 0.47222222222222
73029, 1.5695652173913, 0.46304347826087, 0.44444444444444
73030, 1.5913043478261, 0.48913043478261, 0.44444444444444
73031, 1.5913043478261, 0.46304347826087, 0.41666666666667
73032, 1.5695652173913, 0.46304347826087, 0.38888888888889
73033, 1.5913043478261, 0.48913043478261, 0.38888888888889
73034, 1.5913043478261, 0.46304347826087, 0.36111111111111
73035, 1.5695652173913, 0.46304347826087, 0.33333333333333
73036, 1.5913043478261, 0.48913043478261, 0.33333333333333
73037, 1.5913043478261, 0.46304347826087, 0.30555555555556
73038, 1.5695652173913, 0.46304347826087, 0.27777777777778
73039, 1.5913043478261, 0.48913043478261, 0.27777777777778
73040, 1.5913043478261, 0.46304347826087, 0.25
73041, 1.5695652173913, 0.46304347826087, 0.22222222222222
73042, 1.5913043478261, 0.48913043478261, 0.22222222222222
73043, 1.5913043478261, 0.46304347826087, 0.19444444444444
73044, 1.5695652173913, 0.46304347826087, 0.16666666666667
73045, 1.5913043478261, 0.48913043478261, 0.16666666666667
73046, 1.5913043478261, 0.46304347826087, 0.13888888888889
73047, 1.5695652173913, 0.46304347826087, 0.11111111111111
73048, 1.5913043478261, 0.48913043478261, 0.11111111111111
73049, 1.5913043478261, 0.46304347826087, 0.083333333333333
73050, 1.5695652173913, 0.46304347826087, 0.055555555555556
73051, 1.5913043478261, 0.48913043478261, 0.055555555555556
73052, 1.5913043478261, 0.46304347826087, 0.027777777777778
73053, 1.6347826086957, 0.46304347826087, 0.47222222222222
73054, 1.6130434782609, 0.46304347826087, 0.44444444444444
73055, 1.6347826086957, 0.48913043478261, 0.44444444444444
73056, 1.6347826086957, 0.46304347826087, 0.41666666666667
73057, 1.6130434782609, 0.46304347826087, 0.38888888888889
73058, 1.6347826086957, 0.48913043478261, 0.38888888888889
73059, 1.6347826086957, 0.46304347826087, 0.36111111111111
73060, 1.6130434782609, 0.46304347826087, 0.33333333333333
73061, 1.6347826086957, 0.48913043478261, 0.33333333333333
73062, 1.6347826086957, 0.46304347826087, 0.30555555555556
73063, 1.6130434782609, 0.46304347826087, 0.27777777777778
73064, 1.6347826086957, 0.48913043478261, 0.27777777777778
73065, 1.6347826086957, 0.46304347826087, 0.25
73066, 1.6130434782609, 0.46304347826087, 0.22222222222222
73067, 1.6347826086957, 0.48913043478261, 0.22222222222222
73068, 1.6347826086957, 0.46304347826087, 0.19444444444444
73069, 1.6130434782609, 0.46304347826087, 0.16666666666667
73070, 1.6347826086957, 0.48913043478261, 0.16666666666667
73071, 1.6347826086957, 0.46304347826087, 0.13888888888889
73072, 1.6130434782609, 0.46304347826087, 0.11111111111111
73073, 1.6347826086957, 0.48913043478261, 0.11111111111111
73074, 1.6347826086957, 0.46304347826087, 0.083333333333333
73075, 1.6130434782609, 0.46304347826087, 0.055555555555556
73076, 1.6347826086957, 0.48913043478261, 0.055555555555556
73077, 1.6347826086957, 0.46304347826087, 0.027777777777778
73078, 1.6782608695652, 0.46304347826087, 0.47222222222222
73079, 1.6565217391304, 0.46304347826087, 0.44444444444444
73080, 1.6782608695652, 0.48913043478261, 0.44444444444444
73081, 1.6782608695652, 0.46304347826087, 0.41666666666667
73082, 1.6565217391304, 0.46304347826087, 0.38888888888889
73083, 1.6782608695652, 0.48913043478261, 0.38888888888889
73084, 1.6782608695652, 0.46304347826087, 0.36111111111111
73085, 1.6565217391304, 0.46304347826087, 0.33333333333333
73086, 1.6782608695652, 0.48913043478261, 0.33333333333333
73087, 1.6782608695652, 0.46304347826087, 0.30555555555556
73088, 1.6565217391304, 0.46304347826087, 0.27777777777778
73089, 1.6782608695652, 0.48913043478261, 0.27777777777778
73090, 1.6782608695652, 0.46304347826087, 0.25
73091, 1.6565217391304, 0.46304347826087, 0.22222222222222
73092, 1.6782608695652, 0.48913043478261, 0.22222222222222
73093, 1.6782608695652, 0.46304347826087, 0.19444444444444
73094, 1.6565217391304, 0.46304347826087, 0.16666666666667
73095, 1.6782608695652, 0.48913043478261, 0.16666666666667
73096, 1.6782608695652, 0.46304347826087, 0.13888888888889
73097, 1.6565217391304, 0.46304347826087, 0.11111111111111
73098, 1.6782608695652, 0.48913043478261, 0.11111111111111
73099, 1.6782608695652, 0.46304347826087, 0.083333333333333
73100, 1.6565217391304, 0.46304347826087, 0.055555555555556
73101, 1.6782608695652, 0.48913043478261, 0.055555555555556
73102, 1.6782608695652, 0.46304347826087, 0.027777777777778
73103, 1.7217391304348, 0.46304347826087, 0.47222222222222
73104, 1.7, 0.46304347826087, 0.44444444444444
73105, 1.7217391304348, 0.48913043478261, 0.44444444444444
73106, 1.7217391304348, 0.46304347826087, 0.41666666666667
73107, 1.7, 0.46304347826087, 0.38888888888889
73108, 1.7217391304348, 0.48913043478261, 0.38888888888889
73109, 1.7217391304348, 0.46304347826087, 0.36111111111111
73110, 1.7, 0.46304347826087, 0.33333333333333
73111, 1.7217391304348, 0.48913043478261, 0.33333333333333
73112, 1.7217391304348, 0.46304347826087, 0.30555555555556
73113, 1.7, 0.46304347826087, 0.27777777777778
73114, 1.7217391304348, 0.48913043478261, 0.27777777777778
73115, 1.7217391304348, 0.46304347826087, 0.25
73116, 1.7, 0.46304347826087, 0.22222222222222
73117, 1.7217391304348, 0.48913043478261, 0.22222222222222
73118, 1.7217391304348, 0.46304347826087, 0.19444444444444
73119, 1.7, 0.46304347826087, 0.16666666666667
73120, 1.7217391304348, 0.48913043478261, 0.16666666666667
73121, 1.7217391304348, 0.46304347826087, 0.13888888888889
73122, 1.7, 0.46304347826087, 0.11111111111111
73123, 1.7217391304348, 0.48913043478261, 0.11111111111111
73124, 1.7217391304348, 0.46304347826087, 0.083333333333333
73125, 1.7, 0.46304347826087, 0.055555555555556
73126, 1.7217391304348, 0.48913043478261, 0.055555555555556
73127, 1.7217391304348, 0.46304347826087, 0.027777777777778
73128, 1.7652173913043, 0.46304347826087, 0.47222222222222
73129, 1.7434782608696, 0.46304347826087, 0.44444444444444
73130, 1.7652173913043, 0.48913043478261, 0.44444444444444
73131, 1.7652173913043, 0.46304347826087, 0.41666666666667
73132, 1.7434782608696, 0.46304347826087, 0.38888888888889
73133, 1.7652173913043, 0.48913043478261, 0.38888888888889
73134, 1.7652173913043, 0.46304347826087, 0.36111111111111
73135, 1.7434782608696, 0.46304347826087, 0.33333333333333
73136, 1.7652173913043, 0.48913043478261, 0.33333333333333
73137, 1.7652173913043, 0.46304347826087, 0.30555555555556
73138, 1.7434782608696, 0.46304347826087, 0.27777777777778
73139, 1.7652173913043, 0.48913043478261, 0.27777777777778
73140, 1.7652173913043, 0.46304347826087, 0.25
73141, 1.7434782608696, 0.46304347826087, 0.22222222222222
73142, 1.7652173913043, 0.48913043478261, 0.22222222222222
73143, 1.7652173913043, 0.46304347826087, 0.19444444444444
73144, 1.7434782608696, 0.46304347826087, 0.16666666666667
73145, 1.7652173913043, 0.48913043478261, 0.16666666666667
73146, 1.7652173913043, 0.46304347826087, 0.13888888888889
73147, 1.7434782608696, 0.46304347826087, 0.11111111111111
73148, 1.7652173913043, 0.48913043478261, 0.11111111111111
73149, 1.7652173913043, 0.46304347826087, 0.083333333333333
73150, 1.7434782608696, 0.46304347826087, 0.055555555555556
73151, 1.7652173913043, 0.48913043478261, 0.055555555555556
73152, 1.7652173913043, 0.46304347826087, 0.027777777777778
73153, 1.8086956521739, 0.46304347826087, 0.47222222222222
73154, 1.7869565217391, 0.46304347826087, 0.44444444444444
73155, 1.8086956521739, 0.48913043478261, 0.44444444444444
73156, 1.8086956521739, 0.46304347826087, 0.41666666666667
73157, 1.7869565217391, 0.46304347826087, 0.38888888888889
73158, 1.8086956521739, 0.48913043478261, 0.38888888888889
73159, 1.8086956521739, 0.46304347826087, 0.36111111111111
73160, 1.7869565217391, 0.46304347826087, 0.33333333333333
73161, 1.8086956521739, 0.48913043478261, 0.33333333333333
73162, 1.8086956521739, 0.46304347826087, 0.30555555555556
73163, 1.7869565217391, 0.46304347826087, 0.27777777777778
73164, 1.8086956521739, 0.48913043478261, 0.27777777777778
73165, 1.8086956521739, 0.46304347826087, 0.25
73166, 1.7869565217391, 0.46304347826087, 0.22222222222222
73167, 1.8086956521739, 0.48913043478261, 0.22222222222222
73168, 1.8086956521739, 0.46304347826087, 0.19444444444444
73169, 1.7869565217391, 0.46304347826087, 0.16666666666667
73170, 1.8086956521739, 0.48913043478261, 0.16666666666667
73171, 1.8086956521739, 0.46304347826087, 0.13888888888889
73172, 1.7869565217391, 0.46304347826087, 0.11111111111111
73173, 1.8086956521739, 0.48913043478261, 0.11111111111111
73174, 1.8086956521739, 0.46304347826087, 0.083333333333333
73175, 1.7869565217391, 0.46304347826087, 0.055555555555556
73176, 1.8086956521739, 0.48913043478261, 0.055555555555556
73177, 1.8086956521739, 0.46304347826087, 0.027777777777778
73178, 1.8521739130435, 0.46304347826087, 0.47222222222222
73179, 1.8304347826087, 0.46304347826087, 0.44444444444444
73180, 1.8521739130435, 0.48913043478261, 0.44444444444444
73181, 1.8521739130435, 0.46304347826087, 0.41666666666667
73182, 1.8304347826087, 0.46304347826087, 0.38888888888889
73183, 1.8521739130435, 0.48913043478261, 0.38888888888889
73184, 1.8521739130435, 0.46304347826087, 0.36111111111111
73185, 1.8304347826087, 0.46304347826087, 0.33333333333333
73186, 1.8521739130435, 0.48913043478261, 0.33333333333333
73187, 1.8521739130435, 0.46304347826087, 0.30555555555556
73188, 1.8304347826087, 0.46304347826087, 0.27777777777778
73189, 1.8521739130435, 0.48913043478261, 0.27777777777778
73190, 1.8521739130435, 0.46304347826087, 0.25
73191, 1.8304347826087, 0.46304347826087, 0.22222222222222
73192, 1.8521739130435, 0.48913043478261, 0.22222222222222
73193, 1.8521739130435, 0.46304347826087, 0.19444444444444
73194, 1.8304347826087, 0.46304347826087, 0.16666666666667
73195, 1.8521739130435, 0.48913043478261, 0.16666666666667
73196, 1.8521739130435, 0.46304347826087, 0.13888888888889
73197, 1.8304347826087, 0.46304347826087, 0.11111111111111
73198, 1.8521739130435, 0.48913043478261, 0.11111111111111
73199, 1.8521739130435, 0.46304347826087, 0.083333333333333
73200, 1.8304347826087, 0.46304347826087, 0.055555555555556
73201, 1.8521739130435, 0.48913043478261, 0.055555555555556
73202, 1.8521739130435, 0.46304347826087, 0.027777777777778
73203, 1.895652173913, 0.46304347826087, 0.47222222222222
73204, 1.8739130434783, 0.46304347826087, 0.44444444444444
73205, 1.895652173913, 0.48913043478261, 0.44444444444444
73206, 1.895652173913, 0.46304347826087, 0.41666666666667
73207, 1.8739130434783, 0.46304347826087, 0.38888888888889
73208, 1.895652173913, 0.48913043478261, 0.38888888888889
73209, 1.895652173913, 0.46304347826087, 0.36111111111111
73210, 1.8739130434783, 0.46304347826087, 0.33333333333333
73211, 1.895652173913, 0.48913043478261, 0.33333333333333
73212, 1.895652173913, 0.46304347826087, 0.30555555555556
73213, 1.8739130434783, 0.46304347826087, 0.27777777777778
73214, 1.895652173913, 0.48913043478261, 0.27777777777778
73215, 1.895652173913, 0.46304347826087, 0.25
73216, 1.8739130434783, 0.46304347826087, 0.22222222222222
73217, 1.895652173913, 0.48913043478261, 0.22222222222222
73218, 1.895652173913, 0.46304347826087, 0.19444444444444
73219, 1.8739130434783, 0.46304347826087, 0.16666666666667
73220, 1.895652173913, 0.48913043478261, 0.16666666666667
73221, 1.895652173913, 0.46304347826087, 0.13888888888889
73222, 1.8739130434783, 0.46304347826087, 0.11111111111111
73223, 1.895652173913, 0.48913043478261, 0.11111111111111
73224, 1.895652173913, 0.46304347826087, 0.083333333333333
73225, 1.8739130434783, 0.46304347826087, 0.055555555555556
73226, 1.895652173913, 0.48913043478261, 0.055555555555556
73227, 1.895652173913, 0.46304347826087, 0.027777777777778
73228, 1.9391304347826, 0.46304347826087, 0.47222222222222
73229, 1.9173913043478, 0.46304347826087, 0.44444444444444
73230, 1.9391304347826, 0.48913043478261, 0.44444444444444
73231, 1.9391304347826, 0.46304347826087, 0.41666666666667
73232, 1.9173913043478, 0.46304347826087, 0.38888888888889
73233, 1.9391304347826, 0.48913043478261, 0.38888888888889
73234, 1.9391304347826, 0.46304347826087, 0.36111111111111
73235, 1.9173913043478, 0.46304347826087, 0.33333333333333
73236, 1.9391304347826, 0.48913043478261, 0.33333333333333
73237, 1.9391304347826, 0.46304347826087, 0.30555555555556
73238, 1.9173913043478, 0.46304347826087, 0.27777777777778
73239, 1.9391304347826, 0.48913043478261, 0.27777777777778
73240, 1.9391304347826, 0.46304347826087, 0.25
73241, 1.9173913043478, 0.46304347826087, 0.22222222222222
73242, 1.9391304347826, 0.48913043478261, 0.22222222222222
73243, 1.9391304347826, 0.46304347826087, 0.19444444444444
73244, 1.9173913043478, 0.46304347826087, 0.16666666666667
73245, 1.9391304347826, 0.48913043478261, 0.16666666666667
73246, 1.9391304347826, 0.46304347826087, 0.13888888888889
73247, 1.9173913043478, 0.46304347826087, 0.11111111111111
73248, 1.9391304347826, 0.48913043478261, 0.11111111111111
73249, 1.9391304347826, 0.46304347826087, 0.083333333333333
73250, 1.9173913043478, 0.46304347826087, 0.055555555555556
73251, 1.9391304347826, 0.48913043478261, 0.055555555555556
73252, 1.9391304347826, 0.46304347826087, 0.027777777777778
73253, 1.9826086956522, 0.46304347826087, 0.47222222222222
73254, 1.9608695652174, 0.46304347826087, 0.44444444444444
73255, 1.9826086956522, 0.48913043478261, 0.44444444444444
73256, 1.9826086956522, 0.46304347826087, 0.41666666666667
73257, 1.9608695652174, 0.46304347826087, 0.38888888888889
73258, 1.9826086956522, 0.48913043478261, 0.38888888888889
73259, 1.9826086956522, 0.46304347826087, 0.36111111111111
73260, 1.9608695652174, 0.46304347826087, 0.33333333333333
73261, 1.9826086956522, 0.48913043478261, 0.33333333333333
73262, 1.9826086956522, 0.46304347826087, 0.30555555555556
73263, 1.9608695652174, 0.46304347826087, 0.27777777777778
73264, 1.9826086956522, 0.48913043478261, 0.27777777777778
73265, 1.9826086956522, 0.46304347826087, 0.25
73266, 1.9608695652174, 0.46304347826087, 0.22222222222222
73267, 1.9826086956522, 0.48913043478261, 0.22222222222222
73268, 1.9826086956522, 0.46304347826087, 0.19444444444444
73269, 1.9608695652174, 0.46304347826087, 0.16666666666667
73270, 1.9826086956522, 0.48913043478261, 0.16666666666667
73271, 1.9826086956522, 0.46304347826087, 0.13888888888889
73272, 1.9608695652174, 0.46304347826087, 0.11111111111111
73273, 1.9826086956522, 0.48913043478261, 0.11111111111111
73274, 1.9826086956522, 0.46304347826087, 0.083333333333333
73275, 1.9608695652174, 0.46304347826087, 0.055555555555556
73276, 1.9826086956522, 0.48913043478261, 0.055555555555556
73277, 1.9826086956522, 0.46304347826087, 0.027777777777778
73278, 2.0260869565217, 0.46304347826087, 0.47222222222222
73279, 2.004347826087, 0.46304347826087, 0.44444444444444
73280, 2.0260869565217, 0.48913043478261, 0.44444444444444
73281, 2.0260869565217, 0.46304347826087, 0.41666666666667
73282, 2.004347826087, 0.46304347826087, 0.38888888888889
73283, 2.0260869565217, 0.48913043478261, 0.38888888888889
73284, 2.0260869565217, 0.46304347826087, 0.36111111111111
73285, 2.004347826087, 0.46304347826087, 0.33333333333333
73286, 2.0260869565217, 0.48913043478261, 0.33333333333333
73287, 2.0260869565217, 0.46304347826087, 0.30555555555556
73288, 2.004347826087, 0.46304347826087, 0.27777777777778
73289, 2.0260869565217, 0.48913043478261, 0.27777777777778
73290, 2.0260869565217, 0.46304347826087, 0.25
73291, 2.004347826087, 0.46304347826087, 0.22222222222222
73292, 2.0260869565217, 0.48913043478261, 0.22222222222222
73293, 2.0260869565217, 0.46304347826087, 0.19444444444444
73294, 2.004347826087, 0.46304347826087, 0.16666666666667
73295, 2.0260869565217, 0.48913043478261, 0.16666666666667
73296, 2.0260869565217, 0.46304347826087, 0.13888888888889
73297, 2.004347826087, 0.46304347826087, 0.11111111111111
73298, 2.0260869565217, 0.48913043478261, 0.11111111111111
73299, 2.0260869565217, 0.46304347826087, 0.083333333333333
73300, 2.004347826087, 0.46304347826087, 0.055555555555556
73301, 2.0260869565217, 0.48913043478261, 0.055555555555556
73302, 2.0260869565217, 0.46304347826087, 0.027777777777778
73303, 2.0695652173913, 0.46304347826087, 0.47222222222222
73304, 2.0478260869565, 0.46304347826087, 0.44444444444444
73305, 2.0695652173913, 0.48913043478261, 0.44444444444444
73306, 2.0695652173913, 0.46304347826087, 0.41666666666667
73307, 2.0478260869565, 0.46304347826087, 0.38888888888889
73308, 2.0695652173913, 0.48913043478261, 0.38888888888889
73309, 2.0695652173913, 0.46304347826087, 0.36111111111111
73310, 2.0478260869565, 0.46304347826087, 0.33333333333333
73311, 2.0695652173913, 0.48913043478261, 0.33333333333333
73312, 2.0695652173913, 0.46304347826087, 0.30555555555556
73313, 2.0478260869565, 0.46304347826087, 0.27777777777778
73314, 2.0695652173913, 0.48913043478261, 0.27777777777778
73315, 2.0695652173913, 0.46304347826087, 0.25
73316, 2.0478260869565, 0.46304347826087, 0.22222222222222
73317, 2.0695652173913, 0.48913043478261, 0.22222222222222
73318, 2.0695652173913, 0.46304347826087, 0.19444444444444
73319, 2.0478260869565, 0.46304347826087, 0.16666666666667
73320, 2.0695652173913, 0.48913043478261, 0.16666666666667
73321, 2.0695652173913, 0.46304347826087, 0.13888888888889
73322, 2.0478260869565, 0.46304347826087, 0.11111111111111
73323, 2.0695652173913, 0.48913043478261, 0.11111111111111
73324, 2.0695652173913, 0.46304347826087, 0.083333333333333
73325, 2.0478260869565, 0.46304347826087, 0.055555555555556
73326, 2.0695652173913, 0.48913043478261, 0.055555555555556
73327, 2.0695652173913, 0.46304347826087, 0.027777777777778
73328, 2.1130434782609, 0.46304347826087, 0.47222222222222
73329, 2.0913043478261, 0.46304347826087, 0.44444444444444
73330, 2.1130434782609, 0.48913043478261, 0.44444444444444
73331, 2.1130434782609, 0.46304347826087, 0.41666666666667
73332, 2.0913043478261, 0.46304347826087, 0.38888888888889
73333, 2.1130434782609, 0.48913043478261, 0.38888888888889
73334, 2.1130434782609, 0.46304347826087, 0.36111111111111
73335, 2.0913043478261, 0.46304347826087, 0.33333333333333
73336, 2.1130434782609, 0.48913043478261, 0.33333333333333
73337, 2.1130434782609, 0.46304347826087, 0.30555555555556
73338, 2.0913043478261, 0.46304347826087, 0.27777777777778
73339, 2.1130434782609, 0.48913043478261, 0.27777777777778
73340, 2.1130434782609, 0.46304347826087, 0.25
73341, 2.0913043478261, 0.46304347826087, 0.22222222222222
73342, 2.1130434782609, 0.48913043478261, 0.22222222222222
73343, 2.1130434782609, 0.46304347826087, 0.19444444444444
73344, 2.0913043478261, 0.46304347826087, 0.16666666666667
73345, 2.1130434782609, 0.48913043478261, 0.16666666666667
73346, 2.1130434782609, 0.46304347826087, 0.13888888888889
73347, 2.0913043478261, 0.46304347826087, 0.11111111111111
73348, 2.1130434782609, 0.48913043478261, 0.11111111111111
73349, 2.1130434782609, 0.46304347826087, 0.083333333333333
73350, 2.0913043478261, 0.46304347826087, 0.055555555555556
73351, 2.1130434782609, 0.48913043478261, 0.055555555555556
73352, 2.1130434782609, 0.46304347826087, 0.027777777777778
73353, 2.1565217391304, 0.46304347826087, 0.47222222222222
73354, 2.1347826086957, 0.46304347826087, 0.44444444444444
73355, 2.1565217391304, 0.48913043478261, 0.44444444444444
73356, 2.1565217391304, 0.46304347826087, 0.41666666666667
73357, 2.1347826086957, 0.46304347826087, 0.38888888888889
73358, 2.1565217391304, 0.48913043478261, 0.38888888888889
73359, 2.1565217391304, 0.46304347826087, 0.36111111111111
73360, 2.1347826086957, 0.46304347826087, 0.33333333333333
73361, 2.1565217391304, 0.48913043478261, 0.33333333333333
73362, 2.1565217391304, 0.46304347826087, 0.30555555555556
73363, 2.1347826086957, 0.46304347826087, 0.27777777777778
73364, 2.1565217391304, 0.48913043478261, 0.27777777777778
73365, 2.1565217391304, 0.46304347826087, 0.25
73366, 2.1347826086957, 0.46304347826087, 0.22222222222222
73367, 2.1565217391304, 0.48913043478261, 0.22222222222222
73368, 2.1565217391304, 0.46304347826087, 0.19444444444444
73369, 2.1347826086957, 0.46304347826087, 0.16666666666667
73370, 2.1565217391304, 0.48913043478261, 0.16666666666667
73371, 2.1565217391304, 0.46304347826087, 0.13888888888889
73372, 2.1347826086957, 0.46304347826087, 0.11111111111111
73373, 2.1565217391304, 0.48913043478261, 0.11111111111111
73374, 2.1565217391304, 0.46304347826087, 0.083333333333333
73375, 2.1347826086957, 0.46304347826087, 0.055555555555556
73376, 2.1565217391304, 0.48913043478261, 0.055555555555556
73377, 2.1565217391304, 0.46304347826087, 0.027777777777778
73378, 2.1782608695652, 0.46304347826087, 0.44444444444444
73379, 2.1782608695652, 0.46304347826087, 0.38888888888889
73380, 2.1782608695652, 0.46304347826087, 0.33333333333333
73381, 2.1782608695652, 0.46304347826087, 0.27777777777778
73382, 2.1782608695652, 0.46304347826087, 0.22222222222222
73383, 2.1782608695652, 0.46304347826087, 0.16666666666667
73384, 2.1782608695652, 0.46304347826087, 0.11111111111111
73385, 2.1782608695652, 0.46304347826087, 0.055555555555556
73386, 1.2434782608696, 0.41086956521739, 0.47222222222222
73387, 1.2217391304348, 0.41086956521739, 0.44444444444444
73388, 1.2434782608696, 0.43695652173913, 0.44444444444444
73389, 1.2434782608696, 0.41086956521739, 0.41666666666667
73390, 1.2217391304348, 0.41086956521739, 0.38888888888889
73391, 1.2434782608696, 0.43695652173913, 0.38888888888889
73392, 1.2434782608696, 0.41086956521739, 0.36111111111111
73393, 1.2217391304348, 0.41086956521739, 0.33333333333333
73394, 1.2434782608696, 0.43695652173913, 0.33333333333333
73395, 1.2434782608696, 0.41086956521739, 0.30555555555556
73396, 1.2217391304348, 0.41086956521739, 0.27777777777778
73397, 1.2434782608696, 0.43695652173913, 0.27777777777778
73398, 1.2434782608696, 0.41086956521739, 0.25
73399, 1.2217391304348, 0.41086956521739, 0.22222222222222
73400, 1.2434782608696, 0.43695652173913, 0.22222222222222
73401, 1.2434782608696, 0.41086956521739, 0.19444444444444
73402, 1.2217391304348, 0.41086956521739, 0.16666666666667
73403, 1.2434782608696, 0.43695652173913, 0.16666666666667
73404, 1.2434782608696, 0.41086956521739, 0.13888888888889
73405, 1.2217391304348, 0.41086956521739, 0.11111111111111
73406, 1.2434782608696, 0.43695652173913, 0.11111111111111
73407, 1.2434782608696, 0.41086956521739, 0.083333333333333
73408, 1.2217391304348, 0.41086956521739, 0.055555555555556
73409, 1.2434782608696, 0.43695652173913, 0.055555555555556
73410, 1.2434782608696, 0.41086956521739, 0.027777777777778
73411, 1.2869565217391, 0.41086956521739, 0.47222222222222
73412, 1.2652173913043, 0.41086956521739, 0.44444444444444
73413, 1.2869565217391, 0.43695652173913, 0.44444444444444
73414, 1.2869565217391, 0.41086956521739, 0.41666666666667
73415, 1.2652173913043, 0.41086956521739, 0.38888888888889
73416, 1.2869565217391, 0.43695652173913, 0.38888888888889
73417, 1.2869565217391, 0.41086956521739, 0.36111111111111
73418, 1.2652173913043, 0.41086956521739, 0.33333333333333
73419, 1.2869565217391, 0.43695652173913, 0.33333333333333
73420, 1.2869565217391, 0.41086956521739, 0.30555555555556
73421, 1.2652173913043, 0.41086956521739, 0.27777777777778
73422, 1.2869565217391, 0.43695652173913, 0.27777777777778
73423, 1.2869565217391, 0.41086956521739, 0.25
73424, 1.2652173913043, 0.41086956521739, 0.22222222222222
73425, 1.2869565217391, 0.43695652173913, 0.22222222222222
73426, 1.2869565217391, 0.41086956521739, 0.19444444444444
73427, 1.2652173913043, 0.41086956521739, 0.16666666666667
73428, 1.2869565217391, 0.43695652173913, 0.16666666666667
73429, 1.2869565217391, 0.41086956521739, 0.13888888888889
73430, 1.2652173913043, 0.41086956521739, 0.11111111111111
73431, 1.2869565217391, 0.43695652173913, 0.11111111111111
73432, 1.2869565217391, 0.41086956521739, 0.083333333333333
73433, 1.2652173913043, 0.41086956521739, 0.055555555555556
73434, 1.2869565217391, 0.43695652173913, 0.055555555555556
73435, 1.2869565217391, 0.41086956521739, 0.027777777777778
73436, 1.3304347826087, 0.41086956521739, 0.47222222222222
73437, 1.3086956521739, 0.41086956521739, 0.44444444444444
73438, 1.3304347826087, 0.43695652173913, 0.44444444444444
73439, 1.3304347826087, 0.41086956521739, 0.41666666666667
73440, 1.3086956521739, 0.41086956521739, 0.38888888888889
73441, 1.3304347826087, 0.43695652173913, 0.38888888888889
73442, 1.3304347826087, 0.41086956521739, 0.36111111111111
73443, 1.3086956521739, 0.41086956521739, 0.33333333333333
73444, 1.3304347826087, 0.43695652173913, 0.33333333333333
73445, 1.3304347826087, 0.41086956521739, 0.30555555555556
73446, 1.3086956521739, 0.41086956521739, 0.27777777777778
73447, 1.3304347826087, 0.43695652173913, 0.27777777777778
73448, 1.3304347826087, 0.41086956521739, 0.25
73449, 1.3086956521739, 0.41086956521739, 0.22222222222222
73450, 1.3304347826087, 0.43695652173913, 0.22222222222222
73451, 1.3304347826087, 0.41086956521739, 0.19444444444444
73452, 1.3086956521739, 0.41086956521739, 0.16666666666667
73453, 1.3304347826087, 0.43695652173913, 0.16666666666667
73454, 1.3304347826087, 0.41086956521739, 0.13888888888889
73455, 1.3086956521739, 0.41086956521739, 0.11111111111111
73456, 1.3304347826087, 0.43695652173913, 0.11111111111111
73457, 1.3304347826087, 0.41086956521739, 0.083333333333333
73458, 1.3086956521739, 0.41086956521739, 0.055555555555556
73459, 1.3304347826087, 0.43695652173913, 0.055555555555556
73460, 1.3304347826087, 0.41086956521739, 0.027777777777778
73461, 1.3739130434783, 0.41086956521739, 0.47222222222222
73462, 1.3521739130435, 0.41086956521739, 0.44444444444444
73463, 1.3739130434783, 0.43695652173913, 0.44444444444444
73464, 1.3739130434783, 0.41086956521739, 0.41666666666667
73465, 1.3521739130435, 0.41086956521739, 0.38888888888889
73466, 1.3739130434783, 0.43695652173913, 0.38888888888889
73467, 1.3739130434783, 0.41086956521739, 0.36111111111111
73468, 1.3521739130435, 0.41086956521739, 0.33333333333333
73469, 1.3739130434783, 0.43695652173913, 0.33333333333333
73470, 1.3739130434783, 0.41086956521739, 0.30555555555556
73471, 1.3521739130435, 0.41086956521739, 0.27777777777778
73472, 1.3739130434783, 0.43695652173913, 0.27777777777778
73473, 1.3739130434783, 0.41086956521739, 0.25
73474, 1.3521739130435, 0.41086956521739, 0.22222222222222
73475, 1.3739130434783, 0.43695652173913, 0.22222222222222
73476, 1.3739130434783, 0.41086956521739, 0.19444444444444
73477, 1.3521739130435, 0.41086956521739, 0.16666666666667
73478, 1.3739130434783, 0.43695652173913, 0.16666666666667
73479, 1.3739130434783, 0.41086956521739, 0.13888888888889
73480, 1.3521739130435, 0.41086956521739, 0.11111111111111
73481, 1.3739130434783, 0.43695652173913, 0.11111111111111
73482, 1.3739130434783, 0.41086956521739, 0.083333333333333
73483, 1.3521739130435, 0.41086956521739, 0.055555555555556
73484, 1.3739130434783, 0.43695652173913, 0.055555555555556
73485, 1.3739130434783, 0.41086956521739, 0.027777777777778
73486, 1.4173913043478, 0.41086956521739, 0.47222222222222
73487, 1.395652173913, 0.41086956521739, 0.44444444444444
73488, 1.4173913043478, 0.43695652173913, 0.44444444444444
73489, 1.4173913043478, 0.41086956521739, 0.41666666666667
73490, 1.395652173913, 0.41086956521739, 0.38888888888889
73491, 1.4173913043478, 0.43695652173913, 0.38888888888889
73492, 1.4173913043478, 0.41086956521739, 0.36111111111111
73493, 1.395652173913, 0.41086956521739, 0.33333333333333
73494, 1.4173913043478, 0.43695652173913, 0.33333333333333
73495, 1.4173913043478, 0.41086956521739, 0.30555555555556
73496, 1.395652173913, 0.41086956521739, 0.27777777777778
73497, 1.4173913043478, 0.43695652173913, 0.27777777777778
73498, 1.4173913043478, 0.41086956521739, 0.25
73499, 1.395652173913, 0.41086956521739, 0.22222222222222
73500, 1.4173913043478, 0.43695652173913, 0.22222222222222
73501, 1.4173913043478, 0.41086956521739, 0.19444444444444
73502, 1.395652173913, 0.41086956521739, 0.16666666666667
73503, 1.4173913043478, 0.43695652173913, 0.16666666666667
73504, 1.4173913043478, 0.41086956521739, 0.13888888888889
73505, 1.395652173913, 0.41086956521739, 0.11111111111111
73506, 1.4173913043478, 0.43695652173913, 0.11111111111111
73507, 1.4173913043478, 0.41086956521739, 0.083333333333333
73508, 1.395652173913, 0.41086956521739, 0.055555555555556
73509, 1.4173913043478, 0.43695652173913, 0.055555555555556
73510, 1.4173913043478, 0.41086956521739, 0.027777777777778
73511, 1.4608695652174, 0.41086956521739, 0.47222222222222
73512, 1.4391304347826, 0.41086956521739, 0.44444444444444
73513, 1.4608695652174, 0.43695652173913, 0.44444444444444
73514, 1.4608695652174, 0.41086956521739, 0.41666666666667
73515, 1.4391304347826, 0.41086956521739, 0.38888888888889
73516, 1.4608695652174, 0.43695652173913, 0.38888888888889
73517, 1.4608695652174, 0.41086956521739, 0.36111111111111
73518, 1.4391304347826, 0.41086956521739, 0.33333333333333
73519, 1.4608695652174, 0.43695652173913, 0.33333333333333
73520, 1.4608695652174, 0.41086956521739, 0.30555555555556
73521, 1.4391304347826, 0.41086956521739, 0.27777777777778
73522, 1.4608695652174, 0.43695652173913, 0.27777777777778
73523, 1.4608695652174, 0.41086956521739, 0.25
73524, 1.4391304347826, 0.41086956521739, 0.22222222222222
73525, 1.4608695652174, 0.43695652173913, 0.22222222222222
73526, 1.4608695652174, 0.41086956521739, 0.19444444444444
73527, 1.4391304347826, 0.41086956521739, 0.16666666666667
73528, 1.4608695652174, 0.43695652173913, 0.16666666666667
73529, 1.4608695652174, 0.41086956521739, 0.13888888888889
73530, 1.4391304347826, 0.41086956521739, 0.11111111111111
73531, 1.4608695652174, 0.43695652173913, 0.11111111111111
73532, 1.4608695652174, 0.41086956521739, 0.083333333333333
73533, 1.4391304347826, 0.41086956521739, 0.055555555555556
73534, 1.4608695652174, 0.43695652173913, 0.055555555555556
73535, 1.4608695652174, 0.41086956521739, 0.027777777777778
73536, 1.504347826087, 0.41086956521739, 0.47222222222222
73537, 1.4826086956522, 0.41086956521739, 0.44444444444444
73538, 1.504347826087, 0.43695652173913, 0.44444444444444
73539, 1.504347826087, 0.41086956521739, 0.41666666666667
73540, 1.4826086956522, 0.41086956521739, 0.38888888888889
73541, 1.504347826087, 0.43695652173913, 0.38888888888889
73542, 1.504347826087, 0.41086956521739, 0.36111111111111
73543, 1.4826086956522, 0.41086956521739, 0.33333333333333
73544, 1.504347826087, 0.43695652173913, 0.33333333333333
73545, 1.504347826087, 0.41086956521739, 0.30555555555556
73546, 1.4826086956522, 0.41086956521739, 0.27777777777778
73547, 1.504347826087, 0.43695652173913, 0.27777777777778
73548, 1.504347826087, 0.41086956521739, 0.25
73549, 1.4826086956522, 0.41086956521739, 0.22222222222222
73550, 1.504347826087, 0.43695652173913, 0.22222222222222
73551, 1.504347826087, 0.41086956521739, 0.19444444444444
73552, 1.4826086956522, 0.41086956521739, 0.16666666666667
73553, 1.504347826087, 0.43695652173913, 0.16666666666667
73554, 1.504347826087, 0.41086956521739, 0.13888888888889
73555, 1.4826086956522, 0.41086956521739, 0.11111111111111
73556, 1.504347826087, 0.43695652173913, 0.11111111111111
73557, 1.504347826087, 0.41086956521739, 0.083333333333333
73558, 1.4826086956522, 0.41086956521739, 0.055555555555556
73559, 1.504347826087, 0.43695652173913, 0.055555555555556
73560, 1.504347826087, 0.41086956521739, 0.027777777777778
73561, 1.5478260869565, 0.41086956521739, 0.47222222222222
73562, 1.5260869565217, 0.41086956521739, 0.44444444444444
73563, 1.5478260869565, 0.43695652173913, 0.44444444444444
73564, 1.5478260869565, 0.41086956521739, 0.41666666666667
73565, 1.5260869565217, 0.41086956521739, 0.38888888888889
73566, 1.5478260869565, 0.43695652173913, 0.38888888888889
73567, 1.5478260869565, 0.41086956521739, 0.36111111111111
73568, 1.5260869565217, 0.41086956521739, 0.33333333333333
73569, 1.5478260869565, 0.43695652173913, 0.33333333333333
73570, 1.5478260869565, 0.41086956521739, 0.30555555555556
73571, 1.5260869565217, 0.41086956521739, 0.27777777777778
73572, 1.5478260869565, 0.43695652173913, 0.27777777777778
73573, 1.5478260869565, 0.41086956521739, 0.25
73574, 1.5260869565217, 0.41086956521739, 0.22222222222222
73575, 1.5478260869565, 0.43695652173913, 0.22222222222222
73576, 1.5478260869565, 0.41086956521739, 0.19444444444444
73577, 1.5260869565217, 0.41086956521739, 0.16666666666667
73578, 1.5478260869565, 0.43695652173913, 0.16666666666667
73579, 1.5478260869565, 0.41086956521739, 0.13888888888889
73580, 1.5260869565217, 0.41086956521739, 0.11111111111111
73581, 1.5478260869565, 0.43695652173913, 0.11111111111111
73582, 1.5478260869565, 0.41086956521739, 0.083333333333333
73583, 1.5260869565217, 0.41086956521739, 0.055555555555556
73584, 1.5478260869565, 0.43695652173913, 0.055555555555556
73585, 1.5478260869565, 0.41086956521739, 0.027777777777778
73586, 1.5913043478261, 0.41086956521739, 0.47222222222222
73587, 1.5695652173913, 0.41086956521739, 0.44444444444444
73588, 1.5913043478261, 0.43695652173913, 0.44444444444444
73589, 1.5913043478261, 0.41086956521739, 0.41666666666667
73590, 1.5695652173913, 0.41086956521739, 0.38888888888889
73591, 1.5913043478261, 0.43695652173913, 0.38888888888889
73592, 1.5913043478261, 0.41086956521739, 0.36111111111111
73593, 1.5695652173913, 0.41086956521739, 0.33333333333333
73594, 1.5913043478261, 0.43695652173913, 0.33333333333333
73595, 1.5913043478261, 0.41086956521739, 0.30555555555556
73596, 1.5695652173913, 0.41086956521739, 0.27777777777778
73597, 1.5913043478261, 0.43695652173913, 0.27777777777778
73598, 1.5913043478261, 0.41086956521739, 0.25
73599, 1.5695652173913, 0.41086956521739, 0.22222222222222
73600, 1.5913043478261, 0.43695652173913, 0.22222222222222
73601, 1.5913043478261, 0.41086956521739, 0.19444444444444
73602, 1.5695652173913, 0.41086956521739, 0.16666666666667
73603, 1.5913043478261, 0.43695652173913, 0.16666666666667
73604, 1.5913043478261, 0.41086956521739, 0.13888888888889
73605, 1.5695652173913, 0.41086956521739, 0.11111111111111
73606, 1.5913043478261, 0.43695652173913, 0.11111111111111
73607, 1.5913043478261, 0.41086956521739, 0.083333333333333
73608, 1.5695652173913, 0.41086956521739, 0.055555555555556
73609, 1.5913043478261, 0.43695652173913, 0.055555555555556
73610, 1.5913043478261, 0.41086956521739, 0.027777777777778
73611, 1.6347826086957, 0.41086956521739, 0.47222222222222
73612, 1.6130434782609, 0.41086956521739, 0.44444444444444
73613, 1.6347826086957, 0.43695652173913, 0.44444444444444
73614, 1.6347826086957, 0.41086956521739, 0.41666666666667
73615, 1.6130434782609, 0.41086956521739, 0.38888888888889
73616, 1.6347826086957, 0.43695652173913, 0.38888888888889
73617, 1.6347826086957, 0.41086956521739, 0.36111111111111
73618, 1.6130434782609, 0.41086956521739, 0.33333333333333
73619, 1.6347826086957, 0.43695652173913, 0.33333333333333
73620, 1.6347826086957, 0.41086956521739, 0.30555555555556
73621, 1.6130434782609, 0.41086956521739, 0.27777777777778
73622, 1.6347826086957, 0.43695652173913, 0.27777777777778
73623, 1.6347826086957, 0.41086956521739, 0.25
73624, 1.6130434782609, 0.41086956521739, 0.22222222222222
73625, 1.6347826086957, 0.43695652173913, 0.22222222222222
73626, 1.6347826086957, 0.41086956521739, 0.19444444444444
73627, 1.6130434782609, 0.41086956521739, 0.16666666666667
73628, 1.6347826086957, 0.43695652173913, 0.16666666666667
73629, 1.6347826086957, 0.41086956521739, 0.13888888888889
73630, 1.6130434782609, 0.41086956521739, 0.11111111111111
73631, 1.6347826086957, 0.43695652173913, 0.11111111111111
73632, 1.6347826086957, 0.41086956521739, 0.083333333333333
73633, 1.6130434782609, 0.41086956521739, 0.055555555555556
73634, 1.6347826086957, 0.43695652173913, 0.055555555555556
73635, 1.6347826086957, 0.41086956521739, 0.027777777777778
73636, 1.6782608695652, 0.41086956521739, 0.47222222222222
73637, 1.6565217391304, 0.41086956521739, 0.44444444444444
73638, 1.6782608695652, 0.43695652173913, 0.44444444444444
73639, 1.6782608695652, 0.41086956521739, 0.41666666666667
73640, 1.6565217391304, 0.41086956521739, 0.38888888888889
73641, 1.6782608695652, 0.43695652173913, 0.38888888888889
73642, 1.6782608695652, 0.41086956521739, 0.36111111111111
73643, 1.6565217391304, 0.41086956521739, 0.33333333333333
73644, 1.6782608695652, 0.43695652173913, 0.33333333333333
73645, 1.6782608695652, 0.41086956521739, 0.30555555555556
73646, 1.6565217391304, 0.41086956521739, 0.27777777777778
73647, 1.6782608695652, 0.43695652173913, 0.27777777777778
73648, 1.6782608695652, 0.41086956521739, 0.25
73649, 1.6565217391304, 0.41086956521739, 0.22222222222222
73650, 1.6782608695652, 0.43695652173913, 0.22222222222222
73651, 1.6782608695652, 0.41086956521739, 0.19444444444444
73652, 1.6565217391304, 0.41086956521739, 0.16666666666667
73653, 1.6782608695652, 0.43695652173913, 0.16666666666667
73654, 1.6782608695652, 0.41086956521739, 0.13888888888889
73655, 1.6565217391304, 0.41086956521739, 0.11111111111111
73656, 1.6782608695652, 0.43695652173913, 0.11111111111111
73657, 1.6782608695652, 0.41086956521739, 0.083333333333333
73658, 1.6565217391304, 0.41086956521739, 0.055555555555556
73659, 1.6782608695652, 0.43695652173913, 0.055555555555556
73660, 1.6782608695652, 0.41086956521739, 0.027777777777778
73661, 1.7217391304348, 0.41086956521739, 0.47222222222222
73662, 1.7, 0.41086956521739, 0.44444444444444
73663, 1.7217391304348, 0.43695652173913, 0.44444444444444
73664, 1.7217391304348, 0.41086956521739, 0.41666666666667
73665, 1.7, 0.41086956521739, 0.38888888888889
73666, 1.7217391304348, 0.43695652173913, 0.38888888888889
73667, 1.7217391304348, 0.41086956521739, 0.36111111111111
73668, 1.7, 0.41086956521739, 0.33333333333333
73669, 1.7217391304348, 0.43695652173913, 0.33333333333333
73670, 1.7217391304348, 0.41086956521739, 0.30555555555556
73671, 1.7, 0.41086956521739, 0.27777777777778
73672, 1.7217391304348, 0.43695652173913, 0.27777777777778
73673, 1.7217391304348, 0.41086956521739, 0.25
73674, 1.7, 0.41086956521739, 0.22222222222222
73675, 1.7217391304348, 0.43695652173913, 0.22222222222222
73676, 1.7217391304348, 0.41086956521739, 0.19444444444444
73677, 1.7, 0.41086956521739, 0.16666666666667
73678, 1.7217391304348, 0.43695652173913, 0.16666666666667
73679, 1.7217391304348, 0.41086956521739, 0.13888888888889
73680, 1.7, 0.41086956521739, 0.11111111111111
73681, 1.7217391304348, 0.43695652173913, 0.11111111111111
73682, 1.7217391304348, 0.41086956521739, 0.083333333333333
73683, 1.7, 0.41086956521739, 0.055555555555556
73684, 1.7217391304348, 0.43695652173913, 0.055555555555556
73685, 1.7217391304348, 0.41086956521739, 0.027777777777778
73686, 1.7652173913043, 0.41086956521739, 0.47222222222222
73687, 1.7434782608696, 0.41086956521739, 0.44444444444444
73688, 1.7652173913043, 0.43695652173913, 0.44444444444444
73689, 1.7652173913043, 0.41086956521739, 0.41666666666667
73690, 1.7434782608696, 0.41086956521739, 0.38888888888889
73691, 1.7652173913043, 0.43695652173913, 0.38888888888889
73692, 1.7652173913043, 0.41086956521739, 0.36111111111111
73693, 1.7434782608696, 0.41086956521739, 0.33333333333333
73694, 1.7652173913043, 0.43695652173913, 0.33333333333333
73695, 1.7652173913043, 0.41086956521739, 0.30555555555556
73696, 1.7434782608696, 0.41086956521739, 0.27777777777778
73697, 1.7652173913043, 0.43695652173913, 0.27777777777778
73698, 1.7652173913043, 0.41086956521739, 0.25
73699, 1.7434782608696, 0.41086956521739, 0.22222222222222
73700, 1.7652173913043, 0.43695652173913, 0.22222222222222
73701, 1.7652173913043, 0.41086956521739, 0.19444444444444
73702, 1.7434782608696, 0.41086956521739, 0.16666666666667
73703, 1.7652173913043, 0.43695652173913, 0.16666666666667
73704, 1.7652173913043, 0.41086956521739, 0.13888888888889
73705, 1.7434782608696, 0.41086956521739, 0.11111111111111
73706, 1.7652173913043, 0.43695652173913, 0.11111111111111
73707, 1.7652173913043, 0.41086956521739, 0.083333333333333
73708, 1.7434782608696, 0.41086956521739, 0.055555555555556
73709, 1.7652173913043, 0.43695652173913, 0.055555555555556
73710, 1.7652173913043, 0.41086956521739, 0.027777777777778
73711, 1.8086956521739, 0.41086956521739, 0.47222222222222
73712, 1.7869565217391, 0.41086956521739, 0.44444444444444
73713, 1.8086956521739, 0.43695652173913, 0.44444444444444
73714, 1.8086956521739, 0.41086956521739, 0.41666666666667
73715, 1.7869565217391, 0.41086956521739, 0.38888888888889
73716, 1.8086956521739, 0.43695652173913, 0.38888888888889
73717, 1.8086956521739, 0.41086956521739, 0.36111111111111
73718, 1.7869565217391, 0.41086956521739, 0.33333333333333
73719, 1.8086956521739, 0.43695652173913, 0.33333333333333
73720, 1.8086956521739, 0.41086956521739, 0.30555555555556
73721, 1.7869565217391, 0.41086956521739, 0.27777777777778
73722, 1.8086956521739, 0.43695652173913, 0.27777777777778
73723, 1.8086956521739, 0.41086956521739, 0.25
73724, 1.7869565217391, 0.41086956521739, 0.22222222222222
73725, 1.8086956521739, 0.43695652173913, 0.22222222222222
73726, 1.8086956521739, 0.41086956521739, 0.19444444444444
73727, 1.7869565217391, 0.41086956521739, 0.16666666666667
73728, 1.8086956521739, 0.43695652173913, 0.16666666666667
73729, 1.8086956521739, 0.41086956521739, 0.13888888888889
73730, 1.7869565217391, 0.41086956521739, 0.11111111111111
73731, 1.8086956521739, 0.43695652173913, 0.11111111111111
73732, 1.8086956521739, 0.41086956521739, 0.083333333333333
73733, 1.7869565217391, 0.41086956521739, 0.055555555555556
73734, 1.8086956521739, 0.43695652173913, 0.055555555555556
73735, 1.8086956521739, 0.41086956521739, 0.027777777777778
73736, 1.8521739130435, 0.41086956521739, 0.47222222222222
73737, 1.8304347826087, 0.41086956521739, 0.44444444444444
73738, 1.8521739130435, 0.43695652173913, 0.44444444444444
73739, 1.8521739130435, 0.41086956521739, 0.41666666666667
73740, 1.8304347826087, 0.41086956521739, 0.38888888888889
73741, 1.8521739130435, 0.43695652173913, 0.38888888888889
73742, 1.8521739130435, 0.41086956521739, 0.36111111111111
73743, 1.8304347826087, 0.41086956521739, 0.33333333333333
73744, 1.8521739130435, 0.43695652173913, 0.33333333333333
73745, 1.8521739130435, 0.41086956521739, 0.30555555555556
73746, 1.8304347826087, 0.41086956521739, 0.27777777777778
73747, 1.8521739130435, 0.43695652173913, 0.27777777777778
73748, 1.8521739130435, 0.41086956521739, 0.25
73749, 1.8304347826087, 0.41086956521739, 0.22222222222222
73750, 1.8521739130435, 0.43695652173913, 0.22222222222222
73751, 1.8521739130435, 0.41086956521739, 0.19444444444444
73752, 1.8304347826087, 0.41086956521739, 0.16666666666667
73753, 1.8521739130435, 0.43695652173913, 0.16666666666667
73754, 1.8521739130435, 0.41086956521739, 0.13888888888889
73755, 1.8304347826087, 0.41086956521739, 0.11111111111111
73756, 1.8521739130435, 0.43695652173913, 0.11111111111111
73757, 1.8521739130435, 0.41086956521739, 0.083333333333333
73758, 1.8304347826087, 0.41086956521739, 0.055555555555556
73759, 1.8521739130435, 0.43695652173913, 0.055555555555556
73760, 1.8521739130435, 0.41086956521739, 0.027777777777778
73761, 1.895652173913, 0.41086956521739, 0.47222222222222
73762, 1.8739130434783, 0.41086956521739, 0.44444444444444
73763, 1.895652173913, 0.43695652173913, 0.44444444444444
73764, 1.895652173913, 0.41086956521739, 0.41666666666667
73765, 1.8739130434783, 0.41086956521739, 0.38888888888889
73766, 1.895652173913, 0.43695652173913, 0.38888888888889
73767, 1.895652173913, 0.41086956521739, 0.36111111111111
73768, 1.8739130434783, 0.41086956521739, 0.33333333333333
73769, 1.895652173913, 0.43695652173913, 0.33333333333333
73770, 1.895652173913, 0.41086956521739, 0.30555555555556
73771, 1.8739130434783, 0.41086956521739, 0.27777777777778
73772, 1.895652173913, 0.43695652173913, 0.27777777777778
73773, 1.895652173913, 0.41086956521739, 0.25
73774, 1.8739130434783, 0.41086956521739, 0.22222222222222
73775, 1.895652173913, 0.43695652173913, 0.22222222222222
73776, 1.895652173913, 0.41086956521739, 0.19444444444444
73777, 1.8739130434783, 0.41086956521739, 0.16666666666667
73778, 1.895652173913, 0.43695652173913, 0.16666666666667
73779, 1.895652173913, 0.41086956521739, 0.13888888888889
73780, 1.8739130434783, 0.41086956521739, 0.11111111111111
73781, 1.895652173913, 0.43695652173913, 0.11111111111111
73782, 1.895652173913, 0.41086956521739, 0.083333333333333
73783, 1.8739130434783, 0.41086956521739, 0.055555555555556
73784, 1.895652173913, 0.43695652173913, 0.055555555555556
73785, 1.895652173913, 0.41086956521739, 0.027777777777778
73786, 1.9391304347826, 0.41086956521739, 0.47222222222222
73787, 1.9173913043478, 0.41086956521739, 0.44444444444444
73788, 1.9391304347826, 0.43695652173913, 0.44444444444444
73789, 1.9391304347826, 0.41086956521739, 0.41666666666667
73790, 1.9173913043478, 0.41086956521739, 0.38888888888889
73791, 1.9391304347826, 0.43695652173913, 0.38888888888889
73792, 1.9391304347826, 0.41086956521739, 0.36111111111111
73793, 1.9173913043478, 0.41086956521739, 0.33333333333333
73794, 1.9391304347826, 0.43695652173913, 0.33333333333333
73795, 1.9391304347826, 0.41086956521739, 0.30555555555556
73796, 1.9173913043478, 0.41086956521739, 0.27777777777778
73797, 1.9391304347826, 0.43695652173913, 0.27777777777778
73798, 1.9391304347826, 0.41086956521739, 0.25
73799, 1.9173913043478, 0.41086956521739, 0.22222222222222
73800, 1.9391304347826, 0.43695652173913, 0.22222222222222
73801, 1.9391304347826, 0.41086956521739, 0.19444444444444
73802, 1.9173913043478, 0.41086956521739, 0.16666666666667
73803, 1.9391304347826, 0.43695652173913, 0.16666666666667
73804, 1.9391304347826, 0.41086956521739, 0.13888888888889
73805, 1.9173913043478, 0.41086956521739, 0.11111111111111
73806, 1.9391304347826, 0.43695652173913, 0.11111111111111
73807, 1.9391304347826, 0.41086956521739, 0.083333333333333
73808, 1.9173913043478, 0.41086956521739, 0.055555555555556
73809, 1.9391304347826, 0.43695652173913, 0.055555555555556
73810, 1.9391304347826, 0.41086956521739, 0.027777777777778
73811, 1.9826086956522, 0.41086956521739, 0.47222222222222
73812, 1.9608695652174, 0.41086956521739, 0.44444444444444
73813, 1.9826086956522, 0.43695652173913, 0.44444444444444
73814, 1.9826086956522, 0.41086956521739, 0.41666666666667
73815, 1.9608695652174, 0.41086956521739, 0.38888888888889
73816, 1.9826086956522, 0.43695652173913, 0.38888888888889
73817, 1.9826086956522, 0.41086956521739, 0.36111111111111
73818, 1.9608695652174, 0.41086956521739, 0.33333333333333
73819, 1.9826086956522, 0.43695652173913, 0.33333333333333
73820, 1.9826086956522, 0.41086956521739, 0.30555555555556
73821, 1.9608695652174, 0.41086956521739, 0.27777777777778
73822, 1.9826086956522, 0.43695652173913, 0.27777777777778
73823, 1.9826086956522, 0.41086956521739, 0.25
73824, 1.9608695652174, 0.41086956521739, 0.22222222222222
73825, 1.9826086956522, 0.43695652173913, 0.22222222222222
73826, 1.9826086956522, 0.41086956521739, 0.19444444444444
73827, 1.9608695652174, 0.41086956521739, 0.16666666666667
73828, 1.9826086956522, 0.43695652173913, 0.16666666666667
73829, 1.9826086956522, 0.41086956521739, 0.13888888888889
73830, 1.9608695652174, 0.41086956521739, 0.11111111111111
73831, 1.9826086956522, 0.43695652173913, 0.11111111111111
73832, 1.9826086956522, 0.41086956521739, 0.083333333333333
73833, 1.9608695652174, 0.41086956521739, 0.055555555555556
73834, 1.9826086956522, 0.43695652173913, 0.055555555555556
73835, 1.9826086956522, 0.41086956521739, 0.027777777777778
73836, 2.0260869565217, 0.41086956521739, 0.47222222222222
73837, 2.004347826087, 0.41086956521739, 0.44444444444444
73838, 2.0260869565217, 0.43695652173913, 0.44444444444444
73839, 2.0260869565217, 0.41086956521739, 0.41666666666667
73840, 2.004347826087, 0.41086956521739, 0.38888888888889
73841, 2.0260869565217, 0.43695652173913, 0.38888888888889
73842, 2.0260869565217, 0.41086956521739, 0.36111111111111
73843, 2.004347826087, 0.41086956521739, 0.33333333333333
73844, 2.0260869565217, 0.43695652173913, 0.33333333333333
73845, 2.0260869565217, 0.41086956521739, 0.30555555555556
73846, 2.004347826087, 0.41086956521739, 0.27777777777778
73847, 2.0260869565217, 0.43695652173913, 0.27777777777778
73848, 2.0260869565217, 0.41086956521739, 0.25
73849, 2.004347826087, 0.41086956521739, 0.22222222222222
73850, 2.0260869565217, 0.43695652173913, 0.22222222222222
73851, 2.0260869565217, 0.41086956521739, 0.19444444444444
73852, 2.004347826087, 0.41086956521739, 0.16666666666667
73853, 2.0260869565217, 0.43695652173913, 0.16666666666667
73854, 2.0260869565217, 0.41086956521739, 0.13888888888889
73855, 2.004347826087, 0.41086956521739, 0.11111111111111
73856, 2.0260869565217, 0.43695652173913, 0.11111111111111
73857, 2.0260869565217, 0.41086956521739, 0.083333333333333
73858, 2.004347826087, 0.41086956521739, 0.055555555555556
73859, 2.0260869565217, 0.43695652173913, 0.055555555555556
73860, 2.0260869565217, 0.41086956521739, 0.027777777777778
73861, 2.0695652173913, 0.41086956521739, 0.47222222222222
73862, 2.0478260869565, 0.41086956521739, 0.44444444444444
73863, 2.0695652173913, 0.43695652173913, 0.44444444444444
73864, 2.0695652173913, 0.41086956521739, 0.41666666666667
73865, 2.0478260869565, 0.41086956521739, 0.38888888888889
73866, 2.0695652173913, 0.43695652173913, 0.38888888888889
73867, 2.0695652173913, 0.41086956521739, 0.36111111111111
73868, 2.0478260869565, 0.41086956521739, 0.33333333333333
73869, 2.0695652173913, 0.43695652173913, 0.33333333333333
73870, 2.0695652173913, 0.41086956521739, 0.30555555555556
73871, 2.0478260869565, 0.41086956521739, 0.27777777777778
73872, 2.0695652173913, 0.43695652173913, 0.27777777777778
73873, 2.0695652173913, 0.41086956521739, 0.25
73874, 2.0478260869565, 0.41086956521739, 0.22222222222222
73875, 2.0695652173913, 0.43695652173913, 0.22222222222222
73876, 2.0695652173913, 0.41086956521739, 0.19444444444444
73877, 2.0478260869565, 0.41086956521739, 0.16666666666667
73878, 2.0695652173913, 0.43695652173913, 0.16666666666667
73879, 2.0695652173913, 0.41086956521739, 0.13888888888889
73880, 2.0478260869565, 0.41086956521739, 0.11111111111111
73881, 2.0695652173913, 0.43695652173913, 0.11111111111111
73882, 2.0695652173913, 0.41086956521739, 0.083333333333333
73883, 2.0478260869565, 0.41086956521739, 0.055555555555556
73884, 2.0695652173913, 0.43695652173913, 0.055555555555556
73885, 2.0695652173913, 0.41086956521739, 0.027777777777778
73886, 2.1130434782609, 0.41086956521739, 0.47222222222222
73887, 2.0913043478261, 0.41086956521739, 0.44444444444444
73888, 2.1130434782609, 0.43695652173913, 0.44444444444444
73889, 2.1130434782609, 0.41086956521739, 0.41666666666667
73890, 2.0913043478261, 0.41086956521739, 0.38888888888889
73891, 2.1130434782609, 0.43695652173913, 0.38888888888889
73892, 2.1130434782609, 0.41086956521739, 0.36111111111111
73893, 2.0913043478261, 0.41086956521739, 0.33333333333333
73894, 2.1130434782609, 0.43695652173913, 0.33333333333333
73895, 2.1130434782609, 0.41086956521739, 0.30555555555556
73896, 2.0913043478261, 0.41086956521739, 0.27777777777778
73897, 2.1130434782609, 0.43695652173913, 0.27777777777778
73898, 2.1130434782609, 0.41086956521739, 0.25
73899, 2.0913043478261, 0.41086956521739, 0.22222222222222
73900, 2.1130434782609, 0.43695652173913, 0.22222222222222
73901, 2.1130434782609, 0.41086956521739, 0.19444444444444
73902, 2.0913043478261, 0.41086956521739, 0.16666666666667
73903, 2.1130434782609, 0.43695652173913, 0.16666666666667
73904, 2.1130434782609, 0.41086956521739, 0.13888888888889
73905, 2.0913043478261, 0.41086956521739, 0.11111111111111
73906, 2.1130434782609, 0.43695652173913, 0.11111111111111
73907, 2.1130434782609, 0.41086956521739, 0.083333333333333
73908, 2.0913043478261, 0.41086956521739, 0.055555555555556
73909, 2.1130434782609, 0.43695652173913, 0.055555555555556
73910, 2.1130434782609, 0.41086956521739, 0.027777777777778
73911, 2.1565217391304, 0.41086956521739, 0.47222222222222
73912, 2.1347826086957, 0.41086956521739, 0.44444444444444
73913, 2.1565217391304, 0.43695652173913, 0.44444444444444
73914, 2.1565217391304, 0.41086956521739, 0.41666666666667
73915, 2.1347826086957, 0.41086956521739, 0.38888888888889
73916, 2.1565217391304, 0.43695652173913, 0.38888888888889
73917, 2.1565217391304, 0.41086956521739, 0.36111111111111
73918, 2.1347826086957, 0.41086956521739, 0.33333333333333
73919, 2.1565217391304, 0.43695652173913, 0.33333333333333
73920, 2.1565217391304, 0.41086956521739, 0.30555555555556
73921, 2.1347826086957, 0.41086956521739, 0.27777777777778
73922, 2.1565217391304, 0.43695652173913, 0.27777777777778
73923, 2.1565217391304, 0.41086956521739, 0.25
73924, 2.1347826086957, 0.41086956521739, 0.22222222222222
73925, 2.1565217391304, 0.43695652173913, 0.22222222222222
73926, 2.1565217391304, 0.41086956521739, 0.19444444444444
73927, 2.1347826086957, 0.41086956521739, 0.16666666666667
73928, 2.1565217391304, 0.43695652173913, 0.16666666666667
73929, 2.1565217391304, 0.41086956521739, 0.13888888888889
73930, 2.1347826086957, 0.41086956521739, 0.11111111111111
73931, 2.1565217391304, 0.43695652173913, 0.11111111111111
73932, 2.1565217391304, 0.41086956521739, 0.083333333333333
73933, 2.1347826086957, 0.41086956521739, 0.055555555555556
73934, 2.1565217391304, 0.43695652173913, 0.055555555555556
73935, 2.1565217391304, 0.41086956521739, 0.027777777777778
73936, 2.1782608695652, 0.41086956521739, 0.44444444444444
73937, 2.1782608695652, 0.41086956521739, 0.38888888888889
73938, 2.1782608695652, 0.41086956521739, 0.33333333333333
73939, 2.1782608695652, 0.41086956521739, 0.27777777777778
73940, 2.1782608695652, 0.41086956521739, 0.22222222222222
73941, 2.1782608695652, 0.41086956521739, 0.16666666666667
73942, 2.1782608695652, 0.41086956521739, 0.11111111111111
73943, 2.1782608695652, 0.41086956521739, 0.055555555555556
73944, 1.2434782608696, 0.35869565217391, 0.47222222222222
73945, 1.2217391304348, 0.35869565217391, 0.44444444444444
73946, 1.2434782608696, 0.38478260869565, 0.44444444444444
73947, 1.2434782608696, 0.35869565217391, 0.41666666666667
73948, 1.2217391304348, 0.35869565217391, 0.38888888888889
73949, 1.2434782608696, 0.38478260869565, 0.38888888888889
73950, 1.2434782608696, 0.35869565217391, 0.36111111111111
73951, 1.2217391304348, 0.35869565217391, 0.33333333333333
73952, 1.2434782608696, 0.38478260869565, 0.33333333333333
73953, 1.2434782608696, 0.35869565217391, 0.30555555555556
73954, 1.2217391304348, 0.35869565217391, 0.27777777777778
73955, 1.2434782608696, 0.38478260869565, 0.27777777777778
73956, 1.2434782608696, 0.35869565217391, 0.25
73957, 1.2217391304348, 0.35869565217391, 0.22222222222222
73958, 1.2434782608696, 0.38478260869565, 0.22222222222222
73959, 1.2434782608696, 0.35869565217391, 0.19444444444444
73960, 1.2217391304348, 0.35869565217391, 0.16666666666667
73961, 1.2434782608696, 0.38478260869565, 0.16666666666667
73962, 1.2434782608696, 0.35869565217391, 0.13888888888889
73963, 1.2217391304348, 0.35869565217391, 0.11111111111111
73964, 1.2434782608696, 0.38478260869565, 0.11111111111111
73965, 1.2434782608696, 0.35869565217391, 0.083333333333333
73966, 1.2217391304348, 0.35869565217391, 0.055555555555556
73967, 1.2434782608696, 0.38478260869565, 0.055555555555556
73968, 1.2434782608696, 0.35869565217391, 0.027777777777778
73969, 1.2869565217391, 0.35869565217391, 0.47222222222222
73970, 1.2652173913043, 0.35869565217391, 0.44444444444444
73971, 1.2869565217391, 0.38478260869565, 0.44444444444444
