51183, 0.91304347826087, 1.0369565217391, 0.027777777777778
51184, 0.93478260869565, 1.0369565217391, 0.055555555555556
51185, 0.91304347826087, 1.0108695652174, 0.055555555555556
51186, 0.91304347826087, 1.0369565217391, 0.083333333333333
51187, 0.93478260869565, 1.0369565217391, 0.11111111111111
51188, 0.91304347826087, 1.0108695652174, 0.11111111111111
51189, 0.91304347826087, 1.0369565217391, 0.13888888888889
51190, 0.93478260869565, 1.0369565217391, 0.16666666666667
51191, 0.91304347826087, 1.0108695652174, 0.16666666666667
51192, 0.91304347826087, 1.0369565217391, 0.19444444444444
51193, 0.93478260869565, 1.0369565217391, 0.22222222222222
51194, 0.91304347826087, 1.0108695652174, 0.22222222222222
51195, 0.91304347826087, 1.0369565217391, 0.25
51196, 0.93478260869565, 1.0369565217391, 0.27777777777778
51197, 0.91304347826087, 1.0108695652174, 0.27777777777778
51198, 0.91304347826087, 1.0369565217391, 0.30555555555556
51199, 0.93478260869565, 1.0369565217391, 0.33333333333333
51200, 0.91304347826087, 1.0108695652174, 0.33333333333333
51201, 0.91304347826087, 1.0369565217391, 0.36111111111111
51202, 0.93478260869565, 1.0369565217391, 0.38888888888889
51203, 0.91304347826087, 1.0108695652174, 0.38888888888889
51204, 0.91304347826087, 1.0369565217391, 0.41666666666667
51205, 0.93478260869565, 1.0369565217391, 0.44444444444444
51206, 0.91304347826087, 1.0108695652174, 0.44444444444444
51207, 0.91304347826087, 1.0369565217391, 0.47222222222222
51208, 0.8695652173913, 1.0369565217391, 0.027777777777778
51209, 0.89130434782609, 1.0369565217391, 0.055555555555556
51210, 0.8695652173913, 1.0108695652174, 0.055555555555556
51211, 0.8695652173913, 1.0369565217391, 0.083333333333333
51212, 0.89130434782609, 1.0369565217391, 0.11111111111111
51213, 0.8695652173913, 1.0108695652174, 0.11111111111111
51214, 0.8695652173913, 1.0369565217391, 0.13888888888889
51215, 0.89130434782609, 1.0369565217391, 0.16666666666667
51216, 0.8695652173913, 1.0108695652174, 0.16666666666667
51217, 0.8695652173913, 1.0369565217391, 0.19444444444444
51218, 0.89130434782609, 1.0369565217391, 0.22222222222222
51219, 0.8695652173913, 1.0108695652174, 0.22222222222222
51220, 0.8695652173913, 1.0369565217391, 0.25
51221, 0.89130434782609, 1.0369565217391, 0.27777777777778
51222, 0.8695652173913, 1.0108695652174, 0.27777777777778
51223, 0.8695652173913, 1.0369565217391, 0.30555555555556
51224, 0.89130434782609, 1.0369565217391, 0.33333333333333
51225, 0.8695652173913, 1.0108695652174, 0.33333333333333
51226, 0.8695652173913, 1.0369565217391, 0.36111111111111
51227, 0.89130434782609, 1.0369565217391, 0.38888888888889
51228, 0.8695652173913, 1.0108695652174, 0.38888888888889
51229, 0.8695652173913, 1.0369565217391, 0.41666666666667
51230, 0.89130434782609, 1.0369565217391, 0.44444444444444
51231, 0.8695652173913, 1.0108695652174, 0.44444444444444
51232, 0.8695652173913, 1.0369565217391, 0.47222222222222
51233, 0.82608695652174, 1.0369565217391, 0.027777777777778
51234, 0.84782608695652, 1.0369565217391, 0.055555555555556
51235, 0.82608695652174, 1.0108695652174, 0.055555555555556
51236, 0.82608695652174, 1.0369565217391, 0.083333333333333
51237, 0.84782608695652, 1.0369565217391, 0.11111111111111
51238, 0.82608695652174, 1.0108695652174, 0.11111111111111
51239, 0.82608695652174, 1.0369565217391, 0.13888888888889
51240, 0.84782608695652, 1.0369565217391, 0.16666666666667
51241, 0.82608695652174, 1.0108695652174, 0.16666666666667
51242, 0.82608695652174, 1.0369565217391, 0.19444444444444
51243, 0.84782608695652, 1.0369565217391, 0.22222222222222
51244, 0.82608695652174, 1.0108695652174, 0.22222222222222
51245, 0.82608695652174, 1.0369565217391, 0.25
51246, 0.84782608695652, 1.0369565217391, 0.27777777777778
51247, 0.82608695652174, 1.0108695652174, 0.27777777777778
51248, 0.82608695652174, 1.0369565217391, 0.30555555555556
51249, 0.84782608695652, 1.0369565217391, 0.33333333333333
51250, 0.82608695652174, 1.0108695652174, 0.33333333333333
51251, 0.82608695652174, 1.0369565217391, 0.36111111111111
51252, 0.84782608695652, 1.0369565217391, 0.38888888888889
51253, 0.82608695652174, 1.0108695652174, 0.38888888888889
51254, 0.82608695652174, 1.0369565217391, 0.41666666666667
51255, 0.84782608695652, 1.0369565217391, 0.44444444444444
51256, 0.82608695652174, 1.0108695652174, 0.44444444444444
51257, 0.82608695652174, 1.0369565217391, 0.47222222222222
51258, 0.78260869565217, 1.0369565217391, 0.027777777777778
51259, 0.80434782608696, 1.0369565217391, 0.055555555555556
51260, 0.78260869565217, 1.0108695652174, 0.055555555555556
51261, 0.78260869565217, 1.0369565217391, 0.083333333333333
51262, 0.80434782608696, 1.0369565217391, 0.11111111111111
51263, 0.78260869565217, 1.0108695652174, 0.11111111111111
51264, 0.78260869565217, 1.0369565217391, 0.13888888888889
51265, 0.80434782608696, 1.0369565217391, 0.16666666666667
51266, 0.78260869565217, 1.0108695652174, 0.16666666666667
51267, 0.78260869565217, 1.0369565217391, 0.19444444444444
51268, 0.80434782608696, 1.0369565217391, 0.22222222222222
51269, 0.78260869565217, 1.0108695652174, 0.22222222222222
51270, 0.78260869565217, 1.0369565217391, 0.25
51271, 0.80434782608696, 1.0369565217391, 0.27777777777778
51272, 0.78260869565217, 1.0108695652174, 0.27777777777778
51273, 0.78260869565217, 1.0369565217391, 0.30555555555556
51274, 0.80434782608696, 1.0369565217391, 0.33333333333333
51275, 0.78260869565217, 1.0108695652174, 0.33333333333333
51276, 0.78260869565217, 1.0369565217391, 0.36111111111111
51277, 0.80434782608696, 1.0369565217391, 0.38888888888889
51278, 0.78260869565217, 1.0108695652174, 0.38888888888889
51279, 0.78260869565217, 1.0369565217391, 0.41666666666667
51280, 0.80434782608696, 1.0369565217391, 0.44444444444444
51281, 0.78260869565217, 1.0108695652174, 0.44444444444444
51282, 0.78260869565217, 1.0369565217391, 0.47222222222222
51283, 0.73913043478261, 1.0369565217391, 0.027777777777778
51284, 0.76086956521739, 1.0369565217391, 0.055555555555556
51285, 0.73913043478261, 1.0108695652174, 0.055555555555556
51286, 0.73913043478261, 1.0369565217391, 0.083333333333333
51287, 0.76086956521739, 1.0369565217391, 0.11111111111111
51288, 0.73913043478261, 1.0108695652174, 0.11111111111111
51289, 0.73913043478261, 1.0369565217391, 0.13888888888889
51290, 0.76086956521739, 1.0369565217391, 0.16666666666667
51291, 0.73913043478261, 1.0108695652174, 0.16666666666667
51292, 0.73913043478261, 1.0369565217391, 0.19444444444444
51293, 0.76086956521739, 1.0369565217391, 0.22222222222222
51294, 0.73913043478261, 1.0108695652174, 0.22222222222222
51295, 0.73913043478261, 1.0369565217391, 0.25
51296, 0.76086956521739, 1.0369565217391, 0.27777777777778
51297, 0.73913043478261, 1.0108695652174, 0.27777777777778
51298, 0.73913043478261, 1.0369565217391, 0.30555555555556
51299, 0.76086956521739, 1.0369565217391, 0.33333333333333
51300, 0.73913043478261, 1.0108695652174, 0.33333333333333
51301, 0.73913043478261, 1.0369565217391, 0.36111111111111
51302, 0.76086956521739, 1.0369565217391, 0.38888888888889
51303, 0.73913043478261, 1.0108695652174, 0.38888888888889
51304, 0.73913043478261, 1.0369565217391, 0.41666666666667
51305, 0.76086956521739, 1.0369565217391, 0.44444444444444
51306, 0.73913043478261, 1.0108695652174, 0.44444444444444
51307, 0.73913043478261, 1.0369565217391, 0.47222222222222
51308, 0.69565217391304, 1.0369565217391, 0.027777777777778
51309, 0.71739130434783, 1.0369565217391, 0.055555555555556
51310, 0.69565217391304, 1.0108695652174, 0.055555555555556
51311, 0.69565217391304, 1.0369565217391, 0.083333333333333
51312, 0.71739130434783, 1.0369565217391, 0.11111111111111
51313, 0.69565217391304, 1.0108695652174, 0.11111111111111
51314, 0.69565217391304, 1.0369565217391, 0.13888888888889
51315, 0.71739130434783, 1.0369565217391, 0.16666666666667
51316, 0.69565217391304, 1.0108695652174, 0.16666666666667
51317, 0.69565217391304, 1.0369565217391, 0.19444444444444
51318, 0.71739130434783, 1.0369565217391, 0.22222222222222
51319, 0.69565217391304, 1.0108695652174, 0.22222222222222
51320, 0.69565217391304, 1.0369565217391, 0.25
51321, 0.71739130434783, 1.0369565217391, 0.27777777777778
51322, 0.69565217391304, 1.0108695652174, 0.27777777777778
51323, 0.69565217391304, 1.0369565217391, 0.30555555555556
51324, 0.71739130434783, 1.0369565217391, 0.33333333333333
51325, 0.69565217391304, 1.0108695652174, 0.33333333333333
51326, 0.69565217391304, 1.0369565217391, 0.36111111111111
51327, 0.71739130434783, 1.0369565217391, 0.38888888888889
51328, 0.69565217391304, 1.0108695652174, 0.38888888888889
51329, 0.69565217391304, 1.0369565217391, 0.41666666666667
51330, 0.71739130434783, 1.0369565217391, 0.44444444444444
51331, 0.69565217391304, 1.0108695652174, 0.44444444444444
51332, 0.69565217391304, 1.0369565217391, 0.47222222222222
51333, 0.65217391304348, 1.0369565217391, 0.027777777777778
51334, 0.67391304347826, 1.0369565217391, 0.055555555555556
51335, 0.65217391304348, 1.0108695652174, 0.055555555555556
51336, 0.65217391304348, 1.0369565217391, 0.083333333333333
51337, 0.67391304347826, 1.0369565217391, 0.11111111111111
51338, 0.65217391304348, 1.0108695652174, 0.11111111111111
51339, 0.65217391304348, 1.0369565217391, 0.13888888888889
51340, 0.67391304347826, 1.0369565217391, 0.16666666666667
51341, 0.65217391304348, 1.0108695652174, 0.16666666666667
51342, 0.65217391304348, 1.0369565217391, 0.19444444444444
51343, 0.67391304347826, 1.0369565217391, 0.22222222222222
51344, 0.65217391304348, 1.0108695652174, 0.22222222222222
51345, 0.65217391304348, 1.0369565217391, 0.25
51346, 0.67391304347826, 1.0369565217391, 0.27777777777778
51347, 0.65217391304348, 1.0108695652174, 0.27777777777778
51348, 0.65217391304348, 1.0369565217391, 0.30555555555556
51349, 0.67391304347826, 1.0369565217391, 0.33333333333333
51350, 0.65217391304348, 1.0108695652174, 0.33333333333333
51351, 0.65217391304348, 1.0369565217391, 0.36111111111111
51352, 0.67391304347826, 1.0369565217391, 0.38888888888889
51353, 0.65217391304348, 1.0108695652174, 0.38888888888889
51354, 0.65217391304348, 1.0369565217391, 0.41666666666667
51355, 0.67391304347826, 1.0369565217391, 0.44444444444444
51356, 0.65217391304348, 1.0108695652174, 0.44444444444444
51357, 0.65217391304348, 1.0369565217391, 0.47222222222222
51358, 0.60869565217391, 1.0369565217391, 0.027777777777778
51359, 0.6304347826087, 1.0369565217391, 0.055555555555556
51360, 0.60869565217391, 1.0108695652174, 0.055555555555556
51361, 0.60869565217391, 1.0369565217391, 0.083333333333333
51362, 0.6304347826087, 1.0369565217391, 0.11111111111111
51363, 0.60869565217391, 1.0108695652174, 0.11111111111111
51364, 0.60869565217391, 1.0369565217391, 0.13888888888889
51365, 0.6304347826087, 1.0369565217391, 0.16666666666667
51366, 0.60869565217391, 1.0108695652174, 0.16666666666667
51367, 0.60869565217391, 1.0369565217391, 0.19444444444444
51368, 0.6304347826087, 1.0369565217391, 0.22222222222222
51369, 0.60869565217391, 1.0108695652174, 0.22222222222222
51370, 0.60869565217391, 1.0369565217391, 0.25
51371, 0.6304347826087, 1.0369565217391, 0.27777777777778
51372, 0.60869565217391, 1.0108695652174, 0.27777777777778
51373, 0.60869565217391, 1.0369565217391, 0.30555555555556
51374, 0.6304347826087, 1.0369565217391, 0.33333333333333
51375, 0.60869565217391, 1.0108695652174, 0.33333333333333
51376, 0.60869565217391, 1.0369565217391, 0.36111111111111
51377, 0.6304347826087, 1.0369565217391, 0.38888888888889
51378, 0.60869565217391, 1.0108695652174, 0.38888888888889
51379, 0.60869565217391, 1.0369565217391, 0.41666666666667
51380, 0.6304347826087, 1.0369565217391, 0.44444444444444
51381, 0.60869565217391, 1.0108695652174, 0.44444444444444
51382, 0.60869565217391, 1.0369565217391, 0.47222222222222
51383, 0.56521739130435, 1.0369565217391, 0.027777777777778
51384, 0.58695652173913, 1.0369565217391, 0.055555555555556
51385, 0.56521739130435, 1.0108695652174, 0.055555555555556
51386, 0.56521739130435, 1.0369565217391, 0.083333333333333
51387, 0.58695652173913, 1.0369565217391, 0.11111111111111
51388, 0.56521739130435, 1.0108695652174, 0.11111111111111
51389, 0.56521739130435, 1.0369565217391, 0.13888888888889
51390, 0.58695652173913, 1.0369565217391, 0.16666666666667
51391, 0.56521739130435, 1.0108695652174, 0.16666666666667
51392, 0.56521739130435, 1.0369565217391, 0.19444444444444
51393, 0.58695652173913, 1.0369565217391, 0.22222222222222
51394, 0.56521739130435, 1.0108695652174, 0.22222222222222
51395, 0.56521739130435, 1.0369565217391, 0.25
51396, 0.58695652173913, 1.0369565217391, 0.27777777777778
51397, 0.56521739130435, 1.0108695652174, 0.27777777777778
51398, 0.56521739130435, 1.0369565217391, 0.30555555555556
51399, 0.58695652173913, 1.0369565217391, 0.33333333333333
51400, 0.56521739130435, 1.0108695652174, 0.33333333333333
51401, 0.56521739130435, 1.0369565217391, 0.36111111111111
51402, 0.58695652173913, 1.0369565217391, 0.38888888888889
51403, 0.56521739130435, 1.0108695652174, 0.38888888888889
51404, 0.56521739130435, 1.0369565217391, 0.41666666666667
51405, 0.58695652173913, 1.0369565217391, 0.44444444444444
51406, 0.56521739130435, 1.0108695652174, 0.44444444444444
51407, 0.56521739130435, 1.0369565217391, 0.47222222222222
51408, 0.52173913043478, 1.0369565217391, 0.027777777777778
51409, 0.54347826086957, 1.0369565217391, 0.055555555555556
51410, 0.52173913043478, 1.0108695652174, 0.055555555555556
51411, 0.52173913043478, 1.0369565217391, 0.083333333333333
51412, 0.54347826086957, 1.0369565217391, 0.11111111111111
51413, 0.52173913043478, 1.0108695652174, 0.11111111111111
51414, 0.52173913043478, 1.0369565217391, 0.13888888888889
51415, 0.54347826086957, 1.0369565217391, 0.16666666666667
51416, 0.52173913043478, 1.0108695652174, 0.16666666666667
51417, 0.52173913043478, 1.0369565217391, 0.19444444444444
51418, 0.54347826086956, 1.0369565217391, 0.22222222222222
51419, 0.52173913043478, 1.0108695652174, 0.22222222222222
51420, 0.52173913043478, 1.0369565217391, 0.25
51421, 0.54347826086956, 1.0369565217391, 0.27777777777778
51422, 0.52173913043478, 1.0108695652174, 0.27777777777778
51423, 0.52173913043478, 1.0369565217391, 0.30555555555556
51424, 0.54347826086956, 1.0369565217391, 0.33333333333333
51425, 0.52173913043478, 1.0108695652174, 0.33333333333333
51426, 0.52173913043478, 1.0369565217391, 0.36111111111111
51427, 0.54347826086956, 1.0369565217391, 0.38888888888889
51428, 0.52173913043478, 1.0108695652174, 0.38888888888889
51429, 0.52173913043478, 1.0369565217391, 0.41666666666667
51430, 0.54347826086956, 1.0369565217391, 0.44444444444444
51431, 0.52173913043478, 1.0108695652174, 0.44444444444444
51432, 0.52173913043478, 1.0369565217391, 0.47222222222222
51433, 0.47826086956522, 1.0369565217391, 0.027777777777778
51434, 0.5, 1.0369565217391, 0.055555555555556
51435, 0.47826086956522, 1.0108695652174, 0.055555555555556
51436, 0.47826086956522, 1.0369565217391, 0.083333333333333
51437, 0.5, 1.0369565217391, 0.11111111111111
51438, 0.47826086956522, 1.0108695652174, 0.11111111111111
51439, 0.47826086956522, 1.0369565217391, 0.13888888888889
51440, 0.5, 1.0369565217391, 0.16666666666667
51441, 0.47826086956522, 1.0108695652174, 0.16666666666667
51442, 0.47826086956522, 1.0369565217391, 0.19444444444444
51443, 0.5, 1.0369565217391, 0.22222222222222
51444, 0.47826086956522, 1.0108695652174, 0.22222222222222
51445, 0.47826086956522, 1.0369565217391, 0.25
51446, 0.5, 1.0369565217391, 0.27777777777778
51447, 0.47826086956522, 1.0108695652174, 0.27777777777778
51448, 0.47826086956522, 1.0369565217391, 0.30555555555556
51449, 0.5, 1.0369565217391, 0.33333333333333
51450, 0.47826086956522, 1.0108695652174, 0.33333333333333
51451, 0.47826086956522, 1.0369565217391, 0.36111111111111
51452, 0.5, 1.0369565217391, 0.38888888888889
51453, 0.47826086956522, 1.0108695652174, 0.38888888888889
51454, 0.47826086956522, 1.0369565217391, 0.41666666666667
51455, 0.5, 1.0369565217391, 0.44444444444444
51456, 0.47826086956522, 1.0108695652174, 0.44444444444444
51457, 0.47826086956522, 1.0369565217391, 0.47222222222222
51458, 0.43478260869565, 1.0369565217391, 0.027777777777778
51459, 0.45652173913043, 1.0369565217391, 0.055555555555556
51460, 0.43478260869565, 1.0108695652174, 0.055555555555556
51461, 0.43478260869565, 1.0369565217391, 0.083333333333333
51462, 0.45652173913043, 1.0369565217391, 0.11111111111111
51463, 0.43478260869565, 1.0108695652174, 0.11111111111111
51464, 0.43478260869565, 1.0369565217391, 0.13888888888889
51465, 0.45652173913043, 1.0369565217391, 0.16666666666667
51466, 0.43478260869565, 1.0108695652174, 0.16666666666667
51467, 0.43478260869565, 1.0369565217391, 0.19444444444444
51468, 0.45652173913043, 1.0369565217391, 0.22222222222222
51469, 0.43478260869565, 1.0108695652174, 0.22222222222222
51470, 0.43478260869565, 1.0369565217391, 0.25
51471, 0.45652173913043, 1.0369565217391, 0.27777777777778
51472, 0.43478260869565, 1.0108695652174, 0.27777777777778
51473, 0.43478260869565, 1.0369565217391, 0.30555555555556
51474, 0.45652173913043, 1.0369565217391, 0.33333333333333
51475, 0.43478260869565, 1.0108695652174, 0.33333333333333
51476, 0.43478260869565, 1.0369565217391, 0.36111111111111
51477, 0.45652173913044, 1.0369565217391, 0.38888888888889
51478, 0.43478260869565, 1.0108695652174, 0.38888888888889
51479, 0.43478260869565, 1.0369565217391, 0.41666666666667
51480, 0.45652173913043, 1.0369565217391, 0.44444444444444
51481, 0.43478260869565, 1.0108695652174, 0.44444444444444
51482, 0.43478260869565, 1.0369565217391, 0.47222222222222
51483, 0.39130434782609, 1.0369565217391, 0.027777777777778
51484, 0.41304347826087, 1.0369565217391, 0.055555555555556
51485, 0.39130434782609, 1.0108695652174, 0.055555555555556
51486, 0.39130434782609, 1.0369565217391, 0.083333333333333
51487, 0.41304347826087, 1.0369565217391, 0.11111111111111
51488, 0.39130434782609, 1.0108695652174, 0.11111111111111
51489, 0.39130434782609, 1.0369565217391, 0.13888888888889
51490, 0.41304347826087, 1.0369565217391, 0.16666666666667
51491, 0.39130434782609, 1.0108695652174, 0.16666666666667
51492, 0.39130434782609, 1.0369565217391, 0.19444444444444
51493, 0.41304347826087, 1.0369565217391, 0.22222222222222
51494, 0.39130434782609, 1.0108695652174, 0.22222222222222
51495, 0.39130434782609, 1.0369565217391, 0.25
51496, 0.41304347826087, 1.0369565217391, 0.27777777777778
51497, 0.39130434782609, 1.0108695652174, 0.27777777777778
51498, 0.39130434782609, 1.0369565217391, 0.30555555555556
51499, 0.41304347826087, 1.0369565217391, 0.33333333333333
51500, 0.39130434782609, 1.0108695652174, 0.33333333333333
51501, 0.39130434782609, 1.0369565217391, 0.36111111111111
51502, 0.41304347826087, 1.0369565217391, 0.38888888888889
51503, 0.39130434782609, 1.0108695652174, 0.38888888888889
51504, 0.39130434782609, 1.0369565217391, 0.41666666666667
51505, 0.41304347826087, 1.0369565217391, 0.44444444444444
51506, 0.39130434782609, 1.0108695652174, 0.44444444444444
51507, 0.39130434782609, 1.0369565217391, 0.47222222222222
51508, 0.34782608695652, 1.0369565217391, 0.027777777777778
51509, 0.3695652173913, 1.0369565217391, 0.055555555555556
51510, 0.34782608695652, 1.0108695652174, 0.055555555555556
51511, 0.34782608695652, 1.0369565217391, 0.083333333333333
51512, 0.3695652173913, 1.0369565217391, 0.11111111111111
51513, 0.34782608695652, 1.0108695652174, 0.11111111111111
51514, 0.34782608695652, 1.0369565217391, 0.13888888888889
51515, 0.3695652173913, 1.0369565217391, 0.16666666666667
51516, 0.34782608695652, 1.0108695652174, 0.16666666666667
51517, 0.34782608695652, 1.0369565217391, 0.19444444444444
51518, 0.3695652173913, 1.0369565217391, 0.22222222222222
51519, 0.34782608695652, 1.0108695652174, 0.22222222222222
51520, 0.34782608695652, 1.0369565217391, 0.25
51521, 0.3695652173913, 1.0369565217391, 0.27777777777778
51522, 0.34782608695652, 1.0108695652174, 0.27777777777778
51523, 0.34782608695652, 1.0369565217391, 0.30555555555556
51524, 0.3695652173913, 1.0369565217391, 0.33333333333333
51525, 0.34782608695652, 1.0108695652174, 0.33333333333333
51526, 0.34782608695652, 1.0369565217391, 0.36111111111111
51527, 0.3695652173913, 1.0369565217391, 0.38888888888889
51528, 0.34782608695652, 1.0108695652174, 0.38888888888889
51529, 0.34782608695652, 1.0369565217391, 0.41666666666667
51530, 0.3695652173913, 1.0369565217391, 0.44444444444444
51531, 0.34782608695652, 1.0108695652174, 0.44444444444444
51532, 0.34782608695652, 1.0369565217391, 0.47222222222222
51533, 0.30434782608696, 1.0369565217391, 0.027777777777778
51534, 0.32608695652174, 1.0369565217391, 0.055555555555556
51535, 0.30434782608696, 1.0108695652174, 0.055555555555556
51536, 0.30434782608696, 1.0369565217391, 0.083333333333333
51537, 0.32608695652174, 1.0369565217391, 0.11111111111111
51538, 0.30434782608696, 1.0108695652174, 0.11111111111111
51539, 0.30434782608696, 1.0369565217391, 0.13888888888889
51540, 0.32608695652174, 1.0369565217391, 0.16666666666667
51541, 0.30434782608696, 1.0108695652174, 0.16666666666667
51542, 0.30434782608696, 1.0369565217391, 0.19444444444444
51543, 0.32608695652174, 1.0369565217391, 0.22222222222222
51544, 0.30434782608696, 1.0108695652174, 0.22222222222222
51545, 0.30434782608696, 1.0369565217391, 0.25
51546, 0.32608695652174, 1.0369565217391, 0.27777777777778
51547, 0.30434782608696, 1.0108695652174, 0.27777777777778
51548, 0.30434782608696, 1.0369565217391, 0.30555555555556
51549, 0.32608695652174, 1.0369565217391, 0.33333333333333
51550, 0.30434782608696, 1.0108695652174, 0.33333333333333
51551, 0.30434782608696, 1.0369565217391, 0.36111111111111
51552, 0.32608695652174, 1.0369565217391, 0.38888888888889
51553, 0.30434782608696, 1.0108695652174, 0.38888888888889
51554, 0.30434782608696, 1.0369565217391, 0.41666666666667
51555, 0.32608695652174, 1.0369565217391, 0.44444444444444
51556, 0.30434782608696, 1.0108695652174, 0.44444444444444
51557, 0.30434782608696, 1.0369565217391, 0.47222222222222
51558, 0.26086956521739, 1.0369565217391, 0.027777777777778
51559, 0.28260869565217, 1.0369565217391, 0.055555555555556
51560, 0.26086956521739, 1.0108695652174, 0.055555555555556
51561, 0.26086956521739, 1.0369565217391, 0.083333333333333
51562, 0.28260869565217, 1.0369565217391, 0.11111111111111
51563, 0.26086956521739, 1.0108695652174, 0.11111111111111
51564, 0.26086956521739, 1.0369565217391, 0.13888888888889
51565, 0.28260869565217, 1.0369565217391, 0.16666666666667
51566, 0.26086956521739, 1.0108695652174, 0.16666666666667
51567, 0.26086956521739, 1.0369565217391, 0.19444444444444
51568, 0.28260869565217, 1.0369565217391, 0.22222222222222
51569, 0.26086956521739, 1.0108695652174, 0.22222222222222
51570, 0.26086956521739, 1.0369565217391, 0.25
51571, 0.28260869565217, 1.0369565217391, 0.27777777777778
51572, 0.26086956521739, 1.0108695652174, 0.27777777777778
51573, 0.26086956521739, 1.0369565217391, 0.30555555555556
51574, 0.28260869565217, 1.0369565217391, 0.33333333333333
51575, 0.26086956521739, 1.0108695652174, 0.33333333333333
51576, 0.26086956521739, 1.0369565217391, 0.36111111111111
51577, 0.28260869565217, 1.0369565217391, 0.38888888888889
51578, 0.26086956521739, 1.0108695652174, 0.38888888888889
51579, 0.26086956521739, 1.0369565217391, 0.41666666666667
51580, 0.28260869565217, 1.0369565217391, 0.44444444444444
51581, 0.26086956521739, 1.0108695652174, 0.44444444444444
51582, 0.26086956521739, 1.0369565217391, 0.47222222222222
51583, 0.21739130434783, 1.0369565217391, 0.027777777777778
51584, 0.23913043478261, 1.0369565217391, 0.055555555555556
51585, 0.21739130434783, 1.0108695652174, 0.055555555555556
51586, 0.21739130434783, 1.0369565217391, 0.083333333333333
51587, 0.23913043478261, 1.0369565217391, 0.11111111111111
51588, 0.21739130434783, 1.0108695652174, 0.11111111111111
51589, 0.21739130434783, 1.0369565217391, 0.13888888888889
51590, 0.23913043478261, 1.0369565217391, 0.16666666666667
51591, 0.21739130434783, 1.0108695652174, 0.16666666666667
51592, 0.21739130434783, 1.0369565217391, 0.19444444444444
51593, 0.23913043478261, 1.0369565217391, 0.22222222222222
51594, 0.21739130434783, 1.0108695652174, 0.22222222222222
51595, 0.21739130434783, 1.0369565217391, 0.25
51596, 0.23913043478261, 1.0369565217391, 0.27777777777778
51597, 0.21739130434783, 1.0108695652174, 0.27777777777778
51598, 0.21739130434783, 1.0369565217391, 0.30555555555556
51599, 0.23913043478261, 1.0369565217391, 0.33333333333333
51600, 0.21739130434783, 1.0108695652174, 0.33333333333333
51601, 0.21739130434783, 1.0369565217391, 0.36111111111111
51602, 0.23913043478261, 1.0369565217391, 0.38888888888889
51603, 0.21739130434783, 1.0108695652174, 0.38888888888889
51604, 0.21739130434783, 1.0369565217391, 0.41666666666667
51605, 0.23913043478261, 1.0369565217391, 0.44444444444444
51606, 0.21739130434783, 1.0108695652174, 0.44444444444444
51607, 0.21739130434783, 1.0369565217391, 0.47222222222222
51608, 0.17391304347826, 1.0369565217391, 0.027777777777778
51609, 0.19565217391304, 1.0369565217391, 0.055555555555556
51610, 0.17391304347826, 1.0108695652174, 0.055555555555556
51611, 0.17391304347826, 1.0369565217391, 0.083333333333333
51612, 0.19565217391304, 1.0369565217391, 0.11111111111111
51613, 0.17391304347826, 1.0108695652174, 0.11111111111111
51614, 0.17391304347826, 1.0369565217391, 0.13888888888889
51615, 0.19565217391304, 1.0369565217391, 0.16666666666667
51616, 0.17391304347826, 1.0108695652174, 0.16666666666667
51617, 0.17391304347826, 1.0369565217391, 0.19444444444444
51618, 0.19565217391304, 1.0369565217391, 0.22222222222222
51619, 0.17391304347826, 1.0108695652174, 0.22222222222222
51620, 0.17391304347826, 1.0369565217391, 0.25
51621, 0.19565217391304, 1.0369565217391, 0.27777777777778
51622, 0.17391304347826, 1.0108695652174, 0.27777777777778
51623, 0.17391304347826, 1.0369565217391, 0.30555555555556
51624, 0.19565217391304, 1.0369565217391, 0.33333333333333
51625, 0.17391304347826, 1.0108695652174, 0.33333333333333
51626, 0.17391304347826, 1.0369565217391, 0.36111111111111
51627, 0.19565217391304, 1.0369565217391, 0.38888888888889
51628, 0.17391304347826, 1.0108695652174, 0.38888888888889
51629, 0.17391304347826, 1.0369565217391, 0.41666666666667
51630, 0.19565217391304, 1.0369565217391, 0.44444444444444
51631, 0.17391304347826, 1.0108695652174, 0.44444444444444
51632, 0.17391304347826, 1.0369565217391, 0.47222222222222
51633, 0.1304347826087, 1.0369565217391, 0.027777777777778
51634, 0.15217391304348, 1.0369565217391, 0.055555555555556
51635, 0.1304347826087, 1.0108695652174, 0.055555555555556
51636, 0.1304347826087, 1.0369565217391, 0.083333333333333
51637, 0.15217391304348, 1.0369565217391, 0.11111111111111
51638, 0.1304347826087, 1.0108695652174, 0.11111111111111
51639, 0.1304347826087, 1.0369565217391, 0.13888888888889
51640, 0.15217391304348, 1.0369565217391, 0.16666666666667
51641, 0.1304347826087, 1.0108695652174, 0.16666666666667
51642, 0.1304347826087, 1.0369565217391, 0.19444444444444
51643, 0.15217391304348, 1.0369565217391, 0.22222222222222
51644, 0.1304347826087, 1.0108695652174, 0.22222222222222
51645, 0.1304347826087, 1.0369565217391, 0.25
51646, 0.15217391304348, 1.0369565217391, 0.27777777777778
51647, 0.1304347826087, 1.0108695652174, 0.27777777777778
51648, 0.1304347826087, 1.0369565217391, 0.30555555555556
51649, 0.15217391304348, 1.0369565217391, 0.33333333333333
51650, 0.1304347826087, 1.0108695652174, 0.33333333333333
51651, 0.1304347826087, 1.0369565217391, 0.36111111111111
51652, 0.15217391304348, 1.0369565217391, 0.38888888888889
51653, 0.1304347826087, 1.0108695652174, 0.38888888888889
51654, 0.1304347826087, 1.0369565217391, 0.41666666666667
51655, 0.15217391304348, 1.0369565217391, 0.44444444444444
51656, 0.1304347826087, 1.0108695652174, 0.44444444444444
51657, 0.1304347826087, 1.0369565217391, 0.47222222222222
51658, 0.08695652173913, 1.0369565217391, 0.027777777777778
51659, 0.10869565217391, 1.0369565217391, 0.055555555555556
51660, 0.08695652173913, 1.0108695652174, 0.055555555555556
51661, 0.08695652173913, 1.0369565217391, 0.083333333333333
51662, 0.10869565217391, 1.0369565217391, 0.11111111111111
51663, 0.08695652173913, 1.0108695652174, 0.11111111111111
51664, 0.08695652173913, 1.0369565217391, 0.13888888888889
51665, 0.10869565217391, 1.0369565217391, 0.16666666666667
51666, 0.08695652173913, 1.0108695652174, 0.16666666666667
51667, 0.08695652173913, 1.0369565217391, 0.19444444444444
51668, 0.10869565217391, 1.0369565217391, 0.22222222222222
51669, 0.08695652173913, 1.0108695652174, 0.22222222222222
51670, 0.08695652173913, 1.0369565217391, 0.25
51671, 0.10869565217391, 1.0369565217391, 0.27777777777778
51672, 0.08695652173913, 1.0108695652174, 0.27777777777778
51673, 0.08695652173913, 1.0369565217391, 0.30555555555556
51674, 0.10869565217391, 1.0369565217391, 0.33333333333333
51675, 0.08695652173913, 1.0108695652174, 0.33333333333333
51676, 0.08695652173913, 1.0369565217391, 0.36111111111111
51677, 0.10869565217391, 1.0369565217391, 0.38888888888889
51678, 0.08695652173913, 1.0108695652174, 0.38888888888889
51679, 0.08695652173913, 1.0369565217391, 0.41666666666667
51680, 0.10869565217391, 1.0369565217391, 0.44444444444444
51681, 0.08695652173913, 1.0108695652174, 0.44444444444444
51682, 0.08695652173913, 1.0369565217391, 0.47222222222222
51683, 0.043478260869565, 1.0369565217391, 0.027777777777778
51684, 0.065217391304348, 1.0369565217391, 0.055555555555556
51685, 0.043478260869565, 1.0108695652174, 0.055555555555556
51686, 0.043478260869565, 1.0369565217391, 0.083333333333333
51687, 0.065217391304348, 1.0369565217391, 0.11111111111111
51688, 0.043478260869565, 1.0108695652174, 0.11111111111111
51689, 0.043478260869565, 1.0369565217391, 0.13888888888889
51690, 0.065217391304348, 1.0369565217391, 0.16666666666667
51691, 0.043478260869565, 1.0108695652174, 0.16666666666667
51692, 0.043478260869565, 1.0369565217391, 0.19444444444444
51693, 0.065217391304348, 1.0369565217391, 0.22222222222222
51694, 0.043478260869565, 1.0108695652174, 0.22222222222222
51695, 0.043478260869565, 1.0369565217391, 0.25
51696, 0.065217391304348, 1.0369565217391, 0.27777777777778
51697, 0.043478260869565, 1.0108695652174, 0.27777777777778
51698, 0.043478260869565, 1.0369565217391, 0.30555555555556
51699, 0.065217391304348, 1.0369565217391, 0.33333333333333
51700, 0.043478260869565, 1.0108695652174, 0.33333333333333
51701, 0.043478260869565, 1.0369565217391, 0.36111111111111
51702, 0.065217391304348, 1.0369565217391, 0.38888888888889
51703, 0.043478260869565, 1.0108695652174, 0.38888888888889
51704, 0.043478260869565, 1.0369565217391, 0.41666666666667
51705, 0.065217391304348, 1.0369565217391, 0.44444444444444
51706, 0.043478260869565, 1.0108695652174, 0.44444444444444
51707, 0.043478260869565, 1.0369565217391, 0.47222222222222
51708, 0.021739130434783, 1.0369565217391, 0.055555555555556
51709, 0.021739130434783, 1.0369565217391, 0.11111111111111
51710, 0.021739130434783, 1.0369565217391, 0.16666666666667
51711, 0.021739130434783, 1.0369565217391, 0.22222222222222
51712, 0.021739130434783, 1.0369565217391, 0.27777777777778
51713, 0.021739130434783, 1.0369565217391, 0.33333333333333
51714, 0.021739130434783, 1.0369565217391, 0.38888888888889
51715, 0.021739130434783, 1.0369565217391, 0.44444444444444
51716, 0.95652173913043, 1.0891304347826, 0.027777777777778
51717, 0.97826086956522, 1.0891304347826, 0.055555555555556
51718, 0.95652173913043, 1.0630434782609, 0.055555555555556
51719, 0.95652173913043, 1.0891304347826, 0.083333333333333
51720, 0.97826086956522, 1.0891304347826, 0.11111111111111
51721, 0.95652173913044, 1.0630434782609, 0.11111111111111
51722, 0.95652173913043, 1.0891304347826, 0.13888888888889
51723, 0.97826086956522, 1.0891304347826, 0.16666666666667
51724, 0.95652173913043, 1.0630434782609, 0.16666666666667
51725, 0.95652173913043, 1.0891304347826, 0.19444444444444
51726, 0.97826086956522, 1.0891304347826, 0.22222222222222
51727, 0.95652173913044, 1.0630434782609, 0.22222222222222
51728, 0.95652173913044, 1.0891304347826, 0.25
51729, 0.97826086956522, 1.0891304347826, 0.27777777777778
51730, 0.95652173913044, 1.0630434782609, 0.27777777777778
51731, 0.95652173913044, 1.0891304347826, 0.30555555555556
51732, 0.97826086956522, 1.0891304347826, 0.33333333333333
51733, 0.95652173913044, 1.0630434782609, 0.33333333333333
51734, 0.95652173913043, 1.0891304347826, 0.36111111111111
51735, 0.97826086956522, 1.0891304347826, 0.38888888888889
51736, 0.95652173913043, 1.0630434782609, 0.38888888888889
51737, 0.95652173913043, 1.0891304347826, 0.41666666666667
51738, 0.97826086956522, 1.0891304347826, 0.44444444444444
51739, 0.95652173913044, 1.0630434782609, 0.44444444444444
51740, 0.95652173913043, 1.0891304347826, 0.47222222222222
51741, 0.91304347826087, 1.0891304347826, 0.027777777777778
51742, 0.93478260869565, 1.0891304347826, 0.055555555555556
51743, 0.91304347826087, 1.0630434782609, 0.055555555555556
51744, 0.91304347826087, 1.0891304347826, 0.083333333333333
51745, 0.93478260869565, 1.0891304347826, 0.11111111111111
51746, 0.91304347826087, 1.0630434782609, 0.11111111111111
51747, 0.91304347826087, 1.0891304347826, 0.13888888888889
51748, 0.93478260869565, 1.0891304347826, 0.16666666666667
51749, 0.91304347826087, 1.0630434782609, 0.16666666666667
51750, 0.91304347826087, 1.0891304347826, 0.19444444444444
51751, 0.93478260869565, 1.0891304347826, 0.22222222222222
51752, 0.91304347826087, 1.0630434782609, 0.22222222222222
51753, 0.91304347826087, 1.0891304347826, 0.25
51754, 0.93478260869565, 1.0891304347826, 0.27777777777778
51755, 0.91304347826087, 1.0630434782609, 0.27777777777778
51756, 0.91304347826087, 1.0891304347826, 0.30555555555556
51757, 0.93478260869565, 1.0891304347826, 0.33333333333333
51758, 0.91304347826087, 1.0630434782609, 0.33333333333333
51759, 0.91304347826087, 1.0891304347826, 0.36111111111111
51760, 0.93478260869565, 1.0891304347826, 0.38888888888889
51761, 0.91304347826087, 1.0630434782609, 0.38888888888889
51762, 0.91304347826087, 1.0891304347826, 0.41666666666667
51763, 0.93478260869565, 1.0891304347826, 0.44444444444444
51764, 0.91304347826087, 1.0630434782609, 0.44444444444444
51765, 0.91304347826087, 1.0891304347826, 0.47222222222222
51766, 0.8695652173913, 1.0891304347826, 0.027777777777778
51767, 0.89130434782609, 1.0891304347826, 0.055555555555556
51768, 0.8695652173913, 1.0630434782609, 0.055555555555556
51769, 0.8695652173913, 1.0891304347826, 0.083333333333333
51770, 0.89130434782609, 1.0891304347826, 0.11111111111111
51771, 0.8695652173913, 1.0630434782609, 0.11111111111111
51772, 0.8695652173913, 1.0891304347826, 0.13888888888889
51773, 0.89130434782609, 1.0891304347826, 0.16666666666667
51774, 0.8695652173913, 1.0630434782609, 0.16666666666667
51775, 0.8695652173913, 1.0891304347826, 0.19444444444444
51776, 0.89130434782609, 1.0891304347826, 0.22222222222222
51777, 0.8695652173913, 1.0630434782609, 0.22222222222222
51778, 0.8695652173913, 1.0891304347826, 0.25
51779, 0.89130434782609, 1.0891304347826, 0.27777777777778
51780, 0.8695652173913, 1.0630434782609, 0.27777777777778
51781, 0.8695652173913, 1.0891304347826, 0.30555555555556
51782, 0.89130434782609, 1.0891304347826, 0.33333333333333
51783, 0.8695652173913, 1.0630434782609, 0.33333333333333
51784, 0.8695652173913, 1.0891304347826, 0.36111111111111
51785, 0.89130434782609, 1.0891304347826, 0.38888888888889
51786, 0.8695652173913, 1.0630434782609, 0.38888888888889
51787, 0.8695652173913, 1.0891304347826, 0.41666666666667
51788, 0.89130434782609, 1.0891304347826, 0.44444444444444
51789, 0.8695652173913, 1.0630434782609, 0.44444444444444
51790, 0.8695652173913, 1.0891304347826, 0.47222222222222
51791, 0.82608695652174, 1.0891304347826, 0.027777777777778
51792, 0.84782608695652, 1.0891304347826, 0.055555555555556
51793, 0.82608695652174, 1.0630434782609, 0.055555555555556
51794, 0.82608695652174, 1.0891304347826, 0.083333333333333
51795, 0.84782608695652, 1.0891304347826, 0.11111111111111
51796, 0.82608695652174, 1.0630434782609, 0.11111111111111
51797, 0.82608695652174, 1.0891304347826, 0.13888888888889
51798, 0.84782608695652, 1.0891304347826, 0.16666666666667
51799, 0.82608695652174, 1.0630434782609, 0.16666666666667
51800, 0.82608695652174, 1.0891304347826, 0.19444444444444
51801, 0.84782608695652, 1.0891304347826, 0.22222222222222
51802, 0.82608695652174, 1.0630434782609, 0.22222222222222
51803, 0.82608695652174, 1.0891304347826, 0.25
51804, 0.84782608695652, 1.0891304347826, 0.27777777777778
51805, 0.82608695652174, 1.0630434782609, 0.27777777777778
51806, 0.82608695652174, 1.0891304347826, 0.30555555555556
51807, 0.84782608695652, 1.0891304347826, 0.33333333333333
51808, 0.82608695652174, 1.0630434782609, 0.33333333333333
51809, 0.82608695652174, 1.0891304347826, 0.36111111111111
51810, 0.84782608695652, 1.0891304347826, 0.38888888888889
51811, 0.82608695652174, 1.0630434782609, 0.38888888888889
51812, 0.82608695652174, 1.0891304347826, 0.41666666666667
51813, 0.84782608695652, 1.0891304347826, 0.44444444444444
51814, 0.82608695652174, 1.0630434782609, 0.44444444444444
51815, 0.82608695652174, 1.0891304347826, 0.47222222222222
51816, 0.78260869565217, 1.0891304347826, 0.027777777777778
51817, 0.80434782608696, 1.0891304347826, 0.055555555555556
51818, 0.78260869565217, 1.0630434782609, 0.055555555555556
51819, 0.78260869565217, 1.0891304347826, 0.083333333333333
51820, 0.80434782608696, 1.0891304347826, 0.11111111111111
51821, 0.78260869565217, 1.0630434782609, 0.11111111111111
51822, 0.78260869565217, 1.0891304347826, 0.13888888888889
51823, 0.80434782608696, 1.0891304347826, 0.16666666666667
51824, 0.78260869565217, 1.0630434782609, 0.16666666666667
51825, 0.78260869565217, 1.0891304347826, 0.19444444444444
51826, 0.80434782608696, 1.0891304347826, 0.22222222222222
51827, 0.78260869565217, 1.0630434782609, 0.22222222222222
51828, 0.78260869565217, 1.0891304347826, 0.25
51829, 0.80434782608696, 1.0891304347826, 0.27777777777778
51830, 0.78260869565217, 1.0630434782609, 0.27777777777778
51831, 0.78260869565217, 1.0891304347826, 0.30555555555556
51832, 0.80434782608696, 1.0891304347826, 0.33333333333333
51833, 0.78260869565217, 1.0630434782609, 0.33333333333333
51834, 0.78260869565217, 1.0891304347826, 0.36111111111111
51835, 0.80434782608696, 1.0891304347826, 0.38888888888889
51836, 0.78260869565217, 1.0630434782609, 0.38888888888889
51837, 0.78260869565217, 1.0891304347826, 0.41666666666667
51838, 0.80434782608696, 1.0891304347826, 0.44444444444444
51839, 0.78260869565217, 1.0630434782609, 0.44444444444444
51840, 0.78260869565217, 1.0891304347826, 0.47222222222222
51841, 0.73913043478261, 1.0891304347826, 0.027777777777778
51842, 0.76086956521739, 1.0891304347826, 0.055555555555556
51843, 0.73913043478261, 1.0630434782609, 0.055555555555556
51844, 0.73913043478261, 1.0891304347826, 0.083333333333333
51845, 0.76086956521739, 1.0891304347826, 0.11111111111111
51846, 0.73913043478261, 1.0630434782609, 0.11111111111111
51847, 0.73913043478261, 1.0891304347826, 0.13888888888889
51848, 0.76086956521739, 1.0891304347826, 0.16666666666667
51849, 0.73913043478261, 1.0630434782609, 0.16666666666667
51850, 0.73913043478261, 1.0891304347826, 0.19444444444444
51851, 0.76086956521739, 1.0891304347826, 0.22222222222222
51852, 0.73913043478261, 1.0630434782609, 0.22222222222222
51853, 0.73913043478261, 1.0891304347826, 0.25
51854, 0.76086956521739, 1.0891304347826, 0.27777777777778
51855, 0.73913043478261, 1.0630434782609, 0.27777777777778
51856, 0.73913043478261, 1.0891304347826, 0.30555555555556
51857, 0.76086956521739, 1.0891304347826, 0.33333333333333
51858, 0.73913043478261, 1.0630434782609, 0.33333333333333
51859, 0.73913043478261, 1.0891304347826, 0.36111111111111
51860, 0.76086956521739, 1.0891304347826, 0.38888888888889
51861, 0.73913043478261, 1.0630434782609, 0.38888888888889
51862, 0.73913043478261, 1.0891304347826, 0.41666666666667
51863, 0.76086956521739, 1.0891304347826, 0.44444444444444
51864, 0.73913043478261, 1.0630434782609, 0.44444444444444
51865, 0.73913043478261, 1.0891304347826, 0.47222222222222
51866, 0.69565217391304, 1.0891304347826, 0.027777777777778
51867, 0.71739130434783, 1.0891304347826, 0.055555555555556
51868, 0.69565217391304, 1.0630434782609, 0.055555555555556
51869, 0.69565217391304, 1.0891304347826, 0.083333333333333
51870, 0.71739130434783, 1.0891304347826, 0.11111111111111
51871, 0.69565217391304, 1.0630434782609, 0.11111111111111
51872, 0.69565217391304, 1.0891304347826, 0.13888888888889
51873, 0.71739130434783, 1.0891304347826, 0.16666666666667
51874, 0.69565217391304, 1.0630434782609, 0.16666666666667
51875, 0.69565217391304, 1.0891304347826, 0.19444444444444
51876, 0.71739130434783, 1.0891304347826, 0.22222222222222
51877, 0.69565217391304, 1.0630434782609, 0.22222222222222
51878, 0.69565217391304, 1.0891304347826, 0.25
51879, 0.71739130434783, 1.0891304347826, 0.27777777777778
51880, 0.69565217391304, 1.0630434782609, 0.27777777777778
51881, 0.69565217391304, 1.0891304347826, 0.30555555555556
51882, 0.71739130434783, 1.0891304347826, 0.33333333333333
51883, 0.69565217391304, 1.0630434782609, 0.33333333333333
51884, 0.69565217391304, 1.0891304347826, 0.36111111111111
51885, 0.71739130434783, 1.0891304347826, 0.38888888888889
51886, 0.69565217391304, 1.0630434782609, 0.38888888888889
51887, 0.69565217391304, 1.0891304347826, 0.41666666666667
51888, 0.71739130434783, 1.0891304347826, 0.44444444444444
51889, 0.69565217391304, 1.0630434782609, 0.44444444444444
51890, 0.69565217391304, 1.0891304347826, 0.47222222222222
51891, 0.65217391304348, 1.0891304347826, 0.027777777777778
51892, 0.67391304347826, 1.0891304347826, 0.055555555555556
51893, 0.65217391304348, 1.0630434782609, 0.055555555555556
51894, 0.65217391304348, 1.0891304347826, 0.083333333333333
51895, 0.67391304347826, 1.0891304347826, 0.11111111111111
51896, 0.65217391304348, 1.0630434782609, 0.11111111111111
51897, 0.65217391304348, 1.0891304347826, 0.13888888888889
51898, 0.67391304347826, 1.0891304347826, 0.16666666666667
51899, 0.65217391304348, 1.0630434782609, 0.16666666666667
51900, 0.65217391304348, 1.0891304347826, 0.19444444444444
51901, 0.67391304347826, 1.0891304347826, 0.22222222222222
51902, 0.65217391304348, 1.0630434782609, 0.22222222222222
51903, 0.65217391304348, 1.0891304347826, 0.25
51904, 0.67391304347826, 1.0891304347826, 0.27777777777778
51905, 0.65217391304348, 1.0630434782609, 0.27777777777778
51906, 0.65217391304348, 1.0891304347826, 0.30555555555556
51907, 0.67391304347826, 1.0891304347826, 0.33333333333333
51908, 0.65217391304348, 1.0630434782609, 0.33333333333333
51909, 0.65217391304348, 1.0891304347826, 0.36111111111111
51910, 0.67391304347826, 1.0891304347826, 0.38888888888889
51911, 0.65217391304348, 1.0630434782609, 0.38888888888889
51912, 0.65217391304348, 1.0891304347826, 0.41666666666667
51913, 0.67391304347826, 1.0891304347826, 0.44444444444444
51914, 0.65217391304348, 1.0630434782609, 0.44444444444444
51915, 0.65217391304348, 1.0891304347826, 0.47222222222222
51916, 0.60869565217391, 1.0891304347826, 0.027777777777778
51917, 0.6304347826087, 1.0891304347826, 0.055555555555556
51918, 0.60869565217391, 1.0630434782609, 0.055555555555556
51919, 0.60869565217391, 1.0891304347826, 0.083333333333333
51920, 0.6304347826087, 1.0891304347826, 0.11111111111111
51921, 0.60869565217391, 1.0630434782609, 0.11111111111111
51922, 0.60869565217391, 1.0891304347826, 0.13888888888889
51923, 0.6304347826087, 1.0891304347826, 0.16666666666667
51924, 0.60869565217391, 1.0630434782609, 0.16666666666667
51925, 0.60869565217391, 1.0891304347826, 0.19444444444444
51926, 0.6304347826087, 1.0891304347826, 0.22222222222222
51927, 0.60869565217391, 1.0630434782609, 0.22222222222222
51928, 0.60869565217391, 1.0891304347826, 0.25
51929, 0.6304347826087, 1.0891304347826, 0.27777777777778
51930, 0.60869565217391, 1.0630434782609, 0.27777777777778
51931, 0.60869565217391, 1.0891304347826, 0.30555555555556
51932, 0.6304347826087, 1.0891304347826, 0.33333333333333
51933, 0.60869565217391, 1.0630434782609, 0.33333333333333
51934, 0.60869565217391, 1.0891304347826, 0.36111111111111
51935, 0.6304347826087, 1.0891304347826, 0.38888888888889
51936, 0.60869565217391, 1.0630434782609, 0.38888888888889
51937, 0.60869565217391, 1.0891304347826, 0.41666666666667
51938, 0.6304347826087, 1.0891304347826, 0.44444444444444
51939, 0.60869565217391, 1.0630434782609, 0.44444444444444
51940, 0.60869565217391, 1.0891304347826, 0.47222222222222
51941, 0.56521739130435, 1.0891304347826, 0.027777777777778
51942, 0.58695652173913, 1.0891304347826, 0.055555555555556
51943, 0.56521739130435, 1.0630434782609, 0.055555555555556
51944, 0.56521739130435, 1.0891304347826, 0.083333333333333
51945, 0.58695652173913, 1.0891304347826, 0.11111111111111
51946, 0.56521739130435, 1.0630434782609, 0.11111111111111
51947, 0.56521739130435, 1.0891304347826, 0.13888888888889
51948, 0.58695652173913, 1.0891304347826, 0.16666666666667
51949, 0.56521739130435, 1.0630434782609, 0.16666666666667
51950, 0.56521739130435, 1.0891304347826, 0.19444444444444
51951, 0.58695652173913, 1.0891304347826, 0.22222222222222
51952, 0.56521739130435, 1.0630434782609, 0.22222222222222
51953, 0.56521739130435, 1.0891304347826, 0.25
51954, 0.58695652173913, 1.0891304347826, 0.27777777777778
51955, 0.56521739130435, 1.0630434782609, 0.27777777777778
51956, 0.56521739130435, 1.0891304347826, 0.30555555555556
51957, 0.58695652173913, 1.0891304347826, 0.33333333333333
51958, 0.56521739130435, 1.0630434782609, 0.33333333333333
51959, 0.56521739130435, 1.0891304347826, 0.36111111111111
51960, 0.58695652173913, 1.0891304347826, 0.38888888888889
51961, 0.56521739130435, 1.0630434782609, 0.38888888888889
51962, 0.56521739130435, 1.0891304347826, 0.41666666666667
51963, 0.58695652173913, 1.0891304347826, 0.44444444444444
51964, 0.56521739130435, 1.0630434782609, 0.44444444444444
51965, 0.56521739130435, 1.0891304347826, 0.47222222222222
51966, 0.52173913043478, 1.0891304347826, 0.027777777777778
51967, 0.54347826086957, 1.0891304347826, 0.055555555555556
51968, 0.52173913043478, 1.0630434782609, 0.055555555555556
51969, 0.52173913043478, 1.0891304347826, 0.083333333333333
51970, 0.54347826086957, 1.0891304347826, 0.11111111111111
51971, 0.52173913043478, 1.0630434782609, 0.11111111111111
51972, 0.52173913043478, 1.0891304347826, 0.13888888888889
51973, 0.54347826086957, 1.0891304347826, 0.16666666666667
51974, 0.52173913043478, 1.0630434782609, 0.16666666666667
51975, 0.52173913043478, 1.0891304347826, 0.19444444444444
51976, 0.54347826086956, 1.0891304347826, 0.22222222222222
51977, 0.52173913043478, 1.0630434782609, 0.22222222222222
51978, 0.52173913043478, 1.0891304347826, 0.25
51979, 0.54347826086956, 1.0891304347826, 0.27777777777778
51980, 0.52173913043478, 1.0630434782609, 0.27777777777778
51981, 0.52173913043478, 1.0891304347826, 0.30555555555556
51982, 0.54347826086956, 1.0891304347826, 0.33333333333333
51983, 0.52173913043478, 1.0630434782609, 0.33333333333333
51984, 0.52173913043478, 1.0891304347826, 0.36111111111111
51985, 0.54347826086956, 1.0891304347826, 0.38888888888889
51986, 0.52173913043478, 1.0630434782609, 0.38888888888889
51987, 0.52173913043478, 1.0891304347826, 0.41666666666667
51988, 0.54347826086956, 1.0891304347826, 0.44444444444444
51989, 0.52173913043478, 1.0630434782609, 0.44444444444444
51990, 0.52173913043478, 1.0891304347826, 0.47222222222222
51991, 0.47826086956522, 1.0891304347826, 0.027777777777778
51992, 0.5, 1.0891304347826, 0.055555555555556
51993, 0.47826086956522, 1.0630434782609, 0.055555555555556
51994, 0.47826086956522, 1.0891304347826, 0.083333333333333
51995, 0.5, 1.0891304347826, 0.11111111111111
51996, 0.47826086956522, 1.0630434782609, 0.11111111111111
51997, 0.47826086956522, 1.0891304347826, 0.13888888888889
51998, 0.5, 1.0891304347826, 0.16666666666667
51999, 0.47826086956522, 1.0630434782609, 0.16666666666667
52000, 0.47826086956522, 1.0891304347826, 0.19444444444444
52001, 0.5, 1.0891304347826, 0.22222222222222
52002, 0.47826086956522, 1.0630434782609, 0.22222222222222
52003, 0.47826086956522, 1.0891304347826, 0.25
52004, 0.5, 1.0891304347826, 0.27777777777778
52005, 0.47826086956522, 1.0630434782609, 0.27777777777778
52006, 0.47826086956522, 1.0891304347826, 0.30555555555556
52007, 0.5, 1.0891304347826, 0.33333333333333
52008, 0.47826086956522, 1.0630434782609, 0.33333333333333
52009, 0.47826086956522, 1.0891304347826, 0.36111111111111
52010, 0.5, 1.0891304347826, 0.38888888888889
52011, 0.47826086956522, 1.0630434782609, 0.38888888888889
52012, 0.47826086956522, 1.0891304347826, 0.41666666666667
52013, 0.5, 1.0891304347826, 0.44444444444444
52014, 0.47826086956522, 1.0630434782609, 0.44444444444444
52015, 0.47826086956522, 1.0891304347826, 0.47222222222222
52016, 0.43478260869565, 1.0891304347826, 0.027777777777778
52017, 0.45652173913043, 1.0891304347826, 0.055555555555556
52018, 0.43478260869565, 1.0630434782609, 0.055555555555556
52019, 0.43478260869565, 1.0891304347826, 0.083333333333333
52020, 0.45652173913043, 1.0891304347826, 0.11111111111111
52021, 0.43478260869565, 1.0630434782609, 0.11111111111111
52022, 0.43478260869565, 1.0891304347826, 0.13888888888889
52023, 0.45652173913043, 1.0891304347826, 0.16666666666667
52024, 0.43478260869565, 1.0630434782609, 0.16666666666667
52025, 0.43478260869565, 1.0891304347826, 0.19444444444444
52026, 0.45652173913043, 1.0891304347826, 0.22222222222222
52027, 0.43478260869565, 1.0630434782609, 0.22222222222222
52028, 0.43478260869565, 1.0891304347826, 0.25
52029, 0.45652173913043, 1.0891304347826, 0.27777777777778
52030, 0.43478260869565, 1.0630434782609, 0.27777777777778
52031, 0.43478260869565, 1.0891304347826, 0.30555555555556
52032, 0.45652173913043, 1.0891304347826, 0.33333333333333
52033, 0.43478260869565, 1.0630434782609, 0.33333333333333
52034, 0.43478260869565, 1.0891304347826, 0.36111111111111
52035, 0.45652173913043, 1.0891304347826, 0.38888888888889
52036, 0.43478260869565, 1.0630434782609, 0.38888888888889
52037, 0.43478260869565, 1.0891304347826, 0.41666666666667
52038, 0.45652173913043, 1.0891304347826, 0.44444444444444
52039, 0.43478260869565, 1.0630434782609, 0.44444444444444
52040, 0.43478260869565, 1.0891304347826, 0.47222222222222
52041, 0.39130434782609, 1.0891304347826, 0.027777777777778
52042, 0.41304347826087, 1.0891304347826, 0.055555555555556
52043, 0.39130434782609, 1.0630434782609, 0.055555555555556
52044, 0.39130434782609, 1.0891304347826, 0.083333333333333
52045, 0.41304347826087, 1.0891304347826, 0.11111111111111
52046, 0.39130434782609, 1.0630434782609, 0.11111111111111
52047, 0.39130434782609, 1.0891304347826, 0.13888888888889
52048, 0.41304347826087, 1.0891304347826, 0.16666666666667
52049, 0.39130434782609, 1.0630434782609, 0.16666666666667
52050, 0.39130434782609, 1.0891304347826, 0.19444444444444
52051, 0.41304347826087, 1.0891304347826, 0.22222222222222
52052, 0.39130434782609, 1.0630434782609, 0.22222222222222
52053, 0.39130434782609, 1.0891304347826, 0.25
52054, 0.41304347826087, 1.0891304347826, 0.27777777777778
52055, 0.39130434782609, 1.0630434782609, 0.27777777777778
52056, 0.39130434782609, 1.0891304347826, 0.30555555555556
52057, 0.41304347826087, 1.0891304347826, 0.33333333333333
52058, 0.39130434782609, 1.0630434782609, 0.33333333333333
52059, 0.39130434782609, 1.0891304347826, 0.36111111111111
52060, 0.41304347826087, 1.0891304347826, 0.38888888888889
52061, 0.39130434782609, 1.0630434782609, 0.38888888888889
52062, 0.39130434782609, 1.0891304347826, 0.41666666666667
52063, 0.41304347826087, 1.0891304347826, 0.44444444444444
52064, 0.39130434782609, 1.0630434782609, 0.44444444444444
52065, 0.39130434782609, 1.0891304347826, 0.47222222222222
52066, 0.34782608695652, 1.0891304347826, 0.027777777777778
52067, 0.3695652173913, 1.0891304347826, 0.055555555555556
52068, 0.34782608695652, 1.0630434782609, 0.055555555555556
52069, 0.34782608695652, 1.0891304347826, 0.083333333333333
52070, 0.3695652173913, 1.0891304347826, 0.11111111111111
52071, 0.34782608695652, 1.0630434782609, 0.11111111111111
52072, 0.34782608695652, 1.0891304347826, 0.13888888888889
52073, 0.3695652173913, 1.0891304347826, 0.16666666666667
52074, 0.34782608695652, 1.0630434782609, 0.16666666666667
52075, 0.34782608695652, 1.0891304347826, 0.19444444444444
52076, 0.3695652173913, 1.0891304347826, 0.22222222222222
52077, 0.34782608695652, 1.0630434782609, 0.22222222222222
52078, 0.34782608695652, 1.0891304347826, 0.25
52079, 0.3695652173913, 1.0891304347826, 0.27777777777778
52080, 0.34782608695652, 1.0630434782609, 0.27777777777778
52081, 0.34782608695652, 1.0891304347826, 0.30555555555556
52082, 0.3695652173913, 1.0891304347826, 0.33333333333333
52083, 0.34782608695652, 1.0630434782609, 0.33333333333333
52084, 0.34782608695652, 1.0891304347826, 0.36111111111111
52085, 0.3695652173913, 1.0891304347826, 0.38888888888889
52086, 0.34782608695652, 1.0630434782609, 0.38888888888889
52087, 0.34782608695652, 1.0891304347826, 0.41666666666667
52088, 0.3695652173913, 1.0891304347826, 0.44444444444444
52089, 0.34782608695652, 1.0630434782609, 0.44444444444444
52090, 0.34782608695652, 1.0891304347826, 0.47222222222222
52091, 0.30434782608696, 1.0891304347826, 0.027777777777778
52092, 0.32608695652174, 1.0891304347826, 0.055555555555556
52093, 0.30434782608696, 1.0630434782609, 0.055555555555556
52094, 0.30434782608696, 1.0891304347826, 0.083333333333333
52095, 0.32608695652174, 1.0891304347826, 0.11111111111111
52096, 0.30434782608696, 1.0630434782609, 0.11111111111111
52097, 0.30434782608696, 1.0891304347826, 0.13888888888889
52098, 0.32608695652174, 1.0891304347826, 0.16666666666667
52099, 0.30434782608696, 1.0630434782609, 0.16666666666667
52100, 0.30434782608696, 1.0891304347826, 0.19444444444444
52101, 0.32608695652174, 1.0891304347826, 0.22222222222222
52102, 0.30434782608696, 1.0630434782609, 0.22222222222222
52103, 0.30434782608696, 1.0891304347826, 0.25
52104, 0.32608695652174, 1.0891304347826, 0.27777777777778
52105, 0.30434782608696, 1.0630434782609, 0.27777777777778
52106, 0.30434782608696, 1.0891304347826, 0.30555555555556
52107, 0.32608695652174, 1.0891304347826, 0.33333333333333
52108, 0.30434782608696, 1.0630434782609, 0.33333333333333
52109, 0.30434782608696, 1.0891304347826, 0.36111111111111
52110, 0.32608695652174, 1.0891304347826, 0.38888888888889
52111, 0.30434782608696, 1.0630434782609, 0.38888888888889
52112, 0.30434782608696, 1.0891304347826, 0.41666666666667
52113, 0.32608695652174, 1.0891304347826, 0.44444444444444
52114, 0.30434782608696, 1.0630434782609, 0.44444444444444
52115, 0.30434782608696, 1.0891304347826, 0.47222222222222
52116, 0.26086956521739, 1.0891304347826, 0.027777777777778
52117, 0.28260869565217, 1.0891304347826, 0.055555555555556
52118, 0.26086956521739, 1.0630434782609, 0.055555555555556
52119, 0.26086956521739, 1.0891304347826, 0.083333333333333
52120, 0.28260869565217, 1.0891304347826, 0.11111111111111
52121, 0.26086956521739, 1.0630434782609, 0.11111111111111
52122, 0.26086956521739, 1.0891304347826, 0.13888888888889
52123, 0.28260869565217, 1.0891304347826, 0.16666666666667
52124, 0.26086956521739, 1.0630434782609, 0.16666666666667
52125, 0.26086956521739, 1.0891304347826, 0.19444444444444
52126, 0.28260869565217, 1.0891304347826, 0.22222222222222
52127, 0.26086956521739, 1.0630434782609, 0.22222222222222
52128, 0.26086956521739, 1.0891304347826, 0.25
52129, 0.28260869565217, 1.0891304347826, 0.27777777777778
52130, 0.26086956521739, 1.0630434782609, 0.27777777777778
52131, 0.26086956521739, 1.0891304347826, 0.30555555555556
52132, 0.28260869565217, 1.0891304347826, 0.33333333333333
52133, 0.26086956521739, 1.0630434782609, 0.33333333333333
52134, 0.26086956521739, 1.0891304347826, 0.36111111111111
52135, 0.28260869565217, 1.0891304347826, 0.38888888888889
52136, 0.26086956521739, 1.0630434782609, 0.38888888888889
52137, 0.26086956521739, 1.0891304347826, 0.41666666666667
52138, 0.28260869565217, 1.0891304347826, 0.44444444444444
52139, 0.26086956521739, 1.0630434782609, 0.44444444444444
52140, 0.26086956521739, 1.0891304347826, 0.47222222222222
52141, 0.21739130434783, 1.0891304347826, 0.027777777777778
52142, 0.23913043478261, 1.0891304347826, 0.055555555555556
52143, 0.21739130434783, 1.0630434782609, 0.055555555555556
52144, 0.21739130434783, 1.0891304347826, 0.083333333333333
52145, 0.23913043478261, 1.0891304347826, 0.11111111111111
52146, 0.21739130434783, 1.0630434782609, 0.11111111111111
52147, 0.21739130434783, 1.0891304347826, 0.13888888888889
52148, 0.23913043478261, 1.0891304347826, 0.16666666666667
52149, 0.21739130434783, 1.0630434782609, 0.16666666666667
52150, 0.21739130434783, 1.0891304347826, 0.19444444444444
52151, 0.23913043478261, 1.0891304347826, 0.22222222222222
52152, 0.21739130434783, 1.0630434782609, 0.22222222222222
52153, 0.21739130434783, 1.0891304347826, 0.25
52154, 0.23913043478261, 1.0891304347826, 0.27777777777778
52155, 0.21739130434783, 1.0630434782609, 0.27777777777778
52156, 0.21739130434783, 1.0891304347826, 0.30555555555556
52157, 0.23913043478261, 1.0891304347826, 0.33333333333333
52158, 0.21739130434783, 1.0630434782609, 0.33333333333333
52159, 0.21739130434783, 1.0891304347826, 0.36111111111111
52160, 0.23913043478261, 1.0891304347826, 0.38888888888889
52161, 0.21739130434783, 1.0630434782609, 0.38888888888889
52162, 0.21739130434783, 1.0891304347826, 0.41666666666667
52163, 0.23913043478261, 1.0891304347826, 0.44444444444444
52164, 0.21739130434783, 1.0630434782609, 0.44444444444444
52165, 0.21739130434783, 1.0891304347826, 0.47222222222222
52166, 0.17391304347826, 1.0891304347826, 0.027777777777778
52167, 0.19565217391304, 1.0891304347826, 0.055555555555556
52168, 0.17391304347826, 1.0630434782609, 0.055555555555556
52169, 0.17391304347826, 1.0891304347826, 0.083333333333333
52170, 0.19565217391304, 1.0891304347826, 0.11111111111111
52171, 0.17391304347826, 1.0630434782609, 0.11111111111111
52172, 0.17391304347826, 1.0891304347826, 0.13888888888889
52173, 0.19565217391304, 1.0891304347826, 0.16666666666667
52174, 0.17391304347826, 1.0630434782609, 0.16666666666667
52175, 0.17391304347826, 1.0891304347826, 0.19444444444444
52176, 0.19565217391304, 1.0891304347826, 0.22222222222222
52177, 0.17391304347826, 1.0630434782609, 0.22222222222222
52178, 0.17391304347826, 1.0891304347826, 0.25
52179, 0.19565217391304, 1.0891304347826, 0.27777777777778
52180, 0.17391304347826, 1.0630434782609, 0.27777777777778
52181, 0.17391304347826, 1.0891304347826, 0.30555555555556
52182, 0.19565217391304, 1.0891304347826, 0.33333333333333
52183, 0.17391304347826, 1.0630434782609, 0.33333333333333
52184, 0.17391304347826, 1.0891304347826, 0.36111111111111
52185, 0.19565217391304, 1.0891304347826, 0.38888888888889
52186, 0.17391304347826, 1.0630434782609, 0.38888888888889
52187, 0.17391304347826, 1.0891304347826, 0.41666666666667
52188, 0.19565217391304, 1.0891304347826, 0.44444444444444
52189, 0.17391304347826, 1.0630434782609, 0.44444444444444
52190, 0.17391304347826, 1.0891304347826, 0.47222222222222
52191, 0.1304347826087, 1.0891304347826, 0.027777777777778
52192, 0.15217391304348, 1.0891304347826, 0.055555555555556
52193, 0.1304347826087, 1.0630434782609, 0.055555555555556
52194, 0.1304347826087, 1.0891304347826, 0.083333333333333
52195, 0.15217391304348, 1.0891304347826, 0.11111111111111
52196, 0.1304347826087, 1.0630434782609, 0.11111111111111
52197, 0.1304347826087, 1.0891304347826, 0.13888888888889
52198, 0.15217391304348, 1.0891304347826, 0.16666666666667
52199, 0.1304347826087, 1.0630434782609, 0.16666666666667
52200, 0.1304347826087, 1.0891304347826, 0.19444444444444
52201, 0.15217391304348, 1.0891304347826, 0.22222222222222
52202, 0.1304347826087, 1.0630434782609, 0.22222222222222
52203, 0.1304347826087, 1.0891304347826, 0.25
52204, 0.15217391304348, 1.0891304347826, 0.27777777777778
52205, 0.1304347826087, 1.0630434782609, 0.27777777777778
52206, 0.1304347826087, 1.0891304347826, 0.30555555555556
52207, 0.15217391304348, 1.0891304347826, 0.33333333333333
52208, 0.1304347826087, 1.0630434782609, 0.33333333333333
52209, 0.1304347826087, 1.0891304347826, 0.36111111111111
52210, 0.15217391304348, 1.0891304347826, 0.38888888888889
52211, 0.1304347826087, 1.0630434782609, 0.38888888888889
52212, 0.1304347826087, 1.0891304347826, 0.41666666666667
52213, 0.15217391304348, 1.0891304347826, 0.44444444444444
52214, 0.1304347826087, 1.0630434782609, 0.44444444444444
52215, 0.1304347826087, 1.0891304347826, 0.47222222222222
52216, 0.08695652173913, 1.0891304347826, 0.027777777777778
52217, 0.10869565217391, 1.0891304347826, 0.055555555555556
52218, 0.08695652173913, 1.0630434782609, 0.055555555555556
52219, 0.08695652173913, 1.0891304347826, 0.083333333333333
52220, 0.10869565217391, 1.0891304347826, 0.11111111111111
52221, 0.08695652173913, 1.0630434782609, 0.11111111111111
52222, 0.08695652173913, 1.0891304347826, 0.13888888888889
52223, 0.10869565217391, 1.0891304347826, 0.16666666666667
52224, 0.08695652173913, 1.0630434782609, 0.16666666666667
52225, 0.08695652173913, 1.0891304347826, 0.19444444444444
52226, 0.10869565217391, 1.0891304347826, 0.22222222222222
52227, 0.08695652173913, 1.0630434782609, 0.22222222222222
52228, 0.08695652173913, 1.0891304347826, 0.25
52229, 0.10869565217391, 1.0891304347826, 0.27777777777778
52230, 0.08695652173913, 1.0630434782609, 0.27777777777778
52231, 0.08695652173913, 1.0891304347826, 0.30555555555556
52232, 0.10869565217391, 1.0891304347826, 0.33333333333333
52233, 0.08695652173913, 1.0630434782609, 0.33333333333333
52234, 0.08695652173913, 1.0891304347826, 0.36111111111111
52235, 0.10869565217391, 1.0891304347826, 0.38888888888889
52236, 0.08695652173913, 1.0630434782609, 0.38888888888889
52237, 0.08695652173913, 1.0891304347826, 0.41666666666667
52238, 0.10869565217391, 1.0891304347826, 0.44444444444444
52239, 0.08695652173913, 1.0630434782609, 0.44444444444444
52240, 0.08695652173913, 1.0891304347826, 0.47222222222222
52241, 0.043478260869565, 1.0891304347826, 0.027777777777778
52242, 0.065217391304348, 1.0891304347826, 0.055555555555556
52243, 0.043478260869565, 1.0630434782609, 0.055555555555556
52244, 0.043478260869565, 1.0891304347826, 0.083333333333333
52245, 0.065217391304348, 1.0891304347826, 0.11111111111111
52246, 0.043478260869565, 1.0630434782609, 0.11111111111111
52247, 0.043478260869565, 1.0891304347826, 0.13888888888889
52248, 0.065217391304348, 1.0891304347826, 0.16666666666667
52249, 0.043478260869565, 1.0630434782609, 0.16666666666667
52250, 0.043478260869565, 1.0891304347826, 0.19444444444444
52251, 0.065217391304348, 1.0891304347826, 0.22222222222222
52252, 0.043478260869565, 1.0630434782609, 0.22222222222222
52253, 0.043478260869565, 1.0891304347826, 0.25
52254, 0.065217391304348, 1.0891304347826, 0.27777777777778
52255, 0.043478260869565, 1.0630434782609, 0.27777777777778
52256, 0.043478260869565, 1.0891304347826, 0.30555555555556
52257, 0.065217391304348, 1.0891304347826, 0.33333333333333
52258, 0.043478260869565, 1.0630434782609, 0.33333333333333
52259, 0.043478260869565, 1.0891304347826, 0.36111111111111
52260, 0.065217391304348, 1.0891304347826, 0.38888888888889
52261, 0.043478260869565, 1.0630434782609, 0.38888888888889
52262, 0.043478260869565, 1.0891304347826, 0.41666666666667
52263, 0.065217391304348, 1.0891304347826, 0.44444444444444
52264, 0.043478260869565, 1.0630434782609, 0.44444444444444
52265, 0.043478260869565, 1.0891304347826, 0.47222222222222
52266, 0.021739130434783, 1.0891304347826, 0.055555555555556
52267, 0.021739130434783, 1.0891304347826, 0.11111111111111
52268, 0.021739130434783, 1.0891304347826, 0.16666666666667
52269, 0.021739130434783, 1.0891304347826, 0.22222222222222
52270, 0.021739130434783, 1.0891304347826, 0.27777777777778
52271, 0.021739130434783, 1.0891304347826, 0.33333333333333
52272, 0.021739130434783, 1.0891304347826, 0.38888888888889
52273, 0.021739130434783, 1.0891304347826, 0.44444444444444
52274, 0.95652173913043, 1.1413043478261, 0.027777777777778
52275, 0.97826086956522, 1.1413043478261, 0.055555555555556
52276, 0.95652173913043, 1.1152173913043, 0.055555555555556
52277, 0.95652173913043, 1.1413043478261, 0.083333333333333
52278, 0.97826086956522, 1.1413043478261, 0.11111111111111
52279, 0.95652173913043, 1.1152173913043, 0.11111111111111
52280, 0.95652173913043, 1.1413043478261, 0.13888888888889
52281, 0.97826086956522, 1.1413043478261, 0.16666666666667
52282, 0.95652173913043, 1.1152173913043, 0.16666666666667
52283, 0.95652173913043, 1.1413043478261, 0.19444444444444
52284, 0.97826086956522, 1.1413043478261, 0.22222222222222
52285, 0.95652173913044, 1.1152173913043, 0.22222222222222
52286, 0.95652173913044, 1.1413043478261, 0.25
52287, 0.97826086956522, 1.1413043478261, 0.27777777777778
52288, 0.95652173913044, 1.1152173913043, 0.27777777777778
52289, 0.95652173913043, 1.1413043478261, 0.30555555555556
52290, 0.97826086956522, 1.1413043478261, 0.33333333333333
52291, 0.95652173913043, 1.1152173913043, 0.33333333333333
52292, 0.95652173913043, 1.1413043478261, 0.36111111111111
52293, 0.97826086956522, 1.1413043478261, 0.38888888888889
52294, 0.95652173913043, 1.1152173913043, 0.38888888888889
52295, 0.95652173913044, 1.1413043478261, 0.41666666666667
52296, 0.97826086956522, 1.1413043478261, 0.44444444444444
52297, 0.95652173913044, 1.1152173913043, 0.44444444444444
52298, 0.95652173913043, 1.1413043478261, 0.47222222222222
52299, 0.91304347826087, 1.1413043478261, 0.027777777777778
52300, 0.93478260869565, 1.1413043478261, 0.055555555555556
52301, 0.91304347826087, 1.1152173913043, 0.055555555555556
52302, 0.91304347826087, 1.1413043478261, 0.083333333333333
52303, 0.93478260869565, 1.1413043478261, 0.11111111111111
52304, 0.91304347826087, 1.1152173913043, 0.11111111111111
52305, 0.91304347826087, 1.1413043478261, 0.13888888888889
52306, 0.93478260869565, 1.1413043478261, 0.16666666666667
52307, 0.91304347826087, 1.1152173913043, 0.16666666666667
52308, 0.91304347826087, 1.1413043478261, 0.19444444444444
52309, 0.93478260869565, 1.1413043478261, 0.22222222222222
52310, 0.91304347826087, 1.1152173913043, 0.22222222222222
52311, 0.91304347826087, 1.1413043478261, 0.25
52312, 0.93478260869565, 1.1413043478261, 0.27777777777778
52313, 0.91304347826087, 1.1152173913043, 0.27777777777778
52314, 0.91304347826087, 1.1413043478261, 0.30555555555556
52315, 0.93478260869565, 1.1413043478261, 0.33333333333333
52316, 0.91304347826087, 1.1152173913043, 0.33333333333333
52317, 0.91304347826087, 1.1413043478261, 0.36111111111111
52318, 0.93478260869565, 1.1413043478261, 0.38888888888889
52319, 0.91304347826087, 1.1152173913043, 0.38888888888889
52320, 0.91304347826087, 1.1413043478261, 0.41666666666667
52321, 0.93478260869565, 1.1413043478261, 0.44444444444444
52322, 0.91304347826087, 1.1152173913043, 0.44444444444444
52323, 0.91304347826087, 1.1413043478261, 0.47222222222222
52324, 0.8695652173913, 1.1413043478261, 0.027777777777778
52325, 0.89130434782609, 1.1413043478261, 0.055555555555556
52326, 0.8695652173913, 1.1152173913043, 0.055555555555556
52327, 0.8695652173913, 1.1413043478261, 0.083333333333333
52328, 0.89130434782609, 1.1413043478261, 0.11111111111111
52329, 0.8695652173913, 1.1152173913043, 0.11111111111111
52330, 0.8695652173913, 1.1413043478261, 0.13888888888889
52331, 0.89130434782609, 1.1413043478261, 0.16666666666667
52332, 0.8695652173913, 1.1152173913043, 0.16666666666667
52333, 0.8695652173913, 1.1413043478261, 0.19444444444444
52334, 0.89130434782609, 1.1413043478261, 0.22222222222222
52335, 0.8695652173913, 1.1152173913043, 0.22222222222222
52336, 0.8695652173913, 1.1413043478261, 0.25
52337, 0.89130434782609, 1.1413043478261, 0.27777777777778
52338, 0.8695652173913, 1.1152173913043, 0.27777777777778
52339, 0.8695652173913, 1.1413043478261, 0.30555555555556
52340, 0.89130434782609, 1.1413043478261, 0.33333333333333
52341, 0.8695652173913, 1.1152173913043, 0.33333333333333
52342, 0.8695652173913, 1.1413043478261, 0.36111111111111
52343, 0.89130434782609, 1.1413043478261, 0.38888888888889
52344, 0.8695652173913, 1.1152173913043, 0.38888888888889
52345, 0.8695652173913, 1.1413043478261, 0.41666666666667
52346, 0.89130434782609, 1.1413043478261, 0.44444444444444
52347, 0.8695652173913, 1.1152173913043, 0.44444444444444
52348, 0.8695652173913, 1.1413043478261, 0.47222222222222
52349, 0.82608695652174, 1.1413043478261, 0.027777777777778
52350, 0.84782608695652, 1.1413043478261, 0.055555555555556
52351, 0.82608695652174, 1.1152173913043, 0.055555555555556
52352, 0.82608695652174, 1.1413043478261, 0.083333333333333
52353, 0.84782608695652, 1.1413043478261, 0.11111111111111
52354, 0.82608695652174, 1.1152173913043, 0.11111111111111
52355, 0.82608695652174, 1.1413043478261, 0.13888888888889
52356, 0.84782608695652, 1.1413043478261, 0.16666666666667
52357, 0.82608695652174, 1.1152173913043, 0.16666666666667
52358, 0.82608695652174, 1.1413043478261, 0.19444444444444
52359, 0.84782608695652, 1.1413043478261, 0.22222222222222
52360, 0.82608695652174, 1.1152173913043, 0.22222222222222
52361, 0.82608695652174, 1.1413043478261, 0.25
52362, 0.84782608695652, 1.1413043478261, 0.27777777777778
52363, 0.82608695652174, 1.1152173913043, 0.27777777777778
52364, 0.82608695652174, 1.1413043478261, 0.30555555555556
52365, 0.84782608695652, 1.1413043478261, 0.33333333333333
52366, 0.82608695652174, 1.1152173913043, 0.33333333333333
52367, 0.82608695652174, 1.1413043478261, 0.36111111111111
52368, 0.84782608695652, 1.1413043478261, 0.38888888888889
52369, 0.82608695652174, 1.1152173913043, 0.38888888888889
52370, 0.82608695652174, 1.1413043478261, 0.41666666666667
52371, 0.84782608695652, 1.1413043478261, 0.44444444444444
52372, 0.82608695652174, 1.1152173913043, 0.44444444444444
52373, 0.82608695652174, 1.1413043478261, 0.47222222222222
52374, 0.78260869565217, 1.1413043478261, 0.027777777777778
52375, 0.80434782608696, 1.1413043478261, 0.055555555555556
52376, 0.78260869565217, 1.1152173913043, 0.055555555555556
52377, 0.78260869565217, 1.1413043478261, 0.083333333333333
52378, 0.80434782608696, 1.1413043478261, 0.11111111111111
52379, 0.78260869565217, 1.1152173913043, 0.11111111111111
52380, 0.78260869565217, 1.1413043478261, 0.13888888888889
52381, 0.80434782608696, 1.1413043478261, 0.16666666666667
52382, 0.78260869565217, 1.1152173913043, 0.16666666666667
52383, 0.78260869565217, 1.1413043478261, 0.19444444444444
52384, 0.80434782608696, 1.1413043478261, 0.22222222222222
52385, 0.78260869565217, 1.1152173913043, 0.22222222222222
52386, 0.78260869565217, 1.1413043478261, 0.25
52387, 0.80434782608696, 1.1413043478261, 0.27777777777778
52388, 0.78260869565217, 1.1152173913043, 0.27777777777778
52389, 0.78260869565217, 1.1413043478261, 0.30555555555556
52390, 0.80434782608696, 1.1413043478261, 0.33333333333333
52391, 0.78260869565217, 1.1152173913043, 0.33333333333333
52392, 0.78260869565217, 1.1413043478261, 0.36111111111111
52393, 0.80434782608696, 1.1413043478261, 0.38888888888889
52394, 0.78260869565217, 1.1152173913043, 0.38888888888889
52395, 0.78260869565217, 1.1413043478261, 0.41666666666667
52396, 0.80434782608696, 1.1413043478261, 0.44444444444444
52397, 0.78260869565217, 1.1152173913043, 0.44444444444444
52398, 0.78260869565217, 1.1413043478261, 0.47222222222222
52399, 0.73913043478261, 1.1413043478261, 0.027777777777778
52400, 0.76086956521739, 1.1413043478261, 0.055555555555556
52401, 0.73913043478261, 1.1152173913043, 0.055555555555556
52402, 0.73913043478261, 1.1413043478261, 0.083333333333333
52403, 0.76086956521739, 1.1413043478261, 0.11111111111111
52404, 0.73913043478261, 1.1152173913043, 0.11111111111111
52405, 0.73913043478261, 1.1413043478261, 0.13888888888889
52406, 0.76086956521739, 1.1413043478261, 0.16666666666667
52407, 0.73913043478261, 1.1152173913043, 0.16666666666667
52408, 0.73913043478261, 1.1413043478261, 0.19444444444444
52409, 0.76086956521739, 1.1413043478261, 0.22222222222222
52410, 0.73913043478261, 1.1152173913043, 0.22222222222222
52411, 0.73913043478261, 1.1413043478261, 0.25
52412, 0.76086956521739, 1.1413043478261, 0.27777777777778
52413, 0.73913043478261, 1.1152173913043, 0.27777777777778
52414, 0.73913043478261, 1.1413043478261, 0.30555555555556
52415, 0.76086956521739, 1.1413043478261, 0.33333333333333
52416, 0.73913043478261, 1.1152173913043, 0.33333333333333
52417, 0.73913043478261, 1.1413043478261, 0.36111111111111
52418, 0.76086956521739, 1.1413043478261, 0.38888888888889
52419, 0.73913043478261, 1.1152173913043, 0.38888888888889
52420, 0.73913043478261, 1.1413043478261, 0.41666666666667
52421, 0.76086956521739, 1.1413043478261, 0.44444444444444
52422, 0.73913043478261, 1.1152173913043, 0.44444444444444
52423, 0.73913043478261, 1.1413043478261, 0.47222222222222
52424, 0.69565217391304, 1.1413043478261, 0.027777777777778
52425, 0.71739130434783, 1.1413043478261, 0.055555555555556
52426, 0.69565217391304, 1.1152173913043, 0.055555555555556
52427, 0.69565217391304, 1.1413043478261, 0.083333333333333
52428, 0.71739130434783, 1.1413043478261, 0.11111111111111
52429, 0.69565217391304, 1.1152173913043, 0.11111111111111
52430, 0.69565217391304, 1.1413043478261, 0.13888888888889
52431, 0.71739130434783, 1.1413043478261, 0.16666666666667
52432, 0.69565217391304, 1.1152173913043, 0.16666666666667
52433, 0.69565217391304, 1.1413043478261, 0.19444444444444
52434, 0.71739130434783, 1.1413043478261, 0.22222222222222
52435, 0.69565217391304, 1.1152173913043, 0.22222222222222
52436, 0.69565217391304, 1.1413043478261, 0.25
52437, 0.71739130434783, 1.1413043478261, 0.27777777777778
52438, 0.69565217391304, 1.1152173913043, 0.27777777777778
52439, 0.69565217391304, 1.1413043478261, 0.30555555555556
52440, 0.71739130434783, 1.1413043478261, 0.33333333333333
52441, 0.69565217391304, 1.1152173913043, 0.33333333333333
52442, 0.69565217391304, 1.1413043478261, 0.36111111111111
52443, 0.71739130434783, 1.1413043478261, 0.38888888888889
52444, 0.69565217391304, 1.1152173913043, 0.38888888888889
52445, 0.69565217391304, 1.1413043478261, 0.41666666666667
52446, 0.71739130434783, 1.1413043478261, 0.44444444444444
52447, 0.69565217391304, 1.1152173913043, 0.44444444444444
52448, 0.69565217391304, 1.1413043478261, 0.47222222222222
52449, 0.65217391304348, 1.1413043478261, 0.027777777777778
52450, 0.67391304347826, 1.1413043478261, 0.055555555555556
52451, 0.65217391304348, 1.1152173913043, 0.055555555555556
52452, 0.65217391304348, 1.1413043478261, 0.083333333333333
52453, 0.67391304347826, 1.1413043478261, 0.11111111111111
52454, 0.65217391304348, 1.1152173913043, 0.11111111111111
52455, 0.65217391304348, 1.1413043478261, 0.13888888888889
52456, 0.67391304347826, 1.1413043478261, 0.16666666666667
52457, 0.65217391304348, 1.1152173913043, 0.16666666666667
52458, 0.65217391304348, 1.1413043478261, 0.19444444444444
52459, 0.67391304347826, 1.1413043478261, 0.22222222222222
52460, 0.65217391304348, 1.1152173913043, 0.22222222222222
52461, 0.65217391304348, 1.1413043478261, 0.25
52462, 0.67391304347826, 1.1413043478261, 0.27777777777778
52463, 0.65217391304348, 1.1152173913043, 0.27777777777778
52464, 0.65217391304348, 1.1413043478261, 0.30555555555556
52465, 0.67391304347826, 1.1413043478261, 0.33333333333333
52466, 0.65217391304348, 1.1152173913043, 0.33333333333333
52467, 0.65217391304348, 1.1413043478261, 0.36111111111111
52468, 0.67391304347826, 1.1413043478261, 0.38888888888889
52469, 0.65217391304348, 1.1152173913043, 0.38888888888889
52470, 0.65217391304348, 1.1413043478261, 0.41666666666667
52471, 0.67391304347826, 1.1413043478261, 0.44444444444444
52472, 0.65217391304348, 1.1152173913043, 0.44444444444444
52473, 0.65217391304348, 1.1413043478261, 0.47222222222222
52474, 0.60869565217391, 1.1413043478261, 0.027777777777778
52475, 0.6304347826087, 1.1413043478261, 0.055555555555556
52476, 0.60869565217391, 1.1152173913043, 0.055555555555556
52477, 0.60869565217391, 1.1413043478261, 0.083333333333333
52478, 0.6304347826087, 1.1413043478261, 0.11111111111111
52479, 0.60869565217391, 1.1152173913043, 0.11111111111111
52480, 0.60869565217391, 1.1413043478261, 0.13888888888889
52481, 0.6304347826087, 1.1413043478261, 0.16666666666667
52482, 0.60869565217391, 1.1152173913043, 0.16666666666667
52483, 0.60869565217391, 1.1413043478261, 0.19444444444444
52484, 0.6304347826087, 1.1413043478261, 0.22222222222222
52485, 0.60869565217391, 1.1152173913043, 0.22222222222222
52486, 0.60869565217391, 1.1413043478261, 0.25
52487, 0.6304347826087, 1.1413043478261, 0.27777777777778
52488, 0.60869565217391, 1.1152173913043, 0.27777777777778
52489, 0.60869565217391, 1.1413043478261, 0.30555555555556
52490, 0.6304347826087, 1.1413043478261, 0.33333333333333
52491, 0.60869565217391, 1.1152173913043, 0.33333333333333
52492, 0.60869565217391, 1.1413043478261, 0.36111111111111
52493, 0.6304347826087, 1.1413043478261, 0.38888888888889
52494, 0.60869565217391, 1.1152173913043, 0.38888888888889
52495, 0.60869565217391, 1.1413043478261, 0.41666666666667
52496, 0.6304347826087, 1.1413043478261, 0.44444444444444
52497, 0.60869565217391, 1.1152173913043, 0.44444444444444
52498, 0.60869565217391, 1.1413043478261, 0.47222222222222
52499, 0.56521739130435, 1.1413043478261, 0.027777777777778
52500, 0.58695652173913, 1.1413043478261, 0.055555555555556
52501, 0.56521739130435, 1.1152173913043, 0.055555555555556
52502, 0.56521739130435, 1.1413043478261, 0.083333333333333
52503, 0.58695652173913, 1.1413043478261, 0.11111111111111
52504, 0.56521739130435, 1.1152173913043, 0.11111111111111
52505, 0.56521739130435, 1.1413043478261, 0.13888888888889
52506, 0.58695652173913, 1.1413043478261, 0.16666666666667
52507, 0.56521739130435, 1.1152173913043, 0.16666666666667
52508, 0.56521739130435, 1.1413043478261, 0.19444444444444
52509, 0.58695652173913, 1.1413043478261, 0.22222222222222
52510, 0.56521739130435, 1.1152173913043, 0.22222222222222
52511, 0.56521739130435, 1.1413043478261, 0.25
52512, 0.58695652173913, 1.1413043478261, 0.27777777777778
52513, 0.56521739130435, 1.1152173913043, 0.27777777777778
52514, 0.56521739130435, 1.1413043478261, 0.30555555555556
52515, 0.58695652173913, 1.1413043478261, 0.33333333333333
52516, 0.56521739130435, 1.1152173913043, 0.33333333333333
52517, 0.56521739130435, 1.1413043478261, 0.36111111111111
52518, 0.58695652173913, 1.1413043478261, 0.38888888888889
52519, 0.56521739130435, 1.1152173913043, 0.38888888888889
52520, 0.56521739130435, 1.1413043478261, 0.41666666666667
52521, 0.58695652173913, 1.1413043478261, 0.44444444444444
52522, 0.56521739130435, 1.1152173913043, 0.44444444444444
52523, 0.56521739130435, 1.1413043478261, 0.47222222222222
52524, 0.52173913043478, 1.1413043478261, 0.027777777777778
52525, 0.54347826086957, 1.1413043478261, 0.055555555555556
52526, 0.52173913043478, 1.1152173913043, 0.055555555555556
52527, 0.52173913043478, 1.1413043478261, 0.083333333333333
52528, 0.54347826086957, 1.1413043478261, 0.11111111111111
52529, 0.52173913043478, 1.1152173913043, 0.11111111111111
52530, 0.52173913043478, 1.1413043478261, 0.13888888888889
52531, 0.54347826086957, 1.1413043478261, 0.16666666666667
52532, 0.52173913043478, 1.1152173913043, 0.16666666666667
52533, 0.52173913043478, 1.1413043478261, 0.19444444444444
52534, 0.54347826086956, 1.1413043478261, 0.22222222222222
52535, 0.52173913043478, 1.1152173913043, 0.22222222222222
52536, 0.52173913043478, 1.1413043478261, 0.25
52537, 0.54347826086956, 1.1413043478261, 0.27777777777778
52538, 0.52173913043478, 1.1152173913043, 0.27777777777778
52539, 0.52173913043478, 1.1413043478261, 0.30555555555556
52540, 0.54347826086956, 1.1413043478261, 0.33333333333333
52541, 0.52173913043478, 1.1152173913043, 0.33333333333333
52542, 0.52173913043478, 1.1413043478261, 0.36111111111111
52543, 0.54347826086956, 1.1413043478261, 0.38888888888889
52544, 0.52173913043478, 1.1152173913043, 0.38888888888889
52545, 0.52173913043478, 1.1413043478261, 0.41666666666667
52546, 0.54347826086956, 1.1413043478261, 0.44444444444444
52547, 0.52173913043478, 1.1152173913043, 0.44444444444444
52548, 0.52173913043478, 1.1413043478261, 0.47222222222222
52549, 0.47826086956522, 1.1413043478261, 0.027777777777778
52550, 0.5, 1.1413043478261, 0.055555555555556
52551, 0.47826086956522, 1.1152173913043, 0.055555555555556
52552, 0.47826086956522, 1.1413043478261, 0.083333333333333
52553, 0.5, 1.1413043478261, 0.11111111111111
52554, 0.47826086956522, 1.1152173913043, 0.11111111111111
52555, 0.47826086956522, 1.1413043478261, 0.13888888888889
52556, 0.5, 1.1413043478261, 0.16666666666667
52557, 0.47826086956522, 1.1152173913043, 0.16666666666667
52558, 0.47826086956522, 1.1413043478261, 0.19444444444444
52559, 0.5, 1.1413043478261, 0.22222222222222
52560, 0.47826086956522, 1.1152173913043, 0.22222222222222
52561, 0.47826086956522, 1.1413043478261, 0.25
52562, 0.5, 1.1413043478261, 0.27777777777778
52563, 0.47826086956522, 1.1152173913043, 0.27777777777778
52564, 0.47826086956522, 1.1413043478261, 0.30555555555556
52565, 0.5, 1.1413043478261, 0.33333333333333
52566, 0.47826086956522, 1.1152173913043, 0.33333333333333
52567, 0.47826086956522, 1.1413043478261, 0.36111111111111
52568, 0.5, 1.1413043478261, 0.38888888888889
52569, 0.47826086956522, 1.1152173913043, 0.38888888888889
52570, 0.47826086956522, 1.1413043478261, 0.41666666666667
52571, 0.5, 1.1413043478261, 0.44444444444444
52572, 0.47826086956522, 1.1152173913043, 0.44444444444444
52573, 0.47826086956522, 1.1413043478261, 0.47222222222222
52574, 0.43478260869565, 1.1413043478261, 0.027777777777778
52575, 0.45652173913043, 1.1413043478261, 0.055555555555556
52576, 0.43478260869565, 1.1152173913043, 0.055555555555556
52577, 0.43478260869565, 1.1413043478261, 0.083333333333333
52578, 0.45652173913043, 1.1413043478261, 0.11111111111111
52579, 0.43478260869565, 1.1152173913043, 0.11111111111111
52580, 0.43478260869565, 1.1413043478261, 0.13888888888889
52581, 0.45652173913043, 1.1413043478261, 0.16666666666667
52582, 0.43478260869565, 1.1152173913043, 0.16666666666667
52583, 0.43478260869565, 1.1413043478261, 0.19444444444444
52584, 0.45652173913043, 1.1413043478261, 0.22222222222222
52585, 0.43478260869565, 1.1152173913043, 0.22222222222222
52586, 0.43478260869565, 1.1413043478261, 0.25
52587, 0.45652173913043, 1.1413043478261, 0.27777777777778
52588, 0.43478260869565, 1.1152173913043, 0.27777777777778
52589, 0.43478260869565, 1.1413043478261, 0.30555555555556
52590, 0.45652173913043, 1.1413043478261, 0.33333333333333
52591, 0.43478260869565, 1.1152173913043, 0.33333333333333
52592, 0.43478260869565, 1.1413043478261, 0.36111111111111
52593, 0.45652173913043, 1.1413043478261, 0.38888888888889
52594, 0.43478260869565, 1.1152173913043, 0.38888888888889
52595, 0.43478260869565, 1.1413043478261, 0.41666666666667
52596, 0.45652173913043, 1.1413043478261, 0.44444444444444
52597, 0.43478260869565, 1.1152173913043, 0.44444444444444
52598, 0.43478260869565, 1.1413043478261, 0.47222222222222
52599, 0.39130434782609, 1.1413043478261, 0.027777777777778
52600, 0.41304347826087, 1.1413043478261, 0.055555555555556
52601, 0.39130434782609, 1.1152173913043, 0.055555555555556
52602, 0.39130434782609, 1.1413043478261, 0.083333333333333
52603, 0.41304347826087, 1.1413043478261, 0.11111111111111
52604, 0.39130434782609, 1.1152173913043, 0.11111111111111
52605, 0.39130434782609, 1.1413043478261, 0.13888888888889
52606, 0.41304347826087, 1.1413043478261, 0.16666666666667
52607, 0.39130434782609, 1.1152173913043, 0.16666666666667
52608, 0.39130434782609, 1.1413043478261, 0.19444444444444
52609, 0.41304347826087, 1.1413043478261, 0.22222222222222
52610, 0.39130434782609, 1.1152173913043, 0.22222222222222
52611, 0.39130434782609, 1.1413043478261, 0.25
52612, 0.41304347826087, 1.1413043478261, 0.27777777777778
52613, 0.39130434782609, 1.1152173913043, 0.27777777777778
52614, 0.39130434782609, 1.1413043478261, 0.30555555555556
52615, 0.41304347826087, 1.1413043478261, 0.33333333333333
52616, 0.39130434782609, 1.1152173913043, 0.33333333333333
52617, 0.39130434782609, 1.1413043478261, 0.36111111111111
52618, 0.41304347826087, 1.1413043478261, 0.38888888888889
52619, 0.39130434782609, 1.1152173913043, 0.38888888888889
52620, 0.39130434782609, 1.1413043478261, 0.41666666666667
52621, 0.41304347826087, 1.1413043478261, 0.44444444444444
52622, 0.39130434782609, 1.1152173913043, 0.44444444444444
52623, 0.39130434782609, 1.1413043478261, 0.47222222222222
52624, 0.34782608695652, 1.1413043478261, 0.027777777777778
52625, 0.3695652173913, 1.1413043478261, 0.055555555555556
52626, 0.34782608695652, 1.1152173913043, 0.055555555555556
52627, 0.34782608695652, 1.1413043478261, 0.083333333333333
52628, 0.3695652173913, 1.1413043478261, 0.11111111111111
52629, 0.34782608695652, 1.1152173913043, 0.11111111111111
52630, 0.34782608695652, 1.1413043478261, 0.13888888888889
52631, 0.3695652173913, 1.1413043478261, 0.16666666666667
52632, 0.34782608695652, 1.1152173913043, 0.16666666666667
52633, 0.34782608695652, 1.1413043478261, 0.19444444444444
52634, 0.3695652173913, 1.1413043478261, 0.22222222222222
52635, 0.34782608695652, 1.1152173913043, 0.22222222222222
52636, 0.34782608695652, 1.1413043478261, 0.25
52637, 0.3695652173913, 1.1413043478261, 0.27777777777778
52638, 0.34782608695652, 1.1152173913043, 0.27777777777778
52639, 0.34782608695652, 1.1413043478261, 0.30555555555556
52640, 0.3695652173913, 1.1413043478261, 0.33333333333333
52641, 0.34782608695652, 1.1152173913043, 0.33333333333333
52642, 0.34782608695652, 1.1413043478261, 0.36111111111111
52643, 0.3695652173913, 1.1413043478261, 0.38888888888889
52644, 0.34782608695652, 1.1152173913043, 0.38888888888889
52645, 0.34782608695652, 1.1413043478261, 0.41666666666667
52646, 0.3695652173913, 1.1413043478261, 0.44444444444444
52647, 0.34782608695652, 1.1152173913043, 0.44444444444444
52648, 0.34782608695652, 1.1413043478261, 0.47222222222222
52649, 0.30434782608696, 1.1413043478261, 0.027777777777778
52650, 0.32608695652174, 1.1413043478261, 0.055555555555556
52651, 0.30434782608696, 1.1152173913043, 0.055555555555556
52652, 0.30434782608696, 1.1413043478261, 0.083333333333333
52653, 0.32608695652174, 1.1413043478261, 0.11111111111111
52654, 0.30434782608696, 1.1152173913043, 0.11111111111111
52655, 0.30434782608696, 1.1413043478261, 0.13888888888889
52656, 0.32608695652174, 1.1413043478261, 0.16666666666667
52657, 0.30434782608696, 1.1152173913043, 0.16666666666667
52658, 0.30434782608696, 1.1413043478261, 0.19444444444444
52659, 0.32608695652174, 1.1413043478261, 0.22222222222222
52660, 0.30434782608696, 1.1152173913043, 0.22222222222222
52661, 0.30434782608696, 1.1413043478261, 0.25
52662, 0.32608695652174, 1.1413043478261, 0.27777777777778
52663, 0.30434782608696, 1.1152173913043, 0.27777777777778
52664, 0.30434782608696, 1.1413043478261, 0.30555555555556
52665, 0.32608695652174, 1.1413043478261, 0.33333333333333
52666, 0.30434782608696, 1.1152173913043, 0.33333333333333
52667, 0.30434782608696, 1.1413043478261, 0.36111111111111
52668, 0.32608695652174, 1.1413043478261, 0.38888888888889
52669, 0.30434782608696, 1.1152173913043, 0.38888888888889
52670, 0.30434782608696, 1.1413043478261, 0.41666666666667
52671, 0.32608695652174, 1.1413043478261, 0.44444444444444
52672, 0.30434782608696, 1.1152173913043, 0.44444444444444
52673, 0.30434782608696, 1.1413043478261, 0.47222222222222
52674, 0.26086956521739, 1.1413043478261, 0.027777777777778
52675, 0.28260869565217, 1.1413043478261, 0.055555555555556
52676, 0.26086956521739, 1.1152173913043, 0.055555555555556
52677, 0.26086956521739, 1.1413043478261, 0.083333333333333
52678, 0.28260869565217, 1.1413043478261, 0.11111111111111
52679, 0.26086956521739, 1.1152173913043, 0.11111111111111
52680, 0.26086956521739, 1.1413043478261, 0.13888888888889
52681, 0.28260869565217, 1.1413043478261, 0.16666666666667
52682, 0.26086956521739, 1.1152173913043, 0.16666666666667
52683, 0.26086956521739, 1.1413043478261, 0.19444444444444
52684, 0.28260869565217, 1.1413043478261, 0.22222222222222
52685, 0.26086956521739, 1.1152173913043, 0.22222222222222
52686, 0.26086956521739, 1.1413043478261, 0.25
52687, 0.28260869565217, 1.1413043478261, 0.27777777777778
52688, 0.26086956521739, 1.1152173913043, 0.27777777777778
52689, 0.26086956521739, 1.1413043478261, 0.30555555555556
52690, 0.28260869565217, 1.1413043478261, 0.33333333333333
52691, 0.26086956521739, 1.1152173913043, 0.33333333333333
52692, 0.26086956521739, 1.1413043478261, 0.36111111111111
52693, 0.28260869565217, 1.1413043478261, 0.38888888888889
52694, 0.26086956521739, 1.1152173913043, 0.38888888888889
52695, 0.26086956521739, 1.1413043478261, 0.41666666666667
52696, 0.28260869565217, 1.1413043478261, 0.44444444444444
52697, 0.26086956521739, 1.1152173913043, 0.44444444444444
52698, 0.26086956521739, 1.1413043478261, 0.47222222222222
52699, 0.21739130434783, 1.1413043478261, 0.027777777777778
52700, 0.23913043478261, 1.1413043478261, 0.055555555555556
52701, 0.21739130434783, 1.1152173913043, 0.055555555555556
52702, 0.21739130434783, 1.1413043478261, 0.083333333333333
52703, 0.23913043478261, 1.1413043478261, 0.11111111111111
52704, 0.21739130434783, 1.1152173913043, 0.11111111111111
52705, 0.21739130434783, 1.1413043478261, 0.13888888888889
52706, 0.23913043478261, 1.1413043478261, 0.16666666666667
52707, 0.21739130434783, 1.1152173913043, 0.16666666666667
52708, 0.21739130434783, 1.1413043478261, 0.19444444444444
52709, 0.23913043478261, 1.1413043478261, 0.22222222222222
52710, 0.21739130434783, 1.1152173913043, 0.22222222222222
52711, 0.21739130434783, 1.1413043478261, 0.25
52712, 0.23913043478261, 1.1413043478261, 0.27777777777778
52713, 0.21739130434783, 1.1152173913043, 0.27777777777778
52714, 0.21739130434783, 1.1413043478261, 0.30555555555556
52715, 0.23913043478261, 1.1413043478261, 0.33333333333333
52716, 0.21739130434783, 1.1152173913043, 0.33333333333333
52717, 0.21739130434783, 1.1413043478261, 0.36111111111111
52718, 0.23913043478261, 1.1413043478261, 0.38888888888889
52719, 0.21739130434783, 1.1152173913043, 0.38888888888889
52720, 0.21739130434783, 1.1413043478261, 0.41666666666667
52721, 0.23913043478261, 1.1413043478261, 0.44444444444444
52722, 0.21739130434783, 1.1152173913043, 0.44444444444444
52723, 0.21739130434783, 1.1413043478261, 0.47222222222222
52724, 0.17391304347826, 1.1413043478261, 0.027777777777778
52725, 0.19565217391304, 1.1413043478261, 0.055555555555556
52726, 0.17391304347826, 1.1152173913043, 0.055555555555556
52727, 0.17391304347826, 1.1413043478261, 0.083333333333333
52728, 0.19565217391304, 1.1413043478261, 0.11111111111111
52729, 0.17391304347826, 1.1152173913043, 0.11111111111111
52730, 0.17391304347826, 1.1413043478261, 0.13888888888889
52731, 0.19565217391304, 1.1413043478261, 0.16666666666667
52732, 0.17391304347826, 1.1152173913043, 0.16666666666667
52733, 0.17391304347826, 1.1413043478261, 0.19444444444444
52734, 0.19565217391304, 1.1413043478261, 0.22222222222222
52735, 0.17391304347826, 1.1152173913043, 0.22222222222222
52736, 0.17391304347826, 1.1413043478261, 0.25
52737, 0.19565217391304, 1.1413043478261, 0.27777777777778
52738, 0.17391304347826, 1.1152173913043, 0.27777777777778
52739, 0.17391304347826, 1.1413043478261, 0.30555555555556
52740, 0.19565217391304, 1.1413043478261, 0.33333333333333
52741, 0.17391304347826, 1.1152173913043, 0.33333333333333
52742, 0.17391304347826, 1.1413043478261, 0.36111111111111
52743, 0.19565217391304, 1.1413043478261, 0.38888888888889
52744, 0.17391304347826, 1.1152173913043, 0.38888888888889
52745, 0.17391304347826, 1.1413043478261, 0.41666666666667
52746, 0.19565217391304, 1.1413043478261, 0.44444444444444
52747, 0.17391304347826, 1.1152173913043, 0.44444444444444
52748, 0.17391304347826, 1.1413043478261, 0.47222222222222
52749, 0.1304347826087, 1.1413043478261, 0.027777777777778
52750, 0.15217391304348, 1.1413043478261, 0.055555555555556
52751, 0.1304347826087, 1.1152173913043, 0.055555555555556
52752, 0.1304347826087, 1.1413043478261, 0.083333333333333
52753, 0.15217391304348, 1.1413043478261, 0.11111111111111
52754, 0.1304347826087, 1.1152173913043, 0.11111111111111
52755, 0.1304347826087, 1.1413043478261, 0.13888888888889
52756, 0.15217391304348, 1.1413043478261, 0.16666666666667
52757, 0.1304347826087, 1.1152173913043, 0.16666666666667
52758, 0.1304347826087, 1.1413043478261, 0.19444444444444
52759, 0.15217391304348, 1.1413043478261, 0.22222222222222
52760, 0.1304347826087, 1.1152173913043, 0.22222222222222
52761, 0.1304347826087, 1.1413043478261, 0.25
52762, 0.15217391304348, 1.1413043478261, 0.27777777777778
52763, 0.1304347826087, 1.1152173913043, 0.27777777777778
52764, 0.1304347826087, 1.1413043478261, 0.30555555555556
52765, 0.15217391304348, 1.1413043478261, 0.33333333333333
52766, 0.1304347826087, 1.1152173913043, 0.33333333333333
52767, 0.1304347826087, 1.1413043478261, 0.36111111111111
52768, 0.15217391304348, 1.1413043478261, 0.38888888888889
52769, 0.1304347826087, 1.1152173913043, 0.38888888888889
52770, 0.1304347826087, 1.1413043478261, 0.41666666666667
52771, 0.15217391304348, 1.1413043478261, 0.44444444444444
52772, 0.1304347826087, 1.1152173913043, 0.44444444444444
52773, 0.1304347826087, 1.1413043478261, 0.47222222222222
52774, 0.08695652173913, 1.1413043478261, 0.027777777777778
52775, 0.10869565217391, 1.1413043478261, 0.055555555555556
52776, 0.08695652173913, 1.1152173913043, 0.055555555555556
52777, 0.08695652173913, 1.1413043478261, 0.083333333333333
52778, 0.10869565217391, 1.1413043478261, 0.11111111111111
52779, 0.08695652173913, 1.1152173913043, 0.11111111111111
52780, 0.08695652173913, 1.1413043478261, 0.13888888888889
52781, 0.10869565217391, 1.1413043478261, 0.16666666666667
52782, 0.08695652173913, 1.1152173913043, 0.16666666666667
52783, 0.08695652173913, 1.1413043478261, 0.19444444444444
52784, 0.10869565217391, 1.1413043478261, 0.22222222222222
52785, 0.08695652173913, 1.1152173913043, 0.22222222222222
52786, 0.08695652173913, 1.1413043478261, 0.25
52787, 0.10869565217391, 1.1413043478261, 0.27777777777778
52788, 0.08695652173913, 1.1152173913043, 0.27777777777778
52789, 0.08695652173913, 1.1413043478261, 0.30555555555556
52790, 0.10869565217391, 1.1413043478261, 0.33333333333333
52791, 0.08695652173913, 1.1152173913043, 0.33333333333333
52792, 0.08695652173913, 1.1413043478261, 0.36111111111111
52793, 0.10869565217391, 1.1413043478261, 0.38888888888889
52794, 0.08695652173913, 1.1152173913043, 0.38888888888889
52795, 0.08695652173913, 1.1413043478261, 0.41666666666667
52796, 0.10869565217391, 1.1413043478261, 0.44444444444444
52797, 0.08695652173913, 1.1152173913043, 0.44444444444444
52798, 0.08695652173913, 1.1413043478261, 0.47222222222222
52799, 0.043478260869565, 1.1413043478261, 0.027777777777778
52800, 0.065217391304348, 1.1413043478261, 0.055555555555556
52801, 0.043478260869565, 1.1152173913043, 0.055555555555556
52802, 0.043478260869565, 1.1413043478261, 0.083333333333333
52803, 0.065217391304348, 1.1413043478261, 0.11111111111111
52804, 0.043478260869565, 1.1152173913043, 0.11111111111111
52805, 0.043478260869565, 1.1413043478261, 0.13888888888889
52806, 0.065217391304348, 1.1413043478261, 0.16666666666667
52807, 0.043478260869565, 1.1152173913043, 0.16666666666667
52808, 0.043478260869565, 1.1413043478261, 0.19444444444444
52809, 0.065217391304348, 1.1413043478261, 0.22222222222222
52810, 0.043478260869565, 1.1152173913043, 0.22222222222222
52811, 0.043478260869565, 1.1413043478261, 0.25
52812, 0.065217391304348, 1.1413043478261, 0.27777777777778
52813, 0.043478260869565, 1.1152173913043, 0.27777777777778
52814, 0.043478260869565, 1.1413043478261, 0.30555555555556
52815, 0.065217391304348, 1.1413043478261, 0.33333333333333
52816, 0.043478260869565, 1.1152173913043, 0.33333333333333
52817, 0.043478260869565, 1.1413043478261, 0.36111111111111
52818, 0.065217391304348, 1.1413043478261, 0.38888888888889
52819, 0.043478260869565, 1.1152173913043, 0.38888888888889
52820, 0.043478260869565, 1.1413043478261, 0.41666666666667
52821, 0.065217391304348, 1.1413043478261, 0.44444444444444
52822, 0.043478260869565, 1.1152173913043, 0.44444444444444
52823, 0.043478260869565, 1.1413043478261, 0.47222222222222
52824, 0.021739130434783, 1.1413043478261, 0.055555555555556
52825, 0.021739130434783, 1.1413043478261, 0.11111111111111
52826, 0.021739130434783, 1.1413043478261, 0.16666666666667
52827, 0.021739130434783, 1.1413043478261, 0.22222222222222
52828, 0.021739130434783, 1.1413043478261, 0.27777777777778
52829, 0.021739130434783, 1.1413043478261, 0.33333333333333
52830, 0.021739130434783, 1.1413043478261, 0.38888888888889
52831, 0.021739130434783, 1.1413043478261, 0.44444444444444
52832, 0.95652173913043, 1.1934782608696, 0.027777777777778
52833, 0.97826086956522, 1.1934782608696, 0.055555555555556
52834, 0.95652173913043, 1.1673913043478, 0.055555555555556
52835, 0.95652173913043, 1.1934782608696, 0.083333333333333
52836, 0.97826086956522, 1.1934782608696, 0.11111111111111
52837, 0.95652173913043, 1.1673913043478, 0.11111111111111
52838, 0.95652173913044, 1.1934782608696, 0.13888888888889
52839, 0.97826086956522, 1.1934782608696, 0.16666666666667
52840, 0.95652173913044, 1.1673913043478, 0.16666666666667
52841, 0.95652173913044, 1.1934782608696, 0.19444444444444
52842, 0.97826086956522, 1.1934782608696, 0.22222222222222
52843, 0.95652173913044, 1.1673913043478, 0.22222222222222
52844, 0.95652173913044, 1.1934782608696, 0.25
52845, 0.97826086956522, 1.1934782608696, 0.27777777777778
52846, 0.95652173913044, 1.1673913043478, 0.27777777777778
52847, 0.95652173913044, 1.1934782608696, 0.30555555555556
52848, 0.97826086956522, 1.1934782608696, 0.33333333333333
52849, 0.95652173913044, 1.1673913043478, 0.33333333333333
52850, 0.95652173913044, 1.1934782608696, 0.36111111111111
52851, 0.97826086956522, 1.1934782608696, 0.38888888888889
52852, 0.95652173913044, 1.1673913043478, 0.38888888888889
52853, 0.95652173913044, 1.1934782608696, 0.41666666666667
52854, 0.97826086956522, 1.1934782608696, 0.44444444444444
52855, 0.95652173913044, 1.1673913043478, 0.44444444444444
52856, 0.95652173913043, 1.1934782608696, 0.47222222222222
52857, 0.91304347826087, 1.1934782608696, 0.027777777777778
52858, 0.93478260869565, 1.1934782608696, 0.055555555555556
52859, 0.91304347826087, 1.1673913043478, 0.055555555555556
52860, 0.91304347826087, 1.1934782608696, 0.083333333333333
52861, 0.93478260869565, 1.1934782608696, 0.11111111111111
52862, 0.91304347826087, 1.1673913043478, 0.11111111111111
52863, 0.91304347826087, 1.1934782608696, 0.13888888888889
52864, 0.93478260869565, 1.1934782608696, 0.16666666666667
52865, 0.91304347826087, 1.1673913043478, 0.16666666666667
52866, 0.91304347826087, 1.1934782608696, 0.19444444444444
52867, 0.93478260869565, 1.1934782608696, 0.22222222222222
52868, 0.91304347826087, 1.1673913043478, 0.22222222222222
52869, 0.91304347826087, 1.1934782608696, 0.25
52870, 0.93478260869565, 1.1934782608696, 0.27777777777778
52871, 0.91304347826087, 1.1673913043478, 0.27777777777778
52872, 0.91304347826087, 1.1934782608696, 0.30555555555556
52873, 0.93478260869565, 1.1934782608696, 0.33333333333333
52874, 0.91304347826087, 1.1673913043478, 0.33333333333333
52875, 0.91304347826087, 1.1934782608696, 0.36111111111111
52876, 0.93478260869565, 1.1934782608696, 0.38888888888889
52877, 0.91304347826087, 1.1673913043478, 0.38888888888889
52878, 0.91304347826087, 1.1934782608696, 0.41666666666667
52879, 0.93478260869565, 1.1934782608696, 0.44444444444444
52880, 0.91304347826087, 1.1673913043478, 0.44444444444444
52881, 0.91304347826087, 1.1934782608696, 0.47222222222222
52882, 0.8695652173913, 1.1934782608696, 0.027777777777778
52883, 0.89130434782609, 1.1934782608696, 0.055555555555556
52884, 0.8695652173913, 1.1673913043478, 0.055555555555556
52885, 0.8695652173913, 1.1934782608696, 0.083333333333333
52886, 0.89130434782609, 1.1934782608696, 0.11111111111111
52887, 0.8695652173913, 1.1673913043478, 0.11111111111111
52888, 0.8695652173913, 1.1934782608696, 0.13888888888889
52889, 0.89130434782609, 1.1934782608696, 0.16666666666667
52890, 0.8695652173913, 1.1673913043478, 0.16666666666667
52891, 0.8695652173913, 1.1934782608696, 0.19444444444444
52892, 0.89130434782609, 1.1934782608696, 0.22222222222222
