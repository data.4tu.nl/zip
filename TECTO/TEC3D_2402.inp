75686, 1.3304347826087, 0.20217391304348, 0.13888888888889
75687, 1.3086956521739, 0.20217391304348, 0.11111111111111
75688, 1.3304347826087, 0.22826086956522, 0.11111111111111
75689, 1.3304347826087, 0.20217391304348, 0.083333333333333
75690, 1.3086956521739, 0.20217391304348, 0.055555555555556
75691, 1.3304347826087, 0.22826086956522, 0.055555555555556
75692, 1.3304347826087, 0.20217391304348, 0.027777777777778
75693, 1.3739130434783, 0.20217391304348, 0.47222222222222
75694, 1.3521739130435, 0.20217391304348, 0.44444444444444
75695, 1.3739130434783, 0.22826086956522, 0.44444444444444
75696, 1.3739130434783, 0.20217391304348, 0.41666666666667
75697, 1.3521739130435, 0.20217391304348, 0.38888888888889
75698, 1.3739130434783, 0.22826086956522, 0.38888888888889
75699, 1.3739130434783, 0.20217391304348, 0.36111111111111
75700, 1.3521739130435, 0.20217391304348, 0.33333333333333
75701, 1.3739130434783, 0.22826086956522, 0.33333333333333
75702, 1.3739130434783, 0.20217391304348, 0.30555555555556
75703, 1.3521739130435, 0.20217391304348, 0.27777777777778
75704, 1.3739130434783, 0.22826086956522, 0.27777777777778
75705, 1.3739130434783, 0.20217391304348, 0.25
75706, 1.3521739130435, 0.20217391304348, 0.22222222222222
75707, 1.3739130434783, 0.22826086956522, 0.22222222222222
75708, 1.3739130434783, 0.20217391304348, 0.19444444444444
75709, 1.3521739130435, 0.20217391304348, 0.16666666666667
75710, 1.3739130434783, 0.22826086956522, 0.16666666666667
75711, 1.3739130434783, 0.20217391304348, 0.13888888888889
75712, 1.3521739130435, 0.20217391304348, 0.11111111111111
75713, 1.3739130434783, 0.22826086956522, 0.11111111111111
75714, 1.3739130434783, 0.20217391304348, 0.083333333333333
75715, 1.3521739130435, 0.20217391304348, 0.055555555555556
75716, 1.3739130434783, 0.22826086956522, 0.055555555555556
75717, 1.3739130434783, 0.20217391304348, 0.027777777777778
75718, 1.4173913043478, 0.20217391304348, 0.47222222222222
75719, 1.395652173913, 0.20217391304348, 0.44444444444444
75720, 1.4173913043478, 0.22826086956522, 0.44444444444444
75721, 1.4173913043478, 0.20217391304348, 0.41666666666667
75722, 1.395652173913, 0.20217391304348, 0.38888888888889
75723, 1.4173913043478, 0.22826086956522, 0.38888888888889
75724, 1.4173913043478, 0.20217391304348, 0.36111111111111
75725, 1.395652173913, 0.20217391304348, 0.33333333333333
75726, 1.4173913043478, 0.22826086956522, 0.33333333333333
75727, 1.4173913043478, 0.20217391304348, 0.30555555555556
75728, 1.395652173913, 0.20217391304348, 0.27777777777778
75729, 1.4173913043478, 0.22826086956522, 0.27777777777778
75730, 1.4173913043478, 0.20217391304348, 0.25
75731, 1.395652173913, 0.20217391304348, 0.22222222222222
75732, 1.4173913043478, 0.22826086956522, 0.22222222222222
75733, 1.4173913043478, 0.20217391304348, 0.19444444444444
75734, 1.395652173913, 0.20217391304348, 0.16666666666667
75735, 1.4173913043478, 0.22826086956522, 0.16666666666667
75736, 1.4173913043478, 0.20217391304348, 0.13888888888889
75737, 1.395652173913, 0.20217391304348, 0.11111111111111
75738, 1.4173913043478, 0.22826086956522, 0.11111111111111
75739, 1.4173913043478, 0.20217391304348, 0.083333333333333
75740, 1.395652173913, 0.20217391304348, 0.055555555555556
75741, 1.4173913043478, 0.22826086956522, 0.055555555555556
75742, 1.4173913043478, 0.20217391304348, 0.027777777777778
75743, 1.4608695652174, 0.20217391304348, 0.47222222222222
75744, 1.4391304347826, 0.20217391304348, 0.44444444444444
75745, 1.4608695652174, 0.22826086956522, 0.44444444444444
75746, 1.4608695652174, 0.20217391304348, 0.41666666666667
75747, 1.4391304347826, 0.20217391304348, 0.38888888888889
75748, 1.4608695652174, 0.22826086956522, 0.38888888888889
75749, 1.4608695652174, 0.20217391304348, 0.36111111111111
75750, 1.4391304347826, 0.20217391304348, 0.33333333333333
75751, 1.4608695652174, 0.22826086956522, 0.33333333333333
75752, 1.4608695652174, 0.20217391304348, 0.30555555555556
75753, 1.4391304347826, 0.20217391304348, 0.27777777777778
75754, 1.4608695652174, 0.22826086956522, 0.27777777777778
75755, 1.4608695652174, 0.20217391304348, 0.25
75756, 1.4391304347826, 0.20217391304348, 0.22222222222222
75757, 1.4608695652174, 0.22826086956522, 0.22222222222222
75758, 1.4608695652174, 0.20217391304348, 0.19444444444444
75759, 1.4391304347826, 0.20217391304348, 0.16666666666667
75760, 1.4608695652174, 0.22826086956522, 0.16666666666667
75761, 1.4608695652174, 0.20217391304348, 0.13888888888889
75762, 1.4391304347826, 0.20217391304348, 0.11111111111111
75763, 1.4608695652174, 0.22826086956522, 0.11111111111111
75764, 1.4608695652174, 0.20217391304348, 0.083333333333333
75765, 1.4391304347826, 0.20217391304348, 0.055555555555556
75766, 1.4608695652174, 0.22826086956522, 0.055555555555556
75767, 1.4608695652174, 0.20217391304348, 0.027777777777778
75768, 1.504347826087, 0.20217391304348, 0.47222222222222
75769, 1.4826086956522, 0.20217391304348, 0.44444444444444
75770, 1.504347826087, 0.22826086956522, 0.44444444444444
75771, 1.504347826087, 0.20217391304348, 0.41666666666667
75772, 1.4826086956522, 0.20217391304348, 0.38888888888889
75773, 1.504347826087, 0.22826086956522, 0.38888888888889
75774, 1.504347826087, 0.20217391304348, 0.36111111111111
75775, 1.4826086956522, 0.20217391304348, 0.33333333333333
75776, 1.504347826087, 0.22826086956522, 0.33333333333333
75777, 1.504347826087, 0.20217391304348, 0.30555555555556
75778, 1.4826086956522, 0.20217391304348, 0.27777777777778
75779, 1.504347826087, 0.22826086956522, 0.27777777777778
75780, 1.504347826087, 0.20217391304348, 0.25
75781, 1.4826086956522, 0.20217391304348, 0.22222222222222
75782, 1.504347826087, 0.22826086956522, 0.22222222222222
75783, 1.504347826087, 0.20217391304348, 0.19444444444444
75784, 1.4826086956522, 0.20217391304348, 0.16666666666667
75785, 1.504347826087, 0.22826086956522, 0.16666666666667
75786, 1.504347826087, 0.20217391304348, 0.13888888888889
75787, 1.4826086956522, 0.20217391304348, 0.11111111111111
75788, 1.504347826087, 0.22826086956522, 0.11111111111111
75789, 1.504347826087, 0.20217391304348, 0.083333333333333
75790, 1.4826086956522, 0.20217391304348, 0.055555555555556
75791, 1.504347826087, 0.22826086956522, 0.055555555555556
75792, 1.504347826087, 0.20217391304348, 0.027777777777778
75793, 1.5478260869565, 0.20217391304348, 0.47222222222222
75794, 1.5260869565217, 0.20217391304348, 0.44444444444444
75795, 1.5478260869565, 0.22826086956522, 0.44444444444444
75796, 1.5478260869565, 0.20217391304348, 0.41666666666667
75797, 1.5260869565217, 0.20217391304348, 0.38888888888889
75798, 1.5478260869565, 0.22826086956522, 0.38888888888889
75799, 1.5478260869565, 0.20217391304348, 0.36111111111111
75800, 1.5260869565217, 0.20217391304348, 0.33333333333333
75801, 1.5478260869565, 0.22826086956522, 0.33333333333333
75802, 1.5478260869565, 0.20217391304348, 0.30555555555556
75803, 1.5260869565217, 0.20217391304348, 0.27777777777778
75804, 1.5478260869565, 0.22826086956522, 0.27777777777778
75805, 1.5478260869565, 0.20217391304348, 0.25
75806, 1.5260869565217, 0.20217391304348, 0.22222222222222
75807, 1.5478260869565, 0.22826086956522, 0.22222222222222
75808, 1.5478260869565, 0.20217391304348, 0.19444444444444
75809, 1.5260869565217, 0.20217391304348, 0.16666666666667
75810, 1.5478260869565, 0.22826086956522, 0.16666666666667
75811, 1.5478260869565, 0.20217391304348, 0.13888888888889
75812, 1.5260869565217, 0.20217391304348, 0.11111111111111
75813, 1.5478260869565, 0.22826086956522, 0.11111111111111
75814, 1.5478260869565, 0.20217391304348, 0.083333333333333
75815, 1.5260869565217, 0.20217391304348, 0.055555555555556
75816, 1.5478260869565, 0.22826086956522, 0.055555555555556
75817, 1.5478260869565, 0.20217391304348, 0.027777777777778
75818, 1.5913043478261, 0.20217391304348, 0.47222222222222
75819, 1.5695652173913, 0.20217391304348, 0.44444444444444
75820, 1.5913043478261, 0.22826086956522, 0.44444444444444
75821, 1.5913043478261, 0.20217391304348, 0.41666666666667
75822, 1.5695652173913, 0.20217391304348, 0.38888888888889
75823, 1.5913043478261, 0.22826086956522, 0.38888888888889
75824, 1.5913043478261, 0.20217391304348, 0.36111111111111
75825, 1.5695652173913, 0.20217391304348, 0.33333333333333
75826, 1.5913043478261, 0.22826086956522, 0.33333333333333
75827, 1.5913043478261, 0.20217391304348, 0.30555555555556
75828, 1.5695652173913, 0.20217391304348, 0.27777777777778
75829, 1.5913043478261, 0.22826086956522, 0.27777777777778
75830, 1.5913043478261, 0.20217391304348, 0.25
75831, 1.5695652173913, 0.20217391304348, 0.22222222222222
75832, 1.5913043478261, 0.22826086956522, 0.22222222222222
75833, 1.5913043478261, 0.20217391304348, 0.19444444444444
75834, 1.5695652173913, 0.20217391304348, 0.16666666666667
75835, 1.5913043478261, 0.22826086956522, 0.16666666666667
75836, 1.5913043478261, 0.20217391304348, 0.13888888888889
75837, 1.5695652173913, 0.20217391304348, 0.11111111111111
75838, 1.5913043478261, 0.22826086956522, 0.11111111111111
75839, 1.5913043478261, 0.20217391304348, 0.083333333333333
75840, 1.5695652173913, 0.20217391304348, 0.055555555555556
75841, 1.5913043478261, 0.22826086956522, 0.055555555555556
75842, 1.5913043478261, 0.20217391304348, 0.027777777777778
75843, 1.6347826086957, 0.20217391304348, 0.47222222222222
75844, 1.6130434782609, 0.20217391304348, 0.44444444444444
75845, 1.6347826086957, 0.22826086956522, 0.44444444444444
75846, 1.6347826086957, 0.20217391304348, 0.41666666666667
75847, 1.6130434782609, 0.20217391304348, 0.38888888888889
75848, 1.6347826086957, 0.22826086956522, 0.38888888888889
75849, 1.6347826086957, 0.20217391304348, 0.36111111111111
75850, 1.6130434782609, 0.20217391304348, 0.33333333333333
75851, 1.6347826086957, 0.22826086956522, 0.33333333333333
75852, 1.6347826086957, 0.20217391304348, 0.30555555555556
75853, 1.6130434782609, 0.20217391304348, 0.27777777777778
75854, 1.6347826086957, 0.22826086956522, 0.27777777777778
75855, 1.6347826086957, 0.20217391304348, 0.25
75856, 1.6130434782609, 0.20217391304348, 0.22222222222222
75857, 1.6347826086957, 0.22826086956522, 0.22222222222222
75858, 1.6347826086957, 0.20217391304348, 0.19444444444444
75859, 1.6130434782609, 0.20217391304348, 0.16666666666667
75860, 1.6347826086957, 0.22826086956522, 0.16666666666667
75861, 1.6347826086957, 0.20217391304348, 0.13888888888889
75862, 1.6130434782609, 0.20217391304348, 0.11111111111111
75863, 1.6347826086957, 0.22826086956522, 0.11111111111111
75864, 1.6347826086957, 0.20217391304348, 0.083333333333333
75865, 1.6130434782609, 0.20217391304348, 0.055555555555556
75866, 1.6347826086957, 0.22826086956522, 0.055555555555556
75867, 1.6347826086957, 0.20217391304348, 0.027777777777778
75868, 1.6782608695652, 0.20217391304348, 0.47222222222222
75869, 1.6565217391304, 0.20217391304348, 0.44444444444444
75870, 1.6782608695652, 0.22826086956522, 0.44444444444444
75871, 1.6782608695652, 0.20217391304348, 0.41666666666667
75872, 1.6565217391304, 0.20217391304348, 0.38888888888889
75873, 1.6782608695652, 0.22826086956522, 0.38888888888889
75874, 1.6782608695652, 0.20217391304348, 0.36111111111111
75875, 1.6565217391304, 0.20217391304348, 0.33333333333333
75876, 1.6782608695652, 0.22826086956522, 0.33333333333333
75877, 1.6782608695652, 0.20217391304348, 0.30555555555556
75878, 1.6565217391304, 0.20217391304348, 0.27777777777778
75879, 1.6782608695652, 0.22826086956522, 0.27777777777778
75880, 1.6782608695652, 0.20217391304348, 0.25
75881, 1.6565217391304, 0.20217391304348, 0.22222222222222
75882, 1.6782608695652, 0.22826086956522, 0.22222222222222
75883, 1.6782608695652, 0.20217391304348, 0.19444444444444
75884, 1.6565217391304, 0.20217391304348, 0.16666666666667
75885, 1.6782608695652, 0.22826086956522, 0.16666666666667
75886, 1.6782608695652, 0.20217391304348, 0.13888888888889
75887, 1.6565217391304, 0.20217391304348, 0.11111111111111
75888, 1.6782608695652, 0.22826086956522, 0.11111111111111
75889, 1.6782608695652, 0.20217391304348, 0.083333333333333
75890, 1.6565217391304, 0.20217391304348, 0.055555555555556
75891, 1.6782608695652, 0.22826086956522, 0.055555555555556
75892, 1.6782608695652, 0.20217391304348, 0.027777777777778
75893, 1.7217391304348, 0.20217391304348, 0.47222222222222
75894, 1.7, 0.20217391304348, 0.44444444444444
75895, 1.7217391304348, 0.22826086956522, 0.44444444444444
75896, 1.7217391304348, 0.20217391304348, 0.41666666666667
75897, 1.7, 0.20217391304348, 0.38888888888889
75898, 1.7217391304348, 0.22826086956522, 0.38888888888889
75899, 1.7217391304348, 0.20217391304348, 0.36111111111111
75900, 1.7, 0.20217391304348, 0.33333333333333
75901, 1.7217391304348, 0.22826086956522, 0.33333333333333
75902, 1.7217391304348, 0.20217391304348, 0.30555555555556
75903, 1.7, 0.20217391304348, 0.27777777777778
75904, 1.7217391304348, 0.22826086956522, 0.27777777777778
75905, 1.7217391304348, 0.20217391304348, 0.25
75906, 1.7, 0.20217391304348, 0.22222222222222
75907, 1.7217391304348, 0.22826086956522, 0.22222222222222
75908, 1.7217391304348, 0.20217391304348, 0.19444444444444
75909, 1.7, 0.20217391304348, 0.16666666666667
75910, 1.7217391304348, 0.22826086956522, 0.16666666666667
75911, 1.7217391304348, 0.20217391304348, 0.13888888888889
75912, 1.7, 0.20217391304348, 0.11111111111111
75913, 1.7217391304348, 0.22826086956522, 0.11111111111111
75914, 1.7217391304348, 0.20217391304348, 0.083333333333333
75915, 1.7, 0.20217391304348, 0.055555555555556
75916, 1.7217391304348, 0.22826086956522, 0.055555555555556
75917, 1.7217391304348, 0.20217391304348, 0.027777777777778
75918, 1.7652173913043, 0.20217391304348, 0.47222222222222
75919, 1.7434782608696, 0.20217391304348, 0.44444444444444
75920, 1.7652173913043, 0.22826086956522, 0.44444444444444
75921, 1.7652173913043, 0.20217391304348, 0.41666666666667
75922, 1.7434782608696, 0.20217391304348, 0.38888888888889
75923, 1.7652173913043, 0.22826086956522, 0.38888888888889
75924, 1.7652173913043, 0.20217391304348, 0.36111111111111
75925, 1.7434782608696, 0.20217391304348, 0.33333333333333
75926, 1.7652173913043, 0.22826086956522, 0.33333333333333
75927, 1.7652173913043, 0.20217391304348, 0.30555555555556
75928, 1.7434782608696, 0.20217391304348, 0.27777777777778
75929, 1.7652173913043, 0.22826086956522, 0.27777777777778
75930, 1.7652173913043, 0.20217391304348, 0.25
75931, 1.7434782608696, 0.20217391304348, 0.22222222222222
75932, 1.7652173913043, 0.22826086956522, 0.22222222222222
75933, 1.7652173913043, 0.20217391304348, 0.19444444444444
75934, 1.7434782608696, 0.20217391304348, 0.16666666666667
75935, 1.7652173913043, 0.22826086956522, 0.16666666666667
75936, 1.7652173913043, 0.20217391304348, 0.13888888888889
75937, 1.7434782608696, 0.20217391304348, 0.11111111111111
75938, 1.7652173913043, 0.22826086956522, 0.11111111111111
75939, 1.7652173913043, 0.20217391304348, 0.083333333333333
75940, 1.7434782608696, 0.20217391304348, 0.055555555555556
75941, 1.7652173913043, 0.22826086956522, 0.055555555555556
75942, 1.7652173913043, 0.20217391304348, 0.027777777777778
75943, 1.8086956521739, 0.20217391304348, 0.47222222222222
75944, 1.7869565217391, 0.20217391304348, 0.44444444444444
75945, 1.8086956521739, 0.22826086956522, 0.44444444444444
75946, 1.8086956521739, 0.20217391304348, 0.41666666666667
75947, 1.7869565217391, 0.20217391304348, 0.38888888888889
75948, 1.8086956521739, 0.22826086956522, 0.38888888888889
75949, 1.8086956521739, 0.20217391304348, 0.36111111111111
75950, 1.7869565217391, 0.20217391304348, 0.33333333333333
75951, 1.8086956521739, 0.22826086956522, 0.33333333333333
75952, 1.8086956521739, 0.20217391304348, 0.30555555555556
75953, 1.7869565217391, 0.20217391304348, 0.27777777777778
75954, 1.8086956521739, 0.22826086956522, 0.27777777777778
75955, 1.8086956521739, 0.20217391304348, 0.25
75956, 1.7869565217391, 0.20217391304348, 0.22222222222222
75957, 1.8086956521739, 0.22826086956522, 0.22222222222222
75958, 1.8086956521739, 0.20217391304348, 0.19444444444444
75959, 1.7869565217391, 0.20217391304348, 0.16666666666667
75960, 1.8086956521739, 0.22826086956522, 0.16666666666667
75961, 1.8086956521739, 0.20217391304348, 0.13888888888889
75962, 1.7869565217391, 0.20217391304348, 0.11111111111111
75963, 1.8086956521739, 0.22826086956522, 0.11111111111111
75964, 1.8086956521739, 0.20217391304348, 0.083333333333333
75965, 1.7869565217391, 0.20217391304348, 0.055555555555556
75966, 1.8086956521739, 0.22826086956522, 0.055555555555556
75967, 1.8086956521739, 0.20217391304348, 0.027777777777778
75968, 1.8521739130435, 0.20217391304348, 0.47222222222222
75969, 1.8304347826087, 0.20217391304348, 0.44444444444444
75970, 1.8521739130435, 0.22826086956522, 0.44444444444444
75971, 1.8521739130435, 0.20217391304348, 0.41666666666667
75972, 1.8304347826087, 0.20217391304348, 0.38888888888889
75973, 1.8521739130435, 0.22826086956522, 0.38888888888889
75974, 1.8521739130435, 0.20217391304348, 0.36111111111111
75975, 1.8304347826087, 0.20217391304348, 0.33333333333333
75976, 1.8521739130435, 0.22826086956522, 0.33333333333333
75977, 1.8521739130435, 0.20217391304348, 0.30555555555556
75978, 1.8304347826087, 0.20217391304348, 0.27777777777778
75979, 1.8521739130435, 0.22826086956522, 0.27777777777778
75980, 1.8521739130435, 0.20217391304348, 0.25
75981, 1.8304347826087, 0.20217391304348, 0.22222222222222
75982, 1.8521739130435, 0.22826086956522, 0.22222222222222
75983, 1.8521739130435, 0.20217391304348, 0.19444444444444
75984, 1.8304347826087, 0.20217391304348, 0.16666666666667
75985, 1.8521739130435, 0.22826086956522, 0.16666666666667
75986, 1.8521739130435, 0.20217391304348, 0.13888888888889
75987, 1.8304347826087, 0.20217391304348, 0.11111111111111
75988, 1.8521739130435, 0.22826086956522, 0.11111111111111
75989, 1.8521739130435, 0.20217391304348, 0.083333333333333
75990, 1.8304347826087, 0.20217391304348, 0.055555555555556
75991, 1.8521739130435, 0.22826086956522, 0.055555555555556
75992, 1.8521739130435, 0.20217391304348, 0.027777777777778
75993, 1.895652173913, 0.20217391304348, 0.47222222222222
75994, 1.8739130434783, 0.20217391304348, 0.44444444444444
75995, 1.895652173913, 0.22826086956522, 0.44444444444444
75996, 1.895652173913, 0.20217391304348, 0.41666666666667
75997, 1.8739130434783, 0.20217391304348, 0.38888888888889
75998, 1.895652173913, 0.22826086956522, 0.38888888888889
75999, 1.895652173913, 0.20217391304348, 0.36111111111111
76000, 1.8739130434783, 0.20217391304348, 0.33333333333333
76001, 1.895652173913, 0.22826086956522, 0.33333333333333
76002, 1.895652173913, 0.20217391304348, 0.30555555555556
76003, 1.8739130434783, 0.20217391304348, 0.27777777777778
76004, 1.895652173913, 0.22826086956522, 0.27777777777778
76005, 1.895652173913, 0.20217391304348, 0.25
76006, 1.8739130434783, 0.20217391304348, 0.22222222222222
76007, 1.895652173913, 0.22826086956522, 0.22222222222222
76008, 1.895652173913, 0.20217391304348, 0.19444444444444
76009, 1.8739130434783, 0.20217391304348, 0.16666666666667
76010, 1.895652173913, 0.22826086956522, 0.16666666666667
76011, 1.895652173913, 0.20217391304348, 0.13888888888889
76012, 1.8739130434783, 0.20217391304348, 0.11111111111111
76013, 1.895652173913, 0.22826086956522, 0.11111111111111
76014, 1.895652173913, 0.20217391304348, 0.083333333333333
76015, 1.8739130434783, 0.20217391304348, 0.055555555555556
76016, 1.895652173913, 0.22826086956522, 0.055555555555556
76017, 1.895652173913, 0.20217391304348, 0.027777777777778
76018, 1.9391304347826, 0.20217391304348, 0.47222222222222
76019, 1.9173913043478, 0.20217391304348, 0.44444444444444
76020, 1.9391304347826, 0.22826086956522, 0.44444444444444
76021, 1.9391304347826, 0.20217391304348, 0.41666666666667
76022, 1.9173913043478, 0.20217391304348, 0.38888888888889
76023, 1.9391304347826, 0.22826086956522, 0.38888888888889
76024, 1.9391304347826, 0.20217391304348, 0.36111111111111
76025, 1.9173913043478, 0.20217391304348, 0.33333333333333
76026, 1.9391304347826, 0.22826086956522, 0.33333333333333
76027, 1.9391304347826, 0.20217391304348, 0.30555555555556
76028, 1.9173913043478, 0.20217391304348, 0.27777777777778
76029, 1.9391304347826, 0.22826086956522, 0.27777777777778
76030, 1.9391304347826, 0.20217391304348, 0.25
76031, 1.9173913043478, 0.20217391304348, 0.22222222222222
76032, 1.9391304347826, 0.22826086956522, 0.22222222222222
76033, 1.9391304347826, 0.20217391304348, 0.19444444444444
76034, 1.9173913043478, 0.20217391304348, 0.16666666666667
76035, 1.9391304347826, 0.22826086956522, 0.16666666666667
76036, 1.9391304347826, 0.20217391304348, 0.13888888888889
76037, 1.9173913043478, 0.20217391304348, 0.11111111111111
76038, 1.9391304347826, 0.22826086956522, 0.11111111111111
76039, 1.9391304347826, 0.20217391304348, 0.083333333333333
76040, 1.9173913043478, 0.20217391304348, 0.055555555555556
76041, 1.9391304347826, 0.22826086956522, 0.055555555555556
76042, 1.9391304347826, 0.20217391304348, 0.027777777777778
76043, 1.9826086956522, 0.20217391304348, 0.47222222222222
76044, 1.9608695652174, 0.20217391304348, 0.44444444444444
76045, 1.9826086956522, 0.22826086956522, 0.44444444444444
76046, 1.9826086956522, 0.20217391304348, 0.41666666666667
76047, 1.9608695652174, 0.20217391304348, 0.38888888888889
76048, 1.9826086956522, 0.22826086956522, 0.38888888888889
76049, 1.9826086956522, 0.20217391304348, 0.36111111111111
76050, 1.9608695652174, 0.20217391304348, 0.33333333333333
76051, 1.9826086956522, 0.22826086956522, 0.33333333333333
76052, 1.9826086956522, 0.20217391304348, 0.30555555555556
76053, 1.9608695652174, 0.20217391304348, 0.27777777777778
76054, 1.9826086956522, 0.22826086956522, 0.27777777777778
76055, 1.9826086956522, 0.20217391304348, 0.25
76056, 1.9608695652174, 0.20217391304348, 0.22222222222222
76057, 1.9826086956522, 0.22826086956522, 0.22222222222222
76058, 1.9826086956522, 0.20217391304348, 0.19444444444444
76059, 1.9608695652174, 0.20217391304348, 0.16666666666667
76060, 1.9826086956522, 0.22826086956522, 0.16666666666667
76061, 1.9826086956522, 0.20217391304348, 0.13888888888889
76062, 1.9608695652174, 0.20217391304348, 0.11111111111111
76063, 1.9826086956522, 0.22826086956522, 0.11111111111111
76064, 1.9826086956522, 0.20217391304348, 0.083333333333333
76065, 1.9608695652174, 0.20217391304348, 0.055555555555556
76066, 1.9826086956522, 0.22826086956522, 0.055555555555556
76067, 1.9826086956522, 0.20217391304348, 0.027777777777778
76068, 2.0260869565217, 0.20217391304348, 0.47222222222222
76069, 2.004347826087, 0.20217391304348, 0.44444444444444
76070, 2.0260869565217, 0.22826086956522, 0.44444444444444
76071, 2.0260869565217, 0.20217391304348, 0.41666666666667
76072, 2.004347826087, 0.20217391304348, 0.38888888888889
76073, 2.0260869565217, 0.22826086956522, 0.38888888888889
76074, 2.0260869565217, 0.20217391304348, 0.36111111111111
76075, 2.004347826087, 0.20217391304348, 0.33333333333333
76076, 2.0260869565217, 0.22826086956522, 0.33333333333333
76077, 2.0260869565217, 0.20217391304348, 0.30555555555556
76078, 2.004347826087, 0.20217391304348, 0.27777777777778
76079, 2.0260869565217, 0.22826086956522, 0.27777777777778
76080, 2.0260869565217, 0.20217391304348, 0.25
76081, 2.004347826087, 0.20217391304348, 0.22222222222222
76082, 2.0260869565217, 0.22826086956522, 0.22222222222222
76083, 2.0260869565217, 0.20217391304348, 0.19444444444444
76084, 2.004347826087, 0.20217391304348, 0.16666666666667
76085, 2.0260869565217, 0.22826086956522, 0.16666666666667
76086, 2.0260869565217, 0.20217391304348, 0.13888888888889
76087, 2.004347826087, 0.20217391304348, 0.11111111111111
76088, 2.0260869565217, 0.22826086956522, 0.11111111111111
76089, 2.0260869565217, 0.20217391304348, 0.083333333333333
76090, 2.004347826087, 0.20217391304348, 0.055555555555556
76091, 2.0260869565217, 0.22826086956522, 0.055555555555556
76092, 2.0260869565217, 0.20217391304348, 0.027777777777778
76093, 2.0695652173913, 0.20217391304348, 0.47222222222222
76094, 2.0478260869565, 0.20217391304348, 0.44444444444444
76095, 2.0695652173913, 0.22826086956522, 0.44444444444444
76096, 2.0695652173913, 0.20217391304348, 0.41666666666667
76097, 2.0478260869565, 0.20217391304348, 0.38888888888889
76098, 2.0695652173913, 0.22826086956522, 0.38888888888889
76099, 2.0695652173913, 0.20217391304348, 0.36111111111111
76100, 2.0478260869565, 0.20217391304348, 0.33333333333333
76101, 2.0695652173913, 0.22826086956522, 0.33333333333333
76102, 2.0695652173913, 0.20217391304348, 0.30555555555556
76103, 2.0478260869565, 0.20217391304348, 0.27777777777778
76104, 2.0695652173913, 0.22826086956522, 0.27777777777778
76105, 2.0695652173913, 0.20217391304348, 0.25
76106, 2.0478260869565, 0.20217391304348, 0.22222222222222
76107, 2.0695652173913, 0.22826086956522, 0.22222222222222
76108, 2.0695652173913, 0.20217391304348, 0.19444444444444
76109, 2.0478260869565, 0.20217391304348, 0.16666666666667
76110, 2.0695652173913, 0.22826086956522, 0.16666666666667
76111, 2.0695652173913, 0.20217391304348, 0.13888888888889
76112, 2.0478260869565, 0.20217391304348, 0.11111111111111
76113, 2.0695652173913, 0.22826086956522, 0.11111111111111
76114, 2.0695652173913, 0.20217391304348, 0.083333333333333
76115, 2.0478260869565, 0.20217391304348, 0.055555555555556
76116, 2.0695652173913, 0.22826086956522, 0.055555555555556
76117, 2.0695652173913, 0.20217391304348, 0.027777777777778
76118, 2.1130434782609, 0.20217391304348, 0.47222222222222
76119, 2.0913043478261, 0.20217391304348, 0.44444444444444
76120, 2.1130434782609, 0.22826086956522, 0.44444444444444
76121, 2.1130434782609, 0.20217391304348, 0.41666666666667
76122, 2.0913043478261, 0.20217391304348, 0.38888888888889
76123, 2.1130434782609, 0.22826086956522, 0.38888888888889
76124, 2.1130434782609, 0.20217391304348, 0.36111111111111
76125, 2.0913043478261, 0.20217391304348, 0.33333333333333
76126, 2.1130434782609, 0.22826086956522, 0.33333333333333
76127, 2.1130434782609, 0.20217391304348, 0.30555555555556
76128, 2.0913043478261, 0.20217391304348, 0.27777777777778
76129, 2.1130434782609, 0.22826086956522, 0.27777777777778
76130, 2.1130434782609, 0.20217391304348, 0.25
76131, 2.0913043478261, 0.20217391304348, 0.22222222222222
76132, 2.1130434782609, 0.22826086956522, 0.22222222222222
76133, 2.1130434782609, 0.20217391304348, 0.19444444444444
76134, 2.0913043478261, 0.20217391304348, 0.16666666666667
76135, 2.1130434782609, 0.22826086956522, 0.16666666666667
76136, 2.1130434782609, 0.20217391304348, 0.13888888888889
76137, 2.0913043478261, 0.20217391304348, 0.11111111111111
76138, 2.1130434782609, 0.22826086956522, 0.11111111111111
76139, 2.1130434782609, 0.20217391304348, 0.083333333333333
76140, 2.0913043478261, 0.20217391304348, 0.055555555555556
76141, 2.1130434782609, 0.22826086956522, 0.055555555555556
76142, 2.1130434782609, 0.20217391304348, 0.027777777777778
76143, 2.1565217391304, 0.20217391304348, 0.47222222222222
76144, 2.1347826086957, 0.20217391304348, 0.44444444444444
76145, 2.1565217391304, 0.22826086956522, 0.44444444444444
76146, 2.1565217391304, 0.20217391304348, 0.41666666666667
76147, 2.1347826086957, 0.20217391304348, 0.38888888888889
76148, 2.1565217391304, 0.22826086956522, 0.38888888888889
76149, 2.1565217391304, 0.20217391304348, 0.36111111111111
76150, 2.1347826086957, 0.20217391304348, 0.33333333333333
76151, 2.1565217391304, 0.22826086956522, 0.33333333333333
76152, 2.1565217391304, 0.20217391304348, 0.30555555555556
76153, 2.1347826086957, 0.20217391304348, 0.27777777777778
76154, 2.1565217391304, 0.22826086956522, 0.27777777777778
76155, 2.1565217391304, 0.20217391304348, 0.25
76156, 2.1347826086957, 0.20217391304348, 0.22222222222222
76157, 2.1565217391304, 0.22826086956522, 0.22222222222222
76158, 2.1565217391304, 0.20217391304348, 0.19444444444444
76159, 2.1347826086957, 0.20217391304348, 0.16666666666667
76160, 2.1565217391304, 0.22826086956522, 0.16666666666667
76161, 2.1565217391304, 0.20217391304348, 0.13888888888889
76162, 2.1347826086957, 0.20217391304348, 0.11111111111111
76163, 2.1565217391304, 0.22826086956522, 0.11111111111111
76164, 2.1565217391304, 0.20217391304348, 0.083333333333333
76165, 2.1347826086957, 0.20217391304348, 0.055555555555556
76166, 2.1565217391304, 0.22826086956522, 0.055555555555556
76167, 2.1565217391304, 0.20217391304348, 0.027777777777778
76168, 2.1782608695652, 0.20217391304348, 0.44444444444444
76169, 2.1782608695652, 0.20217391304348, 0.38888888888889
76170, 2.1782608695652, 0.20217391304348, 0.33333333333333
76171, 2.1782608695652, 0.20217391304348, 0.27777777777778
76172, 2.1782608695652, 0.20217391304348, 0.22222222222222
76173, 2.1782608695652, 0.20217391304348, 0.16666666666667
76174, 2.1782608695652, 0.20217391304348, 0.11111111111111
76175, 2.1782608695652, 0.20217391304348, 0.055555555555556
76176, 1.2434782608696, 0.17608695652174, 0.44444444444444
76177, 1.2434782608696, 0.17608695652174, 0.38888888888889
76178, 1.2434782608696, 0.17608695652174, 0.33333333333333
76179, 1.2434782608696, 0.17608695652174, 0.27777777777778
76180, 1.2434782608696, 0.17608695652174, 0.22222222222222
76181, 1.2434782608696, 0.17608695652174, 0.16666666666667
76182, 1.2434782608696, 0.17608695652174, 0.11111111111111
76183, 1.2434782608696, 0.17608695652174, 0.055555555555556
76184, 1.2869565217391, 0.17608695652174, 0.44444444444444
76185, 1.2869565217391, 0.17608695652174, 0.38888888888889
76186, 1.2869565217391, 0.17608695652174, 0.33333333333333
76187, 1.2869565217391, 0.17608695652174, 0.27777777777778
76188, 1.2869565217391, 0.17608695652174, 0.22222222222222
76189, 1.2869565217391, 0.17608695652174, 0.16666666666667
76190, 1.2869565217391, 0.17608695652174, 0.11111111111111
76191, 1.2869565217391, 0.17608695652174, 0.055555555555556
76192, 1.3304347826087, 0.17608695652174, 0.44444444444444
76193, 1.3304347826087, 0.17608695652174, 0.38888888888889
76194, 1.3304347826087, 0.17608695652174, 0.33333333333333
76195, 1.3304347826087, 0.17608695652174, 0.27777777777778
76196, 1.3304347826087, 0.17608695652174, 0.22222222222222
76197, 1.3304347826087, 0.17608695652174, 0.16666666666667
76198, 1.3304347826087, 0.17608695652174, 0.11111111111111
76199, 1.3304347826087, 0.17608695652174, 0.055555555555556
76200, 1.3739130434783, 0.17608695652174, 0.44444444444444
76201, 1.3739130434783, 0.17608695652174, 0.38888888888889
76202, 1.3739130434783, 0.17608695652174, 0.33333333333333
76203, 1.3739130434783, 0.17608695652174, 0.27777777777778
76204, 1.3739130434783, 0.17608695652174, 0.22222222222222
76205, 1.3739130434783, 0.17608695652174, 0.16666666666667
76206, 1.3739130434783, 0.17608695652174, 0.11111111111111
76207, 1.3739130434783, 0.17608695652174, 0.055555555555556
76208, 1.4173913043478, 0.17608695652174, 0.44444444444444
76209, 1.4173913043478, 0.17608695652174, 0.38888888888889
76210, 1.4173913043478, 0.17608695652174, 0.33333333333333
76211, 1.4173913043478, 0.17608695652174, 0.27777777777778
76212, 1.4173913043478, 0.17608695652174, 0.22222222222222
76213, 1.4173913043478, 0.17608695652174, 0.16666666666667
76214, 1.4173913043478, 0.17608695652174, 0.11111111111111
76215, 1.4173913043478, 0.17608695652174, 0.055555555555556
76216, 1.4608695652174, 0.17608695652174, 0.44444444444444
76217, 1.4608695652174, 0.17608695652174, 0.38888888888889
76218, 1.4608695652174, 0.17608695652174, 0.33333333333333
76219, 1.4608695652174, 0.17608695652174, 0.27777777777778
76220, 1.4608695652174, 0.17608695652174, 0.22222222222222
76221, 1.4608695652174, 0.17608695652174, 0.16666666666667
76222, 1.4608695652174, 0.17608695652174, 0.11111111111111
76223, 1.4608695652174, 0.17608695652174, 0.055555555555556
76224, 1.504347826087, 0.17608695652174, 0.44444444444444
76225, 1.504347826087, 0.17608695652174, 0.38888888888889
76226, 1.504347826087, 0.17608695652174, 0.33333333333333
76227, 1.504347826087, 0.17608695652174, 0.27777777777778
76228, 1.504347826087, 0.17608695652174, 0.22222222222222
76229, 1.504347826087, 0.17608695652174, 0.16666666666667
76230, 1.504347826087, 0.17608695652174, 0.11111111111111
76231, 1.504347826087, 0.17608695652174, 0.055555555555556
76232, 1.5478260869565, 0.17608695652174, 0.44444444444444
76233, 1.5478260869565, 0.17608695652174, 0.38888888888889
76234, 1.5478260869565, 0.17608695652174, 0.33333333333333
76235, 1.5478260869565, 0.17608695652174, 0.27777777777778
76236, 1.5478260869565, 0.17608695652174, 0.22222222222222
76237, 1.5478260869565, 0.17608695652174, 0.16666666666667
76238, 1.5478260869565, 0.17608695652174, 0.11111111111111
76239, 1.5478260869565, 0.17608695652174, 0.055555555555556
76240, 1.5913043478261, 0.17608695652174, 0.44444444444444
76241, 1.5913043478261, 0.17608695652174, 0.38888888888889
76242, 1.5913043478261, 0.17608695652174, 0.33333333333333
76243, 1.5913043478261, 0.17608695652174, 0.27777777777778
76244, 1.5913043478261, 0.17608695652174, 0.22222222222222
76245, 1.5913043478261, 0.17608695652174, 0.16666666666667
76246, 1.5913043478261, 0.17608695652174, 0.11111111111111
76247, 1.5913043478261, 0.17608695652174, 0.055555555555556
76248, 1.6347826086957, 0.17608695652174, 0.44444444444444
76249, 1.6347826086957, 0.17608695652174, 0.38888888888889
76250, 1.6347826086957, 0.17608695652174, 0.33333333333333
76251, 1.6347826086957, 0.17608695652174, 0.27777777777778
76252, 1.6347826086957, 0.17608695652174, 0.22222222222222
76253, 1.6347826086957, 0.17608695652174, 0.16666666666667
76254, 1.6347826086957, 0.17608695652174, 0.11111111111111
76255, 1.6347826086957, 0.17608695652174, 0.055555555555556
76256, 1.6782608695652, 0.17608695652174, 0.44444444444444
76257, 1.6782608695652, 0.17608695652174, 0.38888888888889
76258, 1.6782608695652, 0.17608695652174, 0.33333333333333
76259, 1.6782608695652, 0.17608695652174, 0.27777777777778
76260, 1.6782608695652, 0.17608695652174, 0.22222222222222
76261, 1.6782608695652, 0.17608695652174, 0.16666666666667
76262, 1.6782608695652, 0.17608695652174, 0.11111111111111
76263, 1.6782608695652, 0.17608695652174, 0.055555555555556
76264, 1.7217391304348, 0.17608695652174, 0.44444444444444
76265, 1.7217391304348, 0.17608695652174, 0.38888888888889
76266, 1.7217391304348, 0.17608695652174, 0.33333333333333
76267, 1.7217391304348, 0.17608695652174, 0.27777777777778
76268, 1.7217391304348, 0.17608695652174, 0.22222222222222
76269, 1.7217391304348, 0.17608695652174, 0.16666666666667
76270, 1.7217391304348, 0.17608695652174, 0.11111111111111
76271, 1.7217391304348, 0.17608695652174, 0.055555555555556
76272, 1.7652173913043, 0.17608695652174, 0.44444444444444
76273, 1.7652173913043, 0.17608695652174, 0.38888888888889
76274, 1.7652173913043, 0.17608695652174, 0.33333333333333
76275, 1.7652173913043, 0.17608695652174, 0.27777777777778
76276, 1.7652173913043, 0.17608695652174, 0.22222222222222
76277, 1.7652173913043, 0.17608695652174, 0.16666666666667
76278, 1.7652173913043, 0.17608695652174, 0.11111111111111
76279, 1.7652173913043, 0.17608695652174, 0.055555555555556
76280, 1.8086956521739, 0.17608695652174, 0.44444444444444
76281, 1.8086956521739, 0.17608695652174, 0.38888888888889
76282, 1.8086956521739, 0.17608695652174, 0.33333333333333
76283, 1.8086956521739, 0.17608695652174, 0.27777777777778
76284, 1.8086956521739, 0.17608695652174, 0.22222222222222
76285, 1.8086956521739, 0.17608695652174, 0.16666666666667
76286, 1.8086956521739, 0.17608695652174, 0.11111111111111
76287, 1.8086956521739, 0.17608695652174, 0.055555555555556
76288, 1.8521739130435, 0.17608695652174, 0.44444444444444
76289, 1.8521739130435, 0.17608695652174, 0.38888888888889
76290, 1.8521739130435, 0.17608695652174, 0.33333333333333
76291, 1.8521739130435, 0.17608695652174, 0.27777777777778
76292, 1.8521739130435, 0.17608695652174, 0.22222222222222
76293, 1.8521739130435, 0.17608695652174, 0.16666666666667
76294, 1.8521739130435, 0.17608695652174, 0.11111111111111
76295, 1.8521739130435, 0.17608695652174, 0.055555555555556
76296, 1.895652173913, 0.17608695652174, 0.44444444444444
76297, 1.895652173913, 0.17608695652174, 0.38888888888889
76298, 1.895652173913, 0.17608695652174, 0.33333333333333
76299, 1.895652173913, 0.17608695652174, 0.27777777777778
76300, 1.895652173913, 0.17608695652174, 0.22222222222222
76301, 1.895652173913, 0.17608695652174, 0.16666666666667
76302, 1.895652173913, 0.17608695652174, 0.11111111111111
76303, 1.895652173913, 0.17608695652174, 0.055555555555556
76304, 1.9391304347826, 0.17608695652174, 0.44444444444444
76305, 1.9391304347826, 0.17608695652174, 0.38888888888889
76306, 1.9391304347826, 0.17608695652174, 0.33333333333333
76307, 1.9391304347826, 0.17608695652174, 0.27777777777778
76308, 1.9391304347826, 0.17608695652174, 0.22222222222222
76309, 1.9391304347826, 0.17608695652174, 0.16666666666667
76310, 1.9391304347826, 0.17608695652174, 0.11111111111111
76311, 1.9391304347826, 0.17608695652174, 0.055555555555556
76312, 1.9826086956522, 0.17608695652174, 0.44444444444444
76313, 1.9826086956522, 0.17608695652174, 0.38888888888889
76314, 1.9826086956522, 0.17608695652174, 0.33333333333333
76315, 1.9826086956522, 0.17608695652174, 0.27777777777778
76316, 1.9826086956522, 0.17608695652174, 0.22222222222222
76317, 1.9826086956522, 0.17608695652174, 0.16666666666667
76318, 1.9826086956522, 0.17608695652174, 0.11111111111111
76319, 1.9826086956522, 0.17608695652174, 0.055555555555556
76320, 2.0260869565217, 0.17608695652174, 0.44444444444444
76321, 2.0260869565217, 0.17608695652174, 0.38888888888889
76322, 2.0260869565217, 0.17608695652174, 0.33333333333333
76323, 2.0260869565217, 0.17608695652174, 0.27777777777778
76324, 2.0260869565217, 0.17608695652174, 0.22222222222222
76325, 2.0260869565217, 0.17608695652174, 0.16666666666667
76326, 2.0260869565217, 0.17608695652174, 0.11111111111111
76327, 2.0260869565217, 0.17608695652174, 0.055555555555556
76328, 2.0695652173913, 0.17608695652174, 0.44444444444444
76329, 2.0695652173913, 0.17608695652174, 0.38888888888889
76330, 2.0695652173913, 0.17608695652174, 0.33333333333333
76331, 2.0695652173913, 0.17608695652174, 0.27777777777778
76332, 2.0695652173913, 0.17608695652174, 0.22222222222222
76333, 2.0695652173913, 0.17608695652174, 0.16666666666667
76334, 2.0695652173913, 0.17608695652174, 0.11111111111111
76335, 2.0695652173913, 0.17608695652174, 0.055555555555556
76336, 2.1130434782609, 0.17608695652174, 0.44444444444444
76337, 2.1130434782609, 0.17608695652174, 0.38888888888889
76338, 2.1130434782609, 0.17608695652174, 0.33333333333333
76339, 2.1130434782609, 0.17608695652174, 0.27777777777778
76340, 2.1130434782609, 0.17608695652174, 0.22222222222222
76341, 2.1130434782609, 0.17608695652174, 0.16666666666667
76342, 2.1130434782609, 0.17608695652174, 0.11111111111111
76343, 2.1130434782609, 0.17608695652174, 0.055555555555556
76344, 2.1565217391304, 0.17608695652174, 0.44444444444444
76345, 2.1565217391304, 0.17608695652174, 0.38888888888889
76346, 2.1565217391304, 0.17608695652174, 0.33333333333333
76347, 2.1565217391304, 0.17608695652174, 0.27777777777778
76348, 2.1565217391304, 0.17608695652174, 0.22222222222222
76349, 2.1565217391304, 0.17608695652174, 0.16666666666667
76350, 2.1565217391304, 0.17608695652174, 0.11111111111111
76351, 2.1565217391304, 0.17608695652174, 0.055555555555556
76352, 1.2434782608696, 0.125, 0.44444444444444
76353, 1.2434782608696, 0.125, 0.38888888888889
76354, 1.2434782608696, 0.125, 0.33333333333333
76355, 1.2434782608696, 0.125, 0.27777777777778
76356, 1.2434782608696, 0.125, 0.22222222222222
76357, 1.2434782608696, 0.125, 0.16666666666667
76358, 1.2434782608696, 0.125, 0.11111111111111
76359, 1.2434782608696, 0.125, 0.055555555555556
76360, 1.2869565217391, 0.125, 0.44444444444444
76361, 1.2869565217391, 0.125, 0.38888888888889
76362, 1.2869565217391, 0.125, 0.33333333333333
76363, 1.2869565217391, 0.125, 0.27777777777778
76364, 1.2869565217391, 0.125, 0.22222222222222
76365, 1.2869565217391, 0.125, 0.16666666666667
76366, 1.2869565217391, 0.125, 0.11111111111111
76367, 1.2869565217391, 0.125, 0.055555555555556
76368, 1.3304347826087, 0.125, 0.44444444444444
76369, 1.3304347826087, 0.125, 0.38888888888889
76370, 1.3304347826087, 0.125, 0.33333333333333
76371, 1.3304347826087, 0.125, 0.27777777777778
76372, 1.3304347826087, 0.125, 0.22222222222222
76373, 1.3304347826087, 0.125, 0.16666666666667
76374, 1.3304347826087, 0.125, 0.11111111111111
76375, 1.3304347826087, 0.125, 0.055555555555556
76376, 1.3739130434783, 0.125, 0.44444444444444
76377, 1.3739130434783, 0.125, 0.38888888888889
76378, 1.3739130434783, 0.125, 0.33333333333333
76379, 1.3739130434783, 0.125, 0.27777777777778
76380, 1.3739130434783, 0.125, 0.22222222222222
76381, 1.3739130434783, 0.125, 0.16666666666667
76382, 1.3739130434783, 0.125, 0.11111111111111
76383, 1.3739130434783, 0.125, 0.055555555555556
76384, 1.4173913043478, 0.125, 0.44444444444444
76385, 1.4173913043478, 0.125, 0.38888888888889
76386, 1.4173913043478, 0.125, 0.33333333333333
76387, 1.4173913043478, 0.125, 0.27777777777778
76388, 1.4173913043478, 0.125, 0.22222222222222
76389, 1.4173913043478, 0.125, 0.16666666666667
76390, 1.4173913043478, 0.125, 0.11111111111111
76391, 1.4173913043478, 0.125, 0.055555555555556
76392, 1.4608695652174, 0.125, 0.44444444444444
76393, 1.4608695652174, 0.125, 0.38888888888889
76394, 1.4608695652174, 0.125, 0.33333333333333
76395, 1.4608695652174, 0.125, 0.27777777777778
76396, 1.4608695652174, 0.125, 0.22222222222222
76397, 1.4608695652174, 0.125, 0.16666666666667
76398, 1.4608695652174, 0.125, 0.11111111111111
76399, 1.4608695652174, 0.125, 0.055555555555556
76400, 1.504347826087, 0.125, 0.44444444444444
76401, 1.504347826087, 0.125, 0.38888888888889
76402, 1.504347826087, 0.125, 0.33333333333333
76403, 1.504347826087, 0.125, 0.27777777777778
76404, 1.504347826087, 0.125, 0.22222222222222
76405, 1.504347826087, 0.125, 0.16666666666667
76406, 1.504347826087, 0.125, 0.11111111111111
76407, 1.504347826087, 0.125, 0.055555555555556
76408, 1.5478260869565, 0.125, 0.44444444444444
76409, 1.5478260869565, 0.125, 0.38888888888889
76410, 1.5478260869565, 0.125, 0.33333333333333
76411, 1.5478260869565, 0.125, 0.27777777777778
76412, 1.5478260869565, 0.125, 0.22222222222222
76413, 1.5478260869565, 0.125, 0.16666666666667
76414, 1.5478260869565, 0.125, 0.11111111111111
76415, 1.5478260869565, 0.125, 0.055555555555556
76416, 1.5913043478261, 0.125, 0.44444444444444
76417, 1.5913043478261, 0.125, 0.38888888888889
76418, 1.5913043478261, 0.125, 0.33333333333333
76419, 1.5913043478261, 0.125, 0.27777777777778
76420, 1.5913043478261, 0.125, 0.22222222222222
76421, 1.5913043478261, 0.125, 0.16666666666667
76422, 1.5913043478261, 0.125, 0.11111111111111
76423, 1.5913043478261, 0.125, 0.055555555555556
76424, 1.6347826086957, 0.125, 0.44444444444444
76425, 1.6347826086957, 0.125, 0.38888888888889
76426, 1.6347826086957, 0.125, 0.33333333333333
76427, 1.6347826086957, 0.125, 0.27777777777778
76428, 1.6347826086957, 0.125, 0.22222222222222
76429, 1.6347826086957, 0.125, 0.16666666666667
76430, 1.6347826086957, 0.125, 0.11111111111111
76431, 1.6347826086957, 0.125, 0.055555555555556
76432, 1.6782608695652, 0.125, 0.44444444444444
76433, 1.6782608695652, 0.125, 0.38888888888889
76434, 1.6782608695652, 0.125, 0.33333333333333
76435, 1.6782608695652, 0.125, 0.27777777777778
76436, 1.6782608695652, 0.125, 0.22222222222222
76437, 1.6782608695652, 0.125, 0.16666666666667
76438, 1.6782608695652, 0.125, 0.11111111111111
76439, 1.6782608695652, 0.125, 0.055555555555556
76440, 1.7217391304348, 0.125, 0.44444444444444
76441, 1.7217391304348, 0.125, 0.38888888888889
76442, 1.7217391304348, 0.125, 0.33333333333333
76443, 1.7217391304348, 0.125, 0.27777777777778
76444, 1.7217391304348, 0.125, 0.22222222222222
76445, 1.7217391304348, 0.125, 0.16666666666667
76446, 1.7217391304348, 0.125, 0.11111111111111
76447, 1.7217391304348, 0.125, 0.055555555555556
76448, 1.7652173913043, 0.125, 0.44444444444444
76449, 1.7652173913043, 0.125, 0.38888888888889
76450, 1.7652173913043, 0.125, 0.33333333333333
76451, 1.7652173913043, 0.125, 0.27777777777778
76452, 1.7652173913043, 0.125, 0.22222222222222
76453, 1.7652173913043, 0.125, 0.16666666666667
76454, 1.7652173913043, 0.125, 0.11111111111111
76455, 1.7652173913043, 0.125, 0.055555555555556
76456, 1.8086956521739, 0.125, 0.44444444444444
76457, 1.8086956521739, 0.125, 0.38888888888889
76458, 1.8086956521739, 0.125, 0.33333333333333
76459, 1.8086956521739, 0.125, 0.27777777777778
76460, 1.8086956521739, 0.125, 0.22222222222222
76461, 1.8086956521739, 0.125, 0.16666666666667
76462, 1.8086956521739, 0.125, 0.11111111111111
76463, 1.8086956521739, 0.125, 0.055555555555556
76464, 1.8521739130435, 0.125, 0.44444444444444
76465, 1.8521739130435, 0.125, 0.38888888888889
76466, 1.8521739130435, 0.125, 0.33333333333333
76467, 1.8521739130435, 0.125, 0.27777777777778
76468, 1.8521739130435, 0.125, 0.22222222222222
76469, 1.8521739130435, 0.125, 0.16666666666667
76470, 1.8521739130435, 0.125, 0.11111111111111
76471, 1.8521739130435, 0.125, 0.055555555555556
76472, 1.895652173913, 0.125, 0.44444444444444
76473, 1.895652173913, 0.125, 0.38888888888889
76474, 1.895652173913, 0.125, 0.33333333333333
76475, 1.895652173913, 0.125, 0.27777777777778
76476, 1.895652173913, 0.125, 0.22222222222222
76477, 1.895652173913, 0.125, 0.16666666666667
76478, 1.895652173913, 0.125, 0.11111111111111
76479, 1.895652173913, 0.125, 0.055555555555556
76480, 1.9391304347826, 0.125, 0.44444444444444
76481, 1.9391304347826, 0.125, 0.38888888888889
76482, 1.9391304347826, 0.125, 0.33333333333333
76483, 1.9391304347826, 0.125, 0.27777777777778
76484, 1.9391304347826, 0.125, 0.22222222222222
76485, 1.9391304347826, 0.125, 0.16666666666667
76486, 1.9391304347826, 0.125, 0.11111111111111
76487, 1.9391304347826, 0.125, 0.055555555555556
76488, 1.9826086956522, 0.125, 0.44444444444444
76489, 1.9826086956522, 0.125, 0.38888888888889
76490, 1.9826086956522, 0.125, 0.33333333333333
76491, 1.9826086956522, 0.125, 0.27777777777778
76492, 1.9826086956522, 0.125, 0.22222222222222
76493, 1.9826086956522, 0.125, 0.16666666666667
76494, 1.9826086956522, 0.125, 0.11111111111111
76495, 1.9826086956522, 0.125, 0.055555555555556
76496, 2.0260869565217, 0.125, 0.44444444444444
76497, 2.0260869565217, 0.125, 0.38888888888889
76498, 2.0260869565217, 0.125, 0.33333333333333
76499, 2.0260869565217, 0.125, 0.27777777777778
76500, 2.0260869565217, 0.125, 0.22222222222222
76501, 2.0260869565217, 0.125, 0.16666666666667
76502, 2.0260869565217, 0.125, 0.11111111111111
76503, 2.0260869565217, 0.125, 0.055555555555556
76504, 2.0695652173913, 0.125, 0.44444444444444
76505, 2.0695652173913, 0.125, 0.38888888888889
76506, 2.0695652173913, 0.125, 0.33333333333333
76507, 2.0695652173913, 0.125, 0.27777777777778
76508, 2.0695652173913, 0.125, 0.22222222222222
76509, 2.0695652173913, 0.125, 0.16666666666667
76510, 2.0695652173913, 0.125, 0.11111111111111
76511, 2.0695652173913, 0.125, 0.055555555555556
76512, 2.1130434782609, 0.125, 0.44444444444444
76513, 2.1130434782609, 0.125, 0.38888888888889
76514, 2.1130434782609, 0.125, 0.33333333333333
76515, 2.1130434782609, 0.125, 0.27777777777778
76516, 2.1130434782609, 0.125, 0.22222222222222
76517, 2.1130434782609, 0.125, 0.16666666666667
76518, 2.1130434782609, 0.125, 0.11111111111111
76519, 2.1130434782609, 0.125, 0.055555555555556
76520, 2.1565217391304, 0.125, 0.44444444444444
76521, 2.1565217391304, 0.125, 0.38888888888889
76522, 2.1565217391304, 0.125, 0.33333333333333
76523, 2.1565217391304, 0.125, 0.27777777777778
76524, 2.1565217391304, 0.125, 0.22222222222222
76525, 2.1565217391304, 0.125, 0.16666666666667
76526, 2.1565217391304, 0.125, 0.11111111111111
76527, 2.1565217391304, 0.125, 0.055555555555556
76528, 1.2434782608696, 0.125, 0.47222222222222
76529, 1.2217391304348, 0.125, 0.44444444444444
76530, 1.2434782608696, 0.1375, 0.44444444444444
76531, 1.2434782608696, 0.125, 0.41666666666667
76532, 1.2217391304348, 0.125, 0.38888888888889
76533, 1.2434782608696, 0.1375, 0.38888888888889
76534, 1.2434782608696, 0.125, 0.36111111111111
76535, 1.2217391304348, 0.125, 0.33333333333333
76536, 1.2434782608696, 0.1375, 0.33333333333333
76537, 1.2434782608696, 0.125, 0.30555555555556
76538, 1.2217391304348, 0.125, 0.27777777777778
76539, 1.2434782608696, 0.1375, 0.27777777777778
76540, 1.2434782608696, 0.125, 0.25
76541, 1.2217391304348, 0.125, 0.22222222222222
76542, 1.2434782608696, 0.1375, 0.22222222222222
76543, 1.2434782608696, 0.125, 0.19444444444444
76544, 1.2217391304348, 0.125, 0.16666666666667
76545, 1.2434782608696, 0.1375, 0.16666666666667
76546, 1.2434782608696, 0.125, 0.13888888888889
76547, 1.2217391304348, 0.125, 0.11111111111111
76548, 1.2434782608696, 0.1375, 0.11111111111111
76549, 1.2434782608696, 0.125, 0.083333333333333
76550, 1.2217391304348, 0.125, 0.055555555555556
76551, 1.2434782608696, 0.1375, 0.055555555555556
76552, 1.2434782608696, 0.125, 0.027777777777778
76553, 1.2869565217391, 0.125, 0.47222222222222
76554, 1.2652173913043, 0.125, 0.44444444444444
76555, 1.2869565217391, 0.1375, 0.44444444444444
76556, 1.2869565217391, 0.125, 0.41666666666667
76557, 1.2652173913043, 0.125, 0.38888888888889
76558, 1.2869565217391, 0.1375, 0.38888888888889
76559, 1.2869565217391, 0.125, 0.36111111111111
76560, 1.2652173913043, 0.125, 0.33333333333333
76561, 1.2869565217391, 0.1375, 0.33333333333333
76562, 1.2869565217391, 0.125, 0.30555555555556
76563, 1.2652173913043, 0.125, 0.27777777777778
76564, 1.2869565217391, 0.1375, 0.27777777777778
76565, 1.2869565217391, 0.125, 0.25
76566, 1.2652173913043, 0.125, 0.22222222222222
76567, 1.2869565217391, 0.1375, 0.22222222222222
76568, 1.2869565217391, 0.125, 0.19444444444444
76569, 1.2652173913043, 0.125, 0.16666666666667
76570, 1.2869565217391, 0.1375, 0.16666666666667
76571, 1.2869565217391, 0.125, 0.13888888888889
76572, 1.2652173913043, 0.125, 0.11111111111111
76573, 1.2869565217391, 0.1375, 0.11111111111111
76574, 1.2869565217391, 0.125, 0.083333333333333
76575, 1.2652173913043, 0.125, 0.055555555555556
76576, 1.2869565217391, 0.1375, 0.055555555555556
76577, 1.2869565217391, 0.125, 0.027777777777778
76578, 1.3304347826087, 0.125, 0.47222222222222
76579, 1.3086956521739, 0.125, 0.44444444444444
76580, 1.3304347826087, 0.1375, 0.44444444444444
76581, 1.3304347826087, 0.125, 0.41666666666667
76582, 1.3086956521739, 0.125, 0.38888888888889
76583, 1.3304347826087, 0.1375, 0.38888888888889
76584, 1.3304347826087, 0.125, 0.36111111111111
76585, 1.3086956521739, 0.125, 0.33333333333333
76586, 1.3304347826087, 0.1375, 0.33333333333333
76587, 1.3304347826087, 0.125, 0.30555555555556
76588, 1.3086956521739, 0.125, 0.27777777777778
76589, 1.3304347826087, 0.1375, 0.27777777777778
76590, 1.3304347826087, 0.125, 0.25
76591, 1.3086956521739, 0.125, 0.22222222222222
76592, 1.3304347826087, 0.1375, 0.22222222222222
76593, 1.3304347826087, 0.125, 0.19444444444444
76594, 1.3086956521739, 0.125, 0.16666666666667
76595, 1.3304347826087, 0.1375, 0.16666666666667
76596, 1.3304347826087, 0.125, 0.13888888888889
76597, 1.3086956521739, 0.125, 0.11111111111111
76598, 1.3304347826087, 0.1375, 0.11111111111111
76599, 1.3304347826087, 0.125, 0.083333333333333
76600, 1.3086956521739, 0.125, 0.055555555555556
76601, 1.3304347826087, 0.1375, 0.055555555555556
76602, 1.3304347826087, 0.125, 0.027777777777778
76603, 1.3739130434783, 0.125, 0.47222222222222
76604, 1.3521739130435, 0.125, 0.44444444444444
76605, 1.3739130434783, 0.1375, 0.44444444444444
76606, 1.3739130434783, 0.125, 0.41666666666667
76607, 1.3521739130435, 0.125, 0.38888888888889
76608, 1.3739130434783, 0.1375, 0.38888888888889
76609, 1.3739130434783, 0.125, 0.36111111111111
76610, 1.3521739130435, 0.125, 0.33333333333333
76611, 1.3739130434783, 0.1375, 0.33333333333333
76612, 1.3739130434783, 0.125, 0.30555555555556
76613, 1.3521739130435, 0.125, 0.27777777777778
76614, 1.3739130434783, 0.1375, 0.27777777777778
76615, 1.3739130434783, 0.125, 0.25
76616, 1.3521739130435, 0.125, 0.22222222222222
76617, 1.3739130434783, 0.1375, 0.22222222222222
76618, 1.3739130434783, 0.125, 0.19444444444444
76619, 1.3521739130435, 0.125, 0.16666666666667
76620, 1.3739130434783, 0.1375, 0.16666666666667
76621, 1.3739130434783, 0.125, 0.13888888888889
76622, 1.3521739130435, 0.125, 0.11111111111111
76623, 1.3739130434783, 0.1375, 0.11111111111111
76624, 1.3739130434783, 0.125, 0.083333333333333
76625, 1.3521739130435, 0.125, 0.055555555555556
76626, 1.3739130434783, 0.1375, 0.055555555555556
76627, 1.3739130434783, 0.125, 0.027777777777778
76628, 1.4173913043478, 0.125, 0.47222222222222
76629, 1.395652173913, 0.125, 0.44444444444444
76630, 1.4173913043478, 0.1375, 0.44444444444444
76631, 1.4173913043478, 0.125, 0.41666666666667
76632, 1.395652173913, 0.125, 0.38888888888889
76633, 1.4173913043478, 0.1375, 0.38888888888889
76634, 1.4173913043478, 0.125, 0.36111111111111
76635, 1.395652173913, 0.125, 0.33333333333333
76636, 1.4173913043478, 0.1375, 0.33333333333333
76637, 1.4173913043478, 0.125, 0.30555555555556
76638, 1.395652173913, 0.125, 0.27777777777778
76639, 1.4173913043478, 0.1375, 0.27777777777778
76640, 1.4173913043478, 0.125, 0.25
76641, 1.395652173913, 0.125, 0.22222222222222
76642, 1.4173913043478, 0.1375, 0.22222222222222
76643, 1.4173913043478, 0.125, 0.19444444444444
76644, 1.395652173913, 0.125, 0.16666666666667
76645, 1.4173913043478, 0.1375, 0.16666666666667
76646, 1.4173913043478, 0.125, 0.13888888888889
76647, 1.395652173913, 0.125, 0.11111111111111
76648, 1.4173913043478, 0.1375, 0.11111111111111
76649, 1.4173913043478, 0.125, 0.083333333333333
76650, 1.395652173913, 0.125, 0.055555555555556
76651, 1.4173913043478, 0.1375, 0.055555555555556
76652, 1.4173913043478, 0.125, 0.027777777777778
76653, 1.4608695652174, 0.125, 0.47222222222222
76654, 1.4391304347826, 0.125, 0.44444444444444
76655, 1.4608695652174, 0.1375, 0.44444444444444
76656, 1.4608695652174, 0.125, 0.41666666666667
76657, 1.4391304347826, 0.125, 0.38888888888889
76658, 1.4608695652174, 0.1375, 0.38888888888889
76659, 1.4608695652174, 0.125, 0.36111111111111
76660, 1.4391304347826, 0.125, 0.33333333333333
76661, 1.4608695652174, 0.1375, 0.33333333333333
76662, 1.4608695652174, 0.125, 0.30555555555556
76663, 1.4391304347826, 0.125, 0.27777777777778
76664, 1.4608695652174, 0.1375, 0.27777777777778
76665, 1.4608695652174, 0.125, 0.25
76666, 1.4391304347826, 0.125, 0.22222222222222
76667, 1.4608695652174, 0.1375, 0.22222222222222
76668, 1.4608695652174, 0.125, 0.19444444444444
76669, 1.4391304347826, 0.125, 0.16666666666667
76670, 1.4608695652174, 0.1375, 0.16666666666667
76671, 1.4608695652174, 0.125, 0.13888888888889
76672, 1.4391304347826, 0.125, 0.11111111111111
76673, 1.4608695652174, 0.1375, 0.11111111111111
76674, 1.4608695652174, 0.125, 0.083333333333333
76675, 1.4391304347826, 0.125, 0.055555555555556
76676, 1.4608695652174, 0.1375, 0.055555555555556
76677, 1.4608695652174, 0.125, 0.027777777777778
76678, 1.504347826087, 0.125, 0.47222222222222
76679, 1.4826086956522, 0.125, 0.44444444444444
76680, 1.504347826087, 0.1375, 0.44444444444444
76681, 1.504347826087, 0.125, 0.41666666666667
76682, 1.4826086956522, 0.125, 0.38888888888889
76683, 1.504347826087, 0.1375, 0.38888888888889
76684, 1.504347826087, 0.125, 0.36111111111111
76685, 1.4826086956522, 0.125, 0.33333333333333
76686, 1.504347826087, 0.1375, 0.33333333333333
76687, 1.504347826087, 0.125, 0.30555555555556
76688, 1.4826086956522, 0.125, 0.27777777777778
76689, 1.504347826087, 0.1375, 0.27777777777778
76690, 1.504347826087, 0.125, 0.25
76691, 1.4826086956522, 0.125, 0.22222222222222
76692, 1.504347826087, 0.1375, 0.22222222222222
76693, 1.504347826087, 0.125, 0.19444444444444
76694, 1.4826086956522, 0.125, 0.16666666666667
76695, 1.504347826087, 0.1375, 0.16666666666667
76696, 1.504347826087, 0.125, 0.13888888888889
76697, 1.4826086956522, 0.125, 0.11111111111111
76698, 1.504347826087, 0.1375, 0.11111111111111
76699, 1.504347826087, 0.125, 0.083333333333333
76700, 1.4826086956522, 0.125, 0.055555555555556
76701, 1.504347826087, 0.1375, 0.055555555555556
76702, 1.504347826087, 0.125, 0.027777777777778
76703, 1.5478260869565, 0.125, 0.47222222222222
76704, 1.5260869565217, 0.125, 0.44444444444444
76705, 1.5478260869565, 0.1375, 0.44444444444444
76706, 1.5478260869565, 0.125, 0.41666666666667
76707, 1.5260869565217, 0.125, 0.38888888888889
76708, 1.5478260869565, 0.1375, 0.38888888888889
76709, 1.5478260869565, 0.125, 0.36111111111111
76710, 1.5260869565217, 0.125, 0.33333333333333
76711, 1.5478260869565, 0.1375, 0.33333333333333
76712, 1.5478260869565, 0.125, 0.30555555555556
76713, 1.5260869565217, 0.125, 0.27777777777778
76714, 1.5478260869565, 0.1375, 0.27777777777778
76715, 1.5478260869565, 0.125, 0.25
76716, 1.5260869565217, 0.125, 0.22222222222222
76717, 1.5478260869565, 0.1375, 0.22222222222222
76718, 1.5478260869565, 0.125, 0.19444444444444
76719, 1.5260869565217, 0.125, 0.16666666666667
76720, 1.5478260869565, 0.1375, 0.16666666666667
76721, 1.5478260869565, 0.125, 0.13888888888889
76722, 1.5260869565217, 0.125, 0.11111111111111
76723, 1.5478260869565, 0.1375, 0.11111111111111
76724, 1.5478260869565, 0.125, 0.083333333333333
76725, 1.5260869565217, 0.125, 0.055555555555556
76726, 1.5478260869565, 0.1375, 0.055555555555556
76727, 1.5478260869565, 0.125, 0.027777777777778
76728, 1.5913043478261, 0.125, 0.47222222222222
76729, 1.5695652173913, 0.125, 0.44444444444444
76730, 1.5913043478261, 0.1375, 0.44444444444444
76731, 1.5913043478261, 0.125, 0.41666666666667
76732, 1.5695652173913, 0.125, 0.38888888888889
76733, 1.5913043478261, 0.1375, 0.38888888888889
76734, 1.5913043478261, 0.125, 0.36111111111111
76735, 1.5695652173913, 0.125, 0.33333333333333
76736, 1.5913043478261, 0.1375, 0.33333333333333
76737, 1.5913043478261, 0.125, 0.30555555555556
76738, 1.5695652173913, 0.125, 0.27777777777778
76739, 1.5913043478261, 0.1375, 0.27777777777778
76740, 1.5913043478261, 0.125, 0.25
76741, 1.5695652173913, 0.125, 0.22222222222222
76742, 1.5913043478261, 0.1375, 0.22222222222222
76743, 1.5913043478261, 0.125, 0.19444444444444
76744, 1.5695652173913, 0.125, 0.16666666666667
76745, 1.5913043478261, 0.1375, 0.16666666666667
76746, 1.5913043478261, 0.125, 0.13888888888889
76747, 1.5695652173913, 0.125, 0.11111111111111
76748, 1.5913043478261, 0.1375, 0.11111111111111
76749, 1.5913043478261, 0.125, 0.083333333333333
76750, 1.5695652173913, 0.125, 0.055555555555556
76751, 1.5913043478261, 0.1375, 0.055555555555556
76752, 1.5913043478261, 0.125, 0.027777777777778
76753, 1.6347826086957, 0.125, 0.47222222222222
76754, 1.6130434782609, 0.125, 0.44444444444444
76755, 1.6347826086957, 0.1375, 0.44444444444444
76756, 1.6347826086957, 0.125, 0.41666666666667
76757, 1.6130434782609, 0.125, 0.38888888888889
76758, 1.6347826086957, 0.1375, 0.38888888888889
76759, 1.6347826086957, 0.125, 0.36111111111111
76760, 1.6130434782609, 0.125, 0.33333333333333
76761, 1.6347826086957, 0.1375, 0.33333333333333
76762, 1.6347826086957, 0.125, 0.30555555555556
76763, 1.6130434782609, 0.125, 0.27777777777778
76764, 1.6347826086957, 0.1375, 0.27777777777778
76765, 1.6347826086957, 0.125, 0.25
76766, 1.6130434782609, 0.125, 0.22222222222222
76767, 1.6347826086957, 0.1375, 0.22222222222222
76768, 1.6347826086957, 0.125, 0.19444444444444
76769, 1.6130434782609, 0.125, 0.16666666666667
76770, 1.6347826086957, 0.1375, 0.16666666666667
76771, 1.6347826086957, 0.125, 0.13888888888889
76772, 1.6130434782609, 0.125, 0.11111111111111
76773, 1.6347826086957, 0.1375, 0.11111111111111
76774, 1.6347826086957, 0.125, 0.083333333333333
76775, 1.6130434782609, 0.125, 0.055555555555556
76776, 1.6347826086957, 0.1375, 0.055555555555556
76777, 1.6347826086957, 0.125, 0.027777777777778
76778, 1.6782608695652, 0.125, 0.47222222222222
76779, 1.6565217391304, 0.125, 0.44444444444444
76780, 1.6782608695652, 0.1375, 0.44444444444444
76781, 1.6782608695652, 0.125, 0.41666666666667
76782, 1.6565217391304, 0.125, 0.38888888888889
76783, 1.6782608695652, 0.1375, 0.38888888888889
76784, 1.6782608695652, 0.125, 0.36111111111111
76785, 1.6565217391304, 0.125, 0.33333333333333
76786, 1.6782608695652, 0.1375, 0.33333333333333
76787, 1.6782608695652, 0.125, 0.30555555555556
76788, 1.6565217391304, 0.125, 0.27777777777778
76789, 1.6782608695652, 0.1375, 0.27777777777778
76790, 1.6782608695652, 0.125, 0.25
76791, 1.6565217391304, 0.125, 0.22222222222222
76792, 1.6782608695652, 0.1375, 0.22222222222222
76793, 1.6782608695652, 0.125, 0.19444444444444
76794, 1.6565217391304, 0.125, 0.16666666666667
76795, 1.6782608695652, 0.1375, 0.16666666666667
76796, 1.6782608695652, 0.125, 0.13888888888889
76797, 1.6565217391304, 0.125, 0.11111111111111
76798, 1.6782608695652, 0.1375, 0.11111111111111
76799, 1.6782608695652, 0.125, 0.083333333333333
76800, 1.6565217391304, 0.125, 0.055555555555556
76801, 1.6782608695652, 0.1375, 0.055555555555556
76802, 1.6782608695652, 0.125, 0.027777777777778
76803, 1.7217391304348, 0.125, 0.47222222222222
76804, 1.7, 0.125, 0.44444444444444
76805, 1.7217391304348, 0.1375, 0.44444444444444
76806, 1.7217391304348, 0.125, 0.41666666666667
76807, 1.7, 0.125, 0.38888888888889
76808, 1.7217391304348, 0.1375, 0.38888888888889
76809, 1.7217391304348, 0.125, 0.36111111111111
76810, 1.7, 0.125, 0.33333333333333
76811, 1.7217391304348, 0.1375, 0.33333333333333
76812, 1.7217391304348, 0.125, 0.30555555555556
76813, 1.7, 0.125, 0.27777777777778
76814, 1.7217391304348, 0.1375, 0.27777777777778
76815, 1.7217391304348, 0.125, 0.25
76816, 1.7, 0.125, 0.22222222222222
76817, 1.7217391304348, 0.1375, 0.22222222222222
76818, 1.7217391304348, 0.125, 0.19444444444444
76819, 1.7, 0.125, 0.16666666666667
76820, 1.7217391304348, 0.1375, 0.16666666666667
76821, 1.7217391304348, 0.125, 0.13888888888889
76822, 1.7, 0.125, 0.11111111111111
76823, 1.7217391304348, 0.1375, 0.11111111111111
76824, 1.7217391304348, 0.125, 0.083333333333333
76825, 1.7, 0.125, 0.055555555555556
76826, 1.7217391304348, 0.1375, 0.055555555555556
76827, 1.7217391304348, 0.125, 0.027777777777778
76828, 1.7652173913043, 0.125, 0.47222222222222
76829, 1.7434782608696, 0.125, 0.44444444444444
76830, 1.7652173913043, 0.1375, 0.44444444444444
76831, 1.7652173913043, 0.125, 0.41666666666667
76832, 1.7434782608696, 0.125, 0.38888888888889
76833, 1.7652173913043, 0.1375, 0.38888888888889
76834, 1.7652173913043, 0.125, 0.36111111111111
76835, 1.7434782608696, 0.125, 0.33333333333333
76836, 1.7652173913043, 0.1375, 0.33333333333333
76837, 1.7652173913043, 0.125, 0.30555555555556
76838, 1.7434782608696, 0.125, 0.27777777777778
76839, 1.7652173913043, 0.1375, 0.27777777777778
76840, 1.7652173913043, 0.125, 0.25
76841, 1.7434782608696, 0.125, 0.22222222222222
76842, 1.7652173913043, 0.1375, 0.22222222222222
76843, 1.7652173913043, 0.125, 0.19444444444444
76844, 1.7434782608696, 0.125, 0.16666666666667
76845, 1.7652173913043, 0.1375, 0.16666666666667
76846, 1.7652173913043, 0.125, 0.13888888888889
76847, 1.7434782608696, 0.125, 0.11111111111111
76848, 1.7652173913043, 0.1375, 0.11111111111111
76849, 1.7652173913043, 0.125, 0.083333333333333
76850, 1.7434782608696, 0.125, 0.055555555555556
76851, 1.7652173913043, 0.1375, 0.055555555555556
76852, 1.7652173913043, 0.125, 0.027777777777778
76853, 1.8086956521739, 0.125, 0.47222222222222
76854, 1.7869565217391, 0.125, 0.44444444444444
76855, 1.8086956521739, 0.1375, 0.44444444444444
76856, 1.8086956521739, 0.125, 0.41666666666667
76857, 1.7869565217391, 0.125, 0.38888888888889
76858, 1.8086956521739, 0.1375, 0.38888888888889
76859, 1.8086956521739, 0.125, 0.36111111111111
76860, 1.7869565217391, 0.125, 0.33333333333333
76861, 1.8086956521739, 0.1375, 0.33333333333333
76862, 1.8086956521739, 0.125, 0.30555555555556
76863, 1.7869565217391, 0.125, 0.27777777777778
76864, 1.8086956521739, 0.1375, 0.27777777777778
76865, 1.8086956521739, 0.125, 0.25
76866, 1.7869565217391, 0.125, 0.22222222222222
76867, 1.8086956521739, 0.1375, 0.22222222222222
76868, 1.8086956521739, 0.125, 0.19444444444444
76869, 1.7869565217391, 0.125, 0.16666666666667
76870, 1.8086956521739, 0.1375, 0.16666666666667
76871, 1.8086956521739, 0.125, 0.13888888888889
76872, 1.7869565217391, 0.125, 0.11111111111111
76873, 1.8086956521739, 0.1375, 0.11111111111111
76874, 1.8086956521739, 0.125, 0.083333333333333
76875, 1.7869565217391, 0.125, 0.055555555555556
76876, 1.8086956521739, 0.1375, 0.055555555555556
76877, 1.8086956521739, 0.125, 0.027777777777778
76878, 1.8521739130435, 0.125, 0.47222222222222
76879, 1.8304347826087, 0.125, 0.44444444444444
76880, 1.8521739130435, 0.1375, 0.44444444444444
76881, 1.8521739130435, 0.125, 0.41666666666667
76882, 1.8304347826087, 0.125, 0.38888888888889
76883, 1.8521739130435, 0.1375, 0.38888888888889
76884, 1.8521739130435, 0.125, 0.36111111111111
76885, 1.8304347826087, 0.125, 0.33333333333333
76886, 1.8521739130435, 0.1375, 0.33333333333333
76887, 1.8521739130435, 0.125, 0.30555555555556
76888, 1.8304347826087, 0.125, 0.27777777777778
76889, 1.8521739130435, 0.1375, 0.27777777777778
76890, 1.8521739130435, 0.125, 0.25
76891, 1.8304347826087, 0.125, 0.22222222222222
76892, 1.8521739130435, 0.1375, 0.22222222222222
76893, 1.8521739130435, 0.125, 0.19444444444444
76894, 1.8304347826087, 0.125, 0.16666666666667
76895, 1.8521739130435, 0.1375, 0.16666666666667
76896, 1.8521739130435, 0.125, 0.13888888888889
76897, 1.8304347826087, 0.125, 0.11111111111111
76898, 1.8521739130435, 0.1375, 0.11111111111111
76899, 1.8521739130435, 0.125, 0.083333333333333
76900, 1.8304347826087, 0.125, 0.055555555555556
76901, 1.8521739130435, 0.1375, 0.055555555555556
76902, 1.8521739130435, 0.125, 0.027777777777778
76903, 1.895652173913, 0.125, 0.47222222222222
76904, 1.8739130434783, 0.125, 0.44444444444444
76905, 1.895652173913, 0.1375, 0.44444444444444
76906, 1.895652173913, 0.125, 0.41666666666667
76907, 1.8739130434783, 0.125, 0.38888888888889
76908, 1.895652173913, 0.1375, 0.38888888888889
76909, 1.895652173913, 0.125, 0.36111111111111
76910, 1.8739130434783, 0.125, 0.33333333333333
76911, 1.895652173913, 0.1375, 0.33333333333333
76912, 1.895652173913, 0.125, 0.30555555555556
76913, 1.8739130434783, 0.125, 0.27777777777778
76914, 1.895652173913, 0.1375, 0.27777777777778
76915, 1.895652173913, 0.125, 0.25
76916, 1.8739130434783, 0.125, 0.22222222222222
76917, 1.895652173913, 0.1375, 0.22222222222222
76918, 1.895652173913, 0.125, 0.19444444444444
76919, 1.8739130434783, 0.125, 0.16666666666667
76920, 1.895652173913, 0.1375, 0.16666666666667
76921, 1.895652173913, 0.125, 0.13888888888889
76922, 1.8739130434783, 0.125, 0.11111111111111
76923, 1.895652173913, 0.1375, 0.11111111111111
76924, 1.895652173913, 0.125, 0.083333333333333
76925, 1.8739130434783, 0.125, 0.055555555555556
76926, 1.895652173913, 0.1375, 0.055555555555556
76927, 1.895652173913, 0.125, 0.027777777777778
76928, 1.9391304347826, 0.125, 0.47222222222222
76929, 1.9173913043478, 0.125, 0.44444444444444
76930, 1.9391304347826, 0.1375, 0.44444444444444
76931, 1.9391304347826, 0.125, 0.41666666666667
76932, 1.9173913043478, 0.125, 0.38888888888889
76933, 1.9391304347826, 0.1375, 0.38888888888889
76934, 1.9391304347826, 0.125, 0.36111111111111
76935, 1.9173913043478, 0.125, 0.33333333333333
76936, 1.9391304347826, 0.1375, 0.33333333333333
76937, 1.9391304347826, 0.125, 0.30555555555556
76938, 1.9173913043478, 0.125, 0.27777777777778
76939, 1.9391304347826, 0.1375, 0.27777777777778
76940, 1.9391304347826, 0.125, 0.25
76941, 1.9173913043478, 0.125, 0.22222222222222
76942, 1.9391304347826, 0.1375, 0.22222222222222
76943, 1.9391304347826, 0.125, 0.19444444444444
76944, 1.9173913043478, 0.125, 0.16666666666667
76945, 1.9391304347826, 0.1375, 0.16666666666667
76946, 1.9391304347826, 0.125, 0.13888888888889
76947, 1.9173913043478, 0.125, 0.11111111111111
76948, 1.9391304347826, 0.1375, 0.11111111111111
76949, 1.9391304347826, 0.125, 0.083333333333333
76950, 1.9173913043478, 0.125, 0.055555555555556
76951, 1.9391304347826, 0.1375, 0.055555555555556
76952, 1.9391304347826, 0.125, 0.027777777777778
76953, 1.9826086956522, 0.125, 0.47222222222222
76954, 1.9608695652174, 0.125, 0.44444444444444
76955, 1.9826086956522, 0.1375, 0.44444444444444
76956, 1.9826086956522, 0.125, 0.41666666666667
76957, 1.9608695652174, 0.125, 0.38888888888889
76958, 1.9826086956522, 0.1375, 0.38888888888889
76959, 1.9826086956522, 0.125, 0.36111111111111
76960, 1.9608695652174, 0.125, 0.33333333333333
76961, 1.9826086956522, 0.1375, 0.33333333333333
76962, 1.9826086956522, 0.125, 0.30555555555556
76963, 1.9608695652174, 0.125, 0.27777777777778
76964, 1.9826086956522, 0.1375, 0.27777777777778
76965, 1.9826086956522, 0.125, 0.25
76966, 1.9608695652174, 0.125, 0.22222222222222
76967, 1.9826086956522, 0.1375, 0.22222222222222
76968, 1.9826086956522, 0.125, 0.19444444444444
76969, 1.9608695652174, 0.125, 0.16666666666667
76970, 1.9826086956522, 0.1375, 0.16666666666667
76971, 1.9826086956522, 0.125, 0.13888888888889
76972, 1.9608695652174, 0.125, 0.11111111111111
76973, 1.9826086956522, 0.1375, 0.11111111111111
76974, 1.9826086956522, 0.125, 0.083333333333333
76975, 1.9608695652174, 0.125, 0.055555555555556
76976, 1.9826086956522, 0.1375, 0.055555555555556
76977, 1.9826086956522, 0.125, 0.027777777777778
76978, 2.0260869565217, 0.125, 0.47222222222222
76979, 2.004347826087, 0.125, 0.44444444444444
76980, 2.0260869565217, 0.1375, 0.44444444444444
76981, 2.0260869565217, 0.125, 0.41666666666667
76982, 2.004347826087, 0.125, 0.38888888888889
76983, 2.0260869565217, 0.1375, 0.38888888888889
76984, 2.0260869565217, 0.125, 0.36111111111111
76985, 2.004347826087, 0.125, 0.33333333333333
76986, 2.0260869565217, 0.1375, 0.33333333333333
76987, 2.0260869565217, 0.125, 0.30555555555556
76988, 2.004347826087, 0.125, 0.27777777777778
76989, 2.0260869565217, 0.1375, 0.27777777777778
76990, 2.0260869565217, 0.125, 0.25
76991, 2.004347826087, 0.125, 0.22222222222222
76992, 2.0260869565217, 0.1375, 0.22222222222222
76993, 2.0260869565217, 0.125, 0.19444444444444
76994, 2.004347826087, 0.125, 0.16666666666667
76995, 2.0260869565217, 0.1375, 0.16666666666667
76996, 2.0260869565217, 0.125, 0.13888888888889
76997, 2.004347826087, 0.125, 0.11111111111111
76998, 2.0260869565217, 0.1375, 0.11111111111111
76999, 2.0260869565217, 0.125, 0.083333333333333
77000, 2.004347826087, 0.125, 0.055555555555556
77001, 2.0260869565217, 0.1375, 0.055555555555556
77002, 2.0260869565217, 0.125, 0.027777777777778
77003, 2.0695652173913, 0.125, 0.47222222222222
77004, 2.0478260869565, 0.125, 0.44444444444444
77005, 2.0695652173913, 0.1375, 0.44444444444444
77006, 2.0695652173913, 0.125, 0.41666666666667
77007, 2.0478260869565, 0.125, 0.38888888888889
77008, 2.0695652173913, 0.1375, 0.38888888888889
77009, 2.0695652173913, 0.125, 0.36111111111111
77010, 2.0478260869565, 0.125, 0.33333333333333
77011, 2.0695652173913, 0.1375, 0.33333333333333
77012, 2.0695652173913, 0.125, 0.30555555555556
77013, 2.0478260869565, 0.125, 0.27777777777778
77014, 2.0695652173913, 0.1375, 0.27777777777778
77015, 2.0695652173913, 0.125, 0.25
77016, 2.0478260869565, 0.125, 0.22222222222222
77017, 2.0695652173913, 0.1375, 0.22222222222222
77018, 2.0695652173913, 0.125, 0.19444444444444
77019, 2.0478260869565, 0.125, 0.16666666666667
77020, 2.0695652173913, 0.1375, 0.16666666666667
77021, 2.0695652173913, 0.125, 0.13888888888889
77022, 2.0478260869565, 0.125, 0.11111111111111
77023, 2.0695652173913, 0.1375, 0.11111111111111
77024, 2.0695652173913, 0.125, 0.083333333333333
77025, 2.0478260869565, 0.125, 0.055555555555556
77026, 2.0695652173913, 0.1375, 0.055555555555556
77027, 2.0695652173913, 0.125, 0.027777777777778
77028, 2.1130434782609, 0.125, 0.47222222222222
77029, 2.0913043478261, 0.125, 0.44444444444444
77030, 2.1130434782609, 0.1375, 0.44444444444444
77031, 2.1130434782609, 0.125, 0.41666666666667
77032, 2.0913043478261, 0.125, 0.38888888888889
77033, 2.1130434782609, 0.1375, 0.38888888888889
77034, 2.1130434782609, 0.125, 0.36111111111111
77035, 2.0913043478261, 0.125, 0.33333333333333
77036, 2.1130434782609, 0.1375, 0.33333333333333
77037, 2.1130434782609, 0.125, 0.30555555555556
77038, 2.0913043478261, 0.125, 0.27777777777778
77039, 2.1130434782609, 0.1375, 0.27777777777778
77040, 2.1130434782609, 0.125, 0.25
77041, 2.0913043478261, 0.125, 0.22222222222222
77042, 2.1130434782609, 0.1375, 0.22222222222222
77043, 2.1130434782609, 0.125, 0.19444444444444
77044, 2.0913043478261, 0.125, 0.16666666666667
77045, 2.1130434782609, 0.1375, 0.16666666666667
77046, 2.1130434782609, 0.125, 0.13888888888889
77047, 2.0913043478261, 0.125, 0.11111111111111
77048, 2.1130434782609, 0.1375, 0.11111111111111
77049, 2.1130434782609, 0.125, 0.083333333333333
77050, 2.0913043478261, 0.125, 0.055555555555556
77051, 2.1130434782609, 0.1375, 0.055555555555556
77052, 2.1130434782609, 0.125, 0.027777777777778
77053, 2.1565217391304, 0.125, 0.47222222222222
77054, 2.1347826086957, 0.125, 0.44444444444444
77055, 2.1565217391304, 0.1375, 0.44444444444444
77056, 2.1565217391304, 0.125, 0.41666666666667
77057, 2.1347826086957, 0.125, 0.38888888888889
77058, 2.1565217391304, 0.1375, 0.38888888888889
77059, 2.1565217391304, 0.125, 0.36111111111111
77060, 2.1347826086957, 0.125, 0.33333333333333
77061, 2.1565217391304, 0.1375, 0.33333333333333
77062, 2.1565217391304, 0.125, 0.30555555555556
77063, 2.1347826086957, 0.125, 0.27777777777778
77064, 2.1565217391304, 0.1375, 0.27777777777778
77065, 2.1565217391304, 0.125, 0.25
77066, 2.1347826086957, 0.125, 0.22222222222222
77067, 2.1565217391304, 0.1375, 0.22222222222222
77068, 2.1565217391304, 0.125, 0.19444444444444
77069, 2.1347826086957, 0.125, 0.16666666666667
77070, 2.1565217391304, 0.1375, 0.16666666666667
77071, 2.1565217391304, 0.125, 0.13888888888889
77072, 2.1347826086957, 0.125, 0.11111111111111
77073, 2.1565217391304, 0.1375, 0.11111111111111
77074, 2.1565217391304, 0.125, 0.083333333333333
77075, 2.1347826086957, 0.125, 0.055555555555556
77076, 2.1565217391304, 0.1375, 0.055555555555556
77077, 2.1565217391304, 0.125, 0.027777777777778
77078, 2.1782608695652, 0.125, 0.44444444444444
77079, 2.1782608695652, 0.125, 0.38888888888889
77080, 2.1782608695652, 0.125, 0.33333333333333
77081, 2.1782608695652, 0.125, 0.27777777777778
77082, 2.1782608695652, 0.125, 0.22222222222222
77083, 2.1782608695652, 0.125, 0.16666666666667
77084, 2.1782608695652, 0.125, 0.11111111111111
77085, 2.1782608695652, 0.125, 0.055555555555556
77086, 1.2434782608696, 0.1125, 0.44444444444444
77087, 1.2434782608696, 0.1125, 0.38888888888889
77088, 1.2434782608696, 0.1125, 0.33333333333333
77089, 1.2434782608696, 0.1125, 0.27777777777778
77090, 1.2434782608696, 0.1125, 0.22222222222222
77091, 1.2434782608696, 0.1125, 0.16666666666667
77092, 1.2434782608696, 0.1125, 0.11111111111111
77093, 1.2434782608696, 0.1125, 0.055555555555556
77094, 1.2869565217391, 0.1125, 0.44444444444444
77095, 1.2869565217391, 0.1125, 0.38888888888889
77096, 1.2869565217391, 0.1125, 0.33333333333333
77097, 1.2869565217391, 0.1125, 0.27777777777778
77098, 1.2869565217391, 0.1125, 0.22222222222222
77099, 1.2869565217391, 0.1125, 0.16666666666667
77100, 1.2869565217391, 0.1125, 0.11111111111111
77101, 1.2869565217391, 0.1125, 0.055555555555556
77102, 1.3304347826087, 0.1125, 0.44444444444444
77103, 1.3304347826087, 0.1125, 0.38888888888889
77104, 1.3304347826087, 0.1125, 0.33333333333333
77105, 1.3304347826087, 0.1125, 0.27777777777778
77106, 1.3304347826087, 0.1125, 0.22222222222222
77107, 1.3304347826087, 0.1125, 0.16666666666667
77108, 1.3304347826087, 0.1125, 0.11111111111111
77109, 1.3304347826087, 0.1125, 0.055555555555556
77110, 1.3739130434783, 0.1125, 0.44444444444444
77111, 1.3739130434783, 0.1125, 0.38888888888889
77112, 1.3739130434783, 0.1125, 0.33333333333333
77113, 1.3739130434783, 0.1125, 0.27777777777778
77114, 1.3739130434783, 0.1125, 0.22222222222222
77115, 1.3739130434783, 0.1125, 0.16666666666667
77116, 1.3739130434783, 0.1125, 0.11111111111111
77117, 1.3739130434783, 0.1125, 0.055555555555556
77118, 1.4173913043478, 0.1125, 0.44444444444444
77119, 1.4173913043478, 0.1125, 0.38888888888889
77120, 1.4173913043478, 0.1125, 0.33333333333333
77121, 1.4173913043478, 0.1125, 0.27777777777778
77122, 1.4173913043478, 0.1125, 0.22222222222222
77123, 1.4173913043478, 0.1125, 0.16666666666667
77124, 1.4173913043478, 0.1125, 0.11111111111111
77125, 1.4173913043478, 0.1125, 0.055555555555556
77126, 1.4608695652174, 0.1125, 0.44444444444444
77127, 1.4608695652174, 0.1125, 0.38888888888889
77128, 1.4608695652174, 0.1125, 0.33333333333333
77129, 1.4608695652174, 0.1125, 0.27777777777778
77130, 1.4608695652174, 0.1125, 0.22222222222222
77131, 1.4608695652174, 0.1125, 0.16666666666667
77132, 1.4608695652174, 0.1125, 0.11111111111111
77133, 1.4608695652174, 0.1125, 0.055555555555556
77134, 1.504347826087, 0.1125, 0.44444444444444
77135, 1.504347826087, 0.1125, 0.38888888888889
77136, 1.504347826087, 0.1125, 0.33333333333333
77137, 1.504347826087, 0.1125, 0.27777777777778
77138, 1.504347826087, 0.1125, 0.22222222222222
77139, 1.504347826087, 0.1125, 0.16666666666667
77140, 1.504347826087, 0.1125, 0.11111111111111
77141, 1.504347826087, 0.1125, 0.055555555555556
77142, 1.5478260869565, 0.1125, 0.44444444444444
77143, 1.5478260869565, 0.1125, 0.38888888888889
77144, 1.5478260869565, 0.1125, 0.33333333333333
77145, 1.5478260869565, 0.1125, 0.27777777777778
77146, 1.5478260869565, 0.1125, 0.22222222222222
77147, 1.5478260869565, 0.1125, 0.16666666666667
77148, 1.5478260869565, 0.1125, 0.11111111111111
77149, 1.5478260869565, 0.1125, 0.055555555555556
77150, 1.5913043478261, 0.1125, 0.44444444444444
77151, 1.5913043478261, 0.1125, 0.38888888888889
77152, 1.5913043478261, 0.1125, 0.33333333333333
77153, 1.5913043478261, 0.1125, 0.27777777777778
77154, 1.5913043478261, 0.1125, 0.22222222222222
77155, 1.5913043478261, 0.1125, 0.16666666666667
77156, 1.5913043478261, 0.1125, 0.11111111111111
77157, 1.5913043478261, 0.1125, 0.055555555555556
77158, 1.6347826086957, 0.1125, 0.44444444444444
77159, 1.6347826086957, 0.1125, 0.38888888888889
77160, 1.6347826086957, 0.1125, 0.33333333333333
77161, 1.6347826086957, 0.1125, 0.27777777777778
77162, 1.6347826086957, 0.1125, 0.22222222222222
77163, 1.6347826086957, 0.1125, 0.16666666666667
77164, 1.6347826086957, 0.1125, 0.11111111111111
77165, 1.6347826086957, 0.1125, 0.055555555555556
77166, 1.6782608695652, 0.1125, 0.44444444444444
77167, 1.6782608695652, 0.1125, 0.38888888888889
77168, 1.6782608695652, 0.1125, 0.33333333333333
77169, 1.6782608695652, 0.1125, 0.27777777777778
77170, 1.6782608695652, 0.1125, 0.22222222222222
77171, 1.6782608695652, 0.1125, 0.16666666666667
77172, 1.6782608695652, 0.1125, 0.11111111111111
77173, 1.6782608695652, 0.1125, 0.055555555555556
77174, 1.7217391304348, 0.1125, 0.44444444444444
77175, 1.7217391304348, 0.1125, 0.38888888888889
77176, 1.7217391304348, 0.1125, 0.33333333333333
77177, 1.7217391304348, 0.1125, 0.27777777777778
77178, 1.7217391304348, 0.1125, 0.22222222222222
77179, 1.7217391304348, 0.1125, 0.16666666666667
77180, 1.7217391304348, 0.1125, 0.11111111111111
77181, 1.7217391304348, 0.1125, 0.055555555555556
77182, 1.7652173913043, 0.1125, 0.44444444444444
77183, 1.7652173913043, 0.1125, 0.38888888888889
77184, 1.7652173913043, 0.1125, 0.33333333333333
77185, 1.7652173913043, 0.1125, 0.27777777777778
77186, 1.7652173913043, 0.1125, 0.22222222222222
77187, 1.7652173913043, 0.1125, 0.16666666666667
77188, 1.7652173913043, 0.1125, 0.11111111111111
77189, 1.7652173913043, 0.1125, 0.055555555555556
77190, 1.8086956521739, 0.1125, 0.44444444444444
77191, 1.8086956521739, 0.1125, 0.38888888888889
77192, 1.8086956521739, 0.1125, 0.33333333333333
77193, 1.8086956521739, 0.1125, 0.27777777777778
77194, 1.8086956521739, 0.1125, 0.22222222222222
77195, 1.8086956521739, 0.1125, 0.16666666666667
77196, 1.8086956521739, 0.1125, 0.11111111111111
77197, 1.8086956521739, 0.1125, 0.055555555555556
77198, 1.8521739130435, 0.1125, 0.44444444444444
77199, 1.8521739130435, 0.1125, 0.38888888888889
77200, 1.8521739130435, 0.1125, 0.33333333333333
77201, 1.8521739130435, 0.1125, 0.27777777777778
77202, 1.8521739130435, 0.1125, 0.22222222222222
77203, 1.8521739130435, 0.1125, 0.16666666666667
77204, 1.8521739130435, 0.1125, 0.11111111111111
77205, 1.8521739130435, 0.1125, 0.055555555555556
77206, 1.895652173913, 0.1125, 0.44444444444444
77207, 1.895652173913, 0.1125, 0.38888888888889
77208, 1.895652173913, 0.1125, 0.33333333333333
77209, 1.895652173913, 0.1125, 0.27777777777778
77210, 1.895652173913, 0.1125, 0.22222222222222
77211, 1.895652173913, 0.1125, 0.16666666666667
77212, 1.895652173913, 0.1125, 0.11111111111111
77213, 1.895652173913, 0.1125, 0.055555555555556
77214, 1.9391304347826, 0.1125, 0.44444444444444
77215, 1.9391304347826, 0.1125, 0.38888888888889
77216, 1.9391304347826, 0.1125, 0.33333333333333
77217, 1.9391304347826, 0.1125, 0.27777777777778
77218, 1.9391304347826, 0.1125, 0.22222222222222
77219, 1.9391304347826, 0.1125, 0.16666666666667
77220, 1.9391304347826, 0.1125, 0.11111111111111
77221, 1.9391304347826, 0.1125, 0.055555555555556
77222, 1.9826086956522, 0.1125, 0.44444444444444
77223, 1.9826086956522, 0.1125, 0.38888888888889
77224, 1.9826086956522, 0.1125, 0.33333333333333
77225, 1.9826086956522, 0.1125, 0.27777777777778
77226, 1.9826086956522, 0.1125, 0.22222222222222
77227, 1.9826086956522, 0.1125, 0.16666666666667
77228, 1.9826086956522, 0.1125, 0.11111111111111
77229, 1.9826086956522, 0.1125, 0.055555555555556
77230, 2.0260869565217, 0.1125, 0.44444444444444
77231, 2.0260869565217, 0.1125, 0.38888888888889
77232, 2.0260869565217, 0.1125, 0.33333333333333
77233, 2.0260869565217, 0.1125, 0.27777777777778
77234, 2.0260869565217, 0.1125, 0.22222222222222
77235, 2.0260869565217, 0.1125, 0.16666666666667
77236, 2.0260869565217, 0.1125, 0.11111111111111
77237, 2.0260869565217, 0.1125, 0.055555555555556
77238, 2.0695652173913, 0.1125, 0.44444444444444
77239, 2.0695652173913, 0.1125, 0.38888888888889
77240, 2.0695652173913, 0.1125, 0.33333333333333
77241, 2.0695652173913, 0.1125, 0.27777777777778
77242, 2.0695652173913, 0.1125, 0.22222222222222
77243, 2.0695652173913, 0.1125, 0.16666666666667
77244, 2.0695652173913, 0.1125, 0.11111111111111
77245, 2.0695652173913, 0.1125, 0.055555555555556
77246, 2.1130434782609, 0.1125, 0.44444444444444
77247, 2.1130434782609, 0.1125, 0.38888888888889
77248, 2.1130434782609, 0.1125, 0.33333333333333
77249, 2.1130434782609, 0.1125, 0.27777777777778
77250, 2.1130434782609, 0.1125, 0.22222222222222
77251, 2.1130434782609, 0.1125, 0.16666666666667
77252, 2.1130434782609, 0.1125, 0.11111111111111
77253, 2.1130434782609, 0.1125, 0.055555555555556
77254, 2.1565217391304, 0.1125, 0.44444444444444
77255, 2.1565217391304, 0.1125, 0.38888888888889
77256, 2.1565217391304, 0.1125, 0.33333333333333
77257, 2.1565217391304, 0.1125, 0.27777777777778
77258, 2.1565217391304, 0.1125, 0.22222222222222
77259, 2.1565217391304, 0.1125, 0.16666666666667
77260, 2.1565217391304, 0.1125, 0.11111111111111
77261, 2.1565217391304, 0.1125, 0.055555555555556
77262, 1.2434782608696, 0.016666666666667, 0.44444444444444
77263, 1.2434782608696, 0.016666666666667, 0.38888888888889
77264, 1.2434782608696, 0.016666666666667, 0.33333333333333
77265, 1.2434782608696, 0.016666666666667, 0.27777777777778
77266, 1.2434782608696, 0.016666666666667, 0.22222222222222
77267, 1.2434782608696, 0.016666666666667, 0.16666666666667
77268, 1.2434782608696, 0.016666666666667, 0.11111111111111
77269, 1.2434782608696, 0.016666666666667, 0.055555555555556
77270, 1.2869565217391, 0.016666666666667, 0.44444444444444
77271, 1.2869565217391, 0.016666666666667, 0.38888888888889
77272, 1.2869565217391, 0.016666666666667, 0.33333333333333
77273, 1.2869565217391, 0.016666666666667, 0.27777777777778
77274, 1.2869565217391, 0.016666666666667, 0.22222222222222
77275, 1.2869565217391, 0.016666666666667, 0.16666666666667
77276, 1.2869565217391, 0.016666666666667, 0.11111111111111
77277, 1.2869565217391, 0.016666666666667, 0.055555555555556
77278, 1.3304347826087, 0.016666666666667, 0.44444444444444
77279, 1.3304347826087, 0.016666666666667, 0.38888888888889
77280, 1.3304347826087, 0.016666666666667, 0.33333333333333
77281, 1.3304347826087, 0.016666666666667, 0.27777777777778
77282, 1.3304347826087, 0.016666666666667, 0.22222222222222
77283, 1.3304347826087, 0.016666666666667, 0.16666666666667
77284, 1.3304347826087, 0.016666666666667, 0.11111111111111
77285, 1.3304347826087, 0.016666666666667, 0.055555555555556
77286, 1.3739130434783, 0.016666666666667, 0.44444444444444
77287, 1.3739130434783, 0.016666666666667, 0.38888888888889
77288, 1.3739130434783, 0.016666666666667, 0.33333333333333
77289, 1.3739130434783, 0.016666666666667, 0.27777777777778
77290, 1.3739130434783, 0.016666666666667, 0.22222222222222
77291, 1.3739130434783, 0.016666666666667, 0.16666666666667
77292, 1.3739130434783, 0.016666666666667, 0.11111111111111
77293, 1.3739130434783, 0.016666666666667, 0.055555555555556
77294, 1.4173913043478, 0.016666666666667, 0.44444444444444
77295, 1.4173913043478, 0.016666666666667, 0.38888888888889
77296, 1.4173913043478, 0.016666666666667, 0.33333333333333
77297, 1.4173913043478, 0.016666666666667, 0.27777777777778
77298, 1.4173913043478, 0.016666666666667, 0.22222222222222
77299, 1.4173913043478, 0.016666666666667, 0.16666666666667
77300, 1.4173913043478, 0.016666666666667, 0.11111111111111
77301, 1.4173913043478, 0.016666666666667, 0.055555555555556
77302, 1.4608695652174, 0.016666666666667, 0.44444444444444
77303, 1.4608695652174, 0.016666666666667, 0.38888888888889
77304, 1.4608695652174, 0.016666666666667, 0.33333333333333
77305, 1.4608695652174, 0.016666666666667, 0.27777777777778
77306, 1.4608695652174, 0.016666666666667, 0.22222222222222
77307, 1.4608695652174, 0.016666666666667, 0.16666666666667
77308, 1.4608695652174, 0.016666666666667, 0.11111111111111
77309, 1.4608695652174, 0.016666666666667, 0.055555555555556
77310, 1.504347826087, 0.016666666666667, 0.44444444444444
77311, 1.504347826087, 0.016666666666667, 0.38888888888889
77312, 1.504347826087, 0.016666666666667, 0.33333333333333
77313, 1.504347826087, 0.016666666666667, 0.27777777777778
77314, 1.504347826087, 0.016666666666667, 0.22222222222222
77315, 1.504347826087, 0.016666666666667, 0.16666666666667
77316, 1.504347826087, 0.016666666666667, 0.11111111111111
77317, 1.504347826087, 0.016666666666667, 0.055555555555556
77318, 1.5478260869565, 0.016666666666667, 0.44444444444444
77319, 1.5478260869565, 0.016666666666667, 0.38888888888889
77320, 1.5478260869565, 0.016666666666667, 0.33333333333333
77321, 1.5478260869565, 0.016666666666667, 0.27777777777778
77322, 1.5478260869565, 0.016666666666667, 0.22222222222222
77323, 1.5478260869565, 0.016666666666667, 0.16666666666667
77324, 1.5478260869565, 0.016666666666667, 0.11111111111111
77325, 1.5478260869565, 0.016666666666667, 0.055555555555556
77326, 1.5913043478261, 0.016666666666667, 0.44444444444444
77327, 1.5913043478261, 0.016666666666667, 0.38888888888889
77328, 1.5913043478261, 0.016666666666667, 0.33333333333333
77329, 1.5913043478261, 0.016666666666667, 0.27777777777778
77330, 1.5913043478261, 0.016666666666667, 0.22222222222222
77331, 1.5913043478261, 0.016666666666667, 0.16666666666667
77332, 1.5913043478261, 0.016666666666667, 0.11111111111111
77333, 1.5913043478261, 0.016666666666667, 0.055555555555556
77334, 1.6347826086957, 0.016666666666667, 0.44444444444444
77335, 1.6347826086957, 0.016666666666667, 0.38888888888889
77336, 1.6347826086957, 0.016666666666667, 0.33333333333333
77337, 1.6347826086957, 0.016666666666667, 0.27777777777778
77338, 1.6347826086957, 0.016666666666667, 0.22222222222222
77339, 1.6347826086957, 0.016666666666667, 0.16666666666667
77340, 1.6347826086957, 0.016666666666667, 0.11111111111111
77341, 1.6347826086957, 0.016666666666667, 0.055555555555556
77342, 1.6782608695652, 0.016666666666667, 0.44444444444444
77343, 1.6782608695652, 0.016666666666667, 0.38888888888889
77344, 1.6782608695652, 0.016666666666667, 0.33333333333333
77345, 1.6782608695652, 0.016666666666667, 0.27777777777778
77346, 1.6782608695652, 0.016666666666667, 0.22222222222222
77347, 1.6782608695652, 0.016666666666667, 0.16666666666667
77348, 1.6782608695652, 0.016666666666667, 0.11111111111111
77349, 1.6782608695652, 0.016666666666667, 0.055555555555556
77350, 1.7217391304348, 0.016666666666667, 0.44444444444444
77351, 1.7217391304348, 0.016666666666667, 0.38888888888889
77352, 1.7217391304348, 0.016666666666667, 0.33333333333333
77353, 1.7217391304348, 0.016666666666667, 0.27777777777778
77354, 1.7217391304348, 0.016666666666667, 0.22222222222222
77355, 1.7217391304348, 0.016666666666667, 0.16666666666667
77356, 1.7217391304348, 0.016666666666667, 0.11111111111111
77357, 1.7217391304348, 0.016666666666667, 0.055555555555556
77358, 1.7652173913043, 0.016666666666667, 0.44444444444444
77359, 1.7652173913043, 0.016666666666667, 0.38888888888889
77360, 1.7652173913043, 0.016666666666667, 0.33333333333333
77361, 1.7652173913043, 0.016666666666667, 0.27777777777778
77362, 1.7652173913043, 0.016666666666667, 0.22222222222222
77363, 1.7652173913043, 0.016666666666667, 0.16666666666667
77364, 1.7652173913043, 0.016666666666667, 0.11111111111111
77365, 1.7652173913043, 0.016666666666667, 0.055555555555556
77366, 1.8086956521739, 0.016666666666667, 0.44444444444444
77367, 1.8086956521739, 0.016666666666667, 0.38888888888889
77368, 1.8086956521739, 0.016666666666667, 0.33333333333333
77369, 1.8086956521739, 0.016666666666667, 0.27777777777778
77370, 1.8086956521739, 0.016666666666667, 0.22222222222222
77371, 1.8086956521739, 0.016666666666667, 0.16666666666667
77372, 1.8086956521739, 0.016666666666667, 0.11111111111111
77373, 1.8086956521739, 0.016666666666667, 0.055555555555556
77374, 1.8521739130435, 0.016666666666667, 0.44444444444444
77375, 1.8521739130435, 0.016666666666667, 0.38888888888889
77376, 1.8521739130435, 0.016666666666667, 0.33333333333333
77377, 1.8521739130435, 0.016666666666667, 0.27777777777778
77378, 1.8521739130435, 0.016666666666667, 0.22222222222222
77379, 1.8521739130435, 0.016666666666667, 0.16666666666667
77380, 1.8521739130435, 0.016666666666667, 0.11111111111111
77381, 1.8521739130435, 0.016666666666667, 0.055555555555556
77382, 1.895652173913, 0.016666666666667, 0.44444444444444
77383, 1.895652173913, 0.016666666666667, 0.38888888888889
77384, 1.895652173913, 0.016666666666667, 0.33333333333333
77385, 1.895652173913, 0.016666666666667, 0.27777777777778
77386, 1.895652173913, 0.016666666666667, 0.22222222222222
77387, 1.895652173913, 0.016666666666667, 0.16666666666667
77388, 1.895652173913, 0.016666666666667, 0.11111111111111
77389, 1.895652173913, 0.016666666666667, 0.055555555555556
77390, 1.9391304347826, 0.016666666666667, 0.44444444444444
77391, 1.9391304347826, 0.016666666666667, 0.38888888888889
77392, 1.9391304347826, 0.016666666666667, 0.33333333333333
77393, 1.9391304347826, 0.016666666666667, 0.27777777777778
77394, 1.9391304347826, 0.016666666666667, 0.22222222222222
77395, 1.9391304347826, 0.016666666666667, 0.16666666666667
77396, 1.9391304347826, 0.016666666666667, 0.11111111111111
77397, 1.9391304347826, 0.016666666666667, 0.055555555555556
77398, 1.9826086956522, 0.016666666666667, 0.44444444444444
77399, 1.9826086956522, 0.016666666666667, 0.38888888888889
77400, 1.9826086956522, 0.016666666666667, 0.33333333333333
77401, 1.9826086956522, 0.016666666666667, 0.27777777777778
77402, 1.9826086956522, 0.016666666666667, 0.22222222222222
77403, 1.9826086956522, 0.016666666666667, 0.16666666666667
77404, 1.9826086956522, 0.016666666666667, 0.11111111111111
77405, 1.9826086956522, 0.016666666666667, 0.055555555555556
77406, 2.0260869565217, 0.016666666666667, 0.44444444444444
77407, 2.0260869565217, 0.016666666666667, 0.38888888888889
77408, 2.0260869565217, 0.016666666666667, 0.33333333333333
77409, 2.0260869565217, 0.016666666666667, 0.27777777777778
77410, 2.0260869565217, 0.016666666666667, 0.22222222222222
77411, 2.0260869565217, 0.016666666666667, 0.16666666666667
77412, 2.0260869565217, 0.016666666666667, 0.11111111111111
77413, 2.0260869565217, 0.016666666666667, 0.055555555555556
77414, 2.0695652173913, 0.016666666666667, 0.44444444444444
77415, 2.0695652173913, 0.016666666666667, 0.38888888888889
77416, 2.0695652173913, 0.016666666666667, 0.33333333333333
77417, 2.0695652173913, 0.016666666666667, 0.27777777777778
77418, 2.0695652173913, 0.016666666666667, 0.22222222222222
77419, 2.0695652173913, 0.016666666666667, 0.16666666666667
77420, 2.0695652173913, 0.016666666666667, 0.11111111111111
77421, 2.0695652173913, 0.016666666666667, 0.055555555555556
77422, 2.1130434782609, 0.016666666666667, 0.44444444444444
77423, 2.1130434782609, 0.016666666666667, 0.38888888888889
77424, 2.1130434782609, 0.016666666666667, 0.33333333333333
77425, 2.1130434782609, 0.016666666666667, 0.27777777777778
77426, 2.1130434782609, 0.016666666666667, 0.22222222222222
77427, 2.1130434782609, 0.016666666666667, 0.16666666666667
77428, 2.1130434782609, 0.016666666666667, 0.11111111111111
77429, 2.1130434782609, 0.016666666666667, 0.055555555555556
77430, 2.1565217391304, 0.016666666666667, 0.44444444444444
77431, 2.1565217391304, 0.016666666666667, 0.38888888888889
77432, 2.1565217391304, 0.016666666666667, 0.33333333333333
77433, 2.1565217391304, 0.016666666666667, 0.27777777777778
77434, 2.1565217391304, 0.016666666666667, 0.22222222222222
77435, 2.1565217391304, 0.016666666666667, 0.16666666666667
77436, 2.1565217391304, 0.016666666666667, 0.11111111111111
77437, 2.1565217391304, 0.016666666666667, 0.055555555555556
77438, 1.2434782608696, -0.016666666666667, 0.44444444444444
77439, 1.2434782608696, -0.016666666666667, 0.38888888888889
77440, 1.2434782608696, -0.016666666666667, 0.33333333333333
77441, 1.2434782608696, -0.016666666666667, 0.27777777777778
77442, 1.2434782608696, -0.016666666666667, 0.22222222222222
77443, 1.2434782608696, -0.016666666666667, 0.16666666666667
77444, 1.2434782608696, -0.016666666666667, 0.11111111111111
77445, 1.2434782608696, -0.016666666666667, 0.055555555555556
77446, 1.2869565217391, -0.016666666666667, 0.44444444444444
77447, 1.2869565217391, -0.016666666666667, 0.38888888888889
77448, 1.2869565217391, -0.016666666666667, 0.33333333333333
77449, 1.2869565217391, -0.016666666666667, 0.27777777777778
77450, 1.2869565217391, -0.016666666666667, 0.22222222222222
77451, 1.2869565217391, -0.016666666666667, 0.16666666666667
77452, 1.2869565217391, -0.016666666666667, 0.11111111111111
77453, 1.2869565217391, -0.016666666666667, 0.055555555555556
77454, 1.3304347826087, -0.016666666666667, 0.44444444444444
77455, 1.3304347826087, -0.016666666666667, 0.38888888888889
77456, 1.3304347826087, -0.016666666666667, 0.33333333333333
77457, 1.3304347826087, -0.016666666666667, 0.27777777777778
77458, 1.3304347826087, -0.016666666666667, 0.22222222222222
77459, 1.3304347826087, -0.016666666666667, 0.16666666666667
77460, 1.3304347826087, -0.016666666666667, 0.11111111111111
77461, 1.3304347826087, -0.016666666666667, 0.055555555555556
77462, 1.3739130434783, -0.016666666666667, 0.44444444444444
77463, 1.3739130434783, -0.016666666666667, 0.38888888888889
77464, 1.3739130434783, -0.016666666666667, 0.33333333333333
77465, 1.3739130434783, -0.016666666666667, 0.27777777777778
77466, 1.3739130434783, -0.016666666666667, 0.22222222222222
77467, 1.3739130434783, -0.016666666666667, 0.16666666666667
77468, 1.3739130434783, -0.016666666666667, 0.11111111111111
77469, 1.3739130434783, -0.016666666666667, 0.055555555555556
77470, 1.4173913043478, -0.016666666666667, 0.44444444444444
77471, 1.4173913043478, -0.016666666666667, 0.38888888888889
77472, 1.4173913043478, -0.016666666666667, 0.33333333333333
77473, 1.4173913043478, -0.016666666666667, 0.27777777777778
77474, 1.4173913043478, -0.016666666666667, 0.22222222222222
77475, 1.4173913043478, -0.016666666666667, 0.16666666666667
77476, 1.4173913043478, -0.016666666666667, 0.11111111111111
77477, 1.4173913043478, -0.016666666666667, 0.055555555555556
77478, 1.4608695652174, -0.016666666666667, 0.44444444444444
77479, 1.4608695652174, -0.016666666666667, 0.38888888888889
77480, 1.4608695652174, -0.016666666666667, 0.33333333333333
77481, 1.4608695652174, -0.016666666666667, 0.27777777777778
77482, 1.4608695652174, -0.016666666666667, 0.22222222222222
77483, 1.4608695652174, -0.016666666666667, 0.16666666666667
77484, 1.4608695652174, -0.016666666666667, 0.11111111111111
77485, 1.4608695652174, -0.016666666666667, 0.055555555555556
77486, 1.504347826087, -0.016666666666667, 0.44444444444444
77487, 1.504347826087, -0.016666666666667, 0.38888888888889
77488, 1.504347826087, -0.016666666666667, 0.33333333333333
77489, 1.504347826087, -0.016666666666667, 0.27777777777778
77490, 1.504347826087, -0.016666666666667, 0.22222222222222
77491, 1.504347826087, -0.016666666666667, 0.16666666666667
77492, 1.504347826087, -0.016666666666667, 0.11111111111111
77493, 1.504347826087, -0.016666666666667, 0.055555555555556
77494, 1.5478260869565, -0.016666666666667, 0.44444444444444
77495, 1.5478260869565, -0.016666666666667, 0.38888888888889
77496, 1.5478260869565, -0.016666666666667, 0.33333333333333
77497, 1.5478260869565, -0.016666666666667, 0.27777777777778
77498, 1.5478260869565, -0.016666666666667, 0.22222222222222
77499, 1.5478260869565, -0.016666666666667, 0.16666666666667
77500, 1.5478260869565, -0.016666666666667, 0.11111111111111
77501, 1.5478260869565, -0.016666666666667, 0.055555555555556
77502, 1.5913043478261, -0.016666666666667, 0.44444444444444
77503, 1.5913043478261, -0.016666666666667, 0.38888888888889
77504, 1.5913043478261, -0.016666666666667, 0.33333333333333
77505, 1.5913043478261, -0.016666666666667, 0.27777777777778
77506, 1.5913043478261, -0.016666666666667, 0.22222222222222
77507, 1.5913043478261, -0.016666666666667, 0.16666666666667
77508, 1.5913043478261, -0.016666666666667, 0.11111111111111
77509, 1.5913043478261, -0.016666666666667, 0.055555555555556
77510, 1.6347826086957, -0.016666666666667, 0.44444444444444
77511, 1.6347826086957, -0.016666666666667, 0.38888888888889
77512, 1.6347826086957, -0.016666666666667, 0.33333333333333
77513, 1.6347826086957, -0.016666666666667, 0.27777777777778
77514, 1.6347826086957, -0.016666666666667, 0.22222222222222
77515, 1.6347826086957, -0.016666666666667, 0.16666666666667
77516, 1.6347826086957, -0.016666666666667, 0.11111111111111
77517, 1.6347826086957, -0.016666666666667, 0.055555555555556
77518, 1.6782608695652, -0.016666666666667, 0.44444444444444
77519, 1.6782608695652, -0.016666666666667, 0.38888888888889
77520, 1.6782608695652, -0.016666666666667, 0.33333333333333
77521, 1.6782608695652, -0.016666666666667, 0.27777777777778
77522, 1.6782608695652, -0.016666666666667, 0.22222222222222
77523, 1.6782608695652, -0.016666666666667, 0.16666666666667
77524, 1.6782608695652, -0.016666666666667, 0.11111111111111
77525, 1.6782608695652, -0.016666666666667, 0.055555555555556
77526, 1.7217391304348, -0.016666666666667, 0.44444444444444
77527, 1.7217391304348, -0.016666666666667, 0.38888888888889
77528, 1.7217391304348, -0.016666666666667, 0.33333333333333
77529, 1.7217391304348, -0.016666666666667, 0.27777777777778
77530, 1.7217391304348, -0.016666666666667, 0.22222222222222
77531, 1.7217391304348, -0.016666666666667, 0.16666666666667
77532, 1.7217391304348, -0.016666666666667, 0.11111111111111
77533, 1.7217391304348, -0.016666666666667, 0.055555555555556
77534, 1.7652173913043, -0.016666666666667, 0.44444444444444
77535, 1.7652173913043, -0.016666666666667, 0.38888888888889
77536, 1.7652173913043, -0.016666666666667, 0.33333333333333
77537, 1.7652173913043, -0.016666666666667, 0.27777777777778
77538, 1.7652173913043, -0.016666666666667, 0.22222222222222
77539, 1.7652173913043, -0.016666666666667, 0.16666666666667
77540, 1.7652173913043, -0.016666666666667, 0.11111111111111
77541, 1.7652173913043, -0.016666666666667, 0.055555555555556
77542, 1.8086956521739, -0.016666666666667, 0.44444444444444
77543, 1.8086956521739, -0.016666666666667, 0.38888888888889
77544, 1.8086956521739, -0.016666666666667, 0.33333333333333
77545, 1.8086956521739, -0.016666666666667, 0.27777777777778
77546, 1.8086956521739, -0.016666666666667, 0.22222222222222
