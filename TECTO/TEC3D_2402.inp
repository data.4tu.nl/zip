39374, 0.21739130434783, 0.46304347826087, 0.055555555555556
39375, 0.21739130434783, 0.46304347826087, 0.11111111111111
39376, 0.21739130434783, 0.46304347826087, 0.16666666666667
39377, 0.21739130434783, 0.46304347826087, 0.22222222222222
39378, 0.21739130434783, 0.46304347826087, 0.27777777777778
39379, 0.21739130434783, 0.46304347826087, 0.33333333333333
39380, 0.21739130434783, 0.46304347826087, 0.38888888888889
39381, 0.21739130434783, 0.46304347826087, 0.44444444444444
39382, 0.17391304347826, 0.46304347826087, 0.055555555555556
39383, 0.17391304347826, 0.46304347826087, 0.11111111111111
39384, 0.17391304347826, 0.46304347826087, 0.16666666666667
39385, 0.17391304347826, 0.46304347826087, 0.22222222222222
39386, 0.17391304347826, 0.46304347826087, 0.27777777777778
39387, 0.17391304347826, 0.46304347826087, 0.33333333333333
39388, 0.17391304347826, 0.46304347826087, 0.38888888888889
39389, 0.17391304347826, 0.46304347826087, 0.44444444444444
39390, 0.1304347826087, 0.46304347826087, 0.055555555555556
39391, 0.1304347826087, 0.46304347826087, 0.11111111111111
39392, 0.1304347826087, 0.46304347826087, 0.16666666666667
39393, 0.1304347826087, 0.46304347826087, 0.22222222222222
39394, 0.1304347826087, 0.46304347826087, 0.27777777777778
39395, 0.1304347826087, 0.46304347826087, 0.33333333333333
39396, 0.1304347826087, 0.46304347826087, 0.38888888888889
39397, 0.1304347826087, 0.46304347826087, 0.44444444444444
39398, 0.08695652173913, 0.46304347826087, 0.055555555555556
39399, 0.08695652173913, 0.46304347826087, 0.11111111111111
39400, 0.08695652173913, 0.46304347826087, 0.16666666666667
39401, 0.08695652173913, 0.46304347826087, 0.22222222222222
39402, 0.08695652173913, 0.46304347826087, 0.27777777777778
39403, 0.08695652173913, 0.46304347826087, 0.33333333333333
39404, 0.08695652173913, 0.46304347826087, 0.38888888888889
39405, 0.08695652173913, 0.46304347826087, 0.44444444444444
39406, 0.043478260869565, 0.46304347826087, 0.055555555555556
39407, 0.043478260869565, 0.46304347826087, 0.11111111111111
39408, 0.043478260869565, 0.46304347826087, 0.16666666666667
39409, 0.043478260869565, 0.46304347826087, 0.22222222222222
39410, 0.043478260869565, 0.46304347826087, 0.27777777777778
39411, 0.043478260869565, 0.46304347826087, 0.33333333333333
39412, 0.043478260869565, 0.46304347826087, 0.38888888888889
39413, 0.043478260869565, 0.46304347826087, 0.44444444444444
39414, 0.95652173913043, 0.51521739130435, 0.055555555555556
39415, 0.95652173913044, 0.51521739130435, 0.11111111111111
39416, 0.95652173913043, 0.51521739130435, 0.16666666666667
39417, 0.95652173913044, 0.51521739130435, 0.22222222222222
39418, 0.95652173913044, 0.51521739130435, 0.27777777777778
39419, 0.95652173913043, 0.51521739130435, 0.33333333333333
39420, 0.95652173913043, 0.51521739130435, 0.38888888888889
39421, 0.95652173913043, 0.51521739130435, 0.44444444444444
39422, 0.91304347826087, 0.51521739130435, 0.055555555555556
39423, 0.91304347826087, 0.51521739130435, 0.11111111111111
39424, 0.91304347826087, 0.51521739130435, 0.16666666666667
39425, 0.91304347826087, 0.51521739130435, 0.22222222222222
39426, 0.91304347826087, 0.51521739130435, 0.27777777777778
39427, 0.91304347826087, 0.51521739130435, 0.33333333333333
39428, 0.91304347826087, 0.51521739130435, 0.38888888888889
39429, 0.91304347826087, 0.51521739130435, 0.44444444444444
39430, 0.8695652173913, 0.51521739130435, 0.055555555555556
39431, 0.8695652173913, 0.51521739130435, 0.11111111111111
39432, 0.8695652173913, 0.51521739130435, 0.16666666666667
39433, 0.8695652173913, 0.51521739130435, 0.22222222222222
39434, 0.8695652173913, 0.51521739130435, 0.27777777777778
39435, 0.8695652173913, 0.51521739130435, 0.33333333333333
39436, 0.8695652173913, 0.51521739130435, 0.38888888888889
39437, 0.8695652173913, 0.51521739130435, 0.44444444444444
39438, 0.82608695652174, 0.51521739130435, 0.055555555555556
39439, 0.82608695652174, 0.51521739130435, 0.11111111111111
39440, 0.82608695652174, 0.51521739130435, 0.16666666666667
39441, 0.82608695652174, 0.51521739130435, 0.22222222222222
39442, 0.82608695652174, 0.51521739130435, 0.27777777777778
39443, 0.82608695652174, 0.51521739130435, 0.33333333333333
39444, 0.82608695652174, 0.51521739130435, 0.38888888888889
39445, 0.82608695652174, 0.51521739130435, 0.44444444444444
39446, 0.78260869565217, 0.51521739130435, 0.055555555555556
39447, 0.78260869565217, 0.51521739130435, 0.11111111111111
39448, 0.78260869565217, 0.51521739130435, 0.16666666666667
39449, 0.78260869565217, 0.51521739130435, 0.22222222222222
39450, 0.78260869565217, 0.51521739130435, 0.27777777777778
39451, 0.78260869565217, 0.51521739130435, 0.33333333333333
39452, 0.78260869565217, 0.51521739130435, 0.38888888888889
39453, 0.78260869565217, 0.51521739130435, 0.44444444444444
39454, 0.73913043478261, 0.51521739130435, 0.055555555555556
39455, 0.73913043478261, 0.51521739130435, 0.11111111111111
39456, 0.73913043478261, 0.51521739130435, 0.16666666666667
39457, 0.73913043478261, 0.51521739130435, 0.22222222222222
39458, 0.73913043478261, 0.51521739130435, 0.27777777777778
39459, 0.73913043478261, 0.51521739130435, 0.33333333333333
39460, 0.73913043478261, 0.51521739130435, 0.38888888888889
39461, 0.73913043478261, 0.51521739130435, 0.44444444444444
39462, 0.69565217391304, 0.51521739130435, 0.055555555555556
39463, 0.69565217391304, 0.51521739130435, 0.11111111111111
39464, 0.69565217391304, 0.51521739130435, 0.16666666666667
39465, 0.69565217391304, 0.51521739130435, 0.22222222222222
39466, 0.69565217391304, 0.51521739130435, 0.27777777777778
39467, 0.69565217391304, 0.51521739130435, 0.33333333333333
39468, 0.69565217391304, 0.51521739130435, 0.38888888888889
39469, 0.69565217391304, 0.51521739130435, 0.44444444444444
39470, 0.65217391304348, 0.51521739130435, 0.055555555555556
39471, 0.65217391304348, 0.51521739130435, 0.11111111111111
39472, 0.65217391304348, 0.51521739130435, 0.16666666666667
39473, 0.65217391304348, 0.51521739130435, 0.22222222222222
39474, 0.65217391304348, 0.51521739130435, 0.27777777777778
39475, 0.65217391304348, 0.51521739130435, 0.33333333333333
39476, 0.65217391304348, 0.51521739130435, 0.38888888888889
39477, 0.65217391304348, 0.51521739130435, 0.44444444444444
39478, 0.60869565217391, 0.51521739130435, 0.055555555555556
39479, 0.60869565217391, 0.51521739130435, 0.11111111111111
39480, 0.60869565217391, 0.51521739130435, 0.16666666666667
39481, 0.60869565217391, 0.51521739130435, 0.22222222222222
39482, 0.60869565217391, 0.51521739130435, 0.27777777777778
39483, 0.60869565217391, 0.51521739130435, 0.33333333333333
39484, 0.60869565217391, 0.51521739130435, 0.38888888888889
39485, 0.60869565217391, 0.51521739130435, 0.44444444444444
39486, 0.56521739130435, 0.51521739130435, 0.055555555555556
39487, 0.56521739130435, 0.51521739130435, 0.11111111111111
39488, 0.56521739130435, 0.51521739130435, 0.16666666666667
39489, 0.56521739130435, 0.51521739130435, 0.22222222222222
39490, 0.56521739130435, 0.51521739130435, 0.27777777777778
39491, 0.56521739130435, 0.51521739130435, 0.33333333333333
39492, 0.56521739130435, 0.51521739130435, 0.38888888888889
39493, 0.56521739130435, 0.51521739130435, 0.44444444444444
39494, 0.52173913043478, 0.51521739130435, 0.055555555555556
39495, 0.52173913043478, 0.51521739130435, 0.11111111111111
39496, 0.52173913043478, 0.51521739130435, 0.16666666666667
39497, 0.52173913043478, 0.51521739130435, 0.22222222222222
39498, 0.52173913043478, 0.51521739130435, 0.27777777777778
39499, 0.52173913043478, 0.51521739130435, 0.33333333333333
39500, 0.52173913043478, 0.51521739130435, 0.38888888888889
39501, 0.52173913043478, 0.51521739130435, 0.44444444444444
39502, 0.47826086956522, 0.51521739130435, 0.055555555555556
39503, 0.47826086956522, 0.51521739130435, 0.11111111111111
39504, 0.47826086956522, 0.51521739130435, 0.16666666666667
39505, 0.47826086956522, 0.51521739130435, 0.22222222222222
39506, 0.47826086956522, 0.51521739130435, 0.27777777777778
39507, 0.47826086956522, 0.51521739130435, 0.33333333333333
39508, 0.47826086956522, 0.51521739130435, 0.38888888888889
39509, 0.47826086956522, 0.51521739130435, 0.44444444444444
39510, 0.43478260869565, 0.51521739130435, 0.055555555555556
39511, 0.43478260869565, 0.51521739130435, 0.11111111111111
39512, 0.43478260869565, 0.51521739130435, 0.16666666666667
39513, 0.43478260869565, 0.51521739130435, 0.22222222222222
39514, 0.43478260869565, 0.51521739130435, 0.27777777777778
39515, 0.43478260869565, 0.51521739130435, 0.33333333333333
39516, 0.43478260869565, 0.51521739130435, 0.38888888888889
39517, 0.43478260869565, 0.51521739130435, 0.44444444444444
39518, 0.39130434782609, 0.51521739130435, 0.055555555555556
39519, 0.39130434782609, 0.51521739130435, 0.11111111111111
39520, 0.39130434782609, 0.51521739130435, 0.16666666666667
39521, 0.39130434782609, 0.51521739130435, 0.22222222222222
39522, 0.39130434782609, 0.51521739130435, 0.27777777777778
39523, 0.39130434782609, 0.51521739130435, 0.33333333333333
39524, 0.39130434782609, 0.51521739130435, 0.38888888888889
39525, 0.39130434782609, 0.51521739130435, 0.44444444444444
39526, 0.34782608695652, 0.51521739130435, 0.055555555555556
39527, 0.34782608695652, 0.51521739130435, 0.11111111111111
39528, 0.34782608695652, 0.51521739130435, 0.16666666666667
39529, 0.34782608695652, 0.51521739130435, 0.22222222222222
39530, 0.34782608695652, 0.51521739130435, 0.27777777777778
39531, 0.34782608695652, 0.51521739130435, 0.33333333333333
39532, 0.34782608695652, 0.51521739130435, 0.38888888888889
39533, 0.34782608695652, 0.51521739130435, 0.44444444444444
39534, 0.30434782608696, 0.51521739130435, 0.055555555555556
39535, 0.30434782608696, 0.51521739130435, 0.11111111111111
39536, 0.30434782608696, 0.51521739130435, 0.16666666666667
39537, 0.30434782608696, 0.51521739130435, 0.22222222222222
39538, 0.30434782608696, 0.51521739130435, 0.27777777777778
39539, 0.30434782608696, 0.51521739130435, 0.33333333333333
39540, 0.30434782608696, 0.51521739130435, 0.38888888888889
39541, 0.30434782608696, 0.51521739130435, 0.44444444444444
39542, 0.26086956521739, 0.51521739130435, 0.055555555555556
39543, 0.26086956521739, 0.51521739130435, 0.11111111111111
39544, 0.26086956521739, 0.51521739130435, 0.16666666666667
39545, 0.26086956521739, 0.51521739130435, 0.22222222222222
39546, 0.26086956521739, 0.51521739130435, 0.27777777777778
39547, 0.26086956521739, 0.51521739130435, 0.33333333333333
39548, 0.26086956521739, 0.51521739130435, 0.38888888888889
39549, 0.26086956521739, 0.51521739130435, 0.44444444444444
39550, 0.21739130434783, 0.51521739130435, 0.055555555555556
39551, 0.21739130434783, 0.51521739130435, 0.11111111111111
39552, 0.21739130434783, 0.51521739130435, 0.16666666666667
39553, 0.21739130434783, 0.51521739130435, 0.22222222222222
39554, 0.21739130434783, 0.51521739130435, 0.27777777777778
39555, 0.21739130434783, 0.51521739130435, 0.33333333333333
39556, 0.21739130434783, 0.51521739130435, 0.38888888888889
39557, 0.21739130434783, 0.51521739130435, 0.44444444444444
39558, 0.17391304347826, 0.51521739130435, 0.055555555555556
39559, 0.17391304347826, 0.51521739130435, 0.11111111111111
39560, 0.17391304347826, 0.51521739130435, 0.16666666666667
39561, 0.17391304347826, 0.51521739130435, 0.22222222222222
39562, 0.17391304347826, 0.51521739130435, 0.27777777777778
39563, 0.17391304347826, 0.51521739130435, 0.33333333333333
39564, 0.17391304347826, 0.51521739130435, 0.38888888888889
39565, 0.17391304347826, 0.51521739130435, 0.44444444444444
39566, 0.1304347826087, 0.51521739130435, 0.055555555555556
39567, 0.1304347826087, 0.51521739130435, 0.11111111111111
39568, 0.1304347826087, 0.51521739130435, 0.16666666666667
39569, 0.1304347826087, 0.51521739130435, 0.22222222222222
39570, 0.1304347826087, 0.51521739130435, 0.27777777777778
39571, 0.1304347826087, 0.51521739130435, 0.33333333333333
39572, 0.1304347826087, 0.51521739130435, 0.38888888888889
39573, 0.1304347826087, 0.51521739130435, 0.44444444444444
39574, 0.08695652173913, 0.51521739130435, 0.055555555555556
39575, 0.08695652173913, 0.51521739130435, 0.11111111111111
39576, 0.08695652173913, 0.51521739130435, 0.16666666666667
39577, 0.08695652173913, 0.51521739130435, 0.22222222222222
39578, 0.08695652173913, 0.51521739130435, 0.27777777777778
39579, 0.08695652173913, 0.51521739130435, 0.33333333333333
39580, 0.08695652173913, 0.51521739130435, 0.38888888888889
39581, 0.08695652173913, 0.51521739130435, 0.44444444444444
39582, 0.043478260869565, 0.51521739130435, 0.055555555555556
39583, 0.043478260869565, 0.51521739130435, 0.11111111111111
39584, 0.043478260869565, 0.51521739130435, 0.16666666666667
39585, 0.043478260869565, 0.51521739130435, 0.22222222222222
39586, 0.043478260869565, 0.51521739130435, 0.27777777777778
39587, 0.043478260869565, 0.51521739130435, 0.33333333333333
39588, 0.043478260869565, 0.51521739130435, 0.38888888888889
39589, 0.043478260869565, 0.51521739130435, 0.44444444444444
39590, 0.95652173913043, 0.56739130434783, 0.055555555555556
39591, 0.95652173913043, 0.56739130434783, 0.11111111111111
39592, 0.95652173913044, 0.56739130434783, 0.16666666666667
39593, 0.95652173913044, 0.56739130434783, 0.22222222222222
39594, 0.95652173913044, 0.56739130434783, 0.27777777777778
39595, 0.95652173913044, 0.56739130434783, 0.33333333333333
39596, 0.95652173913044, 0.56739130434783, 0.38888888888889
39597, 0.95652173913043, 0.56739130434783, 0.44444444444444
39598, 0.91304347826087, 0.56739130434783, 0.055555555555556
39599, 0.91304347826087, 0.56739130434783, 0.11111111111111
39600, 0.91304347826087, 0.56739130434783, 0.16666666666667
39601, 0.91304347826087, 0.56739130434783, 0.22222222222222
39602, 0.91304347826087, 0.56739130434783, 0.27777777777778
39603, 0.91304347826087, 0.56739130434783, 0.33333333333333
39604, 0.91304347826087, 0.56739130434783, 0.38888888888889
39605, 0.91304347826087, 0.56739130434783, 0.44444444444444
39606, 0.8695652173913, 0.56739130434783, 0.055555555555556
39607, 0.8695652173913, 0.56739130434783, 0.11111111111111
39608, 0.8695652173913, 0.56739130434783, 0.16666666666667
39609, 0.8695652173913, 0.56739130434783, 0.22222222222222
39610, 0.8695652173913, 0.56739130434783, 0.27777777777778
39611, 0.8695652173913, 0.56739130434783, 0.33333333333333
39612, 0.8695652173913, 0.56739130434783, 0.38888888888889
39613, 0.8695652173913, 0.56739130434783, 0.44444444444444
39614, 0.82608695652174, 0.56739130434783, 0.055555555555556
39615, 0.82608695652174, 0.56739130434783, 0.11111111111111
39616, 0.82608695652174, 0.56739130434783, 0.16666666666667
39617, 0.82608695652174, 0.56739130434783, 0.22222222222222
39618, 0.82608695652174, 0.56739130434783, 0.27777777777778
39619, 0.82608695652174, 0.56739130434783, 0.33333333333333
39620, 0.82608695652174, 0.56739130434783, 0.38888888888889
39621, 0.82608695652174, 0.56739130434783, 0.44444444444444
39622, 0.78260869565217, 0.56739130434783, 0.055555555555556
39623, 0.78260869565217, 0.56739130434783, 0.11111111111111
39624, 0.78260869565217, 0.56739130434783, 0.16666666666667
39625, 0.78260869565217, 0.56739130434783, 0.22222222222222
39626, 0.78260869565217, 0.56739130434783, 0.27777777777778
39627, 0.78260869565217, 0.56739130434783, 0.33333333333333
39628, 0.78260869565217, 0.56739130434783, 0.38888888888889
39629, 0.78260869565217, 0.56739130434783, 0.44444444444444
39630, 0.73913043478261, 0.56739130434783, 0.055555555555556
39631, 0.73913043478261, 0.56739130434783, 0.11111111111111
39632, 0.73913043478261, 0.56739130434783, 0.16666666666667
39633, 0.73913043478261, 0.56739130434783, 0.22222222222222
39634, 0.73913043478261, 0.56739130434783, 0.27777777777778
39635, 0.73913043478261, 0.56739130434783, 0.33333333333333
39636, 0.73913043478261, 0.56739130434783, 0.38888888888889
39637, 0.73913043478261, 0.56739130434783, 0.44444444444444
39638, 0.69565217391304, 0.56739130434783, 0.055555555555556
39639, 0.69565217391304, 0.56739130434783, 0.11111111111111
39640, 0.69565217391304, 0.56739130434783, 0.16666666666667
39641, 0.69565217391304, 0.56739130434783, 0.22222222222222
39642, 0.69565217391304, 0.56739130434783, 0.27777777777778
39643, 0.69565217391304, 0.56739130434783, 0.33333333333333
39644, 0.69565217391304, 0.56739130434783, 0.38888888888889
39645, 0.69565217391304, 0.56739130434783, 0.44444444444444
39646, 0.65217391304348, 0.56739130434783, 0.055555555555556
39647, 0.65217391304348, 0.56739130434783, 0.11111111111111
39648, 0.65217391304348, 0.56739130434783, 0.16666666666667
39649, 0.65217391304348, 0.56739130434783, 0.22222222222222
39650, 0.65217391304348, 0.56739130434783, 0.27777777777778
39651, 0.65217391304348, 0.56739130434783, 0.33333333333333
39652, 0.65217391304348, 0.56739130434783, 0.38888888888889
39653, 0.65217391304348, 0.56739130434783, 0.44444444444444
39654, 0.60869565217391, 0.56739130434783, 0.055555555555556
39655, 0.60869565217391, 0.56739130434783, 0.11111111111111
39656, 0.60869565217391, 0.56739130434783, 0.16666666666667
39657, 0.60869565217391, 0.56739130434783, 0.22222222222222
39658, 0.60869565217391, 0.56739130434783, 0.27777777777778
39659, 0.60869565217391, 0.56739130434783, 0.33333333333333
39660, 0.60869565217391, 0.56739130434783, 0.38888888888889
39661, 0.60869565217391, 0.56739130434783, 0.44444444444444
39662, 0.56521739130435, 0.56739130434783, 0.055555555555556
39663, 0.56521739130435, 0.56739130434783, 0.11111111111111
39664, 0.56521739130435, 0.56739130434783, 0.16666666666667
39665, 0.56521739130435, 0.56739130434783, 0.22222222222222
39666, 0.56521739130435, 0.56739130434783, 0.27777777777778
39667, 0.56521739130435, 0.56739130434783, 0.33333333333333
39668, 0.56521739130435, 0.56739130434783, 0.38888888888889
39669, 0.56521739130435, 0.56739130434783, 0.44444444444444
39670, 0.52173913043478, 0.56739130434783, 0.055555555555556
39671, 0.52173913043478, 0.56739130434783, 0.11111111111111
39672, 0.52173913043478, 0.56739130434783, 0.16666666666667
39673, 0.52173913043478, 0.56739130434783, 0.22222222222222
39674, 0.52173913043478, 0.56739130434783, 0.27777777777778
39675, 0.52173913043478, 0.56739130434783, 0.33333333333333
39676, 0.52173913043478, 0.56739130434783, 0.38888888888889
39677, 0.52173913043478, 0.56739130434783, 0.44444444444444
39678, 0.47826086956522, 0.56739130434783, 0.055555555555556
39679, 0.47826086956522, 0.56739130434783, 0.11111111111111
39680, 0.47826086956522, 0.56739130434783, 0.16666666666667
39681, 0.47826086956522, 0.56739130434783, 0.22222222222222
39682, 0.47826086956522, 0.56739130434783, 0.27777777777778
39683, 0.47826086956522, 0.56739130434783, 0.33333333333333
39684, 0.47826086956522, 0.56739130434783, 0.38888888888889
39685, 0.47826086956522, 0.56739130434783, 0.44444444444444
39686, 0.43478260869565, 0.56739130434783, 0.055555555555556
39687, 0.43478260869565, 0.56739130434783, 0.11111111111111
39688, 0.43478260869565, 0.56739130434783, 0.16666666666667
39689, 0.43478260869565, 0.56739130434783, 0.22222222222222
39690, 0.43478260869565, 0.56739130434783, 0.27777777777778
39691, 0.43478260869565, 0.56739130434783, 0.33333333333333
39692, 0.43478260869565, 0.56739130434783, 0.38888888888889
39693, 0.43478260869565, 0.56739130434783, 0.44444444444444
39694, 0.39130434782609, 0.56739130434783, 0.055555555555556
39695, 0.39130434782609, 0.56739130434783, 0.11111111111111
39696, 0.39130434782609, 0.56739130434783, 0.16666666666667
39697, 0.39130434782609, 0.56739130434783, 0.22222222222222
39698, 0.39130434782609, 0.56739130434783, 0.27777777777778
39699, 0.39130434782609, 0.56739130434783, 0.33333333333333
39700, 0.39130434782609, 0.56739130434783, 0.38888888888889
39701, 0.39130434782609, 0.56739130434783, 0.44444444444444
39702, 0.34782608695652, 0.56739130434783, 0.055555555555556
39703, 0.34782608695652, 0.56739130434783, 0.11111111111111
39704, 0.34782608695652, 0.56739130434783, 0.16666666666667
39705, 0.34782608695652, 0.56739130434783, 0.22222222222222
39706, 0.34782608695652, 0.56739130434783, 0.27777777777778
39707, 0.34782608695652, 0.56739130434783, 0.33333333333333
39708, 0.34782608695652, 0.56739130434783, 0.38888888888889
39709, 0.34782608695652, 0.56739130434783, 0.44444444444444
39710, 0.30434782608696, 0.56739130434783, 0.055555555555556
39711, 0.30434782608696, 0.56739130434783, 0.11111111111111
39712, 0.30434782608696, 0.56739130434783, 0.16666666666667
39713, 0.30434782608696, 0.56739130434783, 0.22222222222222
39714, 0.30434782608696, 0.56739130434783, 0.27777777777778
39715, 0.30434782608696, 0.56739130434783, 0.33333333333333
39716, 0.30434782608696, 0.56739130434783, 0.38888888888889
39717, 0.30434782608696, 0.56739130434783, 0.44444444444444
39718, 0.26086956521739, 0.56739130434783, 0.055555555555556
39719, 0.26086956521739, 0.56739130434783, 0.11111111111111
39720, 0.26086956521739, 0.56739130434783, 0.16666666666667
39721, 0.26086956521739, 0.56739130434783, 0.22222222222222
39722, 0.26086956521739, 0.56739130434783, 0.27777777777778
39723, 0.26086956521739, 0.56739130434783, 0.33333333333333
39724, 0.26086956521739, 0.56739130434783, 0.38888888888889
39725, 0.26086956521739, 0.56739130434783, 0.44444444444444
39726, 0.21739130434783, 0.56739130434783, 0.055555555555556
39727, 0.21739130434783, 0.56739130434783, 0.11111111111111
39728, 0.21739130434783, 0.56739130434783, 0.16666666666667
39729, 0.21739130434783, 0.56739130434783, 0.22222222222222
39730, 0.21739130434783, 0.56739130434783, 0.27777777777778
39731, 0.21739130434783, 0.56739130434783, 0.33333333333333
39732, 0.21739130434783, 0.56739130434783, 0.38888888888889
39733, 0.21739130434783, 0.56739130434783, 0.44444444444444
39734, 0.17391304347826, 0.56739130434783, 0.055555555555556
39735, 0.17391304347826, 0.56739130434783, 0.11111111111111
39736, 0.17391304347826, 0.56739130434783, 0.16666666666667
39737, 0.17391304347826, 0.56739130434783, 0.22222222222222
39738, 0.17391304347826, 0.56739130434783, 0.27777777777778
39739, 0.17391304347826, 0.56739130434783, 0.33333333333333
39740, 0.17391304347826, 0.56739130434783, 0.38888888888889
39741, 0.17391304347826, 0.56739130434783, 0.44444444444444
39742, 0.1304347826087, 0.56739130434783, 0.055555555555556
39743, 0.1304347826087, 0.56739130434783, 0.11111111111111
39744, 0.1304347826087, 0.56739130434783, 0.16666666666667
39745, 0.1304347826087, 0.56739130434783, 0.22222222222222
39746, 0.1304347826087, 0.56739130434783, 0.27777777777778
39747, 0.1304347826087, 0.56739130434783, 0.33333333333333
39748, 0.1304347826087, 0.56739130434783, 0.38888888888889
39749, 0.1304347826087, 0.56739130434783, 0.44444444444444
39750, 0.08695652173913, 0.56739130434783, 0.055555555555556
39751, 0.08695652173913, 0.56739130434783, 0.11111111111111
39752, 0.08695652173913, 0.56739130434783, 0.16666666666667
39753, 0.08695652173913, 0.56739130434783, 0.22222222222222
39754, 0.08695652173913, 0.56739130434783, 0.27777777777778
39755, 0.08695652173913, 0.56739130434783, 0.33333333333333
39756, 0.08695652173913, 0.56739130434783, 0.38888888888889
39757, 0.08695652173913, 0.56739130434783, 0.44444444444444
39758, 0.043478260869565, 0.56739130434783, 0.055555555555556
39759, 0.043478260869565, 0.56739130434783, 0.11111111111111
39760, 0.043478260869565, 0.56739130434783, 0.16666666666667
39761, 0.043478260869565, 0.56739130434783, 0.22222222222222
39762, 0.043478260869565, 0.56739130434783, 0.27777777777778
39763, 0.043478260869565, 0.56739130434783, 0.33333333333333
39764, 0.043478260869565, 0.56739130434783, 0.38888888888889
39765, 0.043478260869565, 0.56739130434783, 0.44444444444444
39766, 0.95652173913043, 0.6195652173913, 0.055555555555556
39767, 0.95652173913044, 0.6195652173913, 0.11111111111111
39768, 0.95652173913044, 0.6195652173913, 0.16666666666667
39769, 0.95652173913044, 0.6195652173913, 0.22222222222222
39770, 0.95652173913044, 0.6195652173913, 0.27777777777778
39771, 0.95652173913044, 0.6195652173913, 0.33333333333333
39772, 0.95652173913044, 0.6195652173913, 0.38888888888889
39773, 0.95652173913044, 0.6195652173913, 0.44444444444444
39774, 0.91304347826087, 0.6195652173913, 0.055555555555556
39775, 0.91304347826087, 0.6195652173913, 0.11111111111111
39776, 0.91304347826087, 0.6195652173913, 0.16666666666667
39777, 0.91304347826087, 0.6195652173913, 0.22222222222222
39778, 0.91304347826087, 0.6195652173913, 0.27777777777778
39779, 0.91304347826087, 0.6195652173913, 0.33333333333333
39780, 0.91304347826087, 0.6195652173913, 0.38888888888889
39781, 0.91304347826087, 0.6195652173913, 0.44444444444444
39782, 0.8695652173913, 0.6195652173913, 0.055555555555556
39783, 0.8695652173913, 0.6195652173913, 0.11111111111111
39784, 0.8695652173913, 0.6195652173913, 0.16666666666667
39785, 0.8695652173913, 0.6195652173913, 0.22222222222222
39786, 0.8695652173913, 0.6195652173913, 0.27777777777778
39787, 0.8695652173913, 0.6195652173913, 0.33333333333333
39788, 0.8695652173913, 0.6195652173913, 0.38888888888889
39789, 0.8695652173913, 0.6195652173913, 0.44444444444444
39790, 0.82608695652174, 0.6195652173913, 0.055555555555556
39791, 0.82608695652174, 0.6195652173913, 0.11111111111111
39792, 0.82608695652174, 0.6195652173913, 0.16666666666667
39793, 0.82608695652174, 0.6195652173913, 0.22222222222222
39794, 0.82608695652174, 0.6195652173913, 0.27777777777778
39795, 0.82608695652174, 0.6195652173913, 0.33333333333333
39796, 0.82608695652174, 0.6195652173913, 0.38888888888889
39797, 0.82608695652174, 0.6195652173913, 0.44444444444444
39798, 0.78260869565217, 0.6195652173913, 0.055555555555556
39799, 0.78260869565217, 0.6195652173913, 0.11111111111111
39800, 0.78260869565217, 0.6195652173913, 0.16666666666667
39801, 0.78260869565217, 0.6195652173913, 0.22222222222222
39802, 0.78260869565217, 0.6195652173913, 0.27777777777778
39803, 0.78260869565217, 0.6195652173913, 0.33333333333333
39804, 0.78260869565217, 0.6195652173913, 0.38888888888889
39805, 0.78260869565217, 0.6195652173913, 0.44444444444444
39806, 0.73913043478261, 0.6195652173913, 0.055555555555556
39807, 0.73913043478261, 0.6195652173913, 0.11111111111111
39808, 0.73913043478261, 0.6195652173913, 0.16666666666667
39809, 0.73913043478261, 0.6195652173913, 0.22222222222222
39810, 0.73913043478261, 0.6195652173913, 0.27777777777778
39811, 0.73913043478261, 0.6195652173913, 0.33333333333333
39812, 0.73913043478261, 0.6195652173913, 0.38888888888889
39813, 0.73913043478261, 0.6195652173913, 0.44444444444444
39814, 0.69565217391304, 0.6195652173913, 0.055555555555556
39815, 0.69565217391304, 0.6195652173913, 0.11111111111111
39816, 0.69565217391304, 0.6195652173913, 0.16666666666667
39817, 0.69565217391304, 0.6195652173913, 0.22222222222222
39818, 0.69565217391304, 0.6195652173913, 0.27777777777778
39819, 0.69565217391304, 0.6195652173913, 0.33333333333333
39820, 0.69565217391304, 0.6195652173913, 0.38888888888889
39821, 0.69565217391304, 0.6195652173913, 0.44444444444444
39822, 0.65217391304348, 0.6195652173913, 0.055555555555556
39823, 0.65217391304348, 0.6195652173913, 0.11111111111111
39824, 0.65217391304348, 0.6195652173913, 0.16666666666667
39825, 0.65217391304348, 0.6195652173913, 0.22222222222222
39826, 0.65217391304348, 0.6195652173913, 0.27777777777778
39827, 0.65217391304348, 0.6195652173913, 0.33333333333333
39828, 0.65217391304348, 0.6195652173913, 0.38888888888889
39829, 0.65217391304348, 0.6195652173913, 0.44444444444444
39830, 0.60869565217391, 0.6195652173913, 0.055555555555556
39831, 0.60869565217391, 0.6195652173913, 0.11111111111111
39832, 0.60869565217391, 0.6195652173913, 0.16666666666667
39833, 0.60869565217391, 0.6195652173913, 0.22222222222222
39834, 0.60869565217391, 0.6195652173913, 0.27777777777778
39835, 0.60869565217391, 0.6195652173913, 0.33333333333333
39836, 0.60869565217391, 0.6195652173913, 0.38888888888889
39837, 0.60869565217391, 0.6195652173913, 0.44444444444444
39838, 0.56521739130435, 0.6195652173913, 0.055555555555556
39839, 0.56521739130435, 0.6195652173913, 0.11111111111111
39840, 0.56521739130435, 0.6195652173913, 0.16666666666667
39841, 0.56521739130435, 0.6195652173913, 0.22222222222222
39842, 0.56521739130435, 0.6195652173913, 0.27777777777778
39843, 0.56521739130435, 0.6195652173913, 0.33333333333333
39844, 0.56521739130435, 0.6195652173913, 0.38888888888889
39845, 0.56521739130435, 0.6195652173913, 0.44444444444444
39846, 0.52173913043478, 0.6195652173913, 0.055555555555556
39847, 0.52173913043478, 0.6195652173913, 0.11111111111111
39848, 0.52173913043478, 0.6195652173913, 0.16666666666667
39849, 0.52173913043478, 0.6195652173913, 0.22222222222222
39850, 0.52173913043478, 0.6195652173913, 0.27777777777778
39851, 0.52173913043478, 0.6195652173913, 0.33333333333333
39852, 0.52173913043478, 0.6195652173913, 0.38888888888889
39853, 0.52173913043478, 0.6195652173913, 0.44444444444444
39854, 0.47826086956522, 0.6195652173913, 0.055555555555556
39855, 0.47826086956522, 0.6195652173913, 0.11111111111111
39856, 0.47826086956522, 0.6195652173913, 0.16666666666667
39857, 0.47826086956522, 0.6195652173913, 0.22222222222222
39858, 0.47826086956522, 0.6195652173913, 0.27777777777778
39859, 0.47826086956522, 0.6195652173913, 0.33333333333333
39860, 0.47826086956522, 0.6195652173913, 0.38888888888889
39861, 0.47826086956522, 0.6195652173913, 0.44444444444444
39862, 0.43478260869565, 0.6195652173913, 0.055555555555556
39863, 0.43478260869565, 0.6195652173913, 0.11111111111111
39864, 0.43478260869565, 0.6195652173913, 0.16666666666667
39865, 0.43478260869565, 0.6195652173913, 0.22222222222222
39866, 0.43478260869565, 0.6195652173913, 0.27777777777778
39867, 0.43478260869565, 0.6195652173913, 0.33333333333333
39868, 0.43478260869565, 0.6195652173913, 0.38888888888889
39869, 0.43478260869565, 0.6195652173913, 0.44444444444444
39870, 0.39130434782609, 0.6195652173913, 0.055555555555556
39871, 0.39130434782609, 0.6195652173913, 0.11111111111111
39872, 0.39130434782609, 0.6195652173913, 0.16666666666667
39873, 0.39130434782609, 0.6195652173913, 0.22222222222222
39874, 0.39130434782609, 0.6195652173913, 0.27777777777778
39875, 0.39130434782609, 0.6195652173913, 0.33333333333333
39876, 0.39130434782609, 0.6195652173913, 0.38888888888889
39877, 0.39130434782609, 0.6195652173913, 0.44444444444444
39878, 0.34782608695652, 0.6195652173913, 0.055555555555556
39879, 0.34782608695652, 0.6195652173913, 0.11111111111111
39880, 0.34782608695652, 0.6195652173913, 0.16666666666667
39881, 0.34782608695652, 0.6195652173913, 0.22222222222222
39882, 0.34782608695652, 0.6195652173913, 0.27777777777778
39883, 0.34782608695652, 0.6195652173913, 0.33333333333333
39884, 0.34782608695652, 0.6195652173913, 0.38888888888889
39885, 0.34782608695652, 0.6195652173913, 0.44444444444444
39886, 0.30434782608696, 0.6195652173913, 0.055555555555556
39887, 0.30434782608696, 0.6195652173913, 0.11111111111111
39888, 0.30434782608696, 0.6195652173913, 0.16666666666667
39889, 0.30434782608696, 0.6195652173913, 0.22222222222222
39890, 0.30434782608696, 0.6195652173913, 0.27777777777778
39891, 0.30434782608696, 0.6195652173913, 0.33333333333333
39892, 0.30434782608696, 0.6195652173913, 0.38888888888889
39893, 0.30434782608696, 0.6195652173913, 0.44444444444444
39894, 0.26086956521739, 0.6195652173913, 0.055555555555556
39895, 0.26086956521739, 0.6195652173913, 0.11111111111111
39896, 0.26086956521739, 0.6195652173913, 0.16666666666667
39897, 0.26086956521739, 0.6195652173913, 0.22222222222222
39898, 0.26086956521739, 0.6195652173913, 0.27777777777778
39899, 0.26086956521739, 0.6195652173913, 0.33333333333333
39900, 0.26086956521739, 0.6195652173913, 0.38888888888889
39901, 0.26086956521739, 0.6195652173913, 0.44444444444444
39902, 0.21739130434783, 0.6195652173913, 0.055555555555556
39903, 0.21739130434783, 0.6195652173913, 0.11111111111111
39904, 0.21739130434783, 0.6195652173913, 0.16666666666667
39905, 0.21739130434783, 0.6195652173913, 0.22222222222222
39906, 0.21739130434783, 0.6195652173913, 0.27777777777778
39907, 0.21739130434783, 0.6195652173913, 0.33333333333333
39908, 0.21739130434783, 0.6195652173913, 0.38888888888889
39909, 0.21739130434783, 0.6195652173913, 0.44444444444444
39910, 0.17391304347826, 0.6195652173913, 0.055555555555556
39911, 0.17391304347826, 0.6195652173913, 0.11111111111111
39912, 0.17391304347826, 0.6195652173913, 0.16666666666667
39913, 0.17391304347826, 0.6195652173913, 0.22222222222222
39914, 0.17391304347826, 0.6195652173913, 0.27777777777778
39915, 0.17391304347826, 0.6195652173913, 0.33333333333333
39916, 0.17391304347826, 0.6195652173913, 0.38888888888889
39917, 0.17391304347826, 0.6195652173913, 0.44444444444444
39918, 0.1304347826087, 0.6195652173913, 0.055555555555556
39919, 0.1304347826087, 0.6195652173913, 0.11111111111111
39920, 0.1304347826087, 0.6195652173913, 0.16666666666667
39921, 0.1304347826087, 0.6195652173913, 0.22222222222222
39922, 0.1304347826087, 0.6195652173913, 0.27777777777778
39923, 0.1304347826087, 0.6195652173913, 0.33333333333333
39924, 0.1304347826087, 0.6195652173913, 0.38888888888889
39925, 0.1304347826087, 0.6195652173913, 0.44444444444444
39926, 0.08695652173913, 0.6195652173913, 0.055555555555556
39927, 0.08695652173913, 0.6195652173913, 0.11111111111111
39928, 0.08695652173913, 0.6195652173913, 0.16666666666667
39929, 0.08695652173913, 0.6195652173913, 0.22222222222222
39930, 0.08695652173913, 0.6195652173913, 0.27777777777778
39931, 0.08695652173913, 0.6195652173913, 0.33333333333333
39932, 0.08695652173913, 0.6195652173913, 0.38888888888889
39933, 0.08695652173913, 0.6195652173913, 0.44444444444444
39934, 0.043478260869565, 0.6195652173913, 0.055555555555556
39935, 0.043478260869565, 0.6195652173913, 0.11111111111111
39936, 0.043478260869565, 0.6195652173913, 0.16666666666667
39937, 0.043478260869565, 0.6195652173913, 0.22222222222222
39938, 0.043478260869565, 0.6195652173913, 0.27777777777778
39939, 0.043478260869565, 0.6195652173913, 0.33333333333333
39940, 0.043478260869565, 0.6195652173913, 0.38888888888889
39941, 0.043478260869565, 0.6195652173913, 0.44444444444444
39942, 0.95652173913043, 0.67173913043478, 0.055555555555556
39943, 0.95652173913044, 0.67173913043478, 0.11111111111111
39944, 0.95652173913044, 0.67173913043478, 0.16666666666667
39945, 0.95652173913044, 0.67173913043478, 0.22222222222222
39946, 0.95652173913043, 0.67173913043478, 0.27777777777778
39947, 0.95652173913044, 0.67173913043478, 0.33333333333333
39948, 0.95652173913044, 0.67173913043478, 0.38888888888889
39949, 0.95652173913044, 0.67173913043478, 0.44444444444444
39950, 0.91304347826087, 0.67173913043478, 0.055555555555556
39951, 0.91304347826087, 0.67173913043478, 0.11111111111111
39952, 0.91304347826087, 0.67173913043478, 0.16666666666667
39953, 0.91304347826087, 0.67173913043478, 0.22222222222222
39954, 0.91304347826087, 0.67173913043478, 0.27777777777778
39955, 0.91304347826087, 0.67173913043478, 0.33333333333333
39956, 0.91304347826087, 0.67173913043478, 0.38888888888889
39957, 0.91304347826087, 0.67173913043478, 0.44444444444444
39958, 0.8695652173913, 0.67173913043478, 0.055555555555556
39959, 0.8695652173913, 0.67173913043478, 0.11111111111111
39960, 0.8695652173913, 0.67173913043478, 0.16666666666667
39961, 0.8695652173913, 0.67173913043478, 0.22222222222222
39962, 0.8695652173913, 0.67173913043478, 0.27777777777778
39963, 0.8695652173913, 0.67173913043478, 0.33333333333333
39964, 0.8695652173913, 0.67173913043478, 0.38888888888889
39965, 0.8695652173913, 0.67173913043478, 0.44444444444444
39966, 0.82608695652174, 0.67173913043478, 0.055555555555556
39967, 0.82608695652174, 0.67173913043478, 0.11111111111111
39968, 0.82608695652174, 0.67173913043478, 0.16666666666667
39969, 0.82608695652174, 0.67173913043478, 0.22222222222222
39970, 0.82608695652174, 0.67173913043478, 0.27777777777778
39971, 0.82608695652174, 0.67173913043478, 0.33333333333333
39972, 0.82608695652174, 0.67173913043478, 0.38888888888889
39973, 0.82608695652174, 0.67173913043478, 0.44444444444444
39974, 0.78260869565217, 0.67173913043478, 0.055555555555556
39975, 0.78260869565217, 0.67173913043478, 0.11111111111111
39976, 0.78260869565217, 0.67173913043478, 0.16666666666667
39977, 0.78260869565217, 0.67173913043478, 0.22222222222222
39978, 0.78260869565217, 0.67173913043478, 0.27777777777778
39979, 0.78260869565217, 0.67173913043478, 0.33333333333333
39980, 0.78260869565217, 0.67173913043478, 0.38888888888889
39981, 0.78260869565217, 0.67173913043478, 0.44444444444444
39982, 0.73913043478261, 0.67173913043478, 0.055555555555556
39983, 0.73913043478261, 0.67173913043478, 0.11111111111111
39984, 0.73913043478261, 0.67173913043478, 0.16666666666667
39985, 0.73913043478261, 0.67173913043478, 0.22222222222222
39986, 0.73913043478261, 0.67173913043478, 0.27777777777778
39987, 0.73913043478261, 0.67173913043478, 0.33333333333333
39988, 0.73913043478261, 0.67173913043478, 0.38888888888889
39989, 0.73913043478261, 0.67173913043478, 0.44444444444444
39990, 0.69565217391304, 0.67173913043478, 0.055555555555556
39991, 0.69565217391304, 0.67173913043478, 0.11111111111111
39992, 0.69565217391304, 0.67173913043478, 0.16666666666667
39993, 0.69565217391304, 0.67173913043478, 0.22222222222222
39994, 0.69565217391304, 0.67173913043478, 0.27777777777778
39995, 0.69565217391304, 0.67173913043478, 0.33333333333333
39996, 0.69565217391304, 0.67173913043478, 0.38888888888889
39997, 0.69565217391304, 0.67173913043478, 0.44444444444444
39998, 0.65217391304348, 0.67173913043478, 0.055555555555556
39999, 0.65217391304348, 0.67173913043478, 0.11111111111111
40000, 0.65217391304348, 0.67173913043478, 0.16666666666667
40001, 0.65217391304348, 0.67173913043478, 0.22222222222222
40002, 0.65217391304348, 0.67173913043478, 0.27777777777778
40003, 0.65217391304348, 0.67173913043478, 0.33333333333333
40004, 0.65217391304348, 0.67173913043478, 0.38888888888889
40005, 0.65217391304348, 0.67173913043478, 0.44444444444444
40006, 0.60869565217391, 0.67173913043478, 0.055555555555556
40007, 0.60869565217391, 0.67173913043478, 0.11111111111111
40008, 0.60869565217391, 0.67173913043478, 0.16666666666667
40009, 0.60869565217391, 0.67173913043478, 0.22222222222222
40010, 0.60869565217391, 0.67173913043478, 0.27777777777778
40011, 0.60869565217391, 0.67173913043478, 0.33333333333333
40012, 0.60869565217391, 0.67173913043478, 0.38888888888889
40013, 0.60869565217391, 0.67173913043478, 0.44444444444444
40014, 0.56521739130435, 0.67173913043478, 0.055555555555556
40015, 0.56521739130435, 0.67173913043478, 0.11111111111111
40016, 0.56521739130435, 0.67173913043478, 0.16666666666667
40017, 0.56521739130435, 0.67173913043478, 0.22222222222222
40018, 0.56521739130435, 0.67173913043478, 0.27777777777778
40019, 0.56521739130435, 0.67173913043478, 0.33333333333333
40020, 0.56521739130435, 0.67173913043478, 0.38888888888889
40021, 0.56521739130435, 0.67173913043478, 0.44444444444444
40022, 0.52173913043478, 0.67173913043478, 0.055555555555556
40023, 0.52173913043478, 0.67173913043478, 0.11111111111111
40024, 0.52173913043478, 0.67173913043478, 0.16666666666667
40025, 0.52173913043478, 0.67173913043478, 0.22222222222222
40026, 0.52173913043478, 0.67173913043478, 0.27777777777778
40027, 0.52173913043478, 0.67173913043478, 0.33333333333333
40028, 0.52173913043478, 0.67173913043478, 0.38888888888889
40029, 0.52173913043478, 0.67173913043478, 0.44444444444444
40030, 0.47826086956522, 0.67173913043478, 0.055555555555556
40031, 0.47826086956522, 0.67173913043478, 0.11111111111111
40032, 0.47826086956522, 0.67173913043478, 0.16666666666667
40033, 0.47826086956522, 0.67173913043478, 0.22222222222222
40034, 0.47826086956522, 0.67173913043478, 0.27777777777778
40035, 0.47826086956522, 0.67173913043478, 0.33333333333333
40036, 0.47826086956522, 0.67173913043478, 0.38888888888889
40037, 0.47826086956522, 0.67173913043478, 0.44444444444444
40038, 0.43478260869565, 0.67173913043478, 0.055555555555556
40039, 0.43478260869565, 0.67173913043478, 0.11111111111111
40040, 0.43478260869565, 0.67173913043478, 0.16666666666667
40041, 0.43478260869565, 0.67173913043478, 0.22222222222222
40042, 0.43478260869565, 0.67173913043478, 0.27777777777778
40043, 0.43478260869565, 0.67173913043478, 0.33333333333333
40044, 0.43478260869565, 0.67173913043478, 0.38888888888889
40045, 0.43478260869565, 0.67173913043478, 0.44444444444444
40046, 0.39130434782609, 0.67173913043478, 0.055555555555556
40047, 0.39130434782609, 0.67173913043478, 0.11111111111111
40048, 0.39130434782609, 0.67173913043478, 0.16666666666667
40049, 0.39130434782609, 0.67173913043478, 0.22222222222222
40050, 0.39130434782609, 0.67173913043478, 0.27777777777778
40051, 0.39130434782609, 0.67173913043478, 0.33333333333333
40052, 0.39130434782609, 0.67173913043478, 0.38888888888889
40053, 0.39130434782609, 0.67173913043478, 0.44444444444444
40054, 0.34782608695652, 0.67173913043478, 0.055555555555556
40055, 0.34782608695652, 0.67173913043478, 0.11111111111111
40056, 0.34782608695652, 0.67173913043478, 0.16666666666667
40057, 0.34782608695652, 0.67173913043478, 0.22222222222222
40058, 0.34782608695652, 0.67173913043478, 0.27777777777778
40059, 0.34782608695652, 0.67173913043478, 0.33333333333333
40060, 0.34782608695652, 0.67173913043478, 0.38888888888889
40061, 0.34782608695652, 0.67173913043478, 0.44444444444444
40062, 0.30434782608696, 0.67173913043478, 0.055555555555556
40063, 0.30434782608696, 0.67173913043478, 0.11111111111111
40064, 0.30434782608696, 0.67173913043478, 0.16666666666667
40065, 0.30434782608696, 0.67173913043478, 0.22222222222222
40066, 0.30434782608696, 0.67173913043478, 0.27777777777778
40067, 0.30434782608696, 0.67173913043478, 0.33333333333333
40068, 0.30434782608696, 0.67173913043478, 0.38888888888889
40069, 0.30434782608696, 0.67173913043478, 0.44444444444444
40070, 0.26086956521739, 0.67173913043478, 0.055555555555556
40071, 0.26086956521739, 0.67173913043478, 0.11111111111111
40072, 0.26086956521739, 0.67173913043478, 0.16666666666667
40073, 0.26086956521739, 0.67173913043478, 0.22222222222222
40074, 0.26086956521739, 0.67173913043478, 0.27777777777778
40075, 0.26086956521739, 0.67173913043478, 0.33333333333333
40076, 0.26086956521739, 0.67173913043478, 0.38888888888889
40077, 0.26086956521739, 0.67173913043478, 0.44444444444444
40078, 0.21739130434783, 0.67173913043478, 0.055555555555556
40079, 0.21739130434783, 0.67173913043478, 0.11111111111111
40080, 0.21739130434783, 0.67173913043478, 0.16666666666667
40081, 0.21739130434783, 0.67173913043478, 0.22222222222222
40082, 0.21739130434783, 0.67173913043478, 0.27777777777778
40083, 0.21739130434783, 0.67173913043478, 0.33333333333333
40084, 0.21739130434783, 0.67173913043478, 0.38888888888889
40085, 0.21739130434783, 0.67173913043478, 0.44444444444444
40086, 0.17391304347826, 0.67173913043478, 0.055555555555556
40087, 0.17391304347826, 0.67173913043478, 0.11111111111111
40088, 0.17391304347826, 0.67173913043478, 0.16666666666667
40089, 0.17391304347826, 0.67173913043478, 0.22222222222222
40090, 0.17391304347826, 0.67173913043478, 0.27777777777778
40091, 0.17391304347826, 0.67173913043478, 0.33333333333333
40092, 0.17391304347826, 0.67173913043478, 0.38888888888889
40093, 0.17391304347826, 0.67173913043478, 0.44444444444444
40094, 0.1304347826087, 0.67173913043478, 0.055555555555556
40095, 0.1304347826087, 0.67173913043478, 0.11111111111111
40096, 0.1304347826087, 0.67173913043478, 0.16666666666667
40097, 0.1304347826087, 0.67173913043478, 0.22222222222222
40098, 0.1304347826087, 0.67173913043478, 0.27777777777778
40099, 0.1304347826087, 0.67173913043478, 0.33333333333333
40100, 0.1304347826087, 0.67173913043478, 0.38888888888889
40101, 0.1304347826087, 0.67173913043478, 0.44444444444444
40102, 0.08695652173913, 0.67173913043478, 0.055555555555556
40103, 0.08695652173913, 0.67173913043478, 0.11111111111111
40104, 0.08695652173913, 0.67173913043478, 0.16666666666667
40105, 0.08695652173913, 0.67173913043478, 0.22222222222222
40106, 0.08695652173913, 0.67173913043478, 0.27777777777778
40107, 0.08695652173913, 0.67173913043478, 0.33333333333333
40108, 0.08695652173913, 0.67173913043478, 0.38888888888889
40109, 0.08695652173913, 0.67173913043478, 0.44444444444444
40110, 0.043478260869565, 0.67173913043478, 0.055555555555556
40111, 0.043478260869565, 0.67173913043478, 0.11111111111111
40112, 0.043478260869565, 0.67173913043478, 0.16666666666667
40113, 0.043478260869565, 0.67173913043478, 0.22222222222222
40114, 0.043478260869565, 0.67173913043478, 0.27777777777778
40115, 0.043478260869565, 0.67173913043478, 0.33333333333333
40116, 0.043478260869565, 0.67173913043478, 0.38888888888889
40117, 0.043478260869565, 0.67173913043478, 0.44444444444444
40118, 0.95652173913043, 0.72391304347826, 0.055555555555556
40119, 0.95652173913044, 0.72391304347826, 0.11111111111111
40120, 0.95652173913044, 0.72391304347826, 0.16666666666667
40121, 0.95652173913044, 0.72391304347826, 0.22222222222222
40122, 0.95652173913044, 0.72391304347826, 0.27777777777778
40123, 0.95652173913044, 0.72391304347826, 0.33333333333333
40124, 0.95652173913044, 0.72391304347826, 0.38888888888889
40125, 0.95652173913044, 0.72391304347826, 0.44444444444444
40126, 0.91304347826087, 0.72391304347826, 0.055555555555556
40127, 0.91304347826087, 0.72391304347826, 0.11111111111111
40128, 0.91304347826087, 0.72391304347826, 0.16666666666667
40129, 0.91304347826087, 0.72391304347826, 0.22222222222222
40130, 0.91304347826087, 0.72391304347826, 0.27777777777778
40131, 0.91304347826087, 0.72391304347826, 0.33333333333333
40132, 0.91304347826087, 0.72391304347826, 0.38888888888889
40133, 0.91304347826087, 0.72391304347826, 0.44444444444444
40134, 0.8695652173913, 0.72391304347826, 0.055555555555556
40135, 0.8695652173913, 0.72391304347826, 0.11111111111111
40136, 0.8695652173913, 0.72391304347826, 0.16666666666667
40137, 0.8695652173913, 0.72391304347826, 0.22222222222222
40138, 0.8695652173913, 0.72391304347826, 0.27777777777778
40139, 0.8695652173913, 0.72391304347826, 0.33333333333333
40140, 0.8695652173913, 0.72391304347826, 0.38888888888889
40141, 0.8695652173913, 0.72391304347826, 0.44444444444444
40142, 0.82608695652174, 0.72391304347826, 0.055555555555556
40143, 0.82608695652174, 0.72391304347826, 0.11111111111111
40144, 0.82608695652174, 0.72391304347826, 0.16666666666667
40145, 0.82608695652174, 0.72391304347826, 0.22222222222222
40146, 0.82608695652174, 0.72391304347826, 0.27777777777778
40147, 0.82608695652174, 0.72391304347826, 0.33333333333333
40148, 0.82608695652174, 0.72391304347826, 0.38888888888889
40149, 0.82608695652174, 0.72391304347826, 0.44444444444444
40150, 0.78260869565217, 0.72391304347826, 0.055555555555556
40151, 0.78260869565217, 0.72391304347826, 0.11111111111111
40152, 0.78260869565217, 0.72391304347826, 0.16666666666667
40153, 0.78260869565217, 0.72391304347826, 0.22222222222222
40154, 0.78260869565217, 0.72391304347826, 0.27777777777778
40155, 0.78260869565217, 0.72391304347826, 0.33333333333333
40156, 0.78260869565217, 0.72391304347826, 0.38888888888889
40157, 0.78260869565217, 0.72391304347826, 0.44444444444444
40158, 0.73913043478261, 0.72391304347826, 0.055555555555556
40159, 0.73913043478261, 0.72391304347826, 0.11111111111111
40160, 0.73913043478261, 0.72391304347826, 0.16666666666667
40161, 0.73913043478261, 0.72391304347826, 0.22222222222222
40162, 0.73913043478261, 0.72391304347826, 0.27777777777778
40163, 0.73913043478261, 0.72391304347826, 0.33333333333333
40164, 0.73913043478261, 0.72391304347826, 0.38888888888889
40165, 0.73913043478261, 0.72391304347826, 0.44444444444444
40166, 0.69565217391304, 0.72391304347826, 0.055555555555556
40167, 0.69565217391304, 0.72391304347826, 0.11111111111111
40168, 0.69565217391304, 0.72391304347826, 0.16666666666667
40169, 0.69565217391304, 0.72391304347826, 0.22222222222222
40170, 0.69565217391304, 0.72391304347826, 0.27777777777778
40171, 0.69565217391304, 0.72391304347826, 0.33333333333333
40172, 0.69565217391304, 0.72391304347826, 0.38888888888889
40173, 0.69565217391304, 0.72391304347826, 0.44444444444444
40174, 0.65217391304348, 0.72391304347826, 0.055555555555556
40175, 0.65217391304348, 0.72391304347826, 0.11111111111111
40176, 0.65217391304348, 0.72391304347826, 0.16666666666667
40177, 0.65217391304348, 0.72391304347826, 0.22222222222222
40178, 0.65217391304348, 0.72391304347826, 0.27777777777778
40179, 0.65217391304348, 0.72391304347826, 0.33333333333333
40180, 0.65217391304348, 0.72391304347826, 0.38888888888889
40181, 0.65217391304348, 0.72391304347826, 0.44444444444444
40182, 0.60869565217391, 0.72391304347826, 0.055555555555556
40183, 0.60869565217391, 0.72391304347826, 0.11111111111111
40184, 0.60869565217391, 0.72391304347826, 0.16666666666667
40185, 0.60869565217391, 0.72391304347826, 0.22222222222222
40186, 0.60869565217391, 0.72391304347826, 0.27777777777778
40187, 0.60869565217391, 0.72391304347826, 0.33333333333333
40188, 0.60869565217391, 0.72391304347826, 0.38888888888889
40189, 0.60869565217391, 0.72391304347826, 0.44444444444444
40190, 0.56521739130435, 0.72391304347826, 0.055555555555556
40191, 0.56521739130435, 0.72391304347826, 0.11111111111111
40192, 0.56521739130435, 0.72391304347826, 0.16666666666667
40193, 0.56521739130435, 0.72391304347826, 0.22222222222222
40194, 0.56521739130435, 0.72391304347826, 0.27777777777778
40195, 0.56521739130435, 0.72391304347826, 0.33333333333333
40196, 0.56521739130435, 0.72391304347826, 0.38888888888889
40197, 0.56521739130435, 0.72391304347826, 0.44444444444444
40198, 0.52173913043478, 0.72391304347826, 0.055555555555556
40199, 0.52173913043478, 0.72391304347826, 0.11111111111111
40200, 0.52173913043478, 0.72391304347826, 0.16666666666667
40201, 0.52173913043478, 0.72391304347826, 0.22222222222222
40202, 0.52173913043478, 0.72391304347826, 0.27777777777778
40203, 0.52173913043478, 0.72391304347826, 0.33333333333333
40204, 0.52173913043478, 0.72391304347826, 0.38888888888889
40205, 0.52173913043478, 0.72391304347826, 0.44444444444444
40206, 0.47826086956522, 0.72391304347826, 0.055555555555556
40207, 0.47826086956522, 0.72391304347826, 0.11111111111111
40208, 0.47826086956522, 0.72391304347826, 0.16666666666667
40209, 0.47826086956522, 0.72391304347826, 0.22222222222222
40210, 0.47826086956522, 0.72391304347826, 0.27777777777778
40211, 0.47826086956522, 0.72391304347826, 0.33333333333333
40212, 0.47826086956522, 0.72391304347826, 0.38888888888889
40213, 0.47826086956522, 0.72391304347826, 0.44444444444444
40214, 0.43478260869565, 0.72391304347826, 0.055555555555556
40215, 0.43478260869565, 0.72391304347826, 0.11111111111111
40216, 0.43478260869565, 0.72391304347826, 0.16666666666667
40217, 0.43478260869565, 0.72391304347826, 0.22222222222222
40218, 0.43478260869565, 0.72391304347826, 0.27777777777778
40219, 0.43478260869565, 0.72391304347826, 0.33333333333333
40220, 0.43478260869565, 0.72391304347826, 0.38888888888889
40221, 0.43478260869565, 0.72391304347826, 0.44444444444444
40222, 0.39130434782609, 0.72391304347826, 0.055555555555556
40223, 0.39130434782609, 0.72391304347826, 0.11111111111111
40224, 0.39130434782609, 0.72391304347826, 0.16666666666667
40225, 0.39130434782609, 0.72391304347826, 0.22222222222222
40226, 0.39130434782609, 0.72391304347826, 0.27777777777778
40227, 0.39130434782609, 0.72391304347826, 0.33333333333333
40228, 0.39130434782609, 0.72391304347826, 0.38888888888889
40229, 0.39130434782609, 0.72391304347826, 0.44444444444444
40230, 0.34782608695652, 0.72391304347826, 0.055555555555556
40231, 0.34782608695652, 0.72391304347826, 0.11111111111111
40232, 0.34782608695652, 0.72391304347826, 0.16666666666667
40233, 0.34782608695652, 0.72391304347826, 0.22222222222222
40234, 0.34782608695652, 0.72391304347826, 0.27777777777778
40235, 0.34782608695652, 0.72391304347826, 0.33333333333333
40236, 0.34782608695652, 0.72391304347826, 0.38888888888889
40237, 0.34782608695652, 0.72391304347826, 0.44444444444444
40238, 0.30434782608696, 0.72391304347826, 0.055555555555556
40239, 0.30434782608696, 0.72391304347826, 0.11111111111111
40240, 0.30434782608696, 0.72391304347826, 0.16666666666667
40241, 0.30434782608696, 0.72391304347826, 0.22222222222222
40242, 0.30434782608696, 0.72391304347826, 0.27777777777778
40243, 0.30434782608696, 0.72391304347826, 0.33333333333333
40244, 0.30434782608696, 0.72391304347826, 0.38888888888889
40245, 0.30434782608696, 0.72391304347826, 0.44444444444444
40246, 0.26086956521739, 0.72391304347826, 0.055555555555556
40247, 0.26086956521739, 0.72391304347826, 0.11111111111111
40248, 0.26086956521739, 0.72391304347826, 0.16666666666667
40249, 0.26086956521739, 0.72391304347826, 0.22222222222222
40250, 0.26086956521739, 0.72391304347826, 0.27777777777778
40251, 0.26086956521739, 0.72391304347826, 0.33333333333333
40252, 0.26086956521739, 0.72391304347826, 0.38888888888889
40253, 0.26086956521739, 0.72391304347826, 0.44444444444444
40254, 0.21739130434783, 0.72391304347826, 0.055555555555556
40255, 0.21739130434783, 0.72391304347826, 0.11111111111111
40256, 0.21739130434783, 0.72391304347826, 0.16666666666667
40257, 0.21739130434783, 0.72391304347826, 0.22222222222222
40258, 0.21739130434783, 0.72391304347826, 0.27777777777778
40259, 0.21739130434783, 0.72391304347826, 0.33333333333333
40260, 0.21739130434783, 0.72391304347826, 0.38888888888889
40261, 0.21739130434783, 0.72391304347826, 0.44444444444444
40262, 0.17391304347826, 0.72391304347826, 0.055555555555556
40263, 0.17391304347826, 0.72391304347826, 0.11111111111111
40264, 0.17391304347826, 0.72391304347826, 0.16666666666667
40265, 0.17391304347826, 0.72391304347826, 0.22222222222222
40266, 0.17391304347826, 0.72391304347826, 0.27777777777778
40267, 0.17391304347826, 0.72391304347826, 0.33333333333333
40268, 0.17391304347826, 0.72391304347826, 0.38888888888889
40269, 0.17391304347826, 0.72391304347826, 0.44444444444444
40270, 0.1304347826087, 0.72391304347826, 0.055555555555556
40271, 0.1304347826087, 0.72391304347826, 0.11111111111111
40272, 0.1304347826087, 0.72391304347826, 0.16666666666667
40273, 0.1304347826087, 0.72391304347826, 0.22222222222222
40274, 0.1304347826087, 0.72391304347826, 0.27777777777778
40275, 0.1304347826087, 0.72391304347826, 0.33333333333333
40276, 0.1304347826087, 0.72391304347826, 0.38888888888889
40277, 0.1304347826087, 0.72391304347826, 0.44444444444444
40278, 0.08695652173913, 0.72391304347826, 0.055555555555556
40279, 0.08695652173913, 0.72391304347826, 0.11111111111111
40280, 0.08695652173913, 0.72391304347826, 0.16666666666667
40281, 0.08695652173913, 0.72391304347826, 0.22222222222222
40282, 0.08695652173913, 0.72391304347826, 0.27777777777778
40283, 0.08695652173913, 0.72391304347826, 0.33333333333333
40284, 0.08695652173913, 0.72391304347826, 0.38888888888889
40285, 0.08695652173913, 0.72391304347826, 0.44444444444444
40286, 0.043478260869565, 0.72391304347826, 0.055555555555556
40287, 0.043478260869565, 0.72391304347826, 0.11111111111111
40288, 0.043478260869565, 0.72391304347826, 0.16666666666667
40289, 0.043478260869565, 0.72391304347826, 0.22222222222222
40290, 0.043478260869565, 0.72391304347826, 0.27777777777778
40291, 0.043478260869565, 0.72391304347826, 0.33333333333333
40292, 0.043478260869565, 0.72391304347826, 0.38888888888889
40293, 0.043478260869565, 0.72391304347826, 0.44444444444444
40294, 0.95652173913043, 0.77608695652174, 0.055555555555556
40295, 0.95652173913044, 0.77608695652174, 0.11111111111111
40296, 0.95652173913044, 0.77608695652174, 0.16666666666667
40297, 0.95652173913044, 0.77608695652174, 0.22222222222222
40298, 0.95652173913044, 0.77608695652174, 0.27777777777778
40299, 0.95652173913044, 0.77608695652174, 0.33333333333333
40300, 0.95652173913044, 0.77608695652174, 0.38888888888889
40301, 0.95652173913044, 0.77608695652174, 0.44444444444444
40302, 0.91304347826087, 0.77608695652174, 0.055555555555556
40303, 0.91304347826087, 0.77608695652174, 0.11111111111111
40304, 0.91304347826087, 0.77608695652174, 0.16666666666667
40305, 0.91304347826087, 0.77608695652174, 0.22222222222222
40306, 0.91304347826087, 0.77608695652174, 0.27777777777778
40307, 0.91304347826087, 0.77608695652174, 0.33333333333333
40308, 0.91304347826087, 0.77608695652174, 0.38888888888889
40309, 0.91304347826087, 0.77608695652174, 0.44444444444444
40310, 0.8695652173913, 0.77608695652174, 0.055555555555556
40311, 0.8695652173913, 0.77608695652174, 0.11111111111111
40312, 0.8695652173913, 0.77608695652174, 0.16666666666667
40313, 0.8695652173913, 0.77608695652174, 0.22222222222222
40314, 0.8695652173913, 0.77608695652174, 0.27777777777778
40315, 0.8695652173913, 0.77608695652174, 0.33333333333333
40316, 0.8695652173913, 0.77608695652174, 0.38888888888889
40317, 0.8695652173913, 0.77608695652174, 0.44444444444444
40318, 0.82608695652174, 0.77608695652174, 0.055555555555556
40319, 0.82608695652174, 0.77608695652174, 0.11111111111111
40320, 0.82608695652174, 0.77608695652174, 0.16666666666667
40321, 0.82608695652174, 0.77608695652174, 0.22222222222222
40322, 0.82608695652174, 0.77608695652174, 0.27777777777778
40323, 0.82608695652174, 0.77608695652174, 0.33333333333333
40324, 0.82608695652174, 0.77608695652174, 0.38888888888889
40325, 0.82608695652174, 0.77608695652174, 0.44444444444444
40326, 0.78260869565217, 0.77608695652174, 0.055555555555556
40327, 0.78260869565217, 0.77608695652174, 0.11111111111111
40328, 0.78260869565217, 0.77608695652174, 0.16666666666667
40329, 0.78260869565217, 0.77608695652174, 0.22222222222222
40330, 0.78260869565217, 0.77608695652174, 0.27777777777778
40331, 0.78260869565217, 0.77608695652174, 0.33333333333333
40332, 0.78260869565217, 0.77608695652174, 0.38888888888889
40333, 0.78260869565217, 0.77608695652174, 0.44444444444444
40334, 0.73913043478261, 0.77608695652174, 0.055555555555556
40335, 0.73913043478261, 0.77608695652174, 0.11111111111111
40336, 0.73913043478261, 0.77608695652174, 0.16666666666667
40337, 0.73913043478261, 0.77608695652174, 0.22222222222222
40338, 0.73913043478261, 0.77608695652174, 0.27777777777778
40339, 0.73913043478261, 0.77608695652174, 0.33333333333333
40340, 0.73913043478261, 0.77608695652174, 0.38888888888889
40341, 0.73913043478261, 0.77608695652174, 0.44444444444444
40342, 0.69565217391304, 0.77608695652174, 0.055555555555556
40343, 0.69565217391304, 0.77608695652174, 0.11111111111111
40344, 0.69565217391304, 0.77608695652174, 0.16666666666667
40345, 0.69565217391304, 0.77608695652174, 0.22222222222222
40346, 0.69565217391304, 0.77608695652174, 0.27777777777778
40347, 0.69565217391304, 0.77608695652174, 0.33333333333333
40348, 0.69565217391304, 0.77608695652174, 0.38888888888889
40349, 0.69565217391304, 0.77608695652174, 0.44444444444444
40350, 0.65217391304348, 0.77608695652174, 0.055555555555556
40351, 0.65217391304348, 0.77608695652174, 0.11111111111111
40352, 0.65217391304348, 0.77608695652174, 0.16666666666667
40353, 0.65217391304348, 0.77608695652174, 0.22222222222222
40354, 0.65217391304348, 0.77608695652174, 0.27777777777778
40355, 0.65217391304348, 0.77608695652174, 0.33333333333333
40356, 0.65217391304348, 0.77608695652174, 0.38888888888889
40357, 0.65217391304348, 0.77608695652174, 0.44444444444444
40358, 0.60869565217391, 0.77608695652174, 0.055555555555556
40359, 0.60869565217391, 0.77608695652174, 0.11111111111111
40360, 0.60869565217391, 0.77608695652174, 0.16666666666667
40361, 0.60869565217391, 0.77608695652174, 0.22222222222222
40362, 0.60869565217391, 0.77608695652174, 0.27777777777778
40363, 0.60869565217391, 0.77608695652174, 0.33333333333333
40364, 0.60869565217391, 0.77608695652174, 0.38888888888889
40365, 0.60869565217391, 0.77608695652174, 0.44444444444444
40366, 0.56521739130435, 0.77608695652174, 0.055555555555556
40367, 0.56521739130435, 0.77608695652174, 0.11111111111111
40368, 0.56521739130435, 0.77608695652174, 0.16666666666667
40369, 0.56521739130435, 0.77608695652174, 0.22222222222222
40370, 0.56521739130435, 0.77608695652174, 0.27777777777778
40371, 0.56521739130435, 0.77608695652174, 0.33333333333333
40372, 0.56521739130435, 0.77608695652174, 0.38888888888889
40373, 0.56521739130435, 0.77608695652174, 0.44444444444444
40374, 0.52173913043478, 0.77608695652174, 0.055555555555556
40375, 0.52173913043478, 0.77608695652174, 0.11111111111111
40376, 0.52173913043478, 0.77608695652174, 0.16666666666667
40377, 0.52173913043478, 0.77608695652174, 0.22222222222222
40378, 0.52173913043478, 0.77608695652174, 0.27777777777778
40379, 0.52173913043478, 0.77608695652174, 0.33333333333333
40380, 0.52173913043478, 0.77608695652174, 0.38888888888889
40381, 0.52173913043478, 0.77608695652174, 0.44444444444444
40382, 0.47826086956522, 0.77608695652174, 0.055555555555556
40383, 0.47826086956522, 0.77608695652174, 0.11111111111111
40384, 0.47826086956522, 0.77608695652174, 0.16666666666667
40385, 0.47826086956522, 0.77608695652174, 0.22222222222222
40386, 0.47826086956522, 0.77608695652174, 0.27777777777778
40387, 0.47826086956522, 0.77608695652174, 0.33333333333333
40388, 0.47826086956522, 0.77608695652174, 0.38888888888889
40389, 0.47826086956522, 0.77608695652174, 0.44444444444444
40390, 0.43478260869565, 0.77608695652174, 0.055555555555556
40391, 0.43478260869565, 0.77608695652174, 0.11111111111111
40392, 0.43478260869565, 0.77608695652174, 0.16666666666667
40393, 0.43478260869565, 0.77608695652174, 0.22222222222222
40394, 0.43478260869565, 0.77608695652174, 0.27777777777778
40395, 0.43478260869565, 0.77608695652174, 0.33333333333333
40396, 0.43478260869565, 0.77608695652174, 0.38888888888889
40397, 0.43478260869565, 0.77608695652174, 0.44444444444444
40398, 0.39130434782609, 0.77608695652174, 0.055555555555556
40399, 0.39130434782609, 0.77608695652174, 0.11111111111111
40400, 0.39130434782609, 0.77608695652174, 0.16666666666667
40401, 0.39130434782609, 0.77608695652174, 0.22222222222222
40402, 0.39130434782609, 0.77608695652174, 0.27777777777778
40403, 0.39130434782609, 0.77608695652174, 0.33333333333333
40404, 0.39130434782609, 0.77608695652174, 0.38888888888889
40405, 0.39130434782609, 0.77608695652174, 0.44444444444444
40406, 0.34782608695652, 0.77608695652174, 0.055555555555556
40407, 0.34782608695652, 0.77608695652174, 0.11111111111111
40408, 0.34782608695652, 0.77608695652174, 0.16666666666667
40409, 0.34782608695652, 0.77608695652174, 0.22222222222222
40410, 0.34782608695652, 0.77608695652174, 0.27777777777778
40411, 0.34782608695652, 0.77608695652174, 0.33333333333333
40412, 0.34782608695652, 0.77608695652174, 0.38888888888889
40413, 0.34782608695652, 0.77608695652174, 0.44444444444444
40414, 0.30434782608696, 0.77608695652174, 0.055555555555556
40415, 0.30434782608696, 0.77608695652174, 0.11111111111111
40416, 0.30434782608696, 0.77608695652174, 0.16666666666667
40417, 0.30434782608696, 0.77608695652174, 0.22222222222222
40418, 0.30434782608696, 0.77608695652174, 0.27777777777778
40419, 0.30434782608696, 0.77608695652174, 0.33333333333333
40420, 0.30434782608696, 0.77608695652174, 0.38888888888889
40421, 0.30434782608696, 0.77608695652174, 0.44444444444444
40422, 0.26086956521739, 0.77608695652174, 0.055555555555556
40423, 0.26086956521739, 0.77608695652174, 0.11111111111111
40424, 0.26086956521739, 0.77608695652174, 0.16666666666667
40425, 0.26086956521739, 0.77608695652174, 0.22222222222222
40426, 0.26086956521739, 0.77608695652174, 0.27777777777778
40427, 0.26086956521739, 0.77608695652174, 0.33333333333333
40428, 0.26086956521739, 0.77608695652174, 0.38888888888889
40429, 0.26086956521739, 0.77608695652174, 0.44444444444444
40430, 0.21739130434783, 0.77608695652174, 0.055555555555556
40431, 0.21739130434783, 0.77608695652174, 0.11111111111111
40432, 0.21739130434783, 0.77608695652174, 0.16666666666667
40433, 0.21739130434783, 0.77608695652174, 0.22222222222222
40434, 0.21739130434783, 0.77608695652174, 0.27777777777778
40435, 0.21739130434783, 0.77608695652174, 0.33333333333333
40436, 0.21739130434783, 0.77608695652174, 0.38888888888889
40437, 0.21739130434783, 0.77608695652174, 0.44444444444444
40438, 0.17391304347826, 0.77608695652174, 0.055555555555556
40439, 0.17391304347826, 0.77608695652174, 0.11111111111111
40440, 0.17391304347826, 0.77608695652174, 0.16666666666667
40441, 0.17391304347826, 0.77608695652174, 0.22222222222222
40442, 0.17391304347826, 0.77608695652174, 0.27777777777778
40443, 0.17391304347826, 0.77608695652174, 0.33333333333333
40444, 0.17391304347826, 0.77608695652174, 0.38888888888889
40445, 0.17391304347826, 0.77608695652174, 0.44444444444444
40446, 0.1304347826087, 0.77608695652174, 0.055555555555556
40447, 0.1304347826087, 0.77608695652174, 0.11111111111111
40448, 0.1304347826087, 0.77608695652174, 0.16666666666667
40449, 0.1304347826087, 0.77608695652174, 0.22222222222222
40450, 0.1304347826087, 0.77608695652174, 0.27777777777778
40451, 0.1304347826087, 0.77608695652174, 0.33333333333333
40452, 0.1304347826087, 0.77608695652174, 0.38888888888889
40453, 0.1304347826087, 0.77608695652174, 0.44444444444444
40454, 0.08695652173913, 0.77608695652174, 0.055555555555556
40455, 0.08695652173913, 0.77608695652174, 0.11111111111111
40456, 0.08695652173913, 0.77608695652174, 0.16666666666667
40457, 0.08695652173913, 0.77608695652174, 0.22222222222222
40458, 0.08695652173913, 0.77608695652174, 0.27777777777778
40459, 0.08695652173913, 0.77608695652174, 0.33333333333333
40460, 0.08695652173913, 0.77608695652174, 0.38888888888889
40461, 0.08695652173913, 0.77608695652174, 0.44444444444444
40462, 0.043478260869565, 0.77608695652174, 0.055555555555556
40463, 0.043478260869565, 0.77608695652174, 0.11111111111111
40464, 0.043478260869565, 0.77608695652174, 0.16666666666667
40465, 0.043478260869565, 0.77608695652174, 0.22222222222222
40466, 0.043478260869565, 0.77608695652174, 0.27777777777778
40467, 0.043478260869565, 0.77608695652174, 0.33333333333333
40468, 0.043478260869565, 0.77608695652174, 0.38888888888889
40469, 0.043478260869565, 0.77608695652174, 0.44444444444444
40470, 0.95652173913043, 0.82826086956522, 0.055555555555556
40471, 0.95652173913044, 0.82826086956522, 0.11111111111111
40472, 0.95652173913044, 0.82826086956522, 0.16666666666667
40473, 0.95652173913044, 0.82826086956522, 0.22222222222222
40474, 0.95652173913044, 0.82826086956522, 0.27777777777778
40475, 0.95652173913044, 0.82826086956522, 0.33333333333333
40476, 0.95652173913044, 0.82826086956522, 0.38888888888889
40477, 0.95652173913044, 0.82826086956522, 0.44444444444444
40478, 0.91304347826087, 0.82826086956522, 0.055555555555556
40479, 0.91304347826087, 0.82826086956522, 0.11111111111111
40480, 0.91304347826087, 0.82826086956522, 0.16666666666667
40481, 0.91304347826087, 0.82826086956522, 0.22222222222222
40482, 0.91304347826087, 0.82826086956522, 0.27777777777778
40483, 0.91304347826087, 0.82826086956522, 0.33333333333333
40484, 0.91304347826087, 0.82826086956522, 0.38888888888889
40485, 0.91304347826087, 0.82826086956522, 0.44444444444444
40486, 0.8695652173913, 0.82826086956522, 0.055555555555556
40487, 0.8695652173913, 0.82826086956522, 0.11111111111111
40488, 0.8695652173913, 0.82826086956522, 0.16666666666667
40489, 0.8695652173913, 0.82826086956522, 0.22222222222222
40490, 0.8695652173913, 0.82826086956522, 0.27777777777778
40491, 0.8695652173913, 0.82826086956522, 0.33333333333333
40492, 0.8695652173913, 0.82826086956522, 0.38888888888889
40493, 0.8695652173913, 0.82826086956522, 0.44444444444444
40494, 0.82608695652174, 0.82826086956522, 0.055555555555556
40495, 0.82608695652174, 0.82826086956522, 0.11111111111111
40496, 0.82608695652174, 0.82826086956522, 0.16666666666667
40497, 0.82608695652174, 0.82826086956522, 0.22222222222222
40498, 0.82608695652174, 0.82826086956522, 0.27777777777778
40499, 0.82608695652174, 0.82826086956522, 0.33333333333333
40500, 0.82608695652174, 0.82826086956522, 0.38888888888889
40501, 0.82608695652174, 0.82826086956522, 0.44444444444444
40502, 0.78260869565217, 0.82826086956522, 0.055555555555556
40503, 0.78260869565217, 0.82826086956522, 0.11111111111111
40504, 0.78260869565217, 0.82826086956522, 0.16666666666667
40505, 0.78260869565217, 0.82826086956522, 0.22222222222222
40506, 0.78260869565217, 0.82826086956522, 0.27777777777778
40507, 0.78260869565217, 0.82826086956522, 0.33333333333333
40508, 0.78260869565217, 0.82826086956522, 0.38888888888889
40509, 0.78260869565217, 0.82826086956522, 0.44444444444444
40510, 0.73913043478261, 0.82826086956522, 0.055555555555556
40511, 0.73913043478261, 0.82826086956522, 0.11111111111111
40512, 0.73913043478261, 0.82826086956522, 0.16666666666667
40513, 0.73913043478261, 0.82826086956522, 0.22222222222222
40514, 0.73913043478261, 0.82826086956522, 0.27777777777778
40515, 0.73913043478261, 0.82826086956522, 0.33333333333333
40516, 0.73913043478261, 0.82826086956522, 0.38888888888889
40517, 0.73913043478261, 0.82826086956522, 0.44444444444444
40518, 0.69565217391304, 0.82826086956522, 0.055555555555556
40519, 0.69565217391304, 0.82826086956522, 0.11111111111111
40520, 0.69565217391304, 0.82826086956522, 0.16666666666667
40521, 0.69565217391304, 0.82826086956522, 0.22222222222222
40522, 0.69565217391304, 0.82826086956522, 0.27777777777778
40523, 0.69565217391304, 0.82826086956522, 0.33333333333333
40524, 0.69565217391304, 0.82826086956522, 0.38888888888889
40525, 0.69565217391304, 0.82826086956522, 0.44444444444444
40526, 0.65217391304348, 0.82826086956522, 0.055555555555556
40527, 0.65217391304348, 0.82826086956522, 0.11111111111111
40528, 0.65217391304348, 0.82826086956522, 0.16666666666667
40529, 0.65217391304348, 0.82826086956522, 0.22222222222222
40530, 0.65217391304348, 0.82826086956522, 0.27777777777778
40531, 0.65217391304348, 0.82826086956522, 0.33333333333333
40532, 0.65217391304348, 0.82826086956522, 0.38888888888889
40533, 0.65217391304348, 0.82826086956522, 0.44444444444444
40534, 0.60869565217391, 0.82826086956522, 0.055555555555556
40535, 0.60869565217391, 0.82826086956522, 0.11111111111111
40536, 0.60869565217391, 0.82826086956522, 0.16666666666667
40537, 0.60869565217391, 0.82826086956522, 0.22222222222222
40538, 0.60869565217391, 0.82826086956522, 0.27777777777778
40539, 0.60869565217391, 0.82826086956522, 0.33333333333333
40540, 0.60869565217391, 0.82826086956522, 0.38888888888889
40541, 0.60869565217391, 0.82826086956522, 0.44444444444444
40542, 0.56521739130435, 0.82826086956522, 0.055555555555556
40543, 0.56521739130435, 0.82826086956522, 0.11111111111111
40544, 0.56521739130435, 0.82826086956522, 0.16666666666667
40545, 0.56521739130435, 0.82826086956522, 0.22222222222222
40546, 0.56521739130435, 0.82826086956522, 0.27777777777778
40547, 0.56521739130435, 0.82826086956522, 0.33333333333333
40548, 0.56521739130435, 0.82826086956522, 0.38888888888889
40549, 0.56521739130435, 0.82826086956522, 0.44444444444444
40550, 0.52173913043478, 0.82826086956522, 0.055555555555556
40551, 0.52173913043478, 0.82826086956522, 0.11111111111111
40552, 0.52173913043478, 0.82826086956522, 0.16666666666667
40553, 0.52173913043478, 0.82826086956522, 0.22222222222222
40554, 0.52173913043478, 0.82826086956522, 0.27777777777778
40555, 0.52173913043478, 0.82826086956522, 0.33333333333333
40556, 0.52173913043478, 0.82826086956522, 0.38888888888889
40557, 0.52173913043478, 0.82826086956522, 0.44444444444444
40558, 0.47826086956522, 0.82826086956522, 0.055555555555556
40559, 0.47826086956522, 0.82826086956522, 0.11111111111111
40560, 0.47826086956522, 0.82826086956522, 0.16666666666667
40561, 0.47826086956522, 0.82826086956522, 0.22222222222222
40562, 0.47826086956522, 0.82826086956522, 0.27777777777778
40563, 0.47826086956522, 0.82826086956522, 0.33333333333333
40564, 0.47826086956522, 0.82826086956522, 0.38888888888889
40565, 0.47826086956522, 0.82826086956522, 0.44444444444444
40566, 0.43478260869565, 0.82826086956522, 0.055555555555556
40567, 0.43478260869565, 0.82826086956522, 0.11111111111111
40568, 0.43478260869565, 0.82826086956522, 0.16666666666667
40569, 0.43478260869565, 0.82826086956522, 0.22222222222222
40570, 0.43478260869565, 0.82826086956522, 0.27777777777778
40571, 0.43478260869565, 0.82826086956522, 0.33333333333333
40572, 0.43478260869565, 0.82826086956522, 0.38888888888889
40573, 0.43478260869565, 0.82826086956522, 0.44444444444444
40574, 0.39130434782609, 0.82826086956522, 0.055555555555556
40575, 0.39130434782609, 0.82826086956522, 0.11111111111111
40576, 0.39130434782609, 0.82826086956522, 0.16666666666667
40577, 0.39130434782609, 0.82826086956522, 0.22222222222222
40578, 0.39130434782609, 0.82826086956522, 0.27777777777778
40579, 0.39130434782609, 0.82826086956522, 0.33333333333333
40580, 0.39130434782609, 0.82826086956522, 0.38888888888889
40581, 0.39130434782609, 0.82826086956522, 0.44444444444444
40582, 0.34782608695652, 0.82826086956522, 0.055555555555556
40583, 0.34782608695652, 0.82826086956522, 0.11111111111111
40584, 0.34782608695652, 0.82826086956522, 0.16666666666667
40585, 0.34782608695652, 0.82826086956522, 0.22222222222222
40586, 0.34782608695652, 0.82826086956522, 0.27777777777778
40587, 0.34782608695652, 0.82826086956522, 0.33333333333333
40588, 0.34782608695652, 0.82826086956522, 0.38888888888889
40589, 0.34782608695652, 0.82826086956522, 0.44444444444444
40590, 0.30434782608696, 0.82826086956522, 0.055555555555556
40591, 0.30434782608696, 0.82826086956522, 0.11111111111111
40592, 0.30434782608696, 0.82826086956522, 0.16666666666667
40593, 0.30434782608696, 0.82826086956522, 0.22222222222222
40594, 0.30434782608696, 0.82826086956522, 0.27777777777778
40595, 0.30434782608696, 0.82826086956522, 0.33333333333333
40596, 0.30434782608696, 0.82826086956522, 0.38888888888889
40597, 0.30434782608696, 0.82826086956522, 0.44444444444444
40598, 0.26086956521739, 0.82826086956522, 0.055555555555556
40599, 0.26086956521739, 0.82826086956522, 0.11111111111111
40600, 0.26086956521739, 0.82826086956522, 0.16666666666667
40601, 0.26086956521739, 0.82826086956522, 0.22222222222222
40602, 0.26086956521739, 0.82826086956522, 0.27777777777778
40603, 0.26086956521739, 0.82826086956522, 0.33333333333333
40604, 0.26086956521739, 0.82826086956522, 0.38888888888889
40605, 0.26086956521739, 0.82826086956522, 0.44444444444444
40606, 0.21739130434783, 0.82826086956522, 0.055555555555556
40607, 0.21739130434783, 0.82826086956522, 0.11111111111111
40608, 0.21739130434783, 0.82826086956522, 0.16666666666667
40609, 0.21739130434783, 0.82826086956522, 0.22222222222222
40610, 0.21739130434783, 0.82826086956522, 0.27777777777778
40611, 0.21739130434783, 0.82826086956522, 0.33333333333333
40612, 0.21739130434783, 0.82826086956522, 0.38888888888889
40613, 0.21739130434783, 0.82826086956522, 0.44444444444444
40614, 0.17391304347826, 0.82826086956522, 0.055555555555556
40615, 0.17391304347826, 0.82826086956522, 0.11111111111111
40616, 0.17391304347826, 0.82826086956522, 0.16666666666667
40617, 0.17391304347826, 0.82826086956522, 0.22222222222222
40618, 0.17391304347826, 0.82826086956522, 0.27777777777778
40619, 0.17391304347826, 0.82826086956522, 0.33333333333333
40620, 0.17391304347826, 0.82826086956522, 0.38888888888889
40621, 0.17391304347826, 0.82826086956522, 0.44444444444444
40622, 0.1304347826087, 0.82826086956522, 0.055555555555556
40623, 0.1304347826087, 0.82826086956522, 0.11111111111111
40624, 0.1304347826087, 0.82826086956522, 0.16666666666667
40625, 0.1304347826087, 0.82826086956522, 0.22222222222222
40626, 0.1304347826087, 0.82826086956522, 0.27777777777778
40627, 0.1304347826087, 0.82826086956522, 0.33333333333333
40628, 0.1304347826087, 0.82826086956522, 0.38888888888889
40629, 0.1304347826087, 0.82826086956522, 0.44444444444444
40630, 0.08695652173913, 0.82826086956522, 0.055555555555556
40631, 0.08695652173913, 0.82826086956522, 0.11111111111111
40632, 0.08695652173913, 0.82826086956522, 0.16666666666667
40633, 0.08695652173913, 0.82826086956522, 0.22222222222222
40634, 0.08695652173913, 0.82826086956522, 0.27777777777778
40635, 0.08695652173913, 0.82826086956522, 0.33333333333333
40636, 0.08695652173913, 0.82826086956522, 0.38888888888889
40637, 0.08695652173913, 0.82826086956522, 0.44444444444444
40638, 0.043478260869565, 0.82826086956522, 0.055555555555556
40639, 0.043478260869565, 0.82826086956522, 0.11111111111111
40640, 0.043478260869565, 0.82826086956522, 0.16666666666667
40641, 0.043478260869565, 0.82826086956522, 0.22222222222222
40642, 0.043478260869565, 0.82826086956522, 0.27777777777778
40643, 0.043478260869565, 0.82826086956522, 0.33333333333333
40644, 0.043478260869565, 0.82826086956522, 0.38888888888889
40645, 0.043478260869565, 0.82826086956522, 0.44444444444444
40646, 0.95652173913043, 0.88043478260869, 0.055555555555556
40647, 0.95652173913044, 0.88043478260869, 0.11111111111111
40648, 0.95652173913044, 0.8804347826087, 0.16666666666667
40649, 0.95652173913044, 0.8804347826087, 0.22222222222222
40650, 0.95652173913044, 0.88043478260869, 0.27777777777778
40651, 0.95652173913044, 0.8804347826087, 0.33333333333333
40652, 0.95652173913044, 0.88043478260869, 0.38888888888889
40653, 0.95652173913044, 0.88043478260869, 0.44444444444444
40654, 0.91304347826087, 0.8804347826087, 0.055555555555556
40655, 0.91304347826087, 0.88043478260869, 0.11111111111111
40656, 0.91304347826087, 0.8804347826087, 0.16666666666667
40657, 0.91304347826087, 0.8804347826087, 0.22222222222222
40658, 0.91304347826087, 0.8804347826087, 0.27777777777778
40659, 0.91304347826087, 0.88043478260869, 0.33333333333333
40660, 0.91304347826087, 0.88043478260869, 0.38888888888889
40661, 0.91304347826087, 0.8804347826087, 0.44444444444444
40662, 0.8695652173913, 0.88043478260869, 0.055555555555556
40663, 0.8695652173913, 0.88043478260869, 0.11111111111111
40664, 0.8695652173913, 0.8804347826087, 0.16666666666667
40665, 0.8695652173913, 0.88043478260869, 0.22222222222222
40666, 0.8695652173913, 0.8804347826087, 0.27777777777778
40667, 0.8695652173913, 0.8804347826087, 0.33333333333333
40668, 0.8695652173913, 0.88043478260869, 0.38888888888889
40669, 0.8695652173913, 0.88043478260869, 0.44444444444444
40670, 0.82608695652174, 0.8804347826087, 0.055555555555556
40671, 0.82608695652174, 0.8804347826087, 0.11111111111111
40672, 0.82608695652174, 0.8804347826087, 0.16666666666667
40673, 0.82608695652174, 0.8804347826087, 0.22222222222222
40674, 0.82608695652174, 0.8804347826087, 0.27777777777778
40675, 0.82608695652174, 0.8804347826087, 0.33333333333333
40676, 0.82608695652174, 0.8804347826087, 0.38888888888889
40677, 0.82608695652174, 0.8804347826087, 0.44444444444444
40678, 0.78260869565217, 0.88043478260869, 0.055555555555556
40679, 0.78260869565217, 0.88043478260869, 0.11111111111111
40680, 0.78260869565217, 0.88043478260869, 0.16666666666667
40681, 0.78260869565217, 0.8804347826087, 0.22222222222222
40682, 0.78260869565217, 0.88043478260869, 0.27777777777778
40683, 0.78260869565217, 0.88043478260869, 0.33333333333333
40684, 0.78260869565217, 0.8804347826087, 0.38888888888889
40685, 0.78260869565217, 0.88043478260869, 0.44444444444444
40686, 0.73913043478261, 0.8804347826087, 0.055555555555556
40687, 0.73913043478261, 0.8804347826087, 0.11111111111111
40688, 0.73913043478261, 0.88043478260869, 0.16666666666667
40689, 0.73913043478261, 0.88043478260869, 0.22222222222222
40690, 0.73913043478261, 0.88043478260869, 0.27777777777778
40691, 0.73913043478261, 0.88043478260869, 0.33333333333333
40692, 0.73913043478261, 0.88043478260869, 0.38888888888889
40693, 0.73913043478261, 0.8804347826087, 0.44444444444444
40694, 0.69565217391304, 0.88043478260869, 0.055555555555556
40695, 0.69565217391304, 0.88043478260869, 0.11111111111111
40696, 0.69565217391304, 0.88043478260869, 0.16666666666667
40697, 0.69565217391304, 0.8804347826087, 0.22222222222222
40698, 0.69565217391304, 0.8804347826087, 0.27777777777778
40699, 0.69565217391304, 0.8804347826087, 0.33333333333333
40700, 0.69565217391304, 0.88043478260869, 0.38888888888889
40701, 0.69565217391304, 0.88043478260869, 0.44444444444444
40702, 0.65217391304348, 0.8804347826087, 0.055555555555556
40703, 0.65217391304348, 0.8804347826087, 0.11111111111111
40704, 0.65217391304348, 0.8804347826087, 0.16666666666667
40705, 0.65217391304348, 0.8804347826087, 0.22222222222222
40706, 0.65217391304348, 0.8804347826087, 0.27777777777778
40707, 0.65217391304348, 0.8804347826087, 0.33333333333333
40708, 0.65217391304348, 0.8804347826087, 0.38888888888889
40709, 0.65217391304348, 0.8804347826087, 0.44444444444444
40710, 0.60869565217391, 0.8804347826087, 0.055555555555556
40711, 0.60869565217391, 0.8804347826087, 0.11111111111111
40712, 0.60869565217391, 0.8804347826087, 0.16666666666667
40713, 0.60869565217391, 0.8804347826087, 0.22222222222222
40714, 0.60869565217391, 0.8804347826087, 0.27777777777778
40715, 0.60869565217391, 0.8804347826087, 0.33333333333333
40716, 0.60869565217391, 0.8804347826087, 0.38888888888889
40717, 0.60869565217391, 0.8804347826087, 0.44444444444444
40718, 0.56521739130435, 0.88043478260869, 0.055555555555556
40719, 0.56521739130435, 0.88043478260869, 0.11111111111111
40720, 0.56521739130435, 0.8804347826087, 0.16666666666667
40721, 0.56521739130435, 0.88043478260869, 0.22222222222222
40722, 0.56521739130435, 0.88043478260869, 0.27777777777778
40723, 0.56521739130435, 0.8804347826087, 0.33333333333333
40724, 0.56521739130435, 0.88043478260869, 0.38888888888889
40725, 0.56521739130435, 0.88043478260869, 0.44444444444444
40726, 0.52173913043478, 0.88043478260869, 0.055555555555556
40727, 0.52173913043478, 0.88043478260869, 0.11111111111111
40728, 0.52173913043478, 0.88043478260869, 0.16666666666667
40729, 0.52173913043478, 0.88043478260869, 0.22222222222222
40730, 0.52173913043478, 0.88043478260869, 0.27777777777778
40731, 0.52173913043478, 0.8804347826087, 0.33333333333333
40732, 0.52173913043478, 0.88043478260869, 0.38888888888889
40733, 0.52173913043478, 0.88043478260869, 0.44444444444444
40734, 0.47826086956522, 0.88043478260869, 0.055555555555556
40735, 0.47826086956522, 0.88043478260869, 0.11111111111111
40736, 0.47826086956522, 0.88043478260869, 0.16666666666667
40737, 0.47826086956522, 0.88043478260869, 0.22222222222222
40738, 0.47826086956522, 0.88043478260869, 0.27777777777778
40739, 0.47826086956522, 0.88043478260869, 0.33333333333333
40740, 0.47826086956522, 0.88043478260869, 0.38888888888889
40741, 0.47826086956522, 0.88043478260869, 0.44444444444444
40742, 0.43478260869565, 0.88043478260869, 0.055555555555556
40743, 0.43478260869565, 0.88043478260869, 0.11111111111111
40744, 0.43478260869565, 0.88043478260869, 0.16666666666667
40745, 0.43478260869565, 0.88043478260869, 0.22222222222222
40746, 0.43478260869565, 0.88043478260869, 0.27777777777778
40747, 0.43478260869565, 0.88043478260869, 0.33333333333333
40748, 0.43478260869565, 0.88043478260869, 0.38888888888889
40749, 0.43478260869565, 0.88043478260869, 0.44444444444444
40750, 0.39130434782609, 0.88043478260869, 0.055555555555556
40751, 0.39130434782609, 0.88043478260869, 0.11111111111111
40752, 0.39130434782609, 0.8804347826087, 0.16666666666667
40753, 0.39130434782609, 0.88043478260869, 0.22222222222222
40754, 0.39130434782609, 0.88043478260869, 0.27777777777778
40755, 0.39130434782609, 0.88043478260869, 0.33333333333333
40756, 0.39130434782609, 0.88043478260869, 0.38888888888889
40757, 0.39130434782609, 0.88043478260869, 0.44444444444444
40758, 0.34782608695652, 0.88043478260869, 0.055555555555556
40759, 0.34782608695652, 0.8804347826087, 0.11111111111111
40760, 0.34782608695652, 0.88043478260869, 0.16666666666667
40761, 0.34782608695652, 0.8804347826087, 0.22222222222222
40762, 0.34782608695652, 0.8804347826087, 0.27777777777778
40763, 0.34782608695652, 0.88043478260869, 0.33333333333333
40764, 0.34782608695652, 0.8804347826087, 0.38888888888889
40765, 0.34782608695652, 0.88043478260869, 0.44444444444444
40766, 0.30434782608696, 0.88043478260869, 0.055555555555556
40767, 0.30434782608696, 0.88043478260869, 0.11111111111111
40768, 0.30434782608696, 0.88043478260869, 0.16666666666667
40769, 0.30434782608696, 0.88043478260869, 0.22222222222222
40770, 0.30434782608696, 0.88043478260869, 0.27777777777778
40771, 0.30434782608696, 0.8804347826087, 0.33333333333333
40772, 0.30434782608696, 0.88043478260869, 0.38888888888889
40773, 0.30434782608696, 0.88043478260869, 0.44444444444444
40774, 0.26086956521739, 0.88043478260869, 0.055555555555556
40775, 0.26086956521739, 0.88043478260869, 0.11111111111111
40776, 0.26086956521739, 0.88043478260869, 0.16666666666667
40777, 0.26086956521739, 0.88043478260869, 0.22222222222222
40778, 0.26086956521739, 0.88043478260869, 0.27777777777778
40779, 0.26086956521739, 0.8804347826087, 0.33333333333333
40780, 0.26086956521739, 0.88043478260869, 0.38888888888889
40781, 0.26086956521739, 0.88043478260869, 0.44444444444444
40782, 0.21739130434783, 0.88043478260869, 0.055555555555556
40783, 0.21739130434783, 0.88043478260869, 0.11111111111111
40784, 0.21739130434783, 0.88043478260869, 0.16666666666667
40785, 0.21739130434783, 0.88043478260869, 0.22222222222222
40786, 0.21739130434783, 0.88043478260869, 0.27777777777778
40787, 0.21739130434783, 0.88043478260869, 0.33333333333333
40788, 0.21739130434783, 0.88043478260869, 0.38888888888889
40789, 0.21739130434783, 0.88043478260869, 0.44444444444444
40790, 0.17391304347826, 0.8804347826087, 0.055555555555556
40791, 0.17391304347826, 0.88043478260869, 0.11111111111111
40792, 0.17391304347826, 0.8804347826087, 0.16666666666667
40793, 0.17391304347826, 0.88043478260869, 0.22222222222222
40794, 0.17391304347826, 0.88043478260869, 0.27777777777778
40795, 0.17391304347826, 0.88043478260869, 0.33333333333333
40796, 0.17391304347826, 0.88043478260869, 0.38888888888889
40797, 0.17391304347826, 0.88043478260869, 0.44444444444444
40798, 0.1304347826087, 0.8804347826087, 0.055555555555556
40799, 0.1304347826087, 0.88043478260869, 0.11111111111111
40800, 0.1304347826087, 0.8804347826087, 0.16666666666667
40801, 0.1304347826087, 0.88043478260869, 0.22222222222222
40802, 0.1304347826087, 0.88043478260869, 0.27777777777778
40803, 0.1304347826087, 0.88043478260869, 0.33333333333333
40804, 0.1304347826087, 0.88043478260869, 0.38888888888889
40805, 0.1304347826087, 0.88043478260869, 0.44444444444444
40806, 0.08695652173913, 0.8804347826087, 0.055555555555556
40807, 0.08695652173913, 0.8804347826087, 0.11111111111111
40808, 0.08695652173913, 0.8804347826087, 0.16666666666667
40809, 0.08695652173913, 0.8804347826087, 0.22222222222222
40810, 0.08695652173913, 0.88043478260869, 0.27777777777778
40811, 0.08695652173913, 0.8804347826087, 0.33333333333333
40812, 0.08695652173913, 0.8804347826087, 0.38888888888889
40813, 0.08695652173913, 0.8804347826087, 0.44444444444444
40814, 0.043478260869565, 0.88043478260869, 0.055555555555556
40815, 0.043478260869565, 0.88043478260869, 0.11111111111111
40816, 0.043478260869565, 0.8804347826087, 0.16666666666667
40817, 0.043478260869565, 0.88043478260869, 0.22222222222222
40818, 0.043478260869565, 0.88043478260869, 0.27777777777778
40819, 0.043478260869565, 0.88043478260869, 0.33333333333333
40820, 0.043478260869565, 0.88043478260869, 0.38888888888889
40821, 0.043478260869565, 0.88043478260869, 0.44444444444444
40822, 0.95652173913043, 0.93260869565217, 0.055555555555556
40823, 0.95652173913044, 0.93260869565217, 0.11111111111111
40824, 0.95652173913043, 0.93260869565217, 0.16666666666667
40825, 0.95652173913044, 0.93260869565217, 0.22222222222222
40826, 0.95652173913044, 0.93260869565217, 0.27777777777778
40827, 0.95652173913044, 0.93260869565217, 0.33333333333333
40828, 0.95652173913044, 0.93260869565217, 0.38888888888889
40829, 0.95652173913044, 0.93260869565217, 0.44444444444444
40830, 0.91304347826087, 0.93260869565217, 0.055555555555556
40831, 0.91304347826087, 0.93260869565217, 0.11111111111111
40832, 0.91304347826087, 0.93260869565217, 0.16666666666667
40833, 0.91304347826087, 0.93260869565217, 0.22222222222222
40834, 0.91304347826087, 0.93260869565217, 0.27777777777778
40835, 0.91304347826087, 0.93260869565217, 0.33333333333333
40836, 0.91304347826087, 0.93260869565217, 0.38888888888889
40837, 0.91304347826087, 0.93260869565217, 0.44444444444444
40838, 0.8695652173913, 0.93260869565217, 0.055555555555556
40839, 0.8695652173913, 0.93260869565217, 0.11111111111111
40840, 0.8695652173913, 0.93260869565217, 0.16666666666667
40841, 0.8695652173913, 0.93260869565217, 0.22222222222222
40842, 0.8695652173913, 0.93260869565217, 0.27777777777778
40843, 0.8695652173913, 0.93260869565217, 0.33333333333333
40844, 0.8695652173913, 0.93260869565217, 0.38888888888889
40845, 0.8695652173913, 0.93260869565217, 0.44444444444444
40846, 0.82608695652174, 0.93260869565217, 0.055555555555556
40847, 0.82608695652174, 0.93260869565217, 0.11111111111111
40848, 0.82608695652174, 0.93260869565217, 0.16666666666667
40849, 0.82608695652174, 0.93260869565217, 0.22222222222222
40850, 0.82608695652174, 0.93260869565217, 0.27777777777778
40851, 0.82608695652174, 0.93260869565217, 0.33333333333333
40852, 0.82608695652174, 0.93260869565217, 0.38888888888889
40853, 0.82608695652174, 0.93260869565217, 0.44444444444444
40854, 0.78260869565217, 0.93260869565217, 0.055555555555556
40855, 0.78260869565217, 0.93260869565217, 0.11111111111111
40856, 0.78260869565217, 0.93260869565217, 0.16666666666667
40857, 0.78260869565217, 0.93260869565217, 0.22222222222222
40858, 0.78260869565217, 0.93260869565217, 0.27777777777778
40859, 0.78260869565217, 0.93260869565217, 0.33333333333333
40860, 0.78260869565217, 0.93260869565217, 0.38888888888889
40861, 0.78260869565217, 0.93260869565217, 0.44444444444444
40862, 0.73913043478261, 0.93260869565217, 0.055555555555556
40863, 0.73913043478261, 0.93260869565217, 0.11111111111111
40864, 0.73913043478261, 0.93260869565217, 0.16666666666667
40865, 0.73913043478261, 0.93260869565217, 0.22222222222222
40866, 0.73913043478261, 0.93260869565217, 0.27777777777778
40867, 0.73913043478261, 0.93260869565217, 0.33333333333333
40868, 0.73913043478261, 0.93260869565217, 0.38888888888889
40869, 0.73913043478261, 0.93260869565217, 0.44444444444444
40870, 0.69565217391304, 0.93260869565217, 0.055555555555556
40871, 0.69565217391304, 0.93260869565217, 0.11111111111111
40872, 0.69565217391304, 0.93260869565217, 0.16666666666667
40873, 0.69565217391304, 0.93260869565217, 0.22222222222222
40874, 0.69565217391304, 0.93260869565217, 0.27777777777778
40875, 0.69565217391304, 0.93260869565217, 0.33333333333333
40876, 0.69565217391304, 0.93260869565217, 0.38888888888889
40877, 0.69565217391304, 0.93260869565217, 0.44444444444444
40878, 0.65217391304348, 0.93260869565217, 0.055555555555556
40879, 0.65217391304348, 0.93260869565217, 0.11111111111111
40880, 0.65217391304348, 0.93260869565217, 0.16666666666667
40881, 0.65217391304348, 0.93260869565217, 0.22222222222222
40882, 0.65217391304348, 0.93260869565217, 0.27777777777778
40883, 0.65217391304348, 0.93260869565217, 0.33333333333333
40884, 0.65217391304348, 0.93260869565217, 0.38888888888889
40885, 0.65217391304348, 0.93260869565217, 0.44444444444444
40886, 0.60869565217391, 0.93260869565217, 0.055555555555556
40887, 0.60869565217391, 0.93260869565217, 0.11111111111111
40888, 0.60869565217391, 0.93260869565217, 0.16666666666667
40889, 0.60869565217391, 0.93260869565217, 0.22222222222222
40890, 0.60869565217391, 0.93260869565217, 0.27777777777778
40891, 0.60869565217391, 0.93260869565217, 0.33333333333333
40892, 0.60869565217391, 0.93260869565217, 0.38888888888889
40893, 0.60869565217391, 0.93260869565217, 0.44444444444444
40894, 0.56521739130435, 0.93260869565217, 0.055555555555556
40895, 0.56521739130435, 0.93260869565217, 0.11111111111111
40896, 0.56521739130435, 0.93260869565217, 0.16666666666667
40897, 0.56521739130435, 0.93260869565217, 0.22222222222222
40898, 0.56521739130435, 0.93260869565217, 0.27777777777778
40899, 0.56521739130435, 0.93260869565217, 0.33333333333333
40900, 0.56521739130435, 0.93260869565217, 0.38888888888889
40901, 0.56521739130435, 0.93260869565217, 0.44444444444444
40902, 0.52173913043478, 0.93260869565217, 0.055555555555556
40903, 0.52173913043478, 0.93260869565217, 0.11111111111111
40904, 0.52173913043478, 0.93260869565217, 0.16666666666667
40905, 0.52173913043478, 0.93260869565217, 0.22222222222222
40906, 0.52173913043478, 0.93260869565217, 0.27777777777778
40907, 0.52173913043478, 0.93260869565217, 0.33333333333333
40908, 0.52173913043478, 0.93260869565217, 0.38888888888889
40909, 0.52173913043478, 0.93260869565217, 0.44444444444444
40910, 0.47826086956522, 0.93260869565217, 0.055555555555556
40911, 0.47826086956522, 0.93260869565217, 0.11111111111111
40912, 0.47826086956522, 0.93260869565217, 0.16666666666667
40913, 0.47826086956522, 0.93260869565217, 0.22222222222222
40914, 0.47826086956522, 0.93260869565217, 0.27777777777778
40915, 0.47826086956522, 0.93260869565217, 0.33333333333333
40916, 0.47826086956522, 0.93260869565217, 0.38888888888889
40917, 0.47826086956522, 0.93260869565217, 0.44444444444444
40918, 0.43478260869565, 0.93260869565217, 0.055555555555556
40919, 0.43478260869565, 0.93260869565217, 0.11111111111111
40920, 0.43478260869565, 0.93260869565217, 0.16666666666667
40921, 0.43478260869565, 0.93260869565217, 0.22222222222222
40922, 0.43478260869565, 0.93260869565217, 0.27777777777778
40923, 0.43478260869565, 0.93260869565217, 0.33333333333333
40924, 0.43478260869565, 0.93260869565217, 0.38888888888889
40925, 0.43478260869565, 0.93260869565217, 0.44444444444444
40926, 0.39130434782609, 0.93260869565217, 0.055555555555556
40927, 0.39130434782609, 0.93260869565217, 0.11111111111111
40928, 0.39130434782609, 0.93260869565217, 0.16666666666667
40929, 0.39130434782609, 0.93260869565217, 0.22222222222222
40930, 0.39130434782609, 0.93260869565217, 0.27777777777778
40931, 0.39130434782609, 0.93260869565217, 0.33333333333333
40932, 0.39130434782609, 0.93260869565217, 0.38888888888889
40933, 0.39130434782609, 0.93260869565217, 0.44444444444444
40934, 0.34782608695652, 0.93260869565217, 0.055555555555556
40935, 0.34782608695652, 0.93260869565217, 0.11111111111111
40936, 0.34782608695652, 0.93260869565217, 0.16666666666667
40937, 0.34782608695652, 0.93260869565217, 0.22222222222222
40938, 0.34782608695652, 0.93260869565217, 0.27777777777778
40939, 0.34782608695652, 0.93260869565217, 0.33333333333333
40940, 0.34782608695652, 0.93260869565217, 0.38888888888889
40941, 0.34782608695652, 0.93260869565217, 0.44444444444444
40942, 0.30434782608696, 0.93260869565217, 0.055555555555556
40943, 0.30434782608696, 0.93260869565217, 0.11111111111111
40944, 0.30434782608696, 0.93260869565217, 0.16666666666667
40945, 0.30434782608696, 0.93260869565217, 0.22222222222222
40946, 0.30434782608696, 0.93260869565217, 0.27777777777778
40947, 0.30434782608696, 0.93260869565217, 0.33333333333333
40948, 0.30434782608696, 0.93260869565217, 0.38888888888889
40949, 0.30434782608696, 0.93260869565217, 0.44444444444444
40950, 0.26086956521739, 0.93260869565217, 0.055555555555556
40951, 0.26086956521739, 0.93260869565217, 0.11111111111111
40952, 0.26086956521739, 0.93260869565217, 0.16666666666667
40953, 0.26086956521739, 0.93260869565217, 0.22222222222222
40954, 0.26086956521739, 0.93260869565217, 0.27777777777778
40955, 0.26086956521739, 0.93260869565217, 0.33333333333333
40956, 0.26086956521739, 0.93260869565217, 0.38888888888889
40957, 0.26086956521739, 0.93260869565217, 0.44444444444444
40958, 0.21739130434783, 0.93260869565217, 0.055555555555556
40959, 0.21739130434783, 0.93260869565217, 0.11111111111111
40960, 0.21739130434783, 0.93260869565217, 0.16666666666667
40961, 0.21739130434783, 0.93260869565217, 0.22222222222222
40962, 0.21739130434783, 0.93260869565217, 0.27777777777778
40963, 0.21739130434783, 0.93260869565217, 0.33333333333333
40964, 0.21739130434783, 0.93260869565217, 0.38888888888889
40965, 0.21739130434783, 0.93260869565217, 0.44444444444444
40966, 0.17391304347826, 0.93260869565217, 0.055555555555556
40967, 0.17391304347826, 0.93260869565217, 0.11111111111111
40968, 0.17391304347826, 0.93260869565217, 0.16666666666667
40969, 0.17391304347826, 0.93260869565217, 0.22222222222222
40970, 0.17391304347826, 0.93260869565217, 0.27777777777778
40971, 0.17391304347826, 0.93260869565217, 0.33333333333333
40972, 0.17391304347826, 0.93260869565217, 0.38888888888889
40973, 0.17391304347826, 0.93260869565217, 0.44444444444444
40974, 0.1304347826087, 0.93260869565217, 0.055555555555556
40975, 0.1304347826087, 0.93260869565217, 0.11111111111111
40976, 0.1304347826087, 0.93260869565217, 0.16666666666667
40977, 0.1304347826087, 0.93260869565217, 0.22222222222222
40978, 0.1304347826087, 0.93260869565217, 0.27777777777778
40979, 0.1304347826087, 0.93260869565217, 0.33333333333333
40980, 0.1304347826087, 0.93260869565217, 0.38888888888889
40981, 0.1304347826087, 0.93260869565217, 0.44444444444444
40982, 0.08695652173913, 0.93260869565217, 0.055555555555556
40983, 0.08695652173913, 0.93260869565217, 0.11111111111111
40984, 0.08695652173913, 0.93260869565217, 0.16666666666667
40985, 0.08695652173913, 0.93260869565217, 0.22222222222222
40986, 0.08695652173913, 0.93260869565217, 0.27777777777778
40987, 0.08695652173913, 0.93260869565217, 0.33333333333333
40988, 0.08695652173913, 0.93260869565217, 0.38888888888889
40989, 0.08695652173913, 0.93260869565217, 0.44444444444444
40990, 0.043478260869565, 0.93260869565217, 0.055555555555556
40991, 0.043478260869565, 0.93260869565217, 0.11111111111111
40992, 0.043478260869565, 0.93260869565217, 0.16666666666667
40993, 0.043478260869565, 0.93260869565217, 0.22222222222222
40994, 0.043478260869565, 0.93260869565217, 0.27777777777778
40995, 0.043478260869565, 0.93260869565217, 0.33333333333333
40996, 0.043478260869565, 0.93260869565217, 0.38888888888889
40997, 0.043478260869565, 0.93260869565217, 0.44444444444444
40998, 0.95652173913043, 0.98478260869565, 0.055555555555556
40999, 0.95652173913044, 0.98478260869565, 0.11111111111111
41000, 0.95652173913044, 0.98478260869565, 0.16666666666667
41001, 0.95652173913044, 0.98478260869565, 0.22222222222222
41002, 0.95652173913044, 0.98478260869565, 0.27777777777778
41003, 0.95652173913044, 0.98478260869565, 0.33333333333333
41004, 0.95652173913043, 0.98478260869565, 0.38888888888889
41005, 0.95652173913044, 0.98478260869565, 0.44444444444444
41006, 0.91304347826087, 0.98478260869565, 0.055555555555556
41007, 0.91304347826087, 0.98478260869565, 0.11111111111111
41008, 0.91304347826087, 0.98478260869565, 0.16666666666667
41009, 0.91304347826087, 0.98478260869565, 0.22222222222222
41010, 0.91304347826087, 0.98478260869565, 0.27777777777778
41011, 0.91304347826087, 0.98478260869565, 0.33333333333333
41012, 0.91304347826087, 0.98478260869565, 0.38888888888889
41013, 0.91304347826087, 0.98478260869565, 0.44444444444444
41014, 0.8695652173913, 0.98478260869565, 0.055555555555556
41015, 0.8695652173913, 0.98478260869565, 0.11111111111111
41016, 0.8695652173913, 0.98478260869565, 0.16666666666667
41017, 0.8695652173913, 0.98478260869565, 0.22222222222222
41018, 0.8695652173913, 0.98478260869565, 0.27777777777778
41019, 0.8695652173913, 0.98478260869565, 0.33333333333333
41020, 0.8695652173913, 0.98478260869565, 0.38888888888889
41021, 0.8695652173913, 0.98478260869565, 0.44444444444444
41022, 0.82608695652174, 0.98478260869565, 0.055555555555556
41023, 0.82608695652174, 0.98478260869565, 0.11111111111111
41024, 0.82608695652174, 0.98478260869565, 0.16666666666667
41025, 0.82608695652174, 0.98478260869565, 0.22222222222222
41026, 0.82608695652174, 0.98478260869565, 0.27777777777778
41027, 0.82608695652174, 0.98478260869565, 0.33333333333333
41028, 0.82608695652174, 0.98478260869565, 0.38888888888889
41029, 0.82608695652174, 0.98478260869565, 0.44444444444444
41030, 0.78260869565217, 0.98478260869565, 0.055555555555556
41031, 0.78260869565217, 0.98478260869565, 0.11111111111111
41032, 0.78260869565217, 0.98478260869565, 0.16666666666667
41033, 0.78260869565217, 0.98478260869565, 0.22222222222222
41034, 0.78260869565217, 0.98478260869565, 0.27777777777778
41035, 0.78260869565217, 0.98478260869565, 0.33333333333333
41036, 0.78260869565217, 0.98478260869565, 0.38888888888889
41037, 0.78260869565217, 0.98478260869565, 0.44444444444444
41038, 0.73913043478261, 0.98478260869565, 0.055555555555556
41039, 0.73913043478261, 0.98478260869565, 0.11111111111111
41040, 0.73913043478261, 0.98478260869565, 0.16666666666667
41041, 0.73913043478261, 0.98478260869565, 0.22222222222222
