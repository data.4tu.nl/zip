85700, 0.21739130434783, -0.125, 0.055555555555556
85701, 0.21739130434783, -0.15, 0.083333333333333
85702, 0.23913043478261, -0.15, 0.11111111111111
85703, 0.21739130434783, -0.125, 0.11111111111111
85704, 0.21739130434783, -0.15, 0.13888888888889
85705, 0.23913043478261, -0.15, 0.16666666666667
85706, 0.21739130434783, -0.125, 0.16666666666667
85707, 0.21739130434783, -0.15, 0.19444444444444
85708, 0.23913043478261, -0.15, 0.22222222222222
85709, 0.21739130434783, -0.125, 0.22222222222222
85710, 0.21739130434783, -0.15, 0.25
85711, 0.23913043478261, -0.15, 0.27777777777778
85712, 0.21739130434783, -0.125, 0.27777777777778
85713, 0.21739130434783, -0.15, 0.30555555555556
85714, 0.23913043478261, -0.15, 0.33333333333333
85715, 0.21739130434783, -0.125, 0.33333333333333
85716, 0.21739130434783, -0.15, 0.36111111111111
85717, 0.23913043478261, -0.15, 0.38888888888889
85718, 0.21739130434783, -0.125, 0.38888888888889
85719, 0.21739130434783, -0.15, 0.41666666666667
85720, 0.23913043478261, -0.15, 0.44444444444444
85721, 0.21739130434783, -0.125, 0.44444444444444
85722, 0.21739130434783, -0.15, 0.47222222222222
85723, 0.17391304347826, -0.15, 0.027777777777778
85724, 0.19565217391304, -0.15, 0.055555555555556
85725, 0.17391304347826, -0.125, 0.055555555555556
85726, 0.17391304347826, -0.15, 0.083333333333333
85727, 0.19565217391304, -0.15, 0.11111111111111
85728, 0.17391304347826, -0.125, 0.11111111111111
85729, 0.17391304347826, -0.15, 0.13888888888889
85730, 0.19565217391304, -0.15, 0.16666666666667
85731, 0.17391304347826, -0.125, 0.16666666666667
85732, 0.17391304347826, -0.15, 0.19444444444444
85733, 0.19565217391304, -0.15, 0.22222222222222
85734, 0.17391304347826, -0.125, 0.22222222222222
85735, 0.17391304347826, -0.15, 0.25
85736, 0.19565217391304, -0.15, 0.27777777777778
85737, 0.17391304347826, -0.125, 0.27777777777778
85738, 0.17391304347826, -0.15, 0.30555555555556
85739, 0.19565217391304, -0.15, 0.33333333333333
85740, 0.17391304347826, -0.125, 0.33333333333333
85741, 0.17391304347826, -0.15, 0.36111111111111
85742, 0.19565217391304, -0.15, 0.38888888888889
85743, 0.17391304347826, -0.125, 0.38888888888889
85744, 0.17391304347826, -0.15, 0.41666666666667
85745, 0.19565217391304, -0.15, 0.44444444444444
85746, 0.17391304347826, -0.125, 0.44444444444444
85747, 0.17391304347826, -0.15, 0.47222222222222
85748, 0.1304347826087, -0.15, 0.027777777777778
85749, 0.15217391304348, -0.15, 0.055555555555556
85750, 0.1304347826087, -0.125, 0.055555555555556
85751, 0.1304347826087, -0.15, 0.083333333333333
85752, 0.15217391304348, -0.15, 0.11111111111111
85753, 0.1304347826087, -0.125, 0.11111111111111
85754, 0.1304347826087, -0.15, 0.13888888888889
85755, 0.15217391304348, -0.15, 0.16666666666667
85756, 0.1304347826087, -0.125, 0.16666666666667
85757, 0.1304347826087, -0.15, 0.19444444444444
85758, 0.15217391304348, -0.15, 0.22222222222222
85759, 0.1304347826087, -0.125, 0.22222222222222
85760, 0.1304347826087, -0.15, 0.25
85761, 0.15217391304348, -0.15, 0.27777777777778
85762, 0.1304347826087, -0.125, 0.27777777777778
85763, 0.1304347826087, -0.15, 0.30555555555556
85764, 0.15217391304348, -0.15, 0.33333333333333
85765, 0.1304347826087, -0.125, 0.33333333333333
85766, 0.1304347826087, -0.15, 0.36111111111111
85767, 0.15217391304348, -0.15, 0.38888888888889
85768, 0.1304347826087, -0.125, 0.38888888888889
85769, 0.1304347826087, -0.15, 0.41666666666667
85770, 0.15217391304348, -0.15, 0.44444444444444
85771, 0.1304347826087, -0.125, 0.44444444444444
85772, 0.1304347826087, -0.15, 0.47222222222222
85773, 0.08695652173913, -0.15, 0.027777777777778
85774, 0.10869565217391, -0.15, 0.055555555555556
85775, 0.08695652173913, -0.125, 0.055555555555556
85776, 0.08695652173913, -0.15, 0.083333333333333
85777, 0.10869565217391, -0.15, 0.11111111111111
85778, 0.08695652173913, -0.125, 0.11111111111111
85779, 0.08695652173913, -0.15, 0.13888888888889
85780, 0.10869565217391, -0.15, 0.16666666666667
85781, 0.08695652173913, -0.125, 0.16666666666667
85782, 0.08695652173913, -0.15, 0.19444444444444
85783, 0.10869565217391, -0.15, 0.22222222222222
85784, 0.08695652173913, -0.125, 0.22222222222222
85785, 0.08695652173913, -0.15, 0.25
85786, 0.10869565217391, -0.15, 0.27777777777778
85787, 0.08695652173913, -0.125, 0.27777777777778
85788, 0.08695652173913, -0.15, 0.30555555555556
85789, 0.10869565217391, -0.15, 0.33333333333333
85790, 0.08695652173913, -0.125, 0.33333333333333
85791, 0.08695652173913, -0.15, 0.36111111111111
85792, 0.10869565217391, -0.15, 0.38888888888889
85793, 0.08695652173913, -0.125, 0.38888888888889
85794, 0.08695652173913, -0.15, 0.41666666666667
85795, 0.10869565217391, -0.15, 0.44444444444444
85796, 0.08695652173913, -0.125, 0.44444444444444
85797, 0.08695652173913, -0.15, 0.47222222222222
85798, 0.043478260869565, -0.15, 0.027777777777778
85799, 0.065217391304348, -0.15, 0.055555555555556
85800, 0.043478260869565, -0.125, 0.055555555555556
85801, 0.043478260869565, -0.15, 0.083333333333333
85802, 0.065217391304348, -0.15, 0.11111111111111
85803, 0.043478260869565, -0.125, 0.11111111111111
85804, 0.043478260869565, -0.15, 0.13888888888889
85805, 0.065217391304348, -0.15, 0.16666666666667
85806, 0.043478260869565, -0.125, 0.16666666666667
85807, 0.043478260869565, -0.15, 0.19444444444444
85808, 0.065217391304348, -0.15, 0.22222222222222
85809, 0.043478260869565, -0.125, 0.22222222222222
85810, 0.043478260869565, -0.15, 0.25
85811, 0.065217391304348, -0.15, 0.27777777777778
85812, 0.043478260869565, -0.125, 0.27777777777778
85813, 0.043478260869565, -0.15, 0.30555555555556
85814, 0.065217391304348, -0.15, 0.33333333333333
85815, 0.043478260869565, -0.125, 0.33333333333333
85816, 0.043478260869565, -0.15, 0.36111111111111
85817, 0.065217391304348, -0.15, 0.38888888888889
85818, 0.043478260869565, -0.125, 0.38888888888889
85819, 0.043478260869565, -0.15, 0.41666666666667
85820, 0.065217391304348, -0.15, 0.44444444444444
85821, 0.043478260869565, -0.125, 0.44444444444444
85822, 0.043478260869565, -0.15, 0.47222222222222
85823, 0.021739130434783, -0.15, 0.055555555555556
85824, 0.021739130434783, -0.15, 0.11111111111111
85825, 0.021739130434783, -0.15, 0.16666666666667
85826, 0.021739130434783, -0.15, 0.22222222222222
85827, 0.021739130434783, -0.15, 0.27777777777778
85828, 0.021739130434783, -0.15, 0.33333333333333
85829, 0.021739130434783, -0.15, 0.38888888888889
85830, 0.021739130434783, -0.15, 0.44444444444444
85831, 0.95652173913043, -0.2, 0.027777777777778
85832, 0.97826086956522, -0.2, 0.055555555555556
85833, 0.95652173913043, -0.175, 0.055555555555556
85834, 0.95652173913043, -0.2, 0.083333333333333
85835, 0.97826086956522, -0.2, 0.11111111111111
85836, 0.95652173913044, -0.175, 0.11111111111111
85837, 0.95652173913044, -0.2, 0.13888888888889
85838, 0.97826086956522, -0.2, 0.16666666666667
85839, 0.95652173913043, -0.175, 0.16666666666667
85840, 0.95652173913043, -0.2, 0.19444444444444
85841, 0.97826086956522, -0.2, 0.22222222222222
85842, 0.95652173913044, -0.175, 0.22222222222222
85843, 0.95652173913044, -0.2, 0.25
85844, 0.97826086956522, -0.2, 0.27777777777778
85845, 0.95652173913044, -0.175, 0.27777777777778
85846, 0.95652173913043, -0.2, 0.30555555555556
85847, 0.97826086956522, -0.2, 0.33333333333333
85848, 0.95652173913043, -0.175, 0.33333333333333
85849, 0.95652173913043, -0.2, 0.36111111111111
85850, 0.97826086956522, -0.2, 0.38888888888889
85851, 0.95652173913044, -0.175, 0.38888888888889
85852, 0.95652173913044, -0.2, 0.41666666666667
85853, 0.97826086956522, -0.2, 0.44444444444444
85854, 0.95652173913044, -0.175, 0.44444444444444
85855, 0.95652173913043, -0.2, 0.47222222222222
85856, 0.91304347826087, -0.2, 0.027777777777778
85857, 0.93478260869565, -0.2, 0.055555555555556
85858, 0.91304347826087, -0.175, 0.055555555555556
85859, 0.91304347826087, -0.2, 0.083333333333333
85860, 0.93478260869565, -0.2, 0.11111111111111
85861, 0.91304347826087, -0.175, 0.11111111111111
85862, 0.91304347826087, -0.2, 0.13888888888889
85863, 0.93478260869565, -0.2, 0.16666666666667
85864, 0.91304347826087, -0.175, 0.16666666666667
85865, 0.91304347826087, -0.2, 0.19444444444444
85866, 0.93478260869565, -0.2, 0.22222222222222
85867, 0.91304347826087, -0.175, 0.22222222222222
85868, 0.91304347826087, -0.2, 0.25
85869, 0.93478260869565, -0.2, 0.27777777777778
85870, 0.91304347826087, -0.175, 0.27777777777778
85871, 0.91304347826087, -0.2, 0.30555555555556
85872, 0.93478260869565, -0.2, 0.33333333333333
85873, 0.91304347826087, -0.175, 0.33333333333333
85874, 0.91304347826087, -0.2, 0.36111111111111
85875, 0.93478260869565, -0.2, 0.38888888888889
85876, 0.91304347826087, -0.175, 0.38888888888889
85877, 0.91304347826087, -0.2, 0.41666666666667
85878, 0.93478260869565, -0.2, 0.44444444444444
85879, 0.91304347826087, -0.175, 0.44444444444444
85880, 0.91304347826087, -0.2, 0.47222222222222
85881, 0.8695652173913, -0.2, 0.027777777777778
85882, 0.89130434782609, -0.2, 0.055555555555556
85883, 0.8695652173913, -0.175, 0.055555555555556
85884, 0.8695652173913, -0.2, 0.083333333333333
85885, 0.89130434782609, -0.2, 0.11111111111111
85886, 0.8695652173913, -0.175, 0.11111111111111
85887, 0.8695652173913, -0.2, 0.13888888888889
85888, 0.89130434782609, -0.2, 0.16666666666667
85889, 0.8695652173913, -0.175, 0.16666666666667
85890, 0.8695652173913, -0.2, 0.19444444444444
85891, 0.89130434782609, -0.2, 0.22222222222222
85892, 0.8695652173913, -0.175, 0.22222222222222
85893, 0.8695652173913, -0.2, 0.25
85894, 0.89130434782609, -0.2, 0.27777777777778
85895, 0.8695652173913, -0.175, 0.27777777777778
85896, 0.8695652173913, -0.2, 0.30555555555556
85897, 0.89130434782609, -0.2, 0.33333333333333
85898, 0.8695652173913, -0.175, 0.33333333333333
85899, 0.8695652173913, -0.2, 0.36111111111111
85900, 0.89130434782609, -0.2, 0.38888888888889
85901, 0.8695652173913, -0.175, 0.38888888888889
85902, 0.8695652173913, -0.2, 0.41666666666667
85903, 0.89130434782609, -0.2, 0.44444444444444
85904, 0.8695652173913, -0.175, 0.44444444444444
85905, 0.8695652173913, -0.2, 0.47222222222222
85906, 0.82608695652174, -0.2, 0.027777777777778
85907, 0.84782608695652, -0.2, 0.055555555555556
85908, 0.82608695652174, -0.175, 0.055555555555556
85909, 0.82608695652174, -0.2, 0.083333333333333
85910, 0.84782608695652, -0.2, 0.11111111111111
85911, 0.82608695652174, -0.175, 0.11111111111111
85912, 0.82608695652174, -0.2, 0.13888888888889
85913, 0.84782608695652, -0.2, 0.16666666666667
85914, 0.82608695652174, -0.175, 0.16666666666667
85915, 0.82608695652174, -0.2, 0.19444444444444
85916, 0.84782608695652, -0.2, 0.22222222222222
85917, 0.82608695652174, -0.175, 0.22222222222222
85918, 0.82608695652174, -0.2, 0.25
85919, 0.84782608695652, -0.2, 0.27777777777778
85920, 0.82608695652174, -0.175, 0.27777777777778
85921, 0.82608695652174, -0.2, 0.30555555555556
85922, 0.84782608695652, -0.2, 0.33333333333333
85923, 0.82608695652174, -0.175, 0.33333333333333
85924, 0.82608695652174, -0.2, 0.36111111111111
85925, 0.84782608695652, -0.2, 0.38888888888889
85926, 0.82608695652174, -0.175, 0.38888888888889
85927, 0.82608695652174, -0.2, 0.41666666666667
85928, 0.84782608695652, -0.2, 0.44444444444444
85929, 0.82608695652174, -0.175, 0.44444444444444
85930, 0.82608695652174, -0.2, 0.47222222222222
85931, 0.78260869565217, -0.2, 0.027777777777778
85932, 0.80434782608696, -0.2, 0.055555555555556
85933, 0.78260869565217, -0.175, 0.055555555555556
85934, 0.78260869565217, -0.2, 0.083333333333333
85935, 0.80434782608696, -0.2, 0.11111111111111
85936, 0.78260869565217, -0.175, 0.11111111111111
85937, 0.78260869565217, -0.2, 0.13888888888889
85938, 0.80434782608696, -0.2, 0.16666666666667
85939, 0.78260869565217, -0.175, 0.16666666666667
85940, 0.78260869565217, -0.2, 0.19444444444444
85941, 0.80434782608696, -0.2, 0.22222222222222
85942, 0.78260869565217, -0.175, 0.22222222222222
85943, 0.78260869565217, -0.2, 0.25
85944, 0.80434782608696, -0.2, 0.27777777777778
85945, 0.78260869565217, -0.175, 0.27777777777778
85946, 0.78260869565217, -0.2, 0.30555555555556
85947, 0.80434782608696, -0.2, 0.33333333333333
85948, 0.78260869565217, -0.175, 0.33333333333333
85949, 0.78260869565217, -0.2, 0.36111111111111
85950, 0.80434782608696, -0.2, 0.38888888888889
85951, 0.78260869565217, -0.175, 0.38888888888889
85952, 0.78260869565217, -0.2, 0.41666666666667
85953, 0.80434782608696, -0.2, 0.44444444444444
85954, 0.78260869565217, -0.175, 0.44444444444444
85955, 0.78260869565217, -0.2, 0.47222222222222
85956, 0.73913043478261, -0.2, 0.027777777777778
85957, 0.76086956521739, -0.2, 0.055555555555556
85958, 0.73913043478261, -0.175, 0.055555555555556
85959, 0.73913043478261, -0.2, 0.083333333333333
85960, 0.76086956521739, -0.2, 0.11111111111111
85961, 0.73913043478261, -0.175, 0.11111111111111
85962, 0.73913043478261, -0.2, 0.13888888888889
85963, 0.76086956521739, -0.2, 0.16666666666667
85964, 0.73913043478261, -0.175, 0.16666666666667
85965, 0.73913043478261, -0.2, 0.19444444444444
85966, 0.76086956521739, -0.2, 0.22222222222222
85967, 0.73913043478261, -0.175, 0.22222222222222
85968, 0.73913043478261, -0.2, 0.25
85969, 0.76086956521739, -0.2, 0.27777777777778
85970, 0.73913043478261, -0.175, 0.27777777777778
85971, 0.73913043478261, -0.2, 0.30555555555556
85972, 0.76086956521739, -0.2, 0.33333333333333
85973, 0.73913043478261, -0.175, 0.33333333333333
85974, 0.73913043478261, -0.2, 0.36111111111111
85975, 0.76086956521739, -0.2, 0.38888888888889
85976, 0.73913043478261, -0.175, 0.38888888888889
85977, 0.73913043478261, -0.2, 0.41666666666667
85978, 0.76086956521739, -0.2, 0.44444444444444
85979, 0.73913043478261, -0.175, 0.44444444444444
85980, 0.73913043478261, -0.2, 0.47222222222222
85981, 0.69565217391304, -0.2, 0.027777777777778
85982, 0.71739130434783, -0.2, 0.055555555555556
85983, 0.69565217391304, -0.175, 0.055555555555556
85984, 0.69565217391304, -0.2, 0.083333333333333
85985, 0.71739130434783, -0.2, 0.11111111111111
85986, 0.69565217391304, -0.175, 0.11111111111111
85987, 0.69565217391304, -0.2, 0.13888888888889
85988, 0.71739130434783, -0.2, 0.16666666666667
85989, 0.69565217391304, -0.175, 0.16666666666667
85990, 0.69565217391304, -0.2, 0.19444444444444
85991, 0.71739130434783, -0.2, 0.22222222222222
85992, 0.69565217391304, -0.175, 0.22222222222222
85993, 0.69565217391304, -0.2, 0.25
85994, 0.71739130434783, -0.2, 0.27777777777778
85995, 0.69565217391304, -0.175, 0.27777777777778
85996, 0.69565217391304, -0.2, 0.30555555555556
85997, 0.71739130434783, -0.2, 0.33333333333333
85998, 0.69565217391304, -0.175, 0.33333333333333
85999, 0.69565217391304, -0.2, 0.36111111111111
86000, 0.71739130434783, -0.2, 0.38888888888889
86001, 0.69565217391304, -0.175, 0.38888888888889
86002, 0.69565217391304, -0.2, 0.41666666666667
86003, 0.71739130434783, -0.2, 0.44444444444444
86004, 0.69565217391304, -0.175, 0.44444444444444
86005, 0.69565217391304, -0.2, 0.47222222222222
86006, 0.65217391304348, -0.2, 0.027777777777778
86007, 0.67391304347826, -0.2, 0.055555555555556
86008, 0.65217391304348, -0.175, 0.055555555555556
86009, 0.65217391304348, -0.2, 0.083333333333333
86010, 0.67391304347826, -0.2, 0.11111111111111
86011, 0.65217391304348, -0.175, 0.11111111111111
86012, 0.65217391304348, -0.2, 0.13888888888889
86013, 0.67391304347826, -0.2, 0.16666666666667
86014, 0.65217391304348, -0.175, 0.16666666666667
86015, 0.65217391304348, -0.2, 0.19444444444444
86016, 0.67391304347826, -0.2, 0.22222222222222
86017, 0.65217391304348, -0.175, 0.22222222222222
86018, 0.65217391304348, -0.2, 0.25
86019, 0.67391304347826, -0.2, 0.27777777777778
86020, 0.65217391304348, -0.175, 0.27777777777778
86021, 0.65217391304348, -0.2, 0.30555555555556
86022, 0.67391304347826, -0.2, 0.33333333333333
86023, 0.65217391304348, -0.175, 0.33333333333333
86024, 0.65217391304348, -0.2, 0.36111111111111
86025, 0.67391304347826, -0.2, 0.38888888888889
86026, 0.65217391304348, -0.175, 0.38888888888889
86027, 0.65217391304348, -0.2, 0.41666666666667
86028, 0.67391304347826, -0.2, 0.44444444444444
86029, 0.65217391304348, -0.175, 0.44444444444444
86030, 0.65217391304348, -0.2, 0.47222222222222
86031, 0.60869565217391, -0.2, 0.027777777777778
86032, 0.6304347826087, -0.2, 0.055555555555556
86033, 0.60869565217391, -0.175, 0.055555555555556
86034, 0.60869565217391, -0.2, 0.083333333333333
86035, 0.6304347826087, -0.2, 0.11111111111111
86036, 0.60869565217391, -0.175, 0.11111111111111
86037, 0.60869565217391, -0.2, 0.13888888888889
86038, 0.6304347826087, -0.2, 0.16666666666667
86039, 0.60869565217391, -0.175, 0.16666666666667
86040, 0.60869565217391, -0.2, 0.19444444444444
86041, 0.6304347826087, -0.2, 0.22222222222222
86042, 0.60869565217391, -0.175, 0.22222222222222
86043, 0.60869565217391, -0.2, 0.25
86044, 0.6304347826087, -0.2, 0.27777777777778
86045, 0.60869565217391, -0.175, 0.27777777777778
86046, 0.60869565217391, -0.2, 0.30555555555556
86047, 0.6304347826087, -0.2, 0.33333333333333
86048, 0.60869565217391, -0.175, 0.33333333333333
86049, 0.60869565217391, -0.2, 0.36111111111111
86050, 0.6304347826087, -0.2, 0.38888888888889
86051, 0.60869565217391, -0.175, 0.38888888888889
86052, 0.60869565217391, -0.2, 0.41666666666667
86053, 0.6304347826087, -0.2, 0.44444444444444
86054, 0.60869565217391, -0.175, 0.44444444444444
86055, 0.60869565217391, -0.2, 0.47222222222222
86056, 0.56521739130435, -0.2, 0.027777777777778
86057, 0.58695652173913, -0.2, 0.055555555555556
86058, 0.56521739130435, -0.175, 0.055555555555556
86059, 0.56521739130435, -0.2, 0.083333333333333
86060, 0.58695652173913, -0.2, 0.11111111111111
86061, 0.56521739130435, -0.175, 0.11111111111111
86062, 0.56521739130435, -0.2, 0.13888888888889
86063, 0.58695652173913, -0.2, 0.16666666666667
86064, 0.56521739130435, -0.175, 0.16666666666667
86065, 0.56521739130435, -0.2, 0.19444444444444
86066, 0.58695652173913, -0.2, 0.22222222222222
86067, 0.56521739130435, -0.175, 0.22222222222222
86068, 0.56521739130435, -0.2, 0.25
86069, 0.58695652173913, -0.2, 0.27777777777778
86070, 0.56521739130435, -0.175, 0.27777777777778
86071, 0.56521739130435, -0.2, 0.30555555555556
86072, 0.58695652173913, -0.2, 0.33333333333333
86073, 0.56521739130435, -0.175, 0.33333333333333
86074, 0.56521739130435, -0.2, 0.36111111111111
86075, 0.58695652173913, -0.2, 0.38888888888889
86076, 0.56521739130435, -0.175, 0.38888888888889
86077, 0.56521739130435, -0.2, 0.41666666666667
86078, 0.58695652173913, -0.2, 0.44444444444444
86079, 0.56521739130435, -0.175, 0.44444444444444
86080, 0.56521739130435, -0.2, 0.47222222222222
86081, 0.52173913043478, -0.2, 0.027777777777778
86082, 0.54347826086957, -0.2, 0.055555555555556
86083, 0.52173913043478, -0.175, 0.055555555555556
86084, 0.52173913043478, -0.2, 0.083333333333333
86085, 0.54347826086956, -0.2, 0.11111111111111
86086, 0.52173913043478, -0.175, 0.11111111111111
86087, 0.52173913043478, -0.2, 0.13888888888889
86088, 0.54347826086957, -0.2, 0.16666666666667
86089, 0.52173913043478, -0.175, 0.16666666666667
86090, 0.52173913043478, -0.2, 0.19444444444444
86091, 0.54347826086956, -0.2, 0.22222222222222
86092, 0.52173913043478, -0.175, 0.22222222222222
86093, 0.52173913043478, -0.2, 0.25
86094, 0.54347826086956, -0.2, 0.27777777777778
86095, 0.52173913043478, -0.175, 0.27777777777778
86096, 0.52173913043478, -0.2, 0.30555555555556
86097, 0.54347826086956, -0.2, 0.33333333333333
86098, 0.52173913043478, -0.175, 0.33333333333333
86099, 0.52173913043478, -0.2, 0.36111111111111
86100, 0.54347826086956, -0.2, 0.38888888888889
86101, 0.52173913043478, -0.175, 0.38888888888889
86102, 0.52173913043478, -0.2, 0.41666666666667
86103, 0.54347826086956, -0.2, 0.44444444444444
86104, 0.52173913043478, -0.175, 0.44444444444444
86105, 0.52173913043478, -0.2, 0.47222222222222
86106, 0.47826086956522, -0.2, 0.027777777777778
86107, 0.5, -0.2, 0.055555555555556
86108, 0.47826086956522, -0.175, 0.055555555555556
86109, 0.47826086956522, -0.2, 0.083333333333333
86110, 0.5, -0.2, 0.11111111111111
86111, 0.47826086956522, -0.175, 0.11111111111111
86112, 0.47826086956522, -0.2, 0.13888888888889
86113, 0.5, -0.2, 0.16666666666667
86114, 0.47826086956522, -0.175, 0.16666666666667
86115, 0.47826086956522, -0.2, 0.19444444444444
86116, 0.5, -0.2, 0.22222222222222
86117, 0.47826086956522, -0.175, 0.22222222222222
86118, 0.47826086956522, -0.2, 0.25
86119, 0.5, -0.2, 0.27777777777778
86120, 0.47826086956522, -0.175, 0.27777777777778
86121, 0.47826086956522, -0.2, 0.30555555555556
86122, 0.5, -0.2, 0.33333333333333
86123, 0.47826086956522, -0.175, 0.33333333333333
86124, 0.47826086956522, -0.2, 0.36111111111111
86125, 0.5, -0.2, 0.38888888888889
86126, 0.47826086956522, -0.175, 0.38888888888889
86127, 0.47826086956522, -0.2, 0.41666666666667
86128, 0.5, -0.2, 0.44444444444444
86129, 0.47826086956522, -0.175, 0.44444444444444
86130, 0.47826086956522, -0.2, 0.47222222222222
86131, 0.43478260869565, -0.2, 0.027777777777778
86132, 0.45652173913043, -0.2, 0.055555555555556
86133, 0.43478260869565, -0.175, 0.055555555555556
86134, 0.43478260869565, -0.2, 0.083333333333333
86135, 0.45652173913043, -0.2, 0.11111111111111
86136, 0.43478260869565, -0.175, 0.11111111111111
86137, 0.43478260869565, -0.2, 0.13888888888889
86138, 0.45652173913043, -0.2, 0.16666666666667
86139, 0.43478260869565, -0.175, 0.16666666666667
86140, 0.43478260869565, -0.2, 0.19444444444444
86141, 0.45652173913043, -0.2, 0.22222222222222
86142, 0.43478260869565, -0.175, 0.22222222222222
86143, 0.43478260869565, -0.2, 0.25
86144, 0.45652173913043, -0.2, 0.27777777777778
86145, 0.43478260869565, -0.175, 0.27777777777778
86146, 0.43478260869565, -0.2, 0.30555555555556
86147, 0.45652173913043, -0.2, 0.33333333333333
86148, 0.43478260869565, -0.175, 0.33333333333333
86149, 0.43478260869565, -0.2, 0.36111111111111
86150, 0.45652173913044, -0.2, 0.38888888888889
86151, 0.43478260869565, -0.175, 0.38888888888889
86152, 0.43478260869565, -0.2, 0.41666666666667
86153, 0.45652173913043, -0.2, 0.44444444444444
86154, 0.43478260869565, -0.175, 0.44444444444444
86155, 0.43478260869565, -0.2, 0.47222222222222
86156, 0.39130434782609, -0.2, 0.027777777777778
86157, 0.41304347826087, -0.2, 0.055555555555556
86158, 0.39130434782609, -0.175, 0.055555555555556
86159, 0.39130434782609, -0.2, 0.083333333333333
86160, 0.41304347826087, -0.2, 0.11111111111111
86161, 0.39130434782609, -0.175, 0.11111111111111
86162, 0.39130434782609, -0.2, 0.13888888888889
86163, 0.41304347826087, -0.2, 0.16666666666667
86164, 0.39130434782609, -0.175, 0.16666666666667
86165, 0.39130434782609, -0.2, 0.19444444444444
86166, 0.41304347826087, -0.2, 0.22222222222222
86167, 0.39130434782609, -0.175, 0.22222222222222
86168, 0.39130434782609, -0.2, 0.25
86169, 0.41304347826087, -0.2, 0.27777777777778
86170, 0.39130434782609, -0.175, 0.27777777777778
86171, 0.39130434782609, -0.2, 0.30555555555556
86172, 0.41304347826087, -0.2, 0.33333333333333
86173, 0.39130434782609, -0.175, 0.33333333333333
86174, 0.39130434782609, -0.2, 0.36111111111111
86175, 0.41304347826087, -0.2, 0.38888888888889
86176, 0.39130434782609, -0.175, 0.38888888888889
86177, 0.39130434782609, -0.2, 0.41666666666667
86178, 0.41304347826087, -0.2, 0.44444444444444
86179, 0.39130434782609, -0.175, 0.44444444444444
86180, 0.39130434782609, -0.2, 0.47222222222222
86181, 0.34782608695652, -0.2, 0.027777777777778
86182, 0.3695652173913, -0.2, 0.055555555555556
86183, 0.34782608695652, -0.175, 0.055555555555556
86184, 0.34782608695652, -0.2, 0.083333333333333
86185, 0.3695652173913, -0.2, 0.11111111111111
86186, 0.34782608695652, -0.175, 0.11111111111111
86187, 0.34782608695652, -0.2, 0.13888888888889
86188, 0.3695652173913, -0.2, 0.16666666666667
86189, 0.34782608695652, -0.175, 0.16666666666667
86190, 0.34782608695652, -0.2, 0.19444444444444
86191, 0.3695652173913, -0.2, 0.22222222222222
86192, 0.34782608695652, -0.175, 0.22222222222222
86193, 0.34782608695652, -0.2, 0.25
86194, 0.3695652173913, -0.2, 0.27777777777778
86195, 0.34782608695652, -0.175, 0.27777777777778
86196, 0.34782608695652, -0.2, 0.30555555555556
86197, 0.3695652173913, -0.2, 0.33333333333333
86198, 0.34782608695652, -0.175, 0.33333333333333
86199, 0.34782608695652, -0.2, 0.36111111111111
86200, 0.3695652173913, -0.2, 0.38888888888889
86201, 0.34782608695652, -0.175, 0.38888888888889
86202, 0.34782608695652, -0.2, 0.41666666666667
86203, 0.3695652173913, -0.2, 0.44444444444444
86204, 0.34782608695652, -0.175, 0.44444444444444
86205, 0.34782608695652, -0.2, 0.47222222222222
86206, 0.30434782608696, -0.2, 0.027777777777778
86207, 0.32608695652174, -0.2, 0.055555555555556
86208, 0.30434782608696, -0.175, 0.055555555555556
86209, 0.30434782608696, -0.2, 0.083333333333333
86210, 0.32608695652174, -0.2, 0.11111111111111
86211, 0.30434782608696, -0.175, 0.11111111111111
86212, 0.30434782608696, -0.2, 0.13888888888889
86213, 0.32608695652174, -0.2, 0.16666666666667
86214, 0.30434782608696, -0.175, 0.16666666666667
86215, 0.30434782608696, -0.2, 0.19444444444444
86216, 0.32608695652174, -0.2, 0.22222222222222
86217, 0.30434782608696, -0.175, 0.22222222222222
86218, 0.30434782608696, -0.2, 0.25
86219, 0.32608695652174, -0.2, 0.27777777777778
86220, 0.30434782608696, -0.175, 0.27777777777778
86221, 0.30434782608696, -0.2, 0.30555555555556
86222, 0.32608695652174, -0.2, 0.33333333333333
86223, 0.30434782608696, -0.175, 0.33333333333333
86224, 0.30434782608696, -0.2, 0.36111111111111
86225, 0.32608695652174, -0.2, 0.38888888888889
86226, 0.30434782608696, -0.175, 0.38888888888889
86227, 0.30434782608696, -0.2, 0.41666666666667
86228, 0.32608695652174, -0.2, 0.44444444444444
86229, 0.30434782608696, -0.175, 0.44444444444444
86230, 0.30434782608696, -0.2, 0.47222222222222
86231, 0.26086956521739, -0.2, 0.027777777777778
86232, 0.28260869565217, -0.2, 0.055555555555556
86233, 0.26086956521739, -0.175, 0.055555555555556
86234, 0.26086956521739, -0.2, 0.083333333333333
86235, 0.28260869565217, -0.2, 0.11111111111111
86236, 0.26086956521739, -0.175, 0.11111111111111
86237, 0.26086956521739, -0.2, 0.13888888888889
86238, 0.28260869565217, -0.2, 0.16666666666667
86239, 0.26086956521739, -0.175, 0.16666666666667
86240, 0.26086956521739, -0.2, 0.19444444444444
86241, 0.28260869565217, -0.2, 0.22222222222222
86242, 0.26086956521739, -0.175, 0.22222222222222
86243, 0.26086956521739, -0.2, 0.25
86244, 0.28260869565217, -0.2, 0.27777777777778
86245, 0.26086956521739, -0.175, 0.27777777777778
86246, 0.26086956521739, -0.2, 0.30555555555556
86247, 0.28260869565217, -0.2, 0.33333333333333
86248, 0.26086956521739, -0.175, 0.33333333333333
86249, 0.26086956521739, -0.2, 0.36111111111111
86250, 0.28260869565217, -0.2, 0.38888888888889
86251, 0.26086956521739, -0.175, 0.38888888888889
86252, 0.26086956521739, -0.2, 0.41666666666667
86253, 0.28260869565217, -0.2, 0.44444444444444
86254, 0.26086956521739, -0.175, 0.44444444444444
86255, 0.26086956521739, -0.2, 0.47222222222222
86256, 0.21739130434783, -0.2, 0.027777777777778
86257, 0.23913043478261, -0.2, 0.055555555555556
86258, 0.21739130434783, -0.175, 0.055555555555556
86259, 0.21739130434783, -0.2, 0.083333333333333
86260, 0.23913043478261, -0.2, 0.11111111111111
86261, 0.21739130434783, -0.175, 0.11111111111111
86262, 0.21739130434783, -0.2, 0.13888888888889
86263, 0.23913043478261, -0.2, 0.16666666666667
86264, 0.21739130434783, -0.175, 0.16666666666667
86265, 0.21739130434783, -0.2, 0.19444444444444
86266, 0.23913043478261, -0.2, 0.22222222222222
86267, 0.21739130434783, -0.175, 0.22222222222222
86268, 0.21739130434783, -0.2, 0.25
86269, 0.23913043478261, -0.2, 0.27777777777778
86270, 0.21739130434783, -0.175, 0.27777777777778
86271, 0.21739130434783, -0.2, 0.30555555555556
86272, 0.23913043478261, -0.2, 0.33333333333333
86273, 0.21739130434783, -0.175, 0.33333333333333
86274, 0.21739130434783, -0.2, 0.36111111111111
86275, 0.23913043478261, -0.2, 0.38888888888889
86276, 0.21739130434783, -0.175, 0.38888888888889
86277, 0.21739130434783, -0.2, 0.41666666666667
86278, 0.23913043478261, -0.2, 0.44444444444444
86279, 0.21739130434783, -0.175, 0.44444444444444
86280, 0.21739130434783, -0.2, 0.47222222222222
86281, 0.17391304347826, -0.2, 0.027777777777778
86282, 0.19565217391304, -0.2, 0.055555555555556
86283, 0.17391304347826, -0.175, 0.055555555555556
86284, 0.17391304347826, -0.2, 0.083333333333333
86285, 0.19565217391304, -0.2, 0.11111111111111
86286, 0.17391304347826, -0.175, 0.11111111111111
86287, 0.17391304347826, -0.2, 0.13888888888889
86288, 0.19565217391304, -0.2, 0.16666666666667
86289, 0.17391304347826, -0.175, 0.16666666666667
86290, 0.17391304347826, -0.2, 0.19444444444444
86291, 0.19565217391304, -0.2, 0.22222222222222
86292, 0.17391304347826, -0.175, 0.22222222222222
86293, 0.17391304347826, -0.2, 0.25
86294, 0.19565217391304, -0.2, 0.27777777777778
86295, 0.17391304347826, -0.175, 0.27777777777778
86296, 0.17391304347826, -0.2, 0.30555555555556
86297, 0.19565217391304, -0.2, 0.33333333333333
86298, 0.17391304347826, -0.175, 0.33333333333333
86299, 0.17391304347826, -0.2, 0.36111111111111
86300, 0.19565217391304, -0.2, 0.38888888888889
86301, 0.17391304347826, -0.175, 0.38888888888889
86302, 0.17391304347826, -0.2, 0.41666666666667
86303, 0.19565217391304, -0.2, 0.44444444444444
86304, 0.17391304347826, -0.175, 0.44444444444444
86305, 0.17391304347826, -0.2, 0.47222222222222
86306, 0.1304347826087, -0.2, 0.027777777777778
86307, 0.15217391304348, -0.2, 0.055555555555556
86308, 0.1304347826087, -0.175, 0.055555555555556
86309, 0.1304347826087, -0.2, 0.083333333333333
86310, 0.15217391304348, -0.2, 0.11111111111111
86311, 0.1304347826087, -0.175, 0.11111111111111
86312, 0.1304347826087, -0.2, 0.13888888888889
86313, 0.15217391304348, -0.2, 0.16666666666667
86314, 0.1304347826087, -0.175, 0.16666666666667
86315, 0.1304347826087, -0.2, 0.19444444444444
86316, 0.15217391304348, -0.2, 0.22222222222222
86317, 0.1304347826087, -0.175, 0.22222222222222
86318, 0.1304347826087, -0.2, 0.25
86319, 0.15217391304348, -0.2, 0.27777777777778
86320, 0.1304347826087, -0.175, 0.27777777777778
86321, 0.1304347826087, -0.2, 0.30555555555556
86322, 0.15217391304348, -0.2, 0.33333333333333
86323, 0.1304347826087, -0.175, 0.33333333333333
86324, 0.1304347826087, -0.2, 0.36111111111111
86325, 0.15217391304348, -0.2, 0.38888888888889
86326, 0.1304347826087, -0.175, 0.38888888888889
86327, 0.1304347826087, -0.2, 0.41666666666667
86328, 0.15217391304348, -0.2, 0.44444444444444
86329, 0.1304347826087, -0.175, 0.44444444444444
86330, 0.1304347826087, -0.2, 0.47222222222222
86331, 0.08695652173913, -0.2, 0.027777777777778
86332, 0.10869565217391, -0.2, 0.055555555555556
86333, 0.08695652173913, -0.175, 0.055555555555556
86334, 0.08695652173913, -0.2, 0.083333333333333
86335, 0.10869565217391, -0.2, 0.11111111111111
86336, 0.08695652173913, -0.175, 0.11111111111111
86337, 0.08695652173913, -0.2, 0.13888888888889
86338, 0.10869565217391, -0.2, 0.16666666666667
86339, 0.08695652173913, -0.175, 0.16666666666667
86340, 0.08695652173913, -0.2, 0.19444444444444
86341, 0.10869565217391, -0.2, 0.22222222222222
86342, 0.08695652173913, -0.175, 0.22222222222222
86343, 0.08695652173913, -0.2, 0.25
86344, 0.10869565217391, -0.2, 0.27777777777778
86345, 0.08695652173913, -0.175, 0.27777777777778
86346, 0.08695652173913, -0.2, 0.30555555555556
86347, 0.10869565217391, -0.2, 0.33333333333333
86348, 0.08695652173913, -0.175, 0.33333333333333
86349, 0.08695652173913, -0.2, 0.36111111111111
86350, 0.10869565217391, -0.2, 0.38888888888889
86351, 0.08695652173913, -0.175, 0.38888888888889
86352, 0.08695652173913, -0.2, 0.41666666666667
86353, 0.10869565217391, -0.2, 0.44444444444444
86354, 0.08695652173913, -0.175, 0.44444444444444
86355, 0.08695652173913, -0.2, 0.47222222222222
86356, 0.043478260869565, -0.2, 0.027777777777778
86357, 0.065217391304348, -0.2, 0.055555555555556
86358, 0.043478260869565, -0.175, 0.055555555555556
86359, 0.043478260869565, -0.2, 0.083333333333333
86360, 0.065217391304348, -0.2, 0.11111111111111
86361, 0.043478260869565, -0.175, 0.11111111111111
86362, 0.043478260869565, -0.2, 0.13888888888889
86363, 0.065217391304348, -0.2, 0.16666666666667
86364, 0.043478260869565, -0.175, 0.16666666666667
86365, 0.043478260869565, -0.2, 0.19444444444444
86366, 0.065217391304348, -0.2, 0.22222222222222
86367, 0.043478260869565, -0.175, 0.22222222222222
86368, 0.043478260869565, -0.2, 0.25
86369, 0.065217391304348, -0.2, 0.27777777777778
86370, 0.043478260869565, -0.175, 0.27777777777778
86371, 0.043478260869565, -0.2, 0.30555555555556
86372, 0.065217391304348, -0.2, 0.33333333333333
86373, 0.043478260869565, -0.175, 0.33333333333333
86374, 0.043478260869565, -0.2, 0.36111111111111
86375, 0.065217391304348, -0.2, 0.38888888888889
86376, 0.043478260869565, -0.175, 0.38888888888889
86377, 0.043478260869565, -0.2, 0.41666666666667
86378, 0.065217391304348, -0.2, 0.44444444444444
86379, 0.043478260869565, -0.175, 0.44444444444444
86380, 0.043478260869565, -0.2, 0.47222222222222
86381, 0.021739130434783, -0.2, 0.055555555555556
86382, 0.021739130434783, -0.2, 0.11111111111111
86383, 0.021739130434783, -0.2, 0.16666666666667
86384, 0.021739130434783, -0.2, 0.22222222222222
86385, 0.021739130434783, -0.2, 0.27777777777778
86386, 0.021739130434783, -0.2, 0.33333333333333
86387, 0.021739130434783, -0.2, 0.38888888888889
86388, 0.021739130434783, -0.2, 0.44444444444444
86389, 0.95652173913043, -0.225, 0.055555555555556
86390, 0.95652173913044, -0.225, 0.11111111111111
86391, 0.95652173913043, -0.225, 0.16666666666667
86392, 0.95652173913043, -0.225, 0.22222222222222
86393, 0.95652173913043, -0.225, 0.27777777777778
86394, 0.95652173913043, -0.225, 0.33333333333333
86395, 0.95652173913043, -0.225, 0.38888888888889
86396, 0.95652173913043, -0.225, 0.44444444444444
86397, 0.91304347826087, -0.225, 0.055555555555556
86398, 0.91304347826087, -0.225, 0.11111111111111
86399, 0.91304347826087, -0.225, 0.16666666666667
86400, 0.91304347826087, -0.225, 0.22222222222222
86401, 0.91304347826087, -0.225, 0.27777777777778
86402, 0.91304347826087, -0.225, 0.33333333333333
86403, 0.91304347826087, -0.225, 0.38888888888889
86404, 0.91304347826087, -0.225, 0.44444444444444
86405, 0.8695652173913, -0.225, 0.055555555555556
86406, 0.8695652173913, -0.225, 0.11111111111111
86407, 0.8695652173913, -0.225, 0.16666666666667
86408, 0.8695652173913, -0.225, 0.22222222222222
86409, 0.8695652173913, -0.225, 0.27777777777778
86410, 0.8695652173913, -0.225, 0.33333333333333
86411, 0.8695652173913, -0.225, 0.38888888888889
86412, 0.8695652173913, -0.225, 0.44444444444444
86413, 0.82608695652174, -0.225, 0.055555555555556
86414, 0.82608695652174, -0.225, 0.11111111111111
86415, 0.82608695652174, -0.225, 0.16666666666667
86416, 0.82608695652174, -0.225, 0.22222222222222
86417, 0.82608695652174, -0.225, 0.27777777777778
86418, 0.82608695652174, -0.225, 0.33333333333333
86419, 0.82608695652174, -0.225, 0.38888888888889
86420, 0.82608695652174, -0.225, 0.44444444444444
86421, 0.78260869565217, -0.225, 0.055555555555556
86422, 0.78260869565217, -0.225, 0.11111111111111
86423, 0.78260869565217, -0.225, 0.16666666666667
86424, 0.78260869565217, -0.225, 0.22222222222222
86425, 0.78260869565217, -0.225, 0.27777777777778
86426, 0.78260869565217, -0.225, 0.33333333333333
86427, 0.78260869565217, -0.225, 0.38888888888889
86428, 0.78260869565217, -0.225, 0.44444444444444
86429, 0.73913043478261, -0.225, 0.055555555555556
86430, 0.73913043478261, -0.225, 0.11111111111111
86431, 0.73913043478261, -0.225, 0.16666666666667
86432, 0.73913043478261, -0.225, 0.22222222222222
86433, 0.73913043478261, -0.225, 0.27777777777778
86434, 0.73913043478261, -0.225, 0.33333333333333
86435, 0.73913043478261, -0.225, 0.38888888888889
86436, 0.73913043478261, -0.225, 0.44444444444444
86437, 0.69565217391304, -0.225, 0.055555555555556
86438, 0.69565217391304, -0.225, 0.11111111111111
86439, 0.69565217391304, -0.225, 0.16666666666667
86440, 0.69565217391304, -0.225, 0.22222222222222
86441, 0.69565217391304, -0.225, 0.27777777777778
86442, 0.69565217391304, -0.225, 0.33333333333333
86443, 0.69565217391304, -0.225, 0.38888888888889
86444, 0.69565217391304, -0.225, 0.44444444444444
86445, 0.65217391304348, -0.225, 0.055555555555556
86446, 0.65217391304348, -0.225, 0.11111111111111
86447, 0.65217391304348, -0.225, 0.16666666666667
86448, 0.65217391304348, -0.225, 0.22222222222222
86449, 0.65217391304348, -0.225, 0.27777777777778
86450, 0.65217391304348, -0.225, 0.33333333333333
86451, 0.65217391304348, -0.225, 0.38888888888889
86452, 0.65217391304348, -0.225, 0.44444444444444
86453, 0.60869565217391, -0.225, 0.055555555555556
86454, 0.60869565217391, -0.225, 0.11111111111111
86455, 0.60869565217391, -0.225, 0.16666666666667
86456, 0.60869565217391, -0.225, 0.22222222222222
86457, 0.60869565217391, -0.225, 0.27777777777778
86458, 0.60869565217391, -0.225, 0.33333333333333
86459, 0.60869565217391, -0.225, 0.38888888888889
86460, 0.60869565217391, -0.225, 0.44444444444444
86461, 0.56521739130435, -0.225, 0.055555555555556
86462, 0.56521739130435, -0.225, 0.11111111111111
86463, 0.56521739130435, -0.225, 0.16666666666667
86464, 0.56521739130435, -0.225, 0.22222222222222
86465, 0.56521739130435, -0.225, 0.27777777777778
86466, 0.56521739130435, -0.225, 0.33333333333333
86467, 0.56521739130435, -0.225, 0.38888888888889
86468, 0.56521739130435, -0.225, 0.44444444444444
86469, 0.52173913043478, -0.225, 0.055555555555556
86470, 0.52173913043478, -0.225, 0.11111111111111
86471, 0.52173913043478, -0.225, 0.16666666666667
86472, 0.52173913043478, -0.225, 0.22222222222222
86473, 0.52173913043478, -0.225, 0.27777777777778
86474, 0.52173913043478, -0.225, 0.33333333333333
86475, 0.52173913043478, -0.225, 0.38888888888889
86476, 0.52173913043478, -0.225, 0.44444444444444
86477, 0.47826086956522, -0.225, 0.055555555555556
86478, 0.47826086956522, -0.225, 0.11111111111111
86479, 0.47826086956522, -0.225, 0.16666666666667
86480, 0.47826086956522, -0.225, 0.22222222222222
86481, 0.47826086956522, -0.225, 0.27777777777778
86482, 0.47826086956522, -0.225, 0.33333333333333
86483, 0.47826086956522, -0.225, 0.38888888888889
86484, 0.47826086956522, -0.225, 0.44444444444444
86485, 0.43478260869565, -0.225, 0.055555555555556
86486, 0.43478260869565, -0.225, 0.11111111111111
86487, 0.43478260869565, -0.225, 0.16666666666667
86488, 0.43478260869565, -0.225, 0.22222222222222
86489, 0.43478260869565, -0.225, 0.27777777777778
86490, 0.43478260869565, -0.225, 0.33333333333333
86491, 0.43478260869565, -0.225, 0.38888888888889
86492, 0.43478260869565, -0.225, 0.44444444444444
86493, 0.39130434782609, -0.225, 0.055555555555556
86494, 0.39130434782609, -0.225, 0.11111111111111
86495, 0.39130434782609, -0.225, 0.16666666666667
86496, 0.39130434782609, -0.225, 0.22222222222222
86497, 0.39130434782609, -0.225, 0.27777777777778
86498, 0.39130434782609, -0.225, 0.33333333333333
86499, 0.39130434782609, -0.225, 0.38888888888889
86500, 0.39130434782609, -0.225, 0.44444444444444
86501, 0.34782608695652, -0.225, 0.055555555555556
86502, 0.34782608695652, -0.225, 0.11111111111111
86503, 0.34782608695652, -0.225, 0.16666666666667
86504, 0.34782608695652, -0.225, 0.22222222222222
86505, 0.34782608695652, -0.225, 0.27777777777778
86506, 0.34782608695652, -0.225, 0.33333333333333
86507, 0.34782608695652, -0.225, 0.38888888888889
86508, 0.34782608695652, -0.225, 0.44444444444444
86509, 0.30434782608696, -0.225, 0.055555555555556
86510, 0.30434782608696, -0.225, 0.11111111111111
86511, 0.30434782608696, -0.225, 0.16666666666667
86512, 0.30434782608696, -0.225, 0.22222222222222
86513, 0.30434782608696, -0.225, 0.27777777777778
86514, 0.30434782608696, -0.225, 0.33333333333333
86515, 0.30434782608696, -0.225, 0.38888888888889
86516, 0.30434782608696, -0.225, 0.44444444444444
86517, 0.26086956521739, -0.225, 0.055555555555556
86518, 0.26086956521739, -0.225, 0.11111111111111
86519, 0.26086956521739, -0.225, 0.16666666666667
86520, 0.26086956521739, -0.225, 0.22222222222222
86521, 0.26086956521739, -0.225, 0.27777777777778
86522, 0.26086956521739, -0.225, 0.33333333333333
86523, 0.26086956521739, -0.225, 0.38888888888889
86524, 0.26086956521739, -0.225, 0.44444444444444
86525, 0.21739130434783, -0.225, 0.055555555555556
86526, 0.21739130434783, -0.225, 0.11111111111111
86527, 0.21739130434783, -0.225, 0.16666666666667
86528, 0.21739130434783, -0.225, 0.22222222222222
86529, 0.21739130434783, -0.225, 0.27777777777778
86530, 0.21739130434783, -0.225, 0.33333333333333
86531, 0.21739130434783, -0.225, 0.38888888888889
86532, 0.21739130434783, -0.225, 0.44444444444444
86533, 0.17391304347826, -0.225, 0.055555555555556
86534, 0.17391304347826, -0.225, 0.11111111111111
86535, 0.17391304347826, -0.225, 0.16666666666667
86536, 0.17391304347826, -0.225, 0.22222222222222
86537, 0.17391304347826, -0.225, 0.27777777777778
86538, 0.17391304347826, -0.225, 0.33333333333333
86539, 0.17391304347826, -0.225, 0.38888888888889
86540, 0.17391304347826, -0.225, 0.44444444444444
86541, 0.1304347826087, -0.225, 0.055555555555556
86542, 0.1304347826087, -0.225, 0.11111111111111
86543, 0.1304347826087, -0.225, 0.16666666666667
86544, 0.1304347826087, -0.225, 0.22222222222222
86545, 0.1304347826087, -0.225, 0.27777777777778
86546, 0.1304347826087, -0.225, 0.33333333333333
86547, 0.1304347826087, -0.225, 0.38888888888889
86548, 0.1304347826087, -0.225, 0.44444444444444
86549, 0.08695652173913, -0.225, 0.055555555555556
86550, 0.08695652173913, -0.225, 0.11111111111111
86551, 0.08695652173913, -0.225, 0.16666666666667
86552, 0.08695652173913, -0.225, 0.22222222222222
86553, 0.08695652173913, -0.225, 0.27777777777778
86554, 0.08695652173913, -0.225, 0.33333333333333
86555, 0.08695652173913, -0.225, 0.38888888888889
86556, 0.08695652173913, -0.225, 0.44444444444444
86557, 0.043478260869565, -0.225, 0.055555555555556
86558, 0.043478260869565, -0.225, 0.11111111111111
86559, 0.043478260869565, -0.225, 0.16666666666667
86560, 0.043478260869565, -0.225, 0.22222222222222
86561, 0.043478260869565, -0.225, 0.27777777777778
86562, 0.043478260869565, -0.225, 0.33333333333333
86563, 0.043478260869565, -0.225, 0.38888888888889
86564, 0.043478260869565, -0.225, 0.44444444444444
86565, -0.05, -0.1, 0.44444444444444
86566, -0.05, -0.1, 0.38888888888889
86567, -0.05, -0.1, 0.33333333333333
86568, -0.05, -0.1, 0.27777777777778
86569, -0.05, -0.1, 0.22222222222222
86570, -0.05, -0.1, 0.16666666666667
86571, -0.05, -0.1, 0.11111111111111
86572, -0.05, -0.1, 0.055555555555556
86573, -0.05, -0.15, 0.44444444444444
86574, -0.05, -0.15, 0.38888888888889
86575, -0.05, -0.15, 0.33333333333333
86576, -0.05, -0.15, 0.27777777777778
86577, -0.05, -0.15, 0.22222222222222
86578, -0.05, -0.15, 0.16666666666667
86579, -0.05, -0.15, 0.11111111111111
86580, -0.05, -0.15, 0.055555555555556
86581, -0.05, -0.2, 0.44444444444444
86582, -0.05, -0.2, 0.38888888888889
86583, -0.05, -0.2, 0.33333333333333
86584, -0.05, -0.2, 0.27777777777778
86585, -0.05, -0.2, 0.22222222222222
86586, -0.05, -0.2, 0.16666666666667
86587, -0.05, -0.2, 0.11111111111111
86588, -0.05, -0.2, 0.055555555555556
86589, -0.05, -0.1, 0.47222222222222
86590, -0.025, -0.1, 0.44444444444444
86591, -0.05, -0.075, 0.44444444444444
86592, -0.05, -0.1, 0.41666666666667
86593, -0.025, -0.1, 0.38888888888889
86594, -0.05, -0.075, 0.38888888888889
86595, -0.05, -0.1, 0.36111111111111
86596, -0.025, -0.1, 0.33333333333333
86597, -0.05, -0.075, 0.33333333333333
86598, -0.05, -0.1, 0.30555555555556
86599, -0.025, -0.1, 0.27777777777778
86600, -0.05, -0.075, 0.27777777777778
86601, -0.05, -0.1, 0.25
86602, -0.025, -0.1, 0.22222222222222
86603, -0.05, -0.075, 0.22222222222222
86604, -0.05, -0.1, 0.19444444444444
86605, -0.025, -0.1, 0.16666666666667
86606, -0.05, -0.075, 0.16666666666667
86607, -0.05, -0.1, 0.13888888888889
86608, -0.025, -0.1, 0.11111111111111
86609, -0.05, -0.075, 0.11111111111111
86610, -0.05, -0.1, 0.083333333333333
86611, -0.025, -0.1, 0.055555555555556
86612, -0.05, -0.075, 0.055555555555556
86613, -0.05, -0.1, 0.027777777777778
86614, -0.075, -0.1, 0.44444444444444
86615, -0.075, -0.1, 0.38888888888889
86616, -0.075, -0.1, 0.33333333333333
86617, -0.075, -0.1, 0.27777777777778
86618, -0.075, -0.1, 0.22222222222222
86619, -0.075, -0.1, 0.16666666666667
86620, -0.075, -0.1, 0.11111111111111
86621, -0.075, -0.1, 0.055555555555556
86622, -0.05, -0.15, 0.47222222222222
86623, -0.025, -0.15, 0.44444444444444
86624, -0.05, -0.125, 0.44444444444444
86625, -0.05, -0.15, 0.41666666666667
86626, -0.025, -0.15, 0.38888888888889
86627, -0.05, -0.125, 0.38888888888889
86628, -0.05, -0.15, 0.36111111111111
86629, -0.025, -0.15, 0.33333333333333
86630, -0.05, -0.125, 0.33333333333333
86631, -0.05, -0.15, 0.30555555555556
86632, -0.025, -0.15, 0.27777777777778
86633, -0.05, -0.125, 0.27777777777778
86634, -0.05, -0.15, 0.25
86635, -0.025, -0.15, 0.22222222222222
86636, -0.05, -0.125, 0.22222222222222
86637, -0.05, -0.15, 0.19444444444444
86638, -0.025, -0.15, 0.16666666666667
86639, -0.05, -0.125, 0.16666666666667
86640, -0.05, -0.15, 0.13888888888889
86641, -0.025, -0.15, 0.11111111111111
86642, -0.05, -0.125, 0.11111111111111
86643, -0.05, -0.15, 0.083333333333333
86644, -0.025, -0.15, 0.055555555555556
86645, -0.05, -0.125, 0.055555555555556
86646, -0.05, -0.15, 0.027777777777778
86647, -0.075, -0.15, 0.44444444444444
86648, -0.075, -0.15, 0.38888888888889
86649, -0.075, -0.15, 0.33333333333333
86650, -0.075, -0.15, 0.27777777777778
86651, -0.075, -0.15, 0.22222222222222
86652, -0.075, -0.15, 0.16666666666667
86653, -0.075, -0.15, 0.11111111111111
86654, -0.075, -0.15, 0.055555555555556
86655, -0.05, -0.2, 0.47222222222222
86656, -0.025, -0.2, 0.44444444444444
86657, -0.05, -0.175, 0.44444444444444
86658, -0.05, -0.2, 0.41666666666667
86659, -0.025, -0.2, 0.38888888888889
86660, -0.05, -0.175, 0.38888888888889
86661, -0.05, -0.2, 0.36111111111111
86662, -0.025, -0.2, 0.33333333333333
86663, -0.05, -0.175, 0.33333333333333
86664, -0.05, -0.2, 0.30555555555556
86665, -0.025, -0.2, 0.27777777777778
86666, -0.05, -0.175, 0.27777777777778
86667, -0.05, -0.2, 0.25
86668, -0.025, -0.2, 0.22222222222222
86669, -0.05, -0.175, 0.22222222222222
86670, -0.05, -0.2, 0.19444444444444
86671, -0.025, -0.2, 0.16666666666667
86672, -0.05, -0.175, 0.16666666666667
86673, -0.05, -0.2, 0.13888888888889
86674, -0.025, -0.2, 0.11111111111111
86675, -0.05, -0.175, 0.11111111111111
86676, -0.05, -0.2, 0.083333333333333
86677, -0.025, -0.2, 0.055555555555556
86678, -0.05, -0.175, 0.055555555555556
86679, -0.05, -0.2, 0.027777777777778
86680, -0.075, -0.2, 0.44444444444444
86681, -0.075, -0.2, 0.38888888888889
86682, -0.075, -0.2, 0.33333333333333
86683, -0.075, -0.2, 0.27777777777778
86684, -0.075, -0.2, 0.22222222222222
86685, -0.075, -0.2, 0.16666666666667
86686, -0.075, -0.2, 0.11111111111111
86687, -0.075, -0.2, 0.055555555555556
86688, -0.05, -0.225, 0.44444444444444
86689, -0.05, -0.225, 0.38888888888889
86690, -0.05, -0.225, 0.33333333333333
86691, -0.05, -0.225, 0.27777777777778
86692, -0.05, -0.225, 0.22222222222222
86693, -0.05, -0.225, 0.16666666666667
86694, -0.05, -0.225, 0.11111111111111
86695, -0.05, -0.225, 0.055555555555556
86696, 1.2434782608696, -0.1, 0.44444444444444
86697, 1.2434782608696, -0.1, 0.38888888888889
86698, 1.2434782608696, -0.1, 0.33333333333333
86699, 1.2434782608696, -0.1, 0.27777777777778
86700, 1.2434782608696, -0.1, 0.22222222222222
86701, 1.2434782608696, -0.1, 0.16666666666667
86702, 1.2434782608696, -0.1, 0.11111111111111
86703, 1.2434782608696, -0.1, 0.055555555555556
86704, 1.2869565217391, -0.1, 0.44444444444444
86705, 1.2869565217391, -0.1, 0.38888888888889
86706, 1.2869565217391, -0.1, 0.33333333333333
86707, 1.2869565217391, -0.1, 0.27777777777778
86708, 1.2869565217391, -0.1, 0.22222222222222
86709, 1.2869565217391, -0.1, 0.16666666666667
86710, 1.2869565217391, -0.1, 0.11111111111111
86711, 1.2869565217391, -0.1, 0.055555555555556
86712, 1.3304347826087, -0.1, 0.44444444444444
86713, 1.3304347826087, -0.1, 0.38888888888889
86714, 1.3304347826087, -0.1, 0.33333333333333
86715, 1.3304347826087, -0.1, 0.27777777777778
86716, 1.3304347826087, -0.1, 0.22222222222222
86717, 1.3304347826087, -0.1, 0.16666666666667
86718, 1.3304347826087, -0.1, 0.11111111111111
86719, 1.3304347826087, -0.1, 0.055555555555556
86720, 1.3739130434783, -0.1, 0.44444444444444
86721, 1.3739130434783, -0.1, 0.38888888888889
86722, 1.3739130434783, -0.1, 0.33333333333333
86723, 1.3739130434783, -0.1, 0.27777777777778
86724, 1.3739130434783, -0.1, 0.22222222222222
86725, 1.3739130434783, -0.1, 0.16666666666667
86726, 1.3739130434783, -0.1, 0.11111111111111
86727, 1.3739130434783, -0.1, 0.055555555555556
86728, 1.4173913043478, -0.1, 0.44444444444444
86729, 1.4173913043478, -0.1, 0.38888888888889
86730, 1.4173913043478, -0.1, 0.33333333333333
86731, 1.4173913043478, -0.1, 0.27777777777778
86732, 1.4173913043478, -0.1, 0.22222222222222
86733, 1.4173913043478, -0.1, 0.16666666666667
86734, 1.4173913043478, -0.1, 0.11111111111111
86735, 1.4173913043478, -0.1, 0.055555555555556
86736, 1.4608695652174, -0.1, 0.44444444444444
86737, 1.4608695652174, -0.1, 0.38888888888889
86738, 1.4608695652174, -0.1, 0.33333333333333
86739, 1.4608695652174, -0.1, 0.27777777777778
86740, 1.4608695652174, -0.1, 0.22222222222222
86741, 1.4608695652174, -0.1, 0.16666666666667
86742, 1.4608695652174, -0.1, 0.11111111111111
86743, 1.4608695652174, -0.1, 0.055555555555556
86744, 1.504347826087, -0.1, 0.44444444444444
86745, 1.504347826087, -0.1, 0.38888888888889
86746, 1.504347826087, -0.1, 0.33333333333333
86747, 1.504347826087, -0.1, 0.27777777777778
86748, 1.504347826087, -0.1, 0.22222222222222
86749, 1.504347826087, -0.1, 0.16666666666667
86750, 1.504347826087, -0.1, 0.11111111111111
86751, 1.504347826087, -0.1, 0.055555555555556
86752, 1.5478260869565, -0.1, 0.44444444444444
86753, 1.5478260869565, -0.1, 0.38888888888889
86754, 1.5478260869565, -0.1, 0.33333333333333
86755, 1.5478260869565, -0.1, 0.27777777777778
86756, 1.5478260869565, -0.1, 0.22222222222222
86757, 1.5478260869565, -0.1, 0.16666666666667
86758, 1.5478260869565, -0.1, 0.11111111111111
86759, 1.5478260869565, -0.1, 0.055555555555556
86760, 1.5913043478261, -0.1, 0.44444444444444
86761, 1.5913043478261, -0.1, 0.38888888888889
86762, 1.5913043478261, -0.1, 0.33333333333333
86763, 1.5913043478261, -0.1, 0.27777777777778
86764, 1.5913043478261, -0.1, 0.22222222222222
86765, 1.5913043478261, -0.1, 0.16666666666667
86766, 1.5913043478261, -0.1, 0.11111111111111
86767, 1.5913043478261, -0.1, 0.055555555555556
86768, 1.6347826086957, -0.1, 0.44444444444444
86769, 1.6347826086957, -0.1, 0.38888888888889
86770, 1.6347826086957, -0.1, 0.33333333333333
86771, 1.6347826086957, -0.1, 0.27777777777778
86772, 1.6347826086957, -0.1, 0.22222222222222
86773, 1.6347826086957, -0.1, 0.16666666666667
86774, 1.6347826086957, -0.1, 0.11111111111111
86775, 1.6347826086957, -0.1, 0.055555555555556
86776, 1.6782608695652, -0.1, 0.44444444444444
86777, 1.6782608695652, -0.1, 0.38888888888889
86778, 1.6782608695652, -0.1, 0.33333333333333
86779, 1.6782608695652, -0.1, 0.27777777777778
86780, 1.6782608695652, -0.1, 0.22222222222222
86781, 1.6782608695652, -0.1, 0.16666666666667
86782, 1.6782608695652, -0.1, 0.11111111111111
86783, 1.6782608695652, -0.1, 0.055555555555556
86784, 1.7217391304348, -0.1, 0.44444444444444
86785, 1.7217391304348, -0.1, 0.38888888888889
86786, 1.7217391304348, -0.1, 0.33333333333333
86787, 1.7217391304348, -0.1, 0.27777777777778
86788, 1.7217391304348, -0.1, 0.22222222222222
86789, 1.7217391304348, -0.1, 0.16666666666667
86790, 1.7217391304348, -0.1, 0.11111111111111
86791, 1.7217391304348, -0.1, 0.055555555555556
86792, 1.7652173913043, -0.1, 0.44444444444444
86793, 1.7652173913043, -0.1, 0.38888888888889
86794, 1.7652173913043, -0.1, 0.33333333333333
86795, 1.7652173913043, -0.1, 0.27777777777778
86796, 1.7652173913043, -0.1, 0.22222222222222
86797, 1.7652173913043, -0.1, 0.16666666666667
86798, 1.7652173913043, -0.1, 0.11111111111111
86799, 1.7652173913043, -0.1, 0.055555555555556
86800, 1.8086956521739, -0.1, 0.44444444444444
86801, 1.8086956521739, -0.1, 0.38888888888889
86802, 1.8086956521739, -0.1, 0.33333333333333
86803, 1.8086956521739, -0.1, 0.27777777777778
86804, 1.8086956521739, -0.1, 0.22222222222222
86805, 1.8086956521739, -0.1, 0.16666666666667
86806, 1.8086956521739, -0.1, 0.11111111111111
86807, 1.8086956521739, -0.1, 0.055555555555556
86808, 1.8521739130435, -0.1, 0.44444444444444
86809, 1.8521739130435, -0.1, 0.38888888888889
86810, 1.8521739130435, -0.1, 0.33333333333333
86811, 1.8521739130435, -0.1, 0.27777777777778
86812, 1.8521739130435, -0.1, 0.22222222222222
86813, 1.8521739130435, -0.1, 0.16666666666667
86814, 1.8521739130435, -0.1, 0.11111111111111
86815, 1.8521739130435, -0.1, 0.055555555555556
86816, 1.895652173913, -0.1, 0.44444444444444
86817, 1.895652173913, -0.1, 0.38888888888889
86818, 1.895652173913, -0.1, 0.33333333333333
86819, 1.895652173913, -0.1, 0.27777777777778
86820, 1.895652173913, -0.1, 0.22222222222222
86821, 1.895652173913, -0.1, 0.16666666666667
86822, 1.895652173913, -0.1, 0.11111111111111
86823, 1.895652173913, -0.1, 0.055555555555556
86824, 1.9391304347826, -0.1, 0.44444444444444
86825, 1.9391304347826, -0.1, 0.38888888888889
86826, 1.9391304347826, -0.1, 0.33333333333333
86827, 1.9391304347826, -0.1, 0.27777777777778
86828, 1.9391304347826, -0.1, 0.22222222222222
86829, 1.9391304347826, -0.1, 0.16666666666667
86830, 1.9391304347826, -0.1, 0.11111111111111
86831, 1.9391304347826, -0.1, 0.055555555555556
86832, 1.9826086956522, -0.1, 0.44444444444444
86833, 1.9826086956522, -0.1, 0.38888888888889
86834, 1.9826086956522, -0.1, 0.33333333333333
86835, 1.9826086956522, -0.1, 0.27777777777778
86836, 1.9826086956522, -0.1, 0.22222222222222
86837, 1.9826086956522, -0.1, 0.16666666666667
86838, 1.9826086956522, -0.1, 0.11111111111111
86839, 1.9826086956522, -0.1, 0.055555555555556
86840, 2.0260869565217, -0.1, 0.44444444444444
86841, 2.0260869565217, -0.1, 0.38888888888889
86842, 2.0260869565217, -0.1, 0.33333333333333
86843, 2.0260869565217, -0.1, 0.27777777777778
86844, 2.0260869565217, -0.1, 0.22222222222222
86845, 2.0260869565217, -0.1, 0.16666666666667
86846, 2.0260869565217, -0.1, 0.11111111111111
86847, 2.0260869565217, -0.1, 0.055555555555556
86848, 2.0695652173913, -0.1, 0.44444444444444
86849, 2.0695652173913, -0.1, 0.38888888888889
86850, 2.0695652173913, -0.1, 0.33333333333333
86851, 2.0695652173913, -0.1, 0.27777777777778
86852, 2.0695652173913, -0.1, 0.22222222222222
86853, 2.0695652173913, -0.1, 0.16666666666667
86854, 2.0695652173913, -0.1, 0.11111111111111
86855, 2.0695652173913, -0.1, 0.055555555555556
86856, 2.1130434782609, -0.1, 0.44444444444444
86857, 2.1130434782609, -0.1, 0.38888888888889
86858, 2.1130434782609, -0.1, 0.33333333333333
86859, 2.1130434782609, -0.1, 0.27777777777778
86860, 2.1130434782609, -0.1, 0.22222222222222
86861, 2.1130434782609, -0.1, 0.16666666666667
86862, 2.1130434782609, -0.1, 0.11111111111111
86863, 2.1130434782609, -0.1, 0.055555555555556
86864, 2.1565217391304, -0.1, 0.44444444444444
86865, 2.1565217391304, -0.1, 0.38888888888889
86866, 2.1565217391304, -0.1, 0.33333333333333
86867, 2.1565217391304, -0.1, 0.27777777777778
86868, 2.1565217391304, -0.1, 0.22222222222222
86869, 2.1565217391304, -0.1, 0.16666666666667
86870, 2.1565217391304, -0.1, 0.11111111111111
86871, 2.1565217391304, -0.1, 0.055555555555556
86872, 1.2434782608696, -0.15, 0.44444444444444
86873, 1.2434782608696, -0.15, 0.38888888888889
86874, 1.2434782608696, -0.15, 0.33333333333333
86875, 1.2434782608696, -0.15, 0.27777777777778
86876, 1.2434782608696, -0.15, 0.22222222222222
86877, 1.2434782608696, -0.15, 0.16666666666667
86878, 1.2434782608696, -0.15, 0.11111111111111
86879, 1.2434782608696, -0.15, 0.055555555555556
86880, 1.2869565217391, -0.15, 0.44444444444444
86881, 1.2869565217391, -0.15, 0.38888888888889
86882, 1.2869565217391, -0.15, 0.33333333333333
86883, 1.2869565217391, -0.15, 0.27777777777778
86884, 1.2869565217391, -0.15, 0.22222222222222
86885, 1.2869565217391, -0.15, 0.16666666666667
86886, 1.2869565217391, -0.15, 0.11111111111111
86887, 1.2869565217391, -0.15, 0.055555555555556
86888, 1.3304347826087, -0.15, 0.44444444444444
86889, 1.3304347826087, -0.15, 0.38888888888889
86890, 1.3304347826087, -0.15, 0.33333333333333
86891, 1.3304347826087, -0.15, 0.27777777777778
86892, 1.3304347826087, -0.15, 0.22222222222222
86893, 1.3304347826087, -0.15, 0.16666666666667
86894, 1.3304347826087, -0.15, 0.11111111111111
86895, 1.3304347826087, -0.15, 0.055555555555556
86896, 1.3739130434783, -0.15, 0.44444444444444
86897, 1.3739130434783, -0.15, 0.38888888888889
86898, 1.3739130434783, -0.15, 0.33333333333333
86899, 1.3739130434783, -0.15, 0.27777777777778
86900, 1.3739130434783, -0.15, 0.22222222222222
86901, 1.3739130434783, -0.15, 0.16666666666667
86902, 1.3739130434783, -0.15, 0.11111111111111
86903, 1.3739130434783, -0.15, 0.055555555555556
86904, 1.4173913043478, -0.15, 0.44444444444444
86905, 1.4173913043478, -0.15, 0.38888888888889
86906, 1.4173913043478, -0.15, 0.33333333333333
86907, 1.4173913043478, -0.15, 0.27777777777778
86908, 1.4173913043478, -0.15, 0.22222222222222
86909, 1.4173913043478, -0.15, 0.16666666666667
86910, 1.4173913043478, -0.15, 0.11111111111111
86911, 1.4173913043478, -0.15, 0.055555555555556
86912, 1.4608695652174, -0.15, 0.44444444444444
86913, 1.4608695652174, -0.15, 0.38888888888889
86914, 1.4608695652174, -0.15, 0.33333333333333
86915, 1.4608695652174, -0.15, 0.27777777777778
86916, 1.4608695652174, -0.15, 0.22222222222222
86917, 1.4608695652174, -0.15, 0.16666666666667
86918, 1.4608695652174, -0.15, 0.11111111111111
86919, 1.4608695652174, -0.15, 0.055555555555556
86920, 1.504347826087, -0.15, 0.44444444444444
86921, 1.504347826087, -0.15, 0.38888888888889
86922, 1.504347826087, -0.15, 0.33333333333333
86923, 1.504347826087, -0.15, 0.27777777777778
86924, 1.504347826087, -0.15, 0.22222222222222
86925, 1.504347826087, -0.15, 0.16666666666667
86926, 1.504347826087, -0.15, 0.11111111111111
86927, 1.504347826087, -0.15, 0.055555555555556
86928, 1.5478260869565, -0.15, 0.44444444444444
86929, 1.5478260869565, -0.15, 0.38888888888889
86930, 1.5478260869565, -0.15, 0.33333333333333
86931, 1.5478260869565, -0.15, 0.27777777777778
86932, 1.5478260869565, -0.15, 0.22222222222222
86933, 1.5478260869565, -0.15, 0.16666666666667
86934, 1.5478260869565, -0.15, 0.11111111111111
86935, 1.5478260869565, -0.15, 0.055555555555556
86936, 1.5913043478261, -0.15, 0.44444444444444
86937, 1.5913043478261, -0.15, 0.38888888888889
86938, 1.5913043478261, -0.15, 0.33333333333333
86939, 1.5913043478261, -0.15, 0.27777777777778
86940, 1.5913043478261, -0.15, 0.22222222222222
86941, 1.5913043478261, -0.15, 0.16666666666667
86942, 1.5913043478261, -0.15, 0.11111111111111
86943, 1.5913043478261, -0.15, 0.055555555555556
86944, 1.6347826086957, -0.15, 0.44444444444444
86945, 1.6347826086957, -0.15, 0.38888888888889
86946, 1.6347826086957, -0.15, 0.33333333333333
86947, 1.6347826086957, -0.15, 0.27777777777778
86948, 1.6347826086957, -0.15, 0.22222222222222
86949, 1.6347826086957, -0.15, 0.16666666666667
86950, 1.6347826086957, -0.15, 0.11111111111111
86951, 1.6347826086957, -0.15, 0.055555555555556
86952, 1.6782608695652, -0.15, 0.44444444444444
86953, 1.6782608695652, -0.15, 0.38888888888889
86954, 1.6782608695652, -0.15, 0.33333333333333
86955, 1.6782608695652, -0.15, 0.27777777777778
86956, 1.6782608695652, -0.15, 0.22222222222222
86957, 1.6782608695652, -0.15, 0.16666666666667
86958, 1.6782608695652, -0.15, 0.11111111111111
86959, 1.6782608695652, -0.15, 0.055555555555556
86960, 1.7217391304348, -0.15, 0.44444444444444
86961, 1.7217391304348, -0.15, 0.38888888888889
86962, 1.7217391304348, -0.15, 0.33333333333333
86963, 1.7217391304348, -0.15, 0.27777777777778
86964, 1.7217391304348, -0.15, 0.22222222222222
86965, 1.7217391304348, -0.15, 0.16666666666667
86966, 1.7217391304348, -0.15, 0.11111111111111
86967, 1.7217391304348, -0.15, 0.055555555555556
86968, 1.7652173913043, -0.15, 0.44444444444444
86969, 1.7652173913043, -0.15, 0.38888888888889
86970, 1.7652173913043, -0.15, 0.33333333333333
86971, 1.7652173913043, -0.15, 0.27777777777778
86972, 1.7652173913043, -0.15, 0.22222222222222
86973, 1.7652173913043, -0.15, 0.16666666666667
86974, 1.7652173913043, -0.15, 0.11111111111111
86975, 1.7652173913043, -0.15, 0.055555555555556
86976, 1.8086956521739, -0.15, 0.44444444444444
86977, 1.8086956521739, -0.15, 0.38888888888889
86978, 1.8086956521739, -0.15, 0.33333333333333
86979, 1.8086956521739, -0.15, 0.27777777777778
86980, 1.8086956521739, -0.15, 0.22222222222222
86981, 1.8086956521739, -0.15, 0.16666666666667
86982, 1.8086956521739, -0.15, 0.11111111111111
86983, 1.8086956521739, -0.15, 0.055555555555556
86984, 1.8521739130435, -0.15, 0.44444444444444
86985, 1.8521739130435, -0.15, 0.38888888888889
86986, 1.8521739130435, -0.15, 0.33333333333333
86987, 1.8521739130435, -0.15, 0.27777777777778
86988, 1.8521739130435, -0.15, 0.22222222222222
86989, 1.8521739130435, -0.15, 0.16666666666667
86990, 1.8521739130435, -0.15, 0.11111111111111
86991, 1.8521739130435, -0.15, 0.055555555555556
86992, 1.895652173913, -0.15, 0.44444444444444
86993, 1.895652173913, -0.15, 0.38888888888889
86994, 1.895652173913, -0.15, 0.33333333333333
86995, 1.895652173913, -0.15, 0.27777777777778
86996, 1.895652173913, -0.15, 0.22222222222222
86997, 1.895652173913, -0.15, 0.16666666666667
86998, 1.895652173913, -0.15, 0.11111111111111
86999, 1.895652173913, -0.15, 0.055555555555556
87000, 1.9391304347826, -0.15, 0.44444444444444
87001, 1.9391304347826, -0.15, 0.38888888888889
87002, 1.9391304347826, -0.15, 0.33333333333333
87003, 1.9391304347826, -0.15, 0.27777777777778
87004, 1.9391304347826, -0.15, 0.22222222222222
87005, 1.9391304347826, -0.15, 0.16666666666667
87006, 1.9391304347826, -0.15, 0.11111111111111
87007, 1.9391304347826, -0.15, 0.055555555555556
87008, 1.9826086956522, -0.15, 0.44444444444444
87009, 1.9826086956522, -0.15, 0.38888888888889
87010, 1.9826086956522, -0.15, 0.33333333333333
87011, 1.9826086956522, -0.15, 0.27777777777778
87012, 1.9826086956522, -0.15, 0.22222222222222
87013, 1.9826086956522, -0.15, 0.16666666666667
87014, 1.9826086956522, -0.15, 0.11111111111111
87015, 1.9826086956522, -0.15, 0.055555555555556
87016, 2.0260869565217, -0.15, 0.44444444444444
87017, 2.0260869565217, -0.15, 0.38888888888889
87018, 2.0260869565217, -0.15, 0.33333333333333
87019, 2.0260869565217, -0.15, 0.27777777777778
87020, 2.0260869565217, -0.15, 0.22222222222222
87021, 2.0260869565217, -0.15, 0.16666666666667
87022, 2.0260869565217, -0.15, 0.11111111111111
87023, 2.0260869565217, -0.15, 0.055555555555556
87024, 2.0695652173913, -0.15, 0.44444444444444
87025, 2.0695652173913, -0.15, 0.38888888888889
87026, 2.0695652173913, -0.15, 0.33333333333333
87027, 2.0695652173913, -0.15, 0.27777777777778
87028, 2.0695652173913, -0.15, 0.22222222222222
87029, 2.0695652173913, -0.15, 0.16666666666667
87030, 2.0695652173913, -0.15, 0.11111111111111
87031, 2.0695652173913, -0.15, 0.055555555555556
87032, 2.1130434782609, -0.15, 0.44444444444444
87033, 2.1130434782609, -0.15, 0.38888888888889
87034, 2.1130434782609, -0.15, 0.33333333333333
87035, 2.1130434782609, -0.15, 0.27777777777778
87036, 2.1130434782609, -0.15, 0.22222222222222
87037, 2.1130434782609, -0.15, 0.16666666666667
87038, 2.1130434782609, -0.15, 0.11111111111111
87039, 2.1130434782609, -0.15, 0.055555555555556
87040, 2.1565217391304, -0.15, 0.44444444444444
87041, 2.1565217391304, -0.15, 0.38888888888889
87042, 2.1565217391304, -0.15, 0.33333333333333
87043, 2.1565217391304, -0.15, 0.27777777777778
87044, 2.1565217391304, -0.15, 0.22222222222222
87045, 2.1565217391304, -0.15, 0.16666666666667
87046, 2.1565217391304, -0.15, 0.11111111111111
87047, 2.1565217391304, -0.15, 0.055555555555556
87048, 1.2434782608696, -0.2, 0.44444444444444
87049, 1.2434782608696, -0.2, 0.38888888888889
87050, 1.2434782608696, -0.2, 0.33333333333333
87051, 1.2434782608696, -0.2, 0.27777777777778
87052, 1.2434782608696, -0.2, 0.22222222222222
87053, 1.2434782608696, -0.2, 0.16666666666667
87054, 1.2434782608696, -0.2, 0.11111111111111
87055, 1.2434782608696, -0.2, 0.055555555555556
87056, 1.2869565217391, -0.2, 0.44444444444444
87057, 1.2869565217391, -0.2, 0.38888888888889
87058, 1.2869565217391, -0.2, 0.33333333333333
87059, 1.2869565217391, -0.2, 0.27777777777778
87060, 1.2869565217391, -0.2, 0.22222222222222
87061, 1.2869565217391, -0.2, 0.16666666666667
87062, 1.2869565217391, -0.2, 0.11111111111111
87063, 1.2869565217391, -0.2, 0.055555555555556
87064, 1.3304347826087, -0.2, 0.44444444444444
87065, 1.3304347826087, -0.2, 0.38888888888889
87066, 1.3304347826087, -0.2, 0.33333333333333
87067, 1.3304347826087, -0.2, 0.27777777777778
87068, 1.3304347826087, -0.2, 0.22222222222222
87069, 1.3304347826087, -0.2, 0.16666666666667
87070, 1.3304347826087, -0.2, 0.11111111111111
87071, 1.3304347826087, -0.2, 0.055555555555556
87072, 1.3739130434783, -0.2, 0.44444444444444
87073, 1.3739130434783, -0.2, 0.38888888888889
87074, 1.3739130434783, -0.2, 0.33333333333333
87075, 1.3739130434783, -0.2, 0.27777777777778
87076, 1.3739130434783, -0.2, 0.22222222222222
87077, 1.3739130434783, -0.2, 0.16666666666667
87078, 1.3739130434783, -0.2, 0.11111111111111
87079, 1.3739130434783, -0.2, 0.055555555555556
87080, 1.4173913043478, -0.2, 0.44444444444444
87081, 1.4173913043478, -0.2, 0.38888888888889
87082, 1.4173913043478, -0.2, 0.33333333333333
87083, 1.4173913043478, -0.2, 0.27777777777778
87084, 1.4173913043478, -0.2, 0.22222222222222
87085, 1.4173913043478, -0.2, 0.16666666666667
87086, 1.4173913043478, -0.2, 0.11111111111111
87087, 1.4173913043478, -0.2, 0.055555555555556
87088, 1.4608695652174, -0.2, 0.44444444444444
87089, 1.4608695652174, -0.2, 0.38888888888889
87090, 1.4608695652174, -0.2, 0.33333333333333
87091, 1.4608695652174, -0.2, 0.27777777777778
87092, 1.4608695652174, -0.2, 0.22222222222222
87093, 1.4608695652174, -0.2, 0.16666666666667
87094, 1.4608695652174, -0.2, 0.11111111111111
87095, 1.4608695652174, -0.2, 0.055555555555556
87096, 1.504347826087, -0.2, 0.44444444444444
87097, 1.504347826087, -0.2, 0.38888888888889
87098, 1.504347826087, -0.2, 0.33333333333333
87099, 1.504347826087, -0.2, 0.27777777777778
87100, 1.504347826087, -0.2, 0.22222222222222
87101, 1.504347826087, -0.2, 0.16666666666667
87102, 1.504347826087, -0.2, 0.11111111111111
87103, 1.504347826087, -0.2, 0.055555555555556
87104, 1.5478260869565, -0.2, 0.44444444444444
87105, 1.5478260869565, -0.2, 0.38888888888889
87106, 1.5478260869565, -0.2, 0.33333333333333
87107, 1.5478260869565, -0.2, 0.27777777777778
87108, 1.5478260869565, -0.2, 0.22222222222222
87109, 1.5478260869565, -0.2, 0.16666666666667
87110, 1.5478260869565, -0.2, 0.11111111111111
87111, 1.5478260869565, -0.2, 0.055555555555556
87112, 1.5913043478261, -0.2, 0.44444444444444
87113, 1.5913043478261, -0.2, 0.38888888888889
87114, 1.5913043478261, -0.2, 0.33333333333333
87115, 1.5913043478261, -0.2, 0.27777777777778
87116, 1.5913043478261, -0.2, 0.22222222222222
87117, 1.5913043478261, -0.2, 0.16666666666667
87118, 1.5913043478261, -0.2, 0.11111111111111
87119, 1.5913043478261, -0.2, 0.055555555555556
87120, 1.6347826086957, -0.2, 0.44444444444444
87121, 1.6347826086957, -0.2, 0.38888888888889
87122, 1.6347826086957, -0.2, 0.33333333333333
87123, 1.6347826086957, -0.2, 0.27777777777778
87124, 1.6347826086957, -0.2, 0.22222222222222
87125, 1.6347826086957, -0.2, 0.16666666666667
87126, 1.6347826086957, -0.2, 0.11111111111111
87127, 1.6347826086957, -0.2, 0.055555555555556
87128, 1.6782608695652, -0.2, 0.44444444444444
87129, 1.6782608695652, -0.2, 0.38888888888889
87130, 1.6782608695652, -0.2, 0.33333333333333
87131, 1.6782608695652, -0.2, 0.27777777777778
87132, 1.6782608695652, -0.2, 0.22222222222222
87133, 1.6782608695652, -0.2, 0.16666666666667
87134, 1.6782608695652, -0.2, 0.11111111111111
87135, 1.6782608695652, -0.2, 0.055555555555556
87136, 1.7217391304348, -0.2, 0.44444444444444
87137, 1.7217391304348, -0.2, 0.38888888888889
87138, 1.7217391304348, -0.2, 0.33333333333333
87139, 1.7217391304348, -0.2, 0.27777777777778
87140, 1.7217391304348, -0.2, 0.22222222222222
87141, 1.7217391304348, -0.2, 0.16666666666667
87142, 1.7217391304348, -0.2, 0.11111111111111
87143, 1.7217391304348, -0.2, 0.055555555555556
87144, 1.7652173913043, -0.2, 0.44444444444444
87145, 1.7652173913043, -0.2, 0.38888888888889
87146, 1.7652173913043, -0.2, 0.33333333333333
87147, 1.7652173913043, -0.2, 0.27777777777778
87148, 1.7652173913043, -0.2, 0.22222222222222
87149, 1.7652173913043, -0.2, 0.16666666666667
87150, 1.7652173913043, -0.2, 0.11111111111111
87151, 1.7652173913043, -0.2, 0.055555555555556
87152, 1.8086956521739, -0.2, 0.44444444444444
87153, 1.8086956521739, -0.2, 0.38888888888889
87154, 1.8086956521739, -0.2, 0.33333333333333
87155, 1.8086956521739, -0.2, 0.27777777777778
87156, 1.8086956521739, -0.2, 0.22222222222222
87157, 1.8086956521739, -0.2, 0.16666666666667
87158, 1.8086956521739, -0.2, 0.11111111111111
87159, 1.8086956521739, -0.2, 0.055555555555556
87160, 1.8521739130435, -0.2, 0.44444444444444
87161, 1.8521739130435, -0.2, 0.38888888888889
87162, 1.8521739130435, -0.2, 0.33333333333333
87163, 1.8521739130435, -0.2, 0.27777777777778
87164, 1.8521739130435, -0.2, 0.22222222222222
87165, 1.8521739130435, -0.2, 0.16666666666667
87166, 1.8521739130435, -0.2, 0.11111111111111
87167, 1.8521739130435, -0.2, 0.055555555555556
87168, 1.895652173913, -0.2, 0.44444444444444
87169, 1.895652173913, -0.2, 0.38888888888889
87170, 1.895652173913, -0.2, 0.33333333333333
87171, 1.895652173913, -0.2, 0.27777777777778
87172, 1.895652173913, -0.2, 0.22222222222222
87173, 1.895652173913, -0.2, 0.16666666666667
87174, 1.895652173913, -0.2, 0.11111111111111
87175, 1.895652173913, -0.2, 0.055555555555556
87176, 1.9391304347826, -0.2, 0.44444444444444
87177, 1.9391304347826, -0.2, 0.38888888888889
87178, 1.9391304347826, -0.2, 0.33333333333333
87179, 1.9391304347826, -0.2, 0.27777777777778
87180, 1.9391304347826, -0.2, 0.22222222222222
87181, 1.9391304347826, -0.2, 0.16666666666667
87182, 1.9391304347826, -0.2, 0.11111111111111
87183, 1.9391304347826, -0.2, 0.055555555555556
87184, 1.9826086956522, -0.2, 0.44444444444444
87185, 1.9826086956522, -0.2, 0.38888888888889
87186, 1.9826086956522, -0.2, 0.33333333333333
87187, 1.9826086956522, -0.2, 0.27777777777778
87188, 1.9826086956522, -0.2, 0.22222222222222
87189, 1.9826086956522, -0.2, 0.16666666666667
87190, 1.9826086956522, -0.2, 0.11111111111111
87191, 1.9826086956522, -0.2, 0.055555555555556
87192, 2.0260869565217, -0.2, 0.44444444444444
87193, 2.0260869565217, -0.2, 0.38888888888889
87194, 2.0260869565217, -0.2, 0.33333333333333
87195, 2.0260869565217, -0.2, 0.27777777777778
87196, 2.0260869565217, -0.2, 0.22222222222222
87197, 2.0260869565217, -0.2, 0.16666666666667
87198, 2.0260869565217, -0.2, 0.11111111111111
87199, 2.0260869565217, -0.2, 0.055555555555556
87200, 2.0695652173913, -0.2, 0.44444444444444
87201, 2.0695652173913, -0.2, 0.38888888888889
87202, 2.0695652173913, -0.2, 0.33333333333333
87203, 2.0695652173913, -0.2, 0.27777777777778
87204, 2.0695652173913, -0.2, 0.22222222222222
87205, 2.0695652173913, -0.2, 0.16666666666667
87206, 2.0695652173913, -0.2, 0.11111111111111
87207, 2.0695652173913, -0.2, 0.055555555555556
87208, 2.1130434782609, -0.2, 0.44444444444444
87209, 2.1130434782609, -0.2, 0.38888888888889
87210, 2.1130434782609, -0.2, 0.33333333333333
87211, 2.1130434782609, -0.2, 0.27777777777778
87212, 2.1130434782609, -0.2, 0.22222222222222
87213, 2.1130434782609, -0.2, 0.16666666666667
87214, 2.1130434782609, -0.2, 0.11111111111111
87215, 2.1130434782609, -0.2, 0.055555555555556
87216, 2.1565217391304, -0.2, 0.44444444444444
87217, 2.1565217391304, -0.2, 0.38888888888889
87218, 2.1565217391304, -0.2, 0.33333333333333
87219, 2.1565217391304, -0.2, 0.27777777777778
87220, 2.1565217391304, -0.2, 0.22222222222222
87221, 2.1565217391304, -0.2, 0.16666666666667
87222, 2.1565217391304, -0.2, 0.11111111111111
87223, 2.1565217391304, -0.2, 0.055555555555556
87224, 1.2434782608696, -0.1, 0.47222222222222
87225, 1.2217391304348, -0.1, 0.44444444444444
87226, 1.2434782608696, -0.075, 0.44444444444444
87227, 1.2434782608696, -0.1, 0.41666666666667
87228, 1.2217391304348, -0.1, 0.38888888888889
87229, 1.2434782608696, -0.075, 0.38888888888889
87230, 1.2434782608696, -0.1, 0.36111111111111
87231, 1.2217391304348, -0.1, 0.33333333333333
87232, 1.2434782608696, -0.075, 0.33333333333333
87233, 1.2434782608696, -0.1, 0.30555555555556
87234, 1.2217391304348, -0.1, 0.27777777777778
87235, 1.2434782608696, -0.075, 0.27777777777778
87236, 1.2434782608696, -0.1, 0.25
87237, 1.2217391304348, -0.1, 0.22222222222222
87238, 1.2434782608696, -0.075, 0.22222222222222
87239, 1.2434782608696, -0.1, 0.19444444444444
87240, 1.2217391304348, -0.1, 0.16666666666667
87241, 1.2434782608696, -0.075, 0.16666666666667
87242, 1.2434782608696, -0.1, 0.13888888888889
87243, 1.2217391304348, -0.1, 0.11111111111111
87244, 1.2434782608696, -0.075, 0.11111111111111
87245, 1.2434782608696, -0.1, 0.083333333333333
87246, 1.2217391304348, -0.1, 0.055555555555556
87247, 1.2434782608696, -0.075, 0.055555555555556
87248, 1.2434782608696, -0.1, 0.027777777777778
87249, 1.2869565217391, -0.1, 0.47222222222222
87250, 1.2652173913043, -0.1, 0.44444444444444
87251, 1.2869565217391, -0.075, 0.44444444444444
87252, 1.2869565217391, -0.1, 0.41666666666667
87253, 1.2652173913043, -0.1, 0.38888888888889
87254, 1.2869565217391, -0.075, 0.38888888888889
87255, 1.2869565217391, -0.1, 0.36111111111111
87256, 1.2652173913043, -0.1, 0.33333333333333
87257, 1.2869565217391, -0.075, 0.33333333333333
87258, 1.2869565217391, -0.1, 0.30555555555556
87259, 1.2652173913043, -0.1, 0.27777777777778
87260, 1.2869565217391, -0.075, 0.27777777777778
87261, 1.2869565217391, -0.1, 0.25
87262, 1.2652173913043, -0.1, 0.22222222222222
87263, 1.2869565217391, -0.075, 0.22222222222222
87264, 1.2869565217391, -0.1, 0.19444444444444
87265, 1.2652173913043, -0.1, 0.16666666666667
87266, 1.2869565217391, -0.075, 0.16666666666667
87267, 1.2869565217391, -0.1, 0.13888888888889
87268, 1.2652173913043, -0.1, 0.11111111111111
87269, 1.2869565217391, -0.075, 0.11111111111111
87270, 1.2869565217391, -0.1, 0.083333333333333
87271, 1.2652173913043, -0.1, 0.055555555555556
87272, 1.2869565217391, -0.075, 0.055555555555556
87273, 1.2869565217391, -0.1, 0.027777777777778
87274, 1.3304347826087, -0.1, 0.47222222222222
87275, 1.3086956521739, -0.1, 0.44444444444444
87276, 1.3304347826087, -0.075, 0.44444444444444
87277, 1.3304347826087, -0.1, 0.41666666666667
87278, 1.3086956521739, -0.1, 0.38888888888889
87279, 1.3304347826087, -0.075, 0.38888888888889
87280, 1.3304347826087, -0.1, 0.36111111111111
87281, 1.3086956521739, -0.1, 0.33333333333333
87282, 1.3304347826087, -0.075, 0.33333333333333
87283, 1.3304347826087, -0.1, 0.30555555555556
87284, 1.3086956521739, -0.1, 0.27777777777778
87285, 1.3304347826087, -0.075, 0.27777777777778
87286, 1.3304347826087, -0.1, 0.25
87287, 1.3086956521739, -0.1, 0.22222222222222
87288, 1.3304347826087, -0.075, 0.22222222222222
87289, 1.3304347826087, -0.1, 0.19444444444444
87290, 1.3086956521739, -0.1, 0.16666666666667
87291, 1.3304347826087, -0.075, 0.16666666666667
87292, 1.3304347826087, -0.1, 0.13888888888889
87293, 1.3086956521739, -0.1, 0.11111111111111
87294, 1.3304347826087, -0.075, 0.11111111111111
87295, 1.3304347826087, -0.1, 0.083333333333333
87296, 1.3086956521739, -0.1, 0.055555555555556
87297, 1.3304347826087, -0.075, 0.055555555555556
87298, 1.3304347826087, -0.1, 0.027777777777778
87299, 1.3739130434783, -0.1, 0.47222222222222
87300, 1.3521739130435, -0.1, 0.44444444444444
87301, 1.3739130434783, -0.075, 0.44444444444444
87302, 1.3739130434783, -0.1, 0.41666666666667
87303, 1.3521739130435, -0.1, 0.38888888888889
87304, 1.3739130434783, -0.075, 0.38888888888889
87305, 1.3739130434783, -0.1, 0.36111111111111
87306, 1.3521739130435, -0.1, 0.33333333333333
87307, 1.3739130434783, -0.075, 0.33333333333333
87308, 1.3739130434783, -0.1, 0.30555555555556
87309, 1.3521739130435, -0.1, 0.27777777777778
87310, 1.3739130434783, -0.075, 0.27777777777778
87311, 1.3739130434783, -0.1, 0.25
87312, 1.3521739130435, -0.1, 0.22222222222222
87313, 1.3739130434783, -0.075, 0.22222222222222
87314, 1.3739130434783, -0.1, 0.19444444444444
87315, 1.3521739130435, -0.1, 0.16666666666667
87316, 1.3739130434783, -0.075, 0.16666666666667
87317, 1.3739130434783, -0.1, 0.13888888888889
87318, 1.3521739130435, -0.1, 0.11111111111111
87319, 1.3739130434783, -0.075, 0.11111111111111
87320, 1.3739130434783, -0.1, 0.083333333333333
87321, 1.3521739130435, -0.1, 0.055555555555556
87322, 1.3739130434783, -0.075, 0.055555555555556
87323, 1.3739130434783, -0.1, 0.027777777777778
87324, 1.4173913043478, -0.1, 0.47222222222222
87325, 1.395652173913, -0.1, 0.44444444444444
87326, 1.4173913043478, -0.075, 0.44444444444444
87327, 1.4173913043478, -0.1, 0.41666666666667
87328, 1.395652173913, -0.1, 0.38888888888889
87329, 1.4173913043478, -0.075, 0.38888888888889
87330, 1.4173913043478, -0.1, 0.36111111111111
87331, 1.395652173913, -0.1, 0.33333333333333
87332, 1.4173913043478, -0.075, 0.33333333333333
87333, 1.4173913043478, -0.1, 0.30555555555556
87334, 1.395652173913, -0.1, 0.27777777777778
87335, 1.4173913043478, -0.075, 0.27777777777778
87336, 1.4173913043478, -0.1, 0.25
87337, 1.395652173913, -0.1, 0.22222222222222
87338, 1.4173913043478, -0.075, 0.22222222222222
87339, 1.4173913043478, -0.1, 0.19444444444444
87340, 1.395652173913, -0.1, 0.16666666666667
87341, 1.4173913043478, -0.075, 0.16666666666667
87342, 1.4173913043478, -0.1, 0.13888888888889
87343, 1.395652173913, -0.1, 0.11111111111111
87344, 1.4173913043478, -0.075, 0.11111111111111
87345, 1.4173913043478, -0.1, 0.083333333333333
87346, 1.395652173913, -0.1, 0.055555555555556
87347, 1.4173913043478, -0.075, 0.055555555555556
87348, 1.4173913043478, -0.1, 0.027777777777778
87349, 1.4608695652174, -0.1, 0.47222222222222
87350, 1.4391304347826, -0.1, 0.44444444444444
87351, 1.4608695652174, -0.075, 0.44444444444444
87352, 1.4608695652174, -0.1, 0.41666666666667
87353, 1.4391304347826, -0.1, 0.38888888888889
87354, 1.4608695652174, -0.075, 0.38888888888889
87355, 1.4608695652174, -0.1, 0.36111111111111
87356, 1.4391304347826, -0.1, 0.33333333333333
87357, 1.4608695652174, -0.075, 0.33333333333333
87358, 1.4608695652174, -0.1, 0.30555555555556
87359, 1.4391304347826, -0.1, 0.27777777777778
87360, 1.4608695652174, -0.075, 0.27777777777778
87361, 1.4608695652174, -0.1, 0.25
87362, 1.4391304347826, -0.1, 0.22222222222222
87363, 1.4608695652174, -0.075, 0.22222222222222
87364, 1.4608695652174, -0.1, 0.19444444444444
87365, 1.4391304347826, -0.1, 0.16666666666667
87366, 1.4608695652174, -0.075, 0.16666666666667
87367, 1.4608695652174, -0.1, 0.13888888888889
87368, 1.4391304347826, -0.1, 0.11111111111111
87369, 1.4608695652174, -0.075, 0.11111111111111
87370, 1.4608695652174, -0.1, 0.083333333333333
87371, 1.4391304347826, -0.1, 0.055555555555556
87372, 1.4608695652174, -0.075, 0.055555555555556
87373, 1.4608695652174, -0.1, 0.027777777777778
87374, 1.504347826087, -0.1, 0.47222222222222
87375, 1.4826086956522, -0.1, 0.44444444444444
87376, 1.504347826087, -0.075, 0.44444444444444
87377, 1.504347826087, -0.1, 0.41666666666667
87378, 1.4826086956522, -0.1, 0.38888888888889
87379, 1.504347826087, -0.075, 0.38888888888889
87380, 1.504347826087, -0.1, 0.36111111111111
87381, 1.4826086956522, -0.1, 0.33333333333333
87382, 1.504347826087, -0.075, 0.33333333333333
87383, 1.504347826087, -0.1, 0.30555555555556
87384, 1.4826086956522, -0.1, 0.27777777777778
87385, 1.504347826087, -0.075, 0.27777777777778
87386, 1.504347826087, -0.1, 0.25
87387, 1.4826086956522, -0.1, 0.22222222222222
87388, 1.504347826087, -0.075, 0.22222222222222
87389, 1.504347826087, -0.1, 0.19444444444444
87390, 1.4826086956522, -0.1, 0.16666666666667
87391, 1.504347826087, -0.075, 0.16666666666667
87392, 1.504347826087, -0.1, 0.13888888888889
87393, 1.4826086956522, -0.1, 0.11111111111111
87394, 1.504347826087, -0.075, 0.11111111111111
87395, 1.504347826087, -0.1, 0.083333333333333
87396, 1.4826086956522, -0.1, 0.055555555555556
87397, 1.504347826087, -0.075, 0.055555555555556
87398, 1.504347826087, -0.1, 0.027777777777778
87399, 1.5478260869565, -0.1, 0.47222222222222
87400, 1.5260869565217, -0.1, 0.44444444444444
87401, 1.5478260869565, -0.075, 0.44444444444444
87402, 1.5478260869565, -0.1, 0.41666666666667
87403, 1.5260869565217, -0.1, 0.38888888888889
87404, 1.5478260869565, -0.075, 0.38888888888889
87405, 1.5478260869565, -0.1, 0.36111111111111
87406, 1.5260869565217, -0.1, 0.33333333333333
87407, 1.5478260869565, -0.075, 0.33333333333333
87408, 1.5478260869565, -0.1, 0.30555555555556
87409, 1.5260869565217, -0.1, 0.27777777777778
87410, 1.5478260869565, -0.075, 0.27777777777778
87411, 1.5478260869565, -0.1, 0.25
87412, 1.5260869565217, -0.1, 0.22222222222222
87413, 1.5478260869565, -0.075, 0.22222222222222
87414, 1.5478260869565, -0.1, 0.19444444444444
87415, 1.5260869565217, -0.1, 0.16666666666667
87416, 1.5478260869565, -0.075, 0.16666666666667
87417, 1.5478260869565, -0.1, 0.13888888888889
87418, 1.5260869565217, -0.1, 0.11111111111111
87419, 1.5478260869565, -0.075, 0.11111111111111
87420, 1.5478260869565, -0.1, 0.083333333333333
87421, 1.5260869565217, -0.1, 0.055555555555556
87422, 1.5478260869565, -0.075, 0.055555555555556
87423, 1.5478260869565, -0.1, 0.027777777777778
87424, 1.5913043478261, -0.1, 0.47222222222222
87425, 1.5695652173913, -0.1, 0.44444444444444
87426, 1.5913043478261, -0.075, 0.44444444444444
87427, 1.5913043478261, -0.1, 0.41666666666667
87428, 1.5695652173913, -0.1, 0.38888888888889
87429, 1.5913043478261, -0.075, 0.38888888888889
87430, 1.5913043478261, -0.1, 0.36111111111111
87431, 1.5695652173913, -0.1, 0.33333333333333
87432, 1.5913043478261, -0.075, 0.33333333333333
87433, 1.5913043478261, -0.1, 0.30555555555556
87434, 1.5695652173913, -0.1, 0.27777777777778
87435, 1.5913043478261, -0.075, 0.27777777777778
87436, 1.5913043478261, -0.1, 0.25
87437, 1.5695652173913, -0.1, 0.22222222222222
87438, 1.5913043478261, -0.075, 0.22222222222222
87439, 1.5913043478261, -0.1, 0.19444444444444
87440, 1.5695652173913, -0.1, 0.16666666666667
87441, 1.5913043478261, -0.075, 0.16666666666667
87442, 1.5913043478261, -0.1, 0.13888888888889
87443, 1.5695652173913, -0.1, 0.11111111111111
87444, 1.5913043478261, -0.075, 0.11111111111111
87445, 1.5913043478261, -0.1, 0.083333333333333
87446, 1.5695652173913, -0.1, 0.055555555555556
87447, 1.5913043478261, -0.075, 0.055555555555556
87448, 1.5913043478261, -0.1, 0.027777777777778
87449, 1.6347826086957, -0.1, 0.47222222222222
87450, 1.6130434782609, -0.1, 0.44444444444444
87451, 1.6347826086957, -0.075, 0.44444444444444
87452, 1.6347826086957, -0.1, 0.41666666666667
87453, 1.6130434782609, -0.1, 0.38888888888889
87454, 1.6347826086957, -0.075, 0.38888888888889
87455, 1.6347826086957, -0.1, 0.36111111111111
87456, 1.6130434782609, -0.1, 0.33333333333333
87457, 1.6347826086957, -0.075, 0.33333333333333
87458, 1.6347826086957, -0.1, 0.30555555555556
87459, 1.6130434782609, -0.1, 0.27777777777778
87460, 1.6347826086957, -0.075, 0.27777777777778
87461, 1.6347826086957, -0.1, 0.25
87462, 1.6130434782609, -0.1, 0.22222222222222
87463, 1.6347826086957, -0.075, 0.22222222222222
87464, 1.6347826086957, -0.1, 0.19444444444444
87465, 1.6130434782609, -0.1, 0.16666666666667
87466, 1.6347826086957, -0.075, 0.16666666666667
87467, 1.6347826086957, -0.1, 0.13888888888889
87468, 1.6130434782609, -0.1, 0.11111111111111
87469, 1.6347826086957, -0.075, 0.11111111111111
87470, 1.6347826086957, -0.1, 0.083333333333333
87471, 1.6130434782609, -0.1, 0.055555555555556
87472, 1.6347826086957, -0.075, 0.055555555555556
87473, 1.6347826086957, -0.1, 0.027777777777778
87474, 1.6782608695652, -0.1, 0.47222222222222
87475, 1.6565217391304, -0.1, 0.44444444444444
87476, 1.6782608695652, -0.075, 0.44444444444444
87477, 1.6782608695652, -0.1, 0.41666666666667
87478, 1.6565217391304, -0.1, 0.38888888888889
87479, 1.6782608695652, -0.075, 0.38888888888889
87480, 1.6782608695652, -0.1, 0.36111111111111
87481, 1.6565217391304, -0.1, 0.33333333333333
87482, 1.6782608695652, -0.075, 0.33333333333333
87483, 1.6782608695652, -0.1, 0.30555555555556
87484, 1.6565217391304, -0.1, 0.27777777777778
87485, 1.6782608695652, -0.075, 0.27777777777778
87486, 1.6782608695652, -0.1, 0.25
87487, 1.6565217391304, -0.1, 0.22222222222222
87488, 1.6782608695652, -0.075, 0.22222222222222
87489, 1.6782608695652, -0.1, 0.19444444444444
87490, 1.6565217391304, -0.1, 0.16666666666667
87491, 1.6782608695652, -0.075, 0.16666666666667
87492, 1.6782608695652, -0.1, 0.13888888888889
87493, 1.6565217391304, -0.1, 0.11111111111111
87494, 1.6782608695652, -0.075, 0.11111111111111
87495, 1.6782608695652, -0.1, 0.083333333333333
87496, 1.6565217391304, -0.1, 0.055555555555556
87497, 1.6782608695652, -0.075, 0.055555555555556
87498, 1.6782608695652, -0.1, 0.027777777777778
87499, 1.7217391304348, -0.1, 0.47222222222222
87500, 1.7, -0.1, 0.44444444444444
87501, 1.7217391304348, -0.075, 0.44444444444444
87502, 1.7217391304348, -0.1, 0.41666666666667
87503, 1.7, -0.1, 0.38888888888889
87504, 1.7217391304348, -0.075, 0.38888888888889
87505, 1.7217391304348, -0.1, 0.36111111111111
87506, 1.7, -0.1, 0.33333333333333
87507, 1.7217391304348, -0.075, 0.33333333333333
87508, 1.7217391304348, -0.1, 0.30555555555556
87509, 1.7, -0.1, 0.27777777777778
87510, 1.7217391304348, -0.075, 0.27777777777778
87511, 1.7217391304348, -0.1, 0.25
87512, 1.7, -0.1, 0.22222222222222
87513, 1.7217391304348, -0.075, 0.22222222222222
87514, 1.7217391304348, -0.1, 0.19444444444444
87515, 1.7, -0.1, 0.16666666666667
87516, 1.7217391304348, -0.075, 0.16666666666667
87517, 1.7217391304348, -0.1, 0.13888888888889
87518, 1.7, -0.1, 0.11111111111111
87519, 1.7217391304348, -0.075, 0.11111111111111
87520, 1.7217391304348, -0.1, 0.083333333333333
87521, 1.7, -0.1, 0.055555555555556
87522, 1.7217391304348, -0.075, 0.055555555555556
87523, 1.7217391304348, -0.1, 0.027777777777778
87524, 1.7652173913043, -0.1, 0.47222222222222
87525, 1.7434782608696, -0.1, 0.44444444444444
87526, 1.7652173913043, -0.075, 0.44444444444444
87527, 1.7652173913043, -0.1, 0.41666666666667
87528, 1.7434782608696, -0.1, 0.38888888888889
87529, 1.7652173913043, -0.075, 0.38888888888889
87530, 1.7652173913043, -0.1, 0.36111111111111
87531, 1.7434782608696, -0.1, 0.33333333333333
87532, 1.7652173913043, -0.075, 0.33333333333333
87533, 1.7652173913043, -0.1, 0.30555555555556
87534, 1.7434782608696, -0.1, 0.27777777777778
87535, 1.7652173913043, -0.075, 0.27777777777778
87536, 1.7652173913043, -0.1, 0.25
87537, 1.7434782608696, -0.1, 0.22222222222222
87538, 1.7652173913043, -0.075, 0.22222222222222
87539, 1.7652173913043, -0.1, 0.19444444444444
87540, 1.7434782608696, -0.1, 0.16666666666667
87541, 1.7652173913043, -0.075, 0.16666666666667
87542, 1.7652173913043, -0.1, 0.13888888888889
87543, 1.7434782608696, -0.1, 0.11111111111111
87544, 1.7652173913043, -0.075, 0.11111111111111
87545, 1.7652173913043, -0.1, 0.083333333333333
87546, 1.7434782608696, -0.1, 0.055555555555556
87547, 1.7652173913043, -0.075, 0.055555555555556
87548, 1.7652173913043, -0.1, 0.027777777777778
87549, 1.8086956521739, -0.1, 0.47222222222222
87550, 1.7869565217391, -0.1, 0.44444444444444
87551, 1.8086956521739, -0.075, 0.44444444444444
87552, 1.8086956521739, -0.1, 0.41666666666667
87553, 1.7869565217391, -0.1, 0.38888888888889
87554, 1.8086956521739, -0.075, 0.38888888888889
87555, 1.8086956521739, -0.1, 0.36111111111111
87556, 1.7869565217391, -0.1, 0.33333333333333
87557, 1.8086956521739, -0.075, 0.33333333333333
87558, 1.8086956521739, -0.1, 0.30555555555556
87559, 1.7869565217391, -0.1, 0.27777777777778
87560, 1.8086956521739, -0.075, 0.27777777777778
87561, 1.8086956521739, -0.1, 0.25
87562, 1.7869565217391, -0.1, 0.22222222222222
87563, 1.8086956521739, -0.075, 0.22222222222222
87564, 1.8086956521739, -0.1, 0.19444444444444
87565, 1.7869565217391, -0.1, 0.16666666666667
87566, 1.8086956521739, -0.075, 0.16666666666667
87567, 1.8086956521739, -0.1, 0.13888888888889
87568, 1.7869565217391, -0.1, 0.11111111111111
87569, 1.8086956521739, -0.075, 0.11111111111111
87570, 1.8086956521739, -0.1, 0.083333333333333
87571, 1.7869565217391, -0.1, 0.055555555555556
87572, 1.8086956521739, -0.075, 0.055555555555556
87573, 1.8086956521739, -0.1, 0.027777777777778
87574, 1.8521739130435, -0.1, 0.47222222222222
87575, 1.8304347826087, -0.1, 0.44444444444444
87576, 1.8521739130435, -0.075, 0.44444444444444
87577, 1.8521739130435, -0.1, 0.41666666666667
87578, 1.8304347826087, -0.1, 0.38888888888889
87579, 1.8521739130435, -0.075, 0.38888888888889
87580, 1.8521739130435, -0.1, 0.36111111111111
87581, 1.8304347826087, -0.1, 0.33333333333333
87582, 1.8521739130435, -0.075, 0.33333333333333
87583, 1.8521739130435, -0.1, 0.30555555555556
87584, 1.8304347826087, -0.1, 0.27777777777778
87585, 1.8521739130435, -0.075, 0.27777777777778
87586, 1.8521739130435, -0.1, 0.25
87587, 1.8304347826087, -0.1, 0.22222222222222
87588, 1.8521739130435, -0.075, 0.22222222222222
87589, 1.8521739130435, -0.1, 0.19444444444444
87590, 1.8304347826087, -0.1, 0.16666666666667
87591, 1.8521739130435, -0.075, 0.16666666666667
87592, 1.8521739130435, -0.1, 0.13888888888889
87593, 1.8304347826087, -0.1, 0.11111111111111
87594, 1.8521739130435, -0.075, 0.11111111111111
87595, 1.8521739130435, -0.1, 0.083333333333333
87596, 1.8304347826087, -0.1, 0.055555555555556
87597, 1.8521739130435, -0.075, 0.055555555555556
87598, 1.8521739130435, -0.1, 0.027777777777778
87599, 1.895652173913, -0.1, 0.47222222222222
87600, 1.8739130434783, -0.1, 0.44444444444444
87601, 1.895652173913, -0.075, 0.44444444444444
87602, 1.895652173913, -0.1, 0.41666666666667
87603, 1.8739130434783, -0.1, 0.38888888888889
87604, 1.895652173913, -0.075, 0.38888888888889
87605, 1.895652173913, -0.1, 0.36111111111111
87606, 1.8739130434783, -0.1, 0.33333333333333
87607, 1.895652173913, -0.075, 0.33333333333333
87608, 1.895652173913, -0.1, 0.30555555555556
87609, 1.8739130434783, -0.1, 0.27777777777778
87610, 1.895652173913, -0.075, 0.27777777777778
87611, 1.895652173913, -0.1, 0.25
87612, 1.8739130434783, -0.1, 0.22222222222222
87613, 1.895652173913, -0.075, 0.22222222222222
87614, 1.895652173913, -0.1, 0.19444444444444
87615, 1.8739130434783, -0.1, 0.16666666666667
87616, 1.895652173913, -0.075, 0.16666666666667
87617, 1.895652173913, -0.1, 0.13888888888889
87618, 1.8739130434783, -0.1, 0.11111111111111
87619, 1.895652173913, -0.075, 0.11111111111111
87620, 1.895652173913, -0.1, 0.083333333333333
87621, 1.8739130434783, -0.1, 0.055555555555556
87622, 1.895652173913, -0.075, 0.055555555555556
87623, 1.895652173913, -0.1, 0.027777777777778
87624, 1.9391304347826, -0.1, 0.47222222222222
87625, 1.9173913043478, -0.1, 0.44444444444444
87626, 1.9391304347826, -0.075, 0.44444444444444
87627, 1.9391304347826, -0.1, 0.41666666666667
87628, 1.9173913043478, -0.1, 0.38888888888889
87629, 1.9391304347826, -0.075, 0.38888888888889
87630, 1.9391304347826, -0.1, 0.36111111111111
87631, 1.9173913043478, -0.1, 0.33333333333333
87632, 1.9391304347826, -0.075, 0.33333333333333
87633, 1.9391304347826, -0.1, 0.30555555555556
87634, 1.9173913043478, -0.1, 0.27777777777778
87635, 1.9391304347826, -0.075, 0.27777777777778
87636, 1.9391304347826, -0.1, 0.25
87637, 1.9173913043478, -0.1, 0.22222222222222
87638, 1.9391304347826, -0.075, 0.22222222222222
87639, 1.9391304347826, -0.1, 0.19444444444444
87640, 1.9173913043478, -0.1, 0.16666666666667
87641, 1.9391304347826, -0.075, 0.16666666666667
87642, 1.9391304347826, -0.1, 0.13888888888889
87643, 1.9173913043478, -0.1, 0.11111111111111
87644, 1.9391304347826, -0.075, 0.11111111111111
87645, 1.9391304347826, -0.1, 0.083333333333333
87646, 1.9173913043478, -0.1, 0.055555555555556
87647, 1.9391304347826, -0.075, 0.055555555555556
87648, 1.9391304347826, -0.1, 0.027777777777778
87649, 1.9826086956522, -0.1, 0.47222222222222
87650, 1.9608695652174, -0.1, 0.44444444444444
87651, 1.9826086956522, -0.075, 0.44444444444444
87652, 1.9826086956522, -0.1, 0.41666666666667
87653, 1.9608695652174, -0.1, 0.38888888888889
87654, 1.9826086956522, -0.075, 0.38888888888889
87655, 1.9826086956522, -0.1, 0.36111111111111
87656, 1.9608695652174, -0.1, 0.33333333333333
87657, 1.9826086956522, -0.075, 0.33333333333333
87658, 1.9826086956522, -0.1, 0.30555555555556
87659, 1.9608695652174, -0.1, 0.27777777777778
87660, 1.9826086956522, -0.075, 0.27777777777778
87661, 1.9826086956522, -0.1, 0.25
87662, 1.9608695652174, -0.1, 0.22222222222222
87663, 1.9826086956522, -0.075, 0.22222222222222
87664, 1.9826086956522, -0.1, 0.19444444444444
87665, 1.9608695652174, -0.1, 0.16666666666667
87666, 1.9826086956522, -0.075, 0.16666666666667
87667, 1.9826086956522, -0.1, 0.13888888888889
87668, 1.9608695652174, -0.1, 0.11111111111111
87669, 1.9826086956522, -0.075, 0.11111111111111
87670, 1.9826086956522, -0.1, 0.083333333333333
87671, 1.9608695652174, -0.1, 0.055555555555556
87672, 1.9826086956522, -0.075, 0.055555555555556
87673, 1.9826086956522, -0.1, 0.027777777777778
87674, 2.0260869565217, -0.1, 0.47222222222222
87675, 2.004347826087, -0.1, 0.44444444444444
87676, 2.0260869565217, -0.075, 0.44444444444444
87677, 2.0260869565217, -0.1, 0.41666666666667
87678, 2.004347826087, -0.1, 0.38888888888889
87679, 2.0260869565217, -0.075, 0.38888888888889
87680, 2.0260869565217, -0.1, 0.36111111111111
87681, 2.004347826087, -0.1, 0.33333333333333
87682, 2.0260869565217, -0.075, 0.33333333333333
87683, 2.0260869565217, -0.1, 0.30555555555556
87684, 2.004347826087, -0.1, 0.27777777777778
87685, 2.0260869565217, -0.075, 0.27777777777778
87686, 2.0260869565217, -0.1, 0.25
87687, 2.004347826087, -0.1, 0.22222222222222
87688, 2.0260869565217, -0.075, 0.22222222222222
87689, 2.0260869565217, -0.1, 0.19444444444444
87690, 2.004347826087, -0.1, 0.16666666666667
87691, 2.0260869565217, -0.075, 0.16666666666667
87692, 2.0260869565217, -0.1, 0.13888888888889
87693, 2.004347826087, -0.1, 0.11111111111111
87694, 2.0260869565217, -0.075, 0.11111111111111
87695, 2.0260869565217, -0.1, 0.083333333333333
87696, 2.004347826087, -0.1, 0.055555555555556
87697, 2.0260869565217, -0.075, 0.055555555555556
87698, 2.0260869565217, -0.1, 0.027777777777778
87699, 2.0695652173913, -0.1, 0.47222222222222
87700, 2.0478260869565, -0.1, 0.44444444444444
87701, 2.0695652173913, -0.075, 0.44444444444444
87702, 2.0695652173913, -0.1, 0.41666666666667
87703, 2.0478260869565, -0.1, 0.38888888888889
87704, 2.0695652173913, -0.075, 0.38888888888889
87705, 2.0695652173913, -0.1, 0.36111111111111
87706, 2.0478260869565, -0.1, 0.33333333333333
87707, 2.0695652173913, -0.075, 0.33333333333333
87708, 2.0695652173913, -0.1, 0.30555555555556
87709, 2.0478260869565, -0.1, 0.27777777777778
87710, 2.0695652173913, -0.075, 0.27777777777778
87711, 2.0695652173913, -0.1, 0.25
87712, 2.0478260869565, -0.1, 0.22222222222222
87713, 2.0695652173913, -0.075, 0.22222222222222
87714, 2.0695652173913, -0.1, 0.19444444444444
87715, 2.0478260869565, -0.1, 0.16666666666667
87716, 2.0695652173913, -0.075, 0.16666666666667
87717, 2.0695652173913, -0.1, 0.13888888888889
87718, 2.0478260869565, -0.1, 0.11111111111111
87719, 2.0695652173913, -0.075, 0.11111111111111
87720, 2.0695652173913, -0.1, 0.083333333333333
87721, 2.0478260869565, -0.1, 0.055555555555556
87722, 2.0695652173913, -0.075, 0.055555555555556
87723, 2.0695652173913, -0.1, 0.027777777777778
87724, 2.1130434782609, -0.1, 0.47222222222222
87725, 2.0913043478261, -0.1, 0.44444444444444
87726, 2.1130434782609, -0.075, 0.44444444444444
87727, 2.1130434782609, -0.1, 0.41666666666667
87728, 2.0913043478261, -0.1, 0.38888888888889
87729, 2.1130434782609, -0.075, 0.38888888888889
87730, 2.1130434782609, -0.1, 0.36111111111111
87731, 2.0913043478261, -0.1, 0.33333333333333
87732, 2.1130434782609, -0.075, 0.33333333333333
87733, 2.1130434782609, -0.1, 0.30555555555556
87734, 2.0913043478261, -0.1, 0.27777777777778
87735, 2.1130434782609, -0.075, 0.27777777777778
87736, 2.1130434782609, -0.1, 0.25
87737, 2.0913043478261, -0.1, 0.22222222222222
87738, 2.1130434782609, -0.075, 0.22222222222222
87739, 2.1130434782609, -0.1, 0.19444444444444
87740, 2.0913043478261, -0.1, 0.16666666666667
87741, 2.1130434782609, -0.075, 0.16666666666667
87742, 2.1130434782609, -0.1, 0.13888888888889
87743, 2.0913043478261, -0.1, 0.11111111111111
87744, 2.1130434782609, -0.075, 0.11111111111111
87745, 2.1130434782609, -0.1, 0.083333333333333
87746, 2.0913043478261, -0.1, 0.055555555555556
87747, 2.1130434782609, -0.075, 0.055555555555556
87748, 2.1130434782609, -0.1, 0.027777777777778
87749, 2.1565217391304, -0.1, 0.47222222222222
87750, 2.1347826086957, -0.1, 0.44444444444444
87751, 2.1565217391304, -0.075, 0.44444444444444
87752, 2.1565217391304, -0.1, 0.41666666666667
87753, 2.1347826086957, -0.1, 0.38888888888889
87754, 2.1565217391304, -0.075, 0.38888888888889
87755, 2.1565217391304, -0.1, 0.36111111111111
87756, 2.1347826086957, -0.1, 0.33333333333333
87757, 2.1565217391304, -0.075, 0.33333333333333
87758, 2.1565217391304, -0.1, 0.30555555555556
87759, 2.1347826086957, -0.1, 0.27777777777778
87760, 2.1565217391304, -0.075, 0.27777777777778
87761, 2.1565217391304, -0.1, 0.25
87762, 2.1347826086957, -0.1, 0.22222222222222
87763, 2.1565217391304, -0.075, 0.22222222222222
87764, 2.1565217391304, -0.1, 0.19444444444444
87765, 2.1347826086957, -0.1, 0.16666666666667
87766, 2.1565217391304, -0.075, 0.16666666666667
87767, 2.1565217391304, -0.1, 0.13888888888889
87768, 2.1347826086957, -0.1, 0.11111111111111
87769, 2.1565217391304, -0.075, 0.11111111111111
87770, 2.1565217391304, -0.1, 0.083333333333333
87771, 2.1347826086957, -0.1, 0.055555555555556
87772, 2.1565217391304, -0.075, 0.055555555555556
87773, 2.1565217391304, -0.1, 0.027777777777778
87774, 2.1782608695652, -0.1, 0.44444444444444
87775, 2.1782608695652, -0.1, 0.38888888888889
87776, 2.1782608695652, -0.1, 0.33333333333333
87777, 2.1782608695652, -0.1, 0.27777777777778
87778, 2.1782608695652, -0.1, 0.22222222222222
87779, 2.1782608695652, -0.1, 0.16666666666667
87780, 2.1782608695652, -0.1, 0.11111111111111
87781, 2.1782608695652, -0.1, 0.055555555555556
87782, 1.2434782608696, -0.15, 0.47222222222222
87783, 1.2217391304348, -0.15, 0.44444444444444
87784, 1.2434782608696, -0.125, 0.44444444444444
87785, 1.2434782608696, -0.15, 0.41666666666667
87786, 1.2217391304348, -0.15, 0.38888888888889
87787, 1.2434782608696, -0.125, 0.38888888888889
87788, 1.2434782608696, -0.15, 0.36111111111111
87789, 1.2217391304348, -0.15, 0.33333333333333
87790, 1.2434782608696, -0.125, 0.33333333333333
87791, 1.2434782608696, -0.15, 0.30555555555556
87792, 1.2217391304348, -0.15, 0.27777777777778
87793, 1.2434782608696, -0.125, 0.27777777777778
87794, 1.2434782608696, -0.15, 0.25
87795, 1.2217391304348, -0.15, 0.22222222222222
87796, 1.2434782608696, -0.125, 0.22222222222222
87797, 1.2434782608696, -0.15, 0.19444444444444
87798, 1.2217391304348, -0.15, 0.16666666666667
87799, 1.2434782608696, -0.125, 0.16666666666667
87800, 1.2434782608696, -0.15, 0.13888888888889
87801, 1.2217391304348, -0.15, 0.11111111111111
87802, 1.2434782608696, -0.125, 0.11111111111111
87803, 1.2434782608696, -0.15, 0.083333333333333
87804, 1.2217391304348, -0.15, 0.055555555555556
87805, 1.2434782608696, -0.125, 0.055555555555556
87806, 1.2434782608696, -0.15, 0.027777777777778
87807, 1.2869565217391, -0.15, 0.47222222222222
87808, 1.2652173913043, -0.15, 0.44444444444444
87809, 1.2869565217391, -0.125, 0.44444444444444
87810, 1.2869565217391, -0.15, 0.41666666666667
87811, 1.2652173913043, -0.15, 0.38888888888889
87812, 1.2869565217391, -0.125, 0.38888888888889
87813, 1.2869565217391, -0.15, 0.36111111111111
87814, 1.2652173913043, -0.15, 0.33333333333333
87815, 1.2869565217391, -0.125, 0.33333333333333
