58279, 1.5478260869565, 1.5, 0.055555555555556
58280, 1.5260869565217, 1.5166666666667, 0.055555555555556
58281, 1.5478260869565, 1.5166666666667, 0.027777777777778
58282, 1.5478260869565, 1.5333333333333, 0.44444444444444
58283, 1.5478260869565, 1.5333333333333, 0.38888888888889
58284, 1.5478260869565, 1.5333333333333, 0.33333333333333
58285, 1.5478260869565, 1.5333333333333, 0.27777777777778
58286, 1.5478260869565, 1.5333333333333, 0.22222222222222
58287, 1.5478260869565, 1.5333333333333, 0.16666666666667
58288, 1.5478260869565, 1.5333333333333, 0.11111111111111
58289, 1.5478260869565, 1.5333333333333, 0.055555555555556
58290, 1.5913043478261, 1.4833333333333, 0.47222222222222
58291, 1.5913043478261, 1.4666666666667, 0.44444444444444
58292, 1.5695652173913, 1.4833333333333, 0.44444444444444
58293, 1.5913043478261, 1.4833333333333, 0.41666666666667
58294, 1.5913043478261, 1.4666666666667, 0.38888888888889
58295, 1.5695652173913, 1.4833333333333, 0.38888888888889
58296, 1.5913043478261, 1.4833333333333, 0.36111111111111
58297, 1.5913043478261, 1.4666666666667, 0.33333333333333
58298, 1.5695652173913, 1.4833333333333, 0.33333333333333
58299, 1.5913043478261, 1.4833333333333, 0.30555555555556
58300, 1.5913043478261, 1.4666666666667, 0.27777777777778
58301, 1.5695652173913, 1.4833333333333, 0.27777777777778
58302, 1.5913043478261, 1.4833333333333, 0.25
58303, 1.5913043478261, 1.4666666666667, 0.22222222222222
58304, 1.5695652173913, 1.4833333333333, 0.22222222222222
58305, 1.5913043478261, 1.4833333333333, 0.19444444444444
58306, 1.5913043478261, 1.4666666666667, 0.16666666666667
58307, 1.5695652173913, 1.4833333333333, 0.16666666666667
58308, 1.5913043478261, 1.4833333333333, 0.13888888888889
58309, 1.5913043478261, 1.4666666666667, 0.11111111111111
58310, 1.5695652173913, 1.4833333333333, 0.11111111111111
58311, 1.5913043478261, 1.4833333333333, 0.083333333333333
58312, 1.5913043478261, 1.4666666666667, 0.055555555555556
58313, 1.5695652173913, 1.4833333333333, 0.055555555555556
58314, 1.5913043478261, 1.4833333333333, 0.027777777777778
58315, 1.5913043478261, 1.5166666666667, 0.47222222222222
58316, 1.5913043478261, 1.5, 0.44444444444444
58317, 1.5695652173913, 1.5166666666667, 0.44444444444444
58318, 1.5913043478261, 1.5166666666667, 0.41666666666667
58319, 1.5913043478261, 1.5, 0.38888888888889
58320, 1.5695652173913, 1.5166666666667, 0.38888888888889
58321, 1.5913043478261, 1.5166666666667, 0.36111111111111
58322, 1.5913043478261, 1.5, 0.33333333333333
58323, 1.5695652173913, 1.5166666666667, 0.33333333333333
58324, 1.5913043478261, 1.5166666666667, 0.30555555555556
58325, 1.5913043478261, 1.5, 0.27777777777778
58326, 1.5695652173913, 1.5166666666667, 0.27777777777778
58327, 1.5913043478261, 1.5166666666667, 0.25
58328, 1.5913043478261, 1.5, 0.22222222222222
58329, 1.5695652173913, 1.5166666666667, 0.22222222222222
58330, 1.5913043478261, 1.5166666666667, 0.19444444444444
58331, 1.5913043478261, 1.5, 0.16666666666667
58332, 1.5695652173913, 1.5166666666667, 0.16666666666667
58333, 1.5913043478261, 1.5166666666667, 0.13888888888889
58334, 1.5913043478261, 1.5, 0.11111111111111
58335, 1.5695652173913, 1.5166666666667, 0.11111111111111
58336, 1.5913043478261, 1.5166666666667, 0.083333333333333
58337, 1.5913043478261, 1.5, 0.055555555555556
58338, 1.5695652173913, 1.5166666666667, 0.055555555555556
58339, 1.5913043478261, 1.5166666666667, 0.027777777777778
58340, 1.5913043478261, 1.5333333333333, 0.44444444444444
58341, 1.5913043478261, 1.5333333333333, 0.38888888888889
58342, 1.5913043478261, 1.5333333333333, 0.33333333333333
58343, 1.5913043478261, 1.5333333333333, 0.27777777777778
58344, 1.5913043478261, 1.5333333333333, 0.22222222222222
58345, 1.5913043478261, 1.5333333333333, 0.16666666666667
58346, 1.5913043478261, 1.5333333333333, 0.11111111111111
58347, 1.5913043478261, 1.5333333333333, 0.055555555555556
58348, 1.6347826086957, 1.4833333333333, 0.47222222222222
58349, 1.6347826086957, 1.4666666666667, 0.44444444444444
58350, 1.6130434782609, 1.4833333333333, 0.44444444444444
58351, 1.6347826086957, 1.4833333333333, 0.41666666666667
58352, 1.6347826086957, 1.4666666666667, 0.38888888888889
58353, 1.6130434782609, 1.4833333333333, 0.38888888888889
58354, 1.6347826086957, 1.4833333333333, 0.36111111111111
58355, 1.6347826086957, 1.4666666666667, 0.33333333333333
58356, 1.6130434782609, 1.4833333333333, 0.33333333333333
58357, 1.6347826086957, 1.4833333333333, 0.30555555555556
58358, 1.6347826086957, 1.4666666666667, 0.27777777777778
58359, 1.6130434782609, 1.4833333333333, 0.27777777777778
58360, 1.6347826086957, 1.4833333333333, 0.25
58361, 1.6347826086957, 1.4666666666667, 0.22222222222222
58362, 1.6130434782609, 1.4833333333333, 0.22222222222222
58363, 1.6347826086957, 1.4833333333333, 0.19444444444444
58364, 1.6347826086957, 1.4666666666667, 0.16666666666667
58365, 1.6130434782609, 1.4833333333333, 0.16666666666667
58366, 1.6347826086957, 1.4833333333333, 0.13888888888889
58367, 1.6347826086957, 1.4666666666667, 0.11111111111111
58368, 1.6130434782609, 1.4833333333333, 0.11111111111111
58369, 1.6347826086957, 1.4833333333333, 0.083333333333333
58370, 1.6347826086957, 1.4666666666667, 0.055555555555556
58371, 1.6130434782609, 1.4833333333333, 0.055555555555556
58372, 1.6347826086957, 1.4833333333333, 0.027777777777778
58373, 1.6347826086957, 1.5166666666667, 0.47222222222222
58374, 1.6347826086957, 1.5, 0.44444444444444
58375, 1.6130434782609, 1.5166666666667, 0.44444444444444
58376, 1.6347826086957, 1.5166666666667, 0.41666666666667
58377, 1.6347826086957, 1.5, 0.38888888888889
58378, 1.6130434782609, 1.5166666666667, 0.38888888888889
58379, 1.6347826086957, 1.5166666666667, 0.36111111111111
58380, 1.6347826086957, 1.5, 0.33333333333333
58381, 1.6130434782609, 1.5166666666667, 0.33333333333333
58382, 1.6347826086957, 1.5166666666667, 0.30555555555556
58383, 1.6347826086957, 1.5, 0.27777777777778
58384, 1.6130434782609, 1.5166666666667, 0.27777777777778
58385, 1.6347826086957, 1.5166666666667, 0.25
58386, 1.6347826086957, 1.5, 0.22222222222222
58387, 1.6130434782609, 1.5166666666667, 0.22222222222222
58388, 1.6347826086957, 1.5166666666667, 0.19444444444444
58389, 1.6347826086957, 1.5, 0.16666666666667
58390, 1.6130434782609, 1.5166666666667, 0.16666666666667
58391, 1.6347826086957, 1.5166666666667, 0.13888888888889
58392, 1.6347826086957, 1.5, 0.11111111111111
58393, 1.6130434782609, 1.5166666666667, 0.11111111111111
58394, 1.6347826086957, 1.5166666666667, 0.083333333333333
58395, 1.6347826086957, 1.5, 0.055555555555556
58396, 1.6130434782609, 1.5166666666667, 0.055555555555556
58397, 1.6347826086957, 1.5166666666667, 0.027777777777778
58398, 1.6347826086957, 1.5333333333333, 0.44444444444444
58399, 1.6347826086957, 1.5333333333333, 0.38888888888889
58400, 1.6347826086957, 1.5333333333333, 0.33333333333333
58401, 1.6347826086957, 1.5333333333333, 0.27777777777778
58402, 1.6347826086957, 1.5333333333333, 0.22222222222222
58403, 1.6347826086957, 1.5333333333333, 0.16666666666667
58404, 1.6347826086957, 1.5333333333333, 0.11111111111111
58405, 1.6347826086957, 1.5333333333333, 0.055555555555556
58406, 1.6782608695652, 1.4833333333333, 0.47222222222222
58407, 1.6782608695652, 1.4666666666667, 0.44444444444444
58408, 1.6565217391304, 1.4833333333333, 0.44444444444444
58409, 1.6782608695652, 1.4833333333333, 0.41666666666667
58410, 1.6782608695652, 1.4666666666667, 0.38888888888889
58411, 1.6565217391304, 1.4833333333333, 0.38888888888889
58412, 1.6782608695652, 1.4833333333333, 0.36111111111111
58413, 1.6782608695652, 1.4666666666667, 0.33333333333333
58414, 1.6565217391304, 1.4833333333333, 0.33333333333333
58415, 1.6782608695652, 1.4833333333333, 0.30555555555556
58416, 1.6782608695652, 1.4666666666667, 0.27777777777778
58417, 1.6565217391304, 1.4833333333333, 0.27777777777778
58418, 1.6782608695652, 1.4833333333333, 0.25
58419, 1.6782608695652, 1.4666666666667, 0.22222222222222
58420, 1.6565217391304, 1.4833333333333, 0.22222222222222
58421, 1.6782608695652, 1.4833333333333, 0.19444444444444
58422, 1.6782608695652, 1.4666666666667, 0.16666666666667
58423, 1.6565217391304, 1.4833333333333, 0.16666666666667
58424, 1.6782608695652, 1.4833333333333, 0.13888888888889
58425, 1.6782608695652, 1.4666666666667, 0.11111111111111
58426, 1.6565217391304, 1.4833333333333, 0.11111111111111
58427, 1.6782608695652, 1.4833333333333, 0.083333333333333
58428, 1.6782608695652, 1.4666666666667, 0.055555555555556
58429, 1.6565217391304, 1.4833333333333, 0.055555555555556
58430, 1.6782608695652, 1.4833333333333, 0.027777777777778
58431, 1.6782608695652, 1.5166666666667, 0.47222222222222
58432, 1.6782608695652, 1.5, 0.44444444444444
58433, 1.6565217391304, 1.5166666666667, 0.44444444444444
58434, 1.6782608695652, 1.5166666666667, 0.41666666666667
58435, 1.6782608695652, 1.5, 0.38888888888889
58436, 1.6565217391304, 1.5166666666667, 0.38888888888889
58437, 1.6782608695652, 1.5166666666667, 0.36111111111111
58438, 1.6782608695652, 1.5, 0.33333333333333
58439, 1.6565217391304, 1.5166666666667, 0.33333333333333
58440, 1.6782608695652, 1.5166666666667, 0.30555555555556
58441, 1.6782608695652, 1.5, 0.27777777777778
58442, 1.6565217391304, 1.5166666666667, 0.27777777777778
58443, 1.6782608695652, 1.5166666666667, 0.25
58444, 1.6782608695652, 1.5, 0.22222222222222
58445, 1.6565217391304, 1.5166666666667, 0.22222222222222
58446, 1.6782608695652, 1.5166666666667, 0.19444444444444
58447, 1.6782608695652, 1.5, 0.16666666666667
58448, 1.6565217391304, 1.5166666666667, 0.16666666666667
58449, 1.6782608695652, 1.5166666666667, 0.13888888888889
58450, 1.6782608695652, 1.5, 0.11111111111111
58451, 1.6565217391304, 1.5166666666667, 0.11111111111111
58452, 1.6782608695652, 1.5166666666667, 0.083333333333333
58453, 1.6782608695652, 1.5, 0.055555555555556
58454, 1.6565217391304, 1.5166666666667, 0.055555555555556
58455, 1.6782608695652, 1.5166666666667, 0.027777777777778
58456, 1.6782608695652, 1.5333333333333, 0.44444444444444
58457, 1.6782608695652, 1.5333333333333, 0.38888888888889
58458, 1.6782608695652, 1.5333333333333, 0.33333333333333
58459, 1.6782608695652, 1.5333333333333, 0.27777777777778
58460, 1.6782608695652, 1.5333333333333, 0.22222222222222
58461, 1.6782608695652, 1.5333333333333, 0.16666666666667
58462, 1.6782608695652, 1.5333333333333, 0.11111111111111
58463, 1.6782608695652, 1.5333333333333, 0.055555555555556
58464, 1.7217391304348, 1.4833333333333, 0.47222222222222
58465, 1.7217391304348, 1.4666666666667, 0.44444444444444
58466, 1.7, 1.4833333333333, 0.44444444444444
58467, 1.7217391304348, 1.4833333333333, 0.41666666666667
58468, 1.7217391304348, 1.4666666666667, 0.38888888888889
58469, 1.7, 1.4833333333333, 0.38888888888889
58470, 1.7217391304348, 1.4833333333333, 0.36111111111111
58471, 1.7217391304348, 1.4666666666667, 0.33333333333333
58472, 1.7, 1.4833333333333, 0.33333333333333
58473, 1.7217391304348, 1.4833333333333, 0.30555555555556
58474, 1.7217391304348, 1.4666666666667, 0.27777777777778
58475, 1.7, 1.4833333333333, 0.27777777777778
58476, 1.7217391304348, 1.4833333333333, 0.25
58477, 1.7217391304348, 1.4666666666667, 0.22222222222222
58478, 1.7, 1.4833333333333, 0.22222222222222
58479, 1.7217391304348, 1.4833333333333, 0.19444444444444
58480, 1.7217391304348, 1.4666666666667, 0.16666666666667
58481, 1.7, 1.4833333333333, 0.16666666666667
58482, 1.7217391304348, 1.4833333333333, 0.13888888888889
58483, 1.7217391304348, 1.4666666666667, 0.11111111111111
58484, 1.7, 1.4833333333333, 0.11111111111111
58485, 1.7217391304348, 1.4833333333333, 0.083333333333333
58486, 1.7217391304348, 1.4666666666667, 0.055555555555556
58487, 1.7, 1.4833333333333, 0.055555555555556
58488, 1.7217391304348, 1.4833333333333, 0.027777777777778
58489, 1.7217391304348, 1.5166666666667, 0.47222222222222
58490, 1.7217391304348, 1.5, 0.44444444444444
58491, 1.7, 1.5166666666667, 0.44444444444444
58492, 1.7217391304348, 1.5166666666667, 0.41666666666667
58493, 1.7217391304348, 1.5, 0.38888888888889
58494, 1.7, 1.5166666666667, 0.38888888888889
58495, 1.7217391304348, 1.5166666666667, 0.36111111111111
58496, 1.7217391304348, 1.5, 0.33333333333333
58497, 1.7, 1.5166666666667, 0.33333333333333
58498, 1.7217391304348, 1.5166666666667, 0.30555555555556
58499, 1.7217391304348, 1.5, 0.27777777777778
58500, 1.7, 1.5166666666667, 0.27777777777778
58501, 1.7217391304348, 1.5166666666667, 0.25
58502, 1.7217391304348, 1.5, 0.22222222222222
58503, 1.7, 1.5166666666667, 0.22222222222222
58504, 1.7217391304348, 1.5166666666667, 0.19444444444444
58505, 1.7217391304348, 1.5, 0.16666666666667
58506, 1.7, 1.5166666666667, 0.16666666666667
58507, 1.7217391304348, 1.5166666666667, 0.13888888888889
58508, 1.7217391304348, 1.5, 0.11111111111111
58509, 1.7, 1.5166666666667, 0.11111111111111
58510, 1.7217391304348, 1.5166666666667, 0.083333333333333
58511, 1.7217391304348, 1.5, 0.055555555555556
58512, 1.7, 1.5166666666667, 0.055555555555556
58513, 1.7217391304348, 1.5166666666667, 0.027777777777778
58514, 1.7217391304348, 1.5333333333333, 0.44444444444444
58515, 1.7217391304348, 1.5333333333333, 0.38888888888889
58516, 1.7217391304348, 1.5333333333333, 0.33333333333333
58517, 1.7217391304348, 1.5333333333333, 0.27777777777778
58518, 1.7217391304348, 1.5333333333333, 0.22222222222222
58519, 1.7217391304348, 1.5333333333333, 0.16666666666667
58520, 1.7217391304348, 1.5333333333333, 0.11111111111111
58521, 1.7217391304348, 1.5333333333333, 0.055555555555556
58522, 1.7652173913043, 1.4833333333333, 0.47222222222222
58523, 1.7652173913043, 1.4666666666667, 0.44444444444444
58524, 1.7434782608696, 1.4833333333333, 0.44444444444444
58525, 1.7652173913043, 1.4833333333333, 0.41666666666667
58526, 1.7652173913043, 1.4666666666667, 0.38888888888889
58527, 1.7434782608696, 1.4833333333333, 0.38888888888889
58528, 1.7652173913043, 1.4833333333333, 0.36111111111111
58529, 1.7652173913043, 1.4666666666667, 0.33333333333333
58530, 1.7434782608696, 1.4833333333333, 0.33333333333333
58531, 1.7652173913043, 1.4833333333333, 0.30555555555556
58532, 1.7652173913043, 1.4666666666667, 0.27777777777778
58533, 1.7434782608696, 1.4833333333333, 0.27777777777778
58534, 1.7652173913043, 1.4833333333333, 0.25
58535, 1.7652173913043, 1.4666666666667, 0.22222222222222
58536, 1.7434782608696, 1.4833333333333, 0.22222222222222
58537, 1.7652173913043, 1.4833333333333, 0.19444444444444
58538, 1.7652173913043, 1.4666666666667, 0.16666666666667
58539, 1.7434782608696, 1.4833333333333, 0.16666666666667
58540, 1.7652173913043, 1.4833333333333, 0.13888888888889
58541, 1.7652173913043, 1.4666666666667, 0.11111111111111
58542, 1.7434782608696, 1.4833333333333, 0.11111111111111
58543, 1.7652173913043, 1.4833333333333, 0.083333333333333
58544, 1.7652173913043, 1.4666666666667, 0.055555555555556
58545, 1.7434782608696, 1.4833333333333, 0.055555555555556
58546, 1.7652173913043, 1.4833333333333, 0.027777777777778
58547, 1.7652173913043, 1.5166666666667, 0.47222222222222
58548, 1.7652173913043, 1.5, 0.44444444444444
58549, 1.7434782608696, 1.5166666666667, 0.44444444444444
58550, 1.7652173913043, 1.5166666666667, 0.41666666666667
58551, 1.7652173913043, 1.5, 0.38888888888889
58552, 1.7434782608696, 1.5166666666667, 0.38888888888889
58553, 1.7652173913043, 1.5166666666667, 0.36111111111111
58554, 1.7652173913043, 1.5, 0.33333333333333
58555, 1.7434782608696, 1.5166666666667, 0.33333333333333
58556, 1.7652173913043, 1.5166666666667, 0.30555555555556
58557, 1.7652173913043, 1.5, 0.27777777777778
58558, 1.7434782608696, 1.5166666666667, 0.27777777777778
58559, 1.7652173913043, 1.5166666666667, 0.25
58560, 1.7652173913043, 1.5, 0.22222222222222
58561, 1.7434782608696, 1.5166666666667, 0.22222222222222
58562, 1.7652173913043, 1.5166666666667, 0.19444444444444
58563, 1.7652173913043, 1.5, 0.16666666666667
58564, 1.7434782608696, 1.5166666666667, 0.16666666666667
58565, 1.7652173913043, 1.5166666666667, 0.13888888888889
58566, 1.7652173913043, 1.5, 0.11111111111111
58567, 1.7434782608696, 1.5166666666667, 0.11111111111111
58568, 1.7652173913043, 1.5166666666667, 0.083333333333333
58569, 1.7652173913043, 1.5, 0.055555555555556
58570, 1.7434782608696, 1.5166666666667, 0.055555555555556
58571, 1.7652173913043, 1.5166666666667, 0.027777777777778
58572, 1.7652173913043, 1.5333333333333, 0.44444444444444
58573, 1.7652173913043, 1.5333333333333, 0.38888888888889
58574, 1.7652173913043, 1.5333333333333, 0.33333333333333
58575, 1.7652173913043, 1.5333333333333, 0.27777777777778
58576, 1.7652173913043, 1.5333333333333, 0.22222222222222
58577, 1.7652173913043, 1.5333333333333, 0.16666666666667
58578, 1.7652173913043, 1.5333333333333, 0.11111111111111
58579, 1.7652173913043, 1.5333333333333, 0.055555555555556
58580, 1.8086956521739, 1.4833333333333, 0.47222222222222
58581, 1.8086956521739, 1.4666666666667, 0.44444444444444
58582, 1.7869565217391, 1.4833333333333, 0.44444444444444
58583, 1.8086956521739, 1.4833333333333, 0.41666666666667
58584, 1.8086956521739, 1.4666666666667, 0.38888888888889
58585, 1.7869565217391, 1.4833333333333, 0.38888888888889
58586, 1.8086956521739, 1.4833333333333, 0.36111111111111
58587, 1.8086956521739, 1.4666666666667, 0.33333333333333
58588, 1.7869565217391, 1.4833333333333, 0.33333333333333
58589, 1.8086956521739, 1.4833333333333, 0.30555555555556
58590, 1.8086956521739, 1.4666666666667, 0.27777777777778
58591, 1.7869565217391, 1.4833333333333, 0.27777777777778
58592, 1.8086956521739, 1.4833333333333, 0.25
58593, 1.8086956521739, 1.4666666666667, 0.22222222222222
58594, 1.7869565217391, 1.4833333333333, 0.22222222222222
58595, 1.8086956521739, 1.4833333333333, 0.19444444444444
58596, 1.8086956521739, 1.4666666666667, 0.16666666666667
58597, 1.7869565217391, 1.4833333333333, 0.16666666666667
58598, 1.8086956521739, 1.4833333333333, 0.13888888888889
58599, 1.8086956521739, 1.4666666666667, 0.11111111111111
58600, 1.7869565217391, 1.4833333333333, 0.11111111111111
58601, 1.8086956521739, 1.4833333333333, 0.083333333333333
58602, 1.8086956521739, 1.4666666666667, 0.055555555555556
58603, 1.7869565217391, 1.4833333333333, 0.055555555555556
58604, 1.8086956521739, 1.4833333333333, 0.027777777777778
58605, 1.8086956521739, 1.5166666666667, 0.47222222222222
58606, 1.8086956521739, 1.5, 0.44444444444444
58607, 1.7869565217391, 1.5166666666667, 0.44444444444444
58608, 1.8086956521739, 1.5166666666667, 0.41666666666667
58609, 1.8086956521739, 1.5, 0.38888888888889
58610, 1.7869565217391, 1.5166666666667, 0.38888888888889
58611, 1.8086956521739, 1.5166666666667, 0.36111111111111
58612, 1.8086956521739, 1.5, 0.33333333333333
58613, 1.7869565217391, 1.5166666666667, 0.33333333333333
58614, 1.8086956521739, 1.5166666666667, 0.30555555555556
58615, 1.8086956521739, 1.5, 0.27777777777778
58616, 1.7869565217391, 1.5166666666667, 0.27777777777778
58617, 1.8086956521739, 1.5166666666667, 0.25
58618, 1.8086956521739, 1.5, 0.22222222222222
58619, 1.7869565217391, 1.5166666666667, 0.22222222222222
58620, 1.8086956521739, 1.5166666666667, 0.19444444444444
58621, 1.8086956521739, 1.5, 0.16666666666667
58622, 1.7869565217391, 1.5166666666667, 0.16666666666667
58623, 1.8086956521739, 1.5166666666667, 0.13888888888889
58624, 1.8086956521739, 1.5, 0.11111111111111
58625, 1.7869565217391, 1.5166666666667, 0.11111111111111
58626, 1.8086956521739, 1.5166666666667, 0.083333333333333
58627, 1.8086956521739, 1.5, 0.055555555555556
58628, 1.7869565217391, 1.5166666666667, 0.055555555555556
58629, 1.8086956521739, 1.5166666666667, 0.027777777777778
58630, 1.8086956521739, 1.5333333333333, 0.44444444444444
58631, 1.8086956521739, 1.5333333333333, 0.38888888888889
58632, 1.8086956521739, 1.5333333333333, 0.33333333333333
58633, 1.8086956521739, 1.5333333333333, 0.27777777777778
58634, 1.8086956521739, 1.5333333333333, 0.22222222222222
58635, 1.8086956521739, 1.5333333333333, 0.16666666666667
58636, 1.8086956521739, 1.5333333333333, 0.11111111111111
58637, 1.8086956521739, 1.5333333333333, 0.055555555555556
58638, 1.8521739130435, 1.4833333333333, 0.47222222222222
58639, 1.8521739130435, 1.4666666666667, 0.44444444444444
58640, 1.8304347826087, 1.4833333333333, 0.44444444444444
58641, 1.8521739130435, 1.4833333333333, 0.41666666666667
58642, 1.8521739130435, 1.4666666666667, 0.38888888888889
58643, 1.8304347826087, 1.4833333333333, 0.38888888888889
58644, 1.8521739130435, 1.4833333333333, 0.36111111111111
58645, 1.8521739130435, 1.4666666666667, 0.33333333333333
58646, 1.8304347826087, 1.4833333333333, 0.33333333333333
58647, 1.8521739130435, 1.4833333333333, 0.30555555555556
58648, 1.8521739130435, 1.4666666666667, 0.27777777777778
58649, 1.8304347826087, 1.4833333333333, 0.27777777777778
58650, 1.8521739130435, 1.4833333333333, 0.25
58651, 1.8521739130435, 1.4666666666667, 0.22222222222222
58652, 1.8304347826087, 1.4833333333333, 0.22222222222222
58653, 1.8521739130435, 1.4833333333333, 0.19444444444444
58654, 1.8521739130435, 1.4666666666667, 0.16666666666667
58655, 1.8304347826087, 1.4833333333333, 0.16666666666667
58656, 1.8521739130435, 1.4833333333333, 0.13888888888889
58657, 1.8521739130435, 1.4666666666667, 0.11111111111111
58658, 1.8304347826087, 1.4833333333333, 0.11111111111111
58659, 1.8521739130435, 1.4833333333333, 0.083333333333333
58660, 1.8521739130435, 1.4666666666667, 0.055555555555556
58661, 1.8304347826087, 1.4833333333333, 0.055555555555556
58662, 1.8521739130435, 1.4833333333333, 0.027777777777778
58663, 1.8521739130435, 1.5166666666667, 0.47222222222222
58664, 1.8521739130435, 1.5, 0.44444444444444
58665, 1.8304347826087, 1.5166666666667, 0.44444444444444
58666, 1.8521739130435, 1.5166666666667, 0.41666666666667
58667, 1.8521739130435, 1.5, 0.38888888888889
58668, 1.8304347826087, 1.5166666666667, 0.38888888888889
58669, 1.8521739130435, 1.5166666666667, 0.36111111111111
58670, 1.8521739130435, 1.5, 0.33333333333333
58671, 1.8304347826087, 1.5166666666667, 0.33333333333333
58672, 1.8521739130435, 1.5166666666667, 0.30555555555556
58673, 1.8521739130435, 1.5, 0.27777777777778
58674, 1.8304347826087, 1.5166666666667, 0.27777777777778
58675, 1.8521739130435, 1.5166666666667, 0.25
58676, 1.8521739130435, 1.5, 0.22222222222222
58677, 1.8304347826087, 1.5166666666667, 0.22222222222222
58678, 1.8521739130435, 1.5166666666667, 0.19444444444444
58679, 1.8521739130435, 1.5, 0.16666666666667
58680, 1.8304347826087, 1.5166666666667, 0.16666666666667
58681, 1.8521739130435, 1.5166666666667, 0.13888888888889
58682, 1.8521739130435, 1.5, 0.11111111111111
58683, 1.8304347826087, 1.5166666666667, 0.11111111111111
58684, 1.8521739130435, 1.5166666666667, 0.083333333333333
58685, 1.8521739130435, 1.5, 0.055555555555556
58686, 1.8304347826087, 1.5166666666667, 0.055555555555556
58687, 1.8521739130435, 1.5166666666667, 0.027777777777778
58688, 1.8521739130435, 1.5333333333333, 0.44444444444444
58689, 1.8521739130435, 1.5333333333333, 0.38888888888889
58690, 1.8521739130435, 1.5333333333333, 0.33333333333333
58691, 1.8521739130435, 1.5333333333333, 0.27777777777778
58692, 1.8521739130435, 1.5333333333333, 0.22222222222222
58693, 1.8521739130435, 1.5333333333333, 0.16666666666667
58694, 1.8521739130435, 1.5333333333333, 0.11111111111111
58695, 1.8521739130435, 1.5333333333333, 0.055555555555556
58696, 1.895652173913, 1.4833333333333, 0.47222222222222
58697, 1.895652173913, 1.4666666666667, 0.44444444444444
58698, 1.8739130434783, 1.4833333333333, 0.44444444444444
58699, 1.895652173913, 1.4833333333333, 0.41666666666667
58700, 1.895652173913, 1.4666666666667, 0.38888888888889
58701, 1.8739130434783, 1.4833333333333, 0.38888888888889
58702, 1.895652173913, 1.4833333333333, 0.36111111111111
58703, 1.895652173913, 1.4666666666667, 0.33333333333333
58704, 1.8739130434783, 1.4833333333333, 0.33333333333333
58705, 1.895652173913, 1.4833333333333, 0.30555555555556
58706, 1.895652173913, 1.4666666666667, 0.27777777777778
58707, 1.8739130434783, 1.4833333333333, 0.27777777777778
58708, 1.895652173913, 1.4833333333333, 0.25
58709, 1.895652173913, 1.4666666666667, 0.22222222222222
58710, 1.8739130434783, 1.4833333333333, 0.22222222222222
58711, 1.895652173913, 1.4833333333333, 0.19444444444444
58712, 1.895652173913, 1.4666666666667, 0.16666666666667
58713, 1.8739130434783, 1.4833333333333, 0.16666666666667
58714, 1.895652173913, 1.4833333333333, 0.13888888888889
58715, 1.895652173913, 1.4666666666667, 0.11111111111111
58716, 1.8739130434783, 1.4833333333333, 0.11111111111111
58717, 1.895652173913, 1.4833333333333, 0.083333333333333
58718, 1.895652173913, 1.4666666666667, 0.055555555555556
58719, 1.8739130434783, 1.4833333333333, 0.055555555555556
58720, 1.895652173913, 1.4833333333333, 0.027777777777778
58721, 1.895652173913, 1.5166666666667, 0.47222222222222
58722, 1.895652173913, 1.5, 0.44444444444444
58723, 1.8739130434783, 1.5166666666667, 0.44444444444444
58724, 1.895652173913, 1.5166666666667, 0.41666666666667
58725, 1.895652173913, 1.5, 0.38888888888889
58726, 1.8739130434783, 1.5166666666667, 0.38888888888889
58727, 1.895652173913, 1.5166666666667, 0.36111111111111
58728, 1.895652173913, 1.5, 0.33333333333333
58729, 1.8739130434783, 1.5166666666667, 0.33333333333333
58730, 1.895652173913, 1.5166666666667, 0.30555555555556
58731, 1.895652173913, 1.5, 0.27777777777778
58732, 1.8739130434783, 1.5166666666667, 0.27777777777778
58733, 1.895652173913, 1.5166666666667, 0.25
58734, 1.895652173913, 1.5, 0.22222222222222
58735, 1.8739130434783, 1.5166666666667, 0.22222222222222
58736, 1.895652173913, 1.5166666666667, 0.19444444444444
58737, 1.895652173913, 1.5, 0.16666666666667
58738, 1.8739130434783, 1.5166666666667, 0.16666666666667
58739, 1.895652173913, 1.5166666666667, 0.13888888888889
58740, 1.895652173913, 1.5, 0.11111111111111
58741, 1.8739130434783, 1.5166666666667, 0.11111111111111
58742, 1.895652173913, 1.5166666666667, 0.083333333333333
58743, 1.895652173913, 1.5, 0.055555555555556
58744, 1.8739130434783, 1.5166666666667, 0.055555555555556
58745, 1.895652173913, 1.5166666666667, 0.027777777777778
58746, 1.895652173913, 1.5333333333333, 0.44444444444444
58747, 1.895652173913, 1.5333333333333, 0.38888888888889
58748, 1.895652173913, 1.5333333333333, 0.33333333333333
58749, 1.895652173913, 1.5333333333333, 0.27777777777778
58750, 1.895652173913, 1.5333333333333, 0.22222222222222
58751, 1.895652173913, 1.5333333333333, 0.16666666666667
58752, 1.895652173913, 1.5333333333333, 0.11111111111111
58753, 1.895652173913, 1.5333333333333, 0.055555555555556
58754, 1.9391304347826, 1.4833333333333, 0.47222222222222
58755, 1.9391304347826, 1.4666666666667, 0.44444444444444
58756, 1.9173913043478, 1.4833333333333, 0.44444444444444
58757, 1.9391304347826, 1.4833333333333, 0.41666666666667
58758, 1.9391304347826, 1.4666666666667, 0.38888888888889
58759, 1.9173913043478, 1.4833333333333, 0.38888888888889
58760, 1.9391304347826, 1.4833333333333, 0.36111111111111
58761, 1.9391304347826, 1.4666666666667, 0.33333333333333
58762, 1.9173913043478, 1.4833333333333, 0.33333333333333
58763, 1.9391304347826, 1.4833333333333, 0.30555555555556
58764, 1.9391304347826, 1.4666666666667, 0.27777777777778
58765, 1.9173913043478, 1.4833333333333, 0.27777777777778
58766, 1.9391304347826, 1.4833333333333, 0.25
58767, 1.9391304347826, 1.4666666666667, 0.22222222222222
58768, 1.9173913043478, 1.4833333333333, 0.22222222222222
58769, 1.9391304347826, 1.4833333333333, 0.19444444444444
58770, 1.9391304347826, 1.4666666666667, 0.16666666666667
58771, 1.9173913043478, 1.4833333333333, 0.16666666666667
58772, 1.9391304347826, 1.4833333333333, 0.13888888888889
58773, 1.9391304347826, 1.4666666666667, 0.11111111111111
58774, 1.9173913043478, 1.4833333333333, 0.11111111111111
58775, 1.9391304347826, 1.4833333333333, 0.083333333333333
58776, 1.9391304347826, 1.4666666666667, 0.055555555555556
58777, 1.9173913043478, 1.4833333333333, 0.055555555555556
58778, 1.9391304347826, 1.4833333333333, 0.027777777777778
58779, 1.9391304347826, 1.5166666666667, 0.47222222222222
58780, 1.9391304347826, 1.5, 0.44444444444444
58781, 1.9173913043478, 1.5166666666667, 0.44444444444444
58782, 1.9391304347826, 1.5166666666667, 0.41666666666667
58783, 1.9391304347826, 1.5, 0.38888888888889
58784, 1.9173913043478, 1.5166666666667, 0.38888888888889
58785, 1.9391304347826, 1.5166666666667, 0.36111111111111
58786, 1.9391304347826, 1.5, 0.33333333333333
58787, 1.9173913043478, 1.5166666666667, 0.33333333333333
58788, 1.9391304347826, 1.5166666666667, 0.30555555555556
58789, 1.9391304347826, 1.5, 0.27777777777778
58790, 1.9173913043478, 1.5166666666667, 0.27777777777778
58791, 1.9391304347826, 1.5166666666667, 0.25
58792, 1.9391304347826, 1.5, 0.22222222222222
58793, 1.9173913043478, 1.5166666666667, 0.22222222222222
58794, 1.9391304347826, 1.5166666666667, 0.19444444444444
58795, 1.9391304347826, 1.5, 0.16666666666667
58796, 1.9173913043478, 1.5166666666667, 0.16666666666667
58797, 1.9391304347826, 1.5166666666667, 0.13888888888889
58798, 1.9391304347826, 1.5, 0.11111111111111
58799, 1.9173913043478, 1.5166666666667, 0.11111111111111
58800, 1.9391304347826, 1.5166666666667, 0.083333333333333
58801, 1.9391304347826, 1.5, 0.055555555555556
58802, 1.9173913043478, 1.5166666666667, 0.055555555555556
58803, 1.9391304347826, 1.5166666666667, 0.027777777777778
58804, 1.9391304347826, 1.5333333333333, 0.44444444444444
58805, 1.9391304347826, 1.5333333333333, 0.38888888888889
58806, 1.9391304347826, 1.5333333333333, 0.33333333333333
58807, 1.9391304347826, 1.5333333333333, 0.27777777777778
58808, 1.9391304347826, 1.5333333333333, 0.22222222222222
58809, 1.9391304347826, 1.5333333333333, 0.16666666666667
58810, 1.9391304347826, 1.5333333333333, 0.11111111111111
58811, 1.9391304347826, 1.5333333333333, 0.055555555555556
58812, 1.9826086956522, 1.4833333333333, 0.47222222222222
58813, 1.9826086956522, 1.4666666666667, 0.44444444444444
58814, 1.9608695652174, 1.4833333333333, 0.44444444444444
58815, 1.9826086956522, 1.4833333333333, 0.41666666666667
58816, 1.9826086956522, 1.4666666666667, 0.38888888888889
58817, 1.9608695652174, 1.4833333333333, 0.38888888888889
58818, 1.9826086956522, 1.4833333333333, 0.36111111111111
58819, 1.9826086956522, 1.4666666666667, 0.33333333333333
58820, 1.9608695652174, 1.4833333333333, 0.33333333333333
58821, 1.9826086956522, 1.4833333333333, 0.30555555555556
58822, 1.9826086956522, 1.4666666666667, 0.27777777777778
58823, 1.9608695652174, 1.4833333333333, 0.27777777777778
58824, 1.9826086956522, 1.4833333333333, 0.25
58825, 1.9826086956522, 1.4666666666667, 0.22222222222222
58826, 1.9608695652174, 1.4833333333333, 0.22222222222222
58827, 1.9826086956522, 1.4833333333333, 0.19444444444444
58828, 1.9826086956522, 1.4666666666667, 0.16666666666667
58829, 1.9608695652174, 1.4833333333333, 0.16666666666667
58830, 1.9826086956522, 1.4833333333333, 0.13888888888889
58831, 1.9826086956522, 1.4666666666667, 0.11111111111111
58832, 1.9608695652174, 1.4833333333333, 0.11111111111111
58833, 1.9826086956522, 1.4833333333333, 0.083333333333333
58834, 1.9826086956522, 1.4666666666667, 0.055555555555556
58835, 1.9608695652174, 1.4833333333333, 0.055555555555556
58836, 1.9826086956522, 1.4833333333333, 0.027777777777778
58837, 1.9826086956522, 1.5166666666667, 0.47222222222222
58838, 1.9826086956522, 1.5, 0.44444444444444
58839, 1.9608695652174, 1.5166666666667, 0.44444444444444
58840, 1.9826086956522, 1.5166666666667, 0.41666666666667
58841, 1.9826086956522, 1.5, 0.38888888888889
58842, 1.9608695652174, 1.5166666666667, 0.38888888888889
58843, 1.9826086956522, 1.5166666666667, 0.36111111111111
58844, 1.9826086956522, 1.5, 0.33333333333333
58845, 1.9608695652174, 1.5166666666667, 0.33333333333333
58846, 1.9826086956522, 1.5166666666667, 0.30555555555556
58847, 1.9826086956522, 1.5, 0.27777777777778
58848, 1.9608695652174, 1.5166666666667, 0.27777777777778
58849, 1.9826086956522, 1.5166666666667, 0.25
58850, 1.9826086956522, 1.5, 0.22222222222222
58851, 1.9608695652174, 1.5166666666667, 0.22222222222222
58852, 1.9826086956522, 1.5166666666667, 0.19444444444444
58853, 1.9826086956522, 1.5, 0.16666666666667
58854, 1.9608695652174, 1.5166666666667, 0.16666666666667
58855, 1.9826086956522, 1.5166666666667, 0.13888888888889
58856, 1.9826086956522, 1.5, 0.11111111111111
58857, 1.9608695652174, 1.5166666666667, 0.11111111111111
58858, 1.9826086956522, 1.5166666666667, 0.083333333333333
58859, 1.9826086956522, 1.5, 0.055555555555556
58860, 1.9608695652174, 1.5166666666667, 0.055555555555556
58861, 1.9826086956522, 1.5166666666667, 0.027777777777778
58862, 1.9826086956522, 1.5333333333333, 0.44444444444444
58863, 1.9826086956522, 1.5333333333333, 0.38888888888889
58864, 1.9826086956522, 1.5333333333333, 0.33333333333333
58865, 1.9826086956522, 1.5333333333333, 0.27777777777778
58866, 1.9826086956522, 1.5333333333333, 0.22222222222222
58867, 1.9826086956522, 1.5333333333333, 0.16666666666667
58868, 1.9826086956522, 1.5333333333333, 0.11111111111111
58869, 1.9826086956522, 1.5333333333333, 0.055555555555556
58870, 2.0260869565217, 1.4833333333333, 0.47222222222222
58871, 2.0260869565217, 1.4666666666667, 0.44444444444444
58872, 2.004347826087, 1.4833333333333, 0.44444444444444
58873, 2.0260869565217, 1.4833333333333, 0.41666666666667
58874, 2.0260869565217, 1.4666666666667, 0.38888888888889
58875, 2.004347826087, 1.4833333333333, 0.38888888888889
58876, 2.0260869565217, 1.4833333333333, 0.36111111111111
58877, 2.0260869565217, 1.4666666666667, 0.33333333333333
58878, 2.004347826087, 1.4833333333333, 0.33333333333333
58879, 2.0260869565217, 1.4833333333333, 0.30555555555556
58880, 2.0260869565217, 1.4666666666667, 0.27777777777778
58881, 2.004347826087, 1.4833333333333, 0.27777777777778
58882, 2.0260869565217, 1.4833333333333, 0.25
58883, 2.0260869565217, 1.4666666666667, 0.22222222222222
58884, 2.004347826087, 1.4833333333333, 0.22222222222222
58885, 2.0260869565217, 1.4833333333333, 0.19444444444444
58886, 2.0260869565217, 1.4666666666667, 0.16666666666667
58887, 2.004347826087, 1.4833333333333, 0.16666666666667
58888, 2.0260869565217, 1.4833333333333, 0.13888888888889
58889, 2.0260869565217, 1.4666666666667, 0.11111111111111
58890, 2.004347826087, 1.4833333333333, 0.11111111111111
58891, 2.0260869565217, 1.4833333333333, 0.083333333333333
58892, 2.0260869565217, 1.4666666666667, 0.055555555555556
58893, 2.004347826087, 1.4833333333333, 0.055555555555556
58894, 2.0260869565217, 1.4833333333333, 0.027777777777778
58895, 2.0260869565217, 1.5166666666667, 0.47222222222222
58896, 2.0260869565217, 1.5, 0.44444444444444
58897, 2.004347826087, 1.5166666666667, 0.44444444444444
58898, 2.0260869565217, 1.5166666666667, 0.41666666666667
58899, 2.0260869565217, 1.5, 0.38888888888889
58900, 2.004347826087, 1.5166666666667, 0.38888888888889
58901, 2.0260869565217, 1.5166666666667, 0.36111111111111
58902, 2.0260869565217, 1.5, 0.33333333333333
58903, 2.004347826087, 1.5166666666667, 0.33333333333333
58904, 2.0260869565217, 1.5166666666667, 0.30555555555556
58905, 2.0260869565217, 1.5, 0.27777777777778
58906, 2.004347826087, 1.5166666666667, 0.27777777777778
58907, 2.0260869565217, 1.5166666666667, 0.25
58908, 2.0260869565217, 1.5, 0.22222222222222
58909, 2.004347826087, 1.5166666666667, 0.22222222222222
58910, 2.0260869565217, 1.5166666666667, 0.19444444444444
58911, 2.0260869565217, 1.5, 0.16666666666667
58912, 2.004347826087, 1.5166666666667, 0.16666666666667
58913, 2.0260869565217, 1.5166666666667, 0.13888888888889
58914, 2.0260869565217, 1.5, 0.11111111111111
58915, 2.004347826087, 1.5166666666667, 0.11111111111111
58916, 2.0260869565217, 1.5166666666667, 0.083333333333333
58917, 2.0260869565217, 1.5, 0.055555555555556
58918, 2.004347826087, 1.5166666666667, 0.055555555555556
58919, 2.0260869565217, 1.5166666666667, 0.027777777777778
58920, 2.0260869565217, 1.5333333333333, 0.44444444444444
58921, 2.0260869565217, 1.5333333333333, 0.38888888888889
58922, 2.0260869565217, 1.5333333333333, 0.33333333333333
58923, 2.0260869565217, 1.5333333333333, 0.27777777777778
58924, 2.0260869565217, 1.5333333333333, 0.22222222222222
58925, 2.0260869565217, 1.5333333333333, 0.16666666666667
58926, 2.0260869565217, 1.5333333333333, 0.11111111111111
58927, 2.0260869565217, 1.5333333333333, 0.055555555555556
58928, 2.0695652173913, 1.4833333333333, 0.47222222222222
58929, 2.0695652173913, 1.4666666666667, 0.44444444444444
58930, 2.0478260869565, 1.4833333333333, 0.44444444444444
58931, 2.0695652173913, 1.4833333333333, 0.41666666666667
58932, 2.0695652173913, 1.4666666666667, 0.38888888888889
58933, 2.0478260869565, 1.4833333333333, 0.38888888888889
58934, 2.0695652173913, 1.4833333333333, 0.36111111111111
58935, 2.0695652173913, 1.4666666666667, 0.33333333333333
58936, 2.0478260869565, 1.4833333333333, 0.33333333333333
58937, 2.0695652173913, 1.4833333333333, 0.30555555555556
58938, 2.0695652173913, 1.4666666666667, 0.27777777777778
58939, 2.0478260869565, 1.4833333333333, 0.27777777777778
58940, 2.0695652173913, 1.4833333333333, 0.25
58941, 2.0695652173913, 1.4666666666667, 0.22222222222222
58942, 2.0478260869565, 1.4833333333333, 0.22222222222222
58943, 2.0695652173913, 1.4833333333333, 0.19444444444444
58944, 2.0695652173913, 1.4666666666667, 0.16666666666667
58945, 2.0478260869565, 1.4833333333333, 0.16666666666667
58946, 2.0695652173913, 1.4833333333333, 0.13888888888889
58947, 2.0695652173913, 1.4666666666667, 0.11111111111111
58948, 2.0478260869565, 1.4833333333333, 0.11111111111111
58949, 2.0695652173913, 1.4833333333333, 0.083333333333333
58950, 2.0695652173913, 1.4666666666667, 0.055555555555556
58951, 2.0478260869565, 1.4833333333333, 0.055555555555556
58952, 2.0695652173913, 1.4833333333333, 0.027777777777778
58953, 2.0695652173913, 1.5166666666667, 0.47222222222222
58954, 2.0695652173913, 1.5, 0.44444444444444
58955, 2.0478260869565, 1.5166666666667, 0.44444444444444
58956, 2.0695652173913, 1.5166666666667, 0.41666666666667
58957, 2.0695652173913, 1.5, 0.38888888888889
58958, 2.0478260869565, 1.5166666666667, 0.38888888888889
58959, 2.0695652173913, 1.5166666666667, 0.36111111111111
58960, 2.0695652173913, 1.5, 0.33333333333333
58961, 2.0478260869565, 1.5166666666667, 0.33333333333333
58962, 2.0695652173913, 1.5166666666667, 0.30555555555556
58963, 2.0695652173913, 1.5, 0.27777777777778
58964, 2.0478260869565, 1.5166666666667, 0.27777777777778
58965, 2.0695652173913, 1.5166666666667, 0.25
58966, 2.0695652173913, 1.5, 0.22222222222222
58967, 2.0478260869565, 1.5166666666667, 0.22222222222222
58968, 2.0695652173913, 1.5166666666667, 0.19444444444444
58969, 2.0695652173913, 1.5, 0.16666666666667
58970, 2.0478260869565, 1.5166666666667, 0.16666666666667
58971, 2.0695652173913, 1.5166666666667, 0.13888888888889
58972, 2.0695652173913, 1.5, 0.11111111111111
58973, 2.0478260869565, 1.5166666666667, 0.11111111111111
58974, 2.0695652173913, 1.5166666666667, 0.083333333333333
58975, 2.0695652173913, 1.5, 0.055555555555556
58976, 2.0478260869565, 1.5166666666667, 0.055555555555556
58977, 2.0695652173913, 1.5166666666667, 0.027777777777778
58978, 2.0695652173913, 1.5333333333333, 0.44444444444444
58979, 2.0695652173913, 1.5333333333333, 0.38888888888889
58980, 2.0695652173913, 1.5333333333333, 0.33333333333333
58981, 2.0695652173913, 1.5333333333333, 0.27777777777778
58982, 2.0695652173913, 1.5333333333333, 0.22222222222222
58983, 2.0695652173913, 1.5333333333333, 0.16666666666667
58984, 2.0695652173913, 1.5333333333333, 0.11111111111111
58985, 2.0695652173913, 1.5333333333333, 0.055555555555556
58986, 2.1130434782609, 1.4833333333333, 0.47222222222222
58987, 2.1130434782609, 1.4666666666667, 0.44444444444444
58988, 2.0913043478261, 1.4833333333333, 0.44444444444444
58989, 2.1130434782609, 1.4833333333333, 0.41666666666667
58990, 2.1130434782609, 1.4666666666667, 0.38888888888889
58991, 2.0913043478261, 1.4833333333333, 0.38888888888889
58992, 2.1130434782609, 1.4833333333333, 0.36111111111111
58993, 2.1130434782609, 1.4666666666667, 0.33333333333333
58994, 2.0913043478261, 1.4833333333333, 0.33333333333333
58995, 2.1130434782609, 1.4833333333333, 0.30555555555556
58996, 2.1130434782609, 1.4666666666667, 0.27777777777778
58997, 2.0913043478261, 1.4833333333333, 0.27777777777778
58998, 2.1130434782609, 1.4833333333333, 0.25
58999, 2.1130434782609, 1.4666666666667, 0.22222222222222
59000, 2.0913043478261, 1.4833333333333, 0.22222222222222
59001, 2.1130434782609, 1.4833333333333, 0.19444444444444
59002, 2.1130434782609, 1.4666666666667, 0.16666666666667
59003, 2.0913043478261, 1.4833333333333, 0.16666666666667
59004, 2.1130434782609, 1.4833333333333, 0.13888888888889
59005, 2.1130434782609, 1.4666666666667, 0.11111111111111
59006, 2.0913043478261, 1.4833333333333, 0.11111111111111
59007, 2.1130434782609, 1.4833333333333, 0.083333333333333
59008, 2.1130434782609, 1.4666666666667, 0.055555555555556
59009, 2.0913043478261, 1.4833333333333, 0.055555555555556
59010, 2.1130434782609, 1.4833333333333, 0.027777777777778
59011, 2.1130434782609, 1.5166666666667, 0.47222222222222
59012, 2.1130434782609, 1.5, 0.44444444444444
59013, 2.0913043478261, 1.5166666666667, 0.44444444444444
59014, 2.1130434782609, 1.5166666666667, 0.41666666666667
59015, 2.1130434782609, 1.5, 0.38888888888889
59016, 2.0913043478261, 1.5166666666667, 0.38888888888889
59017, 2.1130434782609, 1.5166666666667, 0.36111111111111
59018, 2.1130434782609, 1.5, 0.33333333333333
59019, 2.0913043478261, 1.5166666666667, 0.33333333333333
59020, 2.1130434782609, 1.5166666666667, 0.30555555555556
59021, 2.1130434782609, 1.5, 0.27777777777778
59022, 2.0913043478261, 1.5166666666667, 0.27777777777778
59023, 2.1130434782609, 1.5166666666667, 0.25
59024, 2.1130434782609, 1.5, 0.22222222222222
59025, 2.0913043478261, 1.5166666666667, 0.22222222222222
59026, 2.1130434782609, 1.5166666666667, 0.19444444444444
59027, 2.1130434782609, 1.5, 0.16666666666667
59028, 2.0913043478261, 1.5166666666667, 0.16666666666667
59029, 2.1130434782609, 1.5166666666667, 0.13888888888889
59030, 2.1130434782609, 1.5, 0.11111111111111
59031, 2.0913043478261, 1.5166666666667, 0.11111111111111
59032, 2.1130434782609, 1.5166666666667, 0.083333333333333
59033, 2.1130434782609, 1.5, 0.055555555555556
59034, 2.0913043478261, 1.5166666666667, 0.055555555555556
59035, 2.1130434782609, 1.5166666666667, 0.027777777777778
59036, 2.1130434782609, 1.5333333333333, 0.44444444444444
59037, 2.1130434782609, 1.5333333333333, 0.38888888888889
59038, 2.1130434782609, 1.5333333333333, 0.33333333333333
59039, 2.1130434782609, 1.5333333333333, 0.27777777777778
59040, 2.1130434782609, 1.5333333333333, 0.22222222222222
59041, 2.1130434782609, 1.5333333333333, 0.16666666666667
59042, 2.1130434782609, 1.5333333333333, 0.11111111111111
59043, 2.1130434782609, 1.5333333333333, 0.055555555555556
59044, 2.1565217391304, 1.4833333333333, 0.47222222222222
59045, 2.1565217391304, 1.4666666666667, 0.44444444444444
59046, 2.1347826086957, 1.4833333333333, 0.44444444444444
59047, 2.1565217391304, 1.4833333333333, 0.41666666666667
59048, 2.1565217391304, 1.4666666666667, 0.38888888888889
59049, 2.1347826086957, 1.4833333333333, 0.38888888888889
59050, 2.1565217391304, 1.4833333333333, 0.36111111111111
59051, 2.1565217391304, 1.4666666666667, 0.33333333333333
59052, 2.1347826086957, 1.4833333333333, 0.33333333333333
59053, 2.1565217391304, 1.4833333333333, 0.30555555555556
59054, 2.1565217391304, 1.4666666666667, 0.27777777777778
59055, 2.1347826086957, 1.4833333333333, 0.27777777777778
59056, 2.1565217391304, 1.4833333333333, 0.25
59057, 2.1565217391304, 1.4666666666667, 0.22222222222222
59058, 2.1347826086957, 1.4833333333333, 0.22222222222222
59059, 2.1565217391304, 1.4833333333333, 0.19444444444444
59060, 2.1565217391304, 1.4666666666667, 0.16666666666667
59061, 2.1347826086957, 1.4833333333333, 0.16666666666667
59062, 2.1565217391304, 1.4833333333333, 0.13888888888889
59063, 2.1565217391304, 1.4666666666667, 0.11111111111111
59064, 2.1347826086957, 1.4833333333333, 0.11111111111111
59065, 2.1565217391304, 1.4833333333333, 0.083333333333333
59066, 2.1565217391304, 1.4666666666667, 0.055555555555556
59067, 2.1347826086957, 1.4833333333333, 0.055555555555556
59068, 2.1565217391304, 1.4833333333333, 0.027777777777778
59069, 2.1565217391304, 1.5166666666667, 0.47222222222222
59070, 2.1565217391304, 1.5, 0.44444444444444
59071, 2.1347826086957, 1.5166666666667, 0.44444444444444
59072, 2.1565217391304, 1.5166666666667, 0.41666666666667
59073, 2.1565217391304, 1.5, 0.38888888888889
59074, 2.1347826086957, 1.5166666666667, 0.38888888888889
59075, 2.1565217391304, 1.5166666666667, 0.36111111111111
59076, 2.1565217391304, 1.5, 0.33333333333333
59077, 2.1347826086957, 1.5166666666667, 0.33333333333333
59078, 2.1565217391304, 1.5166666666667, 0.30555555555556
59079, 2.1565217391304, 1.5, 0.27777777777778
59080, 2.1347826086957, 1.5166666666667, 0.27777777777778
59081, 2.1565217391304, 1.5166666666667, 0.25
59082, 2.1565217391304, 1.5, 0.22222222222222
59083, 2.1347826086957, 1.5166666666667, 0.22222222222222
59084, 2.1565217391304, 1.5166666666667, 0.19444444444444
59085, 2.1565217391304, 1.5, 0.16666666666667
59086, 2.1347826086957, 1.5166666666667, 0.16666666666667
59087, 2.1565217391304, 1.5166666666667, 0.13888888888889
59088, 2.1565217391304, 1.5, 0.11111111111111
59089, 2.1347826086957, 1.5166666666667, 0.11111111111111
59090, 2.1565217391304, 1.5166666666667, 0.083333333333333
59091, 2.1565217391304, 1.5, 0.055555555555556
59092, 2.1347826086957, 1.5166666666667, 0.055555555555556
59093, 2.1565217391304, 1.5166666666667, 0.027777777777778
59094, 2.1565217391304, 1.5333333333333, 0.44444444444444
59095, 2.1565217391304, 1.5333333333333, 0.38888888888889
59096, 2.1565217391304, 1.5333333333333, 0.33333333333333
59097, 2.1565217391304, 1.5333333333333, 0.27777777777778
59098, 2.1565217391304, 1.5333333333333, 0.22222222222222
59099, 2.1565217391304, 1.5333333333333, 0.16666666666667
59100, 2.1565217391304, 1.5333333333333, 0.11111111111111
59101, 2.1565217391304, 1.5333333333333, 0.055555555555556
59102, 2.1782608695652, 1.4833333333333, 0.44444444444444
59103, 2.1782608695652, 1.4833333333333, 0.38888888888889
59104, 2.1782608695652, 1.4833333333333, 0.33333333333333
59105, 2.1782608695652, 1.4833333333333, 0.27777777777778
59106, 2.1782608695652, 1.4833333333333, 0.22222222222222
59107, 2.1782608695652, 1.4833333333333, 0.16666666666667
59108, 2.1782608695652, 1.4833333333333, 0.11111111111111
59109, 2.1782608695652, 1.4833333333333, 0.055555555555556
59110, 2.1782608695652, 1.5166666666667, 0.44444444444444
59111, 2.1782608695652, 1.5166666666667, 0.38888888888889
59112, 2.1782608695652, 1.5166666666667, 0.33333333333333
59113, 2.1782608695652, 1.5166666666667, 0.27777777777778
59114, 2.1782608695652, 1.5166666666667, 0.22222222222222
59115, 2.1782608695652, 1.5166666666667, 0.16666666666667
59116, 2.1782608695652, 1.5166666666667, 0.11111111111111
59117, 2.1782608695652, 1.5166666666667, 0.055555555555556
59118, 1.2434782608696, 1.425, 0.44444444444444
59119, 1.2434782608696, 1.425, 0.38888888888889
59120, 1.2434782608696, 1.425, 0.33333333333333
59121, 1.2434782608696, 1.425, 0.27777777777778
59122, 1.2434782608696, 1.425, 0.22222222222222
59123, 1.2434782608696, 1.425, 0.16666666666667
59124, 1.2434782608696, 1.425, 0.11111111111111
59125, 1.2434782608696, 1.425, 0.055555555555556
59126, 1.2869565217391, 1.425, 0.44444444444444
59127, 1.2869565217391, 1.425, 0.38888888888889
59128, 1.2869565217391, 1.425, 0.33333333333333
59129, 1.2869565217391, 1.425, 0.27777777777778
59130, 1.2869565217391, 1.425, 0.22222222222222
59131, 1.2869565217391, 1.425, 0.16666666666667
59132, 1.2869565217391, 1.425, 0.11111111111111
59133, 1.2869565217391, 1.425, 0.055555555555556
59134, 1.3304347826087, 1.425, 0.44444444444444
59135, 1.3304347826087, 1.425, 0.38888888888889
59136, 1.3304347826087, 1.425, 0.33333333333333
59137, 1.3304347826087, 1.425, 0.27777777777778
59138, 1.3304347826087, 1.425, 0.22222222222222
59139, 1.3304347826087, 1.425, 0.16666666666667
59140, 1.3304347826087, 1.425, 0.11111111111111
59141, 1.3304347826087, 1.425, 0.055555555555556
59142, 1.3739130434783, 1.425, 0.44444444444444
59143, 1.3739130434783, 1.425, 0.38888888888889
59144, 1.3739130434783, 1.425, 0.33333333333333
59145, 1.3739130434783, 1.425, 0.27777777777778
59146, 1.3739130434783, 1.425, 0.22222222222222
59147, 1.3739130434783, 1.425, 0.16666666666667
59148, 1.3739130434783, 1.425, 0.11111111111111
59149, 1.3739130434783, 1.425, 0.055555555555556
59150, 1.4173913043478, 1.425, 0.44444444444444
59151, 1.4173913043478, 1.425, 0.38888888888889
59152, 1.4173913043478, 1.425, 0.33333333333333
59153, 1.4173913043478, 1.425, 0.27777777777778
59154, 1.4173913043478, 1.425, 0.22222222222222
59155, 1.4173913043478, 1.425, 0.16666666666667
59156, 1.4173913043478, 1.425, 0.11111111111111
59157, 1.4173913043478, 1.425, 0.055555555555556
59158, 1.4608695652174, 1.425, 0.44444444444444
59159, 1.4608695652174, 1.425, 0.38888888888889
59160, 1.4608695652174, 1.425, 0.33333333333333
59161, 1.4608695652174, 1.425, 0.27777777777778
59162, 1.4608695652174, 1.425, 0.22222222222222
59163, 1.4608695652174, 1.425, 0.16666666666667
59164, 1.4608695652174, 1.425, 0.11111111111111
59165, 1.4608695652174, 1.425, 0.055555555555556
59166, 1.504347826087, 1.425, 0.44444444444444
59167, 1.504347826087, 1.425, 0.38888888888889
59168, 1.504347826087, 1.425, 0.33333333333333
59169, 1.504347826087, 1.425, 0.27777777777778
59170, 1.504347826087, 1.425, 0.22222222222222
59171, 1.504347826087, 1.425, 0.16666666666667
59172, 1.504347826087, 1.425, 0.11111111111111
59173, 1.504347826087, 1.425, 0.055555555555556
59174, 1.5478260869565, 1.425, 0.44444444444444
59175, 1.5478260869565, 1.425, 0.38888888888889
59176, 1.5478260869565, 1.425, 0.33333333333333
59177, 1.5478260869565, 1.425, 0.27777777777778
59178, 1.5478260869565, 1.425, 0.22222222222222
59179, 1.5478260869565, 1.425, 0.16666666666667
59180, 1.5478260869565, 1.425, 0.11111111111111
59181, 1.5478260869565, 1.425, 0.055555555555556
59182, 1.5913043478261, 1.425, 0.44444444444444
59183, 1.5913043478261, 1.425, 0.38888888888889
59184, 1.5913043478261, 1.425, 0.33333333333333
59185, 1.5913043478261, 1.425, 0.27777777777778
59186, 1.5913043478261, 1.425, 0.22222222222222
59187, 1.5913043478261, 1.425, 0.16666666666667
59188, 1.5913043478261, 1.425, 0.11111111111111
59189, 1.5913043478261, 1.425, 0.055555555555556
59190, 1.6347826086957, 1.425, 0.44444444444444
59191, 1.6347826086957, 1.425, 0.38888888888889
59192, 1.6347826086957, 1.425, 0.33333333333333
59193, 1.6347826086957, 1.425, 0.27777777777778
59194, 1.6347826086957, 1.425, 0.22222222222222
59195, 1.6347826086957, 1.425, 0.16666666666667
59196, 1.6347826086957, 1.425, 0.11111111111111
59197, 1.6347826086957, 1.425, 0.055555555555556
59198, 1.6782608695652, 1.425, 0.44444444444444
59199, 1.6782608695652, 1.425, 0.38888888888889
59200, 1.6782608695652, 1.425, 0.33333333333333
59201, 1.6782608695652, 1.425, 0.27777777777778
59202, 1.6782608695652, 1.425, 0.22222222222222
59203, 1.6782608695652, 1.425, 0.16666666666667
59204, 1.6782608695652, 1.425, 0.11111111111111
59205, 1.6782608695652, 1.425, 0.055555555555556
59206, 1.7217391304348, 1.425, 0.44444444444444
59207, 1.7217391304348, 1.425, 0.38888888888889
59208, 1.7217391304348, 1.425, 0.33333333333333
59209, 1.7217391304348, 1.425, 0.27777777777778
59210, 1.7217391304348, 1.425, 0.22222222222222
59211, 1.7217391304348, 1.425, 0.16666666666667
59212, 1.7217391304348, 1.425, 0.11111111111111
59213, 1.7217391304348, 1.425, 0.055555555555556
59214, 1.7652173913043, 1.425, 0.44444444444444
59215, 1.7652173913043, 1.425, 0.38888888888889
59216, 1.7652173913043, 1.425, 0.33333333333333
59217, 1.7652173913043, 1.425, 0.27777777777778
59218, 1.7652173913043, 1.425, 0.22222222222222
59219, 1.7652173913043, 1.425, 0.16666666666667
59220, 1.7652173913043, 1.425, 0.11111111111111
59221, 1.7652173913043, 1.425, 0.055555555555556
59222, 1.8086956521739, 1.425, 0.44444444444444
59223, 1.8086956521739, 1.425, 0.38888888888889
59224, 1.8086956521739, 1.425, 0.33333333333333
59225, 1.8086956521739, 1.425, 0.27777777777778
59226, 1.8086956521739, 1.425, 0.22222222222222
59227, 1.8086956521739, 1.425, 0.16666666666667
59228, 1.8086956521739, 1.425, 0.11111111111111
59229, 1.8086956521739, 1.425, 0.055555555555556
59230, 1.8521739130435, 1.425, 0.44444444444444
59231, 1.8521739130435, 1.425, 0.38888888888889
59232, 1.8521739130435, 1.425, 0.33333333333333
59233, 1.8521739130435, 1.425, 0.27777777777778
59234, 1.8521739130435, 1.425, 0.22222222222222
59235, 1.8521739130435, 1.425, 0.16666666666667
59236, 1.8521739130435, 1.425, 0.11111111111111
59237, 1.8521739130435, 1.425, 0.055555555555556
59238, 1.895652173913, 1.425, 0.44444444444444
59239, 1.895652173913, 1.425, 0.38888888888889
59240, 1.895652173913, 1.425, 0.33333333333333
59241, 1.895652173913, 1.425, 0.27777777777778
59242, 1.895652173913, 1.425, 0.22222222222222
59243, 1.895652173913, 1.425, 0.16666666666667
59244, 1.895652173913, 1.425, 0.11111111111111
59245, 1.895652173913, 1.425, 0.055555555555556
59246, 1.9391304347826, 1.425, 0.44444444444444
59247, 1.9391304347826, 1.425, 0.38888888888889
59248, 1.9391304347826, 1.425, 0.33333333333333
59249, 1.9391304347826, 1.425, 0.27777777777778
59250, 1.9391304347826, 1.425, 0.22222222222222
59251, 1.9391304347826, 1.425, 0.16666666666667
59252, 1.9391304347826, 1.425, 0.11111111111111
59253, 1.9391304347826, 1.425, 0.055555555555556
59254, 1.9826086956522, 1.425, 0.44444444444444
59255, 1.9826086956522, 1.425, 0.38888888888889
59256, 1.9826086956522, 1.425, 0.33333333333333
59257, 1.9826086956522, 1.425, 0.27777777777778
59258, 1.9826086956522, 1.425, 0.22222222222222
59259, 1.9826086956522, 1.425, 0.16666666666667
59260, 1.9826086956522, 1.425, 0.11111111111111
59261, 1.9826086956522, 1.425, 0.055555555555556
59262, 2.0260869565217, 1.425, 0.44444444444444
59263, 2.0260869565217, 1.425, 0.38888888888889
59264, 2.0260869565217, 1.425, 0.33333333333333
59265, 2.0260869565217, 1.425, 0.27777777777778
59266, 2.0260869565217, 1.425, 0.22222222222222
59267, 2.0260869565217, 1.425, 0.16666666666667
59268, 2.0260869565217, 1.425, 0.11111111111111
59269, 2.0260869565217, 1.425, 0.055555555555556
59270, 2.0695652173913, 1.425, 0.44444444444444
59271, 2.0695652173913, 1.425, 0.38888888888889
59272, 2.0695652173913, 1.425, 0.33333333333333
59273, 2.0695652173913, 1.425, 0.27777777777778
59274, 2.0695652173913, 1.425, 0.22222222222222
59275, 2.0695652173913, 1.425, 0.16666666666667
59276, 2.0695652173913, 1.425, 0.11111111111111
59277, 2.0695652173913, 1.425, 0.055555555555556
59278, 2.1130434782609, 1.425, 0.44444444444444
59279, 2.1130434782609, 1.425, 0.38888888888889
59280, 2.1130434782609, 1.425, 0.33333333333333
59281, 2.1130434782609, 1.425, 0.27777777777778
59282, 2.1130434782609, 1.425, 0.22222222222222
59283, 2.1130434782609, 1.425, 0.16666666666667
59284, 2.1130434782609, 1.425, 0.11111111111111
59285, 2.1130434782609, 1.425, 0.055555555555556
59286, 2.1565217391304, 1.425, 0.44444444444444
59287, 2.1565217391304, 1.425, 0.38888888888889
59288, 2.1565217391304, 1.425, 0.33333333333333
59289, 2.1565217391304, 1.425, 0.27777777777778
59290, 2.1565217391304, 1.425, 0.22222222222222
59291, 2.1565217391304, 1.425, 0.16666666666667
59292, 2.1565217391304, 1.425, 0.11111111111111
59293, 2.1565217391304, 1.425, 0.055555555555556
59294, 1.2434782608696, 1.425, 0.47222222222222
59295, 1.2217391304348, 1.425, 0.44444444444444
59296, 1.2434782608696, 1.4375, 0.44444444444444
59297, 1.2434782608696, 1.425, 0.41666666666667
59298, 1.2217391304348, 1.425, 0.38888888888889
59299, 1.2434782608696, 1.4375, 0.38888888888889
59300, 1.2434782608696, 1.425, 0.36111111111111
59301, 1.2217391304348, 1.425, 0.33333333333333
59302, 1.2434782608696, 1.4375, 0.33333333333333
59303, 1.2434782608696, 1.425, 0.30555555555556
59304, 1.2217391304348, 1.425, 0.27777777777778
59305, 1.2434782608696, 1.4375, 0.27777777777778
59306, 1.2434782608696, 1.425, 0.25
59307, 1.2217391304348, 1.425, 0.22222222222222
59308, 1.2434782608696, 1.4375, 0.22222222222222
59309, 1.2434782608696, 1.425, 0.19444444444444
59310, 1.2217391304348, 1.425, 0.16666666666667
59311, 1.2434782608696, 1.4375, 0.16666666666667
59312, 1.2434782608696, 1.425, 0.13888888888889
59313, 1.2217391304348, 1.425, 0.11111111111111
59314, 1.2434782608696, 1.4375, 0.11111111111111
59315, 1.2434782608696, 1.425, 0.083333333333333
59316, 1.2217391304348, 1.425, 0.055555555555556
59317, 1.2434782608696, 1.4375, 0.055555555555556
59318, 1.2434782608696, 1.425, 0.027777777777778
59319, 1.2869565217391, 1.425, 0.47222222222222
59320, 1.2652173913043, 1.425, 0.44444444444444
59321, 1.2869565217391, 1.4375, 0.44444444444444
59322, 1.2869565217391, 1.425, 0.41666666666667
59323, 1.2652173913043, 1.425, 0.38888888888889
59324, 1.2869565217391, 1.4375, 0.38888888888889
59325, 1.2869565217391, 1.425, 0.36111111111111
59326, 1.2652173913043, 1.425, 0.33333333333333
59327, 1.2869565217391, 1.4375, 0.33333333333333
59328, 1.2869565217391, 1.425, 0.30555555555556
59329, 1.2652173913043, 1.425, 0.27777777777778
59330, 1.2869565217391, 1.4375, 0.27777777777778
59331, 1.2869565217391, 1.425, 0.25
59332, 1.2652173913043, 1.425, 0.22222222222222
59333, 1.2869565217391, 1.4375, 0.22222222222222
59334, 1.2869565217391, 1.425, 0.19444444444444
59335, 1.2652173913043, 1.425, 0.16666666666667
59336, 1.2869565217391, 1.4375, 0.16666666666667
59337, 1.2869565217391, 1.425, 0.13888888888889
59338, 1.2652173913043, 1.425, 0.11111111111111
59339, 1.2869565217391, 1.4375, 0.11111111111111
59340, 1.2869565217391, 1.425, 0.083333333333333
59341, 1.2652173913043, 1.425, 0.055555555555556
59342, 1.2869565217391, 1.4375, 0.055555555555556
59343, 1.2869565217391, 1.425, 0.027777777777778
59344, 1.3304347826087, 1.425, 0.47222222222222
59345, 1.3086956521739, 1.425, 0.44444444444444
59346, 1.3304347826087, 1.4375, 0.44444444444444
59347, 1.3304347826087, 1.425, 0.41666666666667
59348, 1.3086956521739, 1.425, 0.38888888888889
59349, 1.3304347826087, 1.4375, 0.38888888888889
59350, 1.3304347826087, 1.425, 0.36111111111111
59351, 1.3086956521739, 1.425, 0.33333333333333
59352, 1.3304347826087, 1.4375, 0.33333333333333
59353, 1.3304347826087, 1.425, 0.30555555555556
59354, 1.3086956521739, 1.425, 0.27777777777778
59355, 1.3304347826087, 1.4375, 0.27777777777778
59356, 1.3304347826087, 1.425, 0.25
59357, 1.3086956521739, 1.425, 0.22222222222222
59358, 1.3304347826087, 1.4375, 0.22222222222222
59359, 1.3304347826087, 1.425, 0.19444444444444
59360, 1.3086956521739, 1.425, 0.16666666666667
59361, 1.3304347826087, 1.4375, 0.16666666666667
59362, 1.3304347826087, 1.425, 0.13888888888889
59363, 1.3086956521739, 1.425, 0.11111111111111
59364, 1.3304347826087, 1.4375, 0.11111111111111
59365, 1.3304347826087, 1.425, 0.083333333333333
59366, 1.3086956521739, 1.425, 0.055555555555556
59367, 1.3304347826087, 1.4375, 0.055555555555556
59368, 1.3304347826087, 1.425, 0.027777777777778
59369, 1.3739130434783, 1.425, 0.47222222222222
59370, 1.3521739130435, 1.425, 0.44444444444444
59371, 1.3739130434783, 1.4375, 0.44444444444444
59372, 1.3739130434783, 1.425, 0.41666666666667
59373, 1.3521739130435, 1.425, 0.38888888888889
59374, 1.3739130434783, 1.4375, 0.38888888888889
59375, 1.3739130434783, 1.425, 0.36111111111111
59376, 1.3521739130435, 1.425, 0.33333333333333
59377, 1.3739130434783, 1.4375, 0.33333333333333
59378, 1.3739130434783, 1.425, 0.30555555555556
59379, 1.3521739130435, 1.425, 0.27777777777778
59380, 1.3739130434783, 1.4375, 0.27777777777778
59381, 1.3739130434783, 1.425, 0.25
59382, 1.3521739130435, 1.425, 0.22222222222222
59383, 1.3739130434783, 1.4375, 0.22222222222222
59384, 1.3739130434783, 1.425, 0.19444444444444
59385, 1.3521739130435, 1.425, 0.16666666666667
59386, 1.3739130434783, 1.4375, 0.16666666666667
59387, 1.3739130434783, 1.425, 0.13888888888889
59388, 1.3521739130435, 1.425, 0.11111111111111
59389, 1.3739130434783, 1.4375, 0.11111111111111
59390, 1.3739130434783, 1.425, 0.083333333333333
59391, 1.3521739130435, 1.425, 0.055555555555556
59392, 1.3739130434783, 1.4375, 0.055555555555556
59393, 1.3739130434783, 1.425, 0.027777777777778
59394, 1.4173913043478, 1.425, 0.47222222222222
59395, 1.395652173913, 1.425, 0.44444444444444
59396, 1.4173913043478, 1.4375, 0.44444444444444
59397, 1.4173913043478, 1.425, 0.41666666666667
59398, 1.395652173913, 1.425, 0.38888888888889
59399, 1.4173913043478, 1.4375, 0.38888888888889
59400, 1.4173913043478, 1.425, 0.36111111111111
59401, 1.395652173913, 1.425, 0.33333333333333
59402, 1.4173913043478, 1.4375, 0.33333333333333
59403, 1.4173913043478, 1.425, 0.30555555555556
59404, 1.395652173913, 1.425, 0.27777777777778
59405, 1.4173913043478, 1.4375, 0.27777777777778
59406, 1.4173913043478, 1.425, 0.25
59407, 1.395652173913, 1.425, 0.22222222222222
59408, 1.4173913043478, 1.4375, 0.22222222222222
59409, 1.4173913043478, 1.425, 0.19444444444444
59410, 1.395652173913, 1.425, 0.16666666666667
59411, 1.4173913043478, 1.4375, 0.16666666666667
59412, 1.4173913043478, 1.425, 0.13888888888889
59413, 1.395652173913, 1.425, 0.11111111111111
59414, 1.4173913043478, 1.4375, 0.11111111111111
59415, 1.4173913043478, 1.425, 0.083333333333333
59416, 1.395652173913, 1.425, 0.055555555555556
59417, 1.4173913043478, 1.4375, 0.055555555555556
59418, 1.4173913043478, 1.425, 0.027777777777778
59419, 1.4608695652174, 1.425, 0.47222222222222
59420, 1.4391304347826, 1.425, 0.44444444444444
59421, 1.4608695652174, 1.4375, 0.44444444444444
59422, 1.4608695652174, 1.425, 0.41666666666667
59423, 1.4391304347826, 1.425, 0.38888888888889
59424, 1.4608695652174, 1.4375, 0.38888888888889
59425, 1.4608695652174, 1.425, 0.36111111111111
59426, 1.4391304347826, 1.425, 0.33333333333333
59427, 1.4608695652174, 1.4375, 0.33333333333333
59428, 1.4608695652174, 1.425, 0.30555555555556
59429, 1.4391304347826, 1.425, 0.27777777777778
59430, 1.4608695652174, 1.4375, 0.27777777777778
59431, 1.4608695652174, 1.425, 0.25
59432, 1.4391304347826, 1.425, 0.22222222222222
59433, 1.4608695652174, 1.4375, 0.22222222222222
59434, 1.4608695652174, 1.425, 0.19444444444444
59435, 1.4391304347826, 1.425, 0.16666666666667
59436, 1.4608695652174, 1.4375, 0.16666666666667
59437, 1.4608695652174, 1.425, 0.13888888888889
59438, 1.4391304347826, 1.425, 0.11111111111111
59439, 1.4608695652174, 1.4375, 0.11111111111111
59440, 1.4608695652174, 1.425, 0.083333333333333
59441, 1.4391304347826, 1.425, 0.055555555555556
59442, 1.4608695652174, 1.4375, 0.055555555555556
59443, 1.4608695652174, 1.425, 0.027777777777778
59444, 1.504347826087, 1.425, 0.47222222222222
59445, 1.4826086956522, 1.425, 0.44444444444444
59446, 1.504347826087, 1.4375, 0.44444444444444
59447, 1.504347826087, 1.425, 0.41666666666667
59448, 1.4826086956522, 1.425, 0.38888888888889
59449, 1.504347826087, 1.4375, 0.38888888888889
59450, 1.504347826087, 1.425, 0.36111111111111
59451, 1.4826086956522, 1.425, 0.33333333333333
59452, 1.504347826087, 1.4375, 0.33333333333333
59453, 1.504347826087, 1.425, 0.30555555555556
59454, 1.4826086956522, 1.425, 0.27777777777778
59455, 1.504347826087, 1.4375, 0.27777777777778
59456, 1.504347826087, 1.425, 0.25
59457, 1.4826086956522, 1.425, 0.22222222222222
59458, 1.504347826087, 1.4375, 0.22222222222222
59459, 1.504347826087, 1.425, 0.19444444444444
59460, 1.4826086956522, 1.425, 0.16666666666667
59461, 1.504347826087, 1.4375, 0.16666666666667
59462, 1.504347826087, 1.425, 0.13888888888889
59463, 1.4826086956522, 1.425, 0.11111111111111
59464, 1.504347826087, 1.4375, 0.11111111111111
59465, 1.504347826087, 1.425, 0.083333333333333
59466, 1.4826086956522, 1.425, 0.055555555555556
59467, 1.504347826087, 1.4375, 0.055555555555556
59468, 1.504347826087, 1.425, 0.027777777777778
59469, 1.5478260869565, 1.425, 0.47222222222222
59470, 1.5260869565217, 1.425, 0.44444444444444
59471, 1.5478260869565, 1.4375, 0.44444444444444
59472, 1.5478260869565, 1.425, 0.41666666666667
59473, 1.5260869565217, 1.425, 0.38888888888889
59474, 1.5478260869565, 1.4375, 0.38888888888889
59475, 1.5478260869565, 1.425, 0.36111111111111
59476, 1.5260869565217, 1.425, 0.33333333333333
59477, 1.5478260869565, 1.4375, 0.33333333333333
59478, 1.5478260869565, 1.425, 0.30555555555556
59479, 1.5260869565217, 1.425, 0.27777777777778
59480, 1.5478260869565, 1.4375, 0.27777777777778
59481, 1.5478260869565, 1.425, 0.25
59482, 1.5260869565217, 1.425, 0.22222222222222
59483, 1.5478260869565, 1.4375, 0.22222222222222
59484, 1.5478260869565, 1.425, 0.19444444444444
59485, 1.5260869565217, 1.425, 0.16666666666667
59486, 1.5478260869565, 1.4375, 0.16666666666667
59487, 1.5478260869565, 1.425, 0.13888888888889
59488, 1.5260869565217, 1.425, 0.11111111111111
59489, 1.5478260869565, 1.4375, 0.11111111111111
59490, 1.5478260869565, 1.425, 0.083333333333333
59491, 1.5260869565217, 1.425, 0.055555555555556
59492, 1.5478260869565, 1.4375, 0.055555555555556
59493, 1.5478260869565, 1.425, 0.027777777777778
59494, 1.5913043478261, 1.425, 0.47222222222222
59495, 1.5695652173913, 1.425, 0.44444444444444
59496, 1.5913043478261, 1.4375, 0.44444444444444
59497, 1.5913043478261, 1.425, 0.41666666666667
59498, 1.5695652173913, 1.425, 0.38888888888889
59499, 1.5913043478261, 1.4375, 0.38888888888889
59500, 1.5913043478261, 1.425, 0.36111111111111
59501, 1.5695652173913, 1.425, 0.33333333333333
59502, 1.5913043478261, 1.4375, 0.33333333333333
59503, 1.5913043478261, 1.425, 0.30555555555556
59504, 1.5695652173913, 1.425, 0.27777777777778
59505, 1.5913043478261, 1.4375, 0.27777777777778
59506, 1.5913043478261, 1.425, 0.25
59507, 1.5695652173913, 1.425, 0.22222222222222
59508, 1.5913043478261, 1.4375, 0.22222222222222
59509, 1.5913043478261, 1.425, 0.19444444444444
59510, 1.5695652173913, 1.425, 0.16666666666667
59511, 1.5913043478261, 1.4375, 0.16666666666667
59512, 1.5913043478261, 1.425, 0.13888888888889
59513, 1.5695652173913, 1.425, 0.11111111111111
59514, 1.5913043478261, 1.4375, 0.11111111111111
59515, 1.5913043478261, 1.425, 0.083333333333333
59516, 1.5695652173913, 1.425, 0.055555555555556
59517, 1.5913043478261, 1.4375, 0.055555555555556
59518, 1.5913043478261, 1.425, 0.027777777777778
59519, 1.6347826086957, 1.425, 0.47222222222222
59520, 1.6130434782609, 1.425, 0.44444444444444
59521, 1.6347826086957, 1.4375, 0.44444444444444
59522, 1.6347826086957, 1.425, 0.41666666666667
59523, 1.6130434782609, 1.425, 0.38888888888889
59524, 1.6347826086957, 1.4375, 0.38888888888889
59525, 1.6347826086957, 1.425, 0.36111111111111
59526, 1.6130434782609, 1.425, 0.33333333333333
59527, 1.6347826086957, 1.4375, 0.33333333333333
59528, 1.6347826086957, 1.425, 0.30555555555556
59529, 1.6130434782609, 1.425, 0.27777777777778
59530, 1.6347826086957, 1.4375, 0.27777777777778
59531, 1.6347826086957, 1.425, 0.25
59532, 1.6130434782609, 1.425, 0.22222222222222
59533, 1.6347826086957, 1.4375, 0.22222222222222
59534, 1.6347826086957, 1.425, 0.19444444444444
59535, 1.6130434782609, 1.425, 0.16666666666667
59536, 1.6347826086957, 1.4375, 0.16666666666667
59537, 1.6347826086957, 1.425, 0.13888888888889
59538, 1.6130434782609, 1.425, 0.11111111111111
59539, 1.6347826086957, 1.4375, 0.11111111111111
59540, 1.6347826086957, 1.425, 0.083333333333333
59541, 1.6130434782609, 1.425, 0.055555555555556
59542, 1.6347826086957, 1.4375, 0.055555555555556
59543, 1.6347826086957, 1.425, 0.027777777777778
59544, 1.6782608695652, 1.425, 0.47222222222222
59545, 1.6565217391304, 1.425, 0.44444444444444
59546, 1.6782608695652, 1.4375, 0.44444444444444
59547, 1.6782608695652, 1.425, 0.41666666666667
59548, 1.6565217391304, 1.425, 0.38888888888889
59549, 1.6782608695652, 1.4375, 0.38888888888889
59550, 1.6782608695652, 1.425, 0.36111111111111
59551, 1.6565217391304, 1.425, 0.33333333333333
59552, 1.6782608695652, 1.4375, 0.33333333333333
59553, 1.6782608695652, 1.425, 0.30555555555556
59554, 1.6565217391304, 1.425, 0.27777777777778
59555, 1.6782608695652, 1.4375, 0.27777777777778
59556, 1.6782608695652, 1.425, 0.25
59557, 1.6565217391304, 1.425, 0.22222222222222
59558, 1.6782608695652, 1.4375, 0.22222222222222
59559, 1.6782608695652, 1.425, 0.19444444444444
59560, 1.6565217391304, 1.425, 0.16666666666667
59561, 1.6782608695652, 1.4375, 0.16666666666667
59562, 1.6782608695652, 1.425, 0.13888888888889
59563, 1.6565217391304, 1.425, 0.11111111111111
59564, 1.6782608695652, 1.4375, 0.11111111111111
59565, 1.6782608695652, 1.425, 0.083333333333333
59566, 1.6565217391304, 1.425, 0.055555555555556
59567, 1.6782608695652, 1.4375, 0.055555555555556
59568, 1.6782608695652, 1.425, 0.027777777777778
59569, 1.7217391304348, 1.425, 0.47222222222222
59570, 1.7, 1.425, 0.44444444444444
59571, 1.7217391304348, 1.4375, 0.44444444444444
59572, 1.7217391304348, 1.425, 0.41666666666667
59573, 1.7, 1.425, 0.38888888888889
59574, 1.7217391304348, 1.4375, 0.38888888888889
59575, 1.7217391304348, 1.425, 0.36111111111111
59576, 1.7, 1.425, 0.33333333333333
59577, 1.7217391304348, 1.4375, 0.33333333333333
59578, 1.7217391304348, 1.425, 0.30555555555556
59579, 1.7, 1.425, 0.27777777777778
59580, 1.7217391304348, 1.4375, 0.27777777777778
59581, 1.7217391304348, 1.425, 0.25
59582, 1.7, 1.425, 0.22222222222222
59583, 1.7217391304348, 1.4375, 0.22222222222222
59584, 1.7217391304348, 1.425, 0.19444444444444
59585, 1.7, 1.425, 0.16666666666667
59586, 1.7217391304348, 1.4375, 0.16666666666667
59587, 1.7217391304348, 1.425, 0.13888888888889
59588, 1.7, 1.425, 0.11111111111111
59589, 1.7217391304348, 1.4375, 0.11111111111111
59590, 1.7217391304348, 1.425, 0.083333333333333
59591, 1.7, 1.425, 0.055555555555556
59592, 1.7217391304348, 1.4375, 0.055555555555556
59593, 1.7217391304348, 1.425, 0.027777777777778
59594, 1.7652173913043, 1.425, 0.47222222222222
59595, 1.7434782608696, 1.425, 0.44444444444444
59596, 1.7652173913043, 1.4375, 0.44444444444444
59597, 1.7652173913043, 1.425, 0.41666666666667
59598, 1.7434782608696, 1.425, 0.38888888888889
59599, 1.7652173913043, 1.4375, 0.38888888888889
59600, 1.7652173913043, 1.425, 0.36111111111111
59601, 1.7434782608696, 1.425, 0.33333333333333
59602, 1.7652173913043, 1.4375, 0.33333333333333
59603, 1.7652173913043, 1.425, 0.30555555555556
59604, 1.7434782608696, 1.425, 0.27777777777778
59605, 1.7652173913043, 1.4375, 0.27777777777778
59606, 1.7652173913043, 1.425, 0.25
59607, 1.7434782608696, 1.425, 0.22222222222222
59608, 1.7652173913043, 1.4375, 0.22222222222222
59609, 1.7652173913043, 1.425, 0.19444444444444
59610, 1.7434782608696, 1.425, 0.16666666666667
59611, 1.7652173913043, 1.4375, 0.16666666666667
59612, 1.7652173913043, 1.425, 0.13888888888889
59613, 1.7434782608696, 1.425, 0.11111111111111
59614, 1.7652173913043, 1.4375, 0.11111111111111
59615, 1.7652173913043, 1.425, 0.083333333333333
59616, 1.7434782608696, 1.425, 0.055555555555556
59617, 1.7652173913043, 1.4375, 0.055555555555556
59618, 1.7652173913043, 1.425, 0.027777777777778
59619, 1.8086956521739, 1.425, 0.47222222222222
59620, 1.7869565217391, 1.425, 0.44444444444444
59621, 1.8086956521739, 1.4375, 0.44444444444444
59622, 1.8086956521739, 1.425, 0.41666666666667
59623, 1.7869565217391, 1.425, 0.38888888888889
59624, 1.8086956521739, 1.4375, 0.38888888888889
59625, 1.8086956521739, 1.425, 0.36111111111111
59626, 1.7869565217391, 1.425, 0.33333333333333
59627, 1.8086956521739, 1.4375, 0.33333333333333
59628, 1.8086956521739, 1.425, 0.30555555555556
59629, 1.7869565217391, 1.425, 0.27777777777778
59630, 1.8086956521739, 1.4375, 0.27777777777778
59631, 1.8086956521739, 1.425, 0.25
59632, 1.7869565217391, 1.425, 0.22222222222222
59633, 1.8086956521739, 1.4375, 0.22222222222222
59634, 1.8086956521739, 1.425, 0.19444444444444
59635, 1.7869565217391, 1.425, 0.16666666666667
59636, 1.8086956521739, 1.4375, 0.16666666666667
59637, 1.8086956521739, 1.425, 0.13888888888889
59638, 1.7869565217391, 1.425, 0.11111111111111
59639, 1.8086956521739, 1.4375, 0.11111111111111
59640, 1.8086956521739, 1.425, 0.083333333333333
59641, 1.7869565217391, 1.425, 0.055555555555556
59642, 1.8086956521739, 1.4375, 0.055555555555556
59643, 1.8086956521739, 1.425, 0.027777777777778
59644, 1.8521739130435, 1.425, 0.47222222222222
59645, 1.8304347826087, 1.425, 0.44444444444444
59646, 1.8521739130435, 1.4375, 0.44444444444444
59647, 1.8521739130435, 1.425, 0.41666666666667
59648, 1.8304347826087, 1.425, 0.38888888888889
59649, 1.8521739130435, 1.4375, 0.38888888888889
59650, 1.8521739130435, 1.425, 0.36111111111111
59651, 1.8304347826087, 1.425, 0.33333333333333
59652, 1.8521739130435, 1.4375, 0.33333333333333
59653, 1.8521739130435, 1.425, 0.30555555555556
59654, 1.8304347826087, 1.425, 0.27777777777778
59655, 1.8521739130435, 1.4375, 0.27777777777778
59656, 1.8521739130435, 1.425, 0.25
59657, 1.8304347826087, 1.425, 0.22222222222222
59658, 1.8521739130435, 1.4375, 0.22222222222222
59659, 1.8521739130435, 1.425, 0.19444444444444
59660, 1.8304347826087, 1.425, 0.16666666666667
59661, 1.8521739130435, 1.4375, 0.16666666666667
59662, 1.8521739130435, 1.425, 0.13888888888889
59663, 1.8304347826087, 1.425, 0.11111111111111
59664, 1.8521739130435, 1.4375, 0.11111111111111
59665, 1.8521739130435, 1.425, 0.083333333333333
59666, 1.8304347826087, 1.425, 0.055555555555556
59667, 1.8521739130435, 1.4375, 0.055555555555556
59668, 1.8521739130435, 1.425, 0.027777777777778
59669, 1.895652173913, 1.425, 0.47222222222222
59670, 1.8739130434783, 1.425, 0.44444444444444
59671, 1.895652173913, 1.4375, 0.44444444444444
59672, 1.895652173913, 1.425, 0.41666666666667
59673, 1.8739130434783, 1.425, 0.38888888888889
59674, 1.895652173913, 1.4375, 0.38888888888889
59675, 1.895652173913, 1.425, 0.36111111111111
59676, 1.8739130434783, 1.425, 0.33333333333333
59677, 1.895652173913, 1.4375, 0.33333333333333
59678, 1.895652173913, 1.425, 0.30555555555556
59679, 1.8739130434783, 1.425, 0.27777777777778
59680, 1.895652173913, 1.4375, 0.27777777777778
59681, 1.895652173913, 1.425, 0.25
59682, 1.8739130434783, 1.425, 0.22222222222222
59683, 1.895652173913, 1.4375, 0.22222222222222
59684, 1.895652173913, 1.425, 0.19444444444444
59685, 1.8739130434783, 1.425, 0.16666666666667
59686, 1.895652173913, 1.4375, 0.16666666666667
59687, 1.895652173913, 1.425, 0.13888888888889
59688, 1.8739130434783, 1.425, 0.11111111111111
59689, 1.895652173913, 1.4375, 0.11111111111111
59690, 1.895652173913, 1.425, 0.083333333333333
59691, 1.8739130434783, 1.425, 0.055555555555556
59692, 1.895652173913, 1.4375, 0.055555555555556
59693, 1.895652173913, 1.425, 0.027777777777778
59694, 1.9391304347826, 1.425, 0.47222222222222
59695, 1.9173913043478, 1.425, 0.44444444444444
59696, 1.9391304347826, 1.4375, 0.44444444444444
59697, 1.9391304347826, 1.425, 0.41666666666667
59698, 1.9173913043478, 1.425, 0.38888888888889
59699, 1.9391304347826, 1.4375, 0.38888888888889
59700, 1.9391304347826, 1.425, 0.36111111111111
59701, 1.9173913043478, 1.425, 0.33333333333333
59702, 1.9391304347826, 1.4375, 0.33333333333333
59703, 1.9391304347826, 1.425, 0.30555555555556
59704, 1.9173913043478, 1.425, 0.27777777777778
59705, 1.9391304347826, 1.4375, 0.27777777777778
59706, 1.9391304347826, 1.425, 0.25
59707, 1.9173913043478, 1.425, 0.22222222222222
59708, 1.9391304347826, 1.4375, 0.22222222222222
59709, 1.9391304347826, 1.425, 0.19444444444444
59710, 1.9173913043478, 1.425, 0.16666666666667
59711, 1.9391304347826, 1.4375, 0.16666666666667
59712, 1.9391304347826, 1.425, 0.13888888888889
59713, 1.9173913043478, 1.425, 0.11111111111111
59714, 1.9391304347826, 1.4375, 0.11111111111111
59715, 1.9391304347826, 1.425, 0.083333333333333
59716, 1.9173913043478, 1.425, 0.055555555555556
59717, 1.9391304347826, 1.4375, 0.055555555555556
59718, 1.9391304347826, 1.425, 0.027777777777778
59719, 1.9826086956522, 1.425, 0.47222222222222
59720, 1.9608695652174, 1.425, 0.44444444444444
59721, 1.9826086956522, 1.4375, 0.44444444444444
59722, 1.9826086956522, 1.425, 0.41666666666667
59723, 1.9608695652174, 1.425, 0.38888888888889
59724, 1.9826086956522, 1.4375, 0.38888888888889
59725, 1.9826086956522, 1.425, 0.36111111111111
59726, 1.9608695652174, 1.425, 0.33333333333333
59727, 1.9826086956522, 1.4375, 0.33333333333333
59728, 1.9826086956522, 1.425, 0.30555555555556
59729, 1.9608695652174, 1.425, 0.27777777777778
59730, 1.9826086956522, 1.4375, 0.27777777777778
59731, 1.9826086956522, 1.425, 0.25
59732, 1.9608695652174, 1.425, 0.22222222222222
59733, 1.9826086956522, 1.4375, 0.22222222222222
59734, 1.9826086956522, 1.425, 0.19444444444444
59735, 1.9608695652174, 1.425, 0.16666666666667
59736, 1.9826086956522, 1.4375, 0.16666666666667
59737, 1.9826086956522, 1.425, 0.13888888888889
59738, 1.9608695652174, 1.425, 0.11111111111111
59739, 1.9826086956522, 1.4375, 0.11111111111111
59740, 1.9826086956522, 1.425, 0.083333333333333
59741, 1.9608695652174, 1.425, 0.055555555555556
59742, 1.9826086956522, 1.4375, 0.055555555555556
59743, 1.9826086956522, 1.425, 0.027777777777778
59744, 2.0260869565217, 1.425, 0.47222222222222
59745, 2.004347826087, 1.425, 0.44444444444444
59746, 2.0260869565217, 1.4375, 0.44444444444444
59747, 2.0260869565217, 1.425, 0.41666666666667
59748, 2.004347826087, 1.425, 0.38888888888889
59749, 2.0260869565217, 1.4375, 0.38888888888889
59750, 2.0260869565217, 1.425, 0.36111111111111
59751, 2.004347826087, 1.425, 0.33333333333333
59752, 2.0260869565217, 1.4375, 0.33333333333333
59753, 2.0260869565217, 1.425, 0.30555555555556
59754, 2.004347826087, 1.425, 0.27777777777778
59755, 2.0260869565217, 1.4375, 0.27777777777778
59756, 2.0260869565217, 1.425, 0.25
59757, 2.004347826087, 1.425, 0.22222222222222
59758, 2.0260869565217, 1.4375, 0.22222222222222
59759, 2.0260869565217, 1.425, 0.19444444444444
59760, 2.004347826087, 1.425, 0.16666666666667
59761, 2.0260869565217, 1.4375, 0.16666666666667
59762, 2.0260869565217, 1.425, 0.13888888888889
59763, 2.004347826087, 1.425, 0.11111111111111
59764, 2.0260869565217, 1.4375, 0.11111111111111
59765, 2.0260869565217, 1.425, 0.083333333333333
59766, 2.004347826087, 1.425, 0.055555555555556
59767, 2.0260869565217, 1.4375, 0.055555555555556
59768, 2.0260869565217, 1.425, 0.027777777777778
59769, 2.0695652173913, 1.425, 0.47222222222222
59770, 2.0478260869565, 1.425, 0.44444444444444
59771, 2.0695652173913, 1.4375, 0.44444444444444
59772, 2.0695652173913, 1.425, 0.41666666666667
59773, 2.0478260869565, 1.425, 0.38888888888889
59774, 2.0695652173913, 1.4375, 0.38888888888889
59775, 2.0695652173913, 1.425, 0.36111111111111
59776, 2.0478260869565, 1.425, 0.33333333333333
59777, 2.0695652173913, 1.4375, 0.33333333333333
59778, 2.0695652173913, 1.425, 0.30555555555556
59779, 2.0478260869565, 1.425, 0.27777777777778
59780, 2.0695652173913, 1.4375, 0.27777777777778
59781, 2.0695652173913, 1.425, 0.25
59782, 2.0478260869565, 1.425, 0.22222222222222
59783, 2.0695652173913, 1.4375, 0.22222222222222
59784, 2.0695652173913, 1.425, 0.19444444444444
59785, 2.0478260869565, 1.425, 0.16666666666667
59786, 2.0695652173913, 1.4375, 0.16666666666667
59787, 2.0695652173913, 1.425, 0.13888888888889
59788, 2.0478260869565, 1.425, 0.11111111111111
59789, 2.0695652173913, 1.4375, 0.11111111111111
59790, 2.0695652173913, 1.425, 0.083333333333333
59791, 2.0478260869565, 1.425, 0.055555555555556
59792, 2.0695652173913, 1.4375, 0.055555555555556
59793, 2.0695652173913, 1.425, 0.027777777777778
59794, 2.1130434782609, 1.425, 0.47222222222222
59795, 2.0913043478261, 1.425, 0.44444444444444
59796, 2.1130434782609, 1.4375, 0.44444444444444
59797, 2.1130434782609, 1.425, 0.41666666666667
59798, 2.0913043478261, 1.425, 0.38888888888889
59799, 2.1130434782609, 1.4375, 0.38888888888889
59800, 2.1130434782609, 1.425, 0.36111111111111
59801, 2.0913043478261, 1.425, 0.33333333333333
59802, 2.1130434782609, 1.4375, 0.33333333333333
59803, 2.1130434782609, 1.425, 0.30555555555556
59804, 2.0913043478261, 1.425, 0.27777777777778
59805, 2.1130434782609, 1.4375, 0.27777777777778
59806, 2.1130434782609, 1.425, 0.25
59807, 2.0913043478261, 1.425, 0.22222222222222
59808, 2.1130434782609, 1.4375, 0.22222222222222
59809, 2.1130434782609, 1.425, 0.19444444444444
59810, 2.0913043478261, 1.425, 0.16666666666667
59811, 2.1130434782609, 1.4375, 0.16666666666667
59812, 2.1130434782609, 1.425, 0.13888888888889
59813, 2.0913043478261, 1.425, 0.11111111111111
59814, 2.1130434782609, 1.4375, 0.11111111111111
59815, 2.1130434782609, 1.425, 0.083333333333333
59816, 2.0913043478261, 1.425, 0.055555555555556
59817, 2.1130434782609, 1.4375, 0.055555555555556
59818, 2.1130434782609, 1.425, 0.027777777777778
59819, 2.1565217391304, 1.425, 0.47222222222222
59820, 2.1347826086957, 1.425, 0.44444444444444
59821, 2.1565217391304, 1.4375, 0.44444444444444
59822, 2.1565217391304, 1.425, 0.41666666666667
59823, 2.1347826086957, 1.425, 0.38888888888889
59824, 2.1565217391304, 1.4375, 0.38888888888889
59825, 2.1565217391304, 1.425, 0.36111111111111
59826, 2.1347826086957, 1.425, 0.33333333333333
59827, 2.1565217391304, 1.4375, 0.33333333333333
59828, 2.1565217391304, 1.425, 0.30555555555556
59829, 2.1347826086957, 1.425, 0.27777777777778
59830, 2.1565217391304, 1.4375, 0.27777777777778
59831, 2.1565217391304, 1.425, 0.25
59832, 2.1347826086957, 1.425, 0.22222222222222
59833, 2.1565217391304, 1.4375, 0.22222222222222
59834, 2.1565217391304, 1.425, 0.19444444444444
59835, 2.1347826086957, 1.425, 0.16666666666667
59836, 2.1565217391304, 1.4375, 0.16666666666667
59837, 2.1565217391304, 1.425, 0.13888888888889
59838, 2.1347826086957, 1.425, 0.11111111111111
59839, 2.1565217391304, 1.4375, 0.11111111111111
59840, 2.1565217391304, 1.425, 0.083333333333333
59841, 2.1347826086957, 1.425, 0.055555555555556
59842, 2.1565217391304, 1.4375, 0.055555555555556
59843, 2.1565217391304, 1.425, 0.027777777777778
59844, 2.1782608695652, 1.425, 0.44444444444444
59845, 2.1782608695652, 1.425, 0.38888888888889
59846, 2.1782608695652, 1.425, 0.33333333333333
59847, 2.1782608695652, 1.425, 0.27777777777778
59848, 2.1782608695652, 1.425, 0.22222222222222
59849, 2.1782608695652, 1.425, 0.16666666666667
59850, 2.1782608695652, 1.425, 0.11111111111111
59851, 2.1782608695652, 1.425, 0.055555555555556
59852, 1.2434782608696, 1.4125, 0.44444444444444
59853, 1.2434782608696, 1.4125, 0.38888888888889
59854, 1.2434782608696, 1.4125, 0.33333333333333
59855, 1.2434782608696, 1.4125, 0.27777777777778
59856, 1.2434782608696, 1.4125, 0.22222222222222
59857, 1.2434782608696, 1.4125, 0.16666666666667
59858, 1.2434782608696, 1.4125, 0.11111111111111
59859, 1.2434782608696, 1.4125, 0.055555555555556
59860, 1.2869565217391, 1.4125, 0.44444444444444
59861, 1.2869565217391, 1.4125, 0.38888888888889
59862, 1.2869565217391, 1.4125, 0.33333333333333
59863, 1.2869565217391, 1.4125, 0.27777777777778
59864, 1.2869565217391, 1.4125, 0.22222222222222
59865, 1.2869565217391, 1.4125, 0.16666666666667
59866, 1.2869565217391, 1.4125, 0.11111111111111
59867, 1.2869565217391, 1.4125, 0.055555555555556
59868, 1.3304347826087, 1.4125, 0.44444444444444
59869, 1.3304347826087, 1.4125, 0.38888888888889
59870, 1.3304347826087, 1.4125, 0.33333333333333
59871, 1.3304347826087, 1.4125, 0.27777777777778
59872, 1.3304347826087, 1.4125, 0.22222222222222
59873, 1.3304347826087, 1.4125, 0.16666666666667
59874, 1.3304347826087, 1.4125, 0.11111111111111
59875, 1.3304347826087, 1.4125, 0.055555555555556
59876, 1.3739130434783, 1.4125, 0.44444444444444
59877, 1.3739130434783, 1.4125, 0.38888888888889
59878, 1.3739130434783, 1.4125, 0.33333333333333
59879, 1.3739130434783, 1.4125, 0.27777777777778
59880, 1.3739130434783, 1.4125, 0.22222222222222
59881, 1.3739130434783, 1.4125, 0.16666666666667
59882, 1.3739130434783, 1.4125, 0.11111111111111
59883, 1.3739130434783, 1.4125, 0.055555555555556
59884, 1.4173913043478, 1.4125, 0.44444444444444
59885, 1.4173913043478, 1.4125, 0.38888888888889
59886, 1.4173913043478, 1.4125, 0.33333333333333
59887, 1.4173913043478, 1.4125, 0.27777777777778
59888, 1.4173913043478, 1.4125, 0.22222222222222
59889, 1.4173913043478, 1.4125, 0.16666666666667
59890, 1.4173913043478, 1.4125, 0.11111111111111
59891, 1.4173913043478, 1.4125, 0.055555555555556
59892, 1.4608695652174, 1.4125, 0.44444444444444
59893, 1.4608695652174, 1.4125, 0.38888888888889
59894, 1.4608695652174, 1.4125, 0.33333333333333
59895, 1.4608695652174, 1.4125, 0.27777777777778
59896, 1.4608695652174, 1.4125, 0.22222222222222
59897, 1.4608695652174, 1.4125, 0.16666666666667
59898, 1.4608695652174, 1.4125, 0.11111111111111
59899, 1.4608695652174, 1.4125, 0.055555555555556
59900, 1.504347826087, 1.4125, 0.44444444444444
59901, 1.504347826087, 1.4125, 0.38888888888889
59902, 1.504347826087, 1.4125, 0.33333333333333
59903, 1.504347826087, 1.4125, 0.27777777777778
59904, 1.504347826087, 1.4125, 0.22222222222222
59905, 1.504347826087, 1.4125, 0.16666666666667
59906, 1.504347826087, 1.4125, 0.11111111111111
59907, 1.504347826087, 1.4125, 0.055555555555556
59908, 1.5478260869565, 1.4125, 0.44444444444444
59909, 1.5478260869565, 1.4125, 0.38888888888889
59910, 1.5478260869565, 1.4125, 0.33333333333333
59911, 1.5478260869565, 1.4125, 0.27777777777778
59912, 1.5478260869565, 1.4125, 0.22222222222222
59913, 1.5478260869565, 1.4125, 0.16666666666667
59914, 1.5478260869565, 1.4125, 0.11111111111111
59915, 1.5478260869565, 1.4125, 0.055555555555556
59916, 1.5913043478261, 1.4125, 0.44444444444444
59917, 1.5913043478261, 1.4125, 0.38888888888889
59918, 1.5913043478261, 1.4125, 0.33333333333333
59919, 1.5913043478261, 1.4125, 0.27777777777778
59920, 1.5913043478261, 1.4125, 0.22222222222222
59921, 1.5913043478261, 1.4125, 0.16666666666667
59922, 1.5913043478261, 1.4125, 0.11111111111111
59923, 1.5913043478261, 1.4125, 0.055555555555556
59924, 1.6347826086957, 1.4125, 0.44444444444444
59925, 1.6347826086957, 1.4125, 0.38888888888889
59926, 1.6347826086957, 1.4125, 0.33333333333333
59927, 1.6347826086957, 1.4125, 0.27777777777778
59928, 1.6347826086957, 1.4125, 0.22222222222222
59929, 1.6347826086957, 1.4125, 0.16666666666667
59930, 1.6347826086957, 1.4125, 0.11111111111111
59931, 1.6347826086957, 1.4125, 0.055555555555556
59932, 1.6782608695652, 1.4125, 0.44444444444444
59933, 1.6782608695652, 1.4125, 0.38888888888889
59934, 1.6782608695652, 1.4125, 0.33333333333333
59935, 1.6782608695652, 1.4125, 0.27777777777778
59936, 1.6782608695652, 1.4125, 0.22222222222222
59937, 1.6782608695652, 1.4125, 0.16666666666667
59938, 1.6782608695652, 1.4125, 0.11111111111111
59939, 1.6782608695652, 1.4125, 0.055555555555556
59940, 1.7217391304348, 1.4125, 0.44444444444444
59941, 1.7217391304348, 1.4125, 0.38888888888889
59942, 1.7217391304348, 1.4125, 0.33333333333333
59943, 1.7217391304348, 1.4125, 0.27777777777778
59944, 1.7217391304348, 1.4125, 0.22222222222222
59945, 1.7217391304348, 1.4125, 0.16666666666667
59946, 1.7217391304348, 1.4125, 0.11111111111111
59947, 1.7217391304348, 1.4125, 0.055555555555556
59948, 1.7652173913043, 1.4125, 0.44444444444444
59949, 1.7652173913043, 1.4125, 0.38888888888889
59950, 1.7652173913043, 1.4125, 0.33333333333333
59951, 1.7652173913043, 1.4125, 0.27777777777778
59952, 1.7652173913043, 1.4125, 0.22222222222222
59953, 1.7652173913043, 1.4125, 0.16666666666667
59954, 1.7652173913043, 1.4125, 0.11111111111111
59955, 1.7652173913043, 1.4125, 0.055555555555556
59956, 1.8086956521739, 1.4125, 0.44444444444444
59957, 1.8086956521739, 1.4125, 0.38888888888889
59958, 1.8086956521739, 1.4125, 0.33333333333333
59959, 1.8086956521739, 1.4125, 0.27777777777778
59960, 1.8086956521739, 1.4125, 0.22222222222222
59961, 1.8086956521739, 1.4125, 0.16666666666667
59962, 1.8086956521739, 1.4125, 0.11111111111111
59963, 1.8086956521739, 1.4125, 0.055555555555556
59964, 1.8521739130435, 1.4125, 0.44444444444444
59965, 1.8521739130435, 1.4125, 0.38888888888889
59966, 1.8521739130435, 1.4125, 0.33333333333333
59967, 1.8521739130435, 1.4125, 0.27777777777778
59968, 1.8521739130435, 1.4125, 0.22222222222222
59969, 1.8521739130435, 1.4125, 0.16666666666667
59970, 1.8521739130435, 1.4125, 0.11111111111111
59971, 1.8521739130435, 1.4125, 0.055555555555556
59972, 1.895652173913, 1.4125, 0.44444444444444
59973, 1.895652173913, 1.4125, 0.38888888888889
59974, 1.895652173913, 1.4125, 0.33333333333333
59975, 1.895652173913, 1.4125, 0.27777777777778
59976, 1.895652173913, 1.4125, 0.22222222222222
59977, 1.895652173913, 1.4125, 0.16666666666667
59978, 1.895652173913, 1.4125, 0.11111111111111
59979, 1.895652173913, 1.4125, 0.055555555555556
59980, 1.9391304347826, 1.4125, 0.44444444444444
59981, 1.9391304347826, 1.4125, 0.38888888888889
59982, 1.9391304347826, 1.4125, 0.33333333333333
59983, 1.9391304347826, 1.4125, 0.27777777777778
59984, 1.9391304347826, 1.4125, 0.22222222222222
59985, 1.9391304347826, 1.4125, 0.16666666666667
59986, 1.9391304347826, 1.4125, 0.11111111111111
59987, 1.9391304347826, 1.4125, 0.055555555555556
59988, 1.9826086956522, 1.4125, 0.44444444444444
59989, 1.9826086956522, 1.4125, 0.38888888888889
59990, 1.9826086956522, 1.4125, 0.33333333333333
59991, 1.9826086956522, 1.4125, 0.27777777777778
59992, 1.9826086956522, 1.4125, 0.22222222222222
59993, 1.9826086956522, 1.4125, 0.16666666666667
59994, 1.9826086956522, 1.4125, 0.11111111111111
59995, 1.9826086956522, 1.4125, 0.055555555555556
59996, 2.0260869565217, 1.4125, 0.44444444444444
59997, 2.0260869565217, 1.4125, 0.38888888888889
59998, 2.0260869565217, 1.4125, 0.33333333333333
59999, 2.0260869565217, 1.4125, 0.27777777777778
60000, 2.0260869565217, 1.4125, 0.22222222222222
60001, 2.0260869565217, 1.4125, 0.16666666666667
60002, 2.0260869565217, 1.4125, 0.11111111111111
60003, 2.0260869565217, 1.4125, 0.055555555555556
60004, 2.0695652173913, 1.4125, 0.44444444444444
60005, 2.0695652173913, 1.4125, 0.38888888888889
60006, 2.0695652173913, 1.4125, 0.33333333333333
60007, 2.0695652173913, 1.4125, 0.27777777777778
60008, 2.0695652173913, 1.4125, 0.22222222222222
60009, 2.0695652173913, 1.4125, 0.16666666666667
60010, 2.0695652173913, 1.4125, 0.11111111111111
60011, 2.0695652173913, 1.4125, 0.055555555555556
60012, 2.1130434782609, 1.4125, 0.44444444444444
60013, 2.1130434782609, 1.4125, 0.38888888888889
60014, 2.1130434782609, 1.4125, 0.33333333333333
60015, 2.1130434782609, 1.4125, 0.27777777777778
60016, 2.1130434782609, 1.4125, 0.22222222222222
60017, 2.1130434782609, 1.4125, 0.16666666666667
60018, 2.1130434782609, 1.4125, 0.11111111111111
60019, 2.1130434782609, 1.4125, 0.055555555555556
60020, 2.1565217391304, 1.4125, 0.44444444444444
60021, 2.1565217391304, 1.4125, 0.38888888888889
60022, 2.1565217391304, 1.4125, 0.33333333333333
60023, 2.1565217391304, 1.4125, 0.27777777777778
60024, 2.1565217391304, 1.4125, 0.22222222222222
60025, 2.1565217391304, 1.4125, 0.16666666666667
60026, 2.1565217391304, 1.4125, 0.11111111111111
60027, 2.1565217391304, 1.4125, 0.055555555555556
60028, 1.2434782608696, 1.2978260869565, 0.44444444444444
60029, 1.2434782608696, 1.2978260869565, 0.38888888888889
60030, 1.2434782608696, 1.2978260869565, 0.33333333333333
60031, 1.2434782608696, 1.2978260869565, 0.27777777777778
60032, 1.2434782608696, 1.2978260869565, 0.22222222222222
60033, 1.2434782608696, 1.2978260869565, 0.16666666666667
60034, 1.2434782608696, 1.2978260869565, 0.11111111111111
60035, 1.2434782608696, 1.2978260869565, 0.055555555555556
60036, 1.2869565217391, 1.2978260869565, 0.44444444444444
60037, 1.2869565217391, 1.2978260869565, 0.38888888888889
60038, 1.2869565217391, 1.2978260869565, 0.33333333333333
60039, 1.2869565217391, 1.2978260869565, 0.27777777777778
60040, 1.2869565217391, 1.2978260869565, 0.22222222222222
60041, 1.2869565217391, 1.2978260869565, 0.16666666666667
60042, 1.2869565217391, 1.2978260869565, 0.11111111111111
60043, 1.2869565217391, 1.2978260869565, 0.055555555555556
60044, 1.3304347826087, 1.2978260869565, 0.44444444444444
60045, 1.3304347826087, 1.2978260869565, 0.38888888888889
60046, 1.3304347826087, 1.2978260869565, 0.33333333333333
60047, 1.3304347826087, 1.2978260869565, 0.27777777777778
60048, 1.3304347826087, 1.2978260869565, 0.22222222222222
60049, 1.3304347826087, 1.2978260869565, 0.16666666666667
60050, 1.3304347826087, 1.2978260869565, 0.11111111111111
60051, 1.3304347826087, 1.2978260869565, 0.055555555555556
60052, 1.3739130434783, 1.2978260869565, 0.44444444444444
60053, 1.3739130434783, 1.2978260869565, 0.38888888888889
60054, 1.3739130434783, 1.2978260869565, 0.33333333333333
60055, 1.3739130434783, 1.2978260869565, 0.27777777777778
60056, 1.3739130434783, 1.2978260869565, 0.22222222222222
60057, 1.3739130434783, 1.2978260869565, 0.16666666666667
60058, 1.3739130434783, 1.2978260869565, 0.11111111111111
60059, 1.3739130434783, 1.2978260869565, 0.055555555555556
60060, 1.4173913043478, 1.2978260869565, 0.44444444444444
60061, 1.4173913043478, 1.2978260869565, 0.38888888888889
60062, 1.4173913043478, 1.2978260869565, 0.33333333333333
60063, 1.4173913043478, 1.2978260869565, 0.27777777777778
60064, 1.4173913043478, 1.2978260869565, 0.22222222222222
60065, 1.4173913043478, 1.2978260869565, 0.16666666666667
60066, 1.4173913043478, 1.2978260869565, 0.11111111111111
60067, 1.4173913043478, 1.2978260869565, 0.055555555555556
60068, 1.4608695652174, 1.2978260869565, 0.44444444444444
60069, 1.4608695652174, 1.2978260869565, 0.38888888888889
60070, 1.4608695652174, 1.2978260869565, 0.33333333333333
60071, 1.4608695652174, 1.2978260869565, 0.27777777777778
60072, 1.4608695652174, 1.2978260869565, 0.22222222222222
60073, 1.4608695652174, 1.2978260869565, 0.16666666666667
60074, 1.4608695652174, 1.2978260869565, 0.11111111111111
60075, 1.4608695652174, 1.2978260869565, 0.055555555555556
60076, 1.504347826087, 1.2978260869565, 0.44444444444444
60077, 1.504347826087, 1.2978260869565, 0.38888888888889
60078, 1.504347826087, 1.2978260869565, 0.33333333333333
60079, 1.504347826087, 1.2978260869565, 0.27777777777778
60080, 1.504347826087, 1.2978260869565, 0.22222222222222
60081, 1.504347826087, 1.2978260869565, 0.16666666666667
60082, 1.504347826087, 1.2978260869565, 0.11111111111111
60083, 1.504347826087, 1.2978260869565, 0.055555555555556
60084, 1.5478260869565, 1.2978260869565, 0.44444444444444
60085, 1.5478260869565, 1.2978260869565, 0.38888888888889
60086, 1.5478260869565, 1.2978260869565, 0.33333333333333
60087, 1.5478260869565, 1.2978260869565, 0.27777777777778
60088, 1.5478260869565, 1.2978260869565, 0.22222222222222
60089, 1.5478260869565, 1.2978260869565, 0.16666666666667
60090, 1.5478260869565, 1.2978260869565, 0.11111111111111
60091, 1.5478260869565, 1.2978260869565, 0.055555555555556
60092, 1.5913043478261, 1.2978260869565, 0.44444444444444
60093, 1.5913043478261, 1.2978260869565, 0.38888888888889
60094, 1.5913043478261, 1.2978260869565, 0.33333333333333
60095, 1.5913043478261, 1.2978260869565, 0.27777777777778
60096, 1.5913043478261, 1.2978260869565, 0.22222222222222
60097, 1.5913043478261, 1.2978260869565, 0.16666666666667
60098, 1.5913043478261, 1.2978260869565, 0.11111111111111
60099, 1.5913043478261, 1.2978260869565, 0.055555555555556
60100, 1.6347826086957, 1.2978260869565, 0.44444444444444
60101, 1.6347826086957, 1.2978260869565, 0.38888888888889
60102, 1.6347826086957, 1.2978260869565, 0.33333333333333
60103, 1.6347826086957, 1.2978260869565, 0.27777777777778
60104, 1.6347826086957, 1.2978260869565, 0.22222222222222
60105, 1.6347826086957, 1.2978260869565, 0.16666666666667
60106, 1.6347826086957, 1.2978260869565, 0.11111111111111
60107, 1.6347826086957, 1.2978260869565, 0.055555555555556
60108, 1.6782608695652, 1.2978260869565, 0.44444444444444
60109, 1.6782608695652, 1.2978260869565, 0.38888888888889
60110, 1.6782608695652, 1.2978260869565, 0.33333333333333
60111, 1.6782608695652, 1.2978260869565, 0.27777777777778
60112, 1.6782608695652, 1.2978260869565, 0.22222222222222
60113, 1.6782608695652, 1.2978260869565, 0.16666666666667
60114, 1.6782608695652, 1.2978260869565, 0.11111111111111
60115, 1.6782608695652, 1.2978260869565, 0.055555555555556
60116, 1.7217391304348, 1.2978260869565, 0.44444444444444
60117, 1.7217391304348, 1.2978260869565, 0.38888888888889
60118, 1.7217391304348, 1.2978260869565, 0.33333333333333
60119, 1.7217391304348, 1.2978260869565, 0.27777777777778
60120, 1.7217391304348, 1.2978260869565, 0.22222222222222
60121, 1.7217391304348, 1.2978260869565, 0.16666666666667
60122, 1.7217391304348, 1.2978260869565, 0.11111111111111
60123, 1.7217391304348, 1.2978260869565, 0.055555555555556
60124, 1.7652173913043, 1.2978260869565, 0.44444444444444
60125, 1.7652173913043, 1.2978260869565, 0.38888888888889
60126, 1.7652173913043, 1.2978260869565, 0.33333333333333
60127, 1.7652173913043, 1.2978260869565, 0.27777777777778
60128, 1.7652173913043, 1.2978260869565, 0.22222222222222
60129, 1.7652173913043, 1.2978260869565, 0.16666666666667
60130, 1.7652173913043, 1.2978260869565, 0.11111111111111
60131, 1.7652173913043, 1.2978260869565, 0.055555555555556
60132, 1.8086956521739, 1.2978260869565, 0.44444444444444
60133, 1.8086956521739, 1.2978260869565, 0.38888888888889
60134, 1.8086956521739, 1.2978260869565, 0.33333333333333
60135, 1.8086956521739, 1.2978260869565, 0.27777777777778
60136, 1.8086956521739, 1.2978260869565, 0.22222222222222
60137, 1.8086956521739, 1.2978260869565, 0.16666666666667
60138, 1.8086956521739, 1.2978260869565, 0.11111111111111
60139, 1.8086956521739, 1.2978260869565, 0.055555555555556
60140, 1.8521739130435, 1.2978260869565, 0.44444444444444
60141, 1.8521739130435, 1.2978260869565, 0.38888888888889
60142, 1.8521739130435, 1.2978260869565, 0.33333333333333
60143, 1.8521739130435, 1.2978260869565, 0.27777777777778
60144, 1.8521739130435, 1.2978260869565, 0.22222222222222
60145, 1.8521739130435, 1.2978260869565, 0.16666666666667
60146, 1.8521739130435, 1.2978260869565, 0.11111111111111
60147, 1.8521739130435, 1.2978260869565, 0.055555555555556
60148, 1.895652173913, 1.2978260869565, 0.44444444444444
60149, 1.895652173913, 1.2978260869565, 0.38888888888889
60150, 1.895652173913, 1.2978260869565, 0.33333333333333
60151, 1.895652173913, 1.2978260869565, 0.27777777777778
60152, 1.895652173913, 1.2978260869565, 0.22222222222222
60153, 1.895652173913, 1.2978260869565, 0.16666666666667
60154, 1.895652173913, 1.2978260869565, 0.11111111111111
60155, 1.895652173913, 1.2978260869565, 0.055555555555556
60156, 1.9391304347826, 1.2978260869565, 0.44444444444444
60157, 1.9391304347826, 1.2978260869565, 0.38888888888889
60158, 1.9391304347826, 1.2978260869565, 0.33333333333333
60159, 1.9391304347826, 1.2978260869565, 0.27777777777778
60160, 1.9391304347826, 1.2978260869565, 0.22222222222222
60161, 1.9391304347826, 1.2978260869565, 0.16666666666667
60162, 1.9391304347826, 1.2978260869565, 0.11111111111111
60163, 1.9391304347826, 1.2978260869565, 0.055555555555556
60164, 1.9826086956522, 1.2978260869565, 0.44444444444444
60165, 1.9826086956522, 1.2978260869565, 0.38888888888889
60166, 1.9826086956522, 1.2978260869565, 0.33333333333333
60167, 1.9826086956522, 1.2978260869565, 0.27777777777778
60168, 1.9826086956522, 1.2978260869565, 0.22222222222222
60169, 1.9826086956522, 1.2978260869565, 0.16666666666667
60170, 1.9826086956522, 1.2978260869565, 0.11111111111111
60171, 1.9826086956522, 1.2978260869565, 0.055555555555556
60172, 2.0260869565217, 1.2978260869565, 0.44444444444444
60173, 2.0260869565217, 1.2978260869565, 0.38888888888889
60174, 2.0260869565217, 1.2978260869565, 0.33333333333333
60175, 2.0260869565217, 1.2978260869565, 0.27777777777778
60176, 2.0260869565217, 1.2978260869565, 0.22222222222222
60177, 2.0260869565217, 1.2978260869565, 0.16666666666667
60178, 2.0260869565217, 1.2978260869565, 0.11111111111111
60179, 2.0260869565217, 1.2978260869565, 0.055555555555556
60180, 2.0695652173913, 1.2978260869565, 0.44444444444444
60181, 2.0695652173913, 1.2978260869565, 0.38888888888889
60182, 2.0695652173913, 1.2978260869565, 0.33333333333333
60183, 2.0695652173913, 1.2978260869565, 0.27777777777778
60184, 2.0695652173913, 1.2978260869565, 0.22222222222222
60185, 2.0695652173913, 1.2978260869565, 0.16666666666667
60186, 2.0695652173913, 1.2978260869565, 0.11111111111111
60187, 2.0695652173913, 1.2978260869565, 0.055555555555556
60188, 2.1130434782609, 1.2978260869565, 0.44444444444444
60189, 2.1130434782609, 1.2978260869565, 0.38888888888889
