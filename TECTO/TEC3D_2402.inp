61904, 1.8521739130435, 0.77608695652174, 0.22222222222222
61905, 1.8521739130435, 0.77608695652174, 0.16666666666667
61906, 1.8521739130435, 0.77608695652174, 0.11111111111111
61907, 1.8521739130435, 0.77608695652174, 0.055555555555556
61908, 1.895652173913, 0.77608695652174, 0.44444444444444
61909, 1.895652173913, 0.77608695652174, 0.38888888888889
61910, 1.895652173913, 0.77608695652174, 0.33333333333333
61911, 1.895652173913, 0.77608695652174, 0.27777777777778
61912, 1.895652173913, 0.77608695652174, 0.22222222222222
61913, 1.895652173913, 0.77608695652174, 0.16666666666667
61914, 1.895652173913, 0.77608695652174, 0.11111111111111
61915, 1.895652173913, 0.77608695652174, 0.055555555555556
61916, 1.9391304347826, 0.77608695652174, 0.44444444444444
61917, 1.9391304347826, 0.77608695652174, 0.38888888888889
61918, 1.9391304347826, 0.77608695652174, 0.33333333333333
61919, 1.9391304347826, 0.77608695652174, 0.27777777777778
61920, 1.9391304347826, 0.77608695652174, 0.22222222222222
61921, 1.9391304347826, 0.77608695652174, 0.16666666666667
61922, 1.9391304347826, 0.77608695652174, 0.11111111111111
61923, 1.9391304347826, 0.77608695652174, 0.055555555555556
61924, 1.9826086956522, 0.77608695652174, 0.44444444444444
61925, 1.9826086956522, 0.77608695652174, 0.38888888888889
61926, 1.9826086956522, 0.77608695652174, 0.33333333333333
61927, 1.9826086956522, 0.77608695652174, 0.27777777777778
61928, 1.9826086956522, 0.77608695652174, 0.22222222222222
61929, 1.9826086956522, 0.77608695652174, 0.16666666666667
61930, 1.9826086956522, 0.77608695652174, 0.11111111111111
61931, 1.9826086956522, 0.77608695652174, 0.055555555555556
61932, 2.0260869565217, 0.77608695652174, 0.44444444444444
61933, 2.0260869565217, 0.77608695652174, 0.38888888888889
61934, 2.0260869565217, 0.77608695652174, 0.33333333333333
61935, 2.0260869565217, 0.77608695652174, 0.27777777777778
61936, 2.0260869565217, 0.77608695652174, 0.22222222222222
61937, 2.0260869565217, 0.77608695652174, 0.16666666666667
61938, 2.0260869565217, 0.77608695652174, 0.11111111111111
61939, 2.0260869565217, 0.77608695652174, 0.055555555555556
61940, 2.0695652173913, 0.77608695652174, 0.44444444444444
61941, 2.0695652173913, 0.77608695652174, 0.38888888888889
61942, 2.0695652173913, 0.77608695652174, 0.33333333333333
61943, 2.0695652173913, 0.77608695652174, 0.27777777777778
61944, 2.0695652173913, 0.77608695652174, 0.22222222222222
61945, 2.0695652173913, 0.77608695652174, 0.16666666666667
61946, 2.0695652173913, 0.77608695652174, 0.11111111111111
61947, 2.0695652173913, 0.77608695652174, 0.055555555555556
61948, 2.1130434782609, 0.77608695652174, 0.44444444444444
61949, 2.1130434782609, 0.77608695652174, 0.38888888888889
61950, 2.1130434782609, 0.77608695652174, 0.33333333333333
61951, 2.1130434782609, 0.77608695652174, 0.27777777777778
61952, 2.1130434782609, 0.77608695652174, 0.22222222222222
61953, 2.1130434782609, 0.77608695652174, 0.16666666666667
61954, 2.1130434782609, 0.77608695652174, 0.11111111111111
61955, 2.1130434782609, 0.77608695652174, 0.055555555555556
61956, 2.1565217391304, 0.77608695652174, 0.44444444444444
61957, 2.1565217391304, 0.77608695652174, 0.38888888888889
61958, 2.1565217391304, 0.77608695652174, 0.33333333333333
61959, 2.1565217391304, 0.77608695652174, 0.27777777777778
61960, 2.1565217391304, 0.77608695652174, 0.22222222222222
61961, 2.1565217391304, 0.77608695652174, 0.16666666666667
61962, 2.1565217391304, 0.77608695652174, 0.11111111111111
61963, 2.1565217391304, 0.77608695652174, 0.055555555555556
61964, 1.2434782608696, 0.72391304347826, 0.44444444444444
61965, 1.2434782608696, 0.72391304347826, 0.38888888888889
61966, 1.2434782608696, 0.72391304347826, 0.33333333333333
61967, 1.2434782608696, 0.72391304347826, 0.27777777777778
61968, 1.2434782608696, 0.72391304347826, 0.22222222222222
61969, 1.2434782608696, 0.72391304347826, 0.16666666666667
61970, 1.2434782608696, 0.72391304347826, 0.11111111111111
61971, 1.2434782608696, 0.72391304347826, 0.055555555555556
61972, 1.2869565217391, 0.72391304347826, 0.44444444444444
61973, 1.2869565217391, 0.72391304347826, 0.38888888888889
61974, 1.2869565217391, 0.72391304347826, 0.33333333333333
61975, 1.2869565217391, 0.72391304347826, 0.27777777777778
61976, 1.2869565217391, 0.72391304347826, 0.22222222222222
61977, 1.2869565217391, 0.72391304347826, 0.16666666666667
61978, 1.2869565217391, 0.72391304347826, 0.11111111111111
61979, 1.2869565217391, 0.72391304347826, 0.055555555555556
61980, 1.3304347826087, 0.72391304347826, 0.44444444444444
61981, 1.3304347826087, 0.72391304347826, 0.38888888888889
61982, 1.3304347826087, 0.72391304347826, 0.33333333333333
61983, 1.3304347826087, 0.72391304347826, 0.27777777777778
61984, 1.3304347826087, 0.72391304347826, 0.22222222222222
61985, 1.3304347826087, 0.72391304347826, 0.16666666666667
61986, 1.3304347826087, 0.72391304347826, 0.11111111111111
61987, 1.3304347826087, 0.72391304347826, 0.055555555555556
61988, 1.3739130434783, 0.72391304347826, 0.44444444444444
61989, 1.3739130434783, 0.72391304347826, 0.38888888888889
61990, 1.3739130434783, 0.72391304347826, 0.33333333333333
61991, 1.3739130434783, 0.72391304347826, 0.27777777777778
61992, 1.3739130434783, 0.72391304347826, 0.22222222222222
61993, 1.3739130434783, 0.72391304347826, 0.16666666666667
61994, 1.3739130434783, 0.72391304347826, 0.11111111111111
61995, 1.3739130434783, 0.72391304347826, 0.055555555555556
61996, 1.4173913043478, 0.72391304347826, 0.44444444444444
61997, 1.4173913043478, 0.72391304347826, 0.38888888888889
61998, 1.4173913043478, 0.72391304347826, 0.33333333333333
61999, 1.4173913043478, 0.72391304347826, 0.27777777777778
62000, 1.4173913043478, 0.72391304347826, 0.22222222222222
62001, 1.4173913043478, 0.72391304347826, 0.16666666666667
62002, 1.4173913043478, 0.72391304347826, 0.11111111111111
62003, 1.4173913043478, 0.72391304347826, 0.055555555555556
62004, 1.4608695652174, 0.72391304347826, 0.44444444444444
62005, 1.4608695652174, 0.72391304347826, 0.38888888888889
62006, 1.4608695652174, 0.72391304347826, 0.33333333333333
62007, 1.4608695652174, 0.72391304347826, 0.27777777777778
62008, 1.4608695652174, 0.72391304347826, 0.22222222222222
62009, 1.4608695652174, 0.72391304347826, 0.16666666666667
62010, 1.4608695652174, 0.72391304347826, 0.11111111111111
62011, 1.4608695652174, 0.72391304347826, 0.055555555555556
62012, 1.504347826087, 0.72391304347826, 0.44444444444444
62013, 1.504347826087, 0.72391304347826, 0.38888888888889
62014, 1.504347826087, 0.72391304347826, 0.33333333333333
62015, 1.504347826087, 0.72391304347826, 0.27777777777778
62016, 1.504347826087, 0.72391304347826, 0.22222222222222
62017, 1.504347826087, 0.72391304347826, 0.16666666666667
62018, 1.504347826087, 0.72391304347826, 0.11111111111111
62019, 1.504347826087, 0.72391304347826, 0.055555555555556
62020, 1.5478260869565, 0.72391304347826, 0.44444444444444
62021, 1.5478260869565, 0.72391304347826, 0.38888888888889
62022, 1.5478260869565, 0.72391304347826, 0.33333333333333
62023, 1.5478260869565, 0.72391304347826, 0.27777777777778
62024, 1.5478260869565, 0.72391304347826, 0.22222222222222
62025, 1.5478260869565, 0.72391304347826, 0.16666666666667
62026, 1.5478260869565, 0.72391304347826, 0.11111111111111
62027, 1.5478260869565, 0.72391304347826, 0.055555555555556
62028, 1.5913043478261, 0.72391304347826, 0.44444444444444
62029, 1.5913043478261, 0.72391304347826, 0.38888888888889
62030, 1.5913043478261, 0.72391304347826, 0.33333333333333
62031, 1.5913043478261, 0.72391304347826, 0.27777777777778
62032, 1.5913043478261, 0.72391304347826, 0.22222222222222
62033, 1.5913043478261, 0.72391304347826, 0.16666666666667
62034, 1.5913043478261, 0.72391304347826, 0.11111111111111
62035, 1.5913043478261, 0.72391304347826, 0.055555555555556
62036, 1.6347826086957, 0.72391304347826, 0.44444444444444
62037, 1.6347826086957, 0.72391304347826, 0.38888888888889
62038, 1.6347826086957, 0.72391304347826, 0.33333333333333
62039, 1.6347826086957, 0.72391304347826, 0.27777777777778
62040, 1.6347826086957, 0.72391304347826, 0.22222222222222
62041, 1.6347826086957, 0.72391304347826, 0.16666666666667
62042, 1.6347826086957, 0.72391304347826, 0.11111111111111
62043, 1.6347826086957, 0.72391304347826, 0.055555555555556
62044, 1.6782608695652, 0.72391304347826, 0.44444444444444
62045, 1.6782608695652, 0.72391304347826, 0.38888888888889
62046, 1.6782608695652, 0.72391304347826, 0.33333333333333
62047, 1.6782608695652, 0.72391304347826, 0.27777777777778
62048, 1.6782608695652, 0.72391304347826, 0.22222222222222
62049, 1.6782608695652, 0.72391304347826, 0.16666666666667
62050, 1.6782608695652, 0.72391304347826, 0.11111111111111
62051, 1.6782608695652, 0.72391304347826, 0.055555555555556
62052, 1.7217391304348, 0.72391304347826, 0.44444444444444
62053, 1.7217391304348, 0.72391304347826, 0.38888888888889
62054, 1.7217391304348, 0.72391304347826, 0.33333333333333
62055, 1.7217391304348, 0.72391304347826, 0.27777777777778
62056, 1.7217391304348, 0.72391304347826, 0.22222222222222
62057, 1.7217391304348, 0.72391304347826, 0.16666666666667
62058, 1.7217391304348, 0.72391304347826, 0.11111111111111
62059, 1.7217391304348, 0.72391304347826, 0.055555555555556
62060, 1.7652173913043, 0.72391304347826, 0.44444444444444
62061, 1.7652173913043, 0.72391304347826, 0.38888888888889
62062, 1.7652173913043, 0.72391304347826, 0.33333333333333
62063, 1.7652173913043, 0.72391304347826, 0.27777777777778
62064, 1.7652173913043, 0.72391304347826, 0.22222222222222
62065, 1.7652173913043, 0.72391304347826, 0.16666666666667
62066, 1.7652173913043, 0.72391304347826, 0.11111111111111
62067, 1.7652173913043, 0.72391304347826, 0.055555555555556
62068, 1.8086956521739, 0.72391304347826, 0.44444444444444
62069, 1.8086956521739, 0.72391304347826, 0.38888888888889
62070, 1.8086956521739, 0.72391304347826, 0.33333333333333
62071, 1.8086956521739, 0.72391304347826, 0.27777777777778
62072, 1.8086956521739, 0.72391304347826, 0.22222222222222
62073, 1.8086956521739, 0.72391304347826, 0.16666666666667
62074, 1.8086956521739, 0.72391304347826, 0.11111111111111
62075, 1.8086956521739, 0.72391304347826, 0.055555555555556
62076, 1.8521739130435, 0.72391304347826, 0.44444444444444
62077, 1.8521739130435, 0.72391304347826, 0.38888888888889
62078, 1.8521739130435, 0.72391304347826, 0.33333333333333
62079, 1.8521739130435, 0.72391304347826, 0.27777777777778
62080, 1.8521739130435, 0.72391304347826, 0.22222222222222
62081, 1.8521739130435, 0.72391304347826, 0.16666666666667
62082, 1.8521739130435, 0.72391304347826, 0.11111111111111
62083, 1.8521739130435, 0.72391304347826, 0.055555555555556
62084, 1.895652173913, 0.72391304347826, 0.44444444444444
62085, 1.895652173913, 0.72391304347826, 0.38888888888889
62086, 1.895652173913, 0.72391304347826, 0.33333333333333
62087, 1.895652173913, 0.72391304347826, 0.27777777777778
62088, 1.895652173913, 0.72391304347826, 0.22222222222222
62089, 1.895652173913, 0.72391304347826, 0.16666666666667
62090, 1.895652173913, 0.72391304347826, 0.11111111111111
62091, 1.895652173913, 0.72391304347826, 0.055555555555556
62092, 1.9391304347826, 0.72391304347826, 0.44444444444444
62093, 1.9391304347826, 0.72391304347826, 0.38888888888889
62094, 1.9391304347826, 0.72391304347826, 0.33333333333333
62095, 1.9391304347826, 0.72391304347826, 0.27777777777778
62096, 1.9391304347826, 0.72391304347826, 0.22222222222222
62097, 1.9391304347826, 0.72391304347826, 0.16666666666667
62098, 1.9391304347826, 0.72391304347826, 0.11111111111111
62099, 1.9391304347826, 0.72391304347826, 0.055555555555556
62100, 1.9826086956522, 0.72391304347826, 0.44444444444444
62101, 1.9826086956522, 0.72391304347826, 0.38888888888889
62102, 1.9826086956522, 0.72391304347826, 0.33333333333333
62103, 1.9826086956522, 0.72391304347826, 0.27777777777778
62104, 1.9826086956522, 0.72391304347826, 0.22222222222222
62105, 1.9826086956522, 0.72391304347826, 0.16666666666667
62106, 1.9826086956522, 0.72391304347826, 0.11111111111111
62107, 1.9826086956522, 0.72391304347826, 0.055555555555556
62108, 2.0260869565217, 0.72391304347826, 0.44444444444444
62109, 2.0260869565217, 0.72391304347826, 0.38888888888889
62110, 2.0260869565217, 0.72391304347826, 0.33333333333333
62111, 2.0260869565217, 0.72391304347826, 0.27777777777778
62112, 2.0260869565217, 0.72391304347826, 0.22222222222222
62113, 2.0260869565217, 0.72391304347826, 0.16666666666667
62114, 2.0260869565217, 0.72391304347826, 0.11111111111111
62115, 2.0260869565217, 0.72391304347826, 0.055555555555556
62116, 2.0695652173913, 0.72391304347826, 0.44444444444444
62117, 2.0695652173913, 0.72391304347826, 0.38888888888889
62118, 2.0695652173913, 0.72391304347826, 0.33333333333333
62119, 2.0695652173913, 0.72391304347826, 0.27777777777778
62120, 2.0695652173913, 0.72391304347826, 0.22222222222222
62121, 2.0695652173913, 0.72391304347826, 0.16666666666667
62122, 2.0695652173913, 0.72391304347826, 0.11111111111111
62123, 2.0695652173913, 0.72391304347826, 0.055555555555556
62124, 2.1130434782609, 0.72391304347826, 0.44444444444444
62125, 2.1130434782609, 0.72391304347826, 0.38888888888889
62126, 2.1130434782609, 0.72391304347826, 0.33333333333333
62127, 2.1130434782609, 0.72391304347826, 0.27777777777778
62128, 2.1130434782609, 0.72391304347826, 0.22222222222222
62129, 2.1130434782609, 0.72391304347826, 0.16666666666667
62130, 2.1130434782609, 0.72391304347826, 0.11111111111111
62131, 2.1130434782609, 0.72391304347826, 0.055555555555556
62132, 2.1565217391304, 0.72391304347826, 0.44444444444444
62133, 2.1565217391304, 0.72391304347826, 0.38888888888889
62134, 2.1565217391304, 0.72391304347826, 0.33333333333333
62135, 2.1565217391304, 0.72391304347826, 0.27777777777778
62136, 2.1565217391304, 0.72391304347826, 0.22222222222222
62137, 2.1565217391304, 0.72391304347826, 0.16666666666667
62138, 2.1565217391304, 0.72391304347826, 0.11111111111111
62139, 2.1565217391304, 0.72391304347826, 0.055555555555556
62140, 1.2434782608696, 0.67173913043478, 0.44444444444444
62141, 1.2434782608696, 0.67173913043478, 0.38888888888889
62142, 1.2434782608696, 0.67173913043478, 0.33333333333333
62143, 1.2434782608696, 0.67173913043478, 0.27777777777778
62144, 1.2434782608696, 0.67173913043478, 0.22222222222222
62145, 1.2434782608696, 0.67173913043478, 0.16666666666667
62146, 1.2434782608696, 0.67173913043478, 0.11111111111111
62147, 1.2434782608696, 0.67173913043478, 0.055555555555556
62148, 1.2869565217391, 0.67173913043478, 0.44444444444444
62149, 1.2869565217391, 0.67173913043478, 0.38888888888889
62150, 1.2869565217391, 0.67173913043478, 0.33333333333333
62151, 1.2869565217391, 0.67173913043478, 0.27777777777778
62152, 1.2869565217391, 0.67173913043478, 0.22222222222222
62153, 1.2869565217391, 0.67173913043478, 0.16666666666667
62154, 1.2869565217391, 0.67173913043478, 0.11111111111111
62155, 1.2869565217391, 0.67173913043478, 0.055555555555556
62156, 1.3304347826087, 0.67173913043478, 0.44444444444444
62157, 1.3304347826087, 0.67173913043478, 0.38888888888889
62158, 1.3304347826087, 0.67173913043478, 0.33333333333333
62159, 1.3304347826087, 0.67173913043478, 0.27777777777778
62160, 1.3304347826087, 0.67173913043478, 0.22222222222222
62161, 1.3304347826087, 0.67173913043478, 0.16666666666667
62162, 1.3304347826087, 0.67173913043478, 0.11111111111111
62163, 1.3304347826087, 0.67173913043478, 0.055555555555556
62164, 1.3739130434783, 0.67173913043478, 0.44444444444444
62165, 1.3739130434783, 0.67173913043478, 0.38888888888889
62166, 1.3739130434783, 0.67173913043478, 0.33333333333333
62167, 1.3739130434783, 0.67173913043478, 0.27777777777778
62168, 1.3739130434783, 0.67173913043478, 0.22222222222222
62169, 1.3739130434783, 0.67173913043478, 0.16666666666667
62170, 1.3739130434783, 0.67173913043478, 0.11111111111111
62171, 1.3739130434783, 0.67173913043478, 0.055555555555556
62172, 1.4173913043478, 0.67173913043478, 0.44444444444444
62173, 1.4173913043478, 0.67173913043478, 0.38888888888889
62174, 1.4173913043478, 0.67173913043478, 0.33333333333333
62175, 1.4173913043478, 0.67173913043478, 0.27777777777778
62176, 1.4173913043478, 0.67173913043478, 0.22222222222222
62177, 1.4173913043478, 0.67173913043478, 0.16666666666667
62178, 1.4173913043478, 0.67173913043478, 0.11111111111111
62179, 1.4173913043478, 0.67173913043478, 0.055555555555556
62180, 1.4608695652174, 0.67173913043478, 0.44444444444444
62181, 1.4608695652174, 0.67173913043478, 0.38888888888889
62182, 1.4608695652174, 0.67173913043478, 0.33333333333333
62183, 1.4608695652174, 0.67173913043478, 0.27777777777778
62184, 1.4608695652174, 0.67173913043478, 0.22222222222222
62185, 1.4608695652174, 0.67173913043478, 0.16666666666667
62186, 1.4608695652174, 0.67173913043478, 0.11111111111111
62187, 1.4608695652174, 0.67173913043478, 0.055555555555556
62188, 1.504347826087, 0.67173913043478, 0.44444444444444
62189, 1.504347826087, 0.67173913043478, 0.38888888888889
62190, 1.504347826087, 0.67173913043478, 0.33333333333333
62191, 1.504347826087, 0.67173913043478, 0.27777777777778
62192, 1.504347826087, 0.67173913043478, 0.22222222222222
62193, 1.504347826087, 0.67173913043478, 0.16666666666667
62194, 1.504347826087, 0.67173913043478, 0.11111111111111
62195, 1.504347826087, 0.67173913043478, 0.055555555555556
62196, 1.5478260869565, 0.67173913043478, 0.44444444444444
62197, 1.5478260869565, 0.67173913043478, 0.38888888888889
62198, 1.5478260869565, 0.67173913043478, 0.33333333333333
62199, 1.5478260869565, 0.67173913043478, 0.27777777777778
62200, 1.5478260869565, 0.67173913043478, 0.22222222222222
62201, 1.5478260869565, 0.67173913043478, 0.16666666666667
62202, 1.5478260869565, 0.67173913043478, 0.11111111111111
62203, 1.5478260869565, 0.67173913043478, 0.055555555555556
62204, 1.5913043478261, 0.67173913043478, 0.44444444444444
62205, 1.5913043478261, 0.67173913043478, 0.38888888888889
62206, 1.5913043478261, 0.67173913043478, 0.33333333333333
62207, 1.5913043478261, 0.67173913043478, 0.27777777777778
62208, 1.5913043478261, 0.67173913043478, 0.22222222222222
62209, 1.5913043478261, 0.67173913043478, 0.16666666666667
62210, 1.5913043478261, 0.67173913043478, 0.11111111111111
62211, 1.5913043478261, 0.67173913043478, 0.055555555555556
62212, 1.6347826086957, 0.67173913043478, 0.44444444444444
62213, 1.6347826086957, 0.67173913043478, 0.38888888888889
62214, 1.6347826086957, 0.67173913043478, 0.33333333333333
62215, 1.6347826086957, 0.67173913043478, 0.27777777777778
62216, 1.6347826086957, 0.67173913043478, 0.22222222222222
62217, 1.6347826086957, 0.67173913043478, 0.16666666666667
62218, 1.6347826086957, 0.67173913043478, 0.11111111111111
62219, 1.6347826086957, 0.67173913043478, 0.055555555555556
62220, 1.6782608695652, 0.67173913043478, 0.44444444444444
62221, 1.6782608695652, 0.67173913043478, 0.38888888888889
62222, 1.6782608695652, 0.67173913043478, 0.33333333333333
62223, 1.6782608695652, 0.67173913043478, 0.27777777777778
62224, 1.6782608695652, 0.67173913043478, 0.22222222222222
62225, 1.6782608695652, 0.67173913043478, 0.16666666666667
62226, 1.6782608695652, 0.67173913043478, 0.11111111111111
62227, 1.6782608695652, 0.67173913043478, 0.055555555555556
62228, 1.7217391304348, 0.67173913043478, 0.44444444444444
62229, 1.7217391304348, 0.67173913043478, 0.38888888888889
62230, 1.7217391304348, 0.67173913043478, 0.33333333333333
62231, 1.7217391304348, 0.67173913043478, 0.27777777777778
62232, 1.7217391304348, 0.67173913043478, 0.22222222222222
62233, 1.7217391304348, 0.67173913043478, 0.16666666666667
62234, 1.7217391304348, 0.67173913043478, 0.11111111111111
62235, 1.7217391304348, 0.67173913043478, 0.055555555555556
62236, 1.7652173913043, 0.67173913043478, 0.44444444444444
62237, 1.7652173913043, 0.67173913043478, 0.38888888888889
62238, 1.7652173913043, 0.67173913043478, 0.33333333333333
62239, 1.7652173913043, 0.67173913043478, 0.27777777777778
62240, 1.7652173913043, 0.67173913043478, 0.22222222222222
62241, 1.7652173913043, 0.67173913043478, 0.16666666666667
62242, 1.7652173913043, 0.67173913043478, 0.11111111111111
62243, 1.7652173913043, 0.67173913043478, 0.055555555555556
62244, 1.8086956521739, 0.67173913043478, 0.44444444444444
62245, 1.8086956521739, 0.67173913043478, 0.38888888888889
62246, 1.8086956521739, 0.67173913043478, 0.33333333333333
62247, 1.8086956521739, 0.67173913043478, 0.27777777777778
62248, 1.8086956521739, 0.67173913043478, 0.22222222222222
62249, 1.8086956521739, 0.67173913043478, 0.16666666666667
62250, 1.8086956521739, 0.67173913043478, 0.11111111111111
62251, 1.8086956521739, 0.67173913043478, 0.055555555555556
62252, 1.8521739130435, 0.67173913043478, 0.44444444444444
62253, 1.8521739130435, 0.67173913043478, 0.38888888888889
62254, 1.8521739130435, 0.67173913043478, 0.33333333333333
62255, 1.8521739130435, 0.67173913043478, 0.27777777777778
62256, 1.8521739130435, 0.67173913043478, 0.22222222222222
62257, 1.8521739130435, 0.67173913043478, 0.16666666666667
62258, 1.8521739130435, 0.67173913043478, 0.11111111111111
62259, 1.8521739130435, 0.67173913043478, 0.055555555555556
62260, 1.895652173913, 0.67173913043478, 0.44444444444444
62261, 1.895652173913, 0.67173913043478, 0.38888888888889
62262, 1.895652173913, 0.67173913043478, 0.33333333333333
62263, 1.895652173913, 0.67173913043478, 0.27777777777778
62264, 1.895652173913, 0.67173913043478, 0.22222222222222
62265, 1.895652173913, 0.67173913043478, 0.16666666666667
62266, 1.895652173913, 0.67173913043478, 0.11111111111111
62267, 1.895652173913, 0.67173913043478, 0.055555555555556
62268, 1.9391304347826, 0.67173913043478, 0.44444444444444
62269, 1.9391304347826, 0.67173913043478, 0.38888888888889
62270, 1.9391304347826, 0.67173913043478, 0.33333333333333
62271, 1.9391304347826, 0.67173913043478, 0.27777777777778
62272, 1.9391304347826, 0.67173913043478, 0.22222222222222
62273, 1.9391304347826, 0.67173913043478, 0.16666666666667
62274, 1.9391304347826, 0.67173913043478, 0.11111111111111
62275, 1.9391304347826, 0.67173913043478, 0.055555555555556
62276, 1.9826086956522, 0.67173913043478, 0.44444444444444
62277, 1.9826086956522, 0.67173913043478, 0.38888888888889
62278, 1.9826086956522, 0.67173913043478, 0.33333333333333
62279, 1.9826086956522, 0.67173913043478, 0.27777777777778
62280, 1.9826086956522, 0.67173913043478, 0.22222222222222
62281, 1.9826086956522, 0.67173913043478, 0.16666666666667
62282, 1.9826086956522, 0.67173913043478, 0.11111111111111
62283, 1.9826086956522, 0.67173913043478, 0.055555555555556
62284, 2.0260869565217, 0.67173913043478, 0.44444444444444
62285, 2.0260869565217, 0.67173913043478, 0.38888888888889
62286, 2.0260869565217, 0.67173913043478, 0.33333333333333
62287, 2.0260869565217, 0.67173913043478, 0.27777777777778
62288, 2.0260869565217, 0.67173913043478, 0.22222222222222
62289, 2.0260869565217, 0.67173913043478, 0.16666666666667
62290, 2.0260869565217, 0.67173913043478, 0.11111111111111
62291, 2.0260869565217, 0.67173913043478, 0.055555555555556
62292, 2.0695652173913, 0.67173913043478, 0.44444444444444
62293, 2.0695652173913, 0.67173913043478, 0.38888888888889
62294, 2.0695652173913, 0.67173913043478, 0.33333333333333
62295, 2.0695652173913, 0.67173913043478, 0.27777777777778
62296, 2.0695652173913, 0.67173913043478, 0.22222222222222
62297, 2.0695652173913, 0.67173913043478, 0.16666666666667
62298, 2.0695652173913, 0.67173913043478, 0.11111111111111
62299, 2.0695652173913, 0.67173913043478, 0.055555555555556
62300, 2.1130434782609, 0.67173913043478, 0.44444444444444
62301, 2.1130434782609, 0.67173913043478, 0.38888888888889
62302, 2.1130434782609, 0.67173913043478, 0.33333333333333
62303, 2.1130434782609, 0.67173913043478, 0.27777777777778
62304, 2.1130434782609, 0.67173913043478, 0.22222222222222
62305, 2.1130434782609, 0.67173913043478, 0.16666666666667
62306, 2.1130434782609, 0.67173913043478, 0.11111111111111
62307, 2.1130434782609, 0.67173913043478, 0.055555555555556
62308, 2.1565217391304, 0.67173913043478, 0.44444444444444
62309, 2.1565217391304, 0.67173913043478, 0.38888888888889
62310, 2.1565217391304, 0.67173913043478, 0.33333333333333
62311, 2.1565217391304, 0.67173913043478, 0.27777777777778
62312, 2.1565217391304, 0.67173913043478, 0.22222222222222
62313, 2.1565217391304, 0.67173913043478, 0.16666666666667
62314, 2.1565217391304, 0.67173913043478, 0.11111111111111
62315, 2.1565217391304, 0.67173913043478, 0.055555555555556
62316, 1.2434782608696, 0.61956521739131, 0.44444444444444
62317, 1.2434782608696, 0.61956521739131, 0.38888888888889
62318, 1.2434782608696, 0.61956521739131, 0.33333333333333
62319, 1.2434782608696, 0.6195652173913, 0.27777777777778
62320, 1.2434782608696, 0.61956521739131, 0.22222222222222
62321, 1.2434782608696, 0.61956521739131, 0.16666666666667
62322, 1.2434782608696, 0.61956521739131, 0.11111111111111
62323, 1.2434782608696, 0.61956521739131, 0.055555555555556
62324, 1.2869565217391, 0.61956521739131, 0.44444444444444
62325, 1.2869565217391, 0.61956521739131, 0.38888888888889
62326, 1.2869565217391, 0.61956521739131, 0.33333333333333
62327, 1.2869565217391, 0.61956521739131, 0.27777777777778
62328, 1.2869565217391, 0.61956521739131, 0.22222222222222
62329, 1.2869565217391, 0.6195652173913, 0.16666666666667
62330, 1.2869565217391, 0.61956521739131, 0.11111111111111
62331, 1.2869565217391, 0.61956521739131, 0.055555555555556
62332, 1.3304347826087, 0.61956521739131, 0.44444444444444
62333, 1.3304347826087, 0.61956521739131, 0.38888888888889
62334, 1.3304347826087, 0.61956521739131, 0.33333333333333
62335, 1.3304347826087, 0.61956521739131, 0.27777777777778
62336, 1.3304347826087, 0.61956521739131, 0.22222222222222
62337, 1.3304347826087, 0.61956521739131, 0.16666666666667
62338, 1.3304347826087, 0.61956521739131, 0.11111111111111
62339, 1.3304347826087, 0.61956521739131, 0.055555555555556
62340, 1.3739130434783, 0.61956521739131, 0.44444444444444
62341, 1.3739130434783, 0.61956521739131, 0.38888888888889
62342, 1.3739130434783, 0.61956521739131, 0.33333333333333
62343, 1.3739130434783, 0.61956521739131, 0.27777777777778
62344, 1.3739130434783, 0.61956521739131, 0.22222222222222
62345, 1.3739130434783, 0.61956521739131, 0.16666666666667
62346, 1.3739130434783, 0.61956521739131, 0.11111111111111
62347, 1.3739130434783, 0.61956521739131, 0.055555555555556
62348, 1.4173913043478, 0.61956521739131, 0.44444444444444
62349, 1.4173913043478, 0.61956521739131, 0.38888888888889
62350, 1.4173913043478, 0.61956521739131, 0.33333333333333
62351, 1.4173913043478, 0.61956521739131, 0.27777777777778
62352, 1.4173913043478, 0.61956521739131, 0.22222222222222
62353, 1.4173913043478, 0.61956521739131, 0.16666666666667
62354, 1.4173913043478, 0.61956521739131, 0.11111111111111
62355, 1.4173913043478, 0.61956521739131, 0.055555555555556
62356, 1.4608695652174, 0.61956521739131, 0.44444444444444
62357, 1.4608695652174, 0.61956521739131, 0.38888888888889
62358, 1.4608695652174, 0.61956521739131, 0.33333333333333
62359, 1.4608695652174, 0.6195652173913, 0.27777777777778
62360, 1.4608695652174, 0.61956521739131, 0.22222222222222
62361, 1.4608695652174, 0.6195652173913, 0.16666666666667
62362, 1.4608695652174, 0.61956521739131, 0.11111111111111
62363, 1.4608695652174, 0.61956521739131, 0.055555555555556
62364, 1.504347826087, 0.61956521739131, 0.44444444444444
62365, 1.504347826087, 0.6195652173913, 0.38888888888889
62366, 1.504347826087, 0.6195652173913, 0.33333333333333
62367, 1.504347826087, 0.6195652173913, 0.27777777777778
62368, 1.504347826087, 0.6195652173913, 0.22222222222222
62369, 1.504347826087, 0.6195652173913, 0.16666666666667
62370, 1.504347826087, 0.6195652173913, 0.11111111111111
62371, 1.504347826087, 0.6195652173913, 0.055555555555556
62372, 1.5478260869565, 0.61956521739131, 0.44444444444444
62373, 1.5478260869565, 0.61956521739131, 0.38888888888889
62374, 1.5478260869565, 0.61956521739131, 0.33333333333333
62375, 1.5478260869565, 0.61956521739131, 0.27777777777778
62376, 1.5478260869565, 0.61956521739131, 0.22222222222222
62377, 1.5478260869565, 0.6195652173913, 0.16666666666667
62378, 1.5478260869565, 0.61956521739131, 0.11111111111111
62379, 1.5478260869565, 0.61956521739131, 0.055555555555556
62380, 1.5913043478261, 0.61956521739131, 0.44444444444444
62381, 1.5913043478261, 0.61956521739131, 0.38888888888889
62382, 1.5913043478261, 0.6195652173913, 0.33333333333333
62383, 1.5913043478261, 0.6195652173913, 0.27777777777778
62384, 1.5913043478261, 0.6195652173913, 0.22222222222222
62385, 1.5913043478261, 0.6195652173913, 0.16666666666667
62386, 1.5913043478261, 0.6195652173913, 0.11111111111111
62387, 1.5913043478261, 0.6195652173913, 0.055555555555556
62388, 1.6347826086957, 0.61956521739131, 0.44444444444444
62389, 1.6347826086957, 0.61956521739131, 0.38888888888889
62390, 1.6347826086957, 0.61956521739131, 0.33333333333333
62391, 1.6347826086957, 0.61956521739131, 0.27777777777778
62392, 1.6347826086957, 0.61956521739131, 0.22222222222222
62393, 1.6347826086957, 0.61956521739131, 0.16666666666667
62394, 1.6347826086957, 0.61956521739131, 0.11111111111111
62395, 1.6347826086957, 0.61956521739131, 0.055555555555556
62396, 1.6782608695652, 0.61956521739131, 0.44444444444444
62397, 1.6782608695652, 0.61956521739131, 0.38888888888889
62398, 1.6782608695652, 0.61956521739131, 0.33333333333333
62399, 1.6782608695652, 0.6195652173913, 0.27777777777778
62400, 1.6782608695652, 0.61956521739131, 0.22222222222222
62401, 1.6782608695652, 0.61956521739131, 0.16666666666667
62402, 1.6782608695652, 0.61956521739131, 0.11111111111111
62403, 1.6782608695652, 0.61956521739131, 0.055555555555556
62404, 1.7217391304348, 0.61956521739131, 0.44444444444444
62405, 1.7217391304348, 0.61956521739131, 0.38888888888889
62406, 1.7217391304348, 0.61956521739131, 0.33333333333333
62407, 1.7217391304348, 0.6195652173913, 0.27777777777778
62408, 1.7217391304348, 0.61956521739131, 0.22222222222222
62409, 1.7217391304348, 0.61956521739131, 0.16666666666667
62410, 1.7217391304348, 0.61956521739131, 0.11111111111111
62411, 1.7217391304348, 0.61956521739131, 0.055555555555556
62412, 1.7652173913043, 0.61956521739131, 0.44444444444444
62413, 1.7652173913043, 0.61956521739131, 0.38888888888889
62414, 1.7652173913043, 0.61956521739131, 0.33333333333333
62415, 1.7652173913043, 0.61956521739131, 0.27777777777778
62416, 1.7652173913043, 0.61956521739131, 0.22222222222222
62417, 1.7652173913043, 0.61956521739131, 0.16666666666667
62418, 1.7652173913043, 0.61956521739131, 0.11111111111111
62419, 1.7652173913043, 0.61956521739131, 0.055555555555556
62420, 1.8086956521739, 0.61956521739131, 0.44444444444444
62421, 1.8086956521739, 0.61956521739131, 0.38888888888889
62422, 1.8086956521739, 0.61956521739131, 0.33333333333333
62423, 1.8086956521739, 0.61956521739131, 0.27777777777778
62424, 1.8086956521739, 0.61956521739131, 0.22222222222222
62425, 1.8086956521739, 0.6195652173913, 0.16666666666667
62426, 1.8086956521739, 0.61956521739131, 0.11111111111111
62427, 1.8086956521739, 0.61956521739131, 0.055555555555556
62428, 1.8521739130435, 0.61956521739131, 0.44444444444444
62429, 1.8521739130435, 0.61956521739131, 0.38888888888889
62430, 1.8521739130435, 0.61956521739131, 0.33333333333333
62431, 1.8521739130435, 0.61956521739131, 0.27777777777778
62432, 1.8521739130435, 0.61956521739131, 0.22222222222222
62433, 1.8521739130435, 0.61956521739131, 0.16666666666667
62434, 1.8521739130435, 0.61956521739131, 0.11111111111111
62435, 1.8521739130435, 0.61956521739131, 0.055555555555556
62436, 1.895652173913, 0.61956521739131, 0.44444444444444
62437, 1.895652173913, 0.61956521739131, 0.38888888888889
62438, 1.895652173913, 0.61956521739131, 0.33333333333333
62439, 1.895652173913, 0.61956521739131, 0.27777777777778
62440, 1.895652173913, 0.61956521739131, 0.22222222222222
62441, 1.895652173913, 0.6195652173913, 0.16666666666667
62442, 1.895652173913, 0.61956521739131, 0.11111111111111
62443, 1.895652173913, 0.61956521739131, 0.055555555555556
62444, 1.9391304347826, 0.61956521739131, 0.44444444444444
62445, 1.9391304347826, 0.61956521739131, 0.38888888888889
62446, 1.9391304347826, 0.61956521739131, 0.33333333333333
62447, 1.9391304347826, 0.61956521739131, 0.27777777777778
62448, 1.9391304347826, 0.61956521739131, 0.22222222222222
62449, 1.9391304347826, 0.61956521739131, 0.16666666666667
62450, 1.9391304347826, 0.61956521739131, 0.11111111111111
62451, 1.9391304347826, 0.61956521739131, 0.055555555555556
62452, 1.9826086956522, 0.61956521739131, 0.44444444444444
62453, 1.9826086956522, 0.61956521739131, 0.38888888888889
62454, 1.9826086956522, 0.61956521739131, 0.33333333333333
62455, 1.9826086956522, 0.61956521739131, 0.27777777777778
62456, 1.9826086956522, 0.61956521739131, 0.22222222222222
62457, 1.9826086956522, 0.61956521739131, 0.16666666666667
62458, 1.9826086956522, 0.61956521739131, 0.11111111111111
62459, 1.9826086956522, 0.61956521739131, 0.055555555555556
62460, 2.0260869565217, 0.61956521739131, 0.44444444444444
62461, 2.0260869565217, 0.61956521739131, 0.38888888888889
62462, 2.0260869565217, 0.6195652173913, 0.33333333333333
62463, 2.0260869565217, 0.6195652173913, 0.27777777777778
62464, 2.0260869565217, 0.61956521739131, 0.22222222222222
62465, 2.0260869565217, 0.6195652173913, 0.16666666666667
62466, 2.0260869565217, 0.61956521739131, 0.11111111111111
62467, 2.0260869565217, 0.61956521739131, 0.055555555555556
62468, 2.0695652173913, 0.61956521739131, 0.44444444444444
62469, 2.0695652173913, 0.61956521739131, 0.38888888888889
62470, 2.0695652173913, 0.61956521739131, 0.33333333333333
62471, 2.0695652173913, 0.6195652173913, 0.27777777777778
62472, 2.0695652173913, 0.61956521739131, 0.22222222222222
62473, 2.0695652173913, 0.6195652173913, 0.16666666666667
62474, 2.0695652173913, 0.61956521739131, 0.11111111111111
62475, 2.0695652173913, 0.61956521739131, 0.055555555555556
62476, 2.1130434782609, 0.61956521739131, 0.44444444444444
62477, 2.1130434782609, 0.61956521739131, 0.38888888888889
62478, 2.1130434782609, 0.61956521739131, 0.33333333333333
62479, 2.1130434782609, 0.61956521739131, 0.27777777777778
62480, 2.1130434782609, 0.61956521739131, 0.22222222222222
62481, 2.1130434782609, 0.61956521739131, 0.16666666666667
62482, 2.1130434782609, 0.61956521739131, 0.11111111111111
62483, 2.1130434782609, 0.61956521739131, 0.055555555555556
62484, 2.1565217391304, 0.61956521739131, 0.44444444444444
62485, 2.1565217391304, 0.61956521739131, 0.38888888888889
62486, 2.1565217391304, 0.61956521739131, 0.33333333333333
62487, 2.1565217391304, 0.61956521739131, 0.27777777777778
62488, 2.1565217391304, 0.61956521739131, 0.22222222222222
62489, 2.1565217391304, 0.61956521739131, 0.16666666666667
62490, 2.1565217391304, 0.61956521739131, 0.11111111111111
62491, 2.1565217391304, 0.61956521739131, 0.055555555555556
62492, 1.2434782608696, 0.56739130434783, 0.44444444444444
62493, 1.2434782608696, 0.56739130434783, 0.38888888888889
62494, 1.2434782608696, 0.56739130434783, 0.33333333333333
62495, 1.2434782608696, 0.56739130434783, 0.27777777777778
62496, 1.2434782608696, 0.56739130434783, 0.22222222222222
62497, 1.2434782608696, 0.56739130434783, 0.16666666666667
62498, 1.2434782608696, 0.56739130434783, 0.11111111111111
62499, 1.2434782608696, 0.56739130434783, 0.055555555555556
62500, 1.2869565217391, 0.56739130434783, 0.44444444444444
62501, 1.2869565217391, 0.56739130434783, 0.38888888888889
62502, 1.2869565217391, 0.56739130434783, 0.33333333333333
62503, 1.2869565217391, 0.56739130434783, 0.27777777777778
62504, 1.2869565217391, 0.56739130434783, 0.22222222222222
62505, 1.2869565217391, 0.56739130434783, 0.16666666666667
62506, 1.2869565217391, 0.56739130434783, 0.11111111111111
62507, 1.2869565217391, 0.56739130434783, 0.055555555555556
62508, 1.3304347826087, 0.56739130434783, 0.44444444444444
62509, 1.3304347826087, 0.56739130434783, 0.38888888888889
62510, 1.3304347826087, 0.56739130434783, 0.33333333333333
62511, 1.3304347826087, 0.56739130434783, 0.27777777777778
62512, 1.3304347826087, 0.56739130434783, 0.22222222222222
62513, 1.3304347826087, 0.56739130434783, 0.16666666666667
62514, 1.3304347826087, 0.56739130434783, 0.11111111111111
62515, 1.3304347826087, 0.56739130434783, 0.055555555555556
62516, 1.3739130434783, 0.56739130434783, 0.44444444444444
62517, 1.3739130434783, 0.56739130434783, 0.38888888888889
62518, 1.3739130434783, 0.56739130434783, 0.33333333333333
62519, 1.3739130434783, 0.56739130434783, 0.27777777777778
62520, 1.3739130434783, 0.56739130434783, 0.22222222222222
62521, 1.3739130434783, 0.56739130434783, 0.16666666666667
62522, 1.3739130434783, 0.56739130434783, 0.11111111111111
62523, 1.3739130434783, 0.56739130434783, 0.055555555555556
62524, 1.4173913043478, 0.56739130434783, 0.44444444444444
62525, 1.4173913043478, 0.56739130434783, 0.38888888888889
62526, 1.4173913043478, 0.56739130434783, 0.33333333333333
62527, 1.4173913043478, 0.56739130434783, 0.27777777777778
62528, 1.4173913043478, 0.56739130434783, 0.22222222222222
62529, 1.4173913043478, 0.56739130434783, 0.16666666666667
62530, 1.4173913043478, 0.56739130434783, 0.11111111111111
62531, 1.4173913043478, 0.56739130434783, 0.055555555555556
62532, 1.4608695652174, 0.56739130434783, 0.44444444444444
62533, 1.4608695652174, 0.56739130434783, 0.38888888888889
62534, 1.4608695652174, 0.56739130434783, 0.33333333333333
62535, 1.4608695652174, 0.56739130434783, 0.27777777777778
62536, 1.4608695652174, 0.56739130434783, 0.22222222222222
62537, 1.4608695652174, 0.56739130434783, 0.16666666666667
62538, 1.4608695652174, 0.56739130434783, 0.11111111111111
62539, 1.4608695652174, 0.56739130434783, 0.055555555555556
62540, 1.504347826087, 0.56739130434783, 0.44444444444444
62541, 1.504347826087, 0.56739130434783, 0.38888888888889
62542, 1.504347826087, 0.56739130434783, 0.33333333333333
62543, 1.504347826087, 0.56739130434783, 0.27777777777778
62544, 1.504347826087, 0.56739130434783, 0.22222222222222
62545, 1.504347826087, 0.56739130434783, 0.16666666666667
62546, 1.504347826087, 0.56739130434783, 0.11111111111111
62547, 1.504347826087, 0.56739130434783, 0.055555555555556
62548, 1.5478260869565, 0.56739130434783, 0.44444444444444
62549, 1.5478260869565, 0.56739130434783, 0.38888888888889
62550, 1.5478260869565, 0.56739130434783, 0.33333333333333
62551, 1.5478260869565, 0.56739130434783, 0.27777777777778
62552, 1.5478260869565, 0.56739130434783, 0.22222222222222
62553, 1.5478260869565, 0.56739130434783, 0.16666666666667
62554, 1.5478260869565, 0.56739130434783, 0.11111111111111
62555, 1.5478260869565, 0.56739130434783, 0.055555555555556
62556, 1.5913043478261, 0.56739130434783, 0.44444444444444
62557, 1.5913043478261, 0.56739130434783, 0.38888888888889
62558, 1.5913043478261, 0.56739130434783, 0.33333333333333
62559, 1.5913043478261, 0.56739130434783, 0.27777777777778
62560, 1.5913043478261, 0.56739130434783, 0.22222222222222
62561, 1.5913043478261, 0.56739130434783, 0.16666666666667
62562, 1.5913043478261, 0.56739130434783, 0.11111111111111
62563, 1.5913043478261, 0.56739130434783, 0.055555555555556
62564, 1.6347826086957, 0.56739130434783, 0.44444444444444
62565, 1.6347826086957, 0.56739130434783, 0.38888888888889
62566, 1.6347826086957, 0.56739130434783, 0.33333333333333
62567, 1.6347826086957, 0.56739130434783, 0.27777777777778
62568, 1.6347826086957, 0.56739130434783, 0.22222222222222
62569, 1.6347826086957, 0.56739130434783, 0.16666666666667
62570, 1.6347826086957, 0.56739130434783, 0.11111111111111
62571, 1.6347826086957, 0.56739130434783, 0.055555555555556
62572, 1.6782608695652, 0.56739130434783, 0.44444444444444
62573, 1.6782608695652, 0.56739130434783, 0.38888888888889
62574, 1.6782608695652, 0.56739130434783, 0.33333333333333
62575, 1.6782608695652, 0.56739130434783, 0.27777777777778
62576, 1.6782608695652, 0.56739130434783, 0.22222222222222
62577, 1.6782608695652, 0.56739130434783, 0.16666666666667
62578, 1.6782608695652, 0.56739130434783, 0.11111111111111
62579, 1.6782608695652, 0.56739130434783, 0.055555555555556
62580, 1.7217391304348, 0.56739130434783, 0.44444444444444
62581, 1.7217391304348, 0.56739130434783, 0.38888888888889
62582, 1.7217391304348, 0.56739130434783, 0.33333333333333
62583, 1.7217391304348, 0.56739130434783, 0.27777777777778
62584, 1.7217391304348, 0.56739130434783, 0.22222222222222
62585, 1.7217391304348, 0.56739130434783, 0.16666666666667
62586, 1.7217391304348, 0.56739130434783, 0.11111111111111
62587, 1.7217391304348, 0.56739130434783, 0.055555555555556
62588, 1.7652173913043, 0.56739130434783, 0.44444444444444
62589, 1.7652173913043, 0.56739130434783, 0.38888888888889
62590, 1.7652173913043, 0.56739130434783, 0.33333333333333
62591, 1.7652173913043, 0.56739130434783, 0.27777777777778
62592, 1.7652173913043, 0.56739130434783, 0.22222222222222
62593, 1.7652173913043, 0.56739130434783, 0.16666666666667
62594, 1.7652173913043, 0.56739130434783, 0.11111111111111
62595, 1.7652173913043, 0.56739130434783, 0.055555555555556
62596, 1.8086956521739, 0.56739130434783, 0.44444444444444
62597, 1.8086956521739, 0.56739130434783, 0.38888888888889
62598, 1.8086956521739, 0.56739130434783, 0.33333333333333
62599, 1.8086956521739, 0.56739130434783, 0.27777777777778
62600, 1.8086956521739, 0.56739130434783, 0.22222222222222
62601, 1.8086956521739, 0.56739130434783, 0.16666666666667
62602, 1.8086956521739, 0.56739130434783, 0.11111111111111
62603, 1.8086956521739, 0.56739130434783, 0.055555555555556
62604, 1.8521739130435, 0.56739130434783, 0.44444444444444
62605, 1.8521739130435, 0.56739130434783, 0.38888888888889
62606, 1.8521739130435, 0.56739130434783, 0.33333333333333
62607, 1.8521739130435, 0.56739130434783, 0.27777777777778
62608, 1.8521739130435, 0.56739130434783, 0.22222222222222
62609, 1.8521739130435, 0.56739130434783, 0.16666666666667
62610, 1.8521739130435, 0.56739130434783, 0.11111111111111
62611, 1.8521739130435, 0.56739130434783, 0.055555555555556
62612, 1.895652173913, 0.56739130434783, 0.44444444444444
62613, 1.895652173913, 0.56739130434783, 0.38888888888889
62614, 1.895652173913, 0.56739130434783, 0.33333333333333
62615, 1.895652173913, 0.56739130434783, 0.27777777777778
62616, 1.895652173913, 0.56739130434783, 0.22222222222222
62617, 1.895652173913, 0.56739130434783, 0.16666666666667
62618, 1.895652173913, 0.56739130434783, 0.11111111111111
62619, 1.895652173913, 0.56739130434783, 0.055555555555556
62620, 1.9391304347826, 0.56739130434783, 0.44444444444444
62621, 1.9391304347826, 0.56739130434783, 0.38888888888889
62622, 1.9391304347826, 0.56739130434783, 0.33333333333333
62623, 1.9391304347826, 0.56739130434783, 0.27777777777778
62624, 1.9391304347826, 0.56739130434783, 0.22222222222222
62625, 1.9391304347826, 0.56739130434783, 0.16666666666667
62626, 1.9391304347826, 0.56739130434783, 0.11111111111111
62627, 1.9391304347826, 0.56739130434783, 0.055555555555556
62628, 1.9826086956522, 0.56739130434783, 0.44444444444444
62629, 1.9826086956522, 0.56739130434783, 0.38888888888889
62630, 1.9826086956522, 0.56739130434783, 0.33333333333333
62631, 1.9826086956522, 0.56739130434783, 0.27777777777778
62632, 1.9826086956522, 0.56739130434783, 0.22222222222222
62633, 1.9826086956522, 0.56739130434783, 0.16666666666667
62634, 1.9826086956522, 0.56739130434783, 0.11111111111111
62635, 1.9826086956522, 0.56739130434783, 0.055555555555556
62636, 2.0260869565217, 0.56739130434783, 0.44444444444444
62637, 2.0260869565217, 0.56739130434783, 0.38888888888889
62638, 2.0260869565217, 0.56739130434783, 0.33333333333333
62639, 2.0260869565217, 0.56739130434783, 0.27777777777778
62640, 2.0260869565217, 0.56739130434783, 0.22222222222222
62641, 2.0260869565217, 0.56739130434783, 0.16666666666667
62642, 2.0260869565217, 0.56739130434783, 0.11111111111111
62643, 2.0260869565217, 0.56739130434783, 0.055555555555556
62644, 2.0695652173913, 0.56739130434783, 0.44444444444444
62645, 2.0695652173913, 0.56739130434783, 0.38888888888889
62646, 2.0695652173913, 0.56739130434783, 0.33333333333333
62647, 2.0695652173913, 0.56739130434783, 0.27777777777778
62648, 2.0695652173913, 0.56739130434783, 0.22222222222222
62649, 2.0695652173913, 0.56739130434783, 0.16666666666667
62650, 2.0695652173913, 0.56739130434783, 0.11111111111111
62651, 2.0695652173913, 0.56739130434783, 0.055555555555556
62652, 2.1130434782609, 0.56739130434783, 0.44444444444444
62653, 2.1130434782609, 0.56739130434783, 0.38888888888889
62654, 2.1130434782609, 0.56739130434783, 0.33333333333333
62655, 2.1130434782609, 0.56739130434783, 0.27777777777778
62656, 2.1130434782609, 0.56739130434783, 0.22222222222222
62657, 2.1130434782609, 0.56739130434783, 0.16666666666667
62658, 2.1130434782609, 0.56739130434783, 0.11111111111111
62659, 2.1130434782609, 0.56739130434783, 0.055555555555556
62660, 2.1565217391304, 0.56739130434783, 0.44444444444444
62661, 2.1565217391304, 0.56739130434783, 0.38888888888889
62662, 2.1565217391304, 0.56739130434783, 0.33333333333333
62663, 2.1565217391304, 0.56739130434783, 0.27777777777778
62664, 2.1565217391304, 0.56739130434783, 0.22222222222222
62665, 2.1565217391304, 0.56739130434783, 0.16666666666667
62666, 2.1565217391304, 0.56739130434783, 0.11111111111111
62667, 2.1565217391304, 0.56739130434783, 0.055555555555556
62668, 1.2434782608696, 0.51521739130435, 0.44444444444444
62669, 1.2434782608696, 0.51521739130435, 0.38888888888889
62670, 1.2434782608696, 0.51521739130435, 0.33333333333333
62671, 1.2434782608696, 0.51521739130435, 0.27777777777778
62672, 1.2434782608696, 0.51521739130435, 0.22222222222222
62673, 1.2434782608696, 0.51521739130435, 0.16666666666667
62674, 1.2434782608696, 0.51521739130435, 0.11111111111111
62675, 1.2434782608696, 0.51521739130435, 0.055555555555556
62676, 1.2869565217391, 0.51521739130435, 0.44444444444444
62677, 1.2869565217391, 0.51521739130435, 0.38888888888889
62678, 1.2869565217391, 0.51521739130435, 0.33333333333333
62679, 1.2869565217391, 0.51521739130435, 0.27777777777778
62680, 1.2869565217391, 0.51521739130435, 0.22222222222222
62681, 1.2869565217391, 0.51521739130435, 0.16666666666667
62682, 1.2869565217391, 0.51521739130435, 0.11111111111111
62683, 1.2869565217391, 0.51521739130435, 0.055555555555556
62684, 1.3304347826087, 0.51521739130435, 0.44444444444444
62685, 1.3304347826087, 0.51521739130435, 0.38888888888889
62686, 1.3304347826087, 0.51521739130435, 0.33333333333333
62687, 1.3304347826087, 0.51521739130435, 0.27777777777778
62688, 1.3304347826087, 0.51521739130435, 0.22222222222222
62689, 1.3304347826087, 0.51521739130435, 0.16666666666667
62690, 1.3304347826087, 0.51521739130435, 0.11111111111111
62691, 1.3304347826087, 0.51521739130435, 0.055555555555556
62692, 1.3739130434783, 0.51521739130435, 0.44444444444444
62693, 1.3739130434783, 0.51521739130435, 0.38888888888889
62694, 1.3739130434783, 0.51521739130435, 0.33333333333333
62695, 1.3739130434783, 0.51521739130435, 0.27777777777778
62696, 1.3739130434783, 0.51521739130435, 0.22222222222222
62697, 1.3739130434783, 0.51521739130435, 0.16666666666667
62698, 1.3739130434783, 0.51521739130435, 0.11111111111111
62699, 1.3739130434783, 0.51521739130435, 0.055555555555556
62700, 1.4173913043478, 0.51521739130435, 0.44444444444444
62701, 1.4173913043478, 0.51521739130435, 0.38888888888889
62702, 1.4173913043478, 0.51521739130435, 0.33333333333333
62703, 1.4173913043478, 0.51521739130435, 0.27777777777778
62704, 1.4173913043478, 0.51521739130435, 0.22222222222222
62705, 1.4173913043478, 0.51521739130435, 0.16666666666667
62706, 1.4173913043478, 0.51521739130435, 0.11111111111111
62707, 1.4173913043478, 0.51521739130435, 0.055555555555556
62708, 1.4608695652174, 0.51521739130435, 0.44444444444444
62709, 1.4608695652174, 0.51521739130435, 0.38888888888889
62710, 1.4608695652174, 0.51521739130435, 0.33333333333333
62711, 1.4608695652174, 0.51521739130435, 0.27777777777778
62712, 1.4608695652174, 0.51521739130435, 0.22222222222222
62713, 1.4608695652174, 0.51521739130435, 0.16666666666667
62714, 1.4608695652174, 0.51521739130435, 0.11111111111111
62715, 1.4608695652174, 0.51521739130435, 0.055555555555556
62716, 1.504347826087, 0.51521739130435, 0.44444444444444
62717, 1.504347826087, 0.51521739130435, 0.38888888888889
62718, 1.504347826087, 0.51521739130435, 0.33333333333333
62719, 1.504347826087, 0.51521739130435, 0.27777777777778
62720, 1.504347826087, 0.51521739130435, 0.22222222222222
62721, 1.504347826087, 0.51521739130435, 0.16666666666667
62722, 1.504347826087, 0.51521739130435, 0.11111111111111
62723, 1.504347826087, 0.51521739130435, 0.055555555555556
62724, 1.5478260869565, 0.51521739130435, 0.44444444444444
62725, 1.5478260869565, 0.51521739130435, 0.38888888888889
62726, 1.5478260869565, 0.51521739130435, 0.33333333333333
62727, 1.5478260869565, 0.51521739130435, 0.27777777777778
62728, 1.5478260869565, 0.51521739130435, 0.22222222222222
62729, 1.5478260869565, 0.51521739130435, 0.16666666666667
62730, 1.5478260869565, 0.51521739130435, 0.11111111111111
62731, 1.5478260869565, 0.51521739130435, 0.055555555555556
62732, 1.5913043478261, 0.51521739130435, 0.44444444444444
62733, 1.5913043478261, 0.51521739130435, 0.38888888888889
62734, 1.5913043478261, 0.51521739130435, 0.33333333333333
62735, 1.5913043478261, 0.51521739130435, 0.27777777777778
62736, 1.5913043478261, 0.51521739130435, 0.22222222222222
62737, 1.5913043478261, 0.51521739130435, 0.16666666666667
62738, 1.5913043478261, 0.51521739130435, 0.11111111111111
62739, 1.5913043478261, 0.51521739130435, 0.055555555555556
62740, 1.6347826086957, 0.51521739130435, 0.44444444444444
62741, 1.6347826086957, 0.51521739130435, 0.38888888888889
62742, 1.6347826086957, 0.51521739130435, 0.33333333333333
62743, 1.6347826086957, 0.51521739130435, 0.27777777777778
62744, 1.6347826086957, 0.51521739130435, 0.22222222222222
62745, 1.6347826086957, 0.51521739130435, 0.16666666666667
62746, 1.6347826086957, 0.51521739130435, 0.11111111111111
62747, 1.6347826086957, 0.51521739130435, 0.055555555555556
62748, 1.6782608695652, 0.51521739130435, 0.44444444444444
62749, 1.6782608695652, 0.51521739130435, 0.38888888888889
62750, 1.6782608695652, 0.51521739130435, 0.33333333333333
62751, 1.6782608695652, 0.51521739130435, 0.27777777777778
62752, 1.6782608695652, 0.51521739130435, 0.22222222222222
62753, 1.6782608695652, 0.51521739130435, 0.16666666666667
62754, 1.6782608695652, 0.51521739130435, 0.11111111111111
62755, 1.6782608695652, 0.51521739130435, 0.055555555555556
62756, 1.7217391304348, 0.51521739130435, 0.44444444444444
62757, 1.7217391304348, 0.51521739130435, 0.38888888888889
62758, 1.7217391304348, 0.51521739130435, 0.33333333333333
62759, 1.7217391304348, 0.51521739130435, 0.27777777777778
62760, 1.7217391304348, 0.51521739130435, 0.22222222222222
62761, 1.7217391304348, 0.51521739130435, 0.16666666666667
62762, 1.7217391304348, 0.51521739130435, 0.11111111111111
62763, 1.7217391304348, 0.51521739130435, 0.055555555555556
62764, 1.7652173913043, 0.51521739130435, 0.44444444444444
62765, 1.7652173913043, 0.51521739130435, 0.38888888888889
62766, 1.7652173913043, 0.51521739130435, 0.33333333333333
62767, 1.7652173913043, 0.51521739130435, 0.27777777777778
62768, 1.7652173913043, 0.51521739130435, 0.22222222222222
62769, 1.7652173913043, 0.51521739130435, 0.16666666666667
62770, 1.7652173913043, 0.51521739130435, 0.11111111111111
62771, 1.7652173913043, 0.51521739130435, 0.055555555555556
62772, 1.8086956521739, 0.51521739130435, 0.44444444444444
62773, 1.8086956521739, 0.51521739130435, 0.38888888888889
62774, 1.8086956521739, 0.51521739130435, 0.33333333333333
62775, 1.8086956521739, 0.51521739130435, 0.27777777777778
62776, 1.8086956521739, 0.51521739130435, 0.22222222222222
62777, 1.8086956521739, 0.51521739130435, 0.16666666666667
62778, 1.8086956521739, 0.51521739130435, 0.11111111111111
62779, 1.8086956521739, 0.51521739130435, 0.055555555555556
62780, 1.8521739130435, 0.51521739130435, 0.44444444444444
62781, 1.8521739130435, 0.51521739130435, 0.38888888888889
62782, 1.8521739130435, 0.51521739130435, 0.33333333333333
62783, 1.8521739130435, 0.51521739130435, 0.27777777777778
62784, 1.8521739130435, 0.51521739130435, 0.22222222222222
62785, 1.8521739130435, 0.51521739130435, 0.16666666666667
62786, 1.8521739130435, 0.51521739130435, 0.11111111111111
62787, 1.8521739130435, 0.51521739130435, 0.055555555555556
62788, 1.895652173913, 0.51521739130435, 0.44444444444444
62789, 1.895652173913, 0.51521739130435, 0.38888888888889
62790, 1.895652173913, 0.51521739130435, 0.33333333333333
62791, 1.895652173913, 0.51521739130435, 0.27777777777778
62792, 1.895652173913, 0.51521739130435, 0.22222222222222
62793, 1.895652173913, 0.51521739130435, 0.16666666666667
62794, 1.895652173913, 0.51521739130435, 0.11111111111111
62795, 1.895652173913, 0.51521739130435, 0.055555555555556
62796, 1.9391304347826, 0.51521739130435, 0.44444444444444
62797, 1.9391304347826, 0.51521739130435, 0.38888888888889
62798, 1.9391304347826, 0.51521739130435, 0.33333333333333
62799, 1.9391304347826, 0.51521739130435, 0.27777777777778
62800, 1.9391304347826, 0.51521739130435, 0.22222222222222
62801, 1.9391304347826, 0.51521739130435, 0.16666666666667
62802, 1.9391304347826, 0.51521739130435, 0.11111111111111
62803, 1.9391304347826, 0.51521739130435, 0.055555555555556
62804, 1.9826086956522, 0.51521739130435, 0.44444444444444
62805, 1.9826086956522, 0.51521739130435, 0.38888888888889
62806, 1.9826086956522, 0.51521739130435, 0.33333333333333
62807, 1.9826086956522, 0.51521739130435, 0.27777777777778
62808, 1.9826086956522, 0.51521739130435, 0.22222222222222
62809, 1.9826086956522, 0.51521739130435, 0.16666666666667
62810, 1.9826086956522, 0.51521739130435, 0.11111111111111
62811, 1.9826086956522, 0.51521739130435, 0.055555555555556
62812, 2.0260869565217, 0.51521739130435, 0.44444444444444
62813, 2.0260869565217, 0.51521739130435, 0.38888888888889
62814, 2.0260869565217, 0.51521739130435, 0.33333333333333
62815, 2.0260869565217, 0.51521739130435, 0.27777777777778
62816, 2.0260869565217, 0.51521739130435, 0.22222222222222
62817, 2.0260869565217, 0.51521739130435, 0.16666666666667
62818, 2.0260869565217, 0.51521739130435, 0.11111111111111
62819, 2.0260869565217, 0.51521739130435, 0.055555555555556
62820, 2.0695652173913, 0.51521739130435, 0.44444444444444
62821, 2.0695652173913, 0.51521739130435, 0.38888888888889
62822, 2.0695652173913, 0.51521739130435, 0.33333333333333
62823, 2.0695652173913, 0.51521739130435, 0.27777777777778
62824, 2.0695652173913, 0.51521739130435, 0.22222222222222
62825, 2.0695652173913, 0.51521739130435, 0.16666666666667
62826, 2.0695652173913, 0.51521739130435, 0.11111111111111
62827, 2.0695652173913, 0.51521739130435, 0.055555555555556
62828, 2.1130434782609, 0.51521739130435, 0.44444444444444
62829, 2.1130434782609, 0.51521739130435, 0.38888888888889
62830, 2.1130434782609, 0.51521739130435, 0.33333333333333
62831, 2.1130434782609, 0.51521739130435, 0.27777777777778
62832, 2.1130434782609, 0.51521739130435, 0.22222222222222
62833, 2.1130434782609, 0.51521739130435, 0.16666666666667
62834, 2.1130434782609, 0.51521739130435, 0.11111111111111
62835, 2.1130434782609, 0.51521739130435, 0.055555555555556
62836, 2.1565217391304, 0.51521739130435, 0.44444444444444
62837, 2.1565217391304, 0.51521739130435, 0.38888888888889
62838, 2.1565217391304, 0.51521739130435, 0.33333333333333
62839, 2.1565217391304, 0.51521739130435, 0.27777777777778
62840, 2.1565217391304, 0.51521739130435, 0.22222222222222
62841, 2.1565217391304, 0.51521739130435, 0.16666666666667
62842, 2.1565217391304, 0.51521739130435, 0.11111111111111
62843, 2.1565217391304, 0.51521739130435, 0.055555555555556
62844, 1.2434782608696, 0.46304347826087, 0.44444444444444
62845, 1.2434782608696, 0.46304347826087, 0.38888888888889
62846, 1.2434782608696, 0.46304347826087, 0.33333333333333
62847, 1.2434782608696, 0.46304347826087, 0.27777777777778
62848, 1.2434782608696, 0.46304347826087, 0.22222222222222
62849, 1.2434782608696, 0.46304347826087, 0.16666666666667
62850, 1.2434782608696, 0.46304347826087, 0.11111111111111
62851, 1.2434782608696, 0.46304347826087, 0.055555555555556
62852, 1.2869565217391, 0.46304347826087, 0.44444444444444
62853, 1.2869565217391, 0.46304347826087, 0.38888888888889
62854, 1.2869565217391, 0.46304347826087, 0.33333333333333
62855, 1.2869565217391, 0.46304347826087, 0.27777777777778
62856, 1.2869565217391, 0.46304347826087, 0.22222222222222
62857, 1.2869565217391, 0.46304347826087, 0.16666666666667
62858, 1.2869565217391, 0.46304347826087, 0.11111111111111
62859, 1.2869565217391, 0.46304347826087, 0.055555555555556
62860, 1.3304347826087, 0.46304347826087, 0.44444444444444
62861, 1.3304347826087, 0.46304347826087, 0.38888888888889
62862, 1.3304347826087, 0.46304347826087, 0.33333333333333
62863, 1.3304347826087, 0.46304347826087, 0.27777777777778
62864, 1.3304347826087, 0.46304347826087, 0.22222222222222
62865, 1.3304347826087, 0.46304347826087, 0.16666666666667
62866, 1.3304347826087, 0.46304347826087, 0.11111111111111
62867, 1.3304347826087, 0.46304347826087, 0.055555555555556
62868, 1.3739130434783, 0.46304347826087, 0.44444444444444
62869, 1.3739130434783, 0.46304347826087, 0.38888888888889
62870, 1.3739130434783, 0.46304347826087, 0.33333333333333
62871, 1.3739130434783, 0.46304347826087, 0.27777777777778
62872, 1.3739130434783, 0.46304347826087, 0.22222222222222
62873, 1.3739130434783, 0.46304347826087, 0.16666666666667
62874, 1.3739130434783, 0.46304347826087, 0.11111111111111
62875, 1.3739130434783, 0.46304347826087, 0.055555555555556
62876, 1.4173913043478, 0.46304347826087, 0.44444444444444
62877, 1.4173913043478, 0.46304347826087, 0.38888888888889
62878, 1.4173913043478, 0.46304347826087, 0.33333333333333
62879, 1.4173913043478, 0.46304347826087, 0.27777777777778
62880, 1.4173913043478, 0.46304347826087, 0.22222222222222
62881, 1.4173913043478, 0.46304347826087, 0.16666666666667
62882, 1.4173913043478, 0.46304347826087, 0.11111111111111
62883, 1.4173913043478, 0.46304347826087, 0.055555555555556
62884, 1.4608695652174, 0.46304347826087, 0.44444444444444
62885, 1.4608695652174, 0.46304347826087, 0.38888888888889
62886, 1.4608695652174, 0.46304347826087, 0.33333333333333
62887, 1.4608695652174, 0.46304347826087, 0.27777777777778
62888, 1.4608695652174, 0.46304347826087, 0.22222222222222
62889, 1.4608695652174, 0.46304347826087, 0.16666666666667
62890, 1.4608695652174, 0.46304347826087, 0.11111111111111
62891, 1.4608695652174, 0.46304347826087, 0.055555555555556
62892, 1.504347826087, 0.46304347826087, 0.44444444444444
62893, 1.504347826087, 0.46304347826087, 0.38888888888889
62894, 1.504347826087, 0.46304347826087, 0.33333333333333
62895, 1.504347826087, 0.46304347826087, 0.27777777777778
62896, 1.504347826087, 0.46304347826087, 0.22222222222222
62897, 1.504347826087, 0.46304347826087, 0.16666666666667
62898, 1.504347826087, 0.46304347826087, 0.11111111111111
62899, 1.504347826087, 0.46304347826087, 0.055555555555556
62900, 1.5478260869565, 0.46304347826087, 0.44444444444444
62901, 1.5478260869565, 0.46304347826087, 0.38888888888889
62902, 1.5478260869565, 0.46304347826087, 0.33333333333333
62903, 1.5478260869565, 0.46304347826087, 0.27777777777778
62904, 1.5478260869565, 0.46304347826087, 0.22222222222222
62905, 1.5478260869565, 0.46304347826087, 0.16666666666667
62906, 1.5478260869565, 0.46304347826087, 0.11111111111111
62907, 1.5478260869565, 0.46304347826087, 0.055555555555556
62908, 1.5913043478261, 0.46304347826087, 0.44444444444444
62909, 1.5913043478261, 0.46304347826087, 0.38888888888889
62910, 1.5913043478261, 0.46304347826087, 0.33333333333333
62911, 1.5913043478261, 0.46304347826087, 0.27777777777778
62912, 1.5913043478261, 0.46304347826087, 0.22222222222222
62913, 1.5913043478261, 0.46304347826087, 0.16666666666667
62914, 1.5913043478261, 0.46304347826087, 0.11111111111111
62915, 1.5913043478261, 0.46304347826087, 0.055555555555556
62916, 1.6347826086957, 0.46304347826087, 0.44444444444444
62917, 1.6347826086957, 0.46304347826087, 0.38888888888889
62918, 1.6347826086957, 0.46304347826087, 0.33333333333333
62919, 1.6347826086957, 0.46304347826087, 0.27777777777778
62920, 1.6347826086957, 0.46304347826087, 0.22222222222222
62921, 1.6347826086957, 0.46304347826087, 0.16666666666667
62922, 1.6347826086957, 0.46304347826087, 0.11111111111111
62923, 1.6347826086957, 0.46304347826087, 0.055555555555556
62924, 1.6782608695652, 0.46304347826087, 0.44444444444444
62925, 1.6782608695652, 0.46304347826087, 0.38888888888889
62926, 1.6782608695652, 0.46304347826087, 0.33333333333333
62927, 1.6782608695652, 0.46304347826087, 0.27777777777778
62928, 1.6782608695652, 0.46304347826087, 0.22222222222222
62929, 1.6782608695652, 0.46304347826087, 0.16666666666667
62930, 1.6782608695652, 0.46304347826087, 0.11111111111111
62931, 1.6782608695652, 0.46304347826087, 0.055555555555556
62932, 1.7217391304348, 0.46304347826087, 0.44444444444444
62933, 1.7217391304348, 0.46304347826087, 0.38888888888889
62934, 1.7217391304348, 0.46304347826087, 0.33333333333333
62935, 1.7217391304348, 0.46304347826087, 0.27777777777778
62936, 1.7217391304348, 0.46304347826087, 0.22222222222222
62937, 1.7217391304348, 0.46304347826087, 0.16666666666667
62938, 1.7217391304348, 0.46304347826087, 0.11111111111111
62939, 1.7217391304348, 0.46304347826087, 0.055555555555556
62940, 1.7652173913043, 0.46304347826087, 0.44444444444444
62941, 1.7652173913043, 0.46304347826087, 0.38888888888889
62942, 1.7652173913043, 0.46304347826087, 0.33333333333333
62943, 1.7652173913043, 0.46304347826087, 0.27777777777778
62944, 1.7652173913043, 0.46304347826087, 0.22222222222222
62945, 1.7652173913043, 0.46304347826087, 0.16666666666667
62946, 1.7652173913043, 0.46304347826087, 0.11111111111111
62947, 1.7652173913043, 0.46304347826087, 0.055555555555556
62948, 1.8086956521739, 0.46304347826087, 0.44444444444444
62949, 1.8086956521739, 0.46304347826087, 0.38888888888889
62950, 1.8086956521739, 0.46304347826087, 0.33333333333333
62951, 1.8086956521739, 0.46304347826087, 0.27777777777778
62952, 1.8086956521739, 0.46304347826087, 0.22222222222222
62953, 1.8086956521739, 0.46304347826087, 0.16666666666667
62954, 1.8086956521739, 0.46304347826087, 0.11111111111111
62955, 1.8086956521739, 0.46304347826087, 0.055555555555556
62956, 1.8521739130435, 0.46304347826087, 0.44444444444444
62957, 1.8521739130435, 0.46304347826087, 0.38888888888889
62958, 1.8521739130435, 0.46304347826087, 0.33333333333333
62959, 1.8521739130435, 0.46304347826087, 0.27777777777778
62960, 1.8521739130435, 0.46304347826087, 0.22222222222222
62961, 1.8521739130435, 0.46304347826087, 0.16666666666667
62962, 1.8521739130435, 0.46304347826087, 0.11111111111111
62963, 1.8521739130435, 0.46304347826087, 0.055555555555556
62964, 1.895652173913, 0.46304347826087, 0.44444444444444
62965, 1.895652173913, 0.46304347826087, 0.38888888888889
62966, 1.895652173913, 0.46304347826087, 0.33333333333333
62967, 1.895652173913, 0.46304347826087, 0.27777777777778
62968, 1.895652173913, 0.46304347826087, 0.22222222222222
62969, 1.895652173913, 0.46304347826087, 0.16666666666667
62970, 1.895652173913, 0.46304347826087, 0.11111111111111
62971, 1.895652173913, 0.46304347826087, 0.055555555555556
62972, 1.9391304347826, 0.46304347826087, 0.44444444444444
62973, 1.9391304347826, 0.46304347826087, 0.38888888888889
62974, 1.9391304347826, 0.46304347826087, 0.33333333333333
62975, 1.9391304347826, 0.46304347826087, 0.27777777777778
62976, 1.9391304347826, 0.46304347826087, 0.22222222222222
62977, 1.9391304347826, 0.46304347826087, 0.16666666666667
62978, 1.9391304347826, 0.46304347826087, 0.11111111111111
62979, 1.9391304347826, 0.46304347826087, 0.055555555555556
62980, 1.9826086956522, 0.46304347826087, 0.44444444444444
62981, 1.9826086956522, 0.46304347826087, 0.38888888888889
62982, 1.9826086956522, 0.46304347826087, 0.33333333333333
62983, 1.9826086956522, 0.46304347826087, 0.27777777777778
62984, 1.9826086956522, 0.46304347826087, 0.22222222222222
62985, 1.9826086956522, 0.46304347826087, 0.16666666666667
62986, 1.9826086956522, 0.46304347826087, 0.11111111111111
62987, 1.9826086956522, 0.46304347826087, 0.055555555555556
62988, 2.0260869565217, 0.46304347826087, 0.44444444444444
62989, 2.0260869565217, 0.46304347826087, 0.38888888888889
62990, 2.0260869565217, 0.46304347826087, 0.33333333333333
62991, 2.0260869565217, 0.46304347826087, 0.27777777777778
62992, 2.0260869565217, 0.46304347826087, 0.22222222222222
62993, 2.0260869565217, 0.46304347826087, 0.16666666666667
62994, 2.0260869565217, 0.46304347826087, 0.11111111111111
62995, 2.0260869565217, 0.46304347826087, 0.055555555555556
62996, 2.0695652173913, 0.46304347826087, 0.44444444444444
62997, 2.0695652173913, 0.46304347826087, 0.38888888888889
62998, 2.0695652173913, 0.46304347826087, 0.33333333333333
62999, 2.0695652173913, 0.46304347826087, 0.27777777777778
63000, 2.0695652173913, 0.46304347826087, 0.22222222222222
63001, 2.0695652173913, 0.46304347826087, 0.16666666666667
63002, 2.0695652173913, 0.46304347826087, 0.11111111111111
63003, 2.0695652173913, 0.46304347826087, 0.055555555555556
63004, 2.1130434782609, 0.46304347826087, 0.44444444444444
63005, 2.1130434782609, 0.46304347826087, 0.38888888888889
63006, 2.1130434782609, 0.46304347826087, 0.33333333333333
63007, 2.1130434782609, 0.46304347826087, 0.27777777777778
63008, 2.1130434782609, 0.46304347826087, 0.22222222222222
63009, 2.1130434782609, 0.46304347826087, 0.16666666666667
63010, 2.1130434782609, 0.46304347826087, 0.11111111111111
63011, 2.1130434782609, 0.46304347826087, 0.055555555555556
63012, 2.1565217391304, 0.46304347826087, 0.44444444444444
63013, 2.1565217391304, 0.46304347826087, 0.38888888888889
63014, 2.1565217391304, 0.46304347826087, 0.33333333333333
63015, 2.1565217391304, 0.46304347826087, 0.27777777777778
63016, 2.1565217391304, 0.46304347826087, 0.22222222222222
63017, 2.1565217391304, 0.46304347826087, 0.16666666666667
63018, 2.1565217391304, 0.46304347826087, 0.11111111111111
63019, 2.1565217391304, 0.46304347826087, 0.055555555555556
63020, 1.2434782608696, 0.41086956521739, 0.44444444444444
63021, 1.2434782608696, 0.41086956521739, 0.38888888888889
63022, 1.2434782608696, 0.41086956521739, 0.33333333333333
63023, 1.2434782608696, 0.41086956521739, 0.27777777777778
63024, 1.2434782608696, 0.41086956521739, 0.22222222222222
63025, 1.2434782608696, 0.41086956521739, 0.16666666666667
63026, 1.2434782608696, 0.41086956521739, 0.11111111111111
63027, 1.2434782608696, 0.41086956521739, 0.055555555555556
63028, 1.2869565217391, 0.41086956521739, 0.44444444444444
63029, 1.2869565217391, 0.41086956521739, 0.38888888888889
63030, 1.2869565217391, 0.41086956521739, 0.33333333333333
63031, 1.2869565217391, 0.41086956521739, 0.27777777777778
63032, 1.2869565217391, 0.41086956521739, 0.22222222222222
63033, 1.2869565217391, 0.41086956521739, 0.16666666666667
63034, 1.2869565217391, 0.41086956521739, 0.11111111111111
63035, 1.2869565217391, 0.41086956521739, 0.055555555555556
63036, 1.3304347826087, 0.41086956521739, 0.44444444444444
63037, 1.3304347826087, 0.41086956521739, 0.38888888888889
63038, 1.3304347826087, 0.41086956521739, 0.33333333333333
63039, 1.3304347826087, 0.41086956521739, 0.27777777777778
63040, 1.3304347826087, 0.41086956521739, 0.22222222222222
63041, 1.3304347826087, 0.41086956521739, 0.16666666666667
63042, 1.3304347826087, 0.41086956521739, 0.11111111111111
63043, 1.3304347826087, 0.41086956521739, 0.055555555555556
63044, 1.3739130434783, 0.41086956521739, 0.44444444444444
63045, 1.3739130434783, 0.41086956521739, 0.38888888888889
63046, 1.3739130434783, 0.41086956521739, 0.33333333333333
63047, 1.3739130434783, 0.41086956521739, 0.27777777777778
63048, 1.3739130434783, 0.41086956521739, 0.22222222222222
63049, 1.3739130434783, 0.41086956521739, 0.16666666666667
63050, 1.3739130434783, 0.41086956521739, 0.11111111111111
63051, 1.3739130434783, 0.41086956521739, 0.055555555555556
63052, 1.4173913043478, 0.41086956521739, 0.44444444444444
63053, 1.4173913043478, 0.41086956521739, 0.38888888888889
63054, 1.4173913043478, 0.41086956521739, 0.33333333333333
63055, 1.4173913043478, 0.41086956521739, 0.27777777777778
63056, 1.4173913043478, 0.41086956521739, 0.22222222222222
63057, 1.4173913043478, 0.41086956521739, 0.16666666666667
63058, 1.4173913043478, 0.41086956521739, 0.11111111111111
63059, 1.4173913043478, 0.41086956521739, 0.055555555555556
63060, 1.4608695652174, 0.41086956521739, 0.44444444444444
63061, 1.4608695652174, 0.41086956521739, 0.38888888888889
63062, 1.4608695652174, 0.41086956521739, 0.33333333333333
63063, 1.4608695652174, 0.41086956521739, 0.27777777777778
63064, 1.4608695652174, 0.41086956521739, 0.22222222222222
63065, 1.4608695652174, 0.41086956521739, 0.16666666666667
63066, 1.4608695652174, 0.41086956521739, 0.11111111111111
63067, 1.4608695652174, 0.41086956521739, 0.055555555555556
63068, 1.504347826087, 0.41086956521739, 0.44444444444444
63069, 1.504347826087, 0.41086956521739, 0.38888888888889
63070, 1.504347826087, 0.41086956521739, 0.33333333333333
63071, 1.504347826087, 0.41086956521739, 0.27777777777778
63072, 1.504347826087, 0.41086956521739, 0.22222222222222
63073, 1.504347826087, 0.41086956521739, 0.16666666666667
63074, 1.504347826087, 0.41086956521739, 0.11111111111111
63075, 1.504347826087, 0.41086956521739, 0.055555555555556
63076, 1.5478260869565, 0.41086956521739, 0.44444444444444
63077, 1.5478260869565, 0.41086956521739, 0.38888888888889
63078, 1.5478260869565, 0.41086956521739, 0.33333333333333
63079, 1.5478260869565, 0.41086956521739, 0.27777777777778
63080, 1.5478260869565, 0.41086956521739, 0.22222222222222
63081, 1.5478260869565, 0.41086956521739, 0.16666666666667
63082, 1.5478260869565, 0.41086956521739, 0.11111111111111
63083, 1.5478260869565, 0.41086956521739, 0.055555555555556
63084, 1.5913043478261, 0.41086956521739, 0.44444444444444
63085, 1.5913043478261, 0.41086956521739, 0.38888888888889
63086, 1.5913043478261, 0.41086956521739, 0.33333333333333
63087, 1.5913043478261, 0.41086956521739, 0.27777777777778
63088, 1.5913043478261, 0.41086956521739, 0.22222222222222
63089, 1.5913043478261, 0.41086956521739, 0.16666666666667
63090, 1.5913043478261, 0.41086956521739, 0.11111111111111
63091, 1.5913043478261, 0.41086956521739, 0.055555555555556
63092, 1.6347826086957, 0.41086956521739, 0.44444444444444
63093, 1.6347826086957, 0.41086956521739, 0.38888888888889
63094, 1.6347826086957, 0.41086956521739, 0.33333333333333
63095, 1.6347826086957, 0.41086956521739, 0.27777777777778
63096, 1.6347826086957, 0.41086956521739, 0.22222222222222
63097, 1.6347826086957, 0.41086956521739, 0.16666666666667
63098, 1.6347826086957, 0.41086956521739, 0.11111111111111
63099, 1.6347826086957, 0.41086956521739, 0.055555555555556
63100, 1.6782608695652, 0.41086956521739, 0.44444444444444
63101, 1.6782608695652, 0.41086956521739, 0.38888888888889
63102, 1.6782608695652, 0.41086956521739, 0.33333333333333
63103, 1.6782608695652, 0.41086956521739, 0.27777777777778
63104, 1.6782608695652, 0.41086956521739, 0.22222222222222
63105, 1.6782608695652, 0.41086956521739, 0.16666666666667
63106, 1.6782608695652, 0.41086956521739, 0.11111111111111
63107, 1.6782608695652, 0.41086956521739, 0.055555555555556
63108, 1.7217391304348, 0.41086956521739, 0.44444444444444
63109, 1.7217391304348, 0.41086956521739, 0.38888888888889
63110, 1.7217391304348, 0.41086956521739, 0.33333333333333
63111, 1.7217391304348, 0.41086956521739, 0.27777777777778
63112, 1.7217391304348, 0.41086956521739, 0.22222222222222
63113, 1.7217391304348, 0.41086956521739, 0.16666666666667
63114, 1.7217391304348, 0.41086956521739, 0.11111111111111
63115, 1.7217391304348, 0.41086956521739, 0.055555555555556
63116, 1.7652173913043, 0.41086956521739, 0.44444444444444
63117, 1.7652173913043, 0.41086956521739, 0.38888888888889
63118, 1.7652173913043, 0.41086956521739, 0.33333333333333
63119, 1.7652173913043, 0.41086956521739, 0.27777777777778
63120, 1.7652173913043, 0.41086956521739, 0.22222222222222
63121, 1.7652173913043, 0.41086956521739, 0.16666666666667
63122, 1.7652173913043, 0.41086956521739, 0.11111111111111
63123, 1.7652173913043, 0.41086956521739, 0.055555555555556
63124, 1.8086956521739, 0.41086956521739, 0.44444444444444
63125, 1.8086956521739, 0.41086956521739, 0.38888888888889
63126, 1.8086956521739, 0.41086956521739, 0.33333333333333
63127, 1.8086956521739, 0.41086956521739, 0.27777777777778
63128, 1.8086956521739, 0.41086956521739, 0.22222222222222
63129, 1.8086956521739, 0.41086956521739, 0.16666666666667
63130, 1.8086956521739, 0.41086956521739, 0.11111111111111
63131, 1.8086956521739, 0.41086956521739, 0.055555555555556
63132, 1.8521739130435, 0.41086956521739, 0.44444444444444
63133, 1.8521739130435, 0.41086956521739, 0.38888888888889
63134, 1.8521739130435, 0.41086956521739, 0.33333333333333
63135, 1.8521739130435, 0.41086956521739, 0.27777777777778
63136, 1.8521739130435, 0.41086956521739, 0.22222222222222
63137, 1.8521739130435, 0.41086956521739, 0.16666666666667
63138, 1.8521739130435, 0.41086956521739, 0.11111111111111
63139, 1.8521739130435, 0.41086956521739, 0.055555555555556
63140, 1.895652173913, 0.41086956521739, 0.44444444444444
63141, 1.895652173913, 0.41086956521739, 0.38888888888889
63142, 1.895652173913, 0.41086956521739, 0.33333333333333
63143, 1.895652173913, 0.41086956521739, 0.27777777777778
63144, 1.895652173913, 0.41086956521739, 0.22222222222222
63145, 1.895652173913, 0.41086956521739, 0.16666666666667
63146, 1.895652173913, 0.41086956521739, 0.11111111111111
63147, 1.895652173913, 0.41086956521739, 0.055555555555556
63148, 1.9391304347826, 0.41086956521739, 0.44444444444444
63149, 1.9391304347826, 0.41086956521739, 0.38888888888889
63150, 1.9391304347826, 0.41086956521739, 0.33333333333333
63151, 1.9391304347826, 0.41086956521739, 0.27777777777778
63152, 1.9391304347826, 0.41086956521739, 0.22222222222222
63153, 1.9391304347826, 0.41086956521739, 0.16666666666667
63154, 1.9391304347826, 0.41086956521739, 0.11111111111111
63155, 1.9391304347826, 0.41086956521739, 0.055555555555556
63156, 1.9826086956522, 0.41086956521739, 0.44444444444444
63157, 1.9826086956522, 0.41086956521739, 0.38888888888889
63158, 1.9826086956522, 0.41086956521739, 0.33333333333333
63159, 1.9826086956522, 0.41086956521739, 0.27777777777778
63160, 1.9826086956522, 0.41086956521739, 0.22222222222222
63161, 1.9826086956522, 0.41086956521739, 0.16666666666667
63162, 1.9826086956522, 0.41086956521739, 0.11111111111111
63163, 1.9826086956522, 0.41086956521739, 0.055555555555556
63164, 2.0260869565217, 0.41086956521739, 0.44444444444444
63165, 2.0260869565217, 0.41086956521739, 0.38888888888889
63166, 2.0260869565217, 0.41086956521739, 0.33333333333333
63167, 2.0260869565217, 0.41086956521739, 0.27777777777778
63168, 2.0260869565217, 0.41086956521739, 0.22222222222222
63169, 2.0260869565217, 0.41086956521739, 0.16666666666667
63170, 2.0260869565217, 0.41086956521739, 0.11111111111111
63171, 2.0260869565217, 0.41086956521739, 0.055555555555556
63172, 2.0695652173913, 0.41086956521739, 0.44444444444444
63173, 2.0695652173913, 0.41086956521739, 0.38888888888889
63174, 2.0695652173913, 0.41086956521739, 0.33333333333333
63175, 2.0695652173913, 0.41086956521739, 0.27777777777778
63176, 2.0695652173913, 0.41086956521739, 0.22222222222222
63177, 2.0695652173913, 0.41086956521739, 0.16666666666667
63178, 2.0695652173913, 0.41086956521739, 0.11111111111111
63179, 2.0695652173913, 0.41086956521739, 0.055555555555556
63180, 2.1130434782609, 0.41086956521739, 0.44444444444444
63181, 2.1130434782609, 0.41086956521739, 0.38888888888889
63182, 2.1130434782609, 0.41086956521739, 0.33333333333333
63183, 2.1130434782609, 0.41086956521739, 0.27777777777778
63184, 2.1130434782609, 0.41086956521739, 0.22222222222222
63185, 2.1130434782609, 0.41086956521739, 0.16666666666667
63186, 2.1130434782609, 0.41086956521739, 0.11111111111111
63187, 2.1130434782609, 0.41086956521739, 0.055555555555556
63188, 2.1565217391304, 0.41086956521739, 0.44444444444444
63189, 2.1565217391304, 0.41086956521739, 0.38888888888889
63190, 2.1565217391304, 0.41086956521739, 0.33333333333333
63191, 2.1565217391304, 0.41086956521739, 0.27777777777778
63192, 2.1565217391304, 0.41086956521739, 0.22222222222222
63193, 2.1565217391304, 0.41086956521739, 0.16666666666667
63194, 2.1565217391304, 0.41086956521739, 0.11111111111111
63195, 2.1565217391304, 0.41086956521739, 0.055555555555556
63196, 1.2434782608696, 0.35869565217391, 0.44444444444444
63197, 1.2434782608696, 0.35869565217391, 0.38888888888889
63198, 1.2434782608696, 0.35869565217391, 0.33333333333333
63199, 1.2434782608696, 0.35869565217391, 0.27777777777778
63200, 1.2434782608696, 0.35869565217391, 0.22222222222222
63201, 1.2434782608696, 0.35869565217391, 0.16666666666667
63202, 1.2434782608696, 0.35869565217391, 0.11111111111111
63203, 1.2434782608696, 0.35869565217391, 0.055555555555556
63204, 1.2869565217391, 0.35869565217391, 0.44444444444444
63205, 1.2869565217391, 0.35869565217391, 0.38888888888889
63206, 1.2869565217391, 0.35869565217391, 0.33333333333333
63207, 1.2869565217391, 0.35869565217391, 0.27777777777778
63208, 1.2869565217391, 0.35869565217391, 0.22222222222222
63209, 1.2869565217391, 0.35869565217391, 0.16666666666667
63210, 1.2869565217391, 0.35869565217391, 0.11111111111111
63211, 1.2869565217391, 0.35869565217391, 0.055555555555556
63212, 1.3304347826087, 0.35869565217391, 0.44444444444444
63213, 1.3304347826087, 0.35869565217391, 0.38888888888889
63214, 1.3304347826087, 0.35869565217391, 0.33333333333333
63215, 1.3304347826087, 0.35869565217391, 0.27777777777778
63216, 1.3304347826087, 0.35869565217391, 0.22222222222222
63217, 1.3304347826087, 0.35869565217391, 0.16666666666667
63218, 1.3304347826087, 0.35869565217391, 0.11111111111111
63219, 1.3304347826087, 0.35869565217391, 0.055555555555556
63220, 1.3739130434783, 0.35869565217391, 0.44444444444444
63221, 1.3739130434783, 0.35869565217391, 0.38888888888889
63222, 1.3739130434783, 0.35869565217391, 0.33333333333333
63223, 1.3739130434783, 0.35869565217391, 0.27777777777778
63224, 1.3739130434783, 0.35869565217391, 0.22222222222222
63225, 1.3739130434783, 0.35869565217391, 0.16666666666667
63226, 1.3739130434783, 0.35869565217391, 0.11111111111111
63227, 1.3739130434783, 0.35869565217391, 0.055555555555556
63228, 1.4173913043478, 0.35869565217391, 0.44444444444444
63229, 1.4173913043478, 0.35869565217391, 0.38888888888889
63230, 1.4173913043478, 0.35869565217391, 0.33333333333333
63231, 1.4173913043478, 0.35869565217391, 0.27777777777778
63232, 1.4173913043478, 0.35869565217391, 0.22222222222222
63233, 1.4173913043478, 0.35869565217391, 0.16666666666667
63234, 1.4173913043478, 0.35869565217391, 0.11111111111111
63235, 1.4173913043478, 0.35869565217391, 0.055555555555556
63236, 1.4608695652174, 0.35869565217391, 0.44444444444444
63237, 1.4608695652174, 0.35869565217391, 0.38888888888889
63238, 1.4608695652174, 0.35869565217391, 0.33333333333333
63239, 1.4608695652174, 0.35869565217391, 0.27777777777778
63240, 1.4608695652174, 0.35869565217391, 0.22222222222222
63241, 1.4608695652174, 0.35869565217391, 0.16666666666667
63242, 1.4608695652174, 0.35869565217391, 0.11111111111111
63243, 1.4608695652174, 0.35869565217391, 0.055555555555556
63244, 1.504347826087, 0.35869565217391, 0.44444444444444
63245, 1.504347826087, 0.35869565217391, 0.38888888888889
63246, 1.504347826087, 0.35869565217391, 0.33333333333333
63247, 1.504347826087, 0.35869565217391, 0.27777777777778
63248, 1.504347826087, 0.35869565217391, 0.22222222222222
63249, 1.504347826087, 0.35869565217391, 0.16666666666667
63250, 1.504347826087, 0.35869565217391, 0.11111111111111
63251, 1.504347826087, 0.35869565217391, 0.055555555555556
63252, 1.5478260869565, 0.35869565217391, 0.44444444444444
63253, 1.5478260869565, 0.35869565217391, 0.38888888888889
63254, 1.5478260869565, 0.35869565217391, 0.33333333333333
63255, 1.5478260869565, 0.35869565217391, 0.27777777777778
63256, 1.5478260869565, 0.35869565217391, 0.22222222222222
63257, 1.5478260869565, 0.35869565217391, 0.16666666666667
63258, 1.5478260869565, 0.35869565217391, 0.11111111111111
63259, 1.5478260869565, 0.35869565217391, 0.055555555555556
63260, 1.5913043478261, 0.35869565217391, 0.44444444444444
63261, 1.5913043478261, 0.35869565217391, 0.38888888888889
63262, 1.5913043478261, 0.35869565217391, 0.33333333333333
63263, 1.5913043478261, 0.35869565217391, 0.27777777777778
63264, 1.5913043478261, 0.35869565217391, 0.22222222222222
63265, 1.5913043478261, 0.35869565217391, 0.16666666666667
63266, 1.5913043478261, 0.35869565217391, 0.11111111111111
63267, 1.5913043478261, 0.35869565217391, 0.055555555555556
63268, 1.6347826086957, 0.35869565217391, 0.44444444444444
63269, 1.6347826086957, 0.35869565217391, 0.38888888888889
63270, 1.6347826086957, 0.35869565217391, 0.33333333333333
63271, 1.6347826086957, 0.35869565217391, 0.27777777777778
63272, 1.6347826086957, 0.35869565217391, 0.22222222222222
63273, 1.6347826086957, 0.35869565217391, 0.16666666666667
63274, 1.6347826086957, 0.35869565217391, 0.11111111111111
63275, 1.6347826086957, 0.35869565217391, 0.055555555555556
63276, 1.6782608695652, 0.35869565217391, 0.44444444444444
63277, 1.6782608695652, 0.35869565217391, 0.38888888888889
63278, 1.6782608695652, 0.35869565217391, 0.33333333333333
63279, 1.6782608695652, 0.35869565217391, 0.27777777777778
63280, 1.6782608695652, 0.35869565217391, 0.22222222222222
63281, 1.6782608695652, 0.35869565217391, 0.16666666666667
63282, 1.6782608695652, 0.35869565217391, 0.11111111111111
63283, 1.6782608695652, 0.35869565217391, 0.055555555555556
63284, 1.7217391304348, 0.35869565217391, 0.44444444444444
63285, 1.7217391304348, 0.35869565217391, 0.38888888888889
63286, 1.7217391304348, 0.35869565217391, 0.33333333333333
63287, 1.7217391304348, 0.35869565217391, 0.27777777777778
63288, 1.7217391304348, 0.35869565217391, 0.22222222222222
63289, 1.7217391304348, 0.35869565217391, 0.16666666666667
63290, 1.7217391304348, 0.35869565217391, 0.11111111111111
63291, 1.7217391304348, 0.35869565217391, 0.055555555555556
63292, 1.7652173913043, 0.35869565217391, 0.44444444444444
63293, 1.7652173913043, 0.35869565217391, 0.38888888888889
63294, 1.7652173913043, 0.35869565217391, 0.33333333333333
63295, 1.7652173913043, 0.35869565217391, 0.27777777777778
63296, 1.7652173913043, 0.35869565217391, 0.22222222222222
63297, 1.7652173913043, 0.35869565217391, 0.16666666666667
63298, 1.7652173913043, 0.35869565217391, 0.11111111111111
63299, 1.7652173913043, 0.35869565217391, 0.055555555555556
63300, 1.8086956521739, 0.35869565217391, 0.44444444444444
63301, 1.8086956521739, 0.35869565217391, 0.38888888888889
63302, 1.8086956521739, 0.35869565217391, 0.33333333333333
63303, 1.8086956521739, 0.35869565217391, 0.27777777777778
63304, 1.8086956521739, 0.35869565217391, 0.22222222222222
63305, 1.8086956521739, 0.35869565217391, 0.16666666666667
63306, 1.8086956521739, 0.35869565217391, 0.11111111111111
63307, 1.8086956521739, 0.35869565217391, 0.055555555555556
63308, 1.8521739130435, 0.35869565217391, 0.44444444444444
63309, 1.8521739130435, 0.35869565217391, 0.38888888888889
63310, 1.8521739130435, 0.35869565217391, 0.33333333333333
63311, 1.8521739130435, 0.35869565217391, 0.27777777777778
63312, 1.8521739130435, 0.35869565217391, 0.22222222222222
63313, 1.8521739130435, 0.35869565217391, 0.16666666666667
63314, 1.8521739130435, 0.35869565217391, 0.11111111111111
63315, 1.8521739130435, 0.35869565217391, 0.055555555555556
63316, 1.895652173913, 0.35869565217391, 0.44444444444444
63317, 1.895652173913, 0.35869565217391, 0.38888888888889
63318, 1.895652173913, 0.35869565217391, 0.33333333333333
63319, 1.895652173913, 0.35869565217391, 0.27777777777778
63320, 1.895652173913, 0.35869565217391, 0.22222222222222
63321, 1.895652173913, 0.35869565217391, 0.16666666666667
63322, 1.895652173913, 0.35869565217391, 0.11111111111111
63323, 1.895652173913, 0.35869565217391, 0.055555555555556
63324, 1.9391304347826, 0.35869565217391, 0.44444444444444
63325, 1.9391304347826, 0.35869565217391, 0.38888888888889
63326, 1.9391304347826, 0.35869565217391, 0.33333333333333
63327, 1.9391304347826, 0.35869565217391, 0.27777777777778
63328, 1.9391304347826, 0.35869565217391, 0.22222222222222
63329, 1.9391304347826, 0.35869565217391, 0.16666666666667
63330, 1.9391304347826, 0.35869565217391, 0.11111111111111
63331, 1.9391304347826, 0.35869565217391, 0.055555555555556
63332, 1.9826086956522, 0.35869565217391, 0.44444444444444
63333, 1.9826086956522, 0.35869565217391, 0.38888888888889
63334, 1.9826086956522, 0.35869565217391, 0.33333333333333
63335, 1.9826086956522, 0.35869565217391, 0.27777777777778
63336, 1.9826086956522, 0.35869565217391, 0.22222222222222
63337, 1.9826086956522, 0.35869565217391, 0.16666666666667
63338, 1.9826086956522, 0.35869565217391, 0.11111111111111
63339, 1.9826086956522, 0.35869565217391, 0.055555555555556
63340, 2.0260869565217, 0.35869565217391, 0.44444444444444
63341, 2.0260869565217, 0.35869565217391, 0.38888888888889
63342, 2.0260869565217, 0.35869565217391, 0.33333333333333
63343, 2.0260869565217, 0.35869565217391, 0.27777777777778
63344, 2.0260869565217, 0.35869565217391, 0.22222222222222
63345, 2.0260869565217, 0.35869565217391, 0.16666666666667
63346, 2.0260869565217, 0.35869565217391, 0.11111111111111
63347, 2.0260869565217, 0.35869565217391, 0.055555555555556
63348, 2.0695652173913, 0.35869565217391, 0.44444444444444
63349, 2.0695652173913, 0.35869565217391, 0.38888888888889
63350, 2.0695652173913, 0.35869565217391, 0.33333333333333
63351, 2.0695652173913, 0.35869565217391, 0.27777777777778
63352, 2.0695652173913, 0.35869565217391, 0.22222222222222
63353, 2.0695652173913, 0.35869565217391, 0.16666666666667
63354, 2.0695652173913, 0.35869565217391, 0.11111111111111
63355, 2.0695652173913, 0.35869565217391, 0.055555555555556
63356, 2.1130434782609, 0.35869565217391, 0.44444444444444
63357, 2.1130434782609, 0.35869565217391, 0.38888888888889
63358, 2.1130434782609, 0.35869565217391, 0.33333333333333
63359, 2.1130434782609, 0.35869565217391, 0.27777777777778
63360, 2.1130434782609, 0.35869565217391, 0.22222222222222
63361, 2.1130434782609, 0.35869565217391, 0.16666666666667
63362, 2.1130434782609, 0.35869565217391, 0.11111111111111
63363, 2.1130434782609, 0.35869565217391, 0.055555555555556
63364, 2.1565217391304, 0.35869565217391, 0.44444444444444
63365, 2.1565217391304, 0.35869565217391, 0.38888888888889
63366, 2.1565217391304, 0.35869565217391, 0.33333333333333
63367, 2.1565217391304, 0.35869565217391, 0.27777777777778
63368, 2.1565217391304, 0.35869565217391, 0.22222222222222
63369, 2.1565217391304, 0.35869565217391, 0.16666666666667
63370, 2.1565217391304, 0.35869565217391, 0.11111111111111
63371, 2.1565217391304, 0.35869565217391, 0.055555555555556
63372, 1.2434782608696, 0.30652173913044, 0.44444444444444
63373, 1.2434782608696, 0.30652173913044, 0.38888888888889
63374, 1.2434782608696, 0.30652173913044, 0.33333333333333
63375, 1.2434782608696, 0.30652173913044, 0.27777777777778
63376, 1.2434782608696, 0.30652173913044, 0.22222222222222
63377, 1.2434782608696, 0.30652173913044, 0.16666666666667
63378, 1.2434782608696, 0.30652173913044, 0.11111111111111
63379, 1.2434782608696, 0.30652173913044, 0.055555555555556
63380, 1.2869565217391, 0.30652173913043, 0.44444444444444
63381, 1.2869565217391, 0.30652173913043, 0.38888888888889
63382, 1.2869565217391, 0.30652173913043, 0.33333333333333
63383, 1.2869565217391, 0.30652173913043, 0.27777777777778
63384, 1.2869565217391, 0.30652173913043, 0.22222222222222
63385, 1.2869565217391, 0.30652173913043, 0.16666666666667
63386, 1.2869565217391, 0.30652173913043, 0.11111111111111
63387, 1.2869565217391, 0.30652173913043, 0.055555555555556
63388, 1.3304347826087, 0.30652173913043, 0.44444444444444
63389, 1.3304347826087, 0.30652173913043, 0.38888888888889
63390, 1.3304347826087, 0.30652173913044, 0.33333333333333
63391, 1.3304347826087, 0.30652173913043, 0.27777777777778
63392, 1.3304347826087, 0.30652173913043, 0.22222222222222
63393, 1.3304347826087, 0.30652173913043, 0.16666666666667
63394, 1.3304347826087, 0.30652173913043, 0.11111111111111
63395, 1.3304347826087, 0.30652173913043, 0.055555555555556
63396, 1.3739130434783, 0.30652173913044, 0.44444444444444
63397, 1.3739130434783, 0.30652173913044, 0.38888888888889
63398, 1.3739130434783, 0.30652173913044, 0.33333333333333
63399, 1.3739130434783, 0.30652173913044, 0.27777777777778
63400, 1.3739130434783, 0.30652173913044, 0.22222222222222
63401, 1.3739130434783, 0.30652173913044, 0.16666666666667
63402, 1.3739130434783, 0.30652173913044, 0.11111111111111
63403, 1.3739130434783, 0.30652173913044, 0.055555555555556
63404, 1.4173913043478, 0.30652173913044, 0.44444444444444
63405, 1.4173913043478, 0.30652173913044, 0.38888888888889
63406, 1.4173913043478, 0.30652173913044, 0.33333333333333
63407, 1.4173913043478, 0.30652173913044, 0.27777777777778
63408, 1.4173913043478, 0.30652173913044, 0.22222222222222
63409, 1.4173913043478, 0.30652173913044, 0.16666666666667
63410, 1.4173913043478, 0.30652173913044, 0.11111111111111
63411, 1.4173913043478, 0.30652173913044, 0.055555555555556
63412, 1.4608695652174, 0.30652173913043, 0.44444444444444
63413, 1.4608695652174, 0.30652173913043, 0.38888888888889
63414, 1.4608695652174, 0.30652173913044, 0.33333333333333
63415, 1.4608695652174, 0.30652173913043, 0.27777777777778
63416, 1.4608695652174, 0.30652173913043, 0.22222222222222
63417, 1.4608695652174, 0.30652173913043, 0.16666666666667
63418, 1.4608695652174, 0.30652173913043, 0.11111111111111
63419, 1.4608695652174, 0.30652173913043, 0.055555555555556
63420, 1.504347826087, 0.30652173913044, 0.44444444444444
63421, 1.504347826087, 0.30652173913044, 0.38888888888889
63422, 1.504347826087, 0.30652173913044, 0.33333333333333
63423, 1.504347826087, 0.30652173913044, 0.27777777777778
63424, 1.504347826087, 0.30652173913044, 0.22222222222222
63425, 1.504347826087, 0.30652173913044, 0.16666666666667
63426, 1.504347826087, 0.30652173913044, 0.11111111111111
63427, 1.504347826087, 0.30652173913044, 0.055555555555556
63428, 1.5478260869565, 0.30652173913044, 0.44444444444444
63429, 1.5478260869565, 0.30652173913044, 0.38888888888889
63430, 1.5478260869565, 0.30652173913044, 0.33333333333333
63431, 1.5478260869565, 0.30652173913044, 0.27777777777778
63432, 1.5478260869565, 0.30652173913044, 0.22222222222222
63433, 1.5478260869565, 0.30652173913044, 0.16666666666667
63434, 1.5478260869565, 0.30652173913044, 0.11111111111111
63435, 1.5478260869565, 0.30652173913044, 0.055555555555556
63436, 1.5913043478261, 0.30652173913044, 0.44444444444444
63437, 1.5913043478261, 0.30652173913044, 0.38888888888889
63438, 1.5913043478261, 0.30652173913044, 0.33333333333333
63439, 1.5913043478261, 0.30652173913044, 0.27777777777778
63440, 1.5913043478261, 0.30652173913044, 0.22222222222222
63441, 1.5913043478261, 0.30652173913044, 0.16666666666667
63442, 1.5913043478261, 0.30652173913043, 0.11111111111111
63443, 1.5913043478261, 0.30652173913044, 0.055555555555556
63444, 1.6347826086957, 0.30652173913043, 0.44444444444444
63445, 1.6347826086957, 0.30652173913043, 0.38888888888889
63446, 1.6347826086957, 0.30652173913044, 0.33333333333333
63447, 1.6347826086957, 0.30652173913043, 0.27777777777778
63448, 1.6347826086957, 0.30652173913043, 0.22222222222222
63449, 1.6347826086957, 0.30652173913043, 0.16666666666667
63450, 1.6347826086957, 0.30652173913043, 0.11111111111111
63451, 1.6347826086957, 0.30652173913043, 0.055555555555556
63452, 1.6782608695652, 0.30652173913043, 0.44444444444444
63453, 1.6782608695652, 0.30652173913043, 0.38888888888889
63454, 1.6782608695652, 0.30652173913044, 0.33333333333333
63455, 1.6782608695652, 0.30652173913043, 0.27777777777778
63456, 1.6782608695652, 0.30652173913043, 0.22222222222222
63457, 1.6782608695652, 0.30652173913043, 0.16666666666667
63458, 1.6782608695652, 0.30652173913043, 0.11111111111111
63459, 1.6782608695652, 0.30652173913043, 0.055555555555556
63460, 1.7217391304348, 0.30652173913043, 0.44444444444444
63461, 1.7217391304348, 0.30652173913043, 0.38888888888889
63462, 1.7217391304348, 0.30652173913044, 0.33333333333333
63463, 1.7217391304348, 0.30652173913043, 0.27777777777778
63464, 1.7217391304348, 0.30652173913043, 0.22222222222222
63465, 1.7217391304348, 0.30652173913043, 0.16666666666667
63466, 1.7217391304348, 0.30652173913043, 0.11111111111111
63467, 1.7217391304348, 0.30652173913043, 0.055555555555556
63468, 1.7652173913043, 0.30652173913043, 0.44444444444444
63469, 1.7652173913043, 0.30652173913043, 0.38888888888889
63470, 1.7652173913043, 0.30652173913044, 0.33333333333333
63471, 1.7652173913043, 0.30652173913043, 0.27777777777778
63472, 1.7652173913043, 0.30652173913043, 0.22222222222222
63473, 1.7652173913043, 0.30652173913043, 0.16666666666667
63474, 1.7652173913043, 0.30652173913043, 0.11111111111111
63475, 1.7652173913043, 0.30652173913043, 0.055555555555556
63476, 1.8086956521739, 0.30652173913044, 0.44444444444444
63477, 1.8086956521739, 0.30652173913044, 0.38888888888889
63478, 1.8086956521739, 0.30652173913044, 0.33333333333333
63479, 1.8086956521739, 0.30652173913044, 0.27777777777778
63480, 1.8086956521739, 0.30652173913044, 0.22222222222222
63481, 1.8086956521739, 0.30652173913044, 0.16666666666667
63482, 1.8086956521739, 0.30652173913044, 0.11111111111111
63483, 1.8086956521739, 0.30652173913044, 0.055555555555556
63484, 1.8521739130435, 0.30652173913043, 0.44444444444444
63485, 1.8521739130435, 0.30652173913043, 0.38888888888889
63486, 1.8521739130435, 0.30652173913043, 0.33333333333333
63487, 1.8521739130435, 0.30652173913043, 0.27777777777778
63488, 1.8521739130435, 0.30652173913043, 0.22222222222222
63489, 1.8521739130435, 0.30652173913043, 0.16666666666667
63490, 1.8521739130435, 0.30652173913043, 0.11111111111111
63491, 1.8521739130435, 0.30652173913043, 0.055555555555556
63492, 1.895652173913, 0.30652173913044, 0.44444444444444
63493, 1.895652173913, 0.30652173913044, 0.38888888888889
63494, 1.895652173913, 0.30652173913044, 0.33333333333333
63495, 1.895652173913, 0.30652173913044, 0.27777777777778
63496, 1.895652173913, 0.30652173913044, 0.22222222222222
63497, 1.895652173913, 0.30652173913044, 0.16666666666667
63498, 1.895652173913, 0.30652173913044, 0.11111111111111
63499, 1.895652173913, 0.30652173913044, 0.055555555555556
63500, 1.9391304347826, 0.30652173913043, 0.44444444444444
63501, 1.9391304347826, 0.30652173913043, 0.38888888888889
63502, 1.9391304347826, 0.30652173913044, 0.33333333333333
63503, 1.9391304347826, 0.30652173913043, 0.27777777777778
63504, 1.9391304347826, 0.30652173913043, 0.22222222222222
63505, 1.9391304347826, 0.30652173913043, 0.16666666666667
63506, 1.9391304347826, 0.30652173913043, 0.11111111111111
63507, 1.9391304347826, 0.30652173913043, 0.055555555555556
63508, 1.9826086956522, 0.30652173913044, 0.44444444444444
63509, 1.9826086956522, 0.30652173913044, 0.38888888888889
63510, 1.9826086956522, 0.30652173913044, 0.33333333333333
63511, 1.9826086956522, 0.30652173913044, 0.27777777777778
63512, 1.9826086956522, 0.30652173913044, 0.22222222222222
63513, 1.9826086956522, 0.30652173913044, 0.16666666666667
63514, 1.9826086956522, 0.30652173913044, 0.11111111111111
63515, 1.9826086956522, 0.30652173913044, 0.055555555555556
63516, 2.0260869565217, 0.30652173913044, 0.44444444444444
63517, 2.0260869565217, 0.30652173913044, 0.38888888888889
63518, 2.0260869565217, 0.30652173913044, 0.33333333333333
63519, 2.0260869565217, 0.30652173913044, 0.27777777777778
63520, 2.0260869565217, 0.30652173913044, 0.22222222222222
63521, 2.0260869565217, 0.30652173913044, 0.16666666666667
63522, 2.0260869565217, 0.30652173913044, 0.11111111111111
63523, 2.0260869565217, 0.30652173913044, 0.055555555555556
63524, 2.0695652173913, 0.30652173913043, 0.44444444444444
63525, 2.0695652173913, 0.30652173913043, 0.38888888888889
63526, 2.0695652173913, 0.30652173913044, 0.33333333333333
63527, 2.0695652173913, 0.30652173913043, 0.27777777777778
63528, 2.0695652173913, 0.30652173913043, 0.22222222222222
63529, 2.0695652173913, 0.30652173913043, 0.16666666666667
63530, 2.0695652173913, 0.30652173913043, 0.11111111111111
63531, 2.0695652173913, 0.30652173913043, 0.055555555555556
63532, 2.1130434782609, 0.30652173913043, 0.44444444444444
63533, 2.1130434782609, 0.30652173913043, 0.38888888888889
63534, 2.1130434782609, 0.30652173913044, 0.33333333333333
63535, 2.1130434782609, 0.30652173913043, 0.27777777777778
63536, 2.1130434782609, 0.30652173913043, 0.22222222222222
63537, 2.1130434782609, 0.30652173913043, 0.16666666666667
63538, 2.1130434782609, 0.30652173913043, 0.11111111111111
63539, 2.1130434782609, 0.30652173913043, 0.055555555555556
63540, 2.1565217391304, 0.30652173913044, 0.44444444444444
63541, 2.1565217391304, 0.30652173913043, 0.38888888888889
63542, 2.1565217391304, 0.30652173913044, 0.33333333333333
63543, 2.1565217391304, 0.30652173913043, 0.27777777777778
63544, 2.1565217391304, 0.30652173913043, 0.22222222222222
63545, 2.1565217391304, 0.30652173913043, 0.16666666666667
63546, 2.1565217391304, 0.30652173913043, 0.11111111111111
63547, 2.1565217391304, 0.30652173913043, 0.055555555555556
63548, 1.2434782608696, 0.25434782608696, 0.44444444444444
63549, 1.2434782608696, 0.25434782608696, 0.38888888888889
63550, 1.2434782608696, 0.25434782608696, 0.33333333333333
63551, 1.2434782608696, 0.25434782608696, 0.27777777777778
63552, 1.2434782608696, 0.25434782608696, 0.22222222222222
63553, 1.2434782608696, 0.25434782608696, 0.16666666666667
63554, 1.2434782608696, 0.25434782608696, 0.11111111111111
63555, 1.2434782608696, 0.25434782608696, 0.055555555555556
63556, 1.2869565217391, 0.25434782608696, 0.44444444444444
63557, 1.2869565217391, 0.25434782608696, 0.38888888888889
63558, 1.2869565217391, 0.25434782608696, 0.33333333333333
63559, 1.2869565217391, 0.25434782608696, 0.27777777777778
63560, 1.2869565217391, 0.25434782608696, 0.22222222222222
63561, 1.2869565217391, 0.25434782608696, 0.16666666666667
63562, 1.2869565217391, 0.25434782608696, 0.11111111111111
63563, 1.2869565217391, 0.25434782608696, 0.055555555555556
63564, 1.3304347826087, 0.25434782608696, 0.44444444444444
63565, 1.3304347826087, 0.25434782608696, 0.38888888888889
63566, 1.3304347826087, 0.25434782608696, 0.33333333333333
63567, 1.3304347826087, 0.25434782608696, 0.27777777777778
63568, 1.3304347826087, 0.25434782608696, 0.22222222222222
63569, 1.3304347826087, 0.25434782608696, 0.16666666666667
63570, 1.3304347826087, 0.25434782608696, 0.11111111111111
63571, 1.3304347826087, 0.25434782608696, 0.055555555555556
63572, 1.3739130434783, 0.25434782608696, 0.44444444444444
63573, 1.3739130434783, 0.25434782608696, 0.38888888888889
63574, 1.3739130434783, 0.25434782608696, 0.33333333333333
63575, 1.3739130434783, 0.25434782608696, 0.27777777777778
63576, 1.3739130434783, 0.25434782608696, 0.22222222222222
63577, 1.3739130434783, 0.25434782608696, 0.16666666666667
63578, 1.3739130434783, 0.25434782608696, 0.11111111111111
63579, 1.3739130434783, 0.25434782608696, 0.055555555555556
63580, 1.4173913043478, 0.25434782608696, 0.44444444444444
63581, 1.4173913043478, 0.25434782608696, 0.38888888888889
63582, 1.4173913043478, 0.25434782608696, 0.33333333333333
63583, 1.4173913043478, 0.25434782608696, 0.27777777777778
63584, 1.4173913043478, 0.25434782608696, 0.22222222222222
63585, 1.4173913043478, 0.25434782608696, 0.16666666666667
63586, 1.4173913043478, 0.25434782608696, 0.11111111111111
63587, 1.4173913043478, 0.25434782608696, 0.055555555555556
63588, 1.4608695652174, 0.25434782608696, 0.44444444444444
63589, 1.4608695652174, 0.25434782608696, 0.38888888888889
63590, 1.4608695652174, 0.25434782608696, 0.33333333333333
63591, 1.4608695652174, 0.25434782608696, 0.27777777777778
63592, 1.4608695652174, 0.25434782608696, 0.22222222222222
63593, 1.4608695652174, 0.25434782608696, 0.16666666666667
63594, 1.4608695652174, 0.25434782608696, 0.11111111111111
63595, 1.4608695652174, 0.25434782608696, 0.055555555555556
63596, 1.504347826087, 0.25434782608696, 0.44444444444444
63597, 1.504347826087, 0.25434782608696, 0.38888888888889
