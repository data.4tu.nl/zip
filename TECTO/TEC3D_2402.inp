60190, 2.1130434782609, 1.2978260869565, 0.33333333333333
60191, 2.1130434782609, 1.2978260869565, 0.27777777777778
60192, 2.1130434782609, 1.2978260869565, 0.22222222222222
60193, 2.1130434782609, 1.2978260869565, 0.16666666666667
60194, 2.1130434782609, 1.2978260869565, 0.11111111111111
60195, 2.1130434782609, 1.2978260869565, 0.055555555555556
60196, 2.1565217391304, 1.2978260869565, 0.44444444444444
60197, 2.1565217391304, 1.2978260869565, 0.38888888888889
60198, 2.1565217391304, 1.2978260869565, 0.33333333333333
60199, 2.1565217391304, 1.2978260869565, 0.27777777777778
60200, 2.1565217391304, 1.2978260869565, 0.22222222222222
60201, 2.1565217391304, 1.2978260869565, 0.16666666666667
60202, 2.1565217391304, 1.2978260869565, 0.11111111111111
60203, 2.1565217391304, 1.2978260869565, 0.055555555555556
60204, 1.2434782608696, 1.245652173913, 0.44444444444444
60205, 1.2434782608696, 1.245652173913, 0.38888888888889
60206, 1.2434782608696, 1.245652173913, 0.33333333333333
60207, 1.2434782608696, 1.245652173913, 0.27777777777778
60208, 1.2434782608696, 1.245652173913, 0.22222222222222
60209, 1.2434782608696, 1.245652173913, 0.16666666666667
60210, 1.2434782608696, 1.245652173913, 0.11111111111111
60211, 1.2434782608696, 1.245652173913, 0.055555555555556
60212, 1.2869565217391, 1.245652173913, 0.44444444444444
60213, 1.2869565217391, 1.245652173913, 0.38888888888889
60214, 1.2869565217391, 1.245652173913, 0.33333333333333
60215, 1.2869565217391, 1.245652173913, 0.27777777777778
60216, 1.2869565217391, 1.245652173913, 0.22222222222222
60217, 1.2869565217391, 1.245652173913, 0.16666666666667
60218, 1.2869565217391, 1.245652173913, 0.11111111111111
60219, 1.2869565217391, 1.245652173913, 0.055555555555556
60220, 1.3304347826087, 1.245652173913, 0.44444444444444
60221, 1.3304347826087, 1.245652173913, 0.38888888888889
60222, 1.3304347826087, 1.245652173913, 0.33333333333333
60223, 1.3304347826087, 1.245652173913, 0.27777777777778
60224, 1.3304347826087, 1.245652173913, 0.22222222222222
60225, 1.3304347826087, 1.245652173913, 0.16666666666667
60226, 1.3304347826087, 1.245652173913, 0.11111111111111
60227, 1.3304347826087, 1.245652173913, 0.055555555555556
60228, 1.3739130434783, 1.245652173913, 0.44444444444444
60229, 1.3739130434783, 1.245652173913, 0.38888888888889
60230, 1.3739130434783, 1.245652173913, 0.33333333333333
60231, 1.3739130434783, 1.245652173913, 0.27777777777778
60232, 1.3739130434783, 1.245652173913, 0.22222222222222
60233, 1.3739130434783, 1.245652173913, 0.16666666666667
60234, 1.3739130434783, 1.245652173913, 0.11111111111111
60235, 1.3739130434783, 1.245652173913, 0.055555555555556
60236, 1.4173913043478, 1.245652173913, 0.44444444444444
60237, 1.4173913043478, 1.245652173913, 0.38888888888889
60238, 1.4173913043478, 1.245652173913, 0.33333333333333
60239, 1.4173913043478, 1.245652173913, 0.27777777777778
60240, 1.4173913043478, 1.245652173913, 0.22222222222222
60241, 1.4173913043478, 1.245652173913, 0.16666666666667
60242, 1.4173913043478, 1.245652173913, 0.11111111111111
60243, 1.4173913043478, 1.245652173913, 0.055555555555556
60244, 1.4608695652174, 1.245652173913, 0.44444444444444
60245, 1.4608695652174, 1.245652173913, 0.38888888888889
60246, 1.4608695652174, 1.245652173913, 0.33333333333333
60247, 1.4608695652174, 1.245652173913, 0.27777777777778
60248, 1.4608695652174, 1.245652173913, 0.22222222222222
60249, 1.4608695652174, 1.245652173913, 0.16666666666667
60250, 1.4608695652174, 1.245652173913, 0.11111111111111
60251, 1.4608695652174, 1.245652173913, 0.055555555555556
60252, 1.504347826087, 1.245652173913, 0.44444444444444
60253, 1.504347826087, 1.245652173913, 0.38888888888889
60254, 1.504347826087, 1.245652173913, 0.33333333333333
60255, 1.504347826087, 1.245652173913, 0.27777777777778
60256, 1.504347826087, 1.245652173913, 0.22222222222222
60257, 1.504347826087, 1.245652173913, 0.16666666666667
60258, 1.504347826087, 1.245652173913, 0.11111111111111
60259, 1.504347826087, 1.245652173913, 0.055555555555556
60260, 1.5478260869565, 1.245652173913, 0.44444444444444
60261, 1.5478260869565, 1.245652173913, 0.38888888888889
60262, 1.5478260869565, 1.245652173913, 0.33333333333333
60263, 1.5478260869565, 1.245652173913, 0.27777777777778
60264, 1.5478260869565, 1.245652173913, 0.22222222222222
60265, 1.5478260869565, 1.245652173913, 0.16666666666667
60266, 1.5478260869565, 1.245652173913, 0.11111111111111
60267, 1.5478260869565, 1.245652173913, 0.055555555555556
60268, 1.5913043478261, 1.245652173913, 0.44444444444444
60269, 1.5913043478261, 1.245652173913, 0.38888888888889
60270, 1.5913043478261, 1.245652173913, 0.33333333333333
60271, 1.5913043478261, 1.245652173913, 0.27777777777778
60272, 1.5913043478261, 1.245652173913, 0.22222222222222
60273, 1.5913043478261, 1.245652173913, 0.16666666666667
60274, 1.5913043478261, 1.245652173913, 0.11111111111111
60275, 1.5913043478261, 1.245652173913, 0.055555555555556
60276, 1.6347826086957, 1.245652173913, 0.44444444444444
60277, 1.6347826086957, 1.245652173913, 0.38888888888889
60278, 1.6347826086957, 1.245652173913, 0.33333333333333
60279, 1.6347826086957, 1.245652173913, 0.27777777777778
60280, 1.6347826086957, 1.245652173913, 0.22222222222222
60281, 1.6347826086957, 1.245652173913, 0.16666666666667
60282, 1.6347826086957, 1.245652173913, 0.11111111111111
60283, 1.6347826086957, 1.245652173913, 0.055555555555556
60284, 1.6782608695652, 1.245652173913, 0.44444444444444
60285, 1.6782608695652, 1.245652173913, 0.38888888888889
60286, 1.6782608695652, 1.245652173913, 0.33333333333333
60287, 1.6782608695652, 1.245652173913, 0.27777777777778
60288, 1.6782608695652, 1.245652173913, 0.22222222222222
60289, 1.6782608695652, 1.245652173913, 0.16666666666667
60290, 1.6782608695652, 1.245652173913, 0.11111111111111
60291, 1.6782608695652, 1.245652173913, 0.055555555555556
60292, 1.7217391304348, 1.245652173913, 0.44444444444444
60293, 1.7217391304348, 1.245652173913, 0.38888888888889
60294, 1.7217391304348, 1.245652173913, 0.33333333333333
60295, 1.7217391304348, 1.245652173913, 0.27777777777778
60296, 1.7217391304348, 1.245652173913, 0.22222222222222
60297, 1.7217391304348, 1.245652173913, 0.16666666666667
60298, 1.7217391304348, 1.245652173913, 0.11111111111111
60299, 1.7217391304348, 1.245652173913, 0.055555555555556
60300, 1.7652173913043, 1.245652173913, 0.44444444444444
60301, 1.7652173913043, 1.245652173913, 0.38888888888889
60302, 1.7652173913043, 1.245652173913, 0.33333333333333
60303, 1.7652173913043, 1.245652173913, 0.27777777777778
60304, 1.7652173913043, 1.245652173913, 0.22222222222222
60305, 1.7652173913043, 1.245652173913, 0.16666666666667
60306, 1.7652173913043, 1.245652173913, 0.11111111111111
60307, 1.7652173913043, 1.245652173913, 0.055555555555556
60308, 1.8086956521739, 1.245652173913, 0.44444444444444
60309, 1.8086956521739, 1.245652173913, 0.38888888888889
60310, 1.8086956521739, 1.245652173913, 0.33333333333333
60311, 1.8086956521739, 1.245652173913, 0.27777777777778
60312, 1.8086956521739, 1.245652173913, 0.22222222222222
60313, 1.8086956521739, 1.245652173913, 0.16666666666667
60314, 1.8086956521739, 1.245652173913, 0.11111111111111
60315, 1.8086956521739, 1.245652173913, 0.055555555555556
60316, 1.8521739130435, 1.245652173913, 0.44444444444444
60317, 1.8521739130435, 1.245652173913, 0.38888888888889
60318, 1.8521739130435, 1.245652173913, 0.33333333333333
60319, 1.8521739130435, 1.245652173913, 0.27777777777778
60320, 1.8521739130435, 1.245652173913, 0.22222222222222
60321, 1.8521739130435, 1.245652173913, 0.16666666666667
60322, 1.8521739130435, 1.245652173913, 0.11111111111111
60323, 1.8521739130435, 1.245652173913, 0.055555555555556
60324, 1.895652173913, 1.245652173913, 0.44444444444444
60325, 1.895652173913, 1.245652173913, 0.38888888888889
60326, 1.895652173913, 1.245652173913, 0.33333333333333
60327, 1.895652173913, 1.245652173913, 0.27777777777778
60328, 1.895652173913, 1.245652173913, 0.22222222222222
60329, 1.895652173913, 1.245652173913, 0.16666666666667
60330, 1.895652173913, 1.245652173913, 0.11111111111111
60331, 1.895652173913, 1.245652173913, 0.055555555555556
60332, 1.9391304347826, 1.245652173913, 0.44444444444444
60333, 1.9391304347826, 1.245652173913, 0.38888888888889
60334, 1.9391304347826, 1.245652173913, 0.33333333333333
60335, 1.9391304347826, 1.245652173913, 0.27777777777778
60336, 1.9391304347826, 1.245652173913, 0.22222222222222
60337, 1.9391304347826, 1.245652173913, 0.16666666666667
60338, 1.9391304347826, 1.245652173913, 0.11111111111111
60339, 1.9391304347826, 1.245652173913, 0.055555555555556
60340, 1.9826086956522, 1.245652173913, 0.44444444444444
60341, 1.9826086956522, 1.245652173913, 0.38888888888889
60342, 1.9826086956522, 1.245652173913, 0.33333333333333
60343, 1.9826086956522, 1.245652173913, 0.27777777777778
60344, 1.9826086956522, 1.245652173913, 0.22222222222222
60345, 1.9826086956522, 1.245652173913, 0.16666666666667
60346, 1.9826086956522, 1.245652173913, 0.11111111111111
60347, 1.9826086956522, 1.245652173913, 0.055555555555556
60348, 2.0260869565217, 1.245652173913, 0.44444444444444
60349, 2.0260869565217, 1.245652173913, 0.38888888888889
60350, 2.0260869565217, 1.245652173913, 0.33333333333333
60351, 2.0260869565217, 1.245652173913, 0.27777777777778
60352, 2.0260869565217, 1.245652173913, 0.22222222222222
60353, 2.0260869565217, 1.245652173913, 0.16666666666667
60354, 2.0260869565217, 1.245652173913, 0.11111111111111
60355, 2.0260869565217, 1.245652173913, 0.055555555555556
60356, 2.0695652173913, 1.245652173913, 0.44444444444444
60357, 2.0695652173913, 1.245652173913, 0.38888888888889
60358, 2.0695652173913, 1.245652173913, 0.33333333333333
60359, 2.0695652173913, 1.245652173913, 0.27777777777778
60360, 2.0695652173913, 1.245652173913, 0.22222222222222
60361, 2.0695652173913, 1.245652173913, 0.16666666666667
60362, 2.0695652173913, 1.245652173913, 0.11111111111111
60363, 2.0695652173913, 1.245652173913, 0.055555555555556
60364, 2.1130434782609, 1.245652173913, 0.44444444444444
60365, 2.1130434782609, 1.245652173913, 0.38888888888889
60366, 2.1130434782609, 1.245652173913, 0.33333333333333
60367, 2.1130434782609, 1.245652173913, 0.27777777777778
60368, 2.1130434782609, 1.245652173913, 0.22222222222222
60369, 2.1130434782609, 1.245652173913, 0.16666666666667
60370, 2.1130434782609, 1.245652173913, 0.11111111111111
60371, 2.1130434782609, 1.245652173913, 0.055555555555556
60372, 2.1565217391304, 1.245652173913, 0.44444444444444
60373, 2.1565217391304, 1.245652173913, 0.38888888888889
60374, 2.1565217391304, 1.245652173913, 0.33333333333333
60375, 2.1565217391304, 1.245652173913, 0.27777777777778
60376, 2.1565217391304, 1.245652173913, 0.22222222222222
60377, 2.1565217391304, 1.245652173913, 0.16666666666667
60378, 2.1565217391304, 1.245652173913, 0.11111111111111
60379, 2.1565217391304, 1.245652173913, 0.055555555555556
60380, 1.2434782608696, 1.1934782608696, 0.44444444444444
60381, 1.2434782608696, 1.1934782608696, 0.38888888888889
60382, 1.2434782608696, 1.1934782608696, 0.33333333333333
60383, 1.2434782608696, 1.1934782608696, 0.27777777777778
60384, 1.2434782608696, 1.1934782608696, 0.22222222222222
60385, 1.2434782608696, 1.1934782608696, 0.16666666666667
60386, 1.2434782608696, 1.1934782608696, 0.11111111111111
60387, 1.2434782608696, 1.1934782608696, 0.055555555555556
60388, 1.2869565217391, 1.1934782608696, 0.44444444444444
60389, 1.2869565217391, 1.1934782608696, 0.38888888888889
60390, 1.2869565217391, 1.1934782608696, 0.33333333333333
60391, 1.2869565217391, 1.1934782608696, 0.27777777777778
60392, 1.2869565217391, 1.1934782608696, 0.22222222222222
60393, 1.2869565217391, 1.1934782608696, 0.16666666666667
60394, 1.2869565217391, 1.1934782608696, 0.11111111111111
60395, 1.2869565217391, 1.1934782608696, 0.055555555555556
60396, 1.3304347826087, 1.1934782608696, 0.44444444444444
60397, 1.3304347826087, 1.1934782608696, 0.38888888888889
60398, 1.3304347826087, 1.1934782608696, 0.33333333333333
60399, 1.3304347826087, 1.1934782608696, 0.27777777777778
60400, 1.3304347826087, 1.1934782608696, 0.22222222222222
60401, 1.3304347826087, 1.1934782608696, 0.16666666666667
60402, 1.3304347826087, 1.1934782608696, 0.11111111111111
60403, 1.3304347826087, 1.1934782608696, 0.055555555555556
60404, 1.3739130434783, 1.1934782608696, 0.44444444444444
60405, 1.3739130434783, 1.1934782608696, 0.38888888888889
60406, 1.3739130434783, 1.1934782608696, 0.33333333333333
60407, 1.3739130434783, 1.1934782608696, 0.27777777777778
60408, 1.3739130434783, 1.1934782608696, 0.22222222222222
60409, 1.3739130434783, 1.1934782608696, 0.16666666666667
60410, 1.3739130434783, 1.1934782608696, 0.11111111111111
60411, 1.3739130434783, 1.1934782608696, 0.055555555555556
60412, 1.4173913043478, 1.1934782608696, 0.44444444444444
60413, 1.4173913043478, 1.1934782608696, 0.38888888888889
60414, 1.4173913043478, 1.1934782608696, 0.33333333333333
60415, 1.4173913043478, 1.1934782608696, 0.27777777777778
60416, 1.4173913043478, 1.1934782608696, 0.22222222222222
60417, 1.4173913043478, 1.1934782608696, 0.16666666666667
60418, 1.4173913043478, 1.1934782608696, 0.11111111111111
60419, 1.4173913043478, 1.1934782608696, 0.055555555555556
60420, 1.4608695652174, 1.1934782608696, 0.44444444444444
60421, 1.4608695652174, 1.1934782608696, 0.38888888888889
60422, 1.4608695652174, 1.1934782608696, 0.33333333333333
60423, 1.4608695652174, 1.1934782608696, 0.27777777777778
60424, 1.4608695652174, 1.1934782608696, 0.22222222222222
60425, 1.4608695652174, 1.1934782608696, 0.16666666666667
60426, 1.4608695652174, 1.1934782608696, 0.11111111111111
60427, 1.4608695652174, 1.1934782608696, 0.055555555555556
60428, 1.504347826087, 1.1934782608696, 0.44444444444444
60429, 1.504347826087, 1.1934782608696, 0.38888888888889
60430, 1.504347826087, 1.1934782608696, 0.33333333333333
60431, 1.504347826087, 1.1934782608696, 0.27777777777778
60432, 1.504347826087, 1.1934782608696, 0.22222222222222
60433, 1.504347826087, 1.1934782608696, 0.16666666666667
60434, 1.504347826087, 1.1934782608696, 0.11111111111111
60435, 1.504347826087, 1.1934782608696, 0.055555555555556
60436, 1.5478260869565, 1.1934782608696, 0.44444444444444
60437, 1.5478260869565, 1.1934782608696, 0.38888888888889
60438, 1.5478260869565, 1.1934782608696, 0.33333333333333
60439, 1.5478260869565, 1.1934782608696, 0.27777777777778
60440, 1.5478260869565, 1.1934782608696, 0.22222222222222
60441, 1.5478260869565, 1.1934782608696, 0.16666666666667
60442, 1.5478260869565, 1.1934782608696, 0.11111111111111
60443, 1.5478260869565, 1.1934782608696, 0.055555555555556
60444, 1.5913043478261, 1.1934782608696, 0.44444444444444
60445, 1.5913043478261, 1.1934782608696, 0.38888888888889
60446, 1.5913043478261, 1.1934782608696, 0.33333333333333
60447, 1.5913043478261, 1.1934782608696, 0.27777777777778
60448, 1.5913043478261, 1.1934782608696, 0.22222222222222
60449, 1.5913043478261, 1.1934782608696, 0.16666666666667
60450, 1.5913043478261, 1.1934782608696, 0.11111111111111
60451, 1.5913043478261, 1.1934782608696, 0.055555555555556
60452, 1.6347826086957, 1.1934782608696, 0.44444444444444
60453, 1.6347826086957, 1.1934782608696, 0.38888888888889
60454, 1.6347826086957, 1.1934782608696, 0.33333333333333
60455, 1.6347826086957, 1.1934782608696, 0.27777777777778
60456, 1.6347826086957, 1.1934782608696, 0.22222222222222
60457, 1.6347826086957, 1.1934782608696, 0.16666666666667
60458, 1.6347826086957, 1.1934782608696, 0.11111111111111
60459, 1.6347826086957, 1.1934782608696, 0.055555555555556
60460, 1.6782608695652, 1.1934782608696, 0.44444444444444
60461, 1.6782608695652, 1.1934782608696, 0.38888888888889
60462, 1.6782608695652, 1.1934782608696, 0.33333333333333
60463, 1.6782608695652, 1.1934782608696, 0.27777777777778
60464, 1.6782608695652, 1.1934782608696, 0.22222222222222
60465, 1.6782608695652, 1.1934782608696, 0.16666666666667
60466, 1.6782608695652, 1.1934782608696, 0.11111111111111
60467, 1.6782608695652, 1.1934782608696, 0.055555555555556
60468, 1.7217391304348, 1.1934782608696, 0.44444444444444
60469, 1.7217391304348, 1.1934782608696, 0.38888888888889
60470, 1.7217391304348, 1.1934782608696, 0.33333333333333
60471, 1.7217391304348, 1.1934782608696, 0.27777777777778
60472, 1.7217391304348, 1.1934782608696, 0.22222222222222
60473, 1.7217391304348, 1.1934782608696, 0.16666666666667
60474, 1.7217391304348, 1.1934782608696, 0.11111111111111
60475, 1.7217391304348, 1.1934782608696, 0.055555555555556
60476, 1.7652173913043, 1.1934782608696, 0.44444444444444
60477, 1.7652173913043, 1.1934782608696, 0.38888888888889
60478, 1.7652173913043, 1.1934782608696, 0.33333333333333
60479, 1.7652173913043, 1.1934782608696, 0.27777777777778
60480, 1.7652173913043, 1.1934782608696, 0.22222222222222
60481, 1.7652173913043, 1.1934782608696, 0.16666666666667
60482, 1.7652173913043, 1.1934782608696, 0.11111111111111
60483, 1.7652173913043, 1.1934782608696, 0.055555555555556
60484, 1.8086956521739, 1.1934782608696, 0.44444444444444
60485, 1.8086956521739, 1.1934782608696, 0.38888888888889
60486, 1.8086956521739, 1.1934782608696, 0.33333333333333
60487, 1.8086956521739, 1.1934782608696, 0.27777777777778
60488, 1.8086956521739, 1.1934782608696, 0.22222222222222
60489, 1.8086956521739, 1.1934782608696, 0.16666666666667
60490, 1.8086956521739, 1.1934782608696, 0.11111111111111
60491, 1.8086956521739, 1.1934782608696, 0.055555555555556
60492, 1.8521739130435, 1.1934782608696, 0.44444444444444
60493, 1.8521739130435, 1.1934782608696, 0.38888888888889
60494, 1.8521739130435, 1.1934782608696, 0.33333333333333
60495, 1.8521739130435, 1.1934782608696, 0.27777777777778
60496, 1.8521739130435, 1.1934782608696, 0.22222222222222
60497, 1.8521739130435, 1.1934782608696, 0.16666666666667
60498, 1.8521739130435, 1.1934782608696, 0.11111111111111
60499, 1.8521739130435, 1.1934782608696, 0.055555555555556
60500, 1.895652173913, 1.1934782608696, 0.44444444444444
60501, 1.895652173913, 1.1934782608696, 0.38888888888889
60502, 1.895652173913, 1.1934782608696, 0.33333333333333
60503, 1.895652173913, 1.1934782608696, 0.27777777777778
60504, 1.895652173913, 1.1934782608696, 0.22222222222222
60505, 1.895652173913, 1.1934782608696, 0.16666666666667
60506, 1.895652173913, 1.1934782608696, 0.11111111111111
60507, 1.895652173913, 1.1934782608696, 0.055555555555556
60508, 1.9391304347826, 1.1934782608696, 0.44444444444444
60509, 1.9391304347826, 1.1934782608696, 0.38888888888889
60510, 1.9391304347826, 1.1934782608696, 0.33333333333333
60511, 1.9391304347826, 1.1934782608696, 0.27777777777778
60512, 1.9391304347826, 1.1934782608696, 0.22222222222222
60513, 1.9391304347826, 1.1934782608696, 0.16666666666667
60514, 1.9391304347826, 1.1934782608696, 0.11111111111111
60515, 1.9391304347826, 1.1934782608696, 0.055555555555556
60516, 1.9826086956522, 1.1934782608696, 0.44444444444444
60517, 1.9826086956522, 1.1934782608696, 0.38888888888889
60518, 1.9826086956522, 1.1934782608696, 0.33333333333333
60519, 1.9826086956522, 1.1934782608696, 0.27777777777778
60520, 1.9826086956522, 1.1934782608696, 0.22222222222222
60521, 1.9826086956522, 1.1934782608696, 0.16666666666667
60522, 1.9826086956522, 1.1934782608696, 0.11111111111111
60523, 1.9826086956522, 1.1934782608696, 0.055555555555556
60524, 2.0260869565217, 1.1934782608696, 0.44444444444444
60525, 2.0260869565217, 1.1934782608696, 0.38888888888889
60526, 2.0260869565217, 1.1934782608696, 0.33333333333333
60527, 2.0260869565217, 1.1934782608696, 0.27777777777778
60528, 2.0260869565217, 1.1934782608696, 0.22222222222222
60529, 2.0260869565217, 1.1934782608696, 0.16666666666667
60530, 2.0260869565217, 1.1934782608696, 0.11111111111111
60531, 2.0260869565217, 1.1934782608696, 0.055555555555556
60532, 2.0695652173913, 1.1934782608696, 0.44444444444444
60533, 2.0695652173913, 1.1934782608696, 0.38888888888889
60534, 2.0695652173913, 1.1934782608696, 0.33333333333333
60535, 2.0695652173913, 1.1934782608696, 0.27777777777778
60536, 2.0695652173913, 1.1934782608696, 0.22222222222222
60537, 2.0695652173913, 1.1934782608696, 0.16666666666667
60538, 2.0695652173913, 1.1934782608696, 0.11111111111111
60539, 2.0695652173913, 1.1934782608696, 0.055555555555556
60540, 2.1130434782609, 1.1934782608696, 0.44444444444444
60541, 2.1130434782609, 1.1934782608696, 0.38888888888889
60542, 2.1130434782609, 1.1934782608696, 0.33333333333333
60543, 2.1130434782609, 1.1934782608696, 0.27777777777778
60544, 2.1130434782609, 1.1934782608696, 0.22222222222222
60545, 2.1130434782609, 1.1934782608696, 0.16666666666667
60546, 2.1130434782609, 1.1934782608696, 0.11111111111111
60547, 2.1130434782609, 1.1934782608696, 0.055555555555556
60548, 2.1565217391304, 1.1934782608696, 0.44444444444444
60549, 2.1565217391304, 1.1934782608696, 0.38888888888889
60550, 2.1565217391304, 1.1934782608696, 0.33333333333333
60551, 2.1565217391304, 1.1934782608696, 0.27777777777778
60552, 2.1565217391304, 1.1934782608696, 0.22222222222222
60553, 2.1565217391304, 1.1934782608696, 0.16666666666667
60554, 2.1565217391304, 1.1934782608696, 0.11111111111111
60555, 2.1565217391304, 1.1934782608696, 0.055555555555556
60556, 1.2434782608696, 1.1413043478261, 0.44444444444444
60557, 1.2434782608696, 1.1413043478261, 0.38888888888889
60558, 1.2434782608696, 1.1413043478261, 0.33333333333333
60559, 1.2434782608696, 1.1413043478261, 0.27777777777778
60560, 1.2434782608696, 1.1413043478261, 0.22222222222222
60561, 1.2434782608696, 1.1413043478261, 0.16666666666667
60562, 1.2434782608696, 1.1413043478261, 0.11111111111111
60563, 1.2434782608696, 1.1413043478261, 0.055555555555556
60564, 1.2869565217391, 1.1413043478261, 0.44444444444444
60565, 1.2869565217391, 1.1413043478261, 0.38888888888889
60566, 1.2869565217391, 1.1413043478261, 0.33333333333333
60567, 1.2869565217391, 1.1413043478261, 0.27777777777778
60568, 1.2869565217391, 1.1413043478261, 0.22222222222222
60569, 1.2869565217391, 1.1413043478261, 0.16666666666667
60570, 1.2869565217391, 1.1413043478261, 0.11111111111111
60571, 1.2869565217391, 1.1413043478261, 0.055555555555556
60572, 1.3304347826087, 1.1413043478261, 0.44444444444444
60573, 1.3304347826087, 1.1413043478261, 0.38888888888889
60574, 1.3304347826087, 1.1413043478261, 0.33333333333333
60575, 1.3304347826087, 1.1413043478261, 0.27777777777778
60576, 1.3304347826087, 1.1413043478261, 0.22222222222222
60577, 1.3304347826087, 1.1413043478261, 0.16666666666667
60578, 1.3304347826087, 1.1413043478261, 0.11111111111111
60579, 1.3304347826087, 1.1413043478261, 0.055555555555556
60580, 1.3739130434783, 1.1413043478261, 0.44444444444444
60581, 1.3739130434783, 1.1413043478261, 0.38888888888889
60582, 1.3739130434783, 1.1413043478261, 0.33333333333333
60583, 1.3739130434783, 1.1413043478261, 0.27777777777778
60584, 1.3739130434783, 1.1413043478261, 0.22222222222222
60585, 1.3739130434783, 1.1413043478261, 0.16666666666667
60586, 1.3739130434783, 1.1413043478261, 0.11111111111111
60587, 1.3739130434783, 1.1413043478261, 0.055555555555556
60588, 1.4173913043478, 1.1413043478261, 0.44444444444444
60589, 1.4173913043478, 1.1413043478261, 0.38888888888889
60590, 1.4173913043478, 1.1413043478261, 0.33333333333333
60591, 1.4173913043478, 1.1413043478261, 0.27777777777778
60592, 1.4173913043478, 1.1413043478261, 0.22222222222222
60593, 1.4173913043478, 1.1413043478261, 0.16666666666667
60594, 1.4173913043478, 1.1413043478261, 0.11111111111111
60595, 1.4173913043478, 1.1413043478261, 0.055555555555556
60596, 1.4608695652174, 1.1413043478261, 0.44444444444444
60597, 1.4608695652174, 1.1413043478261, 0.38888888888889
60598, 1.4608695652174, 1.1413043478261, 0.33333333333333
60599, 1.4608695652174, 1.1413043478261, 0.27777777777778
60600, 1.4608695652174, 1.1413043478261, 0.22222222222222
60601, 1.4608695652174, 1.1413043478261, 0.16666666666667
60602, 1.4608695652174, 1.1413043478261, 0.11111111111111
60603, 1.4608695652174, 1.1413043478261, 0.055555555555556
60604, 1.504347826087, 1.1413043478261, 0.44444444444444
60605, 1.504347826087, 1.1413043478261, 0.38888888888889
60606, 1.504347826087, 1.1413043478261, 0.33333333333333
60607, 1.504347826087, 1.1413043478261, 0.27777777777778
60608, 1.504347826087, 1.1413043478261, 0.22222222222222
60609, 1.504347826087, 1.1413043478261, 0.16666666666667
60610, 1.504347826087, 1.1413043478261, 0.11111111111111
60611, 1.504347826087, 1.1413043478261, 0.055555555555556
60612, 1.5478260869565, 1.1413043478261, 0.44444444444444
60613, 1.5478260869565, 1.1413043478261, 0.38888888888889
60614, 1.5478260869565, 1.1413043478261, 0.33333333333333
60615, 1.5478260869565, 1.1413043478261, 0.27777777777778
60616, 1.5478260869565, 1.1413043478261, 0.22222222222222
60617, 1.5478260869565, 1.1413043478261, 0.16666666666667
60618, 1.5478260869565, 1.1413043478261, 0.11111111111111
60619, 1.5478260869565, 1.1413043478261, 0.055555555555556
60620, 1.5913043478261, 1.1413043478261, 0.44444444444444
60621, 1.5913043478261, 1.1413043478261, 0.38888888888889
60622, 1.5913043478261, 1.1413043478261, 0.33333333333333
60623, 1.5913043478261, 1.1413043478261, 0.27777777777778
60624, 1.5913043478261, 1.1413043478261, 0.22222222222222
60625, 1.5913043478261, 1.1413043478261, 0.16666666666667
60626, 1.5913043478261, 1.1413043478261, 0.11111111111111
60627, 1.5913043478261, 1.1413043478261, 0.055555555555556
60628, 1.6347826086957, 1.1413043478261, 0.44444444444444
60629, 1.6347826086957, 1.1413043478261, 0.38888888888889
60630, 1.6347826086957, 1.1413043478261, 0.33333333333333
60631, 1.6347826086957, 1.1413043478261, 0.27777777777778
60632, 1.6347826086957, 1.1413043478261, 0.22222222222222
60633, 1.6347826086957, 1.1413043478261, 0.16666666666667
60634, 1.6347826086957, 1.1413043478261, 0.11111111111111
60635, 1.6347826086957, 1.1413043478261, 0.055555555555556
60636, 1.6782608695652, 1.1413043478261, 0.44444444444444
60637, 1.6782608695652, 1.1413043478261, 0.38888888888889
60638, 1.6782608695652, 1.1413043478261, 0.33333333333333
60639, 1.6782608695652, 1.1413043478261, 0.27777777777778
60640, 1.6782608695652, 1.1413043478261, 0.22222222222222
60641, 1.6782608695652, 1.1413043478261, 0.16666666666667
60642, 1.6782608695652, 1.1413043478261, 0.11111111111111
60643, 1.6782608695652, 1.1413043478261, 0.055555555555556
60644, 1.7217391304348, 1.1413043478261, 0.44444444444444
60645, 1.7217391304348, 1.1413043478261, 0.38888888888889
60646, 1.7217391304348, 1.1413043478261, 0.33333333333333
60647, 1.7217391304348, 1.1413043478261, 0.27777777777778
60648, 1.7217391304348, 1.1413043478261, 0.22222222222222
60649, 1.7217391304348, 1.1413043478261, 0.16666666666667
60650, 1.7217391304348, 1.1413043478261, 0.11111111111111
60651, 1.7217391304348, 1.1413043478261, 0.055555555555556
60652, 1.7652173913043, 1.1413043478261, 0.44444444444444
60653, 1.7652173913043, 1.1413043478261, 0.38888888888889
60654, 1.7652173913043, 1.1413043478261, 0.33333333333333
60655, 1.7652173913043, 1.1413043478261, 0.27777777777778
60656, 1.7652173913043, 1.1413043478261, 0.22222222222222
60657, 1.7652173913043, 1.1413043478261, 0.16666666666667
60658, 1.7652173913043, 1.1413043478261, 0.11111111111111
60659, 1.7652173913043, 1.1413043478261, 0.055555555555556
60660, 1.8086956521739, 1.1413043478261, 0.44444444444444
60661, 1.8086956521739, 1.1413043478261, 0.38888888888889
60662, 1.8086956521739, 1.1413043478261, 0.33333333333333
60663, 1.8086956521739, 1.1413043478261, 0.27777777777778
60664, 1.8086956521739, 1.1413043478261, 0.22222222222222
60665, 1.8086956521739, 1.1413043478261, 0.16666666666667
60666, 1.8086956521739, 1.1413043478261, 0.11111111111111
60667, 1.8086956521739, 1.1413043478261, 0.055555555555556
60668, 1.8521739130435, 1.1413043478261, 0.44444444444444
60669, 1.8521739130435, 1.1413043478261, 0.38888888888889
60670, 1.8521739130435, 1.1413043478261, 0.33333333333333
60671, 1.8521739130435, 1.1413043478261, 0.27777777777778
60672, 1.8521739130435, 1.1413043478261, 0.22222222222222
60673, 1.8521739130435, 1.1413043478261, 0.16666666666667
60674, 1.8521739130435, 1.1413043478261, 0.11111111111111
60675, 1.8521739130435, 1.1413043478261, 0.055555555555556
60676, 1.895652173913, 1.1413043478261, 0.44444444444444
60677, 1.895652173913, 1.1413043478261, 0.38888888888889
60678, 1.895652173913, 1.1413043478261, 0.33333333333333
60679, 1.895652173913, 1.1413043478261, 0.27777777777778
60680, 1.895652173913, 1.1413043478261, 0.22222222222222
60681, 1.895652173913, 1.1413043478261, 0.16666666666667
60682, 1.895652173913, 1.1413043478261, 0.11111111111111
60683, 1.895652173913, 1.1413043478261, 0.055555555555556
60684, 1.9391304347826, 1.1413043478261, 0.44444444444444
60685, 1.9391304347826, 1.1413043478261, 0.38888888888889
60686, 1.9391304347826, 1.1413043478261, 0.33333333333333
60687, 1.9391304347826, 1.1413043478261, 0.27777777777778
60688, 1.9391304347826, 1.1413043478261, 0.22222222222222
60689, 1.9391304347826, 1.1413043478261, 0.16666666666667
60690, 1.9391304347826, 1.1413043478261, 0.11111111111111
60691, 1.9391304347826, 1.1413043478261, 0.055555555555556
60692, 1.9826086956522, 1.1413043478261, 0.44444444444444
60693, 1.9826086956522, 1.1413043478261, 0.38888888888889
60694, 1.9826086956522, 1.1413043478261, 0.33333333333333
60695, 1.9826086956522, 1.1413043478261, 0.27777777777778
60696, 1.9826086956522, 1.1413043478261, 0.22222222222222
60697, 1.9826086956522, 1.1413043478261, 0.16666666666667
60698, 1.9826086956522, 1.1413043478261, 0.11111111111111
60699, 1.9826086956522, 1.1413043478261, 0.055555555555556
60700, 2.0260869565217, 1.1413043478261, 0.44444444444444
60701, 2.0260869565217, 1.1413043478261, 0.38888888888889
60702, 2.0260869565217, 1.1413043478261, 0.33333333333333
60703, 2.0260869565217, 1.1413043478261, 0.27777777777778
60704, 2.0260869565217, 1.1413043478261, 0.22222222222222
60705, 2.0260869565217, 1.1413043478261, 0.16666666666667
60706, 2.0260869565217, 1.1413043478261, 0.11111111111111
60707, 2.0260869565217, 1.1413043478261, 0.055555555555556
60708, 2.0695652173913, 1.1413043478261, 0.44444444444444
60709, 2.0695652173913, 1.1413043478261, 0.38888888888889
60710, 2.0695652173913, 1.1413043478261, 0.33333333333333
60711, 2.0695652173913, 1.1413043478261, 0.27777777777778
60712, 2.0695652173913, 1.1413043478261, 0.22222222222222
60713, 2.0695652173913, 1.1413043478261, 0.16666666666667
60714, 2.0695652173913, 1.1413043478261, 0.11111111111111
60715, 2.0695652173913, 1.1413043478261, 0.055555555555556
60716, 2.1130434782609, 1.1413043478261, 0.44444444444444
60717, 2.1130434782609, 1.1413043478261, 0.38888888888889
60718, 2.1130434782609, 1.1413043478261, 0.33333333333333
60719, 2.1130434782609, 1.1413043478261, 0.27777777777778
60720, 2.1130434782609, 1.1413043478261, 0.22222222222222
60721, 2.1130434782609, 1.1413043478261, 0.16666666666667
60722, 2.1130434782609, 1.1413043478261, 0.11111111111111
60723, 2.1130434782609, 1.1413043478261, 0.055555555555556
60724, 2.1565217391304, 1.1413043478261, 0.44444444444444
60725, 2.1565217391304, 1.1413043478261, 0.38888888888889
60726, 2.1565217391304, 1.1413043478261, 0.33333333333333
60727, 2.1565217391304, 1.1413043478261, 0.27777777777778
60728, 2.1565217391304, 1.1413043478261, 0.22222222222222
60729, 2.1565217391304, 1.1413043478261, 0.16666666666667
60730, 2.1565217391304, 1.1413043478261, 0.11111111111111
60731, 2.1565217391304, 1.1413043478261, 0.055555555555556
60732, 1.2434782608696, 1.0891304347826, 0.44444444444444
60733, 1.2434782608696, 1.0891304347826, 0.38888888888889
60734, 1.2434782608696, 1.0891304347826, 0.33333333333333
60735, 1.2434782608696, 1.0891304347826, 0.27777777777778
60736, 1.2434782608696, 1.0891304347826, 0.22222222222222
60737, 1.2434782608696, 1.0891304347826, 0.16666666666667
60738, 1.2434782608696, 1.0891304347826, 0.11111111111111
60739, 1.2434782608696, 1.0891304347826, 0.055555555555556
60740, 1.2869565217391, 1.0891304347826, 0.44444444444444
60741, 1.2869565217391, 1.0891304347826, 0.38888888888889
60742, 1.2869565217391, 1.0891304347826, 0.33333333333333
60743, 1.2869565217391, 1.0891304347826, 0.27777777777778
60744, 1.2869565217391, 1.0891304347826, 0.22222222222222
60745, 1.2869565217391, 1.0891304347826, 0.16666666666667
60746, 1.2869565217391, 1.0891304347826, 0.11111111111111
60747, 1.2869565217391, 1.0891304347826, 0.055555555555556
60748, 1.3304347826087, 1.0891304347826, 0.44444444444444
60749, 1.3304347826087, 1.0891304347826, 0.38888888888889
60750, 1.3304347826087, 1.0891304347826, 0.33333333333333
60751, 1.3304347826087, 1.0891304347826, 0.27777777777778
60752, 1.3304347826087, 1.0891304347826, 0.22222222222222
60753, 1.3304347826087, 1.0891304347826, 0.16666666666667
60754, 1.3304347826087, 1.0891304347826, 0.11111111111111
60755, 1.3304347826087, 1.0891304347826, 0.055555555555556
60756, 1.3739130434783, 1.0891304347826, 0.44444444444444
60757, 1.3739130434783, 1.0891304347826, 0.38888888888889
60758, 1.3739130434783, 1.0891304347826, 0.33333333333333
60759, 1.3739130434783, 1.0891304347826, 0.27777777777778
60760, 1.3739130434783, 1.0891304347826, 0.22222222222222
60761, 1.3739130434783, 1.0891304347826, 0.16666666666667
60762, 1.3739130434783, 1.0891304347826, 0.11111111111111
60763, 1.3739130434783, 1.0891304347826, 0.055555555555556
60764, 1.4173913043478, 1.0891304347826, 0.44444444444444
60765, 1.4173913043478, 1.0891304347826, 0.38888888888889
60766, 1.4173913043478, 1.0891304347826, 0.33333333333333
60767, 1.4173913043478, 1.0891304347826, 0.27777777777778
60768, 1.4173913043478, 1.0891304347826, 0.22222222222222
60769, 1.4173913043478, 1.0891304347826, 0.16666666666667
60770, 1.4173913043478, 1.0891304347826, 0.11111111111111
60771, 1.4173913043478, 1.0891304347826, 0.055555555555556
60772, 1.4608695652174, 1.0891304347826, 0.44444444444444
60773, 1.4608695652174, 1.0891304347826, 0.38888888888889
60774, 1.4608695652174, 1.0891304347826, 0.33333333333333
60775, 1.4608695652174, 1.0891304347826, 0.27777777777778
60776, 1.4608695652174, 1.0891304347826, 0.22222222222222
60777, 1.4608695652174, 1.0891304347826, 0.16666666666667
60778, 1.4608695652174, 1.0891304347826, 0.11111111111111
60779, 1.4608695652174, 1.0891304347826, 0.055555555555556
60780, 1.504347826087, 1.0891304347826, 0.44444444444444
60781, 1.504347826087, 1.0891304347826, 0.38888888888889
60782, 1.504347826087, 1.0891304347826, 0.33333333333333
60783, 1.504347826087, 1.0891304347826, 0.27777777777778
60784, 1.504347826087, 1.0891304347826, 0.22222222222222
60785, 1.504347826087, 1.0891304347826, 0.16666666666667
60786, 1.504347826087, 1.0891304347826, 0.11111111111111
60787, 1.504347826087, 1.0891304347826, 0.055555555555556
60788, 1.5478260869565, 1.0891304347826, 0.44444444444444
60789, 1.5478260869565, 1.0891304347826, 0.38888888888889
60790, 1.5478260869565, 1.0891304347826, 0.33333333333333
60791, 1.5478260869565, 1.0891304347826, 0.27777777777778
60792, 1.5478260869565, 1.0891304347826, 0.22222222222222
60793, 1.5478260869565, 1.0891304347826, 0.16666666666667
60794, 1.5478260869565, 1.0891304347826, 0.11111111111111
60795, 1.5478260869565, 1.0891304347826, 0.055555555555556
60796, 1.5913043478261, 1.0891304347826, 0.44444444444444
60797, 1.5913043478261, 1.0891304347826, 0.38888888888889
60798, 1.5913043478261, 1.0891304347826, 0.33333333333333
60799, 1.5913043478261, 1.0891304347826, 0.27777777777778
60800, 1.5913043478261, 1.0891304347826, 0.22222222222222
60801, 1.5913043478261, 1.0891304347826, 0.16666666666667
60802, 1.5913043478261, 1.0891304347826, 0.11111111111111
60803, 1.5913043478261, 1.0891304347826, 0.055555555555556
60804, 1.6347826086957, 1.0891304347826, 0.44444444444444
60805, 1.6347826086957, 1.0891304347826, 0.38888888888889
60806, 1.6347826086957, 1.0891304347826, 0.33333333333333
60807, 1.6347826086957, 1.0891304347826, 0.27777777777778
60808, 1.6347826086957, 1.0891304347826, 0.22222222222222
60809, 1.6347826086957, 1.0891304347826, 0.16666666666667
60810, 1.6347826086957, 1.0891304347826, 0.11111111111111
60811, 1.6347826086957, 1.0891304347826, 0.055555555555556
60812, 1.6782608695652, 1.0891304347826, 0.44444444444444
60813, 1.6782608695652, 1.0891304347826, 0.38888888888889
60814, 1.6782608695652, 1.0891304347826, 0.33333333333333
60815, 1.6782608695652, 1.0891304347826, 0.27777777777778
60816, 1.6782608695652, 1.0891304347826, 0.22222222222222
60817, 1.6782608695652, 1.0891304347826, 0.16666666666667
60818, 1.6782608695652, 1.0891304347826, 0.11111111111111
60819, 1.6782608695652, 1.0891304347826, 0.055555555555556
60820, 1.7217391304348, 1.0891304347826, 0.44444444444444
60821, 1.7217391304348, 1.0891304347826, 0.38888888888889
60822, 1.7217391304348, 1.0891304347826, 0.33333333333333
60823, 1.7217391304348, 1.0891304347826, 0.27777777777778
60824, 1.7217391304348, 1.0891304347826, 0.22222222222222
60825, 1.7217391304348, 1.0891304347826, 0.16666666666667
60826, 1.7217391304348, 1.0891304347826, 0.11111111111111
60827, 1.7217391304348, 1.0891304347826, 0.055555555555556
60828, 1.7652173913043, 1.0891304347826, 0.44444444444444
60829, 1.7652173913043, 1.0891304347826, 0.38888888888889
60830, 1.7652173913043, 1.0891304347826, 0.33333333333333
60831, 1.7652173913043, 1.0891304347826, 0.27777777777778
60832, 1.7652173913043, 1.0891304347826, 0.22222222222222
60833, 1.7652173913043, 1.0891304347826, 0.16666666666667
60834, 1.7652173913043, 1.0891304347826, 0.11111111111111
60835, 1.7652173913043, 1.0891304347826, 0.055555555555556
60836, 1.8086956521739, 1.0891304347826, 0.44444444444444
60837, 1.8086956521739, 1.0891304347826, 0.38888888888889
60838, 1.8086956521739, 1.0891304347826, 0.33333333333333
60839, 1.8086956521739, 1.0891304347826, 0.27777777777778
60840, 1.8086956521739, 1.0891304347826, 0.22222222222222
60841, 1.8086956521739, 1.0891304347826, 0.16666666666667
60842, 1.8086956521739, 1.0891304347826, 0.11111111111111
60843, 1.8086956521739, 1.0891304347826, 0.055555555555556
60844, 1.8521739130435, 1.0891304347826, 0.44444444444444
60845, 1.8521739130435, 1.0891304347826, 0.38888888888889
60846, 1.8521739130435, 1.0891304347826, 0.33333333333333
60847, 1.8521739130435, 1.0891304347826, 0.27777777777778
60848, 1.8521739130435, 1.0891304347826, 0.22222222222222
60849, 1.8521739130435, 1.0891304347826, 0.16666666666667
60850, 1.8521739130435, 1.0891304347826, 0.11111111111111
60851, 1.8521739130435, 1.0891304347826, 0.055555555555556
60852, 1.895652173913, 1.0891304347826, 0.44444444444444
60853, 1.895652173913, 1.0891304347826, 0.38888888888889
60854, 1.895652173913, 1.0891304347826, 0.33333333333333
60855, 1.895652173913, 1.0891304347826, 0.27777777777778
60856, 1.895652173913, 1.0891304347826, 0.22222222222222
60857, 1.895652173913, 1.0891304347826, 0.16666666666667
60858, 1.895652173913, 1.0891304347826, 0.11111111111111
60859, 1.895652173913, 1.0891304347826, 0.055555555555556
60860, 1.9391304347826, 1.0891304347826, 0.44444444444444
60861, 1.9391304347826, 1.0891304347826, 0.38888888888889
60862, 1.9391304347826, 1.0891304347826, 0.33333333333333
60863, 1.9391304347826, 1.0891304347826, 0.27777777777778
60864, 1.9391304347826, 1.0891304347826, 0.22222222222222
60865, 1.9391304347826, 1.0891304347826, 0.16666666666667
60866, 1.9391304347826, 1.0891304347826, 0.11111111111111
60867, 1.9391304347826, 1.0891304347826, 0.055555555555556
60868, 1.9826086956522, 1.0891304347826, 0.44444444444444
60869, 1.9826086956522, 1.0891304347826, 0.38888888888889
60870, 1.9826086956522, 1.0891304347826, 0.33333333333333
60871, 1.9826086956522, 1.0891304347826, 0.27777777777778
60872, 1.9826086956522, 1.0891304347826, 0.22222222222222
60873, 1.9826086956522, 1.0891304347826, 0.16666666666667
60874, 1.9826086956522, 1.0891304347826, 0.11111111111111
60875, 1.9826086956522, 1.0891304347826, 0.055555555555556
60876, 2.0260869565217, 1.0891304347826, 0.44444444444444
60877, 2.0260869565217, 1.0891304347826, 0.38888888888889
60878, 2.0260869565217, 1.0891304347826, 0.33333333333333
60879, 2.0260869565217, 1.0891304347826, 0.27777777777778
60880, 2.0260869565217, 1.0891304347826, 0.22222222222222
60881, 2.0260869565217, 1.0891304347826, 0.16666666666667
60882, 2.0260869565217, 1.0891304347826, 0.11111111111111
60883, 2.0260869565217, 1.0891304347826, 0.055555555555556
60884, 2.0695652173913, 1.0891304347826, 0.44444444444444
60885, 2.0695652173913, 1.0891304347826, 0.38888888888889
60886, 2.0695652173913, 1.0891304347826, 0.33333333333333
60887, 2.0695652173913, 1.0891304347826, 0.27777777777778
60888, 2.0695652173913, 1.0891304347826, 0.22222222222222
60889, 2.0695652173913, 1.0891304347826, 0.16666666666667
60890, 2.0695652173913, 1.0891304347826, 0.11111111111111
60891, 2.0695652173913, 1.0891304347826, 0.055555555555556
60892, 2.1130434782609, 1.0891304347826, 0.44444444444444
60893, 2.1130434782609, 1.0891304347826, 0.38888888888889
60894, 2.1130434782609, 1.0891304347826, 0.33333333333333
60895, 2.1130434782609, 1.0891304347826, 0.27777777777778
60896, 2.1130434782609, 1.0891304347826, 0.22222222222222
60897, 2.1130434782609, 1.0891304347826, 0.16666666666667
60898, 2.1130434782609, 1.0891304347826, 0.11111111111111
60899, 2.1130434782609, 1.0891304347826, 0.055555555555556
60900, 2.1565217391304, 1.0891304347826, 0.44444444444444
60901, 2.1565217391304, 1.0891304347826, 0.38888888888889
60902, 2.1565217391304, 1.0891304347826, 0.33333333333333
60903, 2.1565217391304, 1.0891304347826, 0.27777777777778
60904, 2.1565217391304, 1.0891304347826, 0.22222222222222
60905, 2.1565217391304, 1.0891304347826, 0.16666666666667
60906, 2.1565217391304, 1.0891304347826, 0.11111111111111
60907, 2.1565217391304, 1.0891304347826, 0.055555555555556
60908, 1.2434782608696, 1.0369565217391, 0.44444444444444
60909, 1.2434782608696, 1.0369565217391, 0.38888888888889
60910, 1.2434782608696, 1.0369565217391, 0.33333333333333
60911, 1.2434782608696, 1.0369565217391, 0.27777777777778
60912, 1.2434782608696, 1.0369565217391, 0.22222222222222
60913, 1.2434782608696, 1.0369565217391, 0.16666666666667
60914, 1.2434782608696, 1.0369565217391, 0.11111111111111
60915, 1.2434782608696, 1.0369565217391, 0.055555555555556
60916, 1.2869565217391, 1.0369565217391, 0.44444444444444
60917, 1.2869565217391, 1.0369565217391, 0.38888888888889
60918, 1.2869565217391, 1.0369565217391, 0.33333333333333
60919, 1.2869565217391, 1.0369565217391, 0.27777777777778
60920, 1.2869565217391, 1.0369565217391, 0.22222222222222
60921, 1.2869565217391, 1.0369565217391, 0.16666666666667
60922, 1.2869565217391, 1.0369565217391, 0.11111111111111
60923, 1.2869565217391, 1.0369565217391, 0.055555555555556
60924, 1.3304347826087, 1.0369565217391, 0.44444444444444
60925, 1.3304347826087, 1.0369565217391, 0.38888888888889
60926, 1.3304347826087, 1.0369565217391, 0.33333333333333
60927, 1.3304347826087, 1.0369565217391, 0.27777777777778
60928, 1.3304347826087, 1.0369565217391, 0.22222222222222
60929, 1.3304347826087, 1.0369565217391, 0.16666666666667
60930, 1.3304347826087, 1.0369565217391, 0.11111111111111
60931, 1.3304347826087, 1.0369565217391, 0.055555555555556
60932, 1.3739130434783, 1.0369565217391, 0.44444444444444
60933, 1.3739130434783, 1.0369565217391, 0.38888888888889
60934, 1.3739130434783, 1.0369565217391, 0.33333333333333
60935, 1.3739130434783, 1.0369565217391, 0.27777777777778
60936, 1.3739130434783, 1.0369565217391, 0.22222222222222
60937, 1.3739130434783, 1.0369565217391, 0.16666666666667
60938, 1.3739130434783, 1.0369565217391, 0.11111111111111
60939, 1.3739130434783, 1.0369565217391, 0.055555555555556
60940, 1.4173913043478, 1.0369565217391, 0.44444444444444
60941, 1.4173913043478, 1.0369565217391, 0.38888888888889
60942, 1.4173913043478, 1.0369565217391, 0.33333333333333
60943, 1.4173913043478, 1.0369565217391, 0.27777777777778
60944, 1.4173913043478, 1.0369565217391, 0.22222222222222
60945, 1.4173913043478, 1.0369565217391, 0.16666666666667
60946, 1.4173913043478, 1.0369565217391, 0.11111111111111
60947, 1.4173913043478, 1.0369565217391, 0.055555555555556
60948, 1.4608695652174, 1.0369565217391, 0.44444444444444
60949, 1.4608695652174, 1.0369565217391, 0.38888888888889
60950, 1.4608695652174, 1.0369565217391, 0.33333333333333
60951, 1.4608695652174, 1.0369565217391, 0.27777777777778
60952, 1.4608695652174, 1.0369565217391, 0.22222222222222
60953, 1.4608695652174, 1.0369565217391, 0.16666666666667
60954, 1.4608695652174, 1.0369565217391, 0.11111111111111
60955, 1.4608695652174, 1.0369565217391, 0.055555555555556
60956, 1.504347826087, 1.0369565217391, 0.44444444444444
60957, 1.504347826087, 1.0369565217391, 0.38888888888889
60958, 1.504347826087, 1.0369565217391, 0.33333333333333
60959, 1.504347826087, 1.0369565217391, 0.27777777777778
60960, 1.504347826087, 1.0369565217391, 0.22222222222222
60961, 1.504347826087, 1.0369565217391, 0.16666666666667
60962, 1.504347826087, 1.0369565217391, 0.11111111111111
60963, 1.504347826087, 1.0369565217391, 0.055555555555556
60964, 1.5478260869565, 1.0369565217391, 0.44444444444444
60965, 1.5478260869565, 1.0369565217391, 0.38888888888889
60966, 1.5478260869565, 1.0369565217391, 0.33333333333333
60967, 1.5478260869565, 1.0369565217391, 0.27777777777778
60968, 1.5478260869565, 1.0369565217391, 0.22222222222222
60969, 1.5478260869565, 1.0369565217391, 0.16666666666667
60970, 1.5478260869565, 1.0369565217391, 0.11111111111111
60971, 1.5478260869565, 1.0369565217391, 0.055555555555556
60972, 1.5913043478261, 1.0369565217391, 0.44444444444444
60973, 1.5913043478261, 1.0369565217391, 0.38888888888889
60974, 1.5913043478261, 1.0369565217391, 0.33333333333333
60975, 1.5913043478261, 1.0369565217391, 0.27777777777778
60976, 1.5913043478261, 1.0369565217391, 0.22222222222222
60977, 1.5913043478261, 1.0369565217391, 0.16666666666667
60978, 1.5913043478261, 1.0369565217391, 0.11111111111111
60979, 1.5913043478261, 1.0369565217391, 0.055555555555556
60980, 1.6347826086957, 1.0369565217391, 0.44444444444444
60981, 1.6347826086957, 1.0369565217391, 0.38888888888889
60982, 1.6347826086957, 1.0369565217391, 0.33333333333333
60983, 1.6347826086957, 1.0369565217391, 0.27777777777778
60984, 1.6347826086957, 1.0369565217391, 0.22222222222222
60985, 1.6347826086957, 1.0369565217391, 0.16666666666667
60986, 1.6347826086957, 1.0369565217391, 0.11111111111111
60987, 1.6347826086957, 1.0369565217391, 0.055555555555556
60988, 1.6782608695652, 1.0369565217391, 0.44444444444444
60989, 1.6782608695652, 1.0369565217391, 0.38888888888889
60990, 1.6782608695652, 1.0369565217391, 0.33333333333333
60991, 1.6782608695652, 1.0369565217391, 0.27777777777778
60992, 1.6782608695652, 1.0369565217391, 0.22222222222222
60993, 1.6782608695652, 1.0369565217391, 0.16666666666667
60994, 1.6782608695652, 1.0369565217391, 0.11111111111111
60995, 1.6782608695652, 1.0369565217391, 0.055555555555556
60996, 1.7217391304348, 1.0369565217391, 0.44444444444444
60997, 1.7217391304348, 1.0369565217391, 0.38888888888889
60998, 1.7217391304348, 1.0369565217391, 0.33333333333333
60999, 1.7217391304348, 1.0369565217391, 0.27777777777778
61000, 1.7217391304348, 1.0369565217391, 0.22222222222222
61001, 1.7217391304348, 1.0369565217391, 0.16666666666667
61002, 1.7217391304348, 1.0369565217391, 0.11111111111111
61003, 1.7217391304348, 1.0369565217391, 0.055555555555556
61004, 1.7652173913043, 1.0369565217391, 0.44444444444444
61005, 1.7652173913043, 1.0369565217391, 0.38888888888889
61006, 1.7652173913043, 1.0369565217391, 0.33333333333333
61007, 1.7652173913043, 1.0369565217391, 0.27777777777778
61008, 1.7652173913043, 1.0369565217391, 0.22222222222222
61009, 1.7652173913043, 1.0369565217391, 0.16666666666667
61010, 1.7652173913043, 1.0369565217391, 0.11111111111111
61011, 1.7652173913043, 1.0369565217391, 0.055555555555556
61012, 1.8086956521739, 1.0369565217391, 0.44444444444444
61013, 1.8086956521739, 1.0369565217391, 0.38888888888889
61014, 1.8086956521739, 1.0369565217391, 0.33333333333333
61015, 1.8086956521739, 1.0369565217391, 0.27777777777778
61016, 1.8086956521739, 1.0369565217391, 0.22222222222222
61017, 1.8086956521739, 1.0369565217391, 0.16666666666667
61018, 1.8086956521739, 1.0369565217391, 0.11111111111111
61019, 1.8086956521739, 1.0369565217391, 0.055555555555556
61020, 1.8521739130435, 1.0369565217391, 0.44444444444444
61021, 1.8521739130435, 1.0369565217391, 0.38888888888889
61022, 1.8521739130435, 1.0369565217391, 0.33333333333333
61023, 1.8521739130435, 1.0369565217391, 0.27777777777778
61024, 1.8521739130435, 1.0369565217391, 0.22222222222222
61025, 1.8521739130435, 1.0369565217391, 0.16666666666667
61026, 1.8521739130435, 1.0369565217391, 0.11111111111111
61027, 1.8521739130435, 1.0369565217391, 0.055555555555556
61028, 1.895652173913, 1.0369565217391, 0.44444444444444
61029, 1.895652173913, 1.0369565217391, 0.38888888888889
61030, 1.895652173913, 1.0369565217391, 0.33333333333333
61031, 1.895652173913, 1.0369565217391, 0.27777777777778
61032, 1.895652173913, 1.0369565217391, 0.22222222222222
61033, 1.895652173913, 1.0369565217391, 0.16666666666667
61034, 1.895652173913, 1.0369565217391, 0.11111111111111
61035, 1.895652173913, 1.0369565217391, 0.055555555555556
61036, 1.9391304347826, 1.0369565217391, 0.44444444444444
61037, 1.9391304347826, 1.0369565217391, 0.38888888888889
61038, 1.9391304347826, 1.0369565217391, 0.33333333333333
61039, 1.9391304347826, 1.0369565217391, 0.27777777777778
61040, 1.9391304347826, 1.0369565217391, 0.22222222222222
61041, 1.9391304347826, 1.0369565217391, 0.16666666666667
61042, 1.9391304347826, 1.0369565217391, 0.11111111111111
61043, 1.9391304347826, 1.0369565217391, 0.055555555555556
61044, 1.9826086956522, 1.0369565217391, 0.44444444444444
61045, 1.9826086956522, 1.0369565217391, 0.38888888888889
61046, 1.9826086956522, 1.0369565217391, 0.33333333333333
61047, 1.9826086956522, 1.0369565217391, 0.27777777777778
61048, 1.9826086956522, 1.0369565217391, 0.22222222222222
61049, 1.9826086956522, 1.0369565217391, 0.16666666666667
61050, 1.9826086956522, 1.0369565217391, 0.11111111111111
61051, 1.9826086956522, 1.0369565217391, 0.055555555555556
61052, 2.0260869565217, 1.0369565217391, 0.44444444444444
61053, 2.0260869565217, 1.0369565217391, 0.38888888888889
61054, 2.0260869565217, 1.0369565217391, 0.33333333333333
61055, 2.0260869565217, 1.0369565217391, 0.27777777777778
61056, 2.0260869565217, 1.0369565217391, 0.22222222222222
61057, 2.0260869565217, 1.0369565217391, 0.16666666666667
61058, 2.0260869565217, 1.0369565217391, 0.11111111111111
61059, 2.0260869565217, 1.0369565217391, 0.055555555555556
61060, 2.0695652173913, 1.0369565217391, 0.44444444444444
61061, 2.0695652173913, 1.0369565217391, 0.38888888888889
61062, 2.0695652173913, 1.0369565217391, 0.33333333333333
61063, 2.0695652173913, 1.0369565217391, 0.27777777777778
61064, 2.0695652173913, 1.0369565217391, 0.22222222222222
61065, 2.0695652173913, 1.0369565217391, 0.16666666666667
61066, 2.0695652173913, 1.0369565217391, 0.11111111111111
61067, 2.0695652173913, 1.0369565217391, 0.055555555555556
61068, 2.1130434782609, 1.0369565217391, 0.44444444444444
61069, 2.1130434782609, 1.0369565217391, 0.38888888888889
61070, 2.1130434782609, 1.0369565217391, 0.33333333333333
61071, 2.1130434782609, 1.0369565217391, 0.27777777777778
61072, 2.1130434782609, 1.0369565217391, 0.22222222222222
61073, 2.1130434782609, 1.0369565217391, 0.16666666666667
61074, 2.1130434782609, 1.0369565217391, 0.11111111111111
61075, 2.1130434782609, 1.0369565217391, 0.055555555555556
61076, 2.1565217391304, 1.0369565217391, 0.44444444444444
61077, 2.1565217391304, 1.0369565217391, 0.38888888888889
61078, 2.1565217391304, 1.0369565217391, 0.33333333333333
61079, 2.1565217391304, 1.0369565217391, 0.27777777777778
61080, 2.1565217391304, 1.0369565217391, 0.22222222222222
61081, 2.1565217391304, 1.0369565217391, 0.16666666666667
61082, 2.1565217391304, 1.0369565217391, 0.11111111111111
61083, 2.1565217391304, 1.0369565217391, 0.055555555555556
61084, 1.2434782608696, 0.98478260869565, 0.44444444444444
61085, 1.2434782608696, 0.98478260869565, 0.38888888888889
61086, 1.2434782608696, 0.98478260869565, 0.33333333333333
61087, 1.2434782608696, 0.98478260869565, 0.27777777777778
61088, 1.2434782608696, 0.98478260869565, 0.22222222222222
61089, 1.2434782608696, 0.98478260869565, 0.16666666666667
61090, 1.2434782608696, 0.98478260869565, 0.11111111111111
61091, 1.2434782608696, 0.98478260869565, 0.055555555555556
61092, 1.2869565217391, 0.98478260869565, 0.44444444444444
61093, 1.2869565217391, 0.98478260869565, 0.38888888888889
61094, 1.2869565217391, 0.98478260869565, 0.33333333333333
61095, 1.2869565217391, 0.98478260869565, 0.27777777777778
61096, 1.2869565217391, 0.98478260869565, 0.22222222222222
61097, 1.2869565217391, 0.98478260869565, 0.16666666666667
61098, 1.2869565217391, 0.98478260869565, 0.11111111111111
61099, 1.2869565217391, 0.98478260869565, 0.055555555555556
61100, 1.3304347826087, 0.98478260869565, 0.44444444444444
61101, 1.3304347826087, 0.98478260869565, 0.38888888888889
61102, 1.3304347826087, 0.98478260869565, 0.33333333333333
61103, 1.3304347826087, 0.98478260869565, 0.27777777777778
61104, 1.3304347826087, 0.98478260869565, 0.22222222222222
61105, 1.3304347826087, 0.98478260869565, 0.16666666666667
61106, 1.3304347826087, 0.98478260869565, 0.11111111111111
61107, 1.3304347826087, 0.98478260869565, 0.055555555555556
61108, 1.3739130434783, 0.98478260869565, 0.44444444444444
61109, 1.3739130434783, 0.98478260869565, 0.38888888888889
61110, 1.3739130434783, 0.98478260869565, 0.33333333333333
61111, 1.3739130434783, 0.98478260869565, 0.27777777777778
61112, 1.3739130434783, 0.98478260869565, 0.22222222222222
61113, 1.3739130434783, 0.98478260869565, 0.16666666666667
61114, 1.3739130434783, 0.98478260869565, 0.11111111111111
61115, 1.3739130434783, 0.98478260869565, 0.055555555555556
61116, 1.4173913043478, 0.98478260869565, 0.44444444444444
61117, 1.4173913043478, 0.98478260869565, 0.38888888888889
61118, 1.4173913043478, 0.98478260869565, 0.33333333333333
61119, 1.4173913043478, 0.98478260869565, 0.27777777777778
61120, 1.4173913043478, 0.98478260869565, 0.22222222222222
61121, 1.4173913043478, 0.98478260869565, 0.16666666666667
61122, 1.4173913043478, 0.98478260869565, 0.11111111111111
61123, 1.4173913043478, 0.98478260869565, 0.055555555555556
61124, 1.4608695652174, 0.98478260869565, 0.44444444444444
61125, 1.4608695652174, 0.98478260869565, 0.38888888888889
61126, 1.4608695652174, 0.98478260869565, 0.33333333333333
61127, 1.4608695652174, 0.98478260869565, 0.27777777777778
61128, 1.4608695652174, 0.98478260869565, 0.22222222222222
61129, 1.4608695652174, 0.98478260869565, 0.16666666666667
61130, 1.4608695652174, 0.98478260869565, 0.11111111111111
61131, 1.4608695652174, 0.98478260869565, 0.055555555555556
61132, 1.504347826087, 0.98478260869565, 0.44444444444444
61133, 1.504347826087, 0.98478260869565, 0.38888888888889
61134, 1.504347826087, 0.98478260869565, 0.33333333333333
61135, 1.504347826087, 0.98478260869565, 0.27777777777778
61136, 1.504347826087, 0.98478260869565, 0.22222222222222
61137, 1.504347826087, 0.98478260869565, 0.16666666666667
61138, 1.504347826087, 0.98478260869565, 0.11111111111111
61139, 1.504347826087, 0.98478260869565, 0.055555555555556
61140, 1.5478260869565, 0.98478260869565, 0.44444444444444
61141, 1.5478260869565, 0.98478260869565, 0.38888888888889
61142, 1.5478260869565, 0.98478260869565, 0.33333333333333
61143, 1.5478260869565, 0.98478260869565, 0.27777777777778
61144, 1.5478260869565, 0.98478260869565, 0.22222222222222
61145, 1.5478260869565, 0.98478260869565, 0.16666666666667
61146, 1.5478260869565, 0.98478260869565, 0.11111111111111
61147, 1.5478260869565, 0.98478260869565, 0.055555555555556
61148, 1.5913043478261, 0.98478260869565, 0.44444444444444
61149, 1.5913043478261, 0.98478260869565, 0.38888888888889
61150, 1.5913043478261, 0.98478260869565, 0.33333333333333
61151, 1.5913043478261, 0.98478260869565, 0.27777777777778
61152, 1.5913043478261, 0.98478260869565, 0.22222222222222
61153, 1.5913043478261, 0.98478260869565, 0.16666666666667
61154, 1.5913043478261, 0.98478260869565, 0.11111111111111
61155, 1.5913043478261, 0.98478260869565, 0.055555555555556
61156, 1.6347826086957, 0.98478260869565, 0.44444444444444
61157, 1.6347826086957, 0.98478260869565, 0.38888888888889
61158, 1.6347826086957, 0.98478260869565, 0.33333333333333
61159, 1.6347826086957, 0.98478260869565, 0.27777777777778
61160, 1.6347826086957, 0.98478260869565, 0.22222222222222
61161, 1.6347826086957, 0.98478260869565, 0.16666666666667
61162, 1.6347826086957, 0.98478260869565, 0.11111111111111
61163, 1.6347826086957, 0.98478260869565, 0.055555555555556
61164, 1.6782608695652, 0.98478260869565, 0.44444444444444
61165, 1.6782608695652, 0.98478260869565, 0.38888888888889
61166, 1.6782608695652, 0.98478260869565, 0.33333333333333
61167, 1.6782608695652, 0.98478260869565, 0.27777777777778
61168, 1.6782608695652, 0.98478260869565, 0.22222222222222
61169, 1.6782608695652, 0.98478260869565, 0.16666666666667
61170, 1.6782608695652, 0.98478260869565, 0.11111111111111
61171, 1.6782608695652, 0.98478260869565, 0.055555555555556
61172, 1.7217391304348, 0.98478260869565, 0.44444444444444
61173, 1.7217391304348, 0.98478260869565, 0.38888888888889
61174, 1.7217391304348, 0.98478260869565, 0.33333333333333
61175, 1.7217391304348, 0.98478260869565, 0.27777777777778
61176, 1.7217391304348, 0.98478260869565, 0.22222222222222
61177, 1.7217391304348, 0.98478260869565, 0.16666666666667
61178, 1.7217391304348, 0.98478260869565, 0.11111111111111
61179, 1.7217391304348, 0.98478260869565, 0.055555555555556
61180, 1.7652173913043, 0.98478260869565, 0.44444444444444
61181, 1.7652173913043, 0.98478260869565, 0.38888888888889
61182, 1.7652173913043, 0.98478260869565, 0.33333333333333
61183, 1.7652173913043, 0.98478260869565, 0.27777777777778
61184, 1.7652173913043, 0.98478260869565, 0.22222222222222
61185, 1.7652173913043, 0.98478260869565, 0.16666666666667
61186, 1.7652173913043, 0.98478260869565, 0.11111111111111
61187, 1.7652173913043, 0.98478260869565, 0.055555555555556
61188, 1.8086956521739, 0.98478260869565, 0.44444444444444
61189, 1.8086956521739, 0.98478260869565, 0.38888888888889
61190, 1.8086956521739, 0.98478260869565, 0.33333333333333
61191, 1.8086956521739, 0.98478260869565, 0.27777777777778
61192, 1.8086956521739, 0.98478260869565, 0.22222222222222
61193, 1.8086956521739, 0.98478260869565, 0.16666666666667
61194, 1.8086956521739, 0.98478260869565, 0.11111111111111
61195, 1.8086956521739, 0.98478260869565, 0.055555555555556
61196, 1.8521739130435, 0.98478260869565, 0.44444444444444
61197, 1.8521739130435, 0.98478260869565, 0.38888888888889
61198, 1.8521739130435, 0.98478260869565, 0.33333333333333
61199, 1.8521739130435, 0.98478260869565, 0.27777777777778
61200, 1.8521739130435, 0.98478260869565, 0.22222222222222
61201, 1.8521739130435, 0.98478260869565, 0.16666666666667
61202, 1.8521739130435, 0.98478260869565, 0.11111111111111
61203, 1.8521739130435, 0.98478260869565, 0.055555555555556
61204, 1.895652173913, 0.98478260869565, 0.44444444444444
61205, 1.895652173913, 0.98478260869565, 0.38888888888889
61206, 1.895652173913, 0.98478260869565, 0.33333333333333
61207, 1.895652173913, 0.98478260869565, 0.27777777777778
61208, 1.895652173913, 0.98478260869565, 0.22222222222222
61209, 1.895652173913, 0.98478260869565, 0.16666666666667
61210, 1.895652173913, 0.98478260869565, 0.11111111111111
61211, 1.895652173913, 0.98478260869565, 0.055555555555556
61212, 1.9391304347826, 0.98478260869565, 0.44444444444444
61213, 1.9391304347826, 0.98478260869565, 0.38888888888889
61214, 1.9391304347826, 0.98478260869565, 0.33333333333333
61215, 1.9391304347826, 0.98478260869565, 0.27777777777778
61216, 1.9391304347826, 0.98478260869565, 0.22222222222222
61217, 1.9391304347826, 0.98478260869565, 0.16666666666667
61218, 1.9391304347826, 0.98478260869565, 0.11111111111111
61219, 1.9391304347826, 0.98478260869565, 0.055555555555556
61220, 1.9826086956522, 0.98478260869565, 0.44444444444444
61221, 1.9826086956522, 0.98478260869565, 0.38888888888889
61222, 1.9826086956522, 0.98478260869565, 0.33333333333333
61223, 1.9826086956522, 0.98478260869565, 0.27777777777778
61224, 1.9826086956522, 0.98478260869565, 0.22222222222222
61225, 1.9826086956522, 0.98478260869565, 0.16666666666667
61226, 1.9826086956522, 0.98478260869565, 0.11111111111111
61227, 1.9826086956522, 0.98478260869565, 0.055555555555556
61228, 2.0260869565217, 0.98478260869565, 0.44444444444444
61229, 2.0260869565217, 0.98478260869565, 0.38888888888889
61230, 2.0260869565217, 0.98478260869565, 0.33333333333333
61231, 2.0260869565217, 0.98478260869565, 0.27777777777778
61232, 2.0260869565217, 0.98478260869565, 0.22222222222222
61233, 2.0260869565217, 0.98478260869565, 0.16666666666667
61234, 2.0260869565217, 0.98478260869565, 0.11111111111111
61235, 2.0260869565217, 0.98478260869565, 0.055555555555556
61236, 2.0695652173913, 0.98478260869565, 0.44444444444444
61237, 2.0695652173913, 0.98478260869565, 0.38888888888889
61238, 2.0695652173913, 0.98478260869565, 0.33333333333333
61239, 2.0695652173913, 0.98478260869565, 0.27777777777778
61240, 2.0695652173913, 0.98478260869565, 0.22222222222222
61241, 2.0695652173913, 0.98478260869565, 0.16666666666667
61242, 2.0695652173913, 0.98478260869565, 0.11111111111111
61243, 2.0695652173913, 0.98478260869565, 0.055555555555556
61244, 2.1130434782609, 0.98478260869565, 0.44444444444444
61245, 2.1130434782609, 0.98478260869565, 0.38888888888889
61246, 2.1130434782609, 0.98478260869565, 0.33333333333333
61247, 2.1130434782609, 0.98478260869565, 0.27777777777778
61248, 2.1130434782609, 0.98478260869565, 0.22222222222222
61249, 2.1130434782609, 0.98478260869565, 0.16666666666667
61250, 2.1130434782609, 0.98478260869565, 0.11111111111111
61251, 2.1130434782609, 0.98478260869565, 0.055555555555556
61252, 2.1565217391304, 0.98478260869565, 0.44444444444444
61253, 2.1565217391304, 0.98478260869565, 0.38888888888889
61254, 2.1565217391304, 0.98478260869565, 0.33333333333333
61255, 2.1565217391304, 0.98478260869565, 0.27777777777778
61256, 2.1565217391304, 0.98478260869565, 0.22222222222222
61257, 2.1565217391304, 0.98478260869565, 0.16666666666667
61258, 2.1565217391304, 0.98478260869565, 0.11111111111111
61259, 2.1565217391304, 0.98478260869565, 0.055555555555556
61260, 1.2434782608696, 0.93260869565218, 0.44444444444444
61261, 1.2434782608696, 0.93260869565217, 0.38888888888889
61262, 1.2434782608696, 0.93260869565217, 0.33333333333333
61263, 1.2434782608696, 0.93260869565218, 0.27777777777778
61264, 1.2434782608696, 0.93260869565217, 0.22222222222222
61265, 1.2434782608696, 0.93260869565217, 0.16666666666667
61266, 1.2434782608696, 0.93260869565217, 0.11111111111111
61267, 1.2434782608696, 0.93260869565217, 0.055555555555556
61268, 1.2869565217391, 0.93260869565218, 0.44444444444444
61269, 1.2869565217391, 0.93260869565217, 0.38888888888889
61270, 1.2869565217391, 0.93260869565217, 0.33333333333333
61271, 1.2869565217391, 0.93260869565217, 0.27777777777778
61272, 1.2869565217391, 0.93260869565217, 0.22222222222222
61273, 1.2869565217391, 0.93260869565217, 0.16666666666667
61274, 1.2869565217391, 0.93260869565217, 0.11111111111111
61275, 1.2869565217391, 0.93260869565217, 0.055555555555556
61276, 1.3304347826087, 0.93260869565218, 0.44444444444444
61277, 1.3304347826087, 0.93260869565217, 0.38888888888889
61278, 1.3304347826087, 0.93260869565217, 0.33333333333333
61279, 1.3304347826087, 0.93260869565218, 0.27777777777778
61280, 1.3304347826087, 0.93260869565217, 0.22222222222222
61281, 1.3304347826087, 0.93260869565217, 0.16666666666667
61282, 1.3304347826087, 0.93260869565218, 0.11111111111111
61283, 1.3304347826087, 0.93260869565218, 0.055555555555556
61284, 1.3739130434783, 0.93260869565218, 0.44444444444444
61285, 1.3739130434783, 0.93260869565217, 0.38888888888889
61286, 1.3739130434783, 0.93260869565217, 0.33333333333333
61287, 1.3739130434783, 0.93260869565218, 0.27777777777778
61288, 1.3739130434783, 0.93260869565217, 0.22222222222222
61289, 1.3739130434783, 0.93260869565217, 0.16666666666667
61290, 1.3739130434783, 0.93260869565217, 0.11111111111111
61291, 1.3739130434783, 0.93260869565217, 0.055555555555556
61292, 1.4173913043478, 0.93260869565218, 0.44444444444444
61293, 1.4173913043478, 0.93260869565217, 0.38888888888889
61294, 1.4173913043478, 0.93260869565217, 0.33333333333333
61295, 1.4173913043478, 0.93260869565218, 0.27777777777778
61296, 1.4173913043478, 0.93260869565217, 0.22222222222222
61297, 1.4173913043478, 0.93260869565217, 0.16666666666667
61298, 1.4173913043478, 0.93260869565217, 0.11111111111111
61299, 1.4173913043478, 0.93260869565217, 0.055555555555556
61300, 1.4608695652174, 0.93260869565218, 0.44444444444444
61301, 1.4608695652174, 0.93260869565217, 0.38888888888889
61302, 1.4608695652174, 0.93260869565217, 0.33333333333333
61303, 1.4608695652174, 0.93260869565218, 0.27777777777778
61304, 1.4608695652174, 0.93260869565217, 0.22222222222222
61305, 1.4608695652174, 0.93260869565217, 0.16666666666667
61306, 1.4608695652174, 0.93260869565217, 0.11111111111111
61307, 1.4608695652174, 0.93260869565217, 0.055555555555556
61308, 1.504347826087, 0.93260869565217, 0.44444444444444
61309, 1.504347826087, 0.93260869565217, 0.38888888888889
61310, 1.504347826087, 0.93260869565217, 0.33333333333333
61311, 1.504347826087, 0.93260869565217, 0.27777777777778
61312, 1.504347826087, 0.93260869565217, 0.22222222222222
61313, 1.504347826087, 0.93260869565217, 0.16666666666667
61314, 1.504347826087, 0.93260869565217, 0.11111111111111
61315, 1.504347826087, 0.93260869565217, 0.055555555555556
61316, 1.5478260869565, 0.93260869565218, 0.44444444444444
61317, 1.5478260869565, 0.93260869565217, 0.38888888888889
61318, 1.5478260869565, 0.93260869565217, 0.33333333333333
61319, 1.5478260869565, 0.93260869565218, 0.27777777777778
61320, 1.5478260869565, 0.93260869565217, 0.22222222222222
61321, 1.5478260869565, 0.93260869565218, 0.16666666666667
61322, 1.5478260869565, 0.93260869565218, 0.11111111111111
61323, 1.5478260869565, 0.93260869565217, 0.055555555555556
61324, 1.5913043478261, 0.93260869565218, 0.44444444444444
61325, 1.5913043478261, 0.93260869565217, 0.38888888888889
61326, 1.5913043478261, 0.93260869565217, 0.33333333333333
61327, 1.5913043478261, 0.93260869565218, 0.27777777777778
61328, 1.5913043478261, 0.93260869565218, 0.22222222222222
61329, 1.5913043478261, 0.93260869565217, 0.16666666666667
61330, 1.5913043478261, 0.93260869565218, 0.11111111111111
61331, 1.5913043478261, 0.93260869565217, 0.055555555555556
61332, 1.6347826086957, 0.93260869565218, 0.44444444444444
61333, 1.6347826086957, 0.93260869565217, 0.38888888888889
61334, 1.6347826086957, 0.93260869565217, 0.33333333333333
61335, 1.6347826086957, 0.93260869565218, 0.27777777777778
61336, 1.6347826086957, 0.93260869565217, 0.22222222222222
61337, 1.6347826086957, 0.93260869565217, 0.16666666666667
61338, 1.6347826086957, 0.93260869565218, 0.11111111111111
61339, 1.6347826086957, 0.93260869565218, 0.055555555555556
61340, 1.6782608695652, 0.93260869565218, 0.44444444444444
61341, 1.6782608695652, 0.93260869565217, 0.38888888888889
61342, 1.6782608695652, 0.93260869565217, 0.33333333333333
61343, 1.6782608695652, 0.93260869565218, 0.27777777777778
61344, 1.6782608695652, 0.93260869565217, 0.22222222222222
61345, 1.6782608695652, 0.93260869565217, 0.16666666666667
61346, 1.6782608695652, 0.93260869565217, 0.11111111111111
61347, 1.6782608695652, 0.93260869565217, 0.055555555555556
61348, 1.7217391304348, 0.93260869565218, 0.44444444444444
61349, 1.7217391304348, 0.93260869565217, 0.38888888888889
61350, 1.7217391304348, 0.93260869565217, 0.33333333333333
61351, 1.7217391304348, 0.93260869565218, 0.27777777777778
61352, 1.7217391304348, 0.93260869565217, 0.22222222222222
61353, 1.7217391304348, 0.93260869565217, 0.16666666666667
61354, 1.7217391304348, 0.93260869565217, 0.11111111111111
61355, 1.7217391304348, 0.93260869565217, 0.055555555555556
61356, 1.7652173913043, 0.93260869565218, 0.44444444444444
61357, 1.7652173913043, 0.93260869565217, 0.38888888888889
61358, 1.7652173913043, 0.93260869565217, 0.33333333333333
61359, 1.7652173913043, 0.93260869565218, 0.27777777777778
61360, 1.7652173913043, 0.93260869565217, 0.22222222222222
61361, 1.7652173913043, 0.93260869565217, 0.16666666666667
61362, 1.7652173913043, 0.93260869565217, 0.11111111111111
61363, 1.7652173913043, 0.93260869565217, 0.055555555555556
61364, 1.8086956521739, 0.93260869565218, 0.44444444444444
61365, 1.8086956521739, 0.93260869565217, 0.38888888888889
61366, 1.8086956521739, 0.93260869565217, 0.33333333333333
61367, 1.8086956521739, 0.93260869565218, 0.27777777777778
61368, 1.8086956521739, 0.93260869565217, 0.22222222222222
61369, 1.8086956521739, 0.93260869565217, 0.16666666666667
61370, 1.8086956521739, 0.93260869565218, 0.11111111111111
61371, 1.8086956521739, 0.93260869565217, 0.055555555555556
61372, 1.8521739130435, 0.93260869565217, 0.44444444444444
61373, 1.8521739130435, 0.93260869565217, 0.38888888888889
61374, 1.8521739130435, 0.93260869565217, 0.33333333333333
61375, 1.8521739130435, 0.93260869565217, 0.27777777777778
61376, 1.8521739130435, 0.93260869565217, 0.22222222222222
61377, 1.8521739130435, 0.93260869565218, 0.16666666666667
61378, 1.8521739130435, 0.93260869565218, 0.11111111111111
61379, 1.8521739130435, 0.93260869565217, 0.055555555555556
61380, 1.895652173913, 0.93260869565218, 0.44444444444444
61381, 1.895652173913, 0.93260869565217, 0.38888888888889
61382, 1.895652173913, 0.93260869565217, 0.33333333333333
61383, 1.895652173913, 0.93260869565218, 0.27777777777778
61384, 1.895652173913, 0.93260869565217, 0.22222222222222
61385, 1.895652173913, 0.93260869565217, 0.16666666666667
61386, 1.895652173913, 0.93260869565217, 0.11111111111111
61387, 1.895652173913, 0.93260869565217, 0.055555555555556
61388, 1.9391304347826, 0.93260869565217, 0.44444444444444
61389, 1.9391304347826, 0.93260869565217, 0.38888888888889
61390, 1.9391304347826, 0.93260869565217, 0.33333333333333
61391, 1.9391304347826, 0.93260869565218, 0.27777777777778
61392, 1.9391304347826, 0.93260869565217, 0.22222222222222
61393, 1.9391304347826, 0.93260869565218, 0.16666666666667
61394, 1.9391304347826, 0.93260869565217, 0.11111111111111
61395, 1.9391304347826, 0.93260869565218, 0.055555555555556
61396, 1.9826086956522, 0.93260869565218, 0.44444444444444
61397, 1.9826086956522, 0.93260869565217, 0.38888888888889
61398, 1.9826086956522, 0.93260869565217, 0.33333333333333
61399, 1.9826086956522, 0.93260869565217, 0.27777777777778
61400, 1.9826086956522, 0.93260869565217, 0.22222222222222
61401, 1.9826086956522, 0.93260869565217, 0.16666666666667
61402, 1.9826086956522, 0.93260869565217, 0.11111111111111
61403, 1.9826086956522, 0.93260869565217, 0.055555555555556
61404, 2.0260869565217, 0.93260869565218, 0.44444444444444
61405, 2.0260869565217, 0.93260869565217, 0.38888888888889
61406, 2.0260869565217, 0.93260869565217, 0.33333333333333
61407, 2.0260869565217, 0.93260869565218, 0.27777777777778
61408, 2.0260869565217, 0.93260869565217, 0.22222222222222
61409, 2.0260869565217, 0.93260869565217, 0.16666666666667
61410, 2.0260869565217, 0.93260869565217, 0.11111111111111
61411, 2.0260869565217, 0.93260869565217, 0.055555555555556
61412, 2.0695652173913, 0.93260869565218, 0.44444444444444
61413, 2.0695652173913, 0.93260869565217, 0.38888888888889
61414, 2.0695652173913, 0.93260869565217, 0.33333333333333
61415, 2.0695652173913, 0.93260869565218, 0.27777777777778
61416, 2.0695652173913, 0.93260869565217, 0.22222222222222
61417, 2.0695652173913, 0.93260869565217, 0.16666666666667
61418, 2.0695652173913, 0.93260869565218, 0.11111111111111
61419, 2.0695652173913, 0.93260869565217, 0.055555555555556
61420, 2.1130434782609, 0.93260869565218, 0.44444444444444
61421, 2.1130434782609, 0.93260869565217, 0.38888888888889
61422, 2.1130434782609, 0.93260869565217, 0.33333333333333
61423, 2.1130434782609, 0.93260869565218, 0.27777777777778
61424, 2.1130434782609, 0.93260869565217, 0.22222222222222
61425, 2.1130434782609, 0.93260869565217, 0.16666666666667
61426, 2.1130434782609, 0.93260869565217, 0.11111111111111
61427, 2.1130434782609, 0.93260869565217, 0.055555555555556
61428, 2.1565217391304, 0.93260869565218, 0.44444444444444
61429, 2.1565217391304, 0.93260869565217, 0.38888888888889
61430, 2.1565217391304, 0.93260869565217, 0.33333333333333
61431, 2.1565217391304, 0.93260869565218, 0.27777777777778
61432, 2.1565217391304, 0.93260869565217, 0.22222222222222
61433, 2.1565217391304, 0.93260869565217, 0.16666666666667
61434, 2.1565217391304, 0.93260869565217, 0.11111111111111
61435, 2.1565217391304, 0.93260869565217, 0.055555555555556
61436, 1.2434782608696, 0.8804347826087, 0.44444444444444
61437, 1.2434782608696, 0.8804347826087, 0.38888888888889
61438, 1.2434782608696, 0.8804347826087, 0.33333333333333
61439, 1.2434782608696, 0.8804347826087, 0.27777777777778
61440, 1.2434782608696, 0.8804347826087, 0.22222222222222
61441, 1.2434782608696, 0.8804347826087, 0.16666666666667
61442, 1.2434782608696, 0.8804347826087, 0.11111111111111
61443, 1.2434782608696, 0.8804347826087, 0.055555555555556
61444, 1.2869565217391, 0.8804347826087, 0.44444444444444
61445, 1.2869565217391, 0.8804347826087, 0.38888888888889
61446, 1.2869565217391, 0.8804347826087, 0.33333333333333
61447, 1.2869565217391, 0.8804347826087, 0.27777777777778
61448, 1.2869565217391, 0.8804347826087, 0.22222222222222
61449, 1.2869565217391, 0.8804347826087, 0.16666666666667
61450, 1.2869565217391, 0.8804347826087, 0.11111111111111
61451, 1.2869565217391, 0.8804347826087, 0.055555555555556
61452, 1.3304347826087, 0.8804347826087, 0.44444444444444
61453, 1.3304347826087, 0.8804347826087, 0.38888888888889
61454, 1.3304347826087, 0.8804347826087, 0.33333333333333
61455, 1.3304347826087, 0.8804347826087, 0.27777777777778
61456, 1.3304347826087, 0.8804347826087, 0.22222222222222
61457, 1.3304347826087, 0.8804347826087, 0.16666666666667
61458, 1.3304347826087, 0.8804347826087, 0.11111111111111
61459, 1.3304347826087, 0.8804347826087, 0.055555555555556
61460, 1.3739130434783, 0.8804347826087, 0.44444444444444
61461, 1.3739130434783, 0.8804347826087, 0.38888888888889
61462, 1.3739130434783, 0.8804347826087, 0.33333333333333
61463, 1.3739130434783, 0.8804347826087, 0.27777777777778
61464, 1.3739130434783, 0.8804347826087, 0.22222222222222
61465, 1.3739130434783, 0.8804347826087, 0.16666666666667
61466, 1.3739130434783, 0.8804347826087, 0.11111111111111
61467, 1.3739130434783, 0.8804347826087, 0.055555555555556
61468, 1.4173913043478, 0.8804347826087, 0.44444444444444
61469, 1.4173913043478, 0.8804347826087, 0.38888888888889
61470, 1.4173913043478, 0.8804347826087, 0.33333333333333
61471, 1.4173913043478, 0.8804347826087, 0.27777777777778
61472, 1.4173913043478, 0.8804347826087, 0.22222222222222
61473, 1.4173913043478, 0.8804347826087, 0.16666666666667
61474, 1.4173913043478, 0.8804347826087, 0.11111111111111
61475, 1.4173913043478, 0.8804347826087, 0.055555555555556
61476, 1.4608695652174, 0.8804347826087, 0.44444444444444
61477, 1.4608695652174, 0.8804347826087, 0.38888888888889
61478, 1.4608695652174, 0.8804347826087, 0.33333333333333
61479, 1.4608695652174, 0.8804347826087, 0.27777777777778
61480, 1.4608695652174, 0.8804347826087, 0.22222222222222
61481, 1.4608695652174, 0.8804347826087, 0.16666666666667
61482, 1.4608695652174, 0.8804347826087, 0.11111111111111
61483, 1.4608695652174, 0.8804347826087, 0.055555555555556
61484, 1.504347826087, 0.8804347826087, 0.44444444444444
61485, 1.504347826087, 0.8804347826087, 0.38888888888889
61486, 1.504347826087, 0.8804347826087, 0.33333333333333
61487, 1.504347826087, 0.8804347826087, 0.27777777777778
61488, 1.504347826087, 0.8804347826087, 0.22222222222222
61489, 1.504347826087, 0.8804347826087, 0.16666666666667
61490, 1.504347826087, 0.8804347826087, 0.11111111111111
61491, 1.504347826087, 0.8804347826087, 0.055555555555556
61492, 1.5478260869565, 0.8804347826087, 0.44444444444444
61493, 1.5478260869565, 0.8804347826087, 0.38888888888889
61494, 1.5478260869565, 0.8804347826087, 0.33333333333333
61495, 1.5478260869565, 0.8804347826087, 0.27777777777778
61496, 1.5478260869565, 0.8804347826087, 0.22222222222222
61497, 1.5478260869565, 0.8804347826087, 0.16666666666667
61498, 1.5478260869565, 0.8804347826087, 0.11111111111111
61499, 1.5478260869565, 0.8804347826087, 0.055555555555556
61500, 1.5913043478261, 0.8804347826087, 0.44444444444444
61501, 1.5913043478261, 0.8804347826087, 0.38888888888889
61502, 1.5913043478261, 0.8804347826087, 0.33333333333333
61503, 1.5913043478261, 0.8804347826087, 0.27777777777778
61504, 1.5913043478261, 0.8804347826087, 0.22222222222222
61505, 1.5913043478261, 0.8804347826087, 0.16666666666667
61506, 1.5913043478261, 0.8804347826087, 0.11111111111111
61507, 1.5913043478261, 0.8804347826087, 0.055555555555556
61508, 1.6347826086957, 0.8804347826087, 0.44444444444444
61509, 1.6347826086957, 0.8804347826087, 0.38888888888889
61510, 1.6347826086957, 0.8804347826087, 0.33333333333333
61511, 1.6347826086957, 0.8804347826087, 0.27777777777778
61512, 1.6347826086957, 0.8804347826087, 0.22222222222222
61513, 1.6347826086957, 0.8804347826087, 0.16666666666667
61514, 1.6347826086957, 0.8804347826087, 0.11111111111111
61515, 1.6347826086957, 0.8804347826087, 0.055555555555556
61516, 1.6782608695652, 0.8804347826087, 0.44444444444444
61517, 1.6782608695652, 0.8804347826087, 0.38888888888889
61518, 1.6782608695652, 0.8804347826087, 0.33333333333333
61519, 1.6782608695652, 0.8804347826087, 0.27777777777778
61520, 1.6782608695652, 0.8804347826087, 0.22222222222222
61521, 1.6782608695652, 0.8804347826087, 0.16666666666667
61522, 1.6782608695652, 0.8804347826087, 0.11111111111111
61523, 1.6782608695652, 0.8804347826087, 0.055555555555556
61524, 1.7217391304348, 0.8804347826087, 0.44444444444444
61525, 1.7217391304348, 0.8804347826087, 0.38888888888889
61526, 1.7217391304348, 0.8804347826087, 0.33333333333333
61527, 1.7217391304348, 0.8804347826087, 0.27777777777778
61528, 1.7217391304348, 0.8804347826087, 0.22222222222222
61529, 1.7217391304348, 0.8804347826087, 0.16666666666667
61530, 1.7217391304348, 0.8804347826087, 0.11111111111111
61531, 1.7217391304348, 0.8804347826087, 0.055555555555556
61532, 1.7652173913043, 0.8804347826087, 0.44444444444444
61533, 1.7652173913043, 0.8804347826087, 0.38888888888889
61534, 1.7652173913043, 0.8804347826087, 0.33333333333333
61535, 1.7652173913043, 0.8804347826087, 0.27777777777778
61536, 1.7652173913043, 0.8804347826087, 0.22222222222222
61537, 1.7652173913043, 0.8804347826087, 0.16666666666667
61538, 1.7652173913043, 0.8804347826087, 0.11111111111111
61539, 1.7652173913043, 0.8804347826087, 0.055555555555556
61540, 1.8086956521739, 0.8804347826087, 0.44444444444444
61541, 1.8086956521739, 0.8804347826087, 0.38888888888889
61542, 1.8086956521739, 0.8804347826087, 0.33333333333333
61543, 1.8086956521739, 0.8804347826087, 0.27777777777778
61544, 1.8086956521739, 0.8804347826087, 0.22222222222222
61545, 1.8086956521739, 0.8804347826087, 0.16666666666667
61546, 1.8086956521739, 0.8804347826087, 0.11111111111111
61547, 1.8086956521739, 0.8804347826087, 0.055555555555556
61548, 1.8521739130435, 0.8804347826087, 0.44444444444444
61549, 1.8521739130435, 0.8804347826087, 0.38888888888889
61550, 1.8521739130435, 0.8804347826087, 0.33333333333333
61551, 1.8521739130435, 0.8804347826087, 0.27777777777778
61552, 1.8521739130435, 0.8804347826087, 0.22222222222222
61553, 1.8521739130435, 0.8804347826087, 0.16666666666667
61554, 1.8521739130435, 0.8804347826087, 0.11111111111111
61555, 1.8521739130435, 0.8804347826087, 0.055555555555556
61556, 1.895652173913, 0.8804347826087, 0.44444444444444
61557, 1.895652173913, 0.8804347826087, 0.38888888888889
61558, 1.895652173913, 0.8804347826087, 0.33333333333333
61559, 1.895652173913, 0.8804347826087, 0.27777777777778
61560, 1.895652173913, 0.8804347826087, 0.22222222222222
61561, 1.895652173913, 0.8804347826087, 0.16666666666667
61562, 1.895652173913, 0.8804347826087, 0.11111111111111
61563, 1.895652173913, 0.8804347826087, 0.055555555555556
61564, 1.9391304347826, 0.8804347826087, 0.44444444444444
61565, 1.9391304347826, 0.8804347826087, 0.38888888888889
61566, 1.9391304347826, 0.8804347826087, 0.33333333333333
61567, 1.9391304347826, 0.8804347826087, 0.27777777777778
61568, 1.9391304347826, 0.8804347826087, 0.22222222222222
61569, 1.9391304347826, 0.8804347826087, 0.16666666666667
61570, 1.9391304347826, 0.8804347826087, 0.11111111111111
61571, 1.9391304347826, 0.8804347826087, 0.055555555555556
61572, 1.9826086956522, 0.8804347826087, 0.44444444444444
61573, 1.9826086956522, 0.8804347826087, 0.38888888888889
61574, 1.9826086956522, 0.8804347826087, 0.33333333333333
61575, 1.9826086956522, 0.8804347826087, 0.27777777777778
61576, 1.9826086956522, 0.8804347826087, 0.22222222222222
61577, 1.9826086956522, 0.8804347826087, 0.16666666666667
61578, 1.9826086956522, 0.8804347826087, 0.11111111111111
61579, 1.9826086956522, 0.8804347826087, 0.055555555555556
61580, 2.0260869565217, 0.8804347826087, 0.44444444444444
61581, 2.0260869565217, 0.8804347826087, 0.38888888888889
61582, 2.0260869565217, 0.8804347826087, 0.33333333333333
61583, 2.0260869565217, 0.8804347826087, 0.27777777777778
61584, 2.0260869565217, 0.8804347826087, 0.22222222222222
61585, 2.0260869565217, 0.8804347826087, 0.16666666666667
61586, 2.0260869565217, 0.8804347826087, 0.11111111111111
61587, 2.0260869565217, 0.8804347826087, 0.055555555555556
61588, 2.0695652173913, 0.8804347826087, 0.44444444444444
61589, 2.0695652173913, 0.8804347826087, 0.38888888888889
61590, 2.0695652173913, 0.8804347826087, 0.33333333333333
61591, 2.0695652173913, 0.8804347826087, 0.27777777777778
61592, 2.0695652173913, 0.8804347826087, 0.22222222222222
61593, 2.0695652173913, 0.8804347826087, 0.16666666666667
61594, 2.0695652173913, 0.8804347826087, 0.11111111111111
61595, 2.0695652173913, 0.8804347826087, 0.055555555555556
61596, 2.1130434782609, 0.8804347826087, 0.44444444444444
61597, 2.1130434782609, 0.8804347826087, 0.38888888888889
61598, 2.1130434782609, 0.8804347826087, 0.33333333333333
61599, 2.1130434782609, 0.8804347826087, 0.27777777777778
61600, 2.1130434782609, 0.8804347826087, 0.22222222222222
61601, 2.1130434782609, 0.8804347826087, 0.16666666666667
61602, 2.1130434782609, 0.8804347826087, 0.11111111111111
61603, 2.1130434782609, 0.8804347826087, 0.055555555555556
61604, 2.1565217391304, 0.8804347826087, 0.44444444444444
61605, 2.1565217391304, 0.8804347826087, 0.38888888888889
61606, 2.1565217391304, 0.8804347826087, 0.33333333333333
61607, 2.1565217391304, 0.8804347826087, 0.27777777777778
61608, 2.1565217391304, 0.8804347826087, 0.22222222222222
61609, 2.1565217391304, 0.8804347826087, 0.16666666666667
61610, 2.1565217391304, 0.8804347826087, 0.11111111111111
61611, 2.1565217391304, 0.8804347826087, 0.055555555555556
61612, 1.2434782608696, 0.82826086956522, 0.44444444444444
61613, 1.2434782608696, 0.82826086956522, 0.38888888888889
61614, 1.2434782608696, 0.82826086956522, 0.33333333333333
61615, 1.2434782608696, 0.82826086956522, 0.27777777777778
61616, 1.2434782608696, 0.82826086956522, 0.22222222222222
61617, 1.2434782608696, 0.82826086956522, 0.16666666666667
61618, 1.2434782608696, 0.82826086956522, 0.11111111111111
61619, 1.2434782608696, 0.82826086956522, 0.055555555555556
61620, 1.2869565217391, 0.82826086956522, 0.44444444444444
61621, 1.2869565217391, 0.82826086956522, 0.38888888888889
61622, 1.2869565217391, 0.82826086956522, 0.33333333333333
61623, 1.2869565217391, 0.82826086956522, 0.27777777777778
61624, 1.2869565217391, 0.82826086956522, 0.22222222222222
61625, 1.2869565217391, 0.82826086956522, 0.16666666666667
61626, 1.2869565217391, 0.82826086956522, 0.11111111111111
61627, 1.2869565217391, 0.82826086956522, 0.055555555555556
61628, 1.3304347826087, 0.82826086956522, 0.44444444444444
61629, 1.3304347826087, 0.82826086956522, 0.38888888888889
61630, 1.3304347826087, 0.82826086956522, 0.33333333333333
61631, 1.3304347826087, 0.82826086956522, 0.27777777777778
61632, 1.3304347826087, 0.82826086956522, 0.22222222222222
61633, 1.3304347826087, 0.82826086956522, 0.16666666666667
61634, 1.3304347826087, 0.82826086956522, 0.11111111111111
61635, 1.3304347826087, 0.82826086956522, 0.055555555555556
61636, 1.3739130434783, 0.82826086956522, 0.44444444444444
61637, 1.3739130434783, 0.82826086956522, 0.38888888888889
61638, 1.3739130434783, 0.82826086956522, 0.33333333333333
61639, 1.3739130434783, 0.82826086956522, 0.27777777777778
61640, 1.3739130434783, 0.82826086956522, 0.22222222222222
61641, 1.3739130434783, 0.82826086956522, 0.16666666666667
61642, 1.3739130434783, 0.82826086956522, 0.11111111111111
61643, 1.3739130434783, 0.82826086956522, 0.055555555555556
61644, 1.4173913043478, 0.82826086956522, 0.44444444444444
61645, 1.4173913043478, 0.82826086956522, 0.38888888888889
61646, 1.4173913043478, 0.82826086956522, 0.33333333333333
61647, 1.4173913043478, 0.82826086956522, 0.27777777777778
61648, 1.4173913043478, 0.82826086956522, 0.22222222222222
61649, 1.4173913043478, 0.82826086956522, 0.16666666666667
61650, 1.4173913043478, 0.82826086956522, 0.11111111111111
61651, 1.4173913043478, 0.82826086956522, 0.055555555555556
61652, 1.4608695652174, 0.82826086956522, 0.44444444444444
61653, 1.4608695652174, 0.82826086956522, 0.38888888888889
61654, 1.4608695652174, 0.82826086956522, 0.33333333333333
61655, 1.4608695652174, 0.82826086956522, 0.27777777777778
61656, 1.4608695652174, 0.82826086956522, 0.22222222222222
61657, 1.4608695652174, 0.82826086956522, 0.16666666666667
61658, 1.4608695652174, 0.82826086956522, 0.11111111111111
61659, 1.4608695652174, 0.82826086956522, 0.055555555555556
61660, 1.504347826087, 0.82826086956522, 0.44444444444444
61661, 1.504347826087, 0.82826086956522, 0.38888888888889
61662, 1.504347826087, 0.82826086956522, 0.33333333333333
61663, 1.504347826087, 0.82826086956522, 0.27777777777778
61664, 1.504347826087, 0.82826086956522, 0.22222222222222
61665, 1.504347826087, 0.82826086956522, 0.16666666666667
61666, 1.504347826087, 0.82826086956522, 0.11111111111111
61667, 1.504347826087, 0.82826086956522, 0.055555555555556
61668, 1.5478260869565, 0.82826086956522, 0.44444444444444
61669, 1.5478260869565, 0.82826086956522, 0.38888888888889
61670, 1.5478260869565, 0.82826086956522, 0.33333333333333
61671, 1.5478260869565, 0.82826086956522, 0.27777777777778
61672, 1.5478260869565, 0.82826086956522, 0.22222222222222
61673, 1.5478260869565, 0.82826086956522, 0.16666666666667
61674, 1.5478260869565, 0.82826086956522, 0.11111111111111
61675, 1.5478260869565, 0.82826086956522, 0.055555555555556
61676, 1.5913043478261, 0.82826086956522, 0.44444444444444
61677, 1.5913043478261, 0.82826086956522, 0.38888888888889
61678, 1.5913043478261, 0.82826086956522, 0.33333333333333
61679, 1.5913043478261, 0.82826086956522, 0.27777777777778
61680, 1.5913043478261, 0.82826086956522, 0.22222222222222
61681, 1.5913043478261, 0.82826086956522, 0.16666666666667
61682, 1.5913043478261, 0.82826086956522, 0.11111111111111
61683, 1.5913043478261, 0.82826086956522, 0.055555555555556
61684, 1.6347826086957, 0.82826086956522, 0.44444444444444
61685, 1.6347826086957, 0.82826086956522, 0.38888888888889
61686, 1.6347826086957, 0.82826086956522, 0.33333333333333
61687, 1.6347826086957, 0.82826086956522, 0.27777777777778
61688, 1.6347826086957, 0.82826086956522, 0.22222222222222
61689, 1.6347826086957, 0.82826086956522, 0.16666666666667
61690, 1.6347826086957, 0.82826086956522, 0.11111111111111
61691, 1.6347826086957, 0.82826086956522, 0.055555555555556
61692, 1.6782608695652, 0.82826086956522, 0.44444444444444
61693, 1.6782608695652, 0.82826086956522, 0.38888888888889
61694, 1.6782608695652, 0.82826086956522, 0.33333333333333
61695, 1.6782608695652, 0.82826086956522, 0.27777777777778
61696, 1.6782608695652, 0.82826086956522, 0.22222222222222
61697, 1.6782608695652, 0.82826086956522, 0.16666666666667
61698, 1.6782608695652, 0.82826086956522, 0.11111111111111
61699, 1.6782608695652, 0.82826086956522, 0.055555555555556
61700, 1.7217391304348, 0.82826086956522, 0.44444444444444
61701, 1.7217391304348, 0.82826086956522, 0.38888888888889
61702, 1.7217391304348, 0.82826086956522, 0.33333333333333
61703, 1.7217391304348, 0.82826086956522, 0.27777777777778
61704, 1.7217391304348, 0.82826086956522, 0.22222222222222
61705, 1.7217391304348, 0.82826086956522, 0.16666666666667
61706, 1.7217391304348, 0.82826086956522, 0.11111111111111
61707, 1.7217391304348, 0.82826086956522, 0.055555555555556
61708, 1.7652173913043, 0.82826086956522, 0.44444444444444
61709, 1.7652173913043, 0.82826086956522, 0.38888888888889
61710, 1.7652173913043, 0.82826086956522, 0.33333333333333
61711, 1.7652173913043, 0.82826086956522, 0.27777777777778
61712, 1.7652173913043, 0.82826086956522, 0.22222222222222
61713, 1.7652173913043, 0.82826086956522, 0.16666666666667
61714, 1.7652173913043, 0.82826086956522, 0.11111111111111
61715, 1.7652173913043, 0.82826086956522, 0.055555555555556
61716, 1.8086956521739, 0.82826086956522, 0.44444444444444
61717, 1.8086956521739, 0.82826086956522, 0.38888888888889
61718, 1.8086956521739, 0.82826086956522, 0.33333333333333
61719, 1.8086956521739, 0.82826086956522, 0.27777777777778
61720, 1.8086956521739, 0.82826086956522, 0.22222222222222
61721, 1.8086956521739, 0.82826086956522, 0.16666666666667
61722, 1.8086956521739, 0.82826086956522, 0.11111111111111
61723, 1.8086956521739, 0.82826086956522, 0.055555555555556
61724, 1.8521739130435, 0.82826086956522, 0.44444444444444
61725, 1.8521739130435, 0.82826086956522, 0.38888888888889
61726, 1.8521739130435, 0.82826086956522, 0.33333333333333
61727, 1.8521739130435, 0.82826086956522, 0.27777777777778
61728, 1.8521739130435, 0.82826086956522, 0.22222222222222
61729, 1.8521739130435, 0.82826086956522, 0.16666666666667
61730, 1.8521739130435, 0.82826086956522, 0.11111111111111
61731, 1.8521739130435, 0.82826086956522, 0.055555555555556
61732, 1.895652173913, 0.82826086956522, 0.44444444444444
61733, 1.895652173913, 0.82826086956522, 0.38888888888889
61734, 1.895652173913, 0.82826086956522, 0.33333333333333
61735, 1.895652173913, 0.82826086956522, 0.27777777777778
61736, 1.895652173913, 0.82826086956522, 0.22222222222222
61737, 1.895652173913, 0.82826086956522, 0.16666666666667
61738, 1.895652173913, 0.82826086956522, 0.11111111111111
61739, 1.895652173913, 0.82826086956522, 0.055555555555556
61740, 1.9391304347826, 0.82826086956522, 0.44444444444444
61741, 1.9391304347826, 0.82826086956522, 0.38888888888889
61742, 1.9391304347826, 0.82826086956522, 0.33333333333333
61743, 1.9391304347826, 0.82826086956522, 0.27777777777778
61744, 1.9391304347826, 0.82826086956522, 0.22222222222222
61745, 1.9391304347826, 0.82826086956522, 0.16666666666667
61746, 1.9391304347826, 0.82826086956522, 0.11111111111111
61747, 1.9391304347826, 0.82826086956522, 0.055555555555556
61748, 1.9826086956522, 0.82826086956522, 0.44444444444444
61749, 1.9826086956522, 0.82826086956522, 0.38888888888889
61750, 1.9826086956522, 0.82826086956522, 0.33333333333333
61751, 1.9826086956522, 0.82826086956522, 0.27777777777778
61752, 1.9826086956522, 0.82826086956522, 0.22222222222222
61753, 1.9826086956522, 0.82826086956522, 0.16666666666667
61754, 1.9826086956522, 0.82826086956522, 0.11111111111111
61755, 1.9826086956522, 0.82826086956522, 0.055555555555556
61756, 2.0260869565217, 0.82826086956522, 0.44444444444444
61757, 2.0260869565217, 0.82826086956522, 0.38888888888889
61758, 2.0260869565217, 0.82826086956522, 0.33333333333333
61759, 2.0260869565217, 0.82826086956522, 0.27777777777778
61760, 2.0260869565217, 0.82826086956522, 0.22222222222222
61761, 2.0260869565217, 0.82826086956522, 0.16666666666667
61762, 2.0260869565217, 0.82826086956522, 0.11111111111111
61763, 2.0260869565217, 0.82826086956522, 0.055555555555556
61764, 2.0695652173913, 0.82826086956522, 0.44444444444444
61765, 2.0695652173913, 0.82826086956522, 0.38888888888889
61766, 2.0695652173913, 0.82826086956522, 0.33333333333333
61767, 2.0695652173913, 0.82826086956522, 0.27777777777778
61768, 2.0695652173913, 0.82826086956522, 0.22222222222222
61769, 2.0695652173913, 0.82826086956522, 0.16666666666667
61770, 2.0695652173913, 0.82826086956522, 0.11111111111111
61771, 2.0695652173913, 0.82826086956522, 0.055555555555556
61772, 2.1130434782609, 0.82826086956522, 0.44444444444444
61773, 2.1130434782609, 0.82826086956522, 0.38888888888889
61774, 2.1130434782609, 0.82826086956522, 0.33333333333333
61775, 2.1130434782609, 0.82826086956522, 0.27777777777778
61776, 2.1130434782609, 0.82826086956522, 0.22222222222222
61777, 2.1130434782609, 0.82826086956522, 0.16666666666667
61778, 2.1130434782609, 0.82826086956522, 0.11111111111111
61779, 2.1130434782609, 0.82826086956522, 0.055555555555556
61780, 2.1565217391304, 0.82826086956522, 0.44444444444444
61781, 2.1565217391304, 0.82826086956522, 0.38888888888889
61782, 2.1565217391304, 0.82826086956522, 0.33333333333333
61783, 2.1565217391304, 0.82826086956522, 0.27777777777778
61784, 2.1565217391304, 0.82826086956522, 0.22222222222222
61785, 2.1565217391304, 0.82826086956522, 0.16666666666667
61786, 2.1565217391304, 0.82826086956522, 0.11111111111111
61787, 2.1565217391304, 0.82826086956522, 0.055555555555556
61788, 1.2434782608696, 0.77608695652174, 0.44444444444444
61789, 1.2434782608696, 0.77608695652174, 0.38888888888889
61790, 1.2434782608696, 0.77608695652174, 0.33333333333333
61791, 1.2434782608696, 0.77608695652174, 0.27777777777778
61792, 1.2434782608696, 0.77608695652174, 0.22222222222222
61793, 1.2434782608696, 0.77608695652174, 0.16666666666667
61794, 1.2434782608696, 0.77608695652174, 0.11111111111111
61795, 1.2434782608696, 0.77608695652174, 0.055555555555556
61796, 1.2869565217391, 0.77608695652174, 0.44444444444444
61797, 1.2869565217391, 0.77608695652174, 0.38888888888889
61798, 1.2869565217391, 0.77608695652174, 0.33333333333333
61799, 1.2869565217391, 0.77608695652174, 0.27777777777778
61800, 1.2869565217391, 0.77608695652174, 0.22222222222222
61801, 1.2869565217391, 0.77608695652174, 0.16666666666667
61802, 1.2869565217391, 0.77608695652174, 0.11111111111111
61803, 1.2869565217391, 0.77608695652174, 0.055555555555556
61804, 1.3304347826087, 0.77608695652174, 0.44444444444444
61805, 1.3304347826087, 0.77608695652174, 0.38888888888889
61806, 1.3304347826087, 0.77608695652174, 0.33333333333333
61807, 1.3304347826087, 0.77608695652174, 0.27777777777778
61808, 1.3304347826087, 0.77608695652174, 0.22222222222222
61809, 1.3304347826087, 0.77608695652174, 0.16666666666667
61810, 1.3304347826087, 0.77608695652174, 0.11111111111111
61811, 1.3304347826087, 0.77608695652174, 0.055555555555556
61812, 1.3739130434783, 0.77608695652174, 0.44444444444444
61813, 1.3739130434783, 0.77608695652174, 0.38888888888889
61814, 1.3739130434783, 0.77608695652174, 0.33333333333333
61815, 1.3739130434783, 0.77608695652174, 0.27777777777778
61816, 1.3739130434783, 0.77608695652174, 0.22222222222222
61817, 1.3739130434783, 0.77608695652174, 0.16666666666667
61818, 1.3739130434783, 0.77608695652174, 0.11111111111111
61819, 1.3739130434783, 0.77608695652174, 0.055555555555556
61820, 1.4173913043478, 0.77608695652174, 0.44444444444444
61821, 1.4173913043478, 0.77608695652174, 0.38888888888889
61822, 1.4173913043478, 0.77608695652174, 0.33333333333333
61823, 1.4173913043478, 0.77608695652174, 0.27777777777778
61824, 1.4173913043478, 0.77608695652174, 0.22222222222222
61825, 1.4173913043478, 0.77608695652174, 0.16666666666667
61826, 1.4173913043478, 0.77608695652174, 0.11111111111111
61827, 1.4173913043478, 0.77608695652174, 0.055555555555556
61828, 1.4608695652174, 0.77608695652174, 0.44444444444444
61829, 1.4608695652174, 0.77608695652174, 0.38888888888889
61830, 1.4608695652174, 0.77608695652174, 0.33333333333333
61831, 1.4608695652174, 0.77608695652174, 0.27777777777778
61832, 1.4608695652174, 0.77608695652174, 0.22222222222222
61833, 1.4608695652174, 0.77608695652174, 0.16666666666667
61834, 1.4608695652174, 0.77608695652174, 0.11111111111111
61835, 1.4608695652174, 0.77608695652174, 0.055555555555556
61836, 1.504347826087, 0.77608695652174, 0.44444444444444
61837, 1.504347826087, 0.77608695652174, 0.38888888888889
61838, 1.504347826087, 0.77608695652174, 0.33333333333333
61839, 1.504347826087, 0.77608695652174, 0.27777777777778
61840, 1.504347826087, 0.77608695652174, 0.22222222222222
61841, 1.504347826087, 0.77608695652174, 0.16666666666667
61842, 1.504347826087, 0.77608695652174, 0.11111111111111
61843, 1.504347826087, 0.77608695652174, 0.055555555555556
61844, 1.5478260869565, 0.77608695652174, 0.44444444444444
61845, 1.5478260869565, 0.77608695652174, 0.38888888888889
61846, 1.5478260869565, 0.77608695652174, 0.33333333333333
61847, 1.5478260869565, 0.77608695652174, 0.27777777777778
61848, 1.5478260869565, 0.77608695652174, 0.22222222222222
61849, 1.5478260869565, 0.77608695652174, 0.16666666666667
61850, 1.5478260869565, 0.77608695652174, 0.11111111111111
61851, 1.5478260869565, 0.77608695652174, 0.055555555555556
61852, 1.5913043478261, 0.77608695652174, 0.44444444444444
61853, 1.5913043478261, 0.77608695652174, 0.38888888888889
61854, 1.5913043478261, 0.77608695652174, 0.33333333333333
61855, 1.5913043478261, 0.77608695652174, 0.27777777777778
61856, 1.5913043478261, 0.77608695652174, 0.22222222222222
61857, 1.5913043478261, 0.77608695652174, 0.16666666666667
61858, 1.5913043478261, 0.77608695652174, 0.11111111111111
61859, 1.5913043478261, 0.77608695652174, 0.055555555555556
61860, 1.6347826086957, 0.77608695652174, 0.44444444444444
61861, 1.6347826086957, 0.77608695652174, 0.38888888888889
61862, 1.6347826086957, 0.77608695652174, 0.33333333333333
61863, 1.6347826086957, 0.77608695652174, 0.27777777777778
61864, 1.6347826086957, 0.77608695652174, 0.22222222222222
61865, 1.6347826086957, 0.77608695652174, 0.16666666666667
61866, 1.6347826086957, 0.77608695652174, 0.11111111111111
61867, 1.6347826086957, 0.77608695652174, 0.055555555555556
61868, 1.6782608695652, 0.77608695652174, 0.44444444444444
61869, 1.6782608695652, 0.77608695652174, 0.38888888888889
61870, 1.6782608695652, 0.77608695652174, 0.33333333333333
61871, 1.6782608695652, 0.77608695652174, 0.27777777777778
61872, 1.6782608695652, 0.77608695652174, 0.22222222222222
61873, 1.6782608695652, 0.77608695652174, 0.16666666666667
61874, 1.6782608695652, 0.77608695652174, 0.11111111111111
61875, 1.6782608695652, 0.77608695652174, 0.055555555555556
61876, 1.7217391304348, 0.77608695652174, 0.44444444444444
61877, 1.7217391304348, 0.77608695652174, 0.38888888888889
61878, 1.7217391304348, 0.77608695652174, 0.33333333333333
61879, 1.7217391304348, 0.77608695652174, 0.27777777777778
61880, 1.7217391304348, 0.77608695652174, 0.22222222222222
61881, 1.7217391304348, 0.77608695652174, 0.16666666666667
61882, 1.7217391304348, 0.77608695652174, 0.11111111111111
61883, 1.7217391304348, 0.77608695652174, 0.055555555555556
61884, 1.7652173913043, 0.77608695652174, 0.44444444444444
61885, 1.7652173913043, 0.77608695652174, 0.38888888888889
61886, 1.7652173913043, 0.77608695652174, 0.33333333333333
61887, 1.7652173913043, 0.77608695652174, 0.27777777777778
61888, 1.7652173913043, 0.77608695652174, 0.22222222222222
61889, 1.7652173913043, 0.77608695652174, 0.16666666666667
61890, 1.7652173913043, 0.77608695652174, 0.11111111111111
61891, 1.7652173913043, 0.77608695652174, 0.055555555555556
61892, 1.8086956521739, 0.77608695652174, 0.44444444444444
61893, 1.8086956521739, 0.77608695652174, 0.38888888888889
61894, 1.8086956521739, 0.77608695652174, 0.33333333333333
61895, 1.8086956521739, 0.77608695652174, 0.27777777777778
61896, 1.8086956521739, 0.77608695652174, 0.22222222222222
61897, 1.8086956521739, 0.77608695652174, 0.16666666666667
61898, 1.8086956521739, 0.77608695652174, 0.11111111111111
61899, 1.8086956521739, 0.77608695652174, 0.055555555555556
61900, 1.8521739130435, 0.77608695652174, 0.44444444444444
61901, 1.8521739130435, 0.77608695652174, 0.38888888888889
61902, 1.8521739130435, 0.77608695652174, 0.33333333333333
61903, 1.8521739130435, 0.77608695652174, 0.27777777777778
