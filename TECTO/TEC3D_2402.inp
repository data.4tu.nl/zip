28770, 1.6347826086957, 1.35, 0.11111111111111
28771, 1.6347826086957, 1.35, 0.055555555555556
28772, 1.6782608695652, 1.35, 0.44444444444444
28773, 1.6782608695652, 1.35, 0.38888888888889
28774, 1.6782608695652, 1.35, 0.33333333333333
28775, 1.6782608695652, 1.35, 0.27777777777778
28776, 1.6782608695652, 1.35, 0.22222222222222
28777, 1.6782608695652, 1.35, 0.16666666666667
28778, 1.6782608695652, 1.35, 0.11111111111111
28779, 1.6782608695652, 1.35, 0.055555555555556
28780, 1.7217391304348, 1.35, 0.44444444444444
28781, 1.7217391304348, 1.35, 0.38888888888889
28782, 1.7217391304348, 1.35, 0.33333333333333
28783, 1.7217391304348, 1.35, 0.27777777777778
28784, 1.7217391304348, 1.35, 0.22222222222222
28785, 1.7217391304348, 1.35, 0.16666666666667
28786, 1.7217391304348, 1.35, 0.11111111111111
28787, 1.7217391304348, 1.35, 0.055555555555556
28788, 1.7652173913043, 1.35, 0.44444444444444
28789, 1.7652173913043, 1.35, 0.38888888888889
28790, 1.7652173913043, 1.35, 0.33333333333333
28791, 1.7652173913043, 1.35, 0.27777777777778
28792, 1.7652173913043, 1.35, 0.22222222222222
28793, 1.7652173913043, 1.35, 0.16666666666667
28794, 1.7652173913043, 1.35, 0.11111111111111
28795, 1.7652173913043, 1.35, 0.055555555555556
28796, 1.8086956521739, 1.35, 0.44444444444444
28797, 1.8086956521739, 1.35, 0.38888888888889
28798, 1.8086956521739, 1.35, 0.33333333333333
28799, 1.8086956521739, 1.35, 0.27777777777778
28800, 1.8086956521739, 1.35, 0.22222222222222
28801, 1.8086956521739, 1.35, 0.16666666666667
28802, 1.8086956521739, 1.35, 0.11111111111111
28803, 1.8086956521739, 1.35, 0.055555555555556
28804, 1.8521739130435, 1.35, 0.44444444444444
28805, 1.8521739130435, 1.35, 0.38888888888889
28806, 1.8521739130435, 1.35, 0.33333333333333
28807, 1.8521739130435, 1.35, 0.27777777777778
28808, 1.8521739130435, 1.35, 0.22222222222222
28809, 1.8521739130435, 1.35, 0.16666666666667
28810, 1.8521739130435, 1.35, 0.11111111111111
28811, 1.8521739130435, 1.35, 0.055555555555556
28812, 1.895652173913, 1.35, 0.44444444444444
28813, 1.895652173913, 1.35, 0.38888888888889
28814, 1.895652173913, 1.35, 0.33333333333333
28815, 1.895652173913, 1.35, 0.27777777777778
28816, 1.895652173913, 1.35, 0.22222222222222
28817, 1.895652173913, 1.35, 0.16666666666667
28818, 1.895652173913, 1.35, 0.11111111111111
28819, 1.895652173913, 1.35, 0.055555555555556
28820, 1.9391304347826, 1.35, 0.44444444444444
28821, 1.9391304347826, 1.35, 0.38888888888889
28822, 1.9391304347826, 1.35, 0.33333333333333
28823, 1.9391304347826, 1.35, 0.27777777777778
28824, 1.9391304347826, 1.35, 0.22222222222222
28825, 1.9391304347826, 1.35, 0.16666666666667
28826, 1.9391304347826, 1.35, 0.11111111111111
28827, 1.9391304347826, 1.35, 0.055555555555556
28828, 1.9826086956522, 1.35, 0.44444444444444
28829, 1.9826086956522, 1.35, 0.38888888888889
28830, 1.9826086956522, 1.35, 0.33333333333333
28831, 1.9826086956522, 1.35, 0.27777777777778
28832, 1.9826086956522, 1.35, 0.22222222222222
28833, 1.9826086956522, 1.35, 0.16666666666667
28834, 1.9826086956522, 1.35, 0.11111111111111
28835, 1.9826086956522, 1.35, 0.055555555555556
28836, 2.0260869565217, 1.35, 0.44444444444444
28837, 2.0260869565217, 1.35, 0.38888888888889
28838, 2.0260869565217, 1.35, 0.33333333333333
28839, 2.0260869565217, 1.35, 0.27777777777778
28840, 2.0260869565217, 1.35, 0.22222222222222
28841, 2.0260869565217, 1.35, 0.16666666666667
28842, 2.0260869565217, 1.35, 0.11111111111111
28843, 2.0260869565217, 1.35, 0.055555555555556
28844, 2.0695652173913, 1.35, 0.44444444444444
28845, 2.0695652173913, 1.35, 0.38888888888889
28846, 2.0695652173913, 1.35, 0.33333333333333
28847, 2.0695652173913, 1.35, 0.27777777777778
28848, 2.0695652173913, 1.35, 0.22222222222222
28849, 2.0695652173913, 1.35, 0.16666666666667
28850, 2.0695652173913, 1.35, 0.11111111111111
28851, 2.0695652173913, 1.35, 0.055555555555556
28852, 2.1130434782609, 1.35, 0.44444444444444
28853, 2.1130434782609, 1.35, 0.38888888888889
28854, 2.1130434782609, 1.35, 0.33333333333333
28855, 2.1130434782609, 1.35, 0.27777777777778
28856, 2.1130434782609, 1.35, 0.22222222222222
28857, 2.1130434782609, 1.35, 0.16666666666667
28858, 2.1130434782609, 1.35, 0.11111111111111
28859, 2.1130434782609, 1.35, 0.055555555555556
28860, 2.1565217391304, 1.35, 0.44444444444444
28861, 2.1565217391304, 1.35, 0.38888888888889
28862, 2.1565217391304, 1.35, 0.33333333333333
28863, 2.1565217391304, 1.35, 0.27777777777778
28864, 2.1565217391304, 1.35, 0.22222222222222
28865, 2.1565217391304, 1.35, 0.16666666666667
28866, 2.1565217391304, 1.35, 0.11111111111111
28867, 2.1565217391304, 1.35, 0.055555555555556
28868, 1.2434782608696, 1.35, 0.47222222222222
28869, 1.2217391304348, 1.35, 0.44444444444444
28870, 1.2434782608696, 1.35, 0.41666666666667
28871, 1.2217391304348, 1.35, 0.38888888888889
28872, 1.2434782608696, 1.35, 0.36111111111111
28873, 1.2217391304348, 1.35, 0.33333333333333
28874, 1.2434782608696, 1.35, 0.30555555555556
28875, 1.2217391304348, 1.35, 0.27777777777778
28876, 1.2434782608696, 1.35, 0.25
28877, 1.2217391304348, 1.35, 0.22222222222222
28878, 1.2434782608696, 1.35, 0.19444444444444
28879, 1.2217391304348, 1.35, 0.16666666666667
28880, 1.2434782608696, 1.35, 0.13888888888889
28881, 1.2217391304348, 1.35, 0.11111111111111
28882, 1.2434782608696, 1.35, 0.083333333333333
28883, 1.2217391304348, 1.35, 0.055555555555556
28884, 1.2434782608696, 1.35, 0.027777777777778
28885, 1.2869565217391, 1.35, 0.47222222222222
28886, 1.2652173913043, 1.35, 0.44444444444444
28887, 1.2869565217391, 1.35, 0.41666666666667
28888, 1.2652173913043, 1.35, 0.38888888888889
28889, 1.2869565217391, 1.35, 0.36111111111111
28890, 1.2652173913043, 1.35, 0.33333333333333
28891, 1.2869565217391, 1.35, 0.30555555555556
28892, 1.2652173913043, 1.35, 0.27777777777778
28893, 1.2869565217391, 1.35, 0.25
28894, 1.2652173913043, 1.35, 0.22222222222222
28895, 1.2869565217391, 1.35, 0.19444444444444
28896, 1.2652173913043, 1.35, 0.16666666666667
28897, 1.2869565217391, 1.35, 0.13888888888889
28898, 1.2652173913043, 1.35, 0.11111111111111
28899, 1.2869565217391, 1.35, 0.083333333333333
28900, 1.2652173913043, 1.35, 0.055555555555556
28901, 1.2869565217391, 1.35, 0.027777777777778
28902, 1.3304347826087, 1.35, 0.47222222222222
28903, 1.3086956521739, 1.35, 0.44444444444444
28904, 1.3304347826087, 1.35, 0.41666666666667
28905, 1.3086956521739, 1.35, 0.38888888888889
28906, 1.3304347826087, 1.35, 0.36111111111111
28907, 1.3086956521739, 1.35, 0.33333333333333
28908, 1.3304347826087, 1.35, 0.30555555555556
28909, 1.3086956521739, 1.35, 0.27777777777778
28910, 1.3304347826087, 1.35, 0.25
28911, 1.3086956521739, 1.35, 0.22222222222222
28912, 1.3304347826087, 1.35, 0.19444444444444
28913, 1.3086956521739, 1.35, 0.16666666666667
28914, 1.3304347826087, 1.35, 0.13888888888889
28915, 1.3086956521739, 1.35, 0.11111111111111
28916, 1.3304347826087, 1.35, 0.083333333333333
28917, 1.3086956521739, 1.35, 0.055555555555556
28918, 1.3304347826087, 1.35, 0.027777777777778
28919, 1.3739130434783, 1.35, 0.47222222222222
28920, 1.3521739130435, 1.35, 0.44444444444444
28921, 1.3739130434783, 1.35, 0.41666666666667
28922, 1.3521739130435, 1.35, 0.38888888888889
28923, 1.3739130434783, 1.35, 0.36111111111111
28924, 1.3521739130435, 1.35, 0.33333333333333
28925, 1.3739130434783, 1.35, 0.30555555555556
28926, 1.3521739130435, 1.35, 0.27777777777778
28927, 1.3739130434783, 1.35, 0.25
28928, 1.3521739130435, 1.35, 0.22222222222222
28929, 1.3739130434783, 1.35, 0.19444444444444
28930, 1.3521739130435, 1.35, 0.16666666666667
28931, 1.3739130434783, 1.35, 0.13888888888889
28932, 1.3521739130435, 1.35, 0.11111111111111
28933, 1.3739130434783, 1.35, 0.083333333333333
28934, 1.3521739130435, 1.35, 0.055555555555556
28935, 1.3739130434783, 1.35, 0.027777777777778
28936, 1.4173913043478, 1.35, 0.47222222222222
28937, 1.395652173913, 1.35, 0.44444444444444
28938, 1.4173913043478, 1.35, 0.41666666666667
28939, 1.395652173913, 1.35, 0.38888888888889
28940, 1.4173913043478, 1.35, 0.36111111111111
28941, 1.395652173913, 1.35, 0.33333333333333
28942, 1.4173913043478, 1.35, 0.30555555555556
28943, 1.395652173913, 1.35, 0.27777777777778
28944, 1.4173913043478, 1.35, 0.25
28945, 1.395652173913, 1.35, 0.22222222222222
28946, 1.4173913043478, 1.35, 0.19444444444444
28947, 1.395652173913, 1.35, 0.16666666666667
28948, 1.4173913043478, 1.35, 0.13888888888889
28949, 1.395652173913, 1.35, 0.11111111111111
28950, 1.4173913043478, 1.35, 0.083333333333333
28951, 1.395652173913, 1.35, 0.055555555555556
28952, 1.4173913043478, 1.35, 0.027777777777778
28953, 1.4608695652174, 1.35, 0.47222222222222
28954, 1.4391304347826, 1.35, 0.44444444444444
28955, 1.4608695652174, 1.35, 0.41666666666667
28956, 1.4391304347826, 1.35, 0.38888888888889
28957, 1.4608695652174, 1.35, 0.36111111111111
28958, 1.4391304347826, 1.35, 0.33333333333333
28959, 1.4608695652174, 1.35, 0.30555555555556
28960, 1.4391304347826, 1.35, 0.27777777777778
28961, 1.4608695652174, 1.35, 0.25
28962, 1.4391304347826, 1.35, 0.22222222222222
28963, 1.4608695652174, 1.35, 0.19444444444444
28964, 1.4391304347826, 1.35, 0.16666666666667
28965, 1.4608695652174, 1.35, 0.13888888888889
28966, 1.4391304347826, 1.35, 0.11111111111111
28967, 1.4608695652174, 1.35, 0.083333333333333
28968, 1.4391304347826, 1.35, 0.055555555555556
28969, 1.4608695652174, 1.35, 0.027777777777778
28970, 1.504347826087, 1.35, 0.47222222222222
28971, 1.4826086956522, 1.35, 0.44444444444444
28972, 1.504347826087, 1.35, 0.41666666666667
28973, 1.4826086956522, 1.35, 0.38888888888889
28974, 1.504347826087, 1.35, 0.36111111111111
28975, 1.4826086956522, 1.35, 0.33333333333333
28976, 1.504347826087, 1.35, 0.30555555555556
28977, 1.4826086956522, 1.35, 0.27777777777778
28978, 1.504347826087, 1.35, 0.25
28979, 1.4826086956522, 1.35, 0.22222222222222
28980, 1.504347826087, 1.35, 0.19444444444444
28981, 1.4826086956522, 1.35, 0.16666666666667
28982, 1.504347826087, 1.35, 0.13888888888889
28983, 1.4826086956522, 1.35, 0.11111111111111
28984, 1.504347826087, 1.35, 0.083333333333333
28985, 1.4826086956522, 1.35, 0.055555555555556
28986, 1.504347826087, 1.35, 0.027777777777778
28987, 1.5478260869565, 1.35, 0.47222222222222
28988, 1.5260869565217, 1.35, 0.44444444444444
28989, 1.5478260869565, 1.35, 0.41666666666667
28990, 1.5260869565217, 1.35, 0.38888888888889
28991, 1.5478260869565, 1.35, 0.36111111111111
28992, 1.5260869565217, 1.35, 0.33333333333333
28993, 1.5478260869565, 1.35, 0.30555555555556
28994, 1.5260869565217, 1.35, 0.27777777777778
28995, 1.5478260869565, 1.35, 0.25
28996, 1.5260869565217, 1.35, 0.22222222222222
28997, 1.5478260869565, 1.35, 0.19444444444444
28998, 1.5260869565217, 1.35, 0.16666666666667
28999, 1.5478260869565, 1.35, 0.13888888888889
29000, 1.5260869565217, 1.35, 0.11111111111111
29001, 1.5478260869565, 1.35, 0.083333333333333
29002, 1.5260869565217, 1.35, 0.055555555555556
29003, 1.5478260869565, 1.35, 0.027777777777778
29004, 1.5913043478261, 1.35, 0.47222222222222
29005, 1.5695652173913, 1.35, 0.44444444444444
29006, 1.5913043478261, 1.35, 0.41666666666667
29007, 1.5695652173913, 1.35, 0.38888888888889
29008, 1.5913043478261, 1.35, 0.36111111111111
29009, 1.5695652173913, 1.35, 0.33333333333333
29010, 1.5913043478261, 1.35, 0.30555555555556
29011, 1.5695652173913, 1.35, 0.27777777777778
29012, 1.5913043478261, 1.35, 0.25
29013, 1.5695652173913, 1.35, 0.22222222222222
29014, 1.5913043478261, 1.35, 0.19444444444444
29015, 1.5695652173913, 1.35, 0.16666666666667
29016, 1.5913043478261, 1.35, 0.13888888888889
29017, 1.5695652173913, 1.35, 0.11111111111111
29018, 1.5913043478261, 1.35, 0.083333333333333
29019, 1.5695652173913, 1.35, 0.055555555555556
29020, 1.5913043478261, 1.35, 0.027777777777778
29021, 1.6347826086957, 1.35, 0.47222222222222
29022, 1.6130434782609, 1.35, 0.44444444444444
29023, 1.6347826086957, 1.35, 0.41666666666667
29024, 1.6130434782609, 1.35, 0.38888888888889
29025, 1.6347826086957, 1.35, 0.36111111111111
29026, 1.6130434782609, 1.35, 0.33333333333333
29027, 1.6347826086957, 1.35, 0.30555555555556
29028, 1.6130434782609, 1.35, 0.27777777777778
29029, 1.6347826086957, 1.35, 0.25
29030, 1.6130434782609, 1.35, 0.22222222222222
29031, 1.6347826086957, 1.35, 0.19444444444444
29032, 1.6130434782609, 1.35, 0.16666666666667
29033, 1.6347826086957, 1.35, 0.13888888888889
29034, 1.6130434782609, 1.35, 0.11111111111111
29035, 1.6347826086957, 1.35, 0.083333333333333
29036, 1.6130434782609, 1.35, 0.055555555555556
29037, 1.6347826086957, 1.35, 0.027777777777778
29038, 1.6782608695652, 1.35, 0.47222222222222
29039, 1.6565217391304, 1.35, 0.44444444444444
29040, 1.6782608695652, 1.35, 0.41666666666667
29041, 1.6565217391304, 1.35, 0.38888888888889
29042, 1.6782608695652, 1.35, 0.36111111111111
29043, 1.6565217391304, 1.35, 0.33333333333333
29044, 1.6782608695652, 1.35, 0.30555555555556
29045, 1.6565217391304, 1.35, 0.27777777777778
29046, 1.6782608695652, 1.35, 0.25
29047, 1.6565217391304, 1.35, 0.22222222222222
29048, 1.6782608695652, 1.35, 0.19444444444444
29049, 1.6565217391304, 1.35, 0.16666666666667
29050, 1.6782608695652, 1.35, 0.13888888888889
29051, 1.6565217391304, 1.35, 0.11111111111111
29052, 1.6782608695652, 1.35, 0.083333333333333
29053, 1.6565217391304, 1.35, 0.055555555555556
29054, 1.6782608695652, 1.35, 0.027777777777778
29055, 1.7217391304348, 1.35, 0.47222222222222
29056, 1.7, 1.35, 0.44444444444444
29057, 1.7217391304348, 1.35, 0.41666666666667
29058, 1.7, 1.35, 0.38888888888889
29059, 1.7217391304348, 1.35, 0.36111111111111
29060, 1.7, 1.35, 0.33333333333333
29061, 1.7217391304348, 1.35, 0.30555555555556
29062, 1.7, 1.35, 0.27777777777778
29063, 1.7217391304348, 1.35, 0.25
29064, 1.7, 1.35, 0.22222222222222
29065, 1.7217391304348, 1.35, 0.19444444444444
29066, 1.7, 1.35, 0.16666666666667
29067, 1.7217391304348, 1.35, 0.13888888888889
29068, 1.7, 1.35, 0.11111111111111
29069, 1.7217391304348, 1.35, 0.083333333333333
29070, 1.7, 1.35, 0.055555555555556
29071, 1.7217391304348, 1.35, 0.027777777777778
29072, 1.7652173913043, 1.35, 0.47222222222222
29073, 1.7434782608696, 1.35, 0.44444444444444
29074, 1.7652173913043, 1.35, 0.41666666666667
29075, 1.7434782608696, 1.35, 0.38888888888889
29076, 1.7652173913043, 1.35, 0.36111111111111
29077, 1.7434782608696, 1.35, 0.33333333333333
29078, 1.7652173913043, 1.35, 0.30555555555556
29079, 1.7434782608696, 1.35, 0.27777777777778
29080, 1.7652173913043, 1.35, 0.25
29081, 1.7434782608696, 1.35, 0.22222222222222
29082, 1.7652173913043, 1.35, 0.19444444444444
29083, 1.7434782608696, 1.35, 0.16666666666667
29084, 1.7652173913043, 1.35, 0.13888888888889
29085, 1.7434782608696, 1.35, 0.11111111111111
29086, 1.7652173913043, 1.35, 0.083333333333333
29087, 1.7434782608696, 1.35, 0.055555555555556
29088, 1.7652173913043, 1.35, 0.027777777777778
29089, 1.8086956521739, 1.35, 0.47222222222222
29090, 1.7869565217391, 1.35, 0.44444444444444
29091, 1.8086956521739, 1.35, 0.41666666666667
29092, 1.7869565217391, 1.35, 0.38888888888889
29093, 1.8086956521739, 1.35, 0.36111111111111
29094, 1.7869565217391, 1.35, 0.33333333333333
29095, 1.8086956521739, 1.35, 0.30555555555556
29096, 1.7869565217391, 1.35, 0.27777777777778
29097, 1.8086956521739, 1.35, 0.25
29098, 1.7869565217391, 1.35, 0.22222222222222
29099, 1.8086956521739, 1.35, 0.19444444444444
29100, 1.7869565217391, 1.35, 0.16666666666667
29101, 1.8086956521739, 1.35, 0.13888888888889
29102, 1.7869565217391, 1.35, 0.11111111111111
29103, 1.8086956521739, 1.35, 0.083333333333333
29104, 1.7869565217391, 1.35, 0.055555555555556
29105, 1.8086956521739, 1.35, 0.027777777777778
29106, 1.8521739130435, 1.35, 0.47222222222222
29107, 1.8304347826087, 1.35, 0.44444444444444
29108, 1.8521739130435, 1.35, 0.41666666666667
29109, 1.8304347826087, 1.35, 0.38888888888889
29110, 1.8521739130435, 1.35, 0.36111111111111
29111, 1.8304347826087, 1.35, 0.33333333333333
29112, 1.8521739130435, 1.35, 0.30555555555556
29113, 1.8304347826087, 1.35, 0.27777777777778
29114, 1.8521739130435, 1.35, 0.25
29115, 1.8304347826087, 1.35, 0.22222222222222
29116, 1.8521739130435, 1.35, 0.19444444444444
29117, 1.8304347826087, 1.35, 0.16666666666667
29118, 1.8521739130435, 1.35, 0.13888888888889
29119, 1.8304347826087, 1.35, 0.11111111111111
29120, 1.8521739130435, 1.35, 0.083333333333333
29121, 1.8304347826087, 1.35, 0.055555555555556
29122, 1.8521739130435, 1.35, 0.027777777777778
29123, 1.895652173913, 1.35, 0.47222222222222
29124, 1.8739130434783, 1.35, 0.44444444444444
29125, 1.895652173913, 1.35, 0.41666666666667
29126, 1.8739130434783, 1.35, 0.38888888888889
29127, 1.895652173913, 1.35, 0.36111111111111
29128, 1.8739130434783, 1.35, 0.33333333333333
29129, 1.895652173913, 1.35, 0.30555555555556
29130, 1.8739130434783, 1.35, 0.27777777777778
29131, 1.895652173913, 1.35, 0.25
29132, 1.8739130434783, 1.35, 0.22222222222222
29133, 1.895652173913, 1.35, 0.19444444444444
29134, 1.8739130434783, 1.35, 0.16666666666667
29135, 1.895652173913, 1.35, 0.13888888888889
29136, 1.8739130434783, 1.35, 0.11111111111111
29137, 1.895652173913, 1.35, 0.083333333333333
29138, 1.8739130434783, 1.35, 0.055555555555556
29139, 1.895652173913, 1.35, 0.027777777777778
29140, 1.9391304347826, 1.35, 0.47222222222222
29141, 1.9173913043478, 1.35, 0.44444444444444
29142, 1.9391304347826, 1.35, 0.41666666666667
29143, 1.9173913043478, 1.35, 0.38888888888889
29144, 1.9391304347826, 1.35, 0.36111111111111
29145, 1.9173913043478, 1.35, 0.33333333333333
29146, 1.9391304347826, 1.35, 0.30555555555556
29147, 1.9173913043478, 1.35, 0.27777777777778
29148, 1.9391304347826, 1.35, 0.25
29149, 1.9173913043478, 1.35, 0.22222222222222
29150, 1.9391304347826, 1.35, 0.19444444444444
29151, 1.9173913043478, 1.35, 0.16666666666667
29152, 1.9391304347826, 1.35, 0.13888888888889
29153, 1.9173913043478, 1.35, 0.11111111111111
29154, 1.9391304347826, 1.35, 0.083333333333333
29155, 1.9173913043478, 1.35, 0.055555555555556
29156, 1.9391304347826, 1.35, 0.027777777777778
29157, 1.9826086956522, 1.35, 0.47222222222222
29158, 1.9608695652174, 1.35, 0.44444444444444
29159, 1.9826086956522, 1.35, 0.41666666666667
29160, 1.9608695652174, 1.35, 0.38888888888889
29161, 1.9826086956522, 1.35, 0.36111111111111
29162, 1.9608695652174, 1.35, 0.33333333333333
29163, 1.9826086956522, 1.35, 0.30555555555556
29164, 1.9608695652174, 1.35, 0.27777777777778
29165, 1.9826086956522, 1.35, 0.25
29166, 1.9608695652174, 1.35, 0.22222222222222
29167, 1.9826086956522, 1.35, 0.19444444444444
29168, 1.9608695652174, 1.35, 0.16666666666667
29169, 1.9826086956522, 1.35, 0.13888888888889
29170, 1.9608695652174, 1.35, 0.11111111111111
29171, 1.9826086956522, 1.35, 0.083333333333333
29172, 1.9608695652174, 1.35, 0.055555555555556
29173, 1.9826086956522, 1.35, 0.027777777777778
29174, 2.0260869565217, 1.35, 0.47222222222222
29175, 2.004347826087, 1.35, 0.44444444444444
29176, 2.0260869565217, 1.35, 0.41666666666667
29177, 2.004347826087, 1.35, 0.38888888888889
29178, 2.0260869565217, 1.35, 0.36111111111111
29179, 2.004347826087, 1.35, 0.33333333333333
29180, 2.0260869565217, 1.35, 0.30555555555556
29181, 2.004347826087, 1.35, 0.27777777777778
29182, 2.0260869565217, 1.35, 0.25
29183, 2.004347826087, 1.35, 0.22222222222222
29184, 2.0260869565217, 1.35, 0.19444444444444
29185, 2.004347826087, 1.35, 0.16666666666667
29186, 2.0260869565217, 1.35, 0.13888888888889
29187, 2.004347826087, 1.35, 0.11111111111111
29188, 2.0260869565217, 1.35, 0.083333333333333
29189, 2.004347826087, 1.35, 0.055555555555556
29190, 2.0260869565217, 1.35, 0.027777777777778
29191, 2.0695652173913, 1.35, 0.47222222222222
29192, 2.0478260869565, 1.35, 0.44444444444444
29193, 2.0695652173913, 1.35, 0.41666666666667
29194, 2.0478260869565, 1.35, 0.38888888888889
29195, 2.0695652173913, 1.35, 0.36111111111111
29196, 2.0478260869565, 1.35, 0.33333333333333
29197, 2.0695652173913, 1.35, 0.30555555555556
29198, 2.0478260869565, 1.35, 0.27777777777778
29199, 2.0695652173913, 1.35, 0.25
29200, 2.0478260869565, 1.35, 0.22222222222222
29201, 2.0695652173913, 1.35, 0.19444444444444
29202, 2.0478260869565, 1.35, 0.16666666666667
29203, 2.0695652173913, 1.35, 0.13888888888889
29204, 2.0478260869565, 1.35, 0.11111111111111
29205, 2.0695652173913, 1.35, 0.083333333333333
29206, 2.0478260869565, 1.35, 0.055555555555556
29207, 2.0695652173913, 1.35, 0.027777777777778
29208, 2.1130434782609, 1.35, 0.47222222222222
29209, 2.0913043478261, 1.35, 0.44444444444444
29210, 2.1130434782609, 1.35, 0.41666666666667
29211, 2.0913043478261, 1.35, 0.38888888888889
29212, 2.1130434782609, 1.35, 0.36111111111111
29213, 2.0913043478261, 1.35, 0.33333333333333
29214, 2.1130434782609, 1.35, 0.30555555555556
29215, 2.0913043478261, 1.35, 0.27777777777778
29216, 2.1130434782609, 1.35, 0.25
29217, 2.0913043478261, 1.35, 0.22222222222222
29218, 2.1130434782609, 1.35, 0.19444444444444
29219, 2.0913043478261, 1.35, 0.16666666666667
29220, 2.1130434782609, 1.35, 0.13888888888889
29221, 2.0913043478261, 1.35, 0.11111111111111
29222, 2.1130434782609, 1.35, 0.083333333333333
29223, 2.0913043478261, 1.35, 0.055555555555556
29224, 2.1130434782609, 1.35, 0.027777777777778
29225, 2.1565217391304, 1.35, 0.47222222222222
29226, 2.1347826086957, 1.35, 0.44444444444444
29227, 2.1565217391304, 1.35, 0.41666666666667
29228, 2.1347826086957, 1.35, 0.38888888888889
29229, 2.1565217391304, 1.35, 0.36111111111111
29230, 2.1347826086957, 1.35, 0.33333333333333
29231, 2.1565217391304, 1.35, 0.30555555555556
29232, 2.1347826086957, 1.35, 0.27777777777778
29233, 2.1565217391304, 1.35, 0.25
29234, 2.1347826086957, 1.35, 0.22222222222222
29235, 2.1565217391304, 1.35, 0.19444444444444
29236, 2.1347826086957, 1.35, 0.16666666666667
29237, 2.1565217391304, 1.35, 0.13888888888889
29238, 2.1347826086957, 1.35, 0.11111111111111
29239, 2.1565217391304, 1.35, 0.083333333333333
29240, 2.1347826086957, 1.35, 0.055555555555556
29241, 2.1565217391304, 1.35, 0.027777777777778
29242, 2.1782608695652, 1.35, 0.44444444444444
29243, 2.1782608695652, 1.35, 0.38888888888889
29244, 2.1782608695652, 1.35, 0.33333333333333
29245, 2.1782608695652, 1.35, 0.27777777777778
29246, 2.1782608695652, 1.35, 0.22222222222222
29247, 2.1782608695652, 1.35, 0.16666666666667
29248, 2.1782608695652, 1.35, 0.11111111111111
29249, 2.1782608695652, 1.35, 0.055555555555556
29250, 1.2434782608696, 0.125, 0.5
29251, 1.2869565217391, 0.125, 0.5
29252, 1.3304347826087, 0.125, 0.5
29253, 1.3739130434783, 0.125, 0.5
29254, 1.4173913043478, 0.125, 0.5
29255, 1.4608695652174, 0.125, 0.5
29256, 1.504347826087, 0.125, 0.5
29257, 1.5478260869565, 0.125, 0.5
29258, 1.5913043478261, 0.125, 0.5
29259, 1.6347826086957, 0.125, 0.5
29260, 1.6782608695652, 0.125, 0.5
29261, 1.7217391304348, 0.125, 0.5
29262, 1.7652173913043, 0.125, 0.5
29263, 1.8086956521739, 0.125, 0.5
29264, 1.8521739130435, 0.125, 0.5
29265, 1.895652173913, 0.125, 0.5
29266, 1.9391304347826, 0.125, 0.5
29267, 1.9826086956522, 0.125, 0.5
29268, 2.0260869565217, 0.125, 0.5
29269, 2.0695652173913, 0.125, 0.5
29270, 2.1130434782609, 0.125, 0.5
29271, 2.1565217391304, 0.125, 0.5
29272, 1.2217391304348, 0.125, 0.5
29273, 1.2434782608696, 0.1375, 0.5
29274, 1.2652173913043, 0.125, 0.5
29275, 1.2869565217391, 0.1375, 0.5
29276, 1.3086956521739, 0.125, 0.5
29277, 1.3304347826087, 0.1375, 0.5
29278, 1.3521739130435, 0.125, 0.5
29279, 1.3739130434783, 0.1375, 0.5
29280, 1.395652173913, 0.125, 0.5
29281, 1.4173913043478, 0.1375, 0.5
29282, 1.4391304347826, 0.125, 0.5
29283, 1.4608695652174, 0.1375, 0.5
29284, 1.4826086956522, 0.125, 0.5
29285, 1.504347826087, 0.1375, 0.5
29286, 1.5260869565217, 0.125, 0.5
29287, 1.5478260869565, 0.1375, 0.5
29288, 1.5695652173913, 0.125, 0.5
29289, 1.5913043478261, 0.1375, 0.5
29290, 1.6130434782609, 0.125, 0.5
29291, 1.6347826086957, 0.1375, 0.5
29292, 1.6565217391304, 0.125, 0.5
29293, 1.6782608695652, 0.1375, 0.5
29294, 1.7, 0.125, 0.5
29295, 1.7217391304348, 0.1375, 0.5
29296, 1.7434782608696, 0.125, 0.5
29297, 1.7652173913043, 0.1375, 0.5
29298, 1.7869565217391, 0.125, 0.5
29299, 1.8086956521739, 0.1375, 0.5
29300, 1.8304347826087, 0.125, 0.5
29301, 1.8521739130435, 0.1375, 0.5
29302, 1.8739130434783, 0.125, 0.5
29303, 1.895652173913, 0.1375, 0.5
29304, 1.9173913043478, 0.125, 0.5
29305, 1.9391304347826, 0.1375, 0.5
29306, 1.9608695652174, 0.125, 0.5
29307, 1.9826086956522, 0.1375, 0.5
29308, 2.004347826087, 0.125, 0.5
29309, 2.0260869565217, 0.1375, 0.5
29310, 2.0478260869565, 0.125, 0.5
29311, 2.0695652173913, 0.1375, 0.5
29312, 2.0913043478261, 0.125, 0.5
29313, 2.1130434782609, 0.1375, 0.5
29314, 2.1347826086957, 0.125, 0.5
29315, 2.1565217391304, 0.1375, 0.5
29316, 2.1782608695652, 0.125, 0.5
29317, 1.2434782608696, 0.1125, 0.5
29318, 1.2869565217391, 0.1125, 0.5
29319, 1.3304347826087, 0.1125, 0.5
29320, 1.3739130434783, 0.1125, 0.5
29321, 1.4173913043478, 0.1125, 0.5
29322, 1.4608695652174, 0.1125, 0.5
29323, 1.504347826087, 0.1125, 0.5
29324, 1.5478260869565, 0.1125, 0.5
29325, 1.5913043478261, 0.1125, 0.5
29326, 1.6347826086957, 0.1125, 0.5
29327, 1.6782608695652, 0.1125, 0.5
29328, 1.7217391304348, 0.1125, 0.5
29329, 1.7652173913043, 0.1125, 0.5
29330, 1.8086956521739, 0.1125, 0.5
29331, 1.8521739130435, 0.1125, 0.5
29332, 1.895652173913, 0.1125, 0.5
29333, 1.9391304347826, 0.1125, 0.5
29334, 1.9826086956522, 0.1125, 0.5
29335, 2.0260869565217, 0.1125, 0.5
29336, 2.0695652173913, 0.1125, 0.5
29337, 2.1130434782609, 0.1125, 0.5
29338, 2.1565217391304, 0.1125, 0.5
29339, 1.2434782608696, 0.125, 0
29340, 1.2869565217391, 0.125, 0
29341, 1.3304347826087, 0.125, 0
29342, 1.3739130434783, 0.125, 0
29343, 1.4173913043478, 0.125, 0
29344, 1.4608695652174, 0.125, 0
29345, 1.504347826087, 0.125, 0
29346, 1.5478260869565, 0.125, 0
29347, 1.5913043478261, 0.125, 0
29348, 1.6347826086957, 0.125, 0
29349, 1.6782608695652, 0.125, 0
29350, 1.7217391304348, 0.125, 0
29351, 1.7652173913043, 0.125, 0
29352, 1.8086956521739, 0.125, 0
29353, 1.8521739130435, 0.125, 0
29354, 1.895652173913, 0.125, 0
29355, 1.9391304347826, 0.125, 0
29356, 1.9826086956522, 0.125, 0
29357, 2.0260869565217, 0.125, 0
29358, 2.0695652173913, 0.125, 0
29359, 2.1130434782609, 0.125, 0
29360, 2.1565217391304, 0.125, 0
29361, 1.2434782608696, 0.1375, 0
29362, 1.2217391304348, 0.125, 0
29363, 1.2869565217391, 0.1375, 0
29364, 1.2652173913043, 0.125, 0
29365, 1.3304347826087, 0.1375, 0
29366, 1.3086956521739, 0.125, 0
29367, 1.3739130434783, 0.1375, 0
29368, 1.3521739130435, 0.125, 0
29369, 1.4173913043478, 0.1375, 0
29370, 1.395652173913, 0.125, 0
29371, 1.4608695652174, 0.1375, 0
29372, 1.4391304347826, 0.125, 0
29373, 1.504347826087, 0.1375, 0
29374, 1.4826086956522, 0.125, 0
29375, 1.5478260869565, 0.1375, 0
29376, 1.5260869565217, 0.125, 0
29377, 1.5913043478261, 0.1375, 0
29378, 1.5695652173913, 0.125, 0
29379, 1.6347826086957, 0.1375, 0
29380, 1.6130434782609, 0.125, 0
29381, 1.6782608695652, 0.1375, 0
29382, 1.6565217391304, 0.125, 0
29383, 1.7217391304348, 0.1375, 0
29384, 1.7, 0.125, 0
29385, 1.7652173913043, 0.1375, 0
29386, 1.7434782608696, 0.125, 0
29387, 1.8086956521739, 0.1375, 0
29388, 1.7869565217391, 0.125, 0
29389, 1.8521739130435, 0.1375, 0
29390, 1.8304347826087, 0.125, 0
29391, 1.895652173913, 0.1375, 0
29392, 1.8739130434783, 0.125, 0
29393, 1.9391304347826, 0.1375, 0
29394, 1.9173913043478, 0.125, 0
29395, 1.9826086956522, 0.1375, 0
29396, 1.9608695652174, 0.125, 0
29397, 2.0260869565217, 0.1375, 0
29398, 2.004347826087, 0.125, 0
29399, 2.0695652173913, 0.1375, 0
29400, 2.0478260869565, 0.125, 0
29401, 2.1130434782609, 0.1375, 0
29402, 2.0913043478261, 0.125, 0
29403, 2.1565217391304, 0.1375, 0
29404, 2.1347826086957, 0.125, 0
29405, 2.1782608695652, 0.125, 0
29406, 1.2434782608696, 0.1125, 0
29407, 1.2869565217391, 0.1125, 0
29408, 1.3304347826087, 0.1125, 0
29409, 1.3739130434783, 0.1125, 0
29410, 1.4173913043478, 0.1125, 0
29411, 1.4608695652174, 0.1125, 0
29412, 1.504347826087, 0.1125, 0
29413, 1.5478260869565, 0.1125, 0
29414, 1.5913043478261, 0.1125, 0
29415, 1.6347826086957, 0.1125, 0
29416, 1.6782608695652, 0.1125, 0
29417, 1.7217391304348, 0.1125, 0
29418, 1.7652173913043, 0.1125, 0
29419, 1.8086956521739, 0.1125, 0
29420, 1.8521739130435, 0.1125, 0
29421, 1.895652173913, 0.1125, 0
29422, 1.9391304347826, 0.1125, 0
29423, 1.9826086956522, 0.1125, 0
29424, 2.0260869565217, 0.1125, 0
29425, 2.0695652173913, 0.1125, 0
29426, 2.1130434782609, 0.1125, 0
29427, 2.1565217391304, 0.1125, 0
29428, 1.2, 0.125, 0.44444444444444
29429, 1.2, 0.125, 0.38888888888889
29430, 1.2, 0.125, 0.33333333333333
29431, 1.2, 0.125, 0.27777777777778
29432, 1.2, 0.125, 0.22222222222222
29433, 1.2, 0.125, 0.16666666666667
29434, 1.2, 0.125, 0.11111111111111
29435, 1.2, 0.125, 0.055555555555556
29436, 1.2, 0.1375, 0.44444444444444
29437, 1.2, 0.125, 0.47222222222222
29438, 1.2, 0.1375, 0.38888888888889
29439, 1.2, 0.125, 0.41666666666667
29440, 1.2, 0.1375, 0.33333333333333
29441, 1.2, 0.125, 0.36111111111111
29442, 1.2, 0.1375, 0.27777777777778
29443, 1.2, 0.125, 0.30555555555556
29444, 1.2, 0.1375, 0.22222222222222
29445, 1.2, 0.125, 0.25
29446, 1.2, 0.1375, 0.16666666666667
29447, 1.2, 0.125, 0.19444444444444
29448, 1.2, 0.1375, 0.11111111111111
29449, 1.2, 0.125, 0.13888888888889
29450, 1.2, 0.1375, 0.055555555555556
29451, 1.2, 0.125, 0.083333333333333
29452, 1.2, 0.125, 0.027777777777778
29453, 1.2, 0.1125, 0.44444444444444
29454, 1.2, 0.1125, 0.38888888888889
29455, 1.2, 0.1125, 0.33333333333333
29456, 1.2, 0.1125, 0.27777777777778
29457, 1.2, 0.1125, 0.22222222222222
29458, 1.2, 0.1125, 0.16666666666667
29459, 1.2, 0.1125, 0.11111111111111
29460, 1.2, 0.1125, 0.055555555555556
29461, 2.2, 0.125, 0.44444444444444
29462, 2.2, 0.125, 0.38888888888889
29463, 2.2, 0.125, 0.33333333333333
29464, 2.2, 0.125, 0.27777777777778
29465, 2.2, 0.125, 0.22222222222222
29466, 2.2, 0.125, 0.16666666666667
29467, 2.2, 0.125, 0.11111111111111
29468, 2.2, 0.125, 0.055555555555556
29469, 2.2, 0.125, 0.47222222222222
29470, 2.2, 0.1375, 0.44444444444444
29471, 2.2, 0.125, 0.41666666666667
29472, 2.2, 0.1375, 0.38888888888889
29473, 2.2, 0.125, 0.36111111111111
29474, 2.2, 0.1375, 0.33333333333333
29475, 2.2, 0.125, 0.30555555555556
29476, 2.2, 0.1375, 0.27777777777778
29477, 2.2, 0.125, 0.25
29478, 2.2, 0.1375, 0.22222222222222
29479, 2.2, 0.125, 0.19444444444444
29480, 2.2, 0.1375, 0.16666666666667
29481, 2.2, 0.125, 0.13888888888889
29482, 2.2, 0.1375, 0.11111111111111
29483, 2.2, 0.125, 0.083333333333333
29484, 2.2, 0.1375, 0.055555555555556
29485, 2.2, 0.125, 0.027777777777778
29486, 2.2, 0.1125, 0.44444444444444
29487, 2.2, 0.1125, 0.38888888888889
29488, 2.2, 0.1125, 0.33333333333333
29489, 2.2, 0.1125, 0.27777777777778
29490, 2.2, 0.1125, 0.22222222222222
29491, 2.2, 0.1125, 0.16666666666667
29492, 2.2, 0.1125, 0.11111111111111
29493, 2.2, 0.1125, 0.055555555555556
29494, 1.2434782608696, 0.1, 0.44444444444444
29495, 1.2434782608696, 0.1, 0.38888888888889
29496, 1.2434782608696, 0.1, 0.33333333333333
29497, 1.2434782608696, 0.1, 0.27777777777778
29498, 1.2434782608696, 0.1, 0.22222222222222
29499, 1.2434782608696, 0.1, 0.16666666666667
29500, 1.2434782608696, 0.1, 0.11111111111111
29501, 1.2434782608696, 0.1, 0.055555555555556
29502, 1.2869565217391, 0.1, 0.44444444444444
29503, 1.2869565217391, 0.1, 0.38888888888889
29504, 1.2869565217391, 0.1, 0.33333333333333
29505, 1.2869565217391, 0.1, 0.27777777777778
29506, 1.2869565217391, 0.1, 0.22222222222222
29507, 1.2869565217391, 0.1, 0.16666666666667
29508, 1.2869565217391, 0.1, 0.11111111111111
29509, 1.2869565217391, 0.1, 0.055555555555556
29510, 1.3304347826087, 0.1, 0.44444444444444
29511, 1.3304347826087, 0.1, 0.38888888888889
29512, 1.3304347826087, 0.1, 0.33333333333333
29513, 1.3304347826087, 0.1, 0.27777777777778
29514, 1.3304347826087, 0.1, 0.22222222222222
29515, 1.3304347826087, 0.1, 0.16666666666667
29516, 1.3304347826087, 0.1, 0.11111111111111
29517, 1.3304347826087, 0.1, 0.055555555555556
29518, 1.3739130434783, 0.1, 0.44444444444444
29519, 1.3739130434783, 0.1, 0.38888888888889
29520, 1.3739130434783, 0.1, 0.33333333333333
29521, 1.3739130434783, 0.1, 0.27777777777778
29522, 1.3739130434783, 0.1, 0.22222222222222
29523, 1.3739130434783, 0.1, 0.16666666666667
29524, 1.3739130434783, 0.1, 0.11111111111111
29525, 1.3739130434783, 0.1, 0.055555555555556
29526, 1.4173913043478, 0.1, 0.44444444444444
29527, 1.4173913043478, 0.1, 0.38888888888889
29528, 1.4173913043478, 0.1, 0.33333333333333
29529, 1.4173913043478, 0.1, 0.27777777777778
29530, 1.4173913043478, 0.1, 0.22222222222222
29531, 1.4173913043478, 0.1, 0.16666666666667
29532, 1.4173913043478, 0.1, 0.11111111111111
29533, 1.4173913043478, 0.1, 0.055555555555556
29534, 1.4608695652174, 0.1, 0.44444444444444
29535, 1.4608695652174, 0.1, 0.38888888888889
29536, 1.4608695652174, 0.1, 0.33333333333333
29537, 1.4608695652174, 0.1, 0.27777777777778
29538, 1.4608695652174, 0.1, 0.22222222222222
29539, 1.4608695652174, 0.1, 0.16666666666667
29540, 1.4608695652174, 0.1, 0.11111111111111
29541, 1.4608695652174, 0.1, 0.055555555555556
29542, 1.504347826087, 0.1, 0.44444444444444
29543, 1.504347826087, 0.1, 0.38888888888889
29544, 1.504347826087, 0.1, 0.33333333333333
29545, 1.504347826087, 0.1, 0.27777777777778
29546, 1.504347826087, 0.1, 0.22222222222222
29547, 1.504347826087, 0.1, 0.16666666666667
29548, 1.504347826087, 0.1, 0.11111111111111
29549, 1.504347826087, 0.1, 0.055555555555556
29550, 1.5478260869565, 0.1, 0.44444444444444
29551, 1.5478260869565, 0.1, 0.38888888888889
29552, 1.5478260869565, 0.1, 0.33333333333333
29553, 1.5478260869565, 0.1, 0.27777777777778
29554, 1.5478260869565, 0.1, 0.22222222222222
29555, 1.5478260869565, 0.1, 0.16666666666667
29556, 1.5478260869565, 0.1, 0.11111111111111
29557, 1.5478260869565, 0.1, 0.055555555555556
29558, 1.5913043478261, 0.1, 0.44444444444444
29559, 1.5913043478261, 0.1, 0.38888888888889
29560, 1.5913043478261, 0.1, 0.33333333333333
29561, 1.5913043478261, 0.1, 0.27777777777778
29562, 1.5913043478261, 0.1, 0.22222222222222
29563, 1.5913043478261, 0.1, 0.16666666666667
29564, 1.5913043478261, 0.1, 0.11111111111111
29565, 1.5913043478261, 0.1, 0.055555555555556
29566, 1.6347826086957, 0.1, 0.44444444444444
29567, 1.6347826086957, 0.1, 0.38888888888889
29568, 1.6347826086957, 0.1, 0.33333333333333
29569, 1.6347826086957, 0.1, 0.27777777777778
29570, 1.6347826086957, 0.1, 0.22222222222222
29571, 1.6347826086957, 0.1, 0.16666666666667
29572, 1.6347826086957, 0.1, 0.11111111111111
29573, 1.6347826086957, 0.1, 0.055555555555556
29574, 1.6782608695652, 0.1, 0.44444444444444
29575, 1.6782608695652, 0.1, 0.38888888888889
29576, 1.6782608695652, 0.1, 0.33333333333333
29577, 1.6782608695652, 0.1, 0.27777777777778
29578, 1.6782608695652, 0.1, 0.22222222222222
29579, 1.6782608695652, 0.1, 0.16666666666667
29580, 1.6782608695652, 0.1, 0.11111111111111
29581, 1.6782608695652, 0.1, 0.055555555555556
29582, 1.7217391304348, 0.1, 0.44444444444444
29583, 1.7217391304348, 0.1, 0.38888888888889
29584, 1.7217391304348, 0.1, 0.33333333333333
29585, 1.7217391304348, 0.1, 0.27777777777778
29586, 1.7217391304348, 0.1, 0.22222222222222
29587, 1.7217391304348, 0.1, 0.16666666666667
29588, 1.7217391304348, 0.1, 0.11111111111111
29589, 1.7217391304348, 0.1, 0.055555555555556
29590, 1.7652173913043, 0.1, 0.44444444444444
29591, 1.7652173913043, 0.1, 0.38888888888889
29592, 1.7652173913043, 0.1, 0.33333333333333
29593, 1.7652173913043, 0.1, 0.27777777777778
29594, 1.7652173913043, 0.1, 0.22222222222222
29595, 1.7652173913043, 0.1, 0.16666666666667
29596, 1.7652173913043, 0.1, 0.11111111111111
29597, 1.7652173913043, 0.1, 0.055555555555556
29598, 1.8086956521739, 0.1, 0.44444444444444
29599, 1.8086956521739, 0.1, 0.38888888888889
29600, 1.8086956521739, 0.1, 0.33333333333333
29601, 1.8086956521739, 0.1, 0.27777777777778
29602, 1.8086956521739, 0.1, 0.22222222222222
29603, 1.8086956521739, 0.1, 0.16666666666667
29604, 1.8086956521739, 0.1, 0.11111111111111
29605, 1.8086956521739, 0.1, 0.055555555555556
29606, 1.8521739130435, 0.1, 0.44444444444444
29607, 1.8521739130435, 0.1, 0.38888888888889
29608, 1.8521739130435, 0.1, 0.33333333333333
29609, 1.8521739130435, 0.1, 0.27777777777778
29610, 1.8521739130435, 0.1, 0.22222222222222
29611, 1.8521739130435, 0.1, 0.16666666666667
29612, 1.8521739130435, 0.1, 0.11111111111111
29613, 1.8521739130435, 0.1, 0.055555555555556
29614, 1.895652173913, 0.1, 0.44444444444444
29615, 1.895652173913, 0.1, 0.38888888888889
29616, 1.895652173913, 0.1, 0.33333333333333
29617, 1.895652173913, 0.1, 0.27777777777778
29618, 1.895652173913, 0.1, 0.22222222222222
29619, 1.895652173913, 0.1, 0.16666666666667
29620, 1.895652173913, 0.1, 0.11111111111111
29621, 1.895652173913, 0.1, 0.055555555555556
29622, 1.9391304347826, 0.1, 0.44444444444444
29623, 1.9391304347826, 0.1, 0.38888888888889
29624, 1.9391304347826, 0.1, 0.33333333333333
29625, 1.9391304347826, 0.1, 0.27777777777778
29626, 1.9391304347826, 0.1, 0.22222222222222
29627, 1.9391304347826, 0.1, 0.16666666666667
29628, 1.9391304347826, 0.1, 0.11111111111111
29629, 1.9391304347826, 0.1, 0.055555555555556
29630, 1.9826086956522, 0.1, 0.44444444444444
29631, 1.9826086956522, 0.1, 0.38888888888889
29632, 1.9826086956522, 0.1, 0.33333333333333
29633, 1.9826086956522, 0.1, 0.27777777777778
29634, 1.9826086956522, 0.1, 0.22222222222222
29635, 1.9826086956522, 0.1, 0.16666666666667
29636, 1.9826086956522, 0.1, 0.11111111111111
29637, 1.9826086956522, 0.1, 0.055555555555556
29638, 2.0260869565217, 0.1, 0.44444444444444
29639, 2.0260869565217, 0.1, 0.38888888888889
29640, 2.0260869565217, 0.1, 0.33333333333333
29641, 2.0260869565217, 0.1, 0.27777777777778
29642, 2.0260869565217, 0.1, 0.22222222222222
29643, 2.0260869565217, 0.1, 0.16666666666667
29644, 2.0260869565217, 0.1, 0.11111111111111
29645, 2.0260869565217, 0.1, 0.055555555555556
29646, 2.0695652173913, 0.1, 0.44444444444444
29647, 2.0695652173913, 0.1, 0.38888888888889
29648, 2.0695652173913, 0.1, 0.33333333333333
29649, 2.0695652173913, 0.1, 0.27777777777778
29650, 2.0695652173913, 0.1, 0.22222222222222
29651, 2.0695652173913, 0.1, 0.16666666666667
29652, 2.0695652173913, 0.1, 0.11111111111111
29653, 2.0695652173913, 0.1, 0.055555555555556
29654, 2.1130434782609, 0.1, 0.44444444444444
29655, 2.1130434782609, 0.1, 0.38888888888889
29656, 2.1130434782609, 0.1, 0.33333333333333
29657, 2.1130434782609, 0.1, 0.27777777777778
29658, 2.1130434782609, 0.1, 0.22222222222222
29659, 2.1130434782609, 0.1, 0.16666666666667
29660, 2.1130434782609, 0.1, 0.11111111111111
29661, 2.1130434782609, 0.1, 0.055555555555556
29662, 2.1565217391304, 0.1, 0.44444444444444
29663, 2.1565217391304, 0.1, 0.38888888888889
29664, 2.1565217391304, 0.1, 0.33333333333333
29665, 2.1565217391304, 0.1, 0.27777777777778
29666, 2.1565217391304, 0.1, 0.22222222222222
29667, 2.1565217391304, 0.1, 0.16666666666667
29668, 2.1565217391304, 0.1, 0.11111111111111
29669, 2.1565217391304, 0.1, 0.055555555555556
29670, 1.2217391304348, 0.1, 0.44444444444444
29671, 1.2434782608696, 0.1, 0.47222222222222
29672, 1.2217391304348, 0.1, 0.38888888888889
29673, 1.2434782608696, 0.1, 0.41666666666667
29674, 1.2217391304348, 0.1, 0.33333333333333
29675, 1.2434782608696, 0.1, 0.36111111111111
29676, 1.2217391304348, 0.1, 0.27777777777778
29677, 1.2434782608696, 0.1, 0.30555555555556
29678, 1.2217391304348, 0.1, 0.22222222222222
29679, 1.2434782608696, 0.1, 0.25
29680, 1.2217391304348, 0.1, 0.16666666666667
29681, 1.2434782608696, 0.1, 0.19444444444444
29682, 1.2217391304348, 0.1, 0.11111111111111
29683, 1.2434782608696, 0.1, 0.13888888888889
29684, 1.2217391304348, 0.1, 0.055555555555556
29685, 1.2434782608696, 0.1, 0.083333333333333
29686, 1.2434782608696, 0.1, 0.027777777777778
29687, 1.2652173913043, 0.1, 0.44444444444444
29688, 1.2869565217391, 0.1, 0.47222222222222
29689, 1.2652173913043, 0.1, 0.38888888888889
29690, 1.2869565217391, 0.1, 0.41666666666667
29691, 1.2652173913043, 0.1, 0.33333333333333
29692, 1.2869565217391, 0.1, 0.36111111111111
29693, 1.2652173913043, 0.1, 0.27777777777778
29694, 1.2869565217391, 0.1, 0.30555555555556
29695, 1.2652173913043, 0.1, 0.22222222222222
29696, 1.2869565217391, 0.1, 0.25
29697, 1.2652173913043, 0.1, 0.16666666666667
29698, 1.2869565217391, 0.1, 0.19444444444444
29699, 1.2652173913043, 0.1, 0.11111111111111
29700, 1.2869565217391, 0.1, 0.13888888888889
29701, 1.2652173913043, 0.1, 0.055555555555556
29702, 1.2869565217391, 0.1, 0.083333333333333
29703, 1.2869565217391, 0.1, 0.027777777777778
29704, 1.3086956521739, 0.1, 0.44444444444444
29705, 1.3304347826087, 0.1, 0.47222222222222
29706, 1.3086956521739, 0.1, 0.38888888888889
29707, 1.3304347826087, 0.1, 0.41666666666667
29708, 1.3086956521739, 0.1, 0.33333333333333
29709, 1.3304347826087, 0.1, 0.36111111111111
29710, 1.3086956521739, 0.1, 0.27777777777778
29711, 1.3304347826087, 0.1, 0.30555555555556
29712, 1.3086956521739, 0.1, 0.22222222222222
29713, 1.3304347826087, 0.1, 0.25
29714, 1.3086956521739, 0.1, 0.16666666666667
29715, 1.3304347826087, 0.1, 0.19444444444444
29716, 1.3086956521739, 0.1, 0.11111111111111
29717, 1.3304347826087, 0.1, 0.13888888888889
29718, 1.3086956521739, 0.1, 0.055555555555556
29719, 1.3304347826087, 0.1, 0.083333333333333
29720, 1.3304347826087, 0.1, 0.027777777777778
29721, 1.3521739130435, 0.1, 0.44444444444444
29722, 1.3739130434783, 0.1, 0.47222222222222
29723, 1.3521739130435, 0.1, 0.38888888888889
29724, 1.3739130434783, 0.1, 0.41666666666667
29725, 1.3521739130435, 0.1, 0.33333333333333
29726, 1.3739130434783, 0.1, 0.36111111111111
29727, 1.3521739130435, 0.1, 0.27777777777778
29728, 1.3739130434783, 0.1, 0.30555555555556
29729, 1.3521739130435, 0.1, 0.22222222222222
29730, 1.3739130434783, 0.1, 0.25
29731, 1.3521739130435, 0.1, 0.16666666666667
29732, 1.3739130434783, 0.1, 0.19444444444444
29733, 1.3521739130435, 0.1, 0.11111111111111
29734, 1.3739130434783, 0.1, 0.13888888888889
29735, 1.3521739130435, 0.1, 0.055555555555556
29736, 1.3739130434783, 0.1, 0.083333333333333
29737, 1.3739130434783, 0.1, 0.027777777777778
29738, 1.395652173913, 0.1, 0.44444444444444
29739, 1.4173913043478, 0.1, 0.47222222222222
29740, 1.395652173913, 0.1, 0.38888888888889
29741, 1.4173913043478, 0.1, 0.41666666666667
29742, 1.395652173913, 0.1, 0.33333333333333
29743, 1.4173913043478, 0.1, 0.36111111111111
29744, 1.395652173913, 0.1, 0.27777777777778
29745, 1.4173913043478, 0.1, 0.30555555555556
29746, 1.395652173913, 0.1, 0.22222222222222
29747, 1.4173913043478, 0.1, 0.25
29748, 1.395652173913, 0.1, 0.16666666666667
29749, 1.4173913043478, 0.1, 0.19444444444444
29750, 1.395652173913, 0.1, 0.11111111111111
29751, 1.4173913043478, 0.1, 0.13888888888889
29752, 1.395652173913, 0.1, 0.055555555555556
29753, 1.4173913043478, 0.1, 0.083333333333333
29754, 1.4173913043478, 0.1, 0.027777777777778
29755, 1.4391304347826, 0.1, 0.44444444444444
29756, 1.4608695652174, 0.1, 0.47222222222222
29757, 1.4391304347826, 0.1, 0.38888888888889
29758, 1.4608695652174, 0.1, 0.41666666666667
29759, 1.4391304347826, 0.1, 0.33333333333333
29760, 1.4608695652174, 0.1, 0.36111111111111
29761, 1.4391304347826, 0.1, 0.27777777777778
29762, 1.4608695652174, 0.1, 0.30555555555556
29763, 1.4391304347826, 0.1, 0.22222222222222
29764, 1.4608695652174, 0.1, 0.25
29765, 1.4391304347826, 0.1, 0.16666666666667
29766, 1.4608695652174, 0.1, 0.19444444444444
29767, 1.4391304347826, 0.1, 0.11111111111111
29768, 1.4608695652174, 0.1, 0.13888888888889
29769, 1.4391304347826, 0.1, 0.055555555555556
29770, 1.4608695652174, 0.1, 0.083333333333333
29771, 1.4608695652174, 0.1, 0.027777777777778
29772, 1.4826086956522, 0.1, 0.44444444444444
29773, 1.504347826087, 0.1, 0.47222222222222
29774, 1.4826086956522, 0.1, 0.38888888888889
29775, 1.504347826087, 0.1, 0.41666666666667
29776, 1.4826086956522, 0.1, 0.33333333333333
29777, 1.504347826087, 0.1, 0.36111111111111
29778, 1.4826086956522, 0.1, 0.27777777777778
29779, 1.504347826087, 0.1, 0.30555555555556
29780, 1.4826086956522, 0.1, 0.22222222222222
29781, 1.504347826087, 0.1, 0.25
29782, 1.4826086956522, 0.1, 0.16666666666667
29783, 1.504347826087, 0.1, 0.19444444444444
29784, 1.4826086956522, 0.1, 0.11111111111111
29785, 1.504347826087, 0.1, 0.13888888888889
29786, 1.4826086956522, 0.1, 0.055555555555556
29787, 1.504347826087, 0.1, 0.083333333333333
29788, 1.504347826087, 0.1, 0.027777777777778
29789, 1.5260869565217, 0.1, 0.44444444444444
29790, 1.5478260869565, 0.1, 0.47222222222222
29791, 1.5260869565217, 0.1, 0.38888888888889
29792, 1.5478260869565, 0.1, 0.41666666666667
29793, 1.5260869565217, 0.1, 0.33333333333333
29794, 1.5478260869565, 0.1, 0.36111111111111
29795, 1.5260869565217, 0.1, 0.27777777777778
29796, 1.5478260869565, 0.1, 0.30555555555556
29797, 1.5260869565217, 0.1, 0.22222222222222
29798, 1.5478260869565, 0.1, 0.25
29799, 1.5260869565217, 0.1, 0.16666666666667
29800, 1.5478260869565, 0.1, 0.19444444444444
29801, 1.5260869565217, 0.1, 0.11111111111111
29802, 1.5478260869565, 0.1, 0.13888888888889
29803, 1.5260869565217, 0.1, 0.055555555555556
29804, 1.5478260869565, 0.1, 0.083333333333333
29805, 1.5478260869565, 0.1, 0.027777777777778
29806, 1.5695652173913, 0.1, 0.44444444444444
29807, 1.5913043478261, 0.1, 0.47222222222222
29808, 1.5695652173913, 0.1, 0.38888888888889
29809, 1.5913043478261, 0.1, 0.41666666666667
29810, 1.5695652173913, 0.1, 0.33333333333333
29811, 1.5913043478261, 0.1, 0.36111111111111
29812, 1.5695652173913, 0.1, 0.27777777777778
29813, 1.5913043478261, 0.1, 0.30555555555556
29814, 1.5695652173913, 0.1, 0.22222222222222
29815, 1.5913043478261, 0.1, 0.25
29816, 1.5695652173913, 0.1, 0.16666666666667
29817, 1.5913043478261, 0.1, 0.19444444444444
29818, 1.5695652173913, 0.1, 0.11111111111111
29819, 1.5913043478261, 0.1, 0.13888888888889
29820, 1.5695652173913, 0.1, 0.055555555555556
29821, 1.5913043478261, 0.1, 0.083333333333333
29822, 1.5913043478261, 0.1, 0.027777777777778
29823, 1.6130434782609, 0.1, 0.44444444444444
29824, 1.6347826086957, 0.1, 0.47222222222222
29825, 1.6130434782609, 0.1, 0.38888888888889
29826, 1.6347826086957, 0.1, 0.41666666666667
29827, 1.6130434782609, 0.1, 0.33333333333333
29828, 1.6347826086957, 0.1, 0.36111111111111
29829, 1.6130434782609, 0.1, 0.27777777777778
29830, 1.6347826086957, 0.1, 0.30555555555556
29831, 1.6130434782609, 0.1, 0.22222222222222
29832, 1.6347826086957, 0.1, 0.25
29833, 1.6130434782609, 0.1, 0.16666666666667
29834, 1.6347826086957, 0.1, 0.19444444444444
29835, 1.6130434782609, 0.1, 0.11111111111111
29836, 1.6347826086957, 0.1, 0.13888888888889
29837, 1.6130434782609, 0.1, 0.055555555555556
29838, 1.6347826086957, 0.1, 0.083333333333333
29839, 1.6347826086957, 0.1, 0.027777777777778
29840, 1.6565217391304, 0.1, 0.44444444444444
29841, 1.6782608695652, 0.1, 0.47222222222222
29842, 1.6565217391304, 0.1, 0.38888888888889
29843, 1.6782608695652, 0.1, 0.41666666666667
29844, 1.6565217391304, 0.1, 0.33333333333333
29845, 1.6782608695652, 0.1, 0.36111111111111
29846, 1.6565217391304, 0.1, 0.27777777777778
29847, 1.6782608695652, 0.1, 0.30555555555556
29848, 1.6565217391304, 0.1, 0.22222222222222
29849, 1.6782608695652, 0.1, 0.25
29850, 1.6565217391304, 0.1, 0.16666666666667
29851, 1.6782608695652, 0.1, 0.19444444444444
29852, 1.6565217391304, 0.1, 0.11111111111111
29853, 1.6782608695652, 0.1, 0.13888888888889
29854, 1.6565217391304, 0.1, 0.055555555555556
29855, 1.6782608695652, 0.1, 0.083333333333333
29856, 1.6782608695652, 0.1, 0.027777777777778
29857, 1.7, 0.1, 0.44444444444444
29858, 1.7217391304348, 0.1, 0.47222222222222
29859, 1.7, 0.1, 0.38888888888889
29860, 1.7217391304348, 0.1, 0.41666666666667
29861, 1.7, 0.1, 0.33333333333333
29862, 1.7217391304348, 0.1, 0.36111111111111
29863, 1.7, 0.1, 0.27777777777778
29864, 1.7217391304348, 0.1, 0.30555555555556
29865, 1.7, 0.1, 0.22222222222222
29866, 1.7217391304348, 0.1, 0.25
29867, 1.7, 0.1, 0.16666666666667
29868, 1.7217391304348, 0.1, 0.19444444444444
29869, 1.7, 0.1, 0.11111111111111
29870, 1.7217391304348, 0.1, 0.13888888888889
29871, 1.7, 0.1, 0.055555555555556
29872, 1.7217391304348, 0.1, 0.083333333333333
29873, 1.7217391304348, 0.1, 0.027777777777778
29874, 1.7434782608696, 0.1, 0.44444444444444
29875, 1.7652173913043, 0.1, 0.47222222222222
29876, 1.7434782608696, 0.1, 0.38888888888889
29877, 1.7652173913043, 0.1, 0.41666666666667
29878, 1.7434782608696, 0.1, 0.33333333333333
29879, 1.7652173913043, 0.1, 0.36111111111111
29880, 1.7434782608696, 0.1, 0.27777777777778
29881, 1.7652173913043, 0.1, 0.30555555555556
29882, 1.7434782608696, 0.1, 0.22222222222222
29883, 1.7652173913043, 0.1, 0.25
29884, 1.7434782608696, 0.1, 0.16666666666667
29885, 1.7652173913043, 0.1, 0.19444444444444
29886, 1.7434782608696, 0.1, 0.11111111111111
29887, 1.7652173913043, 0.1, 0.13888888888889
29888, 1.7434782608696, 0.1, 0.055555555555556
29889, 1.7652173913043, 0.1, 0.083333333333333
29890, 1.7652173913043, 0.1, 0.027777777777778
29891, 1.7869565217391, 0.1, 0.44444444444444
29892, 1.8086956521739, 0.1, 0.47222222222222
29893, 1.7869565217391, 0.1, 0.38888888888889
29894, 1.8086956521739, 0.1, 0.41666666666667
29895, 1.7869565217391, 0.1, 0.33333333333333
29896, 1.8086956521739, 0.1, 0.36111111111111
29897, 1.7869565217391, 0.1, 0.27777777777778
29898, 1.8086956521739, 0.1, 0.30555555555556
29899, 1.7869565217391, 0.1, 0.22222222222222
29900, 1.8086956521739, 0.1, 0.25
29901, 1.7869565217391, 0.1, 0.16666666666667
29902, 1.8086956521739, 0.1, 0.19444444444444
29903, 1.7869565217391, 0.1, 0.11111111111111
29904, 1.8086956521739, 0.1, 0.13888888888889
29905, 1.7869565217391, 0.1, 0.055555555555556
29906, 1.8086956521739, 0.1, 0.083333333333333
29907, 1.8086956521739, 0.1, 0.027777777777778
29908, 1.8304347826087, 0.1, 0.44444444444444
29909, 1.8521739130435, 0.1, 0.47222222222222
29910, 1.8304347826087, 0.1, 0.38888888888889
29911, 1.8521739130435, 0.1, 0.41666666666667
29912, 1.8304347826087, 0.1, 0.33333333333333
29913, 1.8521739130435, 0.1, 0.36111111111111
29914, 1.8304347826087, 0.1, 0.27777777777778
29915, 1.8521739130435, 0.1, 0.30555555555556
29916, 1.8304347826087, 0.1, 0.22222222222222
29917, 1.8521739130435, 0.1, 0.25
29918, 1.8304347826087, 0.1, 0.16666666666667
29919, 1.8521739130435, 0.1, 0.19444444444444
29920, 1.8304347826087, 0.1, 0.11111111111111
29921, 1.8521739130435, 0.1, 0.13888888888889
29922, 1.8304347826087, 0.1, 0.055555555555556
29923, 1.8521739130435, 0.1, 0.083333333333333
29924, 1.8521739130435, 0.1, 0.027777777777778
29925, 1.8739130434783, 0.1, 0.44444444444444
29926, 1.895652173913, 0.1, 0.47222222222222
29927, 1.8739130434783, 0.1, 0.38888888888889
29928, 1.895652173913, 0.1, 0.41666666666667
29929, 1.8739130434783, 0.1, 0.33333333333333
29930, 1.895652173913, 0.1, 0.36111111111111
29931, 1.8739130434783, 0.1, 0.27777777777778
29932, 1.895652173913, 0.1, 0.30555555555556
29933, 1.8739130434783, 0.1, 0.22222222222222
29934, 1.895652173913, 0.1, 0.25
29935, 1.8739130434783, 0.1, 0.16666666666667
29936, 1.895652173913, 0.1, 0.19444444444444
29937, 1.8739130434783, 0.1, 0.11111111111111
29938, 1.895652173913, 0.1, 0.13888888888889
29939, 1.8739130434783, 0.1, 0.055555555555556
29940, 1.895652173913, 0.1, 0.083333333333333
29941, 1.895652173913, 0.1, 0.027777777777778
29942, 1.9173913043478, 0.1, 0.44444444444444
29943, 1.9391304347826, 0.1, 0.47222222222222
29944, 1.9173913043478, 0.1, 0.38888888888889
29945, 1.9391304347826, 0.1, 0.41666666666667
29946, 1.9173913043478, 0.1, 0.33333333333333
29947, 1.9391304347826, 0.1, 0.36111111111111
29948, 1.9173913043478, 0.1, 0.27777777777778
29949, 1.9391304347826, 0.1, 0.30555555555556
29950, 1.9173913043478, 0.1, 0.22222222222222
29951, 1.9391304347826, 0.1, 0.25
29952, 1.9173913043478, 0.1, 0.16666666666667
29953, 1.9391304347826, 0.1, 0.19444444444444
29954, 1.9173913043478, 0.1, 0.11111111111111
29955, 1.9391304347826, 0.1, 0.13888888888889
29956, 1.9173913043478, 0.1, 0.055555555555556
29957, 1.9391304347826, 0.1, 0.083333333333333
29958, 1.9391304347826, 0.1, 0.027777777777778
29959, 1.9608695652174, 0.1, 0.44444444444444
29960, 1.9826086956522, 0.1, 0.47222222222222
29961, 1.9608695652174, 0.1, 0.38888888888889
29962, 1.9826086956522, 0.1, 0.41666666666667
29963, 1.9608695652174, 0.1, 0.33333333333333
29964, 1.9826086956522, 0.1, 0.36111111111111
29965, 1.9608695652174, 0.1, 0.27777777777778
29966, 1.9826086956522, 0.1, 0.30555555555556
29967, 1.9608695652174, 0.1, 0.22222222222222
29968, 1.9826086956522, 0.1, 0.25
29969, 1.9608695652174, 0.1, 0.16666666666667
29970, 1.9826086956522, 0.1, 0.19444444444444
29971, 1.9608695652174, 0.1, 0.11111111111111
29972, 1.9826086956522, 0.1, 0.13888888888889
29973, 1.9608695652174, 0.1, 0.055555555555556
29974, 1.9826086956522, 0.1, 0.083333333333333
29975, 1.9826086956522, 0.1, 0.027777777777778
29976, 2.004347826087, 0.1, 0.44444444444444
29977, 2.0260869565217, 0.1, 0.47222222222222
29978, 2.004347826087, 0.1, 0.38888888888889
29979, 2.0260869565217, 0.1, 0.41666666666667
29980, 2.004347826087, 0.1, 0.33333333333333
29981, 2.0260869565217, 0.1, 0.36111111111111
29982, 2.004347826087, 0.1, 0.27777777777778
29983, 2.0260869565217, 0.1, 0.30555555555556
29984, 2.004347826087, 0.1, 0.22222222222222
29985, 2.0260869565217, 0.1, 0.25
29986, 2.004347826087, 0.1, 0.16666666666667
29987, 2.0260869565217, 0.1, 0.19444444444444
29988, 2.004347826087, 0.1, 0.11111111111111
29989, 2.0260869565217, 0.1, 0.13888888888889
29990, 2.004347826087, 0.1, 0.055555555555556
29991, 2.0260869565217, 0.1, 0.083333333333333
29992, 2.0260869565217, 0.1, 0.027777777777778
29993, 2.0478260869565, 0.1, 0.44444444444444
29994, 2.0695652173913, 0.1, 0.47222222222222
29995, 2.0478260869565, 0.1, 0.38888888888889
29996, 2.0695652173913, 0.1, 0.41666666666667
29997, 2.0478260869565, 0.1, 0.33333333333333
29998, 2.0695652173913, 0.1, 0.36111111111111
29999, 2.0478260869565, 0.1, 0.27777777777778
30000, 2.0695652173913, 0.1, 0.30555555555556
30001, 2.0478260869565, 0.1, 0.22222222222222
30002, 2.0695652173913, 0.1, 0.25
30003, 2.0478260869565, 0.1, 0.16666666666667
30004, 2.0695652173913, 0.1, 0.19444444444444
30005, 2.0478260869565, 0.1, 0.11111111111111
30006, 2.0695652173913, 0.1, 0.13888888888889
30007, 2.0478260869565, 0.1, 0.055555555555556
30008, 2.0695652173913, 0.1, 0.083333333333333
30009, 2.0695652173913, 0.1, 0.027777777777778
30010, 2.0913043478261, 0.1, 0.44444444444444
30011, 2.1130434782609, 0.1, 0.47222222222222
30012, 2.0913043478261, 0.1, 0.38888888888889
30013, 2.1130434782609, 0.1, 0.41666666666667
30014, 2.0913043478261, 0.1, 0.33333333333333
30015, 2.1130434782609, 0.1, 0.36111111111111
30016, 2.0913043478261, 0.1, 0.27777777777778
30017, 2.1130434782609, 0.1, 0.30555555555556
30018, 2.0913043478261, 0.1, 0.22222222222222
30019, 2.1130434782609, 0.1, 0.25
30020, 2.0913043478261, 0.1, 0.16666666666667
30021, 2.1130434782609, 0.1, 0.19444444444444
30022, 2.0913043478261, 0.1, 0.11111111111111
30023, 2.1130434782609, 0.1, 0.13888888888889
30024, 2.0913043478261, 0.1, 0.055555555555556
30025, 2.1130434782609, 0.1, 0.083333333333333
30026, 2.1130434782609, 0.1, 0.027777777777778
30027, 2.1347826086957, 0.1, 0.44444444444444
30028, 2.1565217391304, 0.1, 0.47222222222222
30029, 2.1347826086957, 0.1, 0.38888888888889
30030, 2.1565217391304, 0.1, 0.41666666666667
30031, 2.1347826086957, 0.1, 0.33333333333333
30032, 2.1565217391304, 0.1, 0.36111111111111
30033, 2.1347826086957, 0.1, 0.27777777777778
30034, 2.1565217391304, 0.1, 0.30555555555556
30035, 2.1347826086957, 0.1, 0.22222222222222
30036, 2.1565217391304, 0.1, 0.25
30037, 2.1347826086957, 0.1, 0.16666666666667
30038, 2.1565217391304, 0.1, 0.19444444444444
30039, 2.1347826086957, 0.1, 0.11111111111111
30040, 2.1565217391304, 0.1, 0.13888888888889
30041, 2.1347826086957, 0.1, 0.055555555555556
30042, 2.1565217391304, 0.1, 0.083333333333333
30043, 2.1565217391304, 0.1, 0.027777777777778
30044, 2.1782608695652, 0.1, 0.44444444444444
30045, 2.1782608695652, 0.1, 0.38888888888889
30046, 2.1782608695652, 0.1, 0.33333333333333
30047, 2.1782608695652, 0.1, 0.27777777777778
30048, 2.1782608695652, 0.1, 0.22222222222222
30049, 2.1782608695652, 0.1, 0.16666666666667
30050, 2.1782608695652, 0.1, 0.11111111111111
30051, 2.1782608695652, 0.1, 0.055555555555556
30052, 1.2434782608696, 0.075, 0.5
30053, 1.2869565217391, 0.075, 0.5
30054, 1.3304347826087, 0.075, 0.5
30055, 1.3739130434783, 0.075, 0.5
30056, 1.4173913043478, 0.075, 0.5
30057, 1.4608695652174, 0.075, 0.5
30058, 1.504347826087, 0.075, 0.5
30059, 1.5478260869565, 0.075, 0.5
30060, 1.5913043478261, 0.075, 0.5
30061, 1.6347826086957, 0.075, 0.5
30062, 1.6782608695652, 0.075, 0.5
30063, 1.7217391304348, 0.075, 0.5
30064, 1.7652173913043, 0.075, 0.5
30065, 1.8086956521739, 0.075, 0.5
30066, 1.8521739130435, 0.075, 0.5
30067, 1.895652173913, 0.075, 0.5
30068, 1.9391304347826, 0.075, 0.5
30069, 1.9826086956522, 0.075, 0.5
30070, 2.0260869565217, 0.075, 0.5
30071, 2.0695652173913, 0.075, 0.5
30072, 2.1130434782609, 0.075, 0.5
30073, 2.1565217391304, 0.075, 0.5
30074, 1.2434782608696, 0.0625, 0.5
30075, 1.2217391304348, 0.075, 0.5
30076, 1.2869565217391, 0.0625, 0.5
30077, 1.2652173913043, 0.075, 0.5
30078, 1.3304347826087, 0.0625, 0.5
30079, 1.3086956521739, 0.075, 0.5
30080, 1.3739130434783, 0.0625, 0.5
30081, 1.3521739130435, 0.075, 0.5
30082, 1.4173913043478, 0.0625, 0.5
30083, 1.395652173913, 0.075, 0.5
30084, 1.4608695652174, 0.0625, 0.5
30085, 1.4391304347826, 0.075, 0.5
30086, 1.504347826087, 0.0625, 0.5
30087, 1.4826086956522, 0.075, 0.5
30088, 1.5478260869565, 0.0625, 0.5
30089, 1.5260869565217, 0.075, 0.5
30090, 1.5913043478261, 0.0625, 0.5
30091, 1.5695652173913, 0.075, 0.5
30092, 1.6347826086957, 0.0625, 0.5
30093, 1.6130434782609, 0.075, 0.5
30094, 1.6782608695652, 0.0625, 0.5
30095, 1.6565217391304, 0.075, 0.5
30096, 1.7217391304348, 0.0625, 0.5
30097, 1.7, 0.075, 0.5
30098, 1.7652173913043, 0.0625, 0.5
30099, 1.7434782608696, 0.075, 0.5
30100, 1.8086956521739, 0.0625, 0.5
30101, 1.7869565217391, 0.075, 0.5
30102, 1.8521739130435, 0.0625, 0.5
30103, 1.8304347826087, 0.075, 0.5
30104, 1.895652173913, 0.0625, 0.5
30105, 1.8739130434783, 0.075, 0.5
30106, 1.9391304347826, 0.0625, 0.5
30107, 1.9173913043478, 0.075, 0.5
30108, 1.9826086956522, 0.0625, 0.5
30109, 1.9608695652174, 0.075, 0.5
30110, 2.0260869565217, 0.0625, 0.5
30111, 2.004347826087, 0.075, 0.5
30112, 2.0695652173913, 0.0625, 0.5
30113, 2.0478260869565, 0.075, 0.5
30114, 2.1130434782609, 0.0625, 0.5
30115, 2.0913043478261, 0.075, 0.5
30116, 2.1565217391304, 0.0625, 0.5
30117, 2.1347826086957, 0.075, 0.5
30118, 2.1782608695652, 0.075, 0.5
30119, 1.2434782608696, 0.0875, 0.5
30120, 1.2869565217391, 0.0875, 0.5
30121, 1.3304347826087, 0.0875, 0.5
30122, 1.3739130434783, 0.0875, 0.5
30123, 1.4173913043478, 0.0875, 0.5
30124, 1.4608695652174, 0.0875, 0.5
30125, 1.504347826087, 0.0875, 0.5
30126, 1.5478260869565, 0.0875, 0.5
30127, 1.5913043478261, 0.0875, 0.5
30128, 1.6347826086957, 0.0875, 0.5
30129, 1.6782608695652, 0.0875, 0.5
30130, 1.7217391304348, 0.0875, 0.5
30131, 1.7652173913043, 0.0875, 0.5
30132, 1.8086956521739, 0.0875, 0.5
30133, 1.8521739130435, 0.0875, 0.5
30134, 1.895652173913, 0.0875, 0.5
30135, 1.9391304347826, 0.0875, 0.5
30136, 1.9826086956522, 0.0875, 0.5
30137, 2.0260869565217, 0.0875, 0.5
30138, 2.0695652173913, 0.0875, 0.5
30139, 2.1130434782609, 0.0875, 0.5
30140, 2.1565217391304, 0.0875, 0.5
30141, 1.2434782608696, 0.075, 0
30142, 1.2869565217391, 0.075, 0
30143, 1.3304347826087, 0.075, 0
30144, 1.3739130434783, 0.075, 0
30145, 1.4173913043478, 0.075, 0
30146, 1.4608695652174, 0.075, 0
30147, 1.504347826087, 0.075, 0
30148, 1.5478260869565, 0.075, 0
30149, 1.5913043478261, 0.075, 0
30150, 1.6347826086957, 0.075, 0
30151, 1.6782608695652, 0.075, 0
30152, 1.7217391304348, 0.075, 0
30153, 1.7652173913043, 0.075, 0
30154, 1.8086956521739, 0.075, 0
30155, 1.8521739130435, 0.075, 0
30156, 1.895652173913, 0.075, 0
30157, 1.9391304347826, 0.075, 0
30158, 1.9826086956522, 0.075, 0
30159, 2.0260869565217, 0.075, 0
30160, 2.0695652173913, 0.075, 0
30161, 2.1130434782609, 0.075, 0
30162, 2.1565217391304, 0.075, 0
30163, 1.2217391304348, 0.075, 0
30164, 1.2434782608696, 0.0625, 0
30165, 1.2652173913043, 0.075, 0
30166, 1.2869565217391, 0.0625, 0
30167, 1.3086956521739, 0.075, 0
30168, 1.3304347826087, 0.0625, 0
30169, 1.3521739130435, 0.075, 0
30170, 1.3739130434783, 0.0625, 0
30171, 1.395652173913, 0.075, 0
30172, 1.4173913043478, 0.0625, 0
30173, 1.4391304347826, 0.075, 0
30174, 1.4608695652174, 0.0625, 0
30175, 1.4826086956522, 0.075, 0
30176, 1.504347826087, 0.0625, 0
30177, 1.5260869565217, 0.075, 0
30178, 1.5478260869565, 0.0625, 0
30179, 1.5695652173913, 0.075, 0
30180, 1.5913043478261, 0.0625, 0
30181, 1.6130434782609, 0.075, 0
30182, 1.6347826086957, 0.0625, 0
30183, 1.6565217391304, 0.075, 0
30184, 1.6782608695652, 0.0625, 0
30185, 1.7, 0.075, 0
30186, 1.7217391304348, 0.0625, 0
30187, 1.7434782608696, 0.075, 0
30188, 1.7652173913043, 0.0625, 0
30189, 1.7869565217391, 0.075, 0
30190, 1.8086956521739, 0.0625, 0
30191, 1.8304347826087, 0.075, 0
30192, 1.8521739130435, 0.0625, 0
30193, 1.8739130434783, 0.075, 0
30194, 1.895652173913, 0.0625, 0
30195, 1.9173913043478, 0.075, 0
30196, 1.9391304347826, 0.0625, 0
30197, 1.9608695652174, 0.075, 0
30198, 1.9826086956522, 0.0625, 0
30199, 2.004347826087, 0.075, 0
30200, 2.0260869565217, 0.0625, 0
30201, 2.0478260869565, 0.075, 0
30202, 2.0695652173913, 0.0625, 0
30203, 2.0913043478261, 0.075, 0
30204, 2.1130434782609, 0.0625, 0
30205, 2.1347826086957, 0.075, 0
30206, 2.1565217391304, 0.0625, 0
30207, 2.1782608695652, 0.075, 0
30208, 1.2434782608696, 0.0875, 0
30209, 1.2869565217391, 0.0875, 0
30210, 1.3304347826087, 0.0875, 0
30211, 1.3739130434783, 0.0875, 0
30212, 1.4173913043478, 0.0875, 0
30213, 1.4608695652174, 0.0875, 0
30214, 1.504347826087, 0.0875, 0
30215, 1.5478260869565, 0.0875, 0
30216, 1.5913043478261, 0.0875, 0
30217, 1.6347826086957, 0.0875, 0
30218, 1.6782608695652, 0.0875, 0
30219, 1.7217391304348, 0.0875, 0
30220, 1.7652173913043, 0.0875, 0
30221, 1.8086956521739, 0.0875, 0
30222, 1.8521739130435, 0.0875, 0
30223, 1.895652173913, 0.0875, 0
30224, 1.9391304347826, 0.0875, 0
30225, 1.9826086956522, 0.0875, 0
30226, 2.0260869565217, 0.0875, 0
30227, 2.0695652173913, 0.0875, 0
30228, 2.1130434782609, 0.0875, 0
30229, 2.1565217391304, 0.0875, 0
30230, 1.2, 0.075, 0.44444444444444
30231, 1.2, 0.075, 0.38888888888889
30232, 1.2, 0.075, 0.33333333333333
30233, 1.2, 0.075, 0.27777777777778
30234, 1.2, 0.075, 0.22222222222222
30235, 1.2, 0.075, 0.16666666666667
30236, 1.2, 0.075, 0.11111111111111
30237, 1.2, 0.075, 0.055555555555556
30238, 1.2, 0.075, 0.47222222222222
30239, 1.2, 0.0625, 0.44444444444444
30240, 1.2, 0.075, 0.41666666666667
30241, 1.2, 0.0625, 0.38888888888889
30242, 1.2, 0.075, 0.36111111111111
30243, 1.2, 0.0625, 0.33333333333333
30244, 1.2, 0.075, 0.30555555555556
30245, 1.2, 0.0625, 0.27777777777778
30246, 1.2, 0.075, 0.25
30247, 1.2, 0.0625, 0.22222222222222
30248, 1.2, 0.075, 0.19444444444444
30249, 1.2, 0.0625, 0.16666666666667
30250, 1.2, 0.075, 0.13888888888889
30251, 1.2, 0.0625, 0.11111111111111
30252, 1.2, 0.075, 0.083333333333333
30253, 1.2, 0.0625, 0.055555555555556
30254, 1.2, 0.075, 0.027777777777778
30255, 1.2, 0.0875, 0.44444444444444
30256, 1.2, 0.0875, 0.38888888888889
30257, 1.2, 0.0875, 0.33333333333333
30258, 1.2, 0.0875, 0.27777777777778
30259, 1.2, 0.0875, 0.22222222222222
30260, 1.2, 0.0875, 0.16666666666667
30261, 1.2, 0.0875, 0.11111111111111
30262, 1.2, 0.0875, 0.055555555555556
30263, 2.2, 0.075, 0.44444444444444
30264, 2.2, 0.075, 0.38888888888889
30265, 2.2, 0.075, 0.33333333333333
30266, 2.2, 0.075, 0.27777777777778
30267, 2.2, 0.075, 0.22222222222222
30268, 2.2, 0.075, 0.16666666666667
30269, 2.2, 0.075, 0.11111111111111
30270, 2.2, 0.075, 0.055555555555556
30271, 2.2, 0.0625, 0.44444444444444
30272, 2.2, 0.075, 0.47222222222222
30273, 2.2, 0.0625, 0.38888888888889
30274, 2.2, 0.075, 0.41666666666667
30275, 2.2, 0.0625, 0.33333333333333
30276, 2.2, 0.075, 0.36111111111111
30277, 2.2, 0.0625, 0.27777777777778
30278, 2.2, 0.075, 0.30555555555556
30279, 2.2, 0.0625, 0.22222222222222
30280, 2.2, 0.075, 0.25
30281, 2.2, 0.0625, 0.16666666666667
30282, 2.2, 0.075, 0.19444444444444
30283, 2.2, 0.0625, 0.11111111111111
30284, 2.2, 0.075, 0.13888888888889
30285, 2.2, 0.0625, 0.055555555555556
30286, 2.2, 0.075, 0.083333333333333
30287, 2.2, 0.075, 0.027777777777778
30288, 2.2, 0.0875, 0.44444444444444
30289, 2.2, 0.0875, 0.38888888888889
30290, 2.2, 0.0875, 0.33333333333333
30291, 2.2, 0.0875, 0.27777777777778
30292, 2.2, 0.0875, 0.22222222222222
30293, 2.2, 0.0875, 0.16666666666667
30294, 2.2, 0.0875, 0.11111111111111
30295, 2.2, 0.0875, 0.055555555555556
30296, 0.95652173913043, 0.075, 0
30297, 0.91304347826087, 0.075, 0
30298, 0.8695652173913, 0.075, 0
30299, 0.82608695652174, 0.075, 0
30300, 0.78260869565217, 0.075, 0
30301, 0.73913043478261, 0.075, 0
30302, 0.69565217391304, 0.075, 0
30303, 0.65217391304348, 0.075, 0
30304, 0.60869565217391, 0.075, 0
30305, 0.56521739130435, 0.075, 0
30306, 0.52173913043478, 0.075, 0
30307, 0.47826086956522, 0.075, 0
30308, 0.43478260869565, 0.075, 0
30309, 0.39130434782609, 0.075, 0
30310, 0.34782608695652, 0.075, 0
30311, 0.30434782608696, 0.075, 0
30312, 0.26086956521739, 0.075, 0
30313, 0.21739130434783, 0.075, 0
30314, 0.17391304347826, 0.075, 0
30315, 0.1304347826087, 0.075, 0
30316, 0.08695652173913, 0.075, 0
30317, 0.043478260869565, 0.075, 0
30318, 0.95652173913043, 0.0625, 0
30319, 0.97826086956522, 0.075, 0
30320, 0.91304347826087, 0.0625, 0
30321, 0.93478260869565, 0.075, 0
30322, 0.8695652173913, 0.0625, 0
30323, 0.89130434782609, 0.075, 0
30324, 0.82608695652174, 0.0625, 0
30325, 0.84782608695652, 0.075, 0
30326, 0.78260869565217, 0.0625, 0
30327, 0.80434782608696, 0.075, 0
30328, 0.73913043478261, 0.0625, 0
30329, 0.76086956521739, 0.075, 0
30330, 0.69565217391304, 0.0625, 0
30331, 0.71739130434783, 0.075, 0
30332, 0.65217391304348, 0.0625, 0
30333, 0.67391304347826, 0.075, 0
30334, 0.60869565217391, 0.0625, 0
30335, 0.6304347826087, 0.075, 0
30336, 0.56521739130435, 0.0625, 0
30337, 0.58695652173913, 0.075, 0
30338, 0.52173913043478, 0.0625, 0
30339, 0.54347826086957, 0.075, 0
30340, 0.47826086956522, 0.0625, 0
30341, 0.5, 0.075, 0
30342, 0.43478260869565, 0.0625, 0
30343, 0.45652173913043, 0.075, 0
30344, 0.39130434782609, 0.0625, 0
30345, 0.41304347826087, 0.075, 0
30346, 0.34782608695652, 0.0625, 0
30347, 0.3695652173913, 0.075, 0
30348, 0.30434782608696, 0.0625, 0
30349, 0.32608695652174, 0.075, 0
30350, 0.26086956521739, 0.0625, 0
30351, 0.28260869565217, 0.075, 0
30352, 0.21739130434783, 0.0625, 0
30353, 0.23913043478261, 0.075, 0
30354, 0.17391304347826, 0.0625, 0
30355, 0.19565217391304, 0.075, 0
30356, 0.1304347826087, 0.0625, 0
30357, 0.15217391304348, 0.075, 0
30358, 0.08695652173913, 0.0625, 0
30359, 0.10869565217391, 0.075, 0
30360, 0.043478260869565, 0.0625, 0
30361, 0.065217391304348, 0.075, 0
30362, 0.021739130434783, 0.075, 0
30363, 0.95652173913043, 0.0875, 0
30364, 0.91304347826087, 0.0875, 0
30365, 0.8695652173913, 0.0875, 0
30366, 0.82608695652174, 0.0875, 0
30367, 0.78260869565217, 0.0875, 0
30368, 0.73913043478261, 0.0875, 0
30369, 0.69565217391304, 0.0875, 0
30370, 0.65217391304348, 0.0875, 0
30371, 0.60869565217391, 0.0875, 0
30372, 0.56521739130435, 0.0875, 0
30373, 0.52173913043478, 0.0875, 0
30374, 0.47826086956522, 0.0875, 0
30375, 0.43478260869565, 0.0875, 0
30376, 0.39130434782609, 0.0875, 0
30377, 0.34782608695652, 0.0875, 0
30378, 0.30434782608696, 0.0875, 0
30379, 0.26086956521739, 0.0875, 0
30380, 0.21739130434783, 0.0875, 0
30381, 0.17391304347826, 0.0875, 0
30382, 0.1304347826087, 0.0875, 0
30383, 0.08695652173913, 0.0875, 0
30384, 0.043478260869565, 0.0875, 0
30385, 1, 0.075, 0.44444444444444
30386, 1, 0.075, 0.38888888888889
30387, 1, 0.075, 0.33333333333333
30388, 1, 0.075, 0.27777777777778
30389, 1, 0.075, 0.22222222222222
30390, 1, 0.075, 0.16666666666667
30391, 1, 0.075, 0.11111111111111
30392, 1, 0.075, 0.055555555555556
30393, 1, 0.0625, 0.44444444444444
30394, 1, 0.075, 0.47222222222222
30395, 1, 0.0625, 0.38888888888889
30396, 1, 0.075, 0.41666666666667
30397, 1, 0.0625, 0.33333333333333
30398, 1, 0.075, 0.36111111111111
30399, 1, 0.0625, 0.27777777777778
30400, 1, 0.075, 0.30555555555556
30401, 1, 0.0625, 0.22222222222222
30402, 1, 0.075, 0.25
30403, 1, 0.0625, 0.16666666666667
30404, 1, 0.075, 0.19444444444444
30405, 1, 0.0625, 0.11111111111111
30406, 1, 0.075, 0.13888888888889
30407, 1, 0.0625, 0.055555555555556
30408, 1, 0.075, 0.083333333333333
30409, 1, 0.075, 0.027777777777778
30410, 1, 0.0875, 0.44444444444444
30411, 1, 0.0875, 0.38888888888889
30412, 1, 0.0875, 0.33333333333333
30413, 1, 0.0875, 0.27777777777778
30414, 1, 0.0875, 0.22222222222222
30415, 1, 0.0875, 0.16666666666667
30416, 1, 0.0875, 0.11111111111111
30417, 1, 0.0875, 0.055555555555556
30418, 0.95652173913043, 0.075, 0.5
30419, 0.91304347826087, 0.075, 0.5
30420, 0.8695652173913, 0.075, 0.5
30421, 0.82608695652174, 0.075, 0.5
30422, 0.78260869565217, 0.075, 0.5
30423, 0.73913043478261, 0.075, 0.5
30424, 0.69565217391304, 0.075, 0.5
30425, 0.65217391304348, 0.075, 0.5
30426, 0.60869565217391, 0.075, 0.5
30427, 0.56521739130435, 0.075, 0.5
30428, 0.52173913043478, 0.075, 0.5
30429, 0.47826086956522, 0.075, 0.5
30430, 0.43478260869565, 0.075, 0.5
30431, 0.39130434782609, 0.075, 0.5
30432, 0.34782608695652, 0.075, 0.5
30433, 0.30434782608696, 0.075, 0.5
30434, 0.26086956521739, 0.075, 0.5
30435, 0.21739130434783, 0.075, 0.5
30436, 0.17391304347826, 0.075, 0.5
30437, 0.1304347826087, 0.075, 0.5
30438, 0.08695652173913, 0.075, 0.5
30439, 0.043478260869565, 0.075, 0.5
30440, 0.97826086956522, 0.075, 0.5
30441, 0.95652173913043, 0.0625, 0.5
30442, 0.93478260869565, 0.075, 0.5
30443, 0.91304347826087, 0.0625, 0.5
30444, 0.89130434782609, 0.075, 0.5
30445, 0.8695652173913, 0.0625, 0.5
30446, 0.84782608695652, 0.075, 0.5
30447, 0.82608695652174, 0.0625, 0.5
30448, 0.80434782608696, 0.075, 0.5
30449, 0.78260869565217, 0.0625, 0.5
30450, 0.76086956521739, 0.075, 0.5
30451, 0.73913043478261, 0.0625, 0.5
30452, 0.71739130434783, 0.075, 0.5
30453, 0.69565217391304, 0.0625, 0.5
30454, 0.67391304347826, 0.075, 0.5
30455, 0.65217391304348, 0.0625, 0.5
30456, 0.6304347826087, 0.075, 0.5
30457, 0.60869565217391, 0.0625, 0.5
30458, 0.58695652173913, 0.075, 0.5
30459, 0.56521739130435, 0.0625, 0.5
30460, 0.54347826086957, 0.075, 0.5
30461, 0.52173913043478, 0.0625, 0.5
30462, 0.5, 0.075, 0.5
30463, 0.47826086956522, 0.0625, 0.5
30464, 0.45652173913043, 0.075, 0.5
30465, 0.43478260869565, 0.0625, 0.5
30466, 0.41304347826087, 0.075, 0.5
30467, 0.39130434782609, 0.0625, 0.5
30468, 0.3695652173913, 0.075, 0.5
30469, 0.34782608695652, 0.0625, 0.5
30470, 0.32608695652174, 0.075, 0.5
30471, 0.30434782608696, 0.0625, 0.5
30472, 0.28260869565217, 0.075, 0.5
30473, 0.26086956521739, 0.0625, 0.5
30474, 0.23913043478261, 0.075, 0.5
30475, 0.21739130434783, 0.0625, 0.5
30476, 0.19565217391304, 0.075, 0.5
30477, 0.17391304347826, 0.0625, 0.5
30478, 0.15217391304348, 0.075, 0.5
30479, 0.1304347826087, 0.0625, 0.5
30480, 0.10869565217391, 0.075, 0.5
30481, 0.08695652173913, 0.0625, 0.5
30482, 0.065217391304348, 0.075, 0.5
30483, 0.043478260869565, 0.0625, 0.5
30484, 0.021739130434783, 0.075, 0.5
30485, 0.95652173913043, 0.0875, 0.5
30486, 0.91304347826087, 0.0875, 0.5
30487, 0.8695652173913, 0.0875, 0.5
30488, 0.82608695652174, 0.0875, 0.5
30489, 0.78260869565217, 0.0875, 0.5
30490, 0.73913043478261, 0.0875, 0.5
30491, 0.69565217391304, 0.0875, 0.5
30492, 0.65217391304348, 0.0875, 0.5
30493, 0.60869565217391, 0.0875, 0.5
30494, 0.56521739130435, 0.0875, 0.5
30495, 0.52173913043478, 0.0875, 0.5
30496, 0.47826086956522, 0.0875, 0.5
30497, 0.43478260869565, 0.0875, 0.5
30498, 0.39130434782609, 0.0875, 0.5
30499, 0.34782608695652, 0.0875, 0.5
30500, 0.30434782608696, 0.0875, 0.5
30501, 0.26086956521739, 0.0875, 0.5
30502, 0.21739130434783, 0.0875, 0.5
30503, 0.17391304347826, 0.0875, 0.5
30504, 0.1304347826087, 0.0875, 0.5
30505, 0.08695652173913, 0.0875, 0.5
30506, 0.043478260869565, 0.0875, 0.5
30507, 0, 0.075, 0.44444444444444
30508, 0, 0.075, 0.38888888888889
30509, 0, 0.075, 0.33333333333333
30510, 0, 0.075, 0.27777777777778
30511, 0, 0.075, 0.22222222222222
30512, 0, 0.075, 0.16666666666667
30513, 0, 0.075, 0.11111111111111
30514, 0, 0.075, 0.055555555555556
30515, 0, 0.075, 0.47222222222222
30516, 0, 0.0625, 0.44444444444444
30517, 0, 0.075, 0.41666666666667
30518, 0, 0.0625, 0.38888888888889
30519, 0, 0.075, 0.36111111111111
30520, 0, 0.0625, 0.33333333333333
30521, 0, 0.075, 0.30555555555556
30522, 0, 0.0625, 0.27777777777778
30523, 0, 0.075, 0.25
30524, 0, 0.0625, 0.22222222222222
30525, 0, 0.075, 0.19444444444444
30526, 0, 0.0625, 0.16666666666667
30527, 0, 0.075, 0.13888888888889
30528, 0, 0.0625, 0.11111111111111
30529, 0, 0.075, 0.083333333333333
30530, 0, 0.0625, 0.055555555555556
30531, 0, 0.075, 0.027777777777778
30532, 0, 0.0875, 0.44444444444444
30533, 0, 0.0875, 0.38888888888889
30534, 0, 0.0875, 0.33333333333333
30535, 0, 0.0875, 0.27777777777778
30536, 0, 0.0875, 0.22222222222222
30537, 0, 0.0875, 0.16666666666667
30538, 0, 0.0875, 0.11111111111111
30539, 0, 0.0875, 0.055555555555556
30540, 0.95652173913043, 1.375, 0
30541, 0.91304347826087, 1.375, 0
30542, 0.8695652173913, 1.375, 0
30543, 0.82608695652174, 1.375, 0
30544, 0.78260869565217, 1.375, 0
30545, 0.73913043478261, 1.375, 0
30546, 0.69565217391304, 1.375, 0
30547, 0.65217391304348, 1.375, 0
30548, 0.60869565217391, 1.375, 0
30549, 0.56521739130435, 1.375, 0
30550, 0.52173913043478, 1.375, 0
30551, 0.47826086956522, 1.375, 0
30552, 0.43478260869565, 1.375, 0
30553, 0.39130434782609, 1.375, 0
30554, 0.34782608695652, 1.375, 0
30555, 0.30434782608696, 1.375, 0
30556, 0.26086956521739, 1.375, 0
30557, 0.21739130434783, 1.375, 0
30558, 0.17391304347826, 1.375, 0
30559, 0.1304347826087, 1.375, 0
30560, 0.08695652173913, 1.375, 0
30561, 0.043478260869565, 1.375, 0
30562, 0.97826086956522, 1.375, 0
30563, 0.95652173913043, 1.3875, 0
30564, 0.93478260869565, 1.375, 0
30565, 0.91304347826087, 1.3875, 0
30566, 0.89130434782609, 1.375, 0
30567, 0.8695652173913, 1.3875, 0
30568, 0.84782608695652, 1.375, 0
30569, 0.82608695652174, 1.3875, 0
30570, 0.80434782608696, 1.375, 0
30571, 0.78260869565217, 1.3875, 0
30572, 0.76086956521739, 1.375, 0
30573, 0.73913043478261, 1.3875, 0
30574, 0.71739130434783, 1.375, 0
30575, 0.69565217391304, 1.3875, 0
30576, 0.67391304347826, 1.375, 0
30577, 0.65217391304348, 1.3875, 0
30578, 0.6304347826087, 1.375, 0
30579, 0.60869565217391, 1.3875, 0
30580, 0.58695652173913, 1.375, 0
30581, 0.56521739130435, 1.3875, 0
30582, 0.54347826086957, 1.375, 0
30583, 0.52173913043478, 1.3875, 0
30584, 0.5, 1.375, 0
30585, 0.47826086956522, 1.3875, 0
30586, 0.45652173913043, 1.375, 0
30587, 0.43478260869565, 1.3875, 0
30588, 0.41304347826087, 1.375, 0
30589, 0.39130434782609, 1.3875, 0
30590, 0.3695652173913, 1.375, 0
30591, 0.34782608695652, 1.3875, 0
30592, 0.32608695652174, 1.375, 0
30593, 0.30434782608696, 1.3875, 0
30594, 0.28260869565217, 1.375, 0
30595, 0.26086956521739, 1.3875, 0
30596, 0.23913043478261, 1.375, 0
30597, 0.21739130434783, 1.3875, 0
30598, 0.19565217391304, 1.375, 0
30599, 0.17391304347826, 1.3875, 0
30600, 0.15217391304348, 1.375, 0
30601, 0.1304347826087, 1.3875, 0
30602, 0.10869565217391, 1.375, 0
30603, 0.08695652173913, 1.3875, 0
30604, 0.065217391304348, 1.375, 0
30605, 0.043478260869565, 1.3875, 0
30606, 0.021739130434783, 1.375, 0
30607, 0.95652173913043, 1.3625, 0
30608, 0.91304347826087, 1.3625, 0
30609, 0.8695652173913, 1.3625, 0
30610, 0.82608695652174, 1.3625, 0
30611, 0.78260869565217, 1.3625, 0
30612, 0.73913043478261, 1.3625, 0
30613, 0.69565217391304, 1.3625, 0
30614, 0.65217391304348, 1.3625, 0
30615, 0.60869565217391, 1.3625, 0
30616, 0.56521739130435, 1.3625, 0
30617, 0.52173913043478, 1.3625, 0
30618, 0.47826086956522, 1.3625, 0
30619, 0.43478260869565, 1.3625, 0
30620, 0.39130434782609, 1.3625, 0
30621, 0.34782608695652, 1.3625, 0
30622, 0.30434782608696, 1.3625, 0
30623, 0.26086956521739, 1.3625, 0
30624, 0.21739130434783, 1.3625, 0
30625, 0.17391304347826, 1.3625, 0
30626, 0.1304347826087, 1.3625, 0
30627, 0.08695652173913, 1.3625, 0
30628, 0.043478260869565, 1.3625, 0
30629, 1, 1.375, 0.44444444444444
30630, 1, 1.375, 0.38888888888889
30631, 1, 1.375, 0.33333333333333
30632, 1, 1.375, 0.27777777777778
30633, 1, 1.375, 0.22222222222222
30634, 1, 1.375, 0.16666666666667
30635, 1, 1.375, 0.11111111111111
30636, 1, 1.375, 0.055555555555556
30637, 1, 1.375, 0.47222222222222
30638, 1, 1.3875, 0.44444444444444
30639, 1, 1.375, 0.41666666666667
30640, 1, 1.3875, 0.38888888888889
30641, 1, 1.375, 0.36111111111111
30642, 1, 1.3875, 0.33333333333333
30643, 1, 1.375, 0.30555555555556
30644, 1, 1.3875, 0.27777777777778
30645, 1, 1.375, 0.25
30646, 1, 1.3875, 0.22222222222222
30647, 1, 1.375, 0.19444444444444
30648, 1, 1.3875, 0.16666666666667
30649, 1, 1.375, 0.13888888888889
30650, 1, 1.3875, 0.11111111111111
30651, 1, 1.375, 0.083333333333333
30652, 1, 1.3875, 0.055555555555556
30653, 1, 1.375, 0.027777777777778
30654, 1, 1.3625, 0.44444444444444
30655, 1, 1.3625, 0.38888888888889
30656, 1, 1.3625, 0.33333333333333
30657, 1, 1.3625, 0.27777777777778
30658, 1, 1.3625, 0.22222222222222
30659, 1, 1.3625, 0.16666666666667
30660, 1, 1.3625, 0.11111111111111
30661, 1, 1.3625, 0.055555555555556
30662, 0.95652173913043, 1.375, 0.5
30663, 0.91304347826087, 1.375, 0.5
30664, 0.8695652173913, 1.375, 0.5
30665, 0.82608695652174, 1.375, 0.5
30666, 0.78260869565217, 1.375, 0.5
30667, 0.73913043478261, 1.375, 0.5
30668, 0.69565217391304, 1.375, 0.5
30669, 0.65217391304348, 1.375, 0.5
30670, 0.60869565217391, 1.375, 0.5
30671, 0.56521739130435, 1.375, 0.5
30672, 0.52173913043478, 1.375, 0.5
30673, 0.47826086956522, 1.375, 0.5
30674, 0.43478260869565, 1.375, 0.5
30675, 0.39130434782609, 1.375, 0.5
30676, 0.34782608695652, 1.375, 0.5
30677, 0.30434782608696, 1.375, 0.5
30678, 0.26086956521739, 1.375, 0.5
30679, 0.21739130434783, 1.375, 0.5
30680, 0.17391304347826, 1.375, 0.5
30681, 0.1304347826087, 1.375, 0.5
30682, 0.08695652173913, 1.375, 0.5
30683, 0.043478260869565, 1.375, 0.5
30684, 0.95652173913043, 1.3875, 0.5
30685, 0.97826086956522, 1.375, 0.5
30686, 0.91304347826087, 1.3875, 0.5
30687, 0.93478260869565, 1.375, 0.5
30688, 0.8695652173913, 1.3875, 0.5
30689, 0.89130434782609, 1.375, 0.5
30690, 0.82608695652174, 1.3875, 0.5
30691, 0.84782608695652, 1.375, 0.5
30692, 0.78260869565217, 1.3875, 0.5
30693, 0.80434782608696, 1.375, 0.5
30694, 0.73913043478261, 1.3875, 0.5
30695, 0.76086956521739, 1.375, 0.5
30696, 0.69565217391304, 1.3875, 0.5
30697, 0.71739130434783, 1.375, 0.5
30698, 0.65217391304348, 1.3875, 0.5
30699, 0.67391304347826, 1.375, 0.5
30700, 0.60869565217391, 1.3875, 0.5
30701, 0.6304347826087, 1.375, 0.5
30702, 0.56521739130435, 1.3875, 0.5
30703, 0.58695652173913, 1.375, 0.5
30704, 0.52173913043478, 1.3875, 0.5
30705, 0.54347826086957, 1.375, 0.5
30706, 0.47826086956522, 1.3875, 0.5
30707, 0.5, 1.375, 0.5
30708, 0.43478260869565, 1.3875, 0.5
30709, 0.45652173913043, 1.375, 0.5
30710, 0.39130434782609, 1.3875, 0.5
30711, 0.41304347826087, 1.375, 0.5
30712, 0.34782608695652, 1.3875, 0.5
30713, 0.3695652173913, 1.375, 0.5
30714, 0.30434782608696, 1.3875, 0.5
30715, 0.32608695652174, 1.375, 0.5
30716, 0.26086956521739, 1.3875, 0.5
30717, 0.28260869565217, 1.375, 0.5
30718, 0.21739130434783, 1.3875, 0.5
30719, 0.23913043478261, 1.375, 0.5
30720, 0.17391304347826, 1.3875, 0.5
30721, 0.19565217391304, 1.375, 0.5
30722, 0.1304347826087, 1.3875, 0.5
30723, 0.15217391304348, 1.375, 0.5
30724, 0.08695652173913, 1.3875, 0.5
30725, 0.10869565217391, 1.375, 0.5
30726, 0.043478260869565, 1.3875, 0.5
30727, 0.065217391304348, 1.375, 0.5
30728, 0.021739130434783, 1.375, 0.5
30729, 0.95652173913043, 1.3625, 0.5
30730, 0.91304347826087, 1.3625, 0.5
30731, 0.8695652173913, 1.3625, 0.5
30732, 0.82608695652174, 1.3625, 0.5
30733, 0.78260869565217, 1.3625, 0.5
30734, 0.73913043478261, 1.3625, 0.5
30735, 0.69565217391304, 1.3625, 0.5
30736, 0.65217391304348, 1.3625, 0.5
30737, 0.60869565217391, 1.3625, 0.5
30738, 0.56521739130435, 1.3625, 0.5
30739, 0.52173913043478, 1.3625, 0.5
30740, 0.47826086956522, 1.3625, 0.5
30741, 0.43478260869565, 1.3625, 0.5
30742, 0.39130434782609, 1.3625, 0.5
30743, 0.34782608695652, 1.3625, 0.5
30744, 0.30434782608696, 1.3625, 0.5
30745, 0.26086956521739, 1.3625, 0.5
30746, 0.21739130434783, 1.3625, 0.5
30747, 0.17391304347826, 1.3625, 0.5
30748, 0.1304347826087, 1.3625, 0.5
30749, 0.08695652173913, 1.3625, 0.5
30750, 0.043478260869565, 1.3625, 0.5
30751, 0, 1.375, 0.44444444444444
30752, 0, 1.375, 0.38888888888889
30753, 0, 1.375, 0.33333333333333
30754, 0, 1.375, 0.27777777777778
30755, 0, 1.375, 0.22222222222222
30756, 0, 1.375, 0.16666666666667
30757, 0, 1.375, 0.11111111111111
30758, 0, 1.375, 0.055555555555556
30759, 0, 1.3875, 0.44444444444444
30760, 0, 1.375, 0.47222222222222
30761, 0, 1.3875, 0.38888888888889
30762, 0, 1.375, 0.41666666666667
30763, 0, 1.3875, 0.33333333333333
30764, 0, 1.375, 0.36111111111111
30765, 0, 1.3875, 0.27777777777778
30766, 0, 1.375, 0.30555555555556
30767, 0, 1.3875, 0.22222222222222
30768, 0, 1.375, 0.25
30769, 0, 1.3875, 0.16666666666667
30770, 0, 1.375, 0.19444444444444
30771, 0, 1.3875, 0.11111111111111
30772, 0, 1.375, 0.13888888888889
30773, 0, 1.3875, 0.055555555555556
30774, 0, 1.375, 0.083333333333333
30775, 0, 1.375, 0.027777777777778
30776, 0, 1.3625, 0.44444444444444
30777, 0, 1.3625, 0.38888888888889
30778, 0, 1.3625, 0.33333333333333
30779, 0, 1.3625, 0.27777777777778
30780, 0, 1.3625, 0.22222222222222
30781, 0, 1.3625, 0.16666666666667
30782, 0, 1.3625, 0.11111111111111
30783, 0, 1.3625, 0.055555555555556
30784, 1.2434782608696, 1.375, 0.5
30785, 1.2869565217391, 1.375, 0.5
30786, 1.3304347826087, 1.375, 0.5
30787, 1.3739130434783, 1.375, 0.5
30788, 1.4173913043478, 1.375, 0.5
30789, 1.4608695652174, 1.375, 0.5
30790, 1.504347826087, 1.375, 0.5
30791, 1.5478260869565, 1.375, 0.5
30792, 1.5913043478261, 1.375, 0.5
30793, 1.6347826086957, 1.375, 0.5
30794, 1.6782608695652, 1.375, 0.5
30795, 1.7217391304348, 1.375, 0.5
30796, 1.7652173913043, 1.375, 0.5
30797, 1.8086956521739, 1.375, 0.5
30798, 1.8521739130435, 1.375, 0.5
30799, 1.895652173913, 1.375, 0.5
30800, 1.9391304347826, 1.375, 0.5
30801, 1.9826086956522, 1.375, 0.5
30802, 2.0260869565217, 1.375, 0.5
30803, 2.0695652173913, 1.375, 0.5
30804, 2.1130434782609, 1.375, 0.5
30805, 2.1565217391304, 1.375, 0.5
30806, 1.2217391304348, 1.375, 0.5
30807, 1.2434782608696, 1.3875, 0.5
30808, 1.2652173913043, 1.375, 0.5
30809, 1.2869565217391, 1.3875, 0.5
30810, 1.3086956521739, 1.375, 0.5
30811, 1.3304347826087, 1.3875, 0.5
30812, 1.3521739130435, 1.375, 0.5
30813, 1.3739130434783, 1.3875, 0.5
30814, 1.395652173913, 1.375, 0.5
30815, 1.4173913043478, 1.3875, 0.5
30816, 1.4391304347826, 1.375, 0.5
30817, 1.4608695652174, 1.3875, 0.5
30818, 1.4826086956522, 1.375, 0.5
30819, 1.504347826087, 1.3875, 0.5
30820, 1.5260869565217, 1.375, 0.5
30821, 1.5478260869565, 1.3875, 0.5
30822, 1.5695652173913, 1.375, 0.5
30823, 1.5913043478261, 1.3875, 0.5
30824, 1.6130434782609, 1.375, 0.5
30825, 1.6347826086957, 1.3875, 0.5
30826, 1.6565217391304, 1.375, 0.5
30827, 1.6782608695652, 1.3875, 0.5
30828, 1.7, 1.375, 0.5
30829, 1.7217391304348, 1.3875, 0.5
30830, 1.7434782608696, 1.375, 0.5
30831, 1.7652173913043, 1.3875, 0.5
30832, 1.7869565217391, 1.375, 0.5
30833, 1.8086956521739, 1.3875, 0.5
30834, 1.8304347826087, 1.375, 0.5
30835, 1.8521739130435, 1.3875, 0.5
30836, 1.8739130434783, 1.375, 0.5
30837, 1.895652173913, 1.3875, 0.5
30838, 1.9173913043478, 1.375, 0.5
30839, 1.9391304347826, 1.3875, 0.5
30840, 1.9608695652174, 1.375, 0.5
30841, 1.9826086956522, 1.3875, 0.5
30842, 2.004347826087, 1.375, 0.5
30843, 2.0260869565217, 1.3875, 0.5
30844, 2.0478260869565, 1.375, 0.5
30845, 2.0695652173913, 1.3875, 0.5
30846, 2.0913043478261, 1.375, 0.5
30847, 2.1130434782609, 1.3875, 0.5
30848, 2.1347826086957, 1.375, 0.5
30849, 2.1565217391304, 1.3875, 0.5
30850, 2.1782608695652, 1.375, 0.5
30851, 1.2434782608696, 1.3625, 0.5
30852, 1.2869565217391, 1.3625, 0.5
30853, 1.3304347826087, 1.3625, 0.5
30854, 1.3739130434783, 1.3625, 0.5
30855, 1.4173913043478, 1.3625, 0.5
30856, 1.4608695652174, 1.3625, 0.5
30857, 1.504347826087, 1.3625, 0.5
30858, 1.5478260869565, 1.3625, 0.5
30859, 1.5913043478261, 1.3625, 0.5
30860, 1.6347826086957, 1.3625, 0.5
30861, 1.6782608695652, 1.3625, 0.5
30862, 1.7217391304348, 1.3625, 0.5
30863, 1.7652173913043, 1.3625, 0.5
30864, 1.8086956521739, 1.3625, 0.5
30865, 1.8521739130435, 1.3625, 0.5
30866, 1.895652173913, 1.3625, 0.5
30867, 1.9391304347826, 1.3625, 0.5
30868, 1.9826086956522, 1.3625, 0.5
30869, 2.0260869565217, 1.3625, 0.5
30870, 2.0695652173913, 1.3625, 0.5
30871, 2.1130434782609, 1.3625, 0.5
30872, 2.1565217391304, 1.3625, 0.5
30873, 1.2434782608696, 1.375, 0
30874, 1.2869565217391, 1.375, 0
30875, 1.3304347826087, 1.375, 0
30876, 1.3739130434783, 1.375, 0
30877, 1.4173913043478, 1.375, 0
30878, 1.4608695652174, 1.375, 0
30879, 1.504347826087, 1.375, 0
30880, 1.5478260869565, 1.375, 0
30881, 1.5913043478261, 1.375, 0
30882, 1.6347826086957, 1.375, 0
30883, 1.6782608695652, 1.375, 0
30884, 1.7217391304348, 1.375, 0
30885, 1.7652173913043, 1.375, 0
30886, 1.8086956521739, 1.375, 0
30887, 1.8521739130435, 1.375, 0
30888, 1.895652173913, 1.375, 0
30889, 1.9391304347826, 1.375, 0
30890, 1.9826086956522, 1.375, 0
30891, 2.0260869565217, 1.375, 0
30892, 2.0695652173913, 1.375, 0
30893, 2.1130434782609, 1.375, 0
30894, 2.1565217391304, 1.375, 0
30895, 1.2434782608696, 1.3875, 0
30896, 1.2217391304348, 1.375, 0
30897, 1.2869565217391, 1.3875, 0
30898, 1.2652173913043, 1.375, 0
30899, 1.3304347826087, 1.3875, 0
30900, 1.3086956521739, 1.375, 0
30901, 1.3739130434783, 1.3875, 0
30902, 1.3521739130435, 1.375, 0
30903, 1.4173913043478, 1.3875, 0
30904, 1.395652173913, 1.375, 0
30905, 1.4608695652174, 1.3875, 0
30906, 1.4391304347826, 1.375, 0
30907, 1.504347826087, 1.3875, 0
30908, 1.4826086956522, 1.375, 0
30909, 1.5478260869565, 1.3875, 0
30910, 1.5260869565217, 1.375, 0
30911, 1.5913043478261, 1.3875, 0
30912, 1.5695652173913, 1.375, 0
30913, 1.6347826086957, 1.3875, 0
30914, 1.6130434782609, 1.375, 0
30915, 1.6782608695652, 1.3875, 0
30916, 1.6565217391304, 1.375, 0
30917, 1.7217391304348, 1.3875, 0
30918, 1.7, 1.375, 0
30919, 1.7652173913043, 1.3875, 0
30920, 1.7434782608696, 1.375, 0
30921, 1.8086956521739, 1.3875, 0
30922, 1.7869565217391, 1.375, 0
30923, 1.8521739130435, 1.3875, 0
30924, 1.8304347826087, 1.375, 0
30925, 1.895652173913, 1.3875, 0
30926, 1.8739130434783, 1.375, 0
30927, 1.9391304347826, 1.3875, 0
30928, 1.9173913043478, 1.375, 0
30929, 1.9826086956522, 1.3875, 0
30930, 1.9608695652174, 1.375, 0
30931, 2.0260869565217, 1.3875, 0
30932, 2.004347826087, 1.375, 0
30933, 2.0695652173913, 1.3875, 0
30934, 2.0478260869565, 1.375, 0
30935, 2.1130434782609, 1.3875, 0
30936, 2.0913043478261, 1.375, 0
30937, 2.1565217391304, 1.3875, 0
30938, 2.1347826086957, 1.375, 0
30939, 2.1782608695652, 1.375, 0
30940, 1.2434782608696, 1.3625, 0
30941, 1.2869565217391, 1.3625, 0
30942, 1.3304347826087, 1.3625, 0
30943, 1.3739130434783, 1.3625, 0
30944, 1.4173913043478, 1.3625, 0
30945, 1.4608695652174, 1.3625, 0
30946, 1.504347826087, 1.3625, 0
30947, 1.5478260869565, 1.3625, 0
30948, 1.5913043478261, 1.3625, 0
30949, 1.6347826086957, 1.3625, 0
30950, 1.6782608695652, 1.3625, 0
30951, 1.7217391304348, 1.3625, 0
30952, 1.7652173913043, 1.3625, 0
30953, 1.8086956521739, 1.3625, 0
30954, 1.8521739130435, 1.3625, 0
30955, 1.895652173913, 1.3625, 0
30956, 1.9391304347826, 1.3625, 0
30957, 1.9826086956522, 1.3625, 0
30958, 2.0260869565217, 1.3625, 0
30959, 2.0695652173913, 1.3625, 0
30960, 2.1130434782609, 1.3625, 0
30961, 2.1565217391304, 1.3625, 0
30962, 1.2, 1.375, 0.44444444444444
30963, 1.2, 1.375, 0.38888888888889
30964, 1.2, 1.375, 0.33333333333333
30965, 1.2, 1.375, 0.27777777777778
30966, 1.2, 1.375, 0.22222222222222
30967, 1.2, 1.375, 0.16666666666667
30968, 1.2, 1.375, 0.11111111111111
30969, 1.2, 1.375, 0.055555555555556
30970, 1.2, 1.3875, 0.44444444444444
30971, 1.2, 1.375, 0.47222222222222
30972, 1.2, 1.3875, 0.38888888888889
30973, 1.2, 1.375, 0.41666666666667
30974, 1.2, 1.3875, 0.33333333333333
30975, 1.2, 1.375, 0.36111111111111
30976, 1.2, 1.3875, 0.27777777777778
30977, 1.2, 1.375, 0.30555555555556
30978, 1.2, 1.3875, 0.22222222222222
30979, 1.2, 1.375, 0.25
30980, 1.2, 1.3875, 0.16666666666667
30981, 1.2, 1.375, 0.19444444444444
30982, 1.2, 1.3875, 0.11111111111111
30983, 1.2, 1.375, 0.13888888888889
30984, 1.2, 1.3875, 0.055555555555556
30985, 1.2, 1.375, 0.083333333333333
30986, 1.2, 1.375, 0.027777777777778
30987, 1.2, 1.3625, 0.44444444444444
30988, 1.2, 1.3625, 0.38888888888889
30989, 1.2, 1.3625, 0.33333333333333
30990, 1.2, 1.3625, 0.27777777777778
30991, 1.2, 1.3625, 0.22222222222222
30992, 1.2, 1.3625, 0.16666666666667
30993, 1.2, 1.3625, 0.11111111111111
30994, 1.2, 1.3625, 0.055555555555556
30995, 2.2, 1.375, 0.44444444444444
30996, 2.2, 1.375, 0.38888888888889
30997, 2.2, 1.375, 0.33333333333333
30998, 2.2, 1.375, 0.27777777777778
30999, 2.2, 1.375, 0.22222222222222
31000, 2.2, 1.375, 0.16666666666667
31001, 2.2, 1.375, 0.11111111111111
31002, 2.2, 1.375, 0.055555555555556
31003, 2.2, 1.375, 0.47222222222222
31004, 2.2, 1.3875, 0.44444444444444
31005, 2.2, 1.375, 0.41666666666667
31006, 2.2, 1.3875, 0.38888888888889
31007, 2.2, 1.375, 0.36111111111111
31008, 2.2, 1.3875, 0.33333333333333
31009, 2.2, 1.375, 0.30555555555556
31010, 2.2, 1.3875, 0.27777777777778
31011, 2.2, 1.375, 0.25
31012, 2.2, 1.3875, 0.22222222222222
31013, 2.2, 1.375, 0.19444444444444
31014, 2.2, 1.3875, 0.16666666666667
31015, 2.2, 1.375, 0.13888888888889
31016, 2.2, 1.3875, 0.11111111111111
31017, 2.2, 1.375, 0.083333333333333
31018, 2.2, 1.3875, 0.055555555555556
31019, 2.2, 1.375, 0.027777777777778
31020, 2.2, 1.3625, 0.44444444444444
31021, 2.2, 1.3625, 0.38888888888889
31022, 2.2, 1.3625, 0.33333333333333
31023, 2.2, 1.3625, 0.27777777777778
31024, 2.2, 1.3625, 0.22222222222222
31025, 2.2, 1.3625, 0.16666666666667
31026, 2.2, 1.3625, 0.11111111111111
31027, 2.2, 1.3625, 0.055555555555556
31028, 1, 0.20217391304348, -0.05
31029, 1, 0.25434782608696, -0.05
31030, 1, 0.30652173913043, -0.05
31031, 1, 0.35869565217391, -0.05
31032, 1, 0.41086956521739, -0.05
31033, 1, 0.46304347826087, -0.05
31034, 1, 0.51521739130435, -0.05
31035, 1, 0.56739130434783, -0.05
31036, 1, 0.6195652173913, -0.05
31037, 1, 0.67173913043478, -0.05
31038, 1, 0.72391304347826, -0.05
31039, 1, 0.77608695652174, -0.05
31040, 1, 0.82826086956522, -0.05
31041, 1, 0.88043478260869, -0.05
31042, 1, 0.93260869565217, -0.05
31043, 1, 0.98478260869565, -0.05
31044, 1, 1.0369565217391, -0.05
31045, 1, 1.0891304347826, -0.05
31046, 1, 1.1413043478261, -0.05
31047, 1, 1.1934782608696, -0.05
31048, 1, 1.245652173913, -0.05
31049, 1, 1.2978260869565, -0.05
31050, 1, 0.20217391304348, -0.1
31051, 1, 0.25434782608696, -0.1
31052, 1, 0.30652173913043, -0.1
31053, 1, 0.35869565217391, -0.1
31054, 1, 0.41086956521739, -0.1
31055, 1, 0.46304347826087, -0.1
31056, 1, 0.51521739130435, -0.1
31057, 1, 0.56739130434783, -0.1
31058, 1, 0.6195652173913, -0.1
31059, 1, 0.67173913043478, -0.1
31060, 1, 0.72391304347826, -0.1
31061, 1, 0.77608695652174, -0.1
31062, 1, 0.82826086956522, -0.1
31063, 1, 0.8804347826087, -0.1
31064, 1, 0.93260869565217, -0.1
31065, 1, 0.98478260869565, -0.1
31066, 1, 1.0369565217391, -0.1
31067, 1, 1.0891304347826, -0.1
31068, 1, 1.1413043478261, -0.1
31069, 1, 1.1934782608696, -0.1
31070, 1, 1.245652173913, -0.1
31071, 1, 1.2978260869565, -0.1
31072, 1, 0.20217391304348, -0.15
31073, 1, 0.25434782608696, -0.15
31074, 1, 0.30652173913043, -0.15
31075, 1, 0.35869565217391, -0.15
31076, 1, 0.41086956521739, -0.15
31077, 1, 0.46304347826087, -0.15
31078, 1, 0.51521739130435, -0.15
31079, 1, 0.56739130434783, -0.15
31080, 1, 0.6195652173913, -0.15
31081, 1, 0.67173913043478, -0.15
31082, 1, 0.72391304347826, -0.15
31083, 1, 0.77608695652174, -0.15
31084, 1, 0.82826086956522, -0.15
31085, 1, 0.88043478260869, -0.15
31086, 1, 0.93260869565217, -0.15
31087, 1, 0.98478260869565, -0.15
31088, 1, 1.0369565217391, -0.15
31089, 1, 1.0891304347826, -0.15
31090, 1, 1.1413043478261, -0.15
31091, 1, 1.1934782608696, -0.15
31092, 1, 1.245652173913, -0.15
31093, 1, 1.2978260869565, -0.15
31094, 1, 0.17608695652174, -0.05
31095, 1, 0.20217391304348, -0.025
31096, 1, 0.22826086956522, -0.05
31097, 1, 0.25434782608696, -0.025
31098, 1, 0.2804347826087, -0.05
31099, 1, 0.30652173913043, -0.025
31100, 1, 0.33260869565217, -0.05
31101, 1, 0.35869565217391, -0.025
31102, 1, 0.38478260869565, -0.05
31103, 1, 0.41086956521739, -0.025
31104, 1, 0.43695652173913, -0.05
31105, 1, 0.46304347826087, -0.025
31106, 1, 0.48913043478261, -0.05
31107, 1, 0.51521739130435, -0.025
31108, 1, 0.54130434782609, -0.05
31109, 1, 0.56739130434783, -0.025
31110, 1, 0.59347826086956, -0.05
31111, 1, 0.6195652173913, -0.025
31112, 1, 0.64565217391304, -0.05
31113, 1, 0.67173913043478, -0.025
31114, 1, 0.69782608695652, -0.05
31115, 1, 0.72391304347826, -0.025
31116, 1, 0.75, -0.05
31117, 1, 0.77608695652174, -0.025
31118, 1, 0.80217391304348, -0.05
31119, 1, 0.82826086956522, -0.025
31120, 1, 0.85434782608696, -0.05
31121, 1, 0.88043478260869, -0.025
31122, 1, 0.90652173913043, -0.05
31123, 1, 0.93260869565217, -0.025
31124, 1, 0.95869565217391, -0.05
31125, 1, 0.98478260869565, -0.025
31126, 1, 1.0108695652174, -0.05
31127, 1, 1.0369565217391, -0.025
31128, 1, 1.0630434782609, -0.05
31129, 1, 1.0891304347826, -0.025
31130, 1, 1.1152173913043, -0.05
31131, 1, 1.1413043478261, -0.025
31132, 1, 1.1673913043478, -0.05
31133, 1, 1.1934782608696, -0.025
31134, 1, 1.2195652173913, -0.05
31135, 1, 1.245652173913, -0.025
31136, 1, 1.2717391304348, -0.05
31137, 1, 1.2978260869565, -0.025
31138, 1, 1.3239130434783, -0.05
31139, 1, 0.17608695652174, -0.1
31140, 1, 0.20217391304348, -0.075
31141, 1, 0.22826086956522, -0.1
31142, 1, 0.25434782608696, -0.075
31143, 1, 0.2804347826087, -0.1
31144, 1, 0.30652173913043, -0.075
31145, 1, 0.33260869565217, -0.1
31146, 1, 0.35869565217391, -0.075
31147, 1, 0.38478260869565, -0.1
31148, 1, 0.41086956521739, -0.075
31149, 1, 0.43695652173913, -0.1
31150, 1, 0.46304347826087, -0.075
31151, 1, 0.48913043478261, -0.1
31152, 1, 0.51521739130435, -0.075
31153, 1, 0.54130434782609, -0.1
31154, 1, 0.56739130434783, -0.075
31155, 1, 0.59347826086956, -0.1
31156, 1, 0.6195652173913, -0.075
31157, 1, 0.64565217391304, -0.1
31158, 1, 0.67173913043478, -0.075
31159, 1, 0.69782608695652, -0.1
31160, 1, 0.72391304347826, -0.075
31161, 1, 0.75, -0.1
31162, 1, 0.77608695652174, -0.075
31163, 1, 0.80217391304348, -0.1
31164, 1, 0.82826086956522, -0.075
31165, 1, 0.85434782608696, -0.1
31166, 1, 0.8804347826087, -0.075
31167, 1, 0.90652173913043, -0.1
31168, 1, 0.93260869565217, -0.075
31169, 1, 0.95869565217391, -0.1
31170, 1, 0.98478260869565, -0.075
31171, 1, 1.0108695652174, -0.1
31172, 1, 1.0369565217391, -0.075
31173, 1, 1.0630434782609, -0.1
31174, 1, 1.0891304347826, -0.075
31175, 1, 1.1152173913043, -0.1
31176, 1, 1.1413043478261, -0.075
31177, 1, 1.1673913043478, -0.1
31178, 1, 1.1934782608696, -0.075
31179, 1, 1.2195652173913, -0.1
31180, 1, 1.245652173913, -0.075
31181, 1, 1.2717391304348, -0.1
31182, 1, 1.2978260869565, -0.075
31183, 1, 1.3239130434783, -0.1
31184, 1, 0.17608695652174, -0.15
31185, 1, 0.20217391304348, -0.125
31186, 1, 0.22826086956522, -0.15
31187, 1, 0.25434782608696, -0.125
31188, 1, 0.2804347826087, -0.15
31189, 1, 0.30652173913043, -0.125
31190, 1, 0.33260869565217, -0.15
31191, 1, 0.35869565217391, -0.125
31192, 1, 0.38478260869565, -0.15
31193, 1, 0.41086956521739, -0.125
31194, 1, 0.43695652173913, -0.15
31195, 1, 0.46304347826087, -0.125
31196, 1, 0.48913043478261, -0.15
31197, 1, 0.51521739130435, -0.125
31198, 1, 0.54130434782609, -0.15
31199, 1, 0.56739130434783, -0.125
31200, 1, 0.59347826086956, -0.15
31201, 1, 0.6195652173913, -0.125
31202, 1, 0.64565217391304, -0.15
31203, 1, 0.67173913043478, -0.125
31204, 1, 0.69782608695652, -0.15
31205, 1, 0.72391304347826, -0.125
31206, 1, 0.75, -0.15
31207, 1, 0.77608695652174, -0.125
31208, 1, 0.80217391304348, -0.15
31209, 1, 0.82826086956522, -0.125
31210, 1, 0.85434782608696, -0.15
31211, 1, 0.88043478260869, -0.125
31212, 1, 0.90652173913043, -0.15
31213, 1, 0.93260869565217, -0.125
31214, 1, 0.95869565217391, -0.15
31215, 1, 0.98478260869565, -0.125
31216, 1, 1.0108695652174, -0.15
31217, 1, 1.0369565217391, -0.125
31218, 1, 1.0630434782609, -0.15
31219, 1, 1.0891304347826, -0.125
31220, 1, 1.1152173913043, -0.15
31221, 1, 1.1413043478261, -0.125
31222, 1, 1.1673913043478, -0.15
31223, 1, 1.1934782608696, -0.125
31224, 1, 1.2195652173913, -0.15
31225, 1, 1.245652173913, -0.125
31226, 1, 1.2717391304348, -0.15
31227, 1, 1.2978260869565, -0.125
31228, 1, 1.3239130434783, -0.15
31229, 1, 0.20217391304348, -0.175
31230, 1, 0.25434782608696, -0.175
31231, 1, 0.30652173913043, -0.175
31232, 1, 0.35869565217391, -0.175
31233, 1, 0.41086956521739, -0.175
31234, 1, 0.46304347826087, -0.175
31235, 1, 0.51521739130435, -0.175
31236, 1, 0.56739130434783, -0.175
31237, 1, 0.6195652173913, -0.175
31238, 1, 0.67173913043478, -0.175
31239, 1, 0.72391304347826, -0.175
31240, 1, 0.77608695652174, -0.175
31241, 1, 0.82826086956522, -0.175
31242, 1, 0.88043478260869, -0.175
31243, 1, 0.93260869565217, -0.175
31244, 1, 0.98478260869565, -0.175
31245, 1, 1.0369565217391, -0.175
31246, 1, 1.0891304347826, -0.175
31247, 1, 1.1413043478261, -0.175
31248, 1, 1.1934782608696, -0.175
31249, 1, 1.245652173913, -0.175
31250, 1, 1.2978260869565, -0.175
31251, 0, 0.20217391304348, -0.05
31252, 0, 0.25434782608696, -0.05
31253, 0, 0.30652173913043, -0.05
31254, 0, 0.35869565217391, -0.05
31255, 0, 0.41086956521739, -0.05
31256, 0, 0.46304347826087, -0.05
31257, 0, 0.51521739130435, -0.05
31258, 0, 0.56739130434783, -0.05
31259, 0, 0.6195652173913, -0.05
31260, 0, 0.67173913043478, -0.05
31261, 0, 0.72391304347826, -0.05
31262, 0, 0.77608695652174, -0.05
31263, 0, 0.82826086956522, -0.05
31264, 0, 0.88043478260869, -0.05
31265, 0, 0.93260869565217, -0.05
31266, 0, 0.98478260869565, -0.05
31267, 0, 1.0369565217391, -0.05
31268, 0, 1.0891304347826, -0.05
31269, 0, 1.1413043478261, -0.05
31270, 0, 1.1934782608696, -0.05
31271, 0, 1.245652173913, -0.05
31272, 0, 1.2978260869565, -0.05
31273, 0, 0.20217391304348, -0.1
31274, 0, 0.25434782608696, -0.1
31275, 0, 0.30652173913043, -0.1
31276, 0, 0.35869565217391, -0.1
31277, 0, 0.41086956521739, -0.1
31278, 0, 0.46304347826087, -0.1
31279, 0, 0.51521739130435, -0.1
31280, 0, 0.56739130434783, -0.1
31281, 0, 0.6195652173913, -0.1
31282, 0, 0.67173913043478, -0.1
31283, 0, 0.72391304347826, -0.1
31284, 0, 0.77608695652174, -0.1
31285, 0, 0.82826086956522, -0.1
31286, 0, 0.8804347826087, -0.1
31287, 0, 0.93260869565217, -0.1
31288, 0, 0.98478260869565, -0.1
31289, 0, 1.0369565217391, -0.1
31290, 0, 1.0891304347826, -0.1
31291, 0, 1.1413043478261, -0.1
31292, 0, 1.1934782608696, -0.1
31293, 0, 1.245652173913, -0.1
31294, 0, 1.2978260869565, -0.1
31295, 0, 0.20217391304348, -0.15
31296, 0, 0.25434782608696, -0.15
31297, 0, 0.30652173913043, -0.15
31298, 0, 0.35869565217391, -0.15
31299, 0, 0.41086956521739, -0.15
31300, 0, 0.46304347826087, -0.15
31301, 0, 0.51521739130435, -0.15
31302, 0, 0.56739130434783, -0.15
31303, 0, 0.6195652173913, -0.15
31304, 0, 0.67173913043478, -0.15
31305, 0, 0.72391304347826, -0.15
31306, 0, 0.77608695652174, -0.15
31307, 0, 0.82826086956522, -0.15
31308, 0, 0.88043478260869, -0.15
31309, 0, 0.93260869565217, -0.15
31310, 0, 0.98478260869565, -0.15
31311, 0, 1.0369565217391, -0.15
31312, 0, 1.0891304347826, -0.15
31313, 0, 1.1413043478261, -0.15
31314, 0, 1.1934782608696, -0.15
31315, 0, 1.245652173913, -0.15
31316, 0, 1.2978260869565, -0.15
31317, 0, 0.20217391304348, -0.025
31318, 0, 0.17608695652174, -0.05
31319, 0, 0.25434782608696, -0.025
