77547, 1.8086956521739, -0.016666666666667, 0.16666666666667
77548, 1.8086956521739, -0.016666666666667, 0.11111111111111
77549, 1.8086956521739, -0.016666666666667, 0.055555555555556
77550, 1.8521739130435, -0.016666666666667, 0.44444444444444
77551, 1.8521739130435, -0.016666666666667, 0.38888888888889
77552, 1.8521739130435, -0.016666666666667, 0.33333333333333
77553, 1.8521739130435, -0.016666666666667, 0.27777777777778
77554, 1.8521739130435, -0.016666666666667, 0.22222222222222
77555, 1.8521739130435, -0.016666666666667, 0.16666666666667
77556, 1.8521739130435, -0.016666666666667, 0.11111111111111
77557, 1.8521739130435, -0.016666666666667, 0.055555555555556
77558, 1.895652173913, -0.016666666666667, 0.44444444444444
77559, 1.895652173913, -0.016666666666667, 0.38888888888889
77560, 1.895652173913, -0.016666666666667, 0.33333333333333
77561, 1.895652173913, -0.016666666666667, 0.27777777777778
77562, 1.895652173913, -0.016666666666667, 0.22222222222222
77563, 1.895652173913, -0.016666666666667, 0.16666666666667
77564, 1.895652173913, -0.016666666666667, 0.11111111111111
77565, 1.895652173913, -0.016666666666667, 0.055555555555556
77566, 1.9391304347826, -0.016666666666667, 0.44444444444444
77567, 1.9391304347826, -0.016666666666667, 0.38888888888889
77568, 1.9391304347826, -0.016666666666667, 0.33333333333333
77569, 1.9391304347826, -0.016666666666667, 0.27777777777778
77570, 1.9391304347826, -0.016666666666667, 0.22222222222222
77571, 1.9391304347826, -0.016666666666667, 0.16666666666667
77572, 1.9391304347826, -0.016666666666667, 0.11111111111111
77573, 1.9391304347826, -0.016666666666667, 0.055555555555556
77574, 1.9826086956522, -0.016666666666667, 0.44444444444444
77575, 1.9826086956522, -0.016666666666667, 0.38888888888889
77576, 1.9826086956522, -0.016666666666667, 0.33333333333333
77577, 1.9826086956522, -0.016666666666667, 0.27777777777778
77578, 1.9826086956522, -0.016666666666667, 0.22222222222222
77579, 1.9826086956522, -0.016666666666667, 0.16666666666667
77580, 1.9826086956522, -0.016666666666667, 0.11111111111111
77581, 1.9826086956522, -0.016666666666667, 0.055555555555556
77582, 2.0260869565217, -0.016666666666667, 0.44444444444444
77583, 2.0260869565217, -0.016666666666667, 0.38888888888889
77584, 2.0260869565217, -0.016666666666667, 0.33333333333333
77585, 2.0260869565217, -0.016666666666667, 0.27777777777778
77586, 2.0260869565217, -0.016666666666667, 0.22222222222222
77587, 2.0260869565217, -0.016666666666667, 0.16666666666667
77588, 2.0260869565217, -0.016666666666667, 0.11111111111111
77589, 2.0260869565217, -0.016666666666667, 0.055555555555556
77590, 2.0695652173913, -0.016666666666667, 0.44444444444444
77591, 2.0695652173913, -0.016666666666667, 0.38888888888889
77592, 2.0695652173913, -0.016666666666667, 0.33333333333333
77593, 2.0695652173913, -0.016666666666667, 0.27777777777778
77594, 2.0695652173913, -0.016666666666667, 0.22222222222222
77595, 2.0695652173913, -0.016666666666667, 0.16666666666667
77596, 2.0695652173913, -0.016666666666667, 0.11111111111111
77597, 2.0695652173913, -0.016666666666667, 0.055555555555556
77598, 2.1130434782609, -0.016666666666667, 0.44444444444444
77599, 2.1130434782609, -0.016666666666667, 0.38888888888889
77600, 2.1130434782609, -0.016666666666667, 0.33333333333333
77601, 2.1130434782609, -0.016666666666667, 0.27777777777778
77602, 2.1130434782609, -0.016666666666667, 0.22222222222222
77603, 2.1130434782609, -0.016666666666667, 0.16666666666667
77604, 2.1130434782609, -0.016666666666667, 0.11111111111111
77605, 2.1130434782609, -0.016666666666667, 0.055555555555556
77606, 2.1565217391304, -0.016666666666667, 0.44444444444444
77607, 2.1565217391304, -0.016666666666667, 0.38888888888889
77608, 2.1565217391304, -0.016666666666667, 0.33333333333333
77609, 2.1565217391304, -0.016666666666667, 0.27777777777778
77610, 2.1565217391304, -0.016666666666667, 0.22222222222222
77611, 2.1565217391304, -0.016666666666667, 0.16666666666667
77612, 2.1565217391304, -0.016666666666667, 0.11111111111111
77613, 2.1565217391304, -0.016666666666667, 0.055555555555556
77614, 1.2434782608696, 0.016666666666667, 0.47222222222222
77615, 1.2217391304348, 0.016666666666667, 0.44444444444444
77616, 1.2434782608696, 0.033333333333333, 0.44444444444444
77617, 1.2434782608696, 0.016666666666667, 0.41666666666667
77618, 1.2217391304348, 0.016666666666667, 0.38888888888889
77619, 1.2434782608696, 0.033333333333333, 0.38888888888889
77620, 1.2434782608696, 0.016666666666667, 0.36111111111111
77621, 1.2217391304348, 0.016666666666667, 0.33333333333333
77622, 1.2434782608696, 0.033333333333333, 0.33333333333333
77623, 1.2434782608696, 0.016666666666667, 0.30555555555556
77624, 1.2217391304348, 0.016666666666667, 0.27777777777778
77625, 1.2434782608696, 0.033333333333333, 0.27777777777778
77626, 1.2434782608696, 0.016666666666667, 0.25
77627, 1.2217391304348, 0.016666666666667, 0.22222222222222
77628, 1.2434782608696, 0.033333333333333, 0.22222222222222
77629, 1.2434782608696, 0.016666666666667, 0.19444444444444
77630, 1.2217391304348, 0.016666666666667, 0.16666666666667
77631, 1.2434782608696, 0.033333333333333, 0.16666666666667
77632, 1.2434782608696, 0.016666666666667, 0.13888888888889
77633, 1.2217391304348, 0.016666666666667, 0.11111111111111
77634, 1.2434782608696, 0.033333333333333, 0.11111111111111
77635, 1.2434782608696, 0.016666666666667, 0.083333333333333
77636, 1.2217391304348, 0.016666666666667, 0.055555555555556
77637, 1.2434782608696, 0.033333333333333, 0.055555555555556
77638, 1.2434782608696, 0.016666666666667, 0.027777777777778
77639, 1.2869565217391, 0.016666666666667, 0.47222222222222
77640, 1.2652173913043, 0.016666666666667, 0.44444444444444
77641, 1.2869565217391, 0.033333333333333, 0.44444444444444
77642, 1.2869565217391, 0.016666666666667, 0.41666666666667
77643, 1.2652173913043, 0.016666666666667, 0.38888888888889
77644, 1.2869565217391, 0.033333333333333, 0.38888888888889
77645, 1.2869565217391, 0.016666666666667, 0.36111111111111
77646, 1.2652173913043, 0.016666666666667, 0.33333333333333
77647, 1.2869565217391, 0.033333333333333, 0.33333333333333
77648, 1.2869565217391, 0.016666666666667, 0.30555555555556
77649, 1.2652173913043, 0.016666666666667, 0.27777777777778
77650, 1.2869565217391, 0.033333333333333, 0.27777777777778
77651, 1.2869565217391, 0.016666666666667, 0.25
77652, 1.2652173913043, 0.016666666666667, 0.22222222222222
77653, 1.2869565217391, 0.033333333333333, 0.22222222222222
77654, 1.2869565217391, 0.016666666666667, 0.19444444444444
77655, 1.2652173913043, 0.016666666666667, 0.16666666666667
77656, 1.2869565217391, 0.033333333333333, 0.16666666666667
77657, 1.2869565217391, 0.016666666666667, 0.13888888888889
77658, 1.2652173913043, 0.016666666666667, 0.11111111111111
77659, 1.2869565217391, 0.033333333333333, 0.11111111111111
77660, 1.2869565217391, 0.016666666666667, 0.083333333333333
77661, 1.2652173913043, 0.016666666666667, 0.055555555555556
77662, 1.2869565217391, 0.033333333333333, 0.055555555555556
77663, 1.2869565217391, 0.016666666666667, 0.027777777777778
77664, 1.3304347826087, 0.016666666666667, 0.47222222222222
77665, 1.3086956521739, 0.016666666666667, 0.44444444444444
77666, 1.3304347826087, 0.033333333333333, 0.44444444444444
77667, 1.3304347826087, 0.016666666666667, 0.41666666666667
77668, 1.3086956521739, 0.016666666666667, 0.38888888888889
77669, 1.3304347826087, 0.033333333333333, 0.38888888888889
77670, 1.3304347826087, 0.016666666666667, 0.36111111111111
77671, 1.3086956521739, 0.016666666666667, 0.33333333333333
77672, 1.3304347826087, 0.033333333333333, 0.33333333333333
77673, 1.3304347826087, 0.016666666666667, 0.30555555555556
77674, 1.3086956521739, 0.016666666666667, 0.27777777777778
77675, 1.3304347826087, 0.033333333333333, 0.27777777777778
77676, 1.3304347826087, 0.016666666666667, 0.25
77677, 1.3086956521739, 0.016666666666667, 0.22222222222222
77678, 1.3304347826087, 0.033333333333333, 0.22222222222222
77679, 1.3304347826087, 0.016666666666667, 0.19444444444444
77680, 1.3086956521739, 0.016666666666667, 0.16666666666667
77681, 1.3304347826087, 0.033333333333333, 0.16666666666667
77682, 1.3304347826087, 0.016666666666667, 0.13888888888889
77683, 1.3086956521739, 0.016666666666667, 0.11111111111111
77684, 1.3304347826087, 0.033333333333333, 0.11111111111111
77685, 1.3304347826087, 0.016666666666667, 0.083333333333333
77686, 1.3086956521739, 0.016666666666667, 0.055555555555556
77687, 1.3304347826087, 0.033333333333333, 0.055555555555556
77688, 1.3304347826087, 0.016666666666667, 0.027777777777778
77689, 1.3739130434783, 0.016666666666667, 0.47222222222222
77690, 1.3521739130435, 0.016666666666667, 0.44444444444444
77691, 1.3739130434783, 0.033333333333333, 0.44444444444444
77692, 1.3739130434783, 0.016666666666667, 0.41666666666667
77693, 1.3521739130435, 0.016666666666667, 0.38888888888889
77694, 1.3739130434783, 0.033333333333333, 0.38888888888889
77695, 1.3739130434783, 0.016666666666667, 0.36111111111111
77696, 1.3521739130435, 0.016666666666667, 0.33333333333333
77697, 1.3739130434783, 0.033333333333333, 0.33333333333333
77698, 1.3739130434783, 0.016666666666667, 0.30555555555556
77699, 1.3521739130435, 0.016666666666667, 0.27777777777778
77700, 1.3739130434783, 0.033333333333333, 0.27777777777778
77701, 1.3739130434783, 0.016666666666667, 0.25
77702, 1.3521739130435, 0.016666666666667, 0.22222222222222
77703, 1.3739130434783, 0.033333333333333, 0.22222222222222
77704, 1.3739130434783, 0.016666666666667, 0.19444444444444
77705, 1.3521739130435, 0.016666666666667, 0.16666666666667
77706, 1.3739130434783, 0.033333333333333, 0.16666666666667
77707, 1.3739130434783, 0.016666666666667, 0.13888888888889
77708, 1.3521739130435, 0.016666666666667, 0.11111111111111
77709, 1.3739130434783, 0.033333333333333, 0.11111111111111
77710, 1.3739130434783, 0.016666666666667, 0.083333333333333
77711, 1.3521739130435, 0.016666666666667, 0.055555555555556
77712, 1.3739130434783, 0.033333333333333, 0.055555555555556
77713, 1.3739130434783, 0.016666666666667, 0.027777777777778
77714, 1.4173913043478, 0.016666666666667, 0.47222222222222
77715, 1.395652173913, 0.016666666666667, 0.44444444444444
77716, 1.4173913043478, 0.033333333333333, 0.44444444444444
77717, 1.4173913043478, 0.016666666666667, 0.41666666666667
77718, 1.395652173913, 0.016666666666667, 0.38888888888889
77719, 1.4173913043478, 0.033333333333333, 0.38888888888889
77720, 1.4173913043478, 0.016666666666667, 0.36111111111111
77721, 1.395652173913, 0.016666666666667, 0.33333333333333
77722, 1.4173913043478, 0.033333333333333, 0.33333333333333
77723, 1.4173913043478, 0.016666666666667, 0.30555555555556
77724, 1.395652173913, 0.016666666666667, 0.27777777777778
77725, 1.4173913043478, 0.033333333333333, 0.27777777777778
77726, 1.4173913043478, 0.016666666666667, 0.25
77727, 1.395652173913, 0.016666666666667, 0.22222222222222
77728, 1.4173913043478, 0.033333333333333, 0.22222222222222
77729, 1.4173913043478, 0.016666666666667, 0.19444444444444
77730, 1.395652173913, 0.016666666666667, 0.16666666666667
77731, 1.4173913043478, 0.033333333333333, 0.16666666666667
77732, 1.4173913043478, 0.016666666666667, 0.13888888888889
77733, 1.395652173913, 0.016666666666667, 0.11111111111111
77734, 1.4173913043478, 0.033333333333333, 0.11111111111111
77735, 1.4173913043478, 0.016666666666667, 0.083333333333333
77736, 1.395652173913, 0.016666666666667, 0.055555555555556
77737, 1.4173913043478, 0.033333333333333, 0.055555555555556
77738, 1.4173913043478, 0.016666666666667, 0.027777777777778
77739, 1.4608695652174, 0.016666666666667, 0.47222222222222
77740, 1.4391304347826, 0.016666666666667, 0.44444444444444
77741, 1.4608695652174, 0.033333333333333, 0.44444444444444
77742, 1.4608695652174, 0.016666666666667, 0.41666666666667
77743, 1.4391304347826, 0.016666666666667, 0.38888888888889
77744, 1.4608695652174, 0.033333333333333, 0.38888888888889
77745, 1.4608695652174, 0.016666666666667, 0.36111111111111
77746, 1.4391304347826, 0.016666666666667, 0.33333333333333
77747, 1.4608695652174, 0.033333333333333, 0.33333333333333
77748, 1.4608695652174, 0.016666666666667, 0.30555555555556
77749, 1.4391304347826, 0.016666666666667, 0.27777777777778
77750, 1.4608695652174, 0.033333333333333, 0.27777777777778
77751, 1.4608695652174, 0.016666666666667, 0.25
77752, 1.4391304347826, 0.016666666666667, 0.22222222222222
77753, 1.4608695652174, 0.033333333333333, 0.22222222222222
77754, 1.4608695652174, 0.016666666666667, 0.19444444444444
77755, 1.4391304347826, 0.016666666666667, 0.16666666666667
77756, 1.4608695652174, 0.033333333333333, 0.16666666666667
77757, 1.4608695652174, 0.016666666666667, 0.13888888888889
77758, 1.4391304347826, 0.016666666666667, 0.11111111111111
77759, 1.4608695652174, 0.033333333333333, 0.11111111111111
77760, 1.4608695652174, 0.016666666666667, 0.083333333333333
77761, 1.4391304347826, 0.016666666666667, 0.055555555555556
77762, 1.4608695652174, 0.033333333333333, 0.055555555555556
77763, 1.4608695652174, 0.016666666666667, 0.027777777777778
77764, 1.504347826087, 0.016666666666667, 0.47222222222222
77765, 1.4826086956522, 0.016666666666667, 0.44444444444444
77766, 1.504347826087, 0.033333333333333, 0.44444444444444
77767, 1.504347826087, 0.016666666666667, 0.41666666666667
77768, 1.4826086956522, 0.016666666666667, 0.38888888888889
77769, 1.504347826087, 0.033333333333333, 0.38888888888889
77770, 1.504347826087, 0.016666666666667, 0.36111111111111
77771, 1.4826086956522, 0.016666666666667, 0.33333333333333
77772, 1.504347826087, 0.033333333333333, 0.33333333333333
77773, 1.504347826087, 0.016666666666667, 0.30555555555556
77774, 1.4826086956522, 0.016666666666667, 0.27777777777778
77775, 1.504347826087, 0.033333333333333, 0.27777777777778
77776, 1.504347826087, 0.016666666666667, 0.25
77777, 1.4826086956522, 0.016666666666667, 0.22222222222222
77778, 1.504347826087, 0.033333333333333, 0.22222222222222
77779, 1.504347826087, 0.016666666666667, 0.19444444444444
77780, 1.4826086956522, 0.016666666666667, 0.16666666666667
77781, 1.504347826087, 0.033333333333333, 0.16666666666667
77782, 1.504347826087, 0.016666666666667, 0.13888888888889
77783, 1.4826086956522, 0.016666666666667, 0.11111111111111
77784, 1.504347826087, 0.033333333333333, 0.11111111111111
77785, 1.504347826087, 0.016666666666667, 0.083333333333333
77786, 1.4826086956522, 0.016666666666667, 0.055555555555556
77787, 1.504347826087, 0.033333333333333, 0.055555555555556
77788, 1.504347826087, 0.016666666666667, 0.027777777777778
77789, 1.5478260869565, 0.016666666666667, 0.47222222222222
77790, 1.5260869565217, 0.016666666666667, 0.44444444444444
77791, 1.5478260869565, 0.033333333333333, 0.44444444444444
77792, 1.5478260869565, 0.016666666666667, 0.41666666666667
77793, 1.5260869565217, 0.016666666666667, 0.38888888888889
77794, 1.5478260869565, 0.033333333333333, 0.38888888888889
77795, 1.5478260869565, 0.016666666666667, 0.36111111111111
77796, 1.5260869565217, 0.016666666666667, 0.33333333333333
77797, 1.5478260869565, 0.033333333333333, 0.33333333333333
77798, 1.5478260869565, 0.016666666666667, 0.30555555555556
77799, 1.5260869565217, 0.016666666666667, 0.27777777777778
77800, 1.5478260869565, 0.033333333333333, 0.27777777777778
77801, 1.5478260869565, 0.016666666666667, 0.25
77802, 1.5260869565217, 0.016666666666667, 0.22222222222222
77803, 1.5478260869565, 0.033333333333333, 0.22222222222222
77804, 1.5478260869565, 0.016666666666667, 0.19444444444444
77805, 1.5260869565217, 0.016666666666667, 0.16666666666667
77806, 1.5478260869565, 0.033333333333333, 0.16666666666667
77807, 1.5478260869565, 0.016666666666667, 0.13888888888889
77808, 1.5260869565217, 0.016666666666667, 0.11111111111111
77809, 1.5478260869565, 0.033333333333333, 0.11111111111111
77810, 1.5478260869565, 0.016666666666667, 0.083333333333333
77811, 1.5260869565217, 0.016666666666667, 0.055555555555556
77812, 1.5478260869565, 0.033333333333333, 0.055555555555556
77813, 1.5478260869565, 0.016666666666667, 0.027777777777778
77814, 1.5913043478261, 0.016666666666667, 0.47222222222222
77815, 1.5695652173913, 0.016666666666667, 0.44444444444444
77816, 1.5913043478261, 0.033333333333333, 0.44444444444444
77817, 1.5913043478261, 0.016666666666667, 0.41666666666667
77818, 1.5695652173913, 0.016666666666667, 0.38888888888889
77819, 1.5913043478261, 0.033333333333333, 0.38888888888889
77820, 1.5913043478261, 0.016666666666667, 0.36111111111111
77821, 1.5695652173913, 0.016666666666667, 0.33333333333333
77822, 1.5913043478261, 0.033333333333333, 0.33333333333333
77823, 1.5913043478261, 0.016666666666667, 0.30555555555556
77824, 1.5695652173913, 0.016666666666667, 0.27777777777778
77825, 1.5913043478261, 0.033333333333333, 0.27777777777778
77826, 1.5913043478261, 0.016666666666667, 0.25
77827, 1.5695652173913, 0.016666666666667, 0.22222222222222
77828, 1.5913043478261, 0.033333333333333, 0.22222222222222
77829, 1.5913043478261, 0.016666666666667, 0.19444444444444
77830, 1.5695652173913, 0.016666666666667, 0.16666666666667
77831, 1.5913043478261, 0.033333333333333, 0.16666666666667
77832, 1.5913043478261, 0.016666666666667, 0.13888888888889
77833, 1.5695652173913, 0.016666666666667, 0.11111111111111
77834, 1.5913043478261, 0.033333333333333, 0.11111111111111
77835, 1.5913043478261, 0.016666666666667, 0.083333333333333
77836, 1.5695652173913, 0.016666666666667, 0.055555555555556
77837, 1.5913043478261, 0.033333333333333, 0.055555555555556
77838, 1.5913043478261, 0.016666666666667, 0.027777777777778
77839, 1.6347826086957, 0.016666666666667, 0.47222222222222
77840, 1.6130434782609, 0.016666666666667, 0.44444444444444
77841, 1.6347826086957, 0.033333333333333, 0.44444444444444
77842, 1.6347826086957, 0.016666666666667, 0.41666666666667
77843, 1.6130434782609, 0.016666666666667, 0.38888888888889
77844, 1.6347826086957, 0.033333333333333, 0.38888888888889
77845, 1.6347826086957, 0.016666666666667, 0.36111111111111
77846, 1.6130434782609, 0.016666666666667, 0.33333333333333
77847, 1.6347826086957, 0.033333333333333, 0.33333333333333
77848, 1.6347826086957, 0.016666666666667, 0.30555555555556
77849, 1.6130434782609, 0.016666666666667, 0.27777777777778
77850, 1.6347826086957, 0.033333333333333, 0.27777777777778
77851, 1.6347826086957, 0.016666666666667, 0.25
77852, 1.6130434782609, 0.016666666666667, 0.22222222222222
77853, 1.6347826086957, 0.033333333333333, 0.22222222222222
77854, 1.6347826086957, 0.016666666666667, 0.19444444444444
77855, 1.6130434782609, 0.016666666666667, 0.16666666666667
77856, 1.6347826086957, 0.033333333333333, 0.16666666666667
77857, 1.6347826086957, 0.016666666666667, 0.13888888888889
77858, 1.6130434782609, 0.016666666666667, 0.11111111111111
77859, 1.6347826086957, 0.033333333333333, 0.11111111111111
77860, 1.6347826086957, 0.016666666666667, 0.083333333333333
77861, 1.6130434782609, 0.016666666666667, 0.055555555555556
77862, 1.6347826086957, 0.033333333333333, 0.055555555555556
77863, 1.6347826086957, 0.016666666666667, 0.027777777777778
77864, 1.6782608695652, 0.016666666666667, 0.47222222222222
77865, 1.6565217391304, 0.016666666666667, 0.44444444444444
77866, 1.6782608695652, 0.033333333333333, 0.44444444444444
77867, 1.6782608695652, 0.016666666666667, 0.41666666666667
77868, 1.6565217391304, 0.016666666666667, 0.38888888888889
77869, 1.6782608695652, 0.033333333333333, 0.38888888888889
77870, 1.6782608695652, 0.016666666666667, 0.36111111111111
77871, 1.6565217391304, 0.016666666666667, 0.33333333333333
77872, 1.6782608695652, 0.033333333333333, 0.33333333333333
77873, 1.6782608695652, 0.016666666666667, 0.30555555555556
77874, 1.6565217391304, 0.016666666666667, 0.27777777777778
77875, 1.6782608695652, 0.033333333333333, 0.27777777777778
77876, 1.6782608695652, 0.016666666666667, 0.25
77877, 1.6565217391304, 0.016666666666667, 0.22222222222222
77878, 1.6782608695652, 0.033333333333333, 0.22222222222222
77879, 1.6782608695652, 0.016666666666667, 0.19444444444444
77880, 1.6565217391304, 0.016666666666667, 0.16666666666667
77881, 1.6782608695652, 0.033333333333333, 0.16666666666667
77882, 1.6782608695652, 0.016666666666667, 0.13888888888889
77883, 1.6565217391304, 0.016666666666667, 0.11111111111111
77884, 1.6782608695652, 0.033333333333333, 0.11111111111111
77885, 1.6782608695652, 0.016666666666667, 0.083333333333333
77886, 1.6565217391304, 0.016666666666667, 0.055555555555556
77887, 1.6782608695652, 0.033333333333333, 0.055555555555556
77888, 1.6782608695652, 0.016666666666667, 0.027777777777778
77889, 1.7217391304348, 0.016666666666667, 0.47222222222222
77890, 1.7, 0.016666666666667, 0.44444444444444
77891, 1.7217391304348, 0.033333333333333, 0.44444444444444
77892, 1.7217391304348, 0.016666666666667, 0.41666666666667
77893, 1.7, 0.016666666666667, 0.38888888888889
77894, 1.7217391304348, 0.033333333333333, 0.38888888888889
77895, 1.7217391304348, 0.016666666666667, 0.36111111111111
77896, 1.7, 0.016666666666667, 0.33333333333333
77897, 1.7217391304348, 0.033333333333333, 0.33333333333333
77898, 1.7217391304348, 0.016666666666667, 0.30555555555556
77899, 1.7, 0.016666666666667, 0.27777777777778
77900, 1.7217391304348, 0.033333333333333, 0.27777777777778
77901, 1.7217391304348, 0.016666666666667, 0.25
77902, 1.7, 0.016666666666667, 0.22222222222222
77903, 1.7217391304348, 0.033333333333333, 0.22222222222222
77904, 1.7217391304348, 0.016666666666667, 0.19444444444444
77905, 1.7, 0.016666666666667, 0.16666666666667
77906, 1.7217391304348, 0.033333333333333, 0.16666666666667
77907, 1.7217391304348, 0.016666666666667, 0.13888888888889
77908, 1.7, 0.016666666666667, 0.11111111111111
77909, 1.7217391304348, 0.033333333333333, 0.11111111111111
77910, 1.7217391304348, 0.016666666666667, 0.083333333333333
77911, 1.7, 0.016666666666667, 0.055555555555556
77912, 1.7217391304348, 0.033333333333333, 0.055555555555556
77913, 1.7217391304348, 0.016666666666667, 0.027777777777778
77914, 1.7652173913043, 0.016666666666667, 0.47222222222222
77915, 1.7434782608696, 0.016666666666667, 0.44444444444444
77916, 1.7652173913043, 0.033333333333333, 0.44444444444444
77917, 1.7652173913043, 0.016666666666667, 0.41666666666667
77918, 1.7434782608696, 0.016666666666667, 0.38888888888889
77919, 1.7652173913043, 0.033333333333333, 0.38888888888889
77920, 1.7652173913043, 0.016666666666667, 0.36111111111111
77921, 1.7434782608696, 0.016666666666667, 0.33333333333333
77922, 1.7652173913043, 0.033333333333333, 0.33333333333333
77923, 1.7652173913043, 0.016666666666667, 0.30555555555556
77924, 1.7434782608696, 0.016666666666667, 0.27777777777778
77925, 1.7652173913043, 0.033333333333333, 0.27777777777778
77926, 1.7652173913043, 0.016666666666667, 0.25
77927, 1.7434782608696, 0.016666666666667, 0.22222222222222
77928, 1.7652173913043, 0.033333333333333, 0.22222222222222
77929, 1.7652173913043, 0.016666666666667, 0.19444444444444
77930, 1.7434782608696, 0.016666666666667, 0.16666666666667
77931, 1.7652173913043, 0.033333333333333, 0.16666666666667
77932, 1.7652173913043, 0.016666666666667, 0.13888888888889
77933, 1.7434782608696, 0.016666666666667, 0.11111111111111
77934, 1.7652173913043, 0.033333333333333, 0.11111111111111
77935, 1.7652173913043, 0.016666666666667, 0.083333333333333
77936, 1.7434782608696, 0.016666666666667, 0.055555555555556
77937, 1.7652173913043, 0.033333333333333, 0.055555555555556
77938, 1.7652173913043, 0.016666666666667, 0.027777777777778
77939, 1.8086956521739, 0.016666666666667, 0.47222222222222
77940, 1.7869565217391, 0.016666666666667, 0.44444444444444
77941, 1.8086956521739, 0.033333333333333, 0.44444444444444
77942, 1.8086956521739, 0.016666666666667, 0.41666666666667
77943, 1.7869565217391, 0.016666666666667, 0.38888888888889
77944, 1.8086956521739, 0.033333333333333, 0.38888888888889
77945, 1.8086956521739, 0.016666666666667, 0.36111111111111
77946, 1.7869565217391, 0.016666666666667, 0.33333333333333
77947, 1.8086956521739, 0.033333333333333, 0.33333333333333
77948, 1.8086956521739, 0.016666666666667, 0.30555555555556
77949, 1.7869565217391, 0.016666666666667, 0.27777777777778
77950, 1.8086956521739, 0.033333333333333, 0.27777777777778
77951, 1.8086956521739, 0.016666666666667, 0.25
77952, 1.7869565217391, 0.016666666666667, 0.22222222222222
77953, 1.8086956521739, 0.033333333333333, 0.22222222222222
77954, 1.8086956521739, 0.016666666666667, 0.19444444444444
77955, 1.7869565217391, 0.016666666666667, 0.16666666666667
77956, 1.8086956521739, 0.033333333333333, 0.16666666666667
77957, 1.8086956521739, 0.016666666666667, 0.13888888888889
77958, 1.7869565217391, 0.016666666666667, 0.11111111111111
77959, 1.8086956521739, 0.033333333333333, 0.11111111111111
77960, 1.8086956521739, 0.016666666666667, 0.083333333333333
77961, 1.7869565217391, 0.016666666666667, 0.055555555555556
77962, 1.8086956521739, 0.033333333333333, 0.055555555555556
77963, 1.8086956521739, 0.016666666666667, 0.027777777777778
77964, 1.8521739130435, 0.016666666666667, 0.47222222222222
77965, 1.8304347826087, 0.016666666666667, 0.44444444444444
77966, 1.8521739130435, 0.033333333333333, 0.44444444444444
77967, 1.8521739130435, 0.016666666666667, 0.41666666666667
77968, 1.8304347826087, 0.016666666666667, 0.38888888888889
77969, 1.8521739130435, 0.033333333333333, 0.38888888888889
77970, 1.8521739130435, 0.016666666666667, 0.36111111111111
77971, 1.8304347826087, 0.016666666666667, 0.33333333333333
77972, 1.8521739130435, 0.033333333333333, 0.33333333333333
77973, 1.8521739130435, 0.016666666666667, 0.30555555555556
77974, 1.8304347826087, 0.016666666666667, 0.27777777777778
77975, 1.8521739130435, 0.033333333333333, 0.27777777777778
77976, 1.8521739130435, 0.016666666666667, 0.25
77977, 1.8304347826087, 0.016666666666667, 0.22222222222222
77978, 1.8521739130435, 0.033333333333333, 0.22222222222222
77979, 1.8521739130435, 0.016666666666667, 0.19444444444444
77980, 1.8304347826087, 0.016666666666667, 0.16666666666667
77981, 1.8521739130435, 0.033333333333333, 0.16666666666667
77982, 1.8521739130435, 0.016666666666667, 0.13888888888889
77983, 1.8304347826087, 0.016666666666667, 0.11111111111111
77984, 1.8521739130435, 0.033333333333333, 0.11111111111111
77985, 1.8521739130435, 0.016666666666667, 0.083333333333333
77986, 1.8304347826087, 0.016666666666667, 0.055555555555556
77987, 1.8521739130435, 0.033333333333333, 0.055555555555556
77988, 1.8521739130435, 0.016666666666667, 0.027777777777778
77989, 1.895652173913, 0.016666666666667, 0.47222222222222
77990, 1.8739130434783, 0.016666666666667, 0.44444444444444
77991, 1.895652173913, 0.033333333333333, 0.44444444444444
77992, 1.895652173913, 0.016666666666667, 0.41666666666667
77993, 1.8739130434783, 0.016666666666667, 0.38888888888889
77994, 1.895652173913, 0.033333333333333, 0.38888888888889
77995, 1.895652173913, 0.016666666666667, 0.36111111111111
77996, 1.8739130434783, 0.016666666666667, 0.33333333333333
77997, 1.895652173913, 0.033333333333333, 0.33333333333333
77998, 1.895652173913, 0.016666666666667, 0.30555555555556
77999, 1.8739130434783, 0.016666666666667, 0.27777777777778
78000, 1.895652173913, 0.033333333333333, 0.27777777777778
78001, 1.895652173913, 0.016666666666667, 0.25
78002, 1.8739130434783, 0.016666666666667, 0.22222222222222
78003, 1.895652173913, 0.033333333333333, 0.22222222222222
78004, 1.895652173913, 0.016666666666667, 0.19444444444444
78005, 1.8739130434783, 0.016666666666667, 0.16666666666667
78006, 1.895652173913, 0.033333333333333, 0.16666666666667
78007, 1.895652173913, 0.016666666666667, 0.13888888888889
78008, 1.8739130434783, 0.016666666666667, 0.11111111111111
78009, 1.895652173913, 0.033333333333333, 0.11111111111111
78010, 1.895652173913, 0.016666666666667, 0.083333333333333
78011, 1.8739130434783, 0.016666666666667, 0.055555555555556
78012, 1.895652173913, 0.033333333333333, 0.055555555555556
78013, 1.895652173913, 0.016666666666667, 0.027777777777778
78014, 1.9391304347826, 0.016666666666667, 0.47222222222222
78015, 1.9173913043478, 0.016666666666667, 0.44444444444444
78016, 1.9391304347826, 0.033333333333333, 0.44444444444444
78017, 1.9391304347826, 0.016666666666667, 0.41666666666667
78018, 1.9173913043478, 0.016666666666667, 0.38888888888889
78019, 1.9391304347826, 0.033333333333333, 0.38888888888889
78020, 1.9391304347826, 0.016666666666667, 0.36111111111111
78021, 1.9173913043478, 0.016666666666667, 0.33333333333333
78022, 1.9391304347826, 0.033333333333333, 0.33333333333333
78023, 1.9391304347826, 0.016666666666667, 0.30555555555556
78024, 1.9173913043478, 0.016666666666667, 0.27777777777778
78025, 1.9391304347826, 0.033333333333333, 0.27777777777778
78026, 1.9391304347826, 0.016666666666667, 0.25
78027, 1.9173913043478, 0.016666666666667, 0.22222222222222
78028, 1.9391304347826, 0.033333333333333, 0.22222222222222
78029, 1.9391304347826, 0.016666666666667, 0.19444444444444
78030, 1.9173913043478, 0.016666666666667, 0.16666666666667
78031, 1.9391304347826, 0.033333333333333, 0.16666666666667
78032, 1.9391304347826, 0.016666666666667, 0.13888888888889
78033, 1.9173913043478, 0.016666666666667, 0.11111111111111
78034, 1.9391304347826, 0.033333333333333, 0.11111111111111
78035, 1.9391304347826, 0.016666666666667, 0.083333333333333
78036, 1.9173913043478, 0.016666666666667, 0.055555555555556
78037, 1.9391304347826, 0.033333333333333, 0.055555555555556
78038, 1.9391304347826, 0.016666666666667, 0.027777777777778
78039, 1.9826086956522, 0.016666666666667, 0.47222222222222
78040, 1.9608695652174, 0.016666666666667, 0.44444444444444
78041, 1.9826086956522, 0.033333333333333, 0.44444444444444
78042, 1.9826086956522, 0.016666666666667, 0.41666666666667
78043, 1.9608695652174, 0.016666666666667, 0.38888888888889
78044, 1.9826086956522, 0.033333333333333, 0.38888888888889
78045, 1.9826086956522, 0.016666666666667, 0.36111111111111
78046, 1.9608695652174, 0.016666666666667, 0.33333333333333
78047, 1.9826086956522, 0.033333333333333, 0.33333333333333
78048, 1.9826086956522, 0.016666666666667, 0.30555555555556
78049, 1.9608695652174, 0.016666666666667, 0.27777777777778
78050, 1.9826086956522, 0.033333333333333, 0.27777777777778
78051, 1.9826086956522, 0.016666666666667, 0.25
78052, 1.9608695652174, 0.016666666666667, 0.22222222222222
78053, 1.9826086956522, 0.033333333333333, 0.22222222222222
78054, 1.9826086956522, 0.016666666666667, 0.19444444444444
78055, 1.9608695652174, 0.016666666666667, 0.16666666666667
78056, 1.9826086956522, 0.033333333333333, 0.16666666666667
78057, 1.9826086956522, 0.016666666666667, 0.13888888888889
78058, 1.9608695652174, 0.016666666666667, 0.11111111111111
78059, 1.9826086956522, 0.033333333333333, 0.11111111111111
78060, 1.9826086956522, 0.016666666666667, 0.083333333333333
78061, 1.9608695652174, 0.016666666666667, 0.055555555555556
78062, 1.9826086956522, 0.033333333333333, 0.055555555555556
78063, 1.9826086956522, 0.016666666666667, 0.027777777777778
78064, 2.0260869565217, 0.016666666666667, 0.47222222222222
78065, 2.004347826087, 0.016666666666667, 0.44444444444444
78066, 2.0260869565217, 0.033333333333333, 0.44444444444444
78067, 2.0260869565217, 0.016666666666667, 0.41666666666667
78068, 2.004347826087, 0.016666666666667, 0.38888888888889
78069, 2.0260869565217, 0.033333333333333, 0.38888888888889
78070, 2.0260869565217, 0.016666666666667, 0.36111111111111
78071, 2.004347826087, 0.016666666666667, 0.33333333333333
78072, 2.0260869565217, 0.033333333333333, 0.33333333333333
78073, 2.0260869565217, 0.016666666666667, 0.30555555555556
78074, 2.004347826087, 0.016666666666667, 0.27777777777778
78075, 2.0260869565217, 0.033333333333333, 0.27777777777778
78076, 2.0260869565217, 0.016666666666667, 0.25
78077, 2.004347826087, 0.016666666666667, 0.22222222222222
78078, 2.0260869565217, 0.033333333333333, 0.22222222222222
78079, 2.0260869565217, 0.016666666666667, 0.19444444444444
78080, 2.004347826087, 0.016666666666667, 0.16666666666667
78081, 2.0260869565217, 0.033333333333333, 0.16666666666667
78082, 2.0260869565217, 0.016666666666667, 0.13888888888889
78083, 2.004347826087, 0.016666666666667, 0.11111111111111
78084, 2.0260869565217, 0.033333333333333, 0.11111111111111
78085, 2.0260869565217, 0.016666666666667, 0.083333333333333
78086, 2.004347826087, 0.016666666666667, 0.055555555555556
78087, 2.0260869565217, 0.033333333333333, 0.055555555555556
78088, 2.0260869565217, 0.016666666666667, 0.027777777777778
78089, 2.0695652173913, 0.016666666666667, 0.47222222222222
78090, 2.0478260869565, 0.016666666666667, 0.44444444444444
78091, 2.0695652173913, 0.033333333333333, 0.44444444444444
78092, 2.0695652173913, 0.016666666666667, 0.41666666666667
78093, 2.0478260869565, 0.016666666666667, 0.38888888888889
78094, 2.0695652173913, 0.033333333333333, 0.38888888888889
78095, 2.0695652173913, 0.016666666666667, 0.36111111111111
78096, 2.0478260869565, 0.016666666666667, 0.33333333333333
78097, 2.0695652173913, 0.033333333333333, 0.33333333333333
78098, 2.0695652173913, 0.016666666666667, 0.30555555555556
78099, 2.0478260869565, 0.016666666666667, 0.27777777777778
78100, 2.0695652173913, 0.033333333333333, 0.27777777777778
78101, 2.0695652173913, 0.016666666666667, 0.25
78102, 2.0478260869565, 0.016666666666667, 0.22222222222222
78103, 2.0695652173913, 0.033333333333333, 0.22222222222222
78104, 2.0695652173913, 0.016666666666667, 0.19444444444444
78105, 2.0478260869565, 0.016666666666667, 0.16666666666667
78106, 2.0695652173913, 0.033333333333333, 0.16666666666667
78107, 2.0695652173913, 0.016666666666667, 0.13888888888889
78108, 2.0478260869565, 0.016666666666667, 0.11111111111111
78109, 2.0695652173913, 0.033333333333333, 0.11111111111111
78110, 2.0695652173913, 0.016666666666667, 0.083333333333333
78111, 2.0478260869565, 0.016666666666667, 0.055555555555556
78112, 2.0695652173913, 0.033333333333333, 0.055555555555556
78113, 2.0695652173913, 0.016666666666667, 0.027777777777778
78114, 2.1130434782609, 0.016666666666667, 0.47222222222222
78115, 2.0913043478261, 0.016666666666667, 0.44444444444444
78116, 2.1130434782609, 0.033333333333333, 0.44444444444444
78117, 2.1130434782609, 0.016666666666667, 0.41666666666667
78118, 2.0913043478261, 0.016666666666667, 0.38888888888889
78119, 2.1130434782609, 0.033333333333333, 0.38888888888889
78120, 2.1130434782609, 0.016666666666667, 0.36111111111111
78121, 2.0913043478261, 0.016666666666667, 0.33333333333333
78122, 2.1130434782609, 0.033333333333333, 0.33333333333333
78123, 2.1130434782609, 0.016666666666667, 0.30555555555556
78124, 2.0913043478261, 0.016666666666667, 0.27777777777778
78125, 2.1130434782609, 0.033333333333333, 0.27777777777778
78126, 2.1130434782609, 0.016666666666667, 0.25
78127, 2.0913043478261, 0.016666666666667, 0.22222222222222
78128, 2.1130434782609, 0.033333333333333, 0.22222222222222
78129, 2.1130434782609, 0.016666666666667, 0.19444444444444
78130, 2.0913043478261, 0.016666666666667, 0.16666666666667
78131, 2.1130434782609, 0.033333333333333, 0.16666666666667
78132, 2.1130434782609, 0.016666666666667, 0.13888888888889
78133, 2.0913043478261, 0.016666666666667, 0.11111111111111
78134, 2.1130434782609, 0.033333333333333, 0.11111111111111
78135, 2.1130434782609, 0.016666666666667, 0.083333333333333
78136, 2.0913043478261, 0.016666666666667, 0.055555555555556
78137, 2.1130434782609, 0.033333333333333, 0.055555555555556
78138, 2.1130434782609, 0.016666666666667, 0.027777777777778
78139, 2.1565217391304, 0.016666666666667, 0.47222222222222
78140, 2.1347826086957, 0.016666666666667, 0.44444444444444
78141, 2.1565217391304, 0.033333333333333, 0.44444444444444
78142, 2.1565217391304, 0.016666666666667, 0.41666666666667
78143, 2.1347826086957, 0.016666666666667, 0.38888888888889
78144, 2.1565217391304, 0.033333333333333, 0.38888888888889
78145, 2.1565217391304, 0.016666666666667, 0.36111111111111
78146, 2.1347826086957, 0.016666666666667, 0.33333333333333
78147, 2.1565217391304, 0.033333333333333, 0.33333333333333
78148, 2.1565217391304, 0.016666666666667, 0.30555555555556
78149, 2.1347826086957, 0.016666666666667, 0.27777777777778
78150, 2.1565217391304, 0.033333333333333, 0.27777777777778
78151, 2.1565217391304, 0.016666666666667, 0.25
78152, 2.1347826086957, 0.016666666666667, 0.22222222222222
78153, 2.1565217391304, 0.033333333333333, 0.22222222222222
78154, 2.1565217391304, 0.016666666666667, 0.19444444444444
78155, 2.1347826086957, 0.016666666666667, 0.16666666666667
78156, 2.1565217391304, 0.033333333333333, 0.16666666666667
78157, 2.1565217391304, 0.016666666666667, 0.13888888888889
78158, 2.1347826086957, 0.016666666666667, 0.11111111111111
78159, 2.1565217391304, 0.033333333333333, 0.11111111111111
78160, 2.1565217391304, 0.016666666666667, 0.083333333333333
78161, 2.1347826086957, 0.016666666666667, 0.055555555555556
78162, 2.1565217391304, 0.033333333333333, 0.055555555555556
78163, 2.1565217391304, 0.016666666666667, 0.027777777777778
78164, 2.1782608695652, 0.016666666666667, 0.44444444444444
78165, 2.1782608695652, 0.016666666666667, 0.38888888888889
78166, 2.1782608695652, 0.016666666666667, 0.33333333333333
78167, 2.1782608695652, 0.016666666666667, 0.27777777777778
78168, 2.1782608695652, 0.016666666666667, 0.22222222222222
78169, 2.1782608695652, 0.016666666666667, 0.16666666666667
78170, 2.1782608695652, 0.016666666666667, 0.11111111111111
78171, 2.1782608695652, 0.016666666666667, 0.055555555555556
78172, 1.2434782608696, -0.016666666666667, 0.47222222222222
78173, 1.2217391304348, -0.016666666666667, 0.44444444444444
78174, 1.2434782608696, -1.0061396160665e-16, 0.44444444444444
78175, 1.2434782608696, -0.016666666666667, 0.41666666666667
78176, 1.2217391304348, -0.016666666666667, 0.38888888888889
78177, 1.2434782608696, -1.0061396160665e-16, 0.38888888888889
78178, 1.2434782608696, -0.016666666666667, 0.36111111111111
78179, 1.2217391304348, -0.016666666666667, 0.33333333333333
78180, 1.2434782608696, -1.1102230246252e-16, 0.33333333333333
78181, 1.2434782608696, -0.016666666666667, 0.30555555555556
78182, 1.2217391304348, -0.016666666666667, 0.27777777777778
78183, 1.2434782608696, -1.0928757898654e-16, 0.27777777777778
78184, 1.2434782608696, -0.016666666666667, 0.25
78185, 1.2217391304348, -0.016666666666667, 0.22222222222222
78186, 1.2434782608696, -1.1275702593849e-16, 0.22222222222222
78187, 1.2434782608696, -0.016666666666667, 0.19444444444444
78188, 1.2217391304348, -0.016666666666667, 0.16666666666667
78189, 1.2434782608696, -1.0755285551056e-16, 0.16666666666667
78190, 1.2434782608696, -0.016666666666667, 0.13888888888889
78191, 1.2217391304348, -0.016666666666667, 0.11111111111111
78192, 1.2434782608696, -1.0928757898654e-16, 0.11111111111111
78193, 1.2434782608696, -0.016666666666667, 0.083333333333333
78194, 1.2217391304348, -0.016666666666667, 0.055555555555556
78195, 1.2434782608696, -1.0581813203459e-16, 0.055555555555556
78196, 1.2434782608696, -0.016666666666667, 0.027777777777778
78197, 1.2869565217391, -0.016666666666667, 0.47222222222222
78198, 1.2652173913043, -0.016666666666667, 0.44444444444444
78199, 1.2869565217391, -8.5001450322864e-17, 0.44444444444444
78200, 1.2869565217391, -0.016666666666667, 0.41666666666667
78201, 1.2652173913043, -0.016666666666667, 0.38888888888889
78202, 1.2869565217391, -9.5409791178724e-17, 0.38888888888889
78203, 1.2869565217391, -0.016666666666667, 0.36111111111111
78204, 1.2652173913043, -0.016666666666667, 0.33333333333333
78205, 1.2869565217391, -1.0234868508263e-16, 0.33333333333333
78206, 1.2869565217391, -0.016666666666667, 0.30555555555556
78207, 1.2652173913043, -0.016666666666667, 0.27777777777778
78208, 1.2869565217391, -1.0061396160665e-16, 0.27777777777778
78209, 1.2869565217391, -0.016666666666667, 0.25
78210, 1.2652173913043, -0.016666666666667, 0.22222222222222
78211, 1.2869565217391, -1.0234868508263e-16, 0.22222222222222
78212, 1.2869565217391, -0.016666666666667, 0.19444444444444
78213, 1.2652173913043, -0.016666666666667, 0.16666666666667
78214, 1.2869565217391, -9.8879238130678e-17, 0.16666666666667
78215, 1.2869565217391, -0.016666666666667, 0.13888888888889
78216, 1.2652173913043, -0.016666666666667, 0.11111111111111
78217, 1.2869565217391, -1.0408340855861e-16, 0.11111111111111
78218, 1.2869565217391, -0.016666666666667, 0.083333333333333
78219, 1.2652173913043, -0.016666666666667, 0.055555555555556
78220, 1.2869565217391, -9.3675067702748e-17, 0.055555555555556
78221, 1.2869565217391, -0.016666666666667, 0.027777777777778
78222, 1.3304347826087, -0.016666666666667, 0.47222222222222
78223, 1.3086956521739, -0.016666666666667, 0.44444444444444
78224, 1.3304347826087, -8.8470897274817e-17, 0.44444444444444
78225, 1.3304347826087, -0.016666666666667, 0.41666666666667
78226, 1.3086956521739, -0.016666666666667, 0.38888888888889
78227, 1.3304347826087, -9.0205620750794e-17, 0.38888888888889
78228, 1.3304347826087, -0.016666666666667, 0.36111111111111
78229, 1.3086956521739, -0.016666666666667, 0.33333333333333
78230, 1.3304347826087, -8.8470897274817e-17, 0.33333333333333
78231, 1.3304347826087, -0.016666666666667, 0.30555555555556
78232, 1.3086956521739, -0.016666666666667, 0.27777777777778
78233, 1.3304347826087, -9.1940344226771e-17, 0.27777777777778
78234, 1.3304347826087, -0.016666666666667, 0.25
78235, 1.3086956521739, -0.016666666666667, 0.22222222222222
78236, 1.3304347826087, -9.0205620750794e-17, 0.22222222222222
78237, 1.3304347826087, -0.016666666666667, 0.19444444444444
78238, 1.3086956521739, -0.016666666666667, 0.16666666666667
78239, 1.3304347826087, -9.1940344226771e-17, 0.16666666666667
78240, 1.3304347826087, -0.016666666666667, 0.13888888888889
78241, 1.3086956521739, -0.016666666666667, 0.11111111111111
78242, 1.3304347826087, -9.0205620750794e-17, 0.11111111111111
78243, 1.3304347826087, -0.016666666666667, 0.083333333333333
78244, 1.3086956521739, -0.016666666666667, 0.055555555555556
78245, 1.3304347826087, -9.0205620750794e-17, 0.055555555555556
78246, 1.3304347826087, -0.016666666666667, 0.027777777777778
78247, 1.3739130434783, -0.016666666666667, 0.47222222222222
78248, 1.3521739130435, -0.016666666666667, 0.44444444444444
78249, 1.3739130434783, -1.0061396160665e-16, 0.44444444444444
78250, 1.3739130434783, -0.016666666666667, 0.41666666666667
78251, 1.3521739130435, -0.016666666666667, 0.38888888888889
78252, 1.3739130434783, -9.8879238130678e-17, 0.38888888888889
78253, 1.3739130434783, -0.016666666666667, 0.36111111111111
78254, 1.3521739130435, -0.016666666666667, 0.33333333333333
78255, 1.3739130434783, -9.8879238130678e-17, 0.33333333333333
78256, 1.3739130434783, -0.016666666666667, 0.30555555555556
78257, 1.3521739130435, -0.016666666666667, 0.27777777777778
78258, 1.3739130434783, -1.0408340855861e-16, 0.27777777777778
78259, 1.3739130434783, -0.016666666666667, 0.25
78260, 1.3521739130435, -0.016666666666667, 0.22222222222222
78261, 1.3739130434783, -1.0408340855861e-16, 0.22222222222222
78262, 1.3739130434783, -0.016666666666667, 0.19444444444444
78263, 1.3521739130435, -0.016666666666667, 0.16666666666667
78264, 1.3739130434783, -1.0234868508263e-16, 0.16666666666667
78265, 1.3739130434783, -0.016666666666667, 0.13888888888889
78266, 1.3521739130435, -0.016666666666667, 0.11111111111111
78267, 1.3739130434783, -1.0408340855861e-16, 0.11111111111111
78268, 1.3739130434783, -0.016666666666667, 0.083333333333333
78269, 1.3521739130435, -0.016666666666667, 0.055555555555556
78270, 1.3739130434783, -1.0061396160665e-16, 0.055555555555556
78271, 1.3739130434783, -0.016666666666667, 0.027777777777778
78272, 1.4173913043478, -0.016666666666667, 0.47222222222222
78273, 1.395652173913, -0.016666666666667, 0.44444444444444
78274, 1.4173913043478, -9.1940344226771e-17, 0.44444444444444
78275, 1.4173913043478, -0.016666666666667, 0.41666666666667
78276, 1.395652173913, -0.016666666666667, 0.38888888888889
78277, 1.4173913043478, -7.9797279894933e-17, 0.38888888888889
78278, 1.4173913043478, -0.016666666666667, 0.36111111111111
78279, 1.395652173913, -0.016666666666667, 0.33333333333333
78280, 1.4173913043478, -9.1940344226771e-17, 0.33333333333333
78281, 1.4173913043478, -0.016666666666667, 0.30555555555556
78282, 1.395652173913, -0.016666666666667, 0.27777777777778
78283, 1.4173913043478, -8.5001450322864e-17, 0.27777777777778
78284, 1.4173913043478, -0.016666666666667, 0.25
78285, 1.395652173913, -0.016666666666667, 0.22222222222222
78286, 1.4173913043478, -8.673617379884e-17, 0.22222222222222
78287, 1.4173913043478, -0.016666666666667, 0.19444444444444
78288, 1.395652173913, -0.016666666666667, 0.16666666666667
78289, 1.4173913043478, -8.673617379884e-17, 0.16666666666667
78290, 1.4173913043478, -0.016666666666667, 0.13888888888889
78291, 1.395652173913, -0.016666666666667, 0.11111111111111
78292, 1.4173913043478, -8.5001450322864e-17, 0.11111111111111
78293, 1.4173913043478, -0.016666666666667, 0.083333333333333
78294, 1.395652173913, -0.016666666666667, 0.055555555555556
78295, 1.4173913043478, -9.1940344226771e-17, 0.055555555555556
78296, 1.4173913043478, -0.016666666666667, 0.027777777777778
78297, 1.4608695652174, -0.016666666666667, 0.47222222222222
78298, 1.4391304347826, -0.016666666666667, 0.44444444444444
78299, 1.4608695652174, -7.4593109467003e-17, 0.44444444444444
78300, 1.4608695652174, -0.016666666666667, 0.41666666666667
78301, 1.4391304347826, -0.016666666666667, 0.38888888888889
78302, 1.4608695652174, -7.8062556418956e-17, 0.38888888888889
78303, 1.4608695652174, -0.016666666666667, 0.36111111111111
78304, 1.4391304347826, -0.016666666666667, 0.33333333333333
78305, 1.4608695652174, -8.5001450322864e-17, 0.33333333333333
78306, 1.4608695652174, -0.016666666666667, 0.30555555555556
78307, 1.4391304347826, -0.016666666666667, 0.27777777777778
78308, 1.4608695652174, -8.3266726846887e-17, 0.27777777777778
78309, 1.4608695652174, -0.016666666666667, 0.25
78310, 1.4391304347826, -0.016666666666667, 0.22222222222222
78311, 1.4608695652174, -7.8062556418956e-17, 0.22222222222222
78312, 1.4608695652174, -0.016666666666667, 0.19444444444444
78313, 1.4391304347826, -0.016666666666667, 0.16666666666667
78314, 1.4608695652174, -7.8062556418956e-17, 0.16666666666667
78315, 1.4608695652174, -0.016666666666667, 0.13888888888889
78316, 1.4391304347826, -0.016666666666667, 0.11111111111111
78317, 1.4608695652174, -7.8062556418956e-17, 0.11111111111111
78318, 1.4608695652174, -0.016666666666667, 0.083333333333333
78319, 1.4391304347826, -0.016666666666667, 0.055555555555556
78320, 1.4608695652174, -6.9388939039072e-17, 0.055555555555556
78321, 1.4608695652174, -0.016666666666667, 0.027777777777778
78322, 1.504347826087, -0.016666666666667, 0.47222222222222
78323, 1.4826086956522, -0.016666666666667, 0.44444444444444
78324, 1.504347826087, -7.2858385991026e-17, 0.44444444444444
78325, 1.504347826087, -0.016666666666667, 0.41666666666667
78326, 1.4826086956522, -0.016666666666667, 0.38888888888889
78327, 1.504347826087, -7.2858385991026e-17, 0.38888888888889
78328, 1.504347826087, -0.016666666666667, 0.36111111111111
78329, 1.4826086956522, -0.016666666666667, 0.33333333333333
78330, 1.504347826087, -8.5001450322864e-17, 0.33333333333333
78331, 1.504347826087, -0.016666666666667, 0.30555555555556
78332, 1.4826086956522, -0.016666666666667, 0.27777777777778
78333, 1.504347826087, -8.3266726846887e-17, 0.27777777777778
78334, 1.504347826087, -0.016666666666667, 0.25
78335, 1.4826086956522, -0.016666666666667, 0.22222222222222
78336, 1.504347826087, -7.632783294298e-17, 0.22222222222222
78337, 1.504347826087, -0.016666666666667, 0.19444444444444
78338, 1.4826086956522, -0.016666666666667, 0.16666666666667
78339, 1.504347826087, -7.9797279894933e-17, 0.16666666666667
78340, 1.504347826087, -0.016666666666667, 0.13888888888889
78341, 1.4826086956522, -0.016666666666667, 0.11111111111111
78342, 1.504347826087, -8.153200337091e-17, 0.11111111111111
78343, 1.504347826087, -0.016666666666667, 0.083333333333333
78344, 1.4826086956522, -0.016666666666667, 0.055555555555556
78345, 1.504347826087, -7.1123662515049e-17, 0.055555555555556
78346, 1.504347826087, -0.016666666666667, 0.027777777777778
78347, 1.5478260869565, -0.016666666666667, 0.47222222222222
78348, 1.5260869565217, -0.016666666666667, 0.44444444444444
78349, 1.5478260869565, -9.7144514654701e-17, 0.44444444444444
78350, 1.5478260869565, -0.016666666666667, 0.41666666666667
78351, 1.5260869565217, -0.016666666666667, 0.38888888888889
78352, 1.5478260869565, -9.0205620750794e-17, 0.38888888888889
78353, 1.5478260869565, -0.016666666666667, 0.36111111111111
78354, 1.5260869565217, -0.016666666666667, 0.33333333333333
78355, 1.5478260869565, -9.8879238130678e-17, 0.33333333333333
78356, 1.5478260869565, -0.016666666666667, 0.30555555555556
78357, 1.5260869565217, -0.016666666666667, 0.27777777777778
78358, 1.5478260869565, -9.5409791178724e-17, 0.27777777777778
78359, 1.5478260869565, -0.016666666666667, 0.25
78360, 1.5260869565217, -0.016666666666667, 0.22222222222222
78361, 1.5478260869565, -9.5409791178724e-17, 0.22222222222222
78362, 1.5478260869565, -0.016666666666667, 0.19444444444444
78363, 1.5260869565217, -0.016666666666667, 0.16666666666667
78364, 1.5478260869565, -9.3675067702748e-17, 0.16666666666667
78365, 1.5478260869565, -0.016666666666667, 0.13888888888889
78366, 1.5260869565217, -0.016666666666667, 0.11111111111111
78367, 1.5478260869565, -1.0061396160665e-16, 0.11111111111111
78368, 1.5478260869565, -0.016666666666667, 0.083333333333333
78369, 1.5260869565217, -0.016666666666667, 0.055555555555556
78370, 1.5478260869565, -9.1940344226771e-17, 0.055555555555556
78371, 1.5478260869565, -0.016666666666667, 0.027777777777778
78372, 1.5913043478261, -0.016666666666667, 0.47222222222222
78373, 1.5695652173913, -0.016666666666667, 0.44444444444444
78374, 1.5913043478261, -7.4593109467003e-17, 0.44444444444444
78375, 1.5913043478261, -0.016666666666667, 0.41666666666667
78376, 1.5695652173913, -0.016666666666667, 0.38888888888889
78377, 1.5913043478261, -7.2858385991026e-17, 0.38888888888889
78378, 1.5913043478261, -0.016666666666667, 0.36111111111111
78379, 1.5695652173913, -0.016666666666667, 0.33333333333333
78380, 1.5913043478261, -8.8470897274817e-17, 0.33333333333333
78381, 1.5913043478261, -0.016666666666667, 0.30555555555556
78382, 1.5695652173913, -0.016666666666667, 0.27777777777778
78383, 1.5913043478261, -8.3266726846887e-17, 0.27777777777778
78384, 1.5913043478261, -0.016666666666667, 0.25
78385, 1.5695652173913, -0.016666666666667, 0.22222222222222
78386, 1.5913043478261, -8.3266726846887e-17, 0.22222222222222
78387, 1.5913043478261, -0.016666666666667, 0.19444444444444
78388, 1.5695652173913, -0.016666666666667, 0.16666666666667
78389, 1.5913043478261, -8.673617379884e-17, 0.16666666666667
78390, 1.5913043478261, -0.016666666666667, 0.13888888888889
78391, 1.5695652173913, -0.016666666666667, 0.11111111111111
78392, 1.5913043478261, -8.673617379884e-17, 0.11111111111111
78393, 1.5913043478261, -0.016666666666667, 0.083333333333333
78394, 1.5695652173913, -0.016666666666667, 0.055555555555556
78395, 1.5913043478261, -7.4593109467003e-17, 0.055555555555556
78396, 1.5913043478261, -0.016666666666667, 0.027777777777778
78397, 1.6347826086957, -0.016666666666667, 0.47222222222222
78398, 1.6130434782609, -0.016666666666667, 0.44444444444444
78399, 1.6347826086957, -8.673617379884e-17, 0.44444444444444
78400, 1.6347826086957, -0.016666666666667, 0.41666666666667
78401, 1.6130434782609, -0.016666666666667, 0.38888888888889
78402, 1.6347826086957, -8.3266726846887e-17, 0.38888888888889
78403, 1.6347826086957, -0.016666666666667, 0.36111111111111
78404, 1.6130434782609, -0.016666666666667, 0.33333333333333
78405, 1.6347826086957, -9.0205620750794e-17, 0.33333333333333
78406, 1.6347826086957, -0.016666666666667, 0.30555555555556
78407, 1.6130434782609, -0.016666666666667, 0.27777777777778
78408, 1.6347826086957, -9.0205620750794e-17, 0.27777777777778
78409, 1.6347826086957, -0.016666666666667, 0.25
78410, 1.6130434782609, -0.016666666666667, 0.22222222222222
78411, 1.6347826086957, -8.8470897274817e-17, 0.22222222222222
78412, 1.6347826086957, -0.016666666666667, 0.19444444444444
78413, 1.6130434782609, -0.016666666666667, 0.16666666666667
78414, 1.6347826086957, -8.8470897274817e-17, 0.16666666666667
78415, 1.6347826086957, -0.016666666666667, 0.13888888888889
78416, 1.6130434782609, -0.016666666666667, 0.11111111111111
78417, 1.6347826086957, -8.8470897274817e-17, 0.11111111111111
78418, 1.6347826086957, -0.016666666666667, 0.083333333333333
78419, 1.6130434782609, -0.016666666666667, 0.055555555555556
78420, 1.6347826086957, -8.5001450322864e-17, 0.055555555555556
78421, 1.6347826086957, -0.016666666666667, 0.027777777777778
78422, 1.6782608695652, -0.016666666666667, 0.47222222222222
78423, 1.6565217391304, -0.016666666666667, 0.44444444444444
78424, 1.6782608695652, -8.153200337091e-17, 0.44444444444444
78425, 1.6782608695652, -0.016666666666667, 0.41666666666667
78426, 1.6565217391304, -0.016666666666667, 0.38888888888889
78427, 1.6782608695652, -8.5001450322864e-17, 0.38888888888889
78428, 1.6782608695652, -0.016666666666667, 0.36111111111111
78429, 1.6565217391304, -0.016666666666667, 0.33333333333333
78430, 1.6782608695652, -8.673617379884e-17, 0.33333333333333
78431, 1.6782608695652, -0.016666666666667, 0.30555555555556
78432, 1.6565217391304, -0.016666666666667, 0.27777777777778
78433, 1.6782608695652, -9.1940344226771e-17, 0.27777777777778
78434, 1.6782608695652, -0.016666666666667, 0.25
78435, 1.6565217391304, -0.016666666666667, 0.22222222222222
78436, 1.6782608695652, -8.673617379884e-17, 0.22222222222222
78437, 1.6782608695652, -0.016666666666667, 0.19444444444444
78438, 1.6565217391304, -0.016666666666667, 0.16666666666667
78439, 1.6782608695652, -8.8470897274817e-17, 0.16666666666667
78440, 1.6782608695652, -0.016666666666667, 0.13888888888889
78441, 1.6565217391304, -0.016666666666667, 0.11111111111111
78442, 1.6782608695652, -8.8470897274817e-17, 0.11111111111111
78443, 1.6782608695652, -0.016666666666667, 0.083333333333333
78444, 1.6565217391304, -0.016666666666667, 0.055555555555556
78445, 1.6782608695652, -8.153200337091e-17, 0.055555555555556
78446, 1.6782608695652, -0.016666666666667, 0.027777777777778
78447, 1.7217391304348, -0.016666666666667, 0.47222222222222
78448, 1.7, -0.016666666666667, 0.44444444444444
78449, 1.7217391304348, -7.4593109467003e-17, 0.44444444444444
78450, 1.7217391304348, -0.016666666666667, 0.41666666666667
78451, 1.7, -0.016666666666667, 0.38888888888889
78452, 1.7217391304348, -8.153200337091e-17, 0.38888888888889
78453, 1.7217391304348, -0.016666666666667, 0.36111111111111
78454, 1.7, -0.016666666666667, 0.33333333333333
78455, 1.7217391304348, -9.0205620750794e-17, 0.33333333333333
78456, 1.7217391304348, -0.016666666666667, 0.30555555555556
78457, 1.7, -0.016666666666667, 0.27777777777778
78458, 1.7217391304348, -8.5001450322864e-17, 0.27777777777778
78459, 1.7217391304348, -0.016666666666667, 0.25
78460, 1.7, -0.016666666666667, 0.22222222222222
78461, 1.7217391304348, -8.673617379884e-17, 0.22222222222222
78462, 1.7217391304348, -0.016666666666667, 0.19444444444444
78463, 1.7, -0.016666666666667, 0.16666666666667
78464, 1.7217391304348, -8.673617379884e-17, 0.16666666666667
78465, 1.7217391304348, -0.016666666666667, 0.13888888888889
78466, 1.7, -0.016666666666667, 0.11111111111111
78467, 1.7217391304348, -8.673617379884e-17, 0.11111111111111
78468, 1.7217391304348, -0.016666666666667, 0.083333333333333
78469, 1.7, -0.016666666666667, 0.055555555555556
78470, 1.7217391304348, -7.8062556418956e-17, 0.055555555555556
78471, 1.7217391304348, -0.016666666666667, 0.027777777777778
78472, 1.7652173913043, -0.016666666666667, 0.47222222222222
78473, 1.7434782608696, -0.016666666666667, 0.44444444444444
78474, 1.7652173913043, -6.9388939039072e-17, 0.44444444444444
78475, 1.7652173913043, -0.016666666666667, 0.41666666666667
78476, 1.7434782608696, -0.016666666666667, 0.38888888888889
78477, 1.7652173913043, -6.9388939039072e-17, 0.38888888888889
78478, 1.7652173913043, -0.016666666666667, 0.36111111111111
78479, 1.7434782608696, -0.016666666666667, 0.33333333333333
78480, 1.7652173913043, -7.1123662515049e-17, 0.33333333333333
78481, 1.7652173913043, -0.016666666666667, 0.30555555555556
78482, 1.7434782608696, -0.016666666666667, 0.27777777777778
78483, 1.7652173913043, -7.2858385991026e-17, 0.27777777777778
78484, 1.7652173913043, -0.016666666666667, 0.25
78485, 1.7434782608696, -0.016666666666667, 0.22222222222222
78486, 1.7652173913043, -7.2858385991026e-17, 0.22222222222222
78487, 1.7652173913043, -0.016666666666667, 0.19444444444444
78488, 1.7434782608696, -0.016666666666667, 0.16666666666667
78489, 1.7652173913043, -7.2858385991026e-17, 0.16666666666667
78490, 1.7652173913043, -0.016666666666667, 0.13888888888889
78491, 1.7434782608696, -0.016666666666667, 0.11111111111111
78492, 1.7652173913043, -7.4593109467003e-17, 0.11111111111111
78493, 1.7652173913043, -0.016666666666667, 0.083333333333333
78494, 1.7434782608696, -0.016666666666667, 0.055555555555556
78495, 1.7652173913043, -6.9388939039072e-17, 0.055555555555556
78496, 1.7652173913043, -0.016666666666667, 0.027777777777778
78497, 1.8086956521739, -0.016666666666667, 0.47222222222222
78498, 1.7869565217391, -0.016666666666667, 0.44444444444444
78499, 1.8086956521739, -5.0306980803327e-17, 0.44444444444444
78500, 1.8086956521739, -0.016666666666667, 0.41666666666667
78501, 1.7869565217391, -0.016666666666667, 0.38888888888889
78502, 1.8086956521739, -5.5511151231258e-17, 0.38888888888889
78503, 1.8086956521739, -0.016666666666667, 0.36111111111111
78504, 1.7869565217391, -0.016666666666667, 0.33333333333333
78505, 1.8086956521739, -5.8980598183211e-17, 0.33333333333333
78506, 1.8086956521739, -0.016666666666667, 0.30555555555556
78507, 1.7869565217391, -0.016666666666667, 0.27777777777778
78508, 1.8086956521739, -5.8980598183211e-17, 0.27777777777778
78509, 1.8086956521739, -0.016666666666667, 0.25
78510, 1.7869565217391, -0.016666666666667, 0.22222222222222
78511, 1.8086956521739, -5.5511151231258e-17, 0.22222222222222
78512, 1.8086956521739, -0.016666666666667, 0.19444444444444
78513, 1.7869565217391, -0.016666666666667, 0.16666666666667
78514, 1.8086956521739, -5.5511151231258e-17, 0.16666666666667
78515, 1.8086956521739, -0.016666666666667, 0.13888888888889
78516, 1.7869565217391, -0.016666666666667, 0.11111111111111
78517, 1.8086956521739, -6.2450045135165e-17, 0.11111111111111
78518, 1.8086956521739, -0.016666666666667, 0.083333333333333
78519, 1.7869565217391, -0.016666666666667, 0.055555555555556
78520, 1.8086956521739, -5.0306980803327e-17, 0.055555555555556
78521, 1.8086956521739, -0.016666666666667, 0.027777777777778
78522, 1.8521739130435, -0.016666666666667, 0.47222222222222
78523, 1.8304347826087, -0.016666666666667, 0.44444444444444
78524, 1.8521739130435, -6.4184768611142e-17, 0.44444444444444
78525, 1.8521739130435, -0.016666666666667, 0.41666666666667
78526, 1.8304347826087, -0.016666666666667, 0.38888888888889
78527, 1.8521739130435, -6.5919492087119e-17, 0.38888888888889
78528, 1.8521739130435, -0.016666666666667, 0.36111111111111
78529, 1.8304347826087, -0.016666666666667, 0.33333333333333
78530, 1.8521739130435, -6.7654215563095e-17, 0.33333333333333
78531, 1.8521739130435, -0.016666666666667, 0.30555555555556
78532, 1.8304347826087, -0.016666666666667, 0.27777777777778
78533, 1.8521739130435, -6.9388939039072e-17, 0.27777777777778
78534, 1.8521739130435, -0.016666666666667, 0.25
78535, 1.8304347826087, -0.016666666666667, 0.22222222222222
78536, 1.8521739130435, -6.9388939039072e-17, 0.22222222222222
78537, 1.8521739130435, -0.016666666666667, 0.19444444444444
78538, 1.8304347826087, -0.016666666666667, 0.16666666666667
78539, 1.8521739130435, -6.9388939039072e-17, 0.16666666666667
78540, 1.8521739130435, -0.016666666666667, 0.13888888888889
78541, 1.8304347826087, -0.016666666666667, 0.11111111111111
78542, 1.8521739130435, -7.1123662515049e-17, 0.11111111111111
78543, 1.8521739130435, -0.016666666666667, 0.083333333333333
78544, 1.8304347826087, -0.016666666666667, 0.055555555555556
78545, 1.8521739130435, -6.4184768611142e-17, 0.055555555555556
78546, 1.8521739130435, -0.016666666666667, 0.027777777777778
78547, 1.895652173913, -0.016666666666667, 0.47222222222222
78548, 1.8739130434783, -0.016666666666667, 0.44444444444444
78549, 1.895652173913, -6.2450045135165e-17, 0.44444444444444
78550, 1.895652173913, -0.016666666666667, 0.41666666666667
78551, 1.8739130434783, -0.016666666666667, 0.38888888888889
78552, 1.895652173913, -6.5919492087119e-17, 0.38888888888889
78553, 1.895652173913, -0.016666666666667, 0.36111111111111
78554, 1.8739130434783, -0.016666666666667, 0.33333333333333
78555, 1.895652173913, -6.9388939039072e-17, 0.33333333333333
78556, 1.895652173913, -0.016666666666667, 0.30555555555556
78557, 1.8739130434783, -0.016666666666667, 0.27777777777778
78558, 1.895652173913, -6.9388939039072e-17, 0.27777777777778
78559, 1.895652173913, -0.016666666666667, 0.25
78560, 1.8739130434783, -0.016666666666667, 0.22222222222222
78561, 1.895652173913, -6.5919492087119e-17, 0.22222222222222
78562, 1.895652173913, -0.016666666666667, 0.19444444444444
78563, 1.8739130434783, -0.016666666666667, 0.16666666666667
78564, 1.895652173913, -6.7654215563095e-17, 0.16666666666667
78565, 1.895652173913, -0.016666666666667, 0.13888888888889
78566, 1.8739130434783, -0.016666666666667, 0.11111111111111
78567, 1.895652173913, -7.1123662515049e-17, 0.11111111111111
78568, 1.895652173913, -0.016666666666667, 0.083333333333333
78569, 1.8739130434783, -0.016666666666667, 0.055555555555556
78570, 1.895652173913, -6.4184768611142e-17, 0.055555555555556
78571, 1.895652173913, -0.016666666666667, 0.027777777777778
78572, 1.9391304347826, -0.016666666666667, 0.47222222222222
78573, 1.9173913043478, -0.016666666666667, 0.44444444444444
78574, 1.9391304347826, -4.336808689942e-17, 0.44444444444444
78575, 1.9391304347826, -0.016666666666667, 0.41666666666667
78576, 1.9173913043478, -0.016666666666667, 0.38888888888889
78577, 1.9391304347826, -4.1633363423443e-17, 0.38888888888889
78578, 1.9391304347826, -0.016666666666667, 0.36111111111111
78579, 1.9173913043478, -0.016666666666667, 0.33333333333333
78580, 1.9391304347826, -4.8572257327351e-17, 0.33333333333333
78581, 1.9391304347826, -0.016666666666667, 0.30555555555556
78582, 1.9173913043478, -0.016666666666667, 0.27777777777778
78583, 1.9391304347826, -4.6837533851374e-17, 0.27777777777778
78584, 1.9391304347826, -0.016666666666667, 0.25
78585, 1.9173913043478, -0.016666666666667, 0.22222222222222
78586, 1.9391304347826, -4.336808689942e-17, 0.22222222222222
78587, 1.9391304347826, -0.016666666666667, 0.19444444444444
78588, 1.9173913043478, -0.016666666666667, 0.16666666666667
78589, 1.9391304347826, -4.5102810375397e-17, 0.16666666666667
78590, 1.9391304347826, -0.016666666666667, 0.13888888888889
78591, 1.9173913043478, -0.016666666666667, 0.11111111111111
78592, 1.9391304347826, -4.336808689942e-17, 0.11111111111111
78593, 1.9391304347826, -0.016666666666667, 0.083333333333333
78594, 1.9173913043478, -0.016666666666667, 0.055555555555556
78595, 1.9391304347826, -4.1633363423443e-17, 0.055555555555556
78596, 1.9391304347826, -0.016666666666667, 0.027777777777778
78597, 1.9826086956522, -0.016666666666667, 0.47222222222222
78598, 1.9608695652174, -0.016666666666667, 0.44444444444444
78599, 1.9826086956522, -5.0306980803327e-17, 0.44444444444444
78600, 1.9826086956522, -0.016666666666667, 0.41666666666667
78601, 1.9608695652174, -0.016666666666667, 0.38888888888889
78602, 1.9826086956522, -5.0306980803327e-17, 0.38888888888889
78603, 1.9826086956522, -0.016666666666667, 0.36111111111111
78604, 1.9608695652174, -0.016666666666667, 0.33333333333333
78605, 1.9826086956522, -5.5511151231258e-17, 0.33333333333333
78606, 1.9826086956522, -0.016666666666667, 0.30555555555556
78607, 1.9608695652174, -0.016666666666667, 0.27777777777778
78608, 1.9826086956522, -5.3776427755281e-17, 0.27777777777778
78609, 1.9826086956522, -0.016666666666667, 0.25
78610, 1.9608695652174, -0.016666666666667, 0.22222222222222
78611, 1.9826086956522, -5.7245874707235e-17, 0.22222222222222
78612, 1.9826086956522, -0.016666666666667, 0.19444444444444
78613, 1.9608695652174, -0.016666666666667, 0.16666666666667
78614, 1.9826086956522, -5.7245874707235e-17, 0.16666666666667
78615, 1.9826086956522, -0.016666666666667, 0.13888888888889
78616, 1.9608695652174, -0.016666666666667, 0.11111111111111
78617, 1.9826086956522, -5.8980598183211e-17, 0.11111111111111
78618, 1.9826086956522, -0.016666666666667, 0.083333333333333
78619, 1.9608695652174, -0.016666666666667, 0.055555555555556
78620, 1.9826086956522, -5.2041704279304e-17, 0.055555555555556
78621, 1.9826086956522, -0.016666666666667, 0.027777777777778
78622, 2.0260869565217, -0.016666666666667, 0.47222222222222
78623, 2.004347826087, -0.016666666666667, 0.44444444444444
78624, 2.0260869565217, -3.6429192995513e-17, 0.44444444444444
78625, 2.0260869565217, -0.016666666666667, 0.41666666666667
78626, 2.004347826087, -0.016666666666667, 0.38888888888889
78627, 2.0260869565217, -4.6837533851374e-17, 0.38888888888889
78628, 2.0260869565217, -0.016666666666667, 0.36111111111111
78629, 2.004347826087, -0.016666666666667, 0.33333333333333
78630, 2.0260869565217, -4.5102810375397e-17, 0.33333333333333
78631, 2.0260869565217, -0.016666666666667, 0.30555555555556
78632, 2.004347826087, -0.016666666666667, 0.27777777777778
78633, 2.0260869565217, -4.6837533851374e-17, 0.27777777777778
78634, 2.0260869565217, -0.016666666666667, 0.25
78635, 2.004347826087, -0.016666666666667, 0.22222222222222
78636, 2.0260869565217, -4.6837533851374e-17, 0.22222222222222
78637, 2.0260869565217, -0.016666666666667, 0.19444444444444
78638, 2.004347826087, -0.016666666666667, 0.16666666666667
78639, 2.0260869565217, -4.5102810375397e-17, 0.16666666666667
78640, 2.0260869565217, -0.016666666666667, 0.13888888888889
78641, 2.004347826087, -0.016666666666667, 0.11111111111111
78642, 2.0260869565217, -4.5102810375397e-17, 0.11111111111111
78643, 2.0260869565217, -0.016666666666667, 0.083333333333333
78644, 2.004347826087, -0.016666666666667, 0.055555555555556
78645, 2.0260869565217, -3.6429192995513e-17, 0.055555555555556
78646, 2.0260869565217, -0.016666666666667, 0.027777777777778
78647, 2.0695652173913, -0.016666666666667, 0.47222222222222
78648, 2.0478260869565, -0.016666666666667, 0.44444444444444
78649, 2.0695652173913, -4.336808689942e-17, 0.44444444444444
78650, 2.0695652173913, -0.016666666666667, 0.41666666666667
78651, 2.0478260869565, -0.016666666666667, 0.38888888888889
78652, 2.0695652173913, -5.0306980803327e-17, 0.38888888888889
78653, 2.0695652173913, -0.016666666666667, 0.36111111111111
78654, 2.0478260869565, -0.016666666666667, 0.33333333333333
78655, 2.0695652173913, -5.7245874707235e-17, 0.33333333333333
78656, 2.0695652173913, -0.016666666666667, 0.30555555555556
78657, 2.0478260869565, -0.016666666666667, 0.27777777777778
78658, 2.0695652173913, -4.6837533851374e-17, 0.27777777777778
78659, 2.0695652173913, -0.016666666666667, 0.25
78660, 2.0478260869565, -0.016666666666667, 0.22222222222222
78661, 2.0695652173913, -5.2041704279304e-17, 0.22222222222222
78662, 2.0695652173913, -0.016666666666667, 0.19444444444444
78663, 2.0478260869565, -0.016666666666667, 0.16666666666667
78664, 2.0695652173913, -5.2041704279304e-17, 0.16666666666667
78665, 2.0695652173913, -0.016666666666667, 0.13888888888889
78666, 2.0478260869565, -0.016666666666667, 0.11111111111111
78667, 2.0695652173913, -5.3776427755281e-17, 0.11111111111111
78668, 2.0695652173913, -0.016666666666667, 0.083333333333333
78669, 2.0478260869565, -0.016666666666667, 0.055555555555556
78670, 2.0695652173913, -4.6837533851374e-17, 0.055555555555556
78671, 2.0695652173913, -0.016666666666667, 0.027777777777778
78672, 2.1130434782609, -0.016666666666667, 0.47222222222222
78673, 2.0913043478261, -0.016666666666667, 0.44444444444444
78674, 2.1130434782609, -3.1225022567583e-17, 0.44444444444444
78675, 2.1130434782609, -0.016666666666667, 0.41666666666667
78676, 2.0913043478261, -0.016666666666667, 0.38888888888889
78677, 2.1130434782609, -3.816391647149e-17, 0.38888888888889
78678, 2.1130434782609, -0.016666666666667, 0.36111111111111
78679, 2.0913043478261, -0.016666666666667, 0.33333333333333
78680, 2.1130434782609, -4.1633363423443e-17, 0.33333333333333
78681, 2.1130434782609, -0.016666666666667, 0.30555555555556
78682, 2.0913043478261, -0.016666666666667, 0.27777777777778
78683, 2.1130434782609, -4.6837533851374e-17, 0.27777777777778
78684, 2.1130434782609, -0.016666666666667, 0.25
78685, 2.0913043478261, -0.016666666666667, 0.22222222222222
78686, 2.1130434782609, -3.6429192995513e-17, 0.22222222222222
78687, 2.1130434782609, -0.016666666666667, 0.19444444444444
78688, 2.0913043478261, -0.016666666666667, 0.16666666666667
78689, 2.1130434782609, -3.4694469519536e-17, 0.16666666666667
78690, 2.1130434782609, -0.016666666666667, 0.13888888888889
78691, 2.0913043478261, -0.016666666666667, 0.11111111111111
78692, 2.1130434782609, -3.9898639947467e-17, 0.11111111111111
78693, 2.1130434782609, -0.016666666666667, 0.083333333333333
78694, 2.0913043478261, -0.016666666666667, 0.055555555555556
78695, 2.1130434782609, -3.1225022567583e-17, 0.055555555555556
78696, 2.1130434782609, -0.016666666666667, 0.027777777777778
78697, 2.1565217391304, -0.016666666666667, 0.47222222222222
78698, 2.1347826086957, -0.016666666666667, 0.44444444444444
78699, 2.1565217391304, -3.816391647149e-17, 0.44444444444444
78700, 2.1565217391304, -0.016666666666667, 0.41666666666667
78701, 2.1347826086957, -0.016666666666667, 0.38888888888889
78702, 2.1565217391304, -4.5102810375397e-17, 0.38888888888889
78703, 2.1565217391304, -0.016666666666667, 0.36111111111111
78704, 2.1347826086957, -0.016666666666667, 0.33333333333333
78705, 2.1565217391304, -4.336808689942e-17, 0.33333333333333
78706, 2.1565217391304, -0.016666666666667, 0.30555555555556
78707, 2.1347826086957, -0.016666666666667, 0.27777777777778
78708, 2.1565217391304, -4.5102810375397e-17, 0.27777777777778
78709, 2.1565217391304, -0.016666666666667, 0.25
78710, 2.1347826086957, -0.016666666666667, 0.22222222222222
78711, 2.1565217391304, -4.5102810375397e-17, 0.22222222222222
78712, 2.1565217391304, -0.016666666666667, 0.19444444444444
78713, 2.1347826086957, -0.016666666666667, 0.16666666666667
78714, 2.1565217391304, -4.336808689942e-17, 0.16666666666667
78715, 2.1565217391304, -0.016666666666667, 0.13888888888889
78716, 2.1347826086957, -0.016666666666667, 0.11111111111111
78717, 2.1565217391304, -5.0306980803327e-17, 0.11111111111111
78718, 2.1565217391304, -0.016666666666667, 0.083333333333333
78719, 2.1347826086957, -0.016666666666667, 0.055555555555556
78720, 2.1565217391304, -3.6429192995513e-17, 0.055555555555556
78721, 2.1565217391304, -0.016666666666667, 0.027777777777778
78722, 2.1782608695652, -0.016666666666667, 0.44444444444444
78723, 2.1782608695652, -0.016666666666667, 0.38888888888889
78724, 2.1782608695652, -0.016666666666667, 0.33333333333333
78725, 2.1782608695652, -0.016666666666667, 0.27777777777778
78726, 2.1782608695652, -0.016666666666667, 0.22222222222222
78727, 2.1782608695652, -0.016666666666667, 0.16666666666667
78728, 2.1782608695652, -0.016666666666667, 0.11111111111111
78729, 2.1782608695652, -0.016666666666667, 0.055555555555556
78730, 1.2434782608696, -0.033333333333333, 0.44444444444444
78731, 1.2434782608696, -0.033333333333333, 0.38888888888889
78732, 1.2434782608696, -0.033333333333333, 0.33333333333333
78733, 1.2434782608696, -0.033333333333333, 0.27777777777778
78734, 1.2434782608696, -0.033333333333333, 0.22222222222222
78735, 1.2434782608696, -0.033333333333333, 0.16666666666667
78736, 1.2434782608696, -0.033333333333333, 0.11111111111111
78737, 1.2434782608696, -0.033333333333333, 0.055555555555556
78738, 1.2869565217391, -0.033333333333333, 0.44444444444444
78739, 1.2869565217391, -0.033333333333333, 0.38888888888889
78740, 1.2869565217391, -0.033333333333333, 0.33333333333333
78741, 1.2869565217391, -0.033333333333333, 0.27777777777778
78742, 1.2869565217391, -0.033333333333333, 0.22222222222222
78743, 1.2869565217391, -0.033333333333333, 0.16666666666667
78744, 1.2869565217391, -0.033333333333333, 0.11111111111111
78745, 1.2869565217391, -0.033333333333333, 0.055555555555556
78746, 1.3304347826087, -0.033333333333333, 0.44444444444444
78747, 1.3304347826087, -0.033333333333333, 0.38888888888889
78748, 1.3304347826087, -0.033333333333333, 0.33333333333333
78749, 1.3304347826087, -0.033333333333333, 0.27777777777778
78750, 1.3304347826087, -0.033333333333333, 0.22222222222222
78751, 1.3304347826087, -0.033333333333333, 0.16666666666667
78752, 1.3304347826087, -0.033333333333333, 0.11111111111111
78753, 1.3304347826087, -0.033333333333333, 0.055555555555556
78754, 1.3739130434783, -0.033333333333333, 0.44444444444444
78755, 1.3739130434783, -0.033333333333333, 0.38888888888889
78756, 1.3739130434783, -0.033333333333333, 0.33333333333333
78757, 1.3739130434783, -0.033333333333333, 0.27777777777778
78758, 1.3739130434783, -0.033333333333333, 0.22222222222222
78759, 1.3739130434783, -0.033333333333333, 0.16666666666667
78760, 1.3739130434783, -0.033333333333333, 0.11111111111111
78761, 1.3739130434783, -0.033333333333333, 0.055555555555556
78762, 1.4173913043478, -0.033333333333333, 0.44444444444444
78763, 1.4173913043478, -0.033333333333333, 0.38888888888889
78764, 1.4173913043478, -0.033333333333333, 0.33333333333333
78765, 1.4173913043478, -0.033333333333333, 0.27777777777778
78766, 1.4173913043478, -0.033333333333333, 0.22222222222222
78767, 1.4173913043478, -0.033333333333333, 0.16666666666667
78768, 1.4173913043478, -0.033333333333333, 0.11111111111111
78769, 1.4173913043478, -0.033333333333333, 0.055555555555556
78770, 1.4608695652174, -0.033333333333333, 0.44444444444444
78771, 1.4608695652174, -0.033333333333333, 0.38888888888889
78772, 1.4608695652174, -0.033333333333333, 0.33333333333333
78773, 1.4608695652174, -0.033333333333333, 0.27777777777778
78774, 1.4608695652174, -0.033333333333333, 0.22222222222222
78775, 1.4608695652174, -0.033333333333333, 0.16666666666667
78776, 1.4608695652174, -0.033333333333333, 0.11111111111111
78777, 1.4608695652174, -0.033333333333333, 0.055555555555556
78778, 1.504347826087, -0.033333333333333, 0.44444444444444
78779, 1.504347826087, -0.033333333333333, 0.38888888888889
78780, 1.504347826087, -0.033333333333333, 0.33333333333333
78781, 1.504347826087, -0.033333333333333, 0.27777777777778
78782, 1.504347826087, -0.033333333333333, 0.22222222222222
78783, 1.504347826087, -0.033333333333333, 0.16666666666667
78784, 1.504347826087, -0.033333333333333, 0.11111111111111
78785, 1.504347826087, -0.033333333333333, 0.055555555555556
78786, 1.5478260869565, -0.033333333333333, 0.44444444444444
78787, 1.5478260869565, -0.033333333333333, 0.38888888888889
78788, 1.5478260869565, -0.033333333333333, 0.33333333333333
78789, 1.5478260869565, -0.033333333333333, 0.27777777777778
78790, 1.5478260869565, -0.033333333333333, 0.22222222222222
78791, 1.5478260869565, -0.033333333333333, 0.16666666666667
78792, 1.5478260869565, -0.033333333333333, 0.11111111111111
78793, 1.5478260869565, -0.033333333333333, 0.055555555555556
78794, 1.5913043478261, -0.033333333333333, 0.44444444444444
78795, 1.5913043478261, -0.033333333333333, 0.38888888888889
78796, 1.5913043478261, -0.033333333333333, 0.33333333333333
78797, 1.5913043478261, -0.033333333333333, 0.27777777777778
78798, 1.5913043478261, -0.033333333333333, 0.22222222222222
78799, 1.5913043478261, -0.033333333333333, 0.16666666666667
78800, 1.5913043478261, -0.033333333333333, 0.11111111111111
78801, 1.5913043478261, -0.033333333333333, 0.055555555555556
78802, 1.6347826086957, -0.033333333333333, 0.44444444444444
78803, 1.6347826086957, -0.033333333333333, 0.38888888888889
78804, 1.6347826086957, -0.033333333333333, 0.33333333333333
78805, 1.6347826086957, -0.033333333333333, 0.27777777777778
78806, 1.6347826086957, -0.033333333333333, 0.22222222222222
78807, 1.6347826086957, -0.033333333333333, 0.16666666666667
78808, 1.6347826086957, -0.033333333333333, 0.11111111111111
78809, 1.6347826086957, -0.033333333333333, 0.055555555555556
78810, 1.6782608695652, -0.033333333333333, 0.44444444444444
78811, 1.6782608695652, -0.033333333333333, 0.38888888888889
78812, 1.6782608695652, -0.033333333333333, 0.33333333333333
78813, 1.6782608695652, -0.033333333333333, 0.27777777777778
78814, 1.6782608695652, -0.033333333333333, 0.22222222222222
78815, 1.6782608695652, -0.033333333333333, 0.16666666666667
78816, 1.6782608695652, -0.033333333333333, 0.11111111111111
78817, 1.6782608695652, -0.033333333333333, 0.055555555555556
78818, 1.7217391304348, -0.033333333333333, 0.44444444444444
78819, 1.7217391304348, -0.033333333333333, 0.38888888888889
78820, 1.7217391304348, -0.033333333333333, 0.33333333333333
78821, 1.7217391304348, -0.033333333333333, 0.27777777777778
78822, 1.7217391304348, -0.033333333333333, 0.22222222222222
78823, 1.7217391304348, -0.033333333333333, 0.16666666666667
78824, 1.7217391304348, -0.033333333333333, 0.11111111111111
78825, 1.7217391304348, -0.033333333333333, 0.055555555555556
78826, 1.7652173913043, -0.033333333333333, 0.44444444444444
78827, 1.7652173913043, -0.033333333333333, 0.38888888888889
78828, 1.7652173913043, -0.033333333333333, 0.33333333333333
78829, 1.7652173913043, -0.033333333333333, 0.27777777777778
78830, 1.7652173913043, -0.033333333333333, 0.22222222222222
78831, 1.7652173913043, -0.033333333333333, 0.16666666666667
78832, 1.7652173913043, -0.033333333333333, 0.11111111111111
78833, 1.7652173913043, -0.033333333333333, 0.055555555555556
78834, 1.8086956521739, -0.033333333333333, 0.44444444444444
78835, 1.8086956521739, -0.033333333333333, 0.38888888888889
78836, 1.8086956521739, -0.033333333333333, 0.33333333333333
78837, 1.8086956521739, -0.033333333333333, 0.27777777777778
78838, 1.8086956521739, -0.033333333333333, 0.22222222222222
78839, 1.8086956521739, -0.033333333333333, 0.16666666666667
78840, 1.8086956521739, -0.033333333333333, 0.11111111111111
78841, 1.8086956521739, -0.033333333333333, 0.055555555555556
78842, 1.8521739130435, -0.033333333333333, 0.44444444444444
78843, 1.8521739130435, -0.033333333333333, 0.38888888888889
78844, 1.8521739130435, -0.033333333333333, 0.33333333333333
78845, 1.8521739130435, -0.033333333333333, 0.27777777777778
78846, 1.8521739130435, -0.033333333333333, 0.22222222222222
78847, 1.8521739130435, -0.033333333333333, 0.16666666666667
78848, 1.8521739130435, -0.033333333333333, 0.11111111111111
78849, 1.8521739130435, -0.033333333333333, 0.055555555555556
78850, 1.895652173913, -0.033333333333333, 0.44444444444444
78851, 1.895652173913, -0.033333333333333, 0.38888888888889
78852, 1.895652173913, -0.033333333333333, 0.33333333333333
78853, 1.895652173913, -0.033333333333333, 0.27777777777778
78854, 1.895652173913, -0.033333333333333, 0.22222222222222
78855, 1.895652173913, -0.033333333333333, 0.16666666666667
78856, 1.895652173913, -0.033333333333333, 0.11111111111111
78857, 1.895652173913, -0.033333333333333, 0.055555555555556
78858, 1.9391304347826, -0.033333333333333, 0.44444444444444
78859, 1.9391304347826, -0.033333333333333, 0.38888888888889
78860, 1.9391304347826, -0.033333333333333, 0.33333333333333
78861, 1.9391304347826, -0.033333333333333, 0.27777777777778
78862, 1.9391304347826, -0.033333333333333, 0.22222222222222
78863, 1.9391304347826, -0.033333333333333, 0.16666666666667
78864, 1.9391304347826, -0.033333333333333, 0.11111111111111
78865, 1.9391304347826, -0.033333333333333, 0.055555555555556
78866, 1.9826086956522, -0.033333333333333, 0.44444444444444
78867, 1.9826086956522, -0.033333333333333, 0.38888888888889
78868, 1.9826086956522, -0.033333333333333, 0.33333333333333
78869, 1.9826086956522, -0.033333333333333, 0.27777777777778
78870, 1.9826086956522, -0.033333333333333, 0.22222222222222
78871, 1.9826086956522, -0.033333333333333, 0.16666666666667
78872, 1.9826086956522, -0.033333333333333, 0.11111111111111
78873, 1.9826086956522, -0.033333333333333, 0.055555555555556
78874, 2.0260869565217, -0.033333333333333, 0.44444444444444
78875, 2.0260869565217, -0.033333333333333, 0.38888888888889
78876, 2.0260869565217, -0.033333333333333, 0.33333333333333
78877, 2.0260869565217, -0.033333333333333, 0.27777777777778
78878, 2.0260869565217, -0.033333333333333, 0.22222222222222
78879, 2.0260869565217, -0.033333333333333, 0.16666666666667
78880, 2.0260869565217, -0.033333333333333, 0.11111111111111
78881, 2.0260869565217, -0.033333333333333, 0.055555555555556
78882, 2.0695652173913, -0.033333333333333, 0.44444444444444
78883, 2.0695652173913, -0.033333333333333, 0.38888888888889
78884, 2.0695652173913, -0.033333333333333, 0.33333333333333
78885, 2.0695652173913, -0.033333333333333, 0.27777777777778
78886, 2.0695652173913, -0.033333333333333, 0.22222222222222
78887, 2.0695652173913, -0.033333333333333, 0.16666666666667
78888, 2.0695652173913, -0.033333333333333, 0.11111111111111
78889, 2.0695652173913, -0.033333333333333, 0.055555555555556
78890, 2.1130434782609, -0.033333333333333, 0.44444444444444
78891, 2.1130434782609, -0.033333333333333, 0.38888888888889
78892, 2.1130434782609, -0.033333333333333, 0.33333333333333
78893, 2.1130434782609, -0.033333333333333, 0.27777777777778
78894, 2.1130434782609, -0.033333333333333, 0.22222222222222
78895, 2.1130434782609, -0.033333333333333, 0.16666666666667
78896, 2.1130434782609, -0.033333333333333, 0.11111111111111
78897, 2.1130434782609, -0.033333333333333, 0.055555555555556
78898, 2.1565217391304, -0.033333333333333, 0.44444444444444
78899, 2.1565217391304, -0.033333333333333, 0.38888888888889
78900, 2.1565217391304, -0.033333333333333, 0.33333333333333
78901, 2.1565217391304, -0.033333333333333, 0.27777777777778
78902, 2.1565217391304, -0.033333333333333, 0.22222222222222
78903, 2.1565217391304, -0.033333333333333, 0.16666666666667
78904, 2.1565217391304, -0.033333333333333, 0.11111111111111
78905, 2.1565217391304, -0.033333333333333, 0.055555555555556
78906, 2.25, 0.016666666666667, 0.44444444444444
78907, 2.25, 0.016666666666667, 0.38888888888889
78908, 2.25, 0.016666666666667, 0.33333333333333
78909, 2.25, 0.016666666666667, 0.27777777777778
78910, 2.25, 0.016666666666667, 0.22222222222222
78911, 2.25, 0.016666666666667, 0.16666666666667
78912, 2.25, 0.016666666666667, 0.11111111111111
78913, 2.25, 0.016666666666667, 0.055555555555556
78914, 2.25, -0.016666666666667, 0.44444444444444
78915, 2.25, -0.016666666666667, 0.38888888888889
78916, 2.25, -0.016666666666667, 0.33333333333333
78917, 2.25, -0.016666666666667, 0.27777777777778
78918, 2.25, -0.016666666666667, 0.22222222222222
78919, 2.25, -0.016666666666667, 0.16666666666667
78920, 2.25, -0.016666666666667, 0.11111111111111
78921, 2.25, -0.016666666666667, 0.055555555555556
78922, 2.25, 0.016666666666667, 0.47222222222222
78923, 2.25, 0.033333333333333, 0.44444444444444
78924, 2.225, 0.016666666666667, 0.44444444444444
78925, 2.25, 0.016666666666667, 0.41666666666667
78926, 2.25, 0.033333333333333, 0.38888888888889
78927, 2.225, 0.016666666666667, 0.38888888888889
78928, 2.25, 0.016666666666667, 0.36111111111111
78929, 2.25, 0.033333333333333, 0.33333333333333
78930, 2.225, 0.016666666666667, 0.33333333333333
78931, 2.25, 0.016666666666667, 0.30555555555556
78932, 2.25, 0.033333333333333, 0.27777777777778
78933, 2.225, 0.016666666666667, 0.27777777777778
78934, 2.25, 0.016666666666667, 0.25
78935, 2.25, 0.033333333333333, 0.22222222222222
78936, 2.225, 0.016666666666667, 0.22222222222222
78937, 2.25, 0.016666666666667, 0.19444444444444
78938, 2.25, 0.033333333333333, 0.16666666666667
78939, 2.225, 0.016666666666667, 0.16666666666667
78940, 2.25, 0.016666666666667, 0.13888888888889
78941, 2.25, 0.033333333333333, 0.11111111111111
78942, 2.225, 0.016666666666667, 0.11111111111111
78943, 2.25, 0.016666666666667, 0.083333333333333
78944, 2.25, 0.033333333333333, 0.055555555555556
78945, 2.225, 0.016666666666667, 0.055555555555556
78946, 2.25, 0.016666666666667, 0.027777777777778
78947, 2.25, -0.016666666666667, 0.47222222222222
78948, 2.25, -1.2316536679435e-16, 0.44444444444444
78949, 2.225, -0.016666666666667, 0.44444444444444
78950, 2.25, -0.016666666666667, 0.41666666666667
78951, 2.25, -1.3183898417424e-16, 0.38888888888889
78952, 2.225, -0.016666666666667, 0.38888888888889
78953, 2.25, -0.016666666666667, 0.36111111111111
78954, 2.25, -1.3010426069826e-16, 0.33333333333333
78955, 2.225, -0.016666666666667, 0.33333333333333
78956, 2.25, -0.016666666666667, 0.30555555555556
78957, 2.25, -1.2143064331838e-16, 0.27777777777778
78958, 2.225, -0.016666666666667, 0.27777777777778
78959, 2.25, -0.016666666666667, 0.25
78960, 2.25, -1.2490009027033e-16, 0.22222222222222
78961, 2.225, -0.016666666666667, 0.22222222222222
78962, 2.25, -0.016666666666667, 0.19444444444444
78963, 2.25, -1.2836953722228e-16, 0.16666666666667
78964, 2.225, -0.016666666666667, 0.16666666666667
78965, 2.25, -0.016666666666667, 0.13888888888889
78966, 2.25, -1.3010426069826e-16, 0.11111111111111
78967, 2.225, -0.016666666666667, 0.11111111111111
78968, 2.25, -0.016666666666667, 0.083333333333333
78969, 2.25, -1.2836953722228e-16, 0.055555555555556
78970, 2.225, -0.016666666666667, 0.055555555555556
78971, 2.25, -0.016666666666667, 0.027777777777778
78972, 2.25, -0.033333333333333, 0.44444444444444
78973, 2.25, -0.033333333333333, 0.38888888888889
78974, 2.25, -0.033333333333333, 0.33333333333333
78975, 2.25, -0.033333333333333, 0.27777777777778
78976, 2.25, -0.033333333333333, 0.22222222222222
78977, 2.25, -0.033333333333333, 0.16666666666667
78978, 2.25, -0.033333333333333, 0.11111111111111
78979, 2.25, -0.033333333333333, 0.055555555555556
78980, 2.275, 0.016666666666667, 0.44444444444444
78981, 2.275, 0.016666666666667, 0.38888888888889
78982, 2.275, 0.016666666666667, 0.33333333333333
78983, 2.275, 0.016666666666667, 0.27777777777778
78984, 2.275, 0.016666666666667, 0.22222222222222
78985, 2.275, 0.016666666666667, 0.16666666666667
78986, 2.275, 0.016666666666667, 0.11111111111111
78987, 2.275, 0.016666666666667, 0.055555555555556
78988, 2.275, -0.016666666666667, 0.44444444444444
78989, 2.275, -0.016666666666667, 0.38888888888889
78990, 2.275, -0.016666666666667, 0.33333333333333
78991, 2.275, -0.016666666666667, 0.27777777777778
78992, 2.275, -0.016666666666667, 0.22222222222222
78993, 2.275, -0.016666666666667, 0.16666666666667
78994, 2.275, -0.016666666666667, 0.11111111111111
78995, 2.275, -0.016666666666667, 0.055555555555556
78996, -0.05, -0.016666666666667, 0.44444444444444
78997, -0.05, 0.016666666666667, 0.44444444444444
78998, -0.05, -0.016666666666667, 0.38888888888889
78999, -0.05, 0.016666666666667, 0.38888888888889
79000, -0.05, -0.016666666666667, 0.33333333333333
79001, -0.05, 0.016666666666667, 0.33333333333333
79002, -0.05, -0.016666666666667, 0.27777777777778
79003, -0.05, 0.016666666666667, 0.27777777777778
79004, -0.05, -0.016666666666667, 0.22222222222222
79005, -0.05, 0.016666666666667, 0.22222222222222
79006, -0.05, -0.016666666666667, 0.16666666666667
79007, -0.05, 0.016666666666667, 0.16666666666667
79008, -0.05, -0.016666666666667, 0.11111111111111
79009, -0.05, 0.016666666666667, 0.11111111111111
79010, -0.05, -0.016666666666667, 0.055555555555556
79011, -0.05, 0.016666666666667, 0.055555555555556
79012, -0.05, -0.033333333333333, 0.44444444444444
79013, -0.05, -0.016666666666667, 0.47222222222222
79014, -0.025, -0.016666666666667, 0.44444444444444
79015, -0.05, 5.7245874707235e-17, 0.44444444444444
79016, -0.05, 0.016666666666667, 0.47222222222222
79017, -0.025, 0.016666666666667, 0.44444444444444
79018, -0.05, 0.033333333333333, 0.44444444444444
79019, -0.05, -0.033333333333333, 0.38888888888889
79020, -0.05, -0.016666666666667, 0.41666666666667
79021, -0.025, -0.016666666666667, 0.38888888888889
79022, -0.05, 5.8980598183211e-17, 0.38888888888889
79023, -0.05, 0.016666666666667, 0.41666666666667
79024, -0.025, 0.016666666666667, 0.38888888888889
79025, -0.05, 0.033333333333333, 0.38888888888889
79026, -0.05, -0.033333333333333, 0.33333333333333
79027, -0.05, -0.016666666666667, 0.36111111111111
79028, -0.025, -0.016666666666667, 0.33333333333333
79029, -0.05, 6.0715321659188e-17, 0.33333333333333
79030, -0.05, 0.016666666666667, 0.36111111111111
79031, -0.025, 0.016666666666667, 0.33333333333333
79032, -0.05, 0.033333333333333, 0.33333333333333
79033, -0.05, -0.033333333333333, 0.27777777777778
79034, -0.05, -0.016666666666667, 0.30555555555556
79035, -0.025, -0.016666666666667, 0.27777777777778
79036, -0.05, 5.8980598183211e-17, 0.27777777777778
79037, -0.05, 0.016666666666667, 0.30555555555556
79038, -0.025, 0.016666666666667, 0.27777777777778
79039, -0.05, 0.033333333333333, 0.27777777777778
79040, -0.05, -0.033333333333333, 0.22222222222222
79041, -0.05, -0.016666666666667, 0.25
79042, -0.025, -0.016666666666667, 0.22222222222222
79043, -0.05, 5.8980598183211e-17, 0.22222222222222
79044, -0.05, 0.016666666666667, 0.25
79045, -0.025, 0.016666666666667, 0.22222222222222
79046, -0.05, 0.033333333333333, 0.22222222222222
79047, -0.05, -0.033333333333333, 0.16666666666667
79048, -0.05, -0.016666666666667, 0.19444444444444
79049, -0.025, -0.016666666666667, 0.16666666666667
79050, -0.05, 6.5919492087119e-17, 0.16666666666667
79051, -0.05, 0.016666666666667, 0.19444444444444
79052, -0.025, 0.016666666666667, 0.16666666666667
79053, -0.05, 0.033333333333333, 0.16666666666667
79054, -0.05, -0.033333333333333, 0.11111111111111
79055, -0.05, -0.016666666666667, 0.13888888888889
79056, -0.025, -0.016666666666667, 0.11111111111111
79057, -0.05, 5.8980598183211e-17, 0.11111111111111
79058, -0.05, 0.016666666666667, 0.13888888888889
79059, -0.025, 0.016666666666667, 0.11111111111111
79060, -0.05, 0.033333333333333, 0.11111111111111
79061, -0.05, -0.033333333333333, 0.055555555555556
79062, -0.05, -0.016666666666667, 0.083333333333333
79063, -0.025, -0.016666666666667, 0.055555555555556
79064, -0.05, 5.7245874707235e-17, 0.055555555555556
79065, -0.05, 0.016666666666667, 0.083333333333333
79066, -0.025, 0.016666666666667, 0.055555555555556
79067, -0.05, 0.033333333333333, 0.055555555555556
79068, -0.05, -0.016666666666667, 0.027777777777778
79069, -0.05, 0.016666666666667, 0.027777777777778
79070, -0.075, -0.016666666666667, 0.44444444444444
79071, -0.075, 0.016666666666667, 0.44444444444444
79072, -0.075, -0.016666666666667, 0.38888888888889
79073, -0.075, 0.016666666666667, 0.38888888888889
79074, -0.075, -0.016666666666667, 0.33333333333333
79075, -0.075, 0.016666666666667, 0.33333333333333
79076, -0.075, -0.016666666666667, 0.27777777777778
79077, -0.075, 0.016666666666667, 0.27777777777778
79078, -0.075, -0.016666666666667, 0.22222222222222
79079, -0.075, 0.016666666666667, 0.22222222222222
79080, -0.075, -0.016666666666667, 0.16666666666667
79081, -0.075, 0.016666666666667, 0.16666666666667
79082, -0.075, -0.016666666666667, 0.11111111111111
79083, -0.075, 0.016666666666667, 0.11111111111111
79084, -0.075, -0.016666666666667, 0.055555555555556
79085, -0.075, 0.016666666666667, 0.055555555555556
79086, 0.95652173913043, 1.6, 0.055555555555556
79087, 0.95652173913044, 1.6, 0.11111111111111
79088, 0.95652173913043, 1.6, 0.16666666666667
79089, 0.95652173913043, 1.6, 0.22222222222222
79090, 0.95652173913044, 1.6, 0.27777777777778
79091, 0.95652173913043, 1.6, 0.33333333333333
79092, 0.95652173913043, 1.6, 0.38888888888889
79093, 0.95652173913044, 1.6, 0.44444444444444
79094, 0.91304347826087, 1.6, 0.055555555555556
79095, 0.91304347826087, 1.6, 0.11111111111111
79096, 0.91304347826087, 1.6, 0.16666666666667
79097, 0.91304347826087, 1.6, 0.22222222222222
79098, 0.91304347826087, 1.6, 0.27777777777778
79099, 0.91304347826087, 1.6, 0.33333333333333
79100, 0.91304347826087, 1.6, 0.38888888888889
79101, 0.91304347826087, 1.6, 0.44444444444444
79102, 0.8695652173913, 1.6, 0.055555555555556
79103, 0.8695652173913, 1.6, 0.11111111111111
79104, 0.8695652173913, 1.6, 0.16666666666667
79105, 0.8695652173913, 1.6, 0.22222222222222
79106, 0.8695652173913, 1.6, 0.27777777777778
79107, 0.8695652173913, 1.6, 0.33333333333333
79108, 0.8695652173913, 1.6, 0.38888888888889
79109, 0.8695652173913, 1.6, 0.44444444444444
79110, 0.82608695652174, 1.6, 0.055555555555556
79111, 0.82608695652174, 1.6, 0.11111111111111
79112, 0.82608695652174, 1.6, 0.16666666666667
79113, 0.82608695652174, 1.6, 0.22222222222222
79114, 0.82608695652174, 1.6, 0.27777777777778
79115, 0.82608695652174, 1.6, 0.33333333333333
79116, 0.82608695652174, 1.6, 0.38888888888889
79117, 0.82608695652174, 1.6, 0.44444444444444
79118, 0.78260869565217, 1.6, 0.055555555555556
79119, 0.78260869565217, 1.6, 0.11111111111111
79120, 0.78260869565217, 1.6, 0.16666666666667
79121, 0.78260869565217, 1.6, 0.22222222222222
79122, 0.78260869565217, 1.6, 0.27777777777778
79123, 0.78260869565217, 1.6, 0.33333333333333
79124, 0.78260869565217, 1.6, 0.38888888888889
79125, 0.78260869565217, 1.6, 0.44444444444444
79126, 0.73913043478261, 1.6, 0.055555555555556
79127, 0.73913043478261, 1.6, 0.11111111111111
79128, 0.73913043478261, 1.6, 0.16666666666667
79129, 0.73913043478261, 1.6, 0.22222222222222
79130, 0.73913043478261, 1.6, 0.27777777777778
79131, 0.73913043478261, 1.6, 0.33333333333333
79132, 0.73913043478261, 1.6, 0.38888888888889
79133, 0.73913043478261, 1.6, 0.44444444444444
79134, 0.69565217391304, 1.6, 0.055555555555556
79135, 0.69565217391304, 1.6, 0.11111111111111
79136, 0.69565217391304, 1.6, 0.16666666666667
79137, 0.69565217391304, 1.6, 0.22222222222222
79138, 0.69565217391304, 1.6, 0.27777777777778
79139, 0.69565217391304, 1.6, 0.33333333333333
79140, 0.69565217391304, 1.6, 0.38888888888889
79141, 0.69565217391304, 1.6, 0.44444444444444
79142, 0.65217391304348, 1.6, 0.055555555555556
79143, 0.65217391304348, 1.6, 0.11111111111111
79144, 0.65217391304348, 1.6, 0.16666666666667
79145, 0.65217391304348, 1.6, 0.22222222222222
79146, 0.65217391304348, 1.6, 0.27777777777778
79147, 0.65217391304348, 1.6, 0.33333333333333
79148, 0.65217391304348, 1.6, 0.38888888888889
79149, 0.65217391304348, 1.6, 0.44444444444444
79150, 0.60869565217391, 1.6, 0.055555555555556
79151, 0.60869565217391, 1.6, 0.11111111111111
79152, 0.60869565217391, 1.6, 0.16666666666667
79153, 0.60869565217391, 1.6, 0.22222222222222
79154, 0.60869565217391, 1.6, 0.27777777777778
79155, 0.60869565217391, 1.6, 0.33333333333333
79156, 0.60869565217391, 1.6, 0.38888888888889
79157, 0.60869565217391, 1.6, 0.44444444444444
79158, 0.56521739130435, 1.6, 0.055555555555556
79159, 0.56521739130435, 1.6, 0.11111111111111
79160, 0.56521739130435, 1.6, 0.16666666666667
79161, 0.56521739130435, 1.6, 0.22222222222222
79162, 0.56521739130435, 1.6, 0.27777777777778
79163, 0.56521739130435, 1.6, 0.33333333333333
79164, 0.56521739130435, 1.6, 0.38888888888889
79165, 0.56521739130435, 1.6, 0.44444444444444
79166, 0.52173913043478, 1.6, 0.055555555555556
79167, 0.52173913043478, 1.6, 0.11111111111111
79168, 0.52173913043478, 1.6, 0.16666666666667
79169, 0.52173913043478, 1.6, 0.22222222222222
79170, 0.52173913043478, 1.6, 0.27777777777778
79171, 0.52173913043478, 1.6, 0.33333333333333
79172, 0.52173913043478, 1.6, 0.38888888888889
79173, 0.52173913043478, 1.6, 0.44444444444444
79174, 0.47826086956522, 1.6, 0.055555555555556
79175, 0.47826086956522, 1.6, 0.11111111111111
79176, 0.47826086956522, 1.6, 0.16666666666667
79177, 0.47826086956522, 1.6, 0.22222222222222
79178, 0.47826086956522, 1.6, 0.27777777777778
79179, 0.47826086956522, 1.6, 0.33333333333333
79180, 0.47826086956522, 1.6, 0.38888888888889
79181, 0.47826086956522, 1.6, 0.44444444444444
79182, 0.43478260869565, 1.6, 0.055555555555556
79183, 0.43478260869565, 1.6, 0.11111111111111
79184, 0.43478260869565, 1.6, 0.16666666666667
79185, 0.43478260869565, 1.6, 0.22222222222222
79186, 0.43478260869565, 1.6, 0.27777777777778
79187, 0.43478260869565, 1.6, 0.33333333333333
79188, 0.43478260869565, 1.6, 0.38888888888889
79189, 0.43478260869565, 1.6, 0.44444444444444
79190, 0.39130434782609, 1.6, 0.055555555555556
79191, 0.39130434782609, 1.6, 0.11111111111111
79192, 0.39130434782609, 1.6, 0.16666666666667
79193, 0.39130434782609, 1.6, 0.22222222222222
79194, 0.39130434782609, 1.6, 0.27777777777778
79195, 0.39130434782609, 1.6, 0.33333333333333
79196, 0.39130434782609, 1.6, 0.38888888888889
79197, 0.39130434782609, 1.6, 0.44444444444444
79198, 0.34782608695652, 1.6, 0.055555555555556
79199, 0.34782608695652, 1.6, 0.11111111111111
79200, 0.34782608695652, 1.6, 0.16666666666667
79201, 0.34782608695652, 1.6, 0.22222222222222
79202, 0.34782608695652, 1.6, 0.27777777777778
79203, 0.34782608695652, 1.6, 0.33333333333333
79204, 0.34782608695652, 1.6, 0.38888888888889
79205, 0.34782608695652, 1.6, 0.44444444444444
79206, 0.30434782608696, 1.6, 0.055555555555556
79207, 0.30434782608696, 1.6, 0.11111111111111
79208, 0.30434782608696, 1.6, 0.16666666666667
79209, 0.30434782608696, 1.6, 0.22222222222222
79210, 0.30434782608696, 1.6, 0.27777777777778
79211, 0.30434782608696, 1.6, 0.33333333333333
79212, 0.30434782608696, 1.6, 0.38888888888889
79213, 0.30434782608696, 1.6, 0.44444444444444
79214, 0.26086956521739, 1.6, 0.055555555555556
79215, 0.26086956521739, 1.6, 0.11111111111111
79216, 0.26086956521739, 1.6, 0.16666666666667
79217, 0.26086956521739, 1.6, 0.22222222222222
79218, 0.26086956521739, 1.6, 0.27777777777778
79219, 0.26086956521739, 1.6, 0.33333333333333
79220, 0.26086956521739, 1.6, 0.38888888888889
79221, 0.26086956521739, 1.6, 0.44444444444444
79222, 0.21739130434783, 1.6, 0.055555555555556
79223, 0.21739130434783, 1.6, 0.11111111111111
79224, 0.21739130434783, 1.6, 0.16666666666667
79225, 0.21739130434783, 1.6, 0.22222222222222
79226, 0.21739130434783, 1.6, 0.27777777777778
79227, 0.21739130434783, 1.6, 0.33333333333333
79228, 0.21739130434783, 1.6, 0.38888888888889
79229, 0.21739130434783, 1.6, 0.44444444444444
79230, 0.17391304347826, 1.6, 0.055555555555556
79231, 0.17391304347826, 1.6, 0.11111111111111
79232, 0.17391304347826, 1.6, 0.16666666666667
79233, 0.17391304347826, 1.6, 0.22222222222222
79234, 0.17391304347826, 1.6, 0.27777777777778
79235, 0.17391304347826, 1.6, 0.33333333333333
79236, 0.17391304347826, 1.6, 0.38888888888889
79237, 0.17391304347826, 1.6, 0.44444444444444
79238, 0.1304347826087, 1.6, 0.055555555555556
79239, 0.1304347826087, 1.6, 0.11111111111111
79240, 0.1304347826087, 1.6, 0.16666666666667
79241, 0.1304347826087, 1.6, 0.22222222222222
79242, 0.1304347826087, 1.6, 0.27777777777778
79243, 0.1304347826087, 1.6, 0.33333333333333
79244, 0.1304347826087, 1.6, 0.38888888888889
79245, 0.1304347826087, 1.6, 0.44444444444444
79246, 0.08695652173913, 1.6, 0.055555555555556
79247, 0.08695652173913, 1.6, 0.11111111111111
79248, 0.08695652173913, 1.6, 0.16666666666667
79249, 0.08695652173913, 1.6, 0.22222222222222
79250, 0.08695652173913, 1.6, 0.27777777777778
79251, 0.08695652173913, 1.6, 0.33333333333333
79252, 0.08695652173913, 1.6, 0.38888888888889
79253, 0.08695652173913, 1.6, 0.44444444444444
79254, 0.043478260869565, 1.6, 0.055555555555556
79255, 0.043478260869565, 1.6, 0.11111111111111
79256, 0.043478260869565, 1.6, 0.16666666666667
79257, 0.043478260869565, 1.6, 0.22222222222222
79258, 0.043478260869565, 1.6, 0.27777777777778
79259, 0.043478260869565, 1.6, 0.33333333333333
79260, 0.043478260869565, 1.6, 0.38888888888889
79261, 0.043478260869565, 1.6, 0.44444444444444
79262, 0.95652173913043, 1.65, 0.055555555555556
79263, 0.95652173913043, 1.65, 0.11111111111111
79264, 0.95652173913044, 1.65, 0.16666666666667
79265, 0.95652173913044, 1.65, 0.22222222222222
79266, 0.95652173913044, 1.65, 0.27777777777778
79267, 0.95652173913044, 1.65, 0.33333333333333
79268, 0.95652173913044, 1.65, 0.38888888888889
79269, 0.95652173913044, 1.65, 0.44444444444444
79270, 0.91304347826087, 1.65, 0.055555555555556
79271, 0.91304347826087, 1.65, 0.11111111111111
79272, 0.91304347826087, 1.65, 0.16666666666667
79273, 0.91304347826087, 1.65, 0.22222222222222
