8538, 19473, 19481, 19482, 19474, 19794, 19795, 19796, 19778
8539, 19474, 19482, 19483, 19475, 19796, 19797, 19798, 19780
8540, 19475, 19483, 19484, 19476, 19798, 19799, 19800, 19782
8541, 19476, 19484, 19485, 19477, 19800, 19801, 19802, 19784
8542, 19477, 19485, 19486, 19478, 19802, 19803, 19804, 19786
8543, 19478, 19486, 19487, 19479, 19804, 19805, 19806, 19788
8544, 19479, 19487, 2774, 2773, 19806, 19807, 2796, 19790
8545, 2706, 2707, 19488, 19480, 2729, 19808, 19809, 19791
8546, 19480, 19488, 19489, 19481, 19809, 19810, 19811, 19793
8547, 19481, 19489, 19490, 19482, 19811, 19812, 19813, 19795
8548, 19482, 19490, 19491, 19483, 19813, 19814, 19815, 19797
8549, 19483, 19491, 19492, 19484, 19815, 19816, 19817, 19799
8550, 19484, 19492, 19493, 19485, 19817, 19818, 19819, 19801
8551, 19485, 19493, 19494, 19486, 19819, 19820, 19821, 19803
8552, 19486, 19494, 19495, 19487, 19821, 19822, 19823, 19805
8553, 19487, 19495, 2775, 2774, 19823, 19824, 2797, 19807
8554, 2707, 2708, 19496, 19488, 2730, 19825, 19826, 19808
8555, 19488, 19496, 19497, 19489, 19826, 19827, 19828, 19810
8556, 19489, 19497, 19498, 19490, 19828, 19829, 19830, 19812
8557, 19490, 19498, 19499, 19491, 19830, 19831, 19832, 19814
8558, 19491, 19499, 19500, 19492, 19832, 19833, 19834, 19816
8559, 19492, 19500, 19501, 19493, 19834, 19835, 19836, 19818
8560, 19493, 19501, 19502, 19494, 19836, 19837, 19838, 19820
8561, 19494, 19502, 19503, 19495, 19838, 19839, 19840, 19822
8562, 19495, 19503, 2776, 2775, 19840, 19841, 2798, 19824
8563, 2708, 2709, 19504, 19496, 2731, 19842, 19843, 19825
8564, 19496, 19504, 19505, 19497, 19843, 19844, 19845, 19827
8565, 19497, 19505, 19506, 19498, 19845, 19846, 19847, 19829
8566, 19498, 19506, 19507, 19499, 19847, 19848, 19849, 19831
8567, 19499, 19507, 19508, 19500, 19849, 19850, 19851, 19833
8568, 19500, 19508, 19509, 19501, 19851, 19852, 19853, 19835
8569, 19501, 19509, 19510, 19502, 19853, 19854, 19855, 19837
8570, 19502, 19510, 19511, 19503, 19855, 19856, 19857, 19839
8571, 19503, 19511, 2777, 2776, 19857, 19858, 2799, 19841
8572, 2709, 2710, 19512, 19504, 2732, 19859, 19860, 19842
8573, 19504, 19512, 19513, 19505, 19860, 19861, 19862, 19844
8574, 19505, 19513, 19514, 19506, 19862, 19863, 19864, 19846
8575, 19506, 19514, 19515, 19507, 19864, 19865, 19866, 19848
8576, 19507, 19515, 19516, 19508, 19866, 19867, 19868, 19850
8577, 19508, 19516, 19517, 19509, 19868, 19869, 19870, 19852
8578, 19509, 19517, 19518, 19510, 19870, 19871, 19872, 19854
8579, 19510, 19518, 19519, 19511, 19872, 19873, 19874, 19856
8580, 19511, 19519, 2778, 2777, 19874, 19875, 2800, 19858
8581, 2710, 2711, 19520, 19512, 2733, 19876, 19877, 19859
8582, 19512, 19520, 19521, 19513, 19877, 19878, 19879, 19861
8583, 19513, 19521, 19522, 19514, 19879, 19880, 19881, 19863
8584, 19514, 19522, 19523, 19515, 19881, 19882, 19883, 19865
8585, 19515, 19523, 19524, 19516, 19883, 19884, 19885, 19867
8586, 19516, 19524, 19525, 19517, 19885, 19886, 19887, 19869
8587, 19517, 19525, 19526, 19518, 19887, 19888, 19889, 19871
8588, 19518, 19526, 19527, 19519, 19889, 19890, 19891, 19873
8589, 19519, 19527, 2779, 2778, 19891, 19892, 2801, 19875
8590, 2711, 2712, 19528, 19520, 2734, 19893, 19894, 19876
8591, 19520, 19528, 19529, 19521, 19894, 19895, 19896, 19878
8592, 19521, 19529, 19530, 19522, 19896, 19897, 19898, 19880
8593, 19522, 19530, 19531, 19523, 19898, 19899, 19900, 19882
8594, 19523, 19531, 19532, 19524, 19900, 19901, 19902, 19884
8595, 19524, 19532, 19533, 19525, 19902, 19903, 19904, 19886
8596, 19525, 19533, 19534, 19526, 19904, 19905, 19906, 19888
8597, 19526, 19534, 19535, 19527, 19906, 19907, 19908, 19890
8598, 19527, 19535, 2780, 2779, 19908, 19909, 2802, 19892
8599, 2712, 85, 2739, 19528, 2735, 2747, 19910, 19893
8600, 19528, 2739, 2740, 19529, 19910, 2748, 19911, 19895
8601, 19529, 2740, 2741, 19530, 19911, 2749, 19912, 19897
8602, 19530, 2741, 2742, 19531, 19912, 2750, 19913, 19899
8603, 19531, 2742, 2743, 19532, 19913, 2751, 19914, 19901
8604, 19532, 2743, 2744, 19533, 19914, 2752, 19915, 19903
8605, 19533, 2744, 2745, 19534, 19915, 2753, 19916, 19905
8606, 19534, 2745, 2746, 19535, 19916, 2754, 19917, 19907
8607, 19535, 2746, 87, 2780, 19917, 2755, 2803, 19909
*ELEMENT, type=CPS8, ELSET=Surface260
8608, 1, 130, 19918, 2821, 153, 20402, 20403, 2843
8609, 130, 129, 19919, 19918, 152, 20404, 20405, 20402
8610, 129, 128, 19920, 19919, 151, 20406, 20407, 20404
8611, 128, 127, 19921, 19920, 150, 20408, 20409, 20406
8612, 127, 126, 19922, 19921, 149, 20410, 20411, 20408
8613, 126, 125, 19923, 19922, 148, 20412, 20413, 20410
8614, 125, 124, 19924, 19923, 147, 20414, 20415, 20412
8615, 124, 123, 19925, 19924, 146, 20416, 20417, 20414
8616, 123, 122, 19926, 19925, 145, 20418, 20419, 20416
8617, 122, 121, 19927, 19926, 144, 20420, 20421, 20418
8618, 121, 120, 19928, 19927, 143, 20422, 20423, 20420
8619, 120, 119, 19929, 19928, 142, 20424, 20425, 20422
8620, 119, 118, 19930, 19929, 141, 20426, 20427, 20424
8621, 118, 117, 19931, 19930, 140, 20428, 20429, 20426
8622, 117, 116, 19932, 19931, 139, 20430, 20431, 20428
8623, 116, 115, 19933, 19932, 138, 20432, 20433, 20430
8624, 115, 114, 19934, 19933, 137, 20434, 20435, 20432
8625, 114, 113, 19935, 19934, 136, 20436, 20437, 20434
8626, 113, 112, 19936, 19935, 135, 20438, 20439, 20436
8627, 112, 111, 19937, 19936, 134, 20440, 20441, 20438
8628, 111, 110, 19938, 19937, 133, 20442, 20443, 20440
8629, 110, 109, 19939, 19938, 132, 20444, 20445, 20442
8630, 109, 2, 2866, 19939, 131, 2888, 20446, 20444
8631, 2821, 19918, 19940, 2822, 20403, 20447, 20448, 2844
8632, 19918, 19919, 19941, 19940, 20405, 20449, 20450, 20447
8633, 19919, 19920, 19942, 19941, 20407, 20451, 20452, 20449
8634, 19920, 19921, 19943, 19942, 20409, 20453, 20454, 20451
8635, 19921, 19922, 19944, 19943, 20411, 20455, 20456, 20453
8636, 19922, 19923, 19945, 19944, 20413, 20457, 20458, 20455
8637, 19923, 19924, 19946, 19945, 20415, 20459, 20460, 20457
8638, 19924, 19925, 19947, 19946, 20417, 20461, 20462, 20459
8639, 19925, 19926, 19948, 19947, 20419, 20463, 20464, 20461
8640, 19926, 19927, 19949, 19948, 20421, 20465, 20466, 20463
8641, 19927, 19928, 19950, 19949, 20423, 20467, 20468, 20465
8642, 19928, 19929, 19951, 19950, 20425, 20469, 20470, 20467
8643, 19929, 19930, 19952, 19951, 20427, 20471, 20472, 20469
8644, 19930, 19931, 19953, 19952, 20429, 20473, 20474, 20471
8645, 19931, 19932, 19954, 19953, 20431, 20475, 20476, 20473
8646, 19932, 19933, 19955, 19954, 20433, 20477, 20478, 20475
8647, 19933, 19934, 19956, 19955, 20435, 20479, 20480, 20477
8648, 19934, 19935, 19957, 19956, 20437, 20481, 20482, 20479
8649, 19935, 19936, 19958, 19957, 20439, 20483, 20484, 20481
8650, 19936, 19937, 19959, 19958, 20441, 20485, 20486, 20483
8651, 19937, 19938, 19960, 19959, 20443, 20487, 20488, 20485
8652, 19938, 19939, 19961, 19960, 20445, 20489, 20490, 20487
8653, 19939, 2866, 2867, 19961, 20446, 2889, 20491, 20489
8654, 2822, 19940, 19962, 2823, 20448, 20492, 20493, 2845
8655, 19940, 19941, 19963, 19962, 20450, 20494, 20495, 20492
8656, 19941, 19942, 19964, 19963, 20452, 20496, 20497, 20494
8657, 19942, 19943, 19965, 19964, 20454, 20498, 20499, 20496
8658, 19943, 19944, 19966, 19965, 20456, 20500, 20501, 20498
8659, 19944, 19945, 19967, 19966, 20458, 20502, 20503, 20500
8660, 19945, 19946, 19968, 19967, 20460, 20504, 20505, 20502
8661, 19946, 19947, 19969, 19968, 20462, 20506, 20507, 20504
8662, 19947, 19948, 19970, 19969, 20464, 20508, 20509, 20506
8663, 19948, 19949, 19971, 19970, 20466, 20510, 20511, 20508
8664, 19949, 19950, 19972, 19971, 20468, 20512, 20513, 20510
8665, 19950, 19951, 19973, 19972, 20470, 20514, 20515, 20512
8666, 19951, 19952, 19974, 19973, 20472, 20516, 20517, 20514
8667, 19952, 19953, 19975, 19974, 20474, 20518, 20519, 20516
8668, 19953, 19954, 19976, 19975, 20476, 20520, 20521, 20518
8669, 19954, 19955, 19977, 19976, 20478, 20522, 20523, 20520
8670, 19955, 19956, 19978, 19977, 20480, 20524, 20525, 20522
8671, 19956, 19957, 19979, 19978, 20482, 20526, 20527, 20524
8672, 19957, 19958, 19980, 19979, 20484, 20528, 20529, 20526
8673, 19958, 19959, 19981, 19980, 20486, 20530, 20531, 20528
8674, 19959, 19960, 19982, 19981, 20488, 20532, 20533, 20530
8675, 19960, 19961, 19983, 19982, 20490, 20534, 20535, 20532
8676, 19961, 2867, 2868, 19983, 20491, 2890, 20536, 20534
8677, 2823, 19962, 19984, 2824, 20493, 20537, 20538, 2846
8678, 19962, 19963, 19985, 19984, 20495, 20539, 20540, 20537
8679, 19963, 19964, 19986, 19985, 20497, 20541, 20542, 20539
8680, 19964, 19965, 19987, 19986, 20499, 20543, 20544, 20541
8681, 19965, 19966, 19988, 19987, 20501, 20545, 20546, 20543
8682, 19966, 19967, 19989, 19988, 20503, 20547, 20548, 20545
8683, 19967, 19968, 19990, 19989, 20505, 20549, 20550, 20547
8684, 19968, 19969, 19991, 19990, 20507, 20551, 20552, 20549
8685, 19969, 19970, 19992, 19991, 20509, 20553, 20554, 20551
8686, 19970, 19971, 19993, 19992, 20511, 20555, 20556, 20553
8687, 19971, 19972, 19994, 19993, 20513, 20557, 20558, 20555
8688, 19972, 19973, 19995, 19994, 20515, 20559, 20560, 20557
8689, 19973, 19974, 19996, 19995, 20517, 20561, 20562, 20559
8690, 19974, 19975, 19997, 19996, 20519, 20563, 20564, 20561
8691, 19975, 19976, 19998, 19997, 20521, 20565, 20566, 20563
8692, 19976, 19977, 19999, 19998, 20523, 20567, 20568, 20565
8693, 19977, 19978, 20000, 19999, 20525, 20569, 20570, 20567
8694, 19978, 19979, 20001, 20000, 20527, 20571, 20572, 20569
8695, 19979, 19980, 20002, 20001, 20529, 20573, 20574, 20571
8696, 19980, 19981, 20003, 20002, 20531, 20575, 20576, 20573
8697, 19981, 19982, 20004, 20003, 20533, 20577, 20578, 20575
8698, 19982, 19983, 20005, 20004, 20535, 20579, 20580, 20577
8699, 19983, 2868, 2869, 20005, 20536, 2891, 20581, 20579
8700, 2824, 19984, 20006, 2825, 20538, 20582, 20583, 2847
8701, 19984, 19985, 20007, 20006, 20540, 20584, 20585, 20582
8702, 19985, 19986, 20008, 20007, 20542, 20586, 20587, 20584
8703, 19986, 19987, 20009, 20008, 20544, 20588, 20589, 20586
8704, 19987, 19988, 20010, 20009, 20546, 20590, 20591, 20588
8705, 19988, 19989, 20011, 20010, 20548, 20592, 20593, 20590
8706, 19989, 19990, 20012, 20011, 20550, 20594, 20595, 20592
8707, 19990, 19991, 20013, 20012, 20552, 20596, 20597, 20594
8708, 19991, 19992, 20014, 20013, 20554, 20598, 20599, 20596
8709, 19992, 19993, 20015, 20014, 20556, 20600, 20601, 20598
8710, 19993, 19994, 20016, 20015, 20558, 20602, 20603, 20600
8711, 19994, 19995, 20017, 20016, 20560, 20604, 20605, 20602
8712, 19995, 19996, 20018, 20017, 20562, 20606, 20607, 20604
8713, 19996, 19997, 20019, 20018, 20564, 20608, 20609, 20606
8714, 19997, 19998, 20020, 20019, 20566, 20610, 20611, 20608
8715, 19998, 19999, 20021, 20020, 20568, 20612, 20613, 20610
8716, 19999, 20000, 20022, 20021, 20570, 20614, 20615, 20612
8717, 20000, 20001, 20023, 20022, 20572, 20616, 20617, 20614
8718, 20001, 20002, 20024, 20023, 20574, 20618, 20619, 20616
8719, 20002, 20003, 20025, 20024, 20576, 20620, 20621, 20618
8720, 20003, 20004, 20026, 20025, 20578, 20622, 20623, 20620
8721, 20004, 20005, 20027, 20026, 20580, 20624, 20625, 20622
8722, 20005, 2869, 2870, 20027, 20581, 2892, 20626, 20624
8723, 2825, 20006, 20028, 2826, 20583, 20627, 20628, 2848
8724, 20006, 20007, 20029, 20028, 20585, 20629, 20630, 20627
8725, 20007, 20008, 20030, 20029, 20587, 20631, 20632, 20629
8726, 20008, 20009, 20031, 20030, 20589, 20633, 20634, 20631
8727, 20009, 20010, 20032, 20031, 20591, 20635, 20636, 20633
8728, 20010, 20011, 20033, 20032, 20593, 20637, 20638, 20635
8729, 20011, 20012, 20034, 20033, 20595, 20639, 20640, 20637
8730, 20012, 20013, 20035, 20034, 20597, 20641, 20642, 20639
8731, 20013, 20014, 20036, 20035, 20599, 20643, 20644, 20641
8732, 20014, 20015, 20037, 20036, 20601, 20645, 20646, 20643
8733, 20015, 20016, 20038, 20037, 20603, 20647, 20648, 20645
8734, 20016, 20017, 20039, 20038, 20605, 20649, 20650, 20647
8735, 20017, 20018, 20040, 20039, 20607, 20651, 20652, 20649
8736, 20018, 20019, 20041, 20040, 20609, 20653, 20654, 20651
8737, 20019, 20020, 20042, 20041, 20611, 20655, 20656, 20653
8738, 20020, 20021, 20043, 20042, 20613, 20657, 20658, 20655
8739, 20021, 20022, 20044, 20043, 20615, 20659, 20660, 20657
8740, 20022, 20023, 20045, 20044, 20617, 20661, 20662, 20659
8741, 20023, 20024, 20046, 20045, 20619, 20663, 20664, 20661
8742, 20024, 20025, 20047, 20046, 20621, 20665, 20666, 20663
8743, 20025, 20026, 20048, 20047, 20623, 20667, 20668, 20665
8744, 20026, 20027, 20049, 20048, 20625, 20669, 20670, 20667
8745, 20027, 2870, 2871, 20049, 20626, 2893, 20671, 20669
8746, 2826, 20028, 20050, 2827, 20628, 20672, 20673, 2849
8747, 20028, 20029, 20051, 20050, 20630, 20674, 20675, 20672
8748, 20029, 20030, 20052, 20051, 20632, 20676, 20677, 20674
8749, 20030, 20031, 20053, 20052, 20634, 20678, 20679, 20676
8750, 20031, 20032, 20054, 20053, 20636, 20680, 20681, 20678
8751, 20032, 20033, 20055, 20054, 20638, 20682, 20683, 20680
8752, 20033, 20034, 20056, 20055, 20640, 20684, 20685, 20682
8753, 20034, 20035, 20057, 20056, 20642, 20686, 20687, 20684
8754, 20035, 20036, 20058, 20057, 20644, 20688, 20689, 20686
8755, 20036, 20037, 20059, 20058, 20646, 20690, 20691, 20688
8756, 20037, 20038, 20060, 20059, 20648, 20692, 20693, 20690
8757, 20038, 20039, 20061, 20060, 20650, 20694, 20695, 20692
8758, 20039, 20040, 20062, 20061, 20652, 20696, 20697, 20694
8759, 20040, 20041, 20063, 20062, 20654, 20698, 20699, 20696
8760, 20041, 20042, 20064, 20063, 20656, 20700, 20701, 20698
8761, 20042, 20043, 20065, 20064, 20658, 20702, 20703, 20700
8762, 20043, 20044, 20066, 20065, 20660, 20704, 20705, 20702
8763, 20044, 20045, 20067, 20066, 20662, 20706, 20707, 20704
8764, 20045, 20046, 20068, 20067, 20664, 20708, 20709, 20706
8765, 20046, 20047, 20069, 20068, 20666, 20710, 20711, 20708
8766, 20047, 20048, 20070, 20069, 20668, 20712, 20713, 20710
8767, 20048, 20049, 20071, 20070, 20670, 20714, 20715, 20712
8768, 20049, 2871, 2872, 20071, 20671, 2894, 20716, 20714
8769, 2827, 20050, 20072, 2828, 20673, 20717, 20718, 2850
8770, 20050, 20051, 20073, 20072, 20675, 20719, 20720, 20717
8771, 20051, 20052, 20074, 20073, 20677, 20721, 20722, 20719
8772, 20052, 20053, 20075, 20074, 20679, 20723, 20724, 20721
8773, 20053, 20054, 20076, 20075, 20681, 20725, 20726, 20723
8774, 20054, 20055, 20077, 20076, 20683, 20727, 20728, 20725
8775, 20055, 20056, 20078, 20077, 20685, 20729, 20730, 20727
8776, 20056, 20057, 20079, 20078, 20687, 20731, 20732, 20729
8777, 20057, 20058, 20080, 20079, 20689, 20733, 20734, 20731
8778, 20058, 20059, 20081, 20080, 20691, 20735, 20736, 20733
8779, 20059, 20060, 20082, 20081, 20693, 20737, 20738, 20735
8780, 20060, 20061, 20083, 20082, 20695, 20739, 20740, 20737
8781, 20061, 20062, 20084, 20083, 20697, 20741, 20742, 20739
8782, 20062, 20063, 20085, 20084, 20699, 20743, 20744, 20741
8783, 20063, 20064, 20086, 20085, 20701, 20745, 20746, 20743
8784, 20064, 20065, 20087, 20086, 20703, 20747, 20748, 20745
8785, 20065, 20066, 20088, 20087, 20705, 20749, 20750, 20747
8786, 20066, 20067, 20089, 20088, 20707, 20751, 20752, 20749
8787, 20067, 20068, 20090, 20089, 20709, 20753, 20754, 20751
8788, 20068, 20069, 20091, 20090, 20711, 20755, 20756, 20753
8789, 20069, 20070, 20092, 20091, 20713, 20757, 20758, 20755
8790, 20070, 20071, 20093, 20092, 20715, 20759, 20760, 20757
8791, 20071, 2872, 2873, 20093, 20716, 2895, 20761, 20759
8792, 2828, 20072, 20094, 2829, 20718, 20762, 20763, 2851
8793, 20072, 20073, 20095, 20094, 20720, 20764, 20765, 20762
8794, 20073, 20074, 20096, 20095, 20722, 20766, 20767, 20764
8795, 20074, 20075, 20097, 20096, 20724, 20768, 20769, 20766
8796, 20075, 20076, 20098, 20097, 20726, 20770, 20771, 20768
8797, 20076, 20077, 20099, 20098, 20728, 20772, 20773, 20770
8798, 20077, 20078, 20100, 20099, 20730, 20774, 20775, 20772
8799, 20078, 20079, 20101, 20100, 20732, 20776, 20777, 20774
8800, 20079, 20080, 20102, 20101, 20734, 20778, 20779, 20776
8801, 20080, 20081, 20103, 20102, 20736, 20780, 20781, 20778
8802, 20081, 20082, 20104, 20103, 20738, 20782, 20783, 20780
8803, 20082, 20083, 20105, 20104, 20740, 20784, 20785, 20782
8804, 20083, 20084, 20106, 20105, 20742, 20786, 20787, 20784
8805, 20084, 20085, 20107, 20106, 20744, 20788, 20789, 20786
8806, 20085, 20086, 20108, 20107, 20746, 20790, 20791, 20788
8807, 20086, 20087, 20109, 20108, 20748, 20792, 20793, 20790
8808, 20087, 20088, 20110, 20109, 20750, 20794, 20795, 20792
8809, 20088, 20089, 20111, 20110, 20752, 20796, 20797, 20794
8810, 20089, 20090, 20112, 20111, 20754, 20798, 20799, 20796
8811, 20090, 20091, 20113, 20112, 20756, 20800, 20801, 20798
8812, 20091, 20092, 20114, 20113, 20758, 20802, 20803, 20800
8813, 20092, 20093, 20115, 20114, 20760, 20804, 20805, 20802
8814, 20093, 2873, 2874, 20115, 20761, 2896, 20806, 20804
8815, 2829, 20094, 20116, 2830, 20763, 20807, 20808, 2852
8816, 20094, 20095, 20117, 20116, 20765, 20809, 20810, 20807
8817, 20095, 20096, 20118, 20117, 20767, 20811, 20812, 20809
8818, 20096, 20097, 20119, 20118, 20769, 20813, 20814, 20811
8819, 20097, 20098, 20120, 20119, 20771, 20815, 20816, 20813
8820, 20098, 20099, 20121, 20120, 20773, 20817, 20818, 20815
8821, 20099, 20100, 20122, 20121, 20775, 20819, 20820, 20817
8822, 20100, 20101, 20123, 20122, 20777, 20821, 20822, 20819
8823, 20101, 20102, 20124, 20123, 20779, 20823, 20824, 20821
8824, 20102, 20103, 20125, 20124, 20781, 20825, 20826, 20823
8825, 20103, 20104, 20126, 20125, 20783, 20827, 20828, 20825
8826, 20104, 20105, 20127, 20126, 20785, 20829, 20830, 20827
8827, 20105, 20106, 20128, 20127, 20787, 20831, 20832, 20829
8828, 20106, 20107, 20129, 20128, 20789, 20833, 20834, 20831
8829, 20107, 20108, 20130, 20129, 20791, 20835, 20836, 20833
8830, 20108, 20109, 20131, 20130, 20793, 20837, 20838, 20835
8831, 20109, 20110, 20132, 20131, 20795, 20839, 20840, 20837
8832, 20110, 20111, 20133, 20132, 20797, 20841, 20842, 20839
8833, 20111, 20112, 20134, 20133, 20799, 20843, 20844, 20841
8834, 20112, 20113, 20135, 20134, 20801, 20845, 20846, 20843
8835, 20113, 20114, 20136, 20135, 20803, 20847, 20848, 20845
8836, 20114, 20115, 20137, 20136, 20805, 20849, 20850, 20847
8837, 20115, 2874, 2875, 20137, 20806, 2897, 20851, 20849
8838, 2830, 20116, 20138, 2831, 20808, 20852, 20853, 2853
8839, 20116, 20117, 20139, 20138, 20810, 20854, 20855, 20852
8840, 20117, 20118, 20140, 20139, 20812, 20856, 20857, 20854
8841, 20118, 20119, 20141, 20140, 20814, 20858, 20859, 20856
8842, 20119, 20120, 20142, 20141, 20816, 20860, 20861, 20858
8843, 20120, 20121, 20143, 20142, 20818, 20862, 20863, 20860
8844, 20121, 20122, 20144, 20143, 20820, 20864, 20865, 20862
8845, 20122, 20123, 20145, 20144, 20822, 20866, 20867, 20864
8846, 20123, 20124, 20146, 20145, 20824, 20868, 20869, 20866
8847, 20124, 20125, 20147, 20146, 20826, 20870, 20871, 20868
8848, 20125, 20126, 20148, 20147, 20828, 20872, 20873, 20870
8849, 20126, 20127, 20149, 20148, 20830, 20874, 20875, 20872
8850, 20127, 20128, 20150, 20149, 20832, 20876, 20877, 20874
8851, 20128, 20129, 20151, 20150, 20834, 20878, 20879, 20876
8852, 20129, 20130, 20152, 20151, 20836, 20880, 20881, 20878
8853, 20130, 20131, 20153, 20152, 20838, 20882, 20883, 20880
8854, 20131, 20132, 20154, 20153, 20840, 20884, 20885, 20882
8855, 20132, 20133, 20155, 20154, 20842, 20886, 20887, 20884
8856, 20133, 20134, 20156, 20155, 20844, 20888, 20889, 20886
8857, 20134, 20135, 20157, 20156, 20846, 20890, 20891, 20888
8858, 20135, 20136, 20158, 20157, 20848, 20892, 20893, 20890
8859, 20136, 20137, 20159, 20158, 20850, 20894, 20895, 20892
8860, 20137, 2875, 2876, 20159, 20851, 2898, 20896, 20894
8861, 2831, 20138, 20160, 2832, 20853, 20897, 20898, 2854
8862, 20138, 20139, 20161, 20160, 20855, 20899, 20900, 20897
8863, 20139, 20140, 20162, 20161, 20857, 20901, 20902, 20899
8864, 20140, 20141, 20163, 20162, 20859, 20903, 20904, 20901
8865, 20141, 20142, 20164, 20163, 20861, 20905, 20906, 20903
8866, 20142, 20143, 20165, 20164, 20863, 20907, 20908, 20905
8867, 20143, 20144, 20166, 20165, 20865, 20909, 20910, 20907
8868, 20144, 20145, 20167, 20166, 20867, 20911, 20912, 20909
8869, 20145, 20146, 20168, 20167, 20869, 20913, 20914, 20911
8870, 20146, 20147, 20169, 20168, 20871, 20915, 20916, 20913
8871, 20147, 20148, 20170, 20169, 20873, 20917, 20918, 20915
8872, 20148, 20149, 20171, 20170, 20875, 20919, 20920, 20917
8873, 20149, 20150, 20172, 20171, 20877, 20921, 20922, 20919
8874, 20150, 20151, 20173, 20172, 20879, 20923, 20924, 20921
8875, 20151, 20152, 20174, 20173, 20881, 20925, 20926, 20923
8876, 20152, 20153, 20175, 20174, 20883, 20927, 20928, 20925
8877, 20153, 20154, 20176, 20175, 20885, 20929, 20930, 20927
8878, 20154, 20155, 20177, 20176, 20887, 20931, 20932, 20929
8879, 20155, 20156, 20178, 20177, 20889, 20933, 20934, 20931
8880, 20156, 20157, 20179, 20178, 20891, 20935, 20936, 20933
8881, 20157, 20158, 20180, 20179, 20893, 20937, 20938, 20935
8882, 20158, 20159, 20181, 20180, 20895, 20939, 20940, 20937
8883, 20159, 2876, 2877, 20181, 20896, 2899, 20941, 20939
8884, 2832, 20160, 20182, 2833, 20898, 20942, 20943, 2855
8885, 20160, 20161, 20183, 20182, 20900, 20944, 20945, 20942
8886, 20161, 20162, 20184, 20183, 20902, 20946, 20947, 20944
8887, 20162, 20163, 20185, 20184, 20904, 20948, 20949, 20946
8888, 20163, 20164, 20186, 20185, 20906, 20950, 20951, 20948
8889, 20164, 20165, 20187, 20186, 20908, 20952, 20953, 20950
8890, 20165, 20166, 20188, 20187, 20910, 20954, 20955, 20952
8891, 20166, 20167, 20189, 20188, 20912, 20956, 20957, 20954
8892, 20167, 20168, 20190, 20189, 20914, 20958, 20959, 20956
8893, 20168, 20169, 20191, 20190, 20916, 20960, 20961, 20958
8894, 20169, 20170, 20192, 20191, 20918, 20962, 20963, 20960
8895, 20170, 20171, 20193, 20192, 20920, 20964, 20965, 20962
8896, 20171, 20172, 20194, 20193, 20922, 20966, 20967, 20964
8897, 20172, 20173, 20195, 20194, 20924, 20968, 20969, 20966
8898, 20173, 20174, 20196, 20195, 20926, 20970, 20971, 20968
8899, 20174, 20175, 20197, 20196, 20928, 20972, 20973, 20970
8900, 20175, 20176, 20198, 20197, 20930, 20974, 20975, 20972
8901, 20176, 20177, 20199, 20198, 20932, 20976, 20977, 20974
8902, 20177, 20178, 20200, 20199, 20934, 20978, 20979, 20976
8903, 20178, 20179, 20201, 20200, 20936, 20980, 20981, 20978
8904, 20179, 20180, 20202, 20201, 20938, 20982, 20983, 20980
8905, 20180, 20181, 20203, 20202, 20940, 20984, 20985, 20982
8906, 20181, 2877, 2878, 20203, 20941, 2900, 20986, 20984
8907, 2833, 20182, 20204, 2834, 20943, 20987, 20988, 2856
8908, 20182, 20183, 20205, 20204, 20945, 20989, 20990, 20987
8909, 20183, 20184, 20206, 20205, 20947, 20991, 20992, 20989
8910, 20184, 20185, 20207, 20206, 20949, 20993, 20994, 20991
8911, 20185, 20186, 20208, 20207, 20951, 20995, 20996, 20993
8912, 20186, 20187, 20209, 20208, 20953, 20997, 20998, 20995
8913, 20187, 20188, 20210, 20209, 20955, 20999, 21000, 20997
8914, 20188, 20189, 20211, 20210, 20957, 21001, 21002, 20999
8915, 20189, 20190, 20212, 20211, 20959, 21003, 21004, 21001
8916, 20190, 20191, 20213, 20212, 20961, 21005, 21006, 21003
8917, 20191, 20192, 20214, 20213, 20963, 21007, 21008, 21005
8918, 20192, 20193, 20215, 20214, 20965, 21009, 21010, 21007
8919, 20193, 20194, 20216, 20215, 20967, 21011, 21012, 21009
8920, 20194, 20195, 20217, 20216, 20969, 21013, 21014, 21011
8921, 20195, 20196, 20218, 20217, 20971, 21015, 21016, 21013
8922, 20196, 20197, 20219, 20218, 20973, 21017, 21018, 21015
8923, 20197, 20198, 20220, 20219, 20975, 21019, 21020, 21017
8924, 20198, 20199, 20221, 20220, 20977, 21021, 21022, 21019
8925, 20199, 20200, 20222, 20221, 20979, 21023, 21024, 21021
8926, 20200, 20201, 20223, 20222, 20981, 21025, 21026, 21023
8927, 20201, 20202, 20224, 20223, 20983, 21027, 21028, 21025
8928, 20202, 20203, 20225, 20224, 20985, 21029, 21030, 21027
8929, 20203, 2878, 2879, 20225, 20986, 2901, 21031, 21029
8930, 2834, 20204, 20226, 2835, 20988, 21032, 21033, 2857
8931, 20204, 20205, 20227, 20226, 20990, 21034, 21035, 21032
8932, 20205, 20206, 20228, 20227, 20992, 21036, 21037, 21034
8933, 20206, 20207, 20229, 20228, 20994, 21038, 21039, 21036
8934, 20207, 20208, 20230, 20229, 20996, 21040, 21041, 21038
8935, 20208, 20209, 20231, 20230, 20998, 21042, 21043, 21040
8936, 20209, 20210, 20232, 20231, 21000, 21044, 21045, 21042
8937, 20210, 20211, 20233, 20232, 21002, 21046, 21047, 21044
8938, 20211, 20212, 20234, 20233, 21004, 21048, 21049, 21046
8939, 20212, 20213, 20235, 20234, 21006, 21050, 21051, 21048
8940, 20213, 20214, 20236, 20235, 21008, 21052, 21053, 21050
8941, 20214, 20215, 20237, 20236, 21010, 21054, 21055, 21052
8942, 20215, 20216, 20238, 20237, 21012, 21056, 21057, 21054
8943, 20216, 20217, 20239, 20238, 21014, 21058, 21059, 21056
8944, 20217, 20218, 20240, 20239, 21016, 21060, 21061, 21058
8945, 20218, 20219, 20241, 20240, 21018, 21062, 21063, 21060
8946, 20219, 20220, 20242, 20241, 21020, 21064, 21065, 21062
8947, 20220, 20221, 20243, 20242, 21022, 21066, 21067, 21064
8948, 20221, 20222, 20244, 20243, 21024, 21068, 21069, 21066
8949, 20222, 20223, 20245, 20244, 21026, 21070, 21071, 21068
8950, 20223, 20224, 20246, 20245, 21028, 21072, 21073, 21070
8951, 20224, 20225, 20247, 20246, 21030, 21074, 21075, 21072
8952, 20225, 2879, 2880, 20247, 21031, 2902, 21076, 21074
8953, 2835, 20226, 20248, 2836, 21033, 21077, 21078, 2858
8954, 20226, 20227, 20249, 20248, 21035, 21079, 21080, 21077
8955, 20227, 20228, 20250, 20249, 21037, 21081, 21082, 21079
8956, 20228, 20229, 20251, 20250, 21039, 21083, 21084, 21081
8957, 20229, 20230, 20252, 20251, 21041, 21085, 21086, 21083
8958, 20230, 20231, 20253, 20252, 21043, 21087, 21088, 21085
8959, 20231, 20232, 20254, 20253, 21045, 21089, 21090, 21087
8960, 20232, 20233, 20255, 20254, 21047, 21091, 21092, 21089
8961, 20233, 20234, 20256, 20255, 21049, 21093, 21094, 21091
8962, 20234, 20235, 20257, 20256, 21051, 21095, 21096, 21093
8963, 20235, 20236, 20258, 20257, 21053, 21097, 21098, 21095
8964, 20236, 20237, 20259, 20258, 21055, 21099, 21100, 21097
8965, 20237, 20238, 20260, 20259, 21057, 21101, 21102, 21099
8966, 20238, 20239, 20261, 20260, 21059, 21103, 21104, 21101
8967, 20239, 20240, 20262, 20261, 21061, 21105, 21106, 21103
8968, 20240, 20241, 20263, 20262, 21063, 21107, 21108, 21105
8969, 20241, 20242, 20264, 20263, 21065, 21109, 21110, 21107
8970, 20242, 20243, 20265, 20264, 21067, 21111, 21112, 21109
8971, 20243, 20244, 20266, 20265, 21069, 21113, 21114, 21111
8972, 20244, 20245, 20267, 20266, 21071, 21115, 21116, 21113
8973, 20245, 20246, 20268, 20267, 21073, 21117, 21118, 21115
8974, 20246, 20247, 20269, 20268, 21075, 21119, 21120, 21117
8975, 20247, 2880, 2881, 20269, 21076, 2903, 21121, 21119
8976, 2836, 20248, 20270, 2837, 21078, 21122, 21123, 2859
8977, 20248, 20249, 20271, 20270, 21080, 21124, 21125, 21122
8978, 20249, 20250, 20272, 20271, 21082, 21126, 21127, 21124
8979, 20250, 20251, 20273, 20272, 21084, 21128, 21129, 21126
8980, 20251, 20252, 20274, 20273, 21086, 21130, 21131, 21128
8981, 20252, 20253, 20275, 20274, 21088, 21132, 21133, 21130
8982, 20253, 20254, 20276, 20275, 21090, 21134, 21135, 21132
8983, 20254, 20255, 20277, 20276, 21092, 21136, 21137, 21134
8984, 20255, 20256, 20278, 20277, 21094, 21138, 21139, 21136
8985, 20256, 20257, 20279, 20278, 21096, 21140, 21141, 21138
8986, 20257, 20258, 20280, 20279, 21098, 21142, 21143, 21140
8987, 20258, 20259, 20281, 20280, 21100, 21144, 21145, 21142
8988, 20259, 20260, 20282, 20281, 21102, 21146, 21147, 21144
8989, 20260, 20261, 20283, 20282, 21104, 21148, 21149, 21146
8990, 20261, 20262, 20284, 20283, 21106, 21150, 21151, 21148
8991, 20262, 20263, 20285, 20284, 21108, 21152, 21153, 21150
8992, 20263, 20264, 20286, 20285, 21110, 21154, 21155, 21152
8993, 20264, 20265, 20287, 20286, 21112, 21156, 21157, 21154
8994, 20265, 20266, 20288, 20287, 21114, 21158, 21159, 21156
8995, 20266, 20267, 20289, 20288, 21116, 21160, 21161, 21158
8996, 20267, 20268, 20290, 20289, 21118, 21162, 21163, 21160
8997, 20268, 20269, 20291, 20290, 21120, 21164, 21165, 21162
8998, 20269, 2881, 2882, 20291, 21121, 2904, 21166, 21164
8999, 2837, 20270, 20292, 2838, 21123, 21167, 21168, 2860
9000, 20270, 20271, 20293, 20292, 21125, 21169, 21170, 21167
9001, 20271, 20272, 20294, 20293, 21127, 21171, 21172, 21169
9002, 20272, 20273, 20295, 20294, 21129, 21173, 21174, 21171
9003, 20273, 20274, 20296, 20295, 21131, 21175, 21176, 21173
9004, 20274, 20275, 20297, 20296, 21133, 21177, 21178, 21175
9005, 20275, 20276, 20298, 20297, 21135, 21179, 21180, 21177
9006, 20276, 20277, 20299, 20298, 21137, 21181, 21182, 21179
9007, 20277, 20278, 20300, 20299, 21139, 21183, 21184, 21181
9008, 20278, 20279, 20301, 20300, 21141, 21185, 21186, 21183
9009, 20279, 20280, 20302, 20301, 21143, 21187, 21188, 21185
9010, 20280, 20281, 20303, 20302, 21145, 21189, 21190, 21187
9011, 20281, 20282, 20304, 20303, 21147, 21191, 21192, 21189
9012, 20282, 20283, 20305, 20304, 21149, 21193, 21194, 21191
9013, 20283, 20284, 20306, 20305, 21151, 21195, 21196, 21193
9014, 20284, 20285, 20307, 20306, 21153, 21197, 21198, 21195
9015, 20285, 20286, 20308, 20307, 21155, 21199, 21200, 21197
9016, 20286, 20287, 20309, 20308, 21157, 21201, 21202, 21199
9017, 20287, 20288, 20310, 20309, 21159, 21203, 21204, 21201
9018, 20288, 20289, 20311, 20310, 21161, 21205, 21206, 21203
9019, 20289, 20290, 20312, 20311, 21163, 21207, 21208, 21205
9020, 20290, 20291, 20313, 20312, 21165, 21209, 21210, 21207
9021, 20291, 2882, 2883, 20313, 21166, 2905, 21211, 21209
9022, 2838, 20292, 20314, 2839, 21168, 21212, 21213, 2861
9023, 20292, 20293, 20315, 20314, 21170, 21214, 21215, 21212
9024, 20293, 20294, 20316, 20315, 21172, 21216, 21217, 21214
9025, 20294, 20295, 20317, 20316, 21174, 21218, 21219, 21216
9026, 20295, 20296, 20318, 20317, 21176, 21220, 21221, 21218
9027, 20296, 20297, 20319, 20318, 21178, 21222, 21223, 21220
9028, 20297, 20298, 20320, 20319, 21180, 21224, 21225, 21222
9029, 20298, 20299, 20321, 20320, 21182, 21226, 21227, 21224
9030, 20299, 20300, 20322, 20321, 21184, 21228, 21229, 21226
9031, 20300, 20301, 20323, 20322, 21186, 21230, 21231, 21228
9032, 20301, 20302, 20324, 20323, 21188, 21232, 21233, 21230
9033, 20302, 20303, 20325, 20324, 21190, 21234, 21235, 21232
9034, 20303, 20304, 20326, 20325, 21192, 21236, 21237, 21234
9035, 20304, 20305, 20327, 20326, 21194, 21238, 21239, 21236
9036, 20305, 20306, 20328, 20327, 21196, 21240, 21241, 21238
9037, 20306, 20307, 20329, 20328, 21198, 21242, 21243, 21240
9038, 20307, 20308, 20330, 20329, 21200, 21244, 21245, 21242
9039, 20308, 20309, 20331, 20330, 21202, 21246, 21247, 21244
9040, 20309, 20310, 20332, 20331, 21204, 21248, 21249, 21246
9041, 20310, 20311, 20333, 20332, 21206, 21250, 21251, 21248
9042, 20311, 20312, 20334, 20333, 21208, 21252, 21253, 21250
9043, 20312, 20313, 20335, 20334, 21210, 21254, 21255, 21252
9044, 20313, 2883, 2884, 20335, 21211, 2906, 21256, 21254
9045, 2839, 20314, 20336, 2840, 21213, 21257, 21258, 2862
9046, 20314, 20315, 20337, 20336, 21215, 21259, 21260, 21257
9047, 20315, 20316, 20338, 20337, 21217, 21261, 21262, 21259
9048, 20316, 20317, 20339, 20338, 21219, 21263, 21264, 21261
9049, 20317, 20318, 20340, 20339, 21221, 21265, 21266, 21263
9050, 20318, 20319, 20341, 20340, 21223, 21267, 21268, 21265
9051, 20319, 20320, 20342, 20341, 21225, 21269, 21270, 21267
9052, 20320, 20321, 20343, 20342, 21227, 21271, 21272, 21269
9053, 20321, 20322, 20344, 20343, 21229, 21273, 21274, 21271
9054, 20322, 20323, 20345, 20344, 21231, 21275, 21276, 21273
9055, 20323, 20324, 20346, 20345, 21233, 21277, 21278, 21275
9056, 20324, 20325, 20347, 20346, 21235, 21279, 21280, 21277
9057, 20325, 20326, 20348, 20347, 21237, 21281, 21282, 21279
9058, 20326, 20327, 20349, 20348, 21239, 21283, 21284, 21281
9059, 20327, 20328, 20350, 20349, 21241, 21285, 21286, 21283
9060, 20328, 20329, 20351, 20350, 21243, 21287, 21288, 21285
9061, 20329, 20330, 20352, 20351, 21245, 21289, 21290, 21287
9062, 20330, 20331, 20353, 20352, 21247, 21291, 21292, 21289
9063, 20331, 20332, 20354, 20353, 21249, 21293, 21294, 21291
9064, 20332, 20333, 20355, 20354, 21251, 21295, 21296, 21293
9065, 20333, 20334, 20356, 20355, 21253, 21297, 21298, 21295
9066, 20334, 20335, 20357, 20356, 21255, 21299, 21300, 21297
9067, 20335, 2884, 2885, 20357, 21256, 2907, 21301, 21299
9068, 2840, 20336, 20358, 2841, 21258, 21302, 21303, 2863
9069, 20336, 20337, 20359, 20358, 21260, 21304, 21305, 21302
9070, 20337, 20338, 20360, 20359, 21262, 21306, 21307, 21304
9071, 20338, 20339, 20361, 20360, 21264, 21308, 21309, 21306
9072, 20339, 20340, 20362, 20361, 21266, 21310, 21311, 21308
9073, 20340, 20341, 20363, 20362, 21268, 21312, 21313, 21310
9074, 20341, 20342, 20364, 20363, 21270, 21314, 21315, 21312
9075, 20342, 20343, 20365, 20364, 21272, 21316, 21317, 21314
9076, 20343, 20344, 20366, 20365, 21274, 21318, 21319, 21316
9077, 20344, 20345, 20367, 20366, 21276, 21320, 21321, 21318
9078, 20345, 20346, 20368, 20367, 21278, 21322, 21323, 21320
9079, 20346, 20347, 20369, 20368, 21280, 21324, 21325, 21322
9080, 20347, 20348, 20370, 20369, 21282, 21326, 21327, 21324
9081, 20348, 20349, 20371, 20370, 21284, 21328, 21329, 21326
9082, 20349, 20350, 20372, 20371, 21286, 21330, 21331, 21328
9083, 20350, 20351, 20373, 20372, 21288, 21332, 21333, 21330
9084, 20351, 20352, 20374, 20373, 21290, 21334, 21335, 21332
9085, 20352, 20353, 20375, 20374, 21292, 21336, 21337, 21334
9086, 20353, 20354, 20376, 20375, 21294, 21338, 21339, 21336
9087, 20354, 20355, 20377, 20376, 21296, 21340, 21341, 21338
9088, 20355, 20356, 20378, 20377, 21298, 21342, 21343, 21340
9089, 20356, 20357, 20379, 20378, 21300, 21344, 21345, 21342
9090, 20357, 2885, 2886, 20379, 21301, 2908, 21346, 21344
9091, 2841, 20358, 20380, 2842, 21303, 21347, 21348, 2864
9092, 20358, 20359, 20381, 20380, 21305, 21349, 21350, 21347
9093, 20359, 20360, 20382, 20381, 21307, 21351, 21352, 21349
9094, 20360, 20361, 20383, 20382, 21309, 21353, 21354, 21351
9095, 20361, 20362, 20384, 20383, 21311, 21355, 21356, 21353
9096, 20362, 20363, 20385, 20384, 21313, 21357, 21358, 21355
9097, 20363, 20364, 20386, 20385, 21315, 21359, 21360, 21357
9098, 20364, 20365, 20387, 20386, 21317, 21361, 21362, 21359
9099, 20365, 20366, 20388, 20387, 21319, 21363, 21364, 21361
9100, 20366, 20367, 20389, 20388, 21321, 21365, 21366, 21363
9101, 20367, 20368, 20390, 20389, 21323, 21367, 21368, 21365
9102, 20368, 20369, 20391, 20390, 21325, 21369, 21370, 21367
9103, 20369, 20370, 20392, 20391, 21327, 21371, 21372, 21369
9104, 20370, 20371, 20393, 20392, 21329, 21373, 21374, 21371
9105, 20371, 20372, 20394, 20393, 21331, 21375, 21376, 21373
9106, 20372, 20373, 20395, 20394, 21333, 21377, 21378, 21375
9107, 20373, 20374, 20396, 20395, 21335, 21379, 21380, 21377
9108, 20374, 20375, 20397, 20396, 21337, 21381, 21382, 21379
9109, 20375, 20376, 20398, 20397, 21339, 21383, 21384, 21381
9110, 20376, 20377, 20399, 20398, 21341, 21385, 21386, 21383
9111, 20377, 20378, 20400, 20399, 21343, 21387, 21388, 21385
9112, 20378, 20379, 20401, 20400, 21345, 21389, 21390, 21387
9113, 20379, 2886, 2887, 20401, 21346, 2909, 21391, 21389
9114, 2842, 20380, 2932, 89, 21348, 21392, 2955, 2865
9115, 20380, 20381, 2931, 2932, 21350, 21393, 2954, 21392
9116, 20381, 20382, 2930, 2931, 21352, 21394, 2953, 21393
9117, 20382, 20383, 2929, 2930, 21354, 21395, 2952, 21394
9118, 20383, 20384, 2928, 2929, 21356, 21396, 2951, 21395
9119, 20384, 20385, 2927, 2928, 21358, 21397, 2950, 21396
9120, 20385, 20386, 2926, 2927, 21360, 21398, 2949, 21397
9121, 20386, 20387, 2925, 2926, 21362, 21399, 2948, 21398
9122, 20387, 20388, 2924, 2925, 21364, 21400, 2947, 21399
9123, 20388, 20389, 2923, 2924, 21366, 21401, 2946, 21400
9124, 20389, 20390, 2922, 2923, 21368, 21402, 2945, 21401
9125, 20390, 20391, 2921, 2922, 21370, 21403, 2944, 21402
9126, 20391, 20392, 2920, 2921, 21372, 21404, 2943, 21403
9127, 20392, 20393, 2919, 2920, 21374, 21405, 2942, 21404
9128, 20393, 20394, 2918, 2919, 21376, 21406, 2941, 21405
9129, 20394, 20395, 2917, 2918, 21378, 21407, 2940, 21406
9130, 20395, 20396, 2916, 2917, 21380, 21408, 2939, 21407
9131, 20396, 20397, 2915, 2916, 21382, 21409, 2938, 21408
9132, 20397, 20398, 2914, 2915, 21384, 21410, 2937, 21409
9133, 20398, 20399, 2913, 2914, 21386, 21411, 2936, 21410
9134, 20399, 20400, 2912, 2913, 21388, 21412, 2935, 21411
9135, 20400, 20401, 2911, 2912, 21390, 21413, 2934, 21412
9136, 20401, 2887, 90, 2911, 21391, 2910, 2933, 21413
*ELEMENT, type=CPS8, ELSET=Surface261
9137, 3, 161, 21414, 2956, 170, 21590, 21591, 2978
9138, 161, 160, 21415, 21414, 169, 21592, 21593, 21590
9139, 160, 159, 21416, 21415, 168, 21594, 21595, 21592
9140, 159, 158, 21417, 21416, 167, 21596, 21597, 21594
9141, 158, 157, 21418, 21417, 166, 21598, 21599, 21596
9142, 157, 156, 21419, 21418, 165, 21600, 21601, 21598
9143, 156, 155, 21420, 21419, 164, 21602, 21603, 21600
9144, 155, 154, 21421, 21420, 163, 21604, 21605, 21602
9145, 154, 1, 2821, 21421, 162, 2843, 21606, 21604
9146, 2956, 21414, 21422, 2957, 21591, 21607, 21608, 2979
9147, 21414, 21415, 21423, 21422, 21593, 21609, 21610, 21607
9148, 21415, 21416, 21424, 21423, 21595, 21611, 21612, 21609
9149, 21416, 21417, 21425, 21424, 21597, 21613, 21614, 21611
9150, 21417, 21418, 21426, 21425, 21599, 21615, 21616, 21613
9151, 21418, 21419, 21427, 21426, 21601, 21617, 21618, 21615
9152, 21419, 21420, 21428, 21427, 21603, 21619, 21620, 21617
9153, 21420, 21421, 21429, 21428, 21605, 21621, 21622, 21619
9154, 21421, 2821, 2822, 21429, 21606, 2844, 21623, 21621
9155, 2957, 21422, 21430, 2958, 21608, 21624, 21625, 2980
9156, 21422, 21423, 21431, 21430, 21610, 21626, 21627, 21624
9157, 21423, 21424, 21432, 21431, 21612, 21628, 21629, 21626
9158, 21424, 21425, 21433, 21432, 21614, 21630, 21631, 21628
9159, 21425, 21426, 21434, 21433, 21616, 21632, 21633, 21630
9160, 21426, 21427, 21435, 21434, 21618, 21634, 21635, 21632
9161, 21427, 21428, 21436, 21435, 21620, 21636, 21637, 21634
9162, 21428, 21429, 21437, 21436, 21622, 21638, 21639, 21636
9163, 21429, 2822, 2823, 21437, 21623, 2845, 21640, 21638
9164, 2958, 21430, 21438, 2959, 21625, 21641, 21642, 2981
9165, 21430, 21431, 21439, 21438, 21627, 21643, 21644, 21641
9166, 21431, 21432, 21440, 21439, 21629, 21645, 21646, 21643
9167, 21432, 21433, 21441, 21440, 21631, 21647, 21648, 21645
9168, 21433, 21434, 21442, 21441, 21633, 21649, 21650, 21647
9169, 21434, 21435, 21443, 21442, 21635, 21651, 21652, 21649
9170, 21435, 21436, 21444, 21443, 21637, 21653, 21654, 21651
9171, 21436, 21437, 21445, 21444, 21639, 21655, 21656, 21653
9172, 21437, 2823, 2824, 21445, 21640, 2846, 21657, 21655
9173, 2959, 21438, 21446, 2960, 21642, 21658, 21659, 2982
9174, 21438, 21439, 21447, 21446, 21644, 21660, 21661, 21658
9175, 21439, 21440, 21448, 21447, 21646, 21662, 21663, 21660
9176, 21440, 21441, 21449, 21448, 21648, 21664, 21665, 21662
9177, 21441, 21442, 21450, 21449, 21650, 21666, 21667, 21664
9178, 21442, 21443, 21451, 21450, 21652, 21668, 21669, 21666
9179, 21443, 21444, 21452, 21451, 21654, 21670, 21671, 21668
9180, 21444, 21445, 21453, 21452, 21656, 21672, 21673, 21670
9181, 21445, 2824, 2825, 21453, 21657, 2847, 21674, 21672
9182, 2960, 21446, 21454, 2961, 21659, 21675, 21676, 2983
9183, 21446, 21447, 21455, 21454, 21661, 21677, 21678, 21675
9184, 21447, 21448, 21456, 21455, 21663, 21679, 21680, 21677
9185, 21448, 21449, 21457, 21456, 21665, 21681, 21682, 21679
9186, 21449, 21450, 21458, 21457, 21667, 21683, 21684, 21681
9187, 21450, 21451, 21459, 21458, 21669, 21685, 21686, 21683
9188, 21451, 21452, 21460, 21459, 21671, 21687, 21688, 21685
9189, 21452, 21453, 21461, 21460, 21673, 21689, 21690, 21687
9190, 21453, 2825, 2826, 21461, 21674, 2848, 21691, 21689
9191, 2961, 21454, 21462, 2962, 21676, 21692, 21693, 2984
9192, 21454, 21455, 21463, 21462, 21678, 21694, 21695, 21692
9193, 21455, 21456, 21464, 21463, 21680, 21696, 21697, 21694
9194, 21456, 21457, 21465, 21464, 21682, 21698, 21699, 21696
9195, 21457, 21458, 21466, 21465, 21684, 21700, 21701, 21698
9196, 21458, 21459, 21467, 21466, 21686, 21702, 21703, 21700
9197, 21459, 21460, 21468, 21467, 21688, 21704, 21705, 21702
9198, 21460, 21461, 21469, 21468, 21690, 21706, 21707, 21704
9199, 21461, 2826, 2827, 21469, 21691, 2849, 21708, 21706
9200, 2962, 21462, 21470, 2963, 21693, 21709, 21710, 2985
9201, 21462, 21463, 21471, 21470, 21695, 21711, 21712, 21709
9202, 21463, 21464, 21472, 21471, 21697, 21713, 21714, 21711
9203, 21464, 21465, 21473, 21472, 21699, 21715, 21716, 21713
9204, 21465, 21466, 21474, 21473, 21701, 21717, 21718, 21715
9205, 21466, 21467, 21475, 21474, 21703, 21719, 21720, 21717
9206, 21467, 21468, 21476, 21475, 21705, 21721, 21722, 21719
9207, 21468, 21469, 21477, 21476, 21707, 21723, 21724, 21721
9208, 21469, 2827, 2828, 21477, 21708, 2850, 21725, 21723
9209, 2963, 21470, 21478, 2964, 21710, 21726, 21727, 2986
9210, 21470, 21471, 21479, 21478, 21712, 21728, 21729, 21726
9211, 21471, 21472, 21480, 21479, 21714, 21730, 21731, 21728
9212, 21472, 21473, 21481, 21480, 21716, 21732, 21733, 21730
9213, 21473, 21474, 21482, 21481, 21718, 21734, 21735, 21732
9214, 21474, 21475, 21483, 21482, 21720, 21736, 21737, 21734
9215, 21475, 21476, 21484, 21483, 21722, 21738, 21739, 21736
9216, 21476, 21477, 21485, 21484, 21724, 21740, 21741, 21738
9217, 21477, 2828, 2829, 21485, 21725, 2851, 21742, 21740
9218, 2964, 21478, 21486, 2965, 21727, 21743, 21744, 2987
9219, 21478, 21479, 21487, 21486, 21729, 21745, 21746, 21743
9220, 21479, 21480, 21488, 21487, 21731, 21747, 21748, 21745
9221, 21480, 21481, 21489, 21488, 21733, 21749, 21750, 21747
9222, 21481, 21482, 21490, 21489, 21735, 21751, 21752, 21749
9223, 21482, 21483, 21491, 21490, 21737, 21753, 21754, 21751
9224, 21483, 21484, 21492, 21491, 21739, 21755, 21756, 21753
9225, 21484, 21485, 21493, 21492, 21741, 21757, 21758, 21755
9226, 21485, 2829, 2830, 21493, 21742, 2852, 21759, 21757
9227, 2965, 21486, 21494, 2966, 21744, 21760, 21761, 2988
9228, 21486, 21487, 21495, 21494, 21746, 21762, 21763, 21760
9229, 21487, 21488, 21496, 21495, 21748, 21764, 21765, 21762
9230, 21488, 21489, 21497, 21496, 21750, 21766, 21767, 21764
9231, 21489, 21490, 21498, 21497, 21752, 21768, 21769, 21766
9232, 21490, 21491, 21499, 21498, 21754, 21770, 21771, 21768
9233, 21491, 21492, 21500, 21499, 21756, 21772, 21773, 21770
9234, 21492, 21493, 21501, 21500, 21758, 21774, 21775, 21772
9235, 21493, 2830, 2831, 21501, 21759, 2853, 21776, 21774
9236, 2966, 21494, 21502, 2967, 21761, 21777, 21778, 2989
9237, 21494, 21495, 21503, 21502, 21763, 21779, 21780, 21777
9238, 21495, 21496, 21504, 21503, 21765, 21781, 21782, 21779
9239, 21496, 21497, 21505, 21504, 21767, 21783, 21784, 21781
9240, 21497, 21498, 21506, 21505, 21769, 21785, 21786, 21783
9241, 21498, 21499, 21507, 21506, 21771, 21787, 21788, 21785
9242, 21499, 21500, 21508, 21507, 21773, 21789, 21790, 21787
9243, 21500, 21501, 21509, 21508, 21775, 21791, 21792, 21789
9244, 21501, 2831, 2832, 21509, 21776, 2854, 21793, 21791
9245, 2967, 21502, 21510, 2968, 21778, 21794, 21795, 2990
9246, 21502, 21503, 21511, 21510, 21780, 21796, 21797, 21794
9247, 21503, 21504, 21512, 21511, 21782, 21798, 21799, 21796
9248, 21504, 21505, 21513, 21512, 21784, 21800, 21801, 21798
9249, 21505, 21506, 21514, 21513, 21786, 21802, 21803, 21800
9250, 21506, 21507, 21515, 21514, 21788, 21804, 21805, 21802
9251, 21507, 21508, 21516, 21515, 21790, 21806, 21807, 21804
9252, 21508, 21509, 21517, 21516, 21792, 21808, 21809, 21806
9253, 21509, 2832, 2833, 21517, 21793, 2855, 21810, 21808
9254, 2968, 21510, 21518, 2969, 21795, 21811, 21812, 2991
9255, 21510, 21511, 21519, 21518, 21797, 21813, 21814, 21811
9256, 21511, 21512, 21520, 21519, 21799, 21815, 21816, 21813
9257, 21512, 21513, 21521, 21520, 21801, 21817, 21818, 21815
9258, 21513, 21514, 21522, 21521, 21803, 21819, 21820, 21817
9259, 21514, 21515, 21523, 21522, 21805, 21821, 21822, 21819
9260, 21515, 21516, 21524, 21523, 21807, 21823, 21824, 21821
9261, 21516, 21517, 21525, 21524, 21809, 21825, 21826, 21823
9262, 21517, 2833, 2834, 21525, 21810, 2856, 21827, 21825
9263, 2969, 21518, 21526, 2970, 21812, 21828, 21829, 2992
9264, 21518, 21519, 21527, 21526, 21814, 21830, 21831, 21828
9265, 21519, 21520, 21528, 21527, 21816, 21832, 21833, 21830
9266, 21520, 21521, 21529, 21528, 21818, 21834, 21835, 21832
9267, 21521, 21522, 21530, 21529, 21820, 21836, 21837, 21834
9268, 21522, 21523, 21531, 21530, 21822, 21838, 21839, 21836
9269, 21523, 21524, 21532, 21531, 21824, 21840, 21841, 21838
9270, 21524, 21525, 21533, 21532, 21826, 21842, 21843, 21840
9271, 21525, 2834, 2835, 21533, 21827, 2857, 21844, 21842
9272, 2970, 21526, 21534, 2971, 21829, 21845, 21846, 2993
9273, 21526, 21527, 21535, 21534, 21831, 21847, 21848, 21845
9274, 21527, 21528, 21536, 21535, 21833, 21849, 21850, 21847
9275, 21528, 21529, 21537, 21536, 21835, 21851, 21852, 21849
9276, 21529, 21530, 21538, 21537, 21837, 21853, 21854, 21851
9277, 21530, 21531, 21539, 21538, 21839, 21855, 21856, 21853
9278, 21531, 21532, 21540, 21539, 21841, 21857, 21858, 21855
9279, 21532, 21533, 21541, 21540, 21843, 21859, 21860, 21857
9280, 21533, 2835, 2836, 21541, 21844, 2858, 21861, 21859
9281, 2971, 21534, 21542, 2972, 21846, 21862, 21863, 2994
9282, 21534, 21535, 21543, 21542, 21848, 21864, 21865, 21862
9283, 21535, 21536, 21544, 21543, 21850, 21866, 21867, 21864
9284, 21536, 21537, 21545, 21544, 21852, 21868, 21869, 21866
9285, 21537, 21538, 21546, 21545, 21854, 21870, 21871, 21868
9286, 21538, 21539, 21547, 21546, 21856, 21872, 21873, 21870
9287, 21539, 21540, 21548, 21547, 21858, 21874, 21875, 21872
9288, 21540, 21541, 21549, 21548, 21860, 21876, 21877, 21874
9289, 21541, 2836, 2837, 21549, 21861, 2859, 21878, 21876
9290, 2972, 21542, 21550, 2973, 21863, 21879, 21880, 2995
9291, 21542, 21543, 21551, 21550, 21865, 21881, 21882, 21879
9292, 21543, 21544, 21552, 21551, 21867, 21883, 21884, 21881
9293, 21544, 21545, 21553, 21552, 21869, 21885, 21886, 21883
9294, 21545, 21546, 21554, 21553, 21871, 21887, 21888, 21885
9295, 21546, 21547, 21555, 21554, 21873, 21889, 21890, 21887
9296, 21547, 21548, 21556, 21555, 21875, 21891, 21892, 21889
9297, 21548, 21549, 21557, 21556, 21877, 21893, 21894, 21891
9298, 21549, 2837, 2838, 21557, 21878, 2860, 21895, 21893
9299, 2973, 21550, 21558, 2974, 21880, 21896, 21897, 2996
9300, 21550, 21551, 21559, 21558, 21882, 21898, 21899, 21896
9301, 21551, 21552, 21560, 21559, 21884, 21900, 21901, 21898
9302, 21552, 21553, 21561, 21560, 21886, 21902, 21903, 21900
9303, 21553, 21554, 21562, 21561, 21888, 21904, 21905, 21902
9304, 21554, 21555, 21563, 21562, 21890, 21906, 21907, 21904
9305, 21555, 21556, 21564, 21563, 21892, 21908, 21909, 21906
9306, 21556, 21557, 21565, 21564, 21894, 21910, 21911, 21908
9307, 21557, 2838, 2839, 21565, 21895, 2861, 21912, 21910
9308, 2974, 21558, 21566, 2975, 21897, 21913, 21914, 2997
9309, 21558, 21559, 21567, 21566, 21899, 21915, 21916, 21913
9310, 21559, 21560, 21568, 21567, 21901, 21917, 21918, 21915
9311, 21560, 21561, 21569, 21568, 21903, 21919, 21920, 21917
9312, 21561, 21562, 21570, 21569, 21905, 21921, 21922, 21919
9313, 21562, 21563, 21571, 21570, 21907, 21923, 21924, 21921
9314, 21563, 21564, 21572, 21571, 21909, 21925, 21926, 21923
9315, 21564, 21565, 21573, 21572, 21911, 21927, 21928, 21925
9316, 21565, 2839, 2840, 21573, 21912, 2862, 21929, 21927
9317, 2975, 21566, 21574, 2976, 21914, 21930, 21931, 2998
9318, 21566, 21567, 21575, 21574, 21916, 21932, 21933, 21930
9319, 21567, 21568, 21576, 21575, 21918, 21934, 21935, 21932
9320, 21568, 21569, 21577, 21576, 21920, 21936, 21937, 21934
9321, 21569, 21570, 21578, 21577, 21922, 21938, 21939, 21936
9322, 21570, 21571, 21579, 21578, 21924, 21940, 21941, 21938
9323, 21571, 21572, 21580, 21579, 21926, 21942, 21943, 21940
9324, 21572, 21573, 21581, 21580, 21928, 21944, 21945, 21942
9325, 21573, 2840, 2841, 21581, 21929, 2863, 21946, 21944
9326, 2976, 21574, 21582, 2977, 21931, 21947, 21948, 2999
9327, 21574, 21575, 21583, 21582, 21933, 21949, 21950, 21947
9328, 21575, 21576, 21584, 21583, 21935, 21951, 21952, 21949
9329, 21576, 21577, 21585, 21584, 21937, 21953, 21954, 21951
9330, 21577, 21578, 21586, 21585, 21939, 21955, 21956, 21953
9331, 21578, 21579, 21587, 21586, 21941, 21957, 21958, 21955
9332, 21579, 21580, 21588, 21587, 21943, 21959, 21960, 21957
9333, 21580, 21581, 21589, 21588, 21945, 21961, 21962, 21959
9334, 21581, 2841, 2842, 21589, 21946, 2864, 21963, 21961
9335, 2977, 21582, 3008, 91, 21948, 21964, 3017, 3000
9336, 21582, 21583, 3007, 3008, 21950, 21965, 3016, 21964
9337, 21583, 21584, 3006, 3007, 21952, 21966, 3015, 21965
9338, 21584, 21585, 3005, 3006, 21954, 21967, 3014, 21966
9339, 21585, 21586, 3004, 3005, 21956, 21968, 3013, 21967
9340, 21586, 21587, 3003, 3004, 21958, 21969, 3012, 21968
9341, 21587, 21588, 3002, 3003, 21960, 21970, 3011, 21969
9342, 21588, 21589, 3001, 3002, 21962, 21971, 3010, 21970
9343, 21589, 2842, 89, 3001, 21963, 2865, 3009, 21971
*ELEMENT, type=CPS8, ELSET=Surface262
9344, 3, 2956, 21972, 192, 2978, 22456, 22457, 215
9345, 192, 21972, 21973, 191, 22457, 22458, 22459, 214
9346, 191, 21973, 21974, 190, 22459, 22460, 22461, 213
9347, 190, 21974, 21975, 189, 22461, 22462, 22463, 212
9348, 189, 21975, 21976, 188, 22463, 22464, 22465, 211
9349, 188, 21976, 21977, 187, 22465, 22466, 22467, 210
9350, 187, 21977, 21978, 186, 22467, 22468, 22469, 209
9351, 186, 21978, 21979, 185, 22469, 22470, 22471, 208
9352, 185, 21979, 21980, 184, 22471, 22472, 22473, 207
9353, 184, 21980, 21981, 183, 22473, 22474, 22475, 206
9354, 183, 21981, 21982, 182, 22475, 22476, 22477, 205
9355, 182, 21982, 21983, 181, 22477, 22478, 22479, 204
9356, 181, 21983, 21984, 180, 22479, 22480, 22481, 203
9357, 180, 21984, 21985, 179, 22481, 22482, 22483, 202
9358, 179, 21985, 21986, 178, 22483, 22484, 22485, 201
9359, 178, 21986, 21987, 177, 22485, 22486, 22487, 200
9360, 177, 21987, 21988, 176, 22487, 22488, 22489, 199
9361, 176, 21988, 21989, 175, 22489, 22490, 22491, 198
9362, 175, 21989, 21990, 174, 22491, 22492, 22493, 197
9363, 174, 21990, 21991, 173, 22493, 22494, 22495, 196
9364, 173, 21991, 21992, 172, 22495, 22496, 22497, 195
9365, 172, 21992, 21993, 171, 22497, 22498, 22499, 194
9366, 171, 21993, 3018, 4, 22499, 22500, 3040, 193
9367, 2956, 2957, 21994, 21972, 2979, 22501, 22502, 22456
9368, 21972, 21994, 21995, 21973, 22502, 22503, 22504, 22458
9369, 21973, 21995, 21996, 21974, 22504, 22505, 22506, 22460
9370, 21974, 21996, 21997, 21975, 22506, 22507, 22508, 22462
9371, 21975, 21997, 21998, 21976, 22508, 22509, 22510, 22464
9372, 21976, 21998, 21999, 21977, 22510, 22511, 22512, 22466
9373, 21977, 21999, 22000, 21978, 22512, 22513, 22514, 22468
9374, 21978, 22000, 22001, 21979, 22514, 22515, 22516, 22470
9375, 21979, 22001, 22002, 21980, 22516, 22517, 22518, 22472
9376, 21980, 22002, 22003, 21981, 22518, 22519, 22520, 22474
9377, 21981, 22003, 22004, 21982, 22520, 22521, 22522, 22476
9378, 21982, 22004, 22005, 21983, 22522, 22523, 22524, 22478
9379, 21983, 22005, 22006, 21984, 22524, 22525, 22526, 22480
9380, 21984, 22006, 22007, 21985, 22526, 22527, 22528, 22482
9381, 21985, 22007, 22008, 21986, 22528, 22529, 22530, 22484
9382, 21986, 22008, 22009, 21987, 22530, 22531, 22532, 22486
9383, 21987, 22009, 22010, 21988, 22532, 22533, 22534, 22488
9384, 21988, 22010, 22011, 21989, 22534, 22535, 22536, 22490
9385, 21989, 22011, 22012, 21990, 22536, 22537, 22538, 22492
9386, 21990, 22012, 22013, 21991, 22538, 22539, 22540, 22494
9387, 21991, 22013, 22014, 21992, 22540, 22541, 22542, 22496
9388, 21992, 22014, 22015, 21993, 22542, 22543, 22544, 22498
9389, 21993, 22015, 3019, 3018, 22544, 22545, 3041, 22500
9390, 2957, 2958, 22016, 21994, 2980, 22546, 22547, 22501
9391, 21994, 22016, 22017, 21995, 22547, 22548, 22549, 22503
9392, 21995, 22017, 22018, 21996, 22549, 22550, 22551, 22505
9393, 21996, 22018, 22019, 21997, 22551, 22552, 22553, 22507
9394, 21997, 22019, 22020, 21998, 22553, 22554, 22555, 22509
9395, 21998, 22020, 22021, 21999, 22555, 22556, 22557, 22511
9396, 21999, 22021, 22022, 22000, 22557, 22558, 22559, 22513
9397, 22000, 22022, 22023, 22001, 22559, 22560, 22561, 22515
9398, 22001, 22023, 22024, 22002, 22561, 22562, 22563, 22517
9399, 22002, 22024, 22025, 22003, 22563, 22564, 22565, 22519
9400, 22003, 22025, 22026, 22004, 22565, 22566, 22567, 22521
9401, 22004, 22026, 22027, 22005, 22567, 22568, 22569, 22523
9402, 22005, 22027, 22028, 22006, 22569, 22570, 22571, 22525
9403, 22006, 22028, 22029, 22007, 22571, 22572, 22573, 22527
9404, 22007, 22029, 22030, 22008, 22573, 22574, 22575, 22529
9405, 22008, 22030, 22031, 22009, 22575, 22576, 22577, 22531
9406, 22009, 22031, 22032, 22010, 22577, 22578, 22579, 22533
9407, 22010, 22032, 22033, 22011, 22579, 22580, 22581, 22535
9408, 22011, 22033, 22034, 22012, 22581, 22582, 22583, 22537
9409, 22012, 22034, 22035, 22013, 22583, 22584, 22585, 22539
9410, 22013, 22035, 22036, 22014, 22585, 22586, 22587, 22541
9411, 22014, 22036, 22037, 22015, 22587, 22588, 22589, 22543
9412, 22015, 22037, 3020, 3019, 22589, 22590, 3042, 22545
9413, 2958, 2959, 22038, 22016, 2981, 22591, 22592, 22546
9414, 22016, 22038, 22039, 22017, 22592, 22593, 22594, 22548
9415, 22017, 22039, 22040, 22018, 22594, 22595, 22596, 22550
9416, 22018, 22040, 22041, 22019, 22596, 22597, 22598, 22552
9417, 22019, 22041, 22042, 22020, 22598, 22599, 22600, 22554
9418, 22020, 22042, 22043, 22021, 22600, 22601, 22602, 22556
9419, 22021, 22043, 22044, 22022, 22602, 22603, 22604, 22558
9420, 22022, 22044, 22045, 22023, 22604, 22605, 22606, 22560
9421, 22023, 22045, 22046, 22024, 22606, 22607, 22608, 22562
9422, 22024, 22046, 22047, 22025, 22608, 22609, 22610, 22564
9423, 22025, 22047, 22048, 22026, 22610, 22611, 22612, 22566
9424, 22026, 22048, 22049, 22027, 22612, 22613, 22614, 22568
9425, 22027, 22049, 22050, 22028, 22614, 22615, 22616, 22570
9426, 22028, 22050, 22051, 22029, 22616, 22617, 22618, 22572
9427, 22029, 22051, 22052, 22030, 22618, 22619, 22620, 22574
9428, 22030, 22052, 22053, 22031, 22620, 22621, 22622, 22576
9429, 22031, 22053, 22054, 22032, 22622, 22623, 22624, 22578
9430, 22032, 22054, 22055, 22033, 22624, 22625, 22626, 22580
9431, 22033, 22055, 22056, 22034, 22626, 22627, 22628, 22582
9432, 22034, 22056, 22057, 22035, 22628, 22629, 22630, 22584
9433, 22035, 22057, 22058, 22036, 22630, 22631, 22632, 22586
9434, 22036, 22058, 22059, 22037, 22632, 22633, 22634, 22588
9435, 22037, 22059, 3021, 3020, 22634, 22635, 3043, 22590
9436, 2959, 2960, 22060, 22038, 2982, 22636, 22637, 22591
9437, 22038, 22060, 22061, 22039, 22637, 22638, 22639, 22593
9438, 22039, 22061, 22062, 22040, 22639, 22640, 22641, 22595
9439, 22040, 22062, 22063, 22041, 22641, 22642, 22643, 22597
9440, 22041, 22063, 22064, 22042, 22643, 22644, 22645, 22599
9441, 22042, 22064, 22065, 22043, 22645, 22646, 22647, 22601
9442, 22043, 22065, 22066, 22044, 22647, 22648, 22649, 22603
9443, 22044, 22066, 22067, 22045, 22649, 22650, 22651, 22605
9444, 22045, 22067, 22068, 22046, 22651, 22652, 22653, 22607
9445, 22046, 22068, 22069, 22047, 22653, 22654, 22655, 22609
9446, 22047, 22069, 22070, 22048, 22655, 22656, 22657, 22611
9447, 22048, 22070, 22071, 22049, 22657, 22658, 22659, 22613
9448, 22049, 22071, 22072, 22050, 22659, 22660, 22661, 22615
9449, 22050, 22072, 22073, 22051, 22661, 22662, 22663, 22617
9450, 22051, 22073, 22074, 22052, 22663, 22664, 22665, 22619
9451, 22052, 22074, 22075, 22053, 22665, 22666, 22667, 22621
9452, 22053, 22075, 22076, 22054, 22667, 22668, 22669, 22623
9453, 22054, 22076, 22077, 22055, 22669, 22670, 22671, 22625
9454, 22055, 22077, 22078, 22056, 22671, 22672, 22673, 22627
9455, 22056, 22078, 22079, 22057, 22673, 22674, 22675, 22629
9456, 22057, 22079, 22080, 22058, 22675, 22676, 22677, 22631
9457, 22058, 22080, 22081, 22059, 22677, 22678, 22679, 22633
9458, 22059, 22081, 3022, 3021, 22679, 22680, 3044, 22635
9459, 2960, 2961, 22082, 22060, 2983, 22681, 22682, 22636
9460, 22060, 22082, 22083, 22061, 22682, 22683, 22684, 22638
9461, 22061, 22083, 22084, 22062, 22684, 22685, 22686, 22640
9462, 22062, 22084, 22085, 22063, 22686, 22687, 22688, 22642
9463, 22063, 22085, 22086, 22064, 22688, 22689, 22690, 22644
9464, 22064, 22086, 22087, 22065, 22690, 22691, 22692, 22646
9465, 22065, 22087, 22088, 22066, 22692, 22693, 22694, 22648
9466, 22066, 22088, 22089, 22067, 22694, 22695, 22696, 22650
9467, 22067, 22089, 22090, 22068, 22696, 22697, 22698, 22652
9468, 22068, 22090, 22091, 22069, 22698, 22699, 22700, 22654
9469, 22069, 22091, 22092, 22070, 22700, 22701, 22702, 22656
9470, 22070, 22092, 22093, 22071, 22702, 22703, 22704, 22658
9471, 22071, 22093, 22094, 22072, 22704, 22705, 22706, 22660
9472, 22072, 22094, 22095, 22073, 22706, 22707, 22708, 22662
9473, 22073, 22095, 22096, 22074, 22708, 22709, 22710, 22664
9474, 22074, 22096, 22097, 22075, 22710, 22711, 22712, 22666
9475, 22075, 22097, 22098, 22076, 22712, 22713, 22714, 22668
9476, 22076, 22098, 22099, 22077, 22714, 22715, 22716, 22670
9477, 22077, 22099, 22100, 22078, 22716, 22717, 22718, 22672
9478, 22078, 22100, 22101, 22079, 22718, 22719, 22720, 22674
9479, 22079, 22101, 22102, 22080, 22720, 22721, 22722, 22676
9480, 22080, 22102, 22103, 22081, 22722, 22723, 22724, 22678
9481, 22081, 22103, 3023, 3022, 22724, 22725, 3045, 22680
9482, 2961, 2962, 22104, 22082, 2984, 22726, 22727, 22681
9483, 22082, 22104, 22105, 22083, 22727, 22728, 22729, 22683
9484, 22083, 22105, 22106, 22084, 22729, 22730, 22731, 22685
9485, 22084, 22106, 22107, 22085, 22731, 22732, 22733, 22687
9486, 22085, 22107, 22108, 22086, 22733, 22734, 22735, 22689
9487, 22086, 22108, 22109, 22087, 22735, 22736, 22737, 22691
9488, 22087, 22109, 22110, 22088, 22737, 22738, 22739, 22693
9489, 22088, 22110, 22111, 22089, 22739, 22740, 22741, 22695
9490, 22089, 22111, 22112, 22090, 22741, 22742, 22743, 22697
9491, 22090, 22112, 22113, 22091, 22743, 22744, 22745, 22699
9492, 22091, 22113, 22114, 22092, 22745, 22746, 22747, 22701
9493, 22092, 22114, 22115, 22093, 22747, 22748, 22749, 22703
9494, 22093, 22115, 22116, 22094, 22749, 22750, 22751, 22705
9495, 22094, 22116, 22117, 22095, 22751, 22752, 22753, 22707
9496, 22095, 22117, 22118, 22096, 22753, 22754, 22755, 22709
9497, 22096, 22118, 22119, 22097, 22755, 22756, 22757, 22711
9498, 22097, 22119, 22120, 22098, 22757, 22758, 22759, 22713
9499, 22098, 22120, 22121, 22099, 22759, 22760, 22761, 22715
9500, 22099, 22121, 22122, 22100, 22761, 22762, 22763, 22717
9501, 22100, 22122, 22123, 22101, 22763, 22764, 22765, 22719
9502, 22101, 22123, 22124, 22102, 22765, 22766, 22767, 22721
9503, 22102, 22124, 22125, 22103, 22767, 22768, 22769, 22723
9504, 22103, 22125, 3024, 3023, 22769, 22770, 3046, 22725
9505, 2962, 2963, 22126, 22104, 2985, 22771, 22772, 22726
9506, 22104, 22126, 22127, 22105, 22772, 22773, 22774, 22728
9507, 22105, 22127, 22128, 22106, 22774, 22775, 22776, 22730
9508, 22106, 22128, 22129, 22107, 22776, 22777, 22778, 22732
9509, 22107, 22129, 22130, 22108, 22778, 22779, 22780, 22734
9510, 22108, 22130, 22131, 22109, 22780, 22781, 22782, 22736
9511, 22109, 22131, 22132, 22110, 22782, 22783, 22784, 22738
9512, 22110, 22132, 22133, 22111, 22784, 22785, 22786, 22740
9513, 22111, 22133, 22134, 22112, 22786, 22787, 22788, 22742
9514, 22112, 22134, 22135, 22113, 22788, 22789, 22790, 22744
9515, 22113, 22135, 22136, 22114, 22790, 22791, 22792, 22746
9516, 22114, 22136, 22137, 22115, 22792, 22793, 22794, 22748
9517, 22115, 22137, 22138, 22116, 22794, 22795, 22796, 22750
9518, 22116, 22138, 22139, 22117, 22796, 22797, 22798, 22752
9519, 22117, 22139, 22140, 22118, 22798, 22799, 22800, 22754
9520, 22118, 22140, 22141, 22119, 22800, 22801, 22802, 22756
9521, 22119, 22141, 22142, 22120, 22802, 22803, 22804, 22758
9522, 22120, 22142, 22143, 22121, 22804, 22805, 22806, 22760
9523, 22121, 22143, 22144, 22122, 22806, 22807, 22808, 22762
9524, 22122, 22144, 22145, 22123, 22808, 22809, 22810, 22764
9525, 22123, 22145, 22146, 22124, 22810, 22811, 22812, 22766
9526, 22124, 22146, 22147, 22125, 22812, 22813, 22814, 22768
9527, 22125, 22147, 3025, 3024, 22814, 22815, 3047, 22770
9528, 2963, 2964, 22148, 22126, 2986, 22816, 22817, 22771
9529, 22126, 22148, 22149, 22127, 22817, 22818, 22819, 22773
9530, 22127, 22149, 22150, 22128, 22819, 22820, 22821, 22775
9531, 22128, 22150, 22151, 22129, 22821, 22822, 22823, 22777
9532, 22129, 22151, 22152, 22130, 22823, 22824, 22825, 22779
9533, 22130, 22152, 22153, 22131, 22825, 22826, 22827, 22781
9534, 22131, 22153, 22154, 22132, 22827, 22828, 22829, 22783
9535, 22132, 22154, 22155, 22133, 22829, 22830, 22831, 22785
9536, 22133, 22155, 22156, 22134, 22831, 22832, 22833, 22787
9537, 22134, 22156, 22157, 22135, 22833, 22834, 22835, 22789
9538, 22135, 22157, 22158, 22136, 22835, 22836, 22837, 22791
9539, 22136, 22158, 22159, 22137, 22837, 22838, 22839, 22793
9540, 22137, 22159, 22160, 22138, 22839, 22840, 22841, 22795
9541, 22138, 22160, 22161, 22139, 22841, 22842, 22843, 22797
9542, 22139, 22161, 22162, 22140, 22843, 22844, 22845, 22799
9543, 22140, 22162, 22163, 22141, 22845, 22846, 22847, 22801
9544, 22141, 22163, 22164, 22142, 22847, 22848, 22849, 22803
9545, 22142, 22164, 22165, 22143, 22849, 22850, 22851, 22805
9546, 22143, 22165, 22166, 22144, 22851, 22852, 22853, 22807
9547, 22144, 22166, 22167, 22145, 22853, 22854, 22855, 22809
9548, 22145, 22167, 22168, 22146, 22855, 22856, 22857, 22811
9549, 22146, 22168, 22169, 22147, 22857, 22858, 22859, 22813
9550, 22147, 22169, 3026, 3025, 22859, 22860, 3048, 22815
9551, 2964, 2965, 22170, 22148, 2987, 22861, 22862, 22816
9552, 22148, 22170, 22171, 22149, 22862, 22863, 22864, 22818
9553, 22149, 22171, 22172, 22150, 22864, 22865, 22866, 22820
9554, 22150, 22172, 22173, 22151, 22866, 22867, 22868, 22822
9555, 22151, 22173, 22174, 22152, 22868, 22869, 22870, 22824
9556, 22152, 22174, 22175, 22153, 22870, 22871, 22872, 22826
9557, 22153, 22175, 22176, 22154, 22872, 22873, 22874, 22828
9558, 22154, 22176, 22177, 22155, 22874, 22875, 22876, 22830
9559, 22155, 22177, 22178, 22156, 22876, 22877, 22878, 22832
9560, 22156, 22178, 22179, 22157, 22878, 22879, 22880, 22834
9561, 22157, 22179, 22180, 22158, 22880, 22881, 22882, 22836
9562, 22158, 22180, 22181, 22159, 22882, 22883, 22884, 22838
9563, 22159, 22181, 22182, 22160, 22884, 22885, 22886, 22840
9564, 22160, 22182, 22183, 22161, 22886, 22887, 22888, 22842
9565, 22161, 22183, 22184, 22162, 22888, 22889, 22890, 22844
9566, 22162, 22184, 22185, 22163, 22890, 22891, 22892, 22846
9567, 22163, 22185, 22186, 22164, 22892, 22893, 22894, 22848
9568, 22164, 22186, 22187, 22165, 22894, 22895, 22896, 22850
9569, 22165, 22187, 22188, 22166, 22896, 22897, 22898, 22852
9570, 22166, 22188, 22189, 22167, 22898, 22899, 22900, 22854
9571, 22167, 22189, 22190, 22168, 22900, 22901, 22902, 22856
9572, 22168, 22190, 22191, 22169, 22902, 22903, 22904, 22858
9573, 22169, 22191, 3027, 3026, 22904, 22905, 3049, 22860
9574, 2965, 2966, 22192, 22170, 2988, 22906, 22907, 22861
9575, 22170, 22192, 22193, 22171, 22907, 22908, 22909, 22863
9576, 22171, 22193, 22194, 22172, 22909, 22910, 22911, 22865
9577, 22172, 22194, 22195, 22173, 22911, 22912, 22913, 22867
9578, 22173, 22195, 22196, 22174, 22913, 22914, 22915, 22869
9579, 22174, 22196, 22197, 22175, 22915, 22916, 22917, 22871
9580, 22175, 22197, 22198, 22176, 22917, 22918, 22919, 22873
9581, 22176, 22198, 22199, 22177, 22919, 22920, 22921, 22875
9582, 22177, 22199, 22200, 22178, 22921, 22922, 22923, 22877
9583, 22178, 22200, 22201, 22179, 22923, 22924, 22925, 22879
9584, 22179, 22201, 22202, 22180, 22925, 22926, 22927, 22881
9585, 22180, 22202, 22203, 22181, 22927, 22928, 22929, 22883
9586, 22181, 22203, 22204, 22182, 22929, 22930, 22931, 22885
9587, 22182, 22204, 22205, 22183, 22931, 22932, 22933, 22887
9588, 22183, 22205, 22206, 22184, 22933, 22934, 22935, 22889
9589, 22184, 22206, 22207, 22185, 22935, 22936, 22937, 22891
9590, 22185, 22207, 22208, 22186, 22937, 22938, 22939, 22893
9591, 22186, 22208, 22209, 22187, 22939, 22940, 22941, 22895
9592, 22187, 22209, 22210, 22188, 22941, 22942, 22943, 22897
9593, 22188, 22210, 22211, 22189, 22943, 22944, 22945, 22899
9594, 22189, 22211, 22212, 22190, 22945, 22946, 22947, 22901
9595, 22190, 22212, 22213, 22191, 22947, 22948, 22949, 22903
9596, 22191, 22213, 3028, 3027, 22949, 22950, 3050, 22905
9597, 2966, 2967, 22214, 22192, 2989, 22951, 22952, 22906
9598, 22192, 22214, 22215, 22193, 22952, 22953, 22954, 22908
9599, 22193, 22215, 22216, 22194, 22954, 22955, 22956, 22910
9600, 22194, 22216, 22217, 22195, 22956, 22957, 22958, 22912
9601, 22195, 22217, 22218, 22196, 22958, 22959, 22960, 22914
9602, 22196, 22218, 22219, 22197, 22960, 22961, 22962, 22916
9603, 22197, 22219, 22220, 22198, 22962, 22963, 22964, 22918
9604, 22198, 22220, 22221, 22199, 22964, 22965, 22966, 22920
9605, 22199, 22221, 22222, 22200, 22966, 22967, 22968, 22922
9606, 22200, 22222, 22223, 22201, 22968, 22969, 22970, 22924
9607, 22201, 22223, 22224, 22202, 22970, 22971, 22972, 22926
9608, 22202, 22224, 22225, 22203, 22972, 22973, 22974, 22928
9609, 22203, 22225, 22226, 22204, 22974, 22975, 22976, 22930
9610, 22204, 22226, 22227, 22205, 22976, 22977, 22978, 22932
9611, 22205, 22227, 22228, 22206, 22978, 22979, 22980, 22934
9612, 22206, 22228, 22229, 22207, 22980, 22981, 22982, 22936
9613, 22207, 22229, 22230, 22208, 22982, 22983, 22984, 22938
9614, 22208, 22230, 22231, 22209, 22984, 22985, 22986, 22940
9615, 22209, 22231, 22232, 22210, 22986, 22987, 22988, 22942
9616, 22210, 22232, 22233, 22211, 22988, 22989, 22990, 22944
9617, 22211, 22233, 22234, 22212, 22990, 22991, 22992, 22946
9618, 22212, 22234, 22235, 22213, 22992, 22993, 22994, 22948
9619, 22213, 22235, 3029, 3028, 22994, 22995, 3051, 22950
9620, 2967, 2968, 22236, 22214, 2990, 22996, 22997, 22951
9621, 22214, 22236, 22237, 22215, 22997, 22998, 22999, 22953
9622, 22215, 22237, 22238, 22216, 22999, 23000, 23001, 22955
9623, 22216, 22238, 22239, 22217, 23001, 23002, 23003, 22957
9624, 22217, 22239, 22240, 22218, 23003, 23004, 23005, 22959
9625, 22218, 22240, 22241, 22219, 23005, 23006, 23007, 22961
9626, 22219, 22241, 22242, 22220, 23007, 23008, 23009, 22963
9627, 22220, 22242, 22243, 22221, 23009, 23010, 23011, 22965
9628, 22221, 22243, 22244, 22222, 23011, 23012, 23013, 22967
9629, 22222, 22244, 22245, 22223, 23013, 23014, 23015, 22969
9630, 22223, 22245, 22246, 22224, 23015, 23016, 23017, 22971
9631, 22224, 22246, 22247, 22225, 23017, 23018, 23019, 22973
9632, 22225, 22247, 22248, 22226, 23019, 23020, 23021, 22975
9633, 22226, 22248, 22249, 22227, 23021, 23022, 23023, 22977
9634, 22227, 22249, 22250, 22228, 23023, 23024, 23025, 22979
9635, 22228, 22250, 22251, 22229, 23025, 23026, 23027, 22981
9636, 22229, 22251, 22252, 22230, 23027, 23028, 23029, 22983
9637, 22230, 22252, 22253, 22231, 23029, 23030, 23031, 22985
9638, 22231, 22253, 22254, 22232, 23031, 23032, 23033, 22987
9639, 22232, 22254, 22255, 22233, 23033, 23034, 23035, 22989
9640, 22233, 22255, 22256, 22234, 23035, 23036, 23037, 22991
9641, 22234, 22256, 22257, 22235, 23037, 23038, 23039, 22993
9642, 22235, 22257, 3030, 3029, 23039, 23040, 3052, 22995
9643, 2968, 2969, 22258, 22236, 2991, 23041, 23042, 22996
9644, 22236, 22258, 22259, 22237, 23042, 23043, 23044, 22998
9645, 22237, 22259, 22260, 22238, 23044, 23045, 23046, 23000
9646, 22238, 22260, 22261, 22239, 23046, 23047, 23048, 23002
9647, 22239, 22261, 22262, 22240, 23048, 23049, 23050, 23004
9648, 22240, 22262, 22263, 22241, 23050, 23051, 23052, 23006
9649, 22241, 22263, 22264, 22242, 23052, 23053, 23054, 23008
9650, 22242, 22264, 22265, 22243, 23054, 23055, 23056, 23010
9651, 22243, 22265, 22266, 22244, 23056, 23057, 23058, 23012
9652, 22244, 22266, 22267, 22245, 23058, 23059, 23060, 23014
9653, 22245, 22267, 22268, 22246, 23060, 23061, 23062, 23016
9654, 22246, 22268, 22269, 22247, 23062, 23063, 23064, 23018
9655, 22247, 22269, 22270, 22248, 23064, 23065, 23066, 23020
9656, 22248, 22270, 22271, 22249, 23066, 23067, 23068, 23022
9657, 22249, 22271, 22272, 22250, 23068, 23069, 23070, 23024
9658, 22250, 22272, 22273, 22251, 23070, 23071, 23072, 23026
9659, 22251, 22273, 22274, 22252, 23072, 23073, 23074, 23028
9660, 22252, 22274, 22275, 22253, 23074, 23075, 23076, 23030
9661, 22253, 22275, 22276, 22254, 23076, 23077, 23078, 23032
9662, 22254, 22276, 22277, 22255, 23078, 23079, 23080, 23034
9663, 22255, 22277, 22278, 22256, 23080, 23081, 23082, 23036
9664, 22256, 22278, 22279, 22257, 23082, 23083, 23084, 23038
9665, 22257, 22279, 3031, 3030, 23084, 23085, 3053, 23040
9666, 2969, 2970, 22280, 22258, 2992, 23086, 23087, 23041
9667, 22258, 22280, 22281, 22259, 23087, 23088, 23089, 23043
9668, 22259, 22281, 22282, 22260, 23089, 23090, 23091, 23045
9669, 22260, 22282, 22283, 22261, 23091, 23092, 23093, 23047
9670, 22261, 22283, 22284, 22262, 23093, 23094, 23095, 23049
9671, 22262, 22284, 22285, 22263, 23095, 23096, 23097, 23051
9672, 22263, 22285, 22286, 22264, 23097, 23098, 23099, 23053
9673, 22264, 22286, 22287, 22265, 23099, 23100, 23101, 23055
9674, 22265, 22287, 22288, 22266, 23101, 23102, 23103, 23057
9675, 22266, 22288, 22289, 22267, 23103, 23104, 23105, 23059
9676, 22267, 22289, 22290, 22268, 23105, 23106, 23107, 23061
9677, 22268, 22290, 22291, 22269, 23107, 23108, 23109, 23063
9678, 22269, 22291, 22292, 22270, 23109, 23110, 23111, 23065
9679, 22270, 22292, 22293, 22271, 23111, 23112, 23113, 23067
9680, 22271, 22293, 22294, 22272, 23113, 23114, 23115, 23069
9681, 22272, 22294, 22295, 22273, 23115, 23116, 23117, 23071
9682, 22273, 22295, 22296, 22274, 23117, 23118, 23119, 23073
9683, 22274, 22296, 22297, 22275, 23119, 23120, 23121, 23075
9684, 22275, 22297, 22298, 22276, 23121, 23122, 23123, 23077
9685, 22276, 22298, 22299, 22277, 23123, 23124, 23125, 23079
9686, 22277, 22299, 22300, 22278, 23125, 23126, 23127, 23081
9687, 22278, 22300, 22301, 22279, 23127, 23128, 23129, 23083
9688, 22279, 22301, 3032, 3031, 23129, 23130, 3054, 23085
9689, 2970, 2971, 22302, 22280, 2993, 23131, 23132, 23086
9690, 22280, 22302, 22303, 22281, 23132, 23133, 23134, 23088
9691, 22281, 22303, 22304, 22282, 23134, 23135, 23136, 23090
9692, 22282, 22304, 22305, 22283, 23136, 23137, 23138, 23092
9693, 22283, 22305, 22306, 22284, 23138, 23139, 23140, 23094
9694, 22284, 22306, 22307, 22285, 23140, 23141, 23142, 23096
9695, 22285, 22307, 22308, 22286, 23142, 23143, 23144, 23098
9696, 22286, 22308, 22309, 22287, 23144, 23145, 23146, 23100
9697, 22287, 22309, 22310, 22288, 23146, 23147, 23148, 23102
9698, 22288, 22310, 22311, 22289, 23148, 23149, 23150, 23104
9699, 22289, 22311, 22312, 22290, 23150, 23151, 23152, 23106
9700, 22290, 22312, 22313, 22291, 23152, 23153, 23154, 23108
9701, 22291, 22313, 22314, 22292, 23154, 23155, 23156, 23110
9702, 22292, 22314, 22315, 22293, 23156, 23157, 23158, 23112
9703, 22293, 22315, 22316, 22294, 23158, 23159, 23160, 23114
9704, 22294, 22316, 22317, 22295, 23160, 23161, 23162, 23116
9705, 22295, 22317, 22318, 22296, 23162, 23163, 23164, 23118
9706, 22296, 22318, 22319, 22297, 23164, 23165, 23166, 23120
9707, 22297, 22319, 22320, 22298, 23166, 23167, 23168, 23122
9708, 22298, 22320, 22321, 22299, 23168, 23169, 23170, 23124
9709, 22299, 22321, 22322, 22300, 23170, 23171, 23172, 23126
9710, 22300, 22322, 22323, 22301, 23172, 23173, 23174, 23128
9711, 22301, 22323, 3033, 3032, 23174, 23175, 3055, 23130
9712, 2971, 2972, 22324, 22302, 2994, 23176, 23177, 23131
9713, 22302, 22324, 22325, 22303, 23177, 23178, 23179, 23133
9714, 22303, 22325, 22326, 22304, 23179, 23180, 23181, 23135
9715, 22304, 22326, 22327, 22305, 23181, 23182, 23183, 23137
9716, 22305, 22327, 22328, 22306, 23183, 23184, 23185, 23139
9717, 22306, 22328, 22329, 22307, 23185, 23186, 23187, 23141
9718, 22307, 22329, 22330, 22308, 23187, 23188, 23189, 23143
9719, 22308, 22330, 22331, 22309, 23189, 23190, 23191, 23145
9720, 22309, 22331, 22332, 22310, 23191, 23192, 23193, 23147
9721, 22310, 22332, 22333, 22311, 23193, 23194, 23195, 23149
9722, 22311, 22333, 22334, 22312, 23195, 23196, 23197, 23151
9723, 22312, 22334, 22335, 22313, 23197, 23198, 23199, 23153
9724, 22313, 22335, 22336, 22314, 23199, 23200, 23201, 23155
9725, 22314, 22336, 22337, 22315, 23201, 23202, 23203, 23157
9726, 22315, 22337, 22338, 22316, 23203, 23204, 23205, 23159
9727, 22316, 22338, 22339, 22317, 23205, 23206, 23207, 23161
9728, 22317, 22339, 22340, 22318, 23207, 23208, 23209, 23163
9729, 22318, 22340, 22341, 22319, 23209, 23210, 23211, 23165
9730, 22319, 22341, 22342, 22320, 23211, 23212, 23213, 23167
9731, 22320, 22342, 22343, 22321, 23213, 23214, 23215, 23169
9732, 22321, 22343, 22344, 22322, 23215, 23216, 23217, 23171
9733, 22322, 22344, 22345, 22323, 23217, 23218, 23219, 23173
9734, 22323, 22345, 3034, 3033, 23219, 23220, 3056, 23175
9735, 2972, 2973, 22346, 22324, 2995, 23221, 23222, 23176
9736, 22324, 22346, 22347, 22325, 23222, 23223, 23224, 23178
9737, 22325, 22347, 22348, 22326, 23224, 23225, 23226, 23180
9738, 22326, 22348, 22349, 22327, 23226, 23227, 23228, 23182
9739, 22327, 22349, 22350, 22328, 23228, 23229, 23230, 23184
9740, 22328, 22350, 22351, 22329, 23230, 23231, 23232, 23186
9741, 22329, 22351, 22352, 22330, 23232, 23233, 23234, 23188
9742, 22330, 22352, 22353, 22331, 23234, 23235, 23236, 23190
9743, 22331, 22353, 22354, 22332, 23236, 23237, 23238, 23192
9744, 22332, 22354, 22355, 22333, 23238, 23239, 23240, 23194
9745, 22333, 22355, 22356, 22334, 23240, 23241, 23242, 23196
9746, 22334, 22356, 22357, 22335, 23242, 23243, 23244, 23198
9747, 22335, 22357, 22358, 22336, 23244, 23245, 23246, 23200
9748, 22336, 22358, 22359, 22337, 23246, 23247, 23248, 23202
9749, 22337, 22359, 22360, 22338, 23248, 23249, 23250, 23204
9750, 22338, 22360, 22361, 22339, 23250, 23251, 23252, 23206
9751, 22339, 22361, 22362, 22340, 23252, 23253, 23254, 23208
9752, 22340, 22362, 22363, 22341, 23254, 23255, 23256, 23210
9753, 22341, 22363, 22364, 22342, 23256, 23257, 23258, 23212
9754, 22342, 22364, 22365, 22343, 23258, 23259, 23260, 23214
9755, 22343, 22365, 22366, 22344, 23260, 23261, 23262, 23216
9756, 22344, 22366, 22367, 22345, 23262, 23263, 23264, 23218
9757, 22345, 22367, 3035, 3034, 23264, 23265, 3057, 23220
9758, 2973, 2974, 22368, 22346, 2996, 23266, 23267, 23221
9759, 22346, 22368, 22369, 22347, 23267, 23268, 23269, 23223
9760, 22347, 22369, 22370, 22348, 23269, 23270, 23271, 23225
9761, 22348, 22370, 22371, 22349, 23271, 23272, 23273, 23227
9762, 22349, 22371, 22372, 22350, 23273, 23274, 23275, 23229
9763, 22350, 22372, 22373, 22351, 23275, 23276, 23277, 23231
9764, 22351, 22373, 22374, 22352, 23277, 23278, 23279, 23233
9765, 22352, 22374, 22375, 22353, 23279, 23280, 23281, 23235
9766, 22353, 22375, 22376, 22354, 23281, 23282, 23283, 23237
9767, 22354, 22376, 22377, 22355, 23283, 23284, 23285, 23239
9768, 22355, 22377, 22378, 22356, 23285, 23286, 23287, 23241
9769, 22356, 22378, 22379, 22357, 23287, 23288, 23289, 23243
9770, 22357, 22379, 22380, 22358, 23289, 23290, 23291, 23245
9771, 22358, 22380, 22381, 22359, 23291, 23292, 23293, 23247
9772, 22359, 22381, 22382, 22360, 23293, 23294, 23295, 23249
9773, 22360, 22382, 22383, 22361, 23295, 23296, 23297, 23251
9774, 22361, 22383, 22384, 22362, 23297, 23298, 23299, 23253
9775, 22362, 22384, 22385, 22363, 23299, 23300, 23301, 23255
9776, 22363, 22385, 22386, 22364, 23301, 23302, 23303, 23257
9777, 22364, 22386, 22387, 22365, 23303, 23304, 23305, 23259
9778, 22365, 22387, 22388, 22366, 23305, 23306, 23307, 23261
9779, 22366, 22388, 22389, 22367, 23307, 23308, 23309, 23263
9780, 22367, 22389, 3036, 3035, 23309, 23310, 3058, 23265
9781, 2974, 2975, 22390, 22368, 2997, 23311, 23312, 23266
9782, 22368, 22390, 22391, 22369, 23312, 23313, 23314, 23268
9783, 22369, 22391, 22392, 22370, 23314, 23315, 23316, 23270
9784, 22370, 22392, 22393, 22371, 23316, 23317, 23318, 23272
9785, 22371, 22393, 22394, 22372, 23318, 23319, 23320, 23274
9786, 22372, 22394, 22395, 22373, 23320, 23321, 23322, 23276
9787, 22373, 22395, 22396, 22374, 23322, 23323, 23324, 23278
9788, 22374, 22396, 22397, 22375, 23324, 23325, 23326, 23280
9789, 22375, 22397, 22398, 22376, 23326, 23327, 23328, 23282
9790, 22376, 22398, 22399, 22377, 23328, 23329, 23330, 23284
9791, 22377, 22399, 22400, 22378, 23330, 23331, 23332, 23286
9792, 22378, 22400, 22401, 22379, 23332, 23333, 23334, 23288
9793, 22379, 22401, 22402, 22380, 23334, 23335, 23336, 23290
9794, 22380, 22402, 22403, 22381, 23336, 23337, 23338, 23292
9795, 22381, 22403, 22404, 22382, 23338, 23339, 23340, 23294
9796, 22382, 22404, 22405, 22383, 23340, 23341, 23342, 23296
9797, 22383, 22405, 22406, 22384, 23342, 23343, 23344, 23298
9798, 22384, 22406, 22407, 22385, 23344, 23345, 23346, 23300
9799, 22385, 22407, 22408, 22386, 23346, 23347, 23348, 23302
9800, 22386, 22408, 22409, 22387, 23348, 23349, 23350, 23304
9801, 22387, 22409, 22410, 22388, 23350, 23351, 23352, 23306
9802, 22388, 22410, 22411, 22389, 23352, 23353, 23354, 23308
9803, 22389, 22411, 3037, 3036, 23354, 23355, 3059, 23310
9804, 2975, 2976, 22412, 22390, 2998, 23356, 23357, 23311
9805, 22390, 22412, 22413, 22391, 23357, 23358, 23359, 23313
9806, 22391, 22413, 22414, 22392, 23359, 23360, 23361, 23315
9807, 22392, 22414, 22415, 22393, 23361, 23362, 23363, 23317
9808, 22393, 22415, 22416, 22394, 23363, 23364, 23365, 23319
9809, 22394, 22416, 22417, 22395, 23365, 23366, 23367, 23321
9810, 22395, 22417, 22418, 22396, 23367, 23368, 23369, 23323
9811, 22396, 22418, 22419, 22397, 23369, 23370, 23371, 23325
9812, 22397, 22419, 22420, 22398, 23371, 23372, 23373, 23327
9813, 22398, 22420, 22421, 22399, 23373, 23374, 23375, 23329
9814, 22399, 22421, 22422, 22400, 23375, 23376, 23377, 23331
9815, 22400, 22422, 22423, 22401, 23377, 23378, 23379, 23333
9816, 22401, 22423, 22424, 22402, 23379, 23380, 23381, 23335
9817, 22402, 22424, 22425, 22403, 23381, 23382, 23383, 23337
9818, 22403, 22425, 22426, 22404, 23383, 23384, 23385, 23339
9819, 22404, 22426, 22427, 22405, 23385, 23386, 23387, 23341
9820, 22405, 22427, 22428, 22406, 23387, 23388, 23389, 23343
9821, 22406, 22428, 22429, 22407, 23389, 23390, 23391, 23345
9822, 22407, 22429, 22430, 22408, 23391, 23392, 23393, 23347
9823, 22408, 22430, 22431, 22409, 23393, 23394, 23395, 23349
9824, 22409, 22431, 22432, 22410, 23395, 23396, 23397, 23351
9825, 22410, 22432, 22433, 22411, 23397, 23398, 23399, 23353
9826, 22411, 22433, 3038, 3037, 23399, 23400, 3060, 23355
9827, 2976, 2977, 22434, 22412, 2999, 23401, 23402, 23356
9828, 22412, 22434, 22435, 22413, 23402, 23403, 23404, 23358
9829, 22413, 22435, 22436, 22414, 23404, 23405, 23406, 23360
9830, 22414, 22436, 22437, 22415, 23406, 23407, 23408, 23362
9831, 22415, 22437, 22438, 22416, 23408, 23409, 23410, 23364
9832, 22416, 22438, 22439, 22417, 23410, 23411, 23412, 23366
9833, 22417, 22439, 22440, 22418, 23412, 23413, 23414, 23368
9834, 22418, 22440, 22441, 22419, 23414, 23415, 23416, 23370
9835, 22419, 22441, 22442, 22420, 23416, 23417, 23418, 23372
9836, 22420, 22442, 22443, 22421, 23418, 23419, 23420, 23374
9837, 22421, 22443, 22444, 22422, 23420, 23421, 23422, 23376
9838, 22422, 22444, 22445, 22423, 23422, 23423, 23424, 23378
9839, 22423, 22445, 22446, 22424, 23424, 23425, 23426, 23380
9840, 22424, 22446, 22447, 22425, 23426, 23427, 23428, 23382
9841, 22425, 22447, 22448, 22426, 23428, 23429, 23430, 23384
9842, 22426, 22448, 22449, 22427, 23430, 23431, 23432, 23386
9843, 22427, 22449, 22450, 22428, 23432, 23433, 23434, 23388
9844, 22428, 22450, 22451, 22429, 23434, 23435, 23436, 23390
9845, 22429, 22451, 22452, 22430, 23436, 23437, 23438, 23392
9846, 22430, 22452, 22453, 22431, 23438, 23439, 23440, 23394
9847, 22431, 22453, 22454, 22432, 23440, 23441, 23442, 23396
9848, 22432, 22454, 22455, 22433, 23442, 23443, 23444, 23398
9849, 22433, 22455, 3039, 3038, 23444, 23445, 3061, 23400
9850, 2977, 91, 3084, 22434, 3000, 3107, 23446, 23401
9851, 22434, 3084, 3083, 22435, 23446, 3106, 23447, 23403
9852, 22435, 3083, 3082, 22436, 23447, 3105, 23448, 23405
9853, 22436, 3082, 3081, 22437, 23448, 3104, 23449, 23407
9854, 22437, 3081, 3080, 22438, 23449, 3103, 23450, 23409
9855, 22438, 3080, 3079, 22439, 23450, 3102, 23451, 23411
9856, 22439, 3079, 3078, 22440, 23451, 3101, 23452, 23413
9857, 22440, 3078, 3077, 22441, 23452, 3100, 23453, 23415
9858, 22441, 3077, 3076, 22442, 23453, 3099, 23454, 23417
9859, 22442, 3076, 3075, 22443, 23454, 3098, 23455, 23419
9860, 22443, 3075, 3074, 22444, 23455, 3097, 23456, 23421
9861, 22444, 3074, 3073, 22445, 23456, 3096, 23457, 23423
9862, 22445, 3073, 3072, 22446, 23457, 3095, 23458, 23425
9863, 22446, 3072, 3071, 22447, 23458, 3094, 23459, 23427
9864, 22447, 3071, 3070, 22448, 23459, 3093, 23460, 23429
9865, 22448, 3070, 3069, 22449, 23460, 3092, 23461, 23431
9866, 22449, 3069, 3068, 22450, 23461, 3091, 23462, 23433
9867, 22450, 3068, 3067, 22451, 23462, 3090, 23463, 23435
9868, 22451, 3067, 3066, 22452, 23463, 3089, 23464, 23437
9869, 22452, 3066, 3065, 22453, 23464, 3088, 23465, 23439
9870, 22453, 3065, 3064, 22454, 23465, 3087, 23466, 23441
9871, 22454, 3064, 3063, 22455, 23466, 3086, 23467, 23443
9872, 22455, 3063, 92, 3039, 23467, 3085, 3062, 23445
*ELEMENT, type=CPS8, ELSET=Surface263
9873, 4, 3018, 23468, 223, 3040, 23644, 23645, 232
9874, 223, 23468, 23469, 222, 23645, 23646, 23647, 231
9875, 222, 23469, 23470, 221, 23647, 23648, 23649, 230
9876, 221, 23470, 23471, 220, 23649, 23650, 23651, 229
9877, 220, 23471, 23472, 219, 23651, 23652, 23653, 228
9878, 219, 23472, 23473, 218, 23653, 23654, 23655, 227
9879, 218, 23473, 23474, 217, 23655, 23656, 23657, 226
9880, 217, 23474, 23475, 216, 23657, 23658, 23659, 225
9881, 216, 23475, 2866, 2, 23659, 23660, 2888, 224
9882, 3018, 3019, 23476, 23468, 3041, 23661, 23662, 23644
9883, 23468, 23476, 23477, 23469, 23662, 23663, 23664, 23646
9884, 23469, 23477, 23478, 23470, 23664, 23665, 23666, 23648
9885, 23470, 23478, 23479, 23471, 23666, 23667, 23668, 23650
9886, 23471, 23479, 23480, 23472, 23668, 23669, 23670, 23652
9887, 23472, 23480, 23481, 23473, 23670, 23671, 23672, 23654
9888, 23473, 23481, 23482, 23474, 23672, 23673, 23674, 23656
9889, 23474, 23482, 23483, 23475, 23674, 23675, 23676, 23658
9890, 23475, 23483, 2867, 2866, 23676, 23677, 2889, 23660
9891, 3019, 3020, 23484, 23476, 3042, 23678, 23679, 23661
9892, 23476, 23484, 23485, 23477, 23679, 23680, 23681, 23663
9893, 23477, 23485, 23486, 23478, 23681, 23682, 23683, 23665
9894, 23478, 23486, 23487, 23479, 23683, 23684, 23685, 23667
9895, 23479, 23487, 23488, 23480, 23685, 23686, 23687, 23669
9896, 23480, 23488, 23489, 23481, 23687, 23688, 23689, 23671
9897, 23481, 23489, 23490, 23482, 23689, 23690, 23691, 23673
9898, 23482, 23490, 23491, 23483, 23691, 23692, 23693, 23675
9899, 23483, 23491, 2868, 2867, 23693, 23694, 2890, 23677
9900, 3020, 3021, 23492, 23484, 3043, 23695, 23696, 23678
9901, 23484, 23492, 23493, 23485, 23696, 23697, 23698, 23680
9902, 23485, 23493, 23494, 23486, 23698, 23699, 23700, 23682
9903, 23486, 23494, 23495, 23487, 23700, 23701, 23702, 23684
9904, 23487, 23495, 23496, 23488, 23702, 23703, 23704, 23686
9905, 23488, 23496, 23497, 23489, 23704, 23705, 23706, 23688
9906, 23489, 23497, 23498, 23490, 23706, 23707, 23708, 23690
9907, 23490, 23498, 23499, 23491, 23708, 23709, 23710, 23692
9908, 23491, 23499, 2869, 2868, 23710, 23711, 2891, 23694
9909, 3021, 3022, 23500, 23492, 3044, 23712, 23713, 23695
9910, 23492, 23500, 23501, 23493, 23713, 23714, 23715, 23697
9911, 23493, 23501, 23502, 23494, 23715, 23716, 23717, 23699
9912, 23494, 23502, 23503, 23495, 23717, 23718, 23719, 23701
9913, 23495, 23503, 23504, 23496, 23719, 23720, 23721, 23703
9914, 23496, 23504, 23505, 23497, 23721, 23722, 23723, 23705
9915, 23497, 23505, 23506, 23498, 23723, 23724, 23725, 23707
9916, 23498, 23506, 23507, 23499, 23725, 23726, 23727, 23709
9917, 23499, 23507, 2870, 2869, 23727, 23728, 2892, 23711
9918, 3022, 3023, 23508, 23500, 3045, 23729, 23730, 23712
9919, 23500, 23508, 23509, 23501, 23730, 23731, 23732, 23714
9920, 23501, 23509, 23510, 23502, 23732, 23733, 23734, 23716
9921, 23502, 23510, 23511, 23503, 23734, 23735, 23736, 23718
9922, 23503, 23511, 23512, 23504, 23736, 23737, 23738, 23720
9923, 23504, 23512, 23513, 23505, 23738, 23739, 23740, 23722
9924, 23505, 23513, 23514, 23506, 23740, 23741, 23742, 23724
9925, 23506, 23514, 23515, 23507, 23742, 23743, 23744, 23726
9926, 23507, 23515, 2871, 2870, 23744, 23745, 2893, 23728
9927, 3023, 3024, 23516, 23508, 3046, 23746, 23747, 23729
9928, 23508, 23516, 23517, 23509, 23747, 23748, 23749, 23731
9929, 23509, 23517, 23518, 23510, 23749, 23750, 23751, 23733
9930, 23510, 23518, 23519, 23511, 23751, 23752, 23753, 23735
9931, 23511, 23519, 23520, 23512, 23753, 23754, 23755, 23737
9932, 23512, 23520, 23521, 23513, 23755, 23756, 23757, 23739
9933, 23513, 23521, 23522, 23514, 23757, 23758, 23759, 23741
9934, 23514, 23522, 23523, 23515, 23759, 23760, 23761, 23743
9935, 23515, 23523, 2872, 2871, 23761, 23762, 2894, 23745
9936, 3024, 3025, 23524, 23516, 3047, 23763, 23764, 23746
9937, 23516, 23524, 23525, 23517, 23764, 23765, 23766, 23748
9938, 23517, 23525, 23526, 23518, 23766, 23767, 23768, 23750
9939, 23518, 23526, 23527, 23519, 23768, 23769, 23770, 23752
9940, 23519, 23527, 23528, 23520, 23770, 23771, 23772, 23754
9941, 23520, 23528, 23529, 23521, 23772, 23773, 23774, 23756
9942, 23521, 23529, 23530, 23522, 23774, 23775, 23776, 23758
9943, 23522, 23530, 23531, 23523, 23776, 23777, 23778, 23760
9944, 23523, 23531, 2873, 2872, 23778, 23779, 2895, 23762
9945, 3025, 3026, 23532, 23524, 3048, 23780, 23781, 23763
9946, 23524, 23532, 23533, 23525, 23781, 23782, 23783, 23765
9947, 23525, 23533, 23534, 23526, 23783, 23784, 23785, 23767
9948, 23526, 23534, 23535, 23527, 23785, 23786, 23787, 23769
9949, 23527, 23535, 23536, 23528, 23787, 23788, 23789, 23771
9950, 23528, 23536, 23537, 23529, 23789, 23790, 23791, 23773
9951, 23529, 23537, 23538, 23530, 23791, 23792, 23793, 23775
9952, 23530, 23538, 23539, 23531, 23793, 23794, 23795, 23777
9953, 23531, 23539, 2874, 2873, 23795, 23796, 2896, 23779
9954, 3026, 3027, 23540, 23532, 3049, 23797, 23798, 23780
9955, 23532, 23540, 23541, 23533, 23798, 23799, 23800, 23782
9956, 23533, 23541, 23542, 23534, 23800, 23801, 23802, 23784
9957, 23534, 23542, 23543, 23535, 23802, 23803, 23804, 23786
9958, 23535, 23543, 23544, 23536, 23804, 23805, 23806, 23788
9959, 23536, 23544, 23545, 23537, 23806, 23807, 23808, 23790
9960, 23537, 23545, 23546, 23538, 23808, 23809, 23810, 23792
9961, 23538, 23546, 23547, 23539, 23810, 23811, 23812, 23794
9962, 23539, 23547, 2875, 2874, 23812, 23813, 2897, 23796
9963, 3027, 3028, 23548, 23540, 3050, 23814, 23815, 23797
9964, 23540, 23548, 23549, 23541, 23815, 23816, 23817, 23799
9965, 23541, 23549, 23550, 23542, 23817, 23818, 23819, 23801
9966, 23542, 23550, 23551, 23543, 23819, 23820, 23821, 23803
9967, 23543, 23551, 23552, 23544, 23821, 23822, 23823, 23805
9968, 23544, 23552, 23553, 23545, 23823, 23824, 23825, 23807
9969, 23545, 23553, 23554, 23546, 23825, 23826, 23827, 23809
9970, 23546, 23554, 23555, 23547, 23827, 23828, 23829, 23811
9971, 23547, 23555, 2876, 2875, 23829, 23830, 2898, 23813
9972, 3028, 3029, 23556, 23548, 3051, 23831, 23832, 23814
9973, 23548, 23556, 23557, 23549, 23832, 23833, 23834, 23816
9974, 23549, 23557, 23558, 23550, 23834, 23835, 23836, 23818
9975, 23550, 23558, 23559, 23551, 23836, 23837, 23838, 23820
9976, 23551, 23559, 23560, 23552, 23838, 23839, 23840, 23822
9977, 23552, 23560, 23561, 23553, 23840, 23841, 23842, 23824
9978, 23553, 23561, 23562, 23554, 23842, 23843, 23844, 23826
9979, 23554, 23562, 23563, 23555, 23844, 23845, 23846, 23828
9980, 23555, 23563, 2877, 2876, 23846, 23847, 2899, 23830
9981, 3029, 3030, 23564, 23556, 3052, 23848, 23849, 23831
9982, 23556, 23564, 23565, 23557, 23849, 23850, 23851, 23833
9983, 23557, 23565, 23566, 23558, 23851, 23852, 23853, 23835
9984, 23558, 23566, 23567, 23559, 23853, 23854, 23855, 23837
9985, 23559, 23567, 23568, 23560, 23855, 23856, 23857, 23839
9986, 23560, 23568, 23569, 23561, 23857, 23858, 23859, 23841
9987, 23561, 23569, 23570, 23562, 23859, 23860, 23861, 23843
9988, 23562, 23570, 23571, 23563, 23861, 23862, 23863, 23845
9989, 23563, 23571, 2878, 2877, 23863, 23864, 2900, 23847
9990, 3030, 3031, 23572, 23564, 3053, 23865, 23866, 23848
9991, 23564, 23572, 23573, 23565, 23866, 23867, 23868, 23850
9992, 23565, 23573, 23574, 23566, 23868, 23869, 23870, 23852
9993, 23566, 23574, 23575, 23567, 23870, 23871, 23872, 23854
9994, 23567, 23575, 23576, 23568, 23872, 23873, 23874, 23856
9995, 23568, 23576, 23577, 23569, 23874, 23875, 23876, 23858
9996, 23569, 23577, 23578, 23570, 23876, 23877, 23878, 23860
9997, 23570, 23578, 23579, 23571, 23878, 23879, 23880, 23862
9998, 23571, 23579, 2879, 2878, 23880, 23881, 2901, 23864
9999, 3031, 3032, 23580, 23572, 3054, 23882, 23883, 23865
10000, 23572, 23580, 23581, 23573, 23883, 23884, 23885, 23867
10001, 23573, 23581, 23582, 23574, 23885, 23886, 23887, 23869
10002, 23574, 23582, 23583, 23575, 23887, 23888, 23889, 23871
10003, 23575, 23583, 23584, 23576, 23889, 23890, 23891, 23873
10004, 23576, 23584, 23585, 23577, 23891, 23892, 23893, 23875
10005, 23577, 23585, 23586, 23578, 23893, 23894, 23895, 23877
10006, 23578, 23586, 23587, 23579, 23895, 23896, 23897, 23879
10007, 23579, 23587, 2880, 2879, 23897, 23898, 2902, 23881
10008, 3032, 3033, 23588, 23580, 3055, 23899, 23900, 23882
10009, 23580, 23588, 23589, 23581, 23900, 23901, 23902, 23884
10010, 23581, 23589, 23590, 23582, 23902, 23903, 23904, 23886
10011, 23582, 23590, 23591, 23583, 23904, 23905, 23906, 23888
10012, 23583, 23591, 23592, 23584, 23906, 23907, 23908, 23890
10013, 23584, 23592, 23593, 23585, 23908, 23909, 23910, 23892
10014, 23585, 23593, 23594, 23586, 23910, 23911, 23912, 23894
10015, 23586, 23594, 23595, 23587, 23912, 23913, 23914, 23896
10016, 23587, 23595, 2881, 2880, 23914, 23915, 2903, 23898
10017, 3033, 3034, 23596, 23588, 3056, 23916, 23917, 23899
10018, 23588, 23596, 23597, 23589, 23917, 23918, 23919, 23901
10019, 23589, 23597, 23598, 23590, 23919, 23920, 23921, 23903
10020, 23590, 23598, 23599, 23591, 23921, 23922, 23923, 23905
10021, 23591, 23599, 23600, 23592, 23923, 23924, 23925, 23907
10022, 23592, 23600, 23601, 23593, 23925, 23926, 23927, 23909
10023, 23593, 23601, 23602, 23594, 23927, 23928, 23929, 23911
10024, 23594, 23602, 23603, 23595, 23929, 23930, 23931, 23913
10025, 23595, 23603, 2882, 2881, 23931, 23932, 2904, 23915
10026, 3034, 3035, 23604, 23596, 3057, 23933, 23934, 23916
10027, 23596, 23604, 23605, 23597, 23934, 23935, 23936, 23918
10028, 23597, 23605, 23606, 23598, 23936, 23937, 23938, 23920
10029, 23598, 23606, 23607, 23599, 23938, 23939, 23940, 23922
10030, 23599, 23607, 23608, 23600, 23940, 23941, 23942, 23924
10031, 23600, 23608, 23609, 23601, 23942, 23943, 23944, 23926
10032, 23601, 23609, 23610, 23602, 23944, 23945, 23946, 23928
10033, 23602, 23610, 23611, 23603, 23946, 23947, 23948, 23930
10034, 23603, 23611, 2883, 2882, 23948, 23949, 2905, 23932
10035, 3035, 3036, 23612, 23604, 3058, 23950, 23951, 23933
10036, 23604, 23612, 23613, 23605, 23951, 23952, 23953, 23935
10037, 23605, 23613, 23614, 23606, 23953, 23954, 23955, 23937
10038, 23606, 23614, 23615, 23607, 23955, 23956, 23957, 23939
10039, 23607, 23615, 23616, 23608, 23957, 23958, 23959, 23941
10040, 23608, 23616, 23617, 23609, 23959, 23960, 23961, 23943
10041, 23609, 23617, 23618, 23610, 23961, 23962, 23963, 23945
10042, 23610, 23618, 23619, 23611, 23963, 23964, 23965, 23947
10043, 23611, 23619, 2884, 2883, 23965, 23966, 2906, 23949
10044, 3036, 3037, 23620, 23612, 3059, 23967, 23968, 23950
10045, 23612, 23620, 23621, 23613, 23968, 23969, 23970, 23952
10046, 23613, 23621, 23622, 23614, 23970, 23971, 23972, 23954
10047, 23614, 23622, 23623, 23615, 23972, 23973, 23974, 23956
10048, 23615, 23623, 23624, 23616, 23974, 23975, 23976, 23958
10049, 23616, 23624, 23625, 23617, 23976, 23977, 23978, 23960
10050, 23617, 23625, 23626, 23618, 23978, 23979, 23980, 23962
10051, 23618, 23626, 23627, 23619, 23980, 23981, 23982, 23964
10052, 23619, 23627, 2885, 2884, 23982, 23983, 2907, 23966
10053, 3037, 3038, 23628, 23620, 3060, 23984, 23985, 23967
10054, 23620, 23628, 23629, 23621, 23985, 23986, 23987, 23969
10055, 23621, 23629, 23630, 23622, 23987, 23988, 23989, 23971
10056, 23622, 23630, 23631, 23623, 23989, 23990, 23991, 23973
10057, 23623, 23631, 23632, 23624, 23991, 23992, 23993, 23975
10058, 23624, 23632, 23633, 23625, 23993, 23994, 23995, 23977
10059, 23625, 23633, 23634, 23626, 23995, 23996, 23997, 23979
10060, 23626, 23634, 23635, 23627, 23997, 23998, 23999, 23981
10061, 23627, 23635, 2886, 2885, 23999, 24000, 2908, 23983
10062, 3038, 3039, 23636, 23628, 3061, 24001, 24002, 23984
10063, 23628, 23636, 23637, 23629, 24002, 24003, 24004, 23986
10064, 23629, 23637, 23638, 23630, 24004, 24005, 24006, 23988
10065, 23630, 23638, 23639, 23631, 24006, 24007, 24008, 23990
10066, 23631, 23639, 23640, 23632, 24008, 24009, 24010, 23992
10067, 23632, 23640, 23641, 23633, 24010, 24011, 24012, 23994
10068, 23633, 23641, 23642, 23634, 24012, 24013, 24014, 23996
10069, 23634, 23642, 23643, 23635, 24014, 24015, 24016, 23998
10070, 23635, 23643, 2887, 2886, 24016, 24017, 2909, 24000
10071, 3039, 92, 3115, 23636, 3062, 3124, 24018, 24001
10072, 23636, 3115, 3114, 23637, 24018, 3123, 24019, 24003
10073, 23637, 3114, 3113, 23638, 24019, 3122, 24020, 24005
10074, 23638, 3113, 3112, 23639, 24020, 3121, 24021, 24007
10075, 23639, 3112, 3111, 23640, 24021, 3120, 24022, 24009
10076, 23640, 3111, 3110, 23641, 24022, 3119, 24023, 24011
10077, 23641, 3110, 3109, 23642, 24023, 3118, 24024, 24013
10078, 23642, 3109, 3108, 23643, 24024, 3117, 24025, 24015
10079, 23643, 3108, 90, 2887, 24025, 3116, 2910, 24017
*ELEMENT, type=CPS8, ELSET=Surface264
10080, 90, 3108, 24026, 2911, 3116, 24202, 24203, 2933
10081, 3108, 3109, 24027, 24026, 3117, 24204, 24205, 24202
10082, 3109, 3110, 24028, 24027, 3118, 24206, 24207, 24204
10083, 3110, 3111, 24029, 24028, 3119, 24208, 24209, 24206
10084, 3111, 3112, 24030, 24029, 3120, 24210, 24211, 24208
10085, 3112, 3113, 24031, 24030, 3121, 24212, 24213, 24210
10086, 3113, 3114, 24032, 24031, 3122, 24214, 24215, 24212
10087, 3114, 3115, 24033, 24032, 3123, 24216, 24217, 24214
10088, 3115, 92, 3063, 24033, 3124, 3085, 24218, 24216
10089, 2911, 24026, 24034, 2912, 24203, 24219, 24220, 2934
10090, 24026, 24027, 24035, 24034, 24205, 24221, 24222, 24219
10091, 24027, 24028, 24036, 24035, 24207, 24223, 24224, 24221
10092, 24028, 24029, 24037, 24036, 24209, 24225, 24226, 24223
10093, 24029, 24030, 24038, 24037, 24211, 24227, 24228, 24225
10094, 24030, 24031, 24039, 24038, 24213, 24229, 24230, 24227
10095, 24031, 24032, 24040, 24039, 24215, 24231, 24232, 24229
10096, 24032, 24033, 24041, 24040, 24217, 24233, 24234, 24231
10097, 24033, 3063, 3064, 24041, 24218, 3086, 24235, 24233
10098, 2912, 24034, 24042, 2913, 24220, 24236, 24237, 2935
10099, 24034, 24035, 24043, 24042, 24222, 24238, 24239, 24236
10100, 24035, 24036, 24044, 24043, 24224, 24240, 24241, 24238
10101, 24036, 24037, 24045, 24044, 24226, 24242, 24243, 24240
10102, 24037, 24038, 24046, 24045, 24228, 24244, 24245, 24242
10103, 24038, 24039, 24047, 24046, 24230, 24246, 24247, 24244
10104, 24039, 24040, 24048, 24047, 24232, 24248, 24249, 24246
10105, 24040, 24041, 24049, 24048, 24234, 24250, 24251, 24248
10106, 24041, 3064, 3065, 24049, 24235, 3087, 24252, 24250
10107, 2913, 24042, 24050, 2914, 24237, 24253, 24254, 2936
10108, 24042, 24043, 24051, 24050, 24239, 24255, 24256, 24253
10109, 24043, 24044, 24052, 24051, 24241, 24257, 24258, 24255
10110, 24044, 24045, 24053, 24052, 24243, 24259, 24260, 24257
10111, 24045, 24046, 24054, 24053, 24245, 24261, 24262, 24259
10112, 24046, 24047, 24055, 24054, 24247, 24263, 24264, 24261
10113, 24047, 24048, 24056, 24055, 24249, 24265, 24266, 24263
10114, 24048, 24049, 24057, 24056, 24251, 24267, 24268, 24265
10115, 24049, 3065, 3066, 24057, 24252, 3088, 24269, 24267
10116, 2914, 24050, 24058, 2915, 24254, 24270, 24271, 2937
10117, 24050, 24051, 24059, 24058, 24256, 24272, 24273, 24270
10118, 24051, 24052, 24060, 24059, 24258, 24274, 24275, 24272
10119, 24052, 24053, 24061, 24060, 24260, 24276, 24277, 24274
10120, 24053, 24054, 24062, 24061, 24262, 24278, 24279, 24276
10121, 24054, 24055, 24063, 24062, 24264, 24280, 24281, 24278
10122, 24055, 24056, 24064, 24063, 24266, 24282, 24283, 24280
10123, 24056, 24057, 24065, 24064, 24268, 24284, 24285, 24282
10124, 24057, 3066, 3067, 24065, 24269, 3089, 24286, 24284
10125, 2915, 24058, 24066, 2916, 24271, 24287, 24288, 2938
10126, 24058, 24059, 24067, 24066, 24273, 24289, 24290, 24287
10127, 24059, 24060, 24068, 24067, 24275, 24291, 24292, 24289
10128, 24060, 24061, 24069, 24068, 24277, 24293, 24294, 24291
10129, 24061, 24062, 24070, 24069, 24279, 24295, 24296, 24293
10130, 24062, 24063, 24071, 24070, 24281, 24297, 24298, 24295
10131, 24063, 24064, 24072, 24071, 24283, 24299, 24300, 24297
10132, 24064, 24065, 24073, 24072, 24285, 24301, 24302, 24299
10133, 24065, 3067, 3068, 24073, 24286, 3090, 24303, 24301
10134, 2916, 24066, 24074, 2917, 24288, 24304, 24305, 2939
10135, 24066, 24067, 24075, 24074, 24290, 24306, 24307, 24304
10136, 24067, 24068, 24076, 24075, 24292, 24308, 24309, 24306
10137, 24068, 24069, 24077, 24076, 24294, 24310, 24311, 24308
10138, 24069, 24070, 24078, 24077, 24296, 24312, 24313, 24310
10139, 24070, 24071, 24079, 24078, 24298, 24314, 24315, 24312
10140, 24071, 24072, 24080, 24079, 24300, 24316, 24317, 24314
10141, 24072, 24073, 24081, 24080, 24302, 24318, 24319, 24316
10142, 24073, 3068, 3069, 24081, 24303, 3091, 24320, 24318
10143, 2917, 24074, 24082, 2918, 24305, 24321, 24322, 2940
10144, 24074, 24075, 24083, 24082, 24307, 24323, 24324, 24321
10145, 24075, 24076, 24084, 24083, 24309, 24325, 24326, 24323
10146, 24076, 24077, 24085, 24084, 24311, 24327, 24328, 24325
10147, 24077, 24078, 24086, 24085, 24313, 24329, 24330, 24327
10148, 24078, 24079, 24087, 24086, 24315, 24331, 24332, 24329
10149, 24079, 24080, 24088, 24087, 24317, 24333, 24334, 24331
10150, 24080, 24081, 24089, 24088, 24319, 24335, 24336, 24333
10151, 24081, 3069, 3070, 24089, 24320, 3092, 24337, 24335
10152, 2918, 24082, 24090, 2919, 24322, 24338, 24339, 2941
10153, 24082, 24083, 24091, 24090, 24324, 24340, 24341, 24338
10154, 24083, 24084, 24092, 24091, 24326, 24342, 24343, 24340
10155, 24084, 24085, 24093, 24092, 24328, 24344, 24345, 24342
10156, 24085, 24086, 24094, 24093, 24330, 24346, 24347, 24344
10157, 24086, 24087, 24095, 24094, 24332, 24348, 24349, 24346
10158, 24087, 24088, 24096, 24095, 24334, 24350, 24351, 24348
10159, 24088, 24089, 24097, 24096, 24336, 24352, 24353, 24350
10160, 24089, 3070, 3071, 24097, 24337, 3093, 24354, 24352
10161, 2919, 24090, 24098, 2920, 24339, 24355, 24356, 2942
10162, 24090, 24091, 24099, 24098, 24341, 24357, 24358, 24355
10163, 24091, 24092, 24100, 24099, 24343, 24359, 24360, 24357
10164, 24092, 24093, 24101, 24100, 24345, 24361, 24362, 24359
10165, 24093, 24094, 24102, 24101, 24347, 24363, 24364, 24361
10166, 24094, 24095, 24103, 24102, 24349, 24365, 24366, 24363
10167, 24095, 24096, 24104, 24103, 24351, 24367, 24368, 24365
10168, 24096, 24097, 24105, 24104, 24353, 24369, 24370, 24367
10169, 24097, 3071, 3072, 24105, 24354, 3094, 24371, 24369
10170, 2920, 24098, 24106, 2921, 24356, 24372, 24373, 2943
10171, 24098, 24099, 24107, 24106, 24358, 24374, 24375, 24372
10172, 24099, 24100, 24108, 24107, 24360, 24376, 24377, 24374
10173, 24100, 24101, 24109, 24108, 24362, 24378, 24379, 24376
10174, 24101, 24102, 24110, 24109, 24364, 24380, 24381, 24378
10175, 24102, 24103, 24111, 24110, 24366, 24382, 24383, 24380
10176, 24103, 24104, 24112, 24111, 24368, 24384, 24385, 24382
10177, 24104, 24105, 24113, 24112, 24370, 24386, 24387, 24384
10178, 24105, 3072, 3073, 24113, 24371, 3095, 24388, 24386
10179, 2921, 24106, 24114, 2922, 24373, 24389, 24390, 2944
10180, 24106, 24107, 24115, 24114, 24375, 24391, 24392, 24389
10181, 24107, 24108, 24116, 24115, 24377, 24393, 24394, 24391
10182, 24108, 24109, 24117, 24116, 24379, 24395, 24396, 24393
10183, 24109, 24110, 24118, 24117, 24381, 24397, 24398, 24395
10184, 24110, 24111, 24119, 24118, 24383, 24399, 24400, 24397
10185, 24111, 24112, 24120, 24119, 24385, 24401, 24402, 24399
10186, 24112, 24113, 24121, 24120, 24387, 24403, 24404, 24401
10187, 24113, 3073, 3074, 24121, 24388, 3096, 24405, 24403
10188, 2922, 24114, 24122, 2923, 24390, 24406, 24407, 2945
10189, 24114, 24115, 24123, 24122, 24392, 24408, 24409, 24406
10190, 24115, 24116, 24124, 24123, 24394, 24410, 24411, 24408
10191, 24116, 24117, 24125, 24124, 24396, 24412, 24413, 24410
