29220, 79531, 14116, 14108, 79539, 79532, 14117, 14109, 79540, 81381, 14387, 81389, 81046, 81382, 14389, 81390, 
81049, 81023, 14390, 14373, 81048
29221, 79532, 14117, 14109, 79540, 79533, 14118, 14110, 79541, 81382, 14389, 81390, 81049, 81383, 14391, 81391, 
81052, 81026, 14392, 14375, 81051
29222, 79533, 14118, 14110, 79541, 13780, 1896, 1895, 13781, 81383, 14391, 81391, 81052, 13937, 1918, 13938, 
13905, 81029, 14393, 14376, 81054
29223, 13558, 1843, 1842, 13559, 79534, 14103, 14095, 79542, 13715, 1865, 13716, 13685, 81384, 14360, 81392, 
81056, 81030, 14361, 14344, 81055
29224, 79534, 14103, 14095, 79542, 79535, 14104, 14096, 79543, 81384, 14360, 81392, 81056, 81385, 14362, 81393, 
81059, 81033, 14363, 14346, 81058
29225, 79535, 14104, 14096, 79543, 79536, 14105, 14097, 79544, 81385, 14362, 81393, 81059, 81386, 14364, 81394, 
81062, 81036, 14365, 14348, 81061
29226, 79536, 14105, 14097, 79544, 79537, 14106, 14098, 79545, 81386, 14364, 81394, 81062, 81387, 14366, 81395, 
81065, 81039, 14367, 14350, 81064
29227, 79537, 14106, 14098, 79545, 79538, 14107, 14099, 79546, 81387, 14366, 81395, 81065, 81388, 14368, 81396, 
81068, 81042, 14369, 14352, 81067
29228, 79538, 14107, 14099, 79546, 79539, 14108, 14100, 79547, 81388, 14368, 81396, 81068, 81389, 14370, 81397, 
81071, 81045, 14371, 14354, 81070
29229, 79539, 14108, 14100, 79547, 79540, 14109, 14101, 79548, 81389, 14370, 81397, 81071, 81390, 14372, 81398, 
81074, 81048, 14373, 14356, 81073
29230, 79540, 14109, 14101, 79548, 79541, 14110, 14102, 79549, 81390, 14372, 81398, 81074, 81391, 14374, 81399, 
81077, 81051, 14375, 14358, 81076
29231, 79541, 14110, 14102, 79549, 13781, 1895, 1894, 13782, 81391, 14374, 81399, 81077, 13938, 1917, 13939, 
13907, 81054, 14376, 14359, 81079
29232, 13559, 1842, 1841, 13560, 79542, 14095, 14087, 79550, 13716, 1864, 13717, 13687, 81392, 14343, 81400, 
81081, 81055, 14344, 14327, 81080
29233, 79542, 14095, 14087, 79550, 79543, 14096, 14088, 79551, 81392, 14343, 81400, 81081, 81393, 14345, 81401, 
81084, 81058, 14346, 14329, 81083
29234, 79543, 14096, 14088, 79551, 79544, 14097, 14089, 79552, 81393, 14345, 81401, 81084, 81394, 14347, 81402, 
81087, 81061, 14348, 14331, 81086
29235, 79544, 14097, 14089, 79552, 79545, 14098, 14090, 79553, 81394, 14347, 81402, 81087, 81395, 14349, 81403, 
81090, 81064, 14350, 14333, 81089
29236, 79545, 14098, 14090, 79553, 79546, 14099, 14091, 79554, 81395, 14349, 81403, 81090, 81396, 14351, 81404, 
81093, 81067, 14352, 14335, 81092
29237, 79546, 14099, 14091, 79554, 79547, 14100, 14092, 79555, 81396, 14351, 81404, 81093, 81397, 14353, 81405, 
81096, 81070, 14354, 14337, 81095
29238, 79547, 14100, 14092, 79555, 79548, 14101, 14093, 79556, 81397, 14353, 81405, 81096, 81398, 14355, 81406, 
81099, 81073, 14356, 14339, 81098
29239, 79548, 14101, 14093, 79556, 79549, 14102, 14094, 79557, 81398, 14355, 81406, 81099, 81399, 14357, 81407, 
81102, 81076, 14358, 14341, 81101
29240, 79549, 14102, 14094, 79557, 13782, 1894, 1893, 13783, 81399, 14357, 81407, 81102, 13939, 1916, 13940, 
13909, 81079, 14359, 14342, 81104
29241, 13560, 1841, 1840, 13561, 79550, 14087, 14079, 79558, 13717, 1863, 13718, 13689, 81400, 14326, 81408, 
81106, 81080, 14327, 14310, 81105
29242, 79550, 14087, 14079, 79558, 79551, 14088, 14080, 79559, 81400, 14326, 81408, 81106, 81401, 14328, 81409, 
81109, 81083, 14329, 14312, 81108
29243, 79551, 14088, 14080, 79559, 79552, 14089, 14081, 79560, 81401, 14328, 81409, 81109, 81402, 14330, 81410, 
81112, 81086, 14331, 14314, 81111
29244, 79552, 14089, 14081, 79560, 79553, 14090, 14082, 79561, 81402, 14330, 81410, 81112, 81403, 14332, 81411, 
81115, 81089, 14333, 14316, 81114
29245, 79553, 14090, 14082, 79561, 79554, 14091, 14083, 79562, 81403, 14332, 81411, 81115, 81404, 14334, 81412, 
81118, 81092, 14335, 14318, 81117
29246, 79554, 14091, 14083, 79562, 79555, 14092, 14084, 79563, 81404, 14334, 81412, 81118, 81405, 14336, 81413, 
81121, 81095, 14337, 14320, 81120
29247, 79555, 14092, 14084, 79563, 79556, 14093, 14085, 79564, 81405, 14336, 81413, 81121, 81406, 14338, 81414, 
81124, 81098, 14339, 14322, 81123
29248, 79556, 14093, 14085, 79564, 79557, 14094, 14086, 79565, 81406, 14338, 81414, 81124, 81407, 14340, 81415, 
81127, 81101, 14341, 14324, 81126
29249, 79557, 14094, 14086, 79565, 13783, 1893, 1892, 13784, 81407, 14340, 81415, 81127, 13940, 1915, 13941, 
13911, 81104, 14342, 14325, 81129
29250, 13561, 1840, 1839, 13562, 79558, 14079, 14071, 79566, 13718, 1862, 13719, 13691, 81408, 14309, 81416, 
81131, 81105, 14310, 14293, 81130
29251, 79558, 14079, 14071, 79566, 79559, 14080, 14072, 79567, 81408, 14309, 81416, 81131, 81409, 14311, 81417, 
81134, 81108, 14312, 14295, 81133
29252, 79559, 14080, 14072, 79567, 79560, 14081, 14073, 79568, 81409, 14311, 81417, 81134, 81410, 14313, 81418, 
81137, 81111, 14314, 14297, 81136
29253, 79560, 14081, 14073, 79568, 79561, 14082, 14074, 79569, 81410, 14313, 81418, 81137, 81411, 14315, 81419, 
81140, 81114, 14316, 14299, 81139
29254, 79561, 14082, 14074, 79569, 79562, 14083, 14075, 79570, 81411, 14315, 81419, 81140, 81412, 14317, 81420, 
81143, 81117, 14318, 14301, 81142
29255, 79562, 14083, 14075, 79570, 79563, 14084, 14076, 79571, 81412, 14317, 81420, 81143, 81413, 14319, 81421, 
81146, 81120, 14320, 14303, 81145
29256, 79563, 14084, 14076, 79571, 79564, 14085, 14077, 79572, 81413, 14319, 81421, 81146, 81414, 14321, 81422, 
81149, 81123, 14322, 14305, 81148
29257, 79564, 14085, 14077, 79572, 79565, 14086, 14078, 79573, 81414, 14321, 81422, 81149, 81415, 14323, 81423, 
81152, 81126, 14324, 14307, 81151
29258, 79565, 14086, 14078, 79573, 13784, 1892, 1891, 13785, 81415, 14323, 81423, 81152, 13941, 1914, 13942, 
13913, 81129, 14325, 14308, 81154
29259, 13562, 1839, 1838, 13563, 79566, 14071, 14063, 79574, 13719, 1861, 13720, 13693, 81416, 14292, 81424, 
81156, 81130, 14293, 14276, 81155
29260, 79566, 14071, 14063, 79574, 79567, 14072, 14064, 79575, 81416, 14292, 81424, 81156, 81417, 14294, 81425, 
81159, 81133, 14295, 14278, 81158
29261, 79567, 14072, 14064, 79575, 79568, 14073, 14065, 79576, 81417, 14294, 81425, 81159, 81418, 14296, 81426, 
81162, 81136, 14297, 14280, 81161
29262, 79568, 14073, 14065, 79576, 79569, 14074, 14066, 79577, 81418, 14296, 81426, 81162, 81419, 14298, 81427, 
81165, 81139, 14299, 14282, 81164
29263, 79569, 14074, 14066, 79577, 79570, 14075, 14067, 79578, 81419, 14298, 81427, 81165, 81420, 14300, 81428, 
81168, 81142, 14301, 14284, 81167
29264, 79570, 14075, 14067, 79578, 79571, 14076, 14068, 79579, 81420, 14300, 81428, 81168, 81421, 14302, 81429, 
81171, 81145, 14303, 14286, 81170
29265, 79571, 14076, 14068, 79579, 79572, 14077, 14069, 79580, 81421, 14302, 81429, 81171, 81422, 14304, 81430, 
81174, 81148, 14305, 14288, 81173
29266, 79572, 14077, 14069, 79580, 79573, 14078, 14070, 79581, 81422, 14304, 81430, 81174, 81423, 14306, 81431, 
81177, 81151, 14307, 14290, 81176
29267, 79573, 14078, 14070, 79581, 13785, 1891, 1890, 13786, 81423, 14306, 81431, 81177, 13942, 1913, 13943, 
13915, 81154, 14308, 14291, 81179
29268, 13563, 1838, 1837, 13564, 79574, 14063, 14055, 79582, 13720, 1860, 13721, 13695, 81424, 14275, 81432, 
81181, 81155, 14276, 14259, 81180
29269, 79574, 14063, 14055, 79582, 79575, 14064, 14056, 79583, 81424, 14275, 81432, 81181, 81425, 14277, 81433, 
81184, 81158, 14278, 14261, 81183
29270, 79575, 14064, 14056, 79583, 79576, 14065, 14057, 79584, 81425, 14277, 81433, 81184, 81426, 14279, 81434, 
81187, 81161, 14280, 14263, 81186
29271, 79576, 14065, 14057, 79584, 79577, 14066, 14058, 79585, 81426, 14279, 81434, 81187, 81427, 14281, 81435, 
81190, 81164, 14282, 14265, 81189
29272, 79577, 14066, 14058, 79585, 79578, 14067, 14059, 79586, 81427, 14281, 81435, 81190, 81428, 14283, 81436, 
81193, 81167, 14284, 14267, 81192
29273, 79578, 14067, 14059, 79586, 79579, 14068, 14060, 79587, 81428, 14283, 81436, 81193, 81429, 14285, 81437, 
81196, 81170, 14286, 14269, 81195
29274, 79579, 14068, 14060, 79587, 79580, 14069, 14061, 79588, 81429, 14285, 81437, 81196, 81430, 14287, 81438, 
81199, 81173, 14288, 14271, 81198
29275, 79580, 14069, 14061, 79588, 79581, 14070, 14062, 79589, 81430, 14287, 81438, 81199, 81431, 14289, 81439, 
81202, 81176, 14290, 14273, 81201
29276, 79581, 14070, 14062, 79589, 13786, 1890, 1889, 13787, 81431, 14289, 81439, 81202, 13943, 1912, 13944, 
13917, 81179, 14291, 14274, 81204
29277, 13564, 1837, 1836, 13565, 79582, 14055, 14047, 79590, 13721, 1859, 13722, 13697, 81432, 14258, 81440, 
81206, 81180, 14259, 14242, 81205
29278, 79582, 14055, 14047, 79590, 79583, 14056, 14048, 79591, 81432, 14258, 81440, 81206, 81433, 14260, 81441, 
81209, 81183, 14261, 14244, 81208
29279, 79583, 14056, 14048, 79591, 79584, 14057, 14049, 79592, 81433, 14260, 81441, 81209, 81434, 14262, 81442, 
81212, 81186, 14263, 14246, 81211
29280, 79584, 14057, 14049, 79592, 79585, 14058, 14050, 79593, 81434, 14262, 81442, 81212, 81435, 14264, 81443, 
81215, 81189, 14265, 14248, 81214
29281, 79585, 14058, 14050, 79593, 79586, 14059, 14051, 79594, 81435, 14264, 81443, 81215, 81436, 14266, 81444, 
81218, 81192, 14267, 14250, 81217
29282, 79586, 14059, 14051, 79594, 79587, 14060, 14052, 79595, 81436, 14266, 81444, 81218, 81437, 14268, 81445, 
81221, 81195, 14269, 14252, 81220
29283, 79587, 14060, 14052, 79595, 79588, 14061, 14053, 79596, 81437, 14268, 81445, 81221, 81438, 14270, 81446, 
81224, 81198, 14271, 14254, 81223
29284, 79588, 14061, 14053, 79596, 79589, 14062, 14054, 79597, 81438, 14270, 81446, 81224, 81439, 14272, 81447, 
81227, 81201, 14273, 14256, 81226
29285, 79589, 14062, 14054, 79597, 13787, 1889, 1888, 13788, 81439, 14272, 81447, 81227, 13944, 1911, 13945, 
13919, 81204, 14274, 14257, 81229
29286, 13565, 1836, 1835, 13566, 79590, 14047, 14039, 79598, 13722, 1858, 13723, 13699, 81440, 14241, 81448, 
81231, 81205, 14242, 14225, 81230
29287, 79590, 14047, 14039, 79598, 79591, 14048, 14040, 79599, 81440, 14241, 81448, 81231, 81441, 14243, 81449, 
81234, 81208, 14244, 14227, 81233
29288, 79591, 14048, 14040, 79599, 79592, 14049, 14041, 79600, 81441, 14243, 81449, 81234, 81442, 14245, 81450, 
81237, 81211, 14246, 14229, 81236
29289, 79592, 14049, 14041, 79600, 79593, 14050, 14042, 79601, 81442, 14245, 81450, 81237, 81443, 14247, 81451, 
81240, 81214, 14248, 14231, 81239
29290, 79593, 14050, 14042, 79601, 79594, 14051, 14043, 79602, 81443, 14247, 81451, 81240, 81444, 14249, 81452, 
81243, 81217, 14250, 14233, 81242
29291, 79594, 14051, 14043, 79602, 79595, 14052, 14044, 79603, 81444, 14249, 81452, 81243, 81445, 14251, 81453, 
81246, 81220, 14252, 14235, 81245
29292, 79595, 14052, 14044, 79603, 79596, 14053, 14045, 79604, 81445, 14251, 81453, 81246, 81446, 14253, 81454, 
81249, 81223, 14254, 14237, 81248
29293, 79596, 14053, 14045, 79604, 79597, 14054, 14046, 79605, 81446, 14253, 81454, 81249, 81447, 14255, 81455, 
81252, 81226, 14256, 14239, 81251
29294, 79597, 14054, 14046, 79605, 13788, 1888, 1887, 13789, 81447, 14255, 81455, 81252, 13945, 1910, 13946, 
13921, 81229, 14257, 14240, 81254
29295, 13566, 1835, 1834, 13567, 79598, 14039, 14031, 79606, 13723, 1857, 13724, 13701, 81448, 14224, 81456, 
81256, 81230, 14225, 14208, 81255
29296, 79598, 14039, 14031, 79606, 79599, 14040, 14032, 79607, 81448, 14224, 81456, 81256, 81449, 14226, 81457, 
81259, 81233, 14227, 14210, 81258
29297, 79599, 14040, 14032, 79607, 79600, 14041, 14033, 79608, 81449, 14226, 81457, 81259, 81450, 14228, 81458, 
81262, 81236, 14229, 14212, 81261
29298, 79600, 14041, 14033, 79608, 79601, 14042, 14034, 79609, 81450, 14228, 81458, 81262, 81451, 14230, 81459, 
81265, 81239, 14231, 14214, 81264
29299, 79601, 14042, 14034, 79609, 79602, 14043, 14035, 79610, 81451, 14230, 81459, 81265, 81452, 14232, 81460, 
81268, 81242, 14233, 14216, 81267
29300, 79602, 14043, 14035, 79610, 79603, 14044, 14036, 79611, 81452, 14232, 81460, 81268, 81453, 14234, 81461, 
81271, 81245, 14235, 14218, 81270
29301, 79603, 14044, 14036, 79611, 79604, 14045, 14037, 79612, 81453, 14234, 81461, 81271, 81454, 14236, 81462, 
81274, 81248, 14237, 14220, 81273
29302, 79604, 14045, 14037, 79612, 79605, 14046, 14038, 79613, 81454, 14236, 81462, 81274, 81455, 14238, 81463, 
81277, 81251, 14239, 14222, 81276
29303, 79605, 14046, 14038, 79613, 13789, 1887, 1886, 13790, 81455, 14238, 81463, 81277, 13946, 1909, 13947, 
13923, 81254, 14240, 14223, 81279
29304, 13567, 1834, 61, 1829, 79606, 14031, 1931, 13971, 13724, 1856, 1833, 13702, 81456, 14207, 14030, 
81280, 81255, 14208, 1939, 14022
29305, 79606, 14031, 1931, 13971, 79607, 14032, 1932, 13970, 81456, 14207, 14030, 81280, 81457, 14209, 14029, 
81281, 81258, 14210, 1940, 14020
29306, 79607, 14032, 1932, 13970, 79608, 14033, 1933, 13969, 81457, 14209, 14029, 81281, 81458, 14211, 14028, 
81282, 81261, 14212, 1941, 14018
29307, 79608, 14033, 1933, 13969, 79609, 14034, 1934, 13968, 81458, 14211, 14028, 81282, 81459, 14213, 14027, 
81283, 81264, 14214, 1942, 14016
29308, 79609, 14034, 1934, 13968, 79610, 14035, 1935, 13967, 81459, 14213, 14027, 81283, 81460, 14215, 14026, 
81284, 81267, 14216, 1943, 14014
29309, 79610, 14035, 1935, 13967, 79611, 14036, 1936, 13966, 81460, 14215, 14026, 81284, 81461, 14217, 14025, 
81285, 81270, 14218, 1944, 14012
29310, 79611, 14036, 1936, 13966, 79612, 14037, 1937, 13965, 81461, 14217, 14025, 81285, 81462, 14219, 14024, 
81286, 81273, 14220, 1945, 14010
29311, 79612, 14037, 1937, 13965, 79613, 14038, 1938, 13964, 81462, 14219, 14024, 81286, 81463, 14221, 14023, 
81287, 81276, 14222, 1946, 14008
29312, 79613, 14038, 1938, 13964, 13790, 1886, 62, 1881, 81463, 14221, 14023, 81287, 13947, 1908, 1885, 
13925, 81279, 14223, 1947, 14006
*ELEMENT, type=C3D20, ELSET=Volume21
29313, 50, 1751, 13187, 1686, 1540, 13253, 81464, 13046, 1754, 13197, 13196, 1689, 13278, 81537, 81538, 
13071, 1549, 13277, 81536, 13070
29314, 1540, 13253, 81464, 13046, 1539, 13254, 81465, 13047, 13278, 81537, 81538, 13071, 13280, 81540, 81541, 
13073, 1548, 13279, 81539, 13072
29315, 1539, 13254, 81465, 13047, 1538, 13255, 81466, 13048, 13280, 81540, 81541, 13073, 13282, 81543, 81544, 
13075, 1547, 13281, 81542, 13074
29316, 1538, 13255, 81466, 13048, 1537, 13256, 81467, 13049, 13282, 81543, 81544, 13075, 13284, 81546, 81547, 
13077, 1546, 13283, 81545, 13076
29317, 1537, 13256, 81467, 13049, 1536, 13257, 81468, 13050, 13284, 81546, 81547, 13077, 13286, 81549, 81550, 
13079, 1545, 13285, 81548, 13078
29318, 1536, 13257, 81468, 13050, 1535, 13258, 81469, 13051, 13286, 81549, 81550, 13079, 13288, 81552, 81553, 
13081, 1544, 13287, 81551, 13080
29319, 1535, 13258, 81469, 13051, 1534, 13259, 81470, 13052, 13288, 81552, 81553, 13081, 13290, 81555, 81556, 
13083, 1543, 13289, 81554, 13082
29320, 1534, 13259, 81470, 13052, 1533, 13260, 81471, 13053, 13290, 81555, 81556, 13083, 13292, 81558, 81559, 
13085, 1542, 13291, 81557, 13084
29321, 1533, 13260, 81471, 13053, 46, 1772, 13220, 1705, 13292, 81558, 81559, 13085, 1775, 13229, 13230, 
1708, 1541, 13293, 81560, 13086
29322, 1686, 13187, 13188, 1687, 13046, 81464, 81472, 13054, 13196, 13199, 13198, 1690, 81538, 81562, 81563, 
13088, 13070, 81536, 81561, 13087
29323, 13046, 81464, 81472, 13054, 13047, 81465, 81473, 13055, 81538, 81562, 81563, 13088, 81541, 81565, 81566, 
13090, 13072, 81539, 81564, 13089
29324, 13047, 81465, 81473, 13055, 13048, 81466, 81474, 13056, 81541, 81565, 81566, 13090, 81544, 81568, 81569, 
13092, 13074, 81542, 81567, 13091
29325, 13048, 81466, 81474, 13056, 13049, 81467, 81475, 13057, 81544, 81568, 81569, 13092, 81547, 81571, 81572, 
13094, 13076, 81545, 81570, 13093
29326, 13049, 81467, 81475, 13057, 13050, 81468, 81476, 13058, 81547, 81571, 81572, 13094, 81550, 81574, 81575, 
13096, 13078, 81548, 81573, 13095
29327, 13050, 81468, 81476, 13058, 13051, 81469, 81477, 13059, 81550, 81574, 81575, 13096, 81553, 81577, 81578, 
13098, 13080, 81551, 81576, 13097
29328, 13051, 81469, 81477, 13059, 13052, 81470, 81478, 13060, 81553, 81577, 81578, 13098, 81556, 81580, 81581, 
13100, 13082, 81554, 81579, 13099
29329, 13052, 81470, 81478, 13060, 13053, 81471, 81479, 13061, 81556, 81580, 81581, 13100, 81559, 81583, 81584, 
13102, 13084, 81557, 81582, 13101
29330, 13053, 81471, 81479, 13061, 1705, 13220, 13221, 1706, 81559, 81583, 81584, 13102, 13230, 13231, 13232, 
1709, 13086, 81560, 81585, 13103
29331, 1687, 13188, 13189, 1688, 13054, 81472, 81480, 13062, 13198, 13201, 13200, 1691, 81563, 81587, 81588, 
13105, 13087, 81561, 81586, 13104
29332, 13054, 81472, 81480, 13062, 13055, 81473, 81481, 13063, 81563, 81587, 81588, 13105, 81566, 81590, 81591, 
13107, 13089, 81564, 81589, 13106
29333, 13055, 81473, 81481, 13063, 13056, 81474, 81482, 13064, 81566, 81590, 81591, 13107, 81569, 81593, 81594, 
13109, 13091, 81567, 81592, 13108
29334, 13056, 81474, 81482, 13064, 13057, 81475, 81483, 13065, 81569, 81593, 81594, 13109, 81572, 81596, 81597, 
13111, 13093, 81570, 81595, 13110
29335, 13057, 81475, 81483, 13065, 13058, 81476, 81484, 13066, 81572, 81596, 81597, 13111, 81575, 81599, 81600, 
13113, 13095, 81573, 81598, 13112
29336, 13058, 81476, 81484, 13066, 13059, 81477, 81485, 13067, 81575, 81599, 81600, 13113, 81578, 81602, 81603, 
13115, 13097, 81576, 81601, 13114
29337, 13059, 81477, 81485, 13067, 13060, 81478, 81486, 13068, 81578, 81602, 81603, 13115, 81581, 81605, 81606, 
13117, 13099, 81579, 81604, 13116
29338, 13060, 81478, 81486, 13068, 13061, 81479, 81487, 13069, 81581, 81605, 81606, 13117, 81584, 81608, 81609, 
13119, 13101, 81582, 81607, 13118
29339, 13061, 81479, 81487, 13069, 1706, 13221, 13222, 1707, 81584, 81608, 81609, 13119, 13232, 13233, 13234, 
1710, 13103, 81585, 81610, 13120
29340, 1688, 13189, 1758, 54, 13062, 81480, 13336, 1741, 13200, 13202, 1761, 1692, 81588, 81611, 13360, 
13121, 13104, 81586, 13361, 1750
29341, 13062, 81480, 13336, 1741, 13063, 81481, 13337, 1740, 81588, 81611, 13360, 13121, 81591, 81612, 13362, 
13122, 13106, 81589, 13363, 1749
29342, 13063, 81481, 13337, 1740, 13064, 81482, 13338, 1739, 81591, 81612, 13362, 13122, 81594, 81613, 13364, 
13123, 13108, 81592, 13365, 1748
29343, 13064, 81482, 13338, 1739, 13065, 81483, 13339, 1738, 81594, 81613, 13364, 13123, 81597, 81614, 13366, 
13124, 13110, 81595, 13367, 1747
29344, 13065, 81483, 13339, 1738, 13066, 81484, 13340, 1737, 81597, 81614, 13366, 13124, 81600, 81615, 13368, 
13125, 13112, 81598, 13369, 1746
29345, 13066, 81484, 13340, 1737, 13067, 81485, 13341, 1736, 81600, 81615, 13368, 13125, 81603, 81616, 13370, 
13126, 13114, 81601, 13371, 1745
29346, 13067, 81485, 13341, 1736, 13068, 81486, 13342, 1735, 81603, 81616, 13370, 13126, 81606, 81617, 13372, 
13127, 13116, 81604, 13373, 1744
29347, 13068, 81486, 13342, 1735, 13069, 81487, 13343, 1734, 81606, 81617, 13372, 13127, 81609, 81618, 13374, 
13128, 13118, 81607, 13375, 1743
29348, 13069, 81487, 13343, 1734, 1707, 13222, 1779, 56, 81609, 81618, 13374, 13128, 13234, 13235, 1782, 
1711, 13120, 81610, 13376, 1742
29349, 1751, 1752, 13190, 13187, 13253, 13261, 81488, 81464, 1755, 13204, 13203, 13197, 13295, 81620, 81621, 
81537, 13277, 13294, 81619, 81536
29350, 13253, 13261, 81488, 81464, 13254, 13262, 81489, 81465, 13295, 81620, 81621, 81537, 13297, 81623, 81624, 
81540, 13279, 13296, 81622, 81539
29351, 13254, 13262, 81489, 81465, 13255, 13263, 81490, 81466, 13297, 81623, 81624, 81540, 13299, 81626, 81627, 
81543, 13281, 13298, 81625, 81542
29352, 13255, 13263, 81490, 81466, 13256, 13264, 81491, 81467, 13299, 81626, 81627, 81543, 13301, 81629, 81630, 
81546, 13283, 13300, 81628, 81545
29353, 13256, 13264, 81491, 81467, 13257, 13265, 81492, 81468, 13301, 81629, 81630, 81546, 13303, 81632, 81633, 
81549, 13285, 13302, 81631, 81548
29354, 13257, 13265, 81492, 81468, 13258, 13266, 81493, 81469, 13303, 81632, 81633, 81549, 13305, 81635, 81636, 
81552, 13287, 13304, 81634, 81551
29355, 13258, 13266, 81493, 81469, 13259, 13267, 81494, 81470, 13305, 81635, 81636, 81552, 13307, 81638, 81639, 
81555, 13289, 13306, 81637, 81554
29356, 13259, 13267, 81494, 81470, 13260, 13268, 81495, 81471, 13307, 81638, 81639, 81555, 13309, 81641, 81642, 
81558, 13291, 13308, 81640, 81557
29357, 13260, 13268, 81495, 81471, 1772, 1773, 13223, 13220, 13309, 81641, 81642, 81558, 1776, 13236, 13237, 
13229, 13293, 13310, 81643, 81560
29358, 13187, 13190, 13191, 13188, 81464, 81488, 81496, 81472, 13203, 13206, 13205, 13199, 81621, 81645, 81646, 
81562, 81536, 81619, 81644, 81561
29359, 81464, 81488, 81496, 81472, 81465, 81489, 81497, 81473, 81621, 81645, 81646, 81562, 81624, 81648, 81649, 
81565, 81539, 81622, 81647, 81564
29360, 81465, 81489, 81497, 81473, 81466, 81490, 81498, 81474, 81624, 81648, 81649, 81565, 81627, 81651, 81652, 
81568, 81542, 81625, 81650, 81567
29361, 81466, 81490, 81498, 81474, 81467, 81491, 81499, 81475, 81627, 81651, 81652, 81568, 81630, 81654, 81655, 
81571, 81545, 81628, 81653, 81570
29362, 81467, 81491, 81499, 81475, 81468, 81492, 81500, 81476, 81630, 81654, 81655, 81571, 81633, 81657, 81658, 
81574, 81548, 81631, 81656, 81573
29363, 81468, 81492, 81500, 81476, 81469, 81493, 81501, 81477, 81633, 81657, 81658, 81574, 81636, 81660, 81661, 
81577, 81551, 81634, 81659, 81576
29364, 81469, 81493, 81501, 81477, 81470, 81494, 81502, 81478, 81636, 81660, 81661, 81577, 81639, 81663, 81664, 
81580, 81554, 81637, 81662, 81579
29365, 81470, 81494, 81502, 81478, 81471, 81495, 81503, 81479, 81639, 81663, 81664, 81580, 81642, 81666, 81667, 
81583, 81557, 81640, 81665, 81582
29366, 81471, 81495, 81503, 81479, 13220, 13223, 13224, 13221, 81642, 81666, 81667, 81583, 13237, 13238, 13239, 
13231, 81560, 81643, 81668, 81585
29367, 13188, 13191, 13192, 13189, 81472, 81496, 81504, 81480, 13205, 13208, 13207, 13201, 81646, 81670, 81671, 
81587, 81561, 81644, 81669, 81586
29368, 81472, 81496, 81504, 81480, 81473, 81497, 81505, 81481, 81646, 81670, 81671, 81587, 81649, 81673, 81674, 
81590, 81564, 81647, 81672, 81589
29369, 81473, 81497, 81505, 81481, 81474, 81498, 81506, 81482, 81649, 81673, 81674, 81590, 81652, 81676, 81677, 
81593, 81567, 81650, 81675, 81592
29370, 81474, 81498, 81506, 81482, 81475, 81499, 81507, 81483, 81652, 81676, 81677, 81593, 81655, 81679, 81680, 
81596, 81570, 81653, 81678, 81595
29371, 81475, 81499, 81507, 81483, 81476, 81500, 81508, 81484, 81655, 81679, 81680, 81596, 81658, 81682, 81683, 
81599, 81573, 81656, 81681, 81598
29372, 81476, 81500, 81508, 81484, 81477, 81501, 81509, 81485, 81658, 81682, 81683, 81599, 81661, 81685, 81686, 
81602, 81576, 81659, 81684, 81601
29373, 81477, 81501, 81509, 81485, 81478, 81502, 81510, 81486, 81661, 81685, 81686, 81602, 81664, 81688, 81689, 
81605, 81579, 81662, 81687, 81604
29374, 81478, 81502, 81510, 81486, 81479, 81503, 81511, 81487, 81664, 81688, 81689, 81605, 81667, 81691, 81692, 
81608, 81582, 81665, 81690, 81607
29375, 81479, 81503, 81511, 81487, 13221, 13224, 13225, 13222, 81667, 81691, 81692, 81608, 13239, 13240, 13241, 
13233, 81585, 81668, 81693, 81610
29376, 13189, 13192, 1759, 1758, 81480, 81504, 13344, 13336, 13207, 13209, 1762, 13202, 81671, 81694, 13377, 
81611, 81586, 81669, 13378, 13361
29377, 81480, 81504, 13344, 13336, 81481, 81505, 13345, 13337, 81671, 81694, 13377, 81611, 81674, 81695, 13379, 
81612, 81589, 81672, 13380, 13363
29378, 81481, 81505, 13345, 13337, 81482, 81506, 13346, 13338, 81674, 81695, 13379, 81612, 81677, 81696, 13381, 
81613, 81592, 81675, 13382, 13365
29379, 81482, 81506, 13346, 13338, 81483, 81507, 13347, 13339, 81677, 81696, 13381, 81613, 81680, 81697, 13383, 
81614, 81595, 81678, 13384, 13367
29380, 81483, 81507, 13347, 13339, 81484, 81508, 13348, 13340, 81680, 81697, 13383, 81614, 81683, 81698, 13385, 
81615, 81598, 81681, 13386, 13369
29381, 81484, 81508, 13348, 13340, 81485, 81509, 13349, 13341, 81683, 81698, 13385, 81615, 81686, 81699, 13387, 
81616, 81601, 81684, 13388, 13371
29382, 81485, 81509, 13349, 13341, 81486, 81510, 13350, 13342, 81686, 81699, 13387, 81616, 81689, 81700, 13389, 
81617, 81604, 81687, 13390, 13373
29383, 81486, 81510, 13350, 13342, 81487, 81511, 13351, 13343, 81689, 81700, 13389, 81617, 81692, 81701, 13391, 
81618, 81607, 81690, 13392, 13375
29384, 81487, 81511, 13351, 13343, 13222, 13225, 1780, 1779, 81692, 81701, 13391, 81618, 13241, 13242, 1783, 
13235, 81610, 81693, 13393, 13376
29385, 1752, 1753, 13193, 13190, 13261, 13269, 81512, 81488, 1756, 13211, 13210, 13204, 13312, 81703, 81704, 
81620, 13294, 13311, 81702, 81619
29386, 13261, 13269, 81512, 81488, 13262, 13270, 81513, 81489, 13312, 81703, 81704, 81620, 13314, 81706, 81707, 
81623, 13296, 13313, 81705, 81622
29387, 13262, 13270, 81513, 81489, 13263, 13271, 81514, 81490, 13314, 81706, 81707, 81623, 13316, 81709, 81710, 
81626, 13298, 13315, 81708, 81625
29388, 13263, 13271, 81514, 81490, 13264, 13272, 81515, 81491, 13316, 81709, 81710, 81626, 13318, 81712, 81713, 
81629, 13300, 13317, 81711, 81628
29389, 13264, 13272, 81515, 81491, 13265, 13273, 81516, 81492, 13318, 81712, 81713, 81629, 13320, 81715, 81716, 
81632, 13302, 13319, 81714, 81631
29390, 13265, 13273, 81516, 81492, 13266, 13274, 81517, 81493, 13320, 81715, 81716, 81632, 13322, 81718, 81719, 
81635, 13304, 13321, 81717, 81634
29391, 13266, 13274, 81517, 81493, 13267, 13275, 81518, 81494, 13322, 81718, 81719, 81635, 13324, 81721, 81722, 
81638, 13306, 13323, 81720, 81637
29392, 13267, 13275, 81518, 81494, 13268, 13276, 81519, 81495, 13324, 81721, 81722, 81638, 13326, 81724, 81725, 
81641, 13308, 13325, 81723, 81640
29393, 13268, 13276, 81519, 81495, 1773, 1774, 13226, 13223, 13326, 81724, 81725, 81641, 1777, 13243, 13244, 
13236, 13310, 13327, 81726, 81643
29394, 13190, 13193, 13194, 13191, 81488, 81512, 81520, 81496, 13210, 13213, 13212, 13206, 81704, 81728, 81729, 
81645, 81619, 81702, 81727, 81644
29395, 81488, 81512, 81520, 81496, 81489, 81513, 81521, 81497, 81704, 81728, 81729, 81645, 81707, 81731, 81732, 
81648, 81622, 81705, 81730, 81647
29396, 81489, 81513, 81521, 81497, 81490, 81514, 81522, 81498, 81707, 81731, 81732, 81648, 81710, 81734, 81735, 
81651, 81625, 81708, 81733, 81650
29397, 81490, 81514, 81522, 81498, 81491, 81515, 81523, 81499, 81710, 81734, 81735, 81651, 81713, 81737, 81738, 
81654, 81628, 81711, 81736, 81653
29398, 81491, 81515, 81523, 81499, 81492, 81516, 81524, 81500, 81713, 81737, 81738, 81654, 81716, 81740, 81741, 
81657, 81631, 81714, 81739, 81656
29399, 81492, 81516, 81524, 81500, 81493, 81517, 81525, 81501, 81716, 81740, 81741, 81657, 81719, 81743, 81744, 
81660, 81634, 81717, 81742, 81659
29400, 81493, 81517, 81525, 81501, 81494, 81518, 81526, 81502, 81719, 81743, 81744, 81660, 81722, 81746, 81747, 
81663, 81637, 81720, 81745, 81662
29401, 81494, 81518, 81526, 81502, 81495, 81519, 81527, 81503, 81722, 81746, 81747, 81663, 81725, 81749, 81750, 
81666, 81640, 81723, 81748, 81665
29402, 81495, 81519, 81527, 81503, 13223, 13226, 13227, 13224, 81725, 81749, 81750, 81666, 13244, 13245, 13246, 
13238, 81643, 81726, 81751, 81668
29403, 13191, 13194, 13195, 13192, 81496, 81520, 81528, 81504, 13212, 13215, 13214, 13208, 81729, 81753, 81754, 
81670, 81644, 81727, 81752, 81669
29404, 81496, 81520, 81528, 81504, 81497, 81521, 81529, 81505, 81729, 81753, 81754, 81670, 81732, 81756, 81757, 
81673, 81647, 81730, 81755, 81672
29405, 81497, 81521, 81529, 81505, 81498, 81522, 81530, 81506, 81732, 81756, 81757, 81673, 81735, 81759, 81760, 
81676, 81650, 81733, 81758, 81675
29406, 81498, 81522, 81530, 81506, 81499, 81523, 81531, 81507, 81735, 81759, 81760, 81676, 81738, 81762, 81763, 
81679, 81653, 81736, 81761, 81678
29407, 81499, 81523, 81531, 81507, 81500, 81524, 81532, 81508, 81738, 81762, 81763, 81679, 81741, 81765, 81766, 
81682, 81656, 81739, 81764, 81681
29408, 81500, 81524, 81532, 81508, 81501, 81525, 81533, 81509, 81741, 81765, 81766, 81682, 81744, 81768, 81769, 
81685, 81659, 81742, 81767, 81684
29409, 81501, 81525, 81533, 81509, 81502, 81526, 81534, 81510, 81744, 81768, 81769, 81685, 81747, 81771, 81772, 
81688, 81662, 81745, 81770, 81687
29410, 81502, 81526, 81534, 81510, 81503, 81527, 81535, 81511, 81747, 81771, 81772, 81688, 81750, 81774, 81775, 
81691, 81665, 81748, 81773, 81690
29411, 81503, 81527, 81535, 81511, 13224, 13227, 13228, 13225, 81750, 81774, 81775, 81691, 13246, 13247, 13248, 
13240, 81668, 81751, 81776, 81693
29412, 13192, 13195, 1760, 1759, 81504, 81528, 13352, 13344, 13214, 13216, 1763, 13209, 81754, 81777, 13394, 
81694, 81669, 81752, 13395, 13378
29413, 81504, 81528, 13352, 13344, 81505, 81529, 13353, 13345, 81754, 81777, 13394, 81694, 81757, 81778, 13396, 
81695, 81672, 81755, 13397, 13380
29414, 81505, 81529, 13353, 13345, 81506, 81530, 13354, 13346, 81757, 81778, 13396, 81695, 81760, 81779, 13398, 
81696, 81675, 81758, 13399, 13382
29415, 81506, 81530, 13354, 13346, 81507, 81531, 13355, 13347, 81760, 81779, 13398, 81696, 81763, 81780, 13400, 
81697, 81678, 81761, 13401, 13384
29416, 81507, 81531, 13355, 13347, 81508, 81532, 13356, 13348, 81763, 81780, 13400, 81697, 81766, 81781, 13402, 
81698, 81681, 81764, 13403, 13386
29417, 81508, 81532, 13356, 13348, 81509, 81533, 13357, 13349, 81766, 81781, 13402, 81698, 81769, 81782, 13404, 
81699, 81684, 81767, 13405, 13388
29418, 81509, 81533, 13357, 13349, 81510, 81534, 13358, 13350, 81769, 81782, 13404, 81699, 81772, 81783, 13406, 
81700, 81687, 81770, 13407, 13390
29419, 81510, 81534, 13358, 13350, 81511, 81535, 13359, 13351, 81772, 81783, 13406, 81700, 81775, 81784, 13408, 
81701, 81690, 81773, 13409, 13392
29420, 81511, 81535, 13359, 13351, 13225, 13228, 1781, 1780, 81775, 81784, 13408, 81701, 13248, 13249, 1784, 
13242, 81693, 81776, 13410, 13393
29421, 1753, 57, 1765, 13193, 13269, 1800, 13419, 81512, 1757, 1768, 13217, 13211, 13328, 13444, 81785, 
81703, 13311, 1809, 13443, 81702
29422, 13269, 1800, 13419, 81512, 13270, 1799, 13420, 81513, 13328, 13444, 81785, 81703, 13329, 13446, 81786, 
81706, 13313, 1808, 13445, 81705
29423, 13270, 1799, 13420, 81513, 13271, 1798, 13421, 81514, 13329, 13446, 81786, 81706, 13330, 13448, 81787, 
81709, 13315, 1807, 13447, 81708
29424, 13271, 1798, 13421, 81514, 13272, 1797, 13422, 81515, 13330, 13448, 81787, 81709, 13331, 13450, 81788, 
81712, 13317, 1806, 13449, 81711
29425, 13272, 1797, 13422, 81515, 13273, 1796, 13423, 81516, 13331, 13450, 81788, 81712, 13332, 13452, 81789, 
81715, 13319, 1805, 13451, 81714
29426, 13273, 1796, 13423, 81516, 13274, 1795, 13424, 81517, 13332, 13452, 81789, 81715, 13333, 13454, 81790, 
81718, 13321, 1804, 13453, 81717
29427, 13274, 1795, 13424, 81517, 13275, 1794, 13425, 81518, 13333, 13454, 81790, 81718, 13334, 13456, 81791, 
81721, 13323, 1803, 13455, 81720
29428, 13275, 1794, 13425, 81518, 13276, 1793, 13426, 81519, 13334, 13456, 81791, 81721, 13335, 13458, 81792, 
81724, 13325, 1802, 13457, 81723
29429, 13276, 1793, 13426, 81519, 1774, 59, 1786, 13226, 13335, 13458, 81792, 81724, 1778, 1789, 13250, 
13243, 13327, 1801, 13459, 81726
29430, 13193, 1765, 1766, 13194, 81512, 13419, 13427, 81520, 13217, 1769, 13218, 13213, 81785, 13461, 81793, 
81728, 81702, 13443, 13460, 81727
29431, 81512, 13419, 13427, 81520, 81513, 13420, 13428, 81521, 81785, 13461, 81793, 81728, 81786, 13463, 81794, 
81731, 81705, 13445, 13462, 81730
29432, 81513, 13420, 13428, 81521, 81514, 13421, 13429, 81522, 81786, 13463, 81794, 81731, 81787, 13465, 81795, 
81734, 81708, 13447, 13464, 81733
29433, 81514, 13421, 13429, 81522, 81515, 13422, 13430, 81523, 81787, 13465, 81795, 81734, 81788, 13467, 81796, 
81737, 81711, 13449, 13466, 81736
29434, 81515, 13422, 13430, 81523, 81516, 13423, 13431, 81524, 81788, 13467, 81796, 81737, 81789, 13469, 81797, 
81740, 81714, 13451, 13468, 81739
29435, 81516, 13423, 13431, 81524, 81517, 13424, 13432, 81525, 81789, 13469, 81797, 81740, 81790, 13471, 81798, 
81743, 81717, 13453, 13470, 81742
29436, 81517, 13424, 13432, 81525, 81518, 13425, 13433, 81526, 81790, 13471, 81798, 81743, 81791, 13473, 81799, 
81746, 81720, 13455, 13472, 81745
29437, 81518, 13425, 13433, 81526, 81519, 13426, 13434, 81527, 81791, 13473, 81799, 81746, 81792, 13475, 81800, 
81749, 81723, 13457, 13474, 81748
29438, 81519, 13426, 13434, 81527, 13226, 1786, 1787, 13227, 81792, 13475, 81800, 81749, 13250, 1790, 13251, 
13245, 81726, 13459, 13476, 81751
29439, 13194, 1766, 1767, 13195, 81520, 13427, 13435, 81528, 13218, 1770, 13219, 13215, 81793, 13478, 81801, 
81753, 81727, 13460, 13477, 81752
29440, 81520, 13427, 13435, 81528, 81521, 13428, 13436, 81529, 81793, 13478, 81801, 81753, 81794, 13480, 81802, 
81756, 81730, 13462, 13479, 81755
29441, 81521, 13428, 13436, 81529, 81522, 13429, 13437, 81530, 81794, 13480, 81802, 81756, 81795, 13482, 81803, 
81759, 81733, 13464, 13481, 81758
29442, 81522, 13429, 13437, 81530, 81523, 13430, 13438, 81531, 81795, 13482, 81803, 81759, 81796, 13484, 81804, 
81762, 81736, 13466, 13483, 81761
29443, 81523, 13430, 13438, 81531, 81524, 13431, 13439, 81532, 81796, 13484, 81804, 81762, 81797, 13486, 81805, 
81765, 81739, 13468, 13485, 81764
29444, 81524, 13431, 13439, 81532, 81525, 13432, 13440, 81533, 81797, 13486, 81805, 81765, 81798, 13488, 81806, 
81768, 81742, 13470, 13487, 81767
29445, 81525, 13432, 13440, 81533, 81526, 13433, 13441, 81534, 81798, 13488, 81806, 81768, 81799, 13490, 81807, 
81771, 81745, 13472, 13489, 81770
29446, 81526, 13433, 13441, 81534, 81527, 13434, 13442, 81535, 81799, 13490, 81807, 81771, 81800, 13492, 81808, 
81774, 81748, 13474, 13491, 81773
29447, 81527, 13434, 13442, 81535, 13227, 1787, 1788, 13228, 81800, 13492, 81808, 81774, 13251, 1791, 13252, 
13247, 81751, 13476, 13493, 81776
29448, 13195, 1767, 58, 1760, 81528, 13435, 1817, 13352, 13219, 1771, 1764, 13216, 81801, 13494, 13411, 
81777, 81752, 13477, 1826, 13395
29449, 81528, 13435, 1817, 13352, 81529, 13436, 1816, 13353, 81801, 13494, 13411, 81777, 81802, 13495, 13412, 
81778, 81755, 13479, 1825, 13397
29450, 81529, 13436, 1816, 13353, 81530, 13437, 1815, 13354, 81802, 13495, 13412, 81778, 81803, 13496, 13413, 
81779, 81758, 13481, 1824, 13399
29451, 81530, 13437, 1815, 13354, 81531, 13438, 1814, 13355, 81803, 13496, 13413, 81779, 81804, 13497, 13414, 
81780, 81761, 13483, 1823, 13401
29452, 81531, 13438, 1814, 13355, 81532, 13439, 1813, 13356, 81804, 13497, 13414, 81780, 81805, 13498, 13415, 
81781, 81764, 13485, 1822, 13403
29453, 81532, 13439, 1813, 13356, 81533, 13440, 1812, 13357, 81805, 13498, 13415, 81781, 81806, 13499, 13416, 
81782, 81767, 13487, 1821, 13405
29454, 81533, 13440, 1812, 13357, 81534, 13441, 1811, 13358, 81806, 13499, 13416, 81782, 81807, 13500, 13417, 
81783, 81770, 13489, 1820, 13407
29455, 81534, 13441, 1811, 13358, 81535, 13442, 1810, 13359, 81807, 13500, 13417, 81783, 81808, 13501, 13418, 
81784, 81773, 13491, 1819, 13409
29456, 81535, 13442, 1810, 13359, 13228, 1788, 60, 1781, 81808, 13501, 13418, 81784, 13252, 1792, 1785, 
13249, 81776, 13493, 1818, 13410
*ELEMENT, type=C3D20, ELSET=Volume22
29457, 54, 1758, 17854, 2387, 1741, 13336, 81809, 17238, 1761, 17921, 17920, 2409, 13360, 82338, 82339, 
17415, 1750, 13361, 82337, 17414
29458, 1741, 13336, 81809, 17238, 1740, 13337, 81810, 17239, 13360, 82338, 82339, 17415, 13362, 82341, 82342, 
17417, 1749, 13363, 82340, 17416
29459, 1740, 13337, 81810, 17239, 1739, 13338, 81811, 17240, 13362, 82341, 82342, 17417, 13364, 82344, 82345, 
17419, 1748, 13365, 82343, 17418
29460, 1739, 13338, 81811, 17240, 1738, 13339, 81812, 17241, 13364, 82344, 82345, 17419, 13366, 82347, 82348, 
17421, 1747, 13367, 82346, 17420
29461, 1738, 13339, 81812, 17241, 1737, 13340, 81813, 17242, 13366, 82347, 82348, 17421, 13368, 82350, 82351, 
17423, 1746, 13369, 82349, 17422
29462, 1737, 13340, 81813, 17242, 1736, 13341, 81814, 17243, 13368, 82350, 82351, 17423, 13370, 82353, 82354, 
17425, 1745, 13371, 82352, 17424
29463, 1736, 13341, 81814, 17243, 1735, 13342, 81815, 17244, 13370, 82353, 82354, 17425, 13372, 82356, 82357, 
17427, 1744, 13373, 82355, 17426
29464, 1735, 13342, 81815, 17244, 1734, 13343, 81816, 17245, 13372, 82356, 82357, 17427, 13374, 82359, 82360, 
17429, 1743, 13375, 82358, 17428
29465, 1734, 13343, 81816, 17245, 56, 1779, 18077, 2437, 13374, 82359, 82360, 17429, 1782, 18143, 18144, 
2459, 1742, 13376, 82361, 17430
29466, 2387, 17854, 17855, 2388, 17238, 81809, 81817, 17246, 17920, 17923, 17922, 2410, 82339, 82363, 82364, 
17432, 17414, 82337, 82362, 17431
29467, 17238, 81809, 81817, 17246, 17239, 81810, 81818, 17247, 82339, 82363, 82364, 17432, 82342, 82366, 82367, 
17434, 17416, 82340, 82365, 17433
29468, 17239, 81810, 81818, 17247, 17240, 81811, 81819, 17248, 82342, 82366, 82367, 17434, 82345, 82369, 82370, 
17436, 17418, 82343, 82368, 17435
29469, 17240, 81811, 81819, 17248, 17241, 81812, 81820, 17249, 82345, 82369, 82370, 17436, 82348, 82372, 82373, 
17438, 17420, 82346, 82371, 17437
29470, 17241, 81812, 81820, 17249, 17242, 81813, 81821, 17250, 82348, 82372, 82373, 17438, 82351, 82375, 82376, 
17440, 17422, 82349, 82374, 17439
29471, 17242, 81813, 81821, 17250, 17243, 81814, 81822, 17251, 82351, 82375, 82376, 17440, 82354, 82378, 82379, 
17442, 17424, 82352, 82377, 17441
29472, 17243, 81814, 81822, 17251, 17244, 81815, 81823, 17252, 82354, 82378, 82379, 17442, 82357, 82381, 82382, 
17444, 17426, 82355, 82380, 17443
29473, 17244, 81815, 81823, 17252, 17245, 81816, 81824, 17253, 82357, 82381, 82382, 17444, 82360, 82384, 82385, 
17446, 17428, 82358, 82383, 17445
29474, 17245, 81816, 81824, 17253, 2437, 18077, 18078, 2438, 82360, 82384, 82385, 17446, 18144, 18145, 18146, 
2460, 17430, 82361, 82386, 17447
29475, 2388, 17855, 17856, 2389, 17246, 81817, 81825, 17254, 17922, 17925, 17924, 2411, 82364, 82388, 82389, 
17449, 17431, 82362, 82387, 17448
29476, 17246, 81817, 81825, 17254, 17247, 81818, 81826, 17255, 82364, 82388, 82389, 17449, 82367, 82391, 82392, 
17451, 17433, 82365, 82390, 17450
29477, 17247, 81818, 81826, 17255, 17248, 81819, 81827, 17256, 82367, 82391, 82392, 17451, 82370, 82394, 82395, 
17453, 17435, 82368, 82393, 17452
29478, 17248, 81819, 81827, 17256, 17249, 81820, 81828, 17257, 82370, 82394, 82395, 17453, 82373, 82397, 82398, 
17455, 17437, 82371, 82396, 17454
29479, 17249, 81820, 81828, 17257, 17250, 81821, 81829, 17258, 82373, 82397, 82398, 17455, 82376, 82400, 82401, 
17457, 17439, 82374, 82399, 17456
29480, 17250, 81821, 81829, 17258, 17251, 81822, 81830, 17259, 82376, 82400, 82401, 17457, 82379, 82403, 82404, 
17459, 17441, 82377, 82402, 17458
29481, 17251, 81822, 81830, 17259, 17252, 81823, 81831, 17260, 82379, 82403, 82404, 17459, 82382, 82406, 82407, 
17461, 17443, 82380, 82405, 17460
29482, 17252, 81823, 81831, 17260, 17253, 81824, 81832, 17261, 82382, 82406, 82407, 17461, 82385, 82409, 82410, 
17463, 17445, 82383, 82408, 17462
29483, 17253, 81824, 81832, 17261, 2438, 18078, 18079, 2439, 82385, 82409, 82410, 17463, 18146, 18147, 18148, 
2461, 17447, 82386, 82411, 17464
29484, 2389, 17856, 17857, 2390, 17254, 81825, 81833, 17262, 17924, 17927, 17926, 2412, 82389, 82413, 82414, 
17466, 17448, 82387, 82412, 17465
29485, 17254, 81825, 81833, 17262, 17255, 81826, 81834, 17263, 82389, 82413, 82414, 17466, 82392, 82416, 82417, 
17468, 17450, 82390, 82415, 17467
29486, 17255, 81826, 81834, 17263, 17256, 81827, 81835, 17264, 82392, 82416, 82417, 17468, 82395, 82419, 82420, 
17470, 17452, 82393, 82418, 17469
29487, 17256, 81827, 81835, 17264, 17257, 81828, 81836, 17265, 82395, 82419, 82420, 17470, 82398, 82422, 82423, 
17472, 17454, 82396, 82421, 17471
29488, 17257, 81828, 81836, 17265, 17258, 81829, 81837, 17266, 82398, 82422, 82423, 17472, 82401, 82425, 82426, 
17474, 17456, 82399, 82424, 17473
29489, 17258, 81829, 81837, 17266, 17259, 81830, 81838, 17267, 82401, 82425, 82426, 17474, 82404, 82428, 82429, 
17476, 17458, 82402, 82427, 17475
29490, 17259, 81830, 81838, 17267, 17260, 81831, 81839, 17268, 82404, 82428, 82429, 17476, 82407, 82431, 82432, 
17478, 17460, 82405, 82430, 17477
29491, 17260, 81831, 81839, 17268, 17261, 81832, 81840, 17269, 82407, 82431, 82432, 17478, 82410, 82434, 82435, 
17480, 17462, 82408, 82433, 17479
29492, 17261, 81832, 81840, 17269, 2439, 18079, 18080, 2440, 82410, 82434, 82435, 17480, 18148, 18149, 18150, 
2462, 17464, 82411, 82436, 17481
29493, 2390, 17857, 17858, 2391, 17262, 81833, 81841, 17270, 17926, 17929, 17928, 2413, 82414, 82438, 82439, 
17483, 17465, 82412, 82437, 17482
29494, 17262, 81833, 81841, 17270, 17263, 81834, 81842, 17271, 82414, 82438, 82439, 17483, 82417, 82441, 82442, 
17485, 17467, 82415, 82440, 17484
29495, 17263, 81834, 81842, 17271, 17264, 81835, 81843, 17272, 82417, 82441, 82442, 17485, 82420, 82444, 82445, 
17487, 17469, 82418, 82443, 17486
29496, 17264, 81835, 81843, 17272, 17265, 81836, 81844, 17273, 82420, 82444, 82445, 17487, 82423, 82447, 82448, 
17489, 17471, 82421, 82446, 17488
29497, 17265, 81836, 81844, 17273, 17266, 81837, 81845, 17274, 82423, 82447, 82448, 17489, 82426, 82450, 82451, 
17491, 17473, 82424, 82449, 17490
29498, 17266, 81837, 81845, 17274, 17267, 81838, 81846, 17275, 82426, 82450, 82451, 17491, 82429, 82453, 82454, 
17493, 17475, 82427, 82452, 17492
29499, 17267, 81838, 81846, 17275, 17268, 81839, 81847, 17276, 82429, 82453, 82454, 17493, 82432, 82456, 82457, 
17495, 17477, 82430, 82455, 17494
29500, 17268, 81839, 81847, 17276, 17269, 81840, 81848, 17277, 82432, 82456, 82457, 17495, 82435, 82459, 82460, 
17497, 17479, 82433, 82458, 17496
29501, 17269, 81840, 81848, 17277, 2440, 18080, 18081, 2441, 82435, 82459, 82460, 17497, 18150, 18151, 18152, 
2463, 17481, 82436, 82461, 17498
29502, 2391, 17858, 17859, 2392, 17270, 81841, 81849, 17278, 17928, 17931, 17930, 2414, 82439, 82463, 82464, 
17500, 17482, 82437, 82462, 17499
29503, 17270, 81841, 81849, 17278, 17271, 81842, 81850, 17279, 82439, 82463, 82464, 17500, 82442, 82466, 82467, 
17502, 17484, 82440, 82465, 17501
29504, 17271, 81842, 81850, 17279, 17272, 81843, 81851, 17280, 82442, 82466, 82467, 17502, 82445, 82469, 82470, 
17504, 17486, 82443, 82468, 17503
29505, 17272, 81843, 81851, 17280, 17273, 81844, 81852, 17281, 82445, 82469, 82470, 17504, 82448, 82472, 82473, 
17506, 17488, 82446, 82471, 17505
29506, 17273, 81844, 81852, 17281, 17274, 81845, 81853, 17282, 82448, 82472, 82473, 17506, 82451, 82475, 82476, 
17508, 17490, 82449, 82474, 17507
29507, 17274, 81845, 81853, 17282, 17275, 81846, 81854, 17283, 82451, 82475, 82476, 17508, 82454, 82478, 82479, 
17510, 17492, 82452, 82477, 17509
29508, 17275, 81846, 81854, 17283, 17276, 81847, 81855, 17284, 82454, 82478, 82479, 17510, 82457, 82481, 82482, 
17512, 17494, 82455, 82480, 17511
29509, 17276, 81847, 81855, 17284, 17277, 81848, 81856, 17285, 82457, 82481, 82482, 17512, 82460, 82484, 82485, 
17514, 17496, 82458, 82483, 17513
29510, 17277, 81848, 81856, 17285, 2441, 18081, 18082, 2442, 82460, 82484, 82485, 17514, 18152, 18153, 18154, 
2464, 17498, 82461, 82486, 17515
29511, 2392, 17859, 17860, 2393, 17278, 81849, 81857, 17286, 17930, 17933, 17932, 2415, 82464, 82488, 82489, 
17517, 17499, 82462, 82487, 17516
29512, 17278, 81849, 81857, 17286, 17279, 81850, 81858, 17287, 82464, 82488, 82489, 17517, 82467, 82491, 82492, 
17519, 17501, 82465, 82490, 17518
29513, 17279, 81850, 81858, 17287, 17280, 81851, 81859, 17288, 82467, 82491, 82492, 17519, 82470, 82494, 82495, 
17521, 17503, 82468, 82493, 17520
29514, 17280, 81851, 81859, 17288, 17281, 81852, 81860, 17289, 82470, 82494, 82495, 17521, 82473, 82497, 82498, 
17523, 17505, 82471, 82496, 17522
29515, 17281, 81852, 81860, 17289, 17282, 81853, 81861, 17290, 82473, 82497, 82498, 17523, 82476, 82500, 82501, 
17525, 17507, 82474, 82499, 17524
29516, 17282, 81853, 81861, 17290, 17283, 81854, 81862, 17291, 82476, 82500, 82501, 17525, 82479, 82503, 82504, 
17527, 17509, 82477, 82502, 17526
29517, 17283, 81854, 81862, 17291, 17284, 81855, 81863, 17292, 82479, 82503, 82504, 17527, 82482, 82506, 82507, 
17529, 17511, 82480, 82505, 17528
29518, 17284, 81855, 81863, 17292, 17285, 81856, 81864, 17293, 82482, 82506, 82507, 17529, 82485, 82509, 82510, 
17531, 17513, 82483, 82508, 17530
29519, 17285, 81856, 81864, 17293, 2442, 18082, 18083, 2443, 82485, 82509, 82510, 17531, 18154, 18155, 18156, 
2465, 17515, 82486, 82511, 17532
29520, 2393, 17860, 17861, 2394, 17286, 81857, 81865, 17294, 17932, 17935, 17934, 2416, 82489, 82513, 82514, 
17534, 17516, 82487, 82512, 17533
29521, 17286, 81857, 81865, 17294, 17287, 81858, 81866, 17295, 82489, 82513, 82514, 17534, 82492, 82516, 82517, 
17536, 17518, 82490, 82515, 17535
29522, 17287, 81858, 81866, 17295, 17288, 81859, 81867, 17296, 82492, 82516, 82517, 17536, 82495, 82519, 82520, 
17538, 17520, 82493, 82518, 17537
29523, 17288, 81859, 81867, 17296, 17289, 81860, 81868, 17297, 82495, 82519, 82520, 17538, 82498, 82522, 82523, 
17540, 17522, 82496, 82521, 17539
29524, 17289, 81860, 81868, 17297, 17290, 81861, 81869, 17298, 82498, 82522, 82523, 17540, 82501, 82525, 82526, 
17542, 17524, 82499, 82524, 17541
29525, 17290, 81861, 81869, 17298, 17291, 81862, 81870, 17299, 82501, 82525, 82526, 17542, 82504, 82528, 82529, 
17544, 17526, 82502, 82527, 17543
29526, 17291, 81862, 81870, 17299, 17292, 81863, 81871, 17300, 82504, 82528, 82529, 17544, 82507, 82531, 82532, 
17546, 17528, 82505, 82530, 17545
29527, 17292, 81863, 81871, 17300, 17293, 81864, 81872, 17301, 82507, 82531, 82532, 17546, 82510, 82534, 82535, 
17548, 17530, 82508, 82533, 17547
29528, 17293, 81864, 81872, 17301, 2443, 18083, 18084, 2444, 82510, 82534, 82535, 17548, 18156, 18157, 18158, 
2466, 17532, 82511, 82536, 17549
29529, 2394, 17861, 17862, 2395, 17294, 81865, 81873, 17302, 17934, 17937, 17936, 2417, 82514, 82538, 82539, 
17551, 17533, 82512, 82537, 17550
29530, 17294, 81865, 81873, 17302, 17295, 81866, 81874, 17303, 82514, 82538, 82539, 17551, 82517, 82541, 82542, 
17553, 17535, 82515, 82540, 17552
29531, 17295, 81866, 81874, 17303, 17296, 81867, 81875, 17304, 82517, 82541, 82542, 17553, 82520, 82544, 82545, 
17555, 17537, 82518, 82543, 17554
29532, 17296, 81867, 81875, 17304, 17297, 81868, 81876, 17305, 82520, 82544, 82545, 17555, 82523, 82547, 82548, 
17557, 17539, 82521, 82546, 17556
29533, 17297, 81868, 81876, 17305, 17298, 81869, 81877, 17306, 82523, 82547, 82548, 17557, 82526, 82550, 82551, 
17559, 17541, 82524, 82549, 17558
29534, 17298, 81869, 81877, 17306, 17299, 81870, 81878, 17307, 82526, 82550, 82551, 17559, 82529, 82553, 82554, 
17561, 17543, 82527, 82552, 17560
29535, 17299, 81870, 81878, 17307, 17300, 81871, 81879, 17308, 82529, 82553, 82554, 17561, 82532, 82556, 82557, 
17563, 17545, 82530, 82555, 17562
29536, 17300, 81871, 81879, 17308, 17301, 81872, 81880, 17309, 82532, 82556, 82557, 17563, 82535, 82559, 82560, 
17565, 17547, 82533, 82558, 17564
29537, 17301, 81872, 81880, 17309, 2444, 18084, 18085, 2445, 82535, 82559, 82560, 17565, 18158, 18159, 18160, 
2467, 17549, 82536, 82561, 17566
29538, 2395, 17862, 17863, 2396, 17302, 81873, 81881, 17310, 17936, 17939, 17938, 2418, 82539, 82563, 82564, 
17568, 17550, 82537, 82562, 17567
29539, 17302, 81873, 81881, 17310, 17303, 81874, 81882, 17311, 82539, 82563, 82564, 17568, 82542, 82566, 82567, 
17570, 17552, 82540, 82565, 17569
29540, 17303, 81874, 81882, 17311, 17304, 81875, 81883, 17312, 82542, 82566, 82567, 17570, 82545, 82569, 82570, 
17572, 17554, 82543, 82568, 17571
29541, 17304, 81875, 81883, 17312, 17305, 81876, 81884, 17313, 82545, 82569, 82570, 17572, 82548, 82572, 82573, 
17574, 17556, 82546, 82571, 17573
29542, 17305, 81876, 81884, 17313, 17306, 81877, 81885, 17314, 82548, 82572, 82573, 17574, 82551, 82575, 82576, 
17576, 17558, 82549, 82574, 17575
29543, 17306, 81877, 81885, 17314, 17307, 81878, 81886, 17315, 82551, 82575, 82576, 17576, 82554, 82578, 82579, 
17578, 17560, 82552, 82577, 17577
29544, 17307, 81878, 81886, 17315, 17308, 81879, 81887, 17316, 82554, 82578, 82579, 17578, 82557, 82581, 82582, 
17580, 17562, 82555, 82580, 17579
29545, 17308, 81879, 81887, 17316, 17309, 81880, 81888, 17317, 82557, 82581, 82582, 17580, 82560, 82584, 82585, 
17582, 17564, 82558, 82583, 17581
29546, 17309, 81880, 81888, 17317, 2445, 18085, 18086, 2446, 82560, 82584, 82585, 17582, 18160, 18161, 18162, 
2468, 17566, 82561, 82586, 17583
29547, 2396, 17863, 17864, 2397, 17310, 81881, 81889, 17318, 17938, 17941, 17940, 2419, 82564, 82588, 82589, 
17585, 17567, 82562, 82587, 17584
29548, 17310, 81881, 81889, 17318, 17311, 81882, 81890, 17319, 82564, 82588, 82589, 17585, 82567, 82591, 82592, 
17587, 17569, 82565, 82590, 17586
29549, 17311, 81882, 81890, 17319, 17312, 81883, 81891, 17320, 82567, 82591, 82592, 17587, 82570, 82594, 82595, 
17589, 17571, 82568, 82593, 17588
29550, 17312, 81883, 81891, 17320, 17313, 81884, 81892, 17321, 82570, 82594, 82595, 17589, 82573, 82597, 82598, 
17591, 17573, 82571, 82596, 17590
29551, 17313, 81884, 81892, 17321, 17314, 81885, 81893, 17322, 82573, 82597, 82598, 17591, 82576, 82600, 82601, 
17593, 17575, 82574, 82599, 17592
29552, 17314, 81885, 81893, 17322, 17315, 81886, 81894, 17323, 82576, 82600, 82601, 17593, 82579, 82603, 82604, 
17595, 17577, 82577, 82602, 17594
29553, 17315, 81886, 81894, 17323, 17316, 81887, 81895, 17324, 82579, 82603, 82604, 17595, 82582, 82606, 82607, 
17597, 17579, 82580, 82605, 17596
29554, 17316, 81887, 81895, 17324, 17317, 81888, 81896, 17325, 82582, 82606, 82607, 17597, 82585, 82609, 82610, 
17599, 17581, 82583, 82608, 17598
29555, 17317, 81888, 81896, 17325, 2446, 18086, 18087, 2447, 82585, 82609, 82610, 17599, 18162, 18163, 18164, 
2469, 17583, 82586, 82611, 17600
29556, 2397, 17864, 17865, 2398, 17318, 81889, 81897, 17326, 17940, 17943, 17942, 2420, 82589, 82613, 82614, 
17602, 17584, 82587, 82612, 17601
29557, 17318, 81889, 81897, 17326, 17319, 81890, 81898, 17327, 82589, 82613, 82614, 17602, 82592, 82616, 82617, 
17604, 17586, 82590, 82615, 17603
29558, 17319, 81890, 81898, 17327, 17320, 81891, 81899, 17328, 82592, 82616, 82617, 17604, 82595, 82619, 82620, 
17606, 17588, 82593, 82618, 17605
29559, 17320, 81891, 81899, 17328, 17321, 81892, 81900, 17329, 82595, 82619, 82620, 17606, 82598, 82622, 82623, 
17608, 17590, 82596, 82621, 17607
29560, 17321, 81892, 81900, 17329, 17322, 81893, 81901, 17330, 82598, 82622, 82623, 17608, 82601, 82625, 82626, 
17610, 17592, 82599, 82624, 17609
29561, 17322, 81893, 81901, 17330, 17323, 81894, 81902, 17331, 82601, 82625, 82626, 17610, 82604, 82628, 82629, 
17612, 17594, 82602, 82627, 17611
29562, 17323, 81894, 81902, 17331, 17324, 81895, 81903, 17332, 82604, 82628, 82629, 17612, 82607, 82631, 82632, 
17614, 17596, 82605, 82630, 17613
29563, 17324, 81895, 81903, 17332, 17325, 81896, 81904, 17333, 82607, 82631, 82632, 17614, 82610, 82634, 82635, 
17616, 17598, 82608, 82633, 17615
29564, 17325, 81896, 81904, 17333, 2447, 18087, 18088, 2448, 82610, 82634, 82635, 17616, 18164, 18165, 18166, 
2470, 17600, 82611, 82636, 17617
29565, 2398, 17865, 17866, 2399, 17326, 81897, 81905, 17334, 17942, 17945, 17944, 2421, 82614, 82638, 82639, 
17619, 17601, 82612, 82637, 17618
29566, 17326, 81897, 81905, 17334, 17327, 81898, 81906, 17335, 82614, 82638, 82639, 17619, 82617, 82641, 82642, 
17621, 17603, 82615, 82640, 17620
29567, 17327, 81898, 81906, 17335, 17328, 81899, 81907, 17336, 82617, 82641, 82642, 17621, 82620, 82644, 82645, 
17623, 17605, 82618, 82643, 17622
29568, 17328, 81899, 81907, 17336, 17329, 81900, 81908, 17337, 82620, 82644, 82645, 17623, 82623, 82647, 82648, 
17625, 17607, 82621, 82646, 17624
29569, 17329, 81900, 81908, 17337, 17330, 81901, 81909, 17338, 82623, 82647, 82648, 17625, 82626, 82650, 82651, 
17627, 17609, 82624, 82649, 17626
29570, 17330, 81901, 81909, 17338, 17331, 81902, 81910, 17339, 82626, 82650, 82651, 17627, 82629, 82653, 82654, 
17629, 17611, 82627, 82652, 17628
29571, 17331, 81902, 81910, 17339, 17332, 81903, 81911, 17340, 82629, 82653, 82654, 17629, 82632, 82656, 82657, 
17631, 17613, 82630, 82655, 17630
29572, 17332, 81903, 81911, 17340, 17333, 81904, 81912, 17341, 82632, 82656, 82657, 17631, 82635, 82659, 82660, 
17633, 17615, 82633, 82658, 17632
29573, 17333, 81904, 81912, 17341, 2448, 18088, 18089, 2449, 82635, 82659, 82660, 17633, 18166, 18167, 18168, 
2471, 17617, 82636, 82661, 17634
29574, 2399, 17866, 17867, 2400, 17334, 81905, 81913, 17342, 17944, 17947, 17946, 2422, 82639, 82663, 82664, 
17636, 17618, 82637, 82662, 17635
29575, 17334, 81905, 81913, 17342, 17335, 81906, 81914, 17343, 82639, 82663, 82664, 17636, 82642, 82666, 82667, 
17638, 17620, 82640, 82665, 17637
29576, 17335, 81906, 81914, 17343, 17336, 81907, 81915, 17344, 82642, 82666, 82667, 17638, 82645, 82669, 82670, 
17640, 17622, 82643, 82668, 17639
29577, 17336, 81907, 81915, 17344, 17337, 81908, 81916, 17345, 82645, 82669, 82670, 17640, 82648, 82672, 82673, 
17642, 17624, 82646, 82671, 17641
29578, 17337, 81908, 81916, 17345, 17338, 81909, 81917, 17346, 82648, 82672, 82673, 17642, 82651, 82675, 82676, 
17644, 17626, 82649, 82674, 17643
29579, 17338, 81909, 81917, 17346, 17339, 81910, 81918, 17347, 82651, 82675, 82676, 17644, 82654, 82678, 82679, 
17646, 17628, 82652, 82677, 17645
29580, 17339, 81910, 81918, 17347, 17340, 81911, 81919, 17348, 82654, 82678, 82679, 17646, 82657, 82681, 82682, 
17648, 17630, 82655, 82680, 17647
29581, 17340, 81911, 81919, 17348, 17341, 81912, 81920, 17349, 82657, 82681, 82682, 17648, 82660, 82684, 82685, 
17650, 17632, 82658, 82683, 17649
29582, 17341, 81912, 81920, 17349, 2449, 18089, 18090, 2450, 82660, 82684, 82685, 17650, 18168, 18169, 18170, 
2472, 17634, 82661, 82686, 17651
29583, 2400, 17867, 17868, 2401, 17342, 81913, 81921, 17350, 17946, 17949, 17948, 2423, 82664, 82688, 82689, 
17653, 17635, 82662, 82687, 17652
29584, 17342, 81913, 81921, 17350, 17343, 81914, 81922, 17351, 82664, 82688, 82689, 17653, 82667, 82691, 82692, 
17655, 17637, 82665, 82690, 17654
29585, 17343, 81914, 81922, 17351, 17344, 81915, 81923, 17352, 82667, 82691, 82692, 17655, 82670, 82694, 82695, 
17657, 17639, 82668, 82693, 17656
29586, 17344, 81915, 81923, 17352, 17345, 81916, 81924, 17353, 82670, 82694, 82695, 17657, 82673, 82697, 82698, 
17659, 17641, 82671, 82696, 17658
29587, 17345, 81916, 81924, 17353, 17346, 81917, 81925, 17354, 82673, 82697, 82698, 17659, 82676, 82700, 82701, 
17661, 17643, 82674, 82699, 17660
29588, 17346, 81917, 81925, 17354, 17347, 81918, 81926, 17355, 82676, 82700, 82701, 17661, 82679, 82703, 82704, 
17663, 17645, 82677, 82702, 17662
29589, 17347, 81918, 81926, 17355, 17348, 81919, 81927, 17356, 82679, 82703, 82704, 17663, 82682, 82706, 82707, 
17665, 17647, 82680, 82705, 17664
29590, 17348, 81919, 81927, 17356, 17349, 81920, 81928, 17357, 82682, 82706, 82707, 17665, 82685, 82709, 82710, 
17667, 17649, 82683, 82708, 17666
29591, 17349, 81920, 81928, 17357, 2450, 18090, 18091, 2451, 82685, 82709, 82710, 17667, 18170, 18171, 18172, 
2473, 17651, 82686, 82711, 17668
29592, 2401, 17868, 17869, 2402, 17350, 81921, 81929, 17358, 17948, 17951, 17950, 2424, 82689, 82713, 82714, 
17670, 17652, 82687, 82712, 17669
29593, 17350, 81921, 81929, 17358, 17351, 81922, 81930, 17359, 82689, 82713, 82714, 17670, 82692, 82716, 82717, 
17672, 17654, 82690, 82715, 17671
29594, 17351, 81922, 81930, 17359, 17352, 81923, 81931, 17360, 82692, 82716, 82717, 17672, 82695, 82719, 82720, 
17674, 17656, 82693, 82718, 17673
29595, 17352, 81923, 81931, 17360, 17353, 81924, 81932, 17361, 82695, 82719, 82720, 17674, 82698, 82722, 82723, 
17676, 17658, 82696, 82721, 17675
29596, 17353, 81924, 81932, 17361, 17354, 81925, 81933, 17362, 82698, 82722, 82723, 17676, 82701, 82725, 82726, 
17678, 17660, 82699, 82724, 17677
29597, 17354, 81925, 81933, 17362, 17355, 81926, 81934, 17363, 82701, 82725, 82726, 17678, 82704, 82728, 82729, 
17680, 17662, 82702, 82727, 17679
29598, 17355, 81926, 81934, 17363, 17356, 81927, 81935, 17364, 82704, 82728, 82729, 17680, 82707, 82731, 82732, 
17682, 17664, 82705, 82730, 17681
29599, 17356, 81927, 81935, 17364, 17357, 81928, 81936, 17365, 82707, 82731, 82732, 17682, 82710, 82734, 82735, 
17684, 17666, 82708, 82733, 17683
29600, 17357, 81928, 81936, 17365, 2451, 18091, 18092, 2452, 82710, 82734, 82735, 17684, 18172, 18173, 18174, 
2474, 17668, 82711, 82736, 17685
29601, 2402, 17869, 17870, 2403, 17358, 81929, 81937, 17366, 17950, 17953, 17952, 2425, 82714, 82738, 82739, 
17687, 17669, 82712, 82737, 17686
29602, 17358, 81929, 81937, 17366, 17359, 81930, 81938, 17367, 82714, 82738, 82739, 17687, 82717, 82741, 82742, 
17689, 17671, 82715, 82740, 17688
29603, 17359, 81930, 81938, 17367, 17360, 81931, 81939, 17368, 82717, 82741, 82742, 17689, 82720, 82744, 82745, 
17691, 17673, 82718, 82743, 17690
29604, 17360, 81931, 81939, 17368, 17361, 81932, 81940, 17369, 82720, 82744, 82745, 17691, 82723, 82747, 82748, 
17693, 17675, 82721, 82746, 17692
29605, 17361, 81932, 81940, 17369, 17362, 81933, 81941, 17370, 82723, 82747, 82748, 17693, 82726, 82750, 82751, 
17695, 17677, 82724, 82749, 17694
29606, 17362, 81933, 81941, 17370, 17363, 81934, 81942, 17371, 82726, 82750, 82751, 17695, 82729, 82753, 82754, 
17697, 17679, 82727, 82752, 17696
29607, 17363, 81934, 81942, 17371, 17364, 81935, 81943, 17372, 82729, 82753, 82754, 17697, 82732, 82756, 82757, 
17699, 17681, 82730, 82755, 17698
29608, 17364, 81935, 81943, 17372, 17365, 81936, 81944, 17373, 82732, 82756, 82757, 17699, 82735, 82759, 82760, 
17701, 17683, 82733, 82758, 17700
29609, 17365, 81936, 81944, 17373, 2452, 18092, 18093, 2453, 82735, 82759, 82760, 17701, 18174, 18175, 18176, 
2475, 17685, 82736, 82761, 17702
29610, 2403, 17870, 17871, 2404, 17366, 81937, 81945, 17374, 17952, 17955, 17954, 2426, 82739, 82763, 82764, 
17704, 17686, 82737, 82762, 17703
29611, 17366, 81937, 81945, 17374, 17367, 81938, 81946, 17375, 82739, 82763, 82764, 17704, 82742, 82766, 82767, 
17706, 17688, 82740, 82765, 17705
29612, 17367, 81938, 81946, 17375, 17368, 81939, 81947, 17376, 82742, 82766, 82767, 17706, 82745, 82769, 82770, 
17708, 17690, 82743, 82768, 17707
29613, 17368, 81939, 81947, 17376, 17369, 81940, 81948, 17377, 82745, 82769, 82770, 17708, 82748, 82772, 82773, 
17710, 17692, 82746, 82771, 17709
29614, 17369, 81940, 81948, 17377, 17370, 81941, 81949, 17378, 82748, 82772, 82773, 17710, 82751, 82775, 82776, 
17712, 17694, 82749, 82774, 17711
29615, 17370, 81941, 81949, 17378, 17371, 81942, 81950, 17379, 82751, 82775, 82776, 17712, 82754, 82778, 82779, 
17714, 17696, 82752, 82777, 17713
29616, 17371, 81942, 81950, 17379, 17372, 81943, 81951, 17380, 82754, 82778, 82779, 17714, 82757, 82781, 82782, 
17716, 17698, 82755, 82780, 17715
29617, 17372, 81943, 81951, 17380, 17373, 81944, 81952, 17381, 82757, 82781, 82782, 17716, 82760, 82784, 82785, 
17718, 17700, 82758, 82783, 17717
29618, 17373, 81944, 81952, 17381, 2453, 18093, 18094, 2454, 82760, 82784, 82785, 17718, 18176, 18177, 18178, 
2476, 17702, 82761, 82786, 17719
29619, 2404, 17871, 17872, 2405, 17374, 81945, 81953, 17382, 17954, 17957, 17956, 2427, 82764, 82788, 82789, 
17721, 17703, 82762, 82787, 17720
29620, 17374, 81945, 81953, 17382, 17375, 81946, 81954, 17383, 82764, 82788, 82789, 17721, 82767, 82791, 82792, 
17723, 17705, 82765, 82790, 17722
29621, 17375, 81946, 81954, 17383, 17376, 81947, 81955, 17384, 82767, 82791, 82792, 17723, 82770, 82794, 82795, 
17725, 17707, 82768, 82793, 17724
29622, 17376, 81947, 81955, 17384, 17377, 81948, 81956, 17385, 82770, 82794, 82795, 17725, 82773, 82797, 82798, 
17727, 17709, 82771, 82796, 17726
29623, 17377, 81948, 81956, 17385, 17378, 81949, 81957, 17386, 82773, 82797, 82798, 17727, 82776, 82800, 82801, 
17729, 17711, 82774, 82799, 17728
29624, 17378, 81949, 81957, 17386, 17379, 81950, 81958, 17387, 82776, 82800, 82801, 17729, 82779, 82803, 82804, 
17731, 17713, 82777, 82802, 17730
29625, 17379, 81950, 81958, 17387, 17380, 81951, 81959, 17388, 82779, 82803, 82804, 17731, 82782, 82806, 82807, 
17733, 17715, 82780, 82805, 17732
29626, 17380, 81951, 81959, 17388, 17381, 81952, 81960, 17389, 82782, 82806, 82807, 17733, 82785, 82809, 82810, 
17735, 17717, 82783, 82808, 17734
29627, 17381, 81952, 81960, 17389, 2454, 18094, 18095, 2455, 82785, 82809, 82810, 17735, 18178, 18179, 18180, 
2477, 17719, 82786, 82811, 17736
29628, 2405, 17872, 17873, 2406, 17382, 81953, 81961, 17390, 17956, 17959, 17958, 2428, 82789, 82813, 82814, 
17738, 17720, 82787, 82812, 17737
29629, 17382, 81953, 81961, 17390, 17383, 81954, 81962, 17391, 82789, 82813, 82814, 17738, 82792, 82816, 82817, 
17740, 17722, 82790, 82815, 17739
29630, 17383, 81954, 81962, 17391, 17384, 81955, 81963, 17392, 82792, 82816, 82817, 17740, 82795, 82819, 82820, 
17742, 17724, 82793, 82818, 17741
29631, 17384, 81955, 81963, 17392, 17385, 81956, 81964, 17393, 82795, 82819, 82820, 17742, 82798, 82822, 82823, 
17744, 17726, 82796, 82821, 17743
29632, 17385, 81956, 81964, 17393, 17386, 81957, 81965, 17394, 82798, 82822, 82823, 17744, 82801, 82825, 82826, 
17746, 17728, 82799, 82824, 17745
29633, 17386, 81957, 81965, 17394, 17387, 81958, 81966, 17395, 82801, 82825, 82826, 17746, 82804, 82828, 82829, 
17748, 17730, 82802, 82827, 17747
29634, 17387, 81958, 81966, 17395, 17388, 81959, 81967, 17396, 82804, 82828, 82829, 17748, 82807, 82831, 82832, 
17750, 17732, 82805, 82830, 17749
29635, 17388, 81959, 81967, 17396, 17389, 81960, 81968, 17397, 82807, 82831, 82832, 17750, 82810, 82834, 82835, 
17752, 17734, 82808, 82833, 17751
29636, 17389, 81960, 81968, 17397, 2455, 18095, 18096, 2456, 82810, 82834, 82835, 17752, 18180, 18181, 18182, 
2478, 17736, 82811, 82836, 17753
29637, 2406, 17873, 17874, 2407, 17390, 81961, 81969, 17398, 17958, 17961, 17960, 2429, 82814, 82838, 82839, 
17755, 17737, 82812, 82837, 17754
29638, 17390, 81961, 81969, 17398, 17391, 81962, 81970, 17399, 82814, 82838, 82839, 17755, 82817, 82841, 82842, 
17757, 17739, 82815, 82840, 17756
29639, 17391, 81962, 81970, 17399, 17392, 81963, 81971, 17400, 82817, 82841, 82842, 17757, 82820, 82844, 82845, 
17759, 17741, 82818, 82843, 17758
29640, 17392, 81963, 81971, 17400, 17393, 81964, 81972, 17401, 82820, 82844, 82845, 17759, 82823, 82847, 82848, 
17761, 17743, 82821, 82846, 17760
29641, 17393, 81964, 81972, 17401, 17394, 81965, 81973, 17402, 82823, 82847, 82848, 17761, 82826, 82850, 82851, 
17763, 17745, 82824, 82849, 17762
29642, 17394, 81965, 81973, 17402, 17395, 81966, 81974, 17403, 82826, 82850, 82851, 17763, 82829, 82853, 82854, 
17765, 17747, 82827, 82852, 17764
29643, 17395, 81966, 81974, 17403, 17396, 81967, 81975, 17404, 82829, 82853, 82854, 17765, 82832, 82856, 82857, 
17767, 17749, 82830, 82855, 17766
29644, 17396, 81967, 81975, 17404, 17397, 81968, 81976, 17405, 82832, 82856, 82857, 17767, 82835, 82859, 82860, 
17769, 17751, 82833, 82858, 17768
29645, 17397, 81968, 81976, 17405, 2456, 18096, 18097, 2457, 82835, 82859, 82860, 17769, 18182, 18183, 18184, 
2479, 17753, 82836, 82861, 17770
29646, 2407, 17874, 17875, 2408, 17398, 81969, 81977, 17406, 17960, 17963, 17962, 2430, 82839, 82863, 82864, 
17772, 17754, 82837, 82862, 17771
29647, 17398, 81969, 81977, 17406, 17399, 81970, 81978, 17407, 82839, 82863, 82864, 17772, 82842, 82866, 82867, 
17774, 17756, 82840, 82865, 17773
29648, 17399, 81970, 81978, 17407, 17400, 81971, 81979, 17408, 82842, 82866, 82867, 17774, 82845, 82869, 82870, 
17776, 17758, 82843, 82868, 17775
29649, 17400, 81971, 81979, 17408, 17401, 81972, 81980, 17409, 82845, 82869, 82870, 17776, 82848, 82872, 82873, 
17778, 17760, 82846, 82871, 17777
29650, 17401, 81972, 81980, 17409, 17402, 81973, 81981, 17410, 82848, 82872, 82873, 17778, 82851, 82875, 82876, 
17780, 17762, 82849, 82874, 17779
29651, 17402, 81973, 81981, 17410, 17403, 81974, 81982, 17411, 82851, 82875, 82876, 17780, 82854, 82878, 82879, 
17782, 17764, 82852, 82877, 17781
29652, 17403, 81974, 81982, 17411, 17404, 81975, 81983, 17412, 82854, 82878, 82879, 17782, 82857, 82881, 82882, 
17784, 17766, 82855, 82880, 17783
29653, 17404, 81975, 81983, 17412, 17405, 81976, 81984, 17413, 82857, 82881, 82882, 17784, 82860, 82884, 82885, 
17786, 17768, 82858, 82883, 17785
29654, 17405, 81976, 81984, 17413, 2457, 18097, 18098, 2458, 82860, 82884, 82885, 17786, 18184, 18185, 18186, 
2480, 17770, 82861, 82886, 17787
29655, 2408, 17875, 2504, 77, 17406, 81977, 18300, 2494, 17962, 17964, 2507, 2431, 82864, 82887, 18324, 
17788, 17771, 82862, 18325, 2503
29656, 17406, 81977, 18300, 2494, 17407, 81978, 18301, 2493, 82864, 82887, 18324, 17788, 82867, 82888, 18326, 
17789, 17773, 82865, 18327, 2502
29657, 17407, 81978, 18301, 2493, 17408, 81979, 18302, 2492, 82867, 82888, 18326, 17789, 82870, 82889, 18328, 
17790, 17775, 82868, 18329, 2501
29658, 17408, 81979, 18302, 2492, 17409, 81980, 18303, 2491, 82870, 82889, 18328, 17790, 82873, 82890, 18330, 
17791, 17777, 82871, 18331, 2500
29659, 17409, 81980, 18303, 2491, 17410, 81981, 18304, 2490, 82873, 82890, 18330, 17791, 82876, 82891, 18332, 
17792, 17779, 82874, 18333, 2499
29660, 17410, 81981, 18304, 2490, 17411, 81982, 18305, 2489, 82876, 82891, 18332, 17792, 82879, 82892, 18334, 
17793, 17781, 82877, 18335, 2498
29661, 17411, 81982, 18305, 2489, 17412, 81983, 18306, 2488, 82879, 82892, 18334, 17793, 82882, 82893, 18336, 
17794, 17783, 82880, 18337, 2497
29662, 17412, 81983, 18306, 2488, 17413, 81984, 18307, 2487, 82882, 82893, 18336, 17794, 82885, 82894, 18338, 
17795, 17785, 82883, 18339, 2496
29663, 17413, 81984, 18307, 2487, 2458, 18098, 2556, 78, 82885, 82894, 18338, 17795, 18186, 18187, 2559, 
2481, 17787, 82886, 18340, 2495
29664, 1758, 1759, 17876, 17854, 13336, 13344, 81985, 81809, 1762, 17966, 17965, 17921, 13377, 82896, 82897, 
82338, 13361, 13378, 82895, 82337
29665, 13336, 13344, 81985, 81809, 13337, 13345, 81986, 81810, 13377, 82896, 82897, 82338, 13379, 82899, 82900, 
82341, 13363, 13380, 82898, 82340
29666, 13337, 13345, 81986, 81810, 13338, 13346, 81987, 81811, 13379, 82899, 82900, 82341, 13381, 82902, 82903, 
82344, 13365, 13382, 82901, 82343
29667, 13338, 13346, 81987, 81811, 13339, 13347, 81988, 81812, 13381, 82902, 82903, 82344, 13383, 82905, 82906, 
82347, 13367, 13384, 82904, 82346
29668, 13339, 13347, 81988, 81812, 13340, 13348, 81989, 81813, 13383, 82905, 82906, 82347, 13385, 82908, 82909, 
82350, 13369, 13386, 82907, 82349
29669, 13340, 13348, 81989, 81813, 13341, 13349, 81990, 81814, 13385, 82908, 82909, 82350, 13387, 82911, 82912, 
82353, 13371, 13388, 82910, 82352
29670, 13341, 13349, 81990, 81814, 13342, 13350, 81991, 81815, 13387, 82911, 82912, 82353, 13389, 82914, 82915, 
82356, 13373, 13390, 82913, 82355
29671, 13342, 13350, 81991, 81815, 13343, 13351, 81992, 81816, 13389, 82914, 82915, 82356, 13391, 82917, 82918, 
82359, 13375, 13392, 82916, 82358
29672, 13343, 13351, 81992, 81816, 1779, 1780, 18099, 18077, 13391, 82917, 82918, 82359, 1783, 18188, 18189, 
18143, 13376, 13393, 82919, 82361
29673, 17854, 17876, 17877, 17855, 81809, 81985, 81993, 81817, 17965, 17968, 17967, 17923, 82897, 82921, 82922, 
82363, 82337, 82895, 82920, 82362
29674, 81809, 81985, 81993, 81817, 81810, 81986, 81994, 81818, 82897, 82921, 82922, 82363, 82900, 82924, 82925, 
82366, 82340, 82898, 82923, 82365
29675, 81810, 81986, 81994, 81818, 81811, 81987, 81995, 81819, 82900, 82924, 82925, 82366, 82903, 82927, 82928, 
82369, 82343, 82901, 82926, 82368
29676, 81811, 81987, 81995, 81819, 81812, 81988, 81996, 81820, 82903, 82927, 82928, 82369, 82906, 82930, 82931, 
82372, 82346, 82904, 82929, 82371
29677, 81812, 81988, 81996, 81820, 81813, 81989, 81997, 81821, 82906, 82930, 82931, 82372, 82909, 82933, 82934, 
82375, 82349, 82907, 82932, 82374
29678, 81813, 81989, 81997, 81821, 81814, 81990, 81998, 81822, 82909, 82933, 82934, 82375, 82912, 82936, 82937, 
82378, 82352, 82910, 82935, 82377
29679, 81814, 81990, 81998, 81822, 81815, 81991, 81999, 81823, 82912, 82936, 82937, 82378, 82915, 82939, 82940, 
82381, 82355, 82913, 82938, 82380
29680, 81815, 81991, 81999, 81823, 81816, 81992, 82000, 81824, 82915, 82939, 82940, 82381, 82918, 82942, 82943, 
82384, 82358, 82916, 82941, 82383
29681, 81816, 81992, 82000, 81824, 18077, 18099, 18100, 18078, 82918, 82942, 82943, 82384, 18189, 18190, 18191, 
18145, 82361, 82919, 82944, 82386
29682, 17855, 17877, 17878, 17856, 81817, 81993, 82001, 81825, 17967, 17970, 17969, 17925, 82922, 82946, 82947, 
82388, 82362, 82920, 82945, 82387
29683, 81817, 81993, 82001, 81825, 81818, 81994, 82002, 81826, 82922, 82946, 82947, 82388, 82925, 82949, 82950, 
82391, 82365, 82923, 82948, 82390
29684, 81818, 81994, 82002, 81826, 81819, 81995, 82003, 81827, 82925, 82949, 82950, 82391, 82928, 82952, 82953, 
82394, 82368, 82926, 82951, 82393
29685, 81819, 81995, 82003, 81827, 81820, 81996, 82004, 81828, 82928, 82952, 82953, 82394, 82931, 82955, 82956, 
82397, 82371, 82929, 82954, 82396
29686, 81820, 81996, 82004, 81828, 81821, 81997, 82005, 81829, 82931, 82955, 82956, 82397, 82934, 82958, 82959, 
82400, 82374, 82932, 82957, 82399
29687, 81821, 81997, 82005, 81829, 81822, 81998, 82006, 81830, 82934, 82958, 82959, 82400, 82937, 82961, 82962, 
82403, 82377, 82935, 82960, 82402
29688, 81822, 81998, 82006, 81830, 81823, 81999, 82007, 81831, 82937, 82961, 82962, 82403, 82940, 82964, 82965, 
82406, 82380, 82938, 82963, 82405
29689, 81823, 81999, 82007, 81831, 81824, 82000, 82008, 81832, 82940, 82964, 82965, 82406, 82943, 82967, 82968, 
82409, 82383, 82941, 82966, 82408
29690, 81824, 82000, 82008, 81832, 18078, 18100, 18101, 18079, 82943, 82967, 82968, 82409, 18191, 18192, 18193, 
18147, 82386, 82944, 82969, 82411
29691, 17856, 17878, 17879, 17857, 81825, 82001, 82009, 81833, 17969, 17972, 17971, 17927, 82947, 82971, 82972, 
82413, 82387, 82945, 82970, 82412
29692, 81825, 82001, 82009, 81833, 81826, 82002, 82010, 81834, 82947, 82971, 82972, 82413, 82950, 82974, 82975, 
82416, 82390, 82948, 82973, 82415
29693, 81826, 82002, 82010, 81834, 81827, 82003, 82011, 81835, 82950, 82974, 82975, 82416, 82953, 82977, 82978, 
82419, 82393, 82951, 82976, 82418
29694, 81827, 82003, 82011, 81835, 81828, 82004, 82012, 81836, 82953, 82977, 82978, 82419, 82956, 82980, 82981, 
82422, 82396, 82954, 82979, 82421
29695, 81828, 82004, 82012, 81836, 81829, 82005, 82013, 81837, 82956, 82980, 82981, 82422, 82959, 82983, 82984, 
82425, 82399, 82957, 82982, 82424
29696, 81829, 82005, 82013, 81837, 81830, 82006, 82014, 81838, 82959, 82983, 82984, 82425, 82962, 82986, 82987, 
82428, 82402, 82960, 82985, 82427
29697, 81830, 82006, 82014, 81838, 81831, 82007, 82015, 81839, 82962, 82986, 82987, 82428, 82965, 82989, 82990, 
82431, 82405, 82963, 82988, 82430
29698, 81831, 82007, 82015, 81839, 81832, 82008, 82016, 81840, 82965, 82989, 82990, 82431, 82968, 82992, 82993, 
82434, 82408, 82966, 82991, 82433
29699, 81832, 82008, 82016, 81840, 18079, 18101, 18102, 18080, 82968, 82992, 82993, 82434, 18193, 18194, 18195, 
18149, 82411, 82969, 82994, 82436
29700, 17857, 17879, 17880, 17858, 81833, 82009, 82017, 81841, 17971, 17974, 17973, 17929, 82972, 82996, 82997, 
82438, 82412, 82970, 82995, 82437
29701, 81833, 82009, 82017, 81841, 81834, 82010, 82018, 81842, 82972, 82996, 82997, 82438, 82975, 82999, 83000, 
82441, 82415, 82973, 82998, 82440
29702, 81834, 82010, 82018, 81842, 81835, 82011, 82019, 81843, 82975, 82999, 83000, 82441, 82978, 83002, 83003, 
82444, 82418, 82976, 83001, 82443
29703, 81835, 82011, 82019, 81843, 81836, 82012, 82020, 81844, 82978, 83002, 83003, 82444, 82981, 83005, 83006, 
82447, 82421, 82979, 83004, 82446
29704, 81836, 82012, 82020, 81844, 81837, 82013, 82021, 81845, 82981, 83005, 83006, 82447, 82984, 83008, 83009, 
82450, 82424, 82982, 83007, 82449
29705, 81837, 82013, 82021, 81845, 81838, 82014, 82022, 81846, 82984, 83008, 83009, 82450, 82987, 83011, 83012, 
82453, 82427, 82985, 83010, 82452
29706, 81838, 82014, 82022, 81846, 81839, 82015, 82023, 81847, 82987, 83011, 83012, 82453, 82990, 83014, 83015, 
82456, 82430, 82988, 83013, 82455
29707, 81839, 82015, 82023, 81847, 81840, 82016, 82024, 81848, 82990, 83014, 83015, 82456, 82993, 83017, 83018, 
82459, 82433, 82991, 83016, 82458
29708, 81840, 82016, 82024, 81848, 18080, 18102, 18103, 18081, 82993, 83017, 83018, 82459, 18195, 18196, 18197, 
18151, 82436, 82994, 83019, 82461
29709, 17858, 17880, 17881, 17859, 81841, 82017, 82025, 81849, 17973, 17976, 17975, 17931, 82997, 83021, 83022, 
82463, 82437, 82995, 83020, 82462
29710, 81841, 82017, 82025, 81849, 81842, 82018, 82026, 81850, 82997, 83021, 83022, 82463, 83000, 83024, 83025, 
82466, 82440, 82998, 83023, 82465
29711, 81842, 82018, 82026, 81850, 81843, 82019, 82027, 81851, 83000, 83024, 83025, 82466, 83003, 83027, 83028, 
82469, 82443, 83001, 83026, 82468
29712, 81843, 82019, 82027, 81851, 81844, 82020, 82028, 81852, 83003, 83027, 83028, 82469, 83006, 83030, 83031, 
82472, 82446, 83004, 83029, 82471
29713, 81844, 82020, 82028, 81852, 81845, 82021, 82029, 81853, 83006, 83030, 83031, 82472, 83009, 83033, 83034, 
82475, 82449, 83007, 83032, 82474
29714, 81845, 82021, 82029, 81853, 81846, 82022, 82030, 81854, 83009, 83033, 83034, 82475, 83012, 83036, 83037, 
82478, 82452, 83010, 83035, 82477
29715, 81846, 82022, 82030, 81854, 81847, 82023, 82031, 81855, 83012, 83036, 83037, 82478, 83015, 83039, 83040, 
82481, 82455, 83013, 83038, 82480
29716, 81847, 82023, 82031, 81855, 81848, 82024, 82032, 81856, 83015, 83039, 83040, 82481, 83018, 83042, 83043, 
82484, 82458, 83016, 83041, 82483
29717, 81848, 82024, 82032, 81856, 18081, 18103, 18104, 18082, 83018, 83042, 83043, 82484, 18197, 18198, 18199, 
18153, 82461, 83019, 83044, 82486
29718, 17859, 17881, 17882, 17860, 81849, 82025, 82033, 81857, 17975, 17978, 17977, 17933, 83022, 83046, 83047, 
82488, 82462, 83020, 83045, 82487
29719, 81849, 82025, 82033, 81857, 81850, 82026, 82034, 81858, 83022, 83046, 83047, 82488, 83025, 83049, 83050, 
82491, 82465, 83023, 83048, 82490
29720, 81850, 82026, 82034, 81858, 81851, 82027, 82035, 81859, 83025, 83049, 83050, 82491, 83028, 83052, 83053, 
82494, 82468, 83026, 83051, 82493
29721, 81851, 82027, 82035, 81859, 81852, 82028, 82036, 81860, 83028, 83052, 83053, 82494, 83031, 83055, 83056, 
82497, 82471, 83029, 83054, 82496
29722, 81852, 82028, 82036, 81860, 81853, 82029, 82037, 81861, 83031, 83055, 83056, 82497, 83034, 83058, 83059, 
82500, 82474, 83032, 83057, 82499
29723, 81853, 82029, 82037, 81861, 81854, 82030, 82038, 81862, 83034, 83058, 83059, 82500, 83037, 83061, 83062, 
82503, 82477, 83035, 83060, 82502
29724, 81854, 82030, 82038, 81862, 81855, 82031, 82039, 81863, 83037, 83061, 83062, 82503, 83040, 83064, 83065, 
82506, 82480, 83038, 83063, 82505
29725, 81855, 82031, 82039, 81863, 81856, 82032, 82040, 81864, 83040, 83064, 83065, 82506, 83043, 83067, 83068, 
82509, 82483, 83041, 83066, 82508
29726, 81856, 82032, 82040, 81864, 18082, 18104, 18105, 18083, 83043, 83067, 83068, 82509, 18199, 18200, 18201, 
18155, 82486, 83044, 83069, 82511
29727, 17860, 17882, 17883, 17861, 81857, 82033, 82041, 81865, 17977, 17980, 17979, 17935, 83047, 83071, 83072, 
82513, 82487, 83045, 83070, 82512
29728, 81857, 82033, 82041, 81865, 81858, 82034, 82042, 81866, 83047, 83071, 83072, 82513, 83050, 83074, 83075, 
82516, 82490, 83048, 83073, 82515
29729, 81858, 82034, 82042, 81866, 81859, 82035, 82043, 81867, 83050, 83074, 83075, 82516, 83053, 83077, 83078, 
82519, 82493, 83051, 83076, 82518
29730, 81859, 82035, 82043, 81867, 81860, 82036, 82044, 81868, 83053, 83077, 83078, 82519, 83056, 83080, 83081, 
82522, 82496, 83054, 83079, 82521
29731, 81860, 82036, 82044, 81868, 81861, 82037, 82045, 81869, 83056, 83080, 83081, 82522, 83059, 83083, 83084, 
82525, 82499, 83057, 83082, 82524
29732, 81861, 82037, 82045, 81869, 81862, 82038, 82046, 81870, 83059, 83083, 83084, 82525, 83062, 83086, 83087, 
82528, 82502, 83060, 83085, 82527
29733, 81862, 82038, 82046, 81870, 81863, 82039, 82047, 81871, 83062, 83086, 83087, 82528, 83065, 83089, 83090, 
82531, 82505, 83063, 83088, 82530
29734, 81863, 82039, 82047, 81871, 81864, 82040, 82048, 81872, 83065, 83089, 83090, 82531, 83068, 83092, 83093, 
82534, 82508, 83066, 83091, 82533
29735, 81864, 82040, 82048, 81872, 18083, 18105, 18106, 18084, 83068, 83092, 83093, 82534, 18201, 18202, 18203, 
18157, 82511, 83069, 83094, 82536
29736, 17861, 17883, 17884, 17862, 81865, 82041, 82049, 81873, 17979, 17982, 17981, 17937, 83072, 83096, 83097, 
82538, 82512, 83070, 83095, 82537
29737, 81865, 82041, 82049, 81873, 81866, 82042, 82050, 81874, 83072, 83096, 83097, 82538, 83075, 83099, 83100, 
82541, 82515, 83073, 83098, 82540
29738, 81866, 82042, 82050, 81874, 81867, 82043, 82051, 81875, 83075, 83099, 83100, 82541, 83078, 83102, 83103, 
82544, 82518, 83076, 83101, 82543
29739, 81867, 82043, 82051, 81875, 81868, 82044, 82052, 81876, 83078, 83102, 83103, 82544, 83081, 83105, 83106, 
82547, 82521, 83079, 83104, 82546
29740, 81868, 82044, 82052, 81876, 81869, 82045, 82053, 81877, 83081, 83105, 83106, 82547, 83084, 83108, 83109, 
82550, 82524, 83082, 83107, 82549
29741, 81869, 82045, 82053, 81877, 81870, 82046, 82054, 81878, 83084, 83108, 83109, 82550, 83087, 83111, 83112, 
82553, 82527, 83085, 83110, 82552
29742, 81870, 82046, 82054, 81878, 81871, 82047, 82055, 81879, 83087, 83111, 83112, 82553, 83090, 83114, 83115, 
82556, 82530, 83088, 83113, 82555
29743, 81871, 82047, 82055, 81879, 81872, 82048, 82056, 81880, 83090, 83114, 83115, 82556, 83093, 83117, 83118, 
82559, 82533, 83091, 83116, 82558
29744, 81872, 82048, 82056, 81880, 18084, 18106, 18107, 18085, 83093, 83117, 83118, 82559, 18203, 18204, 18205, 
18159, 82536, 83094, 83119, 82561
29745, 17862, 17884, 17885, 17863, 81873, 82049, 82057, 81881, 17981, 17984, 17983, 17939, 83097, 83121, 83122, 
82563, 82537, 83095, 83120, 82562
29746, 81873, 82049, 82057, 81881, 81874, 82050, 82058, 81882, 83097, 83121, 83122, 82563, 83100, 83124, 83125, 
82566, 82540, 83098, 83123, 82565
29747, 81874, 82050, 82058, 81882, 81875, 82051, 82059, 81883, 83100, 83124, 83125, 82566, 83103, 83127, 83128, 
82569, 82543, 83101, 83126, 82568
29748, 81875, 82051, 82059, 81883, 81876, 82052, 82060, 81884, 83103, 83127, 83128, 82569, 83106, 83130, 83131, 
82572, 82546, 83104, 83129, 82571
29749, 81876, 82052, 82060, 81884, 81877, 82053, 82061, 81885, 83106, 83130, 83131, 82572, 83109, 83133, 83134, 
82575, 82549, 83107, 83132, 82574
29750, 81877, 82053, 82061, 81885, 81878, 82054, 82062, 81886, 83109, 83133, 83134, 82575, 83112, 83136, 83137, 
82578, 82552, 83110, 83135, 82577
29751, 81878, 82054, 82062, 81886, 81879, 82055, 82063, 81887, 83112, 83136, 83137, 82578, 83115, 83139, 83140, 
82581, 82555, 83113, 83138, 82580
29752, 81879, 82055, 82063, 81887, 81880, 82056, 82064, 81888, 83115, 83139, 83140, 82581, 83118, 83142, 83143, 
82584, 82558, 83116, 83141, 82583
29753, 81880, 82056, 82064, 81888, 18085, 18107, 18108, 18086, 83118, 83142, 83143, 82584, 18205, 18206, 18207, 
18161, 82561, 83119, 83144, 82586
29754, 17863, 17885, 17886, 17864, 81881, 82057, 82065, 81889, 17983, 17986, 17985, 17941, 83122, 83146, 83147, 
82588, 82562, 83120, 83145, 82587
29755, 81881, 82057, 82065, 81889, 81882, 82058, 82066, 81890, 83122, 83146, 83147, 82588, 83125, 83149, 83150, 
82591, 82565, 83123, 83148, 82590
29756, 81882, 82058, 82066, 81890, 81883, 82059, 82067, 81891, 83125, 83149, 83150, 82591, 83128, 83152, 83153, 
82594, 82568, 83126, 83151, 82593
29757, 81883, 82059, 82067, 81891, 81884, 82060, 82068, 81892, 83128, 83152, 83153, 82594, 83131, 83155, 83156, 
82597, 82571, 83129, 83154, 82596
29758, 81884, 82060, 82068, 81892, 81885, 82061, 82069, 81893, 83131, 83155, 83156, 82597, 83134, 83158, 83159, 
82600, 82574, 83132, 83157, 82599
29759, 81885, 82061, 82069, 81893, 81886, 82062, 82070, 81894, 83134, 83158, 83159, 82600, 83137, 83161, 83162, 
82603, 82577, 83135, 83160, 82602
29760, 81886, 82062, 82070, 81894, 81887, 82063, 82071, 81895, 83137, 83161, 83162, 82603, 83140, 83164, 83165, 
82606, 82580, 83138, 83163, 82605
29761, 81887, 82063, 82071, 81895, 81888, 82064, 82072, 81896, 83140, 83164, 83165, 82606, 83143, 83167, 83168, 
82609, 82583, 83141, 83166, 82608
29762, 81888, 82064, 82072, 81896, 18086, 18108, 18109, 18087, 83143, 83167, 83168, 82609, 18207, 18208, 18209, 
18163, 82586, 83144, 83169, 82611
29763, 17864, 17886, 17887, 17865, 81889, 82065, 82073, 81897, 17985, 17988, 17987, 17943, 83147, 83171, 83172, 
82613, 82587, 83145, 83170, 82612
29764, 81889, 82065, 82073, 81897, 81890, 82066, 82074, 81898, 83147, 83171, 83172, 82613, 83150, 83174, 83175, 
82616, 82590, 83148, 83173, 82615
29765, 81890, 82066, 82074, 81898, 81891, 82067, 82075, 81899, 83150, 83174, 83175, 82616, 83153, 83177, 83178, 
82619, 82593, 83151, 83176, 82618
29766, 81891, 82067, 82075, 81899, 81892, 82068, 82076, 81900, 83153, 83177, 83178, 82619, 83156, 83180, 83181, 
82622, 82596, 83154, 83179, 82621
29767, 81892, 82068, 82076, 81900, 81893, 82069, 82077, 81901, 83156, 83180, 83181, 82622, 83159, 83183, 83184, 
82625, 82599, 83157, 83182, 82624
29768, 81893, 82069, 82077, 81901, 81894, 82070, 82078, 81902, 83159, 83183, 83184, 82625, 83162, 83186, 83187, 
82628, 82602, 83160, 83185, 82627
29769, 81894, 82070, 82078, 81902, 81895, 82071, 82079, 81903, 83162, 83186, 83187, 82628, 83165, 83189, 83190, 
82631, 82605, 83163, 83188, 82630
29770, 81895, 82071, 82079, 81903, 81896, 82072, 82080, 81904, 83165, 83189, 83190, 82631, 83168, 83192, 83193, 
82634, 82608, 83166, 83191, 82633
29771, 81896, 82072, 82080, 81904, 18087, 18109, 18110, 18088, 83168, 83192, 83193, 82634, 18209, 18210, 18211, 
18165, 82611, 83169, 83194, 82636
29772, 17865, 17887, 17888, 17866, 81897, 82073, 82081, 81905, 17987, 17990, 17989, 17945, 83172, 83196, 83197, 
82638, 82612, 83170, 83195, 82637
29773, 81897, 82073, 82081, 81905, 81898, 82074, 82082, 81906, 83172, 83196, 83197, 82638, 83175, 83199, 83200, 
82641, 82615, 83173, 83198, 82640
29774, 81898, 82074, 82082, 81906, 81899, 82075, 82083, 81907, 83175, 83199, 83200, 82641, 83178, 83202, 83203, 
82644, 82618, 83176, 83201, 82643
29775, 81899, 82075, 82083, 81907, 81900, 82076, 82084, 81908, 83178, 83202, 83203, 82644, 83181, 83205, 83206, 
82647, 82621, 83179, 83204, 82646
29776, 81900, 82076, 82084, 81908, 81901, 82077, 82085, 81909, 83181, 83205, 83206, 82647, 83184, 83208, 83209, 
82650, 82624, 83182, 83207, 82649
29777, 81901, 82077, 82085, 81909, 81902, 82078, 82086, 81910, 83184, 83208, 83209, 82650, 83187, 83211, 83212, 
82653, 82627, 83185, 83210, 82652
29778, 81902, 82078, 82086, 81910, 81903, 82079, 82087, 81911, 83187, 83211, 83212, 82653, 83190, 83214, 83215, 
82656, 82630, 83188, 83213, 82655
29779, 81903, 82079, 82087, 81911, 81904, 82080, 82088, 81912, 83190, 83214, 83215, 82656, 83193, 83217, 83218, 
82659, 82633, 83191, 83216, 82658
29780, 81904, 82080, 82088, 81912, 18088, 18110, 18111, 18089, 83193, 83217, 83218, 82659, 18211, 18212, 18213, 
18167, 82636, 83194, 83219, 82661
29781, 17866, 17888, 17889, 17867, 81905, 82081, 82089, 81913, 17989, 17992, 17991, 17947, 83197, 83221, 83222, 
82663, 82637, 83195, 83220, 82662
29782, 81905, 82081, 82089, 81913, 81906, 82082, 82090, 81914, 83197, 83221, 83222, 82663, 83200, 83224, 83225, 
82666, 82640, 83198, 83223, 82665
29783, 81906, 82082, 82090, 81914, 81907, 82083, 82091, 81915, 83200, 83224, 83225, 82666, 83203, 83227, 83228, 
82669, 82643, 83201, 83226, 82668
29784, 81907, 82083, 82091, 81915, 81908, 82084, 82092, 81916, 83203, 83227, 83228, 82669, 83206, 83230, 83231, 
82672, 82646, 83204, 83229, 82671
29785, 81908, 82084, 82092, 81916, 81909, 82085, 82093, 81917, 83206, 83230, 83231, 82672, 83209, 83233, 83234, 
82675, 82649, 83207, 83232, 82674
29786, 81909, 82085, 82093, 81917, 81910, 82086, 82094, 81918, 83209, 83233, 83234, 82675, 83212, 83236, 83237, 
82678, 82652, 83210, 83235, 82677
29787, 81910, 82086, 82094, 81918, 81911, 82087, 82095, 81919, 83212, 83236, 83237, 82678, 83215, 83239, 83240, 
82681, 82655, 83213, 83238, 82680
29788, 81911, 82087, 82095, 81919, 81912, 82088, 82096, 81920, 83215, 83239, 83240, 82681, 83218, 83242, 83243, 
82684, 82658, 83216, 83241, 82683
29789, 81912, 82088, 82096, 81920, 18089, 18111, 18112, 18090, 83218, 83242, 83243, 82684, 18213, 18214, 18215, 
18169, 82661, 83219, 83244, 82686
29790, 17867, 17889, 17890, 17868, 81913, 82089, 82097, 81921, 17991, 17994, 17993, 17949, 83222, 83246, 83247, 
82688, 82662, 83220, 83245, 82687
29791, 81913, 82089, 82097, 81921, 81914, 82090, 82098, 81922, 83222, 83246, 83247, 82688, 83225, 83249, 83250, 
82691, 82665, 83223, 83248, 82690
29792, 81914, 82090, 82098, 81922, 81915, 82091, 82099, 81923, 83225, 83249, 83250, 82691, 83228, 83252, 83253, 
82694, 82668, 83226, 83251, 82693
29793, 81915, 82091, 82099, 81923, 81916, 82092, 82100, 81924, 83228, 83252, 83253, 82694, 83231, 83255, 83256, 
82697, 82671, 83229, 83254, 82696
29794, 81916, 82092, 82100, 81924, 81917, 82093, 82101, 81925, 83231, 83255, 83256, 82697, 83234, 83258, 83259, 
82700, 82674, 83232, 83257, 82699
29795, 81917, 82093, 82101, 81925, 81918, 82094, 82102, 81926, 83234, 83258, 83259, 82700, 83237, 83261, 83262, 
82703, 82677, 83235, 83260, 82702
29796, 81918, 82094, 82102, 81926, 81919, 82095, 82103, 81927, 83237, 83261, 83262, 82703, 83240, 83264, 83265, 
82706, 82680, 83238, 83263, 82705
29797, 81919, 82095, 82103, 81927, 81920, 82096, 82104, 81928, 83240, 83264, 83265, 82706, 83243, 83267, 83268, 
82709, 82683, 83241, 83266, 82708
29798, 81920, 82096, 82104, 81928, 18090, 18112, 18113, 18091, 83243, 83267, 83268, 82709, 18215, 18216, 18217, 
18171, 82686, 83244, 83269, 82711
29799, 17868, 17890, 17891, 17869, 81921, 82097, 82105, 81929, 17993, 17996, 17995, 17951, 83247, 83271, 83272, 
82713, 82687, 83245, 83270, 82712
29800, 81921, 82097, 82105, 81929, 81922, 82098, 82106, 81930, 83247, 83271, 83272, 82713, 83250, 83274, 83275, 
82716, 82690, 83248, 83273, 82715
29801, 81922, 82098, 82106, 81930, 81923, 82099, 82107, 81931, 83250, 83274, 83275, 82716, 83253, 83277, 83278, 
82719, 82693, 83251, 83276, 82718
29802, 81923, 82099, 82107, 81931, 81924, 82100, 82108, 81932, 83253, 83277, 83278, 82719, 83256, 83280, 83281, 
82722, 82696, 83254, 83279, 82721
29803, 81924, 82100, 82108, 81932, 81925, 82101, 82109, 81933, 83256, 83280, 83281, 82722, 83259, 83283, 83284, 
82725, 82699, 83257, 83282, 82724
29804, 81925, 82101, 82109, 81933, 81926, 82102, 82110, 81934, 83259, 83283, 83284, 82725, 83262, 83286, 83287, 
82728, 82702, 83260, 83285, 82727
29805, 81926, 82102, 82110, 81934, 81927, 82103, 82111, 81935, 83262, 83286, 83287, 82728, 83265, 83289, 83290, 
82731, 82705, 83263, 83288, 82730
29806, 81927, 82103, 82111, 81935, 81928, 82104, 82112, 81936, 83265, 83289, 83290, 82731, 83268, 83292, 83293, 
82734, 82708, 83266, 83291, 82733
29807, 81928, 82104, 82112, 81936, 18091, 18113, 18114, 18092, 83268, 83292, 83293, 82734, 18217, 18218, 18219, 
18173, 82711, 83269, 83294, 82736
29808, 17869, 17891, 17892, 17870, 81929, 82105, 82113, 81937, 17995, 17998, 17997, 17953, 83272, 83296, 83297, 
82738, 82712, 83270, 83295, 82737
29809, 81929, 82105, 82113, 81937, 81930, 82106, 82114, 81938, 83272, 83296, 83297, 82738, 83275, 83299, 83300, 
82741, 82715, 83273, 83298, 82740
29810, 81930, 82106, 82114, 81938, 81931, 82107, 82115, 81939, 83275, 83299, 83300, 82741, 83278, 83302, 83303, 
82744, 82718, 83276, 83301, 82743
29811, 81931, 82107, 82115, 81939, 81932, 82108, 82116, 81940, 83278, 83302, 83303, 82744, 83281, 83305, 83306, 
82747, 82721, 83279, 83304, 82746
29812, 81932, 82108, 82116, 81940, 81933, 82109, 82117, 81941, 83281, 83305, 83306, 82747, 83284, 83308, 83309, 
82750, 82724, 83282, 83307, 82749
29813, 81933, 82109, 82117, 81941, 81934, 82110, 82118, 81942, 83284, 83308, 83309, 82750, 83287, 83311, 83312, 
82753, 82727, 83285, 83310, 82752
29814, 81934, 82110, 82118, 81942, 81935, 82111, 82119, 81943, 83287, 83311, 83312, 82753, 83290, 83314, 83315, 
82756, 82730, 83288, 83313, 82755
29815, 81935, 82111, 82119, 81943, 81936, 82112, 82120, 81944, 83290, 83314, 83315, 82756, 83293, 83317, 83318, 
82759, 82733, 83291, 83316, 82758
29816, 81936, 82112, 82120, 81944, 18092, 18114, 18115, 18093, 83293, 83317, 83318, 82759, 18219, 18220, 18221, 
18175, 82736, 83294, 83319, 82761
29817, 17870, 17892, 17893, 17871, 81937, 82113, 82121, 81945, 17997, 18000, 17999, 17955, 83297, 83321, 83322, 
82763, 82737, 83295, 83320, 82762
29818, 81937, 82113, 82121, 81945, 81938, 82114, 82122, 81946, 83297, 83321, 83322, 82763, 83300, 83324, 83325, 
82766, 82740, 83298, 83323, 82765
29819, 81938, 82114, 82122, 81946, 81939, 82115, 82123, 81947, 83300, 83324, 83325, 82766, 83303, 83327, 83328, 
82769, 82743, 83301, 83326, 82768
29820, 81939, 82115, 82123, 81947, 81940, 82116, 82124, 81948, 83303, 83327, 83328, 82769, 83306, 83330, 83331, 
82772, 82746, 83304, 83329, 82771
29821, 81940, 82116, 82124, 81948, 81941, 82117, 82125, 81949, 83306, 83330, 83331, 82772, 83309, 83333, 83334, 
82775, 82749, 83307, 83332, 82774
29822, 81941, 82117, 82125, 81949, 81942, 82118, 82126, 81950, 83309, 83333, 83334, 82775, 83312, 83336, 83337, 
82778, 82752, 83310, 83335, 82777
29823, 81942, 82118, 82126, 81950, 81943, 82119, 82127, 81951, 83312, 83336, 83337, 82778, 83315, 83339, 83340, 
82781, 82755, 83313, 83338, 82780
29824, 81943, 82119, 82127, 81951, 81944, 82120, 82128, 81952, 83315, 83339, 83340, 82781, 83318, 83342, 83343, 
82784, 82758, 83316, 83341, 82783
29825, 81944, 82120, 82128, 81952, 18093, 18115, 18116, 18094, 83318, 83342, 83343, 82784, 18221, 18222, 18223, 
18177, 82761, 83319, 83344, 82786
29826, 17871, 17893, 17894, 17872, 81945, 82121, 82129, 81953, 17999, 18002, 18001, 17957, 83322, 83346, 83347, 
82788, 82762, 83320, 83345, 82787
29827, 81945, 82121, 82129, 81953, 81946, 82122, 82130, 81954, 83322, 83346, 83347, 82788, 83325, 83349, 83350, 
82791, 82765, 83323, 83348, 82790
29828, 81946, 82122, 82130, 81954, 81947, 82123, 82131, 81955, 83325, 83349, 83350, 82791, 83328, 83352, 83353, 
82794, 82768, 83326, 83351, 82793
29829, 81947, 82123, 82131, 81955, 81948, 82124, 82132, 81956, 83328, 83352, 83353, 82794, 83331, 83355, 83356, 
82797, 82771, 83329, 83354, 82796
29830, 81948, 82124, 82132, 81956, 81949, 82125, 82133, 81957, 83331, 83355, 83356, 82797, 83334, 83358, 83359, 
82800, 82774, 83332, 83357, 82799
29831, 81949, 82125, 82133, 81957, 81950, 82126, 82134, 81958, 83334, 83358, 83359, 82800, 83337, 83361, 83362, 
82803, 82777, 83335, 83360, 82802
29832, 81950, 82126, 82134, 81958, 81951, 82127, 82135, 81959, 83337, 83361, 83362, 82803, 83340, 83364, 83365, 
82806, 82780, 83338, 83363, 82805
29833, 81951, 82127, 82135, 81959, 81952, 82128, 82136, 81960, 83340, 83364, 83365, 82806, 83343, 83367, 83368, 
82809, 82783, 83341, 83366, 82808
29834, 81952, 82128, 82136, 81960, 18094, 18116, 18117, 18095, 83343, 83367, 83368, 82809, 18223, 18224, 18225, 
18179, 82786, 83344, 83369, 82811
29835, 17872, 17894, 17895, 17873, 81953, 82129, 82137, 81961, 18001, 18004, 18003, 17959, 83347, 83371, 83372, 
82813, 82787, 83345, 83370, 82812
29836, 81953, 82129, 82137, 81961, 81954, 82130, 82138, 81962, 83347, 83371, 83372, 82813, 83350, 83374, 83375, 
82816, 82790, 83348, 83373, 82815
29837, 81954, 82130, 82138, 81962, 81955, 82131, 82139, 81963, 83350, 83374, 83375, 82816, 83353, 83377, 83378, 
82819, 82793, 83351, 83376, 82818
29838, 81955, 82131, 82139, 81963, 81956, 82132, 82140, 81964, 83353, 83377, 83378, 82819, 83356, 83380, 83381, 
82822, 82796, 83354, 83379, 82821
29839, 81956, 82132, 82140, 81964, 81957, 82133, 82141, 81965, 83356, 83380, 83381, 82822, 83359, 83383, 83384, 
82825, 82799, 83357, 83382, 82824
29840, 81957, 82133, 82141, 81965, 81958, 82134, 82142, 81966, 83359, 83383, 83384, 82825, 83362, 83386, 83387, 
82828, 82802, 83360, 83385, 82827
29841, 81958, 82134, 82142, 81966, 81959, 82135, 82143, 81967, 83362, 83386, 83387, 82828, 83365, 83389, 83390, 
82831, 82805, 83363, 83388, 82830
29842, 81959, 82135, 82143, 81967, 81960, 82136, 82144, 81968, 83365, 83389, 83390, 82831, 83368, 83392, 83393, 
82834, 82808, 83366, 83391, 82833
29843, 81960, 82136, 82144, 81968, 18095, 18117, 18118, 18096, 83368, 83392, 83393, 82834, 18225, 18226, 18227, 
18181, 82811, 83369, 83394, 82836
29844, 17873, 17895, 17896, 17874, 81961, 82137, 82145, 81969, 18003, 18006, 18005, 17961, 83372, 83396, 83397, 
82838, 82812, 83370, 83395, 82837
29845, 81961, 82137, 82145, 81969, 81962, 82138, 82146, 81970, 83372, 83396, 83397, 82838, 83375, 83399, 83400, 
82841, 82815, 83373, 83398, 82840
29846, 81962, 82138, 82146, 81970, 81963, 82139, 82147, 81971, 83375, 83399, 83400, 82841, 83378, 83402, 83403, 
82844, 82818, 83376, 83401, 82843
29847, 81963, 82139, 82147, 81971, 81964, 82140, 82148, 81972, 83378, 83402, 83403, 82844, 83381, 83405, 83406, 
82847, 82821, 83379, 83404, 82846
29848, 81964, 82140, 82148, 81972, 81965, 82141, 82149, 81973, 83381, 83405, 83406, 82847, 83384, 83408, 83409, 
82850, 82824, 83382, 83407, 82849
29849, 81965, 82141, 82149, 81973, 81966, 82142, 82150, 81974, 83384, 83408, 83409, 82850, 83387, 83411, 83412, 
82853, 82827, 83385, 83410, 82852
29850, 81966, 82142, 82150, 81974, 81967, 82143, 82151, 81975, 83387, 83411, 83412, 82853, 83390, 83414, 83415, 
82856, 82830, 83388, 83413, 82855
29851, 81967, 82143, 82151, 81975, 81968, 82144, 82152, 81976, 83390, 83414, 83415, 82856, 83393, 83417, 83418, 
82859, 82833, 83391, 83416, 82858
29852, 81968, 82144, 82152, 81976, 18096, 18118, 18119, 18097, 83393, 83417, 83418, 82859, 18227, 18228, 18229, 
18183, 82836, 83394, 83419, 82861
29853, 17874, 17896, 17897, 17875, 81969, 82145, 82153, 81977, 18005, 18008, 18007, 17963, 83397, 83421, 83422, 
82863, 82837, 83395, 83420, 82862
29854, 81969, 82145, 82153, 81977, 81970, 82146, 82154, 81978, 83397, 83421, 83422, 82863, 83400, 83424, 83425, 
82866, 82840, 83398, 83423, 82865
29855, 81970, 82146, 82154, 81978, 81971, 82147, 82155, 81979, 83400, 83424, 83425, 82866, 83403, 83427, 83428, 
82869, 82843, 83401, 83426, 82868
29856, 81971, 82147, 82155, 81979, 81972, 82148, 82156, 81980, 83403, 83427, 83428, 82869, 83406, 83430, 83431, 
82872, 82846, 83404, 83429, 82871
29857, 81972, 82148, 82156, 81980, 81973, 82149, 82157, 81981, 83406, 83430, 83431, 82872, 83409, 83433, 83434, 
82875, 82849, 83407, 83432, 82874
29858, 81973, 82149, 82157, 81981, 81974, 82150, 82158, 81982, 83409, 83433, 83434, 82875, 83412, 83436, 83437, 
82878, 82852, 83410, 83435, 82877
29859, 81974, 82150, 82158, 81982, 81975, 82151, 82159, 81983, 83412, 83436, 83437, 82878, 83415, 83439, 83440, 
82881, 82855, 83413, 83438, 82880
29860, 81975, 82151, 82159, 81983, 81976, 82152, 82160, 81984, 83415, 83439, 83440, 82881, 83418, 83442, 83443, 
82884, 82858, 83416, 83441, 82883
29861, 81976, 82152, 82160, 81984, 18097, 18119, 18120, 18098, 83418, 83442, 83443, 82884, 18229, 18230, 18231, 
18185, 82861, 83419, 83444, 82886
29862, 17875, 17897, 2505, 2504, 81977, 82153, 18308, 18300, 18007, 18009, 2508, 17964, 83422, 83445, 18341, 
82887, 82862, 83420, 18342, 18325
29863, 81977, 82153, 18308, 18300, 81978, 82154, 18309, 18301, 83422, 83445, 18341, 82887, 83425, 83446, 18343, 
82888, 82865, 83423, 18344, 18327
29864, 81978, 82154, 18309, 18301, 81979, 82155, 18310, 18302, 83425, 83446, 18343, 82888, 83428, 83447, 18345, 
82889, 82868, 83426, 18346, 18329
29865, 81979, 82155, 18310, 18302, 81980, 82156, 18311, 18303, 83428, 83447, 18345, 82889, 83431, 83448, 18347, 
82890, 82871, 83429, 18348, 18331
29866, 81980, 82156, 18311, 18303, 81981, 82157, 18312, 18304, 83431, 83448, 18347, 82890, 83434, 83449, 18349, 
82891, 82874, 83432, 18350, 18333
29867, 81981, 82157, 18312, 18304, 81982, 82158, 18313, 18305, 83434, 83449, 18349, 82891, 83437, 83450, 18351, 
82892, 82877, 83435, 18352, 18335
29868, 81982, 82158, 18313, 18305, 81983, 82159, 18314, 18306, 83437, 83450, 18351, 82892, 83440, 83451, 18353, 
82893, 82880, 83438, 18354, 18337
29869, 81983, 82159, 18314, 18306, 81984, 82160, 18315, 18307, 83440, 83451, 18353, 82893, 83443, 83452, 18355, 
82894, 82883, 83441, 18356, 18339
29870, 81984, 82160, 18315, 18307, 18098, 18120, 2557, 2556, 83443, 83452, 18355, 82894, 18231, 18232, 2560, 
18187, 82886, 83444, 18357, 18340
29871, 1759, 1760, 17898, 17876, 13344, 13352, 82161, 81985, 1763, 18011, 18010, 17966, 13394, 83454, 83455, 
82896, 13378, 13395, 83453, 82895
29872, 13344, 13352, 82161, 81985, 13345, 13353, 82162, 81986, 13394, 83454, 83455, 82896, 13396, 83457, 83458, 
82899, 13380, 13397, 83456, 82898
29873, 13345, 13353, 82162, 81986, 13346, 13354, 82163, 81987, 13396, 83457, 83458, 82899, 13398, 83460, 83461, 
82902, 13382, 13399, 83459, 82901
29874, 13346, 13354, 82163, 81987, 13347, 13355, 82164, 81988, 13398, 83460, 83461, 82902, 13400, 83463, 83464, 
82905, 13384, 13401, 83462, 82904
29875, 13347, 13355, 82164, 81988, 13348, 13356, 82165, 81989, 13400, 83463, 83464, 82905, 13402, 83466, 83467, 
82908, 13386, 13403, 83465, 82907
29876, 13348, 13356, 82165, 81989, 13349, 13357, 82166, 81990, 13402, 83466, 83467, 82908, 13404, 83469, 83470, 
82911, 13388, 13405, 83468, 82910
29877, 13349, 13357, 82166, 81990, 13350, 13358, 82167, 81991, 13404, 83469, 83470, 82911, 13406, 83472, 83473, 
82914, 13390, 13407, 83471, 82913
29878, 13350, 13358, 82167, 81991, 13351, 13359, 82168, 81992, 13406, 83472, 83473, 82914, 13408, 83475, 83476, 
82917, 13392, 13409, 83474, 82916
29879, 13351, 13359, 82168, 81992, 1780, 1781, 18121, 18099, 13408, 83475, 83476, 82917, 1784, 18233, 18234, 
18188, 13393, 13410, 83477, 82919
29880, 17876, 17898, 17899, 17877, 81985, 82161, 82169, 81993, 18010, 18013, 18012, 17968, 83455, 83479, 83480, 
82921, 82895, 83453, 83478, 82920
29881, 81985, 82161, 82169, 81993, 81986, 82162, 82170, 81994, 83455, 83479, 83480, 82921, 83458, 83482, 83483, 
82924, 82898, 83456, 83481, 82923
29882, 81986, 82162, 82170, 81994, 81987, 82163, 82171, 81995, 83458, 83482, 83483, 82924, 83461, 83485, 83486, 
82927, 82901, 83459, 83484, 82926
29883, 81987, 82163, 82171, 81995, 81988, 82164, 82172, 81996, 83461, 83485, 83486, 82927, 83464, 83488, 83489, 
82930, 82904, 83462, 83487, 82929
29884, 81988, 82164, 82172, 81996, 81989, 82165, 82173, 81997, 83464, 83488, 83489, 82930, 83467, 83491, 83492, 
82933, 82907, 83465, 83490, 82932
29885, 81989, 82165, 82173, 81997, 81990, 82166, 82174, 81998, 83467, 83491, 83492, 82933, 83470, 83494, 83495, 
82936, 82910, 83468, 83493, 82935
29886, 81990, 82166, 82174, 81998, 81991, 82167, 82175, 81999, 83470, 83494, 83495, 82936, 83473, 83497, 83498, 
82939, 82913, 83471, 83496, 82938
29887, 81991, 82167, 82175, 81999, 81992, 82168, 82176, 82000, 83473, 83497, 83498, 82939, 83476, 83500, 83501, 
82942, 82916, 83474, 83499, 82941
29888, 81992, 82168, 82176, 82000, 18099, 18121, 18122, 18100, 83476, 83500, 83501, 82942, 18234, 18235, 18236, 
18190, 82919, 83477, 83502, 82944
29889, 17877, 17899, 17900, 17878, 81993, 82169, 82177, 82001, 18012, 18015, 18014, 17970, 83480, 83504, 83505, 
82946, 82920, 83478, 83503, 82945
29890, 81993, 82169, 82177, 82001, 81994, 82170, 82178, 82002, 83480, 83504, 83505, 82946, 83483, 83507, 83508, 
82949, 82923, 83481, 83506, 82948
29891, 81994, 82170, 82178, 82002, 81995, 82171, 82179, 82003, 83483, 83507, 83508, 82949, 83486, 83510, 83511, 
82952, 82926, 83484, 83509, 82951
29892, 81995, 82171, 82179, 82003, 81996, 82172, 82180, 82004, 83486, 83510, 83511, 82952, 83489, 83513, 83514, 
82955, 82929, 83487, 83512, 82954
29893, 81996, 82172, 82180, 82004, 81997, 82173, 82181, 82005, 83489, 83513, 83514, 82955, 83492, 83516, 83517, 
82958, 82932, 83490, 83515, 82957
29894, 81997, 82173, 82181, 82005, 81998, 82174, 82182, 82006, 83492, 83516, 83517, 82958, 83495, 83519, 83520, 
82961, 82935, 83493, 83518, 82960
29895, 81998, 82174, 82182, 82006, 81999, 82175, 82183, 82007, 83495, 83519, 83520, 82961, 83498, 83522, 83523, 
82964, 82938, 83496, 83521, 82963
29896, 81999, 82175, 82183, 82007, 82000, 82176, 82184, 82008, 83498, 83522, 83523, 82964, 83501, 83525, 83526, 
82967, 82941, 83499, 83524, 82966
29897, 82000, 82176, 82184, 82008, 18100, 18122, 18123, 18101, 83501, 83525, 83526, 82967, 18236, 18237, 18238, 
18192, 82944, 83502, 83527, 82969
29898, 17878, 17900, 17901, 17879, 82001, 82177, 82185, 82009, 18014, 18017, 18016, 17972, 83505, 83529, 83530, 
82971, 82945, 83503, 83528, 82970
29899, 82001, 82177, 82185, 82009, 82002, 82178, 82186, 82010, 83505, 83529, 83530, 82971, 83508, 83532, 83533, 
82974, 82948, 83506, 83531, 82973
29900, 82002, 82178, 82186, 82010, 82003, 82179, 82187, 82011, 83508, 83532, 83533, 82974, 83511, 83535, 83536, 
82977, 82951, 83509, 83534, 82976
29901, 82003, 82179, 82187, 82011, 82004, 82180, 82188, 82012, 83511, 83535, 83536, 82977, 83514, 83538, 83539, 
82980, 82954, 83512, 83537, 82979
29902, 82004, 82180, 82188, 82012, 82005, 82181, 82189, 82013, 83514, 83538, 83539, 82980, 83517, 83541, 83542, 
82983, 82957, 83515, 83540, 82982
