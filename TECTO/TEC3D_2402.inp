81381, 0.47826086956522, 1.725, 0.33333333333333
81382, 0.47826086956522, 1.725, 0.38888888888889
81383, 0.47826086956522, 1.725, 0.44444444444444
81384, 0.43478260869565, 1.725, 0.055555555555556
81385, 0.43478260869565, 1.725, 0.11111111111111
81386, 0.43478260869565, 1.725, 0.16666666666667
81387, 0.43478260869565, 1.725, 0.22222222222222
81388, 0.43478260869565, 1.725, 0.27777777777778
81389, 0.43478260869565, 1.725, 0.33333333333333
81390, 0.43478260869565, 1.725, 0.38888888888889
81391, 0.43478260869565, 1.725, 0.44444444444444
81392, 0.39130434782609, 1.725, 0.055555555555556
81393, 0.39130434782609, 1.725, 0.11111111111111
81394, 0.39130434782609, 1.725, 0.16666666666667
81395, 0.39130434782609, 1.725, 0.22222222222222
81396, 0.39130434782609, 1.725, 0.27777777777778
81397, 0.39130434782609, 1.725, 0.33333333333333
81398, 0.39130434782609, 1.725, 0.38888888888889
81399, 0.39130434782609, 1.725, 0.44444444444444
81400, 0.34782608695652, 1.725, 0.055555555555556
81401, 0.34782608695652, 1.725, 0.11111111111111
81402, 0.34782608695652, 1.725, 0.16666666666667
81403, 0.34782608695652, 1.725, 0.22222222222222
81404, 0.34782608695652, 1.725, 0.27777777777778
81405, 0.34782608695652, 1.725, 0.33333333333333
81406, 0.34782608695652, 1.725, 0.38888888888889
81407, 0.34782608695652, 1.725, 0.44444444444444
81408, 0.30434782608696, 1.725, 0.055555555555556
81409, 0.30434782608696, 1.725, 0.11111111111111
81410, 0.30434782608696, 1.725, 0.16666666666667
81411, 0.30434782608696, 1.725, 0.22222222222222
81412, 0.30434782608696, 1.725, 0.27777777777778
81413, 0.30434782608696, 1.725, 0.33333333333333
81414, 0.30434782608696, 1.725, 0.38888888888889
81415, 0.30434782608696, 1.725, 0.44444444444444
81416, 0.26086956521739, 1.725, 0.055555555555556
81417, 0.26086956521739, 1.725, 0.11111111111111
81418, 0.26086956521739, 1.725, 0.16666666666667
81419, 0.26086956521739, 1.725, 0.22222222222222
81420, 0.26086956521739, 1.725, 0.27777777777778
81421, 0.26086956521739, 1.725, 0.33333333333333
81422, 0.26086956521739, 1.725, 0.38888888888889
81423, 0.26086956521739, 1.725, 0.44444444444444
81424, 0.21739130434783, 1.725, 0.055555555555556
81425, 0.21739130434783, 1.725, 0.11111111111111
81426, 0.21739130434783, 1.725, 0.16666666666667
81427, 0.21739130434783, 1.725, 0.22222222222222
81428, 0.21739130434783, 1.725, 0.27777777777778
81429, 0.21739130434783, 1.725, 0.33333333333333
81430, 0.21739130434783, 1.725, 0.38888888888889
81431, 0.21739130434783, 1.725, 0.44444444444444
81432, 0.17391304347826, 1.725, 0.055555555555556
81433, 0.17391304347826, 1.725, 0.11111111111111
81434, 0.17391304347826, 1.725, 0.16666666666667
81435, 0.17391304347826, 1.725, 0.22222222222222
81436, 0.17391304347826, 1.725, 0.27777777777778
81437, 0.17391304347826, 1.725, 0.33333333333333
81438, 0.17391304347826, 1.725, 0.38888888888889
81439, 0.17391304347826, 1.725, 0.44444444444444
81440, 0.1304347826087, 1.725, 0.055555555555556
81441, 0.1304347826087, 1.725, 0.11111111111111
81442, 0.1304347826087, 1.725, 0.16666666666667
81443, 0.1304347826087, 1.725, 0.22222222222222
81444, 0.1304347826087, 1.725, 0.27777777777778
81445, 0.1304347826087, 1.725, 0.33333333333333
81446, 0.1304347826087, 1.725, 0.38888888888889
81447, 0.1304347826087, 1.725, 0.44444444444444
81448, 0.08695652173913, 1.725, 0.055555555555556
81449, 0.08695652173913, 1.725, 0.11111111111111
81450, 0.08695652173913, 1.725, 0.16666666666667
81451, 0.08695652173913, 1.725, 0.22222222222222
81452, 0.08695652173913, 1.725, 0.27777777777778
81453, 0.08695652173913, 1.725, 0.33333333333333
81454, 0.08695652173913, 1.725, 0.38888888888889
81455, 0.08695652173913, 1.725, 0.44444444444444
81456, 0.043478260869565, 1.725, 0.055555555555556
81457, 0.043478260869565, 1.725, 0.11111111111111
81458, 0.043478260869565, 1.725, 0.16666666666667
81459, 0.043478260869565, 1.725, 0.22222222222222
81460, 0.043478260869565, 1.725, 0.27777777777778
81461, 0.043478260869565, 1.725, 0.33333333333333
81462, 0.043478260869565, 1.725, 0.38888888888889
81463, 0.043478260869565, 1.725, 0.44444444444444
81464, 1.05, 1.6, 0.44444444444444
81465, 1.05, 1.6, 0.38888888888889
81466, 1.05, 1.6, 0.33333333333333
81467, 1.05, 1.6, 0.27777777777778
81468, 1.05, 1.6, 0.22222222222222
81469, 1.05, 1.6, 0.16666666666667
81470, 1.05, 1.6, 0.11111111111111
81471, 1.05, 1.6, 0.055555555555556
81472, 1.1, 1.6, 0.44444444444444
81473, 1.1, 1.6, 0.38888888888889
81474, 1.1, 1.6, 0.33333333333333
81475, 1.1, 1.6, 0.27777777777778
81476, 1.1, 1.6, 0.22222222222222
81477, 1.1, 1.6, 0.16666666666667
81478, 1.1, 1.6, 0.11111111111111
81479, 1.1, 1.6, 0.055555555555556
81480, 1.15, 1.6, 0.44444444444444
81481, 1.15, 1.6, 0.38888888888889
81482, 1.15, 1.6, 0.33333333333333
81483, 1.15, 1.6, 0.27777777777778
81484, 1.15, 1.6, 0.22222222222222
81485, 1.15, 1.6, 0.16666666666667
81486, 1.15, 1.6, 0.11111111111111
81487, 1.15, 1.6, 0.055555555555556
81488, 1.05, 1.65, 0.44444444444444
81489, 1.05, 1.65, 0.38888888888889
81490, 1.05, 1.65, 0.33333333333333
81491, 1.05, 1.65, 0.27777777777778
81492, 1.05, 1.65, 0.22222222222222
81493, 1.05, 1.65, 0.16666666666667
81494, 1.05, 1.65, 0.11111111111111
81495, 1.05, 1.65, 0.055555555555556
81496, 1.1, 1.65, 0.44444444444444
81497, 1.1, 1.65, 0.38888888888889
81498, 1.1, 1.65, 0.33333333333333
81499, 1.1, 1.65, 0.27777777777778
81500, 1.1, 1.65, 0.22222222222222
81501, 1.1, 1.65, 0.16666666666667
81502, 1.1, 1.65, 0.11111111111111
81503, 1.1, 1.65, 0.055555555555556
81504, 1.15, 1.65, 0.44444444444444
81505, 1.15, 1.65, 0.38888888888889
81506, 1.15, 1.65, 0.33333333333333
81507, 1.15, 1.65, 0.27777777777778
81508, 1.15, 1.65, 0.22222222222222
81509, 1.15, 1.65, 0.16666666666667
81510, 1.15, 1.65, 0.11111111111111
81511, 1.15, 1.65, 0.055555555555556
81512, 1.05, 1.7, 0.44444444444444
81513, 1.05, 1.7, 0.38888888888889
81514, 1.05, 1.7, 0.33333333333333
81515, 1.05, 1.7, 0.27777777777778
81516, 1.05, 1.7, 0.22222222222222
81517, 1.05, 1.7, 0.16666666666667
81518, 1.05, 1.7, 0.11111111111111
81519, 1.05, 1.7, 0.055555555555556
81520, 1.1, 1.7, 0.44444444444444
81521, 1.1, 1.7, 0.38888888888889
81522, 1.1, 1.7, 0.33333333333333
81523, 1.1, 1.7, 0.27777777777778
81524, 1.1, 1.7, 0.22222222222222
81525, 1.1, 1.7, 0.16666666666667
81526, 1.1, 1.7, 0.11111111111111
81527, 1.1, 1.7, 0.055555555555556
81528, 1.15, 1.7, 0.44444444444444
81529, 1.15, 1.7, 0.38888888888889
81530, 1.15, 1.7, 0.33333333333333
81531, 1.15, 1.7, 0.27777777777778
81532, 1.15, 1.7, 0.22222222222222
81533, 1.15, 1.7, 0.16666666666667
81534, 1.15, 1.7, 0.11111111111111
81535, 1.15, 1.7, 0.055555555555556
81536, 1.05, 1.6, 0.47222222222222
81537, 1.025, 1.6, 0.44444444444444
81538, 1.05, 1.575, 0.44444444444444
81539, 1.05, 1.6, 0.41666666666667
81540, 1.025, 1.6, 0.38888888888889
81541, 1.05, 1.575, 0.38888888888889
81542, 1.05, 1.6, 0.36111111111111
81543, 1.025, 1.6, 0.33333333333333
81544, 1.05, 1.575, 0.33333333333333
81545, 1.05, 1.6, 0.30555555555556
81546, 1.025, 1.6, 0.27777777777778
81547, 1.05, 1.575, 0.27777777777778
81548, 1.05, 1.6, 0.25
81549, 1.025, 1.6, 0.22222222222222
81550, 1.05, 1.575, 0.22222222222222
81551, 1.05, 1.6, 0.19444444444444
81552, 1.025, 1.6, 0.16666666666667
81553, 1.05, 1.575, 0.16666666666667
81554, 1.05, 1.6, 0.13888888888889
81555, 1.025, 1.6, 0.11111111111111
81556, 1.05, 1.575, 0.11111111111111
81557, 1.05, 1.6, 0.083333333333333
81558, 1.025, 1.6, 0.055555555555556
81559, 1.05, 1.575, 0.055555555555556
81560, 1.05, 1.6, 0.027777777777778
81561, 1.1, 1.6, 0.47222222222222
81562, 1.075, 1.6, 0.44444444444444
81563, 1.1, 1.575, 0.44444444444444
81564, 1.1, 1.6, 0.41666666666667
81565, 1.075, 1.6, 0.38888888888889
81566, 1.1, 1.575, 0.38888888888889
81567, 1.1, 1.6, 0.36111111111111
81568, 1.075, 1.6, 0.33333333333333
81569, 1.1, 1.575, 0.33333333333333
81570, 1.1, 1.6, 0.30555555555556
81571, 1.075, 1.6, 0.27777777777778
81572, 1.1, 1.575, 0.27777777777778
81573, 1.1, 1.6, 0.25
81574, 1.075, 1.6, 0.22222222222222
81575, 1.1, 1.575, 0.22222222222222
81576, 1.1, 1.6, 0.19444444444444
81577, 1.075, 1.6, 0.16666666666667
81578, 1.1, 1.575, 0.16666666666667
81579, 1.1, 1.6, 0.13888888888889
81580, 1.075, 1.6, 0.11111111111111
81581, 1.1, 1.575, 0.11111111111111
81582, 1.1, 1.6, 0.083333333333333
81583, 1.075, 1.6, 0.055555555555556
81584, 1.1, 1.575, 0.055555555555556
81585, 1.1, 1.6, 0.027777777777778
81586, 1.15, 1.6, 0.47222222222222
81587, 1.125, 1.6, 0.44444444444444
81588, 1.15, 1.575, 0.44444444444444
81589, 1.15, 1.6, 0.41666666666667
81590, 1.125, 1.6, 0.38888888888889
81591, 1.15, 1.575, 0.38888888888889
81592, 1.15, 1.6, 0.36111111111111
81593, 1.125, 1.6, 0.33333333333333
81594, 1.15, 1.575, 0.33333333333333
81595, 1.15, 1.6, 0.30555555555556
81596, 1.125, 1.6, 0.27777777777778
81597, 1.15, 1.575, 0.27777777777778
81598, 1.15, 1.6, 0.25
81599, 1.125, 1.6, 0.22222222222222
81600, 1.15, 1.575, 0.22222222222222
81601, 1.15, 1.6, 0.19444444444444
81602, 1.125, 1.6, 0.16666666666667
81603, 1.15, 1.575, 0.16666666666667
81604, 1.15, 1.6, 0.13888888888889
81605, 1.125, 1.6, 0.11111111111111
81606, 1.15, 1.575, 0.11111111111111
81607, 1.15, 1.6, 0.083333333333333
81608, 1.125, 1.6, 0.055555555555556
81609, 1.15, 1.575, 0.055555555555556
81610, 1.15, 1.6, 0.027777777777778
81611, 1.175, 1.6, 0.44444444444444
81612, 1.175, 1.6, 0.38888888888889
81613, 1.175, 1.6, 0.33333333333333
81614, 1.175, 1.6, 0.27777777777778
81615, 1.175, 1.6, 0.22222222222222
81616, 1.175, 1.6, 0.16666666666667
81617, 1.175, 1.6, 0.11111111111111
81618, 1.175, 1.6, 0.055555555555556
81619, 1.05, 1.65, 0.47222222222222
81620, 1.025, 1.65, 0.44444444444444
81621, 1.05, 1.625, 0.44444444444444
81622, 1.05, 1.65, 0.41666666666667
81623, 1.025, 1.65, 0.38888888888889
81624, 1.05, 1.625, 0.38888888888889
81625, 1.05, 1.65, 0.36111111111111
81626, 1.025, 1.65, 0.33333333333333
81627, 1.05, 1.625, 0.33333333333333
81628, 1.05, 1.65, 0.30555555555556
81629, 1.025, 1.65, 0.27777777777778
81630, 1.05, 1.625, 0.27777777777778
81631, 1.05, 1.65, 0.25
81632, 1.025, 1.65, 0.22222222222222
81633, 1.05, 1.625, 0.22222222222222
81634, 1.05, 1.65, 0.19444444444444
81635, 1.025, 1.65, 0.16666666666667
81636, 1.05, 1.625, 0.16666666666667
81637, 1.05, 1.65, 0.13888888888889
81638, 1.025, 1.65, 0.11111111111111
81639, 1.05, 1.625, 0.11111111111111
81640, 1.05, 1.65, 0.083333333333333
81641, 1.025, 1.65, 0.055555555555556
81642, 1.05, 1.625, 0.055555555555556
81643, 1.05, 1.65, 0.027777777777778
81644, 1.1, 1.65, 0.47222222222222
81645, 1.075, 1.65, 0.44444444444444
81646, 1.1, 1.625, 0.44444444444444
81647, 1.1, 1.65, 0.41666666666667
81648, 1.075, 1.65, 0.38888888888889
81649, 1.1, 1.625, 0.38888888888889
81650, 1.1, 1.65, 0.36111111111111
81651, 1.075, 1.65, 0.33333333333333
81652, 1.1, 1.625, 0.33333333333333
81653, 1.1, 1.65, 0.30555555555556
81654, 1.075, 1.65, 0.27777777777778
81655, 1.1, 1.625, 0.27777777777778
81656, 1.1, 1.65, 0.25
81657, 1.075, 1.65, 0.22222222222222
81658, 1.1, 1.625, 0.22222222222222
81659, 1.1, 1.65, 0.19444444444444
81660, 1.075, 1.65, 0.16666666666667
81661, 1.1, 1.625, 0.16666666666667
81662, 1.1, 1.65, 0.13888888888889
81663, 1.075, 1.65, 0.11111111111111
81664, 1.1, 1.625, 0.11111111111111
81665, 1.1, 1.65, 0.083333333333333
81666, 1.075, 1.65, 0.055555555555556
81667, 1.1, 1.625, 0.055555555555556
81668, 1.1, 1.65, 0.027777777777778
81669, 1.15, 1.65, 0.47222222222222
81670, 1.125, 1.65, 0.44444444444444
81671, 1.15, 1.625, 0.44444444444444
81672, 1.15, 1.65, 0.41666666666667
81673, 1.125, 1.65, 0.38888888888889
81674, 1.15, 1.625, 0.38888888888889
81675, 1.15, 1.65, 0.36111111111111
81676, 1.125, 1.65, 0.33333333333333
81677, 1.15, 1.625, 0.33333333333333
81678, 1.15, 1.65, 0.30555555555556
81679, 1.125, 1.65, 0.27777777777778
81680, 1.15, 1.625, 0.27777777777778
81681, 1.15, 1.65, 0.25
81682, 1.125, 1.65, 0.22222222222222
81683, 1.15, 1.625, 0.22222222222222
81684, 1.15, 1.65, 0.19444444444444
81685, 1.125, 1.65, 0.16666666666667
81686, 1.15, 1.625, 0.16666666666667
81687, 1.15, 1.65, 0.13888888888889
81688, 1.125, 1.65, 0.11111111111111
81689, 1.15, 1.625, 0.11111111111111
81690, 1.15, 1.65, 0.083333333333333
81691, 1.125, 1.65, 0.055555555555556
81692, 1.15, 1.625, 0.055555555555556
81693, 1.15, 1.65, 0.027777777777778
81694, 1.175, 1.65, 0.44444444444444
81695, 1.175, 1.65, 0.38888888888889
81696, 1.175, 1.65, 0.33333333333333
81697, 1.175, 1.65, 0.27777777777778
81698, 1.175, 1.65, 0.22222222222222
81699, 1.175, 1.65, 0.16666666666667
81700, 1.175, 1.65, 0.11111111111111
81701, 1.175, 1.65, 0.055555555555556
81702, 1.05, 1.7, 0.47222222222222
81703, 1.025, 1.7, 0.44444444444444
81704, 1.05, 1.675, 0.44444444444444
81705, 1.05, 1.7, 0.41666666666667
81706, 1.025, 1.7, 0.38888888888889
81707, 1.05, 1.675, 0.38888888888889
81708, 1.05, 1.7, 0.36111111111111
81709, 1.025, 1.7, 0.33333333333333
81710, 1.05, 1.675, 0.33333333333333
81711, 1.05, 1.7, 0.30555555555556
81712, 1.025, 1.7, 0.27777777777778
81713, 1.05, 1.675, 0.27777777777778
81714, 1.05, 1.7, 0.25
81715, 1.025, 1.7, 0.22222222222222
81716, 1.05, 1.675, 0.22222222222222
81717, 1.05, 1.7, 0.19444444444444
81718, 1.025, 1.7, 0.16666666666667
81719, 1.05, 1.675, 0.16666666666667
81720, 1.05, 1.7, 0.13888888888889
81721, 1.025, 1.7, 0.11111111111111
81722, 1.05, 1.675, 0.11111111111111
81723, 1.05, 1.7, 0.083333333333333
81724, 1.025, 1.7, 0.055555555555556
81725, 1.05, 1.675, 0.055555555555556
81726, 1.05, 1.7, 0.027777777777778
81727, 1.1, 1.7, 0.47222222222222
81728, 1.075, 1.7, 0.44444444444444
81729, 1.1, 1.675, 0.44444444444444
81730, 1.1, 1.7, 0.41666666666667
81731, 1.075, 1.7, 0.38888888888889
81732, 1.1, 1.675, 0.38888888888889
81733, 1.1, 1.7, 0.36111111111111
81734, 1.075, 1.7, 0.33333333333333
81735, 1.1, 1.675, 0.33333333333333
81736, 1.1, 1.7, 0.30555555555556
81737, 1.075, 1.7, 0.27777777777778
81738, 1.1, 1.675, 0.27777777777778
81739, 1.1, 1.7, 0.25
81740, 1.075, 1.7, 0.22222222222222
81741, 1.1, 1.675, 0.22222222222222
81742, 1.1, 1.7, 0.19444444444444
81743, 1.075, 1.7, 0.16666666666667
81744, 1.1, 1.675, 0.16666666666667
81745, 1.1, 1.7, 0.13888888888889
81746, 1.075, 1.7, 0.11111111111111
81747, 1.1, 1.675, 0.11111111111111
81748, 1.1, 1.7, 0.083333333333333
81749, 1.075, 1.7, 0.055555555555556
81750, 1.1, 1.675, 0.055555555555556
81751, 1.1, 1.7, 0.027777777777778
81752, 1.15, 1.7, 0.47222222222222
81753, 1.125, 1.7, 0.44444444444444
81754, 1.15, 1.675, 0.44444444444444
81755, 1.15, 1.7, 0.41666666666667
81756, 1.125, 1.7, 0.38888888888889
81757, 1.15, 1.675, 0.38888888888889
81758, 1.15, 1.7, 0.36111111111111
81759, 1.125, 1.7, 0.33333333333333
81760, 1.15, 1.675, 0.33333333333333
81761, 1.15, 1.7, 0.30555555555556
81762, 1.125, 1.7, 0.27777777777778
81763, 1.15, 1.675, 0.27777777777778
81764, 1.15, 1.7, 0.25
81765, 1.125, 1.7, 0.22222222222222
81766, 1.15, 1.675, 0.22222222222222
81767, 1.15, 1.7, 0.19444444444444
81768, 1.125, 1.7, 0.16666666666667
81769, 1.15, 1.675, 0.16666666666667
81770, 1.15, 1.7, 0.13888888888889
81771, 1.125, 1.7, 0.11111111111111
81772, 1.15, 1.675, 0.11111111111111
81773, 1.15, 1.7, 0.083333333333333
81774, 1.125, 1.7, 0.055555555555556
81775, 1.15, 1.675, 0.055555555555556
81776, 1.15, 1.7, 0.027777777777778
81777, 1.175, 1.7, 0.44444444444444
81778, 1.175, 1.7, 0.38888888888889
81779, 1.175, 1.7, 0.33333333333333
81780, 1.175, 1.7, 0.27777777777778
81781, 1.175, 1.7, 0.22222222222222
81782, 1.175, 1.7, 0.16666666666667
81783, 1.175, 1.7, 0.11111111111111
81784, 1.175, 1.7, 0.055555555555556
81785, 1.05, 1.725, 0.44444444444444
81786, 1.05, 1.725, 0.38888888888889
81787, 1.05, 1.725, 0.33333333333333
81788, 1.05, 1.725, 0.27777777777778
81789, 1.05, 1.725, 0.22222222222222
81790, 1.05, 1.725, 0.16666666666667
81791, 1.05, 1.725, 0.11111111111111
81792, 1.05, 1.725, 0.055555555555556
81793, 1.1, 1.725, 0.44444444444444
81794, 1.1, 1.725, 0.38888888888889
81795, 1.1, 1.725, 0.33333333333333
81796, 1.1, 1.725, 0.27777777777778
81797, 1.1, 1.725, 0.22222222222222
81798, 1.1, 1.725, 0.16666666666667
81799, 1.1, 1.725, 0.11111111111111
81800, 1.1, 1.725, 0.055555555555556
81801, 1.15, 1.725, 0.44444444444444
81802, 1.15, 1.725, 0.38888888888889
81803, 1.15, 1.725, 0.33333333333333
81804, 1.15, 1.725, 0.27777777777778
81805, 1.15, 1.725, 0.22222222222222
81806, 1.15, 1.725, 0.16666666666667
81807, 1.15, 1.725, 0.11111111111111
81808, 1.15, 1.725, 0.055555555555556
81809, 1.2434782608696, 1.6, 0.44444444444444
81810, 1.2434782608696, 1.6, 0.38888888888889
81811, 1.2434782608696, 1.6, 0.33333333333333
81812, 1.2434782608696, 1.6, 0.27777777777778
81813, 1.2434782608696, 1.6, 0.22222222222222
81814, 1.2434782608696, 1.6, 0.16666666666667
81815, 1.2434782608696, 1.6, 0.11111111111111
81816, 1.2434782608696, 1.6, 0.055555555555556
81817, 1.2869565217391, 1.6, 0.44444444444444
81818, 1.2869565217391, 1.6, 0.38888888888889
81819, 1.2869565217391, 1.6, 0.33333333333333
81820, 1.2869565217391, 1.6, 0.27777777777778
81821, 1.2869565217391, 1.6, 0.22222222222222
81822, 1.2869565217391, 1.6, 0.16666666666667
81823, 1.2869565217391, 1.6, 0.11111111111111
81824, 1.2869565217391, 1.6, 0.055555555555556
81825, 1.3304347826087, 1.6, 0.44444444444444
81826, 1.3304347826087, 1.6, 0.38888888888889
81827, 1.3304347826087, 1.6, 0.33333333333333
81828, 1.3304347826087, 1.6, 0.27777777777778
81829, 1.3304347826087, 1.6, 0.22222222222222
81830, 1.3304347826087, 1.6, 0.16666666666667
81831, 1.3304347826087, 1.6, 0.11111111111111
81832, 1.3304347826087, 1.6, 0.055555555555556
81833, 1.3739130434783, 1.6, 0.44444444444444
81834, 1.3739130434783, 1.6, 0.38888888888889
81835, 1.3739130434783, 1.6, 0.33333333333333
81836, 1.3739130434783, 1.6, 0.27777777777778
81837, 1.3739130434783, 1.6, 0.22222222222222
81838, 1.3739130434783, 1.6, 0.16666666666667
81839, 1.3739130434783, 1.6, 0.11111111111111
81840, 1.3739130434783, 1.6, 0.055555555555556
81841, 1.4173913043478, 1.6, 0.44444444444444
81842, 1.4173913043478, 1.6, 0.38888888888889
81843, 1.4173913043478, 1.6, 0.33333333333333
81844, 1.4173913043478, 1.6, 0.27777777777778
81845, 1.4173913043478, 1.6, 0.22222222222222
81846, 1.4173913043478, 1.6, 0.16666666666667
81847, 1.4173913043478, 1.6, 0.11111111111111
81848, 1.4173913043478, 1.6, 0.055555555555556
81849, 1.4608695652174, 1.6, 0.44444444444444
81850, 1.4608695652174, 1.6, 0.38888888888889
81851, 1.4608695652174, 1.6, 0.33333333333333
81852, 1.4608695652174, 1.6, 0.27777777777778
81853, 1.4608695652174, 1.6, 0.22222222222222
81854, 1.4608695652174, 1.6, 0.16666666666667
81855, 1.4608695652174, 1.6, 0.11111111111111
81856, 1.4608695652174, 1.6, 0.055555555555556
81857, 1.504347826087, 1.6, 0.44444444444444
81858, 1.504347826087, 1.6, 0.38888888888889
81859, 1.504347826087, 1.6, 0.33333333333333
81860, 1.504347826087, 1.6, 0.27777777777778
81861, 1.504347826087, 1.6, 0.22222222222222
81862, 1.504347826087, 1.6, 0.16666666666667
81863, 1.504347826087, 1.6, 0.11111111111111
81864, 1.504347826087, 1.6, 0.055555555555556
81865, 1.5478260869565, 1.6, 0.44444444444444
81866, 1.5478260869565, 1.6, 0.38888888888889
81867, 1.5478260869565, 1.6, 0.33333333333333
81868, 1.5478260869565, 1.6, 0.27777777777778
81869, 1.5478260869565, 1.6, 0.22222222222222
81870, 1.5478260869565, 1.6, 0.16666666666667
81871, 1.5478260869565, 1.6, 0.11111111111111
81872, 1.5478260869565, 1.6, 0.055555555555556
81873, 1.5913043478261, 1.6, 0.44444444444444
81874, 1.5913043478261, 1.6, 0.38888888888889
81875, 1.5913043478261, 1.6, 0.33333333333333
81876, 1.5913043478261, 1.6, 0.27777777777778
81877, 1.5913043478261, 1.6, 0.22222222222222
81878, 1.5913043478261, 1.6, 0.16666666666667
81879, 1.5913043478261, 1.6, 0.11111111111111
81880, 1.5913043478261, 1.6, 0.055555555555556
81881, 1.6347826086957, 1.6, 0.44444444444444
81882, 1.6347826086957, 1.6, 0.38888888888889
81883, 1.6347826086957, 1.6, 0.33333333333333
81884, 1.6347826086957, 1.6, 0.27777777777778
81885, 1.6347826086957, 1.6, 0.22222222222222
81886, 1.6347826086957, 1.6, 0.16666666666667
81887, 1.6347826086957, 1.6, 0.11111111111111
81888, 1.6347826086957, 1.6, 0.055555555555556
81889, 1.6782608695652, 1.6, 0.44444444444444
81890, 1.6782608695652, 1.6, 0.38888888888889
81891, 1.6782608695652, 1.6, 0.33333333333333
81892, 1.6782608695652, 1.6, 0.27777777777778
81893, 1.6782608695652, 1.6, 0.22222222222222
81894, 1.6782608695652, 1.6, 0.16666666666667
81895, 1.6782608695652, 1.6, 0.11111111111111
81896, 1.6782608695652, 1.6, 0.055555555555556
81897, 1.7217391304348, 1.6, 0.44444444444444
81898, 1.7217391304348, 1.6, 0.38888888888889
81899, 1.7217391304348, 1.6, 0.33333333333333
81900, 1.7217391304348, 1.6, 0.27777777777778
81901, 1.7217391304348, 1.6, 0.22222222222222
81902, 1.7217391304348, 1.6, 0.16666666666667
81903, 1.7217391304348, 1.6, 0.11111111111111
81904, 1.7217391304348, 1.6, 0.055555555555556
81905, 1.7652173913043, 1.6, 0.44444444444444
81906, 1.7652173913043, 1.6, 0.38888888888889
81907, 1.7652173913043, 1.6, 0.33333333333333
81908, 1.7652173913043, 1.6, 0.27777777777778
81909, 1.7652173913043, 1.6, 0.22222222222222
81910, 1.7652173913043, 1.6, 0.16666666666667
81911, 1.7652173913043, 1.6, 0.11111111111111
81912, 1.7652173913043, 1.6, 0.055555555555556
81913, 1.8086956521739, 1.6, 0.44444444444444
81914, 1.8086956521739, 1.6, 0.38888888888889
81915, 1.8086956521739, 1.6, 0.33333333333333
81916, 1.8086956521739, 1.6, 0.27777777777778
81917, 1.8086956521739, 1.6, 0.22222222222222
81918, 1.8086956521739, 1.6, 0.16666666666667
81919, 1.8086956521739, 1.6, 0.11111111111111
81920, 1.8086956521739, 1.6, 0.055555555555556
81921, 1.8521739130435, 1.6, 0.44444444444444
81922, 1.8521739130435, 1.6, 0.38888888888889
81923, 1.8521739130435, 1.6, 0.33333333333333
81924, 1.8521739130435, 1.6, 0.27777777777778
81925, 1.8521739130435, 1.6, 0.22222222222222
81926, 1.8521739130435, 1.6, 0.16666666666667
81927, 1.8521739130435, 1.6, 0.11111111111111
81928, 1.8521739130435, 1.6, 0.055555555555556
81929, 1.895652173913, 1.6, 0.44444444444444
81930, 1.895652173913, 1.6, 0.38888888888889
81931, 1.895652173913, 1.6, 0.33333333333333
81932, 1.895652173913, 1.6, 0.27777777777778
81933, 1.895652173913, 1.6, 0.22222222222222
81934, 1.895652173913, 1.6, 0.16666666666667
81935, 1.895652173913, 1.6, 0.11111111111111
81936, 1.895652173913, 1.6, 0.055555555555556
81937, 1.9391304347826, 1.6, 0.44444444444444
81938, 1.9391304347826, 1.6, 0.38888888888889
81939, 1.9391304347826, 1.6, 0.33333333333333
81940, 1.9391304347826, 1.6, 0.27777777777778
81941, 1.9391304347826, 1.6, 0.22222222222222
81942, 1.9391304347826, 1.6, 0.16666666666667
81943, 1.9391304347826, 1.6, 0.11111111111111
81944, 1.9391304347826, 1.6, 0.055555555555556
81945, 1.9826086956522, 1.6, 0.44444444444444
81946, 1.9826086956522, 1.6, 0.38888888888889
81947, 1.9826086956522, 1.6, 0.33333333333333
81948, 1.9826086956522, 1.6, 0.27777777777778
81949, 1.9826086956522, 1.6, 0.22222222222222
81950, 1.9826086956522, 1.6, 0.16666666666667
81951, 1.9826086956522, 1.6, 0.11111111111111
81952, 1.9826086956522, 1.6, 0.055555555555556
81953, 2.0260869565217, 1.6, 0.44444444444444
81954, 2.0260869565217, 1.6, 0.38888888888889
81955, 2.0260869565217, 1.6, 0.33333333333333
81956, 2.0260869565217, 1.6, 0.27777777777778
81957, 2.0260869565217, 1.6, 0.22222222222222
81958, 2.0260869565217, 1.6, 0.16666666666667
81959, 2.0260869565217, 1.6, 0.11111111111111
81960, 2.0260869565217, 1.6, 0.055555555555556
81961, 2.0695652173913, 1.6, 0.44444444444444
81962, 2.0695652173913, 1.6, 0.38888888888889
81963, 2.0695652173913, 1.6, 0.33333333333333
81964, 2.0695652173913, 1.6, 0.27777777777778
81965, 2.0695652173913, 1.6, 0.22222222222222
81966, 2.0695652173913, 1.6, 0.16666666666667
81967, 2.0695652173913, 1.6, 0.11111111111111
81968, 2.0695652173913, 1.6, 0.055555555555556
81969, 2.1130434782609, 1.6, 0.44444444444444
81970, 2.1130434782609, 1.6, 0.38888888888889
81971, 2.1130434782609, 1.6, 0.33333333333333
81972, 2.1130434782609, 1.6, 0.27777777777778
81973, 2.1130434782609, 1.6, 0.22222222222222
81974, 2.1130434782609, 1.6, 0.16666666666667
81975, 2.1130434782609, 1.6, 0.11111111111111
81976, 2.1130434782609, 1.6, 0.055555555555556
81977, 2.1565217391304, 1.6, 0.44444444444444
81978, 2.1565217391304, 1.6, 0.38888888888889
81979, 2.1565217391304, 1.6, 0.33333333333333
81980, 2.1565217391304, 1.6, 0.27777777777778
81981, 2.1565217391304, 1.6, 0.22222222222222
81982, 2.1565217391304, 1.6, 0.16666666666667
81983, 2.1565217391304, 1.6, 0.11111111111111
81984, 2.1565217391304, 1.6, 0.055555555555556
81985, 1.2434782608696, 1.65, 0.44444444444444
81986, 1.2434782608696, 1.65, 0.38888888888889
81987, 1.2434782608696, 1.65, 0.33333333333333
81988, 1.2434782608696, 1.65, 0.27777777777778
81989, 1.2434782608696, 1.65, 0.22222222222222
81990, 1.2434782608696, 1.65, 0.16666666666667
81991, 1.2434782608696, 1.65, 0.11111111111111
81992, 1.2434782608696, 1.65, 0.055555555555556
81993, 1.2869565217391, 1.65, 0.44444444444444
81994, 1.2869565217391, 1.65, 0.38888888888889
81995, 1.2869565217391, 1.65, 0.33333333333333
81996, 1.2869565217391, 1.65, 0.27777777777778
81997, 1.2869565217391, 1.65, 0.22222222222222
81998, 1.2869565217391, 1.65, 0.16666666666667
81999, 1.2869565217391, 1.65, 0.11111111111111
82000, 1.2869565217391, 1.65, 0.055555555555556
82001, 1.3304347826087, 1.65, 0.44444444444444
82002, 1.3304347826087, 1.65, 0.38888888888889
82003, 1.3304347826087, 1.65, 0.33333333333333
82004, 1.3304347826087, 1.65, 0.27777777777778
82005, 1.3304347826087, 1.65, 0.22222222222222
82006, 1.3304347826087, 1.65, 0.16666666666667
82007, 1.3304347826087, 1.65, 0.11111111111111
82008, 1.3304347826087, 1.65, 0.055555555555556
82009, 1.3739130434783, 1.65, 0.44444444444444
82010, 1.3739130434783, 1.65, 0.38888888888889
82011, 1.3739130434783, 1.65, 0.33333333333333
82012, 1.3739130434783, 1.65, 0.27777777777778
82013, 1.3739130434783, 1.65, 0.22222222222222
82014, 1.3739130434783, 1.65, 0.16666666666667
82015, 1.3739130434783, 1.65, 0.11111111111111
82016, 1.3739130434783, 1.65, 0.055555555555556
82017, 1.4173913043478, 1.65, 0.44444444444444
82018, 1.4173913043478, 1.65, 0.38888888888889
82019, 1.4173913043478, 1.65, 0.33333333333333
82020, 1.4173913043478, 1.65, 0.27777777777778
82021, 1.4173913043478, 1.65, 0.22222222222222
82022, 1.4173913043478, 1.65, 0.16666666666667
82023, 1.4173913043478, 1.65, 0.11111111111111
82024, 1.4173913043478, 1.65, 0.055555555555556
82025, 1.4608695652174, 1.65, 0.44444444444444
82026, 1.4608695652174, 1.65, 0.38888888888889
82027, 1.4608695652174, 1.65, 0.33333333333333
82028, 1.4608695652174, 1.65, 0.27777777777778
82029, 1.4608695652174, 1.65, 0.22222222222222
82030, 1.4608695652174, 1.65, 0.16666666666667
82031, 1.4608695652174, 1.65, 0.11111111111111
82032, 1.4608695652174, 1.65, 0.055555555555556
82033, 1.504347826087, 1.65, 0.44444444444444
82034, 1.504347826087, 1.65, 0.38888888888889
82035, 1.504347826087, 1.65, 0.33333333333333
82036, 1.504347826087, 1.65, 0.27777777777778
82037, 1.504347826087, 1.65, 0.22222222222222
82038, 1.504347826087, 1.65, 0.16666666666667
82039, 1.504347826087, 1.65, 0.11111111111111
82040, 1.504347826087, 1.65, 0.055555555555556
82041, 1.5478260869565, 1.65, 0.44444444444444
82042, 1.5478260869565, 1.65, 0.38888888888889
82043, 1.5478260869565, 1.65, 0.33333333333333
82044, 1.5478260869565, 1.65, 0.27777777777778
82045, 1.5478260869565, 1.65, 0.22222222222222
82046, 1.5478260869565, 1.65, 0.16666666666667
82047, 1.5478260869565, 1.65, 0.11111111111111
82048, 1.5478260869565, 1.65, 0.055555555555556
82049, 1.5913043478261, 1.65, 0.44444444444444
82050, 1.5913043478261, 1.65, 0.38888888888889
82051, 1.5913043478261, 1.65, 0.33333333333333
82052, 1.5913043478261, 1.65, 0.27777777777778
82053, 1.5913043478261, 1.65, 0.22222222222222
82054, 1.5913043478261, 1.65, 0.16666666666667
82055, 1.5913043478261, 1.65, 0.11111111111111
82056, 1.5913043478261, 1.65, 0.055555555555556
82057, 1.6347826086957, 1.65, 0.44444444444444
82058, 1.6347826086957, 1.65, 0.38888888888889
82059, 1.6347826086957, 1.65, 0.33333333333333
82060, 1.6347826086957, 1.65, 0.27777777777778
82061, 1.6347826086957, 1.65, 0.22222222222222
82062, 1.6347826086957, 1.65, 0.16666666666667
82063, 1.6347826086957, 1.65, 0.11111111111111
82064, 1.6347826086957, 1.65, 0.055555555555556
82065, 1.6782608695652, 1.65, 0.44444444444444
82066, 1.6782608695652, 1.65, 0.38888888888889
82067, 1.6782608695652, 1.65, 0.33333333333333
82068, 1.6782608695652, 1.65, 0.27777777777778
82069, 1.6782608695652, 1.65, 0.22222222222222
82070, 1.6782608695652, 1.65, 0.16666666666667
82071, 1.6782608695652, 1.65, 0.11111111111111
82072, 1.6782608695652, 1.65, 0.055555555555556
82073, 1.7217391304348, 1.65, 0.44444444444444
82074, 1.7217391304348, 1.65, 0.38888888888889
82075, 1.7217391304348, 1.65, 0.33333333333333
82076, 1.7217391304348, 1.65, 0.27777777777778
82077, 1.7217391304348, 1.65, 0.22222222222222
82078, 1.7217391304348, 1.65, 0.16666666666667
82079, 1.7217391304348, 1.65, 0.11111111111111
82080, 1.7217391304348, 1.65, 0.055555555555556
82081, 1.7652173913043, 1.65, 0.44444444444444
82082, 1.7652173913043, 1.65, 0.38888888888889
82083, 1.7652173913043, 1.65, 0.33333333333333
82084, 1.7652173913043, 1.65, 0.27777777777778
82085, 1.7652173913043, 1.65, 0.22222222222222
82086, 1.7652173913043, 1.65, 0.16666666666667
82087, 1.7652173913043, 1.65, 0.11111111111111
82088, 1.7652173913043, 1.65, 0.055555555555556
82089, 1.8086956521739, 1.65, 0.44444444444444
82090, 1.8086956521739, 1.65, 0.38888888888889
82091, 1.8086956521739, 1.65, 0.33333333333333
82092, 1.8086956521739, 1.65, 0.27777777777778
82093, 1.8086956521739, 1.65, 0.22222222222222
82094, 1.8086956521739, 1.65, 0.16666666666667
82095, 1.8086956521739, 1.65, 0.11111111111111
82096, 1.8086956521739, 1.65, 0.055555555555556
82097, 1.8521739130435, 1.65, 0.44444444444444
82098, 1.8521739130435, 1.65, 0.38888888888889
82099, 1.8521739130435, 1.65, 0.33333333333333
82100, 1.8521739130435, 1.65, 0.27777777777778
82101, 1.8521739130435, 1.65, 0.22222222222222
82102, 1.8521739130435, 1.65, 0.16666666666667
82103, 1.8521739130435, 1.65, 0.11111111111111
82104, 1.8521739130435, 1.65, 0.055555555555556
82105, 1.895652173913, 1.65, 0.44444444444444
82106, 1.895652173913, 1.65, 0.38888888888889
82107, 1.895652173913, 1.65, 0.33333333333333
82108, 1.895652173913, 1.65, 0.27777777777778
82109, 1.895652173913, 1.65, 0.22222222222222
82110, 1.895652173913, 1.65, 0.16666666666667
82111, 1.895652173913, 1.65, 0.11111111111111
82112, 1.895652173913, 1.65, 0.055555555555556
82113, 1.9391304347826, 1.65, 0.44444444444444
82114, 1.9391304347826, 1.65, 0.38888888888889
82115, 1.9391304347826, 1.65, 0.33333333333333
82116, 1.9391304347826, 1.65, 0.27777777777778
82117, 1.9391304347826, 1.65, 0.22222222222222
82118, 1.9391304347826, 1.65, 0.16666666666667
82119, 1.9391304347826, 1.65, 0.11111111111111
82120, 1.9391304347826, 1.65, 0.055555555555556
82121, 1.9826086956522, 1.65, 0.44444444444444
82122, 1.9826086956522, 1.65, 0.38888888888889
82123, 1.9826086956522, 1.65, 0.33333333333333
82124, 1.9826086956522, 1.65, 0.27777777777778
82125, 1.9826086956522, 1.65, 0.22222222222222
82126, 1.9826086956522, 1.65, 0.16666666666667
82127, 1.9826086956522, 1.65, 0.11111111111111
82128, 1.9826086956522, 1.65, 0.055555555555556
82129, 2.0260869565217, 1.65, 0.44444444444444
82130, 2.0260869565217, 1.65, 0.38888888888889
82131, 2.0260869565217, 1.65, 0.33333333333333
82132, 2.0260869565217, 1.65, 0.27777777777778
82133, 2.0260869565217, 1.65, 0.22222222222222
82134, 2.0260869565217, 1.65, 0.16666666666667
82135, 2.0260869565217, 1.65, 0.11111111111111
82136, 2.0260869565217, 1.65, 0.055555555555556
82137, 2.0695652173913, 1.65, 0.44444444444444
82138, 2.0695652173913, 1.65, 0.38888888888889
82139, 2.0695652173913, 1.65, 0.33333333333333
82140, 2.0695652173913, 1.65, 0.27777777777778
82141, 2.0695652173913, 1.65, 0.22222222222222
82142, 2.0695652173913, 1.65, 0.16666666666667
82143, 2.0695652173913, 1.65, 0.11111111111111
82144, 2.0695652173913, 1.65, 0.055555555555556
82145, 2.1130434782609, 1.65, 0.44444444444444
82146, 2.1130434782609, 1.65, 0.38888888888889
82147, 2.1130434782609, 1.65, 0.33333333333333
82148, 2.1130434782609, 1.65, 0.27777777777778
82149, 2.1130434782609, 1.65, 0.22222222222222
82150, 2.1130434782609, 1.65, 0.16666666666667
82151, 2.1130434782609, 1.65, 0.11111111111111
82152, 2.1130434782609, 1.65, 0.055555555555556
82153, 2.1565217391304, 1.65, 0.44444444444444
82154, 2.1565217391304, 1.65, 0.38888888888889
82155, 2.1565217391304, 1.65, 0.33333333333333
82156, 2.1565217391304, 1.65, 0.27777777777778
82157, 2.1565217391304, 1.65, 0.22222222222222
82158, 2.1565217391304, 1.65, 0.16666666666667
82159, 2.1565217391304, 1.65, 0.11111111111111
82160, 2.1565217391304, 1.65, 0.055555555555556
82161, 1.2434782608696, 1.7, 0.44444444444444
82162, 1.2434782608696, 1.7, 0.38888888888889
82163, 1.2434782608696, 1.7, 0.33333333333333
82164, 1.2434782608696, 1.7, 0.27777777777778
82165, 1.2434782608696, 1.7, 0.22222222222222
82166, 1.2434782608696, 1.7, 0.16666666666667
82167, 1.2434782608696, 1.7, 0.11111111111111
82168, 1.2434782608696, 1.7, 0.055555555555556
82169, 1.2869565217391, 1.7, 0.44444444444444
82170, 1.2869565217391, 1.7, 0.38888888888889
82171, 1.2869565217391, 1.7, 0.33333333333333
82172, 1.2869565217391, 1.7, 0.27777777777778
82173, 1.2869565217391, 1.7, 0.22222222222222
82174, 1.2869565217391, 1.7, 0.16666666666667
82175, 1.2869565217391, 1.7, 0.11111111111111
82176, 1.2869565217391, 1.7, 0.055555555555556
82177, 1.3304347826087, 1.7, 0.44444444444444
82178, 1.3304347826087, 1.7, 0.38888888888889
82179, 1.3304347826087, 1.7, 0.33333333333333
82180, 1.3304347826087, 1.7, 0.27777777777778
82181, 1.3304347826087, 1.7, 0.22222222222222
82182, 1.3304347826087, 1.7, 0.16666666666667
82183, 1.3304347826087, 1.7, 0.11111111111111
82184, 1.3304347826087, 1.7, 0.055555555555556
82185, 1.3739130434783, 1.7, 0.44444444444444
82186, 1.3739130434783, 1.7, 0.38888888888889
82187, 1.3739130434783, 1.7, 0.33333333333333
82188, 1.3739130434783, 1.7, 0.27777777777778
82189, 1.3739130434783, 1.7, 0.22222222222222
82190, 1.3739130434783, 1.7, 0.16666666666667
82191, 1.3739130434783, 1.7, 0.11111111111111
82192, 1.3739130434783, 1.7, 0.055555555555556
82193, 1.4173913043478, 1.7, 0.44444444444444
82194, 1.4173913043478, 1.7, 0.38888888888889
82195, 1.4173913043478, 1.7, 0.33333333333333
82196, 1.4173913043478, 1.7, 0.27777777777778
82197, 1.4173913043478, 1.7, 0.22222222222222
82198, 1.4173913043478, 1.7, 0.16666666666667
82199, 1.4173913043478, 1.7, 0.11111111111111
82200, 1.4173913043478, 1.7, 0.055555555555556
82201, 1.4608695652174, 1.7, 0.44444444444444
82202, 1.4608695652174, 1.7, 0.38888888888889
82203, 1.4608695652174, 1.7, 0.33333333333333
82204, 1.4608695652174, 1.7, 0.27777777777778
82205, 1.4608695652174, 1.7, 0.22222222222222
82206, 1.4608695652174, 1.7, 0.16666666666667
82207, 1.4608695652174, 1.7, 0.11111111111111
82208, 1.4608695652174, 1.7, 0.055555555555556
82209, 1.504347826087, 1.7, 0.44444444444444
82210, 1.504347826087, 1.7, 0.38888888888889
82211, 1.504347826087, 1.7, 0.33333333333333
82212, 1.504347826087, 1.7, 0.27777777777778
82213, 1.504347826087, 1.7, 0.22222222222222
82214, 1.504347826087, 1.7, 0.16666666666667
82215, 1.504347826087, 1.7, 0.11111111111111
82216, 1.504347826087, 1.7, 0.055555555555556
82217, 1.5478260869565, 1.7, 0.44444444444444
82218, 1.5478260869565, 1.7, 0.38888888888889
82219, 1.5478260869565, 1.7, 0.33333333333333
82220, 1.5478260869565, 1.7, 0.27777777777778
82221, 1.5478260869565, 1.7, 0.22222222222222
82222, 1.5478260869565, 1.7, 0.16666666666667
82223, 1.5478260869565, 1.7, 0.11111111111111
82224, 1.5478260869565, 1.7, 0.055555555555556
82225, 1.5913043478261, 1.7, 0.44444444444444
82226, 1.5913043478261, 1.7, 0.38888888888889
82227, 1.5913043478261, 1.7, 0.33333333333333
82228, 1.5913043478261, 1.7, 0.27777777777778
82229, 1.5913043478261, 1.7, 0.22222222222222
82230, 1.5913043478261, 1.7, 0.16666666666667
82231, 1.5913043478261, 1.7, 0.11111111111111
82232, 1.5913043478261, 1.7, 0.055555555555556
82233, 1.6347826086957, 1.7, 0.44444444444444
82234, 1.6347826086957, 1.7, 0.38888888888889
82235, 1.6347826086957, 1.7, 0.33333333333333
82236, 1.6347826086957, 1.7, 0.27777777777778
82237, 1.6347826086957, 1.7, 0.22222222222222
82238, 1.6347826086957, 1.7, 0.16666666666667
82239, 1.6347826086957, 1.7, 0.11111111111111
82240, 1.6347826086957, 1.7, 0.055555555555556
82241, 1.6782608695652, 1.7, 0.44444444444444
82242, 1.6782608695652, 1.7, 0.38888888888889
82243, 1.6782608695652, 1.7, 0.33333333333333
82244, 1.6782608695652, 1.7, 0.27777777777778
82245, 1.6782608695652, 1.7, 0.22222222222222
82246, 1.6782608695652, 1.7, 0.16666666666667
82247, 1.6782608695652, 1.7, 0.11111111111111
82248, 1.6782608695652, 1.7, 0.055555555555556
82249, 1.7217391304348, 1.7, 0.44444444444444
82250, 1.7217391304348, 1.7, 0.38888888888889
82251, 1.7217391304348, 1.7, 0.33333333333333
82252, 1.7217391304348, 1.7, 0.27777777777778
82253, 1.7217391304348, 1.7, 0.22222222222222
82254, 1.7217391304348, 1.7, 0.16666666666667
82255, 1.7217391304348, 1.7, 0.11111111111111
82256, 1.7217391304348, 1.7, 0.055555555555556
82257, 1.7652173913043, 1.7, 0.44444444444444
82258, 1.7652173913043, 1.7, 0.38888888888889
82259, 1.7652173913043, 1.7, 0.33333333333333
82260, 1.7652173913043, 1.7, 0.27777777777778
82261, 1.7652173913043, 1.7, 0.22222222222222
82262, 1.7652173913043, 1.7, 0.16666666666667
82263, 1.7652173913043, 1.7, 0.11111111111111
82264, 1.7652173913043, 1.7, 0.055555555555556
82265, 1.8086956521739, 1.7, 0.44444444444444
82266, 1.8086956521739, 1.7, 0.38888888888889
82267, 1.8086956521739, 1.7, 0.33333333333333
82268, 1.8086956521739, 1.7, 0.27777777777778
82269, 1.8086956521739, 1.7, 0.22222222222222
82270, 1.8086956521739, 1.7, 0.16666666666667
82271, 1.8086956521739, 1.7, 0.11111111111111
82272, 1.8086956521739, 1.7, 0.055555555555556
82273, 1.8521739130435, 1.7, 0.44444444444444
82274, 1.8521739130435, 1.7, 0.38888888888889
82275, 1.8521739130435, 1.7, 0.33333333333333
82276, 1.8521739130435, 1.7, 0.27777777777778
82277, 1.8521739130435, 1.7, 0.22222222222222
82278, 1.8521739130435, 1.7, 0.16666666666667
82279, 1.8521739130435, 1.7, 0.11111111111111
82280, 1.8521739130435, 1.7, 0.055555555555556
82281, 1.895652173913, 1.7, 0.44444444444444
82282, 1.895652173913, 1.7, 0.38888888888889
82283, 1.895652173913, 1.7, 0.33333333333333
82284, 1.895652173913, 1.7, 0.27777777777778
82285, 1.895652173913, 1.7, 0.22222222222222
82286, 1.895652173913, 1.7, 0.16666666666667
82287, 1.895652173913, 1.7, 0.11111111111111
82288, 1.895652173913, 1.7, 0.055555555555556
82289, 1.9391304347826, 1.7, 0.44444444444444
82290, 1.9391304347826, 1.7, 0.38888888888889
82291, 1.9391304347826, 1.7, 0.33333333333333
82292, 1.9391304347826, 1.7, 0.27777777777778
82293, 1.9391304347826, 1.7, 0.22222222222222
82294, 1.9391304347826, 1.7, 0.16666666666667
82295, 1.9391304347826, 1.7, 0.11111111111111
82296, 1.9391304347826, 1.7, 0.055555555555556
82297, 1.9826086956522, 1.7, 0.44444444444444
82298, 1.9826086956522, 1.7, 0.38888888888889
82299, 1.9826086956522, 1.7, 0.33333333333333
82300, 1.9826086956522, 1.7, 0.27777777777778
82301, 1.9826086956522, 1.7, 0.22222222222222
82302, 1.9826086956522, 1.7, 0.16666666666667
82303, 1.9826086956522, 1.7, 0.11111111111111
82304, 1.9826086956522, 1.7, 0.055555555555556
82305, 2.0260869565217, 1.7, 0.44444444444444
82306, 2.0260869565217, 1.7, 0.38888888888889
82307, 2.0260869565217, 1.7, 0.33333333333333
82308, 2.0260869565217, 1.7, 0.27777777777778
82309, 2.0260869565217, 1.7, 0.22222222222222
82310, 2.0260869565217, 1.7, 0.16666666666667
82311, 2.0260869565217, 1.7, 0.11111111111111
82312, 2.0260869565217, 1.7, 0.055555555555556
82313, 2.0695652173913, 1.7, 0.44444444444444
82314, 2.0695652173913, 1.7, 0.38888888888889
82315, 2.0695652173913, 1.7, 0.33333333333333
82316, 2.0695652173913, 1.7, 0.27777777777778
82317, 2.0695652173913, 1.7, 0.22222222222222
82318, 2.0695652173913, 1.7, 0.16666666666667
82319, 2.0695652173913, 1.7, 0.11111111111111
82320, 2.0695652173913, 1.7, 0.055555555555556
82321, 2.1130434782609, 1.7, 0.44444444444444
82322, 2.1130434782609, 1.7, 0.38888888888889
82323, 2.1130434782609, 1.7, 0.33333333333333
82324, 2.1130434782609, 1.7, 0.27777777777778
82325, 2.1130434782609, 1.7, 0.22222222222222
82326, 2.1130434782609, 1.7, 0.16666666666667
82327, 2.1130434782609, 1.7, 0.11111111111111
82328, 2.1130434782609, 1.7, 0.055555555555556
82329, 2.1565217391304, 1.7, 0.44444444444444
82330, 2.1565217391304, 1.7, 0.38888888888889
82331, 2.1565217391304, 1.7, 0.33333333333333
82332, 2.1565217391304, 1.7, 0.27777777777778
82333, 2.1565217391304, 1.7, 0.22222222222222
82334, 2.1565217391304, 1.7, 0.16666666666667
82335, 2.1565217391304, 1.7, 0.11111111111111
82336, 2.1565217391304, 1.7, 0.055555555555556
82337, 1.2434782608696, 1.6, 0.47222222222222
82338, 1.2217391304348, 1.6, 0.44444444444444
82339, 1.2434782608696, 1.575, 0.44444444444444
82340, 1.2434782608696, 1.6, 0.41666666666667
82341, 1.2217391304348, 1.6, 0.38888888888889
82342, 1.2434782608696, 1.575, 0.38888888888889
82343, 1.2434782608696, 1.6, 0.36111111111111
82344, 1.2217391304348, 1.6, 0.33333333333333
82345, 1.2434782608696, 1.575, 0.33333333333333
82346, 1.2434782608696, 1.6, 0.30555555555556
82347, 1.2217391304348, 1.6, 0.27777777777778
82348, 1.2434782608696, 1.575, 0.27777777777778
82349, 1.2434782608696, 1.6, 0.25
82350, 1.2217391304348, 1.6, 0.22222222222222
82351, 1.2434782608696, 1.575, 0.22222222222222
82352, 1.2434782608696, 1.6, 0.19444444444444
82353, 1.2217391304348, 1.6, 0.16666666666667
82354, 1.2434782608696, 1.575, 0.16666666666667
82355, 1.2434782608696, 1.6, 0.13888888888889
82356, 1.2217391304348, 1.6, 0.11111111111111
82357, 1.2434782608696, 1.575, 0.11111111111111
82358, 1.2434782608696, 1.6, 0.083333333333333
82359, 1.2217391304348, 1.6, 0.055555555555556
82360, 1.2434782608696, 1.575, 0.055555555555556
82361, 1.2434782608696, 1.6, 0.027777777777778
82362, 1.2869565217391, 1.6, 0.47222222222222
82363, 1.2652173913043, 1.6, 0.44444444444444
82364, 1.2869565217391, 1.575, 0.44444444444444
82365, 1.2869565217391, 1.6, 0.41666666666667
82366, 1.2652173913043, 1.6, 0.38888888888889
82367, 1.2869565217391, 1.575, 0.38888888888889
82368, 1.2869565217391, 1.6, 0.36111111111111
82369, 1.2652173913043, 1.6, 0.33333333333333
82370, 1.2869565217391, 1.575, 0.33333333333333
82371, 1.2869565217391, 1.6, 0.30555555555556
82372, 1.2652173913043, 1.6, 0.27777777777778
82373, 1.2869565217391, 1.575, 0.27777777777778
82374, 1.2869565217391, 1.6, 0.25
82375, 1.2652173913043, 1.6, 0.22222222222222
82376, 1.2869565217391, 1.575, 0.22222222222222
82377, 1.2869565217391, 1.6, 0.19444444444444
82378, 1.2652173913043, 1.6, 0.16666666666667
82379, 1.2869565217391, 1.575, 0.16666666666667
82380, 1.2869565217391, 1.6, 0.13888888888889
82381, 1.2652173913043, 1.6, 0.11111111111111
82382, 1.2869565217391, 1.575, 0.11111111111111
82383, 1.2869565217391, 1.6, 0.083333333333333
82384, 1.2652173913043, 1.6, 0.055555555555556
82385, 1.2869565217391, 1.575, 0.055555555555556
82386, 1.2869565217391, 1.6, 0.027777777777778
82387, 1.3304347826087, 1.6, 0.47222222222222
82388, 1.3086956521739, 1.6, 0.44444444444444
82389, 1.3304347826087, 1.575, 0.44444444444444
82390, 1.3304347826087, 1.6, 0.41666666666667
82391, 1.3086956521739, 1.6, 0.38888888888889
82392, 1.3304347826087, 1.575, 0.38888888888889
82393, 1.3304347826087, 1.6, 0.36111111111111
82394, 1.3086956521739, 1.6, 0.33333333333333
82395, 1.3304347826087, 1.575, 0.33333333333333
82396, 1.3304347826087, 1.6, 0.30555555555556
82397, 1.3086956521739, 1.6, 0.27777777777778
82398, 1.3304347826087, 1.575, 0.27777777777778
82399, 1.3304347826087, 1.6, 0.25
82400, 1.3086956521739, 1.6, 0.22222222222222
82401, 1.3304347826087, 1.575, 0.22222222222222
82402, 1.3304347826087, 1.6, 0.19444444444444
82403, 1.3086956521739, 1.6, 0.16666666666667
82404, 1.3304347826087, 1.575, 0.16666666666667
82405, 1.3304347826087, 1.6, 0.13888888888889
82406, 1.3086956521739, 1.6, 0.11111111111111
82407, 1.3304347826087, 1.575, 0.11111111111111
82408, 1.3304347826087, 1.6, 0.083333333333333
82409, 1.3086956521739, 1.6, 0.055555555555556
82410, 1.3304347826087, 1.575, 0.055555555555556
82411, 1.3304347826087, 1.6, 0.027777777777778
82412, 1.3739130434783, 1.6, 0.47222222222222
82413, 1.3521739130435, 1.6, 0.44444444444444
82414, 1.3739130434783, 1.575, 0.44444444444444
82415, 1.3739130434783, 1.6, 0.41666666666667
82416, 1.3521739130435, 1.6, 0.38888888888889
82417, 1.3739130434783, 1.575, 0.38888888888889
82418, 1.3739130434783, 1.6, 0.36111111111111
82419, 1.3521739130435, 1.6, 0.33333333333333
82420, 1.3739130434783, 1.575, 0.33333333333333
82421, 1.3739130434783, 1.6, 0.30555555555556
82422, 1.3521739130435, 1.6, 0.27777777777778
82423, 1.3739130434783, 1.575, 0.27777777777778
82424, 1.3739130434783, 1.6, 0.25
82425, 1.3521739130435, 1.6, 0.22222222222222
82426, 1.3739130434783, 1.575, 0.22222222222222
82427, 1.3739130434783, 1.6, 0.19444444444444
82428, 1.3521739130435, 1.6, 0.16666666666667
82429, 1.3739130434783, 1.575, 0.16666666666667
82430, 1.3739130434783, 1.6, 0.13888888888889
82431, 1.3521739130435, 1.6, 0.11111111111111
82432, 1.3739130434783, 1.575, 0.11111111111111
82433, 1.3739130434783, 1.6, 0.083333333333333
82434, 1.3521739130435, 1.6, 0.055555555555556
82435, 1.3739130434783, 1.575, 0.055555555555556
82436, 1.3739130434783, 1.6, 0.027777777777778
82437, 1.4173913043478, 1.6, 0.47222222222222
82438, 1.395652173913, 1.6, 0.44444444444444
82439, 1.4173913043478, 1.575, 0.44444444444444
82440, 1.4173913043478, 1.6, 0.41666666666667
82441, 1.395652173913, 1.6, 0.38888888888889
82442, 1.4173913043478, 1.575, 0.38888888888889
82443, 1.4173913043478, 1.6, 0.36111111111111
82444, 1.395652173913, 1.6, 0.33333333333333
82445, 1.4173913043478, 1.575, 0.33333333333333
82446, 1.4173913043478, 1.6, 0.30555555555556
82447, 1.395652173913, 1.6, 0.27777777777778
82448, 1.4173913043478, 1.575, 0.27777777777778
82449, 1.4173913043478, 1.6, 0.25
82450, 1.395652173913, 1.6, 0.22222222222222
82451, 1.4173913043478, 1.575, 0.22222222222222
82452, 1.4173913043478, 1.6, 0.19444444444444
82453, 1.395652173913, 1.6, 0.16666666666667
82454, 1.4173913043478, 1.575, 0.16666666666667
82455, 1.4173913043478, 1.6, 0.13888888888889
82456, 1.395652173913, 1.6, 0.11111111111111
82457, 1.4173913043478, 1.575, 0.11111111111111
82458, 1.4173913043478, 1.6, 0.083333333333333
82459, 1.395652173913, 1.6, 0.055555555555556
82460, 1.4173913043478, 1.575, 0.055555555555556
82461, 1.4173913043478, 1.6, 0.027777777777778
82462, 1.4608695652174, 1.6, 0.47222222222222
82463, 1.4391304347826, 1.6, 0.44444444444444
82464, 1.4608695652174, 1.575, 0.44444444444444
82465, 1.4608695652174, 1.6, 0.41666666666667
82466, 1.4391304347826, 1.6, 0.38888888888889
82467, 1.4608695652174, 1.575, 0.38888888888889
82468, 1.4608695652174, 1.6, 0.36111111111111
82469, 1.4391304347826, 1.6, 0.33333333333333
82470, 1.4608695652174, 1.575, 0.33333333333333
82471, 1.4608695652174, 1.6, 0.30555555555556
82472, 1.4391304347826, 1.6, 0.27777777777778
82473, 1.4608695652174, 1.575, 0.27777777777778
82474, 1.4608695652174, 1.6, 0.25
82475, 1.4391304347826, 1.6, 0.22222222222222
82476, 1.4608695652174, 1.575, 0.22222222222222
82477, 1.4608695652174, 1.6, 0.19444444444444
82478, 1.4391304347826, 1.6, 0.16666666666667
82479, 1.4608695652174, 1.575, 0.16666666666667
82480, 1.4608695652174, 1.6, 0.13888888888889
82481, 1.4391304347826, 1.6, 0.11111111111111
82482, 1.4608695652174, 1.575, 0.11111111111111
82483, 1.4608695652174, 1.6, 0.083333333333333
82484, 1.4391304347826, 1.6, 0.055555555555556
82485, 1.4608695652174, 1.575, 0.055555555555556
82486, 1.4608695652174, 1.6, 0.027777777777778
82487, 1.504347826087, 1.6, 0.47222222222222
82488, 1.4826086956522, 1.6, 0.44444444444444
82489, 1.504347826087, 1.575, 0.44444444444444
82490, 1.504347826087, 1.6, 0.41666666666667
82491, 1.4826086956522, 1.6, 0.38888888888889
82492, 1.504347826087, 1.575, 0.38888888888889
82493, 1.504347826087, 1.6, 0.36111111111111
82494, 1.4826086956522, 1.6, 0.33333333333333
82495, 1.504347826087, 1.575, 0.33333333333333
82496, 1.504347826087, 1.6, 0.30555555555556
82497, 1.4826086956522, 1.6, 0.27777777777778
82498, 1.504347826087, 1.575, 0.27777777777778
82499, 1.504347826087, 1.6, 0.25
82500, 1.4826086956522, 1.6, 0.22222222222222
82501, 1.504347826087, 1.575, 0.22222222222222
82502, 1.504347826087, 1.6, 0.19444444444444
82503, 1.4826086956522, 1.6, 0.16666666666667
82504, 1.504347826087, 1.575, 0.16666666666667
82505, 1.504347826087, 1.6, 0.13888888888889
82506, 1.4826086956522, 1.6, 0.11111111111111
82507, 1.504347826087, 1.575, 0.11111111111111
82508, 1.504347826087, 1.6, 0.083333333333333
82509, 1.4826086956522, 1.6, 0.055555555555556
82510, 1.504347826087, 1.575, 0.055555555555556
82511, 1.504347826087, 1.6, 0.027777777777778
82512, 1.5478260869565, 1.6, 0.47222222222222
82513, 1.5260869565217, 1.6, 0.44444444444444
82514, 1.5478260869565, 1.575, 0.44444444444444
82515, 1.5478260869565, 1.6, 0.41666666666667
82516, 1.5260869565217, 1.6, 0.38888888888889
82517, 1.5478260869565, 1.575, 0.38888888888889
82518, 1.5478260869565, 1.6, 0.36111111111111
82519, 1.5260869565217, 1.6, 0.33333333333333
82520, 1.5478260869565, 1.575, 0.33333333333333
82521, 1.5478260869565, 1.6, 0.30555555555556
82522, 1.5260869565217, 1.6, 0.27777777777778
82523, 1.5478260869565, 1.575, 0.27777777777778
82524, 1.5478260869565, 1.6, 0.25
82525, 1.5260869565217, 1.6, 0.22222222222222
82526, 1.5478260869565, 1.575, 0.22222222222222
82527, 1.5478260869565, 1.6, 0.19444444444444
82528, 1.5260869565217, 1.6, 0.16666666666667
82529, 1.5478260869565, 1.575, 0.16666666666667
82530, 1.5478260869565, 1.6, 0.13888888888889
82531, 1.5260869565217, 1.6, 0.11111111111111
82532, 1.5478260869565, 1.575, 0.11111111111111
82533, 1.5478260869565, 1.6, 0.083333333333333
82534, 1.5260869565217, 1.6, 0.055555555555556
82535, 1.5478260869565, 1.575, 0.055555555555556
82536, 1.5478260869565, 1.6, 0.027777777777778
82537, 1.5913043478261, 1.6, 0.47222222222222
82538, 1.5695652173913, 1.6, 0.44444444444444
82539, 1.5913043478261, 1.575, 0.44444444444444
82540, 1.5913043478261, 1.6, 0.41666666666667
82541, 1.5695652173913, 1.6, 0.38888888888889
82542, 1.5913043478261, 1.575, 0.38888888888889
82543, 1.5913043478261, 1.6, 0.36111111111111
82544, 1.5695652173913, 1.6, 0.33333333333333
82545, 1.5913043478261, 1.575, 0.33333333333333
82546, 1.5913043478261, 1.6, 0.30555555555556
82547, 1.5695652173913, 1.6, 0.27777777777778
82548, 1.5913043478261, 1.575, 0.27777777777778
82549, 1.5913043478261, 1.6, 0.25
82550, 1.5695652173913, 1.6, 0.22222222222222
82551, 1.5913043478261, 1.575, 0.22222222222222
82552, 1.5913043478261, 1.6, 0.19444444444444
82553, 1.5695652173913, 1.6, 0.16666666666667
82554, 1.5913043478261, 1.575, 0.16666666666667
82555, 1.5913043478261, 1.6, 0.13888888888889
82556, 1.5695652173913, 1.6, 0.11111111111111
82557, 1.5913043478261, 1.575, 0.11111111111111
82558, 1.5913043478261, 1.6, 0.083333333333333
82559, 1.5695652173913, 1.6, 0.055555555555556
82560, 1.5913043478261, 1.575, 0.055555555555556
82561, 1.5913043478261, 1.6, 0.027777777777778
82562, 1.6347826086957, 1.6, 0.47222222222222
82563, 1.6130434782609, 1.6, 0.44444444444444
82564, 1.6347826086957, 1.575, 0.44444444444444
82565, 1.6347826086957, 1.6, 0.41666666666667
82566, 1.6130434782609, 1.6, 0.38888888888889
82567, 1.6347826086957, 1.575, 0.38888888888889
82568, 1.6347826086957, 1.6, 0.36111111111111
82569, 1.6130434782609, 1.6, 0.33333333333333
82570, 1.6347826086957, 1.575, 0.33333333333333
82571, 1.6347826086957, 1.6, 0.30555555555556
82572, 1.6130434782609, 1.6, 0.27777777777778
82573, 1.6347826086957, 1.575, 0.27777777777778
82574, 1.6347826086957, 1.6, 0.25
82575, 1.6130434782609, 1.6, 0.22222222222222
82576, 1.6347826086957, 1.575, 0.22222222222222
82577, 1.6347826086957, 1.6, 0.19444444444444
82578, 1.6130434782609, 1.6, 0.16666666666667
82579, 1.6347826086957, 1.575, 0.16666666666667
82580, 1.6347826086957, 1.6, 0.13888888888889
82581, 1.6130434782609, 1.6, 0.11111111111111
82582, 1.6347826086957, 1.575, 0.11111111111111
82583, 1.6347826086957, 1.6, 0.083333333333333
82584, 1.6130434782609, 1.6, 0.055555555555556
82585, 1.6347826086957, 1.575, 0.055555555555556
82586, 1.6347826086957, 1.6, 0.027777777777778
82587, 1.6782608695652, 1.6, 0.47222222222222
82588, 1.6565217391304, 1.6, 0.44444444444444
82589, 1.6782608695652, 1.575, 0.44444444444444
82590, 1.6782608695652, 1.6, 0.41666666666667
82591, 1.6565217391304, 1.6, 0.38888888888889
82592, 1.6782608695652, 1.575, 0.38888888888889
82593, 1.6782608695652, 1.6, 0.36111111111111
82594, 1.6565217391304, 1.6, 0.33333333333333
82595, 1.6782608695652, 1.575, 0.33333333333333
82596, 1.6782608695652, 1.6, 0.30555555555556
82597, 1.6565217391304, 1.6, 0.27777777777778
82598, 1.6782608695652, 1.575, 0.27777777777778
82599, 1.6782608695652, 1.6, 0.25
82600, 1.6565217391304, 1.6, 0.22222222222222
82601, 1.6782608695652, 1.575, 0.22222222222222
82602, 1.6782608695652, 1.6, 0.19444444444444
82603, 1.6565217391304, 1.6, 0.16666666666667
82604, 1.6782608695652, 1.575, 0.16666666666667
82605, 1.6782608695652, 1.6, 0.13888888888889
82606, 1.6565217391304, 1.6, 0.11111111111111
82607, 1.6782608695652, 1.575, 0.11111111111111
82608, 1.6782608695652, 1.6, 0.083333333333333
82609, 1.6565217391304, 1.6, 0.055555555555556
82610, 1.6782608695652, 1.575, 0.055555555555556
82611, 1.6782608695652, 1.6, 0.027777777777778
82612, 1.7217391304348, 1.6, 0.47222222222222
82613, 1.7, 1.6, 0.44444444444444
82614, 1.7217391304348, 1.575, 0.44444444444444
82615, 1.7217391304348, 1.6, 0.41666666666667
82616, 1.7, 1.6, 0.38888888888889
82617, 1.7217391304348, 1.575, 0.38888888888889
82618, 1.7217391304348, 1.6, 0.36111111111111
82619, 1.7, 1.6, 0.33333333333333
82620, 1.7217391304348, 1.575, 0.33333333333333
82621, 1.7217391304348, 1.6, 0.30555555555556
82622, 1.7, 1.6, 0.27777777777778
82623, 1.7217391304348, 1.575, 0.27777777777778
82624, 1.7217391304348, 1.6, 0.25
82625, 1.7, 1.6, 0.22222222222222
82626, 1.7217391304348, 1.575, 0.22222222222222
82627, 1.7217391304348, 1.6, 0.19444444444444
82628, 1.7, 1.6, 0.16666666666667
82629, 1.7217391304348, 1.575, 0.16666666666667
82630, 1.7217391304348, 1.6, 0.13888888888889
82631, 1.7, 1.6, 0.11111111111111
82632, 1.7217391304348, 1.575, 0.11111111111111
82633, 1.7217391304348, 1.6, 0.083333333333333
82634, 1.7, 1.6, 0.055555555555556
82635, 1.7217391304348, 1.575, 0.055555555555556
82636, 1.7217391304348, 1.6, 0.027777777777778
82637, 1.7652173913043, 1.6, 0.47222222222222
82638, 1.7434782608696, 1.6, 0.44444444444444
82639, 1.7652173913043, 1.575, 0.44444444444444
82640, 1.7652173913043, 1.6, 0.41666666666667
82641, 1.7434782608696, 1.6, 0.38888888888889
82642, 1.7652173913043, 1.575, 0.38888888888889
82643, 1.7652173913043, 1.6, 0.36111111111111
82644, 1.7434782608696, 1.6, 0.33333333333333
82645, 1.7652173913043, 1.575, 0.33333333333333
82646, 1.7652173913043, 1.6, 0.30555555555556
82647, 1.7434782608696, 1.6, 0.27777777777778
82648, 1.7652173913043, 1.575, 0.27777777777778
82649, 1.7652173913043, 1.6, 0.25
82650, 1.7434782608696, 1.6, 0.22222222222222
82651, 1.7652173913043, 1.575, 0.22222222222222
82652, 1.7652173913043, 1.6, 0.19444444444444
82653, 1.7434782608696, 1.6, 0.16666666666667
82654, 1.7652173913043, 1.575, 0.16666666666667
82655, 1.7652173913043, 1.6, 0.13888888888889
82656, 1.7434782608696, 1.6, 0.11111111111111
82657, 1.7652173913043, 1.575, 0.11111111111111
82658, 1.7652173913043, 1.6, 0.083333333333333
82659, 1.7434782608696, 1.6, 0.055555555555556
82660, 1.7652173913043, 1.575, 0.055555555555556
82661, 1.7652173913043, 1.6, 0.027777777777778
82662, 1.8086956521739, 1.6, 0.47222222222222
82663, 1.7869565217391, 1.6, 0.44444444444444
82664, 1.8086956521739, 1.575, 0.44444444444444
82665, 1.8086956521739, 1.6, 0.41666666666667
82666, 1.7869565217391, 1.6, 0.38888888888889
82667, 1.8086956521739, 1.575, 0.38888888888889
82668, 1.8086956521739, 1.6, 0.36111111111111
82669, 1.7869565217391, 1.6, 0.33333333333333
82670, 1.8086956521739, 1.575, 0.33333333333333
82671, 1.8086956521739, 1.6, 0.30555555555556
82672, 1.7869565217391, 1.6, 0.27777777777778
82673, 1.8086956521739, 1.575, 0.27777777777778
82674, 1.8086956521739, 1.6, 0.25
82675, 1.7869565217391, 1.6, 0.22222222222222
82676, 1.8086956521739, 1.575, 0.22222222222222
82677, 1.8086956521739, 1.6, 0.19444444444444
82678, 1.7869565217391, 1.6, 0.16666666666667
82679, 1.8086956521739, 1.575, 0.16666666666667
82680, 1.8086956521739, 1.6, 0.13888888888889
82681, 1.7869565217391, 1.6, 0.11111111111111
82682, 1.8086956521739, 1.575, 0.11111111111111
82683, 1.8086956521739, 1.6, 0.083333333333333
82684, 1.7869565217391, 1.6, 0.055555555555556
82685, 1.8086956521739, 1.575, 0.055555555555556
82686, 1.8086956521739, 1.6, 0.027777777777778
82687, 1.8521739130435, 1.6, 0.47222222222222
82688, 1.8304347826087, 1.6, 0.44444444444444
82689, 1.8521739130435, 1.575, 0.44444444444444
82690, 1.8521739130435, 1.6, 0.41666666666667
82691, 1.8304347826087, 1.6, 0.38888888888889
82692, 1.8521739130435, 1.575, 0.38888888888889
82693, 1.8521739130435, 1.6, 0.36111111111111
82694, 1.8304347826087, 1.6, 0.33333333333333
82695, 1.8521739130435, 1.575, 0.33333333333333
82696, 1.8521739130435, 1.6, 0.30555555555556
82697, 1.8304347826087, 1.6, 0.27777777777778
82698, 1.8521739130435, 1.575, 0.27777777777778
82699, 1.8521739130435, 1.6, 0.25
82700, 1.8304347826087, 1.6, 0.22222222222222
82701, 1.8521739130435, 1.575, 0.22222222222222
82702, 1.8521739130435, 1.6, 0.19444444444444
82703, 1.8304347826087, 1.6, 0.16666666666667
82704, 1.8521739130435, 1.575, 0.16666666666667
82705, 1.8521739130435, 1.6, 0.13888888888889
82706, 1.8304347826087, 1.6, 0.11111111111111
82707, 1.8521739130435, 1.575, 0.11111111111111
82708, 1.8521739130435, 1.6, 0.083333333333333
82709, 1.8304347826087, 1.6, 0.055555555555556
82710, 1.8521739130435, 1.575, 0.055555555555556
82711, 1.8521739130435, 1.6, 0.027777777777778
82712, 1.895652173913, 1.6, 0.47222222222222
82713, 1.8739130434783, 1.6, 0.44444444444444
82714, 1.895652173913, 1.575, 0.44444444444444
82715, 1.895652173913, 1.6, 0.41666666666667
82716, 1.8739130434783, 1.6, 0.38888888888889
82717, 1.895652173913, 1.575, 0.38888888888889
82718, 1.895652173913, 1.6, 0.36111111111111
82719, 1.8739130434783, 1.6, 0.33333333333333
82720, 1.895652173913, 1.575, 0.33333333333333
82721, 1.895652173913, 1.6, 0.30555555555556
82722, 1.8739130434783, 1.6, 0.27777777777778
82723, 1.895652173913, 1.575, 0.27777777777778
82724, 1.895652173913, 1.6, 0.25
82725, 1.8739130434783, 1.6, 0.22222222222222
82726, 1.895652173913, 1.575, 0.22222222222222
82727, 1.895652173913, 1.6, 0.19444444444444
82728, 1.8739130434783, 1.6, 0.16666666666667
82729, 1.895652173913, 1.575, 0.16666666666667
82730, 1.895652173913, 1.6, 0.13888888888889
82731, 1.8739130434783, 1.6, 0.11111111111111
82732, 1.895652173913, 1.575, 0.11111111111111
82733, 1.895652173913, 1.6, 0.083333333333333
82734, 1.8739130434783, 1.6, 0.055555555555556
82735, 1.895652173913, 1.575, 0.055555555555556
82736, 1.895652173913, 1.6, 0.027777777777778
82737, 1.9391304347826, 1.6, 0.47222222222222
82738, 1.9173913043478, 1.6, 0.44444444444444
82739, 1.9391304347826, 1.575, 0.44444444444444
82740, 1.9391304347826, 1.6, 0.41666666666667
82741, 1.9173913043478, 1.6, 0.38888888888889
82742, 1.9391304347826, 1.575, 0.38888888888889
82743, 1.9391304347826, 1.6, 0.36111111111111
82744, 1.9173913043478, 1.6, 0.33333333333333
82745, 1.9391304347826, 1.575, 0.33333333333333
82746, 1.9391304347826, 1.6, 0.30555555555556
82747, 1.9173913043478, 1.6, 0.27777777777778
82748, 1.9391304347826, 1.575, 0.27777777777778
82749, 1.9391304347826, 1.6, 0.25
82750, 1.9173913043478, 1.6, 0.22222222222222
82751, 1.9391304347826, 1.575, 0.22222222222222
82752, 1.9391304347826, 1.6, 0.19444444444444
82753, 1.9173913043478, 1.6, 0.16666666666667
82754, 1.9391304347826, 1.575, 0.16666666666667
82755, 1.9391304347826, 1.6, 0.13888888888889
82756, 1.9173913043478, 1.6, 0.11111111111111
82757, 1.9391304347826, 1.575, 0.11111111111111
82758, 1.9391304347826, 1.6, 0.083333333333333
82759, 1.9173913043478, 1.6, 0.055555555555556
82760, 1.9391304347826, 1.575, 0.055555555555556
82761, 1.9391304347826, 1.6, 0.027777777777778
82762, 1.9826086956522, 1.6, 0.47222222222222
82763, 1.9608695652174, 1.6, 0.44444444444444
82764, 1.9826086956522, 1.575, 0.44444444444444
82765, 1.9826086956522, 1.6, 0.41666666666667
82766, 1.9608695652174, 1.6, 0.38888888888889
82767, 1.9826086956522, 1.575, 0.38888888888889
82768, 1.9826086956522, 1.6, 0.36111111111111
82769, 1.9608695652174, 1.6, 0.33333333333333
82770, 1.9826086956522, 1.575, 0.33333333333333
82771, 1.9826086956522, 1.6, 0.30555555555556
82772, 1.9608695652174, 1.6, 0.27777777777778
82773, 1.9826086956522, 1.575, 0.27777777777778
82774, 1.9826086956522, 1.6, 0.25
82775, 1.9608695652174, 1.6, 0.22222222222222
82776, 1.9826086956522, 1.575, 0.22222222222222
82777, 1.9826086956522, 1.6, 0.19444444444444
82778, 1.9608695652174, 1.6, 0.16666666666667
82779, 1.9826086956522, 1.575, 0.16666666666667
82780, 1.9826086956522, 1.6, 0.13888888888889
82781, 1.9608695652174, 1.6, 0.11111111111111
82782, 1.9826086956522, 1.575, 0.11111111111111
82783, 1.9826086956522, 1.6, 0.083333333333333
82784, 1.9608695652174, 1.6, 0.055555555555556
82785, 1.9826086956522, 1.575, 0.055555555555556
82786, 1.9826086956522, 1.6, 0.027777777777778
82787, 2.0260869565217, 1.6, 0.47222222222222
82788, 2.004347826087, 1.6, 0.44444444444444
82789, 2.0260869565217, 1.575, 0.44444444444444
82790, 2.0260869565217, 1.6, 0.41666666666667
82791, 2.004347826087, 1.6, 0.38888888888889
82792, 2.0260869565217, 1.575, 0.38888888888889
82793, 2.0260869565217, 1.6, 0.36111111111111
82794, 2.004347826087, 1.6, 0.33333333333333
82795, 2.0260869565217, 1.575, 0.33333333333333
82796, 2.0260869565217, 1.6, 0.30555555555556
82797, 2.004347826087, 1.6, 0.27777777777778
82798, 2.0260869565217, 1.575, 0.27777777777778
82799, 2.0260869565217, 1.6, 0.25
82800, 2.004347826087, 1.6, 0.22222222222222
82801, 2.0260869565217, 1.575, 0.22222222222222
82802, 2.0260869565217, 1.6, 0.19444444444444
82803, 2.004347826087, 1.6, 0.16666666666667
82804, 2.0260869565217, 1.575, 0.16666666666667
82805, 2.0260869565217, 1.6, 0.13888888888889
82806, 2.004347826087, 1.6, 0.11111111111111
82807, 2.0260869565217, 1.575, 0.11111111111111
82808, 2.0260869565217, 1.6, 0.083333333333333
82809, 2.004347826087, 1.6, 0.055555555555556
82810, 2.0260869565217, 1.575, 0.055555555555556
82811, 2.0260869565217, 1.6, 0.027777777777778
82812, 2.0695652173913, 1.6, 0.47222222222222
82813, 2.0478260869565, 1.6, 0.44444444444444
82814, 2.0695652173913, 1.575, 0.44444444444444
82815, 2.0695652173913, 1.6, 0.41666666666667
82816, 2.0478260869565, 1.6, 0.38888888888889
82817, 2.0695652173913, 1.575, 0.38888888888889
82818, 2.0695652173913, 1.6, 0.36111111111111
82819, 2.0478260869565, 1.6, 0.33333333333333
82820, 2.0695652173913, 1.575, 0.33333333333333
82821, 2.0695652173913, 1.6, 0.30555555555556
82822, 2.0478260869565, 1.6, 0.27777777777778
82823, 2.0695652173913, 1.575, 0.27777777777778
82824, 2.0695652173913, 1.6, 0.25
82825, 2.0478260869565, 1.6, 0.22222222222222
82826, 2.0695652173913, 1.575, 0.22222222222222
82827, 2.0695652173913, 1.6, 0.19444444444444
82828, 2.0478260869565, 1.6, 0.16666666666667
82829, 2.0695652173913, 1.575, 0.16666666666667
82830, 2.0695652173913, 1.6, 0.13888888888889
82831, 2.0478260869565, 1.6, 0.11111111111111
82832, 2.0695652173913, 1.575, 0.11111111111111
82833, 2.0695652173913, 1.6, 0.083333333333333
82834, 2.0478260869565, 1.6, 0.055555555555556
82835, 2.0695652173913, 1.575, 0.055555555555556
82836, 2.0695652173913, 1.6, 0.027777777777778
82837, 2.1130434782609, 1.6, 0.47222222222222
82838, 2.0913043478261, 1.6, 0.44444444444444
82839, 2.1130434782609, 1.575, 0.44444444444444
82840, 2.1130434782609, 1.6, 0.41666666666667
82841, 2.0913043478261, 1.6, 0.38888888888889
82842, 2.1130434782609, 1.575, 0.38888888888889
82843, 2.1130434782609, 1.6, 0.36111111111111
82844, 2.0913043478261, 1.6, 0.33333333333333
82845, 2.1130434782609, 1.575, 0.33333333333333
82846, 2.1130434782609, 1.6, 0.30555555555556
82847, 2.0913043478261, 1.6, 0.27777777777778
82848, 2.1130434782609, 1.575, 0.27777777777778
82849, 2.1130434782609, 1.6, 0.25
82850, 2.0913043478261, 1.6, 0.22222222222222
82851, 2.1130434782609, 1.575, 0.22222222222222
82852, 2.1130434782609, 1.6, 0.19444444444444
82853, 2.0913043478261, 1.6, 0.16666666666667
82854, 2.1130434782609, 1.575, 0.16666666666667
82855, 2.1130434782609, 1.6, 0.13888888888889
82856, 2.0913043478261, 1.6, 0.11111111111111
82857, 2.1130434782609, 1.575, 0.11111111111111
82858, 2.1130434782609, 1.6, 0.083333333333333
82859, 2.0913043478261, 1.6, 0.055555555555556
82860, 2.1130434782609, 1.575, 0.055555555555556
82861, 2.1130434782609, 1.6, 0.027777777777778
82862, 2.1565217391304, 1.6, 0.47222222222222
82863, 2.1347826086957, 1.6, 0.44444444444444
82864, 2.1565217391304, 1.575, 0.44444444444444
82865, 2.1565217391304, 1.6, 0.41666666666667
82866, 2.1347826086957, 1.6, 0.38888888888889
82867, 2.1565217391304, 1.575, 0.38888888888889
82868, 2.1565217391304, 1.6, 0.36111111111111
82869, 2.1347826086957, 1.6, 0.33333333333333
82870, 2.1565217391304, 1.575, 0.33333333333333
82871, 2.1565217391304, 1.6, 0.30555555555556
82872, 2.1347826086957, 1.6, 0.27777777777778
82873, 2.1565217391304, 1.575, 0.27777777777778
82874, 2.1565217391304, 1.6, 0.25
82875, 2.1347826086957, 1.6, 0.22222222222222
82876, 2.1565217391304, 1.575, 0.22222222222222
82877, 2.1565217391304, 1.6, 0.19444444444444
82878, 2.1347826086957, 1.6, 0.16666666666667
82879, 2.1565217391304, 1.575, 0.16666666666667
82880, 2.1565217391304, 1.6, 0.13888888888889
82881, 2.1347826086957, 1.6, 0.11111111111111
82882, 2.1565217391304, 1.575, 0.11111111111111
82883, 2.1565217391304, 1.6, 0.083333333333333
82884, 2.1347826086957, 1.6, 0.055555555555556
82885, 2.1565217391304, 1.575, 0.055555555555556
82886, 2.1565217391304, 1.6, 0.027777777777778
82887, 2.1782608695652, 1.6, 0.44444444444444
82888, 2.1782608695652, 1.6, 0.38888888888889
82889, 2.1782608695652, 1.6, 0.33333333333333
82890, 2.1782608695652, 1.6, 0.27777777777778
82891, 2.1782608695652, 1.6, 0.22222222222222
82892, 2.1782608695652, 1.6, 0.16666666666667
82893, 2.1782608695652, 1.6, 0.11111111111111
82894, 2.1782608695652, 1.6, 0.055555555555556
82895, 1.2434782608696, 1.65, 0.47222222222222
82896, 1.2217391304348, 1.65, 0.44444444444444
82897, 1.2434782608696, 1.625, 0.44444444444444
82898, 1.2434782608696, 1.65, 0.41666666666667
82899, 1.2217391304348, 1.65, 0.38888888888889
82900, 1.2434782608696, 1.625, 0.38888888888889
82901, 1.2434782608696, 1.65, 0.36111111111111
82902, 1.2217391304348, 1.65, 0.33333333333333
82903, 1.2434782608696, 1.625, 0.33333333333333
82904, 1.2434782608696, 1.65, 0.30555555555556
82905, 1.2217391304348, 1.65, 0.27777777777778
82906, 1.2434782608696, 1.625, 0.27777777777778
82907, 1.2434782608696, 1.65, 0.25
82908, 1.2217391304348, 1.65, 0.22222222222222
82909, 1.2434782608696, 1.625, 0.22222222222222
82910, 1.2434782608696, 1.65, 0.19444444444444
82911, 1.2217391304348, 1.65, 0.16666666666667
82912, 1.2434782608696, 1.625, 0.16666666666667
82913, 1.2434782608696, 1.65, 0.13888888888889
82914, 1.2217391304348, 1.65, 0.11111111111111
82915, 1.2434782608696, 1.625, 0.11111111111111
82916, 1.2434782608696, 1.65, 0.083333333333333
82917, 1.2217391304348, 1.65, 0.055555555555556
82918, 1.2434782608696, 1.625, 0.055555555555556
82919, 1.2434782608696, 1.65, 0.027777777777778
82920, 1.2869565217391, 1.65, 0.47222222222222
82921, 1.2652173913043, 1.65, 0.44444444444444
82922, 1.2869565217391, 1.625, 0.44444444444444
82923, 1.2869565217391, 1.65, 0.41666666666667
82924, 1.2652173913043, 1.65, 0.38888888888889
82925, 1.2869565217391, 1.625, 0.38888888888889
82926, 1.2869565217391, 1.65, 0.36111111111111
82927, 1.2652173913043, 1.65, 0.33333333333333
82928, 1.2869565217391, 1.625, 0.33333333333333
82929, 1.2869565217391, 1.65, 0.30555555555556
82930, 1.2652173913043, 1.65, 0.27777777777778
82931, 1.2869565217391, 1.625, 0.27777777777778
82932, 1.2869565217391, 1.65, 0.25
82933, 1.2652173913043, 1.65, 0.22222222222222
82934, 1.2869565217391, 1.625, 0.22222222222222
82935, 1.2869565217391, 1.65, 0.19444444444444
82936, 1.2652173913043, 1.65, 0.16666666666667
82937, 1.2869565217391, 1.625, 0.16666666666667
82938, 1.2869565217391, 1.65, 0.13888888888889
82939, 1.2652173913043, 1.65, 0.11111111111111
82940, 1.2869565217391, 1.625, 0.11111111111111
82941, 1.2869565217391, 1.65, 0.083333333333333
82942, 1.2652173913043, 1.65, 0.055555555555556
82943, 1.2869565217391, 1.625, 0.055555555555556
82944, 1.2869565217391, 1.65, 0.027777777777778
82945, 1.3304347826087, 1.65, 0.47222222222222
82946, 1.3086956521739, 1.65, 0.44444444444444
82947, 1.3304347826087, 1.625, 0.44444444444444
82948, 1.3304347826087, 1.65, 0.41666666666667
82949, 1.3086956521739, 1.65, 0.38888888888889
82950, 1.3304347826087, 1.625, 0.38888888888889
82951, 1.3304347826087, 1.65, 0.36111111111111
82952, 1.3086956521739, 1.65, 0.33333333333333
82953, 1.3304347826087, 1.625, 0.33333333333333
82954, 1.3304347826087, 1.65, 0.30555555555556
82955, 1.3086956521739, 1.65, 0.27777777777778
82956, 1.3304347826087, 1.625, 0.27777777777778
82957, 1.3304347826087, 1.65, 0.25
82958, 1.3086956521739, 1.65, 0.22222222222222
82959, 1.3304347826087, 1.625, 0.22222222222222
82960, 1.3304347826087, 1.65, 0.19444444444444
82961, 1.3086956521739, 1.65, 0.16666666666667
82962, 1.3304347826087, 1.625, 0.16666666666667
82963, 1.3304347826087, 1.65, 0.13888888888889
82964, 1.3086956521739, 1.65, 0.11111111111111
82965, 1.3304347826087, 1.625, 0.11111111111111
82966, 1.3304347826087, 1.65, 0.083333333333333
82967, 1.3086956521739, 1.65, 0.055555555555556
82968, 1.3304347826087, 1.625, 0.055555555555556
82969, 1.3304347826087, 1.65, 0.027777777777778
82970, 1.3739130434783, 1.65, 0.47222222222222
82971, 1.3521739130435, 1.65, 0.44444444444444
82972, 1.3739130434783, 1.625, 0.44444444444444
82973, 1.3739130434783, 1.65, 0.41666666666667
82974, 1.3521739130435, 1.65, 0.38888888888889
82975, 1.3739130434783, 1.625, 0.38888888888889
82976, 1.3739130434783, 1.65, 0.36111111111111
82977, 1.3521739130435, 1.65, 0.33333333333333
82978, 1.3739130434783, 1.625, 0.33333333333333
82979, 1.3739130434783, 1.65, 0.30555555555556
82980, 1.3521739130435, 1.65, 0.27777777777778
82981, 1.3739130434783, 1.625, 0.27777777777778
82982, 1.3739130434783, 1.65, 0.25
82983, 1.3521739130435, 1.65, 0.22222222222222
82984, 1.3739130434783, 1.625, 0.22222222222222
82985, 1.3739130434783, 1.65, 0.19444444444444
82986, 1.3521739130435, 1.65, 0.16666666666667
82987, 1.3739130434783, 1.625, 0.16666666666667
82988, 1.3739130434783, 1.65, 0.13888888888889
82989, 1.3521739130435, 1.65, 0.11111111111111
82990, 1.3739130434783, 1.625, 0.11111111111111
82991, 1.3739130434783, 1.65, 0.083333333333333
82992, 1.3521739130435, 1.65, 0.055555555555556
82993, 1.3739130434783, 1.625, 0.055555555555556
82994, 1.3739130434783, 1.65, 0.027777777777778
82995, 1.4173913043478, 1.65, 0.47222222222222
82996, 1.395652173913, 1.65, 0.44444444444444
82997, 1.4173913043478, 1.625, 0.44444444444444
82998, 1.4173913043478, 1.65, 0.41666666666667
82999, 1.395652173913, 1.65, 0.38888888888889
83000, 1.4173913043478, 1.625, 0.38888888888889
83001, 1.4173913043478, 1.65, 0.36111111111111
83002, 1.395652173913, 1.65, 0.33333333333333
83003, 1.4173913043478, 1.625, 0.33333333333333
83004, 1.4173913043478, 1.65, 0.30555555555556
83005, 1.395652173913, 1.65, 0.27777777777778
83006, 1.4173913043478, 1.625, 0.27777777777778
83007, 1.4173913043478, 1.65, 0.25
83008, 1.395652173913, 1.65, 0.22222222222222
83009, 1.4173913043478, 1.625, 0.22222222222222
83010, 1.4173913043478, 1.65, 0.19444444444444
83011, 1.395652173913, 1.65, 0.16666666666667
83012, 1.4173913043478, 1.625, 0.16666666666667
83013, 1.4173913043478, 1.65, 0.13888888888889
83014, 1.395652173913, 1.65, 0.11111111111111
83015, 1.4173913043478, 1.625, 0.11111111111111
83016, 1.4173913043478, 1.65, 0.083333333333333
83017, 1.395652173913, 1.65, 0.055555555555556
83018, 1.4173913043478, 1.625, 0.055555555555556
83019, 1.4173913043478, 1.65, 0.027777777777778
83020, 1.4608695652174, 1.65, 0.47222222222222
83021, 1.4391304347826, 1.65, 0.44444444444444
83022, 1.4608695652174, 1.625, 0.44444444444444
83023, 1.4608695652174, 1.65, 0.41666666666667
83024, 1.4391304347826, 1.65, 0.38888888888889
83025, 1.4608695652174, 1.625, 0.38888888888889
83026, 1.4608695652174, 1.65, 0.36111111111111
83027, 1.4391304347826, 1.65, 0.33333333333333
83028, 1.4608695652174, 1.625, 0.33333333333333
83029, 1.4608695652174, 1.65, 0.30555555555556
83030, 1.4391304347826, 1.65, 0.27777777777778
83031, 1.4608695652174, 1.625, 0.27777777777778
83032, 1.4608695652174, 1.65, 0.25
83033, 1.4391304347826, 1.65, 0.22222222222222
83034, 1.4608695652174, 1.625, 0.22222222222222
83035, 1.4608695652174, 1.65, 0.19444444444444
83036, 1.4391304347826, 1.65, 0.16666666666667
83037, 1.4608695652174, 1.625, 0.16666666666667
83038, 1.4608695652174, 1.65, 0.13888888888889
83039, 1.4391304347826, 1.65, 0.11111111111111
83040, 1.4608695652174, 1.625, 0.11111111111111
83041, 1.4608695652174, 1.65, 0.083333333333333
83042, 1.4391304347826, 1.65, 0.055555555555556
83043, 1.4608695652174, 1.625, 0.055555555555556
83044, 1.4608695652174, 1.65, 0.027777777777778
83045, 1.504347826087, 1.65, 0.47222222222222
83046, 1.4826086956522, 1.65, 0.44444444444444
83047, 1.504347826087, 1.625, 0.44444444444444
83048, 1.504347826087, 1.65, 0.41666666666667
83049, 1.4826086956522, 1.65, 0.38888888888889
83050, 1.504347826087, 1.625, 0.38888888888889
83051, 1.504347826087, 1.65, 0.36111111111111
83052, 1.4826086956522, 1.65, 0.33333333333333
83053, 1.504347826087, 1.625, 0.33333333333333
83054, 1.504347826087, 1.65, 0.30555555555556
83055, 1.4826086956522, 1.65, 0.27777777777778
83056, 1.504347826087, 1.625, 0.27777777777778
83057, 1.504347826087, 1.65, 0.25
83058, 1.4826086956522, 1.65, 0.22222222222222
83059, 1.504347826087, 1.625, 0.22222222222222
83060, 1.504347826087, 1.65, 0.19444444444444
83061, 1.4826086956522, 1.65, 0.16666666666667
83062, 1.504347826087, 1.625, 0.16666666666667
83063, 1.504347826087, 1.65, 0.13888888888889
83064, 1.4826086956522, 1.65, 0.11111111111111
83065, 1.504347826087, 1.625, 0.11111111111111
83066, 1.504347826087, 1.65, 0.083333333333333
83067, 1.4826086956522, 1.65, 0.055555555555556
83068, 1.504347826087, 1.625, 0.055555555555556
83069, 1.504347826087, 1.65, 0.027777777777778
83070, 1.5478260869565, 1.65, 0.47222222222222
83071, 1.5260869565217, 1.65, 0.44444444444444
83072, 1.5478260869565, 1.625, 0.44444444444444
83073, 1.5478260869565, 1.65, 0.41666666666667
83074, 1.5260869565217, 1.65, 0.38888888888889
83075, 1.5478260869565, 1.625, 0.38888888888889
83076, 1.5478260869565, 1.65, 0.36111111111111
83077, 1.5260869565217, 1.65, 0.33333333333333
83078, 1.5478260869565, 1.625, 0.33333333333333
83079, 1.5478260869565, 1.65, 0.30555555555556
83080, 1.5260869565217, 1.65, 0.27777777777778
83081, 1.5478260869565, 1.625, 0.27777777777778
83082, 1.5478260869565, 1.65, 0.25
83083, 1.5260869565217, 1.65, 0.22222222222222
83084, 1.5478260869565, 1.625, 0.22222222222222
83085, 1.5478260869565, 1.65, 0.19444444444444
83086, 1.5260869565217, 1.65, 0.16666666666667
83087, 1.5478260869565, 1.625, 0.16666666666667
83088, 1.5478260869565, 1.65, 0.13888888888889
83089, 1.5260869565217, 1.65, 0.11111111111111
83090, 1.5478260869565, 1.625, 0.11111111111111
83091, 1.5478260869565, 1.65, 0.083333333333333
83092, 1.5260869565217, 1.65, 0.055555555555556
83093, 1.5478260869565, 1.625, 0.055555555555556
83094, 1.5478260869565, 1.65, 0.027777777777778
83095, 1.5913043478261, 1.65, 0.47222222222222
83096, 1.5695652173913, 1.65, 0.44444444444444
83097, 1.5913043478261, 1.625, 0.44444444444444
83098, 1.5913043478261, 1.65, 0.41666666666667
83099, 1.5695652173913, 1.65, 0.38888888888889
83100, 1.5913043478261, 1.625, 0.38888888888889
83101, 1.5913043478261, 1.65, 0.36111111111111
83102, 1.5695652173913, 1.65, 0.33333333333333
83103, 1.5913043478261, 1.625, 0.33333333333333
83104, 1.5913043478261, 1.65, 0.30555555555556
83105, 1.5695652173913, 1.65, 0.27777777777778
83106, 1.5913043478261, 1.625, 0.27777777777778
83107, 1.5913043478261, 1.65, 0.25
83108, 1.5695652173913, 1.65, 0.22222222222222
83109, 1.5913043478261, 1.625, 0.22222222222222
83110, 1.5913043478261, 1.65, 0.19444444444444
83111, 1.5695652173913, 1.65, 0.16666666666667
83112, 1.5913043478261, 1.625, 0.16666666666667
83113, 1.5913043478261, 1.65, 0.13888888888889
83114, 1.5695652173913, 1.65, 0.11111111111111
83115, 1.5913043478261, 1.625, 0.11111111111111
83116, 1.5913043478261, 1.65, 0.083333333333333
83117, 1.5695652173913, 1.65, 0.055555555555556
83118, 1.5913043478261, 1.625, 0.055555555555556
83119, 1.5913043478261, 1.65, 0.027777777777778
83120, 1.6347826086957, 1.65, 0.47222222222222
83121, 1.6130434782609, 1.65, 0.44444444444444
83122, 1.6347826086957, 1.625, 0.44444444444444
83123, 1.6347826086957, 1.65, 0.41666666666667
83124, 1.6130434782609, 1.65, 0.38888888888889
83125, 1.6347826086957, 1.625, 0.38888888888889
83126, 1.6347826086957, 1.65, 0.36111111111111
83127, 1.6130434782609, 1.65, 0.33333333333333
83128, 1.6347826086957, 1.625, 0.33333333333333
83129, 1.6347826086957, 1.65, 0.30555555555556
83130, 1.6130434782609, 1.65, 0.27777777777778
83131, 1.6347826086957, 1.625, 0.27777777777778
83132, 1.6347826086957, 1.65, 0.25
83133, 1.6130434782609, 1.65, 0.22222222222222
83134, 1.6347826086957, 1.625, 0.22222222222222
83135, 1.6347826086957, 1.65, 0.19444444444444
83136, 1.6130434782609, 1.65, 0.16666666666667
83137, 1.6347826086957, 1.625, 0.16666666666667
83138, 1.6347826086957, 1.65, 0.13888888888889
83139, 1.6130434782609, 1.65, 0.11111111111111
83140, 1.6347826086957, 1.625, 0.11111111111111
83141, 1.6347826086957, 1.65, 0.083333333333333
83142, 1.6130434782609, 1.65, 0.055555555555556
83143, 1.6347826086957, 1.625, 0.055555555555556
83144, 1.6347826086957, 1.65, 0.027777777777778
83145, 1.6782608695652, 1.65, 0.47222222222222
83146, 1.6565217391304, 1.65, 0.44444444444444
83147, 1.6782608695652, 1.625, 0.44444444444444
83148, 1.6782608695652, 1.65, 0.41666666666667
83149, 1.6565217391304, 1.65, 0.38888888888889
83150, 1.6782608695652, 1.625, 0.38888888888889
83151, 1.6782608695652, 1.65, 0.36111111111111
83152, 1.6565217391304, 1.65, 0.33333333333333
83153, 1.6782608695652, 1.625, 0.33333333333333
83154, 1.6782608695652, 1.65, 0.30555555555556
83155, 1.6565217391304, 1.65, 0.27777777777778
83156, 1.6782608695652, 1.625, 0.27777777777778
83157, 1.6782608695652, 1.65, 0.25
83158, 1.6565217391304, 1.65, 0.22222222222222
83159, 1.6782608695652, 1.625, 0.22222222222222
83160, 1.6782608695652, 1.65, 0.19444444444444
83161, 1.6565217391304, 1.65, 0.16666666666667
83162, 1.6782608695652, 1.625, 0.16666666666667
83163, 1.6782608695652, 1.65, 0.13888888888889
83164, 1.6565217391304, 1.65, 0.11111111111111
83165, 1.6782608695652, 1.625, 0.11111111111111
83166, 1.6782608695652, 1.65, 0.083333333333333
83167, 1.6565217391304, 1.65, 0.055555555555556
83168, 1.6782608695652, 1.625, 0.055555555555556
83169, 1.6782608695652, 1.65, 0.027777777777778
83170, 1.7217391304348, 1.65, 0.47222222222222
83171, 1.7, 1.65, 0.44444444444444
83172, 1.7217391304348, 1.625, 0.44444444444444
83173, 1.7217391304348, 1.65, 0.41666666666667
83174, 1.7, 1.65, 0.38888888888889
83175, 1.7217391304348, 1.625, 0.38888888888889
83176, 1.7217391304348, 1.65, 0.36111111111111
83177, 1.7, 1.65, 0.33333333333333
83178, 1.7217391304348, 1.625, 0.33333333333333
83179, 1.7217391304348, 1.65, 0.30555555555556
83180, 1.7, 1.65, 0.27777777777778
83181, 1.7217391304348, 1.625, 0.27777777777778
83182, 1.7217391304348, 1.65, 0.25
83183, 1.7, 1.65, 0.22222222222222
83184, 1.7217391304348, 1.625, 0.22222222222222
83185, 1.7217391304348, 1.65, 0.19444444444444
83186, 1.7, 1.65, 0.16666666666667
83187, 1.7217391304348, 1.625, 0.16666666666667
83188, 1.7217391304348, 1.65, 0.13888888888889
83189, 1.7, 1.65, 0.11111111111111
83190, 1.7217391304348, 1.625, 0.11111111111111
83191, 1.7217391304348, 1.65, 0.083333333333333
83192, 1.7, 1.65, 0.055555555555556
83193, 1.7217391304348, 1.625, 0.055555555555556
83194, 1.7217391304348, 1.65, 0.027777777777778
83195, 1.7652173913043, 1.65, 0.47222222222222
83196, 1.7434782608696, 1.65, 0.44444444444444
83197, 1.7652173913043, 1.625, 0.44444444444444
83198, 1.7652173913043, 1.65, 0.41666666666667
83199, 1.7434782608696, 1.65, 0.38888888888889
83200, 1.7652173913043, 1.625, 0.38888888888889
83201, 1.7652173913043, 1.65, 0.36111111111111
83202, 1.7434782608696, 1.65, 0.33333333333333
83203, 1.7652173913043, 1.625, 0.33333333333333
83204, 1.7652173913043, 1.65, 0.30555555555556
83205, 1.7434782608696, 1.65, 0.27777777777778
83206, 1.7652173913043, 1.625, 0.27777777777778
83207, 1.7652173913043, 1.65, 0.25
83208, 1.7434782608696, 1.65, 0.22222222222222
83209, 1.7652173913043, 1.625, 0.22222222222222
83210, 1.7652173913043, 1.65, 0.19444444444444
83211, 1.7434782608696, 1.65, 0.16666666666667
83212, 1.7652173913043, 1.625, 0.16666666666667
83213, 1.7652173913043, 1.65, 0.13888888888889
83214, 1.7434782608696, 1.65, 0.11111111111111
83215, 1.7652173913043, 1.625, 0.11111111111111
83216, 1.7652173913043, 1.65, 0.083333333333333
83217, 1.7434782608696, 1.65, 0.055555555555556
83218, 1.7652173913043, 1.625, 0.055555555555556
83219, 1.7652173913043, 1.65, 0.027777777777778
83220, 1.8086956521739, 1.65, 0.47222222222222
83221, 1.7869565217391, 1.65, 0.44444444444444
83222, 1.8086956521739, 1.625, 0.44444444444444
83223, 1.8086956521739, 1.65, 0.41666666666667
83224, 1.7869565217391, 1.65, 0.38888888888889
83225, 1.8086956521739, 1.625, 0.38888888888889
83226, 1.8086956521739, 1.65, 0.36111111111111
83227, 1.7869565217391, 1.65, 0.33333333333333
83228, 1.8086956521739, 1.625, 0.33333333333333
83229, 1.8086956521739, 1.65, 0.30555555555556
83230, 1.7869565217391, 1.65, 0.27777777777778
83231, 1.8086956521739, 1.625, 0.27777777777778
83232, 1.8086956521739, 1.65, 0.25
83233, 1.7869565217391, 1.65, 0.22222222222222
83234, 1.8086956521739, 1.625, 0.22222222222222
83235, 1.8086956521739, 1.65, 0.19444444444444
83236, 1.7869565217391, 1.65, 0.16666666666667
83237, 1.8086956521739, 1.625, 0.16666666666667
83238, 1.8086956521739, 1.65, 0.13888888888889
83239, 1.7869565217391, 1.65, 0.11111111111111
83240, 1.8086956521739, 1.625, 0.11111111111111
83241, 1.8086956521739, 1.65, 0.083333333333333
83242, 1.7869565217391, 1.65, 0.055555555555556
83243, 1.8086956521739, 1.625, 0.055555555555556
83244, 1.8086956521739, 1.65, 0.027777777777778
83245, 1.8521739130435, 1.65, 0.47222222222222
83246, 1.8304347826087, 1.65, 0.44444444444444
83247, 1.8521739130435, 1.625, 0.44444444444444
83248, 1.8521739130435, 1.65, 0.41666666666667
83249, 1.8304347826087, 1.65, 0.38888888888889
83250, 1.8521739130435, 1.625, 0.38888888888889
83251, 1.8521739130435, 1.65, 0.36111111111111
83252, 1.8304347826087, 1.65, 0.33333333333333
83253, 1.8521739130435, 1.625, 0.33333333333333
83254, 1.8521739130435, 1.65, 0.30555555555556
83255, 1.8304347826087, 1.65, 0.27777777777778
83256, 1.8521739130435, 1.625, 0.27777777777778
83257, 1.8521739130435, 1.65, 0.25
83258, 1.8304347826087, 1.65, 0.22222222222222
83259, 1.8521739130435, 1.625, 0.22222222222222
83260, 1.8521739130435, 1.65, 0.19444444444444
83261, 1.8304347826087, 1.65, 0.16666666666667
83262, 1.8521739130435, 1.625, 0.16666666666667
83263, 1.8521739130435, 1.65, 0.13888888888889
83264, 1.8304347826087, 1.65, 0.11111111111111
83265, 1.8521739130435, 1.625, 0.11111111111111
83266, 1.8521739130435, 1.65, 0.083333333333333
83267, 1.8304347826087, 1.65, 0.055555555555556
83268, 1.8521739130435, 1.625, 0.055555555555556
83269, 1.8521739130435, 1.65, 0.027777777777778
83270, 1.895652173913, 1.65, 0.47222222222222
83271, 1.8739130434783, 1.65, 0.44444444444444
83272, 1.895652173913, 1.625, 0.44444444444444
83273, 1.895652173913, 1.65, 0.41666666666667
83274, 1.8739130434783, 1.65, 0.38888888888889
83275, 1.895652173913, 1.625, 0.38888888888889
83276, 1.895652173913, 1.65, 0.36111111111111
83277, 1.8739130434783, 1.65, 0.33333333333333
83278, 1.895652173913, 1.625, 0.33333333333333
83279, 1.895652173913, 1.65, 0.30555555555556
83280, 1.8739130434783, 1.65, 0.27777777777778
83281, 1.895652173913, 1.625, 0.27777777777778
83282, 1.895652173913, 1.65, 0.25
83283, 1.8739130434783, 1.65, 0.22222222222222
83284, 1.895652173913, 1.625, 0.22222222222222
83285, 1.895652173913, 1.65, 0.19444444444444
83286, 1.8739130434783, 1.65, 0.16666666666667
83287, 1.895652173913, 1.625, 0.16666666666667
83288, 1.895652173913, 1.65, 0.13888888888889
83289, 1.8739130434783, 1.65, 0.11111111111111
83290, 1.895652173913, 1.625, 0.11111111111111
83291, 1.895652173913, 1.65, 0.083333333333333
83292, 1.8739130434783, 1.65, 0.055555555555556
83293, 1.895652173913, 1.625, 0.055555555555556
83294, 1.895652173913, 1.65, 0.027777777777778
83295, 1.9391304347826, 1.65, 0.47222222222222
83296, 1.9173913043478, 1.65, 0.44444444444444
83297, 1.9391304347826, 1.625, 0.44444444444444
83298, 1.9391304347826, 1.65, 0.41666666666667
83299, 1.9173913043478, 1.65, 0.38888888888889
83300, 1.9391304347826, 1.625, 0.38888888888889
83301, 1.9391304347826, 1.65, 0.36111111111111
83302, 1.9173913043478, 1.65, 0.33333333333333
83303, 1.9391304347826, 1.625, 0.33333333333333
83304, 1.9391304347826, 1.65, 0.30555555555556
83305, 1.9173913043478, 1.65, 0.27777777777778
83306, 1.9391304347826, 1.625, 0.27777777777778
83307, 1.9391304347826, 1.65, 0.25
83308, 1.9173913043478, 1.65, 0.22222222222222
83309, 1.9391304347826, 1.625, 0.22222222222222
83310, 1.9391304347826, 1.65, 0.19444444444444
83311, 1.9173913043478, 1.65, 0.16666666666667
83312, 1.9391304347826, 1.625, 0.16666666666667
83313, 1.9391304347826, 1.65, 0.13888888888889
83314, 1.9173913043478, 1.65, 0.11111111111111
83315, 1.9391304347826, 1.625, 0.11111111111111
83316, 1.9391304347826, 1.65, 0.083333333333333
83317, 1.9173913043478, 1.65, 0.055555555555556
83318, 1.9391304347826, 1.625, 0.055555555555556
83319, 1.9391304347826, 1.65, 0.027777777777778
83320, 1.9826086956522, 1.65, 0.47222222222222
83321, 1.9608695652174, 1.65, 0.44444444444444
83322, 1.9826086956522, 1.625, 0.44444444444444
83323, 1.9826086956522, 1.65, 0.41666666666667
83324, 1.9608695652174, 1.65, 0.38888888888889
83325, 1.9826086956522, 1.625, 0.38888888888889
83326, 1.9826086956522, 1.65, 0.36111111111111
83327, 1.9608695652174, 1.65, 0.33333333333333
83328, 1.9826086956522, 1.625, 0.33333333333333
83329, 1.9826086956522, 1.65, 0.30555555555556
83330, 1.9608695652174, 1.65, 0.27777777777778
83331, 1.9826086956522, 1.625, 0.27777777777778
83332, 1.9826086956522, 1.65, 0.25
83333, 1.9608695652174, 1.65, 0.22222222222222
83334, 1.9826086956522, 1.625, 0.22222222222222
83335, 1.9826086956522, 1.65, 0.19444444444444
83336, 1.9608695652174, 1.65, 0.16666666666667
83337, 1.9826086956522, 1.625, 0.16666666666667
83338, 1.9826086956522, 1.65, 0.13888888888889
83339, 1.9608695652174, 1.65, 0.11111111111111
83340, 1.9826086956522, 1.625, 0.11111111111111
83341, 1.9826086956522, 1.65, 0.083333333333333
83342, 1.9608695652174, 1.65, 0.055555555555556
83343, 1.9826086956522, 1.625, 0.055555555555556
83344, 1.9826086956522, 1.65, 0.027777777777778
83345, 2.0260869565217, 1.65, 0.47222222222222
83346, 2.004347826087, 1.65, 0.44444444444444
83347, 2.0260869565217, 1.625, 0.44444444444444
83348, 2.0260869565217, 1.65, 0.41666666666667
83349, 2.004347826087, 1.65, 0.38888888888889
83350, 2.0260869565217, 1.625, 0.38888888888889
83351, 2.0260869565217, 1.65, 0.36111111111111
83352, 2.004347826087, 1.65, 0.33333333333333
83353, 2.0260869565217, 1.625, 0.33333333333333
83354, 2.0260869565217, 1.65, 0.30555555555556
83355, 2.004347826087, 1.65, 0.27777777777778
83356, 2.0260869565217, 1.625, 0.27777777777778
83357, 2.0260869565217, 1.65, 0.25
83358, 2.004347826087, 1.65, 0.22222222222222
83359, 2.0260869565217, 1.625, 0.22222222222222
83360, 2.0260869565217, 1.65, 0.19444444444444
83361, 2.004347826087, 1.65, 0.16666666666667
83362, 2.0260869565217, 1.625, 0.16666666666667
83363, 2.0260869565217, 1.65, 0.13888888888889
83364, 2.004347826087, 1.65, 0.11111111111111
83365, 2.0260869565217, 1.625, 0.11111111111111
83366, 2.0260869565217, 1.65, 0.083333333333333
83367, 2.004347826087, 1.65, 0.055555555555556
83368, 2.0260869565217, 1.625, 0.055555555555556
83369, 2.0260869565217, 1.65, 0.027777777777778
83370, 2.0695652173913, 1.65, 0.47222222222222
83371, 2.0478260869565, 1.65, 0.44444444444444
83372, 2.0695652173913, 1.625, 0.44444444444444
83373, 2.0695652173913, 1.65, 0.41666666666667
83374, 2.0478260869565, 1.65, 0.38888888888889
83375, 2.0695652173913, 1.625, 0.38888888888889
83376, 2.0695652173913, 1.65, 0.36111111111111
83377, 2.0478260869565, 1.65, 0.33333333333333
83378, 2.0695652173913, 1.625, 0.33333333333333
83379, 2.0695652173913, 1.65, 0.30555555555556
83380, 2.0478260869565, 1.65, 0.27777777777778
83381, 2.0695652173913, 1.625, 0.27777777777778
83382, 2.0695652173913, 1.65, 0.25
83383, 2.0478260869565, 1.65, 0.22222222222222
83384, 2.0695652173913, 1.625, 0.22222222222222
83385, 2.0695652173913, 1.65, 0.19444444444444
83386, 2.0478260869565, 1.65, 0.16666666666667
83387, 2.0695652173913, 1.625, 0.16666666666667
83388, 2.0695652173913, 1.65, 0.13888888888889
83389, 2.0478260869565, 1.65, 0.11111111111111
83390, 2.0695652173913, 1.625, 0.11111111111111
83391, 2.0695652173913, 1.65, 0.083333333333333
83392, 2.0478260869565, 1.65, 0.055555555555556
83393, 2.0695652173913, 1.625, 0.055555555555556
83394, 2.0695652173913, 1.65, 0.027777777777778
83395, 2.1130434782609, 1.65, 0.47222222222222
83396, 2.0913043478261, 1.65, 0.44444444444444
83397, 2.1130434782609, 1.625, 0.44444444444444
83398, 2.1130434782609, 1.65, 0.41666666666667
83399, 2.0913043478261, 1.65, 0.38888888888889
83400, 2.1130434782609, 1.625, 0.38888888888889
83401, 2.1130434782609, 1.65, 0.36111111111111
83402, 2.0913043478261, 1.65, 0.33333333333333
83403, 2.1130434782609, 1.625, 0.33333333333333
83404, 2.1130434782609, 1.65, 0.30555555555556
83405, 2.0913043478261, 1.65, 0.27777777777778
83406, 2.1130434782609, 1.625, 0.27777777777778
83407, 2.1130434782609, 1.65, 0.25
83408, 2.0913043478261, 1.65, 0.22222222222222
83409, 2.1130434782609, 1.625, 0.22222222222222
83410, 2.1130434782609, 1.65, 0.19444444444444
83411, 2.0913043478261, 1.65, 0.16666666666667
83412, 2.1130434782609, 1.625, 0.16666666666667
83413, 2.1130434782609, 1.65, 0.13888888888889
83414, 2.0913043478261, 1.65, 0.11111111111111
83415, 2.1130434782609, 1.625, 0.11111111111111
83416, 2.1130434782609, 1.65, 0.083333333333333
83417, 2.0913043478261, 1.65, 0.055555555555556
83418, 2.1130434782609, 1.625, 0.055555555555556
83419, 2.1130434782609, 1.65, 0.027777777777778
83420, 2.1565217391304, 1.65, 0.47222222222222
83421, 2.1347826086957, 1.65, 0.44444444444444
83422, 2.1565217391304, 1.625, 0.44444444444444
83423, 2.1565217391304, 1.65, 0.41666666666667
83424, 2.1347826086957, 1.65, 0.38888888888889
83425, 2.1565217391304, 1.625, 0.38888888888889
83426, 2.1565217391304, 1.65, 0.36111111111111
83427, 2.1347826086957, 1.65, 0.33333333333333
83428, 2.1565217391304, 1.625, 0.33333333333333
83429, 2.1565217391304, 1.65, 0.30555555555556
83430, 2.1347826086957, 1.65, 0.27777777777778
83431, 2.1565217391304, 1.625, 0.27777777777778
83432, 2.1565217391304, 1.65, 0.25
83433, 2.1347826086957, 1.65, 0.22222222222222
83434, 2.1565217391304, 1.625, 0.22222222222222
83435, 2.1565217391304, 1.65, 0.19444444444444
83436, 2.1347826086957, 1.65, 0.16666666666667
83437, 2.1565217391304, 1.625, 0.16666666666667
83438, 2.1565217391304, 1.65, 0.13888888888889
83439, 2.1347826086957, 1.65, 0.11111111111111
83440, 2.1565217391304, 1.625, 0.11111111111111
83441, 2.1565217391304, 1.65, 0.083333333333333
83442, 2.1347826086957, 1.65, 0.055555555555556
83443, 2.1565217391304, 1.625, 0.055555555555556
83444, 2.1565217391304, 1.65, 0.027777777777778
83445, 2.1782608695652, 1.65, 0.44444444444444
83446, 2.1782608695652, 1.65, 0.38888888888889
83447, 2.1782608695652, 1.65, 0.33333333333333
83448, 2.1782608695652, 1.65, 0.27777777777778
83449, 2.1782608695652, 1.65, 0.22222222222222
83450, 2.1782608695652, 1.65, 0.16666666666667
83451, 2.1782608695652, 1.65, 0.11111111111111
83452, 2.1782608695652, 1.65, 0.055555555555556
83453, 1.2434782608696, 1.7, 0.47222222222222
83454, 1.2217391304348, 1.7, 0.44444444444444
83455, 1.2434782608696, 1.675, 0.44444444444444
83456, 1.2434782608696, 1.7, 0.41666666666667
83457, 1.2217391304348, 1.7, 0.38888888888889
83458, 1.2434782608696, 1.675, 0.38888888888889
83459, 1.2434782608696, 1.7, 0.36111111111111
83460, 1.2217391304348, 1.7, 0.33333333333333
83461, 1.2434782608696, 1.675, 0.33333333333333
83462, 1.2434782608696, 1.7, 0.30555555555556
83463, 1.2217391304348, 1.7, 0.27777777777778
83464, 1.2434782608696, 1.675, 0.27777777777778
83465, 1.2434782608696, 1.7, 0.25
83466, 1.2217391304348, 1.7, 0.22222222222222
83467, 1.2434782608696, 1.675, 0.22222222222222
83468, 1.2434782608696, 1.7, 0.19444444444444
83469, 1.2217391304348, 1.7, 0.16666666666667
83470, 1.2434782608696, 1.675, 0.16666666666667
83471, 1.2434782608696, 1.7, 0.13888888888889
83472, 1.2217391304348, 1.7, 0.11111111111111
83473, 1.2434782608696, 1.675, 0.11111111111111
83474, 1.2434782608696, 1.7, 0.083333333333333
83475, 1.2217391304348, 1.7, 0.055555555555556
83476, 1.2434782608696, 1.675, 0.055555555555556
83477, 1.2434782608696, 1.7, 0.027777777777778
83478, 1.2869565217391, 1.7, 0.47222222222222
83479, 1.2652173913043, 1.7, 0.44444444444444
83480, 1.2869565217391, 1.675, 0.44444444444444
83481, 1.2869565217391, 1.7, 0.41666666666667
83482, 1.2652173913043, 1.7, 0.38888888888889
83483, 1.2869565217391, 1.675, 0.38888888888889
83484, 1.2869565217391, 1.7, 0.36111111111111
83485, 1.2652173913043, 1.7, 0.33333333333333
83486, 1.2869565217391, 1.675, 0.33333333333333
83487, 1.2869565217391, 1.7, 0.30555555555556
83488, 1.2652173913043, 1.7, 0.27777777777778
83489, 1.2869565217391, 1.675, 0.27777777777778
83490, 1.2869565217391, 1.7, 0.25
83491, 1.2652173913043, 1.7, 0.22222222222222
83492, 1.2869565217391, 1.675, 0.22222222222222
83493, 1.2869565217391, 1.7, 0.19444444444444
83494, 1.2652173913043, 1.7, 0.16666666666667
83495, 1.2869565217391, 1.675, 0.16666666666667
83496, 1.2869565217391, 1.7, 0.13888888888889
83497, 1.2652173913043, 1.7, 0.11111111111111
83498, 1.2869565217391, 1.675, 0.11111111111111
83499, 1.2869565217391, 1.7, 0.083333333333333
83500, 1.2652173913043, 1.7, 0.055555555555556
83501, 1.2869565217391, 1.675, 0.055555555555556
83502, 1.2869565217391, 1.7, 0.027777777777778
83503, 1.3304347826087, 1.7, 0.47222222222222
83504, 1.3086956521739, 1.7, 0.44444444444444
83505, 1.3304347826087, 1.675, 0.44444444444444
83506, 1.3304347826087, 1.7, 0.41666666666667
83507, 1.3086956521739, 1.7, 0.38888888888889
83508, 1.3304347826087, 1.675, 0.38888888888889
83509, 1.3304347826087, 1.7, 0.36111111111111
83510, 1.3086956521739, 1.7, 0.33333333333333
83511, 1.3304347826087, 1.675, 0.33333333333333
83512, 1.3304347826087, 1.7, 0.30555555555556
83513, 1.3086956521739, 1.7, 0.27777777777778
83514, 1.3304347826087, 1.675, 0.27777777777778
83515, 1.3304347826087, 1.7, 0.25
83516, 1.3086956521739, 1.7, 0.22222222222222
83517, 1.3304347826087, 1.675, 0.22222222222222
83518, 1.3304347826087, 1.7, 0.19444444444444
83519, 1.3086956521739, 1.7, 0.16666666666667
83520, 1.3304347826087, 1.675, 0.16666666666667
83521, 1.3304347826087, 1.7, 0.13888888888889
83522, 1.3086956521739, 1.7, 0.11111111111111
83523, 1.3304347826087, 1.675, 0.11111111111111
83524, 1.3304347826087, 1.7, 0.083333333333333
83525, 1.3086956521739, 1.7, 0.055555555555556
83526, 1.3304347826087, 1.675, 0.055555555555556
83527, 1.3304347826087, 1.7, 0.027777777777778
83528, 1.3739130434783, 1.7, 0.47222222222222
83529, 1.3521739130435, 1.7, 0.44444444444444
83530, 1.3739130434783, 1.675, 0.44444444444444
83531, 1.3739130434783, 1.7, 0.41666666666667
83532, 1.3521739130435, 1.7, 0.38888888888889
83533, 1.3739130434783, 1.675, 0.38888888888889
83534, 1.3739130434783, 1.7, 0.36111111111111
83535, 1.3521739130435, 1.7, 0.33333333333333
83536, 1.3739130434783, 1.675, 0.33333333333333
83537, 1.3739130434783, 1.7, 0.30555555555556
83538, 1.3521739130435, 1.7, 0.27777777777778
83539, 1.3739130434783, 1.675, 0.27777777777778
83540, 1.3739130434783, 1.7, 0.25
83541, 1.3521739130435, 1.7, 0.22222222222222
83542, 1.3739130434783, 1.675, 0.22222222222222
83543, 1.3739130434783, 1.7, 0.19444444444444
83544, 1.3521739130435, 1.7, 0.16666666666667
83545, 1.3739130434783, 1.675, 0.16666666666667
83546, 1.3739130434783, 1.7, 0.13888888888889
83547, 1.3521739130435, 1.7, 0.11111111111111
83548, 1.3739130434783, 1.675, 0.11111111111111
83549, 1.3739130434783, 1.7, 0.083333333333333
83550, 1.3521739130435, 1.7, 0.055555555555556
83551, 1.3739130434783, 1.675, 0.055555555555556
83552, 1.3739130434783, 1.7, 0.027777777777778
83553, 1.4173913043478, 1.7, 0.47222222222222
83554, 1.395652173913, 1.7, 0.44444444444444
83555, 1.4173913043478, 1.675, 0.44444444444444
83556, 1.4173913043478, 1.7, 0.41666666666667
83557, 1.395652173913, 1.7, 0.38888888888889
83558, 1.4173913043478, 1.675, 0.38888888888889
83559, 1.4173913043478, 1.7, 0.36111111111111
83560, 1.395652173913, 1.7, 0.33333333333333
83561, 1.4173913043478, 1.675, 0.33333333333333
83562, 1.4173913043478, 1.7, 0.30555555555556
83563, 1.395652173913, 1.7, 0.27777777777778
83564, 1.4173913043478, 1.675, 0.27777777777778
83565, 1.4173913043478, 1.7, 0.25
83566, 1.395652173913, 1.7, 0.22222222222222
83567, 1.4173913043478, 1.675, 0.22222222222222
83568, 1.4173913043478, 1.7, 0.19444444444444
83569, 1.395652173913, 1.7, 0.16666666666667
83570, 1.4173913043478, 1.675, 0.16666666666667
83571, 1.4173913043478, 1.7, 0.13888888888889
83572, 1.395652173913, 1.7, 0.11111111111111
83573, 1.4173913043478, 1.675, 0.11111111111111
83574, 1.4173913043478, 1.7, 0.083333333333333
83575, 1.395652173913, 1.7, 0.055555555555556
83576, 1.4173913043478, 1.675, 0.055555555555556
83577, 1.4173913043478, 1.7, 0.027777777777778
83578, 1.4608695652174, 1.7, 0.47222222222222
83579, 1.4391304347826, 1.7, 0.44444444444444
83580, 1.4608695652174, 1.675, 0.44444444444444
83581, 1.4608695652174, 1.7, 0.41666666666667
83582, 1.4391304347826, 1.7, 0.38888888888889
83583, 1.4608695652174, 1.675, 0.38888888888889
83584, 1.4608695652174, 1.7, 0.36111111111111
83585, 1.4391304347826, 1.7, 0.33333333333333
83586, 1.4608695652174, 1.675, 0.33333333333333
83587, 1.4608695652174, 1.7, 0.30555555555556
83588, 1.4391304347826, 1.7, 0.27777777777778
83589, 1.4608695652174, 1.675, 0.27777777777778
83590, 1.4608695652174, 1.7, 0.25
83591, 1.4391304347826, 1.7, 0.22222222222222
83592, 1.4608695652174, 1.675, 0.22222222222222
83593, 1.4608695652174, 1.7, 0.19444444444444
83594, 1.4391304347826, 1.7, 0.16666666666667
83595, 1.4608695652174, 1.675, 0.16666666666667
83596, 1.4608695652174, 1.7, 0.13888888888889
83597, 1.4391304347826, 1.7, 0.11111111111111
83598, 1.4608695652174, 1.675, 0.11111111111111
83599, 1.4608695652174, 1.7, 0.083333333333333
83600, 1.4391304347826, 1.7, 0.055555555555556
83601, 1.4608695652174, 1.675, 0.055555555555556
83602, 1.4608695652174, 1.7, 0.027777777777778
83603, 1.504347826087, 1.7, 0.47222222222222
83604, 1.4826086956522, 1.7, 0.44444444444444
83605, 1.504347826087, 1.675, 0.44444444444444
83606, 1.504347826087, 1.7, 0.41666666666667
83607, 1.4826086956522, 1.7, 0.38888888888889
83608, 1.504347826087, 1.675, 0.38888888888889
83609, 1.504347826087, 1.7, 0.36111111111111
83610, 1.4826086956522, 1.7, 0.33333333333333
83611, 1.504347826087, 1.675, 0.33333333333333
