100400, 2.0260869565217, 1.245652173913, -0.1
100401, 2.0695652173913, 1.245652173913, -0.1
100402, 2.1130434782609, 1.245652173913, -0.1
100403, 2.1565217391304, 1.245652173913, -0.1
100404, 1.2434782608696, 1.1934782608696, -0.1
100405, 1.2869565217391, 1.1934782608696, -0.1
100406, 1.3304347826087, 1.1934782608696, -0.1
100407, 1.3739130434783, 1.1934782608696, -0.1
100408, 1.4173913043478, 1.1934782608696, -0.1
100409, 1.4608695652174, 1.1934782608696, -0.1
100410, 1.504347826087, 1.1934782608696, -0.1
100411, 1.5478260869565, 1.1934782608696, -0.1
100412, 1.5913043478261, 1.1934782608696, -0.1
100413, 1.6347826086957, 1.1934782608696, -0.1
100414, 1.6782608695652, 1.1934782608696, -0.1
100415, 1.7217391304348, 1.1934782608696, -0.1
100416, 1.7652173913043, 1.1934782608696, -0.1
100417, 1.8086956521739, 1.1934782608696, -0.1
100418, 1.8521739130435, 1.1934782608696, -0.1
100419, 1.895652173913, 1.1934782608696, -0.1
100420, 1.9391304347826, 1.1934782608696, -0.1
100421, 1.9826086956522, 1.1934782608696, -0.1
100422, 2.0260869565217, 1.1934782608696, -0.1
100423, 2.0695652173913, 1.1934782608696, -0.1
100424, 2.1130434782609, 1.1934782608696, -0.1
100425, 2.1565217391304, 1.1934782608696, -0.1
100426, 1.2434782608696, 1.1413043478261, -0.1
100427, 1.2869565217391, 1.1413043478261, -0.1
100428, 1.3304347826087, 1.1413043478261, -0.1
100429, 1.3739130434783, 1.1413043478261, -0.1
100430, 1.4173913043478, 1.1413043478261, -0.1
100431, 1.4608695652174, 1.1413043478261, -0.1
100432, 1.504347826087, 1.1413043478261, -0.1
100433, 1.5478260869565, 1.1413043478261, -0.1
100434, 1.5913043478261, 1.1413043478261, -0.1
100435, 1.6347826086957, 1.1413043478261, -0.1
100436, 1.6782608695652, 1.1413043478261, -0.1
100437, 1.7217391304348, 1.1413043478261, -0.1
100438, 1.7652173913043, 1.1413043478261, -0.1
100439, 1.8086956521739, 1.1413043478261, -0.1
100440, 1.8521739130435, 1.1413043478261, -0.1
100441, 1.895652173913, 1.1413043478261, -0.1
100442, 1.9391304347826, 1.1413043478261, -0.1
100443, 1.9826086956522, 1.1413043478261, -0.1
100444, 2.0260869565217, 1.1413043478261, -0.1
100445, 2.0695652173913, 1.1413043478261, -0.1
100446, 2.1130434782609, 1.1413043478261, -0.1
100447, 2.1565217391304, 1.1413043478261, -0.1
100448, 1.2434782608696, 1.0891304347826, -0.1
100449, 1.2869565217391, 1.0891304347826, -0.1
100450, 1.3304347826087, 1.0891304347826, -0.1
100451, 1.3739130434783, 1.0891304347826, -0.1
100452, 1.4173913043478, 1.0891304347826, -0.1
100453, 1.4608695652174, 1.0891304347826, -0.1
100454, 1.504347826087, 1.0891304347826, -0.1
100455, 1.5478260869565, 1.0891304347826, -0.1
100456, 1.5913043478261, 1.0891304347826, -0.1
100457, 1.6347826086957, 1.0891304347826, -0.1
100458, 1.6782608695652, 1.0891304347826, -0.1
100459, 1.7217391304348, 1.0891304347826, -0.1
100460, 1.7652173913043, 1.0891304347826, -0.1
100461, 1.8086956521739, 1.0891304347826, -0.1
100462, 1.8521739130435, 1.0891304347826, -0.1
100463, 1.895652173913, 1.0891304347826, -0.1
100464, 1.9391304347826, 1.0891304347826, -0.1
100465, 1.9826086956522, 1.0891304347826, -0.1
100466, 2.0260869565217, 1.0891304347826, -0.1
100467, 2.0695652173913, 1.0891304347826, -0.1
100468, 2.1130434782609, 1.0891304347826, -0.1
100469, 2.1565217391304, 1.0891304347826, -0.1
100470, 1.2434782608696, 1.0369565217391, -0.1
100471, 1.2869565217391, 1.0369565217391, -0.1
100472, 1.3304347826087, 1.0369565217391, -0.1
100473, 1.3739130434783, 1.0369565217391, -0.1
100474, 1.4173913043478, 1.0369565217391, -0.1
100475, 1.4608695652174, 1.0369565217391, -0.1
100476, 1.504347826087, 1.0369565217391, -0.1
100477, 1.5478260869565, 1.0369565217391, -0.1
100478, 1.5913043478261, 1.0369565217391, -0.1
100479, 1.6347826086957, 1.0369565217391, -0.1
100480, 1.6782608695652, 1.0369565217391, -0.1
100481, 1.7217391304348, 1.0369565217391, -0.1
100482, 1.7652173913043, 1.0369565217391, -0.1
100483, 1.8086956521739, 1.0369565217391, -0.1
100484, 1.8521739130435, 1.0369565217391, -0.1
100485, 1.895652173913, 1.0369565217391, -0.1
100486, 1.9391304347826, 1.0369565217391, -0.1
100487, 1.9826086956522, 1.0369565217391, -0.1
100488, 2.0260869565217, 1.0369565217391, -0.1
100489, 2.0695652173913, 1.0369565217391, -0.1
100490, 2.1130434782609, 1.0369565217391, -0.1
100491, 2.1565217391304, 1.0369565217391, -0.1
100492, 1.2434782608696, 0.98478260869565, -0.1
100493, 1.2869565217391, 0.98478260869565, -0.1
100494, 1.3304347826087, 0.98478260869565, -0.1
100495, 1.3739130434783, 0.98478260869565, -0.1
100496, 1.4173913043478, 0.98478260869565, -0.1
100497, 1.4608695652174, 0.98478260869565, -0.1
100498, 1.504347826087, 0.98478260869565, -0.1
100499, 1.5478260869565, 0.98478260869565, -0.1
100500, 1.5913043478261, 0.98478260869565, -0.1
100501, 1.6347826086957, 0.98478260869565, -0.1
100502, 1.6782608695652, 0.98478260869565, -0.1
100503, 1.7217391304348, 0.98478260869565, -0.1
100504, 1.7652173913043, 0.98478260869565, -0.1
100505, 1.8086956521739, 0.98478260869565, -0.1
100506, 1.8521739130435, 0.98478260869565, -0.1
100507, 1.895652173913, 0.98478260869565, -0.1
100508, 1.9391304347826, 0.98478260869565, -0.1
100509, 1.9826086956522, 0.98478260869565, -0.1
100510, 2.0260869565217, 0.98478260869565, -0.1
100511, 2.0695652173913, 0.98478260869565, -0.1
100512, 2.1130434782609, 0.98478260869565, -0.1
100513, 2.1565217391304, 0.98478260869565, -0.1
100514, 1.2434782608696, 0.93260869565217, -0.1
100515, 1.2869565217391, 0.93260869565217, -0.1
100516, 1.3304347826087, 0.93260869565217, -0.1
100517, 1.3739130434783, 0.93260869565217, -0.1
100518, 1.4173913043478, 0.93260869565217, -0.1
100519, 1.4608695652174, 0.93260869565217, -0.1
100520, 1.504347826087, 0.93260869565217, -0.1
100521, 1.5478260869565, 0.93260869565217, -0.1
100522, 1.5913043478261, 0.93260869565217, -0.1
100523, 1.6347826086957, 0.93260869565217, -0.1
100524, 1.6782608695652, 0.93260869565217, -0.1
100525, 1.7217391304348, 0.93260869565217, -0.1
100526, 1.7652173913043, 0.93260869565217, -0.1
100527, 1.8086956521739, 0.93260869565217, -0.1
100528, 1.8521739130435, 0.93260869565218, -0.1
100529, 1.895652173913, 0.93260869565217, -0.1
100530, 1.9391304347826, 0.93260869565218, -0.1
100531, 1.9826086956522, 0.93260869565217, -0.1
100532, 2.0260869565217, 0.93260869565217, -0.1
100533, 2.0695652173913, 0.93260869565217, -0.1
100534, 2.1130434782609, 0.93260869565217, -0.1
100535, 2.1565217391304, 0.93260869565217, -0.1
100536, 1.2434782608696, 0.8804347826087, -0.1
100537, 1.2869565217391, 0.8804347826087, -0.1
100538, 1.3304347826087, 0.8804347826087, -0.1
100539, 1.3739130434783, 0.8804347826087, -0.1
100540, 1.4173913043478, 0.8804347826087, -0.1
100541, 1.4608695652174, 0.8804347826087, -0.1
100542, 1.504347826087, 0.8804347826087, -0.1
100543, 1.5478260869565, 0.8804347826087, -0.1
100544, 1.5913043478261, 0.8804347826087, -0.1
100545, 1.6347826086957, 0.8804347826087, -0.1
100546, 1.6782608695652, 0.8804347826087, -0.1
100547, 1.7217391304348, 0.8804347826087, -0.1
100548, 1.7652173913043, 0.8804347826087, -0.1
100549, 1.8086956521739, 0.8804347826087, -0.1
100550, 1.8521739130435, 0.8804347826087, -0.1
100551, 1.895652173913, 0.8804347826087, -0.1
100552, 1.9391304347826, 0.8804347826087, -0.1
100553, 1.9826086956522, 0.8804347826087, -0.1
100554, 2.0260869565217, 0.8804347826087, -0.1
100555, 2.0695652173913, 0.8804347826087, -0.1
100556, 2.1130434782609, 0.8804347826087, -0.1
100557, 2.1565217391304, 0.8804347826087, -0.1
100558, 1.2434782608696, 0.82826086956522, -0.1
100559, 1.2869565217391, 0.82826086956522, -0.1
100560, 1.3304347826087, 0.82826086956522, -0.1
100561, 1.3739130434783, 0.82826086956522, -0.1
100562, 1.4173913043478, 0.82826086956522, -0.1
100563, 1.4608695652174, 0.82826086956522, -0.1
100564, 1.504347826087, 0.82826086956522, -0.1
100565, 1.5478260869565, 0.82826086956522, -0.1
100566, 1.5913043478261, 0.82826086956522, -0.1
100567, 1.6347826086957, 0.82826086956522, -0.1
100568, 1.6782608695652, 0.82826086956522, -0.1
100569, 1.7217391304348, 0.82826086956522, -0.1
100570, 1.7652173913043, 0.82826086956522, -0.1
100571, 1.8086956521739, 0.82826086956522, -0.1
100572, 1.8521739130435, 0.82826086956522, -0.1
100573, 1.895652173913, 0.82826086956522, -0.1
100574, 1.9391304347826, 0.82826086956522, -0.1
100575, 1.9826086956522, 0.82826086956522, -0.1
100576, 2.0260869565217, 0.82826086956522, -0.1
100577, 2.0695652173913, 0.82826086956522, -0.1
100578, 2.1130434782609, 0.82826086956522, -0.1
100579, 2.1565217391304, 0.82826086956522, -0.1
100580, 1.2434782608696, 0.77608695652174, -0.1
100581, 1.2869565217391, 0.77608695652174, -0.1
100582, 1.3304347826087, 0.77608695652174, -0.1
100583, 1.3739130434783, 0.77608695652174, -0.1
100584, 1.4173913043478, 0.77608695652174, -0.1
100585, 1.4608695652174, 0.77608695652174, -0.1
100586, 1.504347826087, 0.77608695652174, -0.1
100587, 1.5478260869565, 0.77608695652174, -0.1
100588, 1.5913043478261, 0.77608695652174, -0.1
100589, 1.6347826086957, 0.77608695652174, -0.1
100590, 1.6782608695652, 0.77608695652174, -0.1
100591, 1.7217391304348, 0.77608695652174, -0.1
100592, 1.7652173913043, 0.77608695652174, -0.1
100593, 1.8086956521739, 0.77608695652174, -0.1
100594, 1.8521739130435, 0.77608695652174, -0.1
100595, 1.895652173913, 0.77608695652174, -0.1
100596, 1.9391304347826, 0.77608695652174, -0.1
100597, 1.9826086956522, 0.77608695652174, -0.1
100598, 2.0260869565217, 0.77608695652174, -0.1
100599, 2.0695652173913, 0.77608695652174, -0.1
100600, 2.1130434782609, 0.77608695652174, -0.1
100601, 2.1565217391304, 0.77608695652174, -0.1
100602, 1.2434782608696, 0.72391304347826, -0.1
100603, 1.2869565217391, 0.72391304347826, -0.1
100604, 1.3304347826087, 0.72391304347826, -0.1
100605, 1.3739130434783, 0.72391304347826, -0.1
100606, 1.4173913043478, 0.72391304347826, -0.1
100607, 1.4608695652174, 0.72391304347826, -0.1
100608, 1.504347826087, 0.72391304347826, -0.1
100609, 1.5478260869565, 0.72391304347826, -0.1
100610, 1.5913043478261, 0.72391304347826, -0.1
100611, 1.6347826086957, 0.72391304347826, -0.1
100612, 1.6782608695652, 0.72391304347826, -0.1
100613, 1.7217391304348, 0.72391304347826, -0.1
100614, 1.7652173913043, 0.72391304347826, -0.1
100615, 1.8086956521739, 0.72391304347826, -0.1
100616, 1.8521739130435, 0.72391304347826, -0.1
100617, 1.895652173913, 0.72391304347826, -0.1
100618, 1.9391304347826, 0.72391304347826, -0.1
100619, 1.9826086956522, 0.72391304347826, -0.1
100620, 2.0260869565217, 0.72391304347826, -0.1
100621, 2.0695652173913, 0.72391304347826, -0.1
100622, 2.1130434782609, 0.72391304347826, -0.1
100623, 2.1565217391304, 0.72391304347826, -0.1
100624, 1.2434782608696, 0.67173913043478, -0.1
100625, 1.2869565217391, 0.67173913043478, -0.1
100626, 1.3304347826087, 0.67173913043478, -0.1
100627, 1.3739130434783, 0.67173913043478, -0.1
100628, 1.4173913043478, 0.67173913043478, -0.1
100629, 1.4608695652174, 0.67173913043478, -0.1
100630, 1.504347826087, 0.67173913043478, -0.1
100631, 1.5478260869565, 0.67173913043478, -0.1
100632, 1.5913043478261, 0.67173913043478, -0.1
100633, 1.6347826086957, 0.67173913043478, -0.1
100634, 1.6782608695652, 0.67173913043478, -0.1
100635, 1.7217391304348, 0.67173913043478, -0.1
100636, 1.7652173913043, 0.67173913043478, -0.1
100637, 1.8086956521739, 0.67173913043478, -0.1
100638, 1.8521739130435, 0.67173913043478, -0.1
100639, 1.895652173913, 0.67173913043478, -0.1
100640, 1.9391304347826, 0.67173913043478, -0.1
100641, 1.9826086956522, 0.67173913043478, -0.1
100642, 2.0260869565217, 0.67173913043478, -0.1
100643, 2.0695652173913, 0.67173913043478, -0.1
100644, 2.1130434782609, 0.67173913043478, -0.1
100645, 2.1565217391304, 0.67173913043478, -0.1
100646, 1.2434782608696, 0.61956521739131, -0.1
100647, 1.2869565217391, 0.61956521739131, -0.1
100648, 1.3304347826087, 0.61956521739131, -0.1
100649, 1.3739130434783, 0.61956521739131, -0.1
100650, 1.4173913043478, 0.61956521739131, -0.1
100651, 1.4608695652174, 0.6195652173913, -0.1
100652, 1.504347826087, 0.6195652173913, -0.1
100653, 1.5478260869565, 0.6195652173913, -0.1
100654, 1.5913043478261, 0.6195652173913, -0.1
100655, 1.6347826086957, 0.61956521739131, -0.1
100656, 1.6782608695652, 0.61956521739131, -0.1
100657, 1.7217391304348, 0.61956521739131, -0.1
100658, 1.7652173913043, 0.61956521739131, -0.1
100659, 1.8086956521739, 0.61956521739131, -0.1
100660, 1.8521739130435, 0.61956521739131, -0.1
100661, 1.895652173913, 0.61956521739131, -0.1
100662, 1.9391304347826, 0.61956521739131, -0.1
100663, 1.9826086956522, 0.61956521739131, -0.1
100664, 2.0260869565217, 0.6195652173913, -0.1
100665, 2.0695652173913, 0.6195652173913, -0.1
100666, 2.1130434782609, 0.61956521739131, -0.1
100667, 2.1565217391304, 0.61956521739131, -0.1
100668, 1.2434782608696, 0.56739130434783, -0.1
100669, 1.2869565217391, 0.56739130434783, -0.1
100670, 1.3304347826087, 0.56739130434783, -0.1
100671, 1.3739130434783, 0.56739130434783, -0.1
100672, 1.4173913043478, 0.56739130434783, -0.1
100673, 1.4608695652174, 0.56739130434783, -0.1
100674, 1.504347826087, 0.56739130434783, -0.1
100675, 1.5478260869565, 0.56739130434783, -0.1
100676, 1.5913043478261, 0.56739130434783, -0.1
100677, 1.6347826086957, 0.56739130434783, -0.1
100678, 1.6782608695652, 0.56739130434783, -0.1
100679, 1.7217391304348, 0.56739130434783, -0.1
100680, 1.7652173913043, 0.56739130434783, -0.1
100681, 1.8086956521739, 0.56739130434783, -0.1
100682, 1.8521739130435, 0.56739130434783, -0.1
100683, 1.895652173913, 0.56739130434783, -0.1
100684, 1.9391304347826, 0.56739130434783, -0.1
100685, 1.9826086956522, 0.56739130434783, -0.1
100686, 2.0260869565217, 0.56739130434783, -0.1
100687, 2.0695652173913, 0.56739130434783, -0.1
100688, 2.1130434782609, 0.56739130434783, -0.1
100689, 2.1565217391304, 0.56739130434783, -0.1
100690, 1.2434782608696, 0.51521739130435, -0.1
100691, 1.2869565217391, 0.51521739130435, -0.1
100692, 1.3304347826087, 0.51521739130435, -0.1
100693, 1.3739130434783, 0.51521739130435, -0.1
100694, 1.4173913043478, 0.51521739130435, -0.1
100695, 1.4608695652174, 0.51521739130435, -0.1
100696, 1.504347826087, 0.51521739130435, -0.1
100697, 1.5478260869565, 0.51521739130435, -0.1
100698, 1.5913043478261, 0.51521739130435, -0.1
100699, 1.6347826086957, 0.51521739130435, -0.1
100700, 1.6782608695652, 0.51521739130435, -0.1
100701, 1.7217391304348, 0.51521739130435, -0.1
100702, 1.7652173913043, 0.51521739130435, -0.1
100703, 1.8086956521739, 0.51521739130435, -0.1
100704, 1.8521739130435, 0.51521739130435, -0.1
100705, 1.895652173913, 0.51521739130435, -0.1
100706, 1.9391304347826, 0.51521739130435, -0.1
100707, 1.9826086956522, 0.51521739130435, -0.1
100708, 2.0260869565217, 0.51521739130435, -0.1
100709, 2.0695652173913, 0.51521739130435, -0.1
100710, 2.1130434782609, 0.51521739130435, -0.1
100711, 2.1565217391304, 0.51521739130435, -0.1
100712, 1.2434782608696, 0.46304347826087, -0.1
100713, 1.2869565217391, 0.46304347826087, -0.1
100714, 1.3304347826087, 0.46304347826087, -0.1
100715, 1.3739130434783, 0.46304347826087, -0.1
100716, 1.4173913043478, 0.46304347826087, -0.1
100717, 1.4608695652174, 0.46304347826087, -0.1
100718, 1.504347826087, 0.46304347826087, -0.1
100719, 1.5478260869565, 0.46304347826087, -0.1
100720, 1.5913043478261, 0.46304347826087, -0.1
100721, 1.6347826086957, 0.46304347826087, -0.1
100722, 1.6782608695652, 0.46304347826087, -0.1
100723, 1.7217391304348, 0.46304347826087, -0.1
100724, 1.7652173913043, 0.46304347826087, -0.1
100725, 1.8086956521739, 0.46304347826087, -0.1
100726, 1.8521739130435, 0.46304347826087, -0.1
100727, 1.895652173913, 0.46304347826087, -0.1
100728, 1.9391304347826, 0.46304347826087, -0.1
100729, 1.9826086956522, 0.46304347826087, -0.1
100730, 2.0260869565217, 0.46304347826087, -0.1
100731, 2.0695652173913, 0.46304347826087, -0.1
100732, 2.1130434782609, 0.46304347826087, -0.1
100733, 2.1565217391304, 0.46304347826087, -0.1
100734, 1.2434782608696, 0.41086956521739, -0.1
100735, 1.2869565217391, 0.41086956521739, -0.1
100736, 1.3304347826087, 0.41086956521739, -0.1
100737, 1.3739130434783, 0.41086956521739, -0.1
100738, 1.4173913043478, 0.41086956521739, -0.1
100739, 1.4608695652174, 0.41086956521739, -0.1
100740, 1.504347826087, 0.41086956521739, -0.1
100741, 1.5478260869565, 0.41086956521739, -0.1
100742, 1.5913043478261, 0.41086956521739, -0.1
100743, 1.6347826086957, 0.41086956521739, -0.1
100744, 1.6782608695652, 0.41086956521739, -0.1
100745, 1.7217391304348, 0.41086956521739, -0.1
100746, 1.7652173913043, 0.41086956521739, -0.1
100747, 1.8086956521739, 0.41086956521739, -0.1
100748, 1.8521739130435, 0.41086956521739, -0.1
100749, 1.895652173913, 0.41086956521739, -0.1
100750, 1.9391304347826, 0.41086956521739, -0.1
100751, 1.9826086956522, 0.41086956521739, -0.1
100752, 2.0260869565217, 0.41086956521739, -0.1
100753, 2.0695652173913, 0.41086956521739, -0.1
100754, 2.1130434782609, 0.41086956521739, -0.1
100755, 2.1565217391304, 0.41086956521739, -0.1
100756, 1.2434782608696, 0.35869565217391, -0.1
100757, 1.2869565217391, 0.35869565217391, -0.1
100758, 1.3304347826087, 0.35869565217391, -0.1
100759, 1.3739130434783, 0.35869565217391, -0.1
100760, 1.4173913043478, 0.35869565217391, -0.1
100761, 1.4608695652174, 0.35869565217391, -0.1
100762, 1.504347826087, 0.35869565217391, -0.1
100763, 1.5478260869565, 0.35869565217391, -0.1
100764, 1.5913043478261, 0.35869565217391, -0.1
100765, 1.6347826086957, 0.35869565217391, -0.1
100766, 1.6782608695652, 0.35869565217391, -0.1
100767, 1.7217391304348, 0.35869565217391, -0.1
100768, 1.7652173913043, 0.35869565217391, -0.1
100769, 1.8086956521739, 0.35869565217391, -0.1
100770, 1.8521739130435, 0.35869565217391, -0.1
100771, 1.895652173913, 0.35869565217391, -0.1
100772, 1.9391304347826, 0.35869565217391, -0.1
100773, 1.9826086956522, 0.35869565217391, -0.1
100774, 2.0260869565217, 0.35869565217391, -0.1
100775, 2.0695652173913, 0.35869565217391, -0.1
100776, 2.1130434782609, 0.35869565217391, -0.1
100777, 2.1565217391304, 0.35869565217391, -0.1
100778, 1.2434782608696, 0.30652173913044, -0.1
100779, 1.2869565217391, 0.30652173913043, -0.1
100780, 1.3304347826087, 0.30652173913043, -0.1
100781, 1.3739130434783, 0.30652173913044, -0.1
100782, 1.4173913043478, 0.30652173913044, -0.1
100783, 1.4608695652174, 0.30652173913043, -0.1
100784, 1.504347826087, 0.30652173913044, -0.1
100785, 1.5478260869565, 0.30652173913044, -0.1
100786, 1.5913043478261, 0.30652173913044, -0.1
100787, 1.6347826086957, 0.30652173913043, -0.1
100788, 1.6782608695652, 0.30652173913043, -0.1
100789, 1.7217391304348, 0.30652173913043, -0.1
100790, 1.7652173913043, 0.30652173913043, -0.1
100791, 1.8086956521739, 0.30652173913044, -0.1
100792, 1.8521739130435, 0.30652173913043, -0.1
100793, 1.895652173913, 0.30652173913044, -0.1
100794, 1.9391304347826, 0.30652173913043, -0.1
100795, 1.9826086956522, 0.30652173913044, -0.1
100796, 2.0260869565217, 0.30652173913044, -0.1
100797, 2.0695652173913, 0.30652173913043, -0.1
100798, 2.1130434782609, 0.30652173913043, -0.1
100799, 2.1565217391304, 0.30652173913043, -0.1
100800, 1.2434782608696, 0.25434782608696, -0.1
100801, 1.2869565217391, 0.25434782608696, -0.1
100802, 1.3304347826087, 0.25434782608696, -0.1
100803, 1.3739130434783, 0.25434782608696, -0.1
100804, 1.4173913043478, 0.25434782608696, -0.1
100805, 1.4608695652174, 0.25434782608696, -0.1
100806, 1.504347826087, 0.25434782608696, -0.1
100807, 1.5478260869565, 0.25434782608696, -0.1
100808, 1.5913043478261, 0.25434782608696, -0.1
100809, 1.6347826086957, 0.25434782608696, -0.1
100810, 1.6782608695652, 0.25434782608696, -0.1
100811, 1.7217391304348, 0.25434782608696, -0.1
100812, 1.7652173913043, 0.25434782608696, -0.1
100813, 1.8086956521739, 0.25434782608696, -0.1
100814, 1.8521739130435, 0.25434782608696, -0.1
100815, 1.895652173913, 0.25434782608696, -0.1
100816, 1.9391304347826, 0.25434782608696, -0.1
100817, 1.9826086956522, 0.25434782608696, -0.1
100818, 2.0260869565217, 0.25434782608696, -0.1
100819, 2.0695652173913, 0.25434782608696, -0.1
100820, 2.1130434782609, 0.25434782608696, -0.1
100821, 2.1565217391304, 0.25434782608696, -0.1
100822, 1.2434782608696, 0.20217391304348, -0.1
100823, 1.2869565217391, 0.20217391304348, -0.1
100824, 1.3304347826087, 0.20217391304348, -0.1
100825, 1.3739130434783, 0.20217391304348, -0.1
100826, 1.4173913043478, 0.20217391304348, -0.1
100827, 1.4608695652174, 0.20217391304348, -0.1
100828, 1.504347826087, 0.20217391304348, -0.1
100829, 1.5478260869565, 0.20217391304348, -0.1
100830, 1.5913043478261, 0.20217391304348, -0.1
100831, 1.6347826086957, 0.20217391304348, -0.1
100832, 1.6782608695652, 0.20217391304348, -0.1
100833, 1.7217391304348, 0.20217391304348, -0.1
100834, 1.7652173913043, 0.20217391304348, -0.1
100835, 1.8086956521739, 0.20217391304348, -0.1
100836, 1.8521739130435, 0.20217391304348, -0.1
100837, 1.895652173913, 0.20217391304348, -0.1
100838, 1.9391304347826, 0.20217391304348, -0.1
100839, 1.9826086956522, 0.20217391304348, -0.1
100840, 2.0260869565217, 0.20217391304348, -0.1
100841, 2.0695652173913, 0.20217391304348, -0.1
100842, 2.1130434782609, 0.20217391304348, -0.1
100843, 2.1565217391304, 0.20217391304348, -0.1
100844, 1.2434782608696, 1.2978260869565, -0.15
100845, 1.2869565217391, 1.2978260869565, -0.15
100846, 1.3304347826087, 1.2978260869565, -0.15
100847, 1.3739130434783, 1.2978260869565, -0.15
100848, 1.4173913043478, 1.2978260869565, -0.15
100849, 1.4608695652174, 1.2978260869565, -0.15
100850, 1.504347826087, 1.2978260869565, -0.15
100851, 1.5478260869565, 1.2978260869565, -0.15
100852, 1.5913043478261, 1.2978260869565, -0.15
100853, 1.6347826086957, 1.2978260869565, -0.15
100854, 1.6782608695652, 1.2978260869565, -0.15
100855, 1.7217391304348, 1.2978260869565, -0.15
100856, 1.7652173913043, 1.2978260869565, -0.15
100857, 1.8086956521739, 1.2978260869565, -0.15
100858, 1.8521739130435, 1.2978260869565, -0.15
100859, 1.895652173913, 1.2978260869565, -0.15
100860, 1.9391304347826, 1.2978260869565, -0.15
100861, 1.9826086956522, 1.2978260869565, -0.15
100862, 2.0260869565217, 1.2978260869565, -0.15
100863, 2.0695652173913, 1.2978260869565, -0.15
100864, 2.1130434782609, 1.2978260869565, -0.15
100865, 2.1565217391304, 1.2978260869565, -0.15
100866, 1.2434782608696, 1.245652173913, -0.15
100867, 1.2869565217391, 1.245652173913, -0.15
100868, 1.3304347826087, 1.245652173913, -0.15
100869, 1.3739130434783, 1.245652173913, -0.15
100870, 1.4173913043478, 1.245652173913, -0.15
100871, 1.4608695652174, 1.245652173913, -0.15
100872, 1.504347826087, 1.245652173913, -0.15
100873, 1.5478260869565, 1.245652173913, -0.15
100874, 1.5913043478261, 1.245652173913, -0.15
100875, 1.6347826086957, 1.245652173913, -0.15
100876, 1.6782608695652, 1.245652173913, -0.15
100877, 1.7217391304348, 1.245652173913, -0.15
100878, 1.7652173913043, 1.245652173913, -0.15
100879, 1.8086956521739, 1.245652173913, -0.15
100880, 1.8521739130435, 1.245652173913, -0.15
100881, 1.895652173913, 1.245652173913, -0.15
100882, 1.9391304347826, 1.245652173913, -0.15
100883, 1.9826086956522, 1.245652173913, -0.15
100884, 2.0260869565217, 1.245652173913, -0.15
100885, 2.0695652173913, 1.245652173913, -0.15
100886, 2.1130434782609, 1.245652173913, -0.15
100887, 2.1565217391304, 1.245652173913, -0.15
100888, 1.2434782608696, 1.1934782608696, -0.15
100889, 1.2869565217391, 1.1934782608696, -0.15
100890, 1.3304347826087, 1.1934782608696, -0.15
100891, 1.3739130434783, 1.1934782608696, -0.15
100892, 1.4173913043478, 1.1934782608696, -0.15
100893, 1.4608695652174, 1.1934782608696, -0.15
100894, 1.504347826087, 1.1934782608696, -0.15
100895, 1.5478260869565, 1.1934782608696, -0.15
100896, 1.5913043478261, 1.1934782608696, -0.15
100897, 1.6347826086957, 1.1934782608696, -0.15
100898, 1.6782608695652, 1.1934782608696, -0.15
100899, 1.7217391304348, 1.1934782608696, -0.15
100900, 1.7652173913043, 1.1934782608696, -0.15
100901, 1.8086956521739, 1.1934782608696, -0.15
100902, 1.8521739130435, 1.1934782608696, -0.15
100903, 1.895652173913, 1.1934782608696, -0.15
100904, 1.9391304347826, 1.1934782608696, -0.15
100905, 1.9826086956522, 1.1934782608696, -0.15
100906, 2.0260869565217, 1.1934782608696, -0.15
100907, 2.0695652173913, 1.1934782608696, -0.15
100908, 2.1130434782609, 1.1934782608696, -0.15
100909, 2.1565217391304, 1.1934782608696, -0.15
100910, 1.2434782608696, 1.1413043478261, -0.15
100911, 1.2869565217391, 1.1413043478261, -0.15
100912, 1.3304347826087, 1.1413043478261, -0.15
100913, 1.3739130434783, 1.1413043478261, -0.15
100914, 1.4173913043478, 1.1413043478261, -0.15
100915, 1.4608695652174, 1.1413043478261, -0.15
100916, 1.504347826087, 1.1413043478261, -0.15
100917, 1.5478260869565, 1.1413043478261, -0.15
100918, 1.5913043478261, 1.1413043478261, -0.15
100919, 1.6347826086957, 1.1413043478261, -0.15
100920, 1.6782608695652, 1.1413043478261, -0.15
100921, 1.7217391304348, 1.1413043478261, -0.15
100922, 1.7652173913043, 1.1413043478261, -0.15
100923, 1.8086956521739, 1.1413043478261, -0.15
100924, 1.8521739130435, 1.1413043478261, -0.15
100925, 1.895652173913, 1.1413043478261, -0.15
100926, 1.9391304347826, 1.1413043478261, -0.15
100927, 1.9826086956522, 1.1413043478261, -0.15
100928, 2.0260869565217, 1.1413043478261, -0.15
100929, 2.0695652173913, 1.1413043478261, -0.15
100930, 2.1130434782609, 1.1413043478261, -0.15
100931, 2.1565217391304, 1.1413043478261, -0.15
100932, 1.2434782608696, 1.0891304347826, -0.15
100933, 1.2869565217391, 1.0891304347826, -0.15
100934, 1.3304347826087, 1.0891304347826, -0.15
100935, 1.3739130434783, 1.0891304347826, -0.15
100936, 1.4173913043478, 1.0891304347826, -0.15
100937, 1.4608695652174, 1.0891304347826, -0.15
100938, 1.504347826087, 1.0891304347826, -0.15
100939, 1.5478260869565, 1.0891304347826, -0.15
100940, 1.5913043478261, 1.0891304347826, -0.15
100941, 1.6347826086957, 1.0891304347826, -0.15
100942, 1.6782608695652, 1.0891304347826, -0.15
100943, 1.7217391304348, 1.0891304347826, -0.15
100944, 1.7652173913043, 1.0891304347826, -0.15
100945, 1.8086956521739, 1.0891304347826, -0.15
100946, 1.8521739130435, 1.0891304347826, -0.15
100947, 1.895652173913, 1.0891304347826, -0.15
100948, 1.9391304347826, 1.0891304347826, -0.15
100949, 1.9826086956522, 1.0891304347826, -0.15
100950, 2.0260869565217, 1.0891304347826, -0.15
100951, 2.0695652173913, 1.0891304347826, -0.15
100952, 2.1130434782609, 1.0891304347826, -0.15
100953, 2.1565217391304, 1.0891304347826, -0.15
100954, 1.2434782608696, 1.0369565217391, -0.15
100955, 1.2869565217391, 1.0369565217391, -0.15
100956, 1.3304347826087, 1.0369565217391, -0.15
100957, 1.3739130434783, 1.0369565217391, -0.15
100958, 1.4173913043478, 1.0369565217391, -0.15
100959, 1.4608695652174, 1.0369565217391, -0.15
100960, 1.504347826087, 1.0369565217391, -0.15
100961, 1.5478260869565, 1.0369565217391, -0.15
100962, 1.5913043478261, 1.0369565217391, -0.15
100963, 1.6347826086957, 1.0369565217391, -0.15
100964, 1.6782608695652, 1.0369565217391, -0.15
100965, 1.7217391304348, 1.0369565217391, -0.15
100966, 1.7652173913043, 1.0369565217391, -0.15
100967, 1.8086956521739, 1.0369565217391, -0.15
100968, 1.8521739130435, 1.0369565217391, -0.15
100969, 1.895652173913, 1.0369565217391, -0.15
100970, 1.9391304347826, 1.0369565217391, -0.15
100971, 1.9826086956522, 1.0369565217391, -0.15
100972, 2.0260869565217, 1.0369565217391, -0.15
100973, 2.0695652173913, 1.0369565217391, -0.15
100974, 2.1130434782609, 1.0369565217391, -0.15
100975, 2.1565217391304, 1.0369565217391, -0.15
100976, 1.2434782608696, 0.98478260869565, -0.15
100977, 1.2869565217391, 0.98478260869565, -0.15
100978, 1.3304347826087, 0.98478260869565, -0.15
100979, 1.3739130434783, 0.98478260869565, -0.15
100980, 1.4173913043478, 0.98478260869565, -0.15
100981, 1.4608695652174, 0.98478260869565, -0.15
100982, 1.504347826087, 0.98478260869565, -0.15
100983, 1.5478260869565, 0.98478260869565, -0.15
100984, 1.5913043478261, 0.98478260869565, -0.15
100985, 1.6347826086957, 0.98478260869565, -0.15
100986, 1.6782608695652, 0.98478260869565, -0.15
100987, 1.7217391304348, 0.98478260869565, -0.15
100988, 1.7652173913043, 0.98478260869565, -0.15
100989, 1.8086956521739, 0.98478260869565, -0.15
100990, 1.8521739130435, 0.98478260869565, -0.15
100991, 1.895652173913, 0.98478260869565, -0.15
100992, 1.9391304347826, 0.98478260869565, -0.15
100993, 1.9826086956522, 0.98478260869565, -0.15
100994, 2.0260869565217, 0.98478260869565, -0.15
100995, 2.0695652173913, 0.98478260869565, -0.15
100996, 2.1130434782609, 0.98478260869565, -0.15
100997, 2.1565217391304, 0.98478260869565, -0.15
100998, 1.2434782608696, 0.93260869565217, -0.15
100999, 1.2869565217391, 0.93260869565217, -0.15
101000, 1.3304347826087, 0.93260869565217, -0.15
101001, 1.3739130434783, 0.93260869565217, -0.15
101002, 1.4173913043478, 0.93260869565217, -0.15
101003, 1.4608695652174, 0.93260869565217, -0.15
101004, 1.504347826087, 0.93260869565217, -0.15
101005, 1.5478260869565, 0.93260869565217, -0.15
101006, 1.5913043478261, 0.93260869565217, -0.15
101007, 1.6347826086957, 0.93260869565217, -0.15
101008, 1.6782608695652, 0.93260869565217, -0.15
101009, 1.7217391304348, 0.93260869565217, -0.15
101010, 1.7652173913043, 0.93260869565217, -0.15
101011, 1.8086956521739, 0.93260869565217, -0.15
101012, 1.8521739130435, 0.93260869565218, -0.15
101013, 1.895652173913, 0.93260869565217, -0.15
101014, 1.9391304347826, 0.93260869565218, -0.15
101015, 1.9826086956522, 0.93260869565217, -0.15
101016, 2.0260869565217, 0.93260869565217, -0.15
101017, 2.0695652173913, 0.93260869565217, -0.15
101018, 2.1130434782609, 0.93260869565217, -0.15
101019, 2.1565217391304, 0.93260869565217, -0.15
101020, 1.2434782608696, 0.8804347826087, -0.15
101021, 1.2869565217391, 0.8804347826087, -0.15
101022, 1.3304347826087, 0.8804347826087, -0.15
101023, 1.3739130434783, 0.8804347826087, -0.15
101024, 1.4173913043478, 0.8804347826087, -0.15
101025, 1.4608695652174, 0.8804347826087, -0.15
101026, 1.504347826087, 0.8804347826087, -0.15
101027, 1.5478260869565, 0.8804347826087, -0.15
101028, 1.5913043478261, 0.8804347826087, -0.15
101029, 1.6347826086957, 0.8804347826087, -0.15
101030, 1.6782608695652, 0.8804347826087, -0.15
101031, 1.7217391304348, 0.8804347826087, -0.15
101032, 1.7652173913043, 0.8804347826087, -0.15
101033, 1.8086956521739, 0.8804347826087, -0.15
101034, 1.8521739130435, 0.8804347826087, -0.15
101035, 1.895652173913, 0.8804347826087, -0.15
101036, 1.9391304347826, 0.8804347826087, -0.15
101037, 1.9826086956522, 0.8804347826087, -0.15
101038, 2.0260869565217, 0.8804347826087, -0.15
101039, 2.0695652173913, 0.8804347826087, -0.15
101040, 2.1130434782609, 0.8804347826087, -0.15
101041, 2.1565217391304, 0.8804347826087, -0.15
101042, 1.2434782608696, 0.82826086956522, -0.15
101043, 1.2869565217391, 0.82826086956522, -0.15
101044, 1.3304347826087, 0.82826086956522, -0.15
101045, 1.3739130434783, 0.82826086956522, -0.15
101046, 1.4173913043478, 0.82826086956522, -0.15
101047, 1.4608695652174, 0.82826086956522, -0.15
101048, 1.504347826087, 0.82826086956522, -0.15
101049, 1.5478260869565, 0.82826086956522, -0.15
101050, 1.5913043478261, 0.82826086956522, -0.15
101051, 1.6347826086957, 0.82826086956522, -0.15
101052, 1.6782608695652, 0.82826086956522, -0.15
101053, 1.7217391304348, 0.82826086956522, -0.15
101054, 1.7652173913043, 0.82826086956522, -0.15
101055, 1.8086956521739, 0.82826086956522, -0.15
101056, 1.8521739130435, 0.82826086956522, -0.15
101057, 1.895652173913, 0.82826086956522, -0.15
101058, 1.9391304347826, 0.82826086956522, -0.15
101059, 1.9826086956522, 0.82826086956522, -0.15
101060, 2.0260869565217, 0.82826086956522, -0.15
101061, 2.0695652173913, 0.82826086956522, -0.15
101062, 2.1130434782609, 0.82826086956522, -0.15
101063, 2.1565217391304, 0.82826086956522, -0.15
101064, 1.2434782608696, 0.77608695652174, -0.15
101065, 1.2869565217391, 0.77608695652174, -0.15
101066, 1.3304347826087, 0.77608695652174, -0.15
101067, 1.3739130434783, 0.77608695652174, -0.15
101068, 1.4173913043478, 0.77608695652174, -0.15
101069, 1.4608695652174, 0.77608695652174, -0.15
101070, 1.504347826087, 0.77608695652174, -0.15
101071, 1.5478260869565, 0.77608695652174, -0.15
101072, 1.5913043478261, 0.77608695652174, -0.15
101073, 1.6347826086957, 0.77608695652174, -0.15
101074, 1.6782608695652, 0.77608695652174, -0.15
101075, 1.7217391304348, 0.77608695652174, -0.15
101076, 1.7652173913043, 0.77608695652174, -0.15
101077, 1.8086956521739, 0.77608695652174, -0.15
101078, 1.8521739130435, 0.77608695652174, -0.15
101079, 1.895652173913, 0.77608695652174, -0.15
101080, 1.9391304347826, 0.77608695652174, -0.15
101081, 1.9826086956522, 0.77608695652174, -0.15
101082, 2.0260869565217, 0.77608695652174, -0.15
101083, 2.0695652173913, 0.77608695652174, -0.15
101084, 2.1130434782609, 0.77608695652174, -0.15
101085, 2.1565217391304, 0.77608695652174, -0.15
101086, 1.2434782608696, 0.72391304347826, -0.15
101087, 1.2869565217391, 0.72391304347826, -0.15
101088, 1.3304347826087, 0.72391304347826, -0.15
101089, 1.3739130434783, 0.72391304347826, -0.15
101090, 1.4173913043478, 0.72391304347826, -0.15
101091, 1.4608695652174, 0.72391304347826, -0.15
101092, 1.504347826087, 0.72391304347826, -0.15
101093, 1.5478260869565, 0.72391304347826, -0.15
101094, 1.5913043478261, 0.72391304347826, -0.15
101095, 1.6347826086957, 0.72391304347826, -0.15
101096, 1.6782608695652, 0.72391304347826, -0.15
101097, 1.7217391304348, 0.72391304347826, -0.15
101098, 1.7652173913043, 0.72391304347826, -0.15
101099, 1.8086956521739, 0.72391304347826, -0.15
101100, 1.8521739130435, 0.72391304347826, -0.15
101101, 1.895652173913, 0.72391304347826, -0.15
101102, 1.9391304347826, 0.72391304347826, -0.15
101103, 1.9826086956522, 0.72391304347826, -0.15
101104, 2.0260869565217, 0.72391304347826, -0.15
101105, 2.0695652173913, 0.72391304347826, -0.15
101106, 2.1130434782609, 0.72391304347826, -0.15
101107, 2.1565217391304, 0.72391304347826, -0.15
101108, 1.2434782608696, 0.67173913043478, -0.15
101109, 1.2869565217391, 0.67173913043478, -0.15
101110, 1.3304347826087, 0.67173913043478, -0.15
101111, 1.3739130434783, 0.67173913043478, -0.15
101112, 1.4173913043478, 0.67173913043478, -0.15
101113, 1.4608695652174, 0.67173913043478, -0.15
101114, 1.504347826087, 0.67173913043478, -0.15
101115, 1.5478260869565, 0.67173913043478, -0.15
101116, 1.5913043478261, 0.67173913043478, -0.15
101117, 1.6347826086957, 0.67173913043478, -0.15
101118, 1.6782608695652, 0.67173913043478, -0.15
101119, 1.7217391304348, 0.67173913043478, -0.15
101120, 1.7652173913043, 0.67173913043478, -0.15
101121, 1.8086956521739, 0.67173913043478, -0.15
101122, 1.8521739130435, 0.67173913043478, -0.15
101123, 1.895652173913, 0.67173913043478, -0.15
101124, 1.9391304347826, 0.67173913043478, -0.15
101125, 1.9826086956522, 0.67173913043478, -0.15
101126, 2.0260869565217, 0.67173913043478, -0.15
101127, 2.0695652173913, 0.67173913043478, -0.15
101128, 2.1130434782609, 0.67173913043478, -0.15
101129, 2.1565217391304, 0.67173913043478, -0.15
101130, 1.2434782608696, 0.6195652173913, -0.15
101131, 1.2869565217391, 0.61956521739131, -0.15
101132, 1.3304347826087, 0.61956521739131, -0.15
101133, 1.3739130434783, 0.61956521739131, -0.15
101134, 1.4173913043478, 0.61956521739131, -0.15
101135, 1.4608695652174, 0.61956521739131, -0.15
101136, 1.504347826087, 0.61956521739131, -0.15
101137, 1.5478260869565, 0.61956521739131, -0.15
101138, 1.5913043478261, 0.61956521739131, -0.15
101139, 1.6347826086957, 0.61956521739131, -0.15
101140, 1.6782608695652, 0.61956521739131, -0.15
101141, 1.7217391304348, 0.61956521739131, -0.15
101142, 1.7652173913043, 0.61956521739131, -0.15
101143, 1.8086956521739, 0.61956521739131, -0.15
101144, 1.8521739130435, 0.61956521739131, -0.15
101145, 1.895652173913, 0.61956521739131, -0.15
101146, 1.9391304347826, 0.61956521739131, -0.15
101147, 1.9826086956522, 0.61956521739131, -0.15
101148, 2.0260869565217, 0.61956521739131, -0.15
101149, 2.0695652173913, 0.61956521739131, -0.15
101150, 2.1130434782609, 0.61956521739131, -0.15
101151, 2.1565217391304, 0.61956521739131, -0.15
101152, 1.2434782608696, 0.56739130434783, -0.15
101153, 1.2869565217391, 0.56739130434783, -0.15
101154, 1.3304347826087, 0.56739130434783, -0.15
101155, 1.3739130434783, 0.56739130434783, -0.15
101156, 1.4173913043478, 0.56739130434783, -0.15
101157, 1.4608695652174, 0.56739130434783, -0.15
101158, 1.504347826087, 0.56739130434783, -0.15
101159, 1.5478260869565, 0.56739130434783, -0.15
101160, 1.5913043478261, 0.56739130434783, -0.15
101161, 1.6347826086957, 0.56739130434783, -0.15
101162, 1.6782608695652, 0.56739130434783, -0.15
101163, 1.7217391304348, 0.56739130434783, -0.15
101164, 1.7652173913043, 0.56739130434783, -0.15
101165, 1.8086956521739, 0.56739130434783, -0.15
101166, 1.8521739130435, 0.56739130434783, -0.15
101167, 1.895652173913, 0.56739130434783, -0.15
101168, 1.9391304347826, 0.56739130434783, -0.15
101169, 1.9826086956522, 0.56739130434783, -0.15
101170, 2.0260869565217, 0.56739130434783, -0.15
101171, 2.0695652173913, 0.56739130434783, -0.15
101172, 2.1130434782609, 0.56739130434783, -0.15
101173, 2.1565217391304, 0.56739130434783, -0.15
101174, 1.2434782608696, 0.51521739130435, -0.15
101175, 1.2869565217391, 0.51521739130435, -0.15
101176, 1.3304347826087, 0.51521739130435, -0.15
101177, 1.3739130434783, 0.51521739130435, -0.15
101178, 1.4173913043478, 0.51521739130435, -0.15
101179, 1.4608695652174, 0.51521739130435, -0.15
101180, 1.504347826087, 0.51521739130435, -0.15
101181, 1.5478260869565, 0.51521739130435, -0.15
101182, 1.5913043478261, 0.51521739130435, -0.15
101183, 1.6347826086957, 0.51521739130435, -0.15
101184, 1.6782608695652, 0.51521739130435, -0.15
101185, 1.7217391304348, 0.51521739130435, -0.15
101186, 1.7652173913043, 0.51521739130435, -0.15
101187, 1.8086956521739, 0.51521739130435, -0.15
101188, 1.8521739130435, 0.51521739130435, -0.15
101189, 1.895652173913, 0.51521739130435, -0.15
101190, 1.9391304347826, 0.51521739130435, -0.15
101191, 1.9826086956522, 0.51521739130435, -0.15
101192, 2.0260869565217, 0.51521739130435, -0.15
101193, 2.0695652173913, 0.51521739130435, -0.15
101194, 2.1130434782609, 0.51521739130435, -0.15
101195, 2.1565217391304, 0.51521739130435, -0.15
101196, 1.2434782608696, 0.46304347826087, -0.15
101197, 1.2869565217391, 0.46304347826087, -0.15
101198, 1.3304347826087, 0.46304347826087, -0.15
101199, 1.3739130434783, 0.46304347826087, -0.15
101200, 1.4173913043478, 0.46304347826087, -0.15
101201, 1.4608695652174, 0.46304347826087, -0.15
101202, 1.504347826087, 0.46304347826087, -0.15
101203, 1.5478260869565, 0.46304347826087, -0.15
101204, 1.5913043478261, 0.46304347826087, -0.15
101205, 1.6347826086957, 0.46304347826087, -0.15
101206, 1.6782608695652, 0.46304347826087, -0.15
101207, 1.7217391304348, 0.46304347826087, -0.15
101208, 1.7652173913043, 0.46304347826087, -0.15
101209, 1.8086956521739, 0.46304347826087, -0.15
101210, 1.8521739130435, 0.46304347826087, -0.15
101211, 1.895652173913, 0.46304347826087, -0.15
101212, 1.9391304347826, 0.46304347826087, -0.15
101213, 1.9826086956522, 0.46304347826087, -0.15
101214, 2.0260869565217, 0.46304347826087, -0.15
101215, 2.0695652173913, 0.46304347826087, -0.15
101216, 2.1130434782609, 0.46304347826087, -0.15
101217, 2.1565217391304, 0.46304347826087, -0.15
101218, 1.2434782608696, 0.41086956521739, -0.15
101219, 1.2869565217391, 0.41086956521739, -0.15
101220, 1.3304347826087, 0.41086956521739, -0.15
101221, 1.3739130434783, 0.41086956521739, -0.15
101222, 1.4173913043478, 0.41086956521739, -0.15
101223, 1.4608695652174, 0.41086956521739, -0.15
101224, 1.504347826087, 0.41086956521739, -0.15
101225, 1.5478260869565, 0.41086956521739, -0.15
101226, 1.5913043478261, 0.41086956521739, -0.15
101227, 1.6347826086957, 0.41086956521739, -0.15
101228, 1.6782608695652, 0.41086956521739, -0.15
101229, 1.7217391304348, 0.41086956521739, -0.15
101230, 1.7652173913043, 0.41086956521739, -0.15
101231, 1.8086956521739, 0.41086956521739, -0.15
101232, 1.8521739130435, 0.41086956521739, -0.15
101233, 1.895652173913, 0.41086956521739, -0.15
101234, 1.9391304347826, 0.41086956521739, -0.15
101235, 1.9826086956522, 0.41086956521739, -0.15
101236, 2.0260869565217, 0.41086956521739, -0.15
101237, 2.0695652173913, 0.41086956521739, -0.15
101238, 2.1130434782609, 0.41086956521739, -0.15
101239, 2.1565217391304, 0.41086956521739, -0.15
101240, 1.2434782608696, 0.35869565217391, -0.15
101241, 1.2869565217391, 0.35869565217391, -0.15
101242, 1.3304347826087, 0.35869565217391, -0.15
101243, 1.3739130434783, 0.35869565217391, -0.15
101244, 1.4173913043478, 0.35869565217391, -0.15
101245, 1.4608695652174, 0.35869565217391, -0.15
101246, 1.504347826087, 0.35869565217391, -0.15
101247, 1.5478260869565, 0.35869565217391, -0.15
101248, 1.5913043478261, 0.35869565217391, -0.15
101249, 1.6347826086957, 0.35869565217391, -0.15
101250, 1.6782608695652, 0.35869565217391, -0.15
101251, 1.7217391304348, 0.35869565217391, -0.15
101252, 1.7652173913043, 0.35869565217391, -0.15
101253, 1.8086956521739, 0.35869565217391, -0.15
101254, 1.8521739130435, 0.35869565217391, -0.15
101255, 1.895652173913, 0.35869565217391, -0.15
101256, 1.9391304347826, 0.35869565217391, -0.15
101257, 1.9826086956522, 0.35869565217391, -0.15
101258, 2.0260869565217, 0.35869565217391, -0.15
101259, 2.0695652173913, 0.35869565217391, -0.15
101260, 2.1130434782609, 0.35869565217391, -0.15
101261, 2.1565217391304, 0.35869565217391, -0.15
101262, 1.2434782608696, 0.30652173913044, -0.15
101263, 1.2869565217391, 0.30652173913043, -0.15
101264, 1.3304347826087, 0.30652173913043, -0.15
101265, 1.3739130434783, 0.30652173913044, -0.15
101266, 1.4173913043478, 0.30652173913044, -0.15
101267, 1.4608695652174, 0.30652173913043, -0.15
101268, 1.504347826087, 0.30652173913044, -0.15
101269, 1.5478260869565, 0.30652173913044, -0.15
101270, 1.5913043478261, 0.30652173913044, -0.15
101271, 1.6347826086957, 0.30652173913043, -0.15
101272, 1.6782608695652, 0.30652173913043, -0.15
101273, 1.7217391304348, 0.30652173913043, -0.15
101274, 1.7652173913043, 0.30652173913043, -0.15
101275, 1.8086956521739, 0.30652173913044, -0.15
101276, 1.8521739130435, 0.30652173913043, -0.15
101277, 1.895652173913, 0.30652173913044, -0.15
101278, 1.9391304347826, 0.30652173913043, -0.15
101279, 1.9826086956522, 0.30652173913044, -0.15
101280, 2.0260869565217, 0.30652173913044, -0.15
101281, 2.0695652173913, 0.30652173913043, -0.15
101282, 2.1130434782609, 0.30652173913043, -0.15
101283, 2.1565217391304, 0.30652173913043, -0.15
101284, 1.2434782608696, 0.25434782608696, -0.15
101285, 1.2869565217391, 0.25434782608696, -0.15
101286, 1.3304347826087, 0.25434782608696, -0.15
101287, 1.3739130434783, 0.25434782608696, -0.15
101288, 1.4173913043478, 0.25434782608696, -0.15
101289, 1.4608695652174, 0.25434782608696, -0.15
101290, 1.504347826087, 0.25434782608696, -0.15
101291, 1.5478260869565, 0.25434782608696, -0.15
101292, 1.5913043478261, 0.25434782608696, -0.15
101293, 1.6347826086957, 0.25434782608696, -0.15
101294, 1.6782608695652, 0.25434782608696, -0.15
101295, 1.7217391304348, 0.25434782608696, -0.15
101296, 1.7652173913043, 0.25434782608696, -0.15
101297, 1.8086956521739, 0.25434782608696, -0.15
101298, 1.8521739130435, 0.25434782608696, -0.15
101299, 1.895652173913, 0.25434782608696, -0.15
101300, 1.9391304347826, 0.25434782608696, -0.15
101301, 1.9826086956522, 0.25434782608696, -0.15
101302, 2.0260869565217, 0.25434782608696, -0.15
101303, 2.0695652173913, 0.25434782608696, -0.15
101304, 2.1130434782609, 0.25434782608696, -0.15
101305, 2.1565217391304, 0.25434782608696, -0.15
101306, 1.2434782608696, 0.20217391304348, -0.15
101307, 1.2869565217391, 0.20217391304348, -0.15
101308, 1.3304347826087, 0.20217391304348, -0.15
101309, 1.3739130434783, 0.20217391304348, -0.15
101310, 1.4173913043478, 0.20217391304348, -0.15
101311, 1.4608695652174, 0.20217391304348, -0.15
101312, 1.504347826087, 0.20217391304348, -0.15
101313, 1.5478260869565, 0.20217391304348, -0.15
101314, 1.5913043478261, 0.20217391304348, -0.15
101315, 1.6347826086957, 0.20217391304348, -0.15
101316, 1.6782608695652, 0.20217391304348, -0.15
101317, 1.7217391304348, 0.20217391304348, -0.15
101318, 1.7652173913043, 0.20217391304348, -0.15
101319, 1.8086956521739, 0.20217391304348, -0.15
101320, 1.8521739130435, 0.20217391304348, -0.15
101321, 1.895652173913, 0.20217391304348, -0.15
101322, 1.9391304347826, 0.20217391304348, -0.15
101323, 1.9826086956522, 0.20217391304348, -0.15
101324, 2.0260869565217, 0.20217391304348, -0.15
101325, 2.0695652173913, 0.20217391304348, -0.15
101326, 2.1130434782609, 0.20217391304348, -0.15
101327, 2.1565217391304, 0.20217391304348, -0.15
101328, 1.2217391304348, 1.2978260869565, -0.05
101329, 1.2434782608696, 1.3239130434783, -0.05
101330, 1.2434782608696, 1.2978260869565, -0.025
101331, 1.2652173913043, 1.2978260869565, -0.05
101332, 1.2869565217391, 1.3239130434783, -0.05
101333, 1.2869565217391, 1.2978260869565, -0.025
101334, 1.3086956521739, 1.2978260869565, -0.05
101335, 1.3304347826087, 1.3239130434783, -0.05
101336, 1.3304347826087, 1.2978260869565, -0.025
101337, 1.3521739130435, 1.2978260869565, -0.05
101338, 1.3739130434783, 1.3239130434783, -0.05
101339, 1.3739130434783, 1.2978260869565, -0.025
101340, 1.395652173913, 1.2978260869565, -0.05
101341, 1.4173913043478, 1.3239130434783, -0.05
101342, 1.4173913043478, 1.2978260869565, -0.025
101343, 1.4391304347826, 1.2978260869565, -0.05
101344, 1.4608695652174, 1.3239130434783, -0.05
101345, 1.4608695652174, 1.2978260869565, -0.025
101346, 1.4826086956522, 1.2978260869565, -0.05
101347, 1.504347826087, 1.3239130434783, -0.05
101348, 1.504347826087, 1.2978260869565, -0.025
101349, 1.5260869565217, 1.2978260869565, -0.05
101350, 1.5478260869565, 1.3239130434783, -0.05
101351, 1.5478260869565, 1.2978260869565, -0.025
101352, 1.5695652173913, 1.2978260869565, -0.05
101353, 1.5913043478261, 1.3239130434783, -0.05
101354, 1.5913043478261, 1.2978260869565, -0.025
101355, 1.6130434782609, 1.2978260869565, -0.05
101356, 1.6347826086957, 1.3239130434783, -0.05
101357, 1.6347826086957, 1.2978260869565, -0.025
101358, 1.6565217391304, 1.2978260869565, -0.05
101359, 1.6782608695652, 1.3239130434783, -0.05
101360, 1.6782608695652, 1.2978260869565, -0.025
101361, 1.7, 1.2978260869565, -0.05
101362, 1.7217391304348, 1.3239130434783, -0.05
101363, 1.7217391304348, 1.2978260869565, -0.025
101364, 1.7434782608696, 1.2978260869565, -0.05
101365, 1.7652173913043, 1.3239130434783, -0.05
101366, 1.7652173913043, 1.2978260869565, -0.025
101367, 1.7869565217391, 1.2978260869565, -0.05
101368, 1.8086956521739, 1.3239130434783, -0.05
101369, 1.8086956521739, 1.2978260869565, -0.025
101370, 1.8304347826087, 1.2978260869565, -0.05
101371, 1.8521739130435, 1.3239130434783, -0.05
101372, 1.8521739130435, 1.2978260869565, -0.025
101373, 1.8739130434783, 1.2978260869565, -0.05
101374, 1.895652173913, 1.3239130434783, -0.05
101375, 1.895652173913, 1.2978260869565, -0.025
101376, 1.9173913043478, 1.2978260869565, -0.05
101377, 1.9391304347826, 1.3239130434783, -0.05
101378, 1.9391304347826, 1.2978260869565, -0.025
101379, 1.9608695652174, 1.2978260869565, -0.05
101380, 1.9826086956522, 1.3239130434783, -0.05
101381, 1.9826086956522, 1.2978260869565, -0.025
101382, 2.004347826087, 1.2978260869565, -0.05
101383, 2.0260869565217, 1.3239130434783, -0.05
101384, 2.0260869565217, 1.2978260869565, -0.025
101385, 2.0478260869565, 1.2978260869565, -0.05
101386, 2.0695652173913, 1.3239130434783, -0.05
101387, 2.0695652173913, 1.2978260869565, -0.025
101388, 2.0913043478261, 1.2978260869565, -0.05
101389, 2.1130434782609, 1.3239130434783, -0.05
101390, 2.1130434782609, 1.2978260869565, -0.025
101391, 2.1347826086957, 1.2978260869565, -0.05
101392, 2.1565217391304, 1.3239130434783, -0.05
101393, 2.1565217391304, 1.2978260869565, -0.025
101394, 2.1782608695652, 1.2978260869565, -0.05
101395, 1.2217391304348, 1.245652173913, -0.05
101396, 1.2434782608696, 1.2717391304348, -0.05
101397, 1.2434782608696, 1.245652173913, -0.025
101398, 1.2652173913043, 1.245652173913, -0.05
101399, 1.2869565217391, 1.2717391304348, -0.05
101400, 1.2869565217391, 1.245652173913, -0.025
101401, 1.3086956521739, 1.245652173913, -0.05
101402, 1.3304347826087, 1.2717391304348, -0.05
101403, 1.3304347826087, 1.245652173913, -0.025
101404, 1.3521739130435, 1.245652173913, -0.05
101405, 1.3739130434783, 1.2717391304348, -0.05
101406, 1.3739130434783, 1.245652173913, -0.025
101407, 1.395652173913, 1.245652173913, -0.05
101408, 1.4173913043478, 1.2717391304348, -0.05
101409, 1.4173913043478, 1.245652173913, -0.025
101410, 1.4391304347826, 1.245652173913, -0.05
101411, 1.4608695652174, 1.2717391304348, -0.05
101412, 1.4608695652174, 1.245652173913, -0.025
101413, 1.4826086956522, 1.245652173913, -0.05
101414, 1.504347826087, 1.2717391304348, -0.05
101415, 1.504347826087, 1.245652173913, -0.025
101416, 1.5260869565217, 1.245652173913, -0.05
101417, 1.5478260869565, 1.2717391304348, -0.05
101418, 1.5478260869565, 1.245652173913, -0.025
101419, 1.5695652173913, 1.245652173913, -0.05
101420, 1.5913043478261, 1.2717391304348, -0.05
101421, 1.5913043478261, 1.245652173913, -0.025
101422, 1.6130434782609, 1.245652173913, -0.05
101423, 1.6347826086957, 1.2717391304348, -0.05
101424, 1.6347826086957, 1.245652173913, -0.025
101425, 1.6565217391304, 1.245652173913, -0.05
101426, 1.6782608695652, 1.2717391304348, -0.05
101427, 1.6782608695652, 1.245652173913, -0.025
101428, 1.7, 1.245652173913, -0.05
101429, 1.7217391304348, 1.2717391304348, -0.05
101430, 1.7217391304348, 1.245652173913, -0.025
101431, 1.7434782608696, 1.245652173913, -0.05
101432, 1.7652173913043, 1.2717391304348, -0.05
101433, 1.7652173913043, 1.245652173913, -0.025
101434, 1.7869565217391, 1.245652173913, -0.05
101435, 1.8086956521739, 1.2717391304348, -0.05
101436, 1.8086956521739, 1.245652173913, -0.025
101437, 1.8304347826087, 1.245652173913, -0.05
101438, 1.8521739130435, 1.2717391304348, -0.05
101439, 1.8521739130435, 1.245652173913, -0.025
101440, 1.8739130434783, 1.245652173913, -0.05
101441, 1.895652173913, 1.2717391304348, -0.05
101442, 1.895652173913, 1.245652173913, -0.025
101443, 1.9173913043478, 1.245652173913, -0.05
101444, 1.9391304347826, 1.2717391304348, -0.05
101445, 1.9391304347826, 1.245652173913, -0.025
101446, 1.9608695652174, 1.245652173913, -0.05
101447, 1.9826086956522, 1.2717391304348, -0.05
101448, 1.9826086956522, 1.245652173913, -0.025
101449, 2.004347826087, 1.245652173913, -0.05
101450, 2.0260869565217, 1.2717391304348, -0.05
101451, 2.0260869565217, 1.245652173913, -0.025
101452, 2.0478260869565, 1.245652173913, -0.05
101453, 2.0695652173913, 1.2717391304348, -0.05
101454, 2.0695652173913, 1.245652173913, -0.025
101455, 2.0913043478261, 1.245652173913, -0.05
101456, 2.1130434782609, 1.2717391304348, -0.05
101457, 2.1130434782609, 1.245652173913, -0.025
101458, 2.1347826086957, 1.245652173913, -0.05
101459, 2.1565217391304, 1.2717391304348, -0.05
101460, 2.1565217391304, 1.245652173913, -0.025
101461, 2.1782608695652, 1.245652173913, -0.05
101462, 1.2217391304348, 1.1934782608696, -0.05
101463, 1.2434782608696, 1.2195652173913, -0.05
101464, 1.2434782608696, 1.1934782608696, -0.025
101465, 1.2652173913043, 1.1934782608696, -0.05
101466, 1.2869565217391, 1.2195652173913, -0.05
101467, 1.2869565217391, 1.1934782608696, -0.025
101468, 1.3086956521739, 1.1934782608696, -0.05
101469, 1.3304347826087, 1.2195652173913, -0.05
101470, 1.3304347826087, 1.1934782608696, -0.025
101471, 1.3521739130435, 1.1934782608696, -0.05
101472, 1.3739130434783, 1.2195652173913, -0.05
101473, 1.3739130434783, 1.1934782608696, -0.025
101474, 1.395652173913, 1.1934782608696, -0.05
101475, 1.4173913043478, 1.2195652173913, -0.05
101476, 1.4173913043478, 1.1934782608696, -0.025
101477, 1.4391304347826, 1.1934782608696, -0.05
101478, 1.4608695652174, 1.2195652173913, -0.05
101479, 1.4608695652174, 1.1934782608696, -0.025
101480, 1.4826086956522, 1.1934782608696, -0.05
101481, 1.504347826087, 1.2195652173913, -0.05
101482, 1.504347826087, 1.1934782608696, -0.025
101483, 1.5260869565217, 1.1934782608696, -0.05
101484, 1.5478260869565, 1.2195652173913, -0.05
101485, 1.5478260869565, 1.1934782608696, -0.025
101486, 1.5695652173913, 1.1934782608696, -0.05
101487, 1.5913043478261, 1.2195652173913, -0.05
101488, 1.5913043478261, 1.1934782608696, -0.025
101489, 1.6130434782609, 1.1934782608696, -0.05
101490, 1.6347826086957, 1.2195652173913, -0.05
101491, 1.6347826086957, 1.1934782608696, -0.025
101492, 1.6565217391304, 1.1934782608696, -0.05
101493, 1.6782608695652, 1.2195652173913, -0.05
101494, 1.6782608695652, 1.1934782608696, -0.025
101495, 1.7, 1.1934782608696, -0.05
101496, 1.7217391304348, 1.2195652173913, -0.05
101497, 1.7217391304348, 1.1934782608696, -0.025
101498, 1.7434782608696, 1.1934782608696, -0.05
101499, 1.7652173913043, 1.2195652173913, -0.05
101500, 1.7652173913043, 1.1934782608696, -0.025
101501, 1.7869565217391, 1.1934782608696, -0.05
101502, 1.8086956521739, 1.2195652173913, -0.05
101503, 1.8086956521739, 1.1934782608696, -0.025
101504, 1.8304347826087, 1.1934782608696, -0.05
101505, 1.8521739130435, 1.2195652173913, -0.05
101506, 1.8521739130435, 1.1934782608696, -0.025
101507, 1.8739130434783, 1.1934782608696, -0.05
101508, 1.895652173913, 1.2195652173913, -0.05
101509, 1.895652173913, 1.1934782608696, -0.025
101510, 1.9173913043478, 1.1934782608696, -0.05
101511, 1.9391304347826, 1.2195652173913, -0.05
101512, 1.9391304347826, 1.1934782608696, -0.025
101513, 1.9608695652174, 1.1934782608696, -0.05
101514, 1.9826086956522, 1.2195652173913, -0.05
101515, 1.9826086956522, 1.1934782608696, -0.025
101516, 2.004347826087, 1.1934782608696, -0.05
101517, 2.0260869565217, 1.2195652173913, -0.05
101518, 2.0260869565217, 1.1934782608696, -0.025
101519, 2.0478260869565, 1.1934782608696, -0.05
101520, 2.0695652173913, 1.2195652173913, -0.05
101521, 2.0695652173913, 1.1934782608696, -0.025
101522, 2.0913043478261, 1.1934782608696, -0.05
101523, 2.1130434782609, 1.2195652173913, -0.05
101524, 2.1130434782609, 1.1934782608696, -0.025
101525, 2.1347826086957, 1.1934782608696, -0.05
101526, 2.1565217391304, 1.2195652173913, -0.05
101527, 2.1565217391304, 1.1934782608696, -0.025
101528, 2.1782608695652, 1.1934782608696, -0.05
101529, 1.2217391304348, 1.1413043478261, -0.05
101530, 1.2434782608696, 1.1673913043478, -0.05
101531, 1.2434782608696, 1.1413043478261, -0.025
101532, 1.2652173913043, 1.1413043478261, -0.05
101533, 1.2869565217391, 1.1673913043478, -0.05
101534, 1.2869565217391, 1.1413043478261, -0.025
101535, 1.3086956521739, 1.1413043478261, -0.05
101536, 1.3304347826087, 1.1673913043478, -0.05
101537, 1.3304347826087, 1.1413043478261, -0.025
101538, 1.3521739130435, 1.1413043478261, -0.05
101539, 1.3739130434783, 1.1673913043478, -0.05
101540, 1.3739130434783, 1.1413043478261, -0.025
101541, 1.395652173913, 1.1413043478261, -0.05
101542, 1.4173913043478, 1.1673913043478, -0.05
101543, 1.4173913043478, 1.1413043478261, -0.025
101544, 1.4391304347826, 1.1413043478261, -0.05
101545, 1.4608695652174, 1.1673913043478, -0.05
101546, 1.4608695652174, 1.1413043478261, -0.025
101547, 1.4826086956522, 1.1413043478261, -0.05
101548, 1.504347826087, 1.1673913043478, -0.05
101549, 1.504347826087, 1.1413043478261, -0.025
101550, 1.5260869565217, 1.1413043478261, -0.05
101551, 1.5478260869565, 1.1673913043478, -0.05
101552, 1.5478260869565, 1.1413043478261, -0.025
101553, 1.5695652173913, 1.1413043478261, -0.05
101554, 1.5913043478261, 1.1673913043478, -0.05
101555, 1.5913043478261, 1.1413043478261, -0.025
101556, 1.6130434782609, 1.1413043478261, -0.05
101557, 1.6347826086957, 1.1673913043478, -0.05
101558, 1.6347826086957, 1.1413043478261, -0.025
101559, 1.6565217391304, 1.1413043478261, -0.05
101560, 1.6782608695652, 1.1673913043478, -0.05
101561, 1.6782608695652, 1.1413043478261, -0.025
101562, 1.7, 1.1413043478261, -0.05
101563, 1.7217391304348, 1.1673913043478, -0.05
101564, 1.7217391304348, 1.1413043478261, -0.025
101565, 1.7434782608696, 1.1413043478261, -0.05
101566, 1.7652173913043, 1.1673913043478, -0.05
101567, 1.7652173913043, 1.1413043478261, -0.025
101568, 1.7869565217391, 1.1413043478261, -0.05
101569, 1.8086956521739, 1.1673913043478, -0.05
101570, 1.8086956521739, 1.1413043478261, -0.025
101571, 1.8304347826087, 1.1413043478261, -0.05
101572, 1.8521739130435, 1.1673913043478, -0.05
101573, 1.8521739130435, 1.1413043478261, -0.025
101574, 1.8739130434783, 1.1413043478261, -0.05
101575, 1.895652173913, 1.1673913043478, -0.05
101576, 1.895652173913, 1.1413043478261, -0.025
101577, 1.9173913043478, 1.1413043478261, -0.05
101578, 1.9391304347826, 1.1673913043478, -0.05
101579, 1.9391304347826, 1.1413043478261, -0.025
101580, 1.9608695652174, 1.1413043478261, -0.05
101581, 1.9826086956522, 1.1673913043478, -0.05
101582, 1.9826086956522, 1.1413043478261, -0.025
101583, 2.004347826087, 1.1413043478261, -0.05
101584, 2.0260869565217, 1.1673913043478, -0.05
101585, 2.0260869565217, 1.1413043478261, -0.025
101586, 2.0478260869565, 1.1413043478261, -0.05
101587, 2.0695652173913, 1.1673913043478, -0.05
101588, 2.0695652173913, 1.1413043478261, -0.025
101589, 2.0913043478261, 1.1413043478261, -0.05
101590, 2.1130434782609, 1.1673913043478, -0.05
101591, 2.1130434782609, 1.1413043478261, -0.025
101592, 2.1347826086957, 1.1413043478261, -0.05
101593, 2.1565217391304, 1.1673913043478, -0.05
101594, 2.1565217391304, 1.1413043478261, -0.025
101595, 2.1782608695652, 1.1413043478261, -0.05
101596, 1.2217391304348, 1.0891304347826, -0.05
101597, 1.2434782608696, 1.1152173913043, -0.05
101598, 1.2434782608696, 1.0891304347826, -0.025
101599, 1.2652173913043, 1.0891304347826, -0.05
101600, 1.2869565217391, 1.1152173913043, -0.05
101601, 1.2869565217391, 1.0891304347826, -0.025
101602, 1.3086956521739, 1.0891304347826, -0.05
101603, 1.3304347826087, 1.1152173913043, -0.05
101604, 1.3304347826087, 1.0891304347826, -0.025
101605, 1.3521739130435, 1.0891304347826, -0.05
101606, 1.3739130434783, 1.1152173913043, -0.05
101607, 1.3739130434783, 1.0891304347826, -0.025
101608, 1.395652173913, 1.0891304347826, -0.05
101609, 1.4173913043478, 1.1152173913043, -0.05
101610, 1.4173913043478, 1.0891304347826, -0.025
101611, 1.4391304347826, 1.0891304347826, -0.05
101612, 1.4608695652174, 1.1152173913043, -0.05
101613, 1.4608695652174, 1.0891304347826, -0.025
101614, 1.4826086956522, 1.0891304347826, -0.05
101615, 1.504347826087, 1.1152173913043, -0.05
101616, 1.504347826087, 1.0891304347826, -0.025
101617, 1.5260869565217, 1.0891304347826, -0.05
101618, 1.5478260869565, 1.1152173913043, -0.05
101619, 1.5478260869565, 1.0891304347826, -0.025
101620, 1.5695652173913, 1.0891304347826, -0.05
101621, 1.5913043478261, 1.1152173913043, -0.05
101622, 1.5913043478261, 1.0891304347826, -0.025
101623, 1.6130434782609, 1.0891304347826, -0.05
101624, 1.6347826086957, 1.1152173913043, -0.05
101625, 1.6347826086957, 1.0891304347826, -0.025
101626, 1.6565217391304, 1.0891304347826, -0.05
101627, 1.6782608695652, 1.1152173913043, -0.05
101628, 1.6782608695652, 1.0891304347826, -0.025
101629, 1.7, 1.0891304347826, -0.05
101630, 1.7217391304348, 1.1152173913043, -0.05
101631, 1.7217391304348, 1.0891304347826, -0.025
101632, 1.7434782608696, 1.0891304347826, -0.05
101633, 1.7652173913043, 1.1152173913043, -0.05
101634, 1.7652173913043, 1.0891304347826, -0.025
101635, 1.7869565217391, 1.0891304347826, -0.05
101636, 1.8086956521739, 1.1152173913043, -0.05
101637, 1.8086956521739, 1.0891304347826, -0.025
101638, 1.8304347826087, 1.0891304347826, -0.05
101639, 1.8521739130435, 1.1152173913043, -0.05
101640, 1.8521739130435, 1.0891304347826, -0.025
101641, 1.8739130434783, 1.0891304347826, -0.05
101642, 1.895652173913, 1.1152173913043, -0.05
101643, 1.895652173913, 1.0891304347826, -0.025
101644, 1.9173913043478, 1.0891304347826, -0.05
101645, 1.9391304347826, 1.1152173913043, -0.05
101646, 1.9391304347826, 1.0891304347826, -0.025
101647, 1.9608695652174, 1.0891304347826, -0.05
101648, 1.9826086956522, 1.1152173913043, -0.05
101649, 1.9826086956522, 1.0891304347826, -0.025
101650, 2.004347826087, 1.0891304347826, -0.05
101651, 2.0260869565217, 1.1152173913043, -0.05
101652, 2.0260869565217, 1.0891304347826, -0.025
101653, 2.0478260869565, 1.0891304347826, -0.05
101654, 2.0695652173913, 1.1152173913043, -0.05
101655, 2.0695652173913, 1.0891304347826, -0.025
101656, 2.0913043478261, 1.0891304347826, -0.05
101657, 2.1130434782609, 1.1152173913043, -0.05
101658, 2.1130434782609, 1.0891304347826, -0.025
101659, 2.1347826086957, 1.0891304347826, -0.05
101660, 2.1565217391304, 1.1152173913043, -0.05
101661, 2.1565217391304, 1.0891304347826, -0.025
101662, 2.1782608695652, 1.0891304347826, -0.05
101663, 1.2217391304348, 1.0369565217391, -0.05
101664, 1.2434782608696, 1.0630434782609, -0.05
101665, 1.2434782608696, 1.0369565217391, -0.025
101666, 1.2652173913043, 1.0369565217391, -0.05
101667, 1.2869565217391, 1.0630434782609, -0.05
101668, 1.2869565217391, 1.0369565217391, -0.025
101669, 1.3086956521739, 1.0369565217391, -0.05
101670, 1.3304347826087, 1.0630434782609, -0.05
101671, 1.3304347826087, 1.0369565217391, -0.025
101672, 1.3521739130435, 1.0369565217391, -0.05
101673, 1.3739130434783, 1.0630434782609, -0.05
101674, 1.3739130434783, 1.0369565217391, -0.025
101675, 1.395652173913, 1.0369565217391, -0.05
101676, 1.4173913043478, 1.0630434782609, -0.05
101677, 1.4173913043478, 1.0369565217391, -0.025
101678, 1.4391304347826, 1.0369565217391, -0.05
101679, 1.4608695652174, 1.0630434782609, -0.05
101680, 1.4608695652174, 1.0369565217391, -0.025
101681, 1.4826086956522, 1.0369565217391, -0.05
101682, 1.504347826087, 1.0630434782609, -0.05
101683, 1.504347826087, 1.0369565217391, -0.025
101684, 1.5260869565217, 1.0369565217391, -0.05
101685, 1.5478260869565, 1.0630434782609, -0.05
101686, 1.5478260869565, 1.0369565217391, -0.025
101687, 1.5695652173913, 1.0369565217391, -0.05
101688, 1.5913043478261, 1.0630434782609, -0.05
101689, 1.5913043478261, 1.0369565217391, -0.025
101690, 1.6130434782609, 1.0369565217391, -0.05
101691, 1.6347826086957, 1.0630434782609, -0.05
101692, 1.6347826086957, 1.0369565217391, -0.025
101693, 1.6565217391304, 1.0369565217391, -0.05
101694, 1.6782608695652, 1.0630434782609, -0.05
101695, 1.6782608695652, 1.0369565217391, -0.025
101696, 1.7, 1.0369565217391, -0.05
101697, 1.7217391304348, 1.0630434782609, -0.05
101698, 1.7217391304348, 1.0369565217391, -0.025
101699, 1.7434782608696, 1.0369565217391, -0.05
101700, 1.7652173913043, 1.0630434782609, -0.05
101701, 1.7652173913043, 1.0369565217391, -0.025
101702, 1.7869565217391, 1.0369565217391, -0.05
101703, 1.8086956521739, 1.0630434782609, -0.05
101704, 1.8086956521739, 1.0369565217391, -0.025
101705, 1.8304347826087, 1.0369565217391, -0.05
101706, 1.8521739130435, 1.0630434782609, -0.05
101707, 1.8521739130435, 1.0369565217391, -0.025
101708, 1.8739130434783, 1.0369565217391, -0.05
101709, 1.895652173913, 1.0630434782609, -0.05
101710, 1.895652173913, 1.0369565217391, -0.025
101711, 1.9173913043478, 1.0369565217391, -0.05
101712, 1.9391304347826, 1.0630434782609, -0.05
101713, 1.9391304347826, 1.0369565217391, -0.025
101714, 1.9608695652174, 1.0369565217391, -0.05
101715, 1.9826086956522, 1.0630434782609, -0.05
101716, 1.9826086956522, 1.0369565217391, -0.025
101717, 2.004347826087, 1.0369565217391, -0.05
101718, 2.0260869565217, 1.0630434782609, -0.05
101719, 2.0260869565217, 1.0369565217391, -0.025
101720, 2.0478260869565, 1.0369565217391, -0.05
101721, 2.0695652173913, 1.0630434782609, -0.05
101722, 2.0695652173913, 1.0369565217391, -0.025
101723, 2.0913043478261, 1.0369565217391, -0.05
101724, 2.1130434782609, 1.0630434782609, -0.05
101725, 2.1130434782609, 1.0369565217391, -0.025
101726, 2.1347826086957, 1.0369565217391, -0.05
101727, 2.1565217391304, 1.0630434782609, -0.05
101728, 2.1565217391304, 1.0369565217391, -0.025
101729, 2.1782608695652, 1.0369565217391, -0.05
101730, 1.2217391304348, 0.98478260869565, -0.05
101731, 1.2434782608696, 1.0108695652174, -0.05
101732, 1.2434782608696, 0.98478260869565, -0.025
101733, 1.2652173913043, 0.98478260869565, -0.05
101734, 1.2869565217391, 1.0108695652174, -0.05
101735, 1.2869565217391, 0.98478260869565, -0.025
101736, 1.3086956521739, 0.98478260869565, -0.05
101737, 1.3304347826087, 1.0108695652174, -0.05
101738, 1.3304347826087, 0.98478260869565, -0.025
101739, 1.3521739130435, 0.98478260869565, -0.05
101740, 1.3739130434783, 1.0108695652174, -0.05
101741, 1.3739130434783, 0.98478260869565, -0.025
101742, 1.395652173913, 0.98478260869565, -0.05
101743, 1.4173913043478, 1.0108695652174, -0.05
101744, 1.4173913043478, 0.98478260869565, -0.025
101745, 1.4391304347826, 0.98478260869565, -0.05
101746, 1.4608695652174, 1.0108695652174, -0.05
101747, 1.4608695652174, 0.98478260869565, -0.025
101748, 1.4826086956522, 0.98478260869565, -0.05
101749, 1.504347826087, 1.0108695652174, -0.05
101750, 1.504347826087, 0.98478260869565, -0.025
101751, 1.5260869565217, 0.98478260869565, -0.05
101752, 1.5478260869565, 1.0108695652174, -0.05
101753, 1.5478260869565, 0.98478260869565, -0.025
101754, 1.5695652173913, 0.98478260869565, -0.05
101755, 1.5913043478261, 1.0108695652174, -0.05
101756, 1.5913043478261, 0.98478260869565, -0.025
101757, 1.6130434782609, 0.98478260869565, -0.05
101758, 1.6347826086957, 1.0108695652174, -0.05
101759, 1.6347826086957, 0.98478260869565, -0.025
101760, 1.6565217391304, 0.98478260869565, -0.05
101761, 1.6782608695652, 1.0108695652174, -0.05
101762, 1.6782608695652, 0.98478260869565, -0.025
101763, 1.7, 0.98478260869565, -0.05
101764, 1.7217391304348, 1.0108695652174, -0.05
101765, 1.7217391304348, 0.98478260869565, -0.025
101766, 1.7434782608696, 0.98478260869565, -0.05
101767, 1.7652173913043, 1.0108695652174, -0.05
101768, 1.7652173913043, 0.98478260869565, -0.025
101769, 1.7869565217391, 0.98478260869565, -0.05
101770, 1.8086956521739, 1.0108695652174, -0.05
101771, 1.8086956521739, 0.98478260869565, -0.025
101772, 1.8304347826087, 0.98478260869565, -0.05
101773, 1.8521739130435, 1.0108695652174, -0.05
101774, 1.8521739130435, 0.98478260869565, -0.025
101775, 1.8739130434783, 0.98478260869565, -0.05
101776, 1.895652173913, 1.0108695652174, -0.05
101777, 1.895652173913, 0.98478260869565, -0.025
101778, 1.9173913043478, 0.98478260869565, -0.05
101779, 1.9391304347826, 1.0108695652174, -0.05
101780, 1.9391304347826, 0.98478260869565, -0.025
101781, 1.9608695652174, 0.98478260869565, -0.05
101782, 1.9826086956522, 1.0108695652174, -0.05
101783, 1.9826086956522, 0.98478260869565, -0.025
101784, 2.004347826087, 0.98478260869565, -0.05
101785, 2.0260869565217, 1.0108695652174, -0.05
101786, 2.0260869565217, 0.98478260869565, -0.025
101787, 2.0478260869565, 0.98478260869565, -0.05
101788, 2.0695652173913, 1.0108695652174, -0.05
101789, 2.0695652173913, 0.98478260869565, -0.025
101790, 2.0913043478261, 0.98478260869565, -0.05
101791, 2.1130434782609, 1.0108695652174, -0.05
101792, 2.1130434782609, 0.98478260869565, -0.025
101793, 2.1347826086957, 0.98478260869565, -0.05
101794, 2.1565217391304, 1.0108695652174, -0.05
101795, 2.1565217391304, 0.98478260869565, -0.025
101796, 2.1782608695652, 0.98478260869565, -0.05
101797, 1.2217391304348, 0.93260869565217, -0.05
101798, 1.2434782608696, 0.95869565217391, -0.05
101799, 1.2434782608696, 0.93260869565217, -0.025
101800, 1.2652173913043, 0.93260869565217, -0.05
101801, 1.2869565217391, 0.95869565217391, -0.05
101802, 1.2869565217391, 0.93260869565217, -0.025
101803, 1.3086956521739, 0.93260869565217, -0.05
101804, 1.3304347826087, 0.95869565217391, -0.05
101805, 1.3304347826087, 0.93260869565217, -0.025
101806, 1.3521739130435, 0.93260869565217, -0.05
101807, 1.3739130434783, 0.95869565217391, -0.05
101808, 1.3739130434783, 0.93260869565217, -0.025
101809, 1.395652173913, 0.93260869565217, -0.05
101810, 1.4173913043478, 0.95869565217391, -0.05
101811, 1.4173913043478, 0.93260869565217, -0.025
101812, 1.4391304347826, 0.93260869565217, -0.05
101813, 1.4608695652174, 0.95869565217391, -0.05
101814, 1.4608695652174, 0.93260869565217, -0.025
101815, 1.4826086956522, 0.93260869565217, -0.05
101816, 1.504347826087, 0.95869565217391, -0.05
101817, 1.504347826087, 0.93260869565217, -0.025
101818, 1.5260869565217, 0.93260869565217, -0.05
101819, 1.5478260869565, 0.95869565217391, -0.05
101820, 1.5478260869565, 0.93260869565217, -0.025
101821, 1.5695652173913, 0.93260869565217, -0.05
101822, 1.5913043478261, 0.95869565217391, -0.05
101823, 1.5913043478261, 0.93260869565217, -0.025
101824, 1.6130434782609, 0.93260869565217, -0.05
101825, 1.6347826086957, 0.95869565217391, -0.05
101826, 1.6347826086957, 0.93260869565217, -0.025
101827, 1.6565217391304, 0.93260869565217, -0.05
101828, 1.6782608695652, 0.95869565217391, -0.05
101829, 1.6782608695652, 0.93260869565217, -0.025
101830, 1.7, 0.93260869565217, -0.05
101831, 1.7217391304348, 0.95869565217391, -0.05
101832, 1.7217391304348, 0.93260869565217, -0.025
101833, 1.7434782608696, 0.93260869565217, -0.05
101834, 1.7652173913043, 0.95869565217391, -0.05
101835, 1.7652173913043, 0.93260869565217, -0.025
101836, 1.7869565217391, 0.93260869565217, -0.05
101837, 1.8086956521739, 0.95869565217391, -0.05
101838, 1.8086956521739, 0.93260869565217, -0.025
101839, 1.8304347826087, 0.93260869565217, -0.05
101840, 1.8521739130435, 0.95869565217391, -0.05
101841, 1.8521739130435, 0.93260869565217, -0.025
101842, 1.8739130434783, 0.93260869565217, -0.05
101843, 1.895652173913, 0.95869565217391, -0.05
101844, 1.895652173913, 0.93260869565217, -0.025
101845, 1.9173913043478, 0.93260869565217, -0.05
101846, 1.9391304347826, 0.95869565217391, -0.05
101847, 1.9391304347826, 0.93260869565217, -0.025
101848, 1.9608695652174, 0.93260869565217, -0.05
101849, 1.9826086956522, 0.95869565217391, -0.05
101850, 1.9826086956522, 0.93260869565217, -0.025
101851, 2.004347826087, 0.93260869565217, -0.05
101852, 2.0260869565217, 0.95869565217391, -0.05
101853, 2.0260869565217, 0.93260869565217, -0.025
101854, 2.0478260869565, 0.93260869565217, -0.05
101855, 2.0695652173913, 0.95869565217391, -0.05
101856, 2.0695652173913, 0.93260869565217, -0.025
101857, 2.0913043478261, 0.93260869565217, -0.05
101858, 2.1130434782609, 0.95869565217391, -0.05
101859, 2.1130434782609, 0.93260869565217, -0.025
101860, 2.1347826086957, 0.93260869565217, -0.05
101861, 2.1565217391304, 0.95869565217391, -0.05
101862, 2.1565217391304, 0.93260869565217, -0.025
101863, 2.1782608695652, 0.93260869565217, -0.05
101864, 1.2217391304348, 0.8804347826087, -0.05
101865, 1.2434782608696, 0.90652173913044, -0.05
101866, 1.2434782608696, 0.8804347826087, -0.025
101867, 1.2652173913043, 0.8804347826087, -0.05
101868, 1.2869565217391, 0.90652173913044, -0.05
101869, 1.2869565217391, 0.8804347826087, -0.025
101870, 1.3086956521739, 0.8804347826087, -0.05
101871, 1.3304347826087, 0.90652173913044, -0.05
101872, 1.3304347826087, 0.8804347826087, -0.025
101873, 1.3521739130435, 0.8804347826087, -0.05
101874, 1.3739130434783, 0.90652173913044, -0.05
101875, 1.3739130434783, 0.8804347826087, -0.025
101876, 1.395652173913, 0.8804347826087, -0.05
101877, 1.4173913043478, 0.90652173913044, -0.05
101878, 1.4173913043478, 0.8804347826087, -0.025
101879, 1.4391304347826, 0.8804347826087, -0.05
101880, 1.4608695652174, 0.90652173913044, -0.05
101881, 1.4608695652174, 0.8804347826087, -0.025
101882, 1.4826086956522, 0.8804347826087, -0.05
101883, 1.504347826087, 0.90652173913044, -0.05
101884, 1.504347826087, 0.8804347826087, -0.025
101885, 1.5260869565217, 0.8804347826087, -0.05
101886, 1.5478260869565, 0.90652173913044, -0.05
101887, 1.5478260869565, 0.8804347826087, -0.025
101888, 1.5695652173913, 0.8804347826087, -0.05
101889, 1.5913043478261, 0.90652173913044, -0.05
101890, 1.5913043478261, 0.8804347826087, -0.025
101891, 1.6130434782609, 0.8804347826087, -0.05
101892, 1.6347826086957, 0.90652173913044, -0.05
101893, 1.6347826086957, 0.8804347826087, -0.025
101894, 1.6565217391304, 0.8804347826087, -0.05
101895, 1.6782608695652, 0.90652173913044, -0.05
101896, 1.6782608695652, 0.8804347826087, -0.025
101897, 1.7, 0.8804347826087, -0.05
101898, 1.7217391304348, 0.90652173913044, -0.05
101899, 1.7217391304348, 0.8804347826087, -0.025
101900, 1.7434782608696, 0.8804347826087, -0.05
101901, 1.7652173913043, 0.90652173913044, -0.05
101902, 1.7652173913043, 0.8804347826087, -0.025
101903, 1.7869565217391, 0.8804347826087, -0.05
101904, 1.8086956521739, 0.90652173913044, -0.05
101905, 1.8086956521739, 0.8804347826087, -0.025
101906, 1.8304347826087, 0.8804347826087, -0.05
101907, 1.8521739130435, 0.90652173913044, -0.05
101908, 1.8521739130435, 0.8804347826087, -0.025
101909, 1.8739130434783, 0.8804347826087, -0.05
101910, 1.895652173913, 0.90652173913044, -0.05
101911, 1.895652173913, 0.8804347826087, -0.025
101912, 1.9173913043478, 0.8804347826087, -0.05
101913, 1.9391304347826, 0.90652173913044, -0.05
101914, 1.9391304347826, 0.8804347826087, -0.025
101915, 1.9608695652174, 0.8804347826087, -0.05
101916, 1.9826086956522, 0.90652173913044, -0.05
101917, 1.9826086956522, 0.8804347826087, -0.025
101918, 2.004347826087, 0.8804347826087, -0.05
101919, 2.0260869565217, 0.90652173913044, -0.05
101920, 2.0260869565217, 0.8804347826087, -0.025
101921, 2.0478260869565, 0.8804347826087, -0.05
101922, 2.0695652173913, 0.90652173913044, -0.05
101923, 2.0695652173913, 0.8804347826087, -0.025
101924, 2.0913043478261, 0.8804347826087, -0.05
101925, 2.1130434782609, 0.90652173913044, -0.05
101926, 2.1130434782609, 0.8804347826087, -0.025
101927, 2.1347826086957, 0.8804347826087, -0.05
101928, 2.1565217391304, 0.90652173913044, -0.05
101929, 2.1565217391304, 0.8804347826087, -0.025
101930, 2.1782608695652, 0.8804347826087, -0.05
101931, 1.2217391304348, 0.82826086956522, -0.05
101932, 1.2434782608696, 0.85434782608696, -0.05
101933, 1.2434782608696, 0.82826086956522, -0.025
101934, 1.2652173913043, 0.82826086956522, -0.05
101935, 1.2869565217391, 0.85434782608696, -0.05
101936, 1.2869565217391, 0.82826086956522, -0.025
101937, 1.3086956521739, 0.82826086956522, -0.05
101938, 1.3304347826087, 0.85434782608696, -0.05
101939, 1.3304347826087, 0.82826086956522, -0.025
101940, 1.3521739130435, 0.82826086956522, -0.05
101941, 1.3739130434783, 0.85434782608696, -0.05
101942, 1.3739130434783, 0.82826086956522, -0.025
101943, 1.395652173913, 0.82826086956522, -0.05
101944, 1.4173913043478, 0.85434782608696, -0.05
101945, 1.4173913043478, 0.82826086956522, -0.025
101946, 1.4391304347826, 0.82826086956522, -0.05
101947, 1.4608695652174, 0.85434782608696, -0.05
101948, 1.4608695652174, 0.82826086956522, -0.025
101949, 1.4826086956522, 0.82826086956522, -0.05
101950, 1.504347826087, 0.85434782608696, -0.05
101951, 1.504347826087, 0.82826086956522, -0.025
101952, 1.5260869565217, 0.82826086956522, -0.05
101953, 1.5478260869565, 0.85434782608696, -0.05
101954, 1.5478260869565, 0.82826086956522, -0.025
101955, 1.5695652173913, 0.82826086956522, -0.05
101956, 1.5913043478261, 0.85434782608696, -0.05
101957, 1.5913043478261, 0.82826086956522, -0.025
101958, 1.6130434782609, 0.82826086956522, -0.05
101959, 1.6347826086957, 0.85434782608696, -0.05
101960, 1.6347826086957, 0.82826086956522, -0.025
101961, 1.6565217391304, 0.82826086956522, -0.05
101962, 1.6782608695652, 0.85434782608696, -0.05
101963, 1.6782608695652, 0.82826086956522, -0.025
101964, 1.7, 0.82826086956522, -0.05
101965, 1.7217391304348, 0.85434782608696, -0.05
101966, 1.7217391304348, 0.82826086956522, -0.025
101967, 1.7434782608696, 0.82826086956522, -0.05
101968, 1.7652173913043, 0.85434782608696, -0.05
101969, 1.7652173913043, 0.82826086956522, -0.025
101970, 1.7869565217391, 0.82826086956522, -0.05
101971, 1.8086956521739, 0.85434782608696, -0.05
101972, 1.8086956521739, 0.82826086956522, -0.025
101973, 1.8304347826087, 0.82826086956522, -0.05
101974, 1.8521739130435, 0.85434782608696, -0.05
101975, 1.8521739130435, 0.82826086956522, -0.025
101976, 1.8739130434783, 0.82826086956522, -0.05
101977, 1.895652173913, 0.85434782608696, -0.05
101978, 1.895652173913, 0.82826086956522, -0.025
101979, 1.9173913043478, 0.82826086956522, -0.05
101980, 1.9391304347826, 0.85434782608696, -0.05
101981, 1.9391304347826, 0.82826086956522, -0.025
101982, 1.9608695652174, 0.82826086956522, -0.05
101983, 1.9826086956522, 0.85434782608696, -0.05
101984, 1.9826086956522, 0.82826086956522, -0.025
101985, 2.004347826087, 0.82826086956522, -0.05
101986, 2.0260869565217, 0.85434782608696, -0.05
101987, 2.0260869565217, 0.82826086956522, -0.025
101988, 2.0478260869565, 0.82826086956522, -0.05
101989, 2.0695652173913, 0.85434782608696, -0.05
101990, 2.0695652173913, 0.82826086956522, -0.025
101991, 2.0913043478261, 0.82826086956522, -0.05
101992, 2.1130434782609, 0.85434782608696, -0.05
101993, 2.1130434782609, 0.82826086956522, -0.025
101994, 2.1347826086957, 0.82826086956522, -0.05
101995, 2.1565217391304, 0.85434782608696, -0.05
101996, 2.1565217391304, 0.82826086956522, -0.025
101997, 2.1782608695652, 0.82826086956522, -0.05
101998, 1.2217391304348, 0.77608695652174, -0.05
101999, 1.2434782608696, 0.80217391304348, -0.05
102000, 1.2434782608696, 0.77608695652174, -0.025
102001, 1.2652173913043, 0.77608695652174, -0.05
102002, 1.2869565217391, 0.80217391304348, -0.05
102003, 1.2869565217391, 0.77608695652174, -0.025
102004, 1.3086956521739, 0.77608695652174, -0.05
102005, 1.3304347826087, 0.80217391304348, -0.05
102006, 1.3304347826087, 0.77608695652174, -0.025
102007, 1.3521739130435, 0.77608695652174, -0.05
102008, 1.3739130434783, 0.80217391304348, -0.05
102009, 1.3739130434783, 0.77608695652174, -0.025
102010, 1.395652173913, 0.77608695652174, -0.05
102011, 1.4173913043478, 0.80217391304348, -0.05
102012, 1.4173913043478, 0.77608695652174, -0.025
102013, 1.4391304347826, 0.77608695652174, -0.05
102014, 1.4608695652174, 0.80217391304348, -0.05
102015, 1.4608695652174, 0.77608695652174, -0.025
102016, 1.4826086956522, 0.77608695652174, -0.05
102017, 1.504347826087, 0.80217391304348, -0.05
102018, 1.504347826087, 0.77608695652174, -0.025
102019, 1.5260869565217, 0.77608695652174, -0.05
102020, 1.5478260869565, 0.80217391304348, -0.05
102021, 1.5478260869565, 0.77608695652174, -0.025
102022, 1.5695652173913, 0.77608695652174, -0.05
102023, 1.5913043478261, 0.80217391304348, -0.05
102024, 1.5913043478261, 0.77608695652174, -0.025
102025, 1.6130434782609, 0.77608695652174, -0.05
102026, 1.6347826086957, 0.80217391304348, -0.05
102027, 1.6347826086957, 0.77608695652174, -0.025
102028, 1.6565217391304, 0.77608695652174, -0.05
102029, 1.6782608695652, 0.80217391304348, -0.05
102030, 1.6782608695652, 0.77608695652174, -0.025
102031, 1.7, 0.77608695652174, -0.05
102032, 1.7217391304348, 0.80217391304348, -0.05
102033, 1.7217391304348, 0.77608695652174, -0.025
102034, 1.7434782608696, 0.77608695652174, -0.05
102035, 1.7652173913043, 0.80217391304348, -0.05
102036, 1.7652173913043, 0.77608695652174, -0.025
102037, 1.7869565217391, 0.77608695652174, -0.05
102038, 1.8086956521739, 0.80217391304348, -0.05
102039, 1.8086956521739, 0.77608695652174, -0.025
102040, 1.8304347826087, 0.77608695652174, -0.05
102041, 1.8521739130435, 0.80217391304348, -0.05
102042, 1.8521739130435, 0.77608695652174, -0.025
102043, 1.8739130434783, 0.77608695652174, -0.05
102044, 1.895652173913, 0.80217391304348, -0.05
102045, 1.895652173913, 0.77608695652174, -0.025
102046, 1.9173913043478, 0.77608695652174, -0.05
102047, 1.9391304347826, 0.80217391304348, -0.05
102048, 1.9391304347826, 0.77608695652174, -0.025
102049, 1.9608695652174, 0.77608695652174, -0.05
102050, 1.9826086956522, 0.80217391304348, -0.05
102051, 1.9826086956522, 0.77608695652174, -0.025
102052, 2.004347826087, 0.77608695652174, -0.05
102053, 2.0260869565217, 0.80217391304348, -0.05
102054, 2.0260869565217, 0.77608695652174, -0.025
102055, 2.0478260869565, 0.77608695652174, -0.05
102056, 2.0695652173913, 0.80217391304348, -0.05
102057, 2.0695652173913, 0.77608695652174, -0.025
102058, 2.0913043478261, 0.77608695652174, -0.05
102059, 2.1130434782609, 0.80217391304348, -0.05
102060, 2.1130434782609, 0.77608695652174, -0.025
102061, 2.1347826086957, 0.77608695652174, -0.05
102062, 2.1565217391304, 0.80217391304348, -0.05
102063, 2.1565217391304, 0.77608695652174, -0.025
102064, 2.1782608695652, 0.77608695652174, -0.05
102065, 1.2217391304348, 0.72391304347826, -0.05
102066, 1.2434782608696, 0.75, -0.05
102067, 1.2434782608696, 0.72391304347826, -0.025
102068, 1.2652173913043, 0.72391304347826, -0.05
102069, 1.2869565217391, 0.75, -0.05
102070, 1.2869565217391, 0.72391304347826, -0.025
102071, 1.3086956521739, 0.72391304347826, -0.05
102072, 1.3304347826087, 0.75, -0.05
102073, 1.3304347826087, 0.72391304347826, -0.025
102074, 1.3521739130435, 0.72391304347826, -0.05
102075, 1.3739130434783, 0.75, -0.05
102076, 1.3739130434783, 0.72391304347826, -0.025
102077, 1.395652173913, 0.72391304347826, -0.05
102078, 1.4173913043478, 0.75, -0.05
102079, 1.4173913043478, 0.72391304347826, -0.025
102080, 1.4391304347826, 0.72391304347826, -0.05
102081, 1.4608695652174, 0.75, -0.05
102082, 1.4608695652174, 0.72391304347826, -0.025
102083, 1.4826086956522, 0.72391304347826, -0.05
102084, 1.504347826087, 0.75, -0.05
102085, 1.504347826087, 0.72391304347826, -0.025
102086, 1.5260869565217, 0.72391304347826, -0.05
102087, 1.5478260869565, 0.75, -0.05
102088, 1.5478260869565, 0.72391304347826, -0.025
102089, 1.5695652173913, 0.72391304347826, -0.05
102090, 1.5913043478261, 0.75, -0.05
102091, 1.5913043478261, 0.72391304347826, -0.025
102092, 1.6130434782609, 0.72391304347826, -0.05
102093, 1.6347826086957, 0.75, -0.05
102094, 1.6347826086957, 0.72391304347826, -0.025
102095, 1.6565217391304, 0.72391304347826, -0.05
102096, 1.6782608695652, 0.75, -0.05
102097, 1.6782608695652, 0.72391304347826, -0.025
102098, 1.7, 0.72391304347826, -0.05
102099, 1.7217391304348, 0.75, -0.05
102100, 1.7217391304348, 0.72391304347826, -0.025
102101, 1.7434782608696, 0.72391304347826, -0.05
102102, 1.7652173913043, 0.75, -0.05
102103, 1.7652173913043, 0.72391304347826, -0.025
102104, 1.7869565217391, 0.72391304347826, -0.05
102105, 1.8086956521739, 0.75, -0.05
102106, 1.8086956521739, 0.72391304347826, -0.025
102107, 1.8304347826087, 0.72391304347826, -0.05
102108, 1.8521739130435, 0.75, -0.05
102109, 1.8521739130435, 0.72391304347826, -0.025
102110, 1.8739130434783, 0.72391304347826, -0.05
102111, 1.895652173913, 0.75, -0.05
102112, 1.895652173913, 0.72391304347826, -0.025
102113, 1.9173913043478, 0.72391304347826, -0.05
102114, 1.9391304347826, 0.75, -0.05
102115, 1.9391304347826, 0.72391304347826, -0.025
102116, 1.9608695652174, 0.72391304347826, -0.05
102117, 1.9826086956522, 0.75, -0.05
102118, 1.9826086956522, 0.72391304347826, -0.025
102119, 2.004347826087, 0.72391304347826, -0.05
102120, 2.0260869565217, 0.75, -0.05
102121, 2.0260869565217, 0.72391304347826, -0.025
102122, 2.0478260869565, 0.72391304347826, -0.05
102123, 2.0695652173913, 0.75, -0.05
102124, 2.0695652173913, 0.72391304347826, -0.025
102125, 2.0913043478261, 0.72391304347826, -0.05
102126, 2.1130434782609, 0.75, -0.05
102127, 2.1130434782609, 0.72391304347826, -0.025
102128, 2.1347826086957, 0.72391304347826, -0.05
102129, 2.1565217391304, 0.75, -0.05
102130, 2.1565217391304, 0.72391304347826, -0.025
102131, 2.1782608695652, 0.72391304347826, -0.05
102132, 1.2217391304348, 0.67173913043478, -0.05
102133, 1.2434782608696, 0.69782608695652, -0.05
102134, 1.2434782608696, 0.67173913043478, -0.025
102135, 1.2652173913043, 0.67173913043478, -0.05
102136, 1.2869565217391, 0.69782608695652, -0.05
102137, 1.2869565217391, 0.67173913043478, -0.025
102138, 1.3086956521739, 0.67173913043478, -0.05
102139, 1.3304347826087, 0.69782608695652, -0.05
102140, 1.3304347826087, 0.67173913043478, -0.025
102141, 1.3521739130435, 0.67173913043478, -0.05
102142, 1.3739130434783, 0.69782608695652, -0.05
102143, 1.3739130434783, 0.67173913043478, -0.025
102144, 1.395652173913, 0.67173913043478, -0.05
102145, 1.4173913043478, 0.69782608695652, -0.05
102146, 1.4173913043478, 0.67173913043478, -0.025
102147, 1.4391304347826, 0.67173913043478, -0.05
102148, 1.4608695652174, 0.69782608695652, -0.05
102149, 1.4608695652174, 0.67173913043478, -0.025
102150, 1.4826086956522, 0.67173913043478, -0.05
102151, 1.504347826087, 0.69782608695652, -0.05
102152, 1.504347826087, 0.67173913043478, -0.025
102153, 1.5260869565217, 0.67173913043478, -0.05
102154, 1.5478260869565, 0.69782608695652, -0.05
102155, 1.5478260869565, 0.67173913043478, -0.025
102156, 1.5695652173913, 0.67173913043478, -0.05
102157, 1.5913043478261, 0.69782608695652, -0.05
102158, 1.5913043478261, 0.67173913043478, -0.025
102159, 1.6130434782609, 0.67173913043478, -0.05
102160, 1.6347826086957, 0.69782608695652, -0.05
102161, 1.6347826086957, 0.67173913043478, -0.025
102162, 1.6565217391304, 0.67173913043478, -0.05
102163, 1.6782608695652, 0.69782608695652, -0.05
102164, 1.6782608695652, 0.67173913043478, -0.025
102165, 1.7, 0.67173913043478, -0.05
102166, 1.7217391304348, 0.69782608695652, -0.05
102167, 1.7217391304348, 0.67173913043478, -0.025
102168, 1.7434782608696, 0.67173913043478, -0.05
102169, 1.7652173913043, 0.69782608695652, -0.05
102170, 1.7652173913043, 0.67173913043478, -0.025
102171, 1.7869565217391, 0.67173913043478, -0.05
102172, 1.8086956521739, 0.69782608695652, -0.05
102173, 1.8086956521739, 0.67173913043478, -0.025
102174, 1.8304347826087, 0.67173913043478, -0.05
102175, 1.8521739130435, 0.69782608695652, -0.05
102176, 1.8521739130435, 0.67173913043478, -0.025
102177, 1.8739130434783, 0.67173913043478, -0.05
102178, 1.895652173913, 0.69782608695652, -0.05
102179, 1.895652173913, 0.67173913043478, -0.025
102180, 1.9173913043478, 0.67173913043478, -0.05
102181, 1.9391304347826, 0.69782608695652, -0.05
102182, 1.9391304347826, 0.67173913043478, -0.025
102183, 1.9608695652174, 0.67173913043478, -0.05
102184, 1.9826086956522, 0.69782608695652, -0.05
102185, 1.9826086956522, 0.67173913043478, -0.025
102186, 2.004347826087, 0.67173913043478, -0.05
102187, 2.0260869565217, 0.69782608695652, -0.05
102188, 2.0260869565217, 0.67173913043478, -0.025
102189, 2.0478260869565, 0.67173913043478, -0.05
102190, 2.0695652173913, 0.69782608695652, -0.05
102191, 2.0695652173913, 0.67173913043478, -0.025
102192, 2.0913043478261, 0.67173913043478, -0.05
102193, 2.1130434782609, 0.69782608695652, -0.05
102194, 2.1130434782609, 0.67173913043478, -0.025
102195, 2.1347826086957, 0.67173913043478, -0.05
102196, 2.1565217391304, 0.69782608695652, -0.05
102197, 2.1565217391304, 0.67173913043478, -0.025
102198, 2.1782608695652, 0.67173913043478, -0.05
102199, 1.2217391304348, 0.61956521739131, -0.05
102200, 1.2434782608696, 0.64565217391304, -0.05
102201, 1.2434782608696, 0.61956521739131, -0.025
102202, 1.2652173913043, 0.61956521739131, -0.05
102203, 1.2869565217391, 0.64565217391304, -0.05
102204, 1.2869565217391, 0.61956521739131, -0.025
102205, 1.3086956521739, 0.61956521739131, -0.05
102206, 1.3304347826087, 0.64565217391304, -0.05
102207, 1.3304347826087, 0.61956521739131, -0.025
102208, 1.3521739130435, 0.61956521739131, -0.05
102209, 1.3739130434783, 0.64565217391304, -0.05
102210, 1.3739130434783, 0.61956521739131, -0.025
102211, 1.395652173913, 0.61956521739131, -0.05
102212, 1.4173913043478, 0.64565217391304, -0.05
102213, 1.4173913043478, 0.61956521739131, -0.025
102214, 1.4391304347826, 0.61956521739131, -0.05
102215, 1.4608695652174, 0.64565217391304, -0.05
102216, 1.4608695652174, 0.61956521739131, -0.025
102217, 1.4826086956522, 0.6195652173913, -0.05
102218, 1.504347826087, 0.64565217391304, -0.05
102219, 1.504347826087, 0.6195652173913, -0.025
102220, 1.5260869565217, 0.6195652173913, -0.05
102221, 1.5478260869565, 0.64565217391304, -0.05
102222, 1.5478260869565, 0.61956521739131, -0.025
102223, 1.5695652173913, 0.61956521739131, -0.05
102224, 1.5913043478261, 0.64565217391304, -0.05
102225, 1.5913043478261, 0.61956521739131, -0.025
102226, 1.6130434782609, 0.61956521739131, -0.05
102227, 1.6347826086957, 0.64565217391304, -0.05
102228, 1.6347826086957, 0.61956521739131, -0.025
102229, 1.6565217391304, 0.61956521739131, -0.05
102230, 1.6782608695652, 0.64565217391304, -0.05
102231, 1.6782608695652, 0.61956521739131, -0.025
102232, 1.7, 0.61956521739131, -0.05
102233, 1.7217391304348, 0.64565217391304, -0.05
102234, 1.7217391304348, 0.61956521739131, -0.025
102235, 1.7434782608696, 0.61956521739131, -0.05
102236, 1.7652173913043, 0.64565217391304, -0.05
102237, 1.7652173913043, 0.61956521739131, -0.025
102238, 1.7869565217391, 0.61956521739131, -0.05
102239, 1.8086956521739, 0.64565217391304, -0.05
102240, 1.8086956521739, 0.61956521739131, -0.025
102241, 1.8304347826087, 0.61956521739131, -0.05
102242, 1.8521739130435, 0.64565217391304, -0.05
102243, 1.8521739130435, 0.61956521739131, -0.025
102244, 1.8739130434783, 0.61956521739131, -0.05
102245, 1.895652173913, 0.64565217391304, -0.05
102246, 1.895652173913, 0.61956521739131, -0.025
102247, 1.9173913043478, 0.61956521739131, -0.05
102248, 1.9391304347826, 0.64565217391304, -0.05
102249, 1.9391304347826, 0.61956521739131, -0.025
102250, 1.9608695652174, 0.61956521739131, -0.05
102251, 1.9826086956522, 0.64565217391304, -0.05
102252, 1.9826086956522, 0.61956521739131, -0.025
102253, 2.004347826087, 0.61956521739131, -0.05
102254, 2.0260869565217, 0.64565217391304, -0.05
102255, 2.0260869565217, 0.61956521739131, -0.025
102256, 2.0478260869565, 0.61956521739131, -0.05
102257, 2.0695652173913, 0.64565217391304, -0.05
102258, 2.0695652173913, 0.61956521739131, -0.025
102259, 2.0913043478261, 0.61956521739131, -0.05
102260, 2.1130434782609, 0.64565217391304, -0.05
102261, 2.1130434782609, 0.61956521739131, -0.025
102262, 2.1347826086957, 0.61956521739131, -0.05
102263, 2.1565217391304, 0.64565217391304, -0.05
102264, 2.1565217391304, 0.61956521739131, -0.025
102265, 2.1782608695652, 0.61956521739131, -0.05
102266, 1.2217391304348, 0.56739130434783, -0.05
102267, 1.2434782608696, 0.59347826086957, -0.05
102268, 1.2434782608696, 0.56739130434783, -0.025
102269, 1.2652173913043, 0.56739130434783, -0.05
102270, 1.2869565217391, 0.59347826086957, -0.05
102271, 1.2869565217391, 0.56739130434783, -0.025
102272, 1.3086956521739, 0.56739130434783, -0.05
102273, 1.3304347826087, 0.59347826086957, -0.05
102274, 1.3304347826087, 0.56739130434783, -0.025
102275, 1.3521739130435, 0.56739130434783, -0.05
102276, 1.3739130434783, 0.59347826086957, -0.05
102277, 1.3739130434783, 0.56739130434783, -0.025
102278, 1.395652173913, 0.56739130434783, -0.05
102279, 1.4173913043478, 0.59347826086957, -0.05
102280, 1.4173913043478, 0.56739130434783, -0.025
102281, 1.4391304347826, 0.56739130434783, -0.05
102282, 1.4608695652174, 0.59347826086957, -0.05
102283, 1.4608695652174, 0.56739130434783, -0.025
102284, 1.4826086956522, 0.56739130434783, -0.05
102285, 1.504347826087, 0.59347826086957, -0.05
102286, 1.504347826087, 0.56739130434783, -0.025
102287, 1.5260869565217, 0.56739130434783, -0.05
102288, 1.5478260869565, 0.59347826086957, -0.05
102289, 1.5478260869565, 0.56739130434783, -0.025
102290, 1.5695652173913, 0.56739130434783, -0.05
102291, 1.5913043478261, 0.59347826086957, -0.05
102292, 1.5913043478261, 0.56739130434783, -0.025
102293, 1.6130434782609, 0.56739130434783, -0.05
102294, 1.6347826086957, 0.59347826086957, -0.05
102295, 1.6347826086957, 0.56739130434783, -0.025
102296, 1.6565217391304, 0.56739130434783, -0.05
102297, 1.6782608695652, 0.59347826086957, -0.05
102298, 1.6782608695652, 0.56739130434783, -0.025
102299, 1.7, 0.56739130434783, -0.05
102300, 1.7217391304348, 0.59347826086957, -0.05
102301, 1.7217391304348, 0.56739130434783, -0.025
102302, 1.7434782608696, 0.56739130434783, -0.05
102303, 1.7652173913043, 0.59347826086957, -0.05
102304, 1.7652173913043, 0.56739130434783, -0.025
102305, 1.7869565217391, 0.56739130434783, -0.05
102306, 1.8086956521739, 0.59347826086957, -0.05
102307, 1.8086956521739, 0.56739130434783, -0.025
102308, 1.8304347826087, 0.56739130434783, -0.05
102309, 1.8521739130435, 0.59347826086957, -0.05
102310, 1.8521739130435, 0.56739130434783, -0.025
102311, 1.8739130434783, 0.56739130434783, -0.05
102312, 1.895652173913, 0.59347826086957, -0.05
102313, 1.895652173913, 0.56739130434783, -0.025
102314, 1.9173913043478, 0.56739130434783, -0.05
102315, 1.9391304347826, 0.59347826086957, -0.05
102316, 1.9391304347826, 0.56739130434783, -0.025
102317, 1.9608695652174, 0.56739130434783, -0.05
102318, 1.9826086956522, 0.59347826086957, -0.05
102319, 1.9826086956522, 0.56739130434783, -0.025
102320, 2.004347826087, 0.56739130434783, -0.05
102321, 2.0260869565217, 0.59347826086957, -0.05
102322, 2.0260869565217, 0.56739130434783, -0.025
102323, 2.0478260869565, 0.56739130434783, -0.05
102324, 2.0695652173913, 0.59347826086957, -0.05
102325, 2.0695652173913, 0.56739130434783, -0.025
102326, 2.0913043478261, 0.56739130434783, -0.05
102327, 2.1130434782609, 0.59347826086957, -0.05
102328, 2.1130434782609, 0.56739130434783, -0.025
102329, 2.1347826086957, 0.56739130434783, -0.05
102330, 2.1565217391304, 0.59347826086957, -0.05
102331, 2.1565217391304, 0.56739130434783, -0.025
102332, 2.1782608695652, 0.56739130434783, -0.05
102333, 1.2217391304348, 0.51521739130435, -0.05
102334, 1.2434782608696, 0.54130434782609, -0.05
102335, 1.2434782608696, 0.51521739130435, -0.025
102336, 1.2652173913043, 0.51521739130435, -0.05
102337, 1.2869565217391, 0.54130434782609, -0.05
102338, 1.2869565217391, 0.51521739130435, -0.025
102339, 1.3086956521739, 0.51521739130435, -0.05
102340, 1.3304347826087, 0.54130434782609, -0.05
102341, 1.3304347826087, 0.51521739130435, -0.025
102342, 1.3521739130435, 0.51521739130435, -0.05
102343, 1.3739130434783, 0.54130434782609, -0.05
102344, 1.3739130434783, 0.51521739130435, -0.025
102345, 1.395652173913, 0.51521739130435, -0.05
102346, 1.4173913043478, 0.54130434782609, -0.05
102347, 1.4173913043478, 0.51521739130435, -0.025
102348, 1.4391304347826, 0.51521739130435, -0.05
102349, 1.4608695652174, 0.54130434782609, -0.05
102350, 1.4608695652174, 0.51521739130435, -0.025
102351, 1.4826086956522, 0.51521739130435, -0.05
102352, 1.504347826087, 0.54130434782609, -0.05
102353, 1.504347826087, 0.51521739130435, -0.025
102354, 1.5260869565217, 0.51521739130435, -0.05
102355, 1.5478260869565, 0.54130434782609, -0.05
102356, 1.5478260869565, 0.51521739130435, -0.025
102357, 1.5695652173913, 0.51521739130435, -0.05
102358, 1.5913043478261, 0.54130434782609, -0.05
102359, 1.5913043478261, 0.51521739130435, -0.025
102360, 1.6130434782609, 0.51521739130435, -0.05
102361, 1.6347826086957, 0.54130434782609, -0.05
102362, 1.6347826086957, 0.51521739130435, -0.025
102363, 1.6565217391304, 0.51521739130435, -0.05
102364, 1.6782608695652, 0.54130434782609, -0.05
102365, 1.6782608695652, 0.51521739130435, -0.025
102366, 1.7, 0.51521739130435, -0.05
102367, 1.7217391304348, 0.54130434782609, -0.05
102368, 1.7217391304348, 0.51521739130435, -0.025
102369, 1.7434782608696, 0.51521739130435, -0.05
102370, 1.7652173913043, 0.54130434782609, -0.05
102371, 1.7652173913043, 0.51521739130435, -0.025
102372, 1.7869565217391, 0.51521739130435, -0.05
102373, 1.8086956521739, 0.54130434782609, -0.05
102374, 1.8086956521739, 0.51521739130435, -0.025
102375, 1.8304347826087, 0.51521739130435, -0.05
102376, 1.8521739130435, 0.54130434782609, -0.05
102377, 1.8521739130435, 0.51521739130435, -0.025
102378, 1.8739130434783, 0.51521739130435, -0.05
102379, 1.895652173913, 0.54130434782609, -0.05
102380, 1.895652173913, 0.51521739130435, -0.025
102381, 1.9173913043478, 0.51521739130435, -0.05
102382, 1.9391304347826, 0.54130434782609, -0.05
102383, 1.9391304347826, 0.51521739130435, -0.025
102384, 1.9608695652174, 0.51521739130435, -0.05
102385, 1.9826086956522, 0.54130434782609, -0.05
102386, 1.9826086956522, 0.51521739130435, -0.025
102387, 2.004347826087, 0.51521739130435, -0.05
102388, 2.0260869565217, 0.54130434782609, -0.05
102389, 2.0260869565217, 0.51521739130435, -0.025
102390, 2.0478260869565, 0.51521739130435, -0.05
102391, 2.0695652173913, 0.54130434782609, -0.05
102392, 2.0695652173913, 0.51521739130435, -0.025
102393, 2.0913043478261, 0.51521739130435, -0.05
102394, 2.1130434782609, 0.54130434782609, -0.05
102395, 2.1130434782609, 0.51521739130435, -0.025
102396, 2.1347826086957, 0.51521739130435, -0.05
102397, 2.1565217391304, 0.54130434782609, -0.05
102398, 2.1565217391304, 0.51521739130435, -0.025
102399, 2.1782608695652, 0.51521739130435, -0.05
102400, 1.2217391304348, 0.46304347826087, -0.05
102401, 1.2434782608696, 0.48913043478261, -0.05
102402, 1.2434782608696, 0.46304347826087, -0.025
102403, 1.2652173913043, 0.46304347826087, -0.05
102404, 1.2869565217391, 0.48913043478261, -0.05
102405, 1.2869565217391, 0.46304347826087, -0.025
102406, 1.3086956521739, 0.46304347826087, -0.05
102407, 1.3304347826087, 0.48913043478261, -0.05
102408, 1.3304347826087, 0.46304347826087, -0.025
102409, 1.3521739130435, 0.46304347826087, -0.05
102410, 1.3739130434783, 0.48913043478261, -0.05
102411, 1.3739130434783, 0.46304347826087, -0.025
102412, 1.395652173913, 0.46304347826087, -0.05
102413, 1.4173913043478, 0.48913043478261, -0.05
102414, 1.4173913043478, 0.46304347826087, -0.025
102415, 1.4391304347826, 0.46304347826087, -0.05
102416, 1.4608695652174, 0.48913043478261, -0.05
102417, 1.4608695652174, 0.46304347826087, -0.025
102418, 1.4826086956522, 0.46304347826087, -0.05
102419, 1.504347826087, 0.48913043478261, -0.05
102420, 1.504347826087, 0.46304347826087, -0.025
102421, 1.5260869565217, 0.46304347826087, -0.05
102422, 1.5478260869565, 0.48913043478261, -0.05
102423, 1.5478260869565, 0.46304347826087, -0.025
102424, 1.5695652173913, 0.46304347826087, -0.05
102425, 1.5913043478261, 0.48913043478261, -0.05
102426, 1.5913043478261, 0.46304347826087, -0.025
102427, 1.6130434782609, 0.46304347826087, -0.05
102428, 1.6347826086957, 0.48913043478261, -0.05
102429, 1.6347826086957, 0.46304347826087, -0.025
102430, 1.6565217391304, 0.46304347826087, -0.05
102431, 1.6782608695652, 0.48913043478261, -0.05
102432, 1.6782608695652, 0.46304347826087, -0.025
102433, 1.7, 0.46304347826087, -0.05
102434, 1.7217391304348, 0.48913043478261, -0.05
102435, 1.7217391304348, 0.46304347826087, -0.025
102436, 1.7434782608696, 0.46304347826087, -0.05
102437, 1.7652173913043, 0.48913043478261, -0.05
102438, 1.7652173913043, 0.46304347826087, -0.025
102439, 1.7869565217391, 0.46304347826087, -0.05
102440, 1.8086956521739, 0.48913043478261, -0.05
102441, 1.8086956521739, 0.46304347826087, -0.025
102442, 1.8304347826087, 0.46304347826087, -0.05
102443, 1.8521739130435, 0.48913043478261, -0.05
102444, 1.8521739130435, 0.46304347826087, -0.025
102445, 1.8739130434783, 0.46304347826087, -0.05
102446, 1.895652173913, 0.48913043478261, -0.05
102447, 1.895652173913, 0.46304347826087, -0.025
102448, 1.9173913043478, 0.46304347826087, -0.05
102449, 1.9391304347826, 0.48913043478261, -0.05
102450, 1.9391304347826, 0.46304347826087, -0.025
102451, 1.9608695652174, 0.46304347826087, -0.05
102452, 1.9826086956522, 0.48913043478261, -0.05
102453, 1.9826086956522, 0.46304347826087, -0.025
102454, 2.004347826087, 0.46304347826087, -0.05
102455, 2.0260869565217, 0.48913043478261, -0.05
102456, 2.0260869565217, 0.46304347826087, -0.025
102457, 2.0478260869565, 0.46304347826087, -0.05
102458, 2.0695652173913, 0.48913043478261, -0.05
102459, 2.0695652173913, 0.46304347826087, -0.025
102460, 2.0913043478261, 0.46304347826087, -0.05
102461, 2.1130434782609, 0.48913043478261, -0.05
102462, 2.1130434782609, 0.46304347826087, -0.025
102463, 2.1347826086957, 0.46304347826087, -0.05
102464, 2.1565217391304, 0.48913043478261, -0.05
102465, 2.1565217391304, 0.46304347826087, -0.025
102466, 2.1782608695652, 0.46304347826087, -0.05
102467, 1.2217391304348, 0.41086956521739, -0.05
102468, 1.2434782608696, 0.43695652173913, -0.05
102469, 1.2434782608696, 0.41086956521739, -0.025
102470, 1.2652173913043, 0.41086956521739, -0.05
102471, 1.2869565217391, 0.43695652173913, -0.05
