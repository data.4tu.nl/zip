24412, 61591, 61583, 61407, 61415, 61592, 61584, 61408, 61416, 68849, 68825, 68291, 68850, 68852, 68828, 68294, 
68853, 68851, 68826, 68268, 68293
24413, 61592, 61584, 61408, 61416, 61593, 61585, 61409, 61417, 68852, 68828, 68294, 68853, 68855, 68831, 68297, 
68856, 68854, 68829, 68271, 68296
24414, 61593, 61585, 61409, 61417, 61594, 61586, 61410, 61418, 68855, 68831, 68297, 68856, 68858, 68834, 68300, 
68859, 68857, 68832, 68274, 68299
24415, 61594, 61586, 61410, 61418, 61595, 61587, 61411, 61419, 68858, 68834, 68300, 68859, 68861, 68837, 68303, 
68862, 68860, 68835, 68277, 68302
24416, 61595, 61587, 61411, 61419, 26275, 26274, 26252, 26253, 68861, 68837, 68303, 68862, 26963, 26960, 26918, 
26962, 68863, 68838, 68280, 68305
24417, 24780, 24779, 24757, 24758, 61596, 61588, 61412, 61420, 25468, 25467, 25423, 25469, 68865, 68841, 68307, 
68866, 68864, 68839, 68281, 68306
24418, 61596, 61588, 61412, 61420, 61597, 61589, 61413, 61421, 68865, 68841, 68307, 68866, 68868, 68844, 68310, 
68869, 68867, 68842, 68284, 68309
24419, 61597, 61589, 61413, 61421, 61598, 61590, 61414, 61422, 68868, 68844, 68310, 68869, 68871, 68847, 68313, 
68872, 68870, 68845, 68287, 68312
24420, 61598, 61590, 61414, 61422, 61599, 61591, 61415, 61423, 68871, 68847, 68313, 68872, 68874, 68850, 68316, 
68875, 68873, 68848, 68290, 68315
24421, 61599, 61591, 61415, 61423, 61600, 61592, 61416, 61424, 68874, 68850, 68316, 68875, 68877, 68853, 68319, 
68878, 68876, 68851, 68293, 68318
24422, 61600, 61592, 61416, 61424, 61601, 61593, 61417, 61425, 68877, 68853, 68319, 68878, 68880, 68856, 68322, 
68881, 68879, 68854, 68296, 68321
24423, 61601, 61593, 61417, 61425, 61602, 61594, 61418, 61426, 68880, 68856, 68322, 68881, 68883, 68859, 68325, 
68884, 68882, 68857, 68299, 68324
24424, 61602, 61594, 61418, 61426, 61603, 61595, 61419, 61427, 68883, 68859, 68325, 68884, 68886, 68862, 68328, 
68887, 68885, 68860, 68302, 68327
24425, 61603, 61595, 61419, 61427, 26276, 26275, 26253, 26254, 68886, 68862, 68328, 68887, 26965, 26962, 26920, 
26964, 68888, 68863, 68305, 68330
24426, 24781, 24780, 24758, 24759, 61604, 61596, 61420, 61428, 25470, 25469, 25425, 25471, 68890, 68866, 68332, 
68891, 68889, 68864, 68306, 68331
24427, 61604, 61596, 61420, 61428, 61605, 61597, 61421, 61429, 68890, 68866, 68332, 68891, 68893, 68869, 68335, 
68894, 68892, 68867, 68309, 68334
24428, 61605, 61597, 61421, 61429, 61606, 61598, 61422, 61430, 68893, 68869, 68335, 68894, 68896, 68872, 68338, 
68897, 68895, 68870, 68312, 68337
24429, 61606, 61598, 61422, 61430, 61607, 61599, 61423, 61431, 68896, 68872, 68338, 68897, 68899, 68875, 68341, 
68900, 68898, 68873, 68315, 68340
24430, 61607, 61599, 61423, 61431, 61608, 61600, 61424, 61432, 68899, 68875, 68341, 68900, 68902, 68878, 68344, 
68903, 68901, 68876, 68318, 68343
24431, 61608, 61600, 61424, 61432, 61609, 61601, 61425, 61433, 68902, 68878, 68344, 68903, 68905, 68881, 68347, 
68906, 68904, 68879, 68321, 68346
24432, 61609, 61601, 61425, 61433, 61610, 61602, 61426, 61434, 68905, 68881, 68347, 68906, 68908, 68884, 68350, 
68909, 68907, 68882, 68324, 68349
24433, 61610, 61602, 61426, 61434, 61611, 61603, 61427, 61435, 68908, 68884, 68350, 68909, 68911, 68887, 68353, 
68912, 68910, 68885, 68327, 68352
24434, 61611, 61603, 61427, 61435, 26277, 26276, 26254, 26255, 68911, 68887, 68353, 68912, 26967, 26964, 26922, 
26966, 68913, 68888, 68330, 68355
24435, 3178, 24781, 24759, 3177, 28198, 61604, 61428, 28190, 25472, 25471, 25427, 3200, 68914, 68891, 68356, 
28447, 28446, 68889, 68331, 28429
24436, 28198, 61604, 61428, 28190, 28199, 61605, 61429, 28191, 68914, 68891, 68356, 28447, 68915, 68894, 68357, 
28449, 28448, 68892, 68334, 28431
24437, 28199, 61605, 61429, 28191, 28200, 61606, 61430, 28192, 68915, 68894, 68357, 28449, 68916, 68897, 68358, 
28451, 28450, 68895, 68337, 28433
24438, 28200, 61606, 61430, 28192, 28201, 61607, 61431, 28193, 68916, 68897, 68358, 28451, 68917, 68900, 68359, 
28453, 28452, 68898, 68340, 28435
24439, 28201, 61607, 61431, 28193, 28202, 61608, 61432, 28194, 68917, 68900, 68359, 28453, 68918, 68903, 68360, 
28455, 28454, 68901, 68343, 28437
24440, 28202, 61608, 61432, 28194, 28203, 61609, 61433, 28195, 68918, 68903, 68360, 28455, 68919, 68906, 68361, 
28457, 28456, 68904, 68346, 28439
24441, 28203, 61609, 61433, 28195, 28204, 61610, 61434, 28196, 68919, 68906, 68361, 28457, 68920, 68909, 68362, 
28459, 28458, 68907, 68349, 28441
24442, 28204, 61610, 61434, 28196, 28205, 61611, 61435, 28197, 68920, 68909, 68362, 28459, 68921, 68912, 68363, 
28461, 28460, 68910, 68352, 28443
24443, 28205, 61611, 61435, 28197, 3313, 26277, 26255, 3312, 68921, 68912, 68363, 28461, 26968, 26966, 26923, 
3335, 28462, 68913, 68355, 28445
24444, 24782, 3134, 3133, 24760, 61612, 27648, 27640, 61436, 25473, 3156, 25428, 25474, 68923, 27905, 68365, 
68924, 68922, 27906, 27889, 68364
24445, 61612, 27648, 27640, 61436, 61613, 27649, 27641, 61437, 68923, 27905, 68365, 68924, 68926, 27907, 68368, 
68927, 68925, 27908, 27891, 68367
24446, 61613, 27649, 27641, 61437, 61614, 27650, 27642, 61438, 68926, 27907, 68368, 68927, 68929, 27909, 68371, 
68930, 68928, 27910, 27893, 68370
24447, 61614, 27650, 27642, 61438, 61615, 27651, 27643, 61439, 68929, 27909, 68371, 68930, 68932, 27911, 68374, 
68933, 68931, 27912, 27895, 68373
24448, 61615, 27651, 27643, 61439, 61616, 27652, 27644, 61440, 68932, 27911, 68374, 68933, 68935, 27913, 68377, 
68936, 68934, 27914, 27897, 68376
24449, 61616, 27652, 27644, 61440, 61617, 27653, 27645, 61441, 68935, 27913, 68377, 68936, 68938, 27915, 68380, 
68939, 68937, 27916, 27899, 68379
24450, 61617, 27653, 27645, 61441, 61618, 27654, 27646, 61442, 68938, 27915, 68380, 68939, 68941, 27917, 68383, 
68942, 68940, 27918, 27901, 68382
24451, 61618, 27654, 27646, 61442, 61619, 27655, 27647, 61443, 68941, 27917, 68383, 68942, 68944, 27919, 68386, 
68945, 68943, 27920, 27903, 68385
24452, 61619, 27655, 27647, 61443, 26278, 3269, 3268, 26256, 68944, 27919, 68386, 68945, 26970, 3291, 26925, 
26969, 68946, 27921, 27904, 68388
24453, 24783, 24782, 24760, 24761, 61620, 61612, 61436, 61444, 25475, 25474, 25430, 25476, 68948, 68924, 68390, 
68949, 68947, 68922, 68364, 68389
24454, 61620, 61612, 61436, 61444, 61621, 61613, 61437, 61445, 68948, 68924, 68390, 68949, 68951, 68927, 68393, 
68952, 68950, 68925, 68367, 68392
24455, 61621, 61613, 61437, 61445, 61622, 61614, 61438, 61446, 68951, 68927, 68393, 68952, 68954, 68930, 68396, 
68955, 68953, 68928, 68370, 68395
24456, 61622, 61614, 61438, 61446, 61623, 61615, 61439, 61447, 68954, 68930, 68396, 68955, 68957, 68933, 68399, 
68958, 68956, 68931, 68373, 68398
24457, 61623, 61615, 61439, 61447, 61624, 61616, 61440, 61448, 68957, 68933, 68399, 68958, 68960, 68936, 68402, 
68961, 68959, 68934, 68376, 68401
24458, 61624, 61616, 61440, 61448, 61625, 61617, 61441, 61449, 68960, 68936, 68402, 68961, 68963, 68939, 68405, 
68964, 68962, 68937, 68379, 68404
24459, 61625, 61617, 61441, 61449, 61626, 61618, 61442, 61450, 68963, 68939, 68405, 68964, 68966, 68942, 68408, 
68967, 68965, 68940, 68382, 68407
24460, 61626, 61618, 61442, 61450, 61627, 61619, 61443, 61451, 68966, 68942, 68408, 68967, 68969, 68945, 68411, 
68970, 68968, 68943, 68385, 68410
24461, 61627, 61619, 61443, 61451, 26279, 26278, 26256, 26257, 68969, 68945, 68411, 68970, 26972, 26969, 26927, 
26971, 68971, 68946, 68388, 68413
24462, 24784, 24783, 24761, 24762, 61628, 61620, 61444, 61452, 25477, 25476, 25432, 25478, 68973, 68949, 68415, 
68974, 68972, 68947, 68389, 68414
24463, 61628, 61620, 61444, 61452, 61629, 61621, 61445, 61453, 68973, 68949, 68415, 68974, 68976, 68952, 68418, 
68977, 68975, 68950, 68392, 68417
24464, 61629, 61621, 61445, 61453, 61630, 61622, 61446, 61454, 68976, 68952, 68418, 68977, 68979, 68955, 68421, 
68980, 68978, 68953, 68395, 68420
24465, 61630, 61622, 61446, 61454, 61631, 61623, 61447, 61455, 68979, 68955, 68421, 68980, 68982, 68958, 68424, 
68983, 68981, 68956, 68398, 68423
24466, 61631, 61623, 61447, 61455, 61632, 61624, 61448, 61456, 68982, 68958, 68424, 68983, 68985, 68961, 68427, 
68986, 68984, 68959, 68401, 68426
24467, 61632, 61624, 61448, 61456, 61633, 61625, 61449, 61457, 68985, 68961, 68427, 68986, 68988, 68964, 68430, 
68989, 68987, 68962, 68404, 68429
24468, 61633, 61625, 61449, 61457, 61634, 61626, 61450, 61458, 68988, 68964, 68430, 68989, 68991, 68967, 68433, 
68992, 68990, 68965, 68407, 68432
24469, 61634, 61626, 61450, 61458, 61635, 61627, 61451, 61459, 68991, 68967, 68433, 68992, 68994, 68970, 68436, 
68995, 68993, 68968, 68410, 68435
24470, 61635, 61627, 61451, 61459, 26280, 26279, 26257, 26258, 68994, 68970, 68436, 68995, 26974, 26971, 26929, 
26973, 68996, 68971, 68413, 68438
24471, 24785, 24784, 24762, 24763, 61636, 61628, 61452, 61460, 25479, 25478, 25434, 25480, 68998, 68974, 68440, 
68999, 68997, 68972, 68414, 68439
24472, 61636, 61628, 61452, 61460, 61637, 61629, 61453, 61461, 68998, 68974, 68440, 68999, 69001, 68977, 68443, 
69002, 69000, 68975, 68417, 68442
24473, 61637, 61629, 61453, 61461, 61638, 61630, 61454, 61462, 69001, 68977, 68443, 69002, 69004, 68980, 68446, 
69005, 69003, 68978, 68420, 68445
24474, 61638, 61630, 61454, 61462, 61639, 61631, 61455, 61463, 69004, 68980, 68446, 69005, 69007, 68983, 68449, 
69008, 69006, 68981, 68423, 68448
24475, 61639, 61631, 61455, 61463, 61640, 61632, 61456, 61464, 69007, 68983, 68449, 69008, 69010, 68986, 68452, 
69011, 69009, 68984, 68426, 68451
24476, 61640, 61632, 61456, 61464, 61641, 61633, 61457, 61465, 69010, 68986, 68452, 69011, 69013, 68989, 68455, 
69014, 69012, 68987, 68429, 68454
24477, 61641, 61633, 61457, 61465, 61642, 61634, 61458, 61466, 69013, 68989, 68455, 69014, 69016, 68992, 68458, 
69017, 69015, 68990, 68432, 68457
24478, 61642, 61634, 61458, 61466, 61643, 61635, 61459, 61467, 69016, 68992, 68458, 69017, 69019, 68995, 68461, 
69020, 69018, 68993, 68435, 68460
24479, 61643, 61635, 61459, 61467, 26281, 26280, 26258, 26259, 69019, 68995, 68461, 69020, 26976, 26973, 26931, 
26975, 69021, 68996, 68438, 68463
24480, 24786, 24785, 24763, 24764, 61644, 61636, 61460, 61468, 25481, 25480, 25436, 25482, 69023, 68999, 68465, 
69024, 69022, 68997, 68439, 68464
24481, 61644, 61636, 61460, 61468, 61645, 61637, 61461, 61469, 69023, 68999, 68465, 69024, 69026, 69002, 68468, 
69027, 69025, 69000, 68442, 68467
24482, 61645, 61637, 61461, 61469, 61646, 61638, 61462, 61470, 69026, 69002, 68468, 69027, 69029, 69005, 68471, 
69030, 69028, 69003, 68445, 68470
24483, 61646, 61638, 61462, 61470, 61647, 61639, 61463, 61471, 69029, 69005, 68471, 69030, 69032, 69008, 68474, 
69033, 69031, 69006, 68448, 68473
24484, 61647, 61639, 61463, 61471, 61648, 61640, 61464, 61472, 69032, 69008, 68474, 69033, 69035, 69011, 68477, 
69036, 69034, 69009, 68451, 68476
24485, 61648, 61640, 61464, 61472, 61649, 61641, 61465, 61473, 69035, 69011, 68477, 69036, 69038, 69014, 68480, 
69039, 69037, 69012, 68454, 68479
24486, 61649, 61641, 61465, 61473, 61650, 61642, 61466, 61474, 69038, 69014, 68480, 69039, 69041, 69017, 68483, 
69042, 69040, 69015, 68457, 68482
24487, 61650, 61642, 61466, 61474, 61651, 61643, 61467, 61475, 69041, 69017, 68483, 69042, 69044, 69020, 68486, 
69045, 69043, 69018, 68460, 68485
24488, 61651, 61643, 61467, 61475, 26282, 26281, 26259, 26260, 69044, 69020, 68486, 69045, 26978, 26975, 26933, 
26977, 69046, 69021, 68463, 68488
24489, 24787, 24786, 24764, 24765, 61652, 61644, 61468, 61476, 25483, 25482, 25438, 25484, 69048, 69024, 68490, 
69049, 69047, 69022, 68464, 68489
24490, 61652, 61644, 61468, 61476, 61653, 61645, 61469, 61477, 69048, 69024, 68490, 69049, 69051, 69027, 68493, 
69052, 69050, 69025, 68467, 68492
24491, 61653, 61645, 61469, 61477, 61654, 61646, 61470, 61478, 69051, 69027, 68493, 69052, 69054, 69030, 68496, 
69055, 69053, 69028, 68470, 68495
24492, 61654, 61646, 61470, 61478, 61655, 61647, 61471, 61479, 69054, 69030, 68496, 69055, 69057, 69033, 68499, 
69058, 69056, 69031, 68473, 68498
24493, 61655, 61647, 61471, 61479, 61656, 61648, 61472, 61480, 69057, 69033, 68499, 69058, 69060, 69036, 68502, 
69061, 69059, 69034, 68476, 68501
24494, 61656, 61648, 61472, 61480, 61657, 61649, 61473, 61481, 69060, 69036, 68502, 69061, 69063, 69039, 68505, 
69064, 69062, 69037, 68479, 68504
24495, 61657, 61649, 61473, 61481, 61658, 61650, 61474, 61482, 69063, 69039, 68505, 69064, 69066, 69042, 68508, 
69067, 69065, 69040, 68482, 68507
24496, 61658, 61650, 61474, 61482, 61659, 61651, 61475, 61483, 69066, 69042, 68508, 69067, 69069, 69045, 68511, 
69070, 69068, 69043, 68485, 68510
24497, 61659, 61651, 61475, 61483, 26283, 26282, 26260, 26261, 69069, 69045, 68511, 69070, 26980, 26977, 26935, 
26979, 69071, 69046, 68488, 68513
24498, 24788, 24787, 24765, 24766, 61660, 61652, 61476, 61484, 25485, 25484, 25440, 25486, 69073, 69049, 68515, 
69074, 69072, 69047, 68489, 68514
24499, 61660, 61652, 61476, 61484, 61661, 61653, 61477, 61485, 69073, 69049, 68515, 69074, 69076, 69052, 68518, 
69077, 69075, 69050, 68492, 68517
24500, 61661, 61653, 61477, 61485, 61662, 61654, 61478, 61486, 69076, 69052, 68518, 69077, 69079, 69055, 68521, 
69080, 69078, 69053, 68495, 68520
24501, 61662, 61654, 61478, 61486, 61663, 61655, 61479, 61487, 69079, 69055, 68521, 69080, 69082, 69058, 68524, 
69083, 69081, 69056, 68498, 68523
24502, 61663, 61655, 61479, 61487, 61664, 61656, 61480, 61488, 69082, 69058, 68524, 69083, 69085, 69061, 68527, 
69086, 69084, 69059, 68501, 68526
24503, 61664, 61656, 61480, 61488, 61665, 61657, 61481, 61489, 69085, 69061, 68527, 69086, 69088, 69064, 68530, 
69089, 69087, 69062, 68504, 68529
24504, 61665, 61657, 61481, 61489, 61666, 61658, 61482, 61490, 69088, 69064, 68530, 69089, 69091, 69067, 68533, 
69092, 69090, 69065, 68507, 68532
24505, 61666, 61658, 61482, 61490, 61667, 61659, 61483, 61491, 69091, 69067, 68533, 69092, 69094, 69070, 68536, 
69095, 69093, 69068, 68510, 68535
24506, 61667, 61659, 61483, 61491, 26284, 26283, 26261, 26262, 69094, 69070, 68536, 69095, 26982, 26979, 26937, 
26981, 69096, 69071, 68513, 68538
24507, 24789, 24788, 24766, 24767, 61668, 61660, 61484, 61492, 25487, 25486, 25442, 25488, 69098, 69074, 68540, 
69099, 69097, 69072, 68514, 68539
24508, 61668, 61660, 61484, 61492, 61669, 61661, 61485, 61493, 69098, 69074, 68540, 69099, 69101, 69077, 68543, 
69102, 69100, 69075, 68517, 68542
24509, 61669, 61661, 61485, 61493, 61670, 61662, 61486, 61494, 69101, 69077, 68543, 69102, 69104, 69080, 68546, 
69105, 69103, 69078, 68520, 68545
24510, 61670, 61662, 61486, 61494, 61671, 61663, 61487, 61495, 69104, 69080, 68546, 69105, 69107, 69083, 68549, 
69108, 69106, 69081, 68523, 68548
24511, 61671, 61663, 61487, 61495, 61672, 61664, 61488, 61496, 69107, 69083, 68549, 69108, 69110, 69086, 68552, 
69111, 69109, 69084, 68526, 68551
24512, 61672, 61664, 61488, 61496, 61673, 61665, 61489, 61497, 69110, 69086, 68552, 69111, 69113, 69089, 68555, 
69114, 69112, 69087, 68529, 68554
24513, 61673, 61665, 61489, 61497, 61674, 61666, 61490, 61498, 69113, 69089, 68555, 69114, 69116, 69092, 68558, 
69117, 69115, 69090, 68532, 68557
24514, 61674, 61666, 61490, 61498, 61675, 61667, 61491, 61499, 69116, 69092, 68558, 69117, 69119, 69095, 68561, 
69120, 69118, 69093, 68535, 68560
24515, 61675, 61667, 61491, 61499, 26285, 26284, 26262, 26263, 69119, 69095, 68561, 69120, 26984, 26981, 26939, 
26983, 69121, 69096, 68538, 68563
24516, 24790, 24789, 24767, 24768, 61676, 61668, 61492, 61500, 25489, 25488, 25444, 25490, 69123, 69099, 68565, 
69124, 69122, 69097, 68539, 68564
24517, 61676, 61668, 61492, 61500, 61677, 61669, 61493, 61501, 69123, 69099, 68565, 69124, 69126, 69102, 68568, 
69127, 69125, 69100, 68542, 68567
24518, 61677, 61669, 61493, 61501, 61678, 61670, 61494, 61502, 69126, 69102, 68568, 69127, 69129, 69105, 68571, 
69130, 69128, 69103, 68545, 68570
24519, 61678, 61670, 61494, 61502, 61679, 61671, 61495, 61503, 69129, 69105, 68571, 69130, 69132, 69108, 68574, 
69133, 69131, 69106, 68548, 68573
24520, 61679, 61671, 61495, 61503, 61680, 61672, 61496, 61504, 69132, 69108, 68574, 69133, 69135, 69111, 68577, 
69136, 69134, 69109, 68551, 68576
24521, 61680, 61672, 61496, 61504, 61681, 61673, 61497, 61505, 69135, 69111, 68577, 69136, 69138, 69114, 68580, 
69139, 69137, 69112, 68554, 68579
24522, 61681, 61673, 61497, 61505, 61682, 61674, 61498, 61506, 69138, 69114, 68580, 69139, 69141, 69117, 68583, 
69142, 69140, 69115, 68557, 68582
24523, 61682, 61674, 61498, 61506, 61683, 61675, 61499, 61507, 69141, 69117, 68583, 69142, 69144, 69120, 68586, 
69145, 69143, 69118, 68560, 68585
24524, 61683, 61675, 61499, 61507, 26286, 26285, 26263, 26264, 69144, 69120, 68586, 69145, 26986, 26983, 26941, 
26985, 69146, 69121, 68563, 68588
24525, 24791, 24790, 24768, 24769, 61684, 61676, 61500, 61508, 25491, 25490, 25446, 25492, 69148, 69124, 68590, 
69149, 69147, 69122, 68564, 68589
24526, 61684, 61676, 61500, 61508, 61685, 61677, 61501, 61509, 69148, 69124, 68590, 69149, 69151, 69127, 68593, 
69152, 69150, 69125, 68567, 68592
24527, 61685, 61677, 61501, 61509, 61686, 61678, 61502, 61510, 69151, 69127, 68593, 69152, 69154, 69130, 68596, 
69155, 69153, 69128, 68570, 68595
24528, 61686, 61678, 61502, 61510, 61687, 61679, 61503, 61511, 69154, 69130, 68596, 69155, 69157, 69133, 68599, 
69158, 69156, 69131, 68573, 68598
24529, 61687, 61679, 61503, 61511, 61688, 61680, 61504, 61512, 69157, 69133, 68599, 69158, 69160, 69136, 68602, 
69161, 69159, 69134, 68576, 68601
24530, 61688, 61680, 61504, 61512, 61689, 61681, 61505, 61513, 69160, 69136, 68602, 69161, 69163, 69139, 68605, 
69164, 69162, 69137, 68579, 68604
24531, 61689, 61681, 61505, 61513, 61690, 61682, 61506, 61514, 69163, 69139, 68605, 69164, 69166, 69142, 68608, 
69167, 69165, 69140, 68582, 68607
24532, 61690, 61682, 61506, 61514, 61691, 61683, 61507, 61515, 69166, 69142, 68608, 69167, 69169, 69145, 68611, 
69170, 69168, 69143, 68585, 68610
24533, 61691, 61683, 61507, 61515, 26287, 26286, 26264, 26265, 69169, 69145, 68611, 69170, 26988, 26985, 26943, 
26987, 69171, 69146, 68588, 68613
24534, 24792, 24791, 24769, 24770, 61692, 61684, 61508, 61516, 25493, 25492, 25448, 25494, 69173, 69149, 68615, 
69174, 69172, 69147, 68589, 68614
24535, 61692, 61684, 61508, 61516, 61693, 61685, 61509, 61517, 69173, 69149, 68615, 69174, 69176, 69152, 68618, 
69177, 69175, 69150, 68592, 68617
24536, 61693, 61685, 61509, 61517, 61694, 61686, 61510, 61518, 69176, 69152, 68618, 69177, 69179, 69155, 68621, 
69180, 69178, 69153, 68595, 68620
24537, 61694, 61686, 61510, 61518, 61695, 61687, 61511, 61519, 69179, 69155, 68621, 69180, 69182, 69158, 68624, 
69183, 69181, 69156, 68598, 68623
24538, 61695, 61687, 61511, 61519, 61696, 61688, 61512, 61520, 69182, 69158, 68624, 69183, 69185, 69161, 68627, 
69186, 69184, 69159, 68601, 68626
24539, 61696, 61688, 61512, 61520, 61697, 61689, 61513, 61521, 69185, 69161, 68627, 69186, 69188, 69164, 68630, 
69189, 69187, 69162, 68604, 68629
24540, 61697, 61689, 61513, 61521, 61698, 61690, 61514, 61522, 69188, 69164, 68630, 69189, 69191, 69167, 68633, 
69192, 69190, 69165, 68607, 68632
24541, 61698, 61690, 61514, 61522, 61699, 61691, 61515, 61523, 69191, 69167, 68633, 69192, 69194, 69170, 68636, 
69195, 69193, 69168, 68610, 68635
24542, 61699, 61691, 61515, 61523, 26288, 26287, 26265, 26266, 69194, 69170, 68636, 69195, 26990, 26987, 26945, 
26989, 69196, 69171, 68613, 68638
24543, 24793, 24792, 24770, 24771, 61700, 61692, 61516, 61524, 25495, 25494, 25450, 25496, 69198, 69174, 68640, 
69199, 69197, 69172, 68614, 68639
24544, 61700, 61692, 61516, 61524, 61701, 61693, 61517, 61525, 69198, 69174, 68640, 69199, 69201, 69177, 68643, 
69202, 69200, 69175, 68617, 68642
24545, 61701, 61693, 61517, 61525, 61702, 61694, 61518, 61526, 69201, 69177, 68643, 69202, 69204, 69180, 68646, 
69205, 69203, 69178, 68620, 68645
24546, 61702, 61694, 61518, 61526, 61703, 61695, 61519, 61527, 69204, 69180, 68646, 69205, 69207, 69183, 68649, 
69208, 69206, 69181, 68623, 68648
24547, 61703, 61695, 61519, 61527, 61704, 61696, 61520, 61528, 69207, 69183, 68649, 69208, 69210, 69186, 68652, 
69211, 69209, 69184, 68626, 68651
24548, 61704, 61696, 61520, 61528, 61705, 61697, 61521, 61529, 69210, 69186, 68652, 69211, 69213, 69189, 68655, 
69214, 69212, 69187, 68629, 68654
24549, 61705, 61697, 61521, 61529, 61706, 61698, 61522, 61530, 69213, 69189, 68655, 69214, 69216, 69192, 68658, 
69217, 69215, 69190, 68632, 68657
24550, 61706, 61698, 61522, 61530, 61707, 61699, 61523, 61531, 69216, 69192, 68658, 69217, 69219, 69195, 68661, 
69220, 69218, 69193, 68635, 68660
24551, 61707, 61699, 61523, 61531, 26289, 26288, 26266, 26267, 69219, 69195, 68661, 69220, 26992, 26989, 26947, 
26991, 69221, 69196, 68638, 68663
24552, 24794, 24793, 24771, 24772, 61708, 61700, 61524, 61532, 25497, 25496, 25452, 25498, 69223, 69199, 68665, 
69224, 69222, 69197, 68639, 68664
24553, 61708, 61700, 61524, 61532, 61709, 61701, 61525, 61533, 69223, 69199, 68665, 69224, 69226, 69202, 68668, 
69227, 69225, 69200, 68642, 68667
24554, 61709, 61701, 61525, 61533, 61710, 61702, 61526, 61534, 69226, 69202, 68668, 69227, 69229, 69205, 68671, 
69230, 69228, 69203, 68645, 68670
24555, 61710, 61702, 61526, 61534, 61711, 61703, 61527, 61535, 69229, 69205, 68671, 69230, 69232, 69208, 68674, 
69233, 69231, 69206, 68648, 68673
24556, 61711, 61703, 61527, 61535, 61712, 61704, 61528, 61536, 69232, 69208, 68674, 69233, 69235, 69211, 68677, 
69236, 69234, 69209, 68651, 68676
24557, 61712, 61704, 61528, 61536, 61713, 61705, 61529, 61537, 69235, 69211, 68677, 69236, 69238, 69214, 68680, 
69239, 69237, 69212, 68654, 68679
24558, 61713, 61705, 61529, 61537, 61714, 61706, 61530, 61538, 69238, 69214, 68680, 69239, 69241, 69217, 68683, 
69242, 69240, 69215, 68657, 68682
24559, 61714, 61706, 61530, 61538, 61715, 61707, 61531, 61539, 69241, 69217, 68683, 69242, 69244, 69220, 68686, 
69245, 69243, 69218, 68660, 68685
24560, 61715, 61707, 61531, 61539, 26290, 26289, 26267, 26268, 69244, 69220, 68686, 69245, 26994, 26991, 26949, 
26993, 69246, 69221, 68663, 68688
24561, 24795, 24794, 24772, 24773, 61716, 61708, 61532, 61540, 25499, 25498, 25454, 25500, 69248, 69224, 68690, 
69249, 69247, 69222, 68664, 68689
24562, 61716, 61708, 61532, 61540, 61717, 61709, 61533, 61541, 69248, 69224, 68690, 69249, 69251, 69227, 68693, 
69252, 69250, 69225, 68667, 68692
24563, 61717, 61709, 61533, 61541, 61718, 61710, 61534, 61542, 69251, 69227, 68693, 69252, 69254, 69230, 68696, 
69255, 69253, 69228, 68670, 68695
24564, 61718, 61710, 61534, 61542, 61719, 61711, 61535, 61543, 69254, 69230, 68696, 69255, 69257, 69233, 68699, 
69258, 69256, 69231, 68673, 68698
24565, 61719, 61711, 61535, 61543, 61720, 61712, 61536, 61544, 69257, 69233, 68699, 69258, 69260, 69236, 68702, 
69261, 69259, 69234, 68676, 68701
24566, 61720, 61712, 61536, 61544, 61721, 61713, 61537, 61545, 69260, 69236, 68702, 69261, 69263, 69239, 68705, 
69264, 69262, 69237, 68679, 68704
24567, 61721, 61713, 61537, 61545, 61722, 61714, 61538, 61546, 69263, 69239, 68705, 69264, 69266, 69242, 68708, 
69267, 69265, 69240, 68682, 68707
24568, 61722, 61714, 61538, 61546, 61723, 61715, 61539, 61547, 69266, 69242, 68708, 69267, 69269, 69245, 68711, 
69270, 69268, 69243, 68685, 68710
24569, 61723, 61715, 61539, 61547, 26291, 26290, 26268, 26269, 69269, 69245, 68711, 69270, 26996, 26993, 26951, 
26995, 69271, 69246, 68688, 68713
24570, 24796, 24795, 24773, 24774, 61724, 61716, 61540, 61548, 25501, 25500, 25456, 25502, 69273, 69249, 68715, 
69274, 69272, 69247, 68689, 68714
24571, 61724, 61716, 61540, 61548, 61725, 61717, 61541, 61549, 69273, 69249, 68715, 69274, 69276, 69252, 68718, 
69277, 69275, 69250, 68692, 68717
24572, 61725, 61717, 61541, 61549, 61726, 61718, 61542, 61550, 69276, 69252, 68718, 69277, 69279, 69255, 68721, 
69280, 69278, 69253, 68695, 68720
24573, 61726, 61718, 61542, 61550, 61727, 61719, 61543, 61551, 69279, 69255, 68721, 69280, 69282, 69258, 68724, 
69283, 69281, 69256, 68698, 68723
24574, 61727, 61719, 61543, 61551, 61728, 61720, 61544, 61552, 69282, 69258, 68724, 69283, 69285, 69261, 68727, 
69286, 69284, 69259, 68701, 68726
24575, 61728, 61720, 61544, 61552, 61729, 61721, 61545, 61553, 69285, 69261, 68727, 69286, 69288, 69264, 68730, 
69289, 69287, 69262, 68704, 68729
24576, 61729, 61721, 61545, 61553, 61730, 61722, 61546, 61554, 69288, 69264, 68730, 69289, 69291, 69267, 68733, 
69292, 69290, 69265, 68707, 68732
24577, 61730, 61722, 61546, 61554, 61731, 61723, 61547, 61555, 69291, 69267, 68733, 69292, 69294, 69270, 68736, 
69295, 69293, 69268, 68710, 68735
24578, 61731, 61723, 61547, 61555, 26292, 26291, 26269, 26270, 69294, 69270, 68736, 69295, 26998, 26995, 26953, 
26997, 69296, 69271, 68713, 68738
24579, 24797, 24796, 24774, 24775, 61732, 61724, 61548, 61556, 25503, 25502, 25458, 25504, 69298, 69274, 68740, 
69299, 69297, 69272, 68714, 68739
24580, 61732, 61724, 61548, 61556, 61733, 61725, 61549, 61557, 69298, 69274, 68740, 69299, 69301, 69277, 68743, 
69302, 69300, 69275, 68717, 68742
24581, 61733, 61725, 61549, 61557, 61734, 61726, 61550, 61558, 69301, 69277, 68743, 69302, 69304, 69280, 68746, 
69305, 69303, 69278, 68720, 68745
24582, 61734, 61726, 61550, 61558, 61735, 61727, 61551, 61559, 69304, 69280, 68746, 69305, 69307, 69283, 68749, 
69308, 69306, 69281, 68723, 68748
24583, 61735, 61727, 61551, 61559, 61736, 61728, 61552, 61560, 69307, 69283, 68749, 69308, 69310, 69286, 68752, 
69311, 69309, 69284, 68726, 68751
24584, 61736, 61728, 61552, 61560, 61737, 61729, 61553, 61561, 69310, 69286, 68752, 69311, 69313, 69289, 68755, 
69314, 69312, 69287, 68729, 68754
24585, 61737, 61729, 61553, 61561, 61738, 61730, 61554, 61562, 69313, 69289, 68755, 69314, 69316, 69292, 68758, 
69317, 69315, 69290, 68732, 68757
24586, 61738, 61730, 61554, 61562, 61739, 61731, 61555, 61563, 69316, 69292, 68758, 69317, 69319, 69295, 68761, 
69320, 69318, 69293, 68735, 68760
24587, 61739, 61731, 61555, 61563, 26293, 26292, 26270, 26271, 69319, 69295, 68761, 69320, 27000, 26997, 26955, 
26999, 69321, 69296, 68738, 68763
24588, 24798, 24797, 24775, 24776, 61740, 61732, 61556, 61564, 25505, 25504, 25460, 25506, 69323, 69299, 68765, 
69324, 69322, 69297, 68739, 68764
24589, 61740, 61732, 61556, 61564, 61741, 61733, 61557, 61565, 69323, 69299, 68765, 69324, 69326, 69302, 68768, 
69327, 69325, 69300, 68742, 68767
24590, 61741, 61733, 61557, 61565, 61742, 61734, 61558, 61566, 69326, 69302, 68768, 69327, 69329, 69305, 68771, 
69330, 69328, 69303, 68745, 68770
24591, 61742, 61734, 61558, 61566, 61743, 61735, 61559, 61567, 69329, 69305, 68771, 69330, 69332, 69308, 68774, 
69333, 69331, 69306, 68748, 68773
24592, 61743, 61735, 61559, 61567, 61744, 61736, 61560, 61568, 69332, 69308, 68774, 69333, 69335, 69311, 68777, 
69336, 69334, 69309, 68751, 68776
24593, 61744, 61736, 61560, 61568, 61745, 61737, 61561, 61569, 69335, 69311, 68777, 69336, 69338, 69314, 68780, 
69339, 69337, 69312, 68754, 68779
24594, 61745, 61737, 61561, 61569, 61746, 61738, 61562, 61570, 69338, 69314, 68780, 69339, 69341, 69317, 68783, 
69342, 69340, 69315, 68757, 68782
24595, 61746, 61738, 61562, 61570, 61747, 61739, 61563, 61571, 69341, 69317, 68783, 69342, 69344, 69320, 68786, 
69345, 69343, 69318, 68760, 68785
24596, 61747, 61739, 61563, 61571, 26294, 26293, 26271, 26272, 69344, 69320, 68786, 69345, 27002, 26999, 26957, 
27001, 69346, 69321, 68763, 68788
24597, 24799, 24798, 24776, 24777, 61748, 61740, 61564, 61572, 25507, 25506, 25462, 25508, 69348, 69324, 68790, 
69349, 69347, 69322, 68764, 68789
24598, 61748, 61740, 61564, 61572, 61749, 61741, 61565, 61573, 69348, 69324, 68790, 69349, 69351, 69327, 68793, 
69352, 69350, 69325, 68767, 68792
24599, 61749, 61741, 61565, 61573, 61750, 61742, 61566, 61574, 69351, 69327, 68793, 69352, 69354, 69330, 68796, 
69355, 69353, 69328, 68770, 68795
24600, 61750, 61742, 61566, 61574, 61751, 61743, 61567, 61575, 69354, 69330, 68796, 69355, 69357, 69333, 68799, 
69358, 69356, 69331, 68773, 68798
24601, 61751, 61743, 61567, 61575, 61752, 61744, 61568, 61576, 69357, 69333, 68799, 69358, 69360, 69336, 68802, 
69361, 69359, 69334, 68776, 68801
24602, 61752, 61744, 61568, 61576, 61753, 61745, 61569, 61577, 69360, 69336, 68802, 69361, 69363, 69339, 68805, 
69364, 69362, 69337, 68779, 68804
24603, 61753, 61745, 61569, 61577, 61754, 61746, 61570, 61578, 69363, 69339, 68805, 69364, 69366, 69342, 68808, 
69367, 69365, 69340, 68782, 68807
24604, 61754, 61746, 61570, 61578, 61755, 61747, 61571, 61579, 69366, 69342, 68808, 69367, 69369, 69345, 68811, 
69370, 69368, 69343, 68785, 68810
24605, 61755, 61747, 61571, 61579, 26295, 26294, 26272, 26273, 69369, 69345, 68811, 69370, 27004, 27001, 26959, 
27003, 69371, 69346, 68788, 68813
24606, 24800, 24799, 24777, 24778, 61756, 61748, 61572, 61580, 25509, 25508, 25464, 25510, 69373, 69349, 68815, 
69374, 69372, 69347, 68789, 68814
24607, 61756, 61748, 61572, 61580, 61757, 61749, 61573, 61581, 69373, 69349, 68815, 69374, 69376, 69352, 68818, 
69377, 69375, 69350, 68792, 68817
24608, 61757, 61749, 61573, 61581, 61758, 61750, 61574, 61582, 69376, 69352, 68818, 69377, 69379, 69355, 68821, 
69380, 69378, 69353, 68795, 68820
24609, 61758, 61750, 61574, 61582, 61759, 61751, 61575, 61583, 69379, 69355, 68821, 69380, 69382, 69358, 68824, 
69383, 69381, 69356, 68798, 68823
24610, 61759, 61751, 61575, 61583, 61760, 61752, 61576, 61584, 69382, 69358, 68824, 69383, 69385, 69361, 68827, 
69386, 69384, 69359, 68801, 68826
24611, 61760, 61752, 61576, 61584, 61761, 61753, 61577, 61585, 69385, 69361, 68827, 69386, 69388, 69364, 68830, 
69389, 69387, 69362, 68804, 68829
24612, 61761, 61753, 61577, 61585, 61762, 61754, 61578, 61586, 69388, 69364, 68830, 69389, 69391, 69367, 68833, 
69392, 69390, 69365, 68807, 68832
24613, 61762, 61754, 61578, 61586, 61763, 61755, 61579, 61587, 69391, 69367, 68833, 69392, 69394, 69370, 68836, 
69395, 69393, 69368, 68810, 68835
24614, 61763, 61755, 61579, 61587, 26296, 26295, 26273, 26274, 69394, 69370, 68836, 69395, 27006, 27003, 26961, 
27005, 69396, 69371, 68813, 68838
24615, 24801, 24800, 24778, 24779, 61764, 61756, 61580, 61588, 25511, 25510, 25466, 25512, 69398, 69374, 68840, 
69399, 69397, 69372, 68814, 68839
24616, 61764, 61756, 61580, 61588, 61765, 61757, 61581, 61589, 69398, 69374, 68840, 69399, 69401, 69377, 68843, 
69402, 69400, 69375, 68817, 68842
24617, 61765, 61757, 61581, 61589, 61766, 61758, 61582, 61590, 69401, 69377, 68843, 69402, 69404, 69380, 68846, 
69405, 69403, 69378, 68820, 68845
24618, 61766, 61758, 61582, 61590, 61767, 61759, 61583, 61591, 69404, 69380, 68846, 69405, 69407, 69383, 68849, 
69408, 69406, 69381, 68823, 68848
24619, 61767, 61759, 61583, 61591, 61768, 61760, 61584, 61592, 69407, 69383, 68849, 69408, 69410, 69386, 68852, 
69411, 69409, 69384, 68826, 68851
24620, 61768, 61760, 61584, 61592, 61769, 61761, 61585, 61593, 69410, 69386, 68852, 69411, 69413, 69389, 68855, 
69414, 69412, 69387, 68829, 68854
24621, 61769, 61761, 61585, 61593, 61770, 61762, 61586, 61594, 69413, 69389, 68855, 69414, 69416, 69392, 68858, 
69417, 69415, 69390, 68832, 68857
24622, 61770, 61762, 61586, 61594, 61771, 61763, 61587, 61595, 69416, 69392, 68858, 69417, 69419, 69395, 68861, 
69420, 69418, 69393, 68835, 68860
24623, 61771, 61763, 61587, 61595, 26297, 26296, 26274, 26275, 69419, 69395, 68861, 69420, 27008, 27005, 26963, 
27007, 69421, 69396, 68838, 68863
24624, 24802, 24801, 24779, 24780, 61772, 61764, 61588, 61596, 25513, 25512, 25468, 25514, 69423, 69399, 68865, 
69424, 69422, 69397, 68839, 68864
24625, 61772, 61764, 61588, 61596, 61773, 61765, 61589, 61597, 69423, 69399, 68865, 69424, 69426, 69402, 68868, 
69427, 69425, 69400, 68842, 68867
24626, 61773, 61765, 61589, 61597, 61774, 61766, 61590, 61598, 69426, 69402, 68868, 69427, 69429, 69405, 68871, 
69430, 69428, 69403, 68845, 68870
24627, 61774, 61766, 61590, 61598, 61775, 61767, 61591, 61599, 69429, 69405, 68871, 69430, 69432, 69408, 68874, 
69433, 69431, 69406, 68848, 68873
24628, 61775, 61767, 61591, 61599, 61776, 61768, 61592, 61600, 69432, 69408, 68874, 69433, 69435, 69411, 68877, 
69436, 69434, 69409, 68851, 68876
24629, 61776, 61768, 61592, 61600, 61777, 61769, 61593, 61601, 69435, 69411, 68877, 69436, 69438, 69414, 68880, 
69439, 69437, 69412, 68854, 68879
24630, 61777, 61769, 61593, 61601, 61778, 61770, 61594, 61602, 69438, 69414, 68880, 69439, 69441, 69417, 68883, 
69442, 69440, 69415, 68857, 68882
24631, 61778, 61770, 61594, 61602, 61779, 61771, 61595, 61603, 69441, 69417, 68883, 69442, 69444, 69420, 68886, 
69445, 69443, 69418, 68860, 68885
24632, 61779, 61771, 61595, 61603, 26298, 26297, 26275, 26276, 69444, 69420, 68886, 69445, 27010, 27007, 26965, 
27009, 69446, 69421, 68863, 68888
24633, 24803, 24802, 24780, 24781, 61780, 61772, 61596, 61604, 25515, 25514, 25470, 25516, 69448, 69424, 68890, 
69449, 69447, 69422, 68864, 68889
24634, 61780, 61772, 61596, 61604, 61781, 61773, 61597, 61605, 69448, 69424, 68890, 69449, 69451, 69427, 68893, 
69452, 69450, 69425, 68867, 68892
24635, 61781, 61773, 61597, 61605, 61782, 61774, 61598, 61606, 69451, 69427, 68893, 69452, 69454, 69430, 68896, 
69455, 69453, 69428, 68870, 68895
24636, 61782, 61774, 61598, 61606, 61783, 61775, 61599, 61607, 69454, 69430, 68896, 69455, 69457, 69433, 68899, 
69458, 69456, 69431, 68873, 68898
24637, 61783, 61775, 61599, 61607, 61784, 61776, 61600, 61608, 69457, 69433, 68899, 69458, 69460, 69436, 68902, 
69461, 69459, 69434, 68876, 68901
24638, 61784, 61776, 61600, 61608, 61785, 61777, 61601, 61609, 69460, 69436, 68902, 69461, 69463, 69439, 68905, 
69464, 69462, 69437, 68879, 68904
24639, 61785, 61777, 61601, 61609, 61786, 61778, 61602, 61610, 69463, 69439, 68905, 69464, 69466, 69442, 68908, 
69467, 69465, 69440, 68882, 68907
24640, 61786, 61778, 61602, 61610, 61787, 61779, 61603, 61611, 69466, 69442, 68908, 69467, 69469, 69445, 68911, 
69470, 69468, 69443, 68885, 68910
24641, 61787, 61779, 61603, 61611, 26299, 26298, 26276, 26277, 69469, 69445, 68911, 69470, 27012, 27009, 26967, 
27011, 69471, 69446, 68888, 68913
24642, 3179, 24803, 24781, 3178, 28206, 61780, 61604, 28198, 25517, 25516, 25472, 3201, 69472, 69449, 68914, 
28464, 28463, 69447, 68889, 28446
24643, 28206, 61780, 61604, 28198, 28207, 61781, 61605, 28199, 69472, 69449, 68914, 28464, 69473, 69452, 68915, 
28466, 28465, 69450, 68892, 28448
24644, 28207, 61781, 61605, 28199, 28208, 61782, 61606, 28200, 69473, 69452, 68915, 28466, 69474, 69455, 68916, 
28468, 28467, 69453, 68895, 28450
24645, 28208, 61782, 61606, 28200, 28209, 61783, 61607, 28201, 69474, 69455, 68916, 28468, 69475, 69458, 68917, 
28470, 28469, 69456, 68898, 28452
24646, 28209, 61783, 61607, 28201, 28210, 61784, 61608, 28202, 69475, 69458, 68917, 28470, 69476, 69461, 68918, 
28472, 28471, 69459, 68901, 28454
24647, 28210, 61784, 61608, 28202, 28211, 61785, 61609, 28203, 69476, 69461, 68918, 28472, 69477, 69464, 68919, 
28474, 28473, 69462, 68904, 28456
24648, 28211, 61785, 61609, 28203, 28212, 61786, 61610, 28204, 69477, 69464, 68919, 28474, 69478, 69467, 68920, 
28476, 28475, 69465, 68907, 28458
24649, 28212, 61786, 61610, 28204, 28213, 61787, 61611, 28205, 69478, 69467, 68920, 28476, 69479, 69470, 68921, 
28478, 28477, 69468, 68910, 28460
24650, 28213, 61787, 61611, 28205, 3314, 26299, 26277, 3313, 69479, 69470, 68921, 28478, 27013, 27011, 26968, 
3336, 28479, 69471, 68913, 28462
24651, 24804, 3135, 3134, 24782, 61788, 27656, 27648, 61612, 25518, 3157, 25473, 25519, 69481, 27922, 68923, 
69482, 69480, 27923, 27906, 68922
24652, 61788, 27656, 27648, 61612, 61789, 27657, 27649, 61613, 69481, 27922, 68923, 69482, 69484, 27924, 68926, 
69485, 69483, 27925, 27908, 68925
24653, 61789, 27657, 27649, 61613, 61790, 27658, 27650, 61614, 69484, 27924, 68926, 69485, 69487, 27926, 68929, 
69488, 69486, 27927, 27910, 68928
24654, 61790, 27658, 27650, 61614, 61791, 27659, 27651, 61615, 69487, 27926, 68929, 69488, 69490, 27928, 68932, 
69491, 69489, 27929, 27912, 68931
24655, 61791, 27659, 27651, 61615, 61792, 27660, 27652, 61616, 69490, 27928, 68932, 69491, 69493, 27930, 68935, 
69494, 69492, 27931, 27914, 68934
24656, 61792, 27660, 27652, 61616, 61793, 27661, 27653, 61617, 69493, 27930, 68935, 69494, 69496, 27932, 68938, 
69497, 69495, 27933, 27916, 68937
24657, 61793, 27661, 27653, 61617, 61794, 27662, 27654, 61618, 69496, 27932, 68938, 69497, 69499, 27934, 68941, 
69500, 69498, 27935, 27918, 68940
24658, 61794, 27662, 27654, 61618, 61795, 27663, 27655, 61619, 69499, 27934, 68941, 69500, 69502, 27936, 68944, 
69503, 69501, 27937, 27920, 68943
24659, 61795, 27663, 27655, 61619, 26300, 3270, 3269, 26278, 69502, 27936, 68944, 69503, 27015, 3292, 26970, 
27014, 69504, 27938, 27921, 68946
24660, 24805, 24804, 24782, 24783, 61796, 61788, 61612, 61620, 25520, 25519, 25475, 25521, 69506, 69482, 68948, 
69507, 69505, 69480, 68922, 68947
24661, 61796, 61788, 61612, 61620, 61797, 61789, 61613, 61621, 69506, 69482, 68948, 69507, 69509, 69485, 68951, 
69510, 69508, 69483, 68925, 68950
24662, 61797, 61789, 61613, 61621, 61798, 61790, 61614, 61622, 69509, 69485, 68951, 69510, 69512, 69488, 68954, 
69513, 69511, 69486, 68928, 68953
24663, 61798, 61790, 61614, 61622, 61799, 61791, 61615, 61623, 69512, 69488, 68954, 69513, 69515, 69491, 68957, 
69516, 69514, 69489, 68931, 68956
24664, 61799, 61791, 61615, 61623, 61800, 61792, 61616, 61624, 69515, 69491, 68957, 69516, 69518, 69494, 68960, 
69519, 69517, 69492, 68934, 68959
24665, 61800, 61792, 61616, 61624, 61801, 61793, 61617, 61625, 69518, 69494, 68960, 69519, 69521, 69497, 68963, 
69522, 69520, 69495, 68937, 68962
24666, 61801, 61793, 61617, 61625, 61802, 61794, 61618, 61626, 69521, 69497, 68963, 69522, 69524, 69500, 68966, 
69525, 69523, 69498, 68940, 68965
24667, 61802, 61794, 61618, 61626, 61803, 61795, 61619, 61627, 69524, 69500, 68966, 69525, 69527, 69503, 68969, 
69528, 69526, 69501, 68943, 68968
24668, 61803, 61795, 61619, 61627, 26301, 26300, 26278, 26279, 69527, 69503, 68969, 69528, 27017, 27014, 26972, 
27016, 69529, 69504, 68946, 68971
24669, 24806, 24805, 24783, 24784, 61804, 61796, 61620, 61628, 25522, 25521, 25477, 25523, 69531, 69507, 68973, 
69532, 69530, 69505, 68947, 68972
24670, 61804, 61796, 61620, 61628, 61805, 61797, 61621, 61629, 69531, 69507, 68973, 69532, 69534, 69510, 68976, 
69535, 69533, 69508, 68950, 68975
24671, 61805, 61797, 61621, 61629, 61806, 61798, 61622, 61630, 69534, 69510, 68976, 69535, 69537, 69513, 68979, 
69538, 69536, 69511, 68953, 68978
24672, 61806, 61798, 61622, 61630, 61807, 61799, 61623, 61631, 69537, 69513, 68979, 69538, 69540, 69516, 68982, 
69541, 69539, 69514, 68956, 68981
24673, 61807, 61799, 61623, 61631, 61808, 61800, 61624, 61632, 69540, 69516, 68982, 69541, 69543, 69519, 68985, 
69544, 69542, 69517, 68959, 68984
24674, 61808, 61800, 61624, 61632, 61809, 61801, 61625, 61633, 69543, 69519, 68985, 69544, 69546, 69522, 68988, 
69547, 69545, 69520, 68962, 68987
24675, 61809, 61801, 61625, 61633, 61810, 61802, 61626, 61634, 69546, 69522, 68988, 69547, 69549, 69525, 68991, 
69550, 69548, 69523, 68965, 68990
24676, 61810, 61802, 61626, 61634, 61811, 61803, 61627, 61635, 69549, 69525, 68991, 69550, 69552, 69528, 68994, 
69553, 69551, 69526, 68968, 68993
24677, 61811, 61803, 61627, 61635, 26302, 26301, 26279, 26280, 69552, 69528, 68994, 69553, 27019, 27016, 26974, 
27018, 69554, 69529, 68971, 68996
24678, 24807, 24806, 24784, 24785, 61812, 61804, 61628, 61636, 25524, 25523, 25479, 25525, 69556, 69532, 68998, 
69557, 69555, 69530, 68972, 68997
24679, 61812, 61804, 61628, 61636, 61813, 61805, 61629, 61637, 69556, 69532, 68998, 69557, 69559, 69535, 69001, 
69560, 69558, 69533, 68975, 69000
24680, 61813, 61805, 61629, 61637, 61814, 61806, 61630, 61638, 69559, 69535, 69001, 69560, 69562, 69538, 69004, 
69563, 69561, 69536, 68978, 69003
24681, 61814, 61806, 61630, 61638, 61815, 61807, 61631, 61639, 69562, 69538, 69004, 69563, 69565, 69541, 69007, 
69566, 69564, 69539, 68981, 69006
24682, 61815, 61807, 61631, 61639, 61816, 61808, 61632, 61640, 69565, 69541, 69007, 69566, 69568, 69544, 69010, 
69569, 69567, 69542, 68984, 69009
24683, 61816, 61808, 61632, 61640, 61817, 61809, 61633, 61641, 69568, 69544, 69010, 69569, 69571, 69547, 69013, 
69572, 69570, 69545, 68987, 69012
24684, 61817, 61809, 61633, 61641, 61818, 61810, 61634, 61642, 69571, 69547, 69013, 69572, 69574, 69550, 69016, 
69575, 69573, 69548, 68990, 69015
24685, 61818, 61810, 61634, 61642, 61819, 61811, 61635, 61643, 69574, 69550, 69016, 69575, 69577, 69553, 69019, 
69578, 69576, 69551, 68993, 69018
24686, 61819, 61811, 61635, 61643, 26303, 26302, 26280, 26281, 69577, 69553, 69019, 69578, 27021, 27018, 26976, 
27020, 69579, 69554, 68996, 69021
24687, 24808, 24807, 24785, 24786, 61820, 61812, 61636, 61644, 25526, 25525, 25481, 25527, 69581, 69557, 69023, 
69582, 69580, 69555, 68997, 69022
24688, 61820, 61812, 61636, 61644, 61821, 61813, 61637, 61645, 69581, 69557, 69023, 69582, 69584, 69560, 69026, 
69585, 69583, 69558, 69000, 69025
24689, 61821, 61813, 61637, 61645, 61822, 61814, 61638, 61646, 69584, 69560, 69026, 69585, 69587, 69563, 69029, 
69588, 69586, 69561, 69003, 69028
24690, 61822, 61814, 61638, 61646, 61823, 61815, 61639, 61647, 69587, 69563, 69029, 69588, 69590, 69566, 69032, 
69591, 69589, 69564, 69006, 69031
24691, 61823, 61815, 61639, 61647, 61824, 61816, 61640, 61648, 69590, 69566, 69032, 69591, 69593, 69569, 69035, 
69594, 69592, 69567, 69009, 69034
24692, 61824, 61816, 61640, 61648, 61825, 61817, 61641, 61649, 69593, 69569, 69035, 69594, 69596, 69572, 69038, 
69597, 69595, 69570, 69012, 69037
24693, 61825, 61817, 61641, 61649, 61826, 61818, 61642, 61650, 69596, 69572, 69038, 69597, 69599, 69575, 69041, 
69600, 69598, 69573, 69015, 69040
24694, 61826, 61818, 61642, 61650, 61827, 61819, 61643, 61651, 69599, 69575, 69041, 69600, 69602, 69578, 69044, 
69603, 69601, 69576, 69018, 69043
24695, 61827, 61819, 61643, 61651, 26304, 26303, 26281, 26282, 69602, 69578, 69044, 69603, 27023, 27020, 26978, 
27022, 69604, 69579, 69021, 69046
24696, 24809, 24808, 24786, 24787, 61828, 61820, 61644, 61652, 25528, 25527, 25483, 25529, 69606, 69582, 69048, 
69607, 69605, 69580, 69022, 69047
24697, 61828, 61820, 61644, 61652, 61829, 61821, 61645, 61653, 69606, 69582, 69048, 69607, 69609, 69585, 69051, 
69610, 69608, 69583, 69025, 69050
24698, 61829, 61821, 61645, 61653, 61830, 61822, 61646, 61654, 69609, 69585, 69051, 69610, 69612, 69588, 69054, 
69613, 69611, 69586, 69028, 69053
24699, 61830, 61822, 61646, 61654, 61831, 61823, 61647, 61655, 69612, 69588, 69054, 69613, 69615, 69591, 69057, 
69616, 69614, 69589, 69031, 69056
24700, 61831, 61823, 61647, 61655, 61832, 61824, 61648, 61656, 69615, 69591, 69057, 69616, 69618, 69594, 69060, 
69619, 69617, 69592, 69034, 69059
24701, 61832, 61824, 61648, 61656, 61833, 61825, 61649, 61657, 69618, 69594, 69060, 69619, 69621, 69597, 69063, 
69622, 69620, 69595, 69037, 69062
24702, 61833, 61825, 61649, 61657, 61834, 61826, 61650, 61658, 69621, 69597, 69063, 69622, 69624, 69600, 69066, 
69625, 69623, 69598, 69040, 69065
24703, 61834, 61826, 61650, 61658, 61835, 61827, 61651, 61659, 69624, 69600, 69066, 69625, 69627, 69603, 69069, 
69628, 69626, 69601, 69043, 69068
24704, 61835, 61827, 61651, 61659, 26305, 26304, 26282, 26283, 69627, 69603, 69069, 69628, 27025, 27022, 26980, 
27024, 69629, 69604, 69046, 69071
24705, 24810, 24809, 24787, 24788, 61836, 61828, 61652, 61660, 25530, 25529, 25485, 25531, 69631, 69607, 69073, 
69632, 69630, 69605, 69047, 69072
24706, 61836, 61828, 61652, 61660, 61837, 61829, 61653, 61661, 69631, 69607, 69073, 69632, 69634, 69610, 69076, 
69635, 69633, 69608, 69050, 69075
24707, 61837, 61829, 61653, 61661, 61838, 61830, 61654, 61662, 69634, 69610, 69076, 69635, 69637, 69613, 69079, 
69638, 69636, 69611, 69053, 69078
24708, 61838, 61830, 61654, 61662, 61839, 61831, 61655, 61663, 69637, 69613, 69079, 69638, 69640, 69616, 69082, 
69641, 69639, 69614, 69056, 69081
24709, 61839, 61831, 61655, 61663, 61840, 61832, 61656, 61664, 69640, 69616, 69082, 69641, 69643, 69619, 69085, 
69644, 69642, 69617, 69059, 69084
24710, 61840, 61832, 61656, 61664, 61841, 61833, 61657, 61665, 69643, 69619, 69085, 69644, 69646, 69622, 69088, 
69647, 69645, 69620, 69062, 69087
24711, 61841, 61833, 61657, 61665, 61842, 61834, 61658, 61666, 69646, 69622, 69088, 69647, 69649, 69625, 69091, 
69650, 69648, 69623, 69065, 69090
24712, 61842, 61834, 61658, 61666, 61843, 61835, 61659, 61667, 69649, 69625, 69091, 69650, 69652, 69628, 69094, 
69653, 69651, 69626, 69068, 69093
24713, 61843, 61835, 61659, 61667, 26306, 26305, 26283, 26284, 69652, 69628, 69094, 69653, 27027, 27024, 26982, 
27026, 69654, 69629, 69071, 69096
24714, 24811, 24810, 24788, 24789, 61844, 61836, 61660, 61668, 25532, 25531, 25487, 25533, 69656, 69632, 69098, 
69657, 69655, 69630, 69072, 69097
24715, 61844, 61836, 61660, 61668, 61845, 61837, 61661, 61669, 69656, 69632, 69098, 69657, 69659, 69635, 69101, 
69660, 69658, 69633, 69075, 69100
24716, 61845, 61837, 61661, 61669, 61846, 61838, 61662, 61670, 69659, 69635, 69101, 69660, 69662, 69638, 69104, 
69663, 69661, 69636, 69078, 69103
24717, 61846, 61838, 61662, 61670, 61847, 61839, 61663, 61671, 69662, 69638, 69104, 69663, 69665, 69641, 69107, 
69666, 69664, 69639, 69081, 69106
24718, 61847, 61839, 61663, 61671, 61848, 61840, 61664, 61672, 69665, 69641, 69107, 69666, 69668, 69644, 69110, 
69669, 69667, 69642, 69084, 69109
24719, 61848, 61840, 61664, 61672, 61849, 61841, 61665, 61673, 69668, 69644, 69110, 69669, 69671, 69647, 69113, 
69672, 69670, 69645, 69087, 69112
24720, 61849, 61841, 61665, 61673, 61850, 61842, 61666, 61674, 69671, 69647, 69113, 69672, 69674, 69650, 69116, 
69675, 69673, 69648, 69090, 69115
24721, 61850, 61842, 61666, 61674, 61851, 61843, 61667, 61675, 69674, 69650, 69116, 69675, 69677, 69653, 69119, 
69678, 69676, 69651, 69093, 69118
24722, 61851, 61843, 61667, 61675, 26307, 26306, 26284, 26285, 69677, 69653, 69119, 69678, 27029, 27026, 26984, 
27028, 69679, 69654, 69096, 69121
24723, 24812, 24811, 24789, 24790, 61852, 61844, 61668, 61676, 25534, 25533, 25489, 25535, 69681, 69657, 69123, 
69682, 69680, 69655, 69097, 69122
24724, 61852, 61844, 61668, 61676, 61853, 61845, 61669, 61677, 69681, 69657, 69123, 69682, 69684, 69660, 69126, 
69685, 69683, 69658, 69100, 69125
24725, 61853, 61845, 61669, 61677, 61854, 61846, 61670, 61678, 69684, 69660, 69126, 69685, 69687, 69663, 69129, 
69688, 69686, 69661, 69103, 69128
24726, 61854, 61846, 61670, 61678, 61855, 61847, 61671, 61679, 69687, 69663, 69129, 69688, 69690, 69666, 69132, 
69691, 69689, 69664, 69106, 69131
24727, 61855, 61847, 61671, 61679, 61856, 61848, 61672, 61680, 69690, 69666, 69132, 69691, 69693, 69669, 69135, 
69694, 69692, 69667, 69109, 69134
24728, 61856, 61848, 61672, 61680, 61857, 61849, 61673, 61681, 69693, 69669, 69135, 69694, 69696, 69672, 69138, 
69697, 69695, 69670, 69112, 69137
24729, 61857, 61849, 61673, 61681, 61858, 61850, 61674, 61682, 69696, 69672, 69138, 69697, 69699, 69675, 69141, 
69700, 69698, 69673, 69115, 69140
24730, 61858, 61850, 61674, 61682, 61859, 61851, 61675, 61683, 69699, 69675, 69141, 69700, 69702, 69678, 69144, 
69703, 69701, 69676, 69118, 69143
24731, 61859, 61851, 61675, 61683, 26308, 26307, 26285, 26286, 69702, 69678, 69144, 69703, 27031, 27028, 26986, 
27030, 69704, 69679, 69121, 69146
24732, 24813, 24812, 24790, 24791, 61860, 61852, 61676, 61684, 25536, 25535, 25491, 25537, 69706, 69682, 69148, 
69707, 69705, 69680, 69122, 69147
24733, 61860, 61852, 61676, 61684, 61861, 61853, 61677, 61685, 69706, 69682, 69148, 69707, 69709, 69685, 69151, 
69710, 69708, 69683, 69125, 69150
24734, 61861, 61853, 61677, 61685, 61862, 61854, 61678, 61686, 69709, 69685, 69151, 69710, 69712, 69688, 69154, 
69713, 69711, 69686, 69128, 69153
24735, 61862, 61854, 61678, 61686, 61863, 61855, 61679, 61687, 69712, 69688, 69154, 69713, 69715, 69691, 69157, 
69716, 69714, 69689, 69131, 69156
24736, 61863, 61855, 61679, 61687, 61864, 61856, 61680, 61688, 69715, 69691, 69157, 69716, 69718, 69694, 69160, 
69719, 69717, 69692, 69134, 69159
24737, 61864, 61856, 61680, 61688, 61865, 61857, 61681, 61689, 69718, 69694, 69160, 69719, 69721, 69697, 69163, 
69722, 69720, 69695, 69137, 69162
24738, 61865, 61857, 61681, 61689, 61866, 61858, 61682, 61690, 69721, 69697, 69163, 69722, 69724, 69700, 69166, 
69725, 69723, 69698, 69140, 69165
24739, 61866, 61858, 61682, 61690, 61867, 61859, 61683, 61691, 69724, 69700, 69166, 69725, 69727, 69703, 69169, 
69728, 69726, 69701, 69143, 69168
24740, 61867, 61859, 61683, 61691, 26309, 26308, 26286, 26287, 69727, 69703, 69169, 69728, 27033, 27030, 26988, 
27032, 69729, 69704, 69146, 69171
24741, 24814, 24813, 24791, 24792, 61868, 61860, 61684, 61692, 25538, 25537, 25493, 25539, 69731, 69707, 69173, 
69732, 69730, 69705, 69147, 69172
24742, 61868, 61860, 61684, 61692, 61869, 61861, 61685, 61693, 69731, 69707, 69173, 69732, 69734, 69710, 69176, 
69735, 69733, 69708, 69150, 69175
24743, 61869, 61861, 61685, 61693, 61870, 61862, 61686, 61694, 69734, 69710, 69176, 69735, 69737, 69713, 69179, 
69738, 69736, 69711, 69153, 69178
24744, 61870, 61862, 61686, 61694, 61871, 61863, 61687, 61695, 69737, 69713, 69179, 69738, 69740, 69716, 69182, 
69741, 69739, 69714, 69156, 69181
24745, 61871, 61863, 61687, 61695, 61872, 61864, 61688, 61696, 69740, 69716, 69182, 69741, 69743, 69719, 69185, 
69744, 69742, 69717, 69159, 69184
24746, 61872, 61864, 61688, 61696, 61873, 61865, 61689, 61697, 69743, 69719, 69185, 69744, 69746, 69722, 69188, 
69747, 69745, 69720, 69162, 69187
24747, 61873, 61865, 61689, 61697, 61874, 61866, 61690, 61698, 69746, 69722, 69188, 69747, 69749, 69725, 69191, 
69750, 69748, 69723, 69165, 69190
24748, 61874, 61866, 61690, 61698, 61875, 61867, 61691, 61699, 69749, 69725, 69191, 69750, 69752, 69728, 69194, 
69753, 69751, 69726, 69168, 69193
24749, 61875, 61867, 61691, 61699, 26310, 26309, 26287, 26288, 69752, 69728, 69194, 69753, 27035, 27032, 26990, 
27034, 69754, 69729, 69171, 69196
24750, 24815, 24814, 24792, 24793, 61876, 61868, 61692, 61700, 25540, 25539, 25495, 25541, 69756, 69732, 69198, 
69757, 69755, 69730, 69172, 69197
24751, 61876, 61868, 61692, 61700, 61877, 61869, 61693, 61701, 69756, 69732, 69198, 69757, 69759, 69735, 69201, 
69760, 69758, 69733, 69175, 69200
24752, 61877, 61869, 61693, 61701, 61878, 61870, 61694, 61702, 69759, 69735, 69201, 69760, 69762, 69738, 69204, 
69763, 69761, 69736, 69178, 69203
24753, 61878, 61870, 61694, 61702, 61879, 61871, 61695, 61703, 69762, 69738, 69204, 69763, 69765, 69741, 69207, 
69766, 69764, 69739, 69181, 69206
24754, 61879, 61871, 61695, 61703, 61880, 61872, 61696, 61704, 69765, 69741, 69207, 69766, 69768, 69744, 69210, 
69769, 69767, 69742, 69184, 69209
24755, 61880, 61872, 61696, 61704, 61881, 61873, 61697, 61705, 69768, 69744, 69210, 69769, 69771, 69747, 69213, 
69772, 69770, 69745, 69187, 69212
24756, 61881, 61873, 61697, 61705, 61882, 61874, 61698, 61706, 69771, 69747, 69213, 69772, 69774, 69750, 69216, 
69775, 69773, 69748, 69190, 69215
24757, 61882, 61874, 61698, 61706, 61883, 61875, 61699, 61707, 69774, 69750, 69216, 69775, 69777, 69753, 69219, 
69778, 69776, 69751, 69193, 69218
24758, 61883, 61875, 61699, 61707, 26311, 26310, 26288, 26289, 69777, 69753, 69219, 69778, 27037, 27034, 26992, 
27036, 69779, 69754, 69196, 69221
24759, 24816, 24815, 24793, 24794, 61884, 61876, 61700, 61708, 25542, 25541, 25497, 25543, 69781, 69757, 69223, 
69782, 69780, 69755, 69197, 69222
24760, 61884, 61876, 61700, 61708, 61885, 61877, 61701, 61709, 69781, 69757, 69223, 69782, 69784, 69760, 69226, 
69785, 69783, 69758, 69200, 69225
24761, 61885, 61877, 61701, 61709, 61886, 61878, 61702, 61710, 69784, 69760, 69226, 69785, 69787, 69763, 69229, 
69788, 69786, 69761, 69203, 69228
24762, 61886, 61878, 61702, 61710, 61887, 61879, 61703, 61711, 69787, 69763, 69229, 69788, 69790, 69766, 69232, 
69791, 69789, 69764, 69206, 69231
24763, 61887, 61879, 61703, 61711, 61888, 61880, 61704, 61712, 69790, 69766, 69232, 69791, 69793, 69769, 69235, 
69794, 69792, 69767, 69209, 69234
24764, 61888, 61880, 61704, 61712, 61889, 61881, 61705, 61713, 69793, 69769, 69235, 69794, 69796, 69772, 69238, 
69797, 69795, 69770, 69212, 69237
24765, 61889, 61881, 61705, 61713, 61890, 61882, 61706, 61714, 69796, 69772, 69238, 69797, 69799, 69775, 69241, 
69800, 69798, 69773, 69215, 69240
24766, 61890, 61882, 61706, 61714, 61891, 61883, 61707, 61715, 69799, 69775, 69241, 69800, 69802, 69778, 69244, 
69803, 69801, 69776, 69218, 69243
24767, 61891, 61883, 61707, 61715, 26312, 26311, 26289, 26290, 69802, 69778, 69244, 69803, 27039, 27036, 26994, 
27038, 69804, 69779, 69221, 69246
24768, 24817, 24816, 24794, 24795, 61892, 61884, 61708, 61716, 25544, 25543, 25499, 25545, 69806, 69782, 69248, 
69807, 69805, 69780, 69222, 69247
24769, 61892, 61884, 61708, 61716, 61893, 61885, 61709, 61717, 69806, 69782, 69248, 69807, 69809, 69785, 69251, 
69810, 69808, 69783, 69225, 69250
24770, 61893, 61885, 61709, 61717, 61894, 61886, 61710, 61718, 69809, 69785, 69251, 69810, 69812, 69788, 69254, 
69813, 69811, 69786, 69228, 69253
24771, 61894, 61886, 61710, 61718, 61895, 61887, 61711, 61719, 69812, 69788, 69254, 69813, 69815, 69791, 69257, 
69816, 69814, 69789, 69231, 69256
24772, 61895, 61887, 61711, 61719, 61896, 61888, 61712, 61720, 69815, 69791, 69257, 69816, 69818, 69794, 69260, 
69819, 69817, 69792, 69234, 69259
24773, 61896, 61888, 61712, 61720, 61897, 61889, 61713, 61721, 69818, 69794, 69260, 69819, 69821, 69797, 69263, 
69822, 69820, 69795, 69237, 69262
24774, 61897, 61889, 61713, 61721, 61898, 61890, 61714, 61722, 69821, 69797, 69263, 69822, 69824, 69800, 69266, 
69825, 69823, 69798, 69240, 69265
24775, 61898, 61890, 61714, 61722, 61899, 61891, 61715, 61723, 69824, 69800, 69266, 69825, 69827, 69803, 69269, 
69828, 69826, 69801, 69243, 69268
24776, 61899, 61891, 61715, 61723, 26313, 26312, 26290, 26291, 69827, 69803, 69269, 69828, 27041, 27038, 26996, 
27040, 69829, 69804, 69246, 69271
24777, 24818, 24817, 24795, 24796, 61900, 61892, 61716, 61724, 25546, 25545, 25501, 25547, 69831, 69807, 69273, 
69832, 69830, 69805, 69247, 69272
24778, 61900, 61892, 61716, 61724, 61901, 61893, 61717, 61725, 69831, 69807, 69273, 69832, 69834, 69810, 69276, 
69835, 69833, 69808, 69250, 69275
24779, 61901, 61893, 61717, 61725, 61902, 61894, 61718, 61726, 69834, 69810, 69276, 69835, 69837, 69813, 69279, 
69838, 69836, 69811, 69253, 69278
24780, 61902, 61894, 61718, 61726, 61903, 61895, 61719, 61727, 69837, 69813, 69279, 69838, 69840, 69816, 69282, 
69841, 69839, 69814, 69256, 69281
24781, 61903, 61895, 61719, 61727, 61904, 61896, 61720, 61728, 69840, 69816, 69282, 69841, 69843, 69819, 69285, 
69844, 69842, 69817, 69259, 69284
24782, 61904, 61896, 61720, 61728, 61905, 61897, 61721, 61729, 69843, 69819, 69285, 69844, 69846, 69822, 69288, 
69847, 69845, 69820, 69262, 69287
24783, 61905, 61897, 61721, 61729, 61906, 61898, 61722, 61730, 69846, 69822, 69288, 69847, 69849, 69825, 69291, 
69850, 69848, 69823, 69265, 69290
24784, 61906, 61898, 61722, 61730, 61907, 61899, 61723, 61731, 69849, 69825, 69291, 69850, 69852, 69828, 69294, 
69853, 69851, 69826, 69268, 69293
24785, 61907, 61899, 61723, 61731, 26314, 26313, 26291, 26292, 69852, 69828, 69294, 69853, 27043, 27040, 26998, 
27042, 69854, 69829, 69271, 69296
24786, 24819, 24818, 24796, 24797, 61908, 61900, 61724, 61732, 25548, 25547, 25503, 25549, 69856, 69832, 69298, 
69857, 69855, 69830, 69272, 69297
24787, 61908, 61900, 61724, 61732, 61909, 61901, 61725, 61733, 69856, 69832, 69298, 69857, 69859, 69835, 69301, 
69860, 69858, 69833, 69275, 69300
24788, 61909, 61901, 61725, 61733, 61910, 61902, 61726, 61734, 69859, 69835, 69301, 69860, 69862, 69838, 69304, 
69863, 69861, 69836, 69278, 69303
24789, 61910, 61902, 61726, 61734, 61911, 61903, 61727, 61735, 69862, 69838, 69304, 69863, 69865, 69841, 69307, 
69866, 69864, 69839, 69281, 69306
24790, 61911, 61903, 61727, 61735, 61912, 61904, 61728, 61736, 69865, 69841, 69307, 69866, 69868, 69844, 69310, 
69869, 69867, 69842, 69284, 69309
24791, 61912, 61904, 61728, 61736, 61913, 61905, 61729, 61737, 69868, 69844, 69310, 69869, 69871, 69847, 69313, 
69872, 69870, 69845, 69287, 69312
24792, 61913, 61905, 61729, 61737, 61914, 61906, 61730, 61738, 69871, 69847, 69313, 69872, 69874, 69850, 69316, 
69875, 69873, 69848, 69290, 69315
24793, 61914, 61906, 61730, 61738, 61915, 61907, 61731, 61739, 69874, 69850, 69316, 69875, 69877, 69853, 69319, 
69878, 69876, 69851, 69293, 69318
24794, 61915, 61907, 61731, 61739, 26315, 26314, 26292, 26293, 69877, 69853, 69319, 69878, 27045, 27042, 27000, 
27044, 69879, 69854, 69296, 69321
24795, 24820, 24819, 24797, 24798, 61916, 61908, 61732, 61740, 25550, 25549, 25505, 25551, 69881, 69857, 69323, 
69882, 69880, 69855, 69297, 69322
24796, 61916, 61908, 61732, 61740, 61917, 61909, 61733, 61741, 69881, 69857, 69323, 69882, 69884, 69860, 69326, 
69885, 69883, 69858, 69300, 69325
24797, 61917, 61909, 61733, 61741, 61918, 61910, 61734, 61742, 69884, 69860, 69326, 69885, 69887, 69863, 69329, 
69888, 69886, 69861, 69303, 69328
24798, 61918, 61910, 61734, 61742, 61919, 61911, 61735, 61743, 69887, 69863, 69329, 69888, 69890, 69866, 69332, 
69891, 69889, 69864, 69306, 69331
24799, 61919, 61911, 61735, 61743, 61920, 61912, 61736, 61744, 69890, 69866, 69332, 69891, 69893, 69869, 69335, 
69894, 69892, 69867, 69309, 69334
24800, 61920, 61912, 61736, 61744, 61921, 61913, 61737, 61745, 69893, 69869, 69335, 69894, 69896, 69872, 69338, 
69897, 69895, 69870, 69312, 69337
24801, 61921, 61913, 61737, 61745, 61922, 61914, 61738, 61746, 69896, 69872, 69338, 69897, 69899, 69875, 69341, 
69900, 69898, 69873, 69315, 69340
24802, 61922, 61914, 61738, 61746, 61923, 61915, 61739, 61747, 69899, 69875, 69341, 69900, 69902, 69878, 69344, 
69903, 69901, 69876, 69318, 69343
24803, 61923, 61915, 61739, 61747, 26316, 26315, 26293, 26294, 69902, 69878, 69344, 69903, 27047, 27044, 27002, 
27046, 69904, 69879, 69321, 69346
24804, 24821, 24820, 24798, 24799, 61924, 61916, 61740, 61748, 25552, 25551, 25507, 25553, 69906, 69882, 69348, 
69907, 69905, 69880, 69322, 69347
24805, 61924, 61916, 61740, 61748, 61925, 61917, 61741, 61749, 69906, 69882, 69348, 69907, 69909, 69885, 69351, 
69910, 69908, 69883, 69325, 69350
24806, 61925, 61917, 61741, 61749, 61926, 61918, 61742, 61750, 69909, 69885, 69351, 69910, 69912, 69888, 69354, 
69913, 69911, 69886, 69328, 69353
24807, 61926, 61918, 61742, 61750, 61927, 61919, 61743, 61751, 69912, 69888, 69354, 69913, 69915, 69891, 69357, 
69916, 69914, 69889, 69331, 69356
24808, 61927, 61919, 61743, 61751, 61928, 61920, 61744, 61752, 69915, 69891, 69357, 69916, 69918, 69894, 69360, 
69919, 69917, 69892, 69334, 69359
24809, 61928, 61920, 61744, 61752, 61929, 61921, 61745, 61753, 69918, 69894, 69360, 69919, 69921, 69897, 69363, 
69922, 69920, 69895, 69337, 69362
24810, 61929, 61921, 61745, 61753, 61930, 61922, 61746, 61754, 69921, 69897, 69363, 69922, 69924, 69900, 69366, 
69925, 69923, 69898, 69340, 69365
24811, 61930, 61922, 61746, 61754, 61931, 61923, 61747, 61755, 69924, 69900, 69366, 69925, 69927, 69903, 69369, 
69928, 69926, 69901, 69343, 69368
24812, 61931, 61923, 61747, 61755, 26317, 26316, 26294, 26295, 69927, 69903, 69369, 69928, 27049, 27046, 27004, 
27048, 69929, 69904, 69346, 69371
24813, 24822, 24821, 24799, 24800, 61932, 61924, 61748, 61756, 25554, 25553, 25509, 25555, 69931, 69907, 69373, 
69932, 69930, 69905, 69347, 69372
24814, 61932, 61924, 61748, 61756, 61933, 61925, 61749, 61757, 69931, 69907, 69373, 69932, 69934, 69910, 69376, 
69935, 69933, 69908, 69350, 69375
24815, 61933, 61925, 61749, 61757, 61934, 61926, 61750, 61758, 69934, 69910, 69376, 69935, 69937, 69913, 69379, 
69938, 69936, 69911, 69353, 69378
24816, 61934, 61926, 61750, 61758, 61935, 61927, 61751, 61759, 69937, 69913, 69379, 69938, 69940, 69916, 69382, 
69941, 69939, 69914, 69356, 69381
24817, 61935, 61927, 61751, 61759, 61936, 61928, 61752, 61760, 69940, 69916, 69382, 69941, 69943, 69919, 69385, 
69944, 69942, 69917, 69359, 69384
24818, 61936, 61928, 61752, 61760, 61937, 61929, 61753, 61761, 69943, 69919, 69385, 69944, 69946, 69922, 69388, 
69947, 69945, 69920, 69362, 69387
24819, 61937, 61929, 61753, 61761, 61938, 61930, 61754, 61762, 69946, 69922, 69388, 69947, 69949, 69925, 69391, 
69950, 69948, 69923, 69365, 69390
24820, 61938, 61930, 61754, 61762, 61939, 61931, 61755, 61763, 69949, 69925, 69391, 69950, 69952, 69928, 69394, 
69953, 69951, 69926, 69368, 69393
24821, 61939, 61931, 61755, 61763, 26318, 26317, 26295, 26296, 69952, 69928, 69394, 69953, 27051, 27048, 27006, 
27050, 69954, 69929, 69371, 69396
24822, 24823, 24822, 24800, 24801, 61940, 61932, 61756, 61764, 25556, 25555, 25511, 25557, 69956, 69932, 69398, 
69957, 69955, 69930, 69372, 69397
24823, 61940, 61932, 61756, 61764, 61941, 61933, 61757, 61765, 69956, 69932, 69398, 69957, 69959, 69935, 69401, 
69960, 69958, 69933, 69375, 69400
24824, 61941, 61933, 61757, 61765, 61942, 61934, 61758, 61766, 69959, 69935, 69401, 69960, 69962, 69938, 69404, 
69963, 69961, 69936, 69378, 69403
24825, 61942, 61934, 61758, 61766, 61943, 61935, 61759, 61767, 69962, 69938, 69404, 69963, 69965, 69941, 69407, 
69966, 69964, 69939, 69381, 69406
24826, 61943, 61935, 61759, 61767, 61944, 61936, 61760, 61768, 69965, 69941, 69407, 69966, 69968, 69944, 69410, 
69969, 69967, 69942, 69384, 69409
24827, 61944, 61936, 61760, 61768, 61945, 61937, 61761, 61769, 69968, 69944, 69410, 69969, 69971, 69947, 69413, 
69972, 69970, 69945, 69387, 69412
24828, 61945, 61937, 61761, 61769, 61946, 61938, 61762, 61770, 69971, 69947, 69413, 69972, 69974, 69950, 69416, 
69975, 69973, 69948, 69390, 69415
24829, 61946, 61938, 61762, 61770, 61947, 61939, 61763, 61771, 69974, 69950, 69416, 69975, 69977, 69953, 69419, 
69978, 69976, 69951, 69393, 69418
24830, 61947, 61939, 61763, 61771, 26319, 26318, 26296, 26297, 69977, 69953, 69419, 69978, 27053, 27050, 27008, 
27052, 69979, 69954, 69396, 69421
24831, 24824, 24823, 24801, 24802, 61948, 61940, 61764, 61772, 25558, 25557, 25513, 25559, 69981, 69957, 69423, 
69982, 69980, 69955, 69397, 69422
24832, 61948, 61940, 61764, 61772, 61949, 61941, 61765, 61773, 69981, 69957, 69423, 69982, 69984, 69960, 69426, 
69985, 69983, 69958, 69400, 69425
24833, 61949, 61941, 61765, 61773, 61950, 61942, 61766, 61774, 69984, 69960, 69426, 69985, 69987, 69963, 69429, 
69988, 69986, 69961, 69403, 69428
24834, 61950, 61942, 61766, 61774, 61951, 61943, 61767, 61775, 69987, 69963, 69429, 69988, 69990, 69966, 69432, 
69991, 69989, 69964, 69406, 69431
24835, 61951, 61943, 61767, 61775, 61952, 61944, 61768, 61776, 69990, 69966, 69432, 69991, 69993, 69969, 69435, 
69994, 69992, 69967, 69409, 69434
24836, 61952, 61944, 61768, 61776, 61953, 61945, 61769, 61777, 69993, 69969, 69435, 69994, 69996, 69972, 69438, 
69997, 69995, 69970, 69412, 69437
24837, 61953, 61945, 61769, 61777, 61954, 61946, 61770, 61778, 69996, 69972, 69438, 69997, 69999, 69975, 69441, 
70000, 69998, 69973, 69415, 69440
24838, 61954, 61946, 61770, 61778, 61955, 61947, 61771, 61779, 69999, 69975, 69441, 70000, 70002, 69978, 69444, 
70003, 70001, 69976, 69418, 69443
24839, 61955, 61947, 61771, 61779, 26320, 26319, 26297, 26298, 70002, 69978, 69444, 70003, 27055, 27052, 27010, 
27054, 70004, 69979, 69421, 69446
24840, 24825, 24824, 24802, 24803, 61956, 61948, 61772, 61780, 25560, 25559, 25515, 25561, 70006, 69982, 69448, 
70007, 70005, 69980, 69422, 69447
24841, 61956, 61948, 61772, 61780, 61957, 61949, 61773, 61781, 70006, 69982, 69448, 70007, 70009, 69985, 69451, 
70010, 70008, 69983, 69425, 69450
24842, 61957, 61949, 61773, 61781, 61958, 61950, 61774, 61782, 70009, 69985, 69451, 70010, 70012, 69988, 69454, 
70013, 70011, 69986, 69428, 69453
24843, 61958, 61950, 61774, 61782, 61959, 61951, 61775, 61783, 70012, 69988, 69454, 70013, 70015, 69991, 69457, 
70016, 70014, 69989, 69431, 69456
24844, 61959, 61951, 61775, 61783, 61960, 61952, 61776, 61784, 70015, 69991, 69457, 70016, 70018, 69994, 69460, 
70019, 70017, 69992, 69434, 69459
24845, 61960, 61952, 61776, 61784, 61961, 61953, 61777, 61785, 70018, 69994, 69460, 70019, 70021, 69997, 69463, 
70022, 70020, 69995, 69437, 69462
24846, 61961, 61953, 61777, 61785, 61962, 61954, 61778, 61786, 70021, 69997, 69463, 70022, 70024, 70000, 69466, 
70025, 70023, 69998, 69440, 69465
24847, 61962, 61954, 61778, 61786, 61963, 61955, 61779, 61787, 70024, 70000, 69466, 70025, 70027, 70003, 69469, 
70028, 70026, 70001, 69443, 69468
24848, 61963, 61955, 61779, 61787, 26321, 26320, 26298, 26299, 70027, 70003, 69469, 70028, 27057, 27054, 27012, 
27056, 70029, 70004, 69446, 69471
24849, 3180, 24825, 24803, 3179, 28214, 61956, 61780, 28206, 25562, 25561, 25517, 3202, 70030, 70007, 69472, 
28481, 28480, 70005, 69447, 28463
24850, 28214, 61956, 61780, 28206, 28215, 61957, 61781, 28207, 70030, 70007, 69472, 28481, 70031, 70010, 69473, 
28483, 28482, 70008, 69450, 28465
24851, 28215, 61957, 61781, 28207, 28216, 61958, 61782, 28208, 70031, 70010, 69473, 28483, 70032, 70013, 69474, 
28485, 28484, 70011, 69453, 28467
24852, 28216, 61958, 61782, 28208, 28217, 61959, 61783, 28209, 70032, 70013, 69474, 28485, 70033, 70016, 69475, 
28487, 28486, 70014, 69456, 28469
24853, 28217, 61959, 61783, 28209, 28218, 61960, 61784, 28210, 70033, 70016, 69475, 28487, 70034, 70019, 69476, 
28489, 28488, 70017, 69459, 28471
24854, 28218, 61960, 61784, 28210, 28219, 61961, 61785, 28211, 70034, 70019, 69476, 28489, 70035, 70022, 69477, 
28491, 28490, 70020, 69462, 28473
24855, 28219, 61961, 61785, 28211, 28220, 61962, 61786, 28212, 70035, 70022, 69477, 28491, 70036, 70025, 69478, 
28493, 28492, 70023, 69465, 28475
24856, 28220, 61962, 61786, 28212, 28221, 61963, 61787, 28213, 70036, 70025, 69478, 28493, 70037, 70028, 69479, 
28495, 28494, 70026, 69468, 28477
24857, 28221, 61963, 61787, 28213, 3315, 26321, 26299, 3314, 70037, 70028, 69479, 28495, 27058, 27056, 27013, 
3337, 28496, 70029, 69471, 28479
24858, 24826, 3136, 3135, 24804, 61964, 27664, 27656, 61788, 25563, 3158, 25518, 25564, 70039, 27939, 69481, 
70040, 70038, 27940, 27923, 69480
24859, 61964, 27664, 27656, 61788, 61965, 27665, 27657, 61789, 70039, 27939, 69481, 70040, 70042, 27941, 69484, 
70043, 70041, 27942, 27925, 69483
24860, 61965, 27665, 27657, 61789, 61966, 27666, 27658, 61790, 70042, 27941, 69484, 70043, 70045, 27943, 69487, 
70046, 70044, 27944, 27927, 69486
24861, 61966, 27666, 27658, 61790, 61967, 27667, 27659, 61791, 70045, 27943, 69487, 70046, 70048, 27945, 69490, 
70049, 70047, 27946, 27929, 69489
24862, 61967, 27667, 27659, 61791, 61968, 27668, 27660, 61792, 70048, 27945, 69490, 70049, 70051, 27947, 69493, 
70052, 70050, 27948, 27931, 69492
24863, 61968, 27668, 27660, 61792, 61969, 27669, 27661, 61793, 70051, 27947, 69493, 70052, 70054, 27949, 69496, 
70055, 70053, 27950, 27933, 69495
24864, 61969, 27669, 27661, 61793, 61970, 27670, 27662, 61794, 70054, 27949, 69496, 70055, 70057, 27951, 69499, 
70058, 70056, 27952, 27935, 69498
24865, 61970, 27670, 27662, 61794, 61971, 27671, 27663, 61795, 70057, 27951, 69499, 70058, 70060, 27953, 69502, 
70061, 70059, 27954, 27937, 69501
24866, 61971, 27671, 27663, 61795, 26322, 3271, 3270, 26300, 70060, 27953, 69502, 70061, 27060, 3293, 27015, 
27059, 70062, 27955, 27938, 69504
24867, 24827, 24826, 24804, 24805, 61972, 61964, 61788, 61796, 25565, 25564, 25520, 25566, 70064, 70040, 69506, 
70065, 70063, 70038, 69480, 69505
24868, 61972, 61964, 61788, 61796, 61973, 61965, 61789, 61797, 70064, 70040, 69506, 70065, 70067, 70043, 69509, 
70068, 70066, 70041, 69483, 69508
24869, 61973, 61965, 61789, 61797, 61974, 61966, 61790, 61798, 70067, 70043, 69509, 70068, 70070, 70046, 69512, 
70071, 70069, 70044, 69486, 69511
24870, 61974, 61966, 61790, 61798, 61975, 61967, 61791, 61799, 70070, 70046, 69512, 70071, 70073, 70049, 69515, 
70074, 70072, 70047, 69489, 69514
24871, 61975, 61967, 61791, 61799, 61976, 61968, 61792, 61800, 70073, 70049, 69515, 70074, 70076, 70052, 69518, 
70077, 70075, 70050, 69492, 69517
24872, 61976, 61968, 61792, 61800, 61977, 61969, 61793, 61801, 70076, 70052, 69518, 70077, 70079, 70055, 69521, 
70080, 70078, 70053, 69495, 69520
24873, 61977, 61969, 61793, 61801, 61978, 61970, 61794, 61802, 70079, 70055, 69521, 70080, 70082, 70058, 69524, 
70083, 70081, 70056, 69498, 69523
24874, 61978, 61970, 61794, 61802, 61979, 61971, 61795, 61803, 70082, 70058, 69524, 70083, 70085, 70061, 69527, 
70086, 70084, 70059, 69501, 69526
24875, 61979, 61971, 61795, 61803, 26323, 26322, 26300, 26301, 70085, 70061, 69527, 70086, 27062, 27059, 27017, 
27061, 70087, 70062, 69504, 69529
24876, 24828, 24827, 24805, 24806, 61980, 61972, 61796, 61804, 25567, 25566, 25522, 25568, 70089, 70065, 69531, 
70090, 70088, 70063, 69505, 69530
24877, 61980, 61972, 61796, 61804, 61981, 61973, 61797, 61805, 70089, 70065, 69531, 70090, 70092, 70068, 69534, 
70093, 70091, 70066, 69508, 69533
24878, 61981, 61973, 61797, 61805, 61982, 61974, 61798, 61806, 70092, 70068, 69534, 70093, 70095, 70071, 69537, 
70096, 70094, 70069, 69511, 69536
24879, 61982, 61974, 61798, 61806, 61983, 61975, 61799, 61807, 70095, 70071, 69537, 70096, 70098, 70074, 69540, 
70099, 70097, 70072, 69514, 69539
24880, 61983, 61975, 61799, 61807, 61984, 61976, 61800, 61808, 70098, 70074, 69540, 70099, 70101, 70077, 69543, 
70102, 70100, 70075, 69517, 69542
24881, 61984, 61976, 61800, 61808, 61985, 61977, 61801, 61809, 70101, 70077, 69543, 70102, 70104, 70080, 69546, 
70105, 70103, 70078, 69520, 69545
24882, 61985, 61977, 61801, 61809, 61986, 61978, 61802, 61810, 70104, 70080, 69546, 70105, 70107, 70083, 69549, 
70108, 70106, 70081, 69523, 69548
24883, 61986, 61978, 61802, 61810, 61987, 61979, 61803, 61811, 70107, 70083, 69549, 70108, 70110, 70086, 69552, 
70111, 70109, 70084, 69526, 69551
24884, 61987, 61979, 61803, 61811, 26324, 26323, 26301, 26302, 70110, 70086, 69552, 70111, 27064, 27061, 27019, 
27063, 70112, 70087, 69529, 69554
24885, 24829, 24828, 24806, 24807, 61988, 61980, 61804, 61812, 25569, 25568, 25524, 25570, 70114, 70090, 69556, 
70115, 70113, 70088, 69530, 69555
24886, 61988, 61980, 61804, 61812, 61989, 61981, 61805, 61813, 70114, 70090, 69556, 70115, 70117, 70093, 69559, 
70118, 70116, 70091, 69533, 69558
24887, 61989, 61981, 61805, 61813, 61990, 61982, 61806, 61814, 70117, 70093, 69559, 70118, 70120, 70096, 69562, 
70121, 70119, 70094, 69536, 69561
24888, 61990, 61982, 61806, 61814, 61991, 61983, 61807, 61815, 70120, 70096, 69562, 70121, 70123, 70099, 69565, 
70124, 70122, 70097, 69539, 69564
24889, 61991, 61983, 61807, 61815, 61992, 61984, 61808, 61816, 70123, 70099, 69565, 70124, 70126, 70102, 69568, 
70127, 70125, 70100, 69542, 69567
24890, 61992, 61984, 61808, 61816, 61993, 61985, 61809, 61817, 70126, 70102, 69568, 70127, 70129, 70105, 69571, 
70130, 70128, 70103, 69545, 69570
24891, 61993, 61985, 61809, 61817, 61994, 61986, 61810, 61818, 70129, 70105, 69571, 70130, 70132, 70108, 69574, 
70133, 70131, 70106, 69548, 69573
24892, 61994, 61986, 61810, 61818, 61995, 61987, 61811, 61819, 70132, 70108, 69574, 70133, 70135, 70111, 69577, 
70136, 70134, 70109, 69551, 69576
24893, 61995, 61987, 61811, 61819, 26325, 26324, 26302, 26303, 70135, 70111, 69577, 70136, 27066, 27063, 27021, 
27065, 70137, 70112, 69554, 69579
24894, 24830, 24829, 24807, 24808, 61996, 61988, 61812, 61820, 25571, 25570, 25526, 25572, 70139, 70115, 69581, 
70140, 70138, 70113, 69555, 69580
24895, 61996, 61988, 61812, 61820, 61997, 61989, 61813, 61821, 70139, 70115, 69581, 70140, 70142, 70118, 69584, 
70143, 70141, 70116, 69558, 69583
24896, 61997, 61989, 61813, 61821, 61998, 61990, 61814, 61822, 70142, 70118, 69584, 70143, 70145, 70121, 69587, 
70146, 70144, 70119, 69561, 69586
24897, 61998, 61990, 61814, 61822, 61999, 61991, 61815, 61823, 70145, 70121, 69587, 70146, 70148, 70124, 69590, 
70149, 70147, 70122, 69564, 69589
24898, 61999, 61991, 61815, 61823, 62000, 61992, 61816, 61824, 70148, 70124, 69590, 70149, 70151, 70127, 69593, 
70152, 70150, 70125, 69567, 69592
24899, 62000, 61992, 61816, 61824, 62001, 61993, 61817, 61825, 70151, 70127, 69593, 70152, 70154, 70130, 69596, 
70155, 70153, 70128, 69570, 69595
24900, 62001, 61993, 61817, 61825, 62002, 61994, 61818, 61826, 70154, 70130, 69596, 70155, 70157, 70133, 69599, 
70158, 70156, 70131, 69573, 69598
24901, 62002, 61994, 61818, 61826, 62003, 61995, 61819, 61827, 70157, 70133, 69599, 70158, 70160, 70136, 69602, 
70161, 70159, 70134, 69576, 69601
24902, 62003, 61995, 61819, 61827, 26326, 26325, 26303, 26304, 70160, 70136, 69602, 70161, 27068, 27065, 27023, 
27067, 70162, 70137, 69579, 69604
24903, 24831, 24830, 24808, 24809, 62004, 61996, 61820, 61828, 25573, 25572, 25528, 25574, 70164, 70140, 69606, 
70165, 70163, 70138, 69580, 69605
24904, 62004, 61996, 61820, 61828, 62005, 61997, 61821, 61829, 70164, 70140, 69606, 70165, 70167, 70143, 69609, 
70168, 70166, 70141, 69583, 69608
24905, 62005, 61997, 61821, 61829, 62006, 61998, 61822, 61830, 70167, 70143, 69609, 70168, 70170, 70146, 69612, 
70171, 70169, 70144, 69586, 69611
24906, 62006, 61998, 61822, 61830, 62007, 61999, 61823, 61831, 70170, 70146, 69612, 70171, 70173, 70149, 69615, 
70174, 70172, 70147, 69589, 69614
24907, 62007, 61999, 61823, 61831, 62008, 62000, 61824, 61832, 70173, 70149, 69615, 70174, 70176, 70152, 69618, 
70177, 70175, 70150, 69592, 69617
24908, 62008, 62000, 61824, 61832, 62009, 62001, 61825, 61833, 70176, 70152, 69618, 70177, 70179, 70155, 69621, 
70180, 70178, 70153, 69595, 69620
24909, 62009, 62001, 61825, 61833, 62010, 62002, 61826, 61834, 70179, 70155, 69621, 70180, 70182, 70158, 69624, 
70183, 70181, 70156, 69598, 69623
24910, 62010, 62002, 61826, 61834, 62011, 62003, 61827, 61835, 70182, 70158, 69624, 70183, 70185, 70161, 69627, 
70186, 70184, 70159, 69601, 69626
24911, 62011, 62003, 61827, 61835, 26327, 26326, 26304, 26305, 70185, 70161, 69627, 70186, 27070, 27067, 27025, 
27069, 70187, 70162, 69604, 69629
24912, 24832, 24831, 24809, 24810, 62012, 62004, 61828, 61836, 25575, 25574, 25530, 25576, 70189, 70165, 69631, 
70190, 70188, 70163, 69605, 69630
24913, 62012, 62004, 61828, 61836, 62013, 62005, 61829, 61837, 70189, 70165, 69631, 70190, 70192, 70168, 69634, 
70193, 70191, 70166, 69608, 69633
24914, 62013, 62005, 61829, 61837, 62014, 62006, 61830, 61838, 70192, 70168, 69634, 70193, 70195, 70171, 69637, 
70196, 70194, 70169, 69611, 69636
24915, 62014, 62006, 61830, 61838, 62015, 62007, 61831, 61839, 70195, 70171, 69637, 70196, 70198, 70174, 69640, 
70199, 70197, 70172, 69614, 69639
24916, 62015, 62007, 61831, 61839, 62016, 62008, 61832, 61840, 70198, 70174, 69640, 70199, 70201, 70177, 69643, 
70202, 70200, 70175, 69617, 69642
24917, 62016, 62008, 61832, 61840, 62017, 62009, 61833, 61841, 70201, 70177, 69643, 70202, 70204, 70180, 69646, 
70205, 70203, 70178, 69620, 69645
24918, 62017, 62009, 61833, 61841, 62018, 62010, 61834, 61842, 70204, 70180, 69646, 70205, 70207, 70183, 69649, 
70208, 70206, 70181, 69623, 69648
24919, 62018, 62010, 61834, 61842, 62019, 62011, 61835, 61843, 70207, 70183, 69649, 70208, 70210, 70186, 69652, 
70211, 70209, 70184, 69626, 69651
24920, 62019, 62011, 61835, 61843, 26328, 26327, 26305, 26306, 70210, 70186, 69652, 70211, 27072, 27069, 27027, 
27071, 70212, 70187, 69629, 69654
24921, 24833, 24832, 24810, 24811, 62020, 62012, 61836, 61844, 25577, 25576, 25532, 25578, 70214, 70190, 69656, 
70215, 70213, 70188, 69630, 69655
24922, 62020, 62012, 61836, 61844, 62021, 62013, 61837, 61845, 70214, 70190, 69656, 70215, 70217, 70193, 69659, 
70218, 70216, 70191, 69633, 69658
24923, 62021, 62013, 61837, 61845, 62022, 62014, 61838, 61846, 70217, 70193, 69659, 70218, 70220, 70196, 69662, 
70221, 70219, 70194, 69636, 69661
24924, 62022, 62014, 61838, 61846, 62023, 62015, 61839, 61847, 70220, 70196, 69662, 70221, 70223, 70199, 69665, 
70224, 70222, 70197, 69639, 69664
24925, 62023, 62015, 61839, 61847, 62024, 62016, 61840, 61848, 70223, 70199, 69665, 70224, 70226, 70202, 69668, 
70227, 70225, 70200, 69642, 69667
24926, 62024, 62016, 61840, 61848, 62025, 62017, 61841, 61849, 70226, 70202, 69668, 70227, 70229, 70205, 69671, 
70230, 70228, 70203, 69645, 69670
24927, 62025, 62017, 61841, 61849, 62026, 62018, 61842, 61850, 70229, 70205, 69671, 70230, 70232, 70208, 69674, 
70233, 70231, 70206, 69648, 69673
24928, 62026, 62018, 61842, 61850, 62027, 62019, 61843, 61851, 70232, 70208, 69674, 70233, 70235, 70211, 69677, 
70236, 70234, 70209, 69651, 69676
24929, 62027, 62019, 61843, 61851, 26329, 26328, 26306, 26307, 70235, 70211, 69677, 70236, 27074, 27071, 27029, 
27073, 70237, 70212, 69654, 69679
24930, 24834, 24833, 24811, 24812, 62028, 62020, 61844, 61852, 25579, 25578, 25534, 25580, 70239, 70215, 69681, 
70240, 70238, 70213, 69655, 69680
24931, 62028, 62020, 61844, 61852, 62029, 62021, 61845, 61853, 70239, 70215, 69681, 70240, 70242, 70218, 69684, 
70243, 70241, 70216, 69658, 69683
24932, 62029, 62021, 61845, 61853, 62030, 62022, 61846, 61854, 70242, 70218, 69684, 70243, 70245, 70221, 69687, 
70246, 70244, 70219, 69661, 69686
24933, 62030, 62022, 61846, 61854, 62031, 62023, 61847, 61855, 70245, 70221, 69687, 70246, 70248, 70224, 69690, 
70249, 70247, 70222, 69664, 69689
24934, 62031, 62023, 61847, 61855, 62032, 62024, 61848, 61856, 70248, 70224, 69690, 70249, 70251, 70227, 69693, 
70252, 70250, 70225, 69667, 69692
24935, 62032, 62024, 61848, 61856, 62033, 62025, 61849, 61857, 70251, 70227, 69693, 70252, 70254, 70230, 69696, 
70255, 70253, 70228, 69670, 69695
24936, 62033, 62025, 61849, 61857, 62034, 62026, 61850, 61858, 70254, 70230, 69696, 70255, 70257, 70233, 69699, 
70258, 70256, 70231, 69673, 69698
24937, 62034, 62026, 61850, 61858, 62035, 62027, 61851, 61859, 70257, 70233, 69699, 70258, 70260, 70236, 69702, 
70261, 70259, 70234, 69676, 69701
24938, 62035, 62027, 61851, 61859, 26330, 26329, 26307, 26308, 70260, 70236, 69702, 70261, 27076, 27073, 27031, 
27075, 70262, 70237, 69679, 69704
24939, 24835, 24834, 24812, 24813, 62036, 62028, 61852, 61860, 25581, 25580, 25536, 25582, 70264, 70240, 69706, 
70265, 70263, 70238, 69680, 69705
24940, 62036, 62028, 61852, 61860, 62037, 62029, 61853, 61861, 70264, 70240, 69706, 70265, 70267, 70243, 69709, 
70268, 70266, 70241, 69683, 69708
24941, 62037, 62029, 61853, 61861, 62038, 62030, 61854, 61862, 70267, 70243, 69709, 70268, 70270, 70246, 69712, 
70271, 70269, 70244, 69686, 69711
24942, 62038, 62030, 61854, 61862, 62039, 62031, 61855, 61863, 70270, 70246, 69712, 70271, 70273, 70249, 69715, 
70274, 70272, 70247, 69689, 69714
24943, 62039, 62031, 61855, 61863, 62040, 62032, 61856, 61864, 70273, 70249, 69715, 70274, 70276, 70252, 69718, 
70277, 70275, 70250, 69692, 69717
24944, 62040, 62032, 61856, 61864, 62041, 62033, 61857, 61865, 70276, 70252, 69718, 70277, 70279, 70255, 69721, 
70280, 70278, 70253, 69695, 69720
24945, 62041, 62033, 61857, 61865, 62042, 62034, 61858, 61866, 70279, 70255, 69721, 70280, 70282, 70258, 69724, 
70283, 70281, 70256, 69698, 69723
24946, 62042, 62034, 61858, 61866, 62043, 62035, 61859, 61867, 70282, 70258, 69724, 70283, 70285, 70261, 69727, 
70286, 70284, 70259, 69701, 69726
24947, 62043, 62035, 61859, 61867, 26331, 26330, 26308, 26309, 70285, 70261, 69727, 70286, 27078, 27075, 27033, 
27077, 70287, 70262, 69704, 69729
24948, 24836, 24835, 24813, 24814, 62044, 62036, 61860, 61868, 25583, 25582, 25538, 25584, 70289, 70265, 69731, 
70290, 70288, 70263, 69705, 69730
24949, 62044, 62036, 61860, 61868, 62045, 62037, 61861, 61869, 70289, 70265, 69731, 70290, 70292, 70268, 69734, 
70293, 70291, 70266, 69708, 69733
24950, 62045, 62037, 61861, 61869, 62046, 62038, 61862, 61870, 70292, 70268, 69734, 70293, 70295, 70271, 69737, 
70296, 70294, 70269, 69711, 69736
24951, 62046, 62038, 61862, 61870, 62047, 62039, 61863, 61871, 70295, 70271, 69737, 70296, 70298, 70274, 69740, 
70299, 70297, 70272, 69714, 69739
24952, 62047, 62039, 61863, 61871, 62048, 62040, 61864, 61872, 70298, 70274, 69740, 70299, 70301, 70277, 69743, 
70302, 70300, 70275, 69717, 69742
24953, 62048, 62040, 61864, 61872, 62049, 62041, 61865, 61873, 70301, 70277, 69743, 70302, 70304, 70280, 69746, 
70305, 70303, 70278, 69720, 69745
24954, 62049, 62041, 61865, 61873, 62050, 62042, 61866, 61874, 70304, 70280, 69746, 70305, 70307, 70283, 69749, 
70308, 70306, 70281, 69723, 69748
24955, 62050, 62042, 61866, 61874, 62051, 62043, 61867, 61875, 70307, 70283, 69749, 70308, 70310, 70286, 69752, 
70311, 70309, 70284, 69726, 69751
24956, 62051, 62043, 61867, 61875, 26332, 26331, 26309, 26310, 70310, 70286, 69752, 70311, 27080, 27077, 27035, 
27079, 70312, 70287, 69729, 69754
24957, 24837, 24836, 24814, 24815, 62052, 62044, 61868, 61876, 25585, 25584, 25540, 25586, 70314, 70290, 69756, 
70315, 70313, 70288, 69730, 69755
24958, 62052, 62044, 61868, 61876, 62053, 62045, 61869, 61877, 70314, 70290, 69756, 70315, 70317, 70293, 69759, 
70318, 70316, 70291, 69733, 69758
24959, 62053, 62045, 61869, 61877, 62054, 62046, 61870, 61878, 70317, 70293, 69759, 70318, 70320, 70296, 69762, 
70321, 70319, 70294, 69736, 69761
24960, 62054, 62046, 61870, 61878, 62055, 62047, 61871, 61879, 70320, 70296, 69762, 70321, 70323, 70299, 69765, 
70324, 70322, 70297, 69739, 69764
24961, 62055, 62047, 61871, 61879, 62056, 62048, 61872, 61880, 70323, 70299, 69765, 70324, 70326, 70302, 69768, 
70327, 70325, 70300, 69742, 69767
24962, 62056, 62048, 61872, 61880, 62057, 62049, 61873, 61881, 70326, 70302, 69768, 70327, 70329, 70305, 69771, 
70330, 70328, 70303, 69745, 69770
24963, 62057, 62049, 61873, 61881, 62058, 62050, 61874, 61882, 70329, 70305, 69771, 70330, 70332, 70308, 69774, 
70333, 70331, 70306, 69748, 69773
24964, 62058, 62050, 61874, 61882, 62059, 62051, 61875, 61883, 70332, 70308, 69774, 70333, 70335, 70311, 69777, 
70336, 70334, 70309, 69751, 69776
24965, 62059, 62051, 61875, 61883, 26333, 26332, 26310, 26311, 70335, 70311, 69777, 70336, 27082, 27079, 27037, 
27081, 70337, 70312, 69754, 69779
24966, 24838, 24837, 24815, 24816, 62060, 62052, 61876, 61884, 25587, 25586, 25542, 25588, 70339, 70315, 69781, 
70340, 70338, 70313, 69755, 69780
24967, 62060, 62052, 61876, 61884, 62061, 62053, 61877, 61885, 70339, 70315, 69781, 70340, 70342, 70318, 69784, 
70343, 70341, 70316, 69758, 69783
24968, 62061, 62053, 61877, 61885, 62062, 62054, 61878, 61886, 70342, 70318, 69784, 70343, 70345, 70321, 69787, 
70346, 70344, 70319, 69761, 69786
24969, 62062, 62054, 61878, 61886, 62063, 62055, 61879, 61887, 70345, 70321, 69787, 70346, 70348, 70324, 69790, 
70349, 70347, 70322, 69764, 69789
24970, 62063, 62055, 61879, 61887, 62064, 62056, 61880, 61888, 70348, 70324, 69790, 70349, 70351, 70327, 69793, 
70352, 70350, 70325, 69767, 69792
24971, 62064, 62056, 61880, 61888, 62065, 62057, 61881, 61889, 70351, 70327, 69793, 70352, 70354, 70330, 69796, 
70355, 70353, 70328, 69770, 69795
24972, 62065, 62057, 61881, 61889, 62066, 62058, 61882, 61890, 70354, 70330, 69796, 70355, 70357, 70333, 69799, 
70358, 70356, 70331, 69773, 69798
24973, 62066, 62058, 61882, 61890, 62067, 62059, 61883, 61891, 70357, 70333, 69799, 70358, 70360, 70336, 69802, 
70361, 70359, 70334, 69776, 69801
24974, 62067, 62059, 61883, 61891, 26334, 26333, 26311, 26312, 70360, 70336, 69802, 70361, 27084, 27081, 27039, 
27083, 70362, 70337, 69779, 69804
24975, 24839, 24838, 24816, 24817, 62068, 62060, 61884, 61892, 25589, 25588, 25544, 25590, 70364, 70340, 69806, 
70365, 70363, 70338, 69780, 69805
24976, 62068, 62060, 61884, 61892, 62069, 62061, 61885, 61893, 70364, 70340, 69806, 70365, 70367, 70343, 69809, 
70368, 70366, 70341, 69783, 69808
24977, 62069, 62061, 61885, 61893, 62070, 62062, 61886, 61894, 70367, 70343, 69809, 70368, 70370, 70346, 69812, 
70371, 70369, 70344, 69786, 69811
24978, 62070, 62062, 61886, 61894, 62071, 62063, 61887, 61895, 70370, 70346, 69812, 70371, 70373, 70349, 69815, 
70374, 70372, 70347, 69789, 69814
24979, 62071, 62063, 61887, 61895, 62072, 62064, 61888, 61896, 70373, 70349, 69815, 70374, 70376, 70352, 69818, 
70377, 70375, 70350, 69792, 69817
24980, 62072, 62064, 61888, 61896, 62073, 62065, 61889, 61897, 70376, 70352, 69818, 70377, 70379, 70355, 69821, 
70380, 70378, 70353, 69795, 69820
24981, 62073, 62065, 61889, 61897, 62074, 62066, 61890, 61898, 70379, 70355, 69821, 70380, 70382, 70358, 69824, 
70383, 70381, 70356, 69798, 69823
24982, 62074, 62066, 61890, 61898, 62075, 62067, 61891, 61899, 70382, 70358, 69824, 70383, 70385, 70361, 69827, 
70386, 70384, 70359, 69801, 69826
24983, 62075, 62067, 61891, 61899, 26335, 26334, 26312, 26313, 70385, 70361, 69827, 70386, 27086, 27083, 27041, 
27085, 70387, 70362, 69804, 69829
24984, 24840, 24839, 24817, 24818, 62076, 62068, 61892, 61900, 25591, 25590, 25546, 25592, 70389, 70365, 69831, 
70390, 70388, 70363, 69805, 69830
24985, 62076, 62068, 61892, 61900, 62077, 62069, 61893, 61901, 70389, 70365, 69831, 70390, 70392, 70368, 69834, 
70393, 70391, 70366, 69808, 69833
24986, 62077, 62069, 61893, 61901, 62078, 62070, 61894, 61902, 70392, 70368, 69834, 70393, 70395, 70371, 69837, 
70396, 70394, 70369, 69811, 69836
24987, 62078, 62070, 61894, 61902, 62079, 62071, 61895, 61903, 70395, 70371, 69837, 70396, 70398, 70374, 69840, 
70399, 70397, 70372, 69814, 69839
24988, 62079, 62071, 61895, 61903, 62080, 62072, 61896, 61904, 70398, 70374, 69840, 70399, 70401, 70377, 69843, 
70402, 70400, 70375, 69817, 69842
24989, 62080, 62072, 61896, 61904, 62081, 62073, 61897, 61905, 70401, 70377, 69843, 70402, 70404, 70380, 69846, 
70405, 70403, 70378, 69820, 69845
24990, 62081, 62073, 61897, 61905, 62082, 62074, 61898, 61906, 70404, 70380, 69846, 70405, 70407, 70383, 69849, 
70408, 70406, 70381, 69823, 69848
24991, 62082, 62074, 61898, 61906, 62083, 62075, 61899, 61907, 70407, 70383, 69849, 70408, 70410, 70386, 69852, 
70411, 70409, 70384, 69826, 69851
24992, 62083, 62075, 61899, 61907, 26336, 26335, 26313, 26314, 70410, 70386, 69852, 70411, 27088, 27085, 27043, 
27087, 70412, 70387, 69829, 69854
24993, 24841, 24840, 24818, 24819, 62084, 62076, 61900, 61908, 25593, 25592, 25548, 25594, 70414, 70390, 69856, 
70415, 70413, 70388, 69830, 69855
24994, 62084, 62076, 61900, 61908, 62085, 62077, 61901, 61909, 70414, 70390, 69856, 70415, 70417, 70393, 69859, 
70418, 70416, 70391, 69833, 69858
24995, 62085, 62077, 61901, 61909, 62086, 62078, 61902, 61910, 70417, 70393, 69859, 70418, 70420, 70396, 69862, 
70421, 70419, 70394, 69836, 69861
24996, 62086, 62078, 61902, 61910, 62087, 62079, 61903, 61911, 70420, 70396, 69862, 70421, 70423, 70399, 69865, 
70424, 70422, 70397, 69839, 69864
24997, 62087, 62079, 61903, 61911, 62088, 62080, 61904, 61912, 70423, 70399, 69865, 70424, 70426, 70402, 69868, 
70427, 70425, 70400, 69842, 69867
24998, 62088, 62080, 61904, 61912, 62089, 62081, 61905, 61913, 70426, 70402, 69868, 70427, 70429, 70405, 69871, 
70430, 70428, 70403, 69845, 69870
24999, 62089, 62081, 61905, 61913, 62090, 62082, 61906, 61914, 70429, 70405, 69871, 70430, 70432, 70408, 69874, 
70433, 70431, 70406, 69848, 69873
25000, 62090, 62082, 61906, 61914, 62091, 62083, 61907, 61915, 70432, 70408, 69874, 70433, 70435, 70411, 69877, 
70436, 70434, 70409, 69851, 69876
25001, 62091, 62083, 61907, 61915, 26337, 26336, 26314, 26315, 70435, 70411, 69877, 70436, 27090, 27087, 27045, 
27089, 70437, 70412, 69854, 69879
25002, 24842, 24841, 24819, 24820, 62092, 62084, 61908, 61916, 25595, 25594, 25550, 25596, 70439, 70415, 69881, 
70440, 70438, 70413, 69855, 69880
25003, 62092, 62084, 61908, 61916, 62093, 62085, 61909, 61917, 70439, 70415, 69881, 70440, 70442, 70418, 69884, 
70443, 70441, 70416, 69858, 69883
25004, 62093, 62085, 61909, 61917, 62094, 62086, 61910, 61918, 70442, 70418, 69884, 70443, 70445, 70421, 69887, 
70446, 70444, 70419, 69861, 69886
25005, 62094, 62086, 61910, 61918, 62095, 62087, 61911, 61919, 70445, 70421, 69887, 70446, 70448, 70424, 69890, 
70449, 70447, 70422, 69864, 69889
25006, 62095, 62087, 61911, 61919, 62096, 62088, 61912, 61920, 70448, 70424, 69890, 70449, 70451, 70427, 69893, 
70452, 70450, 70425, 69867, 69892
25007, 62096, 62088, 61912, 61920, 62097, 62089, 61913, 61921, 70451, 70427, 69893, 70452, 70454, 70430, 69896, 
70455, 70453, 70428, 69870, 69895
25008, 62097, 62089, 61913, 61921, 62098, 62090, 61914, 61922, 70454, 70430, 69896, 70455, 70457, 70433, 69899, 
70458, 70456, 70431, 69873, 69898
25009, 62098, 62090, 61914, 61922, 62099, 62091, 61915, 61923, 70457, 70433, 69899, 70458, 70460, 70436, 69902, 
70461, 70459, 70434, 69876, 69901
25010, 62099, 62091, 61915, 61923, 26338, 26337, 26315, 26316, 70460, 70436, 69902, 70461, 27092, 27089, 27047, 
27091, 70462, 70437, 69879, 69904
25011, 24843, 24842, 24820, 24821, 62100, 62092, 61916, 61924, 25597, 25596, 25552, 25598, 70464, 70440, 69906, 
70465, 70463, 70438, 69880, 69905
25012, 62100, 62092, 61916, 61924, 62101, 62093, 61917, 61925, 70464, 70440, 69906, 70465, 70467, 70443, 69909, 
70468, 70466, 70441, 69883, 69908
25013, 62101, 62093, 61917, 61925, 62102, 62094, 61918, 61926, 70467, 70443, 69909, 70468, 70470, 70446, 69912, 
70471, 70469, 70444, 69886, 69911
25014, 62102, 62094, 61918, 61926, 62103, 62095, 61919, 61927, 70470, 70446, 69912, 70471, 70473, 70449, 69915, 
70474, 70472, 70447, 69889, 69914
25015, 62103, 62095, 61919, 61927, 62104, 62096, 61920, 61928, 70473, 70449, 69915, 70474, 70476, 70452, 69918, 
70477, 70475, 70450, 69892, 69917
25016, 62104, 62096, 61920, 61928, 62105, 62097, 61921, 61929, 70476, 70452, 69918, 70477, 70479, 70455, 69921, 
70480, 70478, 70453, 69895, 69920
25017, 62105, 62097, 61921, 61929, 62106, 62098, 61922, 61930, 70479, 70455, 69921, 70480, 70482, 70458, 69924, 
70483, 70481, 70456, 69898, 69923
25018, 62106, 62098, 61922, 61930, 62107, 62099, 61923, 61931, 70482, 70458, 69924, 70483, 70485, 70461, 69927, 
70486, 70484, 70459, 69901, 69926
25019, 62107, 62099, 61923, 61931, 26339, 26338, 26316, 26317, 70485, 70461, 69927, 70486, 27094, 27091, 27049, 
27093, 70487, 70462, 69904, 69929
25020, 24844, 24843, 24821, 24822, 62108, 62100, 61924, 61932, 25599, 25598, 25554, 25600, 70489, 70465, 69931, 
70490, 70488, 70463, 69905, 69930
25021, 62108, 62100, 61924, 61932, 62109, 62101, 61925, 61933, 70489, 70465, 69931, 70490, 70492, 70468, 69934, 
70493, 70491, 70466, 69908, 69933
25022, 62109, 62101, 61925, 61933, 62110, 62102, 61926, 61934, 70492, 70468, 69934, 70493, 70495, 70471, 69937, 
70496, 70494, 70469, 69911, 69936
25023, 62110, 62102, 61926, 61934, 62111, 62103, 61927, 61935, 70495, 70471, 69937, 70496, 70498, 70474, 69940, 
70499, 70497, 70472, 69914, 69939
25024, 62111, 62103, 61927, 61935, 62112, 62104, 61928, 61936, 70498, 70474, 69940, 70499, 70501, 70477, 69943, 
70502, 70500, 70475, 69917, 69942
25025, 62112, 62104, 61928, 61936, 62113, 62105, 61929, 61937, 70501, 70477, 69943, 70502, 70504, 70480, 69946, 
70505, 70503, 70478, 69920, 69945
25026, 62113, 62105, 61929, 61937, 62114, 62106, 61930, 61938, 70504, 70480, 69946, 70505, 70507, 70483, 69949, 
70508, 70506, 70481, 69923, 69948
25027, 62114, 62106, 61930, 61938, 62115, 62107, 61931, 61939, 70507, 70483, 69949, 70508, 70510, 70486, 69952, 
70511, 70509, 70484, 69926, 69951
25028, 62115, 62107, 61931, 61939, 26340, 26339, 26317, 26318, 70510, 70486, 69952, 70511, 27096, 27093, 27051, 
27095, 70512, 70487, 69929, 69954
25029, 24845, 24844, 24822, 24823, 62116, 62108, 61932, 61940, 25601, 25600, 25556, 25602, 70514, 70490, 69956, 
70515, 70513, 70488, 69930, 69955
25030, 62116, 62108, 61932, 61940, 62117, 62109, 61933, 61941, 70514, 70490, 69956, 70515, 70517, 70493, 69959, 
70518, 70516, 70491, 69933, 69958
25031, 62117, 62109, 61933, 61941, 62118, 62110, 61934, 61942, 70517, 70493, 69959, 70518, 70520, 70496, 69962, 
70521, 70519, 70494, 69936, 69961
25032, 62118, 62110, 61934, 61942, 62119, 62111, 61935, 61943, 70520, 70496, 69962, 70521, 70523, 70499, 69965, 
70524, 70522, 70497, 69939, 69964
25033, 62119, 62111, 61935, 61943, 62120, 62112, 61936, 61944, 70523, 70499, 69965, 70524, 70526, 70502, 69968, 
70527, 70525, 70500, 69942, 69967
25034, 62120, 62112, 61936, 61944, 62121, 62113, 61937, 61945, 70526, 70502, 69968, 70527, 70529, 70505, 69971, 
70530, 70528, 70503, 69945, 69970
25035, 62121, 62113, 61937, 61945, 62122, 62114, 61938, 61946, 70529, 70505, 69971, 70530, 70532, 70508, 69974, 
70533, 70531, 70506, 69948, 69973
25036, 62122, 62114, 61938, 61946, 62123, 62115, 61939, 61947, 70532, 70508, 69974, 70533, 70535, 70511, 69977, 
70536, 70534, 70509, 69951, 69976
25037, 62123, 62115, 61939, 61947, 26341, 26340, 26318, 26319, 70535, 70511, 69977, 70536, 27098, 27095, 27053, 
27097, 70537, 70512, 69954, 69979
25038, 24846, 24845, 24823, 24824, 62124, 62116, 61940, 61948, 25603, 25602, 25558, 25604, 70539, 70515, 69981, 
70540, 70538, 70513, 69955, 69980
25039, 62124, 62116, 61940, 61948, 62125, 62117, 61941, 61949, 70539, 70515, 69981, 70540, 70542, 70518, 69984, 
70543, 70541, 70516, 69958, 69983
25040, 62125, 62117, 61941, 61949, 62126, 62118, 61942, 61950, 70542, 70518, 69984, 70543, 70545, 70521, 69987, 
70546, 70544, 70519, 69961, 69986
25041, 62126, 62118, 61942, 61950, 62127, 62119, 61943, 61951, 70545, 70521, 69987, 70546, 70548, 70524, 69990, 
70549, 70547, 70522, 69964, 69989
25042, 62127, 62119, 61943, 61951, 62128, 62120, 61944, 61952, 70548, 70524, 69990, 70549, 70551, 70527, 69993, 
70552, 70550, 70525, 69967, 69992
25043, 62128, 62120, 61944, 61952, 62129, 62121, 61945, 61953, 70551, 70527, 69993, 70552, 70554, 70530, 69996, 
70555, 70553, 70528, 69970, 69995
25044, 62129, 62121, 61945, 61953, 62130, 62122, 61946, 61954, 70554, 70530, 69996, 70555, 70557, 70533, 69999, 
70558, 70556, 70531, 69973, 69998
25045, 62130, 62122, 61946, 61954, 62131, 62123, 61947, 61955, 70557, 70533, 69999, 70558, 70560, 70536, 70002, 
70561, 70559, 70534, 69976, 70001
25046, 62131, 62123, 61947, 61955, 26342, 26341, 26319, 26320, 70560, 70536, 70002, 70561, 27100, 27097, 27055, 
27099, 70562, 70537, 69979, 70004
25047, 24847, 24846, 24824, 24825, 62132, 62124, 61948, 61956, 25605, 25604, 25560, 25606, 70564, 70540, 70006, 
70565, 70563, 70538, 69980, 70005
25048, 62132, 62124, 61948, 61956, 62133, 62125, 61949, 61957, 70564, 70540, 70006, 70565, 70567, 70543, 70009, 
70568, 70566, 70541, 69983, 70008
25049, 62133, 62125, 61949, 61957, 62134, 62126, 61950, 61958, 70567, 70543, 70009, 70568, 70570, 70546, 70012, 
70571, 70569, 70544, 69986, 70011
25050, 62134, 62126, 61950, 61958, 62135, 62127, 61951, 61959, 70570, 70546, 70012, 70571, 70573, 70549, 70015, 
70574, 70572, 70547, 69989, 70014
25051, 62135, 62127, 61951, 61959, 62136, 62128, 61952, 61960, 70573, 70549, 70015, 70574, 70576, 70552, 70018, 
70577, 70575, 70550, 69992, 70017
25052, 62136, 62128, 61952, 61960, 62137, 62129, 61953, 61961, 70576, 70552, 70018, 70577, 70579, 70555, 70021, 
70580, 70578, 70553, 69995, 70020
25053, 62137, 62129, 61953, 61961, 62138, 62130, 61954, 61962, 70579, 70555, 70021, 70580, 70582, 70558, 70024, 
70583, 70581, 70556, 69998, 70023
25054, 62138, 62130, 61954, 61962, 62139, 62131, 61955, 61963, 70582, 70558, 70024, 70583, 70585, 70561, 70027, 
70586, 70584, 70559, 70001, 70026
25055, 62139, 62131, 61955, 61963, 26343, 26342, 26320, 26321, 70585, 70561, 70027, 70586, 27102, 27099, 27057, 
27101, 70587, 70562, 70004, 70029
25056, 3181, 24847, 24825, 3180, 28222, 62132, 61956, 28214, 25607, 25606, 25562, 3203, 70588, 70565, 70030, 
28498, 28497, 70563, 70005, 28480
25057, 28222, 62132, 61956, 28214, 28223, 62133, 61957, 28215, 70588, 70565, 70030, 28498, 70589, 70568, 70031, 
28500, 28499, 70566, 70008, 28482
25058, 28223, 62133, 61957, 28215, 28224, 62134, 61958, 28216, 70589, 70568, 70031, 28500, 70590, 70571, 70032, 
28502, 28501, 70569, 70011, 28484
25059, 28224, 62134, 61958, 28216, 28225, 62135, 61959, 28217, 70590, 70571, 70032, 28502, 70591, 70574, 70033, 
28504, 28503, 70572, 70014, 28486
25060, 28225, 62135, 61959, 28217, 28226, 62136, 61960, 28218, 70591, 70574, 70033, 28504, 70592, 70577, 70034, 
28506, 28505, 70575, 70017, 28488
25061, 28226, 62136, 61960, 28218, 28227, 62137, 61961, 28219, 70592, 70577, 70034, 28506, 70593, 70580, 70035, 
28508, 28507, 70578, 70020, 28490
25062, 28227, 62137, 61961, 28219, 28228, 62138, 61962, 28220, 70593, 70580, 70035, 28508, 70594, 70583, 70036, 
28510, 28509, 70581, 70023, 28492
25063, 28228, 62138, 61962, 28220, 28229, 62139, 61963, 28221, 70594, 70583, 70036, 28510, 70595, 70586, 70037, 
28512, 28511, 70584, 70026, 28494
25064, 28229, 62139, 61963, 28221, 3316, 26343, 26321, 3315, 70595, 70586, 70037, 28512, 27103, 27101, 27058, 
3338, 28513, 70587, 70029, 28496
25065, 24848, 3137, 3136, 24826, 62140, 27672, 27664, 61964, 25608, 3159, 25563, 25609, 70597, 27956, 70039, 
70598, 70596, 27957, 27940, 70038
25066, 62140, 27672, 27664, 61964, 62141, 27673, 27665, 61965, 70597, 27956, 70039, 70598, 70600, 27958, 70042, 
70601, 70599, 27959, 27942, 70041
25067, 62141, 27673, 27665, 61965, 62142, 27674, 27666, 61966, 70600, 27958, 70042, 70601, 70603, 27960, 70045, 
70604, 70602, 27961, 27944, 70044
25068, 62142, 27674, 27666, 61966, 62143, 27675, 27667, 61967, 70603, 27960, 70045, 70604, 70606, 27962, 70048, 
70607, 70605, 27963, 27946, 70047
25069, 62143, 27675, 27667, 61967, 62144, 27676, 27668, 61968, 70606, 27962, 70048, 70607, 70609, 27964, 70051, 
70610, 70608, 27965, 27948, 70050
25070, 62144, 27676, 27668, 61968, 62145, 27677, 27669, 61969, 70609, 27964, 70051, 70610, 70612, 27966, 70054, 
70613, 70611, 27967, 27950, 70053
25071, 62145, 27677, 27669, 61969, 62146, 27678, 27670, 61970, 70612, 27966, 70054, 70613, 70615, 27968, 70057, 
70616, 70614, 27969, 27952, 70056
25072, 62146, 27678, 27670, 61970, 62147, 27679, 27671, 61971, 70615, 27968, 70057, 70616, 70618, 27970, 70060, 
70619, 70617, 27971, 27954, 70059
25073, 62147, 27679, 27671, 61971, 26344, 3272, 3271, 26322, 70618, 27970, 70060, 70619, 27105, 3294, 27060, 
27104, 70620, 27972, 27955, 70062
25074, 24849, 24848, 24826, 24827, 62148, 62140, 61964, 61972, 25610, 25609, 25565, 25611, 70622, 70598, 70064, 
70623, 70621, 70596, 70038, 70063
25075, 62148, 62140, 61964, 61972, 62149, 62141, 61965, 61973, 70622, 70598, 70064, 70623, 70625, 70601, 70067, 
70626, 70624, 70599, 70041, 70066
25076, 62149, 62141, 61965, 61973, 62150, 62142, 61966, 61974, 70625, 70601, 70067, 70626, 70628, 70604, 70070, 
70629, 70627, 70602, 70044, 70069
25077, 62150, 62142, 61966, 61974, 62151, 62143, 61967, 61975, 70628, 70604, 70070, 70629, 70631, 70607, 70073, 
70632, 70630, 70605, 70047, 70072
25078, 62151, 62143, 61967, 61975, 62152, 62144, 61968, 61976, 70631, 70607, 70073, 70632, 70634, 70610, 70076, 
70635, 70633, 70608, 70050, 70075
25079, 62152, 62144, 61968, 61976, 62153, 62145, 61969, 61977, 70634, 70610, 70076, 70635, 70637, 70613, 70079, 
70638, 70636, 70611, 70053, 70078
25080, 62153, 62145, 61969, 61977, 62154, 62146, 61970, 61978, 70637, 70613, 70079, 70638, 70640, 70616, 70082, 
70641, 70639, 70614, 70056, 70081
25081, 62154, 62146, 61970, 61978, 62155, 62147, 61971, 61979, 70640, 70616, 70082, 70641, 70643, 70619, 70085, 
70644, 70642, 70617, 70059, 70084
25082, 62155, 62147, 61971, 61979, 26345, 26344, 26322, 26323, 70643, 70619, 70085, 70644, 27107, 27104, 27062, 
27106, 70645, 70620, 70062, 70087
25083, 24850, 24849, 24827, 24828, 62156, 62148, 61972, 61980, 25612, 25611, 25567, 25613, 70647, 70623, 70089, 
70648, 70646, 70621, 70063, 70088
25084, 62156, 62148, 61972, 61980, 62157, 62149, 61973, 61981, 70647, 70623, 70089, 70648, 70650, 70626, 70092, 
70651, 70649, 70624, 70066, 70091
25085, 62157, 62149, 61973, 61981, 62158, 62150, 61974, 61982, 70650, 70626, 70092, 70651, 70653, 70629, 70095, 
70654, 70652, 70627, 70069, 70094
25086, 62158, 62150, 61974, 61982, 62159, 62151, 61975, 61983, 70653, 70629, 70095, 70654, 70656, 70632, 70098, 
70657, 70655, 70630, 70072, 70097
25087, 62159, 62151, 61975, 61983, 62160, 62152, 61976, 61984, 70656, 70632, 70098, 70657, 70659, 70635, 70101, 
70660, 70658, 70633, 70075, 70100
25088, 62160, 62152, 61976, 61984, 62161, 62153, 61977, 61985, 70659, 70635, 70101, 70660, 70662, 70638, 70104, 
70663, 70661, 70636, 70078, 70103
25089, 62161, 62153, 61977, 61985, 62162, 62154, 61978, 61986, 70662, 70638, 70104, 70663, 70665, 70641, 70107, 
70666, 70664, 70639, 70081, 70106
25090, 62162, 62154, 61978, 61986, 62163, 62155, 61979, 61987, 70665, 70641, 70107, 70666, 70668, 70644, 70110, 
70669, 70667, 70642, 70084, 70109
25091, 62163, 62155, 61979, 61987, 26346, 26345, 26323, 26324, 70668, 70644, 70110, 70669, 27109, 27106, 27064, 
27108, 70670, 70645, 70087, 70112
