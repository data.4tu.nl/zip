6864, 2169, 15585, 15586, 2170, 15627, 15628, 15629, 2192
6865, 2170, 15586, 15587, 2171, 15629, 15630, 15631, 2193
6866, 2171, 15587, 2147, 72, 15631, 15632, 2148, 2194
6867, 2144, 71, 2195, 15566, 2146, 2217, 15633, 15588
6868, 15566, 2195, 2196, 15567, 15633, 2218, 15634, 15590
6869, 15567, 2196, 2197, 15568, 15634, 2219, 15635, 15592
6870, 15568, 2197, 2198, 15569, 15635, 2220, 15636, 15594
6871, 15569, 2198, 2199, 15570, 15636, 2221, 15637, 15596
6872, 15570, 2199, 2200, 15571, 15637, 2222, 15638, 15598
6873, 15571, 2200, 2201, 15572, 15638, 2223, 15639, 15600
6874, 15572, 2201, 2202, 15573, 15639, 2224, 15640, 15602
6875, 15573, 2202, 2203, 15574, 15640, 2225, 15641, 15604
6876, 15574, 2203, 2204, 15575, 15641, 2226, 15642, 15606
6877, 15575, 2204, 2205, 15576, 15642, 2227, 15643, 15608
6878, 15576, 2205, 2206, 15577, 15643, 2228, 15644, 15610
6879, 15577, 2206, 2207, 15578, 15644, 2229, 15645, 15612
6880, 15578, 2207, 2208, 15579, 15645, 2230, 15646, 15614
6881, 15579, 2208, 2209, 15580, 15646, 2231, 15647, 15616
6882, 15580, 2209, 2210, 15581, 15647, 2232, 15648, 15618
6883, 15581, 2210, 2211, 15582, 15648, 2233, 15649, 15620
6884, 15582, 2211, 2212, 15583, 15649, 2234, 15650, 15622
6885, 15583, 2212, 2213, 15584, 15650, 2235, 15651, 15624
6886, 15584, 2213, 2214, 15585, 15651, 2236, 15652, 15626
6887, 15585, 2214, 2215, 15586, 15652, 2237, 15653, 15628
6888, 15586, 2215, 2216, 15587, 15653, 2238, 15654, 15630
6889, 15587, 2216, 73, 2147, 15654, 2239, 2149, 15632
*ELEMENT, type=CPS8, ELSET=Surface237
6890, 55, 2246, 15655, 2240, 2268, 15677, 15678, 2241
6891, 2246, 2247, 15656, 15655, 2269, 15679, 15680, 15677
6892, 2247, 2248, 15657, 15656, 2270, 15681, 15682, 15679
6893, 2248, 2249, 15658, 15657, 2271, 15683, 15684, 15681
6894, 2249, 2250, 15659, 15658, 2272, 15685, 15686, 15683
6895, 2250, 2251, 15660, 15659, 2273, 15687, 15688, 15685
6896, 2251, 2252, 15661, 15660, 2274, 15689, 15690, 15687
6897, 2252, 2253, 15662, 15661, 2275, 15691, 15692, 15689
6898, 2253, 2254, 15663, 15662, 2276, 15693, 15694, 15691
6899, 2254, 2255, 15664, 15663, 2277, 15695, 15696, 15693
6900, 2255, 2256, 15665, 15664, 2278, 15697, 15698, 15695
6901, 2256, 2257, 15666, 15665, 2279, 15699, 15700, 15697
6902, 2257, 2258, 15667, 15666, 2280, 15701, 15702, 15699
6903, 2258, 2259, 15668, 15667, 2281, 15703, 15704, 15701
6904, 2259, 2260, 15669, 15668, 2282, 15705, 15706, 15703
6905, 2260, 2261, 15670, 15669, 2283, 15707, 15708, 15705
6906, 2261, 2262, 15671, 15670, 2284, 15709, 15710, 15707
6907, 2262, 2263, 15672, 15671, 2285, 15711, 15712, 15709
6908, 2263, 2264, 15673, 15672, 2286, 15713, 15714, 15711
6909, 2264, 2265, 15674, 15673, 2287, 15715, 15716, 15713
6910, 2265, 2266, 15675, 15674, 2288, 15717, 15718, 15715
6911, 2266, 2267, 15676, 15675, 2289, 15719, 15720, 15717
6912, 2267, 75, 2243, 15676, 2290, 2244, 15721, 15719
6913, 2240, 15655, 2291, 74, 15678, 15722, 2313, 2242
6914, 15655, 15656, 2292, 2291, 15680, 15723, 2314, 15722
6915, 15656, 15657, 2293, 2292, 15682, 15724, 2315, 15723
6916, 15657, 15658, 2294, 2293, 15684, 15725, 2316, 15724
6917, 15658, 15659, 2295, 2294, 15686, 15726, 2317, 15725
6918, 15659, 15660, 2296, 2295, 15688, 15727, 2318, 15726
6919, 15660, 15661, 2297, 2296, 15690, 15728, 2319, 15727
6920, 15661, 15662, 2298, 2297, 15692, 15729, 2320, 15728
6921, 15662, 15663, 2299, 2298, 15694, 15730, 2321, 15729
6922, 15663, 15664, 2300, 2299, 15696, 15731, 2322, 15730
6923, 15664, 15665, 2301, 2300, 15698, 15732, 2323, 15731
6924, 15665, 15666, 2302, 2301, 15700, 15733, 2324, 15732
6925, 15666, 15667, 2303, 2302, 15702, 15734, 2325, 15733
6926, 15667, 15668, 2304, 2303, 15704, 15735, 2326, 15734
6927, 15668, 15669, 2305, 2304, 15706, 15736, 2327, 15735
6928, 15669, 15670, 2306, 2305, 15708, 15737, 2328, 15736
6929, 15670, 15671, 2307, 2306, 15710, 15738, 2329, 15737
6930, 15671, 15672, 2308, 2307, 15712, 15739, 2330, 15738
6931, 15672, 15673, 2309, 2308, 15714, 15740, 2331, 15739
6932, 15673, 15674, 2310, 2309, 15716, 15741, 2332, 15740
6933, 15674, 15675, 2311, 2310, 15718, 15742, 2333, 15741
6934, 15675, 15676, 2312, 2311, 15720, 15743, 2334, 15742
6935, 15676, 2243, 76, 2312, 15721, 2245, 2335, 15743
*ELEMENT, type=CPS8, ELSET=Surface238
6936, 53, 1724, 15744, 2144, 1733, 15752, 15753, 2145
6937, 1724, 1723, 15745, 15744, 1732, 15754, 15755, 15752
6938, 1723, 1722, 15746, 15745, 1731, 15756, 15757, 15754
6939, 1722, 1721, 15747, 15746, 1730, 15758, 15759, 15756
6940, 1721, 1720, 15748, 15747, 1729, 15760, 15761, 15758
6941, 1720, 1719, 15749, 15748, 1728, 15762, 15763, 15760
6942, 1719, 1718, 15750, 15749, 1727, 15764, 15765, 15762
6943, 1718, 1717, 15751, 15750, 1726, 15766, 15767, 15764
6944, 1717, 55, 2240, 15751, 1725, 2241, 15768, 15766
6945, 2144, 15744, 2343, 71, 15753, 15769, 2352, 2146
6946, 15744, 15745, 2342, 2343, 15755, 15770, 2351, 15769
6947, 15745, 15746, 2341, 2342, 15757, 15771, 2350, 15770
6948, 15746, 15747, 2340, 2341, 15759, 15772, 2349, 15771
6949, 15747, 15748, 2339, 2340, 15761, 15773, 2348, 15772
6950, 15748, 15749, 2338, 2339, 15763, 15774, 2347, 15773
6951, 15749, 15750, 2337, 2338, 15765, 15775, 2346, 15774
6952, 15750, 15751, 2336, 2337, 15767, 15776, 2345, 15775
6953, 15751, 2240, 74, 2336, 15768, 2242, 2344, 15776
*ELEMENT, type=CPS8, ELSET=Surface239
6954, 72, 2147, 15777, 2360, 2148, 15785, 15786, 2369
6955, 2360, 15777, 15778, 2359, 15786, 15787, 15788, 2368
6956, 2359, 15778, 15779, 2358, 15788, 15789, 15790, 2367
6957, 2358, 15779, 15780, 2357, 15790, 15791, 15792, 2366
6958, 2357, 15780, 15781, 2356, 15792, 15793, 15794, 2365
6959, 2356, 15781, 15782, 2355, 15794, 15795, 15796, 2364
6960, 2355, 15782, 15783, 2354, 15796, 15797, 15798, 2363
6961, 2354, 15783, 15784, 2353, 15798, 15799, 15800, 2362
6962, 2353, 15784, 2243, 75, 15800, 15801, 2244, 2361
6963, 2147, 73, 2377, 15777, 2149, 2386, 15802, 15785
6964, 15777, 2377, 2376, 15778, 15802, 2385, 15803, 15787
6965, 15778, 2376, 2375, 15779, 15803, 2384, 15804, 15789
6966, 15779, 2375, 2374, 15780, 15804, 2383, 15805, 15791
6967, 15780, 2374, 2373, 15781, 15805, 2382, 15806, 15793
6968, 15781, 2373, 2372, 15782, 15806, 2381, 15807, 15795
6969, 15782, 2372, 2371, 15783, 15807, 2380, 15808, 15797
6970, 15783, 2371, 2370, 15784, 15808, 2379, 15809, 15799
6971, 15784, 2370, 76, 2243, 15809, 2378, 2245, 15801
*ELEMENT, type=CPS8, ELSET=Surface240
6972, 53, 2150, 15810, 1724, 2172, 15986, 15987, 1733
6973, 1724, 15810, 15811, 1723, 15987, 15988, 15989, 1732
6974, 1723, 15811, 15812, 1722, 15989, 15990, 15991, 1731
6975, 1722, 15812, 15813, 1721, 15991, 15992, 15993, 1730
6976, 1721, 15813, 15814, 1720, 15993, 15994, 15995, 1729
6977, 1720, 15814, 15815, 1719, 15995, 15996, 15997, 1728
6978, 1719, 15815, 15816, 1718, 15997, 15998, 15999, 1727
6979, 1718, 15816, 15817, 1717, 15999, 16000, 16001, 1726
6980, 1717, 15817, 2246, 55, 16001, 16002, 2268, 1725
6981, 2150, 2151, 15818, 15810, 2173, 16003, 16004, 15986
6982, 15810, 15818, 15819, 15811, 16004, 16005, 16006, 15988
6983, 15811, 15819, 15820, 15812, 16006, 16007, 16008, 15990
6984, 15812, 15820, 15821, 15813, 16008, 16009, 16010, 15992
6985, 15813, 15821, 15822, 15814, 16010, 16011, 16012, 15994
6986, 15814, 15822, 15823, 15815, 16012, 16013, 16014, 15996
6987, 15815, 15823, 15824, 15816, 16014, 16015, 16016, 15998
6988, 15816, 15824, 15825, 15817, 16016, 16017, 16018, 16000
6989, 15817, 15825, 2247, 2246, 16018, 16019, 2269, 16002
6990, 2151, 2152, 15826, 15818, 2174, 16020, 16021, 16003
6991, 15818, 15826, 15827, 15819, 16021, 16022, 16023, 16005
6992, 15819, 15827, 15828, 15820, 16023, 16024, 16025, 16007
6993, 15820, 15828, 15829, 15821, 16025, 16026, 16027, 16009
6994, 15821, 15829, 15830, 15822, 16027, 16028, 16029, 16011
6995, 15822, 15830, 15831, 15823, 16029, 16030, 16031, 16013
6996, 15823, 15831, 15832, 15824, 16031, 16032, 16033, 16015
6997, 15824, 15832, 15833, 15825, 16033, 16034, 16035, 16017
6998, 15825, 15833, 2248, 2247, 16035, 16036, 2270, 16019
6999, 2152, 2153, 15834, 15826, 2175, 16037, 16038, 16020
7000, 15826, 15834, 15835, 15827, 16038, 16039, 16040, 16022
7001, 15827, 15835, 15836, 15828, 16040, 16041, 16042, 16024
7002, 15828, 15836, 15837, 15829, 16042, 16043, 16044, 16026
7003, 15829, 15837, 15838, 15830, 16044, 16045, 16046, 16028
7004, 15830, 15838, 15839, 15831, 16046, 16047, 16048, 16030
7005, 15831, 15839, 15840, 15832, 16048, 16049, 16050, 16032
7006, 15832, 15840, 15841, 15833, 16050, 16051, 16052, 16034
7007, 15833, 15841, 2249, 2248, 16052, 16053, 2271, 16036
7008, 2153, 2154, 15842, 15834, 2176, 16054, 16055, 16037
7009, 15834, 15842, 15843, 15835, 16055, 16056, 16057, 16039
7010, 15835, 15843, 15844, 15836, 16057, 16058, 16059, 16041
7011, 15836, 15844, 15845, 15837, 16059, 16060, 16061, 16043
7012, 15837, 15845, 15846, 15838, 16061, 16062, 16063, 16045
7013, 15838, 15846, 15847, 15839, 16063, 16064, 16065, 16047
7014, 15839, 15847, 15848, 15840, 16065, 16066, 16067, 16049
7015, 15840, 15848, 15849, 15841, 16067, 16068, 16069, 16051
7016, 15841, 15849, 2250, 2249, 16069, 16070, 2272, 16053
7017, 2154, 2155, 15850, 15842, 2177, 16071, 16072, 16054
7018, 15842, 15850, 15851, 15843, 16072, 16073, 16074, 16056
7019, 15843, 15851, 15852, 15844, 16074, 16075, 16076, 16058
7020, 15844, 15852, 15853, 15845, 16076, 16077, 16078, 16060
7021, 15845, 15853, 15854, 15846, 16078, 16079, 16080, 16062
7022, 15846, 15854, 15855, 15847, 16080, 16081, 16082, 16064
7023, 15847, 15855, 15856, 15848, 16082, 16083, 16084, 16066
7024, 15848, 15856, 15857, 15849, 16084, 16085, 16086, 16068
7025, 15849, 15857, 2251, 2250, 16086, 16087, 2273, 16070
7026, 2155, 2156, 15858, 15850, 2178, 16088, 16089, 16071
7027, 15850, 15858, 15859, 15851, 16089, 16090, 16091, 16073
7028, 15851, 15859, 15860, 15852, 16091, 16092, 16093, 16075
7029, 15852, 15860, 15861, 15853, 16093, 16094, 16095, 16077
7030, 15853, 15861, 15862, 15854, 16095, 16096, 16097, 16079
7031, 15854, 15862, 15863, 15855, 16097, 16098, 16099, 16081
7032, 15855, 15863, 15864, 15856, 16099, 16100, 16101, 16083
7033, 15856, 15864, 15865, 15857, 16101, 16102, 16103, 16085
7034, 15857, 15865, 2252, 2251, 16103, 16104, 2274, 16087
7035, 2156, 2157, 15866, 15858, 2179, 16105, 16106, 16088
7036, 15858, 15866, 15867, 15859, 16106, 16107, 16108, 16090
7037, 15859, 15867, 15868, 15860, 16108, 16109, 16110, 16092
7038, 15860, 15868, 15869, 15861, 16110, 16111, 16112, 16094
7039, 15861, 15869, 15870, 15862, 16112, 16113, 16114, 16096
7040, 15862, 15870, 15871, 15863, 16114, 16115, 16116, 16098
7041, 15863, 15871, 15872, 15864, 16116, 16117, 16118, 16100
7042, 15864, 15872, 15873, 15865, 16118, 16119, 16120, 16102
7043, 15865, 15873, 2253, 2252, 16120, 16121, 2275, 16104
7044, 2157, 2158, 15874, 15866, 2180, 16122, 16123, 16105
7045, 15866, 15874, 15875, 15867, 16123, 16124, 16125, 16107
7046, 15867, 15875, 15876, 15868, 16125, 16126, 16127, 16109
7047, 15868, 15876, 15877, 15869, 16127, 16128, 16129, 16111
7048, 15869, 15877, 15878, 15870, 16129, 16130, 16131, 16113
7049, 15870, 15878, 15879, 15871, 16131, 16132, 16133, 16115
7050, 15871, 15879, 15880, 15872, 16133, 16134, 16135, 16117
7051, 15872, 15880, 15881, 15873, 16135, 16136, 16137, 16119
7052, 15873, 15881, 2254, 2253, 16137, 16138, 2276, 16121
7053, 2158, 2159, 15882, 15874, 2181, 16139, 16140, 16122
7054, 15874, 15882, 15883, 15875, 16140, 16141, 16142, 16124
7055, 15875, 15883, 15884, 15876, 16142, 16143, 16144, 16126
7056, 15876, 15884, 15885, 15877, 16144, 16145, 16146, 16128
7057, 15877, 15885, 15886, 15878, 16146, 16147, 16148, 16130
7058, 15878, 15886, 15887, 15879, 16148, 16149, 16150, 16132
7059, 15879, 15887, 15888, 15880, 16150, 16151, 16152, 16134
7060, 15880, 15888, 15889, 15881, 16152, 16153, 16154, 16136
7061, 15881, 15889, 2255, 2254, 16154, 16155, 2277, 16138
7062, 2159, 2160, 15890, 15882, 2182, 16156, 16157, 16139
7063, 15882, 15890, 15891, 15883, 16157, 16158, 16159, 16141
7064, 15883, 15891, 15892, 15884, 16159, 16160, 16161, 16143
7065, 15884, 15892, 15893, 15885, 16161, 16162, 16163, 16145
7066, 15885, 15893, 15894, 15886, 16163, 16164, 16165, 16147
7067, 15886, 15894, 15895, 15887, 16165, 16166, 16167, 16149
7068, 15887, 15895, 15896, 15888, 16167, 16168, 16169, 16151
7069, 15888, 15896, 15897, 15889, 16169, 16170, 16171, 16153
7070, 15889, 15897, 2256, 2255, 16171, 16172, 2278, 16155
7071, 2160, 2161, 15898, 15890, 2183, 16173, 16174, 16156
7072, 15890, 15898, 15899, 15891, 16174, 16175, 16176, 16158
7073, 15891, 15899, 15900, 15892, 16176, 16177, 16178, 16160
7074, 15892, 15900, 15901, 15893, 16178, 16179, 16180, 16162
7075, 15893, 15901, 15902, 15894, 16180, 16181, 16182, 16164
7076, 15894, 15902, 15903, 15895, 16182, 16183, 16184, 16166
7077, 15895, 15903, 15904, 15896, 16184, 16185, 16186, 16168
7078, 15896, 15904, 15905, 15897, 16186, 16187, 16188, 16170
7079, 15897, 15905, 2257, 2256, 16188, 16189, 2279, 16172
7080, 2161, 2162, 15906, 15898, 2184, 16190, 16191, 16173
7081, 15898, 15906, 15907, 15899, 16191, 16192, 16193, 16175
7082, 15899, 15907, 15908, 15900, 16193, 16194, 16195, 16177
7083, 15900, 15908, 15909, 15901, 16195, 16196, 16197, 16179
7084, 15901, 15909, 15910, 15902, 16197, 16198, 16199, 16181
7085, 15902, 15910, 15911, 15903, 16199, 16200, 16201, 16183
7086, 15903, 15911, 15912, 15904, 16201, 16202, 16203, 16185
7087, 15904, 15912, 15913, 15905, 16203, 16204, 16205, 16187
7088, 15905, 15913, 2258, 2257, 16205, 16206, 2280, 16189
7089, 2162, 2163, 15914, 15906, 2185, 16207, 16208, 16190
7090, 15906, 15914, 15915, 15907, 16208, 16209, 16210, 16192
7091, 15907, 15915, 15916, 15908, 16210, 16211, 16212, 16194
7092, 15908, 15916, 15917, 15909, 16212, 16213, 16214, 16196
7093, 15909, 15917, 15918, 15910, 16214, 16215, 16216, 16198
7094, 15910, 15918, 15919, 15911, 16216, 16217, 16218, 16200
7095, 15911, 15919, 15920, 15912, 16218, 16219, 16220, 16202
7096, 15912, 15920, 15921, 15913, 16220, 16221, 16222, 16204
7097, 15913, 15921, 2259, 2258, 16222, 16223, 2281, 16206
7098, 2163, 2164, 15922, 15914, 2186, 16224, 16225, 16207
7099, 15914, 15922, 15923, 15915, 16225, 16226, 16227, 16209
7100, 15915, 15923, 15924, 15916, 16227, 16228, 16229, 16211
7101, 15916, 15924, 15925, 15917, 16229, 16230, 16231, 16213
7102, 15917, 15925, 15926, 15918, 16231, 16232, 16233, 16215
7103, 15918, 15926, 15927, 15919, 16233, 16234, 16235, 16217
7104, 15919, 15927, 15928, 15920, 16235, 16236, 16237, 16219
7105, 15920, 15928, 15929, 15921, 16237, 16238, 16239, 16221
7106, 15921, 15929, 2260, 2259, 16239, 16240, 2282, 16223
7107, 2164, 2165, 15930, 15922, 2187, 16241, 16242, 16224
7108, 15922, 15930, 15931, 15923, 16242, 16243, 16244, 16226
7109, 15923, 15931, 15932, 15924, 16244, 16245, 16246, 16228
7110, 15924, 15932, 15933, 15925, 16246, 16247, 16248, 16230
7111, 15925, 15933, 15934, 15926, 16248, 16249, 16250, 16232
7112, 15926, 15934, 15935, 15927, 16250, 16251, 16252, 16234
7113, 15927, 15935, 15936, 15928, 16252, 16253, 16254, 16236
7114, 15928, 15936, 15937, 15929, 16254, 16255, 16256, 16238
7115, 15929, 15937, 2261, 2260, 16256, 16257, 2283, 16240
7116, 2165, 2166, 15938, 15930, 2188, 16258, 16259, 16241
7117, 15930, 15938, 15939, 15931, 16259, 16260, 16261, 16243
7118, 15931, 15939, 15940, 15932, 16261, 16262, 16263, 16245
7119, 15932, 15940, 15941, 15933, 16263, 16264, 16265, 16247
7120, 15933, 15941, 15942, 15934, 16265, 16266, 16267, 16249
7121, 15934, 15942, 15943, 15935, 16267, 16268, 16269, 16251
7122, 15935, 15943, 15944, 15936, 16269, 16270, 16271, 16253
7123, 15936, 15944, 15945, 15937, 16271, 16272, 16273, 16255
7124, 15937, 15945, 2262, 2261, 16273, 16274, 2284, 16257
7125, 2166, 2167, 15946, 15938, 2189, 16275, 16276, 16258
7126, 15938, 15946, 15947, 15939, 16276, 16277, 16278, 16260
7127, 15939, 15947, 15948, 15940, 16278, 16279, 16280, 16262
7128, 15940, 15948, 15949, 15941, 16280, 16281, 16282, 16264
7129, 15941, 15949, 15950, 15942, 16282, 16283, 16284, 16266
7130, 15942, 15950, 15951, 15943, 16284, 16285, 16286, 16268
7131, 15943, 15951, 15952, 15944, 16286, 16287, 16288, 16270
7132, 15944, 15952, 15953, 15945, 16288, 16289, 16290, 16272
7133, 15945, 15953, 2263, 2262, 16290, 16291, 2285, 16274
7134, 2167, 2168, 15954, 15946, 2190, 16292, 16293, 16275
7135, 15946, 15954, 15955, 15947, 16293, 16294, 16295, 16277
7136, 15947, 15955, 15956, 15948, 16295, 16296, 16297, 16279
7137, 15948, 15956, 15957, 15949, 16297, 16298, 16299, 16281
7138, 15949, 15957, 15958, 15950, 16299, 16300, 16301, 16283
7139, 15950, 15958, 15959, 15951, 16301, 16302, 16303, 16285
7140, 15951, 15959, 15960, 15952, 16303, 16304, 16305, 16287
7141, 15952, 15960, 15961, 15953, 16305, 16306, 16307, 16289
7142, 15953, 15961, 2264, 2263, 16307, 16308, 2286, 16291
7143, 2168, 2169, 15962, 15954, 2191, 16309, 16310, 16292
7144, 15954, 15962, 15963, 15955, 16310, 16311, 16312, 16294
7145, 15955, 15963, 15964, 15956, 16312, 16313, 16314, 16296
7146, 15956, 15964, 15965, 15957, 16314, 16315, 16316, 16298
7147, 15957, 15965, 15966, 15958, 16316, 16317, 16318, 16300
7148, 15958, 15966, 15967, 15959, 16318, 16319, 16320, 16302
7149, 15959, 15967, 15968, 15960, 16320, 16321, 16322, 16304
7150, 15960, 15968, 15969, 15961, 16322, 16323, 16324, 16306
7151, 15961, 15969, 2265, 2264, 16324, 16325, 2287, 16308
7152, 2169, 2170, 15970, 15962, 2192, 16326, 16327, 16309
7153, 15962, 15970, 15971, 15963, 16327, 16328, 16329, 16311
7154, 15963, 15971, 15972, 15964, 16329, 16330, 16331, 16313
7155, 15964, 15972, 15973, 15965, 16331, 16332, 16333, 16315
7156, 15965, 15973, 15974, 15966, 16333, 16334, 16335, 16317
7157, 15966, 15974, 15975, 15967, 16335, 16336, 16337, 16319
7158, 15967, 15975, 15976, 15968, 16337, 16338, 16339, 16321
7159, 15968, 15976, 15977, 15969, 16339, 16340, 16341, 16323
7160, 15969, 15977, 2266, 2265, 16341, 16342, 2288, 16325
7161, 2170, 2171, 15978, 15970, 2193, 16343, 16344, 16326
7162, 15970, 15978, 15979, 15971, 16344, 16345, 16346, 16328
7163, 15971, 15979, 15980, 15972, 16346, 16347, 16348, 16330
7164, 15972, 15980, 15981, 15973, 16348, 16349, 16350, 16332
7165, 15973, 15981, 15982, 15974, 16350, 16351, 16352, 16334
7166, 15974, 15982, 15983, 15975, 16352, 16353, 16354, 16336
7167, 15975, 15983, 15984, 15976, 16354, 16355, 16356, 16338
7168, 15976, 15984, 15985, 15977, 16356, 16357, 16358, 16340
7169, 15977, 15985, 2267, 2266, 16358, 16359, 2289, 16342
7170, 2171, 72, 2360, 15978, 2194, 2369, 16360, 16343
7171, 15978, 2360, 2359, 15979, 16360, 2368, 16361, 16345
7172, 15979, 2359, 2358, 15980, 16361, 2367, 16362, 16347
7173, 15980, 2358, 2357, 15981, 16362, 2366, 16363, 16349
7174, 15981, 2357, 2356, 15982, 16363, 2365, 16364, 16351
7175, 15982, 2356, 2355, 15983, 16364, 2364, 16365, 16353
7176, 15983, 2355, 2354, 15984, 16365, 2363, 16366, 16355
7177, 15984, 2354, 2353, 15985, 16366, 2362, 16367, 16357
7178, 15985, 2353, 75, 2267, 16367, 2361, 2290, 16359
*ELEMENT, type=CPS8, ELSET=Surface241
7179, 71, 2343, 16368, 2195, 2352, 16544, 16545, 2217
7180, 2343, 2342, 16369, 16368, 2351, 16546, 16547, 16544
7181, 2342, 2341, 16370, 16369, 2350, 16548, 16549, 16546
7182, 2341, 2340, 16371, 16370, 2349, 16550, 16551, 16548
7183, 2340, 2339, 16372, 16371, 2348, 16552, 16553, 16550
7184, 2339, 2338, 16373, 16372, 2347, 16554, 16555, 16552
7185, 2338, 2337, 16374, 16373, 2346, 16556, 16557, 16554
7186, 2337, 2336, 16375, 16374, 2345, 16558, 16559, 16556
7187, 2336, 74, 2291, 16375, 2344, 2313, 16560, 16558
7188, 2195, 16368, 16376, 2196, 16545, 16561, 16562, 2218
7189, 16368, 16369, 16377, 16376, 16547, 16563, 16564, 16561
7190, 16369, 16370, 16378, 16377, 16549, 16565, 16566, 16563
7191, 16370, 16371, 16379, 16378, 16551, 16567, 16568, 16565
7192, 16371, 16372, 16380, 16379, 16553, 16569, 16570, 16567
7193, 16372, 16373, 16381, 16380, 16555, 16571, 16572, 16569
7194, 16373, 16374, 16382, 16381, 16557, 16573, 16574, 16571
7195, 16374, 16375, 16383, 16382, 16559, 16575, 16576, 16573
7196, 16375, 2291, 2292, 16383, 16560, 2314, 16577, 16575
7197, 2196, 16376, 16384, 2197, 16562, 16578, 16579, 2219
7198, 16376, 16377, 16385, 16384, 16564, 16580, 16581, 16578
7199, 16377, 16378, 16386, 16385, 16566, 16582, 16583, 16580
7200, 16378, 16379, 16387, 16386, 16568, 16584, 16585, 16582
7201, 16379, 16380, 16388, 16387, 16570, 16586, 16587, 16584
7202, 16380, 16381, 16389, 16388, 16572, 16588, 16589, 16586
7203, 16381, 16382, 16390, 16389, 16574, 16590, 16591, 16588
7204, 16382, 16383, 16391, 16390, 16576, 16592, 16593, 16590
7205, 16383, 2292, 2293, 16391, 16577, 2315, 16594, 16592
7206, 2197, 16384, 16392, 2198, 16579, 16595, 16596, 2220
7207, 16384, 16385, 16393, 16392, 16581, 16597, 16598, 16595
7208, 16385, 16386, 16394, 16393, 16583, 16599, 16600, 16597
7209, 16386, 16387, 16395, 16394, 16585, 16601, 16602, 16599
7210, 16387, 16388, 16396, 16395, 16587, 16603, 16604, 16601
7211, 16388, 16389, 16397, 16396, 16589, 16605, 16606, 16603
7212, 16389, 16390, 16398, 16397, 16591, 16607, 16608, 16605
7213, 16390, 16391, 16399, 16398, 16593, 16609, 16610, 16607
7214, 16391, 2293, 2294, 16399, 16594, 2316, 16611, 16609
7215, 2198, 16392, 16400, 2199, 16596, 16612, 16613, 2221
7216, 16392, 16393, 16401, 16400, 16598, 16614, 16615, 16612
7217, 16393, 16394, 16402, 16401, 16600, 16616, 16617, 16614
7218, 16394, 16395, 16403, 16402, 16602, 16618, 16619, 16616
7219, 16395, 16396, 16404, 16403, 16604, 16620, 16621, 16618
7220, 16396, 16397, 16405, 16404, 16606, 16622, 16623, 16620
7221, 16397, 16398, 16406, 16405, 16608, 16624, 16625, 16622
7222, 16398, 16399, 16407, 16406, 16610, 16626, 16627, 16624
7223, 16399, 2294, 2295, 16407, 16611, 2317, 16628, 16626
7224, 2199, 16400, 16408, 2200, 16613, 16629, 16630, 2222
7225, 16400, 16401, 16409, 16408, 16615, 16631, 16632, 16629
7226, 16401, 16402, 16410, 16409, 16617, 16633, 16634, 16631
7227, 16402, 16403, 16411, 16410, 16619, 16635, 16636, 16633
7228, 16403, 16404, 16412, 16411, 16621, 16637, 16638, 16635
7229, 16404, 16405, 16413, 16412, 16623, 16639, 16640, 16637
7230, 16405, 16406, 16414, 16413, 16625, 16641, 16642, 16639
7231, 16406, 16407, 16415, 16414, 16627, 16643, 16644, 16641
7232, 16407, 2295, 2296, 16415, 16628, 2318, 16645, 16643
7233, 2200, 16408, 16416, 2201, 16630, 16646, 16647, 2223
7234, 16408, 16409, 16417, 16416, 16632, 16648, 16649, 16646
7235, 16409, 16410, 16418, 16417, 16634, 16650, 16651, 16648
7236, 16410, 16411, 16419, 16418, 16636, 16652, 16653, 16650
7237, 16411, 16412, 16420, 16419, 16638, 16654, 16655, 16652
7238, 16412, 16413, 16421, 16420, 16640, 16656, 16657, 16654
7239, 16413, 16414, 16422, 16421, 16642, 16658, 16659, 16656
7240, 16414, 16415, 16423, 16422, 16644, 16660, 16661, 16658
7241, 16415, 2296, 2297, 16423, 16645, 2319, 16662, 16660
7242, 2201, 16416, 16424, 2202, 16647, 16663, 16664, 2224
7243, 16416, 16417, 16425, 16424, 16649, 16665, 16666, 16663
7244, 16417, 16418, 16426, 16425, 16651, 16667, 16668, 16665
7245, 16418, 16419, 16427, 16426, 16653, 16669, 16670, 16667
7246, 16419, 16420, 16428, 16427, 16655, 16671, 16672, 16669
7247, 16420, 16421, 16429, 16428, 16657, 16673, 16674, 16671
7248, 16421, 16422, 16430, 16429, 16659, 16675, 16676, 16673
7249, 16422, 16423, 16431, 16430, 16661, 16677, 16678, 16675
7250, 16423, 2297, 2298, 16431, 16662, 2320, 16679, 16677
7251, 2202, 16424, 16432, 2203, 16664, 16680, 16681, 2225
7252, 16424, 16425, 16433, 16432, 16666, 16682, 16683, 16680
7253, 16425, 16426, 16434, 16433, 16668, 16684, 16685, 16682
7254, 16426, 16427, 16435, 16434, 16670, 16686, 16687, 16684
7255, 16427, 16428, 16436, 16435, 16672, 16688, 16689, 16686
7256, 16428, 16429, 16437, 16436, 16674, 16690, 16691, 16688
7257, 16429, 16430, 16438, 16437, 16676, 16692, 16693, 16690
7258, 16430, 16431, 16439, 16438, 16678, 16694, 16695, 16692
7259, 16431, 2298, 2299, 16439, 16679, 2321, 16696, 16694
7260, 2203, 16432, 16440, 2204, 16681, 16697, 16698, 2226
7261, 16432, 16433, 16441, 16440, 16683, 16699, 16700, 16697
7262, 16433, 16434, 16442, 16441, 16685, 16701, 16702, 16699
7263, 16434, 16435, 16443, 16442, 16687, 16703, 16704, 16701
7264, 16435, 16436, 16444, 16443, 16689, 16705, 16706, 16703
7265, 16436, 16437, 16445, 16444, 16691, 16707, 16708, 16705
7266, 16437, 16438, 16446, 16445, 16693, 16709, 16710, 16707
7267, 16438, 16439, 16447, 16446, 16695, 16711, 16712, 16709
7268, 16439, 2299, 2300, 16447, 16696, 2322, 16713, 16711
7269, 2204, 16440, 16448, 2205, 16698, 16714, 16715, 2227
7270, 16440, 16441, 16449, 16448, 16700, 16716, 16717, 16714
7271, 16441, 16442, 16450, 16449, 16702, 16718, 16719, 16716
7272, 16442, 16443, 16451, 16450, 16704, 16720, 16721, 16718
7273, 16443, 16444, 16452, 16451, 16706, 16722, 16723, 16720
7274, 16444, 16445, 16453, 16452, 16708, 16724, 16725, 16722
7275, 16445, 16446, 16454, 16453, 16710, 16726, 16727, 16724
7276, 16446, 16447, 16455, 16454, 16712, 16728, 16729, 16726
7277, 16447, 2300, 2301, 16455, 16713, 2323, 16730, 16728
7278, 2205, 16448, 16456, 2206, 16715, 16731, 16732, 2228
7279, 16448, 16449, 16457, 16456, 16717, 16733, 16734, 16731
7280, 16449, 16450, 16458, 16457, 16719, 16735, 16736, 16733
7281, 16450, 16451, 16459, 16458, 16721, 16737, 16738, 16735
7282, 16451, 16452, 16460, 16459, 16723, 16739, 16740, 16737
7283, 16452, 16453, 16461, 16460, 16725, 16741, 16742, 16739
7284, 16453, 16454, 16462, 16461, 16727, 16743, 16744, 16741
7285, 16454, 16455, 16463, 16462, 16729, 16745, 16746, 16743
7286, 16455, 2301, 2302, 16463, 16730, 2324, 16747, 16745
7287, 2206, 16456, 16464, 2207, 16732, 16748, 16749, 2229
7288, 16456, 16457, 16465, 16464, 16734, 16750, 16751, 16748
7289, 16457, 16458, 16466, 16465, 16736, 16752, 16753, 16750
7290, 16458, 16459, 16467, 16466, 16738, 16754, 16755, 16752
7291, 16459, 16460, 16468, 16467, 16740, 16756, 16757, 16754
7292, 16460, 16461, 16469, 16468, 16742, 16758, 16759, 16756
7293, 16461, 16462, 16470, 16469, 16744, 16760, 16761, 16758
7294, 16462, 16463, 16471, 16470, 16746, 16762, 16763, 16760
7295, 16463, 2302, 2303, 16471, 16747, 2325, 16764, 16762
7296, 2207, 16464, 16472, 2208, 16749, 16765, 16766, 2230
7297, 16464, 16465, 16473, 16472, 16751, 16767, 16768, 16765
7298, 16465, 16466, 16474, 16473, 16753, 16769, 16770, 16767
7299, 16466, 16467, 16475, 16474, 16755, 16771, 16772, 16769
7300, 16467, 16468, 16476, 16475, 16757, 16773, 16774, 16771
7301, 16468, 16469, 16477, 16476, 16759, 16775, 16776, 16773
7302, 16469, 16470, 16478, 16477, 16761, 16777, 16778, 16775
7303, 16470, 16471, 16479, 16478, 16763, 16779, 16780, 16777
7304, 16471, 2303, 2304, 16479, 16764, 2326, 16781, 16779
7305, 2208, 16472, 16480, 2209, 16766, 16782, 16783, 2231
7306, 16472, 16473, 16481, 16480, 16768, 16784, 16785, 16782
7307, 16473, 16474, 16482, 16481, 16770, 16786, 16787, 16784
7308, 16474, 16475, 16483, 16482, 16772, 16788, 16789, 16786
7309, 16475, 16476, 16484, 16483, 16774, 16790, 16791, 16788
7310, 16476, 16477, 16485, 16484, 16776, 16792, 16793, 16790
7311, 16477, 16478, 16486, 16485, 16778, 16794, 16795, 16792
7312, 16478, 16479, 16487, 16486, 16780, 16796, 16797, 16794
7313, 16479, 2304, 2305, 16487, 16781, 2327, 16798, 16796
7314, 2209, 16480, 16488, 2210, 16783, 16799, 16800, 2232
7315, 16480, 16481, 16489, 16488, 16785, 16801, 16802, 16799
7316, 16481, 16482, 16490, 16489, 16787, 16803, 16804, 16801
7317, 16482, 16483, 16491, 16490, 16789, 16805, 16806, 16803
7318, 16483, 16484, 16492, 16491, 16791, 16807, 16808, 16805
7319, 16484, 16485, 16493, 16492, 16793, 16809, 16810, 16807
7320, 16485, 16486, 16494, 16493, 16795, 16811, 16812, 16809
7321, 16486, 16487, 16495, 16494, 16797, 16813, 16814, 16811
7322, 16487, 2305, 2306, 16495, 16798, 2328, 16815, 16813
7323, 2210, 16488, 16496, 2211, 16800, 16816, 16817, 2233
7324, 16488, 16489, 16497, 16496, 16802, 16818, 16819, 16816
7325, 16489, 16490, 16498, 16497, 16804, 16820, 16821, 16818
7326, 16490, 16491, 16499, 16498, 16806, 16822, 16823, 16820
7327, 16491, 16492, 16500, 16499, 16808, 16824, 16825, 16822
7328, 16492, 16493, 16501, 16500, 16810, 16826, 16827, 16824
7329, 16493, 16494, 16502, 16501, 16812, 16828, 16829, 16826
7330, 16494, 16495, 16503, 16502, 16814, 16830, 16831, 16828
7331, 16495, 2306, 2307, 16503, 16815, 2329, 16832, 16830
7332, 2211, 16496, 16504, 2212, 16817, 16833, 16834, 2234
7333, 16496, 16497, 16505, 16504, 16819, 16835, 16836, 16833
7334, 16497, 16498, 16506, 16505, 16821, 16837, 16838, 16835
7335, 16498, 16499, 16507, 16506, 16823, 16839, 16840, 16837
7336, 16499, 16500, 16508, 16507, 16825, 16841, 16842, 16839
7337, 16500, 16501, 16509, 16508, 16827, 16843, 16844, 16841
7338, 16501, 16502, 16510, 16509, 16829, 16845, 16846, 16843
7339, 16502, 16503, 16511, 16510, 16831, 16847, 16848, 16845
7340, 16503, 2307, 2308, 16511, 16832, 2330, 16849, 16847
7341, 2212, 16504, 16512, 2213, 16834, 16850, 16851, 2235
7342, 16504, 16505, 16513, 16512, 16836, 16852, 16853, 16850
7343, 16505, 16506, 16514, 16513, 16838, 16854, 16855, 16852
7344, 16506, 16507, 16515, 16514, 16840, 16856, 16857, 16854
7345, 16507, 16508, 16516, 16515, 16842, 16858, 16859, 16856
7346, 16508, 16509, 16517, 16516, 16844, 16860, 16861, 16858
7347, 16509, 16510, 16518, 16517, 16846, 16862, 16863, 16860
7348, 16510, 16511, 16519, 16518, 16848, 16864, 16865, 16862
7349, 16511, 2308, 2309, 16519, 16849, 2331, 16866, 16864
7350, 2213, 16512, 16520, 2214, 16851, 16867, 16868, 2236
7351, 16512, 16513, 16521, 16520, 16853, 16869, 16870, 16867
7352, 16513, 16514, 16522, 16521, 16855, 16871, 16872, 16869
7353, 16514, 16515, 16523, 16522, 16857, 16873, 16874, 16871
7354, 16515, 16516, 16524, 16523, 16859, 16875, 16876, 16873
7355, 16516, 16517, 16525, 16524, 16861, 16877, 16878, 16875
7356, 16517, 16518, 16526, 16525, 16863, 16879, 16880, 16877
7357, 16518, 16519, 16527, 16526, 16865, 16881, 16882, 16879
7358, 16519, 2309, 2310, 16527, 16866, 2332, 16883, 16881
7359, 2214, 16520, 16528, 2215, 16868, 16884, 16885, 2237
7360, 16520, 16521, 16529, 16528, 16870, 16886, 16887, 16884
7361, 16521, 16522, 16530, 16529, 16872, 16888, 16889, 16886
7362, 16522, 16523, 16531, 16530, 16874, 16890, 16891, 16888
7363, 16523, 16524, 16532, 16531, 16876, 16892, 16893, 16890
7364, 16524, 16525, 16533, 16532, 16878, 16894, 16895, 16892
7365, 16525, 16526, 16534, 16533, 16880, 16896, 16897, 16894
7366, 16526, 16527, 16535, 16534, 16882, 16898, 16899, 16896
7367, 16527, 2310, 2311, 16535, 16883, 2333, 16900, 16898
7368, 2215, 16528, 16536, 2216, 16885, 16901, 16902, 2238
7369, 16528, 16529, 16537, 16536, 16887, 16903, 16904, 16901
7370, 16529, 16530, 16538, 16537, 16889, 16905, 16906, 16903
7371, 16530, 16531, 16539, 16538, 16891, 16907, 16908, 16905
7372, 16531, 16532, 16540, 16539, 16893, 16909, 16910, 16907
7373, 16532, 16533, 16541, 16540, 16895, 16911, 16912, 16909
7374, 16533, 16534, 16542, 16541, 16897, 16913, 16914, 16911
7375, 16534, 16535, 16543, 16542, 16899, 16915, 16916, 16913
7376, 16535, 2311, 2312, 16543, 16900, 2334, 16917, 16915
7377, 2216, 16536, 2377, 73, 16902, 16918, 2386, 2239
7378, 16536, 16537, 2376, 2377, 16904, 16919, 2385, 16918
7379, 16537, 16538, 2375, 2376, 16906, 16920, 2384, 16919
7380, 16538, 16539, 2374, 2375, 16908, 16921, 2383, 16920
7381, 16539, 16540, 2373, 2374, 16910, 16922, 2382, 16921
7382, 16540, 16541, 2372, 2373, 16912, 16923, 2381, 16922
7383, 16541, 16542, 2371, 2372, 16914, 16924, 2380, 16923
7384, 16542, 16543, 2370, 2371, 16916, 16925, 2379, 16924
7385, 16543, 2312, 76, 2370, 16917, 2335, 2378, 16925
*ELEMENT, type=CPS8, ELSET=Surface242
7386, 53, 2150, 16926, 1693, 2172, 16970, 16971, 1695
7387, 1693, 16926, 16927, 1694, 16971, 16972, 16973, 1696
7388, 1694, 16927, 2387, 54, 16973, 16974, 2409, 1697
7389, 2150, 2151, 16928, 16926, 2173, 16975, 16976, 16970
7390, 16926, 16928, 16929, 16927, 16976, 16977, 16978, 16972
7391, 16927, 16929, 2388, 2387, 16978, 16979, 2410, 16974
7392, 2151, 2152, 16930, 16928, 2174, 16980, 16981, 16975
7393, 16928, 16930, 16931, 16929, 16981, 16982, 16983, 16977
7394, 16929, 16931, 2389, 2388, 16983, 16984, 2411, 16979
7395, 2152, 2153, 16932, 16930, 2175, 16985, 16986, 16980
7396, 16930, 16932, 16933, 16931, 16986, 16987, 16988, 16982
7397, 16931, 16933, 2390, 2389, 16988, 16989, 2412, 16984
7398, 2153, 2154, 16934, 16932, 2176, 16990, 16991, 16985
7399, 16932, 16934, 16935, 16933, 16991, 16992, 16993, 16987
7400, 16933, 16935, 2391, 2390, 16993, 16994, 2413, 16989
7401, 2154, 2155, 16936, 16934, 2177, 16995, 16996, 16990
7402, 16934, 16936, 16937, 16935, 16996, 16997, 16998, 16992
7403, 16935, 16937, 2392, 2391, 16998, 16999, 2414, 16994
7404, 2155, 2156, 16938, 16936, 2178, 17000, 17001, 16995
7405, 16936, 16938, 16939, 16937, 17001, 17002, 17003, 16997
7406, 16937, 16939, 2393, 2392, 17003, 17004, 2415, 16999
7407, 2156, 2157, 16940, 16938, 2179, 17005, 17006, 17000
7408, 16938, 16940, 16941, 16939, 17006, 17007, 17008, 17002
7409, 16939, 16941, 2394, 2393, 17008, 17009, 2416, 17004
7410, 2157, 2158, 16942, 16940, 2180, 17010, 17011, 17005
7411, 16940, 16942, 16943, 16941, 17011, 17012, 17013, 17007
7412, 16941, 16943, 2395, 2394, 17013, 17014, 2417, 17009
7413, 2158, 2159, 16944, 16942, 2181, 17015, 17016, 17010
7414, 16942, 16944, 16945, 16943, 17016, 17017, 17018, 17012
7415, 16943, 16945, 2396, 2395, 17018, 17019, 2418, 17014
7416, 2159, 2160, 16946, 16944, 2182, 17020, 17021, 17015
7417, 16944, 16946, 16947, 16945, 17021, 17022, 17023, 17017
7418, 16945, 16947, 2397, 2396, 17023, 17024, 2419, 17019
7419, 2160, 2161, 16948, 16946, 2183, 17025, 17026, 17020
7420, 16946, 16948, 16949, 16947, 17026, 17027, 17028, 17022
7421, 16947, 16949, 2398, 2397, 17028, 17029, 2420, 17024
7422, 2161, 2162, 16950, 16948, 2184, 17030, 17031, 17025
7423, 16948, 16950, 16951, 16949, 17031, 17032, 17033, 17027
7424, 16949, 16951, 2399, 2398, 17033, 17034, 2421, 17029
7425, 2162, 2163, 16952, 16950, 2185, 17035, 17036, 17030
7426, 16950, 16952, 16953, 16951, 17036, 17037, 17038, 17032
7427, 16951, 16953, 2400, 2399, 17038, 17039, 2422, 17034
7428, 2163, 2164, 16954, 16952, 2186, 17040, 17041, 17035
7429, 16952, 16954, 16955, 16953, 17041, 17042, 17043, 17037
7430, 16953, 16955, 2401, 2400, 17043, 17044, 2423, 17039
7431, 2164, 2165, 16956, 16954, 2187, 17045, 17046, 17040
7432, 16954, 16956, 16957, 16955, 17046, 17047, 17048, 17042
7433, 16955, 16957, 2402, 2401, 17048, 17049, 2424, 17044
7434, 2165, 2166, 16958, 16956, 2188, 17050, 17051, 17045
7435, 16956, 16958, 16959, 16957, 17051, 17052, 17053, 17047
7436, 16957, 16959, 2403, 2402, 17053, 17054, 2425, 17049
7437, 2166, 2167, 16960, 16958, 2189, 17055, 17056, 17050
7438, 16958, 16960, 16961, 16959, 17056, 17057, 17058, 17052
7439, 16959, 16961, 2404, 2403, 17058, 17059, 2426, 17054
7440, 2167, 2168, 16962, 16960, 2190, 17060, 17061, 17055
7441, 16960, 16962, 16963, 16961, 17061, 17062, 17063, 17057
7442, 16961, 16963, 2405, 2404, 17063, 17064, 2427, 17059
7443, 2168, 2169, 16964, 16962, 2191, 17065, 17066, 17060
7444, 16962, 16964, 16965, 16963, 17066, 17067, 17068, 17062
7445, 16963, 16965, 2406, 2405, 17068, 17069, 2428, 17064
7446, 2169, 2170, 16966, 16964, 2192, 17070, 17071, 17065
7447, 16964, 16966, 16967, 16965, 17071, 17072, 17073, 17067
7448, 16965, 16967, 2407, 2406, 17073, 17074, 2429, 17069
7449, 2170, 2171, 16968, 16966, 2193, 17075, 17076, 17070
7450, 16966, 16968, 16969, 16967, 17076, 17077, 17078, 17072
7451, 16967, 16969, 2408, 2407, 17078, 17079, 2430, 17074
7452, 2171, 72, 2432, 16968, 2194, 2434, 17080, 17075
7453, 16968, 2432, 2433, 16969, 17080, 2435, 17081, 17077
7454, 16969, 2433, 77, 2408, 17081, 2436, 2431, 17079
*ELEMENT, type=CPS8, ELSET=Surface243
7455, 55, 1712, 17082, 2246, 1714, 17126, 17127, 2268
7456, 1712, 1713, 17083, 17082, 1715, 17128, 17129, 17126
7457, 1713, 56, 2437, 17083, 1716, 2459, 17130, 17128
7458, 2246, 17082, 17084, 2247, 17127, 17131, 17132, 2269
7459, 17082, 17083, 17085, 17084, 17129, 17133, 17134, 17131
7460, 17083, 2437, 2438, 17085, 17130, 2460, 17135, 17133
7461, 2247, 17084, 17086, 2248, 17132, 17136, 17137, 2270
7462, 17084, 17085, 17087, 17086, 17134, 17138, 17139, 17136
7463, 17085, 2438, 2439, 17087, 17135, 2461, 17140, 17138
7464, 2248, 17086, 17088, 2249, 17137, 17141, 17142, 2271
7465, 17086, 17087, 17089, 17088, 17139, 17143, 17144, 17141
7466, 17087, 2439, 2440, 17089, 17140, 2462, 17145, 17143
7467, 2249, 17088, 17090, 2250, 17142, 17146, 17147, 2272
7468, 17088, 17089, 17091, 17090, 17144, 17148, 17149, 17146
7469, 17089, 2440, 2441, 17091, 17145, 2463, 17150, 17148
7470, 2250, 17090, 17092, 2251, 17147, 17151, 17152, 2273
7471, 17090, 17091, 17093, 17092, 17149, 17153, 17154, 17151
7472, 17091, 2441, 2442, 17093, 17150, 2464, 17155, 17153
7473, 2251, 17092, 17094, 2252, 17152, 17156, 17157, 2274
7474, 17092, 17093, 17095, 17094, 17154, 17158, 17159, 17156
7475, 17093, 2442, 2443, 17095, 17155, 2465, 17160, 17158
7476, 2252, 17094, 17096, 2253, 17157, 17161, 17162, 2275
7477, 17094, 17095, 17097, 17096, 17159, 17163, 17164, 17161
7478, 17095, 2443, 2444, 17097, 17160, 2466, 17165, 17163
7479, 2253, 17096, 17098, 2254, 17162, 17166, 17167, 2276
7480, 17096, 17097, 17099, 17098, 17164, 17168, 17169, 17166
7481, 17097, 2444, 2445, 17099, 17165, 2467, 17170, 17168
7482, 2254, 17098, 17100, 2255, 17167, 17171, 17172, 2277
7483, 17098, 17099, 17101, 17100, 17169, 17173, 17174, 17171
7484, 17099, 2445, 2446, 17101, 17170, 2468, 17175, 17173
7485, 2255, 17100, 17102, 2256, 17172, 17176, 17177, 2278
7486, 17100, 17101, 17103, 17102, 17174, 17178, 17179, 17176
7487, 17101, 2446, 2447, 17103, 17175, 2469, 17180, 17178
7488, 2256, 17102, 17104, 2257, 17177, 17181, 17182, 2279
7489, 17102, 17103, 17105, 17104, 17179, 17183, 17184, 17181
7490, 17103, 2447, 2448, 17105, 17180, 2470, 17185, 17183
7491, 2257, 17104, 17106, 2258, 17182, 17186, 17187, 2280
7492, 17104, 17105, 17107, 17106, 17184, 17188, 17189, 17186
7493, 17105, 2448, 2449, 17107, 17185, 2471, 17190, 17188
7494, 2258, 17106, 17108, 2259, 17187, 17191, 17192, 2281
7495, 17106, 17107, 17109, 17108, 17189, 17193, 17194, 17191
7496, 17107, 2449, 2450, 17109, 17190, 2472, 17195, 17193
7497, 2259, 17108, 17110, 2260, 17192, 17196, 17197, 2282
7498, 17108, 17109, 17111, 17110, 17194, 17198, 17199, 17196
7499, 17109, 2450, 2451, 17111, 17195, 2473, 17200, 17198
7500, 2260, 17110, 17112, 2261, 17197, 17201, 17202, 2283
7501, 17110, 17111, 17113, 17112, 17199, 17203, 17204, 17201
7502, 17111, 2451, 2452, 17113, 17200, 2474, 17205, 17203
7503, 2261, 17112, 17114, 2262, 17202, 17206, 17207, 2284
7504, 17112, 17113, 17115, 17114, 17204, 17208, 17209, 17206
7505, 17113, 2452, 2453, 17115, 17205, 2475, 17210, 17208
7506, 2262, 17114, 17116, 2263, 17207, 17211, 17212, 2285
7507, 17114, 17115, 17117, 17116, 17209, 17213, 17214, 17211
7508, 17115, 2453, 2454, 17117, 17210, 2476, 17215, 17213
7509, 2263, 17116, 17118, 2264, 17212, 17216, 17217, 2286
7510, 17116, 17117, 17119, 17118, 17214, 17218, 17219, 17216
7511, 17117, 2454, 2455, 17119, 17215, 2477, 17220, 17218
7512, 2264, 17118, 17120, 2265, 17217, 17221, 17222, 2287
7513, 17118, 17119, 17121, 17120, 17219, 17223, 17224, 17221
7514, 17119, 2455, 2456, 17121, 17220, 2478, 17225, 17223
7515, 2265, 17120, 17122, 2266, 17222, 17226, 17227, 2288
7516, 17120, 17121, 17123, 17122, 17224, 17228, 17229, 17226
7517, 17121, 2456, 2457, 17123, 17225, 2479, 17230, 17228
7518, 2266, 17122, 17124, 2267, 17227, 17231, 17232, 2289
7519, 17122, 17123, 17125, 17124, 17229, 17233, 17234, 17231
7520, 17123, 2457, 2458, 17125, 17230, 2480, 17235, 17233
7521, 2267, 17124, 2482, 75, 17232, 17236, 2484, 2290
7522, 17124, 17125, 2483, 2482, 17234, 17237, 2485, 17236
7523, 17125, 2458, 78, 2483, 17235, 2481, 2486, 17237
*ELEMENT, type=CPS8, ELSET=Surface244
7524, 54, 2387, 17238, 1741, 2409, 17414, 17415, 1750
7525, 1741, 17238, 17239, 1740, 17415, 17416, 17417, 1749
7526, 1740, 17239, 17240, 1739, 17417, 17418, 17419, 1748
7527, 1739, 17240, 17241, 1738, 17419, 17420, 17421, 1747
7528, 1738, 17241, 17242, 1737, 17421, 17422, 17423, 1746
7529, 1737, 17242, 17243, 1736, 17423, 17424, 17425, 1745
7530, 1736, 17243, 17244, 1735, 17425, 17426, 17427, 1744
7531, 1735, 17244, 17245, 1734, 17427, 17428, 17429, 1743
7532, 1734, 17245, 2437, 56, 17429, 17430, 2459, 1742
7533, 2387, 2388, 17246, 17238, 2410, 17431, 17432, 17414
7534, 17238, 17246, 17247, 17239, 17432, 17433, 17434, 17416
7535, 17239, 17247, 17248, 17240, 17434, 17435, 17436, 17418
7536, 17240, 17248, 17249, 17241, 17436, 17437, 17438, 17420
7537, 17241, 17249, 17250, 17242, 17438, 17439, 17440, 17422
7538, 17242, 17250, 17251, 17243, 17440, 17441, 17442, 17424
7539, 17243, 17251, 17252, 17244, 17442, 17443, 17444, 17426
7540, 17244, 17252, 17253, 17245, 17444, 17445, 17446, 17428
7541, 17245, 17253, 2438, 2437, 17446, 17447, 2460, 17430
7542, 2388, 2389, 17254, 17246, 2411, 17448, 17449, 17431
7543, 17246, 17254, 17255, 17247, 17449, 17450, 17451, 17433
7544, 17247, 17255, 17256, 17248, 17451, 17452, 17453, 17435
7545, 17248, 17256, 17257, 17249, 17453, 17454, 17455, 17437
7546, 17249, 17257, 17258, 17250, 17455, 17456, 17457, 17439
7547, 17250, 17258, 17259, 17251, 17457, 17458, 17459, 17441
7548, 17251, 17259, 17260, 17252, 17459, 17460, 17461, 17443
7549, 17252, 17260, 17261, 17253, 17461, 17462, 17463, 17445
7550, 17253, 17261, 2439, 2438, 17463, 17464, 2461, 17447
7551, 2389, 2390, 17262, 17254, 2412, 17465, 17466, 17448
7552, 17254, 17262, 17263, 17255, 17466, 17467, 17468, 17450
7553, 17255, 17263, 17264, 17256, 17468, 17469, 17470, 17452
7554, 17256, 17264, 17265, 17257, 17470, 17471, 17472, 17454
7555, 17257, 17265, 17266, 17258, 17472, 17473, 17474, 17456
7556, 17258, 17266, 17267, 17259, 17474, 17475, 17476, 17458
7557, 17259, 17267, 17268, 17260, 17476, 17477, 17478, 17460
7558, 17260, 17268, 17269, 17261, 17478, 17479, 17480, 17462
7559, 17261, 17269, 2440, 2439, 17480, 17481, 2462, 17464
7560, 2390, 2391, 17270, 17262, 2413, 17482, 17483, 17465
7561, 17262, 17270, 17271, 17263, 17483, 17484, 17485, 17467
7562, 17263, 17271, 17272, 17264, 17485, 17486, 17487, 17469
7563, 17264, 17272, 17273, 17265, 17487, 17488, 17489, 17471
7564, 17265, 17273, 17274, 17266, 17489, 17490, 17491, 17473
7565, 17266, 17274, 17275, 17267, 17491, 17492, 17493, 17475
7566, 17267, 17275, 17276, 17268, 17493, 17494, 17495, 17477
7567, 17268, 17276, 17277, 17269, 17495, 17496, 17497, 17479
7568, 17269, 17277, 2441, 2440, 17497, 17498, 2463, 17481
7569, 2391, 2392, 17278, 17270, 2414, 17499, 17500, 17482
7570, 17270, 17278, 17279, 17271, 17500, 17501, 17502, 17484
7571, 17271, 17279, 17280, 17272, 17502, 17503, 17504, 17486
7572, 17272, 17280, 17281, 17273, 17504, 17505, 17506, 17488
7573, 17273, 17281, 17282, 17274, 17506, 17507, 17508, 17490
7574, 17274, 17282, 17283, 17275, 17508, 17509, 17510, 17492
7575, 17275, 17283, 17284, 17276, 17510, 17511, 17512, 17494
7576, 17276, 17284, 17285, 17277, 17512, 17513, 17514, 17496
7577, 17277, 17285, 2442, 2441, 17514, 17515, 2464, 17498
7578, 2392, 2393, 17286, 17278, 2415, 17516, 17517, 17499
7579, 17278, 17286, 17287, 17279, 17517, 17518, 17519, 17501
7580, 17279, 17287, 17288, 17280, 17519, 17520, 17521, 17503
7581, 17280, 17288, 17289, 17281, 17521, 17522, 17523, 17505
7582, 17281, 17289, 17290, 17282, 17523, 17524, 17525, 17507
7583, 17282, 17290, 17291, 17283, 17525, 17526, 17527, 17509
7584, 17283, 17291, 17292, 17284, 17527, 17528, 17529, 17511
7585, 17284, 17292, 17293, 17285, 17529, 17530, 17531, 17513
7586, 17285, 17293, 2443, 2442, 17531, 17532, 2465, 17515
7587, 2393, 2394, 17294, 17286, 2416, 17533, 17534, 17516
7588, 17286, 17294, 17295, 17287, 17534, 17535, 17536, 17518
7589, 17287, 17295, 17296, 17288, 17536, 17537, 17538, 17520
7590, 17288, 17296, 17297, 17289, 17538, 17539, 17540, 17522
7591, 17289, 17297, 17298, 17290, 17540, 17541, 17542, 17524
7592, 17290, 17298, 17299, 17291, 17542, 17543, 17544, 17526
7593, 17291, 17299, 17300, 17292, 17544, 17545, 17546, 17528
7594, 17292, 17300, 17301, 17293, 17546, 17547, 17548, 17530
7595, 17293, 17301, 2444, 2443, 17548, 17549, 2466, 17532
7596, 2394, 2395, 17302, 17294, 2417, 17550, 17551, 17533
7597, 17294, 17302, 17303, 17295, 17551, 17552, 17553, 17535
7598, 17295, 17303, 17304, 17296, 17553, 17554, 17555, 17537
7599, 17296, 17304, 17305, 17297, 17555, 17556, 17557, 17539
7600, 17297, 17305, 17306, 17298, 17557, 17558, 17559, 17541
7601, 17298, 17306, 17307, 17299, 17559, 17560, 17561, 17543
7602, 17299, 17307, 17308, 17300, 17561, 17562, 17563, 17545
7603, 17300, 17308, 17309, 17301, 17563, 17564, 17565, 17547
7604, 17301, 17309, 2445, 2444, 17565, 17566, 2467, 17549
7605, 2395, 2396, 17310, 17302, 2418, 17567, 17568, 17550
7606, 17302, 17310, 17311, 17303, 17568, 17569, 17570, 17552
7607, 17303, 17311, 17312, 17304, 17570, 17571, 17572, 17554
7608, 17304, 17312, 17313, 17305, 17572, 17573, 17574, 17556
7609, 17305, 17313, 17314, 17306, 17574, 17575, 17576, 17558
7610, 17306, 17314, 17315, 17307, 17576, 17577, 17578, 17560
7611, 17307, 17315, 17316, 17308, 17578, 17579, 17580, 17562
7612, 17308, 17316, 17317, 17309, 17580, 17581, 17582, 17564
7613, 17309, 17317, 2446, 2445, 17582, 17583, 2468, 17566
7614, 2396, 2397, 17318, 17310, 2419, 17584, 17585, 17567
7615, 17310, 17318, 17319, 17311, 17585, 17586, 17587, 17569
7616, 17311, 17319, 17320, 17312, 17587, 17588, 17589, 17571
7617, 17312, 17320, 17321, 17313, 17589, 17590, 17591, 17573
7618, 17313, 17321, 17322, 17314, 17591, 17592, 17593, 17575
7619, 17314, 17322, 17323, 17315, 17593, 17594, 17595, 17577
7620, 17315, 17323, 17324, 17316, 17595, 17596, 17597, 17579
7621, 17316, 17324, 17325, 17317, 17597, 17598, 17599, 17581
7622, 17317, 17325, 2447, 2446, 17599, 17600, 2469, 17583
7623, 2397, 2398, 17326, 17318, 2420, 17601, 17602, 17584
7624, 17318, 17326, 17327, 17319, 17602, 17603, 17604, 17586
7625, 17319, 17327, 17328, 17320, 17604, 17605, 17606, 17588
7626, 17320, 17328, 17329, 17321, 17606, 17607, 17608, 17590
7627, 17321, 17329, 17330, 17322, 17608, 17609, 17610, 17592
7628, 17322, 17330, 17331, 17323, 17610, 17611, 17612, 17594
7629, 17323, 17331, 17332, 17324, 17612, 17613, 17614, 17596
7630, 17324, 17332, 17333, 17325, 17614, 17615, 17616, 17598
7631, 17325, 17333, 2448, 2447, 17616, 17617, 2470, 17600
7632, 2398, 2399, 17334, 17326, 2421, 17618, 17619, 17601
7633, 17326, 17334, 17335, 17327, 17619, 17620, 17621, 17603
7634, 17327, 17335, 17336, 17328, 17621, 17622, 17623, 17605
7635, 17328, 17336, 17337, 17329, 17623, 17624, 17625, 17607
7636, 17329, 17337, 17338, 17330, 17625, 17626, 17627, 17609
7637, 17330, 17338, 17339, 17331, 17627, 17628, 17629, 17611
7638, 17331, 17339, 17340, 17332, 17629, 17630, 17631, 17613
7639, 17332, 17340, 17341, 17333, 17631, 17632, 17633, 17615
7640, 17333, 17341, 2449, 2448, 17633, 17634, 2471, 17617
7641, 2399, 2400, 17342, 17334, 2422, 17635, 17636, 17618
7642, 17334, 17342, 17343, 17335, 17636, 17637, 17638, 17620
7643, 17335, 17343, 17344, 17336, 17638, 17639, 17640, 17622
7644, 17336, 17344, 17345, 17337, 17640, 17641, 17642, 17624
7645, 17337, 17345, 17346, 17338, 17642, 17643, 17644, 17626
7646, 17338, 17346, 17347, 17339, 17644, 17645, 17646, 17628
7647, 17339, 17347, 17348, 17340, 17646, 17647, 17648, 17630
7648, 17340, 17348, 17349, 17341, 17648, 17649, 17650, 17632
7649, 17341, 17349, 2450, 2449, 17650, 17651, 2472, 17634
7650, 2400, 2401, 17350, 17342, 2423, 17652, 17653, 17635
7651, 17342, 17350, 17351, 17343, 17653, 17654, 17655, 17637
7652, 17343, 17351, 17352, 17344, 17655, 17656, 17657, 17639
7653, 17344, 17352, 17353, 17345, 17657, 17658, 17659, 17641
7654, 17345, 17353, 17354, 17346, 17659, 17660, 17661, 17643
7655, 17346, 17354, 17355, 17347, 17661, 17662, 17663, 17645
7656, 17347, 17355, 17356, 17348, 17663, 17664, 17665, 17647
7657, 17348, 17356, 17357, 17349, 17665, 17666, 17667, 17649
7658, 17349, 17357, 2451, 2450, 17667, 17668, 2473, 17651
7659, 2401, 2402, 17358, 17350, 2424, 17669, 17670, 17652
7660, 17350, 17358, 17359, 17351, 17670, 17671, 17672, 17654
7661, 17351, 17359, 17360, 17352, 17672, 17673, 17674, 17656
7662, 17352, 17360, 17361, 17353, 17674, 17675, 17676, 17658
7663, 17353, 17361, 17362, 17354, 17676, 17677, 17678, 17660
7664, 17354, 17362, 17363, 17355, 17678, 17679, 17680, 17662
7665, 17355, 17363, 17364, 17356, 17680, 17681, 17682, 17664
7666, 17356, 17364, 17365, 17357, 17682, 17683, 17684, 17666
7667, 17357, 17365, 2452, 2451, 17684, 17685, 2474, 17668
7668, 2402, 2403, 17366, 17358, 2425, 17686, 17687, 17669
7669, 17358, 17366, 17367, 17359, 17687, 17688, 17689, 17671
7670, 17359, 17367, 17368, 17360, 17689, 17690, 17691, 17673
7671, 17360, 17368, 17369, 17361, 17691, 17692, 17693, 17675
7672, 17361, 17369, 17370, 17362, 17693, 17694, 17695, 17677
7673, 17362, 17370, 17371, 17363, 17695, 17696, 17697, 17679
7674, 17363, 17371, 17372, 17364, 17697, 17698, 17699, 17681
7675, 17364, 17372, 17373, 17365, 17699, 17700, 17701, 17683
7676, 17365, 17373, 2453, 2452, 17701, 17702, 2475, 17685
7677, 2403, 2404, 17374, 17366, 2426, 17703, 17704, 17686
7678, 17366, 17374, 17375, 17367, 17704, 17705, 17706, 17688
7679, 17367, 17375, 17376, 17368, 17706, 17707, 17708, 17690
7680, 17368, 17376, 17377, 17369, 17708, 17709, 17710, 17692
7681, 17369, 17377, 17378, 17370, 17710, 17711, 17712, 17694
7682, 17370, 17378, 17379, 17371, 17712, 17713, 17714, 17696
7683, 17371, 17379, 17380, 17372, 17714, 17715, 17716, 17698
7684, 17372, 17380, 17381, 17373, 17716, 17717, 17718, 17700
7685, 17373, 17381, 2454, 2453, 17718, 17719, 2476, 17702
7686, 2404, 2405, 17382, 17374, 2427, 17720, 17721, 17703
7687, 17374, 17382, 17383, 17375, 17721, 17722, 17723, 17705
7688, 17375, 17383, 17384, 17376, 17723, 17724, 17725, 17707
7689, 17376, 17384, 17385, 17377, 17725, 17726, 17727, 17709
7690, 17377, 17385, 17386, 17378, 17727, 17728, 17729, 17711
7691, 17378, 17386, 17387, 17379, 17729, 17730, 17731, 17713
7692, 17379, 17387, 17388, 17380, 17731, 17732, 17733, 17715
7693, 17380, 17388, 17389, 17381, 17733, 17734, 17735, 17717
7694, 17381, 17389, 2455, 2454, 17735, 17736, 2477, 17719
7695, 2405, 2406, 17390, 17382, 2428, 17737, 17738, 17720
7696, 17382, 17390, 17391, 17383, 17738, 17739, 17740, 17722
7697, 17383, 17391, 17392, 17384, 17740, 17741, 17742, 17724
7698, 17384, 17392, 17393, 17385, 17742, 17743, 17744, 17726
7699, 17385, 17393, 17394, 17386, 17744, 17745, 17746, 17728
7700, 17386, 17394, 17395, 17387, 17746, 17747, 17748, 17730
7701, 17387, 17395, 17396, 17388, 17748, 17749, 17750, 17732
7702, 17388, 17396, 17397, 17389, 17750, 17751, 17752, 17734
7703, 17389, 17397, 2456, 2455, 17752, 17753, 2478, 17736
7704, 2406, 2407, 17398, 17390, 2429, 17754, 17755, 17737
7705, 17390, 17398, 17399, 17391, 17755, 17756, 17757, 17739
7706, 17391, 17399, 17400, 17392, 17757, 17758, 17759, 17741
7707, 17392, 17400, 17401, 17393, 17759, 17760, 17761, 17743
7708, 17393, 17401, 17402, 17394, 17761, 17762, 17763, 17745
7709, 17394, 17402, 17403, 17395, 17763, 17764, 17765, 17747
7710, 17395, 17403, 17404, 17396, 17765, 17766, 17767, 17749
7711, 17396, 17404, 17405, 17397, 17767, 17768, 17769, 17751
7712, 17397, 17405, 2457, 2456, 17769, 17770, 2479, 17753
7713, 2407, 2408, 17406, 17398, 2430, 17771, 17772, 17754
7714, 17398, 17406, 17407, 17399, 17772, 17773, 17774, 17756
7715, 17399, 17407, 17408, 17400, 17774, 17775, 17776, 17758
7716, 17400, 17408, 17409, 17401, 17776, 17777, 17778, 17760
7717, 17401, 17409, 17410, 17402, 17778, 17779, 17780, 17762
7718, 17402, 17410, 17411, 17403, 17780, 17781, 17782, 17764
7719, 17403, 17411, 17412, 17404, 17782, 17783, 17784, 17766
7720, 17404, 17412, 17413, 17405, 17784, 17785, 17786, 17768
7721, 17405, 17413, 2458, 2457, 17786, 17787, 2480, 17770
7722, 2408, 77, 2494, 17406, 2431, 2503, 17788, 17771
7723, 17406, 2494, 2493, 17407, 17788, 2502, 17789, 17773
7724, 17407, 2493, 2492, 17408, 17789, 2501, 17790, 17775
7725, 17408, 2492, 2491, 17409, 17790, 2500, 17791, 17777
7726, 17409, 2491, 2490, 17410, 17791, 2499, 17792, 17779
7727, 17410, 2490, 2489, 17411, 17792, 2498, 17793, 17781
7728, 17411, 2489, 2488, 17412, 17793, 2497, 17794, 17783
7729, 17412, 2488, 2487, 17413, 17794, 2496, 17795, 17785
7730, 17413, 2487, 78, 2458, 17795, 2495, 2481, 17787
*ELEMENT, type=CPS8, ELSET=Surface245
7731, 72, 2360, 17796, 2432, 2369, 17812, 17813, 2434
7732, 2360, 2359, 17797, 17796, 2368, 17814, 17815, 17812
7733, 2359, 2358, 17798, 17797, 2367, 17816, 17817, 17814
7734, 2358, 2357, 17799, 17798, 2366, 17818, 17819, 17816
7735, 2357, 2356, 17800, 17799, 2365, 17820, 17821, 17818
7736, 2356, 2355, 17801, 17800, 2364, 17822, 17823, 17820
7737, 2355, 2354, 17802, 17801, 2363, 17824, 17825, 17822
7738, 2354, 2353, 17803, 17802, 2362, 17826, 17827, 17824
7739, 2353, 75, 2482, 17803, 2361, 2484, 17828, 17826
7740, 2432, 17796, 17804, 2433, 17813, 17829, 17830, 2435
7741, 17796, 17797, 17805, 17804, 17815, 17831, 17832, 17829
7742, 17797, 17798, 17806, 17805, 17817, 17833, 17834, 17831
7743, 17798, 17799, 17807, 17806, 17819, 17835, 17836, 17833
7744, 17799, 17800, 17808, 17807, 17821, 17837, 17838, 17835
7745, 17800, 17801, 17809, 17808, 17823, 17839, 17840, 17837
7746, 17801, 17802, 17810, 17809, 17825, 17841, 17842, 17839
7747, 17802, 17803, 17811, 17810, 17827, 17843, 17844, 17841
7748, 17803, 2482, 2483, 17811, 17828, 2485, 17845, 17843
7749, 2433, 17804, 2494, 77, 17830, 17846, 2503, 2436
7750, 17804, 17805, 2493, 2494, 17832, 17847, 2502, 17846
7751, 17805, 17806, 2492, 2493, 17834, 17848, 2501, 17847
7752, 17806, 17807, 2491, 2492, 17836, 17849, 2500, 17848
7753, 17807, 17808, 2490, 2491, 17838, 17850, 2499, 17849
7754, 17808, 17809, 2489, 2490, 17840, 17851, 2498, 17850
7755, 17809, 17810, 2488, 2489, 17842, 17852, 2497, 17851
7756, 17810, 17811, 2487, 2488, 17844, 17853, 2496, 17852
7757, 17811, 2483, 78, 2487, 17845, 2486, 2495, 17853
*ELEMENT, type=CPS8, ELSET=Surface246
7758, 54, 2387, 17854, 1758, 2409, 17920, 17921, 1761
7759, 2387, 2388, 17855, 17854, 2410, 17922, 17923, 17920
7760, 2388, 2389, 17856, 17855, 2411, 17924, 17925, 17922
7761, 2389, 2390, 17857, 17856, 2412, 17926, 17927, 17924
7762, 2390, 2391, 17858, 17857, 2413, 17928, 17929, 17926
7763, 2391, 2392, 17859, 17858, 2414, 17930, 17931, 17928
7764, 2392, 2393, 17860, 17859, 2415, 17932, 17933, 17930
7765, 2393, 2394, 17861, 17860, 2416, 17934, 17935, 17932
7766, 2394, 2395, 17862, 17861, 2417, 17936, 17937, 17934
7767, 2395, 2396, 17863, 17862, 2418, 17938, 17939, 17936
7768, 2396, 2397, 17864, 17863, 2419, 17940, 17941, 17938
7769, 2397, 2398, 17865, 17864, 2420, 17942, 17943, 17940
7770, 2398, 2399, 17866, 17865, 2421, 17944, 17945, 17942
7771, 2399, 2400, 17867, 17866, 2422, 17946, 17947, 17944
7772, 2400, 2401, 17868, 17867, 2423, 17948, 17949, 17946
7773, 2401, 2402, 17869, 17868, 2424, 17950, 17951, 17948
7774, 2402, 2403, 17870, 17869, 2425, 17952, 17953, 17950
7775, 2403, 2404, 17871, 17870, 2426, 17954, 17955, 17952
7776, 2404, 2405, 17872, 17871, 2427, 17956, 17957, 17954
7777, 2405, 2406, 17873, 17872, 2428, 17958, 17959, 17956
7778, 2406, 2407, 17874, 17873, 2429, 17960, 17961, 17958
7779, 2407, 2408, 17875, 17874, 2430, 17962, 17963, 17960
7780, 2408, 77, 2504, 17875, 2431, 2507, 17964, 17962
7781, 1758, 17854, 17876, 1759, 17921, 17965, 17966, 1762
7782, 17854, 17855, 17877, 17876, 17923, 17967, 17968, 17965
7783, 17855, 17856, 17878, 17877, 17925, 17969, 17970, 17967
7784, 17856, 17857, 17879, 17878, 17927, 17971, 17972, 17969
7785, 17857, 17858, 17880, 17879, 17929, 17973, 17974, 17971
7786, 17858, 17859, 17881, 17880, 17931, 17975, 17976, 17973
7787, 17859, 17860, 17882, 17881, 17933, 17977, 17978, 17975
7788, 17860, 17861, 17883, 17882, 17935, 17979, 17980, 17977
7789, 17861, 17862, 17884, 17883, 17937, 17981, 17982, 17979
7790, 17862, 17863, 17885, 17884, 17939, 17983, 17984, 17981
7791, 17863, 17864, 17886, 17885, 17941, 17985, 17986, 17983
7792, 17864, 17865, 17887, 17886, 17943, 17987, 17988, 17985
7793, 17865, 17866, 17888, 17887, 17945, 17989, 17990, 17987
7794, 17866, 17867, 17889, 17888, 17947, 17991, 17992, 17989
7795, 17867, 17868, 17890, 17889, 17949, 17993, 17994, 17991
7796, 17868, 17869, 17891, 17890, 17951, 17995, 17996, 17993
7797, 17869, 17870, 17892, 17891, 17953, 17997, 17998, 17995
7798, 17870, 17871, 17893, 17892, 17955, 17999, 18000, 17997
7799, 17871, 17872, 17894, 17893, 17957, 18001, 18002, 17999
7800, 17872, 17873, 17895, 17894, 17959, 18003, 18004, 18001
7801, 17873, 17874, 17896, 17895, 17961, 18005, 18006, 18003
7802, 17874, 17875, 17897, 17896, 17963, 18007, 18008, 18005
7803, 17875, 2504, 2505, 17897, 17964, 2508, 18009, 18007
7804, 1759, 17876, 17898, 1760, 17966, 18010, 18011, 1763
7805, 17876, 17877, 17899, 17898, 17968, 18012, 18013, 18010
7806, 17877, 17878, 17900, 17899, 17970, 18014, 18015, 18012
7807, 17878, 17879, 17901, 17900, 17972, 18016, 18017, 18014
7808, 17879, 17880, 17902, 17901, 17974, 18018, 18019, 18016
7809, 17880, 17881, 17903, 17902, 17976, 18020, 18021, 18018
7810, 17881, 17882, 17904, 17903, 17978, 18022, 18023, 18020
7811, 17882, 17883, 17905, 17904, 17980, 18024, 18025, 18022
7812, 17883, 17884, 17906, 17905, 17982, 18026, 18027, 18024
7813, 17884, 17885, 17907, 17906, 17984, 18028, 18029, 18026
7814, 17885, 17886, 17908, 17907, 17986, 18030, 18031, 18028
7815, 17886, 17887, 17909, 17908, 17988, 18032, 18033, 18030
7816, 17887, 17888, 17910, 17909, 17990, 18034, 18035, 18032
7817, 17888, 17889, 17911, 17910, 17992, 18036, 18037, 18034
7818, 17889, 17890, 17912, 17911, 17994, 18038, 18039, 18036
7819, 17890, 17891, 17913, 17912, 17996, 18040, 18041, 18038
7820, 17891, 17892, 17914, 17913, 17998, 18042, 18043, 18040
7821, 17892, 17893, 17915, 17914, 18000, 18044, 18045, 18042
7822, 17893, 17894, 17916, 17915, 18002, 18046, 18047, 18044
7823, 17894, 17895, 17917, 17916, 18004, 18048, 18049, 18046
7824, 17895, 17896, 17918, 17917, 18006, 18050, 18051, 18048
7825, 17896, 17897, 17919, 17918, 18008, 18052, 18053, 18050
7826, 17897, 2505, 2506, 17919, 18009, 2509, 18054, 18052
7827, 1760, 17898, 2511, 58, 18011, 18055, 2533, 1764
7828, 17898, 17899, 2512, 2511, 18013, 18056, 2534, 18055
7829, 17899, 17900, 2513, 2512, 18015, 18057, 2535, 18056
7830, 17900, 17901, 2514, 2513, 18017, 18058, 2536, 18057
7831, 17901, 17902, 2515, 2514, 18019, 18059, 2537, 18058
7832, 17902, 17903, 2516, 2515, 18021, 18060, 2538, 18059
7833, 17903, 17904, 2517, 2516, 18023, 18061, 2539, 18060
7834, 17904, 17905, 2518, 2517, 18025, 18062, 2540, 18061
7835, 17905, 17906, 2519, 2518, 18027, 18063, 2541, 18062
7836, 17906, 17907, 2520, 2519, 18029, 18064, 2542, 18063
7837, 17907, 17908, 2521, 2520, 18031, 18065, 2543, 18064
7838, 17908, 17909, 2522, 2521, 18033, 18066, 2544, 18065
7839, 17909, 17910, 2523, 2522, 18035, 18067, 2545, 18066
7840, 17910, 17911, 2524, 2523, 18037, 18068, 2546, 18067
7841, 17911, 17912, 2525, 2524, 18039, 18069, 2547, 18068
7842, 17912, 17913, 2526, 2525, 18041, 18070, 2548, 18069
7843, 17913, 17914, 2527, 2526, 18043, 18071, 2549, 18070
7844, 17914, 17915, 2528, 2527, 18045, 18072, 2550, 18071
7845, 17915, 17916, 2529, 2528, 18047, 18073, 2551, 18072
7846, 17916, 17917, 2530, 2529, 18049, 18074, 2552, 18073
7847, 17917, 17918, 2531, 2530, 18051, 18075, 2553, 18074
7848, 17918, 17919, 2532, 2531, 18053, 18076, 2554, 18075
7849, 17919, 2506, 79, 2532, 18054, 2510, 2555, 18076
*ELEMENT, type=CPS8, ELSET=Surface247
7850, 56, 1779, 18077, 2437, 1782, 18143, 18144, 2459
7851, 2437, 18077, 18078, 2438, 18144, 18145, 18146, 2460
7852, 2438, 18078, 18079, 2439, 18146, 18147, 18148, 2461
7853, 2439, 18079, 18080, 2440, 18148, 18149, 18150, 2462
7854, 2440, 18080, 18081, 2441, 18150, 18151, 18152, 2463
7855, 2441, 18081, 18082, 2442, 18152, 18153, 18154, 2464
7856, 2442, 18082, 18083, 2443, 18154, 18155, 18156, 2465
7857, 2443, 18083, 18084, 2444, 18156, 18157, 18158, 2466
7858, 2444, 18084, 18085, 2445, 18158, 18159, 18160, 2467
7859, 2445, 18085, 18086, 2446, 18160, 18161, 18162, 2468
7860, 2446, 18086, 18087, 2447, 18162, 18163, 18164, 2469
7861, 2447, 18087, 18088, 2448, 18164, 18165, 18166, 2470
7862, 2448, 18088, 18089, 2449, 18166, 18167, 18168, 2471
7863, 2449, 18089, 18090, 2450, 18168, 18169, 18170, 2472
7864, 2450, 18090, 18091, 2451, 18170, 18171, 18172, 2473
7865, 2451, 18091, 18092, 2452, 18172, 18173, 18174, 2474
7866, 2452, 18092, 18093, 2453, 18174, 18175, 18176, 2475
7867, 2453, 18093, 18094, 2454, 18176, 18177, 18178, 2476
7868, 2454, 18094, 18095, 2455, 18178, 18179, 18180, 2477
7869, 2455, 18095, 18096, 2456, 18180, 18181, 18182, 2478
7870, 2456, 18096, 18097, 2457, 18182, 18183, 18184, 2479
7871, 2457, 18097, 18098, 2458, 18184, 18185, 18186, 2480
7872, 2458, 18098, 2556, 78, 18186, 18187, 2559, 2481
7873, 1779, 1780, 18099, 18077, 1783, 18188, 18189, 18143
7874, 18077, 18099, 18100, 18078, 18189, 18190, 18191, 18145
7875, 18078, 18100, 18101, 18079, 18191, 18192, 18193, 18147
7876, 18079, 18101, 18102, 18080, 18193, 18194, 18195, 18149
7877, 18080, 18102, 18103, 18081, 18195, 18196, 18197, 18151
7878, 18081, 18103, 18104, 18082, 18197, 18198, 18199, 18153
7879, 18082, 18104, 18105, 18083, 18199, 18200, 18201, 18155
7880, 18083, 18105, 18106, 18084, 18201, 18202, 18203, 18157
7881, 18084, 18106, 18107, 18085, 18203, 18204, 18205, 18159
7882, 18085, 18107, 18108, 18086, 18205, 18206, 18207, 18161
7883, 18086, 18108, 18109, 18087, 18207, 18208, 18209, 18163
7884, 18087, 18109, 18110, 18088, 18209, 18210, 18211, 18165
7885, 18088, 18110, 18111, 18089, 18211, 18212, 18213, 18167
7886, 18089, 18111, 18112, 18090, 18213, 18214, 18215, 18169
7887, 18090, 18112, 18113, 18091, 18215, 18216, 18217, 18171
7888, 18091, 18113, 18114, 18092, 18217, 18218, 18219, 18173
7889, 18092, 18114, 18115, 18093, 18219, 18220, 18221, 18175
7890, 18093, 18115, 18116, 18094, 18221, 18222, 18223, 18177
7891, 18094, 18116, 18117, 18095, 18223, 18224, 18225, 18179
7892, 18095, 18117, 18118, 18096, 18225, 18226, 18227, 18181
7893, 18096, 18118, 18119, 18097, 18227, 18228, 18229, 18183
7894, 18097, 18119, 18120, 18098, 18229, 18230, 18231, 18185
7895, 18098, 18120, 2557, 2556, 18231, 18232, 2560, 18187
7896, 1780, 1781, 18121, 18099, 1784, 18233, 18234, 18188
7897, 18099, 18121, 18122, 18100, 18234, 18235, 18236, 18190
7898, 18100, 18122, 18123, 18101, 18236, 18237, 18238, 18192
7899, 18101, 18123, 18124, 18102, 18238, 18239, 18240, 18194
7900, 18102, 18124, 18125, 18103, 18240, 18241, 18242, 18196
7901, 18103, 18125, 18126, 18104, 18242, 18243, 18244, 18198
7902, 18104, 18126, 18127, 18105, 18244, 18245, 18246, 18200
7903, 18105, 18127, 18128, 18106, 18246, 18247, 18248, 18202
7904, 18106, 18128, 18129, 18107, 18248, 18249, 18250, 18204
7905, 18107, 18129, 18130, 18108, 18250, 18251, 18252, 18206
7906, 18108, 18130, 18131, 18109, 18252, 18253, 18254, 18208
7907, 18109, 18131, 18132, 18110, 18254, 18255, 18256, 18210
7908, 18110, 18132, 18133, 18111, 18256, 18257, 18258, 18212
7909, 18111, 18133, 18134, 18112, 18258, 18259, 18260, 18214
7910, 18112, 18134, 18135, 18113, 18260, 18261, 18262, 18216
7911, 18113, 18135, 18136, 18114, 18262, 18263, 18264, 18218
7912, 18114, 18136, 18137, 18115, 18264, 18265, 18266, 18220
7913, 18115, 18137, 18138, 18116, 18266, 18267, 18268, 18222
7914, 18116, 18138, 18139, 18117, 18268, 18269, 18270, 18224
7915, 18117, 18139, 18140, 18118, 18270, 18271, 18272, 18226
7916, 18118, 18140, 18141, 18119, 18272, 18273, 18274, 18228
7917, 18119, 18141, 18142, 18120, 18274, 18275, 18276, 18230
7918, 18120, 18142, 2558, 2557, 18276, 18277, 2561, 18232
7919, 1781, 60, 2563, 18121, 1785, 2585, 18278, 18233
7920, 18121, 2563, 2564, 18122, 18278, 2586, 18279, 18235
7921, 18122, 2564, 2565, 18123, 18279, 2587, 18280, 18237
7922, 18123, 2565, 2566, 18124, 18280, 2588, 18281, 18239
7923, 18124, 2566, 2567, 18125, 18281, 2589, 18282, 18241
7924, 18125, 2567, 2568, 18126, 18282, 2590, 18283, 18243
7925, 18126, 2568, 2569, 18127, 18283, 2591, 18284, 18245
7926, 18127, 2569, 2570, 18128, 18284, 2592, 18285, 18247
7927, 18128, 2570, 2571, 18129, 18285, 2593, 18286, 18249
7928, 18129, 2571, 2572, 18130, 18286, 2594, 18287, 18251
7929, 18130, 2572, 2573, 18131, 18287, 2595, 18288, 18253
7930, 18131, 2573, 2574, 18132, 18288, 2596, 18289, 18255
7931, 18132, 2574, 2575, 18133, 18289, 2597, 18290, 18257
7932, 18133, 2575, 2576, 18134, 18290, 2598, 18291, 18259
7933, 18134, 2576, 2577, 18135, 18291, 2599, 18292, 18261
7934, 18135, 2577, 2578, 18136, 18292, 2600, 18293, 18263
7935, 18136, 2578, 2579, 18137, 18293, 2601, 18294, 18265
7936, 18137, 2579, 2580, 18138, 18294, 2602, 18295, 18267
7937, 18138, 2580, 2581, 18139, 18295, 2603, 18296, 18269
7938, 18139, 2581, 2582, 18140, 18296, 2604, 18297, 18271
7939, 18140, 2582, 2583, 18141, 18297, 2605, 18298, 18273
7940, 18141, 2583, 2584, 18142, 18298, 2606, 18299, 18275
7941, 18142, 2584, 80, 2558, 18299, 2607, 2562, 18277
*ELEMENT, type=CPS8, ELSET=Surface248
7942, 77, 2494, 18300, 2504, 2503, 18324, 18325, 2507
7943, 2494, 2493, 18301, 18300, 2502, 18326, 18327, 18324
7944, 2493, 2492, 18302, 18301, 2501, 18328, 18329, 18326
7945, 2492, 2491, 18303, 18302, 2500, 18330, 18331, 18328
7946, 2491, 2490, 18304, 18303, 2499, 18332, 18333, 18330
7947, 2490, 2489, 18305, 18304, 2498, 18334, 18335, 18332
7948, 2489, 2488, 18306, 18305, 2497, 18336, 18337, 18334
7949, 2488, 2487, 18307, 18306, 2496, 18338, 18339, 18336
7950, 2487, 78, 2556, 18307, 2495, 2559, 18340, 18338
7951, 2504, 18300, 18308, 2505, 18325, 18341, 18342, 2508
7952, 18300, 18301, 18309, 18308, 18327, 18343, 18344, 18341
7953, 18301, 18302, 18310, 18309, 18329, 18345, 18346, 18343
7954, 18302, 18303, 18311, 18310, 18331, 18347, 18348, 18345
7955, 18303, 18304, 18312, 18311, 18333, 18349, 18350, 18347
7956, 18304, 18305, 18313, 18312, 18335, 18351, 18352, 18349
7957, 18305, 18306, 18314, 18313, 18337, 18353, 18354, 18351
7958, 18306, 18307, 18315, 18314, 18339, 18355, 18356, 18353
7959, 18307, 2556, 2557, 18315, 18340, 2560, 18357, 18355
7960, 2505, 18308, 18316, 2506, 18342, 18358, 18359, 2509
7961, 18308, 18309, 18317, 18316, 18344, 18360, 18361, 18358
7962, 18309, 18310, 18318, 18317, 18346, 18362, 18363, 18360
7963, 18310, 18311, 18319, 18318, 18348, 18364, 18365, 18362
7964, 18311, 18312, 18320, 18319, 18350, 18366, 18367, 18364
7965, 18312, 18313, 18321, 18320, 18352, 18368, 18369, 18366
7966, 18313, 18314, 18322, 18321, 18354, 18370, 18371, 18368
7967, 18314, 18315, 18323, 18322, 18356, 18372, 18373, 18370
7968, 18315, 2557, 2558, 18323, 18357, 2561, 18374, 18372
7969, 2506, 18316, 2615, 79, 18359, 18375, 2624, 2510
7970, 18316, 18317, 2614, 2615, 18361, 18376, 2623, 18375
7971, 18317, 18318, 2613, 2614, 18363, 18377, 2622, 18376
7972, 18318, 18319, 2612, 2613, 18365, 18378, 2621, 18377
7973, 18319, 18320, 2611, 2612, 18367, 18379, 2620, 18378
7974, 18320, 18321, 2610, 2611, 18369, 18380, 2619, 18379
7975, 18321, 18322, 2609, 2610, 18371, 18381, 2618, 18380
7976, 18322, 18323, 2608, 2609, 18373, 18382, 2617, 18381
7977, 18323, 2558, 80, 2608, 18374, 2562, 2616, 18382
*ELEMENT, type=CPS8, ELSET=Surface249
7978, 58, 2511, 18383, 1817, 2533, 18559, 18560, 1826
7979, 1817, 18383, 18384, 1816, 18560, 18561, 18562, 1825
7980, 1816, 18384, 18385, 1815, 18562, 18563, 18564, 1824
7981, 1815, 18385, 18386, 1814, 18564, 18565, 18566, 1823
7982, 1814, 18386, 18387, 1813, 18566, 18567, 18568, 1822
7983, 1813, 18387, 18388, 1812, 18568, 18569, 18570, 1821
7984, 1812, 18388, 18389, 1811, 18570, 18571, 18572, 1820
7985, 1811, 18389, 18390, 1810, 18572, 18573, 18574, 1819
7986, 1810, 18390, 2563, 60, 18574, 18575, 2585, 1818
7987, 2511, 2512, 18391, 18383, 2534, 18576, 18577, 18559
7988, 18383, 18391, 18392, 18384, 18577, 18578, 18579, 18561
7989, 18384, 18392, 18393, 18385, 18579, 18580, 18581, 18563
7990, 18385, 18393, 18394, 18386, 18581, 18582, 18583, 18565
7991, 18386, 18394, 18395, 18387, 18583, 18584, 18585, 18567
7992, 18387, 18395, 18396, 18388, 18585, 18586, 18587, 18569
7993, 18388, 18396, 18397, 18389, 18587, 18588, 18589, 18571
7994, 18389, 18397, 18398, 18390, 18589, 18590, 18591, 18573
7995, 18390, 18398, 2564, 2563, 18591, 18592, 2586, 18575
7996, 2512, 2513, 18399, 18391, 2535, 18593, 18594, 18576
7997, 18391, 18399, 18400, 18392, 18594, 18595, 18596, 18578
7998, 18392, 18400, 18401, 18393, 18596, 18597, 18598, 18580
7999, 18393, 18401, 18402, 18394, 18598, 18599, 18600, 18582
8000, 18394, 18402, 18403, 18395, 18600, 18601, 18602, 18584
8001, 18395, 18403, 18404, 18396, 18602, 18603, 18604, 18586
8002, 18396, 18404, 18405, 18397, 18604, 18605, 18606, 18588
8003, 18397, 18405, 18406, 18398, 18606, 18607, 18608, 18590
8004, 18398, 18406, 2565, 2564, 18608, 18609, 2587, 18592
8005, 2513, 2514, 18407, 18399, 2536, 18610, 18611, 18593
8006, 18399, 18407, 18408, 18400, 18611, 18612, 18613, 18595
8007, 18400, 18408, 18409, 18401, 18613, 18614, 18615, 18597
8008, 18401, 18409, 18410, 18402, 18615, 18616, 18617, 18599
8009, 18402, 18410, 18411, 18403, 18617, 18618, 18619, 18601
8010, 18403, 18411, 18412, 18404, 18619, 18620, 18621, 18603
8011, 18404, 18412, 18413, 18405, 18621, 18622, 18623, 18605
8012, 18405, 18413, 18414, 18406, 18623, 18624, 18625, 18607
8013, 18406, 18414, 2566, 2565, 18625, 18626, 2588, 18609
8014, 2514, 2515, 18415, 18407, 2537, 18627, 18628, 18610
8015, 18407, 18415, 18416, 18408, 18628, 18629, 18630, 18612
8016, 18408, 18416, 18417, 18409, 18630, 18631, 18632, 18614
8017, 18409, 18417, 18418, 18410, 18632, 18633, 18634, 18616
8018, 18410, 18418, 18419, 18411, 18634, 18635, 18636, 18618
8019, 18411, 18419, 18420, 18412, 18636, 18637, 18638, 18620
8020, 18412, 18420, 18421, 18413, 18638, 18639, 18640, 18622
8021, 18413, 18421, 18422, 18414, 18640, 18641, 18642, 18624
8022, 18414, 18422, 2567, 2566, 18642, 18643, 2589, 18626
8023, 2515, 2516, 18423, 18415, 2538, 18644, 18645, 18627
8024, 18415, 18423, 18424, 18416, 18645, 18646, 18647, 18629
8025, 18416, 18424, 18425, 18417, 18647, 18648, 18649, 18631
8026, 18417, 18425, 18426, 18418, 18649, 18650, 18651, 18633
8027, 18418, 18426, 18427, 18419, 18651, 18652, 18653, 18635
8028, 18419, 18427, 18428, 18420, 18653, 18654, 18655, 18637
8029, 18420, 18428, 18429, 18421, 18655, 18656, 18657, 18639
8030, 18421, 18429, 18430, 18422, 18657, 18658, 18659, 18641
8031, 18422, 18430, 2568, 2567, 18659, 18660, 2590, 18643
8032, 2516, 2517, 18431, 18423, 2539, 18661, 18662, 18644
8033, 18423, 18431, 18432, 18424, 18662, 18663, 18664, 18646
8034, 18424, 18432, 18433, 18425, 18664, 18665, 18666, 18648
8035, 18425, 18433, 18434, 18426, 18666, 18667, 18668, 18650
8036, 18426, 18434, 18435, 18427, 18668, 18669, 18670, 18652
8037, 18427, 18435, 18436, 18428, 18670, 18671, 18672, 18654
8038, 18428, 18436, 18437, 18429, 18672, 18673, 18674, 18656
8039, 18429, 18437, 18438, 18430, 18674, 18675, 18676, 18658
8040, 18430, 18438, 2569, 2568, 18676, 18677, 2591, 18660
8041, 2517, 2518, 18439, 18431, 2540, 18678, 18679, 18661
8042, 18431, 18439, 18440, 18432, 18679, 18680, 18681, 18663
8043, 18432, 18440, 18441, 18433, 18681, 18682, 18683, 18665
8044, 18433, 18441, 18442, 18434, 18683, 18684, 18685, 18667
8045, 18434, 18442, 18443, 18435, 18685, 18686, 18687, 18669
8046, 18435, 18443, 18444, 18436, 18687, 18688, 18689, 18671
8047, 18436, 18444, 18445, 18437, 18689, 18690, 18691, 18673
8048, 18437, 18445, 18446, 18438, 18691, 18692, 18693, 18675
8049, 18438, 18446, 2570, 2569, 18693, 18694, 2592, 18677
8050, 2518, 2519, 18447, 18439, 2541, 18695, 18696, 18678
8051, 18439, 18447, 18448, 18440, 18696, 18697, 18698, 18680
8052, 18440, 18448, 18449, 18441, 18698, 18699, 18700, 18682
8053, 18441, 18449, 18450, 18442, 18700, 18701, 18702, 18684
8054, 18442, 18450, 18451, 18443, 18702, 18703, 18704, 18686
8055, 18443, 18451, 18452, 18444, 18704, 18705, 18706, 18688
8056, 18444, 18452, 18453, 18445, 18706, 18707, 18708, 18690
8057, 18445, 18453, 18454, 18446, 18708, 18709, 18710, 18692
8058, 18446, 18454, 2571, 2570, 18710, 18711, 2593, 18694
8059, 2519, 2520, 18455, 18447, 2542, 18712, 18713, 18695
8060, 18447, 18455, 18456, 18448, 18713, 18714, 18715, 18697
8061, 18448, 18456, 18457, 18449, 18715, 18716, 18717, 18699
8062, 18449, 18457, 18458, 18450, 18717, 18718, 18719, 18701
8063, 18450, 18458, 18459, 18451, 18719, 18720, 18721, 18703
8064, 18451, 18459, 18460, 18452, 18721, 18722, 18723, 18705
8065, 18452, 18460, 18461, 18453, 18723, 18724, 18725, 18707
8066, 18453, 18461, 18462, 18454, 18725, 18726, 18727, 18709
8067, 18454, 18462, 2572, 2571, 18727, 18728, 2594, 18711
8068, 2520, 2521, 18463, 18455, 2543, 18729, 18730, 18712
8069, 18455, 18463, 18464, 18456, 18730, 18731, 18732, 18714
8070, 18456, 18464, 18465, 18457, 18732, 18733, 18734, 18716
8071, 18457, 18465, 18466, 18458, 18734, 18735, 18736, 18718
8072, 18458, 18466, 18467, 18459, 18736, 18737, 18738, 18720
8073, 18459, 18467, 18468, 18460, 18738, 18739, 18740, 18722
8074, 18460, 18468, 18469, 18461, 18740, 18741, 18742, 18724
8075, 18461, 18469, 18470, 18462, 18742, 18743, 18744, 18726
8076, 18462, 18470, 2573, 2572, 18744, 18745, 2595, 18728
8077, 2521, 2522, 18471, 18463, 2544, 18746, 18747, 18729
8078, 18463, 18471, 18472, 18464, 18747, 18748, 18749, 18731
8079, 18464, 18472, 18473, 18465, 18749, 18750, 18751, 18733
8080, 18465, 18473, 18474, 18466, 18751, 18752, 18753, 18735
8081, 18466, 18474, 18475, 18467, 18753, 18754, 18755, 18737
8082, 18467, 18475, 18476, 18468, 18755, 18756, 18757, 18739
8083, 18468, 18476, 18477, 18469, 18757, 18758, 18759, 18741
8084, 18469, 18477, 18478, 18470, 18759, 18760, 18761, 18743
8085, 18470, 18478, 2574, 2573, 18761, 18762, 2596, 18745
8086, 2522, 2523, 18479, 18471, 2545, 18763, 18764, 18746
8087, 18471, 18479, 18480, 18472, 18764, 18765, 18766, 18748
8088, 18472, 18480, 18481, 18473, 18766, 18767, 18768, 18750
8089, 18473, 18481, 18482, 18474, 18768, 18769, 18770, 18752
8090, 18474, 18482, 18483, 18475, 18770, 18771, 18772, 18754
8091, 18475, 18483, 18484, 18476, 18772, 18773, 18774, 18756
8092, 18476, 18484, 18485, 18477, 18774, 18775, 18776, 18758
8093, 18477, 18485, 18486, 18478, 18776, 18777, 18778, 18760
8094, 18478, 18486, 2575, 2574, 18778, 18779, 2597, 18762
8095, 2523, 2524, 18487, 18479, 2546, 18780, 18781, 18763
8096, 18479, 18487, 18488, 18480, 18781, 18782, 18783, 18765
8097, 18480, 18488, 18489, 18481, 18783, 18784, 18785, 18767
8098, 18481, 18489, 18490, 18482, 18785, 18786, 18787, 18769
8099, 18482, 18490, 18491, 18483, 18787, 18788, 18789, 18771
8100, 18483, 18491, 18492, 18484, 18789, 18790, 18791, 18773
8101, 18484, 18492, 18493, 18485, 18791, 18792, 18793, 18775
8102, 18485, 18493, 18494, 18486, 18793, 18794, 18795, 18777
8103, 18486, 18494, 2576, 2575, 18795, 18796, 2598, 18779
8104, 2524, 2525, 18495, 18487, 2547, 18797, 18798, 18780
8105, 18487, 18495, 18496, 18488, 18798, 18799, 18800, 18782
8106, 18488, 18496, 18497, 18489, 18800, 18801, 18802, 18784
8107, 18489, 18497, 18498, 18490, 18802, 18803, 18804, 18786
8108, 18490, 18498, 18499, 18491, 18804, 18805, 18806, 18788
8109, 18491, 18499, 18500, 18492, 18806, 18807, 18808, 18790
8110, 18492, 18500, 18501, 18493, 18808, 18809, 18810, 18792
8111, 18493, 18501, 18502, 18494, 18810, 18811, 18812, 18794
8112, 18494, 18502, 2577, 2576, 18812, 18813, 2599, 18796
8113, 2525, 2526, 18503, 18495, 2548, 18814, 18815, 18797
8114, 18495, 18503, 18504, 18496, 18815, 18816, 18817, 18799
8115, 18496, 18504, 18505, 18497, 18817, 18818, 18819, 18801
8116, 18497, 18505, 18506, 18498, 18819, 18820, 18821, 18803
8117, 18498, 18506, 18507, 18499, 18821, 18822, 18823, 18805
8118, 18499, 18507, 18508, 18500, 18823, 18824, 18825, 18807
8119, 18500, 18508, 18509, 18501, 18825, 18826, 18827, 18809
8120, 18501, 18509, 18510, 18502, 18827, 18828, 18829, 18811
8121, 18502, 18510, 2578, 2577, 18829, 18830, 2600, 18813
8122, 2526, 2527, 18511, 18503, 2549, 18831, 18832, 18814
8123, 18503, 18511, 18512, 18504, 18832, 18833, 18834, 18816
8124, 18504, 18512, 18513, 18505, 18834, 18835, 18836, 18818
8125, 18505, 18513, 18514, 18506, 18836, 18837, 18838, 18820
8126, 18506, 18514, 18515, 18507, 18838, 18839, 18840, 18822
8127, 18507, 18515, 18516, 18508, 18840, 18841, 18842, 18824
8128, 18508, 18516, 18517, 18509, 18842, 18843, 18844, 18826
8129, 18509, 18517, 18518, 18510, 18844, 18845, 18846, 18828
8130, 18510, 18518, 2579, 2578, 18846, 18847, 2601, 18830
8131, 2527, 2528, 18519, 18511, 2550, 18848, 18849, 18831
8132, 18511, 18519, 18520, 18512, 18849, 18850, 18851, 18833
8133, 18512, 18520, 18521, 18513, 18851, 18852, 18853, 18835
8134, 18513, 18521, 18522, 18514, 18853, 18854, 18855, 18837
8135, 18514, 18522, 18523, 18515, 18855, 18856, 18857, 18839
8136, 18515, 18523, 18524, 18516, 18857, 18858, 18859, 18841
8137, 18516, 18524, 18525, 18517, 18859, 18860, 18861, 18843
8138, 18517, 18525, 18526, 18518, 18861, 18862, 18863, 18845
8139, 18518, 18526, 2580, 2579, 18863, 18864, 2602, 18847
8140, 2528, 2529, 18527, 18519, 2551, 18865, 18866, 18848
8141, 18519, 18527, 18528, 18520, 18866, 18867, 18868, 18850
8142, 18520, 18528, 18529, 18521, 18868, 18869, 18870, 18852
8143, 18521, 18529, 18530, 18522, 18870, 18871, 18872, 18854
8144, 18522, 18530, 18531, 18523, 18872, 18873, 18874, 18856
8145, 18523, 18531, 18532, 18524, 18874, 18875, 18876, 18858
8146, 18524, 18532, 18533, 18525, 18876, 18877, 18878, 18860
8147, 18525, 18533, 18534, 18526, 18878, 18879, 18880, 18862
8148, 18526, 18534, 2581, 2580, 18880, 18881, 2603, 18864
8149, 2529, 2530, 18535, 18527, 2552, 18882, 18883, 18865
8150, 18527, 18535, 18536, 18528, 18883, 18884, 18885, 18867
8151, 18528, 18536, 18537, 18529, 18885, 18886, 18887, 18869
8152, 18529, 18537, 18538, 18530, 18887, 18888, 18889, 18871
8153, 18530, 18538, 18539, 18531, 18889, 18890, 18891, 18873
8154, 18531, 18539, 18540, 18532, 18891, 18892, 18893, 18875
8155, 18532, 18540, 18541, 18533, 18893, 18894, 18895, 18877
8156, 18533, 18541, 18542, 18534, 18895, 18896, 18897, 18879
8157, 18534, 18542, 2582, 2581, 18897, 18898, 2604, 18881
8158, 2530, 2531, 18543, 18535, 2553, 18899, 18900, 18882
8159, 18535, 18543, 18544, 18536, 18900, 18901, 18902, 18884
8160, 18536, 18544, 18545, 18537, 18902, 18903, 18904, 18886
8161, 18537, 18545, 18546, 18538, 18904, 18905, 18906, 18888
8162, 18538, 18546, 18547, 18539, 18906, 18907, 18908, 18890
8163, 18539, 18547, 18548, 18540, 18908, 18909, 18910, 18892
8164, 18540, 18548, 18549, 18541, 18910, 18911, 18912, 18894
8165, 18541, 18549, 18550, 18542, 18912, 18913, 18914, 18896
8166, 18542, 18550, 2583, 2582, 18914, 18915, 2605, 18898
8167, 2531, 2532, 18551, 18543, 2554, 18916, 18917, 18899
8168, 18543, 18551, 18552, 18544, 18917, 18918, 18919, 18901
8169, 18544, 18552, 18553, 18545, 18919, 18920, 18921, 18903
8170, 18545, 18553, 18554, 18546, 18921, 18922, 18923, 18905
8171, 18546, 18554, 18555, 18547, 18923, 18924, 18925, 18907
8172, 18547, 18555, 18556, 18548, 18925, 18926, 18927, 18909
8173, 18548, 18556, 18557, 18549, 18927, 18928, 18929, 18911
8174, 18549, 18557, 18558, 18550, 18929, 18930, 18931, 18913
8175, 18550, 18558, 2584, 2583, 18931, 18932, 2606, 18915
8176, 2532, 79, 2615, 18551, 2555, 2624, 18933, 18916
8177, 18551, 2615, 2614, 18552, 18933, 2623, 18934, 18918
8178, 18552, 2614, 2613, 18553, 18934, 2622, 18935, 18920
8179, 18553, 2613, 2612, 18554, 18935, 2621, 18936, 18922
8180, 18554, 2612, 2611, 18555, 18936, 2620, 18937, 18924
8181, 18555, 2611, 2610, 18556, 18937, 2619, 18938, 18926
8182, 18556, 2610, 2609, 18557, 18938, 2618, 18939, 18928
8183, 18557, 2609, 2608, 18558, 18939, 2617, 18940, 18930
8184, 18558, 2608, 80, 2584, 18940, 2616, 2607, 18932
*ELEMENT, type=CPS8, ELSET=Surface250
8185, 77, 2625, 18941, 2504, 2626, 18944, 18945, 2507
8186, 2504, 18941, 18942, 2505, 18945, 18946, 18947, 2508
8187, 2505, 18942, 18943, 2506, 18947, 18948, 18949, 2509
8188, 2506, 18943, 2628, 79, 18949, 18950, 2629, 2510
8189, 2625, 81, 2631, 18941, 2627, 2634, 18951, 18944
8190, 18941, 2631, 2632, 18942, 18951, 2635, 18952, 18946
8191, 18942, 2632, 2633, 18943, 18952, 2636, 18953, 18948
8192, 18943, 2633, 82, 2628, 18953, 2637, 2630, 18950
*ELEMENT, type=CPS8, ELSET=Surface251
8193, 78, 2556, 18954, 2638, 2559, 18957, 18958, 2639
8194, 2556, 2557, 18955, 18954, 2560, 18959, 18960, 18957
8195, 2557, 2558, 18956, 18955, 2561, 18961, 18962, 18959
8196, 2558, 80, 2641, 18956, 2562, 2642, 18963, 18961
8197, 2638, 18954, 2644, 83, 18958, 18964, 2647, 2640
8198, 18954, 18955, 2645, 2644, 18960, 18965, 2648, 18964
8199, 18955, 18956, 2646, 2645, 18962, 18966, 2649, 18965
8200, 18956, 2641, 84, 2646, 18963, 2643, 2650, 18966
*ELEMENT, type=CPS8, ELSET=Surface252
8201, 77, 2494, 18967, 2625, 2503, 18975, 18976, 2626
8202, 2494, 2493, 18968, 18967, 2502, 18977, 18978, 18975
8203, 2493, 2492, 18969, 18968, 2501, 18979, 18980, 18977
8204, 2492, 2491, 18970, 18969, 2500, 18981, 18982, 18979
8205, 2491, 2490, 18971, 18970, 2499, 18983, 18984, 18981
8206, 2490, 2489, 18972, 18971, 2498, 18985, 18986, 18983
8207, 2489, 2488, 18973, 18972, 2497, 18987, 18988, 18985
8208, 2488, 2487, 18974, 18973, 2496, 18989, 18990, 18987
8209, 2487, 78, 2638, 18974, 2495, 2639, 18991, 18989
8210, 2625, 18967, 2658, 81, 18976, 18992, 2667, 2627
8211, 18967, 18968, 2657, 2658, 18978, 18993, 2666, 18992
8212, 18968, 18969, 2656, 2657, 18980, 18994, 2665, 18993
8213, 18969, 18970, 2655, 2656, 18982, 18995, 2664, 18994
8214, 18970, 18971, 2654, 2655, 18984, 18996, 2663, 18995
8215, 18971, 18972, 2653, 2654, 18986, 18997, 2662, 18996
8216, 18972, 18973, 2652, 2653, 18988, 18998, 2661, 18997
8217, 18973, 18974, 2651, 2652, 18990, 18999, 2660, 18998
8218, 18974, 2638, 83, 2651, 18991, 2640, 2659, 18999
*ELEMENT, type=CPS8, ELSET=Surface253
8219, 79, 2628, 19000, 2615, 2629, 19008, 19009, 2624
8220, 2615, 19000, 19001, 2614, 19009, 19010, 19011, 2623
8221, 2614, 19001, 19002, 2613, 19011, 19012, 19013, 2622
8222, 2613, 19002, 19003, 2612, 19013, 19014, 19015, 2621
8223, 2612, 19003, 19004, 2611, 19015, 19016, 19017, 2620
8224, 2611, 19004, 19005, 2610, 19017, 19018, 19019, 2619
8225, 2610, 19005, 19006, 2609, 19019, 19020, 19021, 2618
8226, 2609, 19006, 19007, 2608, 19021, 19022, 19023, 2617
8227, 2608, 19007, 2641, 80, 19023, 19024, 2642, 2616
8228, 2628, 82, 2675, 19000, 2630, 2684, 19025, 19008
8229, 19000, 2675, 2674, 19001, 19025, 2683, 19026, 19010
8230, 19001, 2674, 2673, 19002, 19026, 2682, 19027, 19012
8231, 19002, 2673, 2672, 19003, 19027, 2681, 19028, 19014
8232, 19003, 2672, 2671, 19004, 19028, 2680, 19029, 19016
8233, 19004, 2671, 2670, 19005, 19029, 2679, 19030, 19018
8234, 19005, 2670, 2669, 19006, 19030, 2678, 19031, 19020
8235, 19006, 2669, 2668, 19007, 19031, 2677, 19032, 19022
8236, 19007, 2668, 84, 2641, 19032, 2676, 2643, 19024
*ELEMENT, type=CPS8, ELSET=Surface254
8237, 81, 2658, 19033, 2631, 2667, 19057, 19058, 2634
8238, 2658, 2657, 19034, 19033, 2666, 19059, 19060, 19057
8239, 2657, 2656, 19035, 19034, 2665, 19061, 19062, 19059
8240, 2656, 2655, 19036, 19035, 2664, 19063, 19064, 19061
8241, 2655, 2654, 19037, 19036, 2663, 19065, 19066, 19063
8242, 2654, 2653, 19038, 19037, 2662, 19067, 19068, 19065
8243, 2653, 2652, 19039, 19038, 2661, 19069, 19070, 19067
8244, 2652, 2651, 19040, 19039, 2660, 19071, 19072, 19069
8245, 2651, 83, 2644, 19040, 2659, 2647, 19073, 19071
8246, 2631, 19033, 19041, 2632, 19058, 19074, 19075, 2635
8247, 19033, 19034, 19042, 19041, 19060, 19076, 19077, 19074
8248, 19034, 19035, 19043, 19042, 19062, 19078, 19079, 19076
8249, 19035, 19036, 19044, 19043, 19064, 19080, 19081, 19078
8250, 19036, 19037, 19045, 19044, 19066, 19082, 19083, 19080
8251, 19037, 19038, 19046, 19045, 19068, 19084, 19085, 19082
8252, 19038, 19039, 19047, 19046, 19070, 19086, 19087, 19084
8253, 19039, 19040, 19048, 19047, 19072, 19088, 19089, 19086
8254, 19040, 2644, 2645, 19048, 19073, 2648, 19090, 19088
8255, 2632, 19041, 19049, 2633, 19075, 19091, 19092, 2636
8256, 19041, 19042, 19050, 19049, 19077, 19093, 19094, 19091
8257, 19042, 19043, 19051, 19050, 19079, 19095, 19096, 19093
8258, 19043, 19044, 19052, 19051, 19081, 19097, 19098, 19095
8259, 19044, 19045, 19053, 19052, 19083, 19099, 19100, 19097
8260, 19045, 19046, 19054, 19053, 19085, 19101, 19102, 19099
8261, 19046, 19047, 19055, 19054, 19087, 19103, 19104, 19101
8262, 19047, 19048, 19056, 19055, 19089, 19105, 19106, 19103
8263, 19048, 2645, 2646, 19056, 19090, 2649, 19107, 19105
8264, 2633, 19049, 2675, 82, 19092, 19108, 2684, 2637
8265, 19049, 19050, 2674, 2675, 19094, 19109, 2683, 19108
8266, 19050, 19051, 2673, 2674, 19096, 19110, 2682, 19109
8267, 19051, 19052, 2672, 2673, 19098, 19111, 2681, 19110
8268, 19052, 19053, 2671, 2672, 19100, 19112, 2680, 19111
8269, 19053, 19054, 2670, 2671, 19102, 19113, 2679, 19112
8270, 19054, 19055, 2669, 2670, 19104, 19114, 2678, 19113
8271, 19055, 19056, 2668, 2669, 19106, 19115, 2677, 19114
8272, 19056, 2646, 84, 2668, 19107, 2650, 2676, 19115
*ELEMENT, type=CPS8, ELSET=Surface255
8273, 85, 2712, 19116, 2685, 2735, 19138, 19139, 2686
8274, 2712, 2711, 19117, 19116, 2734, 19140, 19141, 19138
8275, 2711, 2710, 19118, 19117, 2733, 19142, 19143, 19140
8276, 2710, 2709, 19119, 19118, 2732, 19144, 19145, 19142
8277, 2709, 2708, 19120, 19119, 2731, 19146, 19147, 19144
8278, 2708, 2707, 19121, 19120, 2730, 19148, 19149, 19146
8279, 2707, 2706, 19122, 19121, 2729, 19150, 19151, 19148
8280, 2706, 2705, 19123, 19122, 2728, 19152, 19153, 19150
8281, 2705, 2704, 19124, 19123, 2727, 19154, 19155, 19152
8282, 2704, 2703, 19125, 19124, 2726, 19156, 19157, 19154
8283, 2703, 2702, 19126, 19125, 2725, 19158, 19159, 19156
8284, 2702, 2701, 19127, 19126, 2724, 19160, 19161, 19158
8285, 2701, 2700, 19128, 19127, 2723, 19162, 19163, 19160
8286, 2700, 2699, 19129, 19128, 2722, 19164, 19165, 19162
8287, 2699, 2698, 19130, 19129, 2721, 19166, 19167, 19164
8288, 2698, 2697, 19131, 19130, 2720, 19168, 19169, 19166
8289, 2697, 2696, 19132, 19131, 2719, 19170, 19171, 19168
8290, 2696, 2695, 19133, 19132, 2718, 19172, 19173, 19170
8291, 2695, 2694, 19134, 19133, 2717, 19174, 19175, 19172
8292, 2694, 2693, 19135, 19134, 2716, 19176, 19177, 19174
8293, 2693, 2692, 19136, 19135, 2715, 19178, 19179, 19176
8294, 2692, 2691, 19137, 19136, 2714, 19180, 19181, 19178
8295, 2691, 86, 2688, 19137, 2713, 2689, 19182, 19180
8296, 2685, 19116, 130, 1, 19139, 19183, 153, 2687
8297, 19116, 19117, 129, 130, 19141, 19184, 152, 19183
8298, 19117, 19118, 128, 129, 19143, 19185, 151, 19184
8299, 19118, 19119, 127, 128, 19145, 19186, 150, 19185
8300, 19119, 19120, 126, 127, 19147, 19187, 149, 19186
8301, 19120, 19121, 125, 126, 19149, 19188, 148, 19187
8302, 19121, 19122, 124, 125, 19151, 19189, 147, 19188
8303, 19122, 19123, 123, 124, 19153, 19190, 146, 19189
8304, 19123, 19124, 122, 123, 19155, 19191, 145, 19190
8305, 19124, 19125, 121, 122, 19157, 19192, 144, 19191
8306, 19125, 19126, 120, 121, 19159, 19193, 143, 19192
8307, 19126, 19127, 119, 120, 19161, 19194, 142, 19193
8308, 19127, 19128, 118, 119, 19163, 19195, 141, 19194
8309, 19128, 19129, 117, 118, 19165, 19196, 140, 19195
8310, 19129, 19130, 116, 117, 19167, 19197, 139, 19196
8311, 19130, 19131, 115, 116, 19169, 19198, 138, 19197
8312, 19131, 19132, 114, 115, 19171, 19199, 137, 19198
8313, 19132, 19133, 113, 114, 19173, 19200, 136, 19199
8314, 19133, 19134, 112, 113, 19175, 19201, 135, 19200
8315, 19134, 19135, 111, 112, 19177, 19202, 134, 19201
8316, 19135, 19136, 110, 111, 19179, 19203, 133, 19202
8317, 19136, 19137, 109, 110, 19181, 19204, 132, 19203
8318, 19137, 2688, 2, 109, 19182, 2690, 131, 19204
*ELEMENT, type=CPS8, ELSET=Surface256
8319, 87, 2746, 19205, 2736, 2755, 19213, 19214, 2737
8320, 2746, 2745, 19206, 19205, 2754, 19215, 19216, 19213
8321, 2745, 2744, 19207, 19206, 2753, 19217, 19218, 19215
8322, 2744, 2743, 19208, 19207, 2752, 19219, 19220, 19217
8323, 2743, 2742, 19209, 19208, 2751, 19221, 19222, 19219
8324, 2742, 2741, 19210, 19209, 2750, 19223, 19224, 19221
8325, 2741, 2740, 19211, 19210, 2749, 19225, 19226, 19223
8326, 2740, 2739, 19212, 19211, 2748, 19227, 19228, 19225
8327, 2739, 85, 2685, 19212, 2747, 2686, 19229, 19227
8328, 2736, 19205, 161, 3, 19214, 19230, 170, 2738
8329, 19205, 19206, 160, 161, 19216, 19231, 169, 19230
8330, 19206, 19207, 159, 160, 19218, 19232, 168, 19231
8331, 19207, 19208, 158, 159, 19220, 19233, 167, 19232
8332, 19208, 19209, 157, 158, 19222, 19234, 166, 19233
8333, 19209, 19210, 156, 157, 19224, 19235, 165, 19234
8334, 19210, 19211, 155, 156, 19226, 19236, 164, 19235
8335, 19211, 19212, 154, 155, 19228, 19237, 163, 19236
8336, 19212, 2685, 1, 154, 19229, 2687, 162, 19237
*ELEMENT, type=CPS8, ELSET=Surface257
8337, 87, 2736, 19238, 2780, 2737, 19260, 19261, 2803
8338, 2780, 19238, 19239, 2779, 19261, 19262, 19263, 2802
8339, 2779, 19239, 19240, 2778, 19263, 19264, 19265, 2801
8340, 2778, 19240, 19241, 2777, 19265, 19266, 19267, 2800
8341, 2777, 19241, 19242, 2776, 19267, 19268, 19269, 2799
8342, 2776, 19242, 19243, 2775, 19269, 19270, 19271, 2798
8343, 2775, 19243, 19244, 2774, 19271, 19272, 19273, 2797
8344, 2774, 19244, 19245, 2773, 19273, 19274, 19275, 2796
8345, 2773, 19245, 19246, 2772, 19275, 19276, 19277, 2795
8346, 2772, 19246, 19247, 2771, 19277, 19278, 19279, 2794
8347, 2771, 19247, 19248, 2770, 19279, 19280, 19281, 2793
8348, 2770, 19248, 19249, 2769, 19281, 19282, 19283, 2792
8349, 2769, 19249, 19250, 2768, 19283, 19284, 19285, 2791
8350, 2768, 19250, 19251, 2767, 19285, 19286, 19287, 2790
8351, 2767, 19251, 19252, 2766, 19287, 19288, 19289, 2789
8352, 2766, 19252, 19253, 2765, 19289, 19290, 19291, 2788
8353, 2765, 19253, 19254, 2764, 19291, 19292, 19293, 2787
8354, 2764, 19254, 19255, 2763, 19293, 19294, 19295, 2786
8355, 2763, 19255, 19256, 2762, 19295, 19296, 19297, 2785
8356, 2762, 19256, 19257, 2761, 19297, 19298, 19299, 2784
8357, 2761, 19257, 19258, 2760, 19299, 19300, 19301, 2783
8358, 2760, 19258, 19259, 2759, 19301, 19302, 19303, 2782
8359, 2759, 19259, 2756, 88, 19303, 19304, 2757, 2781
8360, 2736, 3, 192, 19238, 2738, 215, 19305, 19260
8361, 19238, 192, 191, 19239, 19305, 214, 19306, 19262
8362, 19239, 191, 190, 19240, 19306, 213, 19307, 19264
8363, 19240, 190, 189, 19241, 19307, 212, 19308, 19266
8364, 19241, 189, 188, 19242, 19308, 211, 19309, 19268
8365, 19242, 188, 187, 19243, 19309, 210, 19310, 19270
8366, 19243, 187, 186, 19244, 19310, 209, 19311, 19272
8367, 19244, 186, 185, 19245, 19311, 208, 19312, 19274
8368, 19245, 185, 184, 19246, 19312, 207, 19313, 19276
8369, 19246, 184, 183, 19247, 19313, 206, 19314, 19278
8370, 19247, 183, 182, 19248, 19314, 205, 19315, 19280
8371, 19248, 182, 181, 19249, 19315, 204, 19316, 19282
8372, 19249, 181, 180, 19250, 19316, 203, 19317, 19284
8373, 19250, 180, 179, 19251, 19317, 202, 19318, 19286
8374, 19251, 179, 178, 19252, 19318, 201, 19319, 19288
8375, 19252, 178, 177, 19253, 19319, 200, 19320, 19290
8376, 19253, 177, 176, 19254, 19320, 199, 19321, 19292
8377, 19254, 176, 175, 19255, 19321, 198, 19322, 19294
8378, 19255, 175, 174, 19256, 19322, 197, 19323, 19296
8379, 19256, 174, 173, 19257, 19323, 196, 19324, 19298
8380, 19257, 173, 172, 19258, 19324, 195, 19325, 19300
8381, 19258, 172, 171, 19259, 19325, 194, 19326, 19302
8382, 19259, 171, 4, 2756, 19326, 193, 2758, 19304
*ELEMENT, type=CPS8, ELSET=Surface258
8383, 88, 2756, 19327, 2811, 2757, 19335, 19336, 2820
8384, 2811, 19327, 19328, 2810, 19336, 19337, 19338, 2819
8385, 2810, 19328, 19329, 2809, 19338, 19339, 19340, 2818
8386, 2809, 19329, 19330, 2808, 19340, 19341, 19342, 2817
8387, 2808, 19330, 19331, 2807, 19342, 19343, 19344, 2816
8388, 2807, 19331, 19332, 2806, 19344, 19345, 19346, 2815
8389, 2806, 19332, 19333, 2805, 19346, 19347, 19348, 2814
8390, 2805, 19333, 19334, 2804, 19348, 19349, 19350, 2813
8391, 2804, 19334, 2688, 86, 19350, 19351, 2689, 2812
8392, 2756, 4, 223, 19327, 2758, 232, 19352, 19335
8393, 19327, 223, 222, 19328, 19352, 231, 19353, 19337
8394, 19328, 222, 221, 19329, 19353, 230, 19354, 19339
8395, 19329, 221, 220, 19330, 19354, 229, 19355, 19341
8396, 19330, 220, 219, 19331, 19355, 228, 19356, 19343
8397, 19331, 219, 218, 19332, 19356, 227, 19357, 19345
8398, 19332, 218, 217, 19333, 19357, 226, 19358, 19347
8399, 19333, 217, 216, 19334, 19358, 225, 19359, 19349
8400, 19334, 216, 2, 2688, 19359, 224, 2690, 19351
*ELEMENT, type=CPS8, ELSET=Surface259
8401, 86, 2691, 19360, 2804, 2713, 19536, 19537, 2812
8402, 2804, 19360, 19361, 2805, 19537, 19538, 19539, 2813
8403, 2805, 19361, 19362, 2806, 19539, 19540, 19541, 2814
8404, 2806, 19362, 19363, 2807, 19541, 19542, 19543, 2815
8405, 2807, 19363, 19364, 2808, 19543, 19544, 19545, 2816
8406, 2808, 19364, 19365, 2809, 19545, 19546, 19547, 2817
8407, 2809, 19365, 19366, 2810, 19547, 19548, 19549, 2818
8408, 2810, 19366, 19367, 2811, 19549, 19550, 19551, 2819
8409, 2811, 19367, 2759, 88, 19551, 19552, 2781, 2820
8410, 2691, 2692, 19368, 19360, 2714, 19553, 19554, 19536
8411, 19360, 19368, 19369, 19361, 19554, 19555, 19556, 19538
8412, 19361, 19369, 19370, 19362, 19556, 19557, 19558, 19540
8413, 19362, 19370, 19371, 19363, 19558, 19559, 19560, 19542
8414, 19363, 19371, 19372, 19364, 19560, 19561, 19562, 19544
8415, 19364, 19372, 19373, 19365, 19562, 19563, 19564, 19546
8416, 19365, 19373, 19374, 19366, 19564, 19565, 19566, 19548
8417, 19366, 19374, 19375, 19367, 19566, 19567, 19568, 19550
8418, 19367, 19375, 2760, 2759, 19568, 19569, 2782, 19552
8419, 2692, 2693, 19376, 19368, 2715, 19570, 19571, 19553
8420, 19368, 19376, 19377, 19369, 19571, 19572, 19573, 19555
8421, 19369, 19377, 19378, 19370, 19573, 19574, 19575, 19557
8422, 19370, 19378, 19379, 19371, 19575, 19576, 19577, 19559
8423, 19371, 19379, 19380, 19372, 19577, 19578, 19579, 19561
8424, 19372, 19380, 19381, 19373, 19579, 19580, 19581, 19563
8425, 19373, 19381, 19382, 19374, 19581, 19582, 19583, 19565
8426, 19374, 19382, 19383, 19375, 19583, 19584, 19585, 19567
8427, 19375, 19383, 2761, 2760, 19585, 19586, 2783, 19569
8428, 2693, 2694, 19384, 19376, 2716, 19587, 19588, 19570
8429, 19376, 19384, 19385, 19377, 19588, 19589, 19590, 19572
8430, 19377, 19385, 19386, 19378, 19590, 19591, 19592, 19574
8431, 19378, 19386, 19387, 19379, 19592, 19593, 19594, 19576
8432, 19379, 19387, 19388, 19380, 19594, 19595, 19596, 19578
8433, 19380, 19388, 19389, 19381, 19596, 19597, 19598, 19580
8434, 19381, 19389, 19390, 19382, 19598, 19599, 19600, 19582
8435, 19382, 19390, 19391, 19383, 19600, 19601, 19602, 19584
8436, 19383, 19391, 2762, 2761, 19602, 19603, 2784, 19586
8437, 2694, 2695, 19392, 19384, 2717, 19604, 19605, 19587
8438, 19384, 19392, 19393, 19385, 19605, 19606, 19607, 19589
8439, 19385, 19393, 19394, 19386, 19607, 19608, 19609, 19591
8440, 19386, 19394, 19395, 19387, 19609, 19610, 19611, 19593
8441, 19387, 19395, 19396, 19388, 19611, 19612, 19613, 19595
8442, 19388, 19396, 19397, 19389, 19613, 19614, 19615, 19597
8443, 19389, 19397, 19398, 19390, 19615, 19616, 19617, 19599
8444, 19390, 19398, 19399, 19391, 19617, 19618, 19619, 19601
8445, 19391, 19399, 2763, 2762, 19619, 19620, 2785, 19603
8446, 2695, 2696, 19400, 19392, 2718, 19621, 19622, 19604
8447, 19392, 19400, 19401, 19393, 19622, 19623, 19624, 19606
8448, 19393, 19401, 19402, 19394, 19624, 19625, 19626, 19608
8449, 19394, 19402, 19403, 19395, 19626, 19627, 19628, 19610
8450, 19395, 19403, 19404, 19396, 19628, 19629, 19630, 19612
8451, 19396, 19404, 19405, 19397, 19630, 19631, 19632, 19614
8452, 19397, 19405, 19406, 19398, 19632, 19633, 19634, 19616
8453, 19398, 19406, 19407, 19399, 19634, 19635, 19636, 19618
8454, 19399, 19407, 2764, 2763, 19636, 19637, 2786, 19620
8455, 2696, 2697, 19408, 19400, 2719, 19638, 19639, 19621
8456, 19400, 19408, 19409, 19401, 19639, 19640, 19641, 19623
8457, 19401, 19409, 19410, 19402, 19641, 19642, 19643, 19625
8458, 19402, 19410, 19411, 19403, 19643, 19644, 19645, 19627
8459, 19403, 19411, 19412, 19404, 19645, 19646, 19647, 19629
8460, 19404, 19412, 19413, 19405, 19647, 19648, 19649, 19631
8461, 19405, 19413, 19414, 19406, 19649, 19650, 19651, 19633
8462, 19406, 19414, 19415, 19407, 19651, 19652, 19653, 19635
8463, 19407, 19415, 2765, 2764, 19653, 19654, 2787, 19637
8464, 2697, 2698, 19416, 19408, 2720, 19655, 19656, 19638
8465, 19408, 19416, 19417, 19409, 19656, 19657, 19658, 19640
8466, 19409, 19417, 19418, 19410, 19658, 19659, 19660, 19642
8467, 19410, 19418, 19419, 19411, 19660, 19661, 19662, 19644
8468, 19411, 19419, 19420, 19412, 19662, 19663, 19664, 19646
8469, 19412, 19420, 19421, 19413, 19664, 19665, 19666, 19648
8470, 19413, 19421, 19422, 19414, 19666, 19667, 19668, 19650
8471, 19414, 19422, 19423, 19415, 19668, 19669, 19670, 19652
8472, 19415, 19423, 2766, 2765, 19670, 19671, 2788, 19654
8473, 2698, 2699, 19424, 19416, 2721, 19672, 19673, 19655
8474, 19416, 19424, 19425, 19417, 19673, 19674, 19675, 19657
8475, 19417, 19425, 19426, 19418, 19675, 19676, 19677, 19659
8476, 19418, 19426, 19427, 19419, 19677, 19678, 19679, 19661
8477, 19419, 19427, 19428, 19420, 19679, 19680, 19681, 19663
8478, 19420, 19428, 19429, 19421, 19681, 19682, 19683, 19665
8479, 19421, 19429, 19430, 19422, 19683, 19684, 19685, 19667
8480, 19422, 19430, 19431, 19423, 19685, 19686, 19687, 19669
8481, 19423, 19431, 2767, 2766, 19687, 19688, 2789, 19671
8482, 2699, 2700, 19432, 19424, 2722, 19689, 19690, 19672
8483, 19424, 19432, 19433, 19425, 19690, 19691, 19692, 19674
8484, 19425, 19433, 19434, 19426, 19692, 19693, 19694, 19676
8485, 19426, 19434, 19435, 19427, 19694, 19695, 19696, 19678
8486, 19427, 19435, 19436, 19428, 19696, 19697, 19698, 19680
8487, 19428, 19436, 19437, 19429, 19698, 19699, 19700, 19682
8488, 19429, 19437, 19438, 19430, 19700, 19701, 19702, 19684
8489, 19430, 19438, 19439, 19431, 19702, 19703, 19704, 19686
8490, 19431, 19439, 2768, 2767, 19704, 19705, 2790, 19688
8491, 2700, 2701, 19440, 19432, 2723, 19706, 19707, 19689
8492, 19432, 19440, 19441, 19433, 19707, 19708, 19709, 19691
8493, 19433, 19441, 19442, 19434, 19709, 19710, 19711, 19693
8494, 19434, 19442, 19443, 19435, 19711, 19712, 19713, 19695
8495, 19435, 19443, 19444, 19436, 19713, 19714, 19715, 19697
8496, 19436, 19444, 19445, 19437, 19715, 19716, 19717, 19699
8497, 19437, 19445, 19446, 19438, 19717, 19718, 19719, 19701
8498, 19438, 19446, 19447, 19439, 19719, 19720, 19721, 19703
8499, 19439, 19447, 2769, 2768, 19721, 19722, 2791, 19705
8500, 2701, 2702, 19448, 19440, 2724, 19723, 19724, 19706
8501, 19440, 19448, 19449, 19441, 19724, 19725, 19726, 19708
8502, 19441, 19449, 19450, 19442, 19726, 19727, 19728, 19710
8503, 19442, 19450, 19451, 19443, 19728, 19729, 19730, 19712
8504, 19443, 19451, 19452, 19444, 19730, 19731, 19732, 19714
8505, 19444, 19452, 19453, 19445, 19732, 19733, 19734, 19716
8506, 19445, 19453, 19454, 19446, 19734, 19735, 19736, 19718
8507, 19446, 19454, 19455, 19447, 19736, 19737, 19738, 19720
8508, 19447, 19455, 2770, 2769, 19738, 19739, 2792, 19722
8509, 2702, 2703, 19456, 19448, 2725, 19740, 19741, 19723
8510, 19448, 19456, 19457, 19449, 19741, 19742, 19743, 19725
8511, 19449, 19457, 19458, 19450, 19743, 19744, 19745, 19727
8512, 19450, 19458, 19459, 19451, 19745, 19746, 19747, 19729
8513, 19451, 19459, 19460, 19452, 19747, 19748, 19749, 19731
8514, 19452, 19460, 19461, 19453, 19749, 19750, 19751, 19733
8515, 19453, 19461, 19462, 19454, 19751, 19752, 19753, 19735
8516, 19454, 19462, 19463, 19455, 19753, 19754, 19755, 19737
8517, 19455, 19463, 2771, 2770, 19755, 19756, 2793, 19739
8518, 2703, 2704, 19464, 19456, 2726, 19757, 19758, 19740
8519, 19456, 19464, 19465, 19457, 19758, 19759, 19760, 19742
8520, 19457, 19465, 19466, 19458, 19760, 19761, 19762, 19744
8521, 19458, 19466, 19467, 19459, 19762, 19763, 19764, 19746
8522, 19459, 19467, 19468, 19460, 19764, 19765, 19766, 19748
8523, 19460, 19468, 19469, 19461, 19766, 19767, 19768, 19750
8524, 19461, 19469, 19470, 19462, 19768, 19769, 19770, 19752
8525, 19462, 19470, 19471, 19463, 19770, 19771, 19772, 19754
8526, 19463, 19471, 2772, 2771, 19772, 19773, 2794, 19756
8527, 2704, 2705, 19472, 19464, 2727, 19774, 19775, 19757
8528, 19464, 19472, 19473, 19465, 19775, 19776, 19777, 19759
8529, 19465, 19473, 19474, 19466, 19777, 19778, 19779, 19761
8530, 19466, 19474, 19475, 19467, 19779, 19780, 19781, 19763
8531, 19467, 19475, 19476, 19468, 19781, 19782, 19783, 19765
8532, 19468, 19476, 19477, 19469, 19783, 19784, 19785, 19767
8533, 19469, 19477, 19478, 19470, 19785, 19786, 19787, 19769
8534, 19470, 19478, 19479, 19471, 19787, 19788, 19789, 19771
8535, 19471, 19479, 2773, 2772, 19789, 19790, 2795, 19773
8536, 2705, 2706, 19480, 19472, 2728, 19791, 19792, 19774
8537, 19472, 19480, 19481, 19473, 19792, 19793, 19794, 19776
