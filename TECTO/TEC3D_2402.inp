29903, 82005, 82181, 82189, 82013, 82006, 82182, 82190, 82014, 83517, 83541, 83542, 82983, 83520, 83544, 83545, 
82986, 82960, 83518, 83543, 82985
29904, 82006, 82182, 82190, 82014, 82007, 82183, 82191, 82015, 83520, 83544, 83545, 82986, 83523, 83547, 83548, 
82989, 82963, 83521, 83546, 82988
29905, 82007, 82183, 82191, 82015, 82008, 82184, 82192, 82016, 83523, 83547, 83548, 82989, 83526, 83550, 83551, 
82992, 82966, 83524, 83549, 82991
29906, 82008, 82184, 82192, 82016, 18101, 18123, 18124, 18102, 83526, 83550, 83551, 82992, 18238, 18239, 18240, 
18194, 82969, 83527, 83552, 82994
29907, 17879, 17901, 17902, 17880, 82009, 82185, 82193, 82017, 18016, 18019, 18018, 17974, 83530, 83554, 83555, 
82996, 82970, 83528, 83553, 82995
29908, 82009, 82185, 82193, 82017, 82010, 82186, 82194, 82018, 83530, 83554, 83555, 82996, 83533, 83557, 83558, 
82999, 82973, 83531, 83556, 82998
29909, 82010, 82186, 82194, 82018, 82011, 82187, 82195, 82019, 83533, 83557, 83558, 82999, 83536, 83560, 83561, 
83002, 82976, 83534, 83559, 83001
29910, 82011, 82187, 82195, 82019, 82012, 82188, 82196, 82020, 83536, 83560, 83561, 83002, 83539, 83563, 83564, 
83005, 82979, 83537, 83562, 83004
29911, 82012, 82188, 82196, 82020, 82013, 82189, 82197, 82021, 83539, 83563, 83564, 83005, 83542, 83566, 83567, 
83008, 82982, 83540, 83565, 83007
29912, 82013, 82189, 82197, 82021, 82014, 82190, 82198, 82022, 83542, 83566, 83567, 83008, 83545, 83569, 83570, 
83011, 82985, 83543, 83568, 83010
29913, 82014, 82190, 82198, 82022, 82015, 82191, 82199, 82023, 83545, 83569, 83570, 83011, 83548, 83572, 83573, 
83014, 82988, 83546, 83571, 83013
29914, 82015, 82191, 82199, 82023, 82016, 82192, 82200, 82024, 83548, 83572, 83573, 83014, 83551, 83575, 83576, 
83017, 82991, 83549, 83574, 83016
29915, 82016, 82192, 82200, 82024, 18102, 18124, 18125, 18103, 83551, 83575, 83576, 83017, 18240, 18241, 18242, 
18196, 82994, 83552, 83577, 83019
29916, 17880, 17902, 17903, 17881, 82017, 82193, 82201, 82025, 18018, 18021, 18020, 17976, 83555, 83579, 83580, 
83021, 82995, 83553, 83578, 83020
29917, 82017, 82193, 82201, 82025, 82018, 82194, 82202, 82026, 83555, 83579, 83580, 83021, 83558, 83582, 83583, 
83024, 82998, 83556, 83581, 83023
29918, 82018, 82194, 82202, 82026, 82019, 82195, 82203, 82027, 83558, 83582, 83583, 83024, 83561, 83585, 83586, 
83027, 83001, 83559, 83584, 83026
29919, 82019, 82195, 82203, 82027, 82020, 82196, 82204, 82028, 83561, 83585, 83586, 83027, 83564, 83588, 83589, 
83030, 83004, 83562, 83587, 83029
29920, 82020, 82196, 82204, 82028, 82021, 82197, 82205, 82029, 83564, 83588, 83589, 83030, 83567, 83591, 83592, 
83033, 83007, 83565, 83590, 83032
29921, 82021, 82197, 82205, 82029, 82022, 82198, 82206, 82030, 83567, 83591, 83592, 83033, 83570, 83594, 83595, 
83036, 83010, 83568, 83593, 83035
29922, 82022, 82198, 82206, 82030, 82023, 82199, 82207, 82031, 83570, 83594, 83595, 83036, 83573, 83597, 83598, 
83039, 83013, 83571, 83596, 83038
29923, 82023, 82199, 82207, 82031, 82024, 82200, 82208, 82032, 83573, 83597, 83598, 83039, 83576, 83600, 83601, 
83042, 83016, 83574, 83599, 83041
29924, 82024, 82200, 82208, 82032, 18103, 18125, 18126, 18104, 83576, 83600, 83601, 83042, 18242, 18243, 18244, 
18198, 83019, 83577, 83602, 83044
29925, 17881, 17903, 17904, 17882, 82025, 82201, 82209, 82033, 18020, 18023, 18022, 17978, 83580, 83604, 83605, 
83046, 83020, 83578, 83603, 83045
29926, 82025, 82201, 82209, 82033, 82026, 82202, 82210, 82034, 83580, 83604, 83605, 83046, 83583, 83607, 83608, 
83049, 83023, 83581, 83606, 83048
29927, 82026, 82202, 82210, 82034, 82027, 82203, 82211, 82035, 83583, 83607, 83608, 83049, 83586, 83610, 83611, 
83052, 83026, 83584, 83609, 83051
29928, 82027, 82203, 82211, 82035, 82028, 82204, 82212, 82036, 83586, 83610, 83611, 83052, 83589, 83613, 83614, 
83055, 83029, 83587, 83612, 83054
29929, 82028, 82204, 82212, 82036, 82029, 82205, 82213, 82037, 83589, 83613, 83614, 83055, 83592, 83616, 83617, 
83058, 83032, 83590, 83615, 83057
29930, 82029, 82205, 82213, 82037, 82030, 82206, 82214, 82038, 83592, 83616, 83617, 83058, 83595, 83619, 83620, 
83061, 83035, 83593, 83618, 83060
29931, 82030, 82206, 82214, 82038, 82031, 82207, 82215, 82039, 83595, 83619, 83620, 83061, 83598, 83622, 83623, 
83064, 83038, 83596, 83621, 83063
29932, 82031, 82207, 82215, 82039, 82032, 82208, 82216, 82040, 83598, 83622, 83623, 83064, 83601, 83625, 83626, 
83067, 83041, 83599, 83624, 83066
29933, 82032, 82208, 82216, 82040, 18104, 18126, 18127, 18105, 83601, 83625, 83626, 83067, 18244, 18245, 18246, 
18200, 83044, 83602, 83627, 83069
29934, 17882, 17904, 17905, 17883, 82033, 82209, 82217, 82041, 18022, 18025, 18024, 17980, 83605, 83629, 83630, 
83071, 83045, 83603, 83628, 83070
29935, 82033, 82209, 82217, 82041, 82034, 82210, 82218, 82042, 83605, 83629, 83630, 83071, 83608, 83632, 83633, 
83074, 83048, 83606, 83631, 83073
29936, 82034, 82210, 82218, 82042, 82035, 82211, 82219, 82043, 83608, 83632, 83633, 83074, 83611, 83635, 83636, 
83077, 83051, 83609, 83634, 83076
29937, 82035, 82211, 82219, 82043, 82036, 82212, 82220, 82044, 83611, 83635, 83636, 83077, 83614, 83638, 83639, 
83080, 83054, 83612, 83637, 83079
29938, 82036, 82212, 82220, 82044, 82037, 82213, 82221, 82045, 83614, 83638, 83639, 83080, 83617, 83641, 83642, 
83083, 83057, 83615, 83640, 83082
29939, 82037, 82213, 82221, 82045, 82038, 82214, 82222, 82046, 83617, 83641, 83642, 83083, 83620, 83644, 83645, 
83086, 83060, 83618, 83643, 83085
29940, 82038, 82214, 82222, 82046, 82039, 82215, 82223, 82047, 83620, 83644, 83645, 83086, 83623, 83647, 83648, 
83089, 83063, 83621, 83646, 83088
29941, 82039, 82215, 82223, 82047, 82040, 82216, 82224, 82048, 83623, 83647, 83648, 83089, 83626, 83650, 83651, 
83092, 83066, 83624, 83649, 83091
29942, 82040, 82216, 82224, 82048, 18105, 18127, 18128, 18106, 83626, 83650, 83651, 83092, 18246, 18247, 18248, 
18202, 83069, 83627, 83652, 83094
29943, 17883, 17905, 17906, 17884, 82041, 82217, 82225, 82049, 18024, 18027, 18026, 17982, 83630, 83654, 83655, 
83096, 83070, 83628, 83653, 83095
29944, 82041, 82217, 82225, 82049, 82042, 82218, 82226, 82050, 83630, 83654, 83655, 83096, 83633, 83657, 83658, 
83099, 83073, 83631, 83656, 83098
29945, 82042, 82218, 82226, 82050, 82043, 82219, 82227, 82051, 83633, 83657, 83658, 83099, 83636, 83660, 83661, 
83102, 83076, 83634, 83659, 83101
29946, 82043, 82219, 82227, 82051, 82044, 82220, 82228, 82052, 83636, 83660, 83661, 83102, 83639, 83663, 83664, 
83105, 83079, 83637, 83662, 83104
29947, 82044, 82220, 82228, 82052, 82045, 82221, 82229, 82053, 83639, 83663, 83664, 83105, 83642, 83666, 83667, 
83108, 83082, 83640, 83665, 83107
29948, 82045, 82221, 82229, 82053, 82046, 82222, 82230, 82054, 83642, 83666, 83667, 83108, 83645, 83669, 83670, 
83111, 83085, 83643, 83668, 83110
29949, 82046, 82222, 82230, 82054, 82047, 82223, 82231, 82055, 83645, 83669, 83670, 83111, 83648, 83672, 83673, 
83114, 83088, 83646, 83671, 83113
29950, 82047, 82223, 82231, 82055, 82048, 82224, 82232, 82056, 83648, 83672, 83673, 83114, 83651, 83675, 83676, 
83117, 83091, 83649, 83674, 83116
29951, 82048, 82224, 82232, 82056, 18106, 18128, 18129, 18107, 83651, 83675, 83676, 83117, 18248, 18249, 18250, 
18204, 83094, 83652, 83677, 83119
29952, 17884, 17906, 17907, 17885, 82049, 82225, 82233, 82057, 18026, 18029, 18028, 17984, 83655, 83679, 83680, 
83121, 83095, 83653, 83678, 83120
29953, 82049, 82225, 82233, 82057, 82050, 82226, 82234, 82058, 83655, 83679, 83680, 83121, 83658, 83682, 83683, 
83124, 83098, 83656, 83681, 83123
29954, 82050, 82226, 82234, 82058, 82051, 82227, 82235, 82059, 83658, 83682, 83683, 83124, 83661, 83685, 83686, 
83127, 83101, 83659, 83684, 83126
29955, 82051, 82227, 82235, 82059, 82052, 82228, 82236, 82060, 83661, 83685, 83686, 83127, 83664, 83688, 83689, 
83130, 83104, 83662, 83687, 83129
29956, 82052, 82228, 82236, 82060, 82053, 82229, 82237, 82061, 83664, 83688, 83689, 83130, 83667, 83691, 83692, 
83133, 83107, 83665, 83690, 83132
29957, 82053, 82229, 82237, 82061, 82054, 82230, 82238, 82062, 83667, 83691, 83692, 83133, 83670, 83694, 83695, 
83136, 83110, 83668, 83693, 83135
29958, 82054, 82230, 82238, 82062, 82055, 82231, 82239, 82063, 83670, 83694, 83695, 83136, 83673, 83697, 83698, 
83139, 83113, 83671, 83696, 83138
29959, 82055, 82231, 82239, 82063, 82056, 82232, 82240, 82064, 83673, 83697, 83698, 83139, 83676, 83700, 83701, 
83142, 83116, 83674, 83699, 83141
29960, 82056, 82232, 82240, 82064, 18107, 18129, 18130, 18108, 83676, 83700, 83701, 83142, 18250, 18251, 18252, 
18206, 83119, 83677, 83702, 83144
29961, 17885, 17907, 17908, 17886, 82057, 82233, 82241, 82065, 18028, 18031, 18030, 17986, 83680, 83704, 83705, 
83146, 83120, 83678, 83703, 83145
29962, 82057, 82233, 82241, 82065, 82058, 82234, 82242, 82066, 83680, 83704, 83705, 83146, 83683, 83707, 83708, 
83149, 83123, 83681, 83706, 83148
29963, 82058, 82234, 82242, 82066, 82059, 82235, 82243, 82067, 83683, 83707, 83708, 83149, 83686, 83710, 83711, 
83152, 83126, 83684, 83709, 83151
29964, 82059, 82235, 82243, 82067, 82060, 82236, 82244, 82068, 83686, 83710, 83711, 83152, 83689, 83713, 83714, 
83155, 83129, 83687, 83712, 83154
29965, 82060, 82236, 82244, 82068, 82061, 82237, 82245, 82069, 83689, 83713, 83714, 83155, 83692, 83716, 83717, 
83158, 83132, 83690, 83715, 83157
29966, 82061, 82237, 82245, 82069, 82062, 82238, 82246, 82070, 83692, 83716, 83717, 83158, 83695, 83719, 83720, 
83161, 83135, 83693, 83718, 83160
29967, 82062, 82238, 82246, 82070, 82063, 82239, 82247, 82071, 83695, 83719, 83720, 83161, 83698, 83722, 83723, 
83164, 83138, 83696, 83721, 83163
29968, 82063, 82239, 82247, 82071, 82064, 82240, 82248, 82072, 83698, 83722, 83723, 83164, 83701, 83725, 83726, 
83167, 83141, 83699, 83724, 83166
29969, 82064, 82240, 82248, 82072, 18108, 18130, 18131, 18109, 83701, 83725, 83726, 83167, 18252, 18253, 18254, 
18208, 83144, 83702, 83727, 83169
29970, 17886, 17908, 17909, 17887, 82065, 82241, 82249, 82073, 18030, 18033, 18032, 17988, 83705, 83729, 83730, 
83171, 83145, 83703, 83728, 83170
29971, 82065, 82241, 82249, 82073, 82066, 82242, 82250, 82074, 83705, 83729, 83730, 83171, 83708, 83732, 83733, 
83174, 83148, 83706, 83731, 83173
29972, 82066, 82242, 82250, 82074, 82067, 82243, 82251, 82075, 83708, 83732, 83733, 83174, 83711, 83735, 83736, 
83177, 83151, 83709, 83734, 83176
29973, 82067, 82243, 82251, 82075, 82068, 82244, 82252, 82076, 83711, 83735, 83736, 83177, 83714, 83738, 83739, 
83180, 83154, 83712, 83737, 83179
29974, 82068, 82244, 82252, 82076, 82069, 82245, 82253, 82077, 83714, 83738, 83739, 83180, 83717, 83741, 83742, 
83183, 83157, 83715, 83740, 83182
29975, 82069, 82245, 82253, 82077, 82070, 82246, 82254, 82078, 83717, 83741, 83742, 83183, 83720, 83744, 83745, 
83186, 83160, 83718, 83743, 83185
29976, 82070, 82246, 82254, 82078, 82071, 82247, 82255, 82079, 83720, 83744, 83745, 83186, 83723, 83747, 83748, 
83189, 83163, 83721, 83746, 83188
29977, 82071, 82247, 82255, 82079, 82072, 82248, 82256, 82080, 83723, 83747, 83748, 83189, 83726, 83750, 83751, 
83192, 83166, 83724, 83749, 83191
29978, 82072, 82248, 82256, 82080, 18109, 18131, 18132, 18110, 83726, 83750, 83751, 83192, 18254, 18255, 18256, 
18210, 83169, 83727, 83752, 83194
29979, 17887, 17909, 17910, 17888, 82073, 82249, 82257, 82081, 18032, 18035, 18034, 17990, 83730, 83754, 83755, 
83196, 83170, 83728, 83753, 83195
29980, 82073, 82249, 82257, 82081, 82074, 82250, 82258, 82082, 83730, 83754, 83755, 83196, 83733, 83757, 83758, 
83199, 83173, 83731, 83756, 83198
29981, 82074, 82250, 82258, 82082, 82075, 82251, 82259, 82083, 83733, 83757, 83758, 83199, 83736, 83760, 83761, 
83202, 83176, 83734, 83759, 83201
29982, 82075, 82251, 82259, 82083, 82076, 82252, 82260, 82084, 83736, 83760, 83761, 83202, 83739, 83763, 83764, 
83205, 83179, 83737, 83762, 83204
29983, 82076, 82252, 82260, 82084, 82077, 82253, 82261, 82085, 83739, 83763, 83764, 83205, 83742, 83766, 83767, 
83208, 83182, 83740, 83765, 83207
29984, 82077, 82253, 82261, 82085, 82078, 82254, 82262, 82086, 83742, 83766, 83767, 83208, 83745, 83769, 83770, 
83211, 83185, 83743, 83768, 83210
29985, 82078, 82254, 82262, 82086, 82079, 82255, 82263, 82087, 83745, 83769, 83770, 83211, 83748, 83772, 83773, 
83214, 83188, 83746, 83771, 83213
29986, 82079, 82255, 82263, 82087, 82080, 82256, 82264, 82088, 83748, 83772, 83773, 83214, 83751, 83775, 83776, 
83217, 83191, 83749, 83774, 83216
29987, 82080, 82256, 82264, 82088, 18110, 18132, 18133, 18111, 83751, 83775, 83776, 83217, 18256, 18257, 18258, 
18212, 83194, 83752, 83777, 83219
29988, 17888, 17910, 17911, 17889, 82081, 82257, 82265, 82089, 18034, 18037, 18036, 17992, 83755, 83779, 83780, 
83221, 83195, 83753, 83778, 83220
29989, 82081, 82257, 82265, 82089, 82082, 82258, 82266, 82090, 83755, 83779, 83780, 83221, 83758, 83782, 83783, 
83224, 83198, 83756, 83781, 83223
29990, 82082, 82258, 82266, 82090, 82083, 82259, 82267, 82091, 83758, 83782, 83783, 83224, 83761, 83785, 83786, 
83227, 83201, 83759, 83784, 83226
29991, 82083, 82259, 82267, 82091, 82084, 82260, 82268, 82092, 83761, 83785, 83786, 83227, 83764, 83788, 83789, 
83230, 83204, 83762, 83787, 83229
29992, 82084, 82260, 82268, 82092, 82085, 82261, 82269, 82093, 83764, 83788, 83789, 83230, 83767, 83791, 83792, 
83233, 83207, 83765, 83790, 83232
29993, 82085, 82261, 82269, 82093, 82086, 82262, 82270, 82094, 83767, 83791, 83792, 83233, 83770, 83794, 83795, 
83236, 83210, 83768, 83793, 83235
29994, 82086, 82262, 82270, 82094, 82087, 82263, 82271, 82095, 83770, 83794, 83795, 83236, 83773, 83797, 83798, 
83239, 83213, 83771, 83796, 83238
29995, 82087, 82263, 82271, 82095, 82088, 82264, 82272, 82096, 83773, 83797, 83798, 83239, 83776, 83800, 83801, 
83242, 83216, 83774, 83799, 83241
29996, 82088, 82264, 82272, 82096, 18111, 18133, 18134, 18112, 83776, 83800, 83801, 83242, 18258, 18259, 18260, 
18214, 83219, 83777, 83802, 83244
29997, 17889, 17911, 17912, 17890, 82089, 82265, 82273, 82097, 18036, 18039, 18038, 17994, 83780, 83804, 83805, 
83246, 83220, 83778, 83803, 83245
29998, 82089, 82265, 82273, 82097, 82090, 82266, 82274, 82098, 83780, 83804, 83805, 83246, 83783, 83807, 83808, 
83249, 83223, 83781, 83806, 83248
29999, 82090, 82266, 82274, 82098, 82091, 82267, 82275, 82099, 83783, 83807, 83808, 83249, 83786, 83810, 83811, 
83252, 83226, 83784, 83809, 83251
30000, 82091, 82267, 82275, 82099, 82092, 82268, 82276, 82100, 83786, 83810, 83811, 83252, 83789, 83813, 83814, 
83255, 83229, 83787, 83812, 83254
30001, 82092, 82268, 82276, 82100, 82093, 82269, 82277, 82101, 83789, 83813, 83814, 83255, 83792, 83816, 83817, 
83258, 83232, 83790, 83815, 83257
30002, 82093, 82269, 82277, 82101, 82094, 82270, 82278, 82102, 83792, 83816, 83817, 83258, 83795, 83819, 83820, 
83261, 83235, 83793, 83818, 83260
30003, 82094, 82270, 82278, 82102, 82095, 82271, 82279, 82103, 83795, 83819, 83820, 83261, 83798, 83822, 83823, 
83264, 83238, 83796, 83821, 83263
30004, 82095, 82271, 82279, 82103, 82096, 82272, 82280, 82104, 83798, 83822, 83823, 83264, 83801, 83825, 83826, 
83267, 83241, 83799, 83824, 83266
30005, 82096, 82272, 82280, 82104, 18112, 18134, 18135, 18113, 83801, 83825, 83826, 83267, 18260, 18261, 18262, 
18216, 83244, 83802, 83827, 83269
30006, 17890, 17912, 17913, 17891, 82097, 82273, 82281, 82105, 18038, 18041, 18040, 17996, 83805, 83829, 83830, 
83271, 83245, 83803, 83828, 83270
30007, 82097, 82273, 82281, 82105, 82098, 82274, 82282, 82106, 83805, 83829, 83830, 83271, 83808, 83832, 83833, 
83274, 83248, 83806, 83831, 83273
30008, 82098, 82274, 82282, 82106, 82099, 82275, 82283, 82107, 83808, 83832, 83833, 83274, 83811, 83835, 83836, 
83277, 83251, 83809, 83834, 83276
30009, 82099, 82275, 82283, 82107, 82100, 82276, 82284, 82108, 83811, 83835, 83836, 83277, 83814, 83838, 83839, 
83280, 83254, 83812, 83837, 83279
30010, 82100, 82276, 82284, 82108, 82101, 82277, 82285, 82109, 83814, 83838, 83839, 83280, 83817, 83841, 83842, 
83283, 83257, 83815, 83840, 83282
30011, 82101, 82277, 82285, 82109, 82102, 82278, 82286, 82110, 83817, 83841, 83842, 83283, 83820, 83844, 83845, 
83286, 83260, 83818, 83843, 83285
30012, 82102, 82278, 82286, 82110, 82103, 82279, 82287, 82111, 83820, 83844, 83845, 83286, 83823, 83847, 83848, 
83289, 83263, 83821, 83846, 83288
30013, 82103, 82279, 82287, 82111, 82104, 82280, 82288, 82112, 83823, 83847, 83848, 83289, 83826, 83850, 83851, 
83292, 83266, 83824, 83849, 83291
30014, 82104, 82280, 82288, 82112, 18113, 18135, 18136, 18114, 83826, 83850, 83851, 83292, 18262, 18263, 18264, 
18218, 83269, 83827, 83852, 83294
30015, 17891, 17913, 17914, 17892, 82105, 82281, 82289, 82113, 18040, 18043, 18042, 17998, 83830, 83854, 83855, 
83296, 83270, 83828, 83853, 83295
30016, 82105, 82281, 82289, 82113, 82106, 82282, 82290, 82114, 83830, 83854, 83855, 83296, 83833, 83857, 83858, 
83299, 83273, 83831, 83856, 83298
30017, 82106, 82282, 82290, 82114, 82107, 82283, 82291, 82115, 83833, 83857, 83858, 83299, 83836, 83860, 83861, 
83302, 83276, 83834, 83859, 83301
30018, 82107, 82283, 82291, 82115, 82108, 82284, 82292, 82116, 83836, 83860, 83861, 83302, 83839, 83863, 83864, 
83305, 83279, 83837, 83862, 83304
30019, 82108, 82284, 82292, 82116, 82109, 82285, 82293, 82117, 83839, 83863, 83864, 83305, 83842, 83866, 83867, 
83308, 83282, 83840, 83865, 83307
30020, 82109, 82285, 82293, 82117, 82110, 82286, 82294, 82118, 83842, 83866, 83867, 83308, 83845, 83869, 83870, 
83311, 83285, 83843, 83868, 83310
30021, 82110, 82286, 82294, 82118, 82111, 82287, 82295, 82119, 83845, 83869, 83870, 83311, 83848, 83872, 83873, 
83314, 83288, 83846, 83871, 83313
30022, 82111, 82287, 82295, 82119, 82112, 82288, 82296, 82120, 83848, 83872, 83873, 83314, 83851, 83875, 83876, 
83317, 83291, 83849, 83874, 83316
30023, 82112, 82288, 82296, 82120, 18114, 18136, 18137, 18115, 83851, 83875, 83876, 83317, 18264, 18265, 18266, 
18220, 83294, 83852, 83877, 83319
30024, 17892, 17914, 17915, 17893, 82113, 82289, 82297, 82121, 18042, 18045, 18044, 18000, 83855, 83879, 83880, 
83321, 83295, 83853, 83878, 83320
30025, 82113, 82289, 82297, 82121, 82114, 82290, 82298, 82122, 83855, 83879, 83880, 83321, 83858, 83882, 83883, 
83324, 83298, 83856, 83881, 83323
30026, 82114, 82290, 82298, 82122, 82115, 82291, 82299, 82123, 83858, 83882, 83883, 83324, 83861, 83885, 83886, 
83327, 83301, 83859, 83884, 83326
30027, 82115, 82291, 82299, 82123, 82116, 82292, 82300, 82124, 83861, 83885, 83886, 83327, 83864, 83888, 83889, 
83330, 83304, 83862, 83887, 83329
30028, 82116, 82292, 82300, 82124, 82117, 82293, 82301, 82125, 83864, 83888, 83889, 83330, 83867, 83891, 83892, 
83333, 83307, 83865, 83890, 83332
30029, 82117, 82293, 82301, 82125, 82118, 82294, 82302, 82126, 83867, 83891, 83892, 83333, 83870, 83894, 83895, 
83336, 83310, 83868, 83893, 83335
30030, 82118, 82294, 82302, 82126, 82119, 82295, 82303, 82127, 83870, 83894, 83895, 83336, 83873, 83897, 83898, 
83339, 83313, 83871, 83896, 83338
30031, 82119, 82295, 82303, 82127, 82120, 82296, 82304, 82128, 83873, 83897, 83898, 83339, 83876, 83900, 83901, 
83342, 83316, 83874, 83899, 83341
30032, 82120, 82296, 82304, 82128, 18115, 18137, 18138, 18116, 83876, 83900, 83901, 83342, 18266, 18267, 18268, 
18222, 83319, 83877, 83902, 83344
30033, 17893, 17915, 17916, 17894, 82121, 82297, 82305, 82129, 18044, 18047, 18046, 18002, 83880, 83904, 83905, 
83346, 83320, 83878, 83903, 83345
30034, 82121, 82297, 82305, 82129, 82122, 82298, 82306, 82130, 83880, 83904, 83905, 83346, 83883, 83907, 83908, 
83349, 83323, 83881, 83906, 83348
30035, 82122, 82298, 82306, 82130, 82123, 82299, 82307, 82131, 83883, 83907, 83908, 83349, 83886, 83910, 83911, 
83352, 83326, 83884, 83909, 83351
30036, 82123, 82299, 82307, 82131, 82124, 82300, 82308, 82132, 83886, 83910, 83911, 83352, 83889, 83913, 83914, 
83355, 83329, 83887, 83912, 83354
30037, 82124, 82300, 82308, 82132, 82125, 82301, 82309, 82133, 83889, 83913, 83914, 83355, 83892, 83916, 83917, 
83358, 83332, 83890, 83915, 83357
30038, 82125, 82301, 82309, 82133, 82126, 82302, 82310, 82134, 83892, 83916, 83917, 83358, 83895, 83919, 83920, 
83361, 83335, 83893, 83918, 83360
30039, 82126, 82302, 82310, 82134, 82127, 82303, 82311, 82135, 83895, 83919, 83920, 83361, 83898, 83922, 83923, 
83364, 83338, 83896, 83921, 83363
30040, 82127, 82303, 82311, 82135, 82128, 82304, 82312, 82136, 83898, 83922, 83923, 83364, 83901, 83925, 83926, 
83367, 83341, 83899, 83924, 83366
30041, 82128, 82304, 82312, 82136, 18116, 18138, 18139, 18117, 83901, 83925, 83926, 83367, 18268, 18269, 18270, 
18224, 83344, 83902, 83927, 83369
30042, 17894, 17916, 17917, 17895, 82129, 82305, 82313, 82137, 18046, 18049, 18048, 18004, 83905, 83929, 83930, 
83371, 83345, 83903, 83928, 83370
30043, 82129, 82305, 82313, 82137, 82130, 82306, 82314, 82138, 83905, 83929, 83930, 83371, 83908, 83932, 83933, 
83374, 83348, 83906, 83931, 83373
30044, 82130, 82306, 82314, 82138, 82131, 82307, 82315, 82139, 83908, 83932, 83933, 83374, 83911, 83935, 83936, 
83377, 83351, 83909, 83934, 83376
30045, 82131, 82307, 82315, 82139, 82132, 82308, 82316, 82140, 83911, 83935, 83936, 83377, 83914, 83938, 83939, 
83380, 83354, 83912, 83937, 83379
30046, 82132, 82308, 82316, 82140, 82133, 82309, 82317, 82141, 83914, 83938, 83939, 83380, 83917, 83941, 83942, 
83383, 83357, 83915, 83940, 83382
30047, 82133, 82309, 82317, 82141, 82134, 82310, 82318, 82142, 83917, 83941, 83942, 83383, 83920, 83944, 83945, 
83386, 83360, 83918, 83943, 83385
30048, 82134, 82310, 82318, 82142, 82135, 82311, 82319, 82143, 83920, 83944, 83945, 83386, 83923, 83947, 83948, 
83389, 83363, 83921, 83946, 83388
30049, 82135, 82311, 82319, 82143, 82136, 82312, 82320, 82144, 83923, 83947, 83948, 83389, 83926, 83950, 83951, 
83392, 83366, 83924, 83949, 83391
30050, 82136, 82312, 82320, 82144, 18117, 18139, 18140, 18118, 83926, 83950, 83951, 83392, 18270, 18271, 18272, 
18226, 83369, 83927, 83952, 83394
30051, 17895, 17917, 17918, 17896, 82137, 82313, 82321, 82145, 18048, 18051, 18050, 18006, 83930, 83954, 83955, 
83396, 83370, 83928, 83953, 83395
30052, 82137, 82313, 82321, 82145, 82138, 82314, 82322, 82146, 83930, 83954, 83955, 83396, 83933, 83957, 83958, 
83399, 83373, 83931, 83956, 83398
30053, 82138, 82314, 82322, 82146, 82139, 82315, 82323, 82147, 83933, 83957, 83958, 83399, 83936, 83960, 83961, 
83402, 83376, 83934, 83959, 83401
30054, 82139, 82315, 82323, 82147, 82140, 82316, 82324, 82148, 83936, 83960, 83961, 83402, 83939, 83963, 83964, 
83405, 83379, 83937, 83962, 83404
30055, 82140, 82316, 82324, 82148, 82141, 82317, 82325, 82149, 83939, 83963, 83964, 83405, 83942, 83966, 83967, 
83408, 83382, 83940, 83965, 83407
30056, 82141, 82317, 82325, 82149, 82142, 82318, 82326, 82150, 83942, 83966, 83967, 83408, 83945, 83969, 83970, 
83411, 83385, 83943, 83968, 83410
30057, 82142, 82318, 82326, 82150, 82143, 82319, 82327, 82151, 83945, 83969, 83970, 83411, 83948, 83972, 83973, 
83414, 83388, 83946, 83971, 83413
30058, 82143, 82319, 82327, 82151, 82144, 82320, 82328, 82152, 83948, 83972, 83973, 83414, 83951, 83975, 83976, 
83417, 83391, 83949, 83974, 83416
30059, 82144, 82320, 82328, 82152, 18118, 18140, 18141, 18119, 83951, 83975, 83976, 83417, 18272, 18273, 18274, 
18228, 83394, 83952, 83977, 83419
30060, 17896, 17918, 17919, 17897, 82145, 82321, 82329, 82153, 18050, 18053, 18052, 18008, 83955, 83979, 83980, 
83421, 83395, 83953, 83978, 83420
30061, 82145, 82321, 82329, 82153, 82146, 82322, 82330, 82154, 83955, 83979, 83980, 83421, 83958, 83982, 83983, 
83424, 83398, 83956, 83981, 83423
30062, 82146, 82322, 82330, 82154, 82147, 82323, 82331, 82155, 83958, 83982, 83983, 83424, 83961, 83985, 83986, 
83427, 83401, 83959, 83984, 83426
30063, 82147, 82323, 82331, 82155, 82148, 82324, 82332, 82156, 83961, 83985, 83986, 83427, 83964, 83988, 83989, 
83430, 83404, 83962, 83987, 83429
30064, 82148, 82324, 82332, 82156, 82149, 82325, 82333, 82157, 83964, 83988, 83989, 83430, 83967, 83991, 83992, 
83433, 83407, 83965, 83990, 83432
30065, 82149, 82325, 82333, 82157, 82150, 82326, 82334, 82158, 83967, 83991, 83992, 83433, 83970, 83994, 83995, 
83436, 83410, 83968, 83993, 83435
30066, 82150, 82326, 82334, 82158, 82151, 82327, 82335, 82159, 83970, 83994, 83995, 83436, 83973, 83997, 83998, 
83439, 83413, 83971, 83996, 83438
30067, 82151, 82327, 82335, 82159, 82152, 82328, 82336, 82160, 83973, 83997, 83998, 83439, 83976, 84000, 84001, 
83442, 83416, 83974, 83999, 83441
30068, 82152, 82328, 82336, 82160, 18119, 18141, 18142, 18120, 83976, 84000, 84001, 83442, 18274, 18275, 18276, 
18230, 83419, 83977, 84002, 83444
30069, 17897, 17919, 2506, 2505, 82153, 82329, 18316, 18308, 18052, 18054, 2509, 18009, 83980, 84003, 18358, 
83445, 83420, 83978, 18359, 18342
30070, 82153, 82329, 18316, 18308, 82154, 82330, 18317, 18309, 83980, 84003, 18358, 83445, 83983, 84004, 18360, 
83446, 83423, 83981, 18361, 18344
30071, 82154, 82330, 18317, 18309, 82155, 82331, 18318, 18310, 83983, 84004, 18360, 83446, 83986, 84005, 18362, 
83447, 83426, 83984, 18363, 18346
30072, 82155, 82331, 18318, 18310, 82156, 82332, 18319, 18311, 83986, 84005, 18362, 83447, 83989, 84006, 18364, 
83448, 83429, 83987, 18365, 18348
30073, 82156, 82332, 18319, 18311, 82157, 82333, 18320, 18312, 83989, 84006, 18364, 83448, 83992, 84007, 18366, 
83449, 83432, 83990, 18367, 18350
30074, 82157, 82333, 18320, 18312, 82158, 82334, 18321, 18313, 83992, 84007, 18366, 83449, 83995, 84008, 18368, 
83450, 83435, 83993, 18369, 18352
30075, 82158, 82334, 18321, 18313, 82159, 82335, 18322, 18314, 83995, 84008, 18368, 83450, 83998, 84009, 18370, 
83451, 83438, 83996, 18371, 18354
30076, 82159, 82335, 18322, 18314, 82160, 82336, 18323, 18315, 83998, 84009, 18370, 83451, 84001, 84010, 18372, 
83452, 83441, 83999, 18373, 18356
30077, 82160, 82336, 18323, 18315, 18120, 18142, 2558, 2557, 84001, 84010, 18372, 83452, 18276, 18277, 2561, 
18232, 83444, 84002, 18374, 18357
30078, 1760, 58, 2511, 17898, 13352, 1817, 18383, 82161, 1764, 2533, 18055, 18011, 13411, 18560, 84011, 
83454, 13395, 1826, 18559, 83453
30079, 13352, 1817, 18383, 82161, 13353, 1816, 18384, 82162, 13411, 18560, 84011, 83454, 13412, 18562, 84012, 
83457, 13397, 1825, 18561, 83456
30080, 13353, 1816, 18384, 82162, 13354, 1815, 18385, 82163, 13412, 18562, 84012, 83457, 13413, 18564, 84013, 
83460, 13399, 1824, 18563, 83459
30081, 13354, 1815, 18385, 82163, 13355, 1814, 18386, 82164, 13413, 18564, 84013, 83460, 13414, 18566, 84014, 
83463, 13401, 1823, 18565, 83462
30082, 13355, 1814, 18386, 82164, 13356, 1813, 18387, 82165, 13414, 18566, 84014, 83463, 13415, 18568, 84015, 
83466, 13403, 1822, 18567, 83465
30083, 13356, 1813, 18387, 82165, 13357, 1812, 18388, 82166, 13415, 18568, 84015, 83466, 13416, 18570, 84016, 
83469, 13405, 1821, 18569, 83468
30084, 13357, 1812, 18388, 82166, 13358, 1811, 18389, 82167, 13416, 18570, 84016, 83469, 13417, 18572, 84017, 
83472, 13407, 1820, 18571, 83471
30085, 13358, 1811, 18389, 82167, 13359, 1810, 18390, 82168, 13417, 18572, 84017, 83472, 13418, 18574, 84018, 
83475, 13409, 1819, 18573, 83474
30086, 13359, 1810, 18390, 82168, 1781, 60, 2563, 18121, 13418, 18574, 84018, 83475, 1785, 2585, 18278, 
18233, 13410, 1818, 18575, 83477
30087, 17898, 2511, 2512, 17899, 82161, 18383, 18391, 82169, 18055, 2534, 18056, 18013, 84011, 18577, 84019, 
83479, 83453, 18559, 18576, 83478
30088, 82161, 18383, 18391, 82169, 82162, 18384, 18392, 82170, 84011, 18577, 84019, 83479, 84012, 18579, 84020, 
83482, 83456, 18561, 18578, 83481
30089, 82162, 18384, 18392, 82170, 82163, 18385, 18393, 82171, 84012, 18579, 84020, 83482, 84013, 18581, 84021, 
83485, 83459, 18563, 18580, 83484
30090, 82163, 18385, 18393, 82171, 82164, 18386, 18394, 82172, 84013, 18581, 84021, 83485, 84014, 18583, 84022, 
83488, 83462, 18565, 18582, 83487
30091, 82164, 18386, 18394, 82172, 82165, 18387, 18395, 82173, 84014, 18583, 84022, 83488, 84015, 18585, 84023, 
83491, 83465, 18567, 18584, 83490
30092, 82165, 18387, 18395, 82173, 82166, 18388, 18396, 82174, 84015, 18585, 84023, 83491, 84016, 18587, 84024, 
83494, 83468, 18569, 18586, 83493
30093, 82166, 18388, 18396, 82174, 82167, 18389, 18397, 82175, 84016, 18587, 84024, 83494, 84017, 18589, 84025, 
83497, 83471, 18571, 18588, 83496
30094, 82167, 18389, 18397, 82175, 82168, 18390, 18398, 82176, 84017, 18589, 84025, 83497, 84018, 18591, 84026, 
83500, 83474, 18573, 18590, 83499
30095, 82168, 18390, 18398, 82176, 18121, 2563, 2564, 18122, 84018, 18591, 84026, 83500, 18278, 2586, 18279, 
18235, 83477, 18575, 18592, 83502
30096, 17899, 2512, 2513, 17900, 82169, 18391, 18399, 82177, 18056, 2535, 18057, 18015, 84019, 18594, 84027, 
83504, 83478, 18576, 18593, 83503
30097, 82169, 18391, 18399, 82177, 82170, 18392, 18400, 82178, 84019, 18594, 84027, 83504, 84020, 18596, 84028, 
83507, 83481, 18578, 18595, 83506
30098, 82170, 18392, 18400, 82178, 82171, 18393, 18401, 82179, 84020, 18596, 84028, 83507, 84021, 18598, 84029, 
83510, 83484, 18580, 18597, 83509
30099, 82171, 18393, 18401, 82179, 82172, 18394, 18402, 82180, 84021, 18598, 84029, 83510, 84022, 18600, 84030, 
83513, 83487, 18582, 18599, 83512
30100, 82172, 18394, 18402, 82180, 82173, 18395, 18403, 82181, 84022, 18600, 84030, 83513, 84023, 18602, 84031, 
83516, 83490, 18584, 18601, 83515
30101, 82173, 18395, 18403, 82181, 82174, 18396, 18404, 82182, 84023, 18602, 84031, 83516, 84024, 18604, 84032, 
83519, 83493, 18586, 18603, 83518
30102, 82174, 18396, 18404, 82182, 82175, 18397, 18405, 82183, 84024, 18604, 84032, 83519, 84025, 18606, 84033, 
83522, 83496, 18588, 18605, 83521
30103, 82175, 18397, 18405, 82183, 82176, 18398, 18406, 82184, 84025, 18606, 84033, 83522, 84026, 18608, 84034, 
83525, 83499, 18590, 18607, 83524
30104, 82176, 18398, 18406, 82184, 18122, 2564, 2565, 18123, 84026, 18608, 84034, 83525, 18279, 2587, 18280, 
18237, 83502, 18592, 18609, 83527
30105, 17900, 2513, 2514, 17901, 82177, 18399, 18407, 82185, 18057, 2536, 18058, 18017, 84027, 18611, 84035, 
83529, 83503, 18593, 18610, 83528
30106, 82177, 18399, 18407, 82185, 82178, 18400, 18408, 82186, 84027, 18611, 84035, 83529, 84028, 18613, 84036, 
83532, 83506, 18595, 18612, 83531
30107, 82178, 18400, 18408, 82186, 82179, 18401, 18409, 82187, 84028, 18613, 84036, 83532, 84029, 18615, 84037, 
83535, 83509, 18597, 18614, 83534
30108, 82179, 18401, 18409, 82187, 82180, 18402, 18410, 82188, 84029, 18615, 84037, 83535, 84030, 18617, 84038, 
83538, 83512, 18599, 18616, 83537
30109, 82180, 18402, 18410, 82188, 82181, 18403, 18411, 82189, 84030, 18617, 84038, 83538, 84031, 18619, 84039, 
83541, 83515, 18601, 18618, 83540
30110, 82181, 18403, 18411, 82189, 82182, 18404, 18412, 82190, 84031, 18619, 84039, 83541, 84032, 18621, 84040, 
83544, 83518, 18603, 18620, 83543
30111, 82182, 18404, 18412, 82190, 82183, 18405, 18413, 82191, 84032, 18621, 84040, 83544, 84033, 18623, 84041, 
83547, 83521, 18605, 18622, 83546
30112, 82183, 18405, 18413, 82191, 82184, 18406, 18414, 82192, 84033, 18623, 84041, 83547, 84034, 18625, 84042, 
83550, 83524, 18607, 18624, 83549
30113, 82184, 18406, 18414, 82192, 18123, 2565, 2566, 18124, 84034, 18625, 84042, 83550, 18280, 2588, 18281, 
18239, 83527, 18609, 18626, 83552
30114, 17901, 2514, 2515, 17902, 82185, 18407, 18415, 82193, 18058, 2537, 18059, 18019, 84035, 18628, 84043, 
83554, 83528, 18610, 18627, 83553
30115, 82185, 18407, 18415, 82193, 82186, 18408, 18416, 82194, 84035, 18628, 84043, 83554, 84036, 18630, 84044, 
83557, 83531, 18612, 18629, 83556
30116, 82186, 18408, 18416, 82194, 82187, 18409, 18417, 82195, 84036, 18630, 84044, 83557, 84037, 18632, 84045, 
83560, 83534, 18614, 18631, 83559
30117, 82187, 18409, 18417, 82195, 82188, 18410, 18418, 82196, 84037, 18632, 84045, 83560, 84038, 18634, 84046, 
83563, 83537, 18616, 18633, 83562
30118, 82188, 18410, 18418, 82196, 82189, 18411, 18419, 82197, 84038, 18634, 84046, 83563, 84039, 18636, 84047, 
83566, 83540, 18618, 18635, 83565
30119, 82189, 18411, 18419, 82197, 82190, 18412, 18420, 82198, 84039, 18636, 84047, 83566, 84040, 18638, 84048, 
83569, 83543, 18620, 18637, 83568
30120, 82190, 18412, 18420, 82198, 82191, 18413, 18421, 82199, 84040, 18638, 84048, 83569, 84041, 18640, 84049, 
83572, 83546, 18622, 18639, 83571
30121, 82191, 18413, 18421, 82199, 82192, 18414, 18422, 82200, 84041, 18640, 84049, 83572, 84042, 18642, 84050, 
83575, 83549, 18624, 18641, 83574
30122, 82192, 18414, 18422, 82200, 18124, 2566, 2567, 18125, 84042, 18642, 84050, 83575, 18281, 2589, 18282, 
18241, 83552, 18626, 18643, 83577
30123, 17902, 2515, 2516, 17903, 82193, 18415, 18423, 82201, 18059, 2538, 18060, 18021, 84043, 18645, 84051, 
83579, 83553, 18627, 18644, 83578
30124, 82193, 18415, 18423, 82201, 82194, 18416, 18424, 82202, 84043, 18645, 84051, 83579, 84044, 18647, 84052, 
83582, 83556, 18629, 18646, 83581
30125, 82194, 18416, 18424, 82202, 82195, 18417, 18425, 82203, 84044, 18647, 84052, 83582, 84045, 18649, 84053, 
83585, 83559, 18631, 18648, 83584
30126, 82195, 18417, 18425, 82203, 82196, 18418, 18426, 82204, 84045, 18649, 84053, 83585, 84046, 18651, 84054, 
83588, 83562, 18633, 18650, 83587
30127, 82196, 18418, 18426, 82204, 82197, 18419, 18427, 82205, 84046, 18651, 84054, 83588, 84047, 18653, 84055, 
83591, 83565, 18635, 18652, 83590
30128, 82197, 18419, 18427, 82205, 82198, 18420, 18428, 82206, 84047, 18653, 84055, 83591, 84048, 18655, 84056, 
83594, 83568, 18637, 18654, 83593
30129, 82198, 18420, 18428, 82206, 82199, 18421, 18429, 82207, 84048, 18655, 84056, 83594, 84049, 18657, 84057, 
83597, 83571, 18639, 18656, 83596
30130, 82199, 18421, 18429, 82207, 82200, 18422, 18430, 82208, 84049, 18657, 84057, 83597, 84050, 18659, 84058, 
83600, 83574, 18641, 18658, 83599
30131, 82200, 18422, 18430, 82208, 18125, 2567, 2568, 18126, 84050, 18659, 84058, 83600, 18282, 2590, 18283, 
18243, 83577, 18643, 18660, 83602
30132, 17903, 2516, 2517, 17904, 82201, 18423, 18431, 82209, 18060, 2539, 18061, 18023, 84051, 18662, 84059, 
83604, 83578, 18644, 18661, 83603
30133, 82201, 18423, 18431, 82209, 82202, 18424, 18432, 82210, 84051, 18662, 84059, 83604, 84052, 18664, 84060, 
83607, 83581, 18646, 18663, 83606
30134, 82202, 18424, 18432, 82210, 82203, 18425, 18433, 82211, 84052, 18664, 84060, 83607, 84053, 18666, 84061, 
83610, 83584, 18648, 18665, 83609
30135, 82203, 18425, 18433, 82211, 82204, 18426, 18434, 82212, 84053, 18666, 84061, 83610, 84054, 18668, 84062, 
83613, 83587, 18650, 18667, 83612
30136, 82204, 18426, 18434, 82212, 82205, 18427, 18435, 82213, 84054, 18668, 84062, 83613, 84055, 18670, 84063, 
83616, 83590, 18652, 18669, 83615
30137, 82205, 18427, 18435, 82213, 82206, 18428, 18436, 82214, 84055, 18670, 84063, 83616, 84056, 18672, 84064, 
83619, 83593, 18654, 18671, 83618
30138, 82206, 18428, 18436, 82214, 82207, 18429, 18437, 82215, 84056, 18672, 84064, 83619, 84057, 18674, 84065, 
83622, 83596, 18656, 18673, 83621
30139, 82207, 18429, 18437, 82215, 82208, 18430, 18438, 82216, 84057, 18674, 84065, 83622, 84058, 18676, 84066, 
83625, 83599, 18658, 18675, 83624
30140, 82208, 18430, 18438, 82216, 18126, 2568, 2569, 18127, 84058, 18676, 84066, 83625, 18283, 2591, 18284, 
18245, 83602, 18660, 18677, 83627
30141, 17904, 2517, 2518, 17905, 82209, 18431, 18439, 82217, 18061, 2540, 18062, 18025, 84059, 18679, 84067, 
83629, 83603, 18661, 18678, 83628
30142, 82209, 18431, 18439, 82217, 82210, 18432, 18440, 82218, 84059, 18679, 84067, 83629, 84060, 18681, 84068, 
83632, 83606, 18663, 18680, 83631
30143, 82210, 18432, 18440, 82218, 82211, 18433, 18441, 82219, 84060, 18681, 84068, 83632, 84061, 18683, 84069, 
83635, 83609, 18665, 18682, 83634
30144, 82211, 18433, 18441, 82219, 82212, 18434, 18442, 82220, 84061, 18683, 84069, 83635, 84062, 18685, 84070, 
83638, 83612, 18667, 18684, 83637
30145, 82212, 18434, 18442, 82220, 82213, 18435, 18443, 82221, 84062, 18685, 84070, 83638, 84063, 18687, 84071, 
83641, 83615, 18669, 18686, 83640
30146, 82213, 18435, 18443, 82221, 82214, 18436, 18444, 82222, 84063, 18687, 84071, 83641, 84064, 18689, 84072, 
83644, 83618, 18671, 18688, 83643
30147, 82214, 18436, 18444, 82222, 82215, 18437, 18445, 82223, 84064, 18689, 84072, 83644, 84065, 18691, 84073, 
83647, 83621, 18673, 18690, 83646
30148, 82215, 18437, 18445, 82223, 82216, 18438, 18446, 82224, 84065, 18691, 84073, 83647, 84066, 18693, 84074, 
83650, 83624, 18675, 18692, 83649
30149, 82216, 18438, 18446, 82224, 18127, 2569, 2570, 18128, 84066, 18693, 84074, 83650, 18284, 2592, 18285, 
18247, 83627, 18677, 18694, 83652
30150, 17905, 2518, 2519, 17906, 82217, 18439, 18447, 82225, 18062, 2541, 18063, 18027, 84067, 18696, 84075, 
83654, 83628, 18678, 18695, 83653
30151, 82217, 18439, 18447, 82225, 82218, 18440, 18448, 82226, 84067, 18696, 84075, 83654, 84068, 18698, 84076, 
83657, 83631, 18680, 18697, 83656
30152, 82218, 18440, 18448, 82226, 82219, 18441, 18449, 82227, 84068, 18698, 84076, 83657, 84069, 18700, 84077, 
83660, 83634, 18682, 18699, 83659
30153, 82219, 18441, 18449, 82227, 82220, 18442, 18450, 82228, 84069, 18700, 84077, 83660, 84070, 18702, 84078, 
83663, 83637, 18684, 18701, 83662
30154, 82220, 18442, 18450, 82228, 82221, 18443, 18451, 82229, 84070, 18702, 84078, 83663, 84071, 18704, 84079, 
83666, 83640, 18686, 18703, 83665
30155, 82221, 18443, 18451, 82229, 82222, 18444, 18452, 82230, 84071, 18704, 84079, 83666, 84072, 18706, 84080, 
83669, 83643, 18688, 18705, 83668
30156, 82222, 18444, 18452, 82230, 82223, 18445, 18453, 82231, 84072, 18706, 84080, 83669, 84073, 18708, 84081, 
83672, 83646, 18690, 18707, 83671
30157, 82223, 18445, 18453, 82231, 82224, 18446, 18454, 82232, 84073, 18708, 84081, 83672, 84074, 18710, 84082, 
83675, 83649, 18692, 18709, 83674
30158, 82224, 18446, 18454, 82232, 18128, 2570, 2571, 18129, 84074, 18710, 84082, 83675, 18285, 2593, 18286, 
18249, 83652, 18694, 18711, 83677
30159, 17906, 2519, 2520, 17907, 82225, 18447, 18455, 82233, 18063, 2542, 18064, 18029, 84075, 18713, 84083, 
83679, 83653, 18695, 18712, 83678
30160, 82225, 18447, 18455, 82233, 82226, 18448, 18456, 82234, 84075, 18713, 84083, 83679, 84076, 18715, 84084, 
83682, 83656, 18697, 18714, 83681
30161, 82226, 18448, 18456, 82234, 82227, 18449, 18457, 82235, 84076, 18715, 84084, 83682, 84077, 18717, 84085, 
83685, 83659, 18699, 18716, 83684
30162, 82227, 18449, 18457, 82235, 82228, 18450, 18458, 82236, 84077, 18717, 84085, 83685, 84078, 18719, 84086, 
83688, 83662, 18701, 18718, 83687
30163, 82228, 18450, 18458, 82236, 82229, 18451, 18459, 82237, 84078, 18719, 84086, 83688, 84079, 18721, 84087, 
83691, 83665, 18703, 18720, 83690
30164, 82229, 18451, 18459, 82237, 82230, 18452, 18460, 82238, 84079, 18721, 84087, 83691, 84080, 18723, 84088, 
83694, 83668, 18705, 18722, 83693
30165, 82230, 18452, 18460, 82238, 82231, 18453, 18461, 82239, 84080, 18723, 84088, 83694, 84081, 18725, 84089, 
83697, 83671, 18707, 18724, 83696
30166, 82231, 18453, 18461, 82239, 82232, 18454, 18462, 82240, 84081, 18725, 84089, 83697, 84082, 18727, 84090, 
83700, 83674, 18709, 18726, 83699
30167, 82232, 18454, 18462, 82240, 18129, 2571, 2572, 18130, 84082, 18727, 84090, 83700, 18286, 2594, 18287, 
18251, 83677, 18711, 18728, 83702
30168, 17907, 2520, 2521, 17908, 82233, 18455, 18463, 82241, 18064, 2543, 18065, 18031, 84083, 18730, 84091, 
83704, 83678, 18712, 18729, 83703
30169, 82233, 18455, 18463, 82241, 82234, 18456, 18464, 82242, 84083, 18730, 84091, 83704, 84084, 18732, 84092, 
83707, 83681, 18714, 18731, 83706
30170, 82234, 18456, 18464, 82242, 82235, 18457, 18465, 82243, 84084, 18732, 84092, 83707, 84085, 18734, 84093, 
83710, 83684, 18716, 18733, 83709
30171, 82235, 18457, 18465, 82243, 82236, 18458, 18466, 82244, 84085, 18734, 84093, 83710, 84086, 18736, 84094, 
83713, 83687, 18718, 18735, 83712
30172, 82236, 18458, 18466, 82244, 82237, 18459, 18467, 82245, 84086, 18736, 84094, 83713, 84087, 18738, 84095, 
83716, 83690, 18720, 18737, 83715
30173, 82237, 18459, 18467, 82245, 82238, 18460, 18468, 82246, 84087, 18738, 84095, 83716, 84088, 18740, 84096, 
83719, 83693, 18722, 18739, 83718
30174, 82238, 18460, 18468, 82246, 82239, 18461, 18469, 82247, 84088, 18740, 84096, 83719, 84089, 18742, 84097, 
83722, 83696, 18724, 18741, 83721
30175, 82239, 18461, 18469, 82247, 82240, 18462, 18470, 82248, 84089, 18742, 84097, 83722, 84090, 18744, 84098, 
83725, 83699, 18726, 18743, 83724
30176, 82240, 18462, 18470, 82248, 18130, 2572, 2573, 18131, 84090, 18744, 84098, 83725, 18287, 2595, 18288, 
18253, 83702, 18728, 18745, 83727
30177, 17908, 2521, 2522, 17909, 82241, 18463, 18471, 82249, 18065, 2544, 18066, 18033, 84091, 18747, 84099, 
83729, 83703, 18729, 18746, 83728
30178, 82241, 18463, 18471, 82249, 82242, 18464, 18472, 82250, 84091, 18747, 84099, 83729, 84092, 18749, 84100, 
83732, 83706, 18731, 18748, 83731
30179, 82242, 18464, 18472, 82250, 82243, 18465, 18473, 82251, 84092, 18749, 84100, 83732, 84093, 18751, 84101, 
83735, 83709, 18733, 18750, 83734
30180, 82243, 18465, 18473, 82251, 82244, 18466, 18474, 82252, 84093, 18751, 84101, 83735, 84094, 18753, 84102, 
83738, 83712, 18735, 18752, 83737
30181, 82244, 18466, 18474, 82252, 82245, 18467, 18475, 82253, 84094, 18753, 84102, 83738, 84095, 18755, 84103, 
83741, 83715, 18737, 18754, 83740
30182, 82245, 18467, 18475, 82253, 82246, 18468, 18476, 82254, 84095, 18755, 84103, 83741, 84096, 18757, 84104, 
83744, 83718, 18739, 18756, 83743
30183, 82246, 18468, 18476, 82254, 82247, 18469, 18477, 82255, 84096, 18757, 84104, 83744, 84097, 18759, 84105, 
83747, 83721, 18741, 18758, 83746
30184, 82247, 18469, 18477, 82255, 82248, 18470, 18478, 82256, 84097, 18759, 84105, 83747, 84098, 18761, 84106, 
83750, 83724, 18743, 18760, 83749
30185, 82248, 18470, 18478, 82256, 18131, 2573, 2574, 18132, 84098, 18761, 84106, 83750, 18288, 2596, 18289, 
18255, 83727, 18745, 18762, 83752
30186, 17909, 2522, 2523, 17910, 82249, 18471, 18479, 82257, 18066, 2545, 18067, 18035, 84099, 18764, 84107, 
83754, 83728, 18746, 18763, 83753
30187, 82249, 18471, 18479, 82257, 82250, 18472, 18480, 82258, 84099, 18764, 84107, 83754, 84100, 18766, 84108, 
83757, 83731, 18748, 18765, 83756
30188, 82250, 18472, 18480, 82258, 82251, 18473, 18481, 82259, 84100, 18766, 84108, 83757, 84101, 18768, 84109, 
83760, 83734, 18750, 18767, 83759
30189, 82251, 18473, 18481, 82259, 82252, 18474, 18482, 82260, 84101, 18768, 84109, 83760, 84102, 18770, 84110, 
83763, 83737, 18752, 18769, 83762
30190, 82252, 18474, 18482, 82260, 82253, 18475, 18483, 82261, 84102, 18770, 84110, 83763, 84103, 18772, 84111, 
83766, 83740, 18754, 18771, 83765
30191, 82253, 18475, 18483, 82261, 82254, 18476, 18484, 82262, 84103, 18772, 84111, 83766, 84104, 18774, 84112, 
83769, 83743, 18756, 18773, 83768
30192, 82254, 18476, 18484, 82262, 82255, 18477, 18485, 82263, 84104, 18774, 84112, 83769, 84105, 18776, 84113, 
83772, 83746, 18758, 18775, 83771
30193, 82255, 18477, 18485, 82263, 82256, 18478, 18486, 82264, 84105, 18776, 84113, 83772, 84106, 18778, 84114, 
83775, 83749, 18760, 18777, 83774
30194, 82256, 18478, 18486, 82264, 18132, 2574, 2575, 18133, 84106, 18778, 84114, 83775, 18289, 2597, 18290, 
18257, 83752, 18762, 18779, 83777
30195, 17910, 2523, 2524, 17911, 82257, 18479, 18487, 82265, 18067, 2546, 18068, 18037, 84107, 18781, 84115, 
83779, 83753, 18763, 18780, 83778
30196, 82257, 18479, 18487, 82265, 82258, 18480, 18488, 82266, 84107, 18781, 84115, 83779, 84108, 18783, 84116, 
83782, 83756, 18765, 18782, 83781
30197, 82258, 18480, 18488, 82266, 82259, 18481, 18489, 82267, 84108, 18783, 84116, 83782, 84109, 18785, 84117, 
83785, 83759, 18767, 18784, 83784
30198, 82259, 18481, 18489, 82267, 82260, 18482, 18490, 82268, 84109, 18785, 84117, 83785, 84110, 18787, 84118, 
83788, 83762, 18769, 18786, 83787
30199, 82260, 18482, 18490, 82268, 82261, 18483, 18491, 82269, 84110, 18787, 84118, 83788, 84111, 18789, 84119, 
83791, 83765, 18771, 18788, 83790
30200, 82261, 18483, 18491, 82269, 82262, 18484, 18492, 82270, 84111, 18789, 84119, 83791, 84112, 18791, 84120, 
83794, 83768, 18773, 18790, 83793
30201, 82262, 18484, 18492, 82270, 82263, 18485, 18493, 82271, 84112, 18791, 84120, 83794, 84113, 18793, 84121, 
83797, 83771, 18775, 18792, 83796
30202, 82263, 18485, 18493, 82271, 82264, 18486, 18494, 82272, 84113, 18793, 84121, 83797, 84114, 18795, 84122, 
83800, 83774, 18777, 18794, 83799
30203, 82264, 18486, 18494, 82272, 18133, 2575, 2576, 18134, 84114, 18795, 84122, 83800, 18290, 2598, 18291, 
18259, 83777, 18779, 18796, 83802
30204, 17911, 2524, 2525, 17912, 82265, 18487, 18495, 82273, 18068, 2547, 18069, 18039, 84115, 18798, 84123, 
83804, 83778, 18780, 18797, 83803
30205, 82265, 18487, 18495, 82273, 82266, 18488, 18496, 82274, 84115, 18798, 84123, 83804, 84116, 18800, 84124, 
83807, 83781, 18782, 18799, 83806
30206, 82266, 18488, 18496, 82274, 82267, 18489, 18497, 82275, 84116, 18800, 84124, 83807, 84117, 18802, 84125, 
83810, 83784, 18784, 18801, 83809
30207, 82267, 18489, 18497, 82275, 82268, 18490, 18498, 82276, 84117, 18802, 84125, 83810, 84118, 18804, 84126, 
83813, 83787, 18786, 18803, 83812
30208, 82268, 18490, 18498, 82276, 82269, 18491, 18499, 82277, 84118, 18804, 84126, 83813, 84119, 18806, 84127, 
83816, 83790, 18788, 18805, 83815
30209, 82269, 18491, 18499, 82277, 82270, 18492, 18500, 82278, 84119, 18806, 84127, 83816, 84120, 18808, 84128, 
83819, 83793, 18790, 18807, 83818
30210, 82270, 18492, 18500, 82278, 82271, 18493, 18501, 82279, 84120, 18808, 84128, 83819, 84121, 18810, 84129, 
83822, 83796, 18792, 18809, 83821
30211, 82271, 18493, 18501, 82279, 82272, 18494, 18502, 82280, 84121, 18810, 84129, 83822, 84122, 18812, 84130, 
83825, 83799, 18794, 18811, 83824
30212, 82272, 18494, 18502, 82280, 18134, 2576, 2577, 18135, 84122, 18812, 84130, 83825, 18291, 2599, 18292, 
18261, 83802, 18796, 18813, 83827
30213, 17912, 2525, 2526, 17913, 82273, 18495, 18503, 82281, 18069, 2548, 18070, 18041, 84123, 18815, 84131, 
83829, 83803, 18797, 18814, 83828
30214, 82273, 18495, 18503, 82281, 82274, 18496, 18504, 82282, 84123, 18815, 84131, 83829, 84124, 18817, 84132, 
83832, 83806, 18799, 18816, 83831
30215, 82274, 18496, 18504, 82282, 82275, 18497, 18505, 82283, 84124, 18817, 84132, 83832, 84125, 18819, 84133, 
83835, 83809, 18801, 18818, 83834
30216, 82275, 18497, 18505, 82283, 82276, 18498, 18506, 82284, 84125, 18819, 84133, 83835, 84126, 18821, 84134, 
83838, 83812, 18803, 18820, 83837
30217, 82276, 18498, 18506, 82284, 82277, 18499, 18507, 82285, 84126, 18821, 84134, 83838, 84127, 18823, 84135, 
83841, 83815, 18805, 18822, 83840
30218, 82277, 18499, 18507, 82285, 82278, 18500, 18508, 82286, 84127, 18823, 84135, 83841, 84128, 18825, 84136, 
83844, 83818, 18807, 18824, 83843
30219, 82278, 18500, 18508, 82286, 82279, 18501, 18509, 82287, 84128, 18825, 84136, 83844, 84129, 18827, 84137, 
83847, 83821, 18809, 18826, 83846
30220, 82279, 18501, 18509, 82287, 82280, 18502, 18510, 82288, 84129, 18827, 84137, 83847, 84130, 18829, 84138, 
83850, 83824, 18811, 18828, 83849
30221, 82280, 18502, 18510, 82288, 18135, 2577, 2578, 18136, 84130, 18829, 84138, 83850, 18292, 2600, 18293, 
18263, 83827, 18813, 18830, 83852
30222, 17913, 2526, 2527, 17914, 82281, 18503, 18511, 82289, 18070, 2549, 18071, 18043, 84131, 18832, 84139, 
83854, 83828, 18814, 18831, 83853
30223, 82281, 18503, 18511, 82289, 82282, 18504, 18512, 82290, 84131, 18832, 84139, 83854, 84132, 18834, 84140, 
83857, 83831, 18816, 18833, 83856
30224, 82282, 18504, 18512, 82290, 82283, 18505, 18513, 82291, 84132, 18834, 84140, 83857, 84133, 18836, 84141, 
83860, 83834, 18818, 18835, 83859
30225, 82283, 18505, 18513, 82291, 82284, 18506, 18514, 82292, 84133, 18836, 84141, 83860, 84134, 18838, 84142, 
83863, 83837, 18820, 18837, 83862
30226, 82284, 18506, 18514, 82292, 82285, 18507, 18515, 82293, 84134, 18838, 84142, 83863, 84135, 18840, 84143, 
83866, 83840, 18822, 18839, 83865
30227, 82285, 18507, 18515, 82293, 82286, 18508, 18516, 82294, 84135, 18840, 84143, 83866, 84136, 18842, 84144, 
83869, 83843, 18824, 18841, 83868
30228, 82286, 18508, 18516, 82294, 82287, 18509, 18517, 82295, 84136, 18842, 84144, 83869, 84137, 18844, 84145, 
83872, 83846, 18826, 18843, 83871
30229, 82287, 18509, 18517, 82295, 82288, 18510, 18518, 82296, 84137, 18844, 84145, 83872, 84138, 18846, 84146, 
83875, 83849, 18828, 18845, 83874
30230, 82288, 18510, 18518, 82296, 18136, 2578, 2579, 18137, 84138, 18846, 84146, 83875, 18293, 2601, 18294, 
18265, 83852, 18830, 18847, 83877
30231, 17914, 2527, 2528, 17915, 82289, 18511, 18519, 82297, 18071, 2550, 18072, 18045, 84139, 18849, 84147, 
83879, 83853, 18831, 18848, 83878
30232, 82289, 18511, 18519, 82297, 82290, 18512, 18520, 82298, 84139, 18849, 84147, 83879, 84140, 18851, 84148, 
83882, 83856, 18833, 18850, 83881
30233, 82290, 18512, 18520, 82298, 82291, 18513, 18521, 82299, 84140, 18851, 84148, 83882, 84141, 18853, 84149, 
83885, 83859, 18835, 18852, 83884
30234, 82291, 18513, 18521, 82299, 82292, 18514, 18522, 82300, 84141, 18853, 84149, 83885, 84142, 18855, 84150, 
83888, 83862, 18837, 18854, 83887
30235, 82292, 18514, 18522, 82300, 82293, 18515, 18523, 82301, 84142, 18855, 84150, 83888, 84143, 18857, 84151, 
83891, 83865, 18839, 18856, 83890
30236, 82293, 18515, 18523, 82301, 82294, 18516, 18524, 82302, 84143, 18857, 84151, 83891, 84144, 18859, 84152, 
83894, 83868, 18841, 18858, 83893
30237, 82294, 18516, 18524, 82302, 82295, 18517, 18525, 82303, 84144, 18859, 84152, 83894, 84145, 18861, 84153, 
83897, 83871, 18843, 18860, 83896
30238, 82295, 18517, 18525, 82303, 82296, 18518, 18526, 82304, 84145, 18861, 84153, 83897, 84146, 18863, 84154, 
83900, 83874, 18845, 18862, 83899
30239, 82296, 18518, 18526, 82304, 18137, 2579, 2580, 18138, 84146, 18863, 84154, 83900, 18294, 2602, 18295, 
18267, 83877, 18847, 18864, 83902
30240, 17915, 2528, 2529, 17916, 82297, 18519, 18527, 82305, 18072, 2551, 18073, 18047, 84147, 18866, 84155, 
83904, 83878, 18848, 18865, 83903
30241, 82297, 18519, 18527, 82305, 82298, 18520, 18528, 82306, 84147, 18866, 84155, 83904, 84148, 18868, 84156, 
83907, 83881, 18850, 18867, 83906
30242, 82298, 18520, 18528, 82306, 82299, 18521, 18529, 82307, 84148, 18868, 84156, 83907, 84149, 18870, 84157, 
83910, 83884, 18852, 18869, 83909
30243, 82299, 18521, 18529, 82307, 82300, 18522, 18530, 82308, 84149, 18870, 84157, 83910, 84150, 18872, 84158, 
83913, 83887, 18854, 18871, 83912
30244, 82300, 18522, 18530, 82308, 82301, 18523, 18531, 82309, 84150, 18872, 84158, 83913, 84151, 18874, 84159, 
83916, 83890, 18856, 18873, 83915
30245, 82301, 18523, 18531, 82309, 82302, 18524, 18532, 82310, 84151, 18874, 84159, 83916, 84152, 18876, 84160, 
83919, 83893, 18858, 18875, 83918
30246, 82302, 18524, 18532, 82310, 82303, 18525, 18533, 82311, 84152, 18876, 84160, 83919, 84153, 18878, 84161, 
83922, 83896, 18860, 18877, 83921
30247, 82303, 18525, 18533, 82311, 82304, 18526, 18534, 82312, 84153, 18878, 84161, 83922, 84154, 18880, 84162, 
83925, 83899, 18862, 18879, 83924
30248, 82304, 18526, 18534, 82312, 18138, 2580, 2581, 18139, 84154, 18880, 84162, 83925, 18295, 2603, 18296, 
18269, 83902, 18864, 18881, 83927
30249, 17916, 2529, 2530, 17917, 82305, 18527, 18535, 82313, 18073, 2552, 18074, 18049, 84155, 18883, 84163, 
83929, 83903, 18865, 18882, 83928
30250, 82305, 18527, 18535, 82313, 82306, 18528, 18536, 82314, 84155, 18883, 84163, 83929, 84156, 18885, 84164, 
83932, 83906, 18867, 18884, 83931
30251, 82306, 18528, 18536, 82314, 82307, 18529, 18537, 82315, 84156, 18885, 84164, 83932, 84157, 18887, 84165, 
83935, 83909, 18869, 18886, 83934
30252, 82307, 18529, 18537, 82315, 82308, 18530, 18538, 82316, 84157, 18887, 84165, 83935, 84158, 18889, 84166, 
83938, 83912, 18871, 18888, 83937
30253, 82308, 18530, 18538, 82316, 82309, 18531, 18539, 82317, 84158, 18889, 84166, 83938, 84159, 18891, 84167, 
83941, 83915, 18873, 18890, 83940
30254, 82309, 18531, 18539, 82317, 82310, 18532, 18540, 82318, 84159, 18891, 84167, 83941, 84160, 18893, 84168, 
83944, 83918, 18875, 18892, 83943
30255, 82310, 18532, 18540, 82318, 82311, 18533, 18541, 82319, 84160, 18893, 84168, 83944, 84161, 18895, 84169, 
83947, 83921, 18877, 18894, 83946
30256, 82311, 18533, 18541, 82319, 82312, 18534, 18542, 82320, 84161, 18895, 84169, 83947, 84162, 18897, 84170, 
83950, 83924, 18879, 18896, 83949
30257, 82312, 18534, 18542, 82320, 18139, 2581, 2582, 18140, 84162, 18897, 84170, 83950, 18296, 2604, 18297, 
18271, 83927, 18881, 18898, 83952
30258, 17917, 2530, 2531, 17918, 82313, 18535, 18543, 82321, 18074, 2553, 18075, 18051, 84163, 18900, 84171, 
83954, 83928, 18882, 18899, 83953
30259, 82313, 18535, 18543, 82321, 82314, 18536, 18544, 82322, 84163, 18900, 84171, 83954, 84164, 18902, 84172, 
83957, 83931, 18884, 18901, 83956
30260, 82314, 18536, 18544, 82322, 82315, 18537, 18545, 82323, 84164, 18902, 84172, 83957, 84165, 18904, 84173, 
83960, 83934, 18886, 18903, 83959
30261, 82315, 18537, 18545, 82323, 82316, 18538, 18546, 82324, 84165, 18904, 84173, 83960, 84166, 18906, 84174, 
83963, 83937, 18888, 18905, 83962
30262, 82316, 18538, 18546, 82324, 82317, 18539, 18547, 82325, 84166, 18906, 84174, 83963, 84167, 18908, 84175, 
83966, 83940, 18890, 18907, 83965
30263, 82317, 18539, 18547, 82325, 82318, 18540, 18548, 82326, 84167, 18908, 84175, 83966, 84168, 18910, 84176, 
83969, 83943, 18892, 18909, 83968
30264, 82318, 18540, 18548, 82326, 82319, 18541, 18549, 82327, 84168, 18910, 84176, 83969, 84169, 18912, 84177, 
83972, 83946, 18894, 18911, 83971
30265, 82319, 18541, 18549, 82327, 82320, 18542, 18550, 82328, 84169, 18912, 84177, 83972, 84170, 18914, 84178, 
83975, 83949, 18896, 18913, 83974
30266, 82320, 18542, 18550, 82328, 18140, 2582, 2583, 18141, 84170, 18914, 84178, 83975, 18297, 2605, 18298, 
18273, 83952, 18898, 18915, 83977
30267, 17918, 2531, 2532, 17919, 82321, 18543, 18551, 82329, 18075, 2554, 18076, 18053, 84171, 18917, 84179, 
83979, 83953, 18899, 18916, 83978
30268, 82321, 18543, 18551, 82329, 82322, 18544, 18552, 82330, 84171, 18917, 84179, 83979, 84172, 18919, 84180, 
83982, 83956, 18901, 18918, 83981
30269, 82322, 18544, 18552, 82330, 82323, 18545, 18553, 82331, 84172, 18919, 84180, 83982, 84173, 18921, 84181, 
83985, 83959, 18903, 18920, 83984
30270, 82323, 18545, 18553, 82331, 82324, 18546, 18554, 82332, 84173, 18921, 84181, 83985, 84174, 18923, 84182, 
83988, 83962, 18905, 18922, 83987
30271, 82324, 18546, 18554, 82332, 82325, 18547, 18555, 82333, 84174, 18923, 84182, 83988, 84175, 18925, 84183, 
83991, 83965, 18907, 18924, 83990
30272, 82325, 18547, 18555, 82333, 82326, 18548, 18556, 82334, 84175, 18925, 84183, 83991, 84176, 18927, 84184, 
83994, 83968, 18909, 18926, 83993
30273, 82326, 18548, 18556, 82334, 82327, 18549, 18557, 82335, 84176, 18927, 84184, 83994, 84177, 18929, 84185, 
83997, 83971, 18911, 18928, 83996
30274, 82327, 18549, 18557, 82335, 82328, 18550, 18558, 82336, 84177, 18929, 84185, 83997, 84178, 18931, 84186, 
84000, 83974, 18913, 18930, 83999
30275, 82328, 18550, 18558, 82336, 18141, 2583, 2584, 18142, 84178, 18931, 84186, 84000, 18298, 2606, 18299, 
18275, 83977, 18915, 18932, 84002
30276, 17919, 2532, 79, 2506, 82329, 18551, 2615, 18316, 18076, 2555, 2510, 18054, 84179, 18933, 18375, 
84003, 83978, 18916, 2624, 18359
30277, 82329, 18551, 2615, 18316, 82330, 18552, 2614, 18317, 84179, 18933, 18375, 84003, 84180, 18934, 18376, 
84004, 83981, 18918, 2623, 18361
30278, 82330, 18552, 2614, 18317, 82331, 18553, 2613, 18318, 84180, 18934, 18376, 84004, 84181, 18935, 18377, 
84005, 83984, 18920, 2622, 18363
30279, 82331, 18553, 2613, 18318, 82332, 18554, 2612, 18319, 84181, 18935, 18377, 84005, 84182, 18936, 18378, 
84006, 83987, 18922, 2621, 18365
30280, 82332, 18554, 2612, 18319, 82333, 18555, 2611, 18320, 84182, 18936, 18378, 84006, 84183, 18937, 18379, 
84007, 83990, 18924, 2620, 18367
30281, 82333, 18555, 2611, 18320, 82334, 18556, 2610, 18321, 84183, 18937, 18379, 84007, 84184, 18938, 18380, 
84008, 83993, 18926, 2619, 18369
30282, 82334, 18556, 2610, 18321, 82335, 18557, 2609, 18322, 84184, 18938, 18380, 84008, 84185, 18939, 18381, 
84009, 83996, 18928, 2618, 18371
30283, 82335, 18557, 2609, 18322, 82336, 18558, 2608, 18323, 84185, 18939, 18381, 84009, 84186, 18940, 18382, 
84010, 83999, 18930, 2617, 18373
30284, 82336, 18558, 2608, 18323, 18142, 2584, 80, 2558, 84186, 18940, 18382, 84010, 18299, 2607, 2562, 
18277, 84002, 18932, 2616, 18374
*ELEMENT, type=C3D20, ELSET=Volume23
30285, 7056, 749, 22, 590, 84187, 7286, 525, 5796, 7122, 752, 613, 7123, 84716, 7318, 6178, 
84717, 84715, 7319, 533, 6161
30286, 84187, 7286, 525, 5796, 84188, 7285, 526, 5797, 84716, 7318, 6178, 84717, 84719, 7316, 6179, 
84720, 84718, 7317, 534, 6163
30287, 84188, 7285, 526, 5797, 84189, 7284, 527, 5798, 84719, 7316, 6179, 84720, 84722, 7314, 6180, 
84723, 84721, 7315, 535, 6165
30288, 84189, 7284, 527, 5798, 84190, 7283, 528, 5799, 84722, 7314, 6180, 84723, 84725, 7312, 6181, 
84726, 84724, 7313, 536, 6167
30289, 84190, 7283, 528, 5799, 84191, 7282, 529, 5800, 84725, 7312, 6181, 84726, 84728, 7310, 6182, 
84729, 84727, 7311, 537, 6169
30290, 84191, 7282, 529, 5800, 84192, 7281, 530, 5801, 84728, 7310, 6182, 84729, 84731, 7308, 6183, 
84732, 84730, 7309, 538, 6171
30291, 84192, 7281, 530, 5801, 84193, 7280, 531, 5802, 84731, 7308, 6183, 84732, 84734, 7306, 6184, 
84735, 84733, 7307, 539, 6173
30292, 84193, 7280, 531, 5802, 84194, 7279, 532, 5803, 84734, 7306, 6184, 84735, 84737, 7304, 6185, 
84738, 84736, 7305, 540, 6175
30293, 84194, 7279, 532, 5803, 7362, 801, 21, 635, 84737, 7304, 6185, 84738, 7429, 804, 658, 
7428, 84739, 7303, 541, 6177
30294, 7057, 7056, 590, 589, 84195, 84187, 5796, 5788, 7124, 7123, 612, 7125, 84741, 84717, 6162, 
84742, 84740, 84715, 6161, 6144
30295, 84195, 84187, 5796, 5788, 84196, 84188, 5797, 5789, 84741, 84717, 6162, 84742, 84744, 84720, 6164, 
84745, 84743, 84718, 6163, 6146
30296, 84196, 84188, 5797, 5789, 84197, 84189, 5798, 5790, 84744, 84720, 6164, 84745, 84747, 84723, 6166, 
84748, 84746, 84721, 6165, 6148
30297, 84197, 84189, 5798, 5790, 84198, 84190, 5799, 5791, 84747, 84723, 6166, 84748, 84750, 84726, 6168, 
84751, 84749, 84724, 6167, 6150
30298, 84198, 84190, 5799, 5791, 84199, 84191, 5800, 5792, 84750, 84726, 6168, 84751, 84753, 84729, 6170, 
84754, 84752, 84727, 6169, 6152
30299, 84199, 84191, 5800, 5792, 84200, 84192, 5801, 5793, 84753, 84729, 6170, 84754, 84756, 84732, 6172, 
84757, 84755, 84730, 6171, 6154
30300, 84200, 84192, 5801, 5793, 84201, 84193, 5802, 5794, 84756, 84732, 6172, 84757, 84759, 84735, 6174, 
84760, 84758, 84733, 6173, 6156
30301, 84201, 84193, 5802, 5794, 84202, 84194, 5803, 5795, 84759, 84735, 6174, 84760, 84762, 84738, 6176, 
84763, 84761, 84736, 6175, 6158
30302, 84202, 84194, 5803, 5795, 7363, 7362, 635, 634, 84762, 84738, 6176, 84763, 7431, 7428, 657, 
7430, 84764, 84739, 6177, 6160
30303, 7058, 7057, 589, 588, 84203, 84195, 5788, 5780, 7126, 7125, 611, 7127, 84766, 84742, 6145, 
84767, 84765, 84740, 6144, 6127
30304, 84203, 84195, 5788, 5780, 84204, 84196, 5789, 5781, 84766, 84742, 6145, 84767, 84769, 84745, 6147, 
84770, 84768, 84743, 6146, 6129
30305, 84204, 84196, 5789, 5781, 84205, 84197, 5790, 5782, 84769, 84745, 6147, 84770, 84772, 84748, 6149, 
84773, 84771, 84746, 6148, 6131
30306, 84205, 84197, 5790, 5782, 84206, 84198, 5791, 5783, 84772, 84748, 6149, 84773, 84775, 84751, 6151, 
84776, 84774, 84749, 6150, 6133
30307, 84206, 84198, 5791, 5783, 84207, 84199, 5792, 5784, 84775, 84751, 6151, 84776, 84778, 84754, 6153, 
84779, 84777, 84752, 6152, 6135
30308, 84207, 84199, 5792, 5784, 84208, 84200, 5793, 5785, 84778, 84754, 6153, 84779, 84781, 84757, 6155, 
84782, 84780, 84755, 6154, 6137
30309, 84208, 84200, 5793, 5785, 84209, 84201, 5794, 5786, 84781, 84757, 6155, 84782, 84784, 84760, 6157, 
84785, 84783, 84758, 6156, 6139
30310, 84209, 84201, 5794, 5786, 84210, 84202, 5795, 5787, 84784, 84760, 6157, 84785, 84787, 84763, 6159, 
84788, 84786, 84761, 6158, 6141
30311, 84210, 84202, 5795, 5787, 7364, 7363, 634, 633, 84787, 84763, 6159, 84788, 7433, 7430, 656, 
7432, 84789, 84764, 6160, 6143
30312, 7059, 7058, 588, 587, 84211, 84203, 5780, 5772, 7128, 7127, 610, 7129, 84791, 84767, 6128, 
84792, 84790, 84765, 6127, 6110
30313, 84211, 84203, 5780, 5772, 84212, 84204, 5781, 5773, 84791, 84767, 6128, 84792, 84794, 84770, 6130, 
84795, 84793, 84768, 6129, 6112
30314, 84212, 84204, 5781, 5773, 84213, 84205, 5782, 5774, 84794, 84770, 6130, 84795, 84797, 84773, 6132, 
84798, 84796, 84771, 6131, 6114
30315, 84213, 84205, 5782, 5774, 84214, 84206, 5783, 5775, 84797, 84773, 6132, 84798, 84800, 84776, 6134, 
84801, 84799, 84774, 6133, 6116
30316, 84214, 84206, 5783, 5775, 84215, 84207, 5784, 5776, 84800, 84776, 6134, 84801, 84803, 84779, 6136, 
84804, 84802, 84777, 6135, 6118
30317, 84215, 84207, 5784, 5776, 84216, 84208, 5785, 5777, 84803, 84779, 6136, 84804, 84806, 84782, 6138, 
84807, 84805, 84780, 6137, 6120
30318, 84216, 84208, 5785, 5777, 84217, 84209, 5786, 5778, 84806, 84782, 6138, 84807, 84809, 84785, 6140, 
84810, 84808, 84783, 6139, 6122
30319, 84217, 84209, 5786, 5778, 84218, 84210, 5787, 5779, 84809, 84785, 6140, 84810, 84812, 84788, 6142, 
84813, 84811, 84786, 6141, 6124
30320, 84218, 84210, 5787, 5779, 7365, 7364, 633, 632, 84812, 84788, 6142, 84813, 7435, 7432, 655, 
7434, 84814, 84789, 6143, 6126
30321, 7060, 7059, 587, 586, 84219, 84211, 5772, 5764, 7130, 7129, 609, 7131, 84816, 84792, 6111, 
84817, 84815, 84790, 6110, 6093
30322, 84219, 84211, 5772, 5764, 84220, 84212, 5773, 5765, 84816, 84792, 6111, 84817, 84819, 84795, 6113, 
84820, 84818, 84793, 6112, 6095
30323, 84220, 84212, 5773, 5765, 84221, 84213, 5774, 5766, 84819, 84795, 6113, 84820, 84822, 84798, 6115, 
84823, 84821, 84796, 6114, 6097
30324, 84221, 84213, 5774, 5766, 84222, 84214, 5775, 5767, 84822, 84798, 6115, 84823, 84825, 84801, 6117, 
84826, 84824, 84799, 6116, 6099
30325, 84222, 84214, 5775, 5767, 84223, 84215, 5776, 5768, 84825, 84801, 6117, 84826, 84828, 84804, 6119, 
84829, 84827, 84802, 6118, 6101
30326, 84223, 84215, 5776, 5768, 84224, 84216, 5777, 5769, 84828, 84804, 6119, 84829, 84831, 84807, 6121, 
84832, 84830, 84805, 6120, 6103
30327, 84224, 84216, 5777, 5769, 84225, 84217, 5778, 5770, 84831, 84807, 6121, 84832, 84834, 84810, 6123, 
84835, 84833, 84808, 6122, 6105
30328, 84225, 84217, 5778, 5770, 84226, 84218, 5779, 5771, 84834, 84810, 6123, 84835, 84837, 84813, 6125, 
84838, 84836, 84811, 6124, 6107
30329, 84226, 84218, 5779, 5771, 7366, 7365, 632, 631, 84837, 84813, 6125, 84838, 7437, 7434, 654, 
7436, 84839, 84814, 6126, 6109
30330, 7061, 7060, 586, 585, 84227, 84219, 5764, 5756, 7132, 7131, 608, 7133, 84841, 84817, 6094, 
84842, 84840, 84815, 6093, 6076
30331, 84227, 84219, 5764, 5756, 84228, 84220, 5765, 5757, 84841, 84817, 6094, 84842, 84844, 84820, 6096, 
84845, 84843, 84818, 6095, 6078
30332, 84228, 84220, 5765, 5757, 84229, 84221, 5766, 5758, 84844, 84820, 6096, 84845, 84847, 84823, 6098, 
84848, 84846, 84821, 6097, 6080
30333, 84229, 84221, 5766, 5758, 84230, 84222, 5767, 5759, 84847, 84823, 6098, 84848, 84850, 84826, 6100, 
84851, 84849, 84824, 6099, 6082
30334, 84230, 84222, 5767, 5759, 84231, 84223, 5768, 5760, 84850, 84826, 6100, 84851, 84853, 84829, 6102, 
84854, 84852, 84827, 6101, 6084
30335, 84231, 84223, 5768, 5760, 84232, 84224, 5769, 5761, 84853, 84829, 6102, 84854, 84856, 84832, 6104, 
84857, 84855, 84830, 6103, 6086
30336, 84232, 84224, 5769, 5761, 84233, 84225, 5770, 5762, 84856, 84832, 6104, 84857, 84859, 84835, 6106, 
84860, 84858, 84833, 6105, 6088
30337, 84233, 84225, 5770, 5762, 84234, 84226, 5771, 5763, 84859, 84835, 6106, 84860, 84862, 84838, 6108, 
84863, 84861, 84836, 6107, 6090
30338, 84234, 84226, 5771, 5763, 7367, 7366, 631, 630, 84862, 84838, 6108, 84863, 7439, 7436, 653, 
7438, 84864, 84839, 6109, 6092
30339, 7062, 7061, 585, 584, 84235, 84227, 5756, 5748, 7134, 7133, 607, 7135, 84866, 84842, 6077, 
84867, 84865, 84840, 6076, 6059
30340, 84235, 84227, 5756, 5748, 84236, 84228, 5757, 5749, 84866, 84842, 6077, 84867, 84869, 84845, 6079, 
84870, 84868, 84843, 6078, 6061
30341, 84236, 84228, 5757, 5749, 84237, 84229, 5758, 5750, 84869, 84845, 6079, 84870, 84872, 84848, 6081, 
84873, 84871, 84846, 6080, 6063
30342, 84237, 84229, 5758, 5750, 84238, 84230, 5759, 5751, 84872, 84848, 6081, 84873, 84875, 84851, 6083, 
84876, 84874, 84849, 6082, 6065
30343, 84238, 84230, 5759, 5751, 84239, 84231, 5760, 5752, 84875, 84851, 6083, 84876, 84878, 84854, 6085, 
84879, 84877, 84852, 6084, 6067
30344, 84239, 84231, 5760, 5752, 84240, 84232, 5761, 5753, 84878, 84854, 6085, 84879, 84881, 84857, 6087, 
84882, 84880, 84855, 6086, 6069
30345, 84240, 84232, 5761, 5753, 84241, 84233, 5762, 5754, 84881, 84857, 6087, 84882, 84884, 84860, 6089, 
84885, 84883, 84858, 6088, 6071
30346, 84241, 84233, 5762, 5754, 84242, 84234, 5763, 5755, 84884, 84860, 6089, 84885, 84887, 84863, 6091, 
84888, 84886, 84861, 6090, 6073
30347, 84242, 84234, 5763, 5755, 7368, 7367, 630, 629, 84887, 84863, 6091, 84888, 7441, 7438, 652, 
7440, 84889, 84864, 6092, 6075
30348, 7063, 7062, 584, 583, 84243, 84235, 5748, 5740, 7136, 7135, 606, 7137, 84891, 84867, 6060, 
84892, 84890, 84865, 6059, 6042
30349, 84243, 84235, 5748, 5740, 84244, 84236, 5749, 5741, 84891, 84867, 6060, 84892, 84894, 84870, 6062, 
84895, 84893, 84868, 6061, 6044
30350, 84244, 84236, 5749, 5741, 84245, 84237, 5750, 5742, 84894, 84870, 6062, 84895, 84897, 84873, 6064, 
84898, 84896, 84871, 6063, 6046
30351, 84245, 84237, 5750, 5742, 84246, 84238, 5751, 5743, 84897, 84873, 6064, 84898, 84900, 84876, 6066, 
84901, 84899, 84874, 6065, 6048
30352, 84246, 84238, 5751, 5743, 84247, 84239, 5752, 5744, 84900, 84876, 6066, 84901, 84903, 84879, 6068, 
84904, 84902, 84877, 6067, 6050
30353, 84247, 84239, 5752, 5744, 84248, 84240, 5753, 5745, 84903, 84879, 6068, 84904, 84906, 84882, 6070, 
84907, 84905, 84880, 6069, 6052
30354, 84248, 84240, 5753, 5745, 84249, 84241, 5754, 5746, 84906, 84882, 6070, 84907, 84909, 84885, 6072, 
84910, 84908, 84883, 6071, 6054
30355, 84249, 84241, 5754, 5746, 84250, 84242, 5755, 5747, 84909, 84885, 6072, 84910, 84912, 84888, 6074, 
84913, 84911, 84886, 6073, 6056
30356, 84250, 84242, 5755, 5747, 7369, 7368, 629, 628, 84912, 84888, 6074, 84913, 7443, 7440, 651, 
7442, 84914, 84889, 6075, 6058
30357, 7064, 7063, 583, 582, 84251, 84243, 5740, 5732, 7138, 7137, 605, 7139, 84916, 84892, 6043, 
84917, 84915, 84890, 6042, 6025
30358, 84251, 84243, 5740, 5732, 84252, 84244, 5741, 5733, 84916, 84892, 6043, 84917, 84919, 84895, 6045, 
84920, 84918, 84893, 6044, 6027
30359, 84252, 84244, 5741, 5733, 84253, 84245, 5742, 5734, 84919, 84895, 6045, 84920, 84922, 84898, 6047, 
84923, 84921, 84896, 6046, 6029
30360, 84253, 84245, 5742, 5734, 84254, 84246, 5743, 5735, 84922, 84898, 6047, 84923, 84925, 84901, 6049, 
84926, 84924, 84899, 6048, 6031
30361, 84254, 84246, 5743, 5735, 84255, 84247, 5744, 5736, 84925, 84901, 6049, 84926, 84928, 84904, 6051, 
84929, 84927, 84902, 6050, 6033
30362, 84255, 84247, 5744, 5736, 84256, 84248, 5745, 5737, 84928, 84904, 6051, 84929, 84931, 84907, 6053, 
84932, 84930, 84905, 6052, 6035
30363, 84256, 84248, 5745, 5737, 84257, 84249, 5746, 5738, 84931, 84907, 6053, 84932, 84934, 84910, 6055, 
84935, 84933, 84908, 6054, 6037
30364, 84257, 84249, 5746, 5738, 84258, 84250, 5747, 5739, 84934, 84910, 6055, 84935, 84937, 84913, 6057, 
84938, 84936, 84911, 6056, 6039
30365, 84258, 84250, 5747, 5739, 7370, 7369, 628, 627, 84937, 84913, 6057, 84938, 7445, 7442, 650, 
7444, 84939, 84914, 6058, 6041
30366, 7065, 7064, 582, 581, 84259, 84251, 5732, 5724, 7140, 7139, 604, 7141, 84941, 84917, 6026, 
84942, 84940, 84915, 6025, 6008
30367, 84259, 84251, 5732, 5724, 84260, 84252, 5733, 5725, 84941, 84917, 6026, 84942, 84944, 84920, 6028, 
84945, 84943, 84918, 6027, 6010
30368, 84260, 84252, 5733, 5725, 84261, 84253, 5734, 5726, 84944, 84920, 6028, 84945, 84947, 84923, 6030, 
84948, 84946, 84921, 6029, 6012
30369, 84261, 84253, 5734, 5726, 84262, 84254, 5735, 5727, 84947, 84923, 6030, 84948, 84950, 84926, 6032, 
84951, 84949, 84924, 6031, 6014
30370, 84262, 84254, 5735, 5727, 84263, 84255, 5736, 5728, 84950, 84926, 6032, 84951, 84953, 84929, 6034, 
84954, 84952, 84927, 6033, 6016
30371, 84263, 84255, 5736, 5728, 84264, 84256, 5737, 5729, 84953, 84929, 6034, 84954, 84956, 84932, 6036, 
84957, 84955, 84930, 6035, 6018
30372, 84264, 84256, 5737, 5729, 84265, 84257, 5738, 5730, 84956, 84932, 6036, 84957, 84959, 84935, 6038, 
84960, 84958, 84933, 6037, 6020
30373, 84265, 84257, 5738, 5730, 84266, 84258, 5739, 5731, 84959, 84935, 6038, 84960, 84962, 84938, 6040, 
84963, 84961, 84936, 6039, 6022
30374, 84266, 84258, 5739, 5731, 7371, 7370, 627, 626, 84962, 84938, 6040, 84963, 7447, 7444, 649, 
7446, 84964, 84939, 6041, 6024
30375, 7066, 7065, 581, 580, 84267, 84259, 5724, 5716, 7142, 7141, 603, 7143, 84966, 84942, 6009, 
84967, 84965, 84940, 6008, 5991
30376, 84267, 84259, 5724, 5716, 84268, 84260, 5725, 5717, 84966, 84942, 6009, 84967, 84969, 84945, 6011, 
84970, 84968, 84943, 6010, 5993
30377, 84268, 84260, 5725, 5717, 84269, 84261, 5726, 5718, 84969, 84945, 6011, 84970, 84972, 84948, 6013, 
84973, 84971, 84946, 6012, 5995
30378, 84269, 84261, 5726, 5718, 84270, 84262, 5727, 5719, 84972, 84948, 6013, 84973, 84975, 84951, 6015, 
84976, 84974, 84949, 6014, 5997
30379, 84270, 84262, 5727, 5719, 84271, 84263, 5728, 5720, 84975, 84951, 6015, 84976, 84978, 84954, 6017, 
84979, 84977, 84952, 6016, 5999
30380, 84271, 84263, 5728, 5720, 84272, 84264, 5729, 5721, 84978, 84954, 6017, 84979, 84981, 84957, 6019, 
84982, 84980, 84955, 6018, 6001
30381, 84272, 84264, 5729, 5721, 84273, 84265, 5730, 5722, 84981, 84957, 6019, 84982, 84984, 84960, 6021, 
84985, 84983, 84958, 6020, 6003
30382, 84273, 84265, 5730, 5722, 84274, 84266, 5731, 5723, 84984, 84960, 6021, 84985, 84987, 84963, 6023, 
84988, 84986, 84961, 6022, 6005
30383, 84274, 84266, 5731, 5723, 7372, 7371, 626, 625, 84987, 84963, 6023, 84988, 7449, 7446, 648, 
7448, 84989, 84964, 6024, 6007
30384, 7067, 7066, 580, 579, 84275, 84267, 5716, 5708, 7144, 7143, 602, 7145, 84991, 84967, 5992, 
84992, 84990, 84965, 5991, 5974
30385, 84275, 84267, 5716, 5708, 84276, 84268, 5717, 5709, 84991, 84967, 5992, 84992, 84994, 84970, 5994, 
84995, 84993, 84968, 5993, 5976
30386, 84276, 84268, 5717, 5709, 84277, 84269, 5718, 5710, 84994, 84970, 5994, 84995, 84997, 84973, 5996, 
84998, 84996, 84971, 5995, 5978
30387, 84277, 84269, 5718, 5710, 84278, 84270, 5719, 5711, 84997, 84973, 5996, 84998, 85000, 84976, 5998, 
85001, 84999, 84974, 5997, 5980
30388, 84278, 84270, 5719, 5711, 84279, 84271, 5720, 5712, 85000, 84976, 5998, 85001, 85003, 84979, 6000, 
85004, 85002, 84977, 5999, 5982
30389, 84279, 84271, 5720, 5712, 84280, 84272, 5721, 5713, 85003, 84979, 6000, 85004, 85006, 84982, 6002, 
85007, 85005, 84980, 6001, 5984
30390, 84280, 84272, 5721, 5713, 84281, 84273, 5722, 5714, 85006, 84982, 6002, 85007, 85009, 84985, 6004, 
85010, 85008, 84983, 6003, 5986
30391, 84281, 84273, 5722, 5714, 84282, 84274, 5723, 5715, 85009, 84985, 6004, 85010, 85012, 84988, 6006, 
85013, 85011, 84986, 6005, 5988
30392, 84282, 84274, 5723, 5715, 7373, 7372, 625, 624, 85012, 84988, 6006, 85013, 7451, 7448, 647, 
7450, 85014, 84989, 6007, 5990
30393, 7068, 7067, 579, 578, 84283, 84275, 5708, 5700, 7146, 7145, 601, 7147, 85016, 84992, 5975, 
85017, 85015, 84990, 5974, 5957
30394, 84283, 84275, 5708, 5700, 84284, 84276, 5709, 5701, 85016, 84992, 5975, 85017, 85019, 84995, 5977, 
85020, 85018, 84993, 5976, 5959
30395, 84284, 84276, 5709, 5701, 84285, 84277, 5710, 5702, 85019, 84995, 5977, 85020, 85022, 84998, 5979, 
85023, 85021, 84996, 5978, 5961
30396, 84285, 84277, 5710, 5702, 84286, 84278, 5711, 5703, 85022, 84998, 5979, 85023, 85025, 85001, 5981, 
85026, 85024, 84999, 5980, 5963
30397, 84286, 84278, 5711, 5703, 84287, 84279, 5712, 5704, 85025, 85001, 5981, 85026, 85028, 85004, 5983, 
85029, 85027, 85002, 5982, 5965
30398, 84287, 84279, 5712, 5704, 84288, 84280, 5713, 5705, 85028, 85004, 5983, 85029, 85031, 85007, 5985, 
85032, 85030, 85005, 5984, 5967
30399, 84288, 84280, 5713, 5705, 84289, 84281, 5714, 5706, 85031, 85007, 5985, 85032, 85034, 85010, 5987, 
85035, 85033, 85008, 5986, 5969
30400, 84289, 84281, 5714, 5706, 84290, 84282, 5715, 5707, 85034, 85010, 5987, 85035, 85037, 85013, 5989, 
85038, 85036, 85011, 5988, 5971
30401, 84290, 84282, 5715, 5707, 7374, 7373, 624, 623, 85037, 85013, 5989, 85038, 7453, 7450, 646, 
7452, 85039, 85014, 5990, 5973
30402, 7069, 7068, 578, 577, 84291, 84283, 5700, 5692, 7148, 7147, 600, 7149, 85041, 85017, 5958, 
85042, 85040, 85015, 5957, 5940
30403, 84291, 84283, 5700, 5692, 84292, 84284, 5701, 5693, 85041, 85017, 5958, 85042, 85044, 85020, 5960, 
85045, 85043, 85018, 5959, 5942
30404, 84292, 84284, 5701, 5693, 84293, 84285, 5702, 5694, 85044, 85020, 5960, 85045, 85047, 85023, 5962, 
85048, 85046, 85021, 5961, 5944
30405, 84293, 84285, 5702, 5694, 84294, 84286, 5703, 5695, 85047, 85023, 5962, 85048, 85050, 85026, 5964, 
85051, 85049, 85024, 5963, 5946
30406, 84294, 84286, 5703, 5695, 84295, 84287, 5704, 5696, 85050, 85026, 5964, 85051, 85053, 85029, 5966, 
85054, 85052, 85027, 5965, 5948
30407, 84295, 84287, 5704, 5696, 84296, 84288, 5705, 5697, 85053, 85029, 5966, 85054, 85056, 85032, 5968, 
85057, 85055, 85030, 5967, 5950
30408, 84296, 84288, 5705, 5697, 84297, 84289, 5706, 5698, 85056, 85032, 5968, 85057, 85059, 85035, 5970, 
85060, 85058, 85033, 5969, 5952
30409, 84297, 84289, 5706, 5698, 84298, 84290, 5707, 5699, 85059, 85035, 5970, 85060, 85062, 85038, 5972, 
85063, 85061, 85036, 5971, 5954
30410, 84298, 84290, 5707, 5699, 7375, 7374, 623, 622, 85062, 85038, 5972, 85063, 7455, 7452, 645, 
7454, 85064, 85039, 5973, 5956
30411, 7070, 7069, 577, 576, 84299, 84291, 5692, 5684, 7150, 7149, 599, 7151, 85066, 85042, 5941, 
85067, 85065, 85040, 5940, 5923
30412, 84299, 84291, 5692, 5684, 84300, 84292, 5693, 5685, 85066, 85042, 5941, 85067, 85069, 85045, 5943, 
85070, 85068, 85043, 5942, 5925
30413, 84300, 84292, 5693, 5685, 84301, 84293, 5694, 5686, 85069, 85045, 5943, 85070, 85072, 85048, 5945, 
85073, 85071, 85046, 5944, 5927
30414, 84301, 84293, 5694, 5686, 84302, 84294, 5695, 5687, 85072, 85048, 5945, 85073, 85075, 85051, 5947, 
85076, 85074, 85049, 5946, 5929
30415, 84302, 84294, 5695, 5687, 84303, 84295, 5696, 5688, 85075, 85051, 5947, 85076, 85078, 85054, 5949, 
85079, 85077, 85052, 5948, 5931
30416, 84303, 84295, 5696, 5688, 84304, 84296, 5697, 5689, 85078, 85054, 5949, 85079, 85081, 85057, 5951, 
85082, 85080, 85055, 5950, 5933
30417, 84304, 84296, 5697, 5689, 84305, 84297, 5698, 5690, 85081, 85057, 5951, 85082, 85084, 85060, 5953, 
85085, 85083, 85058, 5952, 5935
30418, 84305, 84297, 5698, 5690, 84306, 84298, 5699, 5691, 85084, 85060, 5953, 85085, 85087, 85063, 5955, 
85088, 85086, 85061, 5954, 5937
30419, 84306, 84298, 5699, 5691, 7376, 7375, 622, 621, 85087, 85063, 5955, 85088, 7457, 7454, 644, 
7456, 85089, 85064, 5956, 5939
30420, 7071, 7070, 576, 575, 84307, 84299, 5684, 5676, 7152, 7151, 598, 7153, 85091, 85067, 5924, 
85092, 85090, 85065, 5923, 5906
30421, 84307, 84299, 5684, 5676, 84308, 84300, 5685, 5677, 85091, 85067, 5924, 85092, 85094, 85070, 5926, 
85095, 85093, 85068, 5925, 5908
30422, 84308, 84300, 5685, 5677, 84309, 84301, 5686, 5678, 85094, 85070, 5926, 85095, 85097, 85073, 5928, 
85098, 85096, 85071, 5927, 5910
30423, 84309, 84301, 5686, 5678, 84310, 84302, 5687, 5679, 85097, 85073, 5928, 85098, 85100, 85076, 5930, 
85101, 85099, 85074, 5929, 5912
30424, 84310, 84302, 5687, 5679, 84311, 84303, 5688, 5680, 85100, 85076, 5930, 85101, 85103, 85079, 5932, 
85104, 85102, 85077, 5931, 5914
30425, 84311, 84303, 5688, 5680, 84312, 84304, 5689, 5681, 85103, 85079, 5932, 85104, 85106, 85082, 5934, 
85107, 85105, 85080, 5933, 5916
30426, 84312, 84304, 5689, 5681, 84313, 84305, 5690, 5682, 85106, 85082, 5934, 85107, 85109, 85085, 5936, 
85110, 85108, 85083, 5935, 5918
30427, 84313, 84305, 5690, 5682, 84314, 84306, 5691, 5683, 85109, 85085, 5936, 85110, 85112, 85088, 5938, 
85113, 85111, 85086, 5937, 5920
30428, 84314, 84306, 5691, 5683, 7377, 7376, 621, 620, 85112, 85088, 5938, 85113, 7459, 7456, 643, 
7458, 85114, 85089, 5939, 5922
30429, 7072, 7071, 575, 574, 84315, 84307, 5676, 5668, 7154, 7153, 597, 7155, 85116, 85092, 5907, 
85117, 85115, 85090, 5906, 5889
30430, 84315, 84307, 5676, 5668, 84316, 84308, 5677, 5669, 85116, 85092, 5907, 85117, 85119, 85095, 5909, 
85120, 85118, 85093, 5908, 5891
30431, 84316, 84308, 5677, 5669, 84317, 84309, 5678, 5670, 85119, 85095, 5909, 85120, 85122, 85098, 5911, 
85123, 85121, 85096, 5910, 5893
30432, 84317, 84309, 5678, 5670, 84318, 84310, 5679, 5671, 85122, 85098, 5911, 85123, 85125, 85101, 5913, 
85126, 85124, 85099, 5912, 5895
30433, 84318, 84310, 5679, 5671, 84319, 84311, 5680, 5672, 85125, 85101, 5913, 85126, 85128, 85104, 5915, 
85129, 85127, 85102, 5914, 5897
30434, 84319, 84311, 5680, 5672, 84320, 84312, 5681, 5673, 85128, 85104, 5915, 85129, 85131, 85107, 5917, 
85132, 85130, 85105, 5916, 5899
30435, 84320, 84312, 5681, 5673, 84321, 84313, 5682, 5674, 85131, 85107, 5917, 85132, 85134, 85110, 5919, 
85135, 85133, 85108, 5918, 5901
30436, 84321, 84313, 5682, 5674, 84322, 84314, 5683, 5675, 85134, 85110, 5919, 85135, 85137, 85113, 5921, 
85138, 85136, 85111, 5920, 5903
30437, 84322, 84314, 5683, 5675, 7378, 7377, 620, 619, 85137, 85113, 5921, 85138, 7461, 7458, 642, 
7460, 85139, 85114, 5922, 5905
30438, 7073, 7072, 574, 573, 84323, 84315, 5668, 5660, 7156, 7155, 596, 7157, 85141, 85117, 5890, 
85142, 85140, 85115, 5889, 5872
30439, 84323, 84315, 5668, 5660, 84324, 84316, 5669, 5661, 85141, 85117, 5890, 85142, 85144, 85120, 5892, 
85145, 85143, 85118, 5891, 5874
30440, 84324, 84316, 5669, 5661, 84325, 84317, 5670, 5662, 85144, 85120, 5892, 85145, 85147, 85123, 5894, 
85148, 85146, 85121, 5893, 5876
30441, 84325, 84317, 5670, 5662, 84326, 84318, 5671, 5663, 85147, 85123, 5894, 85148, 85150, 85126, 5896, 
85151, 85149, 85124, 5895, 5878
30442, 84326, 84318, 5671, 5663, 84327, 84319, 5672, 5664, 85150, 85126, 5896, 85151, 85153, 85129, 5898, 
85154, 85152, 85127, 5897, 5880
30443, 84327, 84319, 5672, 5664, 84328, 84320, 5673, 5665, 85153, 85129, 5898, 85154, 85156, 85132, 5900, 
85157, 85155, 85130, 5899, 5882
30444, 84328, 84320, 5673, 5665, 84329, 84321, 5674, 5666, 85156, 85132, 5900, 85157, 85159, 85135, 5902, 
85160, 85158, 85133, 5901, 5884
30445, 84329, 84321, 5674, 5666, 84330, 84322, 5675, 5667, 85159, 85135, 5902, 85160, 85162, 85138, 5904, 
85163, 85161, 85136, 5903, 5886
30446, 84330, 84322, 5675, 5667, 7379, 7378, 619, 618, 85162, 85138, 5904, 85163, 7463, 7460, 641, 
7462, 85164, 85139, 5905, 5888
30447, 7074, 7073, 573, 572, 84331, 84323, 5660, 5652, 7158, 7157, 595, 7159, 85166, 85142, 5873, 
85167, 85165, 85140, 5872, 5855
30448, 84331, 84323, 5660, 5652, 84332, 84324, 5661, 5653, 85166, 85142, 5873, 85167, 85169, 85145, 5875, 
85170, 85168, 85143, 5874, 5857
30449, 84332, 84324, 5661, 5653, 84333, 84325, 5662, 5654, 85169, 85145, 5875, 85170, 85172, 85148, 5877, 
85173, 85171, 85146, 5876, 5859
30450, 84333, 84325, 5662, 5654, 84334, 84326, 5663, 5655, 85172, 85148, 5877, 85173, 85175, 85151, 5879, 
85176, 85174, 85149, 5878, 5861
30451, 84334, 84326, 5663, 5655, 84335, 84327, 5664, 5656, 85175, 85151, 5879, 85176, 85178, 85154, 5881, 
85179, 85177, 85152, 5880, 5863
30452, 84335, 84327, 5664, 5656, 84336, 84328, 5665, 5657, 85178, 85154, 5881, 85179, 85181, 85157, 5883, 
85182, 85180, 85155, 5882, 5865
30453, 84336, 84328, 5665, 5657, 84337, 84329, 5666, 5658, 85181, 85157, 5883, 85182, 85184, 85160, 5885, 
85185, 85183, 85158, 5884, 5867
30454, 84337, 84329, 5666, 5658, 84338, 84330, 5667, 5659, 85184, 85160, 5885, 85185, 85187, 85163, 5887, 
85188, 85186, 85161, 5886, 5869
30455, 84338, 84330, 5667, 5659, 7380, 7379, 618, 617, 85187, 85163, 5887, 85188, 7465, 7462, 640, 
7464, 85189, 85164, 5888, 5871
30456, 7075, 7074, 572, 571, 84339, 84331, 5652, 5644, 7160, 7159, 594, 7161, 85191, 85167, 5856, 
85192, 85190, 85165, 5855, 5838
30457, 84339, 84331, 5652, 5644, 84340, 84332, 5653, 5645, 85191, 85167, 5856, 85192, 85194, 85170, 5858, 
85195, 85193, 85168, 5857, 5840
30458, 84340, 84332, 5653, 5645, 84341, 84333, 5654, 5646, 85194, 85170, 5858, 85195, 85197, 85173, 5860, 
85198, 85196, 85171, 5859, 5842
30459, 84341, 84333, 5654, 5646, 84342, 84334, 5655, 5647, 85197, 85173, 5860, 85198, 85200, 85176, 5862, 
85201, 85199, 85174, 5861, 5844
30460, 84342, 84334, 5655, 5647, 84343, 84335, 5656, 5648, 85200, 85176, 5862, 85201, 85203, 85179, 5864, 
85204, 85202, 85177, 5863, 5846
30461, 84343, 84335, 5656, 5648, 84344, 84336, 5657, 5649, 85203, 85179, 5864, 85204, 85206, 85182, 5866, 
85207, 85205, 85180, 5865, 5848
30462, 84344, 84336, 5657, 5649, 84345, 84337, 5658, 5650, 85206, 85182, 5866, 85207, 85209, 85185, 5868, 
85210, 85208, 85183, 5867, 5850
30463, 84345, 84337, 5658, 5650, 84346, 84338, 5659, 5651, 85209, 85185, 5868, 85210, 85212, 85188, 5870, 
85213, 85211, 85186, 5869, 5852
30464, 84346, 84338, 5659, 5651, 7381, 7380, 617, 616, 85212, 85188, 5870, 85213, 7467, 7464, 639, 
7466, 85214, 85189, 5871, 5854
30465, 7076, 7075, 571, 570, 84347, 84339, 5644, 5636, 7162, 7161, 593, 7163, 85216, 85192, 5839, 
85217, 85215, 85190, 5838, 5821
30466, 84347, 84339, 5644, 5636, 84348, 84340, 5645, 5637, 85216, 85192, 5839, 85217, 85219, 85195, 5841, 
85220, 85218, 85193, 5840, 5823
30467, 84348, 84340, 5645, 5637, 84349, 84341, 5646, 5638, 85219, 85195, 5841, 85220, 85222, 85198, 5843, 
85223, 85221, 85196, 5842, 5825
30468, 84349, 84341, 5646, 5638, 84350, 84342, 5647, 5639, 85222, 85198, 5843, 85223, 85225, 85201, 5845, 
85226, 85224, 85199, 5844, 5827
30469, 84350, 84342, 5647, 5639, 84351, 84343, 5648, 5640, 85225, 85201, 5845, 85226, 85228, 85204, 5847, 
85229, 85227, 85202, 5846, 5829
30470, 84351, 84343, 5648, 5640, 84352, 84344, 5649, 5641, 85228, 85204, 5847, 85229, 85231, 85207, 5849, 
85232, 85230, 85205, 5848, 5831
30471, 84352, 84344, 5649, 5641, 84353, 84345, 5650, 5642, 85231, 85207, 5849, 85232, 85234, 85210, 5851, 
85235, 85233, 85208, 5850, 5833
30472, 84353, 84345, 5650, 5642, 84354, 84346, 5651, 5643, 85234, 85210, 5851, 85235, 85237, 85213, 5853, 
85238, 85236, 85211, 5852, 5835
30473, 84354, 84346, 5651, 5643, 7382, 7381, 616, 615, 85237, 85213, 5853, 85238, 7469, 7466, 638, 
7468, 85239, 85214, 5854, 5837
30474, 7077, 7076, 570, 569, 84355, 84347, 5636, 5628, 7164, 7163, 592, 7165, 85241, 85217, 5822, 
85242, 85240, 85215, 5821, 5804
30475, 84355, 84347, 5636, 5628, 84356, 84348, 5637, 5629, 85241, 85217, 5822, 85242, 85244, 85220, 5824, 
85245, 85243, 85218, 5823, 5806
30476, 84356, 84348, 5637, 5629, 84357, 84349, 5638, 5630, 85244, 85220, 5824, 85245, 85247, 85223, 5826, 
85248, 85246, 85221, 5825, 5808
30477, 84357, 84349, 5638, 5630, 84358, 84350, 5639, 5631, 85247, 85223, 5826, 85248, 85250, 85226, 5828, 
85251, 85249, 85224, 5827, 5810
30478, 84358, 84350, 5639, 5631, 84359, 84351, 5640, 5632, 85250, 85226, 5828, 85251, 85253, 85229, 5830, 
85254, 85252, 85227, 5829, 5812
30479, 84359, 84351, 5640, 5632, 84360, 84352, 5641, 5633, 85253, 85229, 5830, 85254, 85256, 85232, 5832, 
85257, 85255, 85230, 5831, 5814
30480, 84360, 84352, 5641, 5633, 84361, 84353, 5642, 5634, 85256, 85232, 5832, 85257, 85259, 85235, 5834, 
85260, 85258, 85233, 5833, 5816
30481, 84361, 84353, 5642, 5634, 84362, 84354, 5643, 5635, 85259, 85235, 5834, 85260, 85262, 85238, 5836, 
85263, 85261, 85236, 5835, 5818
30482, 84362, 84354, 5643, 5635, 7383, 7382, 615, 614, 85262, 85238, 5836, 85263, 7471, 7468, 637, 
7470, 85264, 85239, 5837, 5820
30483, 474, 7077, 569, 13, 5378, 84355, 5628, 376, 7166, 7165, 591, 477, 85265, 85242, 5805, 
5410, 5411, 85240, 5804, 384
30484, 5378, 84355, 5628, 376, 5377, 84356, 5629, 377, 85265, 85242, 5805, 5410, 85266, 85245, 5807, 
5408, 5409, 85243, 5806, 385
30485, 5377, 84356, 5629, 377, 5376, 84357, 5630, 378, 85266, 85245, 5807, 5408, 85267, 85248, 5809, 
5406, 5407, 85246, 5808, 386
30486, 5376, 84357, 5630, 378, 5375, 84358, 5631, 379, 85267, 85248, 5809, 5406, 85268, 85251, 5811, 
5404, 5405, 85249, 5810, 387
30487, 5375, 84358, 5631, 379, 5374, 84359, 5632, 380, 85268, 85251, 5811, 5404, 85269, 85254, 5813, 
5402, 5403, 85252, 5812, 388
30488, 5374, 84359, 5632, 380, 5373, 84360, 5633, 381, 85269, 85254, 5813, 5402, 85270, 85257, 5815, 
5400, 5401, 85255, 5814, 389
30489, 5373, 84360, 5633, 381, 5372, 84361, 5634, 382, 85270, 85257, 5815, 5400, 85271, 85260, 5817, 
5398, 5399, 85258, 5816, 390
30490, 5372, 84361, 5634, 382, 5371, 84362, 5635, 383, 85271, 85260, 5817, 5398, 85272, 85263, 5819, 
5396, 5397, 85261, 5818, 391
30491, 5371, 84362, 5635, 383, 457, 7383, 614, 11, 85272, 85263, 5819, 5396, 7472, 7470, 636, 
460, 5395, 85264, 5820, 392
30492, 7078, 750, 749, 7056, 84363, 7294, 7286, 84187, 7167, 753, 7122, 7168, 85274, 7335, 84716, 
85275, 85273, 7336, 7319, 84715
30493, 84363, 7294, 7286, 84187, 84364, 7293, 7285, 84188, 85274, 7335, 84716, 85275, 85277, 7333, 84719, 
85278, 85276, 7334, 7317, 84718
30494, 84364, 7293, 7285, 84188, 84365, 7292, 7284, 84189, 85277, 7333, 84719, 85278, 85280, 7331, 84722, 
85281, 85279, 7332, 7315, 84721
30495, 84365, 7292, 7284, 84189, 84366, 7291, 7283, 84190, 85280, 7331, 84722, 85281, 85283, 7329, 84725, 
85284, 85282, 7330, 7313, 84724
30496, 84366, 7291, 7283, 84190, 84367, 7290, 7282, 84191, 85283, 7329, 84725, 85284, 85286, 7327, 84728, 
85287, 85285, 7328, 7311, 84727
30497, 84367, 7290, 7282, 84191, 84368, 7289, 7281, 84192, 85286, 7327, 84728, 85287, 85289, 7325, 84731, 
85290, 85288, 7326, 7309, 84730
30498, 84368, 7289, 7281, 84192, 84369, 7288, 7280, 84193, 85289, 7325, 84731, 85290, 85292, 7323, 84734, 
85293, 85291, 7324, 7307, 84733
30499, 84369, 7288, 7280, 84193, 84370, 7287, 7279, 84194, 85292, 7323, 84734, 85293, 85295, 7321, 84737, 
85296, 85294, 7322, 7305, 84736
30500, 84370, 7287, 7279, 84194, 7384, 802, 801, 7362, 85295, 7321, 84737, 85296, 7474, 805, 7429, 
7473, 85297, 7320, 7303, 84739
30501, 7079, 7078, 7056, 7057, 84371, 84363, 84187, 84195, 7169, 7168, 7124, 7170, 85299, 85275, 84741, 
85300, 85298, 85273, 84715, 84740
30502, 84371, 84363, 84187, 84195, 84372, 84364, 84188, 84196, 85299, 85275, 84741, 85300, 85302, 85278, 84744, 
85303, 85301, 85276, 84718, 84743
30503, 84372, 84364, 84188, 84196, 84373, 84365, 84189, 84197, 85302, 85278, 84744, 85303, 85305, 85281, 84747, 
85306, 85304, 85279, 84721, 84746
30504, 84373, 84365, 84189, 84197, 84374, 84366, 84190, 84198, 85305, 85281, 84747, 85306, 85308, 85284, 84750, 
85309, 85307, 85282, 84724, 84749
30505, 84374, 84366, 84190, 84198, 84375, 84367, 84191, 84199, 85308, 85284, 84750, 85309, 85311, 85287, 84753, 
85312, 85310, 85285, 84727, 84752
30506, 84375, 84367, 84191, 84199, 84376, 84368, 84192, 84200, 85311, 85287, 84753, 85312, 85314, 85290, 84756, 
85315, 85313, 85288, 84730, 84755
30507, 84376, 84368, 84192, 84200, 84377, 84369, 84193, 84201, 85314, 85290, 84756, 85315, 85317, 85293, 84759, 
85318, 85316, 85291, 84733, 84758
30508, 84377, 84369, 84193, 84201, 84378, 84370, 84194, 84202, 85317, 85293, 84759, 85318, 85320, 85296, 84762, 
85321, 85319, 85294, 84736, 84761
30509, 84378, 84370, 84194, 84202, 7385, 7384, 7362, 7363, 85320, 85296, 84762, 85321, 7476, 7473, 7431, 
7475, 85322, 85297, 84739, 84764
30510, 7080, 7079, 7057, 7058, 84379, 84371, 84195, 84203, 7171, 7170, 7126, 7172, 85324, 85300, 84766, 
85325, 85323, 85298, 84740, 84765
30511, 84379, 84371, 84195, 84203, 84380, 84372, 84196, 84204, 85324, 85300, 84766, 85325, 85327, 85303, 84769, 
85328, 85326, 85301, 84743, 84768
30512, 84380, 84372, 84196, 84204, 84381, 84373, 84197, 84205, 85327, 85303, 84769, 85328, 85330, 85306, 84772, 
85331, 85329, 85304, 84746, 84771
30513, 84381, 84373, 84197, 84205, 84382, 84374, 84198, 84206, 85330, 85306, 84772, 85331, 85333, 85309, 84775, 
85334, 85332, 85307, 84749, 84774
30514, 84382, 84374, 84198, 84206, 84383, 84375, 84199, 84207, 85333, 85309, 84775, 85334, 85336, 85312, 84778, 
85337, 85335, 85310, 84752, 84777
30515, 84383, 84375, 84199, 84207, 84384, 84376, 84200, 84208, 85336, 85312, 84778, 85337, 85339, 85315, 84781, 
85340, 85338, 85313, 84755, 84780
30516, 84384, 84376, 84200, 84208, 84385, 84377, 84201, 84209, 85339, 85315, 84781, 85340, 85342, 85318, 84784, 
85343, 85341, 85316, 84758, 84783
30517, 84385, 84377, 84201, 84209, 84386, 84378, 84202, 84210, 85342, 85318, 84784, 85343, 85345, 85321, 84787, 
85346, 85344, 85319, 84761, 84786
30518, 84386, 84378, 84202, 84210, 7386, 7385, 7363, 7364, 85345, 85321, 84787, 85346, 7478, 7475, 7433, 
7477, 85347, 85322, 84764, 84789
30519, 7081, 7080, 7058, 7059, 84387, 84379, 84203, 84211, 7173, 7172, 7128, 7174, 85349, 85325, 84791, 
85350, 85348, 85323, 84765, 84790
30520, 84387, 84379, 84203, 84211, 84388, 84380, 84204, 84212, 85349, 85325, 84791, 85350, 85352, 85328, 84794, 
85353, 85351, 85326, 84768, 84793
30521, 84388, 84380, 84204, 84212, 84389, 84381, 84205, 84213, 85352, 85328, 84794, 85353, 85355, 85331, 84797, 
85356, 85354, 85329, 84771, 84796
30522, 84389, 84381, 84205, 84213, 84390, 84382, 84206, 84214, 85355, 85331, 84797, 85356, 85358, 85334, 84800, 
85359, 85357, 85332, 84774, 84799
30523, 84390, 84382, 84206, 84214, 84391, 84383, 84207, 84215, 85358, 85334, 84800, 85359, 85361, 85337, 84803, 
85362, 85360, 85335, 84777, 84802
30524, 84391, 84383, 84207, 84215, 84392, 84384, 84208, 84216, 85361, 85337, 84803, 85362, 85364, 85340, 84806, 
85365, 85363, 85338, 84780, 84805
30525, 84392, 84384, 84208, 84216, 84393, 84385, 84209, 84217, 85364, 85340, 84806, 85365, 85367, 85343, 84809, 
85368, 85366, 85341, 84783, 84808
30526, 84393, 84385, 84209, 84217, 84394, 84386, 84210, 84218, 85367, 85343, 84809, 85368, 85370, 85346, 84812, 
85371, 85369, 85344, 84786, 84811
30527, 84394, 84386, 84210, 84218, 7387, 7386, 7364, 7365, 85370, 85346, 84812, 85371, 7480, 7477, 7435, 
7479, 85372, 85347, 84789, 84814
30528, 7082, 7081, 7059, 7060, 84395, 84387, 84211, 84219, 7175, 7174, 7130, 7176, 85374, 85350, 84816, 
85375, 85373, 85348, 84790, 84815
30529, 84395, 84387, 84211, 84219, 84396, 84388, 84212, 84220, 85374, 85350, 84816, 85375, 85377, 85353, 84819, 
85378, 85376, 85351, 84793, 84818
30530, 84396, 84388, 84212, 84220, 84397, 84389, 84213, 84221, 85377, 85353, 84819, 85378, 85380, 85356, 84822, 
85381, 85379, 85354, 84796, 84821
30531, 84397, 84389, 84213, 84221, 84398, 84390, 84214, 84222, 85380, 85356, 84822, 85381, 85383, 85359, 84825, 
85384, 85382, 85357, 84799, 84824
30532, 84398, 84390, 84214, 84222, 84399, 84391, 84215, 84223, 85383, 85359, 84825, 85384, 85386, 85362, 84828, 
85387, 85385, 85360, 84802, 84827
30533, 84399, 84391, 84215, 84223, 84400, 84392, 84216, 84224, 85386, 85362, 84828, 85387, 85389, 85365, 84831, 
85390, 85388, 85363, 84805, 84830
30534, 84400, 84392, 84216, 84224, 84401, 84393, 84217, 84225, 85389, 85365, 84831, 85390, 85392, 85368, 84834, 
85393, 85391, 85366, 84808, 84833
30535, 84401, 84393, 84217, 84225, 84402, 84394, 84218, 84226, 85392, 85368, 84834, 85393, 85395, 85371, 84837, 
85396, 85394, 85369, 84811, 84836
30536, 84402, 84394, 84218, 84226, 7388, 7387, 7365, 7366, 85395, 85371, 84837, 85396, 7482, 7479, 7437, 
7481, 85397, 85372, 84814, 84839
30537, 7083, 7082, 7060, 7061, 84403, 84395, 84219, 84227, 7177, 7176, 7132, 7178, 85399, 85375, 84841, 
85400, 85398, 85373, 84815, 84840
30538, 84403, 84395, 84219, 84227, 84404, 84396, 84220, 84228, 85399, 85375, 84841, 85400, 85402, 85378, 84844, 
85403, 85401, 85376, 84818, 84843
30539, 84404, 84396, 84220, 84228, 84405, 84397, 84221, 84229, 85402, 85378, 84844, 85403, 85405, 85381, 84847, 
85406, 85404, 85379, 84821, 84846
30540, 84405, 84397, 84221, 84229, 84406, 84398, 84222, 84230, 85405, 85381, 84847, 85406, 85408, 85384, 84850, 
85409, 85407, 85382, 84824, 84849
30541, 84406, 84398, 84222, 84230, 84407, 84399, 84223, 84231, 85408, 85384, 84850, 85409, 85411, 85387, 84853, 
85412, 85410, 85385, 84827, 84852
30542, 84407, 84399, 84223, 84231, 84408, 84400, 84224, 84232, 85411, 85387, 84853, 85412, 85414, 85390, 84856, 
85415, 85413, 85388, 84830, 84855
30543, 84408, 84400, 84224, 84232, 84409, 84401, 84225, 84233, 85414, 85390, 84856, 85415, 85417, 85393, 84859, 
85418, 85416, 85391, 84833, 84858
30544, 84409, 84401, 84225, 84233, 84410, 84402, 84226, 84234, 85417, 85393, 84859, 85418, 85420, 85396, 84862, 
85421, 85419, 85394, 84836, 84861
30545, 84410, 84402, 84226, 84234, 7389, 7388, 7366, 7367, 85420, 85396, 84862, 85421, 7484, 7481, 7439, 
7483, 85422, 85397, 84839, 84864
30546, 7084, 7083, 7061, 7062, 84411, 84403, 84227, 84235, 7179, 7178, 7134, 7180, 85424, 85400, 84866, 
85425, 85423, 85398, 84840, 84865
30547, 84411, 84403, 84227, 84235, 84412, 84404, 84228, 84236, 85424, 85400, 84866, 85425, 85427, 85403, 84869, 
85428, 85426, 85401, 84843, 84868
30548, 84412, 84404, 84228, 84236, 84413, 84405, 84229, 84237, 85427, 85403, 84869, 85428, 85430, 85406, 84872, 
85431, 85429, 85404, 84846, 84871
30549, 84413, 84405, 84229, 84237, 84414, 84406, 84230, 84238, 85430, 85406, 84872, 85431, 85433, 85409, 84875, 
85434, 85432, 85407, 84849, 84874
30550, 84414, 84406, 84230, 84238, 84415, 84407, 84231, 84239, 85433, 85409, 84875, 85434, 85436, 85412, 84878, 
85437, 85435, 85410, 84852, 84877
30551, 84415, 84407, 84231, 84239, 84416, 84408, 84232, 84240, 85436, 85412, 84878, 85437, 85439, 85415, 84881, 
85440, 85438, 85413, 84855, 84880
30552, 84416, 84408, 84232, 84240, 84417, 84409, 84233, 84241, 85439, 85415, 84881, 85440, 85442, 85418, 84884, 
85443, 85441, 85416, 84858, 84883
30553, 84417, 84409, 84233, 84241, 84418, 84410, 84234, 84242, 85442, 85418, 84884, 85443, 85445, 85421, 84887, 
85446, 85444, 85419, 84861, 84886
30554, 84418, 84410, 84234, 84242, 7390, 7389, 7367, 7368, 85445, 85421, 84887, 85446, 7486, 7483, 7441, 
7485, 85447, 85422, 84864, 84889
30555, 7085, 7084, 7062, 7063, 84419, 84411, 84235, 84243, 7181, 7180, 7136, 7182, 85449, 85425, 84891, 
85450, 85448, 85423, 84865, 84890
30556, 84419, 84411, 84235, 84243, 84420, 84412, 84236, 84244, 85449, 85425, 84891, 85450, 85452, 85428, 84894, 
85453, 85451, 85426, 84868, 84893
30557, 84420, 84412, 84236, 84244, 84421, 84413, 84237, 84245, 85452, 85428, 84894, 85453, 85455, 85431, 84897, 
85456, 85454, 85429, 84871, 84896
30558, 84421, 84413, 84237, 84245, 84422, 84414, 84238, 84246, 85455, 85431, 84897, 85456, 85458, 85434, 84900, 
85459, 85457, 85432, 84874, 84899
30559, 84422, 84414, 84238, 84246, 84423, 84415, 84239, 84247, 85458, 85434, 84900, 85459, 85461, 85437, 84903, 
85462, 85460, 85435, 84877, 84902
30560, 84423, 84415, 84239, 84247, 84424, 84416, 84240, 84248, 85461, 85437, 84903, 85462, 85464, 85440, 84906, 
85465, 85463, 85438, 84880, 84905
30561, 84424, 84416, 84240, 84248, 84425, 84417, 84241, 84249, 85464, 85440, 84906, 85465, 85467, 85443, 84909, 
85468, 85466, 85441, 84883, 84908
30562, 84425, 84417, 84241, 84249, 84426, 84418, 84242, 84250, 85467, 85443, 84909, 85468, 85470, 85446, 84912, 
85471, 85469, 85444, 84886, 84911
30563, 84426, 84418, 84242, 84250, 7391, 7390, 7368, 7369, 85470, 85446, 84912, 85471, 7488, 7485, 7443, 
7487, 85472, 85447, 84889, 84914
30564, 7086, 7085, 7063, 7064, 84427, 84419, 84243, 84251, 7183, 7182, 7138, 7184, 85474, 85450, 84916, 
85475, 85473, 85448, 84890, 84915
30565, 84427, 84419, 84243, 84251, 84428, 84420, 84244, 84252, 85474, 85450, 84916, 85475, 85477, 85453, 84919, 
85478, 85476, 85451, 84893, 84918
30566, 84428, 84420, 84244, 84252, 84429, 84421, 84245, 84253, 85477, 85453, 84919, 85478, 85480, 85456, 84922, 
85481, 85479, 85454, 84896, 84921
30567, 84429, 84421, 84245, 84253, 84430, 84422, 84246, 84254, 85480, 85456, 84922, 85481, 85483, 85459, 84925, 
85484, 85482, 85457, 84899, 84924
30568, 84430, 84422, 84246, 84254, 84431, 84423, 84247, 84255, 85483, 85459, 84925, 85484, 85486, 85462, 84928, 
85487, 85485, 85460, 84902, 84927
30569, 84431, 84423, 84247, 84255, 84432, 84424, 84248, 84256, 85486, 85462, 84928, 85487, 85489, 85465, 84931, 
85490, 85488, 85463, 84905, 84930
30570, 84432, 84424, 84248, 84256, 84433, 84425, 84249, 84257, 85489, 85465, 84931, 85490, 85492, 85468, 84934, 
85493, 85491, 85466, 84908, 84933
30571, 84433, 84425, 84249, 84257, 84434, 84426, 84250, 84258, 85492, 85468, 84934, 85493, 85495, 85471, 84937, 
85496, 85494, 85469, 84911, 84936
30572, 84434, 84426, 84250, 84258, 7392, 7391, 7369, 7370, 85495, 85471, 84937, 85496, 7490, 7487, 7445, 
7489, 85497, 85472, 84914, 84939
30573, 7087, 7086, 7064, 7065, 84435, 84427, 84251, 84259, 7185, 7184, 7140, 7186, 85499, 85475, 84941, 
85500, 85498, 85473, 84915, 84940
30574, 84435, 84427, 84251, 84259, 84436, 84428, 84252, 84260, 85499, 85475, 84941, 85500, 85502, 85478, 84944, 
85503, 85501, 85476, 84918, 84943
30575, 84436, 84428, 84252, 84260, 84437, 84429, 84253, 84261, 85502, 85478, 84944, 85503, 85505, 85481, 84947, 
85506, 85504, 85479, 84921, 84946
30576, 84437, 84429, 84253, 84261, 84438, 84430, 84254, 84262, 85505, 85481, 84947, 85506, 85508, 85484, 84950, 
85509, 85507, 85482, 84924, 84949
30577, 84438, 84430, 84254, 84262, 84439, 84431, 84255, 84263, 85508, 85484, 84950, 85509, 85511, 85487, 84953, 
85512, 85510, 85485, 84927, 84952
30578, 84439, 84431, 84255, 84263, 84440, 84432, 84256, 84264, 85511, 85487, 84953, 85512, 85514, 85490, 84956, 
85515, 85513, 85488, 84930, 84955
30579, 84440, 84432, 84256, 84264, 84441, 84433, 84257, 84265, 85514, 85490, 84956, 85515, 85517, 85493, 84959, 
85518, 85516, 85491, 84933, 84958
30580, 84441, 84433, 84257, 84265, 84442, 84434, 84258, 84266, 85517, 85493, 84959, 85518, 85520, 85496, 84962, 
85521, 85519, 85494, 84936, 84961
30581, 84442, 84434, 84258, 84266, 7393, 7392, 7370, 7371, 85520, 85496, 84962, 85521, 7492, 7489, 7447, 
7491, 85522, 85497, 84939, 84964
30582, 7088, 7087, 7065, 7066, 84443, 84435, 84259, 84267, 7187, 7186, 7142, 7188, 85524, 85500, 84966, 
85525, 85523, 85498, 84940, 84965
30583, 84443, 84435, 84259, 84267, 84444, 84436, 84260, 84268, 85524, 85500, 84966, 85525, 85527, 85503, 84969, 
85528, 85526, 85501, 84943, 84968
30584, 84444, 84436, 84260, 84268, 84445, 84437, 84261, 84269, 85527, 85503, 84969, 85528, 85530, 85506, 84972, 
85531, 85529, 85504, 84946, 84971
30585, 84445, 84437, 84261, 84269, 84446, 84438, 84262, 84270, 85530, 85506, 84972, 85531, 85533, 85509, 84975, 
85534, 85532, 85507, 84949, 84974
30586, 84446, 84438, 84262, 84270, 84447, 84439, 84263, 84271, 85533, 85509, 84975, 85534, 85536, 85512, 84978, 
85537, 85535, 85510, 84952, 84977
30587, 84447, 84439, 84263, 84271, 84448, 84440, 84264, 84272, 85536, 85512, 84978, 85537, 85539, 85515, 84981, 
85540, 85538, 85513, 84955, 84980
30588, 84448, 84440, 84264, 84272, 84449, 84441, 84265, 84273, 85539, 85515, 84981, 85540, 85542, 85518, 84984, 
85543, 85541, 85516, 84958, 84983
30589, 84449, 84441, 84265, 84273, 84450, 84442, 84266, 84274, 85542, 85518, 84984, 85543, 85545, 85521, 84987, 
85546, 85544, 85519, 84961, 84986
30590, 84450, 84442, 84266, 84274, 7394, 7393, 7371, 7372, 85545, 85521, 84987, 85546, 7494, 7491, 7449, 
7493, 85547, 85522, 84964, 84989
30591, 7089, 7088, 7066, 7067, 84451, 84443, 84267, 84275, 7189, 7188, 7144, 7190, 85549, 85525, 84991, 
85550, 85548, 85523, 84965, 84990
30592, 84451, 84443, 84267, 84275, 84452, 84444, 84268, 84276, 85549, 85525, 84991, 85550, 85552, 85528, 84994, 
85553, 85551, 85526, 84968, 84993
30593, 84452, 84444, 84268, 84276, 84453, 84445, 84269, 84277, 85552, 85528, 84994, 85553, 85555, 85531, 84997, 
85556, 85554, 85529, 84971, 84996
30594, 84453, 84445, 84269, 84277, 84454, 84446, 84270, 84278, 85555, 85531, 84997, 85556, 85558, 85534, 85000, 
85559, 85557, 85532, 84974, 84999
30595, 84454, 84446, 84270, 84278, 84455, 84447, 84271, 84279, 85558, 85534, 85000, 85559, 85561, 85537, 85003, 
85562, 85560, 85535, 84977, 85002
30596, 84455, 84447, 84271, 84279, 84456, 84448, 84272, 84280, 85561, 85537, 85003, 85562, 85564, 85540, 85006, 
85565, 85563, 85538, 84980, 85005
30597, 84456, 84448, 84272, 84280, 84457, 84449, 84273, 84281, 85564, 85540, 85006, 85565, 85567, 85543, 85009, 
85568, 85566, 85541, 84983, 85008
30598, 84457, 84449, 84273, 84281, 84458, 84450, 84274, 84282, 85567, 85543, 85009, 85568, 85570, 85546, 85012, 
85571, 85569, 85544, 84986, 85011
30599, 84458, 84450, 84274, 84282, 7395, 7394, 7372, 7373, 85570, 85546, 85012, 85571, 7496, 7493, 7451, 
7495, 85572, 85547, 84989, 85014
30600, 7090, 7089, 7067, 7068, 84459, 84451, 84275, 84283, 7191, 7190, 7146, 7192, 85574, 85550, 85016, 
85575, 85573, 85548, 84990, 85015
