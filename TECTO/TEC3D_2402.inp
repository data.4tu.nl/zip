19888, 0.91304347826087, 0.1, 0.36111111111111
19889, 0.89130434782609, 0.1, 0.38888888888889
19890, 0.91304347826087, 0.1, 0.41666666666667
19891, 0.89130434782609, 0.1, 0.44444444444444
19892, 0.91304347826087, 0.1, 0.47222222222222
19893, 0.95652173913043, 0.1, 0.027777777777778
19894, 0.93478260869565, 0.1, 0.055555555555556
19895, 0.95652173913043, 0.1, 0.083333333333333
19896, 0.93478260869565, 0.1, 0.11111111111111
19897, 0.95652173913043, 0.1, 0.13888888888889
19898, 0.93478260869565, 0.1, 0.16666666666667
19899, 0.95652173913043, 0.1, 0.19444444444444
19900, 0.93478260869565, 0.1, 0.22222222222222
19901, 0.95652173913043, 0.1, 0.25
19902, 0.93478260869565, 0.1, 0.27777777777778
19903, 0.95652173913043, 0.1, 0.30555555555556
19904, 0.93478260869565, 0.1, 0.33333333333333
19905, 0.95652173913043, 0.1, 0.36111111111111
19906, 0.93478260869565, 0.1, 0.38888888888889
19907, 0.95652173913043, 0.1, 0.41666666666667
19908, 0.93478260869565, 0.1, 0.44444444444444
19909, 0.95652173913043, 0.1, 0.47222222222222
19910, 0.97826086956522, 0.1, 0.055555555555556
19911, 0.97826086956522, 0.1, 0.11111111111111
19912, 0.97826086956522, 0.1, 0.16666666666667
19913, 0.97826086956522, 0.1, 0.22222222222222
19914, 0.97826086956522, 0.1, 0.27777777777778
19915, 0.97826086956522, 0.1, 0.33333333333333
19916, 0.97826086956522, 0.1, 0.38888888888889
19917, 0.97826086956522, 0.1, 0.44444444444444
19918, 0.95652173913043, 0.20217391304348, 0
19919, 0.91304347826087, 0.20217391304348, 0
19920, 0.8695652173913, 0.20217391304348, 0
19921, 0.82608695652174, 0.20217391304348, 0
19922, 0.78260869565217, 0.20217391304348, 0
19923, 0.73913043478261, 0.20217391304348, 0
19924, 0.69565217391304, 0.20217391304348, 0
19925, 0.65217391304348, 0.20217391304348, 0
19926, 0.60869565217391, 0.20217391304348, 0
19927, 0.56521739130435, 0.20217391304348, 0
19928, 0.52173913043478, 0.20217391304348, 0
19929, 0.47826086956522, 0.20217391304348, 0
19930, 0.43478260869565, 0.20217391304348, 0
19931, 0.39130434782609, 0.20217391304348, 0
19932, 0.34782608695652, 0.20217391304348, 0
19933, 0.30434782608696, 0.20217391304348, 0
19934, 0.26086956521739, 0.20217391304348, 0
19935, 0.21739130434783, 0.20217391304348, 0
19936, 0.17391304347826, 0.20217391304348, 0
19937, 0.1304347826087, 0.20217391304348, 0
19938, 0.08695652173913, 0.20217391304348, 0
19939, 0.043478260869565, 0.20217391304348, 0
19940, 0.95652173913043, 0.25434782608696, 0
19941, 0.91304347826087, 0.25434782608696, 0
19942, 0.8695652173913, 0.25434782608696, 0
19943, 0.82608695652174, 0.25434782608696, 0
19944, 0.78260869565217, 0.25434782608696, 0
19945, 0.73913043478261, 0.25434782608696, 0
19946, 0.69565217391304, 0.25434782608696, 0
19947, 0.65217391304348, 0.25434782608696, 0
19948, 0.60869565217391, 0.25434782608696, 0
19949, 0.56521739130435, 0.25434782608696, 0
19950, 0.52173913043478, 0.25434782608696, 0
19951, 0.47826086956522, 0.25434782608696, 0
19952, 0.43478260869565, 0.25434782608696, 0
19953, 0.39130434782609, 0.25434782608696, 0
19954, 0.34782608695652, 0.25434782608696, 0
19955, 0.30434782608696, 0.25434782608696, 0
19956, 0.26086956521739, 0.25434782608696, 0
19957, 0.21739130434783, 0.25434782608696, 0
19958, 0.17391304347826, 0.25434782608696, 0
19959, 0.1304347826087, 0.25434782608696, 0
19960, 0.08695652173913, 0.25434782608696, 0
19961, 0.043478260869565, 0.25434782608696, 0
19962, 0.95652173913043, 0.30652173913043, 0
19963, 0.91304347826087, 0.30652173913043, 0
19964, 0.8695652173913, 0.30652173913043, 0
19965, 0.82608695652174, 0.30652173913043, 0
19966, 0.78260869565217, 0.30652173913043, 0
19967, 0.73913043478261, 0.30652173913043, 0
19968, 0.69565217391304, 0.30652173913043, 0
19969, 0.65217391304348, 0.30652173913043, 0
19970, 0.60869565217391, 0.30652173913043, 0
19971, 0.56521739130435, 0.30652173913043, 0
19972, 0.52173913043478, 0.30652173913043, 0
19973, 0.47826086956522, 0.30652173913043, 0
19974, 0.43478260869565, 0.30652173913043, 0
19975, 0.39130434782609, 0.30652173913043, 0
19976, 0.34782608695652, 0.30652173913043, 0
19977, 0.30434782608696, 0.30652173913043, 0
19978, 0.26086956521739, 0.30652173913043, 0
19979, 0.21739130434783, 0.30652173913043, 0
19980, 0.17391304347826, 0.30652173913043, 0
19981, 0.1304347826087, 0.30652173913043, 0
19982, 0.08695652173913, 0.30652173913043, 0
19983, 0.043478260869565, 0.30652173913043, 0
19984, 0.95652173913043, 0.35869565217391, 0
19985, 0.91304347826087, 0.35869565217391, 0
19986, 0.8695652173913, 0.35869565217391, 0
19987, 0.82608695652174, 0.35869565217391, 0
19988, 0.78260869565217, 0.35869565217391, 0
19989, 0.73913043478261, 0.35869565217391, 0
19990, 0.69565217391304, 0.35869565217391, 0
19991, 0.65217391304348, 0.35869565217391, 0
19992, 0.60869565217391, 0.35869565217391, 0
19993, 0.56521739130435, 0.35869565217391, 0
19994, 0.52173913043478, 0.35869565217391, 0
19995, 0.47826086956522, 0.35869565217391, 0
19996, 0.43478260869565, 0.35869565217391, 0
19997, 0.39130434782609, 0.35869565217391, 0
19998, 0.34782608695652, 0.35869565217391, 0
19999, 0.30434782608696, 0.35869565217391, 0
20000, 0.26086956521739, 0.35869565217391, 0
20001, 0.21739130434783, 0.35869565217391, 0
20002, 0.17391304347826, 0.35869565217391, 0
20003, 0.1304347826087, 0.35869565217391, 0
20004, 0.08695652173913, 0.35869565217391, 0
20005, 0.043478260869565, 0.35869565217391, 0
20006, 0.95652173913043, 0.41086956521739, 0
20007, 0.91304347826087, 0.41086956521739, 0
20008, 0.8695652173913, 0.41086956521739, 0
20009, 0.82608695652174, 0.41086956521739, 0
20010, 0.78260869565217, 0.41086956521739, 0
20011, 0.73913043478261, 0.41086956521739, 0
20012, 0.69565217391304, 0.41086956521739, 0
20013, 0.65217391304348, 0.41086956521739, 0
20014, 0.60869565217391, 0.41086956521739, 0
20015, 0.56521739130435, 0.41086956521739, 0
20016, 0.52173913043478, 0.41086956521739, 0
20017, 0.47826086956522, 0.41086956521739, 0
20018, 0.43478260869565, 0.41086956521739, 0
20019, 0.39130434782609, 0.41086956521739, 0
20020, 0.34782608695652, 0.41086956521739, 0
20021, 0.30434782608696, 0.41086956521739, 0
20022, 0.26086956521739, 0.41086956521739, 0
20023, 0.21739130434783, 0.41086956521739, 0
20024, 0.17391304347826, 0.41086956521739, 0
20025, 0.1304347826087, 0.41086956521739, 0
20026, 0.08695652173913, 0.41086956521739, 0
20027, 0.043478260869565, 0.41086956521739, 0
20028, 0.95652173913043, 0.46304347826087, 0
20029, 0.91304347826087, 0.46304347826087, 0
20030, 0.8695652173913, 0.46304347826087, 0
20031, 0.82608695652174, 0.46304347826087, 0
20032, 0.78260869565217, 0.46304347826087, 0
20033, 0.73913043478261, 0.46304347826087, 0
20034, 0.69565217391304, 0.46304347826087, 0
20035, 0.65217391304348, 0.46304347826087, 0
20036, 0.60869565217391, 0.46304347826087, 0
20037, 0.56521739130435, 0.46304347826087, 0
20038, 0.52173913043478, 0.46304347826087, 0
20039, 0.47826086956522, 0.46304347826087, 0
20040, 0.43478260869565, 0.46304347826087, 0
20041, 0.39130434782609, 0.46304347826087, 0
20042, 0.34782608695652, 0.46304347826087, 0
20043, 0.30434782608696, 0.46304347826087, 0
20044, 0.26086956521739, 0.46304347826087, 0
20045, 0.21739130434783, 0.46304347826087, 0
20046, 0.17391304347826, 0.46304347826087, 0
20047, 0.1304347826087, 0.46304347826087, 0
20048, 0.08695652173913, 0.46304347826087, 0
20049, 0.043478260869565, 0.46304347826087, 0
20050, 0.95652173913043, 0.51521739130435, 0
20051, 0.91304347826087, 0.51521739130435, 0
20052, 0.8695652173913, 0.51521739130435, 0
20053, 0.82608695652174, 0.51521739130435, 0
20054, 0.78260869565217, 0.51521739130435, 0
20055, 0.73913043478261, 0.51521739130435, 0
20056, 0.69565217391304, 0.51521739130435, 0
20057, 0.65217391304348, 0.51521739130435, 0
20058, 0.60869565217391, 0.51521739130435, 0
20059, 0.56521739130435, 0.51521739130435, 0
20060, 0.52173913043478, 0.51521739130435, 0
20061, 0.47826086956522, 0.51521739130435, 0
20062, 0.43478260869565, 0.51521739130435, 0
20063, 0.39130434782609, 0.51521739130435, 0
20064, 0.34782608695652, 0.51521739130435, 0
20065, 0.30434782608696, 0.51521739130435, 0
20066, 0.26086956521739, 0.51521739130435, 0
20067, 0.21739130434783, 0.51521739130435, 0
20068, 0.17391304347826, 0.51521739130435, 0
20069, 0.1304347826087, 0.51521739130435, 0
20070, 0.08695652173913, 0.51521739130435, 0
20071, 0.043478260869565, 0.51521739130435, 0
20072, 0.95652173913043, 0.56739130434783, 0
20073, 0.91304347826087, 0.56739130434783, 0
20074, 0.8695652173913, 0.56739130434783, 0
20075, 0.82608695652174, 0.56739130434783, 0
20076, 0.78260869565217, 0.56739130434783, 0
20077, 0.73913043478261, 0.56739130434783, 0
20078, 0.69565217391304, 0.56739130434783, 0
20079, 0.65217391304348, 0.56739130434783, 0
20080, 0.60869565217391, 0.56739130434783, 0
20081, 0.56521739130435, 0.56739130434783, 0
20082, 0.52173913043478, 0.56739130434783, 0
20083, 0.47826086956522, 0.56739130434783, 0
20084, 0.43478260869565, 0.56739130434783, 0
20085, 0.39130434782609, 0.56739130434783, 0
20086, 0.34782608695652, 0.56739130434783, 0
20087, 0.30434782608696, 0.56739130434783, 0
20088, 0.26086956521739, 0.56739130434783, 0
20089, 0.21739130434783, 0.56739130434783, 0
20090, 0.17391304347826, 0.56739130434783, 0
20091, 0.1304347826087, 0.56739130434783, 0
20092, 0.08695652173913, 0.56739130434783, 0
20093, 0.043478260869565, 0.56739130434783, 0
20094, 0.95652173913043, 0.6195652173913, 0
20095, 0.91304347826087, 0.6195652173913, 0
20096, 0.8695652173913, 0.6195652173913, 0
20097, 0.82608695652174, 0.6195652173913, 0
20098, 0.78260869565217, 0.6195652173913, 0
20099, 0.73913043478261, 0.6195652173913, 0
20100, 0.69565217391304, 0.6195652173913, 0
20101, 0.65217391304348, 0.6195652173913, 0
20102, 0.60869565217391, 0.6195652173913, 0
20103, 0.56521739130435, 0.6195652173913, 0
20104, 0.52173913043478, 0.6195652173913, 0
20105, 0.47826086956522, 0.6195652173913, 0
20106, 0.43478260869565, 0.6195652173913, 0
20107, 0.39130434782609, 0.6195652173913, 0
20108, 0.34782608695652, 0.6195652173913, 0
20109, 0.30434782608696, 0.6195652173913, 0
20110, 0.26086956521739, 0.6195652173913, 0
20111, 0.21739130434783, 0.6195652173913, 0
20112, 0.17391304347826, 0.6195652173913, 0
20113, 0.1304347826087, 0.6195652173913, 0
20114, 0.08695652173913, 0.6195652173913, 0
20115, 0.043478260869565, 0.6195652173913, 0
20116, 0.95652173913043, 0.67173913043478, 0
20117, 0.91304347826087, 0.67173913043478, 0
20118, 0.8695652173913, 0.67173913043478, 0
20119, 0.82608695652174, 0.67173913043478, 0
20120, 0.78260869565217, 0.67173913043478, 0
20121, 0.73913043478261, 0.67173913043478, 0
20122, 0.69565217391304, 0.67173913043478, 0
20123, 0.65217391304348, 0.67173913043478, 0
20124, 0.60869565217391, 0.67173913043478, 0
20125, 0.56521739130435, 0.67173913043478, 0
20126, 0.52173913043478, 0.67173913043478, 0
20127, 0.47826086956522, 0.67173913043478, 0
20128, 0.43478260869565, 0.67173913043478, 0
20129, 0.39130434782609, 0.67173913043478, 0
20130, 0.34782608695652, 0.67173913043478, 0
20131, 0.30434782608696, 0.67173913043478, 0
20132, 0.26086956521739, 0.67173913043478, 0
20133, 0.21739130434783, 0.67173913043478, 0
20134, 0.17391304347826, 0.67173913043478, 0
20135, 0.1304347826087, 0.67173913043478, 0
20136, 0.08695652173913, 0.67173913043478, 0
20137, 0.043478260869565, 0.67173913043478, 0
20138, 0.95652173913043, 0.72391304347826, 0
20139, 0.91304347826087, 0.72391304347826, 0
20140, 0.8695652173913, 0.72391304347826, 0
20141, 0.82608695652174, 0.72391304347826, 0
20142, 0.78260869565217, 0.72391304347826, 0
20143, 0.73913043478261, 0.72391304347826, 0
20144, 0.69565217391304, 0.72391304347826, 0
20145, 0.65217391304348, 0.72391304347826, 0
20146, 0.60869565217391, 0.72391304347826, 0
20147, 0.56521739130435, 0.72391304347826, 0
20148, 0.52173913043478, 0.72391304347826, 0
20149, 0.47826086956522, 0.72391304347826, 0
20150, 0.43478260869565, 0.72391304347826, 0
20151, 0.39130434782609, 0.72391304347826, 0
20152, 0.34782608695652, 0.72391304347826, 0
20153, 0.30434782608696, 0.72391304347826, 0
20154, 0.26086956521739, 0.72391304347826, 0
20155, 0.21739130434783, 0.72391304347826, 0
20156, 0.17391304347826, 0.72391304347826, 0
20157, 0.1304347826087, 0.72391304347826, 0
20158, 0.08695652173913, 0.72391304347826, 0
20159, 0.043478260869565, 0.72391304347826, 0
20160, 0.95652173913043, 0.77608695652174, 0
20161, 0.91304347826087, 0.77608695652174, 0
20162, 0.8695652173913, 0.77608695652174, 0
20163, 0.82608695652174, 0.77608695652174, 0
20164, 0.78260869565217, 0.77608695652174, 0
20165, 0.73913043478261, 0.77608695652174, 0
20166, 0.69565217391304, 0.77608695652174, 0
20167, 0.65217391304348, 0.77608695652174, 0
20168, 0.60869565217391, 0.77608695652174, 0
20169, 0.56521739130435, 0.77608695652174, 0
20170, 0.52173913043478, 0.77608695652174, 0
20171, 0.47826086956522, 0.77608695652174, 0
20172, 0.43478260869565, 0.77608695652174, 0
20173, 0.39130434782609, 0.77608695652174, 0
20174, 0.34782608695652, 0.77608695652174, 0
20175, 0.30434782608696, 0.77608695652174, 0
20176, 0.26086956521739, 0.77608695652174, 0
20177, 0.21739130434783, 0.77608695652174, 0
20178, 0.17391304347826, 0.77608695652174, 0
20179, 0.1304347826087, 0.77608695652174, 0
20180, 0.08695652173913, 0.77608695652174, 0
20181, 0.043478260869565, 0.77608695652174, 0
20182, 0.95652173913043, 0.82826086956522, 0
20183, 0.91304347826087, 0.82826086956522, 0
20184, 0.8695652173913, 0.82826086956522, 0
20185, 0.82608695652174, 0.82826086956522, 0
20186, 0.78260869565217, 0.82826086956522, 0
20187, 0.73913043478261, 0.82826086956522, 0
20188, 0.69565217391304, 0.82826086956522, 0
20189, 0.65217391304348, 0.82826086956522, 0
20190, 0.60869565217391, 0.82826086956522, 0
20191, 0.56521739130435, 0.82826086956522, 0
20192, 0.52173913043478, 0.82826086956522, 0
20193, 0.47826086956522, 0.82826086956522, 0
20194, 0.43478260869565, 0.82826086956522, 0
20195, 0.39130434782609, 0.82826086956522, 0
20196, 0.34782608695652, 0.82826086956522, 0
20197, 0.30434782608696, 0.82826086956522, 0
20198, 0.26086956521739, 0.82826086956522, 0
20199, 0.21739130434783, 0.82826086956522, 0
20200, 0.17391304347826, 0.82826086956522, 0
20201, 0.1304347826087, 0.82826086956522, 0
20202, 0.08695652173913, 0.82826086956522, 0
20203, 0.043478260869565, 0.82826086956522, 0
20204, 0.95652173913043, 0.8804347826087, 0
20205, 0.91304347826087, 0.8804347826087, 0
20206, 0.8695652173913, 0.88043478260869, 0
20207, 0.82608695652174, 0.8804347826087, 0
20208, 0.78260869565217, 0.8804347826087, 0
20209, 0.73913043478261, 0.8804347826087, 0
20210, 0.69565217391304, 0.8804347826087, 0
20211, 0.65217391304348, 0.8804347826087, 0
20212, 0.60869565217391, 0.8804347826087, 0
20213, 0.56521739130435, 0.8804347826087, 0
20214, 0.52173913043478, 0.88043478260869, 0
20215, 0.47826086956522, 0.8804347826087, 0
20216, 0.43478260869565, 0.8804347826087, 0
20217, 0.39130434782609, 0.88043478260869, 0
20218, 0.34782608695652, 0.8804347826087, 0
20219, 0.30434782608696, 0.8804347826087, 0
20220, 0.26086956521739, 0.8804347826087, 0
20221, 0.21739130434783, 0.8804347826087, 0
20222, 0.17391304347826, 0.8804347826087, 0
20223, 0.1304347826087, 0.8804347826087, 0
20224, 0.08695652173913, 0.8804347826087, 0
20225, 0.043478260869565, 0.8804347826087, 0
20226, 0.95652173913043, 0.93260869565217, 0
20227, 0.91304347826087, 0.93260869565217, 0
20228, 0.8695652173913, 0.93260869565217, 0
20229, 0.82608695652174, 0.93260869565217, 0
20230, 0.78260869565217, 0.93260869565217, 0
20231, 0.73913043478261, 0.93260869565217, 0
20232, 0.69565217391304, 0.93260869565217, 0
20233, 0.65217391304348, 0.93260869565217, 0
20234, 0.60869565217391, 0.93260869565217, 0
20235, 0.56521739130435, 0.93260869565217, 0
20236, 0.52173913043478, 0.93260869565217, 0
20237, 0.47826086956522, 0.93260869565217, 0
20238, 0.43478260869565, 0.93260869565217, 0
20239, 0.39130434782609, 0.93260869565217, 0
20240, 0.34782608695652, 0.93260869565217, 0
20241, 0.30434782608696, 0.93260869565217, 0
20242, 0.26086956521739, 0.93260869565217, 0
20243, 0.21739130434783, 0.93260869565217, 0
20244, 0.17391304347826, 0.93260869565217, 0
20245, 0.1304347826087, 0.93260869565217, 0
20246, 0.08695652173913, 0.93260869565217, 0
20247, 0.043478260869565, 0.93260869565217, 0
20248, 0.95652173913043, 0.98478260869565, 0
20249, 0.91304347826087, 0.98478260869565, 0
20250, 0.8695652173913, 0.98478260869565, 0
20251, 0.82608695652174, 0.98478260869565, 0
20252, 0.78260869565217, 0.98478260869565, 0
20253, 0.73913043478261, 0.98478260869565, 0
20254, 0.69565217391304, 0.98478260869565, 0
20255, 0.65217391304348, 0.98478260869565, 0
20256, 0.60869565217391, 0.98478260869565, 0
20257, 0.56521739130435, 0.98478260869565, 0
20258, 0.52173913043478, 0.98478260869565, 0
20259, 0.47826086956522, 0.98478260869565, 0
20260, 0.43478260869565, 0.98478260869565, 0
20261, 0.39130434782609, 0.98478260869565, 0
20262, 0.34782608695652, 0.98478260869565, 0
20263, 0.30434782608696, 0.98478260869565, 0
20264, 0.26086956521739, 0.98478260869565, 0
20265, 0.21739130434783, 0.98478260869565, 0
20266, 0.17391304347826, 0.98478260869565, 0
20267, 0.1304347826087, 0.98478260869565, 0
20268, 0.08695652173913, 0.98478260869565, 0
20269, 0.043478260869565, 0.98478260869565, 0
20270, 0.95652173913043, 1.0369565217391, 0
20271, 0.91304347826087, 1.0369565217391, 0
20272, 0.8695652173913, 1.0369565217391, 0
20273, 0.82608695652174, 1.0369565217391, 0
20274, 0.78260869565217, 1.0369565217391, 0
20275, 0.73913043478261, 1.0369565217391, 0
20276, 0.69565217391304, 1.0369565217391, 0
20277, 0.65217391304348, 1.0369565217391, 0
20278, 0.60869565217391, 1.0369565217391, 0
20279, 0.56521739130435, 1.0369565217391, 0
20280, 0.52173913043478, 1.0369565217391, 0
20281, 0.47826086956522, 1.0369565217391, 0
20282, 0.43478260869565, 1.0369565217391, 0
20283, 0.39130434782609, 1.0369565217391, 0
20284, 0.34782608695652, 1.0369565217391, 0
20285, 0.30434782608696, 1.0369565217391, 0
20286, 0.26086956521739, 1.0369565217391, 0
20287, 0.21739130434783, 1.0369565217391, 0
20288, 0.17391304347826, 1.0369565217391, 0
20289, 0.1304347826087, 1.0369565217391, 0
20290, 0.08695652173913, 1.0369565217391, 0
20291, 0.043478260869565, 1.0369565217391, 0
20292, 0.95652173913043, 1.0891304347826, 0
20293, 0.91304347826087, 1.0891304347826, 0
20294, 0.8695652173913, 1.0891304347826, 0
20295, 0.82608695652174, 1.0891304347826, 0
20296, 0.78260869565217, 1.0891304347826, 0
20297, 0.73913043478261, 1.0891304347826, 0
20298, 0.69565217391304, 1.0891304347826, 0
20299, 0.65217391304348, 1.0891304347826, 0
20300, 0.60869565217391, 1.0891304347826, 0
20301, 0.56521739130435, 1.0891304347826, 0
20302, 0.52173913043478, 1.0891304347826, 0
20303, 0.47826086956522, 1.0891304347826, 0
20304, 0.43478260869565, 1.0891304347826, 0
20305, 0.39130434782609, 1.0891304347826, 0
20306, 0.34782608695652, 1.0891304347826, 0
20307, 0.30434782608696, 1.0891304347826, 0
20308, 0.26086956521739, 1.0891304347826, 0
20309, 0.21739130434783, 1.0891304347826, 0
20310, 0.17391304347826, 1.0891304347826, 0
20311, 0.1304347826087, 1.0891304347826, 0
20312, 0.08695652173913, 1.0891304347826, 0
20313, 0.043478260869565, 1.0891304347826, 0
20314, 0.95652173913043, 1.1413043478261, 0
20315, 0.91304347826087, 1.1413043478261, 0
20316, 0.8695652173913, 1.1413043478261, 0
20317, 0.82608695652174, 1.1413043478261, 0
20318, 0.78260869565217, 1.1413043478261, 0
20319, 0.73913043478261, 1.1413043478261, 0
20320, 0.69565217391304, 1.1413043478261, 0
20321, 0.65217391304348, 1.1413043478261, 0
20322, 0.60869565217391, 1.1413043478261, 0
20323, 0.56521739130435, 1.1413043478261, 0
20324, 0.52173913043478, 1.1413043478261, 0
20325, 0.47826086956522, 1.1413043478261, 0
20326, 0.43478260869565, 1.1413043478261, 0
20327, 0.39130434782609, 1.1413043478261, 0
20328, 0.34782608695652, 1.1413043478261, 0
20329, 0.30434782608696, 1.1413043478261, 0
20330, 0.26086956521739, 1.1413043478261, 0
20331, 0.21739130434783, 1.1413043478261, 0
20332, 0.17391304347826, 1.1413043478261, 0
20333, 0.1304347826087, 1.1413043478261, 0
20334, 0.08695652173913, 1.1413043478261, 0
20335, 0.043478260869565, 1.1413043478261, 0
20336, 0.95652173913043, 1.1934782608696, 0
20337, 0.91304347826087, 1.1934782608696, 0
20338, 0.8695652173913, 1.1934782608696, 0
20339, 0.82608695652174, 1.1934782608696, 0
20340, 0.78260869565217, 1.1934782608696, 0
20341, 0.73913043478261, 1.1934782608696, 0
20342, 0.69565217391304, 1.1934782608696, 0
20343, 0.65217391304348, 1.1934782608696, 0
20344, 0.60869565217391, 1.1934782608696, 0
20345, 0.56521739130435, 1.1934782608696, 0
20346, 0.52173913043478, 1.1934782608696, 0
20347, 0.47826086956522, 1.1934782608696, 0
20348, 0.43478260869565, 1.1934782608696, 0
20349, 0.39130434782609, 1.1934782608696, 0
20350, 0.34782608695652, 1.1934782608696, 0
20351, 0.30434782608696, 1.1934782608696, 0
20352, 0.26086956521739, 1.1934782608696, 0
20353, 0.21739130434783, 1.1934782608696, 0
20354, 0.17391304347826, 1.1934782608696, 0
20355, 0.1304347826087, 1.1934782608696, 0
20356, 0.08695652173913, 1.1934782608696, 0
20357, 0.043478260869565, 1.1934782608696, 0
20358, 0.95652173913043, 1.245652173913, 0
20359, 0.91304347826087, 1.245652173913, 0
20360, 0.8695652173913, 1.245652173913, 0
20361, 0.82608695652174, 1.245652173913, 0
20362, 0.78260869565217, 1.245652173913, 0
20363, 0.73913043478261, 1.245652173913, 0
20364, 0.69565217391304, 1.245652173913, 0
20365, 0.65217391304348, 1.245652173913, 0
20366, 0.60869565217391, 1.245652173913, 0
20367, 0.56521739130435, 1.245652173913, 0
20368, 0.52173913043478, 1.245652173913, 0
20369, 0.47826086956522, 1.245652173913, 0
20370, 0.43478260869565, 1.245652173913, 0
20371, 0.39130434782609, 1.245652173913, 0
20372, 0.34782608695652, 1.245652173913, 0
20373, 0.30434782608696, 1.245652173913, 0
20374, 0.26086956521739, 1.245652173913, 0
20375, 0.21739130434783, 1.245652173913, 0
20376, 0.17391304347826, 1.245652173913, 0
20377, 0.1304347826087, 1.245652173913, 0
20378, 0.08695652173913, 1.245652173913, 0
20379, 0.043478260869565, 1.245652173913, 0
20380, 0.95652173913043, 1.2978260869565, 0
20381, 0.91304347826087, 1.2978260869565, 0
20382, 0.8695652173913, 1.2978260869565, 0
20383, 0.82608695652174, 1.2978260869565, 0
20384, 0.78260869565217, 1.2978260869565, 0
20385, 0.73913043478261, 1.2978260869565, 0
20386, 0.69565217391304, 1.2978260869565, 0
20387, 0.65217391304348, 1.2978260869565, 0
20388, 0.60869565217391, 1.2978260869565, 0
20389, 0.56521739130435, 1.2978260869565, 0
20390, 0.52173913043478, 1.2978260869565, 0
20391, 0.47826086956522, 1.2978260869565, 0
20392, 0.43478260869565, 1.2978260869565, 0
20393, 0.39130434782609, 1.2978260869565, 0
20394, 0.34782608695652, 1.2978260869565, 0
20395, 0.30434782608696, 1.2978260869565, 0
20396, 0.26086956521739, 1.2978260869565, 0
20397, 0.21739130434783, 1.2978260869565, 0
20398, 0.17391304347826, 1.2978260869565, 0
20399, 0.1304347826087, 1.2978260869565, 0
20400, 0.08695652173913, 1.2978260869565, 0
20401, 0.043478260869565, 1.2978260869565, 0
20402, 0.95652173913043, 0.17608695652174, 0
20403, 0.97826086956522, 0.20217391304348, 0
20404, 0.91304347826087, 0.17608695652174, 0
20405, 0.93478260869565, 0.20217391304348, 0
20406, 0.8695652173913, 0.17608695652174, 0
20407, 0.89130434782609, 0.20217391304348, 0
20408, 0.82608695652174, 0.17608695652174, 0
20409, 0.84782608695652, 0.20217391304348, 0
20410, 0.78260869565217, 0.17608695652174, 0
20411, 0.80434782608696, 0.20217391304348, 0
20412, 0.73913043478261, 0.17608695652174, 0
20413, 0.76086956521739, 0.20217391304348, 0
20414, 0.69565217391304, 0.17608695652174, 0
20415, 0.71739130434783, 0.20217391304348, 0
20416, 0.65217391304348, 0.17608695652174, 0
20417, 0.67391304347826, 0.20217391304348, 0
20418, 0.60869565217391, 0.17608695652174, 0
20419, 0.6304347826087, 0.20217391304348, 0
20420, 0.56521739130435, 0.17608695652174, 0
20421, 0.58695652173913, 0.20217391304348, 0
20422, 0.52173913043478, 0.17608695652174, 0
20423, 0.54347826086957, 0.20217391304348, 0
20424, 0.47826086956522, 0.17608695652174, 0
20425, 0.5, 0.20217391304348, 0
20426, 0.43478260869565, 0.17608695652174, 0
20427, 0.45652173913043, 0.20217391304348, 0
20428, 0.39130434782609, 0.17608695652174, 0
20429, 0.41304347826087, 0.20217391304348, 0
20430, 0.34782608695652, 0.17608695652174, 0
20431, 0.3695652173913, 0.20217391304348, 0
20432, 0.30434782608696, 0.17608695652174, 0
20433, 0.32608695652174, 0.20217391304348, 0
20434, 0.26086956521739, 0.17608695652174, 0
20435, 0.28260869565217, 0.20217391304348, 0
20436, 0.21739130434783, 0.17608695652174, 0
20437, 0.23913043478261, 0.20217391304348, 0
20438, 0.17391304347826, 0.17608695652174, 0
20439, 0.19565217391304, 0.20217391304348, 0
20440, 0.1304347826087, 0.17608695652174, 0
20441, 0.15217391304348, 0.20217391304348, 0
20442, 0.08695652173913, 0.17608695652174, 0
20443, 0.10869565217391, 0.20217391304348, 0
20444, 0.043478260869565, 0.17608695652174, 0
20445, 0.065217391304348, 0.20217391304348, 0
20446, 0.021739130434783, 0.20217391304348, 0
20447, 0.95652173913043, 0.22826086956522, 0
20448, 0.97826086956522, 0.25434782608696, 0
20449, 0.91304347826087, 0.22826086956522, 0
20450, 0.93478260869565, 0.25434782608696, 0
20451, 0.8695652173913, 0.22826086956522, 0
20452, 0.89130434782609, 0.25434782608696, 0
20453, 0.82608695652174, 0.22826086956522, 0
20454, 0.84782608695652, 0.25434782608696, 0
20455, 0.78260869565217, 0.22826086956522, 0
20456, 0.80434782608696, 0.25434782608696, 0
20457, 0.73913043478261, 0.22826086956522, 0
20458, 0.76086956521739, 0.25434782608696, 0
20459, 0.69565217391304, 0.22826086956522, 0
20460, 0.71739130434783, 0.25434782608696, 0
20461, 0.65217391304348, 0.22826086956522, 0
20462, 0.67391304347826, 0.25434782608696, 0
20463, 0.60869565217391, 0.22826086956522, 0
20464, 0.6304347826087, 0.25434782608696, 0
20465, 0.56521739130435, 0.22826086956522, 0
20466, 0.58695652173913, 0.25434782608696, 0
20467, 0.52173913043478, 0.22826086956522, 0
20468, 0.54347826086957, 0.25434782608696, 0
20469, 0.47826086956522, 0.22826086956522, 0
20470, 0.5, 0.25434782608696, 0
20471, 0.43478260869565, 0.22826086956522, 0
20472, 0.45652173913043, 0.25434782608696, 0
20473, 0.39130434782609, 0.22826086956522, 0
20474, 0.41304347826087, 0.25434782608696, 0
20475, 0.34782608695652, 0.22826086956522, 0
20476, 0.3695652173913, 0.25434782608696, 0
20477, 0.30434782608696, 0.22826086956522, 0
20478, 0.32608695652174, 0.25434782608696, 0
20479, 0.26086956521739, 0.22826086956522, 0
20480, 0.28260869565217, 0.25434782608696, 0
20481, 0.21739130434783, 0.22826086956522, 0
20482, 0.23913043478261, 0.25434782608696, 0
20483, 0.17391304347826, 0.22826086956522, 0
20484, 0.19565217391304, 0.25434782608696, 0
20485, 0.1304347826087, 0.22826086956522, 0
20486, 0.15217391304348, 0.25434782608696, 0
20487, 0.08695652173913, 0.22826086956522, 0
20488, 0.10869565217391, 0.25434782608696, 0
20489, 0.043478260869565, 0.22826086956522, 0
20490, 0.065217391304348, 0.25434782608696, 0
20491, 0.021739130434783, 0.25434782608696, 0
20492, 0.95652173913043, 0.2804347826087, 0
20493, 0.97826086956522, 0.30652173913043, 0
20494, 0.91304347826087, 0.2804347826087, 0
20495, 0.93478260869565, 0.30652173913043, 0
20496, 0.8695652173913, 0.2804347826087, 0
20497, 0.89130434782609, 0.30652173913043, 0
20498, 0.82608695652174, 0.2804347826087, 0
20499, 0.84782608695652, 0.30652173913043, 0
20500, 0.78260869565217, 0.2804347826087, 0
20501, 0.80434782608696, 0.30652173913043, 0
20502, 0.73913043478261, 0.2804347826087, 0
20503, 0.76086956521739, 0.30652173913043, 0
20504, 0.69565217391304, 0.2804347826087, 0
20505, 0.71739130434783, 0.30652173913043, 0
20506, 0.65217391304348, 0.2804347826087, 0
20507, 0.67391304347826, 0.30652173913043, 0
20508, 0.60869565217391, 0.2804347826087, 0
20509, 0.6304347826087, 0.30652173913043, 0
20510, 0.56521739130435, 0.2804347826087, 0
20511, 0.58695652173913, 0.30652173913043, 0
20512, 0.52173913043478, 0.2804347826087, 0
20513, 0.54347826086957, 0.30652173913043, 0
20514, 0.47826086956522, 0.2804347826087, 0
20515, 0.5, 0.30652173913043, 0
20516, 0.43478260869565, 0.2804347826087, 0
20517, 0.45652173913043, 0.30652173913043, 0
20518, 0.39130434782609, 0.2804347826087, 0
20519, 0.41304347826087, 0.30652173913043, 0
20520, 0.34782608695652, 0.2804347826087, 0
20521, 0.3695652173913, 0.30652173913043, 0
20522, 0.30434782608696, 0.2804347826087, 0
20523, 0.32608695652174, 0.30652173913043, 0
20524, 0.26086956521739, 0.2804347826087, 0
20525, 0.28260869565217, 0.30652173913043, 0
20526, 0.21739130434783, 0.2804347826087, 0
20527, 0.23913043478261, 0.30652173913043, 0
20528, 0.17391304347826, 0.2804347826087, 0
20529, 0.19565217391304, 0.30652173913043, 0
20530, 0.1304347826087, 0.2804347826087, 0
20531, 0.15217391304348, 0.30652173913043, 0
20532, 0.08695652173913, 0.2804347826087, 0
20533, 0.10869565217391, 0.30652173913043, 0
20534, 0.043478260869565, 0.2804347826087, 0
20535, 0.065217391304348, 0.30652173913043, 0
20536, 0.021739130434783, 0.30652173913043, 0
20537, 0.95652173913043, 0.33260869565217, 0
20538, 0.97826086956522, 0.35869565217391, 0
20539, 0.91304347826087, 0.33260869565217, 0
20540, 0.93478260869565, 0.35869565217391, 0
20541, 0.8695652173913, 0.33260869565217, 0
20542, 0.89130434782609, 0.35869565217391, 0
20543, 0.82608695652174, 0.33260869565217, 0
20544, 0.84782608695652, 0.35869565217391, 0
20545, 0.78260869565217, 0.33260869565217, 0
20546, 0.80434782608696, 0.35869565217391, 0
20547, 0.73913043478261, 0.33260869565217, 0
20548, 0.76086956521739, 0.35869565217391, 0
20549, 0.69565217391304, 0.33260869565217, 0
20550, 0.71739130434783, 0.35869565217391, 0
20551, 0.65217391304348, 0.33260869565217, 0
20552, 0.67391304347826, 0.35869565217391, 0
20553, 0.60869565217391, 0.33260869565217, 0
20554, 0.6304347826087, 0.35869565217391, 0
20555, 0.56521739130435, 0.33260869565217, 0
20556, 0.58695652173913, 0.35869565217391, 0
20557, 0.52173913043478, 0.33260869565217, 0
20558, 0.54347826086957, 0.35869565217391, 0
20559, 0.47826086956522, 0.33260869565217, 0
20560, 0.5, 0.35869565217391, 0
20561, 0.43478260869565, 0.33260869565217, 0
20562, 0.45652173913043, 0.35869565217391, 0
20563, 0.39130434782609, 0.33260869565217, 0
20564, 0.41304347826087, 0.35869565217391, 0
20565, 0.34782608695652, 0.33260869565217, 0
20566, 0.3695652173913, 0.35869565217391, 0
20567, 0.30434782608696, 0.33260869565217, 0
20568, 0.32608695652174, 0.35869565217391, 0
20569, 0.26086956521739, 0.33260869565217, 0
20570, 0.28260869565217, 0.35869565217391, 0
20571, 0.21739130434783, 0.33260869565217, 0
20572, 0.23913043478261, 0.35869565217391, 0
20573, 0.17391304347826, 0.33260869565217, 0
20574, 0.19565217391304, 0.35869565217391, 0
20575, 0.1304347826087, 0.33260869565217, 0
20576, 0.15217391304348, 0.35869565217391, 0
20577, 0.08695652173913, 0.33260869565217, 0
20578, 0.10869565217391, 0.35869565217391, 0
20579, 0.043478260869565, 0.33260869565217, 0
20580, 0.065217391304348, 0.35869565217391, 0
20581, 0.021739130434783, 0.35869565217391, 0
20582, 0.95652173913043, 0.38478260869565, 0
20583, 0.97826086956522, 0.41086956521739, 0
20584, 0.91304347826087, 0.38478260869565, 0
20585, 0.93478260869565, 0.41086956521739, 0
20586, 0.8695652173913, 0.38478260869565, 0
20587, 0.89130434782609, 0.41086956521739, 0
20588, 0.82608695652174, 0.38478260869565, 0
20589, 0.84782608695652, 0.41086956521739, 0
20590, 0.78260869565217, 0.38478260869565, 0
20591, 0.80434782608696, 0.41086956521739, 0
20592, 0.73913043478261, 0.38478260869565, 0
20593, 0.76086956521739, 0.41086956521739, 0
20594, 0.69565217391304, 0.38478260869565, 0
20595, 0.71739130434783, 0.41086956521739, 0
20596, 0.65217391304348, 0.38478260869565, 0
20597, 0.67391304347826, 0.41086956521739, 0
20598, 0.60869565217391, 0.38478260869565, 0
20599, 0.6304347826087, 0.41086956521739, 0
20600, 0.56521739130435, 0.38478260869565, 0
20601, 0.58695652173913, 0.41086956521739, 0
20602, 0.52173913043478, 0.38478260869565, 0
20603, 0.54347826086957, 0.41086956521739, 0
20604, 0.47826086956522, 0.38478260869565, 0
20605, 0.5, 0.41086956521739, 0
20606, 0.43478260869565, 0.38478260869565, 0
20607, 0.45652173913043, 0.41086956521739, 0
20608, 0.39130434782609, 0.38478260869565, 0
20609, 0.41304347826087, 0.41086956521739, 0
20610, 0.34782608695652, 0.38478260869565, 0
20611, 0.3695652173913, 0.41086956521739, 0
20612, 0.30434782608696, 0.38478260869565, 0
20613, 0.32608695652174, 0.41086956521739, 0
20614, 0.26086956521739, 0.38478260869565, 0
20615, 0.28260869565217, 0.41086956521739, 0
20616, 0.21739130434783, 0.38478260869565, 0
20617, 0.23913043478261, 0.41086956521739, 0
20618, 0.17391304347826, 0.38478260869565, 0
20619, 0.19565217391304, 0.41086956521739, 0
20620, 0.1304347826087, 0.38478260869565, 0
20621, 0.15217391304348, 0.41086956521739, 0
20622, 0.08695652173913, 0.38478260869565, 0
20623, 0.10869565217391, 0.41086956521739, 0
20624, 0.043478260869565, 0.38478260869565, 0
20625, 0.065217391304348, 0.41086956521739, 0
20626, 0.021739130434783, 0.41086956521739, 0
20627, 0.95652173913043, 0.43695652173913, 0
20628, 0.97826086956522, 0.46304347826087, 0
20629, 0.91304347826087, 0.43695652173913, 0
20630, 0.93478260869565, 0.46304347826087, 0
20631, 0.8695652173913, 0.43695652173913, 0
20632, 0.89130434782609, 0.46304347826087, 0
20633, 0.82608695652174, 0.43695652173913, 0
20634, 0.84782608695652, 0.46304347826087, 0
20635, 0.78260869565217, 0.43695652173913, 0
20636, 0.80434782608696, 0.46304347826087, 0
20637, 0.73913043478261, 0.43695652173913, 0
20638, 0.76086956521739, 0.46304347826087, 0
20639, 0.69565217391304, 0.43695652173913, 0
20640, 0.71739130434783, 0.46304347826087, 0
20641, 0.65217391304348, 0.43695652173913, 0
20642, 0.67391304347826, 0.46304347826087, 0
20643, 0.60869565217391, 0.43695652173913, 0
20644, 0.6304347826087, 0.46304347826087, 0
20645, 0.56521739130435, 0.43695652173913, 0
20646, 0.58695652173913, 0.46304347826087, 0
20647, 0.52173913043478, 0.43695652173913, 0
20648, 0.54347826086957, 0.46304347826087, 0
20649, 0.47826086956522, 0.43695652173913, 0
20650, 0.5, 0.46304347826087, 0
20651, 0.43478260869565, 0.43695652173913, 0
20652, 0.45652173913043, 0.46304347826087, 0
20653, 0.39130434782609, 0.43695652173913, 0
20654, 0.41304347826087, 0.46304347826087, 0
20655, 0.34782608695652, 0.43695652173913, 0
20656, 0.3695652173913, 0.46304347826087, 0
20657, 0.30434782608696, 0.43695652173913, 0
20658, 0.32608695652174, 0.46304347826087, 0
20659, 0.26086956521739, 0.43695652173913, 0
20660, 0.28260869565217, 0.46304347826087, 0
20661, 0.21739130434783, 0.43695652173913, 0
20662, 0.23913043478261, 0.46304347826087, 0
20663, 0.17391304347826, 0.43695652173913, 0
20664, 0.19565217391304, 0.46304347826087, 0
20665, 0.1304347826087, 0.43695652173913, 0
20666, 0.15217391304348, 0.46304347826087, 0
20667, 0.08695652173913, 0.43695652173913, 0
20668, 0.10869565217391, 0.46304347826087, 0
20669, 0.043478260869565, 0.43695652173913, 0
20670, 0.065217391304348, 0.46304347826087, 0
20671, 0.021739130434783, 0.46304347826087, 0
20672, 0.95652173913043, 0.48913043478261, 0
20673, 0.97826086956522, 0.51521739130435, 0
20674, 0.91304347826087, 0.48913043478261, 0
20675, 0.93478260869565, 0.51521739130435, 0
20676, 0.8695652173913, 0.48913043478261, 0
20677, 0.89130434782609, 0.51521739130435, 0
20678, 0.82608695652174, 0.48913043478261, 0
20679, 0.84782608695652, 0.51521739130435, 0
20680, 0.78260869565217, 0.48913043478261, 0
20681, 0.80434782608696, 0.51521739130435, 0
20682, 0.73913043478261, 0.48913043478261, 0
20683, 0.76086956521739, 0.51521739130435, 0
20684, 0.69565217391304, 0.48913043478261, 0
20685, 0.71739130434783, 0.51521739130435, 0
20686, 0.65217391304348, 0.48913043478261, 0
20687, 0.67391304347826, 0.51521739130435, 0
20688, 0.60869565217391, 0.48913043478261, 0
20689, 0.6304347826087, 0.51521739130435, 0
20690, 0.56521739130435, 0.48913043478261, 0
20691, 0.58695652173913, 0.51521739130435, 0
20692, 0.52173913043478, 0.48913043478261, 0
20693, 0.54347826086957, 0.51521739130435, 0
20694, 0.47826086956522, 0.48913043478261, 0
20695, 0.5, 0.51521739130435, 0
20696, 0.43478260869565, 0.48913043478261, 0
20697, 0.45652173913043, 0.51521739130435, 0
20698, 0.39130434782609, 0.48913043478261, 0
20699, 0.41304347826087, 0.51521739130435, 0
20700, 0.34782608695652, 0.48913043478261, 0
20701, 0.3695652173913, 0.51521739130435, 0
20702, 0.30434782608696, 0.48913043478261, 0
20703, 0.32608695652174, 0.51521739130435, 0
20704, 0.26086956521739, 0.48913043478261, 0
20705, 0.28260869565217, 0.51521739130435, 0
20706, 0.21739130434783, 0.48913043478261, 0
20707, 0.23913043478261, 0.51521739130435, 0
20708, 0.17391304347826, 0.48913043478261, 0
20709, 0.19565217391304, 0.51521739130435, 0
20710, 0.1304347826087, 0.48913043478261, 0
20711, 0.15217391304348, 0.51521739130435, 0
20712, 0.08695652173913, 0.48913043478261, 0
20713, 0.10869565217391, 0.51521739130435, 0
20714, 0.043478260869565, 0.48913043478261, 0
20715, 0.065217391304348, 0.51521739130435, 0
20716, 0.021739130434783, 0.51521739130435, 0
20717, 0.95652173913043, 0.54130434782609, 0
20718, 0.97826086956522, 0.56739130434783, 0
20719, 0.91304347826087, 0.54130434782609, 0
20720, 0.93478260869565, 0.56739130434783, 0
20721, 0.8695652173913, 0.54130434782609, 0
20722, 0.89130434782609, 0.56739130434783, 0
20723, 0.82608695652174, 0.54130434782609, 0
20724, 0.84782608695652, 0.56739130434783, 0
20725, 0.78260869565217, 0.54130434782609, 0
20726, 0.80434782608696, 0.56739130434783, 0
20727, 0.73913043478261, 0.54130434782609, 0
20728, 0.76086956521739, 0.56739130434783, 0
20729, 0.69565217391304, 0.54130434782609, 0
20730, 0.71739130434783, 0.56739130434783, 0
20731, 0.65217391304348, 0.54130434782609, 0
20732, 0.67391304347826, 0.56739130434783, 0
20733, 0.60869565217391, 0.54130434782609, 0
20734, 0.6304347826087, 0.56739130434783, 0
20735, 0.56521739130435, 0.54130434782609, 0
20736, 0.58695652173913, 0.56739130434783, 0
20737, 0.52173913043478, 0.54130434782609, 0
20738, 0.54347826086957, 0.56739130434783, 0
20739, 0.47826086956522, 0.54130434782609, 0
20740, 0.5, 0.56739130434783, 0
20741, 0.43478260869565, 0.54130434782609, 0
20742, 0.45652173913043, 0.56739130434783, 0
20743, 0.39130434782609, 0.54130434782609, 0
20744, 0.41304347826087, 0.56739130434783, 0
20745, 0.34782608695652, 0.54130434782609, 0
20746, 0.3695652173913, 0.56739130434783, 0
20747, 0.30434782608696, 0.54130434782609, 0
20748, 0.32608695652174, 0.56739130434783, 0
20749, 0.26086956521739, 0.54130434782609, 0
20750, 0.28260869565217, 0.56739130434783, 0
20751, 0.21739130434783, 0.54130434782609, 0
20752, 0.23913043478261, 0.56739130434783, 0
20753, 0.17391304347826, 0.54130434782609, 0
20754, 0.19565217391304, 0.56739130434783, 0
20755, 0.1304347826087, 0.54130434782609, 0
20756, 0.15217391304348, 0.56739130434783, 0
20757, 0.08695652173913, 0.54130434782609, 0
20758, 0.10869565217391, 0.56739130434783, 0
20759, 0.043478260869565, 0.54130434782609, 0
20760, 0.065217391304348, 0.56739130434783, 0
20761, 0.021739130434783, 0.56739130434783, 0
20762, 0.95652173913043, 0.59347826086956, 0
20763, 0.97826086956522, 0.6195652173913, 0
20764, 0.91304347826087, 0.59347826086956, 0
20765, 0.93478260869565, 0.6195652173913, 0
20766, 0.8695652173913, 0.59347826086956, 0
20767, 0.89130434782609, 0.6195652173913, 0
20768, 0.82608695652174, 0.59347826086956, 0
20769, 0.84782608695652, 0.6195652173913, 0
20770, 0.78260869565217, 0.59347826086956, 0
20771, 0.80434782608696, 0.6195652173913, 0
20772, 0.73913043478261, 0.59347826086956, 0
20773, 0.76086956521739, 0.6195652173913, 0
20774, 0.69565217391304, 0.59347826086956, 0
20775, 0.71739130434783, 0.6195652173913, 0
20776, 0.65217391304348, 0.59347826086956, 0
20777, 0.67391304347826, 0.6195652173913, 0
20778, 0.60869565217391, 0.59347826086956, 0
20779, 0.6304347826087, 0.6195652173913, 0
20780, 0.56521739130435, 0.59347826086956, 0
20781, 0.58695652173913, 0.6195652173913, 0
20782, 0.52173913043478, 0.59347826086956, 0
20783, 0.54347826086957, 0.6195652173913, 0
20784, 0.47826086956522, 0.59347826086956, 0
20785, 0.5, 0.6195652173913, 0
20786, 0.43478260869565, 0.59347826086956, 0
20787, 0.45652173913043, 0.6195652173913, 0
20788, 0.39130434782609, 0.59347826086956, 0
20789, 0.41304347826087, 0.6195652173913, 0
20790, 0.34782608695652, 0.59347826086956, 0
20791, 0.3695652173913, 0.6195652173913, 0
20792, 0.30434782608696, 0.59347826086956, 0
20793, 0.32608695652174, 0.6195652173913, 0
20794, 0.26086956521739, 0.59347826086956, 0
20795, 0.28260869565217, 0.6195652173913, 0
20796, 0.21739130434783, 0.59347826086956, 0
20797, 0.23913043478261, 0.6195652173913, 0
20798, 0.17391304347826, 0.59347826086956, 0
20799, 0.19565217391304, 0.6195652173913, 0
20800, 0.1304347826087, 0.59347826086956, 0
20801, 0.15217391304348, 0.6195652173913, 0
20802, 0.08695652173913, 0.59347826086956, 0
20803, 0.10869565217391, 0.6195652173913, 0
20804, 0.043478260869565, 0.59347826086956, 0
20805, 0.065217391304348, 0.6195652173913, 0
20806, 0.021739130434783, 0.6195652173913, 0
20807, 0.95652173913043, 0.64565217391304, 0
20808, 0.97826086956522, 0.67173913043478, 0
20809, 0.91304347826087, 0.64565217391304, 0
20810, 0.93478260869565, 0.67173913043478, 0
20811, 0.8695652173913, 0.64565217391304, 0
20812, 0.89130434782609, 0.67173913043478, 0
20813, 0.82608695652174, 0.64565217391304, 0
20814, 0.84782608695652, 0.67173913043478, 0
20815, 0.78260869565217, 0.64565217391304, 0
20816, 0.80434782608696, 0.67173913043478, 0
20817, 0.73913043478261, 0.64565217391304, 0
20818, 0.76086956521739, 0.67173913043478, 0
20819, 0.69565217391304, 0.64565217391304, 0
20820, 0.71739130434783, 0.67173913043478, 0
20821, 0.65217391304348, 0.64565217391304, 0
20822, 0.67391304347826, 0.67173913043478, 0
20823, 0.60869565217391, 0.64565217391304, 0
20824, 0.6304347826087, 0.67173913043478, 0
20825, 0.56521739130435, 0.64565217391304, 0
20826, 0.58695652173913, 0.67173913043478, 0
20827, 0.52173913043478, 0.64565217391304, 0
20828, 0.54347826086957, 0.67173913043478, 0
20829, 0.47826086956522, 0.64565217391304, 0
20830, 0.5, 0.67173913043478, 0
20831, 0.43478260869565, 0.64565217391304, 0
20832, 0.45652173913043, 0.67173913043478, 0
20833, 0.39130434782609, 0.64565217391304, 0
20834, 0.41304347826087, 0.67173913043478, 0
20835, 0.34782608695652, 0.64565217391304, 0
20836, 0.3695652173913, 0.67173913043478, 0
20837, 0.30434782608696, 0.64565217391304, 0
20838, 0.32608695652174, 0.67173913043478, 0
20839, 0.26086956521739, 0.64565217391304, 0
20840, 0.28260869565217, 0.67173913043478, 0
20841, 0.21739130434783, 0.64565217391304, 0
20842, 0.23913043478261, 0.67173913043478, 0
20843, 0.17391304347826, 0.64565217391304, 0
20844, 0.19565217391304, 0.67173913043478, 0
20845, 0.1304347826087, 0.64565217391304, 0
20846, 0.15217391304348, 0.67173913043478, 0
20847, 0.08695652173913, 0.64565217391304, 0
20848, 0.10869565217391, 0.67173913043478, 0
20849, 0.043478260869565, 0.64565217391304, 0
20850, 0.065217391304348, 0.67173913043478, 0
20851, 0.021739130434783, 0.67173913043478, 0
20852, 0.95652173913043, 0.69782608695652, 0
20853, 0.97826086956522, 0.72391304347826, 0
20854, 0.91304347826087, 0.69782608695652, 0
20855, 0.93478260869565, 0.72391304347826, 0
20856, 0.8695652173913, 0.69782608695652, 0
20857, 0.89130434782609, 0.72391304347826, 0
20858, 0.82608695652174, 0.69782608695652, 0
20859, 0.84782608695652, 0.72391304347826, 0
20860, 0.78260869565217, 0.69782608695652, 0
20861, 0.80434782608696, 0.72391304347826, 0
20862, 0.73913043478261, 0.69782608695652, 0
20863, 0.76086956521739, 0.72391304347826, 0
20864, 0.69565217391304, 0.69782608695652, 0
20865, 0.71739130434783, 0.72391304347826, 0
20866, 0.65217391304348, 0.69782608695652, 0
20867, 0.67391304347826, 0.72391304347826, 0
20868, 0.60869565217391, 0.69782608695652, 0
20869, 0.6304347826087, 0.72391304347826, 0
20870, 0.56521739130435, 0.69782608695652, 0
20871, 0.58695652173913, 0.72391304347826, 0
20872, 0.52173913043478, 0.69782608695652, 0
20873, 0.54347826086957, 0.72391304347826, 0
20874, 0.47826086956522, 0.69782608695652, 0
20875, 0.5, 0.72391304347826, 0
20876, 0.43478260869565, 0.69782608695652, 0
20877, 0.45652173913043, 0.72391304347826, 0
20878, 0.39130434782609, 0.69782608695652, 0
20879, 0.41304347826087, 0.72391304347826, 0
20880, 0.34782608695652, 0.69782608695652, 0
20881, 0.3695652173913, 0.72391304347826, 0
20882, 0.30434782608696, 0.69782608695652, 0
20883, 0.32608695652174, 0.72391304347826, 0
20884, 0.26086956521739, 0.69782608695652, 0
20885, 0.28260869565217, 0.72391304347826, 0
20886, 0.21739130434783, 0.69782608695652, 0
20887, 0.23913043478261, 0.72391304347826, 0
20888, 0.17391304347826, 0.69782608695652, 0
20889, 0.19565217391304, 0.72391304347826, 0
20890, 0.1304347826087, 0.69782608695652, 0
20891, 0.15217391304348, 0.72391304347826, 0
20892, 0.08695652173913, 0.69782608695652, 0
20893, 0.10869565217391, 0.72391304347826, 0
20894, 0.043478260869565, 0.69782608695652, 0
20895, 0.065217391304348, 0.72391304347826, 0
20896, 0.021739130434783, 0.72391304347826, 0
20897, 0.95652173913043, 0.75, 0
20898, 0.97826086956522, 0.77608695652174, 0
20899, 0.91304347826087, 0.75, 0
20900, 0.93478260869565, 0.77608695652174, 0
20901, 0.8695652173913, 0.75, 0
20902, 0.89130434782609, 0.77608695652174, 0
20903, 0.82608695652174, 0.75, 0
20904, 0.84782608695652, 0.77608695652174, 0
20905, 0.78260869565217, 0.75, 0
20906, 0.80434782608696, 0.77608695652174, 0
20907, 0.73913043478261, 0.75, 0
20908, 0.76086956521739, 0.77608695652174, 0
20909, 0.69565217391304, 0.75, 0
20910, 0.71739130434783, 0.77608695652174, 0
20911, 0.65217391304348, 0.75, 0
20912, 0.67391304347826, 0.77608695652174, 0
20913, 0.60869565217391, 0.75, 0
20914, 0.6304347826087, 0.77608695652174, 0
20915, 0.56521739130435, 0.75, 0
20916, 0.58695652173913, 0.77608695652174, 0
20917, 0.52173913043478, 0.75, 0
20918, 0.54347826086957, 0.77608695652174, 0
20919, 0.47826086956522, 0.75, 0
20920, 0.5, 0.77608695652174, 0
20921, 0.43478260869565, 0.75, 0
20922, 0.45652173913043, 0.77608695652174, 0
20923, 0.39130434782609, 0.75, 0
20924, 0.41304347826087, 0.77608695652174, 0
20925, 0.34782608695652, 0.75, 0
20926, 0.3695652173913, 0.77608695652174, 0
20927, 0.30434782608696, 0.75, 0
20928, 0.32608695652174, 0.77608695652174, 0
20929, 0.26086956521739, 0.75, 0
20930, 0.28260869565217, 0.77608695652174, 0
20931, 0.21739130434783, 0.75, 0
20932, 0.23913043478261, 0.77608695652174, 0
20933, 0.17391304347826, 0.75, 0
20934, 0.19565217391304, 0.77608695652174, 0
20935, 0.1304347826087, 0.75, 0
20936, 0.15217391304348, 0.77608695652174, 0
20937, 0.08695652173913, 0.75, 0
20938, 0.10869565217391, 0.77608695652174, 0
20939, 0.043478260869565, 0.75, 0
20940, 0.065217391304348, 0.77608695652174, 0
20941, 0.021739130434783, 0.77608695652174, 0
20942, 0.95652173913043, 0.80217391304348, 0
20943, 0.97826086956522, 0.82826086956522, 0
20944, 0.91304347826087, 0.80217391304348, 0
20945, 0.93478260869565, 0.82826086956522, 0
20946, 0.8695652173913, 0.80217391304348, 0
20947, 0.89130434782609, 0.82826086956522, 0
20948, 0.82608695652174, 0.80217391304348, 0
20949, 0.84782608695652, 0.82826086956522, 0
20950, 0.78260869565217, 0.80217391304348, 0
20951, 0.80434782608696, 0.82826086956522, 0
20952, 0.73913043478261, 0.80217391304348, 0
20953, 0.76086956521739, 0.82826086956522, 0
20954, 0.69565217391304, 0.80217391304348, 0
20955, 0.71739130434783, 0.82826086956522, 0
20956, 0.65217391304348, 0.80217391304348, 0
20957, 0.67391304347826, 0.82826086956522, 0
20958, 0.60869565217391, 0.80217391304348, 0
20959, 0.6304347826087, 0.82826086956522, 0
20960, 0.56521739130435, 0.80217391304348, 0
20961, 0.58695652173913, 0.82826086956522, 0
20962, 0.52173913043478, 0.80217391304348, 0
20963, 0.54347826086957, 0.82826086956522, 0
20964, 0.47826086956522, 0.80217391304348, 0
20965, 0.5, 0.82826086956522, 0
20966, 0.43478260869565, 0.80217391304348, 0
20967, 0.45652173913043, 0.82826086956522, 0
20968, 0.39130434782609, 0.80217391304348, 0
20969, 0.41304347826087, 0.82826086956522, 0
20970, 0.34782608695652, 0.80217391304348, 0
20971, 0.3695652173913, 0.82826086956522, 0
20972, 0.30434782608696, 0.80217391304348, 0
20973, 0.32608695652174, 0.82826086956522, 0
20974, 0.26086956521739, 0.80217391304348, 0
20975, 0.28260869565217, 0.82826086956522, 0
20976, 0.21739130434783, 0.80217391304348, 0
20977, 0.23913043478261, 0.82826086956522, 0
20978, 0.17391304347826, 0.80217391304348, 0
20979, 0.19565217391304, 0.82826086956522, 0
20980, 0.1304347826087, 0.80217391304348, 0
20981, 0.15217391304348, 0.82826086956522, 0
20982, 0.08695652173913, 0.80217391304348, 0
20983, 0.10869565217391, 0.82826086956522, 0
20984, 0.043478260869565, 0.80217391304348, 0
20985, 0.065217391304348, 0.82826086956522, 0
20986, 0.021739130434783, 0.82826086956522, 0
20987, 0.95652173913043, 0.85434782608696, 0
20988, 0.97826086956522, 0.8804347826087, 0
20989, 0.91304347826087, 0.85434782608696, 0
20990, 0.93478260869565, 0.8804347826087, 0
20991, 0.8695652173913, 0.85434782608696, 0
20992, 0.89130434782609, 0.8804347826087, 0
20993, 0.82608695652174, 0.85434782608696, 0
20994, 0.84782608695652, 0.8804347826087, 0
20995, 0.78260869565217, 0.85434782608696, 0
20996, 0.80434782608696, 0.8804347826087, 0
20997, 0.73913043478261, 0.85434782608696, 0
20998, 0.76086956521739, 0.8804347826087, 0
20999, 0.69565217391304, 0.85434782608696, 0
21000, 0.71739130434783, 0.8804347826087, 0
21001, 0.65217391304348, 0.85434782608696, 0
21002, 0.67391304347826, 0.8804347826087, 0
21003, 0.60869565217391, 0.85434782608696, 0
21004, 0.6304347826087, 0.8804347826087, 0
21005, 0.56521739130435, 0.85434782608696, 0
21006, 0.58695652173913, 0.8804347826087, 0
21007, 0.52173913043478, 0.85434782608696, 0
21008, 0.54347826086957, 0.88043478260869, 0
21009, 0.47826086956522, 0.85434782608696, 0
21010, 0.5, 0.88043478260869, 0
21011, 0.43478260869565, 0.85434782608696, 0
21012, 0.45652173913043, 0.8804347826087, 0
21013, 0.39130434782609, 0.85434782608696, 0
21014, 0.41304347826087, 0.88043478260869, 0
21015, 0.34782608695652, 0.85434782608696, 0
21016, 0.3695652173913, 0.8804347826087, 0
21017, 0.30434782608696, 0.85434782608696, 0
21018, 0.32608695652174, 0.8804347826087, 0
21019, 0.26086956521739, 0.85434782608696, 0
21020, 0.28260869565217, 0.8804347826087, 0
21021, 0.21739130434783, 0.85434782608696, 0
21022, 0.23913043478261, 0.8804347826087, 0
21023, 0.17391304347826, 0.85434782608696, 0
21024, 0.19565217391304, 0.8804347826087, 0
21025, 0.1304347826087, 0.85434782608696, 0
21026, 0.15217391304348, 0.8804347826087, 0
21027, 0.08695652173913, 0.85434782608696, 0
21028, 0.10869565217391, 0.8804347826087, 0
21029, 0.043478260869565, 0.85434782608696, 0
21030, 0.065217391304348, 0.8804347826087, 0
21031, 0.021739130434783, 0.8804347826087, 0
21032, 0.95652173913043, 0.90652173913043, 0
21033, 0.97826086956522, 0.93260869565217, 0
21034, 0.91304347826087, 0.90652173913043, 0
21035, 0.93478260869565, 0.93260869565217, 0
21036, 0.8695652173913, 0.90652173913043, 0
21037, 0.89130434782609, 0.93260869565217, 0
21038, 0.82608695652174, 0.90652173913043, 0
21039, 0.84782608695652, 0.93260869565217, 0
21040, 0.78260869565217, 0.90652173913043, 0
21041, 0.80434782608696, 0.93260869565217, 0
21042, 0.73913043478261, 0.90652173913043, 0
21043, 0.76086956521739, 0.93260869565217, 0
21044, 0.69565217391304, 0.90652173913043, 0
21045, 0.71739130434783, 0.93260869565217, 0
21046, 0.65217391304348, 0.90652173913043, 0
21047, 0.67391304347826, 0.93260869565217, 0
21048, 0.60869565217391, 0.90652173913043, 0
21049, 0.6304347826087, 0.93260869565217, 0
21050, 0.56521739130435, 0.90652173913043, 0
21051, 0.58695652173913, 0.93260869565217, 0
21052, 0.52173913043478, 0.90652173913043, 0
21053, 0.54347826086957, 0.93260869565217, 0
21054, 0.47826086956522, 0.90652173913043, 0
21055, 0.5, 0.93260869565217, 0
21056, 0.43478260869565, 0.90652173913043, 0
21057, 0.45652173913043, 0.93260869565217, 0
21058, 0.39130434782609, 0.90652173913043, 0
21059, 0.41304347826087, 0.93260869565217, 0
21060, 0.34782608695652, 0.90652173913043, 0
21061, 0.3695652173913, 0.93260869565217, 0
21062, 0.30434782608696, 0.90652173913043, 0
21063, 0.32608695652174, 0.93260869565217, 0
21064, 0.26086956521739, 0.90652173913043, 0
21065, 0.28260869565217, 0.93260869565217, 0
21066, 0.21739130434783, 0.90652173913043, 0
21067, 0.23913043478261, 0.93260869565217, 0
21068, 0.17391304347826, 0.90652173913043, 0
21069, 0.19565217391304, 0.93260869565217, 0
21070, 0.1304347826087, 0.90652173913043, 0
21071, 0.15217391304348, 0.93260869565217, 0
21072, 0.08695652173913, 0.90652173913043, 0
21073, 0.10869565217391, 0.93260869565217, 0
21074, 0.043478260869565, 0.90652173913043, 0
21075, 0.065217391304348, 0.93260869565217, 0
21076, 0.021739130434783, 0.93260869565217, 0
21077, 0.95652173913043, 0.95869565217391, 0
21078, 0.97826086956522, 0.98478260869565, 0
21079, 0.91304347826087, 0.95869565217391, 0
21080, 0.93478260869565, 0.98478260869565, 0
21081, 0.8695652173913, 0.95869565217391, 0
21082, 0.89130434782609, 0.98478260869565, 0
21083, 0.82608695652174, 0.95869565217391, 0
21084, 0.84782608695652, 0.98478260869565, 0
21085, 0.78260869565217, 0.95869565217391, 0
21086, 0.80434782608696, 0.98478260869565, 0
21087, 0.73913043478261, 0.95869565217391, 0
21088, 0.76086956521739, 0.98478260869565, 0
21089, 0.69565217391304, 0.95869565217391, 0
21090, 0.71739130434783, 0.98478260869565, 0
21091, 0.65217391304348, 0.95869565217391, 0
21092, 0.67391304347826, 0.98478260869565, 0
21093, 0.60869565217391, 0.95869565217391, 0
21094, 0.6304347826087, 0.98478260869565, 0
21095, 0.56521739130435, 0.95869565217391, 0
21096, 0.58695652173913, 0.98478260869565, 0
21097, 0.52173913043478, 0.95869565217391, 0
21098, 0.54347826086957, 0.98478260869565, 0
21099, 0.47826086956522, 0.95869565217391, 0
21100, 0.5, 0.98478260869565, 0
21101, 0.43478260869565, 0.95869565217391, 0
21102, 0.45652173913043, 0.98478260869565, 0
21103, 0.39130434782609, 0.95869565217391, 0
21104, 0.41304347826087, 0.98478260869565, 0
21105, 0.34782608695652, 0.95869565217391, 0
21106, 0.3695652173913, 0.98478260869565, 0
21107, 0.30434782608696, 0.95869565217391, 0
21108, 0.32608695652174, 0.98478260869565, 0
21109, 0.26086956521739, 0.95869565217391, 0
21110, 0.28260869565217, 0.98478260869565, 0
21111, 0.21739130434783, 0.95869565217391, 0
21112, 0.23913043478261, 0.98478260869565, 0
21113, 0.17391304347826, 0.95869565217391, 0
21114, 0.19565217391304, 0.98478260869565, 0
21115, 0.1304347826087, 0.95869565217391, 0
21116, 0.15217391304348, 0.98478260869565, 0
21117, 0.08695652173913, 0.95869565217391, 0
21118, 0.10869565217391, 0.98478260869565, 0
21119, 0.043478260869565, 0.95869565217391, 0
21120, 0.065217391304348, 0.98478260869565, 0
21121, 0.021739130434783, 0.98478260869565, 0
21122, 0.95652173913043, 1.0108695652174, 0
21123, 0.97826086956522, 1.0369565217391, 0
21124, 0.91304347826087, 1.0108695652174, 0
21125, 0.93478260869565, 1.0369565217391, 0
21126, 0.8695652173913, 1.0108695652174, 0
21127, 0.89130434782609, 1.0369565217391, 0
21128, 0.82608695652174, 1.0108695652174, 0
21129, 0.84782608695652, 1.0369565217391, 0
21130, 0.78260869565217, 1.0108695652174, 0
21131, 0.80434782608696, 1.0369565217391, 0
21132, 0.73913043478261, 1.0108695652174, 0
21133, 0.76086956521739, 1.0369565217391, 0
21134, 0.69565217391304, 1.0108695652174, 0
21135, 0.71739130434783, 1.0369565217391, 0
21136, 0.65217391304348, 1.0108695652174, 0
21137, 0.67391304347826, 1.0369565217391, 0
21138, 0.60869565217391, 1.0108695652174, 0
21139, 0.6304347826087, 1.0369565217391, 0
21140, 0.56521739130435, 1.0108695652174, 0
21141, 0.58695652173913, 1.0369565217391, 0
21142, 0.52173913043478, 1.0108695652174, 0
21143, 0.54347826086957, 1.0369565217391, 0
21144, 0.47826086956522, 1.0108695652174, 0
21145, 0.5, 1.0369565217391, 0
21146, 0.43478260869565, 1.0108695652174, 0
21147, 0.45652173913043, 1.0369565217391, 0
21148, 0.39130434782609, 1.0108695652174, 0
21149, 0.41304347826087, 1.0369565217391, 0
21150, 0.34782608695652, 1.0108695652174, 0
21151, 0.3695652173913, 1.0369565217391, 0
21152, 0.30434782608696, 1.0108695652174, 0
21153, 0.32608695652174, 1.0369565217391, 0
21154, 0.26086956521739, 1.0108695652174, 0
21155, 0.28260869565217, 1.0369565217391, 0
21156, 0.21739130434783, 1.0108695652174, 0
21157, 0.23913043478261, 1.0369565217391, 0
21158, 0.17391304347826, 1.0108695652174, 0
21159, 0.19565217391304, 1.0369565217391, 0
21160, 0.1304347826087, 1.0108695652174, 0
21161, 0.15217391304348, 1.0369565217391, 0
21162, 0.08695652173913, 1.0108695652174, 0
21163, 0.10869565217391, 1.0369565217391, 0
21164, 0.043478260869565, 1.0108695652174, 0
21165, 0.065217391304348, 1.0369565217391, 0
21166, 0.021739130434783, 1.0369565217391, 0
21167, 0.95652173913043, 1.0630434782609, 0
21168, 0.97826086956522, 1.0891304347826, 0
21169, 0.91304347826087, 1.0630434782609, 0
21170, 0.93478260869565, 1.0891304347826, 0
21171, 0.8695652173913, 1.0630434782609, 0
21172, 0.89130434782609, 1.0891304347826, 0
21173, 0.82608695652174, 1.0630434782609, 0
21174, 0.84782608695652, 1.0891304347826, 0
21175, 0.78260869565217, 1.0630434782609, 0
21176, 0.80434782608696, 1.0891304347826, 0
21177, 0.73913043478261, 1.0630434782609, 0
21178, 0.76086956521739, 1.0891304347826, 0
21179, 0.69565217391304, 1.0630434782609, 0
21180, 0.71739130434783, 1.0891304347826, 0
21181, 0.65217391304348, 1.0630434782609, 0
21182, 0.67391304347826, 1.0891304347826, 0
21183, 0.60869565217391, 1.0630434782609, 0
21184, 0.6304347826087, 1.0891304347826, 0
21185, 0.56521739130435, 1.0630434782609, 0
21186, 0.58695652173913, 1.0891304347826, 0
21187, 0.52173913043478, 1.0630434782609, 0
21188, 0.54347826086957, 1.0891304347826, 0
21189, 0.47826086956522, 1.0630434782609, 0
21190, 0.5, 1.0891304347826, 0
21191, 0.43478260869565, 1.0630434782609, 0
21192, 0.45652173913043, 1.0891304347826, 0
21193, 0.39130434782609, 1.0630434782609, 0
21194, 0.41304347826087, 1.0891304347826, 0
21195, 0.34782608695652, 1.0630434782609, 0
21196, 0.3695652173913, 1.0891304347826, 0
21197, 0.30434782608696, 1.0630434782609, 0
21198, 0.32608695652174, 1.0891304347826, 0
21199, 0.26086956521739, 1.0630434782609, 0
21200, 0.28260869565217, 1.0891304347826, 0
21201, 0.21739130434783, 1.0630434782609, 0
21202, 0.23913043478261, 1.0891304347826, 0
21203, 0.17391304347826, 1.0630434782609, 0
21204, 0.19565217391304, 1.0891304347826, 0
21205, 0.1304347826087, 1.0630434782609, 0
21206, 0.15217391304348, 1.0891304347826, 0
21207, 0.08695652173913, 1.0630434782609, 0
21208, 0.10869565217391, 1.0891304347826, 0
21209, 0.043478260869565, 1.0630434782609, 0
21210, 0.065217391304348, 1.0891304347826, 0
21211, 0.021739130434783, 1.0891304347826, 0
21212, 0.95652173913043, 1.1152173913043, 0
21213, 0.97826086956522, 1.1413043478261, 0
21214, 0.91304347826087, 1.1152173913043, 0
21215, 0.93478260869565, 1.1413043478261, 0
21216, 0.8695652173913, 1.1152173913043, 0
21217, 0.89130434782609, 1.1413043478261, 0
21218, 0.82608695652174, 1.1152173913043, 0
21219, 0.84782608695652, 1.1413043478261, 0
21220, 0.78260869565217, 1.1152173913043, 0
21221, 0.80434782608696, 1.1413043478261, 0
21222, 0.73913043478261, 1.1152173913043, 0
21223, 0.76086956521739, 1.1413043478261, 0
21224, 0.69565217391304, 1.1152173913043, 0
21225, 0.71739130434783, 1.1413043478261, 0
21226, 0.65217391304348, 1.1152173913043, 0
21227, 0.67391304347826, 1.1413043478261, 0
21228, 0.60869565217391, 1.1152173913043, 0
21229, 0.6304347826087, 1.1413043478261, 0
21230, 0.56521739130435, 1.1152173913043, 0
21231, 0.58695652173913, 1.1413043478261, 0
21232, 0.52173913043478, 1.1152173913043, 0
21233, 0.54347826086957, 1.1413043478261, 0
21234, 0.47826086956522, 1.1152173913043, 0
21235, 0.5, 1.1413043478261, 0
21236, 0.43478260869565, 1.1152173913043, 0
21237, 0.45652173913043, 1.1413043478261, 0
21238, 0.39130434782609, 1.1152173913043, 0
21239, 0.41304347826087, 1.1413043478261, 0
21240, 0.34782608695652, 1.1152173913043, 0
21241, 0.3695652173913, 1.1413043478261, 0
21242, 0.30434782608696, 1.1152173913043, 0
21243, 0.32608695652174, 1.1413043478261, 0
21244, 0.26086956521739, 1.1152173913043, 0
21245, 0.28260869565217, 1.1413043478261, 0
21246, 0.21739130434783, 1.1152173913043, 0
21247, 0.23913043478261, 1.1413043478261, 0
21248, 0.17391304347826, 1.1152173913043, 0
21249, 0.19565217391304, 1.1413043478261, 0
21250, 0.1304347826087, 1.1152173913043, 0
21251, 0.15217391304348, 1.1413043478261, 0
21252, 0.08695652173913, 1.1152173913043, 0
21253, 0.10869565217391, 1.1413043478261, 0
21254, 0.043478260869565, 1.1152173913043, 0
21255, 0.065217391304348, 1.1413043478261, 0
21256, 0.021739130434783, 1.1413043478261, 0
21257, 0.95652173913043, 1.1673913043478, 0
21258, 0.97826086956522, 1.1934782608696, 0
21259, 0.91304347826087, 1.1673913043478, 0
21260, 0.93478260869565, 1.1934782608696, 0
21261, 0.8695652173913, 1.1673913043478, 0
21262, 0.89130434782609, 1.1934782608696, 0
21263, 0.82608695652174, 1.1673913043478, 0
21264, 0.84782608695652, 1.1934782608696, 0
21265, 0.78260869565217, 1.1673913043478, 0
21266, 0.80434782608696, 1.1934782608696, 0
21267, 0.73913043478261, 1.1673913043478, 0
21268, 0.76086956521739, 1.1934782608696, 0
21269, 0.69565217391304, 1.1673913043478, 0
21270, 0.71739130434783, 1.1934782608696, 0
21271, 0.65217391304348, 1.1673913043478, 0
21272, 0.67391304347826, 1.1934782608696, 0
21273, 0.60869565217391, 1.1673913043478, 0
21274, 0.6304347826087, 1.1934782608696, 0
21275, 0.56521739130435, 1.1673913043478, 0
21276, 0.58695652173913, 1.1934782608696, 0
21277, 0.52173913043478, 1.1673913043478, 0
21278, 0.54347826086957, 1.1934782608696, 0
21279, 0.47826086956522, 1.1673913043478, 0
21280, 0.5, 1.1934782608696, 0
21281, 0.43478260869565, 1.1673913043478, 0
21282, 0.45652173913043, 1.1934782608696, 0
21283, 0.39130434782609, 1.1673913043478, 0
21284, 0.41304347826087, 1.1934782608696, 0
21285, 0.34782608695652, 1.1673913043478, 0
21286, 0.3695652173913, 1.1934782608696, 0
21287, 0.30434782608696, 1.1673913043478, 0
21288, 0.32608695652174, 1.1934782608696, 0
21289, 0.26086956521739, 1.1673913043478, 0
21290, 0.28260869565217, 1.1934782608696, 0
21291, 0.21739130434783, 1.1673913043478, 0
21292, 0.23913043478261, 1.1934782608696, 0
21293, 0.17391304347826, 1.1673913043478, 0
21294, 0.19565217391304, 1.1934782608696, 0
21295, 0.1304347826087, 1.1673913043478, 0
21296, 0.15217391304348, 1.1934782608696, 0
21297, 0.08695652173913, 1.1673913043478, 0
21298, 0.10869565217391, 1.1934782608696, 0
21299, 0.043478260869565, 1.1673913043478, 0
21300, 0.065217391304348, 1.1934782608696, 0
21301, 0.021739130434783, 1.1934782608696, 0
21302, 0.95652173913043, 1.2195652173913, 0
21303, 0.97826086956522, 1.245652173913, 0
21304, 0.91304347826087, 1.2195652173913, 0
21305, 0.93478260869565, 1.245652173913, 0
21306, 0.8695652173913, 1.2195652173913, 0
21307, 0.89130434782609, 1.245652173913, 0
21308, 0.82608695652174, 1.2195652173913, 0
21309, 0.84782608695652, 1.245652173913, 0
21310, 0.78260869565217, 1.2195652173913, 0
21311, 0.80434782608696, 1.245652173913, 0
21312, 0.73913043478261, 1.2195652173913, 0
21313, 0.76086956521739, 1.245652173913, 0
21314, 0.69565217391304, 1.2195652173913, 0
21315, 0.71739130434783, 1.245652173913, 0
21316, 0.65217391304348, 1.2195652173913, 0
21317, 0.67391304347826, 1.245652173913, 0
21318, 0.60869565217391, 1.2195652173913, 0
21319, 0.6304347826087, 1.245652173913, 0
21320, 0.56521739130435, 1.2195652173913, 0
21321, 0.58695652173913, 1.245652173913, 0
21322, 0.52173913043478, 1.2195652173913, 0
21323, 0.54347826086957, 1.245652173913, 0
21324, 0.47826086956522, 1.2195652173913, 0
21325, 0.5, 1.245652173913, 0
21326, 0.43478260869565, 1.2195652173913, 0
21327, 0.45652173913043, 1.245652173913, 0
21328, 0.39130434782609, 1.2195652173913, 0
21329, 0.41304347826087, 1.245652173913, 0
21330, 0.34782608695652, 1.2195652173913, 0
21331, 0.3695652173913, 1.245652173913, 0
21332, 0.30434782608696, 1.2195652173913, 0
21333, 0.32608695652174, 1.245652173913, 0
21334, 0.26086956521739, 1.2195652173913, 0
21335, 0.28260869565217, 1.245652173913, 0
21336, 0.21739130434783, 1.2195652173913, 0
21337, 0.23913043478261, 1.245652173913, 0
21338, 0.17391304347826, 1.2195652173913, 0
21339, 0.19565217391304, 1.245652173913, 0
21340, 0.1304347826087, 1.2195652173913, 0
21341, 0.15217391304348, 1.245652173913, 0
21342, 0.08695652173913, 1.2195652173913, 0
21343, 0.10869565217391, 1.245652173913, 0
21344, 0.043478260869565, 1.2195652173913, 0
21345, 0.065217391304348, 1.245652173913, 0
21346, 0.021739130434783, 1.245652173913, 0
21347, 0.95652173913043, 1.2717391304348, 0
21348, 0.97826086956522, 1.2978260869565, 0
21349, 0.91304347826087, 1.2717391304348, 0
21350, 0.93478260869565, 1.2978260869565, 0
21351, 0.8695652173913, 1.2717391304348, 0
21352, 0.89130434782609, 1.2978260869565, 0
21353, 0.82608695652174, 1.2717391304348, 0
21354, 0.84782608695652, 1.2978260869565, 0
21355, 0.78260869565217, 1.2717391304348, 0
21356, 0.80434782608696, 1.2978260869565, 0
21357, 0.73913043478261, 1.2717391304348, 0
21358, 0.76086956521739, 1.2978260869565, 0
21359, 0.69565217391304, 1.2717391304348, 0
21360, 0.71739130434783, 1.2978260869565, 0
21361, 0.65217391304348, 1.2717391304348, 0
21362, 0.67391304347826, 1.2978260869565, 0
21363, 0.60869565217391, 1.2717391304348, 0
21364, 0.6304347826087, 1.2978260869565, 0
21365, 0.56521739130435, 1.2717391304348, 0
21366, 0.58695652173913, 1.2978260869565, 0
21367, 0.52173913043478, 1.2717391304348, 0
21368, 0.54347826086957, 1.2978260869565, 0
21369, 0.47826086956522, 1.2717391304348, 0
21370, 0.5, 1.2978260869565, 0
21371, 0.43478260869565, 1.2717391304348, 0
21372, 0.45652173913043, 1.2978260869565, 0
21373, 0.39130434782609, 1.2717391304348, 0
21374, 0.41304347826087, 1.2978260869565, 0
21375, 0.34782608695652, 1.2717391304348, 0
21376, 0.3695652173913, 1.2978260869565, 0
21377, 0.30434782608696, 1.2717391304348, 0
21378, 0.32608695652174, 1.2978260869565, 0
21379, 0.26086956521739, 1.2717391304348, 0
21380, 0.28260869565217, 1.2978260869565, 0
21381, 0.21739130434783, 1.2717391304348, 0
21382, 0.23913043478261, 1.2978260869565, 0
21383, 0.17391304347826, 1.2717391304348, 0
21384, 0.19565217391304, 1.2978260869565, 0
21385, 0.1304347826087, 1.2717391304348, 0
21386, 0.15217391304348, 1.2978260869565, 0
21387, 0.08695652173913, 1.2717391304348, 0
21388, 0.10869565217391, 1.2978260869565, 0
21389, 0.043478260869565, 1.2717391304348, 0
21390, 0.065217391304348, 1.2978260869565, 0
21391, 0.021739130434783, 1.2978260869565, 0
21392, 0.95652173913043, 1.3239130434783, 0
21393, 0.91304347826087, 1.3239130434783, 0
21394, 0.8695652173913, 1.3239130434783, 0
21395, 0.82608695652174, 1.3239130434783, 0
21396, 0.78260869565217, 1.3239130434783, 0
21397, 0.73913043478261, 1.3239130434783, 0
21398, 0.69565217391304, 1.3239130434783, 0
21399, 0.65217391304348, 1.3239130434783, 0
21400, 0.60869565217391, 1.3239130434783, 0
21401, 0.56521739130435, 1.3239130434783, 0
21402, 0.52173913043478, 1.3239130434783, 0
21403, 0.47826086956522, 1.3239130434783, 0
21404, 0.43478260869565, 1.3239130434783, 0
21405, 0.39130434782609, 1.3239130434783, 0
21406, 0.34782608695652, 1.3239130434783, 0
21407, 0.30434782608696, 1.3239130434783, 0
21408, 0.26086956521739, 1.3239130434783, 0
21409, 0.21739130434783, 1.3239130434783, 0
21410, 0.17391304347826, 1.3239130434783, 0
21411, 0.1304347826087, 1.3239130434783, 0
21412, 0.08695652173913, 1.3239130434783, 0
21413, 0.043478260869565, 1.3239130434783, 0
21414, 1, 0.20217391304348, 0.44444444444444
21415, 1, 0.20217391304348, 0.38888888888889
21416, 1, 0.20217391304348, 0.33333333333333
21417, 1, 0.20217391304348, 0.27777777777778
21418, 1, 0.20217391304348, 0.22222222222222
21419, 1, 0.20217391304348, 0.16666666666667
21420, 1, 0.20217391304348, 0.11111111111111
21421, 1, 0.20217391304348, 0.055555555555556
21422, 1, 0.25434782608696, 0.44444444444444
21423, 1, 0.25434782608696, 0.38888888888889
21424, 1, 0.25434782608696, 0.33333333333333
21425, 1, 0.25434782608696, 0.27777777777778
21426, 1, 0.25434782608696, 0.22222222222222
21427, 1, 0.25434782608696, 0.16666666666667
21428, 1, 0.25434782608696, 0.11111111111111
21429, 1, 0.25434782608696, 0.055555555555556
21430, 1, 0.30652173913043, 0.44444444444444
21431, 1, 0.30652173913043, 0.38888888888889
21432, 1, 0.30652173913043, 0.33333333333333
21433, 1, 0.30652173913043, 0.27777777777778
21434, 1, 0.30652173913043, 0.22222222222222
21435, 1, 0.30652173913043, 0.16666666666667
21436, 1, 0.30652173913043, 0.11111111111111
21437, 1, 0.30652173913043, 0.055555555555556
21438, 1, 0.35869565217391, 0.44444444444444
21439, 1, 0.35869565217391, 0.38888888888889
21440, 1, 0.35869565217391, 0.33333333333333
21441, 1, 0.35869565217391, 0.27777777777778
21442, 1, 0.35869565217391, 0.22222222222222
21443, 1, 0.35869565217391, 0.16666666666667
21444, 1, 0.35869565217391, 0.11111111111111
21445, 1, 0.35869565217391, 0.055555555555556
21446, 1, 0.41086956521739, 0.44444444444444
21447, 1, 0.41086956521739, 0.38888888888889
21448, 1, 0.41086956521739, 0.33333333333333
21449, 1, 0.41086956521739, 0.27777777777778
21450, 1, 0.41086956521739, 0.22222222222222
21451, 1, 0.41086956521739, 0.16666666666667
21452, 1, 0.41086956521739, 0.11111111111111
21453, 1, 0.41086956521739, 0.055555555555556
21454, 1, 0.46304347826087, 0.44444444444444
21455, 1, 0.46304347826087, 0.38888888888889
21456, 1, 0.46304347826087, 0.33333333333333
21457, 1, 0.46304347826087, 0.27777777777778
21458, 1, 0.46304347826087, 0.22222222222222
21459, 1, 0.46304347826087, 0.16666666666667
21460, 1, 0.46304347826087, 0.11111111111111
21461, 1, 0.46304347826087, 0.055555555555556
21462, 1, 0.51521739130435, 0.44444444444444
21463, 1, 0.51521739130435, 0.38888888888889
21464, 1, 0.51521739130435, 0.33333333333333
21465, 1, 0.51521739130435, 0.27777777777778
21466, 1, 0.51521739130435, 0.22222222222222
21467, 1, 0.51521739130435, 0.16666666666667
21468, 1, 0.51521739130435, 0.11111111111111
21469, 1, 0.51521739130435, 0.055555555555556
21470, 1, 0.56739130434783, 0.44444444444444
21471, 1, 0.56739130434783, 0.38888888888889
21472, 1, 0.56739130434783, 0.33333333333333
21473, 1, 0.56739130434783, 0.27777777777778
21474, 1, 0.56739130434783, 0.22222222222222
21475, 1, 0.56739130434783, 0.16666666666667
21476, 1, 0.56739130434783, 0.11111111111111
21477, 1, 0.56739130434783, 0.055555555555556
21478, 1, 0.6195652173913, 0.44444444444444
21479, 1, 0.6195652173913, 0.38888888888889
21480, 1, 0.6195652173913, 0.33333333333333
21481, 1, 0.6195652173913, 0.27777777777778
21482, 1, 0.6195652173913, 0.22222222222222
21483, 1, 0.6195652173913, 0.16666666666667
21484, 1, 0.6195652173913, 0.11111111111111
21485, 1, 0.6195652173913, 0.055555555555556
21486, 1, 0.67173913043478, 0.44444444444444
21487, 1, 0.67173913043478, 0.38888888888889
21488, 1, 0.67173913043478, 0.33333333333333
21489, 1, 0.67173913043478, 0.27777777777778
21490, 1, 0.67173913043478, 0.22222222222222
21491, 1, 0.67173913043478, 0.16666666666667
21492, 1, 0.67173913043478, 0.11111111111111
21493, 1, 0.67173913043478, 0.055555555555556
21494, 1, 0.72391304347826, 0.44444444444444
21495, 1, 0.72391304347826, 0.38888888888889
21496, 1, 0.72391304347826, 0.33333333333333
21497, 1, 0.72391304347826, 0.27777777777778
21498, 1, 0.72391304347826, 0.22222222222222
21499, 1, 0.72391304347826, 0.16666666666667
21500, 1, 0.72391304347826, 0.11111111111111
21501, 1, 0.72391304347826, 0.055555555555556
21502, 1, 0.77608695652174, 0.44444444444444
21503, 1, 0.77608695652174, 0.38888888888889
21504, 1, 0.77608695652174, 0.33333333333333
21505, 1, 0.77608695652174, 0.27777777777778
21506, 1, 0.77608695652174, 0.22222222222222
21507, 1, 0.77608695652174, 0.16666666666667
21508, 1, 0.77608695652174, 0.11111111111111
21509, 1, 0.77608695652174, 0.055555555555556
21510, 1, 0.82826086956522, 0.44444444444444
21511, 1, 0.82826086956522, 0.38888888888889
21512, 1, 0.82826086956522, 0.33333333333333
21513, 1, 0.82826086956522, 0.27777777777778
21514, 1, 0.82826086956522, 0.22222222222222
21515, 1, 0.82826086956522, 0.16666666666667
21516, 1, 0.82826086956522, 0.11111111111111
21517, 1, 0.82826086956522, 0.055555555555556
21518, 1, 0.88043478260869, 0.44444444444444
21519, 1, 0.8804347826087, 0.38888888888889
21520, 1, 0.8804347826087, 0.33333333333333
21521, 1, 0.8804347826087, 0.27777777777778
21522, 1, 0.8804347826087, 0.22222222222222
21523, 1, 0.8804347826087, 0.16666666666667
21524, 1, 0.8804347826087, 0.11111111111111
21525, 1, 0.8804347826087, 0.055555555555556
21526, 1, 0.93260869565217, 0.44444444444444
21527, 1, 0.93260869565217, 0.38888888888889
21528, 1, 0.93260869565217, 0.33333333333333
21529, 1, 0.93260869565217, 0.27777777777778
21530, 1, 0.93260869565217, 0.22222222222222
21531, 1, 0.93260869565217, 0.16666666666667
21532, 1, 0.93260869565217, 0.11111111111111
21533, 1, 0.93260869565217, 0.055555555555556
21534, 1, 0.98478260869565, 0.44444444444444
21535, 1, 0.98478260869565, 0.38888888888889
21536, 1, 0.98478260869565, 0.33333333333333
21537, 1, 0.98478260869565, 0.27777777777778
21538, 1, 0.98478260869565, 0.22222222222222
21539, 1, 0.98478260869565, 0.16666666666667
21540, 1, 0.98478260869565, 0.11111111111111
21541, 1, 0.98478260869565, 0.055555555555556
21542, 1, 1.0369565217391, 0.44444444444444
21543, 1, 1.0369565217391, 0.38888888888889
21544, 1, 1.0369565217391, 0.33333333333333
21545, 1, 1.0369565217391, 0.27777777777778
21546, 1, 1.0369565217391, 0.22222222222222
21547, 1, 1.0369565217391, 0.16666666666667
21548, 1, 1.0369565217391, 0.11111111111111
21549, 1, 1.0369565217391, 0.055555555555556
21550, 1, 1.0891304347826, 0.44444444444444
21551, 1, 1.0891304347826, 0.38888888888889
21552, 1, 1.0891304347826, 0.33333333333333
21553, 1, 1.0891304347826, 0.27777777777778
21554, 1, 1.0891304347826, 0.22222222222222
21555, 1, 1.0891304347826, 0.16666666666667
21556, 1, 1.0891304347826, 0.11111111111111
21557, 1, 1.0891304347826, 0.055555555555556
21558, 1, 1.1413043478261, 0.44444444444444
21559, 1, 1.1413043478261, 0.38888888888889
21560, 1, 1.1413043478261, 0.33333333333333
21561, 1, 1.1413043478261, 0.27777777777778
21562, 1, 1.1413043478261, 0.22222222222222
21563, 1, 1.1413043478261, 0.16666666666667
21564, 1, 1.1413043478261, 0.11111111111111
21565, 1, 1.1413043478261, 0.055555555555556
21566, 1, 1.1934782608696, 0.44444444444444
21567, 1, 1.1934782608696, 0.38888888888889
21568, 1, 1.1934782608696, 0.33333333333333
21569, 1, 1.1934782608696, 0.27777777777778
21570, 1, 1.1934782608696, 0.22222222222222
21571, 1, 1.1934782608696, 0.16666666666667
21572, 1, 1.1934782608696, 0.11111111111111
21573, 1, 1.1934782608696, 0.055555555555556
21574, 1, 1.245652173913, 0.44444444444444
21575, 1, 1.245652173913, 0.38888888888889
21576, 1, 1.245652173913, 0.33333333333333
21577, 1, 1.245652173913, 0.27777777777778
21578, 1, 1.245652173913, 0.22222222222222
21579, 1, 1.245652173913, 0.16666666666667
21580, 1, 1.245652173913, 0.11111111111111
21581, 1, 1.245652173913, 0.055555555555556
21582, 1, 1.2978260869565, 0.44444444444444
21583, 1, 1.2978260869565, 0.38888888888889
21584, 1, 1.2978260869565, 0.33333333333333
21585, 1, 1.2978260869565, 0.27777777777778
21586, 1, 1.2978260869565, 0.22222222222222
21587, 1, 1.2978260869565, 0.16666666666667
21588, 1, 1.2978260869565, 0.11111111111111
21589, 1, 1.2978260869565, 0.055555555555556
21590, 1, 0.17608695652174, 0.44444444444444
21591, 1, 0.20217391304348, 0.47222222222222
21592, 1, 0.17608695652174, 0.38888888888889
21593, 1, 0.20217391304348, 0.41666666666667
21594, 1, 0.17608695652174, 0.33333333333333
21595, 1, 0.20217391304348, 0.36111111111111
21596, 1, 0.17608695652174, 0.27777777777778
21597, 1, 0.20217391304348, 0.30555555555556
21598, 1, 0.17608695652174, 0.22222222222222
21599, 1, 0.20217391304348, 0.25
21600, 1, 0.17608695652174, 0.16666666666667
21601, 1, 0.20217391304348, 0.19444444444444
21602, 1, 0.17608695652174, 0.11111111111111
21603, 1, 0.20217391304348, 0.13888888888889
21604, 1, 0.17608695652174, 0.055555555555556
21605, 1, 0.20217391304348, 0.083333333333333
21606, 1, 0.20217391304348, 0.027777777777778
21607, 1, 0.22826086956522, 0.44444444444444
21608, 1, 0.25434782608696, 0.47222222222222
21609, 1, 0.22826086956522, 0.38888888888889
21610, 1, 0.25434782608696, 0.41666666666667
21611, 1, 0.22826086956522, 0.33333333333333
21612, 1, 0.25434782608696, 0.36111111111111
21613, 1, 0.22826086956522, 0.27777777777778
21614, 1, 0.25434782608696, 0.30555555555556
21615, 1, 0.22826086956522, 0.22222222222222
21616, 1, 0.25434782608696, 0.25
21617, 1, 0.22826086956522, 0.16666666666667
21618, 1, 0.25434782608696, 0.19444444444444
21619, 1, 0.22826086956522, 0.11111111111111
21620, 1, 0.25434782608696, 0.13888888888889
21621, 1, 0.22826086956522, 0.055555555555556
21622, 1, 0.25434782608696, 0.083333333333333
21623, 1, 0.25434782608696, 0.027777777777778
21624, 1, 0.2804347826087, 0.44444444444444
21625, 1, 0.30652173913043, 0.47222222222222
21626, 1, 0.2804347826087, 0.38888888888889
21627, 1, 0.30652173913043, 0.41666666666667
21628, 1, 0.2804347826087, 0.33333333333333
21629, 1, 0.30652173913043, 0.36111111111111
21630, 1, 0.2804347826087, 0.27777777777778
21631, 1, 0.30652173913043, 0.30555555555556
21632, 1, 0.2804347826087, 0.22222222222222
21633, 1, 0.30652173913043, 0.25
21634, 1, 0.2804347826087, 0.16666666666667
21635, 1, 0.30652173913043, 0.19444444444444
21636, 1, 0.2804347826087, 0.11111111111111
21637, 1, 0.30652173913043, 0.13888888888889
21638, 1, 0.2804347826087, 0.055555555555556
21639, 1, 0.30652173913043, 0.083333333333333
21640, 1, 0.30652173913043, 0.027777777777778
21641, 1, 0.33260869565217, 0.44444444444444
21642, 1, 0.35869565217391, 0.47222222222222
21643, 1, 0.33260869565217, 0.38888888888889
21644, 1, 0.35869565217391, 0.41666666666667
21645, 1, 0.33260869565217, 0.33333333333333
21646, 1, 0.35869565217391, 0.36111111111111
21647, 1, 0.33260869565217, 0.27777777777778
21648, 1, 0.35869565217391, 0.30555555555556
21649, 1, 0.33260869565217, 0.22222222222222
21650, 1, 0.35869565217391, 0.25
21651, 1, 0.33260869565217, 0.16666666666667
21652, 1, 0.35869565217391, 0.19444444444444
21653, 1, 0.33260869565217, 0.11111111111111
21654, 1, 0.35869565217391, 0.13888888888889
21655, 1, 0.33260869565217, 0.055555555555556
21656, 1, 0.35869565217391, 0.083333333333333
21657, 1, 0.35869565217391, 0.027777777777778
21658, 1, 0.38478260869565, 0.44444444444444
21659, 1, 0.41086956521739, 0.47222222222222
21660, 1, 0.38478260869565, 0.38888888888889
21661, 1, 0.41086956521739, 0.41666666666667
21662, 1, 0.38478260869565, 0.33333333333333
21663, 1, 0.41086956521739, 0.36111111111111
21664, 1, 0.38478260869565, 0.27777777777778
21665, 1, 0.41086956521739, 0.30555555555556
21666, 1, 0.38478260869565, 0.22222222222222
21667, 1, 0.41086956521739, 0.25
21668, 1, 0.38478260869565, 0.16666666666667
21669, 1, 0.41086956521739, 0.19444444444444
21670, 1, 0.38478260869565, 0.11111111111111
21671, 1, 0.41086956521739, 0.13888888888889
21672, 1, 0.38478260869565, 0.055555555555556
21673, 1, 0.41086956521739, 0.083333333333333
21674, 1, 0.41086956521739, 0.027777777777778
21675, 1, 0.43695652173913, 0.44444444444444
21676, 1, 0.46304347826087, 0.47222222222222
21677, 1, 0.43695652173913, 0.38888888888889
21678, 1, 0.46304347826087, 0.41666666666667
21679, 1, 0.43695652173913, 0.33333333333333
21680, 1, 0.46304347826087, 0.36111111111111
21681, 1, 0.43695652173913, 0.27777777777778
21682, 1, 0.46304347826087, 0.30555555555556
21683, 1, 0.43695652173913, 0.22222222222222
21684, 1, 0.46304347826087, 0.25
21685, 1, 0.43695652173913, 0.16666666666667
21686, 1, 0.46304347826087, 0.19444444444444
21687, 1, 0.43695652173913, 0.11111111111111
21688, 1, 0.46304347826087, 0.13888888888889
21689, 1, 0.43695652173913, 0.055555555555556
21690, 1, 0.46304347826087, 0.083333333333333
21691, 1, 0.46304347826087, 0.027777777777778
21692, 1, 0.48913043478261, 0.44444444444444
21693, 1, 0.51521739130435, 0.47222222222222
21694, 1, 0.48913043478261, 0.38888888888889
21695, 1, 0.51521739130435, 0.41666666666667
21696, 1, 0.48913043478261, 0.33333333333333
21697, 1, 0.51521739130435, 0.36111111111111
21698, 1, 0.48913043478261, 0.27777777777778
21699, 1, 0.51521739130435, 0.30555555555556
21700, 1, 0.48913043478261, 0.22222222222222
21701, 1, 0.51521739130435, 0.25
21702, 1, 0.48913043478261, 0.16666666666667
21703, 1, 0.51521739130435, 0.19444444444444
21704, 1, 0.48913043478261, 0.11111111111111
21705, 1, 0.51521739130435, 0.13888888888889
21706, 1, 0.48913043478261, 0.055555555555556
21707, 1, 0.51521739130435, 0.083333333333333
21708, 1, 0.51521739130435, 0.027777777777778
21709, 1, 0.54130434782609, 0.44444444444444
21710, 1, 0.56739130434783, 0.47222222222222
21711, 1, 0.54130434782609, 0.38888888888889
21712, 1, 0.56739130434783, 0.41666666666667
21713, 1, 0.54130434782609, 0.33333333333333
21714, 1, 0.56739130434783, 0.36111111111111
21715, 1, 0.54130434782609, 0.27777777777778
21716, 1, 0.56739130434783, 0.30555555555556
21717, 1, 0.54130434782609, 0.22222222222222
21718, 1, 0.56739130434783, 0.25
21719, 1, 0.54130434782609, 0.16666666666667
21720, 1, 0.56739130434783, 0.19444444444444
21721, 1, 0.54130434782609, 0.11111111111111
21722, 1, 0.56739130434783, 0.13888888888889
21723, 1, 0.54130434782609, 0.055555555555556
21724, 1, 0.56739130434783, 0.083333333333333
21725, 1, 0.56739130434783, 0.027777777777778
21726, 1, 0.59347826086956, 0.44444444444444
21727, 1, 0.6195652173913, 0.47222222222222
21728, 1, 0.59347826086956, 0.38888888888889
21729, 1, 0.6195652173913, 0.41666666666667
21730, 1, 0.59347826086956, 0.33333333333333
21731, 1, 0.6195652173913, 0.36111111111111
21732, 1, 0.59347826086956, 0.27777777777778
21733, 1, 0.6195652173913, 0.30555555555556
21734, 1, 0.59347826086956, 0.22222222222222
21735, 1, 0.6195652173913, 0.25
21736, 1, 0.59347826086956, 0.16666666666667
21737, 1, 0.6195652173913, 0.19444444444444
21738, 1, 0.59347826086956, 0.11111111111111
21739, 1, 0.6195652173913, 0.13888888888889
21740, 1, 0.59347826086956, 0.055555555555556
21741, 1, 0.6195652173913, 0.083333333333333
21742, 1, 0.6195652173913, 0.027777777777778
21743, 1, 0.64565217391304, 0.44444444444444
21744, 1, 0.67173913043478, 0.47222222222222
21745, 1, 0.64565217391304, 0.38888888888889
21746, 1, 0.67173913043478, 0.41666666666667
21747, 1, 0.64565217391304, 0.33333333333333
21748, 1, 0.67173913043478, 0.36111111111111
21749, 1, 0.64565217391304, 0.27777777777778
21750, 1, 0.67173913043478, 0.30555555555556
21751, 1, 0.64565217391304, 0.22222222222222
21752, 1, 0.67173913043478, 0.25
21753, 1, 0.64565217391304, 0.16666666666667
21754, 1, 0.67173913043478, 0.19444444444444
21755, 1, 0.64565217391304, 0.11111111111111
21756, 1, 0.67173913043478, 0.13888888888889
21757, 1, 0.64565217391304, 0.055555555555556
21758, 1, 0.67173913043478, 0.083333333333333
21759, 1, 0.67173913043478, 0.027777777777778
21760, 1, 0.69782608695652, 0.44444444444444
21761, 1, 0.72391304347826, 0.47222222222222
21762, 1, 0.69782608695652, 0.38888888888889
21763, 1, 0.72391304347826, 0.41666666666667
21764, 1, 0.69782608695652, 0.33333333333333
21765, 1, 0.72391304347826, 0.36111111111111
21766, 1, 0.69782608695652, 0.27777777777778
21767, 1, 0.72391304347826, 0.30555555555556
21768, 1, 0.69782608695652, 0.22222222222222
21769, 1, 0.72391304347826, 0.25
21770, 1, 0.69782608695652, 0.16666666666667
21771, 1, 0.72391304347826, 0.19444444444444
21772, 1, 0.69782608695652, 0.11111111111111
21773, 1, 0.72391304347826, 0.13888888888889
21774, 1, 0.69782608695652, 0.055555555555556
21775, 1, 0.72391304347826, 0.083333333333333
21776, 1, 0.72391304347826, 0.027777777777778
21777, 1, 0.75, 0.44444444444444
21778, 1, 0.77608695652174, 0.47222222222222
21779, 1, 0.75, 0.38888888888889
21780, 1, 0.77608695652174, 0.41666666666667
21781, 1, 0.75, 0.33333333333333
21782, 1, 0.77608695652174, 0.36111111111111
21783, 1, 0.75, 0.27777777777778
21784, 1, 0.77608695652174, 0.30555555555556
21785, 1, 0.75, 0.22222222222222
21786, 1, 0.77608695652174, 0.25
21787, 1, 0.75, 0.16666666666667
21788, 1, 0.77608695652174, 0.19444444444444
21789, 1, 0.75, 0.11111111111111
21790, 1, 0.77608695652174, 0.13888888888889
21791, 1, 0.75, 0.055555555555556
21792, 1, 0.77608695652174, 0.083333333333333
21793, 1, 0.77608695652174, 0.027777777777778
21794, 1, 0.80217391304348, 0.44444444444444
21795, 1, 0.82826086956522, 0.47222222222222
21796, 1, 0.80217391304348, 0.38888888888889
21797, 1, 0.82826086956522, 0.41666666666667
21798, 1, 0.80217391304348, 0.33333333333333
21799, 1, 0.82826086956522, 0.36111111111111
21800, 1, 0.80217391304348, 0.27777777777778
21801, 1, 0.82826086956522, 0.30555555555556
21802, 1, 0.80217391304348, 0.22222222222222
21803, 1, 0.82826086956522, 0.25
21804, 1, 0.80217391304348, 0.16666666666667
21805, 1, 0.82826086956522, 0.19444444444444
21806, 1, 0.80217391304348, 0.11111111111111
21807, 1, 0.82826086956522, 0.13888888888889
21808, 1, 0.80217391304348, 0.055555555555556
21809, 1, 0.82826086956522, 0.083333333333333
21810, 1, 0.82826086956522, 0.027777777777778
21811, 1, 0.85434782608696, 0.44444444444444
21812, 1, 0.88043478260869, 0.47222222222222
21813, 1, 0.85434782608696, 0.38888888888889
21814, 1, 0.88043478260869, 0.41666666666667
21815, 1, 0.85434782608696, 0.33333333333333
21816, 1, 0.8804347826087, 0.36111111111111
21817, 1, 0.85434782608696, 0.27777777777778
21818, 1, 0.8804347826087, 0.30555555555556
21819, 1, 0.85434782608696, 0.22222222222222
21820, 1, 0.8804347826087, 0.25
21821, 1, 0.85434782608696, 0.16666666666667
21822, 1, 0.8804347826087, 0.19444444444444
21823, 1, 0.85434782608696, 0.11111111111111
21824, 1, 0.8804347826087, 0.13888888888889
21825, 1, 0.85434782608696, 0.055555555555556
21826, 1, 0.8804347826087, 0.083333333333333
21827, 1, 0.8804347826087, 0.027777777777778
21828, 1, 0.90652173913043, 0.44444444444444
21829, 1, 0.93260869565217, 0.47222222222222
21830, 1, 0.90652173913043, 0.38888888888889
21831, 1, 0.93260869565217, 0.41666666666667
21832, 1, 0.90652173913043, 0.33333333333333
21833, 1, 0.93260869565217, 0.36111111111111
21834, 1, 0.90652173913043, 0.27777777777778
21835, 1, 0.93260869565217, 0.30555555555556
21836, 1, 0.90652173913043, 0.22222222222222
21837, 1, 0.93260869565217, 0.25
21838, 1, 0.90652173913043, 0.16666666666667
21839, 1, 0.93260869565217, 0.19444444444444
21840, 1, 0.90652173913043, 0.11111111111111
21841, 1, 0.93260869565217, 0.13888888888889
21842, 1, 0.90652173913043, 0.055555555555556
21843, 1, 0.93260869565217, 0.083333333333333
21844, 1, 0.93260869565217, 0.027777777777778
21845, 1, 0.95869565217391, 0.44444444444444
21846, 1, 0.98478260869565, 0.47222222222222
21847, 1, 0.95869565217391, 0.38888888888889
21848, 1, 0.98478260869565, 0.41666666666667
21849, 1, 0.95869565217391, 0.33333333333333
21850, 1, 0.98478260869565, 0.36111111111111
21851, 1, 0.95869565217391, 0.27777777777778
21852, 1, 0.98478260869565, 0.30555555555556
21853, 1, 0.95869565217391, 0.22222222222222
21854, 1, 0.98478260869565, 0.25
21855, 1, 0.95869565217391, 0.16666666666667
21856, 1, 0.98478260869565, 0.19444444444444
21857, 1, 0.95869565217391, 0.11111111111111
21858, 1, 0.98478260869565, 0.13888888888889
21859, 1, 0.95869565217391, 0.055555555555556
21860, 1, 0.98478260869565, 0.083333333333333
21861, 1, 0.98478260869565, 0.027777777777778
21862, 1, 1.0108695652174, 0.44444444444444
21863, 1, 1.0369565217391, 0.47222222222222
21864, 1, 1.0108695652174, 0.38888888888889
21865, 1, 1.0369565217391, 0.41666666666667
21866, 1, 1.0108695652174, 0.33333333333333
21867, 1, 1.0369565217391, 0.36111111111111
21868, 1, 1.0108695652174, 0.27777777777778
21869, 1, 1.0369565217391, 0.30555555555556
21870, 1, 1.0108695652174, 0.22222222222222
21871, 1, 1.0369565217391, 0.25
21872, 1, 1.0108695652174, 0.16666666666667
21873, 1, 1.0369565217391, 0.19444444444444
21874, 1, 1.0108695652174, 0.11111111111111
21875, 1, 1.0369565217391, 0.13888888888889
21876, 1, 1.0108695652174, 0.055555555555556
21877, 1, 1.0369565217391, 0.083333333333333
21878, 1, 1.0369565217391, 0.027777777777778
21879, 1, 1.0630434782609, 0.44444444444444
21880, 1, 1.0891304347826, 0.47222222222222
21881, 1, 1.0630434782609, 0.38888888888889
21882, 1, 1.0891304347826, 0.41666666666667
21883, 1, 1.0630434782609, 0.33333333333333
21884, 1, 1.0891304347826, 0.36111111111111
21885, 1, 1.0630434782609, 0.27777777777778
21886, 1, 1.0891304347826, 0.30555555555556
21887, 1, 1.0630434782609, 0.22222222222222
21888, 1, 1.0891304347826, 0.25
21889, 1, 1.0630434782609, 0.16666666666667
21890, 1, 1.0891304347826, 0.19444444444444
21891, 1, 1.0630434782609, 0.11111111111111
21892, 1, 1.0891304347826, 0.13888888888889
21893, 1, 1.0630434782609, 0.055555555555556
21894, 1, 1.0891304347826, 0.083333333333333
21895, 1, 1.0891304347826, 0.027777777777778
21896, 1, 1.1152173913043, 0.44444444444444
21897, 1, 1.1413043478261, 0.47222222222222
21898, 1, 1.1152173913043, 0.38888888888889
21899, 1, 1.1413043478261, 0.41666666666667
21900, 1, 1.1152173913043, 0.33333333333333
21901, 1, 1.1413043478261, 0.36111111111111
21902, 1, 1.1152173913043, 0.27777777777778
21903, 1, 1.1413043478261, 0.30555555555556
21904, 1, 1.1152173913043, 0.22222222222222
21905, 1, 1.1413043478261, 0.25
21906, 1, 1.1152173913043, 0.16666666666667
21907, 1, 1.1413043478261, 0.19444444444444
21908, 1, 1.1152173913043, 0.11111111111111
21909, 1, 1.1413043478261, 0.13888888888889
21910, 1, 1.1152173913043, 0.055555555555556
21911, 1, 1.1413043478261, 0.083333333333333
21912, 1, 1.1413043478261, 0.027777777777778
21913, 1, 1.1673913043478, 0.44444444444444
21914, 1, 1.1934782608696, 0.47222222222222
21915, 1, 1.1673913043478, 0.38888888888889
21916, 1, 1.1934782608696, 0.41666666666667
21917, 1, 1.1673913043478, 0.33333333333333
21918, 1, 1.1934782608696, 0.36111111111111
21919, 1, 1.1673913043478, 0.27777777777778
21920, 1, 1.1934782608696, 0.30555555555556
21921, 1, 1.1673913043478, 0.22222222222222
21922, 1, 1.1934782608696, 0.25
21923, 1, 1.1673913043478, 0.16666666666667
21924, 1, 1.1934782608696, 0.19444444444444
21925, 1, 1.1673913043478, 0.11111111111111
21926, 1, 1.1934782608696, 0.13888888888889
21927, 1, 1.1673913043478, 0.055555555555556
21928, 1, 1.1934782608696, 0.083333333333333
21929, 1, 1.1934782608696, 0.027777777777778
21930, 1, 1.2195652173913, 0.44444444444444
21931, 1, 1.245652173913, 0.47222222222222
21932, 1, 1.2195652173913, 0.38888888888889
21933, 1, 1.245652173913, 0.41666666666667
21934, 1, 1.2195652173913, 0.33333333333333
21935, 1, 1.245652173913, 0.36111111111111
21936, 1, 1.2195652173913, 0.27777777777778
21937, 1, 1.245652173913, 0.30555555555556
21938, 1, 1.2195652173913, 0.22222222222222
21939, 1, 1.245652173913, 0.25
21940, 1, 1.2195652173913, 0.16666666666667
21941, 1, 1.245652173913, 0.19444444444444
21942, 1, 1.2195652173913, 0.11111111111111
21943, 1, 1.245652173913, 0.13888888888889
21944, 1, 1.2195652173913, 0.055555555555556
21945, 1, 1.245652173913, 0.083333333333333
21946, 1, 1.245652173913, 0.027777777777778
21947, 1, 1.2717391304348, 0.44444444444444
21948, 1, 1.2978260869565, 0.47222222222222
21949, 1, 1.2717391304348, 0.38888888888889
21950, 1, 1.2978260869565, 0.41666666666667
21951, 1, 1.2717391304348, 0.33333333333333
21952, 1, 1.2978260869565, 0.36111111111111
21953, 1, 1.2717391304348, 0.27777777777778
21954, 1, 1.2978260869565, 0.30555555555556
21955, 1, 1.2717391304348, 0.22222222222222
21956, 1, 1.2978260869565, 0.25
21957, 1, 1.2717391304348, 0.16666666666667
21958, 1, 1.2978260869565, 0.19444444444444
21959, 1, 1.2717391304348, 0.11111111111111
21960, 1, 1.2978260869565, 0.13888888888889
21961, 1, 1.2717391304348, 0.055555555555556
21962, 1, 1.2978260869565, 0.083333333333333
21963, 1, 1.2978260869565, 0.027777777777778
21964, 1, 1.3239130434783, 0.44444444444444
21965, 1, 1.3239130434783, 0.38888888888889
21966, 1, 1.3239130434783, 0.33333333333333
21967, 1, 1.3239130434783, 0.27777777777778
21968, 1, 1.3239130434783, 0.22222222222222
21969, 1, 1.3239130434783, 0.16666666666667
21970, 1, 1.3239130434783, 0.11111111111111
21971, 1, 1.3239130434783, 0.055555555555556
21972, 0.95652173913043, 0.20217391304348, 0.5
21973, 0.91304347826087, 0.20217391304348, 0.5
21974, 0.8695652173913, 0.20217391304348, 0.5
21975, 0.82608695652174, 0.20217391304348, 0.5
21976, 0.78260869565217, 0.20217391304348, 0.5
21977, 0.73913043478261, 0.20217391304348, 0.5
21978, 0.69565217391304, 0.20217391304348, 0.5
21979, 0.65217391304348, 0.20217391304348, 0.5
21980, 0.60869565217391, 0.20217391304348, 0.5
21981, 0.56521739130435, 0.20217391304348, 0.5
21982, 0.52173913043478, 0.20217391304348, 0.5
21983, 0.47826086956522, 0.20217391304348, 0.5
21984, 0.43478260869565, 0.20217391304348, 0.5
21985, 0.39130434782609, 0.20217391304348, 0.5
21986, 0.34782608695652, 0.20217391304348, 0.5
21987, 0.30434782608696, 0.20217391304348, 0.5
21988, 0.26086956521739, 0.20217391304348, 0.5
21989, 0.21739130434783, 0.20217391304348, 0.5
21990, 0.17391304347826, 0.20217391304348, 0.5
21991, 0.1304347826087, 0.20217391304348, 0.5
21992, 0.08695652173913, 0.20217391304348, 0.5
21993, 0.043478260869565, 0.20217391304348, 0.5
21994, 0.95652173913043, 0.25434782608696, 0.5
21995, 0.91304347826087, 0.25434782608696, 0.5
21996, 0.8695652173913, 0.25434782608696, 0.5
21997, 0.82608695652174, 0.25434782608696, 0.5
21998, 0.78260869565217, 0.25434782608696, 0.5
21999, 0.73913043478261, 0.25434782608696, 0.5
22000, 0.69565217391304, 0.25434782608696, 0.5
22001, 0.65217391304348, 0.25434782608696, 0.5
22002, 0.60869565217391, 0.25434782608696, 0.5
22003, 0.56521739130435, 0.25434782608696, 0.5
22004, 0.52173913043478, 0.25434782608696, 0.5
22005, 0.47826086956522, 0.25434782608696, 0.5
22006, 0.43478260869565, 0.25434782608696, 0.5
22007, 0.39130434782609, 0.25434782608696, 0.5
22008, 0.34782608695652, 0.25434782608696, 0.5
22009, 0.30434782608696, 0.25434782608696, 0.5
22010, 0.26086956521739, 0.25434782608696, 0.5
22011, 0.21739130434783, 0.25434782608696, 0.5
22012, 0.17391304347826, 0.25434782608696, 0.5
22013, 0.1304347826087, 0.25434782608696, 0.5
22014, 0.08695652173913, 0.25434782608696, 0.5
22015, 0.043478260869565, 0.25434782608696, 0.5
22016, 0.95652173913043, 0.30652173913043, 0.5
22017, 0.91304347826087, 0.30652173913043, 0.5
22018, 0.8695652173913, 0.30652173913043, 0.5
22019, 0.82608695652174, 0.30652173913043, 0.5
22020, 0.78260869565217, 0.30652173913043, 0.5
22021, 0.73913043478261, 0.30652173913043, 0.5
22022, 0.69565217391304, 0.30652173913043, 0.5
22023, 0.65217391304348, 0.30652173913043, 0.5
22024, 0.60869565217391, 0.30652173913043, 0.5
22025, 0.56521739130435, 0.30652173913043, 0.5
22026, 0.52173913043478, 0.30652173913043, 0.5
22027, 0.47826086956522, 0.30652173913043, 0.5
22028, 0.43478260869565, 0.30652173913043, 0.5
22029, 0.39130434782609, 0.30652173913043, 0.5
22030, 0.34782608695652, 0.30652173913043, 0.5
22031, 0.30434782608696, 0.30652173913043, 0.5
22032, 0.26086956521739, 0.30652173913043, 0.5
22033, 0.21739130434783, 0.30652173913043, 0.5
22034, 0.17391304347826, 0.30652173913043, 0.5
22035, 0.1304347826087, 0.30652173913043, 0.5
22036, 0.08695652173913, 0.30652173913043, 0.5
22037, 0.043478260869565, 0.30652173913043, 0.5
22038, 0.95652173913043, 0.35869565217391, 0.5
22039, 0.91304347826087, 0.35869565217391, 0.5
22040, 0.8695652173913, 0.35869565217391, 0.5
22041, 0.82608695652174, 0.35869565217391, 0.5
22042, 0.78260869565217, 0.35869565217391, 0.5
22043, 0.73913043478261, 0.35869565217391, 0.5
22044, 0.69565217391304, 0.35869565217391, 0.5
22045, 0.65217391304348, 0.35869565217391, 0.5
22046, 0.60869565217391, 0.35869565217391, 0.5
22047, 0.56521739130435, 0.35869565217391, 0.5
22048, 0.52173913043478, 0.35869565217391, 0.5
22049, 0.47826086956522, 0.35869565217391, 0.5
22050, 0.43478260869565, 0.35869565217391, 0.5
22051, 0.39130434782609, 0.35869565217391, 0.5
22052, 0.34782608695652, 0.35869565217391, 0.5
22053, 0.30434782608696, 0.35869565217391, 0.5
22054, 0.26086956521739, 0.35869565217391, 0.5
22055, 0.21739130434783, 0.35869565217391, 0.5
22056, 0.17391304347826, 0.35869565217391, 0.5
22057, 0.1304347826087, 0.35869565217391, 0.5
22058, 0.08695652173913, 0.35869565217391, 0.5
22059, 0.043478260869565, 0.35869565217391, 0.5
22060, 0.95652173913043, 0.41086956521739, 0.5
22061, 0.91304347826087, 0.41086956521739, 0.5
22062, 0.8695652173913, 0.41086956521739, 0.5
22063, 0.82608695652174, 0.41086956521739, 0.5
22064, 0.78260869565217, 0.41086956521739, 0.5
22065, 0.73913043478261, 0.41086956521739, 0.5
22066, 0.69565217391304, 0.41086956521739, 0.5
22067, 0.65217391304348, 0.41086956521739, 0.5
22068, 0.60869565217391, 0.41086956521739, 0.5
22069, 0.56521739130435, 0.41086956521739, 0.5
22070, 0.52173913043478, 0.41086956521739, 0.5
22071, 0.47826086956522, 0.41086956521739, 0.5
22072, 0.43478260869565, 0.41086956521739, 0.5
22073, 0.39130434782609, 0.41086956521739, 0.5
22074, 0.34782608695652, 0.41086956521739, 0.5
22075, 0.30434782608696, 0.41086956521739, 0.5
22076, 0.26086956521739, 0.41086956521739, 0.5
22077, 0.21739130434783, 0.41086956521739, 0.5
22078, 0.17391304347826, 0.41086956521739, 0.5
22079, 0.1304347826087, 0.41086956521739, 0.5
22080, 0.08695652173913, 0.41086956521739, 0.5
22081, 0.043478260869565, 0.41086956521739, 0.5
22082, 0.95652173913043, 0.46304347826087, 0.5
22083, 0.91304347826087, 0.46304347826087, 0.5
22084, 0.8695652173913, 0.46304347826087, 0.5
22085, 0.82608695652174, 0.46304347826087, 0.5
22086, 0.78260869565217, 0.46304347826087, 0.5
22087, 0.73913043478261, 0.46304347826087, 0.5
22088, 0.69565217391304, 0.46304347826087, 0.5
22089, 0.65217391304348, 0.46304347826087, 0.5
22090, 0.60869565217391, 0.46304347826087, 0.5
22091, 0.56521739130435, 0.46304347826087, 0.5
22092, 0.52173913043478, 0.46304347826087, 0.5
22093, 0.47826086956522, 0.46304347826087, 0.5
22094, 0.43478260869565, 0.46304347826087, 0.5
22095, 0.39130434782609, 0.46304347826087, 0.5
22096, 0.34782608695652, 0.46304347826087, 0.5
22097, 0.30434782608696, 0.46304347826087, 0.5
22098, 0.26086956521739, 0.46304347826087, 0.5
22099, 0.21739130434783, 0.46304347826087, 0.5
22100, 0.17391304347826, 0.46304347826087, 0.5
22101, 0.1304347826087, 0.46304347826087, 0.5
22102, 0.08695652173913, 0.46304347826087, 0.5
22103, 0.043478260869565, 0.46304347826087, 0.5
22104, 0.95652173913043, 0.51521739130435, 0.5
22105, 0.91304347826087, 0.51521739130435, 0.5
22106, 0.8695652173913, 0.51521739130435, 0.5
22107, 0.82608695652174, 0.51521739130435, 0.5
22108, 0.78260869565217, 0.51521739130435, 0.5
22109, 0.73913043478261, 0.51521739130435, 0.5
22110, 0.69565217391304, 0.51521739130435, 0.5
22111, 0.65217391304348, 0.51521739130435, 0.5
22112, 0.60869565217391, 0.51521739130435, 0.5
22113, 0.56521739130435, 0.51521739130435, 0.5
22114, 0.52173913043478, 0.51521739130435, 0.5
22115, 0.47826086956522, 0.51521739130435, 0.5
22116, 0.43478260869565, 0.51521739130435, 0.5
22117, 0.39130434782609, 0.51521739130435, 0.5
22118, 0.34782608695652, 0.51521739130435, 0.5
22119, 0.30434782608696, 0.51521739130435, 0.5
22120, 0.26086956521739, 0.51521739130435, 0.5
22121, 0.21739130434783, 0.51521739130435, 0.5
22122, 0.17391304347826, 0.51521739130435, 0.5
22123, 0.1304347826087, 0.51521739130435, 0.5
22124, 0.08695652173913, 0.51521739130435, 0.5
22125, 0.043478260869565, 0.51521739130435, 0.5
22126, 0.95652173913043, 0.56739130434783, 0.5
22127, 0.91304347826087, 0.56739130434783, 0.5
22128, 0.8695652173913, 0.56739130434783, 0.5
22129, 0.82608695652174, 0.56739130434783, 0.5
22130, 0.78260869565217, 0.56739130434783, 0.5
22131, 0.73913043478261, 0.56739130434783, 0.5
22132, 0.69565217391304, 0.56739130434783, 0.5
22133, 0.65217391304348, 0.56739130434783, 0.5
22134, 0.60869565217391, 0.56739130434783, 0.5
22135, 0.56521739130435, 0.56739130434783, 0.5
22136, 0.52173913043478, 0.56739130434783, 0.5
22137, 0.47826086956522, 0.56739130434783, 0.5
