46097, 0.10869565217391, 0.51521739130435, 0.38888888888889
46098, 0.08695652173913, 0.48913043478261, 0.38888888888889
46099, 0.08695652173913, 0.51521739130435, 0.41666666666667
46100, 0.10869565217391, 0.51521739130435, 0.44444444444444
46101, 0.08695652173913, 0.48913043478261, 0.44444444444444
46102, 0.08695652173913, 0.51521739130435, 0.47222222222222
46103, 0.043478260869565, 0.51521739130435, 0.027777777777778
46104, 0.065217391304348, 0.51521739130435, 0.055555555555556
46105, 0.043478260869565, 0.48913043478261, 0.055555555555556
46106, 0.043478260869565, 0.51521739130435, 0.083333333333333
46107, 0.065217391304348, 0.51521739130435, 0.11111111111111
46108, 0.043478260869565, 0.48913043478261, 0.11111111111111
46109, 0.043478260869565, 0.51521739130435, 0.13888888888889
46110, 0.065217391304348, 0.51521739130435, 0.16666666666667
46111, 0.043478260869565, 0.48913043478261, 0.16666666666667
46112, 0.043478260869565, 0.51521739130435, 0.19444444444444
46113, 0.065217391304348, 0.51521739130435, 0.22222222222222
46114, 0.043478260869565, 0.48913043478261, 0.22222222222222
46115, 0.043478260869565, 0.51521739130435, 0.25
46116, 0.065217391304348, 0.51521739130435, 0.27777777777778
46117, 0.043478260869565, 0.48913043478261, 0.27777777777778
46118, 0.043478260869565, 0.51521739130435, 0.30555555555556
46119, 0.065217391304348, 0.51521739130435, 0.33333333333333
46120, 0.043478260869565, 0.48913043478261, 0.33333333333333
46121, 0.043478260869565, 0.51521739130435, 0.36111111111111
46122, 0.065217391304348, 0.51521739130435, 0.38888888888889
46123, 0.043478260869565, 0.48913043478261, 0.38888888888889
46124, 0.043478260869565, 0.51521739130435, 0.41666666666667
46125, 0.065217391304348, 0.51521739130435, 0.44444444444444
46126, 0.043478260869565, 0.48913043478261, 0.44444444444444
46127, 0.043478260869565, 0.51521739130435, 0.47222222222222
46128, 0.021739130434783, 0.51521739130435, 0.055555555555556
46129, 0.021739130434783, 0.51521739130435, 0.11111111111111
46130, 0.021739130434783, 0.51521739130435, 0.16666666666667
46131, 0.021739130434783, 0.51521739130435, 0.22222222222222
46132, 0.021739130434783, 0.51521739130435, 0.27777777777778
46133, 0.021739130434783, 0.51521739130435, 0.33333333333333
46134, 0.021739130434783, 0.51521739130435, 0.38888888888889
46135, 0.021739130434783, 0.51521739130435, 0.44444444444444
46136, 0.95652173913043, 0.56739130434783, 0.027777777777778
46137, 0.97826086956522, 0.56739130434783, 0.055555555555556
46138, 0.95652173913043, 0.54130434782609, 0.055555555555556
46139, 0.95652173913043, 0.56739130434783, 0.083333333333333
46140, 0.97826086956522, 0.56739130434783, 0.11111111111111
46141, 0.95652173913044, 0.54130434782609, 0.11111111111111
46142, 0.95652173913044, 0.56739130434783, 0.13888888888889
46143, 0.97826086956522, 0.56739130434783, 0.16666666666667
46144, 0.95652173913043, 0.54130434782609, 0.16666666666667
46145, 0.95652173913044, 0.56739130434783, 0.19444444444444
46146, 0.97826086956522, 0.56739130434783, 0.22222222222222
46147, 0.95652173913044, 0.54130434782609, 0.22222222222222
46148, 0.95652173913044, 0.56739130434783, 0.25
46149, 0.97826086956522, 0.56739130434783, 0.27777777777778
46150, 0.95652173913044, 0.54130434782609, 0.27777777777778
46151, 0.95652173913044, 0.56739130434783, 0.30555555555556
46152, 0.97826086956522, 0.56739130434783, 0.33333333333333
46153, 0.95652173913043, 0.54130434782609, 0.33333333333333
46154, 0.95652173913044, 0.56739130434783, 0.36111111111111
46155, 0.97826086956522, 0.56739130434783, 0.38888888888889
46156, 0.95652173913043, 0.54130434782609, 0.38888888888889
46157, 0.95652173913044, 0.56739130434783, 0.41666666666667
46158, 0.97826086956522, 0.56739130434783, 0.44444444444444
46159, 0.95652173913043, 0.54130434782609, 0.44444444444444
46160, 0.95652173913043, 0.56739130434783, 0.47222222222222
46161, 0.91304347826087, 0.56739130434783, 0.027777777777778
46162, 0.93478260869565, 0.56739130434783, 0.055555555555556
46163, 0.91304347826087, 0.54130434782609, 0.055555555555556
46164, 0.91304347826087, 0.56739130434783, 0.083333333333333
46165, 0.93478260869565, 0.56739130434783, 0.11111111111111
46166, 0.91304347826087, 0.54130434782609, 0.11111111111111
46167, 0.91304347826087, 0.56739130434783, 0.13888888888889
46168, 0.93478260869565, 0.56739130434783, 0.16666666666667
46169, 0.91304347826087, 0.54130434782609, 0.16666666666667
46170, 0.91304347826087, 0.56739130434783, 0.19444444444444
46171, 0.93478260869565, 0.56739130434783, 0.22222222222222
46172, 0.91304347826087, 0.54130434782609, 0.22222222222222
46173, 0.91304347826087, 0.56739130434783, 0.25
46174, 0.93478260869565, 0.56739130434783, 0.27777777777778
46175, 0.91304347826087, 0.54130434782609, 0.27777777777778
46176, 0.91304347826087, 0.56739130434783, 0.30555555555556
46177, 0.93478260869565, 0.56739130434783, 0.33333333333333
46178, 0.91304347826087, 0.54130434782609, 0.33333333333333
46179, 0.91304347826087, 0.56739130434783, 0.36111111111111
46180, 0.93478260869565, 0.56739130434783, 0.38888888888889
46181, 0.91304347826087, 0.54130434782609, 0.38888888888889
46182, 0.91304347826087, 0.56739130434783, 0.41666666666667
46183, 0.93478260869565, 0.56739130434783, 0.44444444444444
46184, 0.91304347826087, 0.54130434782609, 0.44444444444444
46185, 0.91304347826087, 0.56739130434783, 0.47222222222222
46186, 0.8695652173913, 0.56739130434783, 0.027777777777778
46187, 0.89130434782609, 0.56739130434783, 0.055555555555556
46188, 0.8695652173913, 0.54130434782609, 0.055555555555556
46189, 0.8695652173913, 0.56739130434783, 0.083333333333333
46190, 0.89130434782609, 0.56739130434783, 0.11111111111111
46191, 0.8695652173913, 0.54130434782609, 0.11111111111111
46192, 0.8695652173913, 0.56739130434783, 0.13888888888889
46193, 0.89130434782609, 0.56739130434783, 0.16666666666667
46194, 0.8695652173913, 0.54130434782609, 0.16666666666667
46195, 0.8695652173913, 0.56739130434783, 0.19444444444444
46196, 0.89130434782609, 0.56739130434783, 0.22222222222222
46197, 0.8695652173913, 0.54130434782609, 0.22222222222222
46198, 0.8695652173913, 0.56739130434783, 0.25
46199, 0.89130434782609, 0.56739130434783, 0.27777777777778
46200, 0.8695652173913, 0.54130434782609, 0.27777777777778
46201, 0.8695652173913, 0.56739130434783, 0.30555555555556
46202, 0.89130434782609, 0.56739130434783, 0.33333333333333
46203, 0.8695652173913, 0.54130434782609, 0.33333333333333
46204, 0.8695652173913, 0.56739130434783, 0.36111111111111
46205, 0.89130434782609, 0.56739130434783, 0.38888888888889
46206, 0.8695652173913, 0.54130434782609, 0.38888888888889
46207, 0.8695652173913, 0.56739130434783, 0.41666666666667
46208, 0.89130434782609, 0.56739130434783, 0.44444444444444
46209, 0.8695652173913, 0.54130434782609, 0.44444444444444
46210, 0.8695652173913, 0.56739130434783, 0.47222222222222
46211, 0.82608695652174, 0.56739130434783, 0.027777777777778
46212, 0.84782608695652, 0.56739130434783, 0.055555555555556
46213, 0.82608695652174, 0.54130434782609, 0.055555555555556
46214, 0.82608695652174, 0.56739130434783, 0.083333333333333
46215, 0.84782608695652, 0.56739130434783, 0.11111111111111
46216, 0.82608695652174, 0.54130434782609, 0.11111111111111
46217, 0.82608695652174, 0.56739130434783, 0.13888888888889
46218, 0.84782608695652, 0.56739130434783, 0.16666666666667
46219, 0.82608695652174, 0.54130434782609, 0.16666666666667
46220, 0.82608695652174, 0.56739130434783, 0.19444444444444
46221, 0.84782608695652, 0.56739130434783, 0.22222222222222
46222, 0.82608695652174, 0.54130434782609, 0.22222222222222
46223, 0.82608695652174, 0.56739130434783, 0.25
46224, 0.84782608695652, 0.56739130434783, 0.27777777777778
46225, 0.82608695652174, 0.54130434782609, 0.27777777777778
46226, 0.82608695652174, 0.56739130434783, 0.30555555555556
46227, 0.84782608695652, 0.56739130434783, 0.33333333333333
46228, 0.82608695652174, 0.54130434782609, 0.33333333333333
46229, 0.82608695652174, 0.56739130434783, 0.36111111111111
46230, 0.84782608695652, 0.56739130434783, 0.38888888888889
46231, 0.82608695652174, 0.54130434782609, 0.38888888888889
46232, 0.82608695652174, 0.56739130434783, 0.41666666666667
46233, 0.84782608695652, 0.56739130434783, 0.44444444444444
46234, 0.82608695652174, 0.54130434782609, 0.44444444444444
46235, 0.82608695652174, 0.56739130434783, 0.47222222222222
46236, 0.78260869565217, 0.56739130434783, 0.027777777777778
46237, 0.80434782608696, 0.56739130434783, 0.055555555555556
46238, 0.78260869565217, 0.54130434782609, 0.055555555555556
46239, 0.78260869565217, 0.56739130434783, 0.083333333333333
46240, 0.80434782608696, 0.56739130434783, 0.11111111111111
46241, 0.78260869565217, 0.54130434782609, 0.11111111111111
46242, 0.78260869565217, 0.56739130434783, 0.13888888888889
46243, 0.80434782608696, 0.56739130434783, 0.16666666666667
46244, 0.78260869565217, 0.54130434782609, 0.16666666666667
46245, 0.78260869565217, 0.56739130434783, 0.19444444444444
46246, 0.80434782608696, 0.56739130434783, 0.22222222222222
46247, 0.78260869565217, 0.54130434782609, 0.22222222222222
46248, 0.78260869565217, 0.56739130434783, 0.25
46249, 0.80434782608696, 0.56739130434783, 0.27777777777778
46250, 0.78260869565217, 0.54130434782609, 0.27777777777778
46251, 0.78260869565217, 0.56739130434783, 0.30555555555556
46252, 0.80434782608696, 0.56739130434783, 0.33333333333333
46253, 0.78260869565217, 0.54130434782609, 0.33333333333333
46254, 0.78260869565217, 0.56739130434783, 0.36111111111111
46255, 0.80434782608696, 0.56739130434783, 0.38888888888889
46256, 0.78260869565217, 0.54130434782609, 0.38888888888889
46257, 0.78260869565217, 0.56739130434783, 0.41666666666667
46258, 0.80434782608696, 0.56739130434783, 0.44444444444444
46259, 0.78260869565217, 0.54130434782609, 0.44444444444444
46260, 0.78260869565217, 0.56739130434783, 0.47222222222222
46261, 0.73913043478261, 0.56739130434783, 0.027777777777778
46262, 0.76086956521739, 0.56739130434783, 0.055555555555556
46263, 0.73913043478261, 0.54130434782609, 0.055555555555556
46264, 0.73913043478261, 0.56739130434783, 0.083333333333333
46265, 0.76086956521739, 0.56739130434783, 0.11111111111111
46266, 0.73913043478261, 0.54130434782609, 0.11111111111111
46267, 0.73913043478261, 0.56739130434783, 0.13888888888889
46268, 0.76086956521739, 0.56739130434783, 0.16666666666667
46269, 0.73913043478261, 0.54130434782609, 0.16666666666667
46270, 0.73913043478261, 0.56739130434783, 0.19444444444444
46271, 0.76086956521739, 0.56739130434783, 0.22222222222222
46272, 0.73913043478261, 0.54130434782609, 0.22222222222222
46273, 0.73913043478261, 0.56739130434783, 0.25
46274, 0.76086956521739, 0.56739130434783, 0.27777777777778
46275, 0.73913043478261, 0.54130434782609, 0.27777777777778
46276, 0.73913043478261, 0.56739130434783, 0.30555555555556
46277, 0.76086956521739, 0.56739130434783, 0.33333333333333
46278, 0.73913043478261, 0.54130434782609, 0.33333333333333
46279, 0.73913043478261, 0.56739130434783, 0.36111111111111
46280, 0.76086956521739, 0.56739130434783, 0.38888888888889
46281, 0.73913043478261, 0.54130434782609, 0.38888888888889
46282, 0.73913043478261, 0.56739130434783, 0.41666666666667
46283, 0.76086956521739, 0.56739130434783, 0.44444444444444
46284, 0.73913043478261, 0.54130434782609, 0.44444444444444
46285, 0.73913043478261, 0.56739130434783, 0.47222222222222
46286, 0.69565217391304, 0.56739130434783, 0.027777777777778
46287, 0.71739130434783, 0.56739130434783, 0.055555555555556
46288, 0.69565217391304, 0.54130434782609, 0.055555555555556
46289, 0.69565217391304, 0.56739130434783, 0.083333333333333
46290, 0.71739130434783, 0.56739130434783, 0.11111111111111
46291, 0.69565217391304, 0.54130434782609, 0.11111111111111
46292, 0.69565217391304, 0.56739130434783, 0.13888888888889
46293, 0.71739130434783, 0.56739130434783, 0.16666666666667
46294, 0.69565217391304, 0.54130434782609, 0.16666666666667
46295, 0.69565217391304, 0.56739130434783, 0.19444444444444
46296, 0.71739130434783, 0.56739130434783, 0.22222222222222
46297, 0.69565217391304, 0.54130434782609, 0.22222222222222
46298, 0.69565217391304, 0.56739130434783, 0.25
46299, 0.71739130434783, 0.56739130434783, 0.27777777777778
46300, 0.69565217391304, 0.54130434782609, 0.27777777777778
46301, 0.69565217391304, 0.56739130434783, 0.30555555555556
46302, 0.71739130434783, 0.56739130434783, 0.33333333333333
46303, 0.69565217391304, 0.54130434782609, 0.33333333333333
46304, 0.69565217391304, 0.56739130434783, 0.36111111111111
46305, 0.71739130434783, 0.56739130434783, 0.38888888888889
46306, 0.69565217391304, 0.54130434782609, 0.38888888888889
46307, 0.69565217391304, 0.56739130434783, 0.41666666666667
46308, 0.71739130434783, 0.56739130434783, 0.44444444444444
46309, 0.69565217391304, 0.54130434782609, 0.44444444444444
46310, 0.69565217391304, 0.56739130434783, 0.47222222222222
46311, 0.65217391304348, 0.56739130434783, 0.027777777777778
46312, 0.67391304347826, 0.56739130434783, 0.055555555555556
46313, 0.65217391304348, 0.54130434782609, 0.055555555555556
46314, 0.65217391304348, 0.56739130434783, 0.083333333333333
46315, 0.67391304347826, 0.56739130434783, 0.11111111111111
46316, 0.65217391304348, 0.54130434782609, 0.11111111111111
46317, 0.65217391304348, 0.56739130434783, 0.13888888888889
46318, 0.67391304347826, 0.56739130434783, 0.16666666666667
46319, 0.65217391304348, 0.54130434782609, 0.16666666666667
46320, 0.65217391304348, 0.56739130434783, 0.19444444444444
46321, 0.67391304347826, 0.56739130434783, 0.22222222222222
46322, 0.65217391304348, 0.54130434782609, 0.22222222222222
46323, 0.65217391304348, 0.56739130434783, 0.25
46324, 0.67391304347826, 0.56739130434783, 0.27777777777778
46325, 0.65217391304348, 0.54130434782609, 0.27777777777778
46326, 0.65217391304348, 0.56739130434783, 0.30555555555556
46327, 0.67391304347826, 0.56739130434783, 0.33333333333333
46328, 0.65217391304348, 0.54130434782609, 0.33333333333333
46329, 0.65217391304348, 0.56739130434783, 0.36111111111111
46330, 0.67391304347826, 0.56739130434783, 0.38888888888889
46331, 0.65217391304348, 0.54130434782609, 0.38888888888889
46332, 0.65217391304348, 0.56739130434783, 0.41666666666667
46333, 0.67391304347826, 0.56739130434783, 0.44444444444444
46334, 0.65217391304348, 0.54130434782609, 0.44444444444444
46335, 0.65217391304348, 0.56739130434783, 0.47222222222222
46336, 0.60869565217391, 0.56739130434783, 0.027777777777778
46337, 0.6304347826087, 0.56739130434783, 0.055555555555556
46338, 0.60869565217391, 0.54130434782609, 0.055555555555556
46339, 0.60869565217391, 0.56739130434783, 0.083333333333333
46340, 0.6304347826087, 0.56739130434783, 0.11111111111111
46341, 0.60869565217391, 0.54130434782609, 0.11111111111111
46342, 0.60869565217391, 0.56739130434783, 0.13888888888889
46343, 0.6304347826087, 0.56739130434783, 0.16666666666667
46344, 0.60869565217391, 0.54130434782609, 0.16666666666667
46345, 0.60869565217391, 0.56739130434783, 0.19444444444444
46346, 0.6304347826087, 0.56739130434783, 0.22222222222222
46347, 0.60869565217391, 0.54130434782609, 0.22222222222222
46348, 0.60869565217391, 0.56739130434783, 0.25
46349, 0.6304347826087, 0.56739130434783, 0.27777777777778
46350, 0.60869565217391, 0.54130434782609, 0.27777777777778
46351, 0.60869565217391, 0.56739130434783, 0.30555555555556
46352, 0.6304347826087, 0.56739130434783, 0.33333333333333
46353, 0.60869565217391, 0.54130434782609, 0.33333333333333
46354, 0.60869565217391, 0.56739130434783, 0.36111111111111
46355, 0.6304347826087, 0.56739130434783, 0.38888888888889
46356, 0.60869565217391, 0.54130434782609, 0.38888888888889
46357, 0.60869565217391, 0.56739130434783, 0.41666666666667
46358, 0.6304347826087, 0.56739130434783, 0.44444444444444
46359, 0.60869565217391, 0.54130434782609, 0.44444444444444
46360, 0.60869565217391, 0.56739130434783, 0.47222222222222
46361, 0.56521739130435, 0.56739130434783, 0.027777777777778
46362, 0.58695652173913, 0.56739130434783, 0.055555555555556
46363, 0.56521739130435, 0.54130434782609, 0.055555555555556
46364, 0.56521739130435, 0.56739130434783, 0.083333333333333
46365, 0.58695652173913, 0.56739130434783, 0.11111111111111
46366, 0.56521739130435, 0.54130434782609, 0.11111111111111
46367, 0.56521739130435, 0.56739130434783, 0.13888888888889
46368, 0.58695652173913, 0.56739130434783, 0.16666666666667
46369, 0.56521739130435, 0.54130434782609, 0.16666666666667
46370, 0.56521739130435, 0.56739130434783, 0.19444444444444
46371, 0.58695652173913, 0.56739130434783, 0.22222222222222
46372, 0.56521739130435, 0.54130434782609, 0.22222222222222
46373, 0.56521739130435, 0.56739130434783, 0.25
46374, 0.58695652173913, 0.56739130434783, 0.27777777777778
46375, 0.56521739130435, 0.54130434782609, 0.27777777777778
46376, 0.56521739130435, 0.56739130434783, 0.30555555555556
46377, 0.58695652173913, 0.56739130434783, 0.33333333333333
46378, 0.56521739130435, 0.54130434782609, 0.33333333333333
46379, 0.56521739130435, 0.56739130434783, 0.36111111111111
46380, 0.58695652173913, 0.56739130434783, 0.38888888888889
46381, 0.56521739130435, 0.54130434782609, 0.38888888888889
46382, 0.56521739130435, 0.56739130434783, 0.41666666666667
46383, 0.58695652173913, 0.56739130434783, 0.44444444444444
46384, 0.56521739130435, 0.54130434782609, 0.44444444444444
46385, 0.56521739130435, 0.56739130434783, 0.47222222222222
46386, 0.52173913043478, 0.56739130434783, 0.027777777777778
46387, 0.54347826086957, 0.56739130434783, 0.055555555555556
46388, 0.52173913043478, 0.54130434782609, 0.055555555555556
46389, 0.52173913043478, 0.56739130434783, 0.083333333333333
46390, 0.54347826086956, 0.56739130434783, 0.11111111111111
46391, 0.52173913043478, 0.54130434782609, 0.11111111111111
46392, 0.52173913043478, 0.56739130434783, 0.13888888888889
46393, 0.54347826086957, 0.56739130434783, 0.16666666666667
46394, 0.52173913043478, 0.54130434782609, 0.16666666666667
46395, 0.52173913043478, 0.56739130434783, 0.19444444444444
46396, 0.54347826086956, 0.56739130434783, 0.22222222222222
46397, 0.52173913043478, 0.54130434782609, 0.22222222222222
46398, 0.52173913043478, 0.56739130434783, 0.25
46399, 0.54347826086956, 0.56739130434783, 0.27777777777778
46400, 0.52173913043478, 0.54130434782609, 0.27777777777778
46401, 0.52173913043478, 0.56739130434783, 0.30555555555556
46402, 0.54347826086956, 0.56739130434783, 0.33333333333333
46403, 0.52173913043478, 0.54130434782609, 0.33333333333333
46404, 0.52173913043478, 0.56739130434783, 0.36111111111111
46405, 0.54347826086956, 0.56739130434783, 0.38888888888889
46406, 0.52173913043478, 0.54130434782609, 0.38888888888889
46407, 0.52173913043478, 0.56739130434783, 0.41666666666667
46408, 0.54347826086956, 0.56739130434783, 0.44444444444444
46409, 0.52173913043478, 0.54130434782609, 0.44444444444444
46410, 0.52173913043478, 0.56739130434783, 0.47222222222222
46411, 0.47826086956522, 0.56739130434783, 0.027777777777778
46412, 0.5, 0.56739130434783, 0.055555555555556
46413, 0.47826086956522, 0.54130434782609, 0.055555555555556
46414, 0.47826086956522, 0.56739130434783, 0.083333333333333
46415, 0.5, 0.56739130434783, 0.11111111111111
46416, 0.47826086956522, 0.54130434782609, 0.11111111111111
46417, 0.47826086956522, 0.56739130434783, 0.13888888888889
46418, 0.5, 0.56739130434783, 0.16666666666667
46419, 0.47826086956522, 0.54130434782609, 0.16666666666667
46420, 0.47826086956522, 0.56739130434783, 0.19444444444444
46421, 0.5, 0.56739130434783, 0.22222222222222
46422, 0.47826086956522, 0.54130434782609, 0.22222222222222
46423, 0.47826086956522, 0.56739130434783, 0.25
46424, 0.5, 0.56739130434783, 0.27777777777778
46425, 0.47826086956522, 0.54130434782609, 0.27777777777778
46426, 0.47826086956522, 0.56739130434783, 0.30555555555556
46427, 0.5, 0.56739130434783, 0.33333333333333
46428, 0.47826086956522, 0.54130434782609, 0.33333333333333
46429, 0.47826086956522, 0.56739130434783, 0.36111111111111
46430, 0.5, 0.56739130434783, 0.38888888888889
46431, 0.47826086956522, 0.54130434782609, 0.38888888888889
46432, 0.47826086956522, 0.56739130434783, 0.41666666666667
46433, 0.5, 0.56739130434783, 0.44444444444444
46434, 0.47826086956522, 0.54130434782609, 0.44444444444444
46435, 0.47826086956522, 0.56739130434783, 0.47222222222222
46436, 0.43478260869565, 0.56739130434783, 0.027777777777778
46437, 0.45652173913043, 0.56739130434783, 0.055555555555556
46438, 0.43478260869565, 0.54130434782609, 0.055555555555556
46439, 0.43478260869565, 0.56739130434783, 0.083333333333333
46440, 0.45652173913043, 0.56739130434783, 0.11111111111111
46441, 0.43478260869565, 0.54130434782609, 0.11111111111111
46442, 0.43478260869565, 0.56739130434783, 0.13888888888889
46443, 0.45652173913043, 0.56739130434783, 0.16666666666667
46444, 0.43478260869565, 0.54130434782609, 0.16666666666667
46445, 0.43478260869565, 0.56739130434783, 0.19444444444444
46446, 0.45652173913043, 0.56739130434783, 0.22222222222222
46447, 0.43478260869565, 0.54130434782609, 0.22222222222222
46448, 0.43478260869565, 0.56739130434783, 0.25
46449, 0.45652173913043, 0.56739130434783, 0.27777777777778
46450, 0.43478260869565, 0.54130434782609, 0.27777777777778
46451, 0.43478260869565, 0.56739130434783, 0.30555555555556
46452, 0.45652173913043, 0.56739130434783, 0.33333333333333
46453, 0.43478260869565, 0.54130434782609, 0.33333333333333
46454, 0.43478260869565, 0.56739130434783, 0.36111111111111
46455, 0.45652173913043, 0.56739130434783, 0.38888888888889
46456, 0.43478260869565, 0.54130434782609, 0.38888888888889
46457, 0.43478260869565, 0.56739130434783, 0.41666666666667
46458, 0.45652173913043, 0.56739130434783, 0.44444444444444
46459, 0.43478260869565, 0.54130434782609, 0.44444444444444
46460, 0.43478260869565, 0.56739130434783, 0.47222222222222
46461, 0.39130434782609, 0.56739130434783, 0.027777777777778
46462, 0.41304347826087, 0.56739130434783, 0.055555555555556
46463, 0.39130434782609, 0.54130434782609, 0.055555555555556
46464, 0.39130434782609, 0.56739130434783, 0.083333333333333
46465, 0.41304347826087, 0.56739130434783, 0.11111111111111
46466, 0.39130434782609, 0.54130434782609, 0.11111111111111
46467, 0.39130434782609, 0.56739130434783, 0.13888888888889
46468, 0.41304347826087, 0.56739130434783, 0.16666666666667
46469, 0.39130434782609, 0.54130434782609, 0.16666666666667
46470, 0.39130434782609, 0.56739130434783, 0.19444444444444
46471, 0.41304347826087, 0.56739130434783, 0.22222222222222
46472, 0.39130434782609, 0.54130434782609, 0.22222222222222
46473, 0.39130434782609, 0.56739130434783, 0.25
46474, 0.41304347826087, 0.56739130434783, 0.27777777777778
46475, 0.39130434782609, 0.54130434782609, 0.27777777777778
46476, 0.39130434782609, 0.56739130434783, 0.30555555555556
46477, 0.41304347826087, 0.56739130434783, 0.33333333333333
46478, 0.39130434782609, 0.54130434782609, 0.33333333333333
46479, 0.39130434782609, 0.56739130434783, 0.36111111111111
46480, 0.41304347826087, 0.56739130434783, 0.38888888888889
46481, 0.39130434782609, 0.54130434782609, 0.38888888888889
46482, 0.39130434782609, 0.56739130434783, 0.41666666666667
46483, 0.41304347826087, 0.56739130434783, 0.44444444444444
46484, 0.39130434782609, 0.54130434782609, 0.44444444444444
46485, 0.39130434782609, 0.56739130434783, 0.47222222222222
46486, 0.34782608695652, 0.56739130434783, 0.027777777777778
46487, 0.3695652173913, 0.56739130434783, 0.055555555555556
46488, 0.34782608695652, 0.54130434782609, 0.055555555555556
46489, 0.34782608695652, 0.56739130434783, 0.083333333333333
46490, 0.3695652173913, 0.56739130434783, 0.11111111111111
46491, 0.34782608695652, 0.54130434782609, 0.11111111111111
46492, 0.34782608695652, 0.56739130434783, 0.13888888888889
46493, 0.3695652173913, 0.56739130434783, 0.16666666666667
46494, 0.34782608695652, 0.54130434782609, 0.16666666666667
46495, 0.34782608695652, 0.56739130434783, 0.19444444444444
46496, 0.3695652173913, 0.56739130434783, 0.22222222222222
46497, 0.34782608695652, 0.54130434782609, 0.22222222222222
46498, 0.34782608695652, 0.56739130434783, 0.25
46499, 0.3695652173913, 0.56739130434783, 0.27777777777778
46500, 0.34782608695652, 0.54130434782609, 0.27777777777778
46501, 0.34782608695652, 0.56739130434783, 0.30555555555556
46502, 0.3695652173913, 0.56739130434783, 0.33333333333333
46503, 0.34782608695652, 0.54130434782609, 0.33333333333333
46504, 0.34782608695652, 0.56739130434783, 0.36111111111111
46505, 0.3695652173913, 0.56739130434783, 0.38888888888889
46506, 0.34782608695652, 0.54130434782609, 0.38888888888889
46507, 0.34782608695652, 0.56739130434783, 0.41666666666667
46508, 0.3695652173913, 0.56739130434783, 0.44444444444444
46509, 0.34782608695652, 0.54130434782609, 0.44444444444444
46510, 0.34782608695652, 0.56739130434783, 0.47222222222222
46511, 0.30434782608696, 0.56739130434783, 0.027777777777778
46512, 0.32608695652174, 0.56739130434783, 0.055555555555556
46513, 0.30434782608696, 0.54130434782609, 0.055555555555556
46514, 0.30434782608696, 0.56739130434783, 0.083333333333333
46515, 0.32608695652174, 0.56739130434783, 0.11111111111111
46516, 0.30434782608696, 0.54130434782609, 0.11111111111111
46517, 0.30434782608696, 0.56739130434783, 0.13888888888889
46518, 0.32608695652174, 0.56739130434783, 0.16666666666667
46519, 0.30434782608696, 0.54130434782609, 0.16666666666667
46520, 0.30434782608696, 0.56739130434783, 0.19444444444444
46521, 0.32608695652174, 0.56739130434783, 0.22222222222222
46522, 0.30434782608696, 0.54130434782609, 0.22222222222222
46523, 0.30434782608696, 0.56739130434783, 0.25
46524, 0.32608695652174, 0.56739130434783, 0.27777777777778
46525, 0.30434782608696, 0.54130434782609, 0.27777777777778
46526, 0.30434782608696, 0.56739130434783, 0.30555555555556
46527, 0.32608695652174, 0.56739130434783, 0.33333333333333
46528, 0.30434782608696, 0.54130434782609, 0.33333333333333
46529, 0.30434782608696, 0.56739130434783, 0.36111111111111
46530, 0.32608695652174, 0.56739130434783, 0.38888888888889
46531, 0.30434782608696, 0.54130434782609, 0.38888888888889
46532, 0.30434782608696, 0.56739130434783, 0.41666666666667
46533, 0.32608695652174, 0.56739130434783, 0.44444444444444
46534, 0.30434782608696, 0.54130434782609, 0.44444444444444
46535, 0.30434782608696, 0.56739130434783, 0.47222222222222
46536, 0.26086956521739, 0.56739130434783, 0.027777777777778
46537, 0.28260869565217, 0.56739130434783, 0.055555555555556
46538, 0.26086956521739, 0.54130434782609, 0.055555555555556
46539, 0.26086956521739, 0.56739130434783, 0.083333333333333
46540, 0.28260869565217, 0.56739130434783, 0.11111111111111
46541, 0.26086956521739, 0.54130434782609, 0.11111111111111
46542, 0.26086956521739, 0.56739130434783, 0.13888888888889
46543, 0.28260869565217, 0.56739130434783, 0.16666666666667
46544, 0.26086956521739, 0.54130434782609, 0.16666666666667
46545, 0.26086956521739, 0.56739130434783, 0.19444444444444
46546, 0.28260869565217, 0.56739130434783, 0.22222222222222
46547, 0.26086956521739, 0.54130434782609, 0.22222222222222
46548, 0.26086956521739, 0.56739130434783, 0.25
46549, 0.28260869565217, 0.56739130434783, 0.27777777777778
46550, 0.26086956521739, 0.54130434782609, 0.27777777777778
46551, 0.26086956521739, 0.56739130434783, 0.30555555555556
46552, 0.28260869565217, 0.56739130434783, 0.33333333333333
46553, 0.26086956521739, 0.54130434782609, 0.33333333333333
46554, 0.26086956521739, 0.56739130434783, 0.36111111111111
46555, 0.28260869565217, 0.56739130434783, 0.38888888888889
46556, 0.26086956521739, 0.54130434782609, 0.38888888888889
46557, 0.26086956521739, 0.56739130434783, 0.41666666666667
46558, 0.28260869565217, 0.56739130434783, 0.44444444444444
46559, 0.26086956521739, 0.54130434782609, 0.44444444444444
46560, 0.26086956521739, 0.56739130434783, 0.47222222222222
46561, 0.21739130434783, 0.56739130434783, 0.027777777777778
46562, 0.23913043478261, 0.56739130434783, 0.055555555555556
46563, 0.21739130434783, 0.54130434782609, 0.055555555555556
46564, 0.21739130434783, 0.56739130434783, 0.083333333333333
46565, 0.23913043478261, 0.56739130434783, 0.11111111111111
46566, 0.21739130434783, 0.54130434782609, 0.11111111111111
46567, 0.21739130434783, 0.56739130434783, 0.13888888888889
46568, 0.23913043478261, 0.56739130434783, 0.16666666666667
46569, 0.21739130434783, 0.54130434782609, 0.16666666666667
46570, 0.21739130434783, 0.56739130434783, 0.19444444444444
46571, 0.23913043478261, 0.56739130434783, 0.22222222222222
46572, 0.21739130434783, 0.54130434782609, 0.22222222222222
46573, 0.21739130434783, 0.56739130434783, 0.25
46574, 0.23913043478261, 0.56739130434783, 0.27777777777778
46575, 0.21739130434783, 0.54130434782609, 0.27777777777778
46576, 0.21739130434783, 0.56739130434783, 0.30555555555556
46577, 0.23913043478261, 0.56739130434783, 0.33333333333333
46578, 0.21739130434783, 0.54130434782609, 0.33333333333333
46579, 0.21739130434783, 0.56739130434783, 0.36111111111111
46580, 0.23913043478261, 0.56739130434783, 0.38888888888889
46581, 0.21739130434783, 0.54130434782609, 0.38888888888889
46582, 0.21739130434783, 0.56739130434783, 0.41666666666667
46583, 0.23913043478261, 0.56739130434783, 0.44444444444444
46584, 0.21739130434783, 0.54130434782609, 0.44444444444444
46585, 0.21739130434783, 0.56739130434783, 0.47222222222222
46586, 0.17391304347826, 0.56739130434783, 0.027777777777778
46587, 0.19565217391304, 0.56739130434783, 0.055555555555556
46588, 0.17391304347826, 0.54130434782609, 0.055555555555556
46589, 0.17391304347826, 0.56739130434783, 0.083333333333333
46590, 0.19565217391304, 0.56739130434783, 0.11111111111111
46591, 0.17391304347826, 0.54130434782609, 0.11111111111111
46592, 0.17391304347826, 0.56739130434783, 0.13888888888889
46593, 0.19565217391304, 0.56739130434783, 0.16666666666667
46594, 0.17391304347826, 0.54130434782609, 0.16666666666667
46595, 0.17391304347826, 0.56739130434783, 0.19444444444444
46596, 0.19565217391304, 0.56739130434783, 0.22222222222222
46597, 0.17391304347826, 0.54130434782609, 0.22222222222222
46598, 0.17391304347826, 0.56739130434783, 0.25
46599, 0.19565217391304, 0.56739130434783, 0.27777777777778
46600, 0.17391304347826, 0.54130434782609, 0.27777777777778
46601, 0.17391304347826, 0.56739130434783, 0.30555555555556
46602, 0.19565217391304, 0.56739130434783, 0.33333333333333
46603, 0.17391304347826, 0.54130434782609, 0.33333333333333
46604, 0.17391304347826, 0.56739130434783, 0.36111111111111
46605, 0.19565217391304, 0.56739130434783, 0.38888888888889
46606, 0.17391304347826, 0.54130434782609, 0.38888888888889
46607, 0.17391304347826, 0.56739130434783, 0.41666666666667
46608, 0.19565217391304, 0.56739130434783, 0.44444444444444
46609, 0.17391304347826, 0.54130434782609, 0.44444444444444
46610, 0.17391304347826, 0.56739130434783, 0.47222222222222
46611, 0.1304347826087, 0.56739130434783, 0.027777777777778
46612, 0.15217391304348, 0.56739130434783, 0.055555555555556
46613, 0.1304347826087, 0.54130434782609, 0.055555555555556
46614, 0.1304347826087, 0.56739130434783, 0.083333333333333
46615, 0.15217391304348, 0.56739130434783, 0.11111111111111
46616, 0.1304347826087, 0.54130434782609, 0.11111111111111
46617, 0.1304347826087, 0.56739130434783, 0.13888888888889
46618, 0.15217391304348, 0.56739130434783, 0.16666666666667
46619, 0.1304347826087, 0.54130434782609, 0.16666666666667
46620, 0.1304347826087, 0.56739130434783, 0.19444444444444
46621, 0.15217391304348, 0.56739130434783, 0.22222222222222
46622, 0.1304347826087, 0.54130434782609, 0.22222222222222
46623, 0.1304347826087, 0.56739130434783, 0.25
46624, 0.15217391304348, 0.56739130434783, 0.27777777777778
46625, 0.1304347826087, 0.54130434782609, 0.27777777777778
46626, 0.1304347826087, 0.56739130434783, 0.30555555555556
46627, 0.15217391304348, 0.56739130434783, 0.33333333333333
46628, 0.1304347826087, 0.54130434782609, 0.33333333333333
46629, 0.1304347826087, 0.56739130434783, 0.36111111111111
46630, 0.15217391304348, 0.56739130434783, 0.38888888888889
46631, 0.1304347826087, 0.54130434782609, 0.38888888888889
46632, 0.1304347826087, 0.56739130434783, 0.41666666666667
46633, 0.15217391304348, 0.56739130434783, 0.44444444444444
46634, 0.1304347826087, 0.54130434782609, 0.44444444444444
46635, 0.1304347826087, 0.56739130434783, 0.47222222222222
46636, 0.08695652173913, 0.56739130434783, 0.027777777777778
46637, 0.10869565217391, 0.56739130434783, 0.055555555555556
46638, 0.08695652173913, 0.54130434782609, 0.055555555555556
46639, 0.08695652173913, 0.56739130434783, 0.083333333333333
46640, 0.10869565217391, 0.56739130434783, 0.11111111111111
46641, 0.08695652173913, 0.54130434782609, 0.11111111111111
46642, 0.08695652173913, 0.56739130434783, 0.13888888888889
46643, 0.10869565217391, 0.56739130434783, 0.16666666666667
46644, 0.08695652173913, 0.54130434782609, 0.16666666666667
46645, 0.08695652173913, 0.56739130434783, 0.19444444444444
46646, 0.10869565217391, 0.56739130434783, 0.22222222222222
46647, 0.08695652173913, 0.54130434782609, 0.22222222222222
46648, 0.08695652173913, 0.56739130434783, 0.25
46649, 0.10869565217391, 0.56739130434783, 0.27777777777778
46650, 0.08695652173913, 0.54130434782609, 0.27777777777778
46651, 0.08695652173913, 0.56739130434783, 0.30555555555556
46652, 0.10869565217391, 0.56739130434783, 0.33333333333333
46653, 0.08695652173913, 0.54130434782609, 0.33333333333333
46654, 0.08695652173913, 0.56739130434783, 0.36111111111111
46655, 0.10869565217391, 0.56739130434783, 0.38888888888889
46656, 0.08695652173913, 0.54130434782609, 0.38888888888889
46657, 0.08695652173913, 0.56739130434783, 0.41666666666667
46658, 0.10869565217391, 0.56739130434783, 0.44444444444444
46659, 0.08695652173913, 0.54130434782609, 0.44444444444444
46660, 0.08695652173913, 0.56739130434783, 0.47222222222222
46661, 0.043478260869565, 0.56739130434783, 0.027777777777778
46662, 0.065217391304348, 0.56739130434783, 0.055555555555556
46663, 0.043478260869565, 0.54130434782609, 0.055555555555556
46664, 0.043478260869565, 0.56739130434783, 0.083333333333333
46665, 0.065217391304348, 0.56739130434783, 0.11111111111111
46666, 0.043478260869565, 0.54130434782609, 0.11111111111111
46667, 0.043478260869565, 0.56739130434783, 0.13888888888889
46668, 0.065217391304348, 0.56739130434783, 0.16666666666667
46669, 0.043478260869565, 0.54130434782609, 0.16666666666667
46670, 0.043478260869565, 0.56739130434783, 0.19444444444444
46671, 0.065217391304348, 0.56739130434783, 0.22222222222222
46672, 0.043478260869565, 0.54130434782609, 0.22222222222222
46673, 0.043478260869565, 0.56739130434783, 0.25
46674, 0.065217391304348, 0.56739130434783, 0.27777777777778
46675, 0.043478260869565, 0.54130434782609, 0.27777777777778
46676, 0.043478260869565, 0.56739130434783, 0.30555555555556
46677, 0.065217391304348, 0.56739130434783, 0.33333333333333
46678, 0.043478260869565, 0.54130434782609, 0.33333333333333
46679, 0.043478260869565, 0.56739130434783, 0.36111111111111
46680, 0.065217391304348, 0.56739130434783, 0.38888888888889
46681, 0.043478260869565, 0.54130434782609, 0.38888888888889
46682, 0.043478260869565, 0.56739130434783, 0.41666666666667
46683, 0.065217391304348, 0.56739130434783, 0.44444444444444
46684, 0.043478260869565, 0.54130434782609, 0.44444444444444
46685, 0.043478260869565, 0.56739130434783, 0.47222222222222
46686, 0.021739130434783, 0.56739130434783, 0.055555555555556
46687, 0.021739130434783, 0.56739130434783, 0.11111111111111
46688, 0.021739130434783, 0.56739130434783, 0.16666666666667
46689, 0.021739130434783, 0.56739130434783, 0.22222222222222
46690, 0.021739130434783, 0.56739130434783, 0.27777777777778
46691, 0.021739130434783, 0.56739130434783, 0.33333333333333
46692, 0.021739130434783, 0.56739130434783, 0.38888888888889
46693, 0.021739130434783, 0.56739130434783, 0.44444444444444
46694, 0.95652173913043, 0.6195652173913, 0.027777777777778
46695, 0.97826086956522, 0.6195652173913, 0.055555555555556
46696, 0.95652173913043, 0.59347826086956, 0.055555555555556
46697, 0.95652173913043, 0.6195652173913, 0.083333333333333
46698, 0.97826086956522, 0.6195652173913, 0.11111111111111
46699, 0.95652173913044, 0.59347826086956, 0.11111111111111
46700, 0.95652173913044, 0.6195652173913, 0.13888888888889
46701, 0.97826086956522, 0.6195652173913, 0.16666666666667
46702, 0.95652173913044, 0.59347826086956, 0.16666666666667
46703, 0.95652173913044, 0.6195652173913, 0.19444444444444
46704, 0.97826086956522, 0.6195652173913, 0.22222222222222
46705, 0.95652173913044, 0.59347826086956, 0.22222222222222
46706, 0.95652173913044, 0.6195652173913, 0.25
46707, 0.97826086956522, 0.6195652173913, 0.27777777777778
46708, 0.95652173913044, 0.59347826086956, 0.27777777777778
46709, 0.95652173913044, 0.6195652173913, 0.30555555555556
46710, 0.97826086956522, 0.6195652173913, 0.33333333333333
46711, 0.95652173913044, 0.59347826086956, 0.33333333333333
46712, 0.95652173913044, 0.6195652173913, 0.36111111111111
46713, 0.97826086956522, 0.6195652173913, 0.38888888888889
46714, 0.95652173913044, 0.59347826086956, 0.38888888888889
46715, 0.95652173913044, 0.6195652173913, 0.41666666666667
46716, 0.97826086956522, 0.6195652173913, 0.44444444444444
46717, 0.95652173913044, 0.59347826086956, 0.44444444444444
46718, 0.95652173913043, 0.6195652173913, 0.47222222222222
46719, 0.91304347826087, 0.6195652173913, 0.027777777777778
46720, 0.93478260869565, 0.6195652173913, 0.055555555555556
46721, 0.91304347826087, 0.59347826086956, 0.055555555555556
46722, 0.91304347826087, 0.6195652173913, 0.083333333333333
46723, 0.93478260869565, 0.6195652173913, 0.11111111111111
46724, 0.91304347826087, 0.59347826086956, 0.11111111111111
46725, 0.91304347826087, 0.6195652173913, 0.13888888888889
46726, 0.93478260869565, 0.6195652173913, 0.16666666666667
46727, 0.91304347826087, 0.59347826086956, 0.16666666666667
46728, 0.91304347826087, 0.6195652173913, 0.19444444444444
46729, 0.93478260869565, 0.6195652173913, 0.22222222222222
46730, 0.91304347826087, 0.59347826086956, 0.22222222222222
46731, 0.91304347826087, 0.6195652173913, 0.25
46732, 0.93478260869565, 0.6195652173913, 0.27777777777778
46733, 0.91304347826087, 0.59347826086957, 0.27777777777778
46734, 0.91304347826087, 0.6195652173913, 0.30555555555556
46735, 0.93478260869565, 0.6195652173913, 0.33333333333333
46736, 0.91304347826087, 0.59347826086956, 0.33333333333333
46737, 0.91304347826087, 0.6195652173913, 0.36111111111111
46738, 0.93478260869565, 0.6195652173913, 0.38888888888889
46739, 0.91304347826087, 0.59347826086957, 0.38888888888889
46740, 0.91304347826087, 0.6195652173913, 0.41666666666667
46741, 0.93478260869565, 0.6195652173913, 0.44444444444444
46742, 0.91304347826087, 0.59347826086956, 0.44444444444444
46743, 0.91304347826087, 0.6195652173913, 0.47222222222222
46744, 0.8695652173913, 0.6195652173913, 0.027777777777778
46745, 0.89130434782609, 0.6195652173913, 0.055555555555556
46746, 0.8695652173913, 0.59347826086956, 0.055555555555556
46747, 0.8695652173913, 0.6195652173913, 0.083333333333333
46748, 0.89130434782609, 0.6195652173913, 0.11111111111111
46749, 0.8695652173913, 0.59347826086956, 0.11111111111111
46750, 0.8695652173913, 0.6195652173913, 0.13888888888889
46751, 0.89130434782609, 0.6195652173913, 0.16666666666667
46752, 0.8695652173913, 0.59347826086956, 0.16666666666667
46753, 0.8695652173913, 0.6195652173913, 0.19444444444444
46754, 0.89130434782609, 0.6195652173913, 0.22222222222222
46755, 0.8695652173913, 0.59347826086956, 0.22222222222222
46756, 0.8695652173913, 0.6195652173913, 0.25
46757, 0.89130434782609, 0.6195652173913, 0.27777777777778
46758, 0.8695652173913, 0.59347826086956, 0.27777777777778
46759, 0.8695652173913, 0.6195652173913, 0.30555555555556
46760, 0.89130434782609, 0.6195652173913, 0.33333333333333
46761, 0.8695652173913, 0.59347826086956, 0.33333333333333
46762, 0.8695652173913, 0.6195652173913, 0.36111111111111
46763, 0.89130434782609, 0.6195652173913, 0.38888888888889
46764, 0.8695652173913, 0.59347826086956, 0.38888888888889
46765, 0.8695652173913, 0.6195652173913, 0.41666666666667
46766, 0.89130434782609, 0.6195652173913, 0.44444444444444
46767, 0.8695652173913, 0.59347826086956, 0.44444444444444
46768, 0.8695652173913, 0.6195652173913, 0.47222222222222
46769, 0.82608695652174, 0.6195652173913, 0.027777777777778
46770, 0.84782608695652, 0.6195652173913, 0.055555555555556
46771, 0.82608695652174, 0.59347826086956, 0.055555555555556
46772, 0.82608695652174, 0.6195652173913, 0.083333333333333
46773, 0.84782608695652, 0.6195652173913, 0.11111111111111
46774, 0.82608695652174, 0.59347826086957, 0.11111111111111
46775, 0.82608695652174, 0.6195652173913, 0.13888888888889
46776, 0.84782608695652, 0.6195652173913, 0.16666666666667
46777, 0.82608695652174, 0.59347826086956, 0.16666666666667
46778, 0.82608695652174, 0.6195652173913, 0.19444444444444
46779, 0.84782608695652, 0.6195652173913, 0.22222222222222
46780, 0.82608695652174, 0.59347826086956, 0.22222222222222
46781, 0.82608695652174, 0.6195652173913, 0.25
46782, 0.84782608695652, 0.6195652173913, 0.27777777777778
46783, 0.82608695652174, 0.59347826086956, 0.27777777777778
46784, 0.82608695652174, 0.6195652173913, 0.30555555555556
46785, 0.84782608695652, 0.6195652173913, 0.33333333333333
46786, 0.82608695652174, 0.59347826086956, 0.33333333333333
46787, 0.82608695652174, 0.6195652173913, 0.36111111111111
46788, 0.84782608695652, 0.6195652173913, 0.38888888888889
46789, 0.82608695652174, 0.59347826086957, 0.38888888888889
46790, 0.82608695652174, 0.6195652173913, 0.41666666666667
46791, 0.84782608695652, 0.6195652173913, 0.44444444444444
46792, 0.82608695652174, 0.59347826086956, 0.44444444444444
46793, 0.82608695652174, 0.6195652173913, 0.47222222222222
46794, 0.78260869565217, 0.6195652173913, 0.027777777777778
46795, 0.80434782608696, 0.6195652173913, 0.055555555555556
46796, 0.78260869565217, 0.59347826086956, 0.055555555555556
46797, 0.78260869565217, 0.6195652173913, 0.083333333333333
46798, 0.80434782608696, 0.6195652173913, 0.11111111111111
46799, 0.78260869565217, 0.59347826086956, 0.11111111111111
46800, 0.78260869565217, 0.6195652173913, 0.13888888888889
46801, 0.80434782608696, 0.6195652173913, 0.16666666666667
46802, 0.78260869565217, 0.59347826086956, 0.16666666666667
46803, 0.78260869565217, 0.6195652173913, 0.19444444444444
46804, 0.80434782608696, 0.6195652173913, 0.22222222222222
46805, 0.78260869565217, 0.59347826086957, 0.22222222222222
46806, 0.78260869565217, 0.6195652173913, 0.25
46807, 0.80434782608696, 0.6195652173913, 0.27777777777778
46808, 0.78260869565217, 0.59347826086957, 0.27777777777778
46809, 0.78260869565217, 0.6195652173913, 0.30555555555556
46810, 0.80434782608696, 0.6195652173913, 0.33333333333333
46811, 0.78260869565217, 0.59347826086956, 0.33333333333333
46812, 0.78260869565217, 0.6195652173913, 0.36111111111111
46813, 0.80434782608696, 0.6195652173913, 0.38888888888889
46814, 0.78260869565217, 0.59347826086956, 0.38888888888889
46815, 0.78260869565217, 0.6195652173913, 0.41666666666667
46816, 0.80434782608696, 0.6195652173913, 0.44444444444444
46817, 0.78260869565217, 0.59347826086956, 0.44444444444444
46818, 0.78260869565217, 0.6195652173913, 0.47222222222222
46819, 0.73913043478261, 0.6195652173913, 0.027777777777778
46820, 0.76086956521739, 0.6195652173913, 0.055555555555556
46821, 0.73913043478261, 0.59347826086956, 0.055555555555556
46822, 0.73913043478261, 0.6195652173913, 0.083333333333333
46823, 0.76086956521739, 0.6195652173913, 0.11111111111111
46824, 0.73913043478261, 0.59347826086956, 0.11111111111111
46825, 0.73913043478261, 0.6195652173913, 0.13888888888889
46826, 0.76086956521739, 0.6195652173913, 0.16666666666667
46827, 0.73913043478261, 0.59347826086956, 0.16666666666667
46828, 0.73913043478261, 0.6195652173913, 0.19444444444444
46829, 0.76086956521739, 0.6195652173913, 0.22222222222222
46830, 0.73913043478261, 0.59347826086956, 0.22222222222222
46831, 0.73913043478261, 0.6195652173913, 0.25
46832, 0.76086956521739, 0.6195652173913, 0.27777777777778
46833, 0.73913043478261, 0.59347826086956, 0.27777777777778
46834, 0.73913043478261, 0.6195652173913, 0.30555555555556
46835, 0.76086956521739, 0.6195652173913, 0.33333333333333
46836, 0.73913043478261, 0.59347826086956, 0.33333333333333
46837, 0.73913043478261, 0.6195652173913, 0.36111111111111
46838, 0.76086956521739, 0.6195652173913, 0.38888888888889
46839, 0.73913043478261, 0.59347826086957, 0.38888888888889
46840, 0.73913043478261, 0.6195652173913, 0.41666666666667
46841, 0.76086956521739, 0.6195652173913, 0.44444444444444
46842, 0.73913043478261, 0.59347826086956, 0.44444444444444
46843, 0.73913043478261, 0.6195652173913, 0.47222222222222
46844, 0.69565217391304, 0.6195652173913, 0.027777777777778
46845, 0.71739130434783, 0.6195652173913, 0.055555555555556
46846, 0.69565217391304, 0.59347826086956, 0.055555555555556
46847, 0.69565217391304, 0.6195652173913, 0.083333333333333
46848, 0.71739130434783, 0.6195652173913, 0.11111111111111
46849, 0.69565217391304, 0.59347826086956, 0.11111111111111
46850, 0.69565217391304, 0.6195652173913, 0.13888888888889
46851, 0.71739130434783, 0.6195652173913, 0.16666666666667
46852, 0.69565217391304, 0.59347826086956, 0.16666666666667
46853, 0.69565217391304, 0.6195652173913, 0.19444444444444
46854, 0.71739130434783, 0.6195652173913, 0.22222222222222
46855, 0.69565217391304, 0.59347826086956, 0.22222222222222
46856, 0.69565217391304, 0.6195652173913, 0.25
46857, 0.71739130434783, 0.6195652173913, 0.27777777777778
46858, 0.69565217391304, 0.59347826086956, 0.27777777777778
46859, 0.69565217391304, 0.6195652173913, 0.30555555555556
46860, 0.71739130434783, 0.6195652173913, 0.33333333333333
46861, 0.69565217391304, 0.59347826086956, 0.33333333333333
46862, 0.69565217391304, 0.6195652173913, 0.36111111111111
46863, 0.71739130434783, 0.6195652173913, 0.38888888888889
46864, 0.69565217391304, 0.59347826086956, 0.38888888888889
46865, 0.69565217391304, 0.6195652173913, 0.41666666666667
46866, 0.71739130434783, 0.6195652173913, 0.44444444444444
46867, 0.69565217391304, 0.59347826086956, 0.44444444444444
46868, 0.69565217391304, 0.6195652173913, 0.47222222222222
46869, 0.65217391304348, 0.6195652173913, 0.027777777777778
46870, 0.67391304347826, 0.6195652173913, 0.055555555555556
46871, 0.65217391304348, 0.59347826086956, 0.055555555555556
46872, 0.65217391304348, 0.6195652173913, 0.083333333333333
46873, 0.67391304347826, 0.6195652173913, 0.11111111111111
46874, 0.65217391304348, 0.59347826086956, 0.11111111111111
46875, 0.65217391304348, 0.6195652173913, 0.13888888888889
46876, 0.67391304347826, 0.6195652173913, 0.16666666666667
46877, 0.65217391304348, 0.59347826086956, 0.16666666666667
46878, 0.65217391304348, 0.6195652173913, 0.19444444444444
46879, 0.67391304347826, 0.6195652173913, 0.22222222222222
46880, 0.65217391304348, 0.59347826086956, 0.22222222222222
46881, 0.65217391304348, 0.6195652173913, 0.25
46882, 0.67391304347826, 0.6195652173913, 0.27777777777778
46883, 0.65217391304348, 0.59347826086956, 0.27777777777778
46884, 0.65217391304348, 0.6195652173913, 0.30555555555556
46885, 0.67391304347826, 0.6195652173913, 0.33333333333333
46886, 0.65217391304348, 0.59347826086956, 0.33333333333333
46887, 0.65217391304348, 0.6195652173913, 0.36111111111111
46888, 0.67391304347826, 0.6195652173913, 0.38888888888889
46889, 0.65217391304348, 0.59347826086957, 0.38888888888889
46890, 0.65217391304348, 0.6195652173913, 0.41666666666667
46891, 0.67391304347826, 0.6195652173913, 0.44444444444444
46892, 0.65217391304348, 0.59347826086956, 0.44444444444444
46893, 0.65217391304348, 0.6195652173913, 0.47222222222222
46894, 0.60869565217391, 0.6195652173913, 0.027777777777778
46895, 0.6304347826087, 0.6195652173913, 0.055555555555556
46896, 0.60869565217391, 0.59347826086956, 0.055555555555556
46897, 0.60869565217391, 0.6195652173913, 0.083333333333333
46898, 0.6304347826087, 0.6195652173913, 0.11111111111111
46899, 0.60869565217391, 0.59347826086956, 0.11111111111111
46900, 0.60869565217391, 0.6195652173913, 0.13888888888889
46901, 0.6304347826087, 0.6195652173913, 0.16666666666667
46902, 0.60869565217391, 0.59347826086956, 0.16666666666667
46903, 0.60869565217391, 0.6195652173913, 0.19444444444444
46904, 0.6304347826087, 0.6195652173913, 0.22222222222222
46905, 0.60869565217391, 0.59347826086956, 0.22222222222222
46906, 0.60869565217391, 0.6195652173913, 0.25
46907, 0.6304347826087, 0.6195652173913, 0.27777777777778
46908, 0.60869565217391, 0.59347826086956, 0.27777777777778
46909, 0.60869565217391, 0.6195652173913, 0.30555555555556
46910, 0.6304347826087, 0.6195652173913, 0.33333333333333
46911, 0.60869565217391, 0.59347826086956, 0.33333333333333
46912, 0.60869565217391, 0.6195652173913, 0.36111111111111
46913, 0.6304347826087, 0.6195652173913, 0.38888888888889
46914, 0.60869565217391, 0.59347826086956, 0.38888888888889
46915, 0.60869565217391, 0.6195652173913, 0.41666666666667
46916, 0.6304347826087, 0.6195652173913, 0.44444444444444
46917, 0.60869565217391, 0.59347826086956, 0.44444444444444
46918, 0.60869565217391, 0.6195652173913, 0.47222222222222
46919, 0.56521739130435, 0.6195652173913, 0.027777777777778
46920, 0.58695652173913, 0.6195652173913, 0.055555555555556
46921, 0.56521739130435, 0.59347826086956, 0.055555555555556
46922, 0.56521739130435, 0.6195652173913, 0.083333333333333
46923, 0.58695652173913, 0.6195652173913, 0.11111111111111
46924, 0.56521739130435, 0.59347826086956, 0.11111111111111
46925, 0.56521739130435, 0.6195652173913, 0.13888888888889
46926, 0.58695652173913, 0.6195652173913, 0.16666666666667
46927, 0.56521739130435, 0.59347826086956, 0.16666666666667
46928, 0.56521739130435, 0.6195652173913, 0.19444444444444
46929, 0.58695652173913, 0.6195652173913, 0.22222222222222
46930, 0.56521739130435, 0.59347826086956, 0.22222222222222
46931, 0.56521739130435, 0.6195652173913, 0.25
46932, 0.58695652173913, 0.6195652173913, 0.27777777777778
46933, 0.56521739130435, 0.59347826086956, 0.27777777777778
46934, 0.56521739130435, 0.6195652173913, 0.30555555555556
46935, 0.58695652173913, 0.6195652173913, 0.33333333333333
46936, 0.56521739130435, 0.59347826086956, 0.33333333333333
46937, 0.56521739130435, 0.6195652173913, 0.36111111111111
46938, 0.58695652173913, 0.6195652173913, 0.38888888888889
46939, 0.56521739130435, 0.59347826086957, 0.38888888888889
46940, 0.56521739130435, 0.6195652173913, 0.41666666666667
46941, 0.58695652173913, 0.6195652173913, 0.44444444444444
46942, 0.56521739130435, 0.59347826086956, 0.44444444444444
46943, 0.56521739130435, 0.6195652173913, 0.47222222222222
46944, 0.52173913043478, 0.6195652173913, 0.027777777777778
46945, 0.54347826086957, 0.6195652173913, 0.055555555555556
46946, 0.52173913043478, 0.59347826086956, 0.055555555555556
46947, 0.52173913043478, 0.6195652173913, 0.083333333333333
46948, 0.54347826086957, 0.6195652173913, 0.11111111111111
46949, 0.52173913043478, 0.59347826086956, 0.11111111111111
46950, 0.52173913043478, 0.6195652173913, 0.13888888888889
46951, 0.54347826086957, 0.6195652173913, 0.16666666666667
46952, 0.52173913043478, 0.59347826086956, 0.16666666666667
46953, 0.52173913043478, 0.6195652173913, 0.19444444444444
46954, 0.54347826086956, 0.6195652173913, 0.22222222222222
46955, 0.52173913043478, 0.59347826086956, 0.22222222222222
46956, 0.52173913043478, 0.6195652173913, 0.25
46957, 0.54347826086956, 0.6195652173913, 0.27777777777778
46958, 0.52173913043478, 0.59347826086956, 0.27777777777778
46959, 0.52173913043478, 0.6195652173913, 0.30555555555556
46960, 0.54347826086956, 0.6195652173913, 0.33333333333333
46961, 0.52173913043478, 0.59347826086956, 0.33333333333333
46962, 0.52173913043478, 0.6195652173913, 0.36111111111111
46963, 0.54347826086956, 0.6195652173913, 0.38888888888889
46964, 0.52173913043478, 0.59347826086956, 0.38888888888889
46965, 0.52173913043478, 0.6195652173913, 0.41666666666667
46966, 0.54347826086956, 0.6195652173913, 0.44444444444444
46967, 0.52173913043478, 0.59347826086956, 0.44444444444444
46968, 0.52173913043478, 0.6195652173913, 0.47222222222222
46969, 0.47826086956522, 0.6195652173913, 0.027777777777778
46970, 0.5, 0.6195652173913, 0.055555555555556
46971, 0.47826086956522, 0.59347826086956, 0.055555555555556
46972, 0.47826086956522, 0.6195652173913, 0.083333333333333
46973, 0.5, 0.6195652173913, 0.11111111111111
46974, 0.47826086956522, 0.59347826086956, 0.11111111111111
46975, 0.47826086956522, 0.6195652173913, 0.13888888888889
46976, 0.5, 0.6195652173913, 0.16666666666667
46977, 0.47826086956522, 0.59347826086957, 0.16666666666667
46978, 0.47826086956522, 0.6195652173913, 0.19444444444444
46979, 0.5, 0.6195652173913, 0.22222222222222
46980, 0.47826086956522, 0.59347826086957, 0.22222222222222
46981, 0.47826086956522, 0.6195652173913, 0.25
46982, 0.5, 0.6195652173913, 0.27777777777778
46983, 0.47826086956522, 0.59347826086956, 0.27777777777778
46984, 0.47826086956522, 0.6195652173913, 0.30555555555556
46985, 0.5, 0.6195652173913, 0.33333333333333
46986, 0.47826086956522, 0.59347826086956, 0.33333333333333
46987, 0.47826086956522, 0.6195652173913, 0.36111111111111
46988, 0.5, 0.6195652173913, 0.38888888888889
46989, 0.47826086956522, 0.59347826086956, 0.38888888888889
46990, 0.47826086956522, 0.6195652173913, 0.41666666666667
46991, 0.5, 0.6195652173913, 0.44444444444444
46992, 0.47826086956522, 0.59347826086956, 0.44444444444444
46993, 0.47826086956522, 0.6195652173913, 0.47222222222222
46994, 0.43478260869565, 0.6195652173913, 0.027777777777778
46995, 0.45652173913043, 0.6195652173913, 0.055555555555556
46996, 0.43478260869565, 0.59347826086956, 0.055555555555556
46997, 0.43478260869565, 0.6195652173913, 0.083333333333333
46998, 0.45652173913043, 0.6195652173913, 0.11111111111111
46999, 0.43478260869565, 0.59347826086956, 0.11111111111111
47000, 0.43478260869565, 0.6195652173913, 0.13888888888889
47001, 0.45652173913043, 0.6195652173913, 0.16666666666667
47002, 0.43478260869565, 0.59347826086956, 0.16666666666667
47003, 0.43478260869565, 0.6195652173913, 0.19444444444444
47004, 0.45652173913043, 0.6195652173913, 0.22222222222222
47005, 0.43478260869565, 0.59347826086956, 0.22222222222222
47006, 0.43478260869565, 0.6195652173913, 0.25
47007, 0.45652173913043, 0.6195652173913, 0.27777777777778
47008, 0.43478260869565, 0.59347826086956, 0.27777777777778
47009, 0.43478260869565, 0.6195652173913, 0.30555555555556
47010, 0.45652173913043, 0.6195652173913, 0.33333333333333
47011, 0.43478260869565, 0.59347826086956, 0.33333333333333
47012, 0.43478260869565, 0.6195652173913, 0.36111111111111
47013, 0.45652173913043, 0.6195652173913, 0.38888888888889
47014, 0.43478260869565, 0.59347826086956, 0.38888888888889
47015, 0.43478260869565, 0.6195652173913, 0.41666666666667
47016, 0.45652173913043, 0.6195652173913, 0.44444444444444
47017, 0.43478260869565, 0.59347826086956, 0.44444444444444
47018, 0.43478260869565, 0.6195652173913, 0.47222222222222
47019, 0.39130434782609, 0.6195652173913, 0.027777777777778
47020, 0.41304347826087, 0.6195652173913, 0.055555555555556
47021, 0.39130434782609, 0.59347826086956, 0.055555555555556
47022, 0.39130434782609, 0.6195652173913, 0.083333333333333
47023, 0.41304347826087, 0.6195652173913, 0.11111111111111
47024, 0.39130434782609, 0.59347826086956, 0.11111111111111
47025, 0.39130434782609, 0.6195652173913, 0.13888888888889
47026, 0.41304347826087, 0.6195652173913, 0.16666666666667
47027, 0.39130434782609, 0.59347826086956, 0.16666666666667
47028, 0.39130434782609, 0.6195652173913, 0.19444444444444
47029, 0.41304347826087, 0.6195652173913, 0.22222222222222
47030, 0.39130434782609, 0.59347826086956, 0.22222222222222
47031, 0.39130434782609, 0.6195652173913, 0.25
47032, 0.41304347826087, 0.6195652173913, 0.27777777777778
47033, 0.39130434782609, 0.59347826086956, 0.27777777777778
47034, 0.39130434782609, 0.6195652173913, 0.30555555555556
47035, 0.41304347826087, 0.6195652173913, 0.33333333333333
47036, 0.39130434782609, 0.59347826086956, 0.33333333333333
47037, 0.39130434782609, 0.6195652173913, 0.36111111111111
47038, 0.41304347826087, 0.6195652173913, 0.38888888888889
47039, 0.39130434782609, 0.59347826086956, 0.38888888888889
47040, 0.39130434782609, 0.6195652173913, 0.41666666666667
47041, 0.41304347826087, 0.6195652173913, 0.44444444444444
47042, 0.39130434782609, 0.59347826086956, 0.44444444444444
47043, 0.39130434782609, 0.6195652173913, 0.47222222222222
47044, 0.34782608695652, 0.6195652173913, 0.027777777777778
47045, 0.3695652173913, 0.6195652173913, 0.055555555555556
47046, 0.34782608695652, 0.59347826086956, 0.055555555555556
47047, 0.34782608695652, 0.6195652173913, 0.083333333333333
47048, 0.3695652173913, 0.6195652173913, 0.11111111111111
47049, 0.34782608695652, 0.59347826086956, 0.11111111111111
47050, 0.34782608695652, 0.6195652173913, 0.13888888888889
47051, 0.3695652173913, 0.6195652173913, 0.16666666666667
47052, 0.34782608695652, 0.59347826086956, 0.16666666666667
47053, 0.34782608695652, 0.6195652173913, 0.19444444444444
47054, 0.3695652173913, 0.6195652173913, 0.22222222222222
47055, 0.34782608695652, 0.59347826086956, 0.22222222222222
47056, 0.34782608695652, 0.6195652173913, 0.25
47057, 0.3695652173913, 0.6195652173913, 0.27777777777778
47058, 0.34782608695652, 0.59347826086956, 0.27777777777778
47059, 0.34782608695652, 0.6195652173913, 0.30555555555556
47060, 0.3695652173913, 0.6195652173913, 0.33333333333333
47061, 0.34782608695652, 0.59347826086956, 0.33333333333333
47062, 0.34782608695652, 0.6195652173913, 0.36111111111111
47063, 0.3695652173913, 0.6195652173913, 0.38888888888889
47064, 0.34782608695652, 0.59347826086956, 0.38888888888889
47065, 0.34782608695652, 0.6195652173913, 0.41666666666667
47066, 0.3695652173913, 0.6195652173913, 0.44444444444444
47067, 0.34782608695652, 0.59347826086956, 0.44444444444444
47068, 0.34782608695652, 0.6195652173913, 0.47222222222222
47069, 0.30434782608696, 0.6195652173913, 0.027777777777778
47070, 0.32608695652174, 0.6195652173913, 0.055555555555556
47071, 0.30434782608696, 0.59347826086956, 0.055555555555556
47072, 0.30434782608696, 0.6195652173913, 0.083333333333333
47073, 0.32608695652174, 0.6195652173913, 0.11111111111111
47074, 0.30434782608696, 0.59347826086956, 0.11111111111111
47075, 0.30434782608696, 0.6195652173913, 0.13888888888889
47076, 0.32608695652174, 0.6195652173913, 0.16666666666667
47077, 0.30434782608696, 0.59347826086956, 0.16666666666667
47078, 0.30434782608696, 0.6195652173913, 0.19444444444444
47079, 0.32608695652174, 0.6195652173913, 0.22222222222222
47080, 0.30434782608696, 0.59347826086956, 0.22222222222222
47081, 0.30434782608696, 0.6195652173913, 0.25
47082, 0.32608695652174, 0.6195652173913, 0.27777777777778
47083, 0.30434782608696, 0.59347826086956, 0.27777777777778
47084, 0.30434782608696, 0.6195652173913, 0.30555555555556
47085, 0.32608695652174, 0.6195652173913, 0.33333333333333
47086, 0.30434782608696, 0.59347826086956, 0.33333333333333
47087, 0.30434782608696, 0.6195652173913, 0.36111111111111
47088, 0.32608695652174, 0.6195652173913, 0.38888888888889
47089, 0.30434782608696, 0.59347826086956, 0.38888888888889
47090, 0.30434782608696, 0.6195652173913, 0.41666666666667
47091, 0.32608695652174, 0.6195652173913, 0.44444444444444
47092, 0.30434782608696, 0.59347826086956, 0.44444444444444
47093, 0.30434782608696, 0.6195652173913, 0.47222222222222
47094, 0.26086956521739, 0.6195652173913, 0.027777777777778
47095, 0.28260869565217, 0.6195652173913, 0.055555555555556
47096, 0.26086956521739, 0.59347826086956, 0.055555555555556
47097, 0.26086956521739, 0.6195652173913, 0.083333333333333
47098, 0.28260869565217, 0.6195652173913, 0.11111111111111
47099, 0.26086956521739, 0.59347826086956, 0.11111111111111
47100, 0.26086956521739, 0.6195652173913, 0.13888888888889
47101, 0.28260869565217, 0.6195652173913, 0.16666666666667
47102, 0.26086956521739, 0.59347826086956, 0.16666666666667
47103, 0.26086956521739, 0.6195652173913, 0.19444444444444
47104, 0.28260869565217, 0.6195652173913, 0.22222222222222
47105, 0.26086956521739, 0.59347826086956, 0.22222222222222
47106, 0.26086956521739, 0.6195652173913, 0.25
47107, 0.28260869565217, 0.6195652173913, 0.27777777777778
47108, 0.26086956521739, 0.59347826086956, 0.27777777777778
47109, 0.26086956521739, 0.6195652173913, 0.30555555555556
47110, 0.28260869565217, 0.6195652173913, 0.33333333333333
47111, 0.26086956521739, 0.59347826086956, 0.33333333333333
47112, 0.26086956521739, 0.6195652173913, 0.36111111111111
47113, 0.28260869565217, 0.6195652173913, 0.38888888888889
47114, 0.26086956521739, 0.59347826086956, 0.38888888888889
47115, 0.26086956521739, 0.6195652173913, 0.41666666666667
47116, 0.28260869565217, 0.6195652173913, 0.44444444444444
47117, 0.26086956521739, 0.59347826086956, 0.44444444444444
47118, 0.26086956521739, 0.6195652173913, 0.47222222222222
47119, 0.21739130434783, 0.6195652173913, 0.027777777777778
47120, 0.23913043478261, 0.6195652173913, 0.055555555555556
47121, 0.21739130434783, 0.59347826086956, 0.055555555555556
47122, 0.21739130434783, 0.6195652173913, 0.083333333333333
47123, 0.23913043478261, 0.6195652173913, 0.11111111111111
47124, 0.21739130434783, 0.59347826086956, 0.11111111111111
47125, 0.21739130434783, 0.6195652173913, 0.13888888888889
47126, 0.23913043478261, 0.6195652173913, 0.16666666666667
47127, 0.21739130434783, 0.59347826086956, 0.16666666666667
47128, 0.21739130434783, 0.6195652173913, 0.19444444444444
47129, 0.23913043478261, 0.6195652173913, 0.22222222222222
47130, 0.21739130434783, 0.59347826086956, 0.22222222222222
47131, 0.21739130434783, 0.6195652173913, 0.25
47132, 0.23913043478261, 0.6195652173913, 0.27777777777778
47133, 0.21739130434783, 0.59347826086956, 0.27777777777778
47134, 0.21739130434783, 0.6195652173913, 0.30555555555556
47135, 0.23913043478261, 0.6195652173913, 0.33333333333333
47136, 0.21739130434783, 0.59347826086956, 0.33333333333333
47137, 0.21739130434783, 0.6195652173913, 0.36111111111111
47138, 0.23913043478261, 0.6195652173913, 0.38888888888889
47139, 0.21739130434783, 0.59347826086956, 0.38888888888889
47140, 0.21739130434783, 0.6195652173913, 0.41666666666667
47141, 0.23913043478261, 0.6195652173913, 0.44444444444444
47142, 0.21739130434783, 0.59347826086956, 0.44444444444444
47143, 0.21739130434783, 0.6195652173913, 0.47222222222222
47144, 0.17391304347826, 0.6195652173913, 0.027777777777778
47145, 0.19565217391304, 0.6195652173913, 0.055555555555556
47146, 0.17391304347826, 0.59347826086956, 0.055555555555556
47147, 0.17391304347826, 0.6195652173913, 0.083333333333333
47148, 0.19565217391304, 0.6195652173913, 0.11111111111111
47149, 0.17391304347826, 0.59347826086956, 0.11111111111111
47150, 0.17391304347826, 0.6195652173913, 0.13888888888889
47151, 0.19565217391304, 0.6195652173913, 0.16666666666667
47152, 0.17391304347826, 0.59347826086956, 0.16666666666667
47153, 0.17391304347826, 0.6195652173913, 0.19444444444444
47154, 0.19565217391304, 0.6195652173913, 0.22222222222222
47155, 0.17391304347826, 0.59347826086956, 0.22222222222222
47156, 0.17391304347826, 0.6195652173913, 0.25
47157, 0.19565217391304, 0.6195652173913, 0.27777777777778
47158, 0.17391304347826, 0.59347826086956, 0.27777777777778
47159, 0.17391304347826, 0.6195652173913, 0.30555555555556
47160, 0.19565217391304, 0.6195652173913, 0.33333333333333
47161, 0.17391304347826, 0.59347826086956, 0.33333333333333
47162, 0.17391304347826, 0.6195652173913, 0.36111111111111
47163, 0.19565217391304, 0.6195652173913, 0.38888888888889
47164, 0.17391304347826, 0.59347826086956, 0.38888888888889
47165, 0.17391304347826, 0.6195652173913, 0.41666666666667
47166, 0.19565217391304, 0.6195652173913, 0.44444444444444
47167, 0.17391304347826, 0.59347826086956, 0.44444444444444
47168, 0.17391304347826, 0.6195652173913, 0.47222222222222
47169, 0.1304347826087, 0.6195652173913, 0.027777777777778
47170, 0.15217391304348, 0.6195652173913, 0.055555555555556
47171, 0.1304347826087, 0.59347826086956, 0.055555555555556
47172, 0.1304347826087, 0.6195652173913, 0.083333333333333
47173, 0.15217391304348, 0.6195652173913, 0.11111111111111
47174, 0.1304347826087, 0.59347826086956, 0.11111111111111
47175, 0.1304347826087, 0.6195652173913, 0.13888888888889
47176, 0.15217391304348, 0.6195652173913, 0.16666666666667
47177, 0.1304347826087, 0.59347826086956, 0.16666666666667
47178, 0.1304347826087, 0.6195652173913, 0.19444444444444
47179, 0.15217391304348, 0.6195652173913, 0.22222222222222
47180, 0.1304347826087, 0.59347826086956, 0.22222222222222
47181, 0.1304347826087, 0.6195652173913, 0.25
47182, 0.15217391304348, 0.6195652173913, 0.27777777777778
47183, 0.1304347826087, 0.59347826086956, 0.27777777777778
47184, 0.1304347826087, 0.6195652173913, 0.30555555555556
47185, 0.15217391304348, 0.6195652173913, 0.33333333333333
47186, 0.1304347826087, 0.59347826086956, 0.33333333333333
47187, 0.1304347826087, 0.6195652173913, 0.36111111111111
47188, 0.15217391304348, 0.6195652173913, 0.38888888888889
47189, 0.1304347826087, 0.59347826086956, 0.38888888888889
47190, 0.1304347826087, 0.6195652173913, 0.41666666666667
47191, 0.15217391304348, 0.6195652173913, 0.44444444444444
47192, 0.1304347826087, 0.59347826086956, 0.44444444444444
47193, 0.1304347826087, 0.6195652173913, 0.47222222222222
47194, 0.08695652173913, 0.6195652173913, 0.027777777777778
47195, 0.10869565217391, 0.6195652173913, 0.055555555555556
47196, 0.08695652173913, 0.59347826086956, 0.055555555555556
47197, 0.08695652173913, 0.6195652173913, 0.083333333333333
47198, 0.10869565217391, 0.6195652173913, 0.11111111111111
47199, 0.08695652173913, 0.59347826086956, 0.11111111111111
47200, 0.08695652173913, 0.6195652173913, 0.13888888888889
47201, 0.10869565217391, 0.6195652173913, 0.16666666666667
47202, 0.08695652173913, 0.59347826086956, 0.16666666666667
47203, 0.08695652173913, 0.6195652173913, 0.19444444444444
47204, 0.10869565217391, 0.6195652173913, 0.22222222222222
47205, 0.08695652173913, 0.59347826086956, 0.22222222222222
47206, 0.08695652173913, 0.6195652173913, 0.25
47207, 0.10869565217391, 0.6195652173913, 0.27777777777778
47208, 0.08695652173913, 0.59347826086956, 0.27777777777778
47209, 0.08695652173913, 0.6195652173913, 0.30555555555556
47210, 0.10869565217391, 0.6195652173913, 0.33333333333333
47211, 0.08695652173913, 0.59347826086956, 0.33333333333333
47212, 0.08695652173913, 0.6195652173913, 0.36111111111111
47213, 0.10869565217391, 0.6195652173913, 0.38888888888889
47214, 0.08695652173913, 0.59347826086956, 0.38888888888889
47215, 0.08695652173913, 0.6195652173913, 0.41666666666667
47216, 0.10869565217391, 0.6195652173913, 0.44444444444444
47217, 0.08695652173913, 0.59347826086956, 0.44444444444444
47218, 0.08695652173913, 0.6195652173913, 0.47222222222222
47219, 0.043478260869565, 0.6195652173913, 0.027777777777778
47220, 0.065217391304348, 0.6195652173913, 0.055555555555556
47221, 0.043478260869565, 0.59347826086956, 0.055555555555556
47222, 0.043478260869565, 0.6195652173913, 0.083333333333333
47223, 0.065217391304348, 0.6195652173913, 0.11111111111111
47224, 0.043478260869565, 0.59347826086956, 0.11111111111111
47225, 0.043478260869565, 0.6195652173913, 0.13888888888889
47226, 0.065217391304348, 0.6195652173913, 0.16666666666667
47227, 0.043478260869565, 0.59347826086956, 0.16666666666667
47228, 0.043478260869565, 0.6195652173913, 0.19444444444444
47229, 0.065217391304348, 0.6195652173913, 0.22222222222222
47230, 0.043478260869565, 0.59347826086956, 0.22222222222222
47231, 0.043478260869565, 0.6195652173913, 0.25
47232, 0.065217391304348, 0.6195652173913, 0.27777777777778
47233, 0.043478260869565, 0.59347826086956, 0.27777777777778
47234, 0.043478260869565, 0.6195652173913, 0.30555555555556
47235, 0.065217391304348, 0.6195652173913, 0.33333333333333
47236, 0.043478260869565, 0.59347826086956, 0.33333333333333
47237, 0.043478260869565, 0.6195652173913, 0.36111111111111
47238, 0.065217391304348, 0.6195652173913, 0.38888888888889
47239, 0.043478260869565, 0.59347826086956, 0.38888888888889
47240, 0.043478260869565, 0.6195652173913, 0.41666666666667
47241, 0.065217391304348, 0.6195652173913, 0.44444444444444
47242, 0.043478260869565, 0.59347826086956, 0.44444444444444
47243, 0.043478260869565, 0.6195652173913, 0.47222222222222
47244, 0.021739130434783, 0.6195652173913, 0.055555555555556
47245, 0.021739130434783, 0.6195652173913, 0.11111111111111
47246, 0.021739130434783, 0.6195652173913, 0.16666666666667
47247, 0.021739130434783, 0.6195652173913, 0.22222222222222
47248, 0.021739130434783, 0.6195652173913, 0.27777777777778
47249, 0.021739130434783, 0.6195652173913, 0.33333333333333
47250, 0.021739130434783, 0.6195652173913, 0.38888888888889
47251, 0.021739130434783, 0.6195652173913, 0.44444444444444
47252, 0.95652173913043, 0.67173913043478, 0.027777777777778
47253, 0.97826086956522, 0.67173913043478, 0.055555555555556
47254, 0.95652173913043, 0.64565217391304, 0.055555555555556
47255, 0.95652173913043, 0.67173913043478, 0.083333333333333
47256, 0.97826086956522, 0.67173913043478, 0.11111111111111
47257, 0.95652173913044, 0.64565217391304, 0.11111111111111
47258, 0.95652173913044, 0.67173913043478, 0.13888888888889
47259, 0.97826086956522, 0.67173913043478, 0.16666666666667
47260, 0.95652173913044, 0.64565217391304, 0.16666666666667
47261, 0.95652173913044, 0.67173913043478, 0.19444444444444
47262, 0.97826086956522, 0.67173913043478, 0.22222222222222
47263, 0.95652173913044, 0.64565217391304, 0.22222222222222
47264, 0.95652173913044, 0.67173913043478, 0.25
47265, 0.97826086956522, 0.67173913043478, 0.27777777777778
47266, 0.95652173913044, 0.64565217391304, 0.27777777777778
47267, 0.95652173913044, 0.67173913043478, 0.30555555555556
47268, 0.97826086956522, 0.67173913043478, 0.33333333333333
47269, 0.95652173913044, 0.64565217391304, 0.33333333333333
47270, 0.95652173913044, 0.67173913043478, 0.36111111111111
47271, 0.97826086956522, 0.67173913043478, 0.38888888888889
47272, 0.95652173913044, 0.64565217391304, 0.38888888888889
47273, 0.95652173913044, 0.67173913043478, 0.41666666666667
47274, 0.97826086956522, 0.67173913043478, 0.44444444444444
47275, 0.95652173913044, 0.64565217391304, 0.44444444444444
47276, 0.95652173913043, 0.67173913043478, 0.47222222222222
47277, 0.91304347826087, 0.67173913043478, 0.027777777777778
47278, 0.93478260869565, 0.67173913043478, 0.055555555555556
47279, 0.91304347826087, 0.64565217391304, 0.055555555555556
47280, 0.91304347826087, 0.67173913043478, 0.083333333333333
47281, 0.93478260869565, 0.67173913043478, 0.11111111111111
47282, 0.91304347826087, 0.64565217391304, 0.11111111111111
47283, 0.91304347826087, 0.67173913043478, 0.13888888888889
47284, 0.93478260869565, 0.67173913043478, 0.16666666666667
47285, 0.91304347826087, 0.64565217391304, 0.16666666666667
47286, 0.91304347826087, 0.67173913043478, 0.19444444444444
47287, 0.93478260869565, 0.67173913043478, 0.22222222222222
47288, 0.91304347826087, 0.64565217391304, 0.22222222222222
47289, 0.91304347826087, 0.67173913043478, 0.25
47290, 0.93478260869565, 0.67173913043478, 0.27777777777778
47291, 0.91304347826087, 0.64565217391304, 0.27777777777778
47292, 0.91304347826087, 0.67173913043478, 0.30555555555556
47293, 0.93478260869565, 0.67173913043478, 0.33333333333333
47294, 0.91304347826087, 0.64565217391304, 0.33333333333333
47295, 0.91304347826087, 0.67173913043478, 0.36111111111111
47296, 0.93478260869565, 0.67173913043478, 0.38888888888889
47297, 0.91304347826087, 0.64565217391304, 0.38888888888889
47298, 0.91304347826087, 0.67173913043478, 0.41666666666667
47299, 0.93478260869565, 0.67173913043478, 0.44444444444444
47300, 0.91304347826087, 0.64565217391304, 0.44444444444444
47301, 0.91304347826087, 0.67173913043478, 0.47222222222222
47302, 0.8695652173913, 0.67173913043478, 0.027777777777778
47303, 0.89130434782609, 0.67173913043478, 0.055555555555556
47304, 0.8695652173913, 0.64565217391304, 0.055555555555556
47305, 0.8695652173913, 0.67173913043478, 0.083333333333333
47306, 0.89130434782609, 0.67173913043478, 0.11111111111111
47307, 0.8695652173913, 0.64565217391304, 0.11111111111111
47308, 0.8695652173913, 0.67173913043478, 0.13888888888889
47309, 0.89130434782609, 0.67173913043478, 0.16666666666667
47310, 0.8695652173913, 0.64565217391304, 0.16666666666667
47311, 0.8695652173913, 0.67173913043478, 0.19444444444444
47312, 0.89130434782609, 0.67173913043478, 0.22222222222222
47313, 0.8695652173913, 0.64565217391304, 0.22222222222222
47314, 0.8695652173913, 0.67173913043478, 0.25
47315, 0.89130434782609, 0.67173913043478, 0.27777777777778
47316, 0.8695652173913, 0.64565217391304, 0.27777777777778
47317, 0.8695652173913, 0.67173913043478, 0.30555555555556
47318, 0.89130434782609, 0.67173913043478, 0.33333333333333
47319, 0.8695652173913, 0.64565217391304, 0.33333333333333
47320, 0.8695652173913, 0.67173913043478, 0.36111111111111
47321, 0.89130434782609, 0.67173913043478, 0.38888888888889
47322, 0.8695652173913, 0.64565217391304, 0.38888888888889
47323, 0.8695652173913, 0.67173913043478, 0.41666666666667
47324, 0.89130434782609, 0.67173913043478, 0.44444444444444
47325, 0.8695652173913, 0.64565217391304, 0.44444444444444
47326, 0.8695652173913, 0.67173913043478, 0.47222222222222
47327, 0.82608695652174, 0.67173913043478, 0.027777777777778
47328, 0.84782608695652, 0.67173913043478, 0.055555555555556
47329, 0.82608695652174, 0.64565217391304, 0.055555555555556
47330, 0.82608695652174, 0.67173913043478, 0.083333333333333
47331, 0.84782608695652, 0.67173913043478, 0.11111111111111
47332, 0.82608695652174, 0.64565217391304, 0.11111111111111
47333, 0.82608695652174, 0.67173913043478, 0.13888888888889
47334, 0.84782608695652, 0.67173913043478, 0.16666666666667
47335, 0.82608695652174, 0.64565217391304, 0.16666666666667
47336, 0.82608695652174, 0.67173913043478, 0.19444444444444
47337, 0.84782608695652, 0.67173913043478, 0.22222222222222
47338, 0.82608695652174, 0.64565217391304, 0.22222222222222
47339, 0.82608695652174, 0.67173913043478, 0.25
47340, 0.84782608695652, 0.67173913043478, 0.27777777777778
47341, 0.82608695652174, 0.64565217391304, 0.27777777777778
47342, 0.82608695652174, 0.67173913043478, 0.30555555555556
47343, 0.84782608695652, 0.67173913043478, 0.33333333333333
47344, 0.82608695652174, 0.64565217391304, 0.33333333333333
47345, 0.82608695652174, 0.67173913043478, 0.36111111111111
47346, 0.84782608695652, 0.67173913043478, 0.38888888888889
47347, 0.82608695652174, 0.64565217391304, 0.38888888888889
47348, 0.82608695652174, 0.67173913043478, 0.41666666666667
47349, 0.84782608695652, 0.67173913043478, 0.44444444444444
47350, 0.82608695652174, 0.64565217391304, 0.44444444444444
47351, 0.82608695652174, 0.67173913043478, 0.47222222222222
47352, 0.78260869565217, 0.67173913043478, 0.027777777777778
47353, 0.80434782608696, 0.67173913043478, 0.055555555555556
47354, 0.78260869565217, 0.64565217391304, 0.055555555555556
47355, 0.78260869565217, 0.67173913043478, 0.083333333333333
47356, 0.80434782608696, 0.67173913043478, 0.11111111111111
47357, 0.78260869565217, 0.64565217391304, 0.11111111111111
47358, 0.78260869565217, 0.67173913043478, 0.13888888888889
47359, 0.80434782608696, 0.67173913043478, 0.16666666666667
47360, 0.78260869565217, 0.64565217391304, 0.16666666666667
47361, 0.78260869565217, 0.67173913043478, 0.19444444444444
47362, 0.80434782608696, 0.67173913043478, 0.22222222222222
47363, 0.78260869565217, 0.64565217391304, 0.22222222222222
47364, 0.78260869565217, 0.67173913043478, 0.25
47365, 0.80434782608696, 0.67173913043478, 0.27777777777778
47366, 0.78260869565217, 0.64565217391304, 0.27777777777778
47367, 0.78260869565217, 0.67173913043478, 0.30555555555556
47368, 0.80434782608696, 0.67173913043478, 0.33333333333333
47369, 0.78260869565217, 0.64565217391304, 0.33333333333333
47370, 0.78260869565217, 0.67173913043478, 0.36111111111111
47371, 0.80434782608696, 0.67173913043478, 0.38888888888889
47372, 0.78260869565217, 0.64565217391304, 0.38888888888889
47373, 0.78260869565217, 0.67173913043478, 0.41666666666667
47374, 0.80434782608696, 0.67173913043478, 0.44444444444444
47375, 0.78260869565217, 0.64565217391304, 0.44444444444444
47376, 0.78260869565217, 0.67173913043478, 0.47222222222222
47377, 0.73913043478261, 0.67173913043478, 0.027777777777778
47378, 0.76086956521739, 0.67173913043478, 0.055555555555556
47379, 0.73913043478261, 0.64565217391304, 0.055555555555556
47380, 0.73913043478261, 0.67173913043478, 0.083333333333333
47381, 0.76086956521739, 0.67173913043478, 0.11111111111111
47382, 0.73913043478261, 0.64565217391304, 0.11111111111111
47383, 0.73913043478261, 0.67173913043478, 0.13888888888889
47384, 0.76086956521739, 0.67173913043478, 0.16666666666667
47385, 0.73913043478261, 0.64565217391304, 0.16666666666667
47386, 0.73913043478261, 0.67173913043478, 0.19444444444444
47387, 0.76086956521739, 0.67173913043478, 0.22222222222222
47388, 0.73913043478261, 0.64565217391304, 0.22222222222222
47389, 0.73913043478261, 0.67173913043478, 0.25
47390, 0.76086956521739, 0.67173913043478, 0.27777777777778
47391, 0.73913043478261, 0.64565217391304, 0.27777777777778
47392, 0.73913043478261, 0.67173913043478, 0.30555555555556
47393, 0.76086956521739, 0.67173913043478, 0.33333333333333
47394, 0.73913043478261, 0.64565217391304, 0.33333333333333
47395, 0.73913043478261, 0.67173913043478, 0.36111111111111
47396, 0.76086956521739, 0.67173913043478, 0.38888888888889
47397, 0.73913043478261, 0.64565217391304, 0.38888888888889
47398, 0.73913043478261, 0.67173913043478, 0.41666666666667
47399, 0.76086956521739, 0.67173913043478, 0.44444444444444
47400, 0.73913043478261, 0.64565217391304, 0.44444444444444
47401, 0.73913043478261, 0.67173913043478, 0.47222222222222
47402, 0.69565217391304, 0.67173913043478, 0.027777777777778
47403, 0.71739130434783, 0.67173913043478, 0.055555555555556
47404, 0.69565217391304, 0.64565217391304, 0.055555555555556
47405, 0.69565217391304, 0.67173913043478, 0.083333333333333
47406, 0.71739130434783, 0.67173913043478, 0.11111111111111
47407, 0.69565217391304, 0.64565217391304, 0.11111111111111
47408, 0.69565217391304, 0.67173913043478, 0.13888888888889
47409, 0.71739130434783, 0.67173913043478, 0.16666666666667
47410, 0.69565217391304, 0.64565217391304, 0.16666666666667
47411, 0.69565217391304, 0.67173913043478, 0.19444444444444
47412, 0.71739130434783, 0.67173913043478, 0.22222222222222
47413, 0.69565217391304, 0.64565217391304, 0.22222222222222
47414, 0.69565217391304, 0.67173913043478, 0.25
47415, 0.71739130434783, 0.67173913043478, 0.27777777777778
47416, 0.69565217391304, 0.64565217391304, 0.27777777777778
47417, 0.69565217391304, 0.67173913043478, 0.30555555555556
47418, 0.71739130434783, 0.67173913043478, 0.33333333333333
47419, 0.69565217391304, 0.64565217391304, 0.33333333333333
47420, 0.69565217391304, 0.67173913043478, 0.36111111111111
47421, 0.71739130434783, 0.67173913043478, 0.38888888888889
47422, 0.69565217391304, 0.64565217391304, 0.38888888888889
47423, 0.69565217391304, 0.67173913043478, 0.41666666666667
47424, 0.71739130434783, 0.67173913043478, 0.44444444444444
47425, 0.69565217391304, 0.64565217391304, 0.44444444444444
47426, 0.69565217391304, 0.67173913043478, 0.47222222222222
47427, 0.65217391304348, 0.67173913043478, 0.027777777777778
47428, 0.67391304347826, 0.67173913043478, 0.055555555555556
47429, 0.65217391304348, 0.64565217391304, 0.055555555555556
47430, 0.65217391304348, 0.67173913043478, 0.083333333333333
47431, 0.67391304347826, 0.67173913043478, 0.11111111111111
47432, 0.65217391304348, 0.64565217391304, 0.11111111111111
47433, 0.65217391304348, 0.67173913043478, 0.13888888888889
47434, 0.67391304347826, 0.67173913043478, 0.16666666666667
47435, 0.65217391304348, 0.64565217391304, 0.16666666666667
47436, 0.65217391304348, 0.67173913043478, 0.19444444444444
47437, 0.67391304347826, 0.67173913043478, 0.22222222222222
47438, 0.65217391304348, 0.64565217391304, 0.22222222222222
47439, 0.65217391304348, 0.67173913043478, 0.25
47440, 0.67391304347826, 0.67173913043478, 0.27777777777778
47441, 0.65217391304348, 0.64565217391304, 0.27777777777778
47442, 0.65217391304348, 0.67173913043478, 0.30555555555556
47443, 0.67391304347826, 0.67173913043478, 0.33333333333333
47444, 0.65217391304348, 0.64565217391304, 0.33333333333333
47445, 0.65217391304348, 0.67173913043478, 0.36111111111111
47446, 0.67391304347826, 0.67173913043478, 0.38888888888889
47447, 0.65217391304348, 0.64565217391304, 0.38888888888889
47448, 0.65217391304348, 0.67173913043478, 0.41666666666667
47449, 0.67391304347826, 0.67173913043478, 0.44444444444444
47450, 0.65217391304348, 0.64565217391304, 0.44444444444444
47451, 0.65217391304348, 0.67173913043478, 0.47222222222222
47452, 0.60869565217391, 0.67173913043478, 0.027777777777778
47453, 0.6304347826087, 0.67173913043478, 0.055555555555556
47454, 0.60869565217391, 0.64565217391304, 0.055555555555556
47455, 0.60869565217391, 0.67173913043478, 0.083333333333333
47456, 0.6304347826087, 0.67173913043478, 0.11111111111111
47457, 0.60869565217391, 0.64565217391304, 0.11111111111111
47458, 0.60869565217391, 0.67173913043478, 0.13888888888889
47459, 0.6304347826087, 0.67173913043478, 0.16666666666667
47460, 0.60869565217391, 0.64565217391304, 0.16666666666667
47461, 0.60869565217391, 0.67173913043478, 0.19444444444444
47462, 0.6304347826087, 0.67173913043478, 0.22222222222222
47463, 0.60869565217391, 0.64565217391304, 0.22222222222222
47464, 0.60869565217391, 0.67173913043478, 0.25
47465, 0.6304347826087, 0.67173913043478, 0.27777777777778
47466, 0.60869565217391, 0.64565217391304, 0.27777777777778
47467, 0.60869565217391, 0.67173913043478, 0.30555555555556
47468, 0.6304347826087, 0.67173913043478, 0.33333333333333
47469, 0.60869565217391, 0.64565217391304, 0.33333333333333
47470, 0.60869565217391, 0.67173913043478, 0.36111111111111
47471, 0.6304347826087, 0.67173913043478, 0.38888888888889
47472, 0.60869565217391, 0.64565217391304, 0.38888888888889
47473, 0.60869565217391, 0.67173913043478, 0.41666666666667
47474, 0.6304347826087, 0.67173913043478, 0.44444444444444
47475, 0.60869565217391, 0.64565217391304, 0.44444444444444
47476, 0.60869565217391, 0.67173913043478, 0.47222222222222
47477, 0.56521739130435, 0.67173913043478, 0.027777777777778
47478, 0.58695652173913, 0.67173913043478, 0.055555555555556
47479, 0.56521739130435, 0.64565217391304, 0.055555555555556
47480, 0.56521739130435, 0.67173913043478, 0.083333333333333
47481, 0.58695652173913, 0.67173913043478, 0.11111111111111
47482, 0.56521739130435, 0.64565217391304, 0.11111111111111
47483, 0.56521739130435, 0.67173913043478, 0.13888888888889
47484, 0.58695652173913, 0.67173913043478, 0.16666666666667
47485, 0.56521739130435, 0.64565217391304, 0.16666666666667
47486, 0.56521739130435, 0.67173913043478, 0.19444444444444
47487, 0.58695652173913, 0.67173913043478, 0.22222222222222
47488, 0.56521739130435, 0.64565217391304, 0.22222222222222
47489, 0.56521739130435, 0.67173913043478, 0.25
47490, 0.58695652173913, 0.67173913043478, 0.27777777777778
47491, 0.56521739130435, 0.64565217391304, 0.27777777777778
47492, 0.56521739130435, 0.67173913043478, 0.30555555555556
47493, 0.58695652173913, 0.67173913043478, 0.33333333333333
47494, 0.56521739130435, 0.64565217391304, 0.33333333333333
47495, 0.56521739130435, 0.67173913043478, 0.36111111111111
47496, 0.58695652173913, 0.67173913043478, 0.38888888888889
47497, 0.56521739130435, 0.64565217391304, 0.38888888888889
47498, 0.56521739130435, 0.67173913043478, 0.41666666666667
47499, 0.58695652173913, 0.67173913043478, 0.44444444444444
47500, 0.56521739130435, 0.64565217391304, 0.44444444444444
47501, 0.56521739130435, 0.67173913043478, 0.47222222222222
47502, 0.52173913043478, 0.67173913043478, 0.027777777777778
47503, 0.54347826086957, 0.67173913043478, 0.055555555555556
47504, 0.52173913043478, 0.64565217391304, 0.055555555555556
47505, 0.52173913043478, 0.67173913043478, 0.083333333333333
47506, 0.54347826086957, 0.67173913043478, 0.11111111111111
47507, 0.52173913043478, 0.64565217391304, 0.11111111111111
47508, 0.52173913043478, 0.67173913043478, 0.13888888888889
47509, 0.54347826086957, 0.67173913043478, 0.16666666666667
47510, 0.52173913043478, 0.64565217391304, 0.16666666666667
47511, 0.52173913043478, 0.67173913043478, 0.19444444444444
47512, 0.54347826086956, 0.67173913043478, 0.22222222222222
47513, 0.52173913043478, 0.64565217391304, 0.22222222222222
47514, 0.52173913043478, 0.67173913043478, 0.25
47515, 0.54347826086956, 0.67173913043478, 0.27777777777778
47516, 0.52173913043478, 0.64565217391304, 0.27777777777778
47517, 0.52173913043478, 0.67173913043478, 0.30555555555556
47518, 0.54347826086956, 0.67173913043478, 0.33333333333333
47519, 0.52173913043478, 0.64565217391304, 0.33333333333333
47520, 0.52173913043478, 0.67173913043478, 0.36111111111111
47521, 0.54347826086956, 0.67173913043478, 0.38888888888889
47522, 0.52173913043478, 0.64565217391304, 0.38888888888889
47523, 0.52173913043478, 0.67173913043478, 0.41666666666667
47524, 0.54347826086956, 0.67173913043478, 0.44444444444444
47525, 0.52173913043478, 0.64565217391304, 0.44444444444444
47526, 0.52173913043478, 0.67173913043478, 0.47222222222222
47527, 0.47826086956522, 0.67173913043478, 0.027777777777778
47528, 0.5, 0.67173913043478, 0.055555555555556
47529, 0.47826086956522, 0.64565217391304, 0.055555555555556
47530, 0.47826086956522, 0.67173913043478, 0.083333333333333
47531, 0.5, 0.67173913043478, 0.11111111111111
47532, 0.47826086956522, 0.64565217391304, 0.11111111111111
47533, 0.47826086956522, 0.67173913043478, 0.13888888888889
47534, 0.5, 0.67173913043478, 0.16666666666667
47535, 0.47826086956522, 0.64565217391304, 0.16666666666667
47536, 0.47826086956522, 0.67173913043478, 0.19444444444444
47537, 0.5, 0.67173913043478, 0.22222222222222
47538, 0.47826086956522, 0.64565217391304, 0.22222222222222
47539, 0.47826086956522, 0.67173913043478, 0.25
47540, 0.5, 0.67173913043478, 0.27777777777778
47541, 0.47826086956522, 0.64565217391304, 0.27777777777778
47542, 0.47826086956522, 0.67173913043478, 0.30555555555556
47543, 0.5, 0.67173913043478, 0.33333333333333
47544, 0.47826086956522, 0.64565217391304, 0.33333333333333
47545, 0.47826086956522, 0.67173913043478, 0.36111111111111
47546, 0.5, 0.67173913043478, 0.38888888888889
47547, 0.47826086956522, 0.64565217391304, 0.38888888888889
47548, 0.47826086956522, 0.67173913043478, 0.41666666666667
47549, 0.5, 0.67173913043478, 0.44444444444444
47550, 0.47826086956522, 0.64565217391304, 0.44444444444444
47551, 0.47826086956522, 0.67173913043478, 0.47222222222222
47552, 0.43478260869565, 0.67173913043478, 0.027777777777778
47553, 0.45652173913043, 0.67173913043478, 0.055555555555556
47554, 0.43478260869565, 0.64565217391304, 0.055555555555556
47555, 0.43478260869565, 0.67173913043478, 0.083333333333333
47556, 0.45652173913043, 0.67173913043478, 0.11111111111111
47557, 0.43478260869565, 0.64565217391304, 0.11111111111111
47558, 0.43478260869565, 0.67173913043478, 0.13888888888889
47559, 0.45652173913043, 0.67173913043478, 0.16666666666667
47560, 0.43478260869565, 0.64565217391304, 0.16666666666667
47561, 0.43478260869565, 0.67173913043478, 0.19444444444444
47562, 0.45652173913043, 0.67173913043478, 0.22222222222222
47563, 0.43478260869565, 0.64565217391304, 0.22222222222222
47564, 0.43478260869565, 0.67173913043478, 0.25
47565, 0.45652173913043, 0.67173913043478, 0.27777777777778
47566, 0.43478260869565, 0.64565217391304, 0.27777777777778
47567, 0.43478260869565, 0.67173913043478, 0.30555555555556
47568, 0.45652173913043, 0.67173913043478, 0.33333333333333
47569, 0.43478260869565, 0.64565217391304, 0.33333333333333
47570, 0.43478260869565, 0.67173913043478, 0.36111111111111
47571, 0.45652173913043, 0.67173913043478, 0.38888888888889
47572, 0.43478260869565, 0.64565217391304, 0.38888888888889
47573, 0.43478260869565, 0.67173913043478, 0.41666666666667
47574, 0.45652173913043, 0.67173913043478, 0.44444444444444
47575, 0.43478260869565, 0.64565217391304, 0.44444444444444
47576, 0.43478260869565, 0.67173913043478, 0.47222222222222
47577, 0.39130434782609, 0.67173913043478, 0.027777777777778
47578, 0.41304347826087, 0.67173913043478, 0.055555555555556
47579, 0.39130434782609, 0.64565217391304, 0.055555555555556
47580, 0.39130434782609, 0.67173913043478, 0.083333333333333
47581, 0.41304347826087, 0.67173913043478, 0.11111111111111
47582, 0.39130434782609, 0.64565217391304, 0.11111111111111
47583, 0.39130434782609, 0.67173913043478, 0.13888888888889
47584, 0.41304347826087, 0.67173913043478, 0.16666666666667
47585, 0.39130434782609, 0.64565217391304, 0.16666666666667
47586, 0.39130434782609, 0.67173913043478, 0.19444444444444
47587, 0.41304347826087, 0.67173913043478, 0.22222222222222
47588, 0.39130434782609, 0.64565217391304, 0.22222222222222
47589, 0.39130434782609, 0.67173913043478, 0.25
47590, 0.41304347826087, 0.67173913043478, 0.27777777777778
47591, 0.39130434782609, 0.64565217391304, 0.27777777777778
47592, 0.39130434782609, 0.67173913043478, 0.30555555555556
47593, 0.41304347826087, 0.67173913043478, 0.33333333333333
47594, 0.39130434782609, 0.64565217391304, 0.33333333333333
47595, 0.39130434782609, 0.67173913043478, 0.36111111111111
47596, 0.41304347826087, 0.67173913043478, 0.38888888888889
47597, 0.39130434782609, 0.64565217391304, 0.38888888888889
47598, 0.39130434782609, 0.67173913043478, 0.41666666666667
47599, 0.41304347826087, 0.67173913043478, 0.44444444444444
47600, 0.39130434782609, 0.64565217391304, 0.44444444444444
47601, 0.39130434782609, 0.67173913043478, 0.47222222222222
47602, 0.34782608695652, 0.67173913043478, 0.027777777777778
47603, 0.3695652173913, 0.67173913043478, 0.055555555555556
47604, 0.34782608695652, 0.64565217391304, 0.055555555555556
47605, 0.34782608695652, 0.67173913043478, 0.083333333333333
47606, 0.3695652173913, 0.67173913043478, 0.11111111111111
47607, 0.34782608695652, 0.64565217391304, 0.11111111111111
47608, 0.34782608695652, 0.67173913043478, 0.13888888888889
47609, 0.3695652173913, 0.67173913043478, 0.16666666666667
47610, 0.34782608695652, 0.64565217391304, 0.16666666666667
47611, 0.34782608695652, 0.67173913043478, 0.19444444444444
47612, 0.3695652173913, 0.67173913043478, 0.22222222222222
47613, 0.34782608695652, 0.64565217391304, 0.22222222222222
47614, 0.34782608695652, 0.67173913043478, 0.25
47615, 0.3695652173913, 0.67173913043478, 0.27777777777778
47616, 0.34782608695652, 0.64565217391304, 0.27777777777778
47617, 0.34782608695652, 0.67173913043478, 0.30555555555556
47618, 0.3695652173913, 0.67173913043478, 0.33333333333333
47619, 0.34782608695652, 0.64565217391304, 0.33333333333333
47620, 0.34782608695652, 0.67173913043478, 0.36111111111111
47621, 0.3695652173913, 0.67173913043478, 0.38888888888889
47622, 0.34782608695652, 0.64565217391304, 0.38888888888889
47623, 0.34782608695652, 0.67173913043478, 0.41666666666667
47624, 0.3695652173913, 0.67173913043478, 0.44444444444444
47625, 0.34782608695652, 0.64565217391304, 0.44444444444444
47626, 0.34782608695652, 0.67173913043478, 0.47222222222222
47627, 0.30434782608696, 0.67173913043478, 0.027777777777778
47628, 0.32608695652174, 0.67173913043478, 0.055555555555556
47629, 0.30434782608696, 0.64565217391304, 0.055555555555556
47630, 0.30434782608696, 0.67173913043478, 0.083333333333333
47631, 0.32608695652174, 0.67173913043478, 0.11111111111111
47632, 0.30434782608696, 0.64565217391304, 0.11111111111111
47633, 0.30434782608696, 0.67173913043478, 0.13888888888889
47634, 0.32608695652174, 0.67173913043478, 0.16666666666667
47635, 0.30434782608696, 0.64565217391304, 0.16666666666667
47636, 0.30434782608696, 0.67173913043478, 0.19444444444444
47637, 0.32608695652174, 0.67173913043478, 0.22222222222222
47638, 0.30434782608696, 0.64565217391304, 0.22222222222222
47639, 0.30434782608696, 0.67173913043478, 0.25
47640, 0.32608695652174, 0.67173913043478, 0.27777777777778
47641, 0.30434782608696, 0.64565217391304, 0.27777777777778
47642, 0.30434782608696, 0.67173913043478, 0.30555555555556
47643, 0.32608695652174, 0.67173913043478, 0.33333333333333
47644, 0.30434782608696, 0.64565217391304, 0.33333333333333
47645, 0.30434782608696, 0.67173913043478, 0.36111111111111
47646, 0.32608695652174, 0.67173913043478, 0.38888888888889
47647, 0.30434782608696, 0.64565217391304, 0.38888888888889
47648, 0.30434782608696, 0.67173913043478, 0.41666666666667
47649, 0.32608695652174, 0.67173913043478, 0.44444444444444
47650, 0.30434782608696, 0.64565217391304, 0.44444444444444
47651, 0.30434782608696, 0.67173913043478, 0.47222222222222
47652, 0.26086956521739, 0.67173913043478, 0.027777777777778
47653, 0.28260869565217, 0.67173913043478, 0.055555555555556
47654, 0.26086956521739, 0.64565217391304, 0.055555555555556
47655, 0.26086956521739, 0.67173913043478, 0.083333333333333
47656, 0.28260869565217, 0.67173913043478, 0.11111111111111
47657, 0.26086956521739, 0.64565217391304, 0.11111111111111
47658, 0.26086956521739, 0.67173913043478, 0.13888888888889
47659, 0.28260869565217, 0.67173913043478, 0.16666666666667
47660, 0.26086956521739, 0.64565217391304, 0.16666666666667
47661, 0.26086956521739, 0.67173913043478, 0.19444444444444
47662, 0.28260869565217, 0.67173913043478, 0.22222222222222
47663, 0.26086956521739, 0.64565217391304, 0.22222222222222
47664, 0.26086956521739, 0.67173913043478, 0.25
47665, 0.28260869565217, 0.67173913043478, 0.27777777777778
47666, 0.26086956521739, 0.64565217391304, 0.27777777777778
47667, 0.26086956521739, 0.67173913043478, 0.30555555555556
47668, 0.28260869565217, 0.67173913043478, 0.33333333333333
47669, 0.26086956521739, 0.64565217391304, 0.33333333333333
47670, 0.26086956521739, 0.67173913043478, 0.36111111111111
47671, 0.28260869565217, 0.67173913043478, 0.38888888888889
47672, 0.26086956521739, 0.64565217391304, 0.38888888888889
47673, 0.26086956521739, 0.67173913043478, 0.41666666666667
47674, 0.28260869565217, 0.67173913043478, 0.44444444444444
47675, 0.26086956521739, 0.64565217391304, 0.44444444444444
47676, 0.26086956521739, 0.67173913043478, 0.47222222222222
47677, 0.21739130434783, 0.67173913043478, 0.027777777777778
47678, 0.23913043478261, 0.67173913043478, 0.055555555555556
47679, 0.21739130434783, 0.64565217391304, 0.055555555555556
47680, 0.21739130434783, 0.67173913043478, 0.083333333333333
47681, 0.23913043478261, 0.67173913043478, 0.11111111111111
47682, 0.21739130434783, 0.64565217391304, 0.11111111111111
47683, 0.21739130434783, 0.67173913043478, 0.13888888888889
47684, 0.23913043478261, 0.67173913043478, 0.16666666666667
47685, 0.21739130434783, 0.64565217391304, 0.16666666666667
47686, 0.21739130434783, 0.67173913043478, 0.19444444444444
47687, 0.23913043478261, 0.67173913043478, 0.22222222222222
47688, 0.21739130434783, 0.64565217391304, 0.22222222222222
47689, 0.21739130434783, 0.67173913043478, 0.25
47690, 0.23913043478261, 0.67173913043478, 0.27777777777778
47691, 0.21739130434783, 0.64565217391304, 0.27777777777778
47692, 0.21739130434783, 0.67173913043478, 0.30555555555556
47693, 0.23913043478261, 0.67173913043478, 0.33333333333333
47694, 0.21739130434783, 0.64565217391304, 0.33333333333333
47695, 0.21739130434783, 0.67173913043478, 0.36111111111111
47696, 0.23913043478261, 0.67173913043478, 0.38888888888889
47697, 0.21739130434783, 0.64565217391304, 0.38888888888889
47698, 0.21739130434783, 0.67173913043478, 0.41666666666667
47699, 0.23913043478261, 0.67173913043478, 0.44444444444444
47700, 0.21739130434783, 0.64565217391304, 0.44444444444444
47701, 0.21739130434783, 0.67173913043478, 0.47222222222222
47702, 0.17391304347826, 0.67173913043478, 0.027777777777778
47703, 0.19565217391304, 0.67173913043478, 0.055555555555556
47704, 0.17391304347826, 0.64565217391304, 0.055555555555556
47705, 0.17391304347826, 0.67173913043478, 0.083333333333333
47706, 0.19565217391304, 0.67173913043478, 0.11111111111111
47707, 0.17391304347826, 0.64565217391304, 0.11111111111111
47708, 0.17391304347826, 0.67173913043478, 0.13888888888889
47709, 0.19565217391304, 0.67173913043478, 0.16666666666667
47710, 0.17391304347826, 0.64565217391304, 0.16666666666667
47711, 0.17391304347826, 0.67173913043478, 0.19444444444444
47712, 0.19565217391304, 0.67173913043478, 0.22222222222222
47713, 0.17391304347826, 0.64565217391304, 0.22222222222222
47714, 0.17391304347826, 0.67173913043478, 0.25
47715, 0.19565217391304, 0.67173913043478, 0.27777777777778
47716, 0.17391304347826, 0.64565217391304, 0.27777777777778
47717, 0.17391304347826, 0.67173913043478, 0.30555555555556
47718, 0.19565217391304, 0.67173913043478, 0.33333333333333
47719, 0.17391304347826, 0.64565217391304, 0.33333333333333
47720, 0.17391304347826, 0.67173913043478, 0.36111111111111
47721, 0.19565217391304, 0.67173913043478, 0.38888888888889
47722, 0.17391304347826, 0.64565217391304, 0.38888888888889
47723, 0.17391304347826, 0.67173913043478, 0.41666666666667
47724, 0.19565217391304, 0.67173913043478, 0.44444444444444
47725, 0.17391304347826, 0.64565217391304, 0.44444444444444
47726, 0.17391304347826, 0.67173913043478, 0.47222222222222
47727, 0.1304347826087, 0.67173913043478, 0.027777777777778
47728, 0.15217391304348, 0.67173913043478, 0.055555555555556
47729, 0.1304347826087, 0.64565217391304, 0.055555555555556
47730, 0.1304347826087, 0.67173913043478, 0.083333333333333
47731, 0.15217391304348, 0.67173913043478, 0.11111111111111
47732, 0.1304347826087, 0.64565217391304, 0.11111111111111
47733, 0.1304347826087, 0.67173913043478, 0.13888888888889
47734, 0.15217391304348, 0.67173913043478, 0.16666666666667
47735, 0.1304347826087, 0.64565217391304, 0.16666666666667
47736, 0.1304347826087, 0.67173913043478, 0.19444444444444
47737, 0.15217391304348, 0.67173913043478, 0.22222222222222
47738, 0.1304347826087, 0.64565217391304, 0.22222222222222
47739, 0.1304347826087, 0.67173913043478, 0.25
47740, 0.15217391304348, 0.67173913043478, 0.27777777777778
47741, 0.1304347826087, 0.64565217391304, 0.27777777777778
47742, 0.1304347826087, 0.67173913043478, 0.30555555555556
47743, 0.15217391304348, 0.67173913043478, 0.33333333333333
47744, 0.1304347826087, 0.64565217391304, 0.33333333333333
47745, 0.1304347826087, 0.67173913043478, 0.36111111111111
47746, 0.15217391304348, 0.67173913043478, 0.38888888888889
47747, 0.1304347826087, 0.64565217391304, 0.38888888888889
47748, 0.1304347826087, 0.67173913043478, 0.41666666666667
47749, 0.15217391304348, 0.67173913043478, 0.44444444444444
47750, 0.1304347826087, 0.64565217391304, 0.44444444444444
47751, 0.1304347826087, 0.67173913043478, 0.47222222222222
47752, 0.08695652173913, 0.67173913043478, 0.027777777777778
47753, 0.10869565217391, 0.67173913043478, 0.055555555555556
47754, 0.08695652173913, 0.64565217391304, 0.055555555555556
47755, 0.08695652173913, 0.67173913043478, 0.083333333333333
47756, 0.10869565217391, 0.67173913043478, 0.11111111111111
47757, 0.08695652173913, 0.64565217391304, 0.11111111111111
47758, 0.08695652173913, 0.67173913043478, 0.13888888888889
47759, 0.10869565217391, 0.67173913043478, 0.16666666666667
47760, 0.08695652173913, 0.64565217391304, 0.16666666666667
47761, 0.08695652173913, 0.67173913043478, 0.19444444444444
47762, 0.10869565217391, 0.67173913043478, 0.22222222222222
47763, 0.08695652173913, 0.64565217391304, 0.22222222222222
47764, 0.08695652173913, 0.67173913043478, 0.25
47765, 0.10869565217391, 0.67173913043478, 0.27777777777778
47766, 0.08695652173913, 0.64565217391304, 0.27777777777778
47767, 0.08695652173913, 0.67173913043478, 0.30555555555556
47768, 0.10869565217391, 0.67173913043478, 0.33333333333333
47769, 0.08695652173913, 0.64565217391304, 0.33333333333333
47770, 0.08695652173913, 0.67173913043478, 0.36111111111111
47771, 0.10869565217391, 0.67173913043478, 0.38888888888889
47772, 0.08695652173913, 0.64565217391304, 0.38888888888889
47773, 0.08695652173913, 0.67173913043478, 0.41666666666667
47774, 0.10869565217391, 0.67173913043478, 0.44444444444444
47775, 0.08695652173913, 0.64565217391304, 0.44444444444444
47776, 0.08695652173913, 0.67173913043478, 0.47222222222222
47777, 0.043478260869565, 0.67173913043478, 0.027777777777778
47778, 0.065217391304348, 0.67173913043478, 0.055555555555556
47779, 0.043478260869565, 0.64565217391304, 0.055555555555556
47780, 0.043478260869565, 0.67173913043478, 0.083333333333333
47781, 0.065217391304348, 0.67173913043478, 0.11111111111111
47782, 0.043478260869565, 0.64565217391304, 0.11111111111111
47783, 0.043478260869565, 0.67173913043478, 0.13888888888889
