28538, 12502, 79125, 79133, 12494, 1617, 13729, 13730, 1616, 79737, 79761, 79762, 12838, 13800, 13801, 13802, 
1639, 12840, 79738, 79763, 12823
28539, 1482, 13507, 13508, 1481, 12487, 79126, 79134, 12479, 13578, 13581, 13580, 1504, 79741, 79765, 79766, 
12807, 12808, 79739, 79764, 12791
28540, 12487, 79126, 79134, 12479, 12488, 79127, 79135, 12480, 79741, 79765, 79766, 12807, 79744, 79768, 79769, 
12809, 12810, 79742, 79767, 12793
28541, 12488, 79127, 79135, 12480, 12489, 79128, 79136, 12481, 79744, 79768, 79769, 12809, 79747, 79771, 79772, 
12811, 12812, 79745, 79770, 12795
28542, 12489, 79128, 79136, 12481, 12490, 79129, 79137, 12482, 79747, 79771, 79772, 12811, 79750, 79774, 79775, 
12813, 12814, 79748, 79773, 12797
28543, 12490, 79129, 79137, 12482, 12491, 79130, 79138, 12483, 79750, 79774, 79775, 12813, 79753, 79777, 79778, 
12815, 12816, 79751, 79776, 12799
28544, 12491, 79130, 79138, 12483, 12492, 79131, 79139, 12484, 79753, 79777, 79778, 12815, 79756, 79780, 79781, 
12817, 12818, 79754, 79779, 12801
28545, 12492, 79131, 79139, 12484, 12493, 79132, 79140, 12485, 79756, 79780, 79781, 12817, 79759, 79783, 79784, 
12819, 12820, 79757, 79782, 12803
28546, 12493, 79132, 79140, 12485, 12494, 79133, 79141, 12486, 79759, 79783, 79784, 12819, 79762, 79786, 79787, 
12821, 12822, 79760, 79785, 12805
28547, 12494, 79133, 79141, 12486, 1616, 13730, 13731, 1615, 79762, 79786, 79787, 12821, 13802, 13803, 13804, 
1638, 12823, 79763, 79788, 12806
28548, 1481, 13508, 13509, 1480, 12479, 79134, 79142, 12471, 13580, 13583, 13582, 1503, 79766, 79790, 79791, 
12790, 12791, 79764, 79789, 12774
28549, 12479, 79134, 79142, 12471, 12480, 79135, 79143, 12472, 79766, 79790, 79791, 12790, 79769, 79793, 79794, 
12792, 12793, 79767, 79792, 12776
28550, 12480, 79135, 79143, 12472, 12481, 79136, 79144, 12473, 79769, 79793, 79794, 12792, 79772, 79796, 79797, 
12794, 12795, 79770, 79795, 12778
28551, 12481, 79136, 79144, 12473, 12482, 79137, 79145, 12474, 79772, 79796, 79797, 12794, 79775, 79799, 79800, 
12796, 12797, 79773, 79798, 12780
28552, 12482, 79137, 79145, 12474, 12483, 79138, 79146, 12475, 79775, 79799, 79800, 12796, 79778, 79802, 79803, 
12798, 12799, 79776, 79801, 12782
28553, 12483, 79138, 79146, 12475, 12484, 79139, 79147, 12476, 79778, 79802, 79803, 12798, 79781, 79805, 79806, 
12800, 12801, 79779, 79804, 12784
28554, 12484, 79139, 79147, 12476, 12485, 79140, 79148, 12477, 79781, 79805, 79806, 12800, 79784, 79808, 79809, 
12802, 12803, 79782, 79807, 12786
28555, 12485, 79140, 79148, 12477, 12486, 79141, 79149, 12478, 79784, 79808, 79809, 12802, 79787, 79811, 79812, 
12804, 12805, 79785, 79810, 12788
28556, 12486, 79141, 79149, 12478, 1615, 13731, 13732, 1614, 79787, 79811, 79812, 12804, 13804, 13805, 13806, 
1637, 12806, 79788, 79813, 12789
28557, 1480, 13509, 13510, 1479, 12471, 79142, 79150, 12463, 13582, 13585, 13584, 1502, 79791, 79815, 79816, 
12773, 12774, 79789, 79814, 12757
28558, 12471, 79142, 79150, 12463, 12472, 79143, 79151, 12464, 79791, 79815, 79816, 12773, 79794, 79818, 79819, 
12775, 12776, 79792, 79817, 12759
28559, 12472, 79143, 79151, 12464, 12473, 79144, 79152, 12465, 79794, 79818, 79819, 12775, 79797, 79821, 79822, 
12777, 12778, 79795, 79820, 12761
28560, 12473, 79144, 79152, 12465, 12474, 79145, 79153, 12466, 79797, 79821, 79822, 12777, 79800, 79824, 79825, 
12779, 12780, 79798, 79823, 12763
28561, 12474, 79145, 79153, 12466, 12475, 79146, 79154, 12467, 79800, 79824, 79825, 12779, 79803, 79827, 79828, 
12781, 12782, 79801, 79826, 12765
28562, 12475, 79146, 79154, 12467, 12476, 79147, 79155, 12468, 79803, 79827, 79828, 12781, 79806, 79830, 79831, 
12783, 12784, 79804, 79829, 12767
28563, 12476, 79147, 79155, 12468, 12477, 79148, 79156, 12469, 79806, 79830, 79831, 12783, 79809, 79833, 79834, 
12785, 12786, 79807, 79832, 12769
28564, 12477, 79148, 79156, 12469, 12478, 79149, 79157, 12470, 79809, 79833, 79834, 12785, 79812, 79836, 79837, 
12787, 12788, 79810, 79835, 12771
28565, 12478, 79149, 79157, 12470, 1614, 13732, 13733, 1613, 79812, 79836, 79837, 12787, 13806, 13807, 13808, 
1636, 12789, 79813, 79838, 12772
28566, 1479, 13510, 13511, 1478, 12463, 79150, 79158, 12455, 13584, 13587, 13586, 1501, 79816, 79840, 79841, 
12756, 12757, 79814, 79839, 12740
28567, 12463, 79150, 79158, 12455, 12464, 79151, 79159, 12456, 79816, 79840, 79841, 12756, 79819, 79843, 79844, 
12758, 12759, 79817, 79842, 12742
28568, 12464, 79151, 79159, 12456, 12465, 79152, 79160, 12457, 79819, 79843, 79844, 12758, 79822, 79846, 79847, 
12760, 12761, 79820, 79845, 12744
28569, 12465, 79152, 79160, 12457, 12466, 79153, 79161, 12458, 79822, 79846, 79847, 12760, 79825, 79849, 79850, 
12762, 12763, 79823, 79848, 12746
28570, 12466, 79153, 79161, 12458, 12467, 79154, 79162, 12459, 79825, 79849, 79850, 12762, 79828, 79852, 79853, 
12764, 12765, 79826, 79851, 12748
28571, 12467, 79154, 79162, 12459, 12468, 79155, 79163, 12460, 79828, 79852, 79853, 12764, 79831, 79855, 79856, 
12766, 12767, 79829, 79854, 12750
28572, 12468, 79155, 79163, 12460, 12469, 79156, 79164, 12461, 79831, 79855, 79856, 12766, 79834, 79858, 79859, 
12768, 12769, 79832, 79857, 12752
28573, 12469, 79156, 79164, 12461, 12470, 79157, 79165, 12462, 79834, 79858, 79859, 12768, 79837, 79861, 79862, 
12770, 12771, 79835, 79860, 12754
28574, 12470, 79157, 79165, 12462, 1613, 13733, 13734, 1612, 79837, 79861, 79862, 12770, 13808, 13809, 13810, 
1635, 12772, 79838, 79863, 12755
28575, 1478, 13511, 13512, 1477, 12455, 79158, 79166, 12447, 13586, 13589, 13588, 1500, 79841, 79865, 79866, 
12739, 12740, 79839, 79864, 12723
28576, 12455, 79158, 79166, 12447, 12456, 79159, 79167, 12448, 79841, 79865, 79866, 12739, 79844, 79868, 79869, 
12741, 12742, 79842, 79867, 12725
28577, 12456, 79159, 79167, 12448, 12457, 79160, 79168, 12449, 79844, 79868, 79869, 12741, 79847, 79871, 79872, 
12743, 12744, 79845, 79870, 12727
28578, 12457, 79160, 79168, 12449, 12458, 79161, 79169, 12450, 79847, 79871, 79872, 12743, 79850, 79874, 79875, 
12745, 12746, 79848, 79873, 12729
28579, 12458, 79161, 79169, 12450, 12459, 79162, 79170, 12451, 79850, 79874, 79875, 12745, 79853, 79877, 79878, 
12747, 12748, 79851, 79876, 12731
28580, 12459, 79162, 79170, 12451, 12460, 79163, 79171, 12452, 79853, 79877, 79878, 12747, 79856, 79880, 79881, 
12749, 12750, 79854, 79879, 12733
28581, 12460, 79163, 79171, 12452, 12461, 79164, 79172, 12453, 79856, 79880, 79881, 12749, 79859, 79883, 79884, 
12751, 12752, 79857, 79882, 12735
28582, 12461, 79164, 79172, 12453, 12462, 79165, 79173, 12454, 79859, 79883, 79884, 12751, 79862, 79886, 79887, 
12753, 12754, 79860, 79885, 12737
28583, 12462, 79165, 79173, 12454, 1612, 13734, 13735, 1611, 79862, 79886, 79887, 12753, 13810, 13811, 13812, 
1634, 12755, 79863, 79888, 12738
28584, 1477, 13512, 13513, 1476, 12447, 79166, 79174, 12439, 13588, 13591, 13590, 1499, 79866, 79890, 79891, 
12722, 12723, 79864, 79889, 12706
28585, 12447, 79166, 79174, 12439, 12448, 79167, 79175, 12440, 79866, 79890, 79891, 12722, 79869, 79893, 79894, 
12724, 12725, 79867, 79892, 12708
28586, 12448, 79167, 79175, 12440, 12449, 79168, 79176, 12441, 79869, 79893, 79894, 12724, 79872, 79896, 79897, 
12726, 12727, 79870, 79895, 12710
28587, 12449, 79168, 79176, 12441, 12450, 79169, 79177, 12442, 79872, 79896, 79897, 12726, 79875, 79899, 79900, 
12728, 12729, 79873, 79898, 12712
28588, 12450, 79169, 79177, 12442, 12451, 79170, 79178, 12443, 79875, 79899, 79900, 12728, 79878, 79902, 79903, 
12730, 12731, 79876, 79901, 12714
28589, 12451, 79170, 79178, 12443, 12452, 79171, 79179, 12444, 79878, 79902, 79903, 12730, 79881, 79905, 79906, 
12732, 12733, 79879, 79904, 12716
28590, 12452, 79171, 79179, 12444, 12453, 79172, 79180, 12445, 79881, 79905, 79906, 12732, 79884, 79908, 79909, 
12734, 12735, 79882, 79907, 12718
28591, 12453, 79172, 79180, 12445, 12454, 79173, 79181, 12446, 79884, 79908, 79909, 12734, 79887, 79911, 79912, 
12736, 12737, 79885, 79910, 12720
28592, 12454, 79173, 79181, 12446, 1611, 13735, 13736, 1610, 79887, 79911, 79912, 12736, 13812, 13813, 13814, 
1633, 12738, 79888, 79913, 12721
28593, 1476, 13513, 13514, 1475, 12439, 79174, 79182, 12431, 13590, 13593, 13592, 1498, 79891, 79915, 79916, 
12705, 12706, 79889, 79914, 12689
28594, 12439, 79174, 79182, 12431, 12440, 79175, 79183, 12432, 79891, 79915, 79916, 12705, 79894, 79918, 79919, 
12707, 12708, 79892, 79917, 12691
28595, 12440, 79175, 79183, 12432, 12441, 79176, 79184, 12433, 79894, 79918, 79919, 12707, 79897, 79921, 79922, 
12709, 12710, 79895, 79920, 12693
28596, 12441, 79176, 79184, 12433, 12442, 79177, 79185, 12434, 79897, 79921, 79922, 12709, 79900, 79924, 79925, 
12711, 12712, 79898, 79923, 12695
28597, 12442, 79177, 79185, 12434, 12443, 79178, 79186, 12435, 79900, 79924, 79925, 12711, 79903, 79927, 79928, 
12713, 12714, 79901, 79926, 12697
28598, 12443, 79178, 79186, 12435, 12444, 79179, 79187, 12436, 79903, 79927, 79928, 12713, 79906, 79930, 79931, 
12715, 12716, 79904, 79929, 12699
28599, 12444, 79179, 79187, 12436, 12445, 79180, 79188, 12437, 79906, 79930, 79931, 12715, 79909, 79933, 79934, 
12717, 12718, 79907, 79932, 12701
28600, 12445, 79180, 79188, 12437, 12446, 79181, 79189, 12438, 79909, 79933, 79934, 12717, 79912, 79936, 79937, 
12719, 12720, 79910, 79935, 12703
28601, 12446, 79181, 79189, 12438, 1610, 13736, 13737, 1609, 79912, 79936, 79937, 12719, 13814, 13815, 13816, 
1632, 12721, 79913, 79938, 12704
28602, 1475, 13514, 13515, 1474, 12431, 79182, 79190, 12423, 13592, 13595, 13594, 1497, 79916, 79940, 79941, 
12688, 12689, 79914, 79939, 12672
28603, 12431, 79182, 79190, 12423, 12432, 79183, 79191, 12424, 79916, 79940, 79941, 12688, 79919, 79943, 79944, 
12690, 12691, 79917, 79942, 12674
28604, 12432, 79183, 79191, 12424, 12433, 79184, 79192, 12425, 79919, 79943, 79944, 12690, 79922, 79946, 79947, 
12692, 12693, 79920, 79945, 12676
28605, 12433, 79184, 79192, 12425, 12434, 79185, 79193, 12426, 79922, 79946, 79947, 12692, 79925, 79949, 79950, 
12694, 12695, 79923, 79948, 12678
28606, 12434, 79185, 79193, 12426, 12435, 79186, 79194, 12427, 79925, 79949, 79950, 12694, 79928, 79952, 79953, 
12696, 12697, 79926, 79951, 12680
28607, 12435, 79186, 79194, 12427, 12436, 79187, 79195, 12428, 79928, 79952, 79953, 12696, 79931, 79955, 79956, 
12698, 12699, 79929, 79954, 12682
28608, 12436, 79187, 79195, 12428, 12437, 79188, 79196, 12429, 79931, 79955, 79956, 12698, 79934, 79958, 79959, 
12700, 12701, 79932, 79957, 12684
28609, 12437, 79188, 79196, 12429, 12438, 79189, 79197, 12430, 79934, 79958, 79959, 12700, 79937, 79961, 79962, 
12702, 12703, 79935, 79960, 12686
28610, 12438, 79189, 79197, 12430, 1609, 13737, 13738, 1608, 79937, 79961, 79962, 12702, 13816, 13817, 13818, 
1631, 12704, 79938, 79963, 12687
28611, 1474, 13515, 13516, 1473, 12423, 79190, 79198, 12415, 13594, 13597, 13596, 1496, 79941, 79965, 79966, 
12671, 12672, 79939, 79964, 12655
28612, 12423, 79190, 79198, 12415, 12424, 79191, 79199, 12416, 79941, 79965, 79966, 12671, 79944, 79968, 79969, 
12673, 12674, 79942, 79967, 12657
28613, 12424, 79191, 79199, 12416, 12425, 79192, 79200, 12417, 79944, 79968, 79969, 12673, 79947, 79971, 79972, 
12675, 12676, 79945, 79970, 12659
28614, 12425, 79192, 79200, 12417, 12426, 79193, 79201, 12418, 79947, 79971, 79972, 12675, 79950, 79974, 79975, 
12677, 12678, 79948, 79973, 12661
28615, 12426, 79193, 79201, 12418, 12427, 79194, 79202, 12419, 79950, 79974, 79975, 12677, 79953, 79977, 79978, 
12679, 12680, 79951, 79976, 12663
28616, 12427, 79194, 79202, 12419, 12428, 79195, 79203, 12420, 79953, 79977, 79978, 12679, 79956, 79980, 79981, 
12681, 12682, 79954, 79979, 12665
28617, 12428, 79195, 79203, 12420, 12429, 79196, 79204, 12421, 79956, 79980, 79981, 12681, 79959, 79983, 79984, 
12683, 12684, 79957, 79982, 12667
28618, 12429, 79196, 79204, 12421, 12430, 79197, 79205, 12422, 79959, 79983, 79984, 12683, 79962, 79986, 79987, 
12685, 12686, 79960, 79985, 12669
28619, 12430, 79197, 79205, 12422, 1608, 13738, 13739, 1607, 79962, 79986, 79987, 12685, 13818, 13819, 13820, 
1630, 12687, 79963, 79988, 12670
28620, 1473, 13516, 13517, 1472, 12415, 79198, 79206, 12407, 13596, 13599, 13598, 1495, 79966, 79990, 79991, 
12654, 12655, 79964, 79989, 12638
28621, 12415, 79198, 79206, 12407, 12416, 79199, 79207, 12408, 79966, 79990, 79991, 12654, 79969, 79993, 79994, 
12656, 12657, 79967, 79992, 12640
28622, 12416, 79199, 79207, 12408, 12417, 79200, 79208, 12409, 79969, 79993, 79994, 12656, 79972, 79996, 79997, 
12658, 12659, 79970, 79995, 12642
28623, 12417, 79200, 79208, 12409, 12418, 79201, 79209, 12410, 79972, 79996, 79997, 12658, 79975, 79999, 80000, 
12660, 12661, 79973, 79998, 12644
28624, 12418, 79201, 79209, 12410, 12419, 79202, 79210, 12411, 79975, 79999, 80000, 12660, 79978, 80002, 80003, 
12662, 12663, 79976, 80001, 12646
28625, 12419, 79202, 79210, 12411, 12420, 79203, 79211, 12412, 79978, 80002, 80003, 12662, 79981, 80005, 80006, 
12664, 12665, 79979, 80004, 12648
28626, 12420, 79203, 79211, 12412, 12421, 79204, 79212, 12413, 79981, 80005, 80006, 12664, 79984, 80008, 80009, 
12666, 12667, 79982, 80007, 12650
28627, 12421, 79204, 79212, 12413, 12422, 79205, 79213, 12414, 79984, 80008, 80009, 12666, 79987, 80011, 80012, 
12668, 12669, 79985, 80010, 12652
28628, 12422, 79205, 79213, 12414, 1607, 13739, 13740, 1606, 79987, 80011, 80012, 12668, 13820, 13821, 13822, 
1629, 12670, 79988, 80013, 12653
28629, 1472, 13517, 13518, 1471, 12407, 79206, 79214, 12399, 13598, 13601, 13600, 1494, 79991, 80015, 80016, 
12637, 12638, 79989, 80014, 12621
28630, 12407, 79206, 79214, 12399, 12408, 79207, 79215, 12400, 79991, 80015, 80016, 12637, 79994, 80018, 80019, 
12639, 12640, 79992, 80017, 12623
28631, 12408, 79207, 79215, 12400, 12409, 79208, 79216, 12401, 79994, 80018, 80019, 12639, 79997, 80021, 80022, 
12641, 12642, 79995, 80020, 12625
28632, 12409, 79208, 79216, 12401, 12410, 79209, 79217, 12402, 79997, 80021, 80022, 12641, 80000, 80024, 80025, 
12643, 12644, 79998, 80023, 12627
28633, 12410, 79209, 79217, 12402, 12411, 79210, 79218, 12403, 80000, 80024, 80025, 12643, 80003, 80027, 80028, 
12645, 12646, 80001, 80026, 12629
28634, 12411, 79210, 79218, 12403, 12412, 79211, 79219, 12404, 80003, 80027, 80028, 12645, 80006, 80030, 80031, 
12647, 12648, 80004, 80029, 12631
28635, 12412, 79211, 79219, 12404, 12413, 79212, 79220, 12405, 80006, 80030, 80031, 12647, 80009, 80033, 80034, 
12649, 12650, 80007, 80032, 12633
28636, 12413, 79212, 79220, 12405, 12414, 79213, 79221, 12406, 80009, 80033, 80034, 12649, 80012, 80036, 80037, 
12651, 12652, 80010, 80035, 12635
28637, 12414, 79213, 79221, 12406, 1606, 13740, 13741, 1605, 80012, 80036, 80037, 12651, 13822, 13823, 13824, 
1628, 12653, 80013, 80038, 12636
28638, 1471, 13518, 13519, 1470, 12399, 79214, 79222, 12391, 13600, 13603, 13602, 1493, 80016, 80040, 80041, 
12620, 12621, 80014, 80039, 12604
28639, 12399, 79214, 79222, 12391, 12400, 79215, 79223, 12392, 80016, 80040, 80041, 12620, 80019, 80043, 80044, 
12622, 12623, 80017, 80042, 12606
28640, 12400, 79215, 79223, 12392, 12401, 79216, 79224, 12393, 80019, 80043, 80044, 12622, 80022, 80046, 80047, 
12624, 12625, 80020, 80045, 12608
28641, 12401, 79216, 79224, 12393, 12402, 79217, 79225, 12394, 80022, 80046, 80047, 12624, 80025, 80049, 80050, 
12626, 12627, 80023, 80048, 12610
28642, 12402, 79217, 79225, 12394, 12403, 79218, 79226, 12395, 80025, 80049, 80050, 12626, 80028, 80052, 80053, 
12628, 12629, 80026, 80051, 12612
28643, 12403, 79218, 79226, 12395, 12404, 79219, 79227, 12396, 80028, 80052, 80053, 12628, 80031, 80055, 80056, 
12630, 12631, 80029, 80054, 12614
28644, 12404, 79219, 79227, 12396, 12405, 79220, 79228, 12397, 80031, 80055, 80056, 12630, 80034, 80058, 80059, 
12632, 12633, 80032, 80057, 12616
28645, 12405, 79220, 79228, 12397, 12406, 79221, 79229, 12398, 80034, 80058, 80059, 12632, 80037, 80061, 80062, 
12634, 12635, 80035, 80060, 12618
28646, 12406, 79221, 79229, 12398, 1605, 13741, 13742, 1604, 80037, 80061, 80062, 12634, 13824, 13825, 13826, 
1627, 12636, 80038, 80063, 12619
28647, 1470, 13519, 13520, 1469, 12391, 79222, 79230, 12383, 13602, 13605, 13604, 1492, 80041, 80065, 80066, 
12603, 12604, 80039, 80064, 12587
28648, 12391, 79222, 79230, 12383, 12392, 79223, 79231, 12384, 80041, 80065, 80066, 12603, 80044, 80068, 80069, 
12605, 12606, 80042, 80067, 12589
28649, 12392, 79223, 79231, 12384, 12393, 79224, 79232, 12385, 80044, 80068, 80069, 12605, 80047, 80071, 80072, 
12607, 12608, 80045, 80070, 12591
28650, 12393, 79224, 79232, 12385, 12394, 79225, 79233, 12386, 80047, 80071, 80072, 12607, 80050, 80074, 80075, 
12609, 12610, 80048, 80073, 12593
28651, 12394, 79225, 79233, 12386, 12395, 79226, 79234, 12387, 80050, 80074, 80075, 12609, 80053, 80077, 80078, 
12611, 12612, 80051, 80076, 12595
28652, 12395, 79226, 79234, 12387, 12396, 79227, 79235, 12388, 80053, 80077, 80078, 12611, 80056, 80080, 80081, 
12613, 12614, 80054, 80079, 12597
28653, 12396, 79227, 79235, 12388, 12397, 79228, 79236, 12389, 80056, 80080, 80081, 12613, 80059, 80083, 80084, 
12615, 12616, 80057, 80082, 12599
28654, 12397, 79228, 79236, 12389, 12398, 79229, 79237, 12390, 80059, 80083, 80084, 12615, 80062, 80086, 80087, 
12617, 12618, 80060, 80085, 12601
28655, 12398, 79229, 79237, 12390, 1604, 13742, 13743, 1603, 80062, 80086, 80087, 12617, 13826, 13827, 13828, 
1626, 12619, 80063, 80088, 12602
28656, 1469, 13520, 13521, 1468, 12383, 79230, 79238, 12375, 13604, 13607, 13606, 1491, 80066, 80090, 80091, 
12586, 12587, 80064, 80089, 12570
28657, 12383, 79230, 79238, 12375, 12384, 79231, 79239, 12376, 80066, 80090, 80091, 12586, 80069, 80093, 80094, 
12588, 12589, 80067, 80092, 12572
28658, 12384, 79231, 79239, 12376, 12385, 79232, 79240, 12377, 80069, 80093, 80094, 12588, 80072, 80096, 80097, 
12590, 12591, 80070, 80095, 12574
28659, 12385, 79232, 79240, 12377, 12386, 79233, 79241, 12378, 80072, 80096, 80097, 12590, 80075, 80099, 80100, 
12592, 12593, 80073, 80098, 12576
28660, 12386, 79233, 79241, 12378, 12387, 79234, 79242, 12379, 80075, 80099, 80100, 12592, 80078, 80102, 80103, 
12594, 12595, 80076, 80101, 12578
28661, 12387, 79234, 79242, 12379, 12388, 79235, 79243, 12380, 80078, 80102, 80103, 12594, 80081, 80105, 80106, 
12596, 12597, 80079, 80104, 12580
28662, 12388, 79235, 79243, 12380, 12389, 79236, 79244, 12381, 80081, 80105, 80106, 12596, 80084, 80108, 80109, 
12598, 12599, 80082, 80107, 12582
28663, 12389, 79236, 79244, 12381, 12390, 79237, 79245, 12382, 80084, 80108, 80109, 12598, 80087, 80111, 80112, 
12600, 12601, 80085, 80110, 12584
28664, 12390, 79237, 79245, 12382, 1603, 13743, 13744, 1602, 80087, 80111, 80112, 12600, 13828, 13829, 13830, 
1625, 12602, 80088, 80113, 12585
28665, 1468, 13521, 13522, 1467, 12375, 79238, 79246, 12367, 13606, 13609, 13608, 1490, 80091, 80115, 80116, 
12569, 12570, 80089, 80114, 12553
28666, 12375, 79238, 79246, 12367, 12376, 79239, 79247, 12368, 80091, 80115, 80116, 12569, 80094, 80118, 80119, 
12571, 12572, 80092, 80117, 12555
28667, 12376, 79239, 79247, 12368, 12377, 79240, 79248, 12369, 80094, 80118, 80119, 12571, 80097, 80121, 80122, 
12573, 12574, 80095, 80120, 12557
28668, 12377, 79240, 79248, 12369, 12378, 79241, 79249, 12370, 80097, 80121, 80122, 12573, 80100, 80124, 80125, 
12575, 12576, 80098, 80123, 12559
28669, 12378, 79241, 79249, 12370, 12379, 79242, 79250, 12371, 80100, 80124, 80125, 12575, 80103, 80127, 80128, 
12577, 12578, 80101, 80126, 12561
28670, 12379, 79242, 79250, 12371, 12380, 79243, 79251, 12372, 80103, 80127, 80128, 12577, 80106, 80130, 80131, 
12579, 12580, 80104, 80129, 12563
28671, 12380, 79243, 79251, 12372, 12381, 79244, 79252, 12373, 80106, 80130, 80131, 12579, 80109, 80133, 80134, 
12581, 12582, 80107, 80132, 12565
28672, 12381, 79244, 79252, 12373, 12382, 79245, 79253, 12374, 80109, 80133, 80134, 12581, 80112, 80136, 80137, 
12583, 12584, 80110, 80135, 12567
28673, 12382, 79245, 79253, 12374, 1602, 13744, 13745, 1601, 80112, 80136, 80137, 12583, 13830, 13831, 13832, 
1624, 12585, 80113, 80138, 12568
28674, 1467, 13522, 13523, 1466, 12367, 79246, 79254, 12359, 13608, 13611, 13610, 1489, 80116, 80140, 80141, 
12552, 12553, 80114, 80139, 12536
28675, 12367, 79246, 79254, 12359, 12368, 79247, 79255, 12360, 80116, 80140, 80141, 12552, 80119, 80143, 80144, 
12554, 12555, 80117, 80142, 12538
28676, 12368, 79247, 79255, 12360, 12369, 79248, 79256, 12361, 80119, 80143, 80144, 12554, 80122, 80146, 80147, 
12556, 12557, 80120, 80145, 12540
28677, 12369, 79248, 79256, 12361, 12370, 79249, 79257, 12362, 80122, 80146, 80147, 12556, 80125, 80149, 80150, 
12558, 12559, 80123, 80148, 12542
28678, 12370, 79249, 79257, 12362, 12371, 79250, 79258, 12363, 80125, 80149, 80150, 12558, 80128, 80152, 80153, 
12560, 12561, 80126, 80151, 12544
28679, 12371, 79250, 79258, 12363, 12372, 79251, 79259, 12364, 80128, 80152, 80153, 12560, 80131, 80155, 80156, 
12562, 12563, 80129, 80154, 12546
28680, 12372, 79251, 79259, 12364, 12373, 79252, 79260, 12365, 80131, 80155, 80156, 12562, 80134, 80158, 80159, 
12564, 12565, 80132, 80157, 12548
28681, 12373, 79252, 79260, 12365, 12374, 79253, 79261, 12366, 80134, 80158, 80159, 12564, 80137, 80161, 80162, 
12566, 12567, 80135, 80160, 12550
28682, 12374, 79253, 79261, 12366, 1601, 13745, 13746, 1600, 80137, 80161, 80162, 12566, 13832, 13833, 13834, 
1623, 12568, 80138, 80163, 12551
28683, 1466, 13523, 1827, 48, 12359, 79254, 13955, 1662, 13610, 13612, 1830, 1488, 80141, 80164, 13987, 
12535, 12536, 80139, 13988, 1670
28684, 12359, 79254, 13955, 1662, 12360, 79255, 13954, 1663, 80141, 80164, 13987, 12535, 80144, 80165, 13985, 
12537, 12538, 80142, 13986, 1671
28685, 12360, 79255, 13954, 1663, 12361, 79256, 13953, 1664, 80144, 80165, 13985, 12537, 80147, 80166, 13983, 
12539, 12540, 80145, 13984, 1672
28686, 12361, 79256, 13953, 1664, 12362, 79257, 13952, 1665, 80147, 80166, 13983, 12539, 80150, 80167, 13981, 
12541, 12542, 80148, 13982, 1673
28687, 12362, 79257, 13952, 1665, 12363, 79258, 13951, 1666, 80150, 80167, 13981, 12541, 80153, 80168, 13979, 
12543, 12544, 80151, 13980, 1674
28688, 12363, 79258, 13951, 1666, 12364, 79259, 13950, 1667, 80153, 80168, 13979, 12543, 80156, 80169, 13977, 
12545, 12546, 80154, 13978, 1675
28689, 12364, 79259, 13950, 1667, 12365, 79260, 13949, 1668, 80156, 80169, 13977, 12545, 80159, 80170, 13975, 
12547, 12548, 80157, 13976, 1676
28690, 12365, 79260, 13949, 1668, 12366, 79261, 13948, 1669, 80159, 80170, 13975, 12547, 80162, 80171, 13973, 
12549, 12550, 80160, 13974, 1677
28691, 12366, 79261, 13948, 1669, 1600, 13746, 1879, 52, 80162, 80171, 13973, 12549, 13834, 13835, 1882, 
1622, 12551, 80163, 13972, 1678
28692, 1772, 1773, 13524, 13502, 13260, 13268, 79262, 79086, 1776, 13614, 13613, 13569, 13309, 80173, 80174, 
79615, 13293, 13310, 80172, 79614
28693, 13260, 13268, 79262, 79086, 13259, 13267, 79263, 79087, 13309, 80173, 80174, 79615, 13307, 80176, 80177, 
79618, 13291, 13308, 80175, 79617
28694, 13259, 13267, 79263, 79087, 13258, 13266, 79264, 79088, 13307, 80176, 80177, 79618, 13305, 80179, 80180, 
79621, 13289, 13306, 80178, 79620
28695, 13258, 13266, 79264, 79088, 13257, 13265, 79265, 79089, 13305, 80179, 80180, 79621, 13303, 80182, 80183, 
79624, 13287, 13304, 80181, 79623
28696, 13257, 13265, 79265, 79089, 13256, 13264, 79266, 79090, 13303, 80182, 80183, 79624, 13301, 80185, 80186, 
79627, 13285, 13302, 80184, 79626
28697, 13256, 13264, 79266, 79090, 13255, 13263, 79267, 79091, 13301, 80185, 80186, 79627, 13299, 80188, 80189, 
79630, 13283, 13300, 80187, 79629
28698, 13255, 13263, 79267, 79091, 13254, 13262, 79268, 79092, 13299, 80188, 80189, 79630, 13297, 80191, 80192, 
79633, 13281, 13298, 80190, 79632
28699, 13254, 13262, 79268, 79092, 13253, 13261, 79269, 79093, 13297, 80191, 80192, 79633, 13295, 80194, 80195, 
79636, 13279, 13296, 80193, 79635
28700, 13253, 13261, 79269, 79093, 1751, 1752, 13747, 13725, 13295, 80194, 80195, 79636, 1755, 13836, 13837, 
13791, 13277, 13294, 80196, 79638
28701, 13502, 13524, 13525, 13503, 79086, 79262, 79270, 79094, 13613, 13616, 13615, 13571, 80174, 80198, 80199, 
79640, 79614, 80172, 80197, 79639
28702, 79086, 79262, 79270, 79094, 79087, 79263, 79271, 79095, 80174, 80198, 80199, 79640, 80177, 80201, 80202, 
79643, 79617, 80175, 80200, 79642
28703, 79087, 79263, 79271, 79095, 79088, 79264, 79272, 79096, 80177, 80201, 80202, 79643, 80180, 80204, 80205, 
79646, 79620, 80178, 80203, 79645
28704, 79088, 79264, 79272, 79096, 79089, 79265, 79273, 79097, 80180, 80204, 80205, 79646, 80183, 80207, 80208, 
79649, 79623, 80181, 80206, 79648
28705, 79089, 79265, 79273, 79097, 79090, 79266, 79274, 79098, 80183, 80207, 80208, 79649, 80186, 80210, 80211, 
79652, 79626, 80184, 80209, 79651
28706, 79090, 79266, 79274, 79098, 79091, 79267, 79275, 79099, 80186, 80210, 80211, 79652, 80189, 80213, 80214, 
79655, 79629, 80187, 80212, 79654
28707, 79091, 79267, 79275, 79099, 79092, 79268, 79276, 79100, 80189, 80213, 80214, 79655, 80192, 80216, 80217, 
79658, 79632, 80190, 80215, 79657
28708, 79092, 79268, 79276, 79100, 79093, 79269, 79277, 79101, 80192, 80216, 80217, 79658, 80195, 80219, 80220, 
79661, 79635, 80193, 80218, 79660
28709, 79093, 79269, 79277, 79101, 13725, 13747, 13748, 13726, 80195, 80219, 80220, 79661, 13837, 13838, 13839, 
13793, 79638, 80196, 80221, 79663
28710, 13503, 13525, 13526, 13504, 79094, 79270, 79278, 79102, 13615, 13618, 13617, 13573, 80199, 80223, 80224, 
79665, 79639, 80197, 80222, 79664
28711, 79094, 79270, 79278, 79102, 79095, 79271, 79279, 79103, 80199, 80223, 80224, 79665, 80202, 80226, 80227, 
79668, 79642, 80200, 80225, 79667
28712, 79095, 79271, 79279, 79103, 79096, 79272, 79280, 79104, 80202, 80226, 80227, 79668, 80205, 80229, 80230, 
79671, 79645, 80203, 80228, 79670
28713, 79096, 79272, 79280, 79104, 79097, 79273, 79281, 79105, 80205, 80229, 80230, 79671, 80208, 80232, 80233, 
79674, 79648, 80206, 80231, 79673
28714, 79097, 79273, 79281, 79105, 79098, 79274, 79282, 79106, 80208, 80232, 80233, 79674, 80211, 80235, 80236, 
79677, 79651, 80209, 80234, 79676
28715, 79098, 79274, 79282, 79106, 79099, 79275, 79283, 79107, 80211, 80235, 80236, 79677, 80214, 80238, 80239, 
79680, 79654, 80212, 80237, 79679
28716, 79099, 79275, 79283, 79107, 79100, 79276, 79284, 79108, 80214, 80238, 80239, 79680, 80217, 80241, 80242, 
79683, 79657, 80215, 80240, 79682
28717, 79100, 79276, 79284, 79108, 79101, 79277, 79285, 79109, 80217, 80241, 80242, 79683, 80220, 80244, 80245, 
79686, 79660, 80218, 80243, 79685
28718, 79101, 79277, 79285, 79109, 13726, 13748, 13749, 13727, 80220, 80244, 80245, 79686, 13839, 13840, 13841, 
13795, 79663, 80221, 80246, 79688
28719, 13504, 13526, 13527, 13505, 79102, 79278, 79286, 79110, 13617, 13620, 13619, 13575, 80224, 80248, 80249, 
79690, 79664, 80222, 80247, 79689
28720, 79102, 79278, 79286, 79110, 79103, 79279, 79287, 79111, 80224, 80248, 80249, 79690, 80227, 80251, 80252, 
79693, 79667, 80225, 80250, 79692
28721, 79103, 79279, 79287, 79111, 79104, 79280, 79288, 79112, 80227, 80251, 80252, 79693, 80230, 80254, 80255, 
79696, 79670, 80228, 80253, 79695
28722, 79104, 79280, 79288, 79112, 79105, 79281, 79289, 79113, 80230, 80254, 80255, 79696, 80233, 80257, 80258, 
79699, 79673, 80231, 80256, 79698
28723, 79105, 79281, 79289, 79113, 79106, 79282, 79290, 79114, 80233, 80257, 80258, 79699, 80236, 80260, 80261, 
79702, 79676, 80234, 80259, 79701
28724, 79106, 79282, 79290, 79114, 79107, 79283, 79291, 79115, 80236, 80260, 80261, 79702, 80239, 80263, 80264, 
79705, 79679, 80237, 80262, 79704
28725, 79107, 79283, 79291, 79115, 79108, 79284, 79292, 79116, 80239, 80263, 80264, 79705, 80242, 80266, 80267, 
79708, 79682, 80240, 80265, 79707
28726, 79108, 79284, 79292, 79116, 79109, 79285, 79293, 79117, 80242, 80266, 80267, 79708, 80245, 80269, 80270, 
79711, 79685, 80243, 80268, 79710
28727, 79109, 79285, 79293, 79117, 13727, 13749, 13750, 13728, 80245, 80269, 80270, 79711, 13841, 13842, 13843, 
13797, 79688, 80246, 80271, 79713
28728, 13505, 13527, 13528, 13506, 79110, 79286, 79294, 79118, 13619, 13622, 13621, 13577, 80249, 80273, 80274, 
79715, 79689, 80247, 80272, 79714
28729, 79110, 79286, 79294, 79118, 79111, 79287, 79295, 79119, 80249, 80273, 80274, 79715, 80252, 80276, 80277, 
79718, 79692, 80250, 80275, 79717
28730, 79111, 79287, 79295, 79119, 79112, 79288, 79296, 79120, 80252, 80276, 80277, 79718, 80255, 80279, 80280, 
79721, 79695, 80253, 80278, 79720
28731, 79112, 79288, 79296, 79120, 79113, 79289, 79297, 79121, 80255, 80279, 80280, 79721, 80258, 80282, 80283, 
79724, 79698, 80256, 80281, 79723
28732, 79113, 79289, 79297, 79121, 79114, 79290, 79298, 79122, 80258, 80282, 80283, 79724, 80261, 80285, 80286, 
79727, 79701, 80259, 80284, 79726
28733, 79114, 79290, 79298, 79122, 79115, 79291, 79299, 79123, 80261, 80285, 80286, 79727, 80264, 80288, 80289, 
79730, 79704, 80262, 80287, 79729
28734, 79115, 79291, 79299, 79123, 79116, 79292, 79300, 79124, 80264, 80288, 80289, 79730, 80267, 80291, 80292, 
79733, 79707, 80265, 80290, 79732
28735, 79116, 79292, 79300, 79124, 79117, 79293, 79301, 79125, 80267, 80291, 80292, 79733, 80270, 80294, 80295, 
79736, 79710, 80268, 80293, 79735
28736, 79117, 79293, 79301, 79125, 13728, 13750, 13751, 13729, 80270, 80294, 80295, 79736, 13843, 13844, 13845, 
13799, 79713, 80271, 80296, 79738
28737, 13506, 13528, 13529, 13507, 79118, 79294, 79302, 79126, 13621, 13624, 13623, 13579, 80274, 80298, 80299, 
79740, 79714, 80272, 80297, 79739
28738, 79118, 79294, 79302, 79126, 79119, 79295, 79303, 79127, 80274, 80298, 80299, 79740, 80277, 80301, 80302, 
79743, 79717, 80275, 80300, 79742
28739, 79119, 79295, 79303, 79127, 79120, 79296, 79304, 79128, 80277, 80301, 80302, 79743, 80280, 80304, 80305, 
79746, 79720, 80278, 80303, 79745
28740, 79120, 79296, 79304, 79128, 79121, 79297, 79305, 79129, 80280, 80304, 80305, 79746, 80283, 80307, 80308, 
79749, 79723, 80281, 80306, 79748
28741, 79121, 79297, 79305, 79129, 79122, 79298, 79306, 79130, 80283, 80307, 80308, 79749, 80286, 80310, 80311, 
79752, 79726, 80284, 80309, 79751
28742, 79122, 79298, 79306, 79130, 79123, 79299, 79307, 79131, 80286, 80310, 80311, 79752, 80289, 80313, 80314, 
79755, 79729, 80287, 80312, 79754
28743, 79123, 79299, 79307, 79131, 79124, 79300, 79308, 79132, 80289, 80313, 80314, 79755, 80292, 80316, 80317, 
79758, 79732, 80290, 80315, 79757
28744, 79124, 79300, 79308, 79132, 79125, 79301, 79309, 79133, 80292, 80316, 80317, 79758, 80295, 80319, 80320, 
79761, 79735, 80293, 80318, 79760
28745, 79125, 79301, 79309, 79133, 13729, 13751, 13752, 13730, 80295, 80319, 80320, 79761, 13845, 13846, 13847, 
13801, 79738, 80296, 80321, 79763
28746, 13507, 13529, 13530, 13508, 79126, 79302, 79310, 79134, 13623, 13626, 13625, 13581, 80299, 80323, 80324, 
79765, 79739, 80297, 80322, 79764
28747, 79126, 79302, 79310, 79134, 79127, 79303, 79311, 79135, 80299, 80323, 80324, 79765, 80302, 80326, 80327, 
79768, 79742, 80300, 80325, 79767
28748, 79127, 79303, 79311, 79135, 79128, 79304, 79312, 79136, 80302, 80326, 80327, 79768, 80305, 80329, 80330, 
79771, 79745, 80303, 80328, 79770
28749, 79128, 79304, 79312, 79136, 79129, 79305, 79313, 79137, 80305, 80329, 80330, 79771, 80308, 80332, 80333, 
79774, 79748, 80306, 80331, 79773
28750, 79129, 79305, 79313, 79137, 79130, 79306, 79314, 79138, 80308, 80332, 80333, 79774, 80311, 80335, 80336, 
79777, 79751, 80309, 80334, 79776
28751, 79130, 79306, 79314, 79138, 79131, 79307, 79315, 79139, 80311, 80335, 80336, 79777, 80314, 80338, 80339, 
79780, 79754, 80312, 80337, 79779
28752, 79131, 79307, 79315, 79139, 79132, 79308, 79316, 79140, 80314, 80338, 80339, 79780, 80317, 80341, 80342, 
79783, 79757, 80315, 80340, 79782
28753, 79132, 79308, 79316, 79140, 79133, 79309, 79317, 79141, 80317, 80341, 80342, 79783, 80320, 80344, 80345, 
79786, 79760, 80318, 80343, 79785
28754, 79133, 79309, 79317, 79141, 13730, 13752, 13753, 13731, 80320, 80344, 80345, 79786, 13847, 13848, 13849, 
13803, 79763, 80321, 80346, 79788
28755, 13508, 13530, 13531, 13509, 79134, 79310, 79318, 79142, 13625, 13628, 13627, 13583, 80324, 80348, 80349, 
79790, 79764, 80322, 80347, 79789
28756, 79134, 79310, 79318, 79142, 79135, 79311, 79319, 79143, 80324, 80348, 80349, 79790, 80327, 80351, 80352, 
79793, 79767, 80325, 80350, 79792
28757, 79135, 79311, 79319, 79143, 79136, 79312, 79320, 79144, 80327, 80351, 80352, 79793, 80330, 80354, 80355, 
79796, 79770, 80328, 80353, 79795
28758, 79136, 79312, 79320, 79144, 79137, 79313, 79321, 79145, 80330, 80354, 80355, 79796, 80333, 80357, 80358, 
79799, 79773, 80331, 80356, 79798
28759, 79137, 79313, 79321, 79145, 79138, 79314, 79322, 79146, 80333, 80357, 80358, 79799, 80336, 80360, 80361, 
79802, 79776, 80334, 80359, 79801
28760, 79138, 79314, 79322, 79146, 79139, 79315, 79323, 79147, 80336, 80360, 80361, 79802, 80339, 80363, 80364, 
79805, 79779, 80337, 80362, 79804
28761, 79139, 79315, 79323, 79147, 79140, 79316, 79324, 79148, 80339, 80363, 80364, 79805, 80342, 80366, 80367, 
79808, 79782, 80340, 80365, 79807
28762, 79140, 79316, 79324, 79148, 79141, 79317, 79325, 79149, 80342, 80366, 80367, 79808, 80345, 80369, 80370, 
79811, 79785, 80343, 80368, 79810
28763, 79141, 79317, 79325, 79149, 13731, 13753, 13754, 13732, 80345, 80369, 80370, 79811, 13849, 13850, 13851, 
13805, 79788, 80346, 80371, 79813
28764, 13509, 13531, 13532, 13510, 79142, 79318, 79326, 79150, 13627, 13630, 13629, 13585, 80349, 80373, 80374, 
79815, 79789, 80347, 80372, 79814
28765, 79142, 79318, 79326, 79150, 79143, 79319, 79327, 79151, 80349, 80373, 80374, 79815, 80352, 80376, 80377, 
79818, 79792, 80350, 80375, 79817
28766, 79143, 79319, 79327, 79151, 79144, 79320, 79328, 79152, 80352, 80376, 80377, 79818, 80355, 80379, 80380, 
79821, 79795, 80353, 80378, 79820
28767, 79144, 79320, 79328, 79152, 79145, 79321, 79329, 79153, 80355, 80379, 80380, 79821, 80358, 80382, 80383, 
79824, 79798, 80356, 80381, 79823
28768, 79145, 79321, 79329, 79153, 79146, 79322, 79330, 79154, 80358, 80382, 80383, 79824, 80361, 80385, 80386, 
79827, 79801, 80359, 80384, 79826
28769, 79146, 79322, 79330, 79154, 79147, 79323, 79331, 79155, 80361, 80385, 80386, 79827, 80364, 80388, 80389, 
79830, 79804, 80362, 80387, 79829
28770, 79147, 79323, 79331, 79155, 79148, 79324, 79332, 79156, 80364, 80388, 80389, 79830, 80367, 80391, 80392, 
79833, 79807, 80365, 80390, 79832
28771, 79148, 79324, 79332, 79156, 79149, 79325, 79333, 79157, 80367, 80391, 80392, 79833, 80370, 80394, 80395, 
79836, 79810, 80368, 80393, 79835
28772, 79149, 79325, 79333, 79157, 13732, 13754, 13755, 13733, 80370, 80394, 80395, 79836, 13851, 13852, 13853, 
13807, 79813, 80371, 80396, 79838
28773, 13510, 13532, 13533, 13511, 79150, 79326, 79334, 79158, 13629, 13632, 13631, 13587, 80374, 80398, 80399, 
79840, 79814, 80372, 80397, 79839
28774, 79150, 79326, 79334, 79158, 79151, 79327, 79335, 79159, 80374, 80398, 80399, 79840, 80377, 80401, 80402, 
79843, 79817, 80375, 80400, 79842
28775, 79151, 79327, 79335, 79159, 79152, 79328, 79336, 79160, 80377, 80401, 80402, 79843, 80380, 80404, 80405, 
79846, 79820, 80378, 80403, 79845
28776, 79152, 79328, 79336, 79160, 79153, 79329, 79337, 79161, 80380, 80404, 80405, 79846, 80383, 80407, 80408, 
79849, 79823, 80381, 80406, 79848
28777, 79153, 79329, 79337, 79161, 79154, 79330, 79338, 79162, 80383, 80407, 80408, 79849, 80386, 80410, 80411, 
79852, 79826, 80384, 80409, 79851
28778, 79154, 79330, 79338, 79162, 79155, 79331, 79339, 79163, 80386, 80410, 80411, 79852, 80389, 80413, 80414, 
79855, 79829, 80387, 80412, 79854
28779, 79155, 79331, 79339, 79163, 79156, 79332, 79340, 79164, 80389, 80413, 80414, 79855, 80392, 80416, 80417, 
79858, 79832, 80390, 80415, 79857
28780, 79156, 79332, 79340, 79164, 79157, 79333, 79341, 79165, 80392, 80416, 80417, 79858, 80395, 80419, 80420, 
79861, 79835, 80393, 80418, 79860
28781, 79157, 79333, 79341, 79165, 13733, 13755, 13756, 13734, 80395, 80419, 80420, 79861, 13853, 13854, 13855, 
13809, 79838, 80396, 80421, 79863
28782, 13511, 13533, 13534, 13512, 79158, 79334, 79342, 79166, 13631, 13634, 13633, 13589, 80399, 80423, 80424, 
79865, 79839, 80397, 80422, 79864
28783, 79158, 79334, 79342, 79166, 79159, 79335, 79343, 79167, 80399, 80423, 80424, 79865, 80402, 80426, 80427, 
79868, 79842, 80400, 80425, 79867
28784, 79159, 79335, 79343, 79167, 79160, 79336, 79344, 79168, 80402, 80426, 80427, 79868, 80405, 80429, 80430, 
79871, 79845, 80403, 80428, 79870
28785, 79160, 79336, 79344, 79168, 79161, 79337, 79345, 79169, 80405, 80429, 80430, 79871, 80408, 80432, 80433, 
79874, 79848, 80406, 80431, 79873
28786, 79161, 79337, 79345, 79169, 79162, 79338, 79346, 79170, 80408, 80432, 80433, 79874, 80411, 80435, 80436, 
79877, 79851, 80409, 80434, 79876
28787, 79162, 79338, 79346, 79170, 79163, 79339, 79347, 79171, 80411, 80435, 80436, 79877, 80414, 80438, 80439, 
79880, 79854, 80412, 80437, 79879
28788, 79163, 79339, 79347, 79171, 79164, 79340, 79348, 79172, 80414, 80438, 80439, 79880, 80417, 80441, 80442, 
79883, 79857, 80415, 80440, 79882
28789, 79164, 79340, 79348, 79172, 79165, 79341, 79349, 79173, 80417, 80441, 80442, 79883, 80420, 80444, 80445, 
79886, 79860, 80418, 80443, 79885
28790, 79165, 79341, 79349, 79173, 13734, 13756, 13757, 13735, 80420, 80444, 80445, 79886, 13855, 13856, 13857, 
13811, 79863, 80421, 80446, 79888
28791, 13512, 13534, 13535, 13513, 79166, 79342, 79350, 79174, 13633, 13636, 13635, 13591, 80424, 80448, 80449, 
79890, 79864, 80422, 80447, 79889
28792, 79166, 79342, 79350, 79174, 79167, 79343, 79351, 79175, 80424, 80448, 80449, 79890, 80427, 80451, 80452, 
79893, 79867, 80425, 80450, 79892
28793, 79167, 79343, 79351, 79175, 79168, 79344, 79352, 79176, 80427, 80451, 80452, 79893, 80430, 80454, 80455, 
79896, 79870, 80428, 80453, 79895
28794, 79168, 79344, 79352, 79176, 79169, 79345, 79353, 79177, 80430, 80454, 80455, 79896, 80433, 80457, 80458, 
79899, 79873, 80431, 80456, 79898
28795, 79169, 79345, 79353, 79177, 79170, 79346, 79354, 79178, 80433, 80457, 80458, 79899, 80436, 80460, 80461, 
79902, 79876, 80434, 80459, 79901
28796, 79170, 79346, 79354, 79178, 79171, 79347, 79355, 79179, 80436, 80460, 80461, 79902, 80439, 80463, 80464, 
79905, 79879, 80437, 80462, 79904
28797, 79171, 79347, 79355, 79179, 79172, 79348, 79356, 79180, 80439, 80463, 80464, 79905, 80442, 80466, 80467, 
79908, 79882, 80440, 80465, 79907
28798, 79172, 79348, 79356, 79180, 79173, 79349, 79357, 79181, 80442, 80466, 80467, 79908, 80445, 80469, 80470, 
79911, 79885, 80443, 80468, 79910
28799, 79173, 79349, 79357, 79181, 13735, 13757, 13758, 13736, 80445, 80469, 80470, 79911, 13857, 13858, 13859, 
13813, 79888, 80446, 80471, 79913
28800, 13513, 13535, 13536, 13514, 79174, 79350, 79358, 79182, 13635, 13638, 13637, 13593, 80449, 80473, 80474, 
79915, 79889, 80447, 80472, 79914
28801, 79174, 79350, 79358, 79182, 79175, 79351, 79359, 79183, 80449, 80473, 80474, 79915, 80452, 80476, 80477, 
79918, 79892, 80450, 80475, 79917
28802, 79175, 79351, 79359, 79183, 79176, 79352, 79360, 79184, 80452, 80476, 80477, 79918, 80455, 80479, 80480, 
79921, 79895, 80453, 80478, 79920
28803, 79176, 79352, 79360, 79184, 79177, 79353, 79361, 79185, 80455, 80479, 80480, 79921, 80458, 80482, 80483, 
79924, 79898, 80456, 80481, 79923
28804, 79177, 79353, 79361, 79185, 79178, 79354, 79362, 79186, 80458, 80482, 80483, 79924, 80461, 80485, 80486, 
79927, 79901, 80459, 80484, 79926
28805, 79178, 79354, 79362, 79186, 79179, 79355, 79363, 79187, 80461, 80485, 80486, 79927, 80464, 80488, 80489, 
79930, 79904, 80462, 80487, 79929
28806, 79179, 79355, 79363, 79187, 79180, 79356, 79364, 79188, 80464, 80488, 80489, 79930, 80467, 80491, 80492, 
79933, 79907, 80465, 80490, 79932
28807, 79180, 79356, 79364, 79188, 79181, 79357, 79365, 79189, 80467, 80491, 80492, 79933, 80470, 80494, 80495, 
79936, 79910, 80468, 80493, 79935
28808, 79181, 79357, 79365, 79189, 13736, 13758, 13759, 13737, 80470, 80494, 80495, 79936, 13859, 13860, 13861, 
13815, 79913, 80471, 80496, 79938
28809, 13514, 13536, 13537, 13515, 79182, 79358, 79366, 79190, 13637, 13640, 13639, 13595, 80474, 80498, 80499, 
79940, 79914, 80472, 80497, 79939
28810, 79182, 79358, 79366, 79190, 79183, 79359, 79367, 79191, 80474, 80498, 80499, 79940, 80477, 80501, 80502, 
79943, 79917, 80475, 80500, 79942
28811, 79183, 79359, 79367, 79191, 79184, 79360, 79368, 79192, 80477, 80501, 80502, 79943, 80480, 80504, 80505, 
79946, 79920, 80478, 80503, 79945
28812, 79184, 79360, 79368, 79192, 79185, 79361, 79369, 79193, 80480, 80504, 80505, 79946, 80483, 80507, 80508, 
79949, 79923, 80481, 80506, 79948
28813, 79185, 79361, 79369, 79193, 79186, 79362, 79370, 79194, 80483, 80507, 80508, 79949, 80486, 80510, 80511, 
79952, 79926, 80484, 80509, 79951
28814, 79186, 79362, 79370, 79194, 79187, 79363, 79371, 79195, 80486, 80510, 80511, 79952, 80489, 80513, 80514, 
79955, 79929, 80487, 80512, 79954
28815, 79187, 79363, 79371, 79195, 79188, 79364, 79372, 79196, 80489, 80513, 80514, 79955, 80492, 80516, 80517, 
79958, 79932, 80490, 80515, 79957
28816, 79188, 79364, 79372, 79196, 79189, 79365, 79373, 79197, 80492, 80516, 80517, 79958, 80495, 80519, 80520, 
79961, 79935, 80493, 80518, 79960
28817, 79189, 79365, 79373, 79197, 13737, 13759, 13760, 13738, 80495, 80519, 80520, 79961, 13861, 13862, 13863, 
13817, 79938, 80496, 80521, 79963
28818, 13515, 13537, 13538, 13516, 79190, 79366, 79374, 79198, 13639, 13642, 13641, 13597, 80499, 80523, 80524, 
79965, 79939, 80497, 80522, 79964
28819, 79190, 79366, 79374, 79198, 79191, 79367, 79375, 79199, 80499, 80523, 80524, 79965, 80502, 80526, 80527, 
79968, 79942, 80500, 80525, 79967
28820, 79191, 79367, 79375, 79199, 79192, 79368, 79376, 79200, 80502, 80526, 80527, 79968, 80505, 80529, 80530, 
79971, 79945, 80503, 80528, 79970
28821, 79192, 79368, 79376, 79200, 79193, 79369, 79377, 79201, 80505, 80529, 80530, 79971, 80508, 80532, 80533, 
79974, 79948, 80506, 80531, 79973
28822, 79193, 79369, 79377, 79201, 79194, 79370, 79378, 79202, 80508, 80532, 80533, 79974, 80511, 80535, 80536, 
79977, 79951, 80509, 80534, 79976
28823, 79194, 79370, 79378, 79202, 79195, 79371, 79379, 79203, 80511, 80535, 80536, 79977, 80514, 80538, 80539, 
79980, 79954, 80512, 80537, 79979
28824, 79195, 79371, 79379, 79203, 79196, 79372, 79380, 79204, 80514, 80538, 80539, 79980, 80517, 80541, 80542, 
79983, 79957, 80515, 80540, 79982
28825, 79196, 79372, 79380, 79204, 79197, 79373, 79381, 79205, 80517, 80541, 80542, 79983, 80520, 80544, 80545, 
79986, 79960, 80518, 80543, 79985
28826, 79197, 79373, 79381, 79205, 13738, 13760, 13761, 13739, 80520, 80544, 80545, 79986, 13863, 13864, 13865, 
13819, 79963, 80521, 80546, 79988
28827, 13516, 13538, 13539, 13517, 79198, 79374, 79382, 79206, 13641, 13644, 13643, 13599, 80524, 80548, 80549, 
79990, 79964, 80522, 80547, 79989
28828, 79198, 79374, 79382, 79206, 79199, 79375, 79383, 79207, 80524, 80548, 80549, 79990, 80527, 80551, 80552, 
79993, 79967, 80525, 80550, 79992
28829, 79199, 79375, 79383, 79207, 79200, 79376, 79384, 79208, 80527, 80551, 80552, 79993, 80530, 80554, 80555, 
79996, 79970, 80528, 80553, 79995
28830, 79200, 79376, 79384, 79208, 79201, 79377, 79385, 79209, 80530, 80554, 80555, 79996, 80533, 80557, 80558, 
79999, 79973, 80531, 80556, 79998
28831, 79201, 79377, 79385, 79209, 79202, 79378, 79386, 79210, 80533, 80557, 80558, 79999, 80536, 80560, 80561, 
80002, 79976, 80534, 80559, 80001
28832, 79202, 79378, 79386, 79210, 79203, 79379, 79387, 79211, 80536, 80560, 80561, 80002, 80539, 80563, 80564, 
80005, 79979, 80537, 80562, 80004
28833, 79203, 79379, 79387, 79211, 79204, 79380, 79388, 79212, 80539, 80563, 80564, 80005, 80542, 80566, 80567, 
80008, 79982, 80540, 80565, 80007
28834, 79204, 79380, 79388, 79212, 79205, 79381, 79389, 79213, 80542, 80566, 80567, 80008, 80545, 80569, 80570, 
80011, 79985, 80543, 80568, 80010
28835, 79205, 79381, 79389, 79213, 13739, 13761, 13762, 13740, 80545, 80569, 80570, 80011, 13865, 13866, 13867, 
13821, 79988, 80546, 80571, 80013
28836, 13517, 13539, 13540, 13518, 79206, 79382, 79390, 79214, 13643, 13646, 13645, 13601, 80549, 80573, 80574, 
80015, 79989, 80547, 80572, 80014
28837, 79206, 79382, 79390, 79214, 79207, 79383, 79391, 79215, 80549, 80573, 80574, 80015, 80552, 80576, 80577, 
80018, 79992, 80550, 80575, 80017
28838, 79207, 79383, 79391, 79215, 79208, 79384, 79392, 79216, 80552, 80576, 80577, 80018, 80555, 80579, 80580, 
80021, 79995, 80553, 80578, 80020
28839, 79208, 79384, 79392, 79216, 79209, 79385, 79393, 79217, 80555, 80579, 80580, 80021, 80558, 80582, 80583, 
80024, 79998, 80556, 80581, 80023
28840, 79209, 79385, 79393, 79217, 79210, 79386, 79394, 79218, 80558, 80582, 80583, 80024, 80561, 80585, 80586, 
80027, 80001, 80559, 80584, 80026
28841, 79210, 79386, 79394, 79218, 79211, 79387, 79395, 79219, 80561, 80585, 80586, 80027, 80564, 80588, 80589, 
80030, 80004, 80562, 80587, 80029
28842, 79211, 79387, 79395, 79219, 79212, 79388, 79396, 79220, 80564, 80588, 80589, 80030, 80567, 80591, 80592, 
80033, 80007, 80565, 80590, 80032
28843, 79212, 79388, 79396, 79220, 79213, 79389, 79397, 79221, 80567, 80591, 80592, 80033, 80570, 80594, 80595, 
80036, 80010, 80568, 80593, 80035
28844, 79213, 79389, 79397, 79221, 13740, 13762, 13763, 13741, 80570, 80594, 80595, 80036, 13867, 13868, 13869, 
13823, 80013, 80571, 80596, 80038
28845, 13518, 13540, 13541, 13519, 79214, 79390, 79398, 79222, 13645, 13648, 13647, 13603, 80574, 80598, 80599, 
80040, 80014, 80572, 80597, 80039
28846, 79214, 79390, 79398, 79222, 79215, 79391, 79399, 79223, 80574, 80598, 80599, 80040, 80577, 80601, 80602, 
80043, 80017, 80575, 80600, 80042
28847, 79215, 79391, 79399, 79223, 79216, 79392, 79400, 79224, 80577, 80601, 80602, 80043, 80580, 80604, 80605, 
80046, 80020, 80578, 80603, 80045
28848, 79216, 79392, 79400, 79224, 79217, 79393, 79401, 79225, 80580, 80604, 80605, 80046, 80583, 80607, 80608, 
80049, 80023, 80581, 80606, 80048
28849, 79217, 79393, 79401, 79225, 79218, 79394, 79402, 79226, 80583, 80607, 80608, 80049, 80586, 80610, 80611, 
80052, 80026, 80584, 80609, 80051
28850, 79218, 79394, 79402, 79226, 79219, 79395, 79403, 79227, 80586, 80610, 80611, 80052, 80589, 80613, 80614, 
80055, 80029, 80587, 80612, 80054
28851, 79219, 79395, 79403, 79227, 79220, 79396, 79404, 79228, 80589, 80613, 80614, 80055, 80592, 80616, 80617, 
80058, 80032, 80590, 80615, 80057
28852, 79220, 79396, 79404, 79228, 79221, 79397, 79405, 79229, 80592, 80616, 80617, 80058, 80595, 80619, 80620, 
80061, 80035, 80593, 80618, 80060
28853, 79221, 79397, 79405, 79229, 13741, 13763, 13764, 13742, 80595, 80619, 80620, 80061, 13869, 13870, 13871, 
13825, 80038, 80596, 80621, 80063
28854, 13519, 13541, 13542, 13520, 79222, 79398, 79406, 79230, 13647, 13650, 13649, 13605, 80599, 80623, 80624, 
80065, 80039, 80597, 80622, 80064
28855, 79222, 79398, 79406, 79230, 79223, 79399, 79407, 79231, 80599, 80623, 80624, 80065, 80602, 80626, 80627, 
80068, 80042, 80600, 80625, 80067
28856, 79223, 79399, 79407, 79231, 79224, 79400, 79408, 79232, 80602, 80626, 80627, 80068, 80605, 80629, 80630, 
80071, 80045, 80603, 80628, 80070
28857, 79224, 79400, 79408, 79232, 79225, 79401, 79409, 79233, 80605, 80629, 80630, 80071, 80608, 80632, 80633, 
80074, 80048, 80606, 80631, 80073
28858, 79225, 79401, 79409, 79233, 79226, 79402, 79410, 79234, 80608, 80632, 80633, 80074, 80611, 80635, 80636, 
80077, 80051, 80609, 80634, 80076
28859, 79226, 79402, 79410, 79234, 79227, 79403, 79411, 79235, 80611, 80635, 80636, 80077, 80614, 80638, 80639, 
80080, 80054, 80612, 80637, 80079
28860, 79227, 79403, 79411, 79235, 79228, 79404, 79412, 79236, 80614, 80638, 80639, 80080, 80617, 80641, 80642, 
80083, 80057, 80615, 80640, 80082
28861, 79228, 79404, 79412, 79236, 79229, 79405, 79413, 79237, 80617, 80641, 80642, 80083, 80620, 80644, 80645, 
80086, 80060, 80618, 80643, 80085
28862, 79229, 79405, 79413, 79237, 13742, 13764, 13765, 13743, 80620, 80644, 80645, 80086, 13871, 13872, 13873, 
13827, 80063, 80621, 80646, 80088
28863, 13520, 13542, 13543, 13521, 79230, 79406, 79414, 79238, 13649, 13652, 13651, 13607, 80624, 80648, 80649, 
80090, 80064, 80622, 80647, 80089
28864, 79230, 79406, 79414, 79238, 79231, 79407, 79415, 79239, 80624, 80648, 80649, 80090, 80627, 80651, 80652, 
80093, 80067, 80625, 80650, 80092
28865, 79231, 79407, 79415, 79239, 79232, 79408, 79416, 79240, 80627, 80651, 80652, 80093, 80630, 80654, 80655, 
80096, 80070, 80628, 80653, 80095
28866, 79232, 79408, 79416, 79240, 79233, 79409, 79417, 79241, 80630, 80654, 80655, 80096, 80633, 80657, 80658, 
80099, 80073, 80631, 80656, 80098
28867, 79233, 79409, 79417, 79241, 79234, 79410, 79418, 79242, 80633, 80657, 80658, 80099, 80636, 80660, 80661, 
80102, 80076, 80634, 80659, 80101
28868, 79234, 79410, 79418, 79242, 79235, 79411, 79419, 79243, 80636, 80660, 80661, 80102, 80639, 80663, 80664, 
80105, 80079, 80637, 80662, 80104
28869, 79235, 79411, 79419, 79243, 79236, 79412, 79420, 79244, 80639, 80663, 80664, 80105, 80642, 80666, 80667, 
80108, 80082, 80640, 80665, 80107
28870, 79236, 79412, 79420, 79244, 79237, 79413, 79421, 79245, 80642, 80666, 80667, 80108, 80645, 80669, 80670, 
80111, 80085, 80643, 80668, 80110
28871, 79237, 79413, 79421, 79245, 13743, 13765, 13766, 13744, 80645, 80669, 80670, 80111, 13873, 13874, 13875, 
13829, 80088, 80646, 80671, 80113
28872, 13521, 13543, 13544, 13522, 79238, 79414, 79422, 79246, 13651, 13654, 13653, 13609, 80649, 80673, 80674, 
80115, 80089, 80647, 80672, 80114
28873, 79238, 79414, 79422, 79246, 79239, 79415, 79423, 79247, 80649, 80673, 80674, 80115, 80652, 80676, 80677, 
80118, 80092, 80650, 80675, 80117
28874, 79239, 79415, 79423, 79247, 79240, 79416, 79424, 79248, 80652, 80676, 80677, 80118, 80655, 80679, 80680, 
80121, 80095, 80653, 80678, 80120
28875, 79240, 79416, 79424, 79248, 79241, 79417, 79425, 79249, 80655, 80679, 80680, 80121, 80658, 80682, 80683, 
80124, 80098, 80656, 80681, 80123
28876, 79241, 79417, 79425, 79249, 79242, 79418, 79426, 79250, 80658, 80682, 80683, 80124, 80661, 80685, 80686, 
80127, 80101, 80659, 80684, 80126
28877, 79242, 79418, 79426, 79250, 79243, 79419, 79427, 79251, 80661, 80685, 80686, 80127, 80664, 80688, 80689, 
80130, 80104, 80662, 80687, 80129
28878, 79243, 79419, 79427, 79251, 79244, 79420, 79428, 79252, 80664, 80688, 80689, 80130, 80667, 80691, 80692, 
80133, 80107, 80665, 80690, 80132
28879, 79244, 79420, 79428, 79252, 79245, 79421, 79429, 79253, 80667, 80691, 80692, 80133, 80670, 80694, 80695, 
80136, 80110, 80668, 80693, 80135
28880, 79245, 79421, 79429, 79253, 13744, 13766, 13767, 13745, 80670, 80694, 80695, 80136, 13875, 13876, 13877, 
13831, 80113, 80671, 80696, 80138
28881, 13522, 13544, 13545, 13523, 79246, 79422, 79430, 79254, 13653, 13656, 13655, 13611, 80674, 80698, 80699, 
80140, 80114, 80672, 80697, 80139
28882, 79246, 79422, 79430, 79254, 79247, 79423, 79431, 79255, 80674, 80698, 80699, 80140, 80677, 80701, 80702, 
80143, 80117, 80675, 80700, 80142
28883, 79247, 79423, 79431, 79255, 79248, 79424, 79432, 79256, 80677, 80701, 80702, 80143, 80680, 80704, 80705, 
80146, 80120, 80678, 80703, 80145
28884, 79248, 79424, 79432, 79256, 79249, 79425, 79433, 79257, 80680, 80704, 80705, 80146, 80683, 80707, 80708, 
80149, 80123, 80681, 80706, 80148
28885, 79249, 79425, 79433, 79257, 79250, 79426, 79434, 79258, 80683, 80707, 80708, 80149, 80686, 80710, 80711, 
80152, 80126, 80684, 80709, 80151
28886, 79250, 79426, 79434, 79258, 79251, 79427, 79435, 79259, 80686, 80710, 80711, 80152, 80689, 80713, 80714, 
80155, 80129, 80687, 80712, 80154
28887, 79251, 79427, 79435, 79259, 79252, 79428, 79436, 79260, 80689, 80713, 80714, 80155, 80692, 80716, 80717, 
80158, 80132, 80690, 80715, 80157
28888, 79252, 79428, 79436, 79260, 79253, 79429, 79437, 79261, 80692, 80716, 80717, 80158, 80695, 80719, 80720, 
80161, 80135, 80693, 80718, 80160
28889, 79253, 79429, 79437, 79261, 13745, 13767, 13768, 13746, 80695, 80719, 80720, 80161, 13877, 13878, 13879, 
13833, 80138, 80696, 80721, 80163
28890, 13523, 13545, 1828, 1827, 79254, 79430, 13963, 13955, 13655, 13657, 1831, 13612, 80699, 80722, 14004, 
80164, 80139, 80697, 14005, 13988
28891, 79254, 79430, 13963, 13955, 79255, 79431, 13962, 13954, 80699, 80722, 14004, 80164, 80702, 80723, 14002, 
80165, 80142, 80700, 14003, 13986
28892, 79255, 79431, 13962, 13954, 79256, 79432, 13961, 13953, 80702, 80723, 14002, 80165, 80705, 80724, 14000, 
80166, 80145, 80703, 14001, 13984
28893, 79256, 79432, 13961, 13953, 79257, 79433, 13960, 13952, 80705, 80724, 14000, 80166, 80708, 80725, 13998, 
80167, 80148, 80706, 13999, 13982
28894, 79257, 79433, 13960, 13952, 79258, 79434, 13959, 13951, 80708, 80725, 13998, 80167, 80711, 80726, 13996, 
80168, 80151, 80709, 13997, 13980
28895, 79258, 79434, 13959, 13951, 79259, 79435, 13958, 13950, 80711, 80726, 13996, 80168, 80714, 80727, 13994, 
80169, 80154, 80712, 13995, 13978
28896, 79259, 79435, 13958, 13950, 79260, 79436, 13957, 13949, 80714, 80727, 13994, 80169, 80717, 80728, 13992, 
80170, 80157, 80715, 13993, 13976
28897, 79260, 79436, 13957, 13949, 79261, 79437, 13956, 13948, 80717, 80728, 13992, 80170, 80720, 80729, 13990, 
80171, 80160, 80718, 13991, 13974
28898, 79261, 79437, 13956, 13948, 13746, 13768, 1880, 1879, 80720, 80729, 13990, 80171, 13879, 13880, 1883, 
13835, 80163, 80721, 13989, 13972
28899, 1773, 1774, 13546, 13524, 13268, 13276, 79438, 79262, 1777, 13659, 13658, 13614, 13326, 80731, 80732, 
80173, 13310, 13327, 80730, 80172
28900, 13268, 13276, 79438, 79262, 13267, 13275, 79439, 79263, 13326, 80731, 80732, 80173, 13324, 80734, 80735, 
80176, 13308, 13325, 80733, 80175
28901, 13267, 13275, 79439, 79263, 13266, 13274, 79440, 79264, 13324, 80734, 80735, 80176, 13322, 80737, 80738, 
80179, 13306, 13323, 80736, 80178
28902, 13266, 13274, 79440, 79264, 13265, 13273, 79441, 79265, 13322, 80737, 80738, 80179, 13320, 80740, 80741, 
80182, 13304, 13321, 80739, 80181
28903, 13265, 13273, 79441, 79265, 13264, 13272, 79442, 79266, 13320, 80740, 80741, 80182, 13318, 80743, 80744, 
80185, 13302, 13319, 80742, 80184
28904, 13264, 13272, 79442, 79266, 13263, 13271, 79443, 79267, 13318, 80743, 80744, 80185, 13316, 80746, 80747, 
80188, 13300, 13317, 80745, 80187
28905, 13263, 13271, 79443, 79267, 13262, 13270, 79444, 79268, 13316, 80746, 80747, 80188, 13314, 80749, 80750, 
80191, 13298, 13315, 80748, 80190
28906, 13262, 13270, 79444, 79268, 13261, 13269, 79445, 79269, 13314, 80749, 80750, 80191, 13312, 80752, 80753, 
80194, 13296, 13313, 80751, 80193
28907, 13261, 13269, 79445, 79269, 1752, 1753, 13769, 13747, 13312, 80752, 80753, 80194, 1756, 13881, 13882, 
13836, 13294, 13311, 80754, 80196
28908, 13524, 13546, 13547, 13525, 79262, 79438, 79446, 79270, 13658, 13661, 13660, 13616, 80732, 80756, 80757, 
80198, 80172, 80730, 80755, 80197
28909, 79262, 79438, 79446, 79270, 79263, 79439, 79447, 79271, 80732, 80756, 80757, 80198, 80735, 80759, 80760, 
80201, 80175, 80733, 80758, 80200
28910, 79263, 79439, 79447, 79271, 79264, 79440, 79448, 79272, 80735, 80759, 80760, 80201, 80738, 80762, 80763, 
80204, 80178, 80736, 80761, 80203
28911, 79264, 79440, 79448, 79272, 79265, 79441, 79449, 79273, 80738, 80762, 80763, 80204, 80741, 80765, 80766, 
80207, 80181, 80739, 80764, 80206
28912, 79265, 79441, 79449, 79273, 79266, 79442, 79450, 79274, 80741, 80765, 80766, 80207, 80744, 80768, 80769, 
80210, 80184, 80742, 80767, 80209
28913, 79266, 79442, 79450, 79274, 79267, 79443, 79451, 79275, 80744, 80768, 80769, 80210, 80747, 80771, 80772, 
80213, 80187, 80745, 80770, 80212
28914, 79267, 79443, 79451, 79275, 79268, 79444, 79452, 79276, 80747, 80771, 80772, 80213, 80750, 80774, 80775, 
80216, 80190, 80748, 80773, 80215
28915, 79268, 79444, 79452, 79276, 79269, 79445, 79453, 79277, 80750, 80774, 80775, 80216, 80753, 80777, 80778, 
80219, 80193, 80751, 80776, 80218
28916, 79269, 79445, 79453, 79277, 13747, 13769, 13770, 13748, 80753, 80777, 80778, 80219, 13882, 13883, 13884, 
13838, 80196, 80754, 80779, 80221
28917, 13525, 13547, 13548, 13526, 79270, 79446, 79454, 79278, 13660, 13663, 13662, 13618, 80757, 80781, 80782, 
80223, 80197, 80755, 80780, 80222
28918, 79270, 79446, 79454, 79278, 79271, 79447, 79455, 79279, 80757, 80781, 80782, 80223, 80760, 80784, 80785, 
80226, 80200, 80758, 80783, 80225
28919, 79271, 79447, 79455, 79279, 79272, 79448, 79456, 79280, 80760, 80784, 80785, 80226, 80763, 80787, 80788, 
80229, 80203, 80761, 80786, 80228
28920, 79272, 79448, 79456, 79280, 79273, 79449, 79457, 79281, 80763, 80787, 80788, 80229, 80766, 80790, 80791, 
80232, 80206, 80764, 80789, 80231
28921, 79273, 79449, 79457, 79281, 79274, 79450, 79458, 79282, 80766, 80790, 80791, 80232, 80769, 80793, 80794, 
80235, 80209, 80767, 80792, 80234
28922, 79274, 79450, 79458, 79282, 79275, 79451, 79459, 79283, 80769, 80793, 80794, 80235, 80772, 80796, 80797, 
80238, 80212, 80770, 80795, 80237
28923, 79275, 79451, 79459, 79283, 79276, 79452, 79460, 79284, 80772, 80796, 80797, 80238, 80775, 80799, 80800, 
80241, 80215, 80773, 80798, 80240
28924, 79276, 79452, 79460, 79284, 79277, 79453, 79461, 79285, 80775, 80799, 80800, 80241, 80778, 80802, 80803, 
80244, 80218, 80776, 80801, 80243
28925, 79277, 79453, 79461, 79285, 13748, 13770, 13771, 13749, 80778, 80802, 80803, 80244, 13884, 13885, 13886, 
13840, 80221, 80779, 80804, 80246
28926, 13526, 13548, 13549, 13527, 79278, 79454, 79462, 79286, 13662, 13665, 13664, 13620, 80782, 80806, 80807, 
80248, 80222, 80780, 80805, 80247
28927, 79278, 79454, 79462, 79286, 79279, 79455, 79463, 79287, 80782, 80806, 80807, 80248, 80785, 80809, 80810, 
80251, 80225, 80783, 80808, 80250
28928, 79279, 79455, 79463, 79287, 79280, 79456, 79464, 79288, 80785, 80809, 80810, 80251, 80788, 80812, 80813, 
80254, 80228, 80786, 80811, 80253
28929, 79280, 79456, 79464, 79288, 79281, 79457, 79465, 79289, 80788, 80812, 80813, 80254, 80791, 80815, 80816, 
80257, 80231, 80789, 80814, 80256
28930, 79281, 79457, 79465, 79289, 79282, 79458, 79466, 79290, 80791, 80815, 80816, 80257, 80794, 80818, 80819, 
80260, 80234, 80792, 80817, 80259
28931, 79282, 79458, 79466, 79290, 79283, 79459, 79467, 79291, 80794, 80818, 80819, 80260, 80797, 80821, 80822, 
80263, 80237, 80795, 80820, 80262
28932, 79283, 79459, 79467, 79291, 79284, 79460, 79468, 79292, 80797, 80821, 80822, 80263, 80800, 80824, 80825, 
80266, 80240, 80798, 80823, 80265
28933, 79284, 79460, 79468, 79292, 79285, 79461, 79469, 79293, 80800, 80824, 80825, 80266, 80803, 80827, 80828, 
80269, 80243, 80801, 80826, 80268
28934, 79285, 79461, 79469, 79293, 13749, 13771, 13772, 13750, 80803, 80827, 80828, 80269, 13886, 13887, 13888, 
13842, 80246, 80804, 80829, 80271
28935, 13527, 13549, 13550, 13528, 79286, 79462, 79470, 79294, 13664, 13667, 13666, 13622, 80807, 80831, 80832, 
80273, 80247, 80805, 80830, 80272
28936, 79286, 79462, 79470, 79294, 79287, 79463, 79471, 79295, 80807, 80831, 80832, 80273, 80810, 80834, 80835, 
80276, 80250, 80808, 80833, 80275
28937, 79287, 79463, 79471, 79295, 79288, 79464, 79472, 79296, 80810, 80834, 80835, 80276, 80813, 80837, 80838, 
80279, 80253, 80811, 80836, 80278
28938, 79288, 79464, 79472, 79296, 79289, 79465, 79473, 79297, 80813, 80837, 80838, 80279, 80816, 80840, 80841, 
80282, 80256, 80814, 80839, 80281
28939, 79289, 79465, 79473, 79297, 79290, 79466, 79474, 79298, 80816, 80840, 80841, 80282, 80819, 80843, 80844, 
80285, 80259, 80817, 80842, 80284
28940, 79290, 79466, 79474, 79298, 79291, 79467, 79475, 79299, 80819, 80843, 80844, 80285, 80822, 80846, 80847, 
80288, 80262, 80820, 80845, 80287
28941, 79291, 79467, 79475, 79299, 79292, 79468, 79476, 79300, 80822, 80846, 80847, 80288, 80825, 80849, 80850, 
80291, 80265, 80823, 80848, 80290
28942, 79292, 79468, 79476, 79300, 79293, 79469, 79477, 79301, 80825, 80849, 80850, 80291, 80828, 80852, 80853, 
80294, 80268, 80826, 80851, 80293
28943, 79293, 79469, 79477, 79301, 13750, 13772, 13773, 13751, 80828, 80852, 80853, 80294, 13888, 13889, 13890, 
13844, 80271, 80829, 80854, 80296
28944, 13528, 13550, 13551, 13529, 79294, 79470, 79478, 79302, 13666, 13669, 13668, 13624, 80832, 80856, 80857, 
80298, 80272, 80830, 80855, 80297
28945, 79294, 79470, 79478, 79302, 79295, 79471, 79479, 79303, 80832, 80856, 80857, 80298, 80835, 80859, 80860, 
80301, 80275, 80833, 80858, 80300
28946, 79295, 79471, 79479, 79303, 79296, 79472, 79480, 79304, 80835, 80859, 80860, 80301, 80838, 80862, 80863, 
80304, 80278, 80836, 80861, 80303
28947, 79296, 79472, 79480, 79304, 79297, 79473, 79481, 79305, 80838, 80862, 80863, 80304, 80841, 80865, 80866, 
80307, 80281, 80839, 80864, 80306
28948, 79297, 79473, 79481, 79305, 79298, 79474, 79482, 79306, 80841, 80865, 80866, 80307, 80844, 80868, 80869, 
80310, 80284, 80842, 80867, 80309
28949, 79298, 79474, 79482, 79306, 79299, 79475, 79483, 79307, 80844, 80868, 80869, 80310, 80847, 80871, 80872, 
80313, 80287, 80845, 80870, 80312
28950, 79299, 79475, 79483, 79307, 79300, 79476, 79484, 79308, 80847, 80871, 80872, 80313, 80850, 80874, 80875, 
80316, 80290, 80848, 80873, 80315
28951, 79300, 79476, 79484, 79308, 79301, 79477, 79485, 79309, 80850, 80874, 80875, 80316, 80853, 80877, 80878, 
80319, 80293, 80851, 80876, 80318
28952, 79301, 79477, 79485, 79309, 13751, 13773, 13774, 13752, 80853, 80877, 80878, 80319, 13890, 13891, 13892, 
13846, 80296, 80854, 80879, 80321
28953, 13529, 13551, 13552, 13530, 79302, 79478, 79486, 79310, 13668, 13671, 13670, 13626, 80857, 80881, 80882, 
80323, 80297, 80855, 80880, 80322
28954, 79302, 79478, 79486, 79310, 79303, 79479, 79487, 79311, 80857, 80881, 80882, 80323, 80860, 80884, 80885, 
80326, 80300, 80858, 80883, 80325
28955, 79303, 79479, 79487, 79311, 79304, 79480, 79488, 79312, 80860, 80884, 80885, 80326, 80863, 80887, 80888, 
80329, 80303, 80861, 80886, 80328
28956, 79304, 79480, 79488, 79312, 79305, 79481, 79489, 79313, 80863, 80887, 80888, 80329, 80866, 80890, 80891, 
80332, 80306, 80864, 80889, 80331
28957, 79305, 79481, 79489, 79313, 79306, 79482, 79490, 79314, 80866, 80890, 80891, 80332, 80869, 80893, 80894, 
80335, 80309, 80867, 80892, 80334
28958, 79306, 79482, 79490, 79314, 79307, 79483, 79491, 79315, 80869, 80893, 80894, 80335, 80872, 80896, 80897, 
80338, 80312, 80870, 80895, 80337
28959, 79307, 79483, 79491, 79315, 79308, 79484, 79492, 79316, 80872, 80896, 80897, 80338, 80875, 80899, 80900, 
80341, 80315, 80873, 80898, 80340
28960, 79308, 79484, 79492, 79316, 79309, 79485, 79493, 79317, 80875, 80899, 80900, 80341, 80878, 80902, 80903, 
80344, 80318, 80876, 80901, 80343
28961, 79309, 79485, 79493, 79317, 13752, 13774, 13775, 13753, 80878, 80902, 80903, 80344, 13892, 13893, 13894, 
13848, 80321, 80879, 80904, 80346
28962, 13530, 13552, 13553, 13531, 79310, 79486, 79494, 79318, 13670, 13673, 13672, 13628, 80882, 80906, 80907, 
80348, 80322, 80880, 80905, 80347
28963, 79310, 79486, 79494, 79318, 79311, 79487, 79495, 79319, 80882, 80906, 80907, 80348, 80885, 80909, 80910, 
80351, 80325, 80883, 80908, 80350
28964, 79311, 79487, 79495, 79319, 79312, 79488, 79496, 79320, 80885, 80909, 80910, 80351, 80888, 80912, 80913, 
80354, 80328, 80886, 80911, 80353
28965, 79312, 79488, 79496, 79320, 79313, 79489, 79497, 79321, 80888, 80912, 80913, 80354, 80891, 80915, 80916, 
80357, 80331, 80889, 80914, 80356
28966, 79313, 79489, 79497, 79321, 79314, 79490, 79498, 79322, 80891, 80915, 80916, 80357, 80894, 80918, 80919, 
80360, 80334, 80892, 80917, 80359
28967, 79314, 79490, 79498, 79322, 79315, 79491, 79499, 79323, 80894, 80918, 80919, 80360, 80897, 80921, 80922, 
80363, 80337, 80895, 80920, 80362
28968, 79315, 79491, 79499, 79323, 79316, 79492, 79500, 79324, 80897, 80921, 80922, 80363, 80900, 80924, 80925, 
80366, 80340, 80898, 80923, 80365
28969, 79316, 79492, 79500, 79324, 79317, 79493, 79501, 79325, 80900, 80924, 80925, 80366, 80903, 80927, 80928, 
80369, 80343, 80901, 80926, 80368
28970, 79317, 79493, 79501, 79325, 13753, 13775, 13776, 13754, 80903, 80927, 80928, 80369, 13894, 13895, 13896, 
13850, 80346, 80904, 80929, 80371
28971, 13531, 13553, 13554, 13532, 79318, 79494, 79502, 79326, 13672, 13675, 13674, 13630, 80907, 80931, 80932, 
80373, 80347, 80905, 80930, 80372
28972, 79318, 79494, 79502, 79326, 79319, 79495, 79503, 79327, 80907, 80931, 80932, 80373, 80910, 80934, 80935, 
80376, 80350, 80908, 80933, 80375
28973, 79319, 79495, 79503, 79327, 79320, 79496, 79504, 79328, 80910, 80934, 80935, 80376, 80913, 80937, 80938, 
80379, 80353, 80911, 80936, 80378
28974, 79320, 79496, 79504, 79328, 79321, 79497, 79505, 79329, 80913, 80937, 80938, 80379, 80916, 80940, 80941, 
80382, 80356, 80914, 80939, 80381
28975, 79321, 79497, 79505, 79329, 79322, 79498, 79506, 79330, 80916, 80940, 80941, 80382, 80919, 80943, 80944, 
80385, 80359, 80917, 80942, 80384
28976, 79322, 79498, 79506, 79330, 79323, 79499, 79507, 79331, 80919, 80943, 80944, 80385, 80922, 80946, 80947, 
80388, 80362, 80920, 80945, 80387
28977, 79323, 79499, 79507, 79331, 79324, 79500, 79508, 79332, 80922, 80946, 80947, 80388, 80925, 80949, 80950, 
80391, 80365, 80923, 80948, 80390
28978, 79324, 79500, 79508, 79332, 79325, 79501, 79509, 79333, 80925, 80949, 80950, 80391, 80928, 80952, 80953, 
80394, 80368, 80926, 80951, 80393
28979, 79325, 79501, 79509, 79333, 13754, 13776, 13777, 13755, 80928, 80952, 80953, 80394, 13896, 13897, 13898, 
13852, 80371, 80929, 80954, 80396
28980, 13532, 13554, 13555, 13533, 79326, 79502, 79510, 79334, 13674, 13677, 13676, 13632, 80932, 80956, 80957, 
80398, 80372, 80930, 80955, 80397
28981, 79326, 79502, 79510, 79334, 79327, 79503, 79511, 79335, 80932, 80956, 80957, 80398, 80935, 80959, 80960, 
80401, 80375, 80933, 80958, 80400
28982, 79327, 79503, 79511, 79335, 79328, 79504, 79512, 79336, 80935, 80959, 80960, 80401, 80938, 80962, 80963, 
80404, 80378, 80936, 80961, 80403
28983, 79328, 79504, 79512, 79336, 79329, 79505, 79513, 79337, 80938, 80962, 80963, 80404, 80941, 80965, 80966, 
80407, 80381, 80939, 80964, 80406
28984, 79329, 79505, 79513, 79337, 79330, 79506, 79514, 79338, 80941, 80965, 80966, 80407, 80944, 80968, 80969, 
80410, 80384, 80942, 80967, 80409
28985, 79330, 79506, 79514, 79338, 79331, 79507, 79515, 79339, 80944, 80968, 80969, 80410, 80947, 80971, 80972, 
80413, 80387, 80945, 80970, 80412
28986, 79331, 79507, 79515, 79339, 79332, 79508, 79516, 79340, 80947, 80971, 80972, 80413, 80950, 80974, 80975, 
80416, 80390, 80948, 80973, 80415
28987, 79332, 79508, 79516, 79340, 79333, 79509, 79517, 79341, 80950, 80974, 80975, 80416, 80953, 80977, 80978, 
80419, 80393, 80951, 80976, 80418
28988, 79333, 79509, 79517, 79341, 13755, 13777, 13778, 13756, 80953, 80977, 80978, 80419, 13898, 13899, 13900, 
13854, 80396, 80954, 80979, 80421
28989, 13533, 13555, 13556, 13534, 79334, 79510, 79518, 79342, 13676, 13679, 13678, 13634, 80957, 80981, 80982, 
80423, 80397, 80955, 80980, 80422
28990, 79334, 79510, 79518, 79342, 79335, 79511, 79519, 79343, 80957, 80981, 80982, 80423, 80960, 80984, 80985, 
80426, 80400, 80958, 80983, 80425
28991, 79335, 79511, 79519, 79343, 79336, 79512, 79520, 79344, 80960, 80984, 80985, 80426, 80963, 80987, 80988, 
80429, 80403, 80961, 80986, 80428
28992, 79336, 79512, 79520, 79344, 79337, 79513, 79521, 79345, 80963, 80987, 80988, 80429, 80966, 80990, 80991, 
80432, 80406, 80964, 80989, 80431
28993, 79337, 79513, 79521, 79345, 79338, 79514, 79522, 79346, 80966, 80990, 80991, 80432, 80969, 80993, 80994, 
80435, 80409, 80967, 80992, 80434
28994, 79338, 79514, 79522, 79346, 79339, 79515, 79523, 79347, 80969, 80993, 80994, 80435, 80972, 80996, 80997, 
80438, 80412, 80970, 80995, 80437
28995, 79339, 79515, 79523, 79347, 79340, 79516, 79524, 79348, 80972, 80996, 80997, 80438, 80975, 80999, 81000, 
80441, 80415, 80973, 80998, 80440
28996, 79340, 79516, 79524, 79348, 79341, 79517, 79525, 79349, 80975, 80999, 81000, 80441, 80978, 81002, 81003, 
80444, 80418, 80976, 81001, 80443
28997, 79341, 79517, 79525, 79349, 13756, 13778, 13779, 13757, 80978, 81002, 81003, 80444, 13900, 13901, 13902, 
13856, 80421, 80979, 81004, 80446
28998, 13534, 13556, 13557, 13535, 79342, 79518, 79526, 79350, 13678, 13681, 13680, 13636, 80982, 81006, 81007, 
80448, 80422, 80980, 81005, 80447
28999, 79342, 79518, 79526, 79350, 79343, 79519, 79527, 79351, 80982, 81006, 81007, 80448, 80985, 81009, 81010, 
80451, 80425, 80983, 81008, 80450
29000, 79343, 79519, 79527, 79351, 79344, 79520, 79528, 79352, 80985, 81009, 81010, 80451, 80988, 81012, 81013, 
80454, 80428, 80986, 81011, 80453
29001, 79344, 79520, 79528, 79352, 79345, 79521, 79529, 79353, 80988, 81012, 81013, 80454, 80991, 81015, 81016, 
80457, 80431, 80989, 81014, 80456
29002, 79345, 79521, 79529, 79353, 79346, 79522, 79530, 79354, 80991, 81015, 81016, 80457, 80994, 81018, 81019, 
80460, 80434, 80992, 81017, 80459
29003, 79346, 79522, 79530, 79354, 79347, 79523, 79531, 79355, 80994, 81018, 81019, 80460, 80997, 81021, 81022, 
80463, 80437, 80995, 81020, 80462
29004, 79347, 79523, 79531, 79355, 79348, 79524, 79532, 79356, 80997, 81021, 81022, 80463, 81000, 81024, 81025, 
80466, 80440, 80998, 81023, 80465
29005, 79348, 79524, 79532, 79356, 79349, 79525, 79533, 79357, 81000, 81024, 81025, 80466, 81003, 81027, 81028, 
80469, 80443, 81001, 81026, 80468
29006, 79349, 79525, 79533, 79357, 13757, 13779, 13780, 13758, 81003, 81027, 81028, 80469, 13902, 13903, 13904, 
13858, 80446, 81004, 81029, 80471
29007, 13535, 13557, 13558, 13536, 79350, 79526, 79534, 79358, 13680, 13683, 13682, 13638, 81007, 81031, 81032, 
80473, 80447, 81005, 81030, 80472
29008, 79350, 79526, 79534, 79358, 79351, 79527, 79535, 79359, 81007, 81031, 81032, 80473, 81010, 81034, 81035, 
80476, 80450, 81008, 81033, 80475
29009, 79351, 79527, 79535, 79359, 79352, 79528, 79536, 79360, 81010, 81034, 81035, 80476, 81013, 81037, 81038, 
80479, 80453, 81011, 81036, 80478
29010, 79352, 79528, 79536, 79360, 79353, 79529, 79537, 79361, 81013, 81037, 81038, 80479, 81016, 81040, 81041, 
80482, 80456, 81014, 81039, 80481
29011, 79353, 79529, 79537, 79361, 79354, 79530, 79538, 79362, 81016, 81040, 81041, 80482, 81019, 81043, 81044, 
80485, 80459, 81017, 81042, 80484
29012, 79354, 79530, 79538, 79362, 79355, 79531, 79539, 79363, 81019, 81043, 81044, 80485, 81022, 81046, 81047, 
80488, 80462, 81020, 81045, 80487
29013, 79355, 79531, 79539, 79363, 79356, 79532, 79540, 79364, 81022, 81046, 81047, 80488, 81025, 81049, 81050, 
80491, 80465, 81023, 81048, 80490
29014, 79356, 79532, 79540, 79364, 79357, 79533, 79541, 79365, 81025, 81049, 81050, 80491, 81028, 81052, 81053, 
80494, 80468, 81026, 81051, 80493
29015, 79357, 79533, 79541, 79365, 13758, 13780, 13781, 13759, 81028, 81052, 81053, 80494, 13904, 13905, 13906, 
13860, 80471, 81029, 81054, 80496
29016, 13536, 13558, 13559, 13537, 79358, 79534, 79542, 79366, 13682, 13685, 13684, 13640, 81032, 81056, 81057, 
80498, 80472, 81030, 81055, 80497
29017, 79358, 79534, 79542, 79366, 79359, 79535, 79543, 79367, 81032, 81056, 81057, 80498, 81035, 81059, 81060, 
80501, 80475, 81033, 81058, 80500
29018, 79359, 79535, 79543, 79367, 79360, 79536, 79544, 79368, 81035, 81059, 81060, 80501, 81038, 81062, 81063, 
80504, 80478, 81036, 81061, 80503
29019, 79360, 79536, 79544, 79368, 79361, 79537, 79545, 79369, 81038, 81062, 81063, 80504, 81041, 81065, 81066, 
80507, 80481, 81039, 81064, 80506
29020, 79361, 79537, 79545, 79369, 79362, 79538, 79546, 79370, 81041, 81065, 81066, 80507, 81044, 81068, 81069, 
80510, 80484, 81042, 81067, 80509
29021, 79362, 79538, 79546, 79370, 79363, 79539, 79547, 79371, 81044, 81068, 81069, 80510, 81047, 81071, 81072, 
80513, 80487, 81045, 81070, 80512
29022, 79363, 79539, 79547, 79371, 79364, 79540, 79548, 79372, 81047, 81071, 81072, 80513, 81050, 81074, 81075, 
80516, 80490, 81048, 81073, 80515
29023, 79364, 79540, 79548, 79372, 79365, 79541, 79549, 79373, 81050, 81074, 81075, 80516, 81053, 81077, 81078, 
80519, 80493, 81051, 81076, 80518
29024, 79365, 79541, 79549, 79373, 13759, 13781, 13782, 13760, 81053, 81077, 81078, 80519, 13906, 13907, 13908, 
13862, 80496, 81054, 81079, 80521
29025, 13537, 13559, 13560, 13538, 79366, 79542, 79550, 79374, 13684, 13687, 13686, 13642, 81057, 81081, 81082, 
80523, 80497, 81055, 81080, 80522
29026, 79366, 79542, 79550, 79374, 79367, 79543, 79551, 79375, 81057, 81081, 81082, 80523, 81060, 81084, 81085, 
80526, 80500, 81058, 81083, 80525
29027, 79367, 79543, 79551, 79375, 79368, 79544, 79552, 79376, 81060, 81084, 81085, 80526, 81063, 81087, 81088, 
80529, 80503, 81061, 81086, 80528
29028, 79368, 79544, 79552, 79376, 79369, 79545, 79553, 79377, 81063, 81087, 81088, 80529, 81066, 81090, 81091, 
80532, 80506, 81064, 81089, 80531
29029, 79369, 79545, 79553, 79377, 79370, 79546, 79554, 79378, 81066, 81090, 81091, 80532, 81069, 81093, 81094, 
80535, 80509, 81067, 81092, 80534
29030, 79370, 79546, 79554, 79378, 79371, 79547, 79555, 79379, 81069, 81093, 81094, 80535, 81072, 81096, 81097, 
80538, 80512, 81070, 81095, 80537
29031, 79371, 79547, 79555, 79379, 79372, 79548, 79556, 79380, 81072, 81096, 81097, 80538, 81075, 81099, 81100, 
80541, 80515, 81073, 81098, 80540
29032, 79372, 79548, 79556, 79380, 79373, 79549, 79557, 79381, 81075, 81099, 81100, 80541, 81078, 81102, 81103, 
80544, 80518, 81076, 81101, 80543
29033, 79373, 79549, 79557, 79381, 13760, 13782, 13783, 13761, 81078, 81102, 81103, 80544, 13908, 13909, 13910, 
13864, 80521, 81079, 81104, 80546
29034, 13538, 13560, 13561, 13539, 79374, 79550, 79558, 79382, 13686, 13689, 13688, 13644, 81082, 81106, 81107, 
80548, 80522, 81080, 81105, 80547
29035, 79374, 79550, 79558, 79382, 79375, 79551, 79559, 79383, 81082, 81106, 81107, 80548, 81085, 81109, 81110, 
80551, 80525, 81083, 81108, 80550
29036, 79375, 79551, 79559, 79383, 79376, 79552, 79560, 79384, 81085, 81109, 81110, 80551, 81088, 81112, 81113, 
80554, 80528, 81086, 81111, 80553
29037, 79376, 79552, 79560, 79384, 79377, 79553, 79561, 79385, 81088, 81112, 81113, 80554, 81091, 81115, 81116, 
80557, 80531, 81089, 81114, 80556
29038, 79377, 79553, 79561, 79385, 79378, 79554, 79562, 79386, 81091, 81115, 81116, 80557, 81094, 81118, 81119, 
80560, 80534, 81092, 81117, 80559
29039, 79378, 79554, 79562, 79386, 79379, 79555, 79563, 79387, 81094, 81118, 81119, 80560, 81097, 81121, 81122, 
80563, 80537, 81095, 81120, 80562
29040, 79379, 79555, 79563, 79387, 79380, 79556, 79564, 79388, 81097, 81121, 81122, 80563, 81100, 81124, 81125, 
80566, 80540, 81098, 81123, 80565
29041, 79380, 79556, 79564, 79388, 79381, 79557, 79565, 79389, 81100, 81124, 81125, 80566, 81103, 81127, 81128, 
80569, 80543, 81101, 81126, 80568
29042, 79381, 79557, 79565, 79389, 13761, 13783, 13784, 13762, 81103, 81127, 81128, 80569, 13910, 13911, 13912, 
13866, 80546, 81104, 81129, 80571
29043, 13539, 13561, 13562, 13540, 79382, 79558, 79566, 79390, 13688, 13691, 13690, 13646, 81107, 81131, 81132, 
80573, 80547, 81105, 81130, 80572
29044, 79382, 79558, 79566, 79390, 79383, 79559, 79567, 79391, 81107, 81131, 81132, 80573, 81110, 81134, 81135, 
80576, 80550, 81108, 81133, 80575
29045, 79383, 79559, 79567, 79391, 79384, 79560, 79568, 79392, 81110, 81134, 81135, 80576, 81113, 81137, 81138, 
80579, 80553, 81111, 81136, 80578
29046, 79384, 79560, 79568, 79392, 79385, 79561, 79569, 79393, 81113, 81137, 81138, 80579, 81116, 81140, 81141, 
80582, 80556, 81114, 81139, 80581
29047, 79385, 79561, 79569, 79393, 79386, 79562, 79570, 79394, 81116, 81140, 81141, 80582, 81119, 81143, 81144, 
80585, 80559, 81117, 81142, 80584
29048, 79386, 79562, 79570, 79394, 79387, 79563, 79571, 79395, 81119, 81143, 81144, 80585, 81122, 81146, 81147, 
80588, 80562, 81120, 81145, 80587
29049, 79387, 79563, 79571, 79395, 79388, 79564, 79572, 79396, 81122, 81146, 81147, 80588, 81125, 81149, 81150, 
80591, 80565, 81123, 81148, 80590
29050, 79388, 79564, 79572, 79396, 79389, 79565, 79573, 79397, 81125, 81149, 81150, 80591, 81128, 81152, 81153, 
80594, 80568, 81126, 81151, 80593
29051, 79389, 79565, 79573, 79397, 13762, 13784, 13785, 13763, 81128, 81152, 81153, 80594, 13912, 13913, 13914, 
13868, 80571, 81129, 81154, 80596
29052, 13540, 13562, 13563, 13541, 79390, 79566, 79574, 79398, 13690, 13693, 13692, 13648, 81132, 81156, 81157, 
80598, 80572, 81130, 81155, 80597
29053, 79390, 79566, 79574, 79398, 79391, 79567, 79575, 79399, 81132, 81156, 81157, 80598, 81135, 81159, 81160, 
80601, 80575, 81133, 81158, 80600
29054, 79391, 79567, 79575, 79399, 79392, 79568, 79576, 79400, 81135, 81159, 81160, 80601, 81138, 81162, 81163, 
80604, 80578, 81136, 81161, 80603
29055, 79392, 79568, 79576, 79400, 79393, 79569, 79577, 79401, 81138, 81162, 81163, 80604, 81141, 81165, 81166, 
80607, 80581, 81139, 81164, 80606
29056, 79393, 79569, 79577, 79401, 79394, 79570, 79578, 79402, 81141, 81165, 81166, 80607, 81144, 81168, 81169, 
80610, 80584, 81142, 81167, 80609
29057, 79394, 79570, 79578, 79402, 79395, 79571, 79579, 79403, 81144, 81168, 81169, 80610, 81147, 81171, 81172, 
80613, 80587, 81145, 81170, 80612
29058, 79395, 79571, 79579, 79403, 79396, 79572, 79580, 79404, 81147, 81171, 81172, 80613, 81150, 81174, 81175, 
80616, 80590, 81148, 81173, 80615
29059, 79396, 79572, 79580, 79404, 79397, 79573, 79581, 79405, 81150, 81174, 81175, 80616, 81153, 81177, 81178, 
80619, 80593, 81151, 81176, 80618
29060, 79397, 79573, 79581, 79405, 13763, 13785, 13786, 13764, 81153, 81177, 81178, 80619, 13914, 13915, 13916, 
13870, 80596, 81154, 81179, 80621
29061, 13541, 13563, 13564, 13542, 79398, 79574, 79582, 79406, 13692, 13695, 13694, 13650, 81157, 81181, 81182, 
80623, 80597, 81155, 81180, 80622
29062, 79398, 79574, 79582, 79406, 79399, 79575, 79583, 79407, 81157, 81181, 81182, 80623, 81160, 81184, 81185, 
80626, 80600, 81158, 81183, 80625
29063, 79399, 79575, 79583, 79407, 79400, 79576, 79584, 79408, 81160, 81184, 81185, 80626, 81163, 81187, 81188, 
80629, 80603, 81161, 81186, 80628
29064, 79400, 79576, 79584, 79408, 79401, 79577, 79585, 79409, 81163, 81187, 81188, 80629, 81166, 81190, 81191, 
80632, 80606, 81164, 81189, 80631
29065, 79401, 79577, 79585, 79409, 79402, 79578, 79586, 79410, 81166, 81190, 81191, 80632, 81169, 81193, 81194, 
80635, 80609, 81167, 81192, 80634
29066, 79402, 79578, 79586, 79410, 79403, 79579, 79587, 79411, 81169, 81193, 81194, 80635, 81172, 81196, 81197, 
80638, 80612, 81170, 81195, 80637
29067, 79403, 79579, 79587, 79411, 79404, 79580, 79588, 79412, 81172, 81196, 81197, 80638, 81175, 81199, 81200, 
80641, 80615, 81173, 81198, 80640
29068, 79404, 79580, 79588, 79412, 79405, 79581, 79589, 79413, 81175, 81199, 81200, 80641, 81178, 81202, 81203, 
80644, 80618, 81176, 81201, 80643
29069, 79405, 79581, 79589, 79413, 13764, 13786, 13787, 13765, 81178, 81202, 81203, 80644, 13916, 13917, 13918, 
13872, 80621, 81179, 81204, 80646
29070, 13542, 13564, 13565, 13543, 79406, 79582, 79590, 79414, 13694, 13697, 13696, 13652, 81182, 81206, 81207, 
80648, 80622, 81180, 81205, 80647
29071, 79406, 79582, 79590, 79414, 79407, 79583, 79591, 79415, 81182, 81206, 81207, 80648, 81185, 81209, 81210, 
80651, 80625, 81183, 81208, 80650
29072, 79407, 79583, 79591, 79415, 79408, 79584, 79592, 79416, 81185, 81209, 81210, 80651, 81188, 81212, 81213, 
80654, 80628, 81186, 81211, 80653
29073, 79408, 79584, 79592, 79416, 79409, 79585, 79593, 79417, 81188, 81212, 81213, 80654, 81191, 81215, 81216, 
80657, 80631, 81189, 81214, 80656
29074, 79409, 79585, 79593, 79417, 79410, 79586, 79594, 79418, 81191, 81215, 81216, 80657, 81194, 81218, 81219, 
80660, 80634, 81192, 81217, 80659
29075, 79410, 79586, 79594, 79418, 79411, 79587, 79595, 79419, 81194, 81218, 81219, 80660, 81197, 81221, 81222, 
80663, 80637, 81195, 81220, 80662
29076, 79411, 79587, 79595, 79419, 79412, 79588, 79596, 79420, 81197, 81221, 81222, 80663, 81200, 81224, 81225, 
80666, 80640, 81198, 81223, 80665
29077, 79412, 79588, 79596, 79420, 79413, 79589, 79597, 79421, 81200, 81224, 81225, 80666, 81203, 81227, 81228, 
80669, 80643, 81201, 81226, 80668
29078, 79413, 79589, 79597, 79421, 13765, 13787, 13788, 13766, 81203, 81227, 81228, 80669, 13918, 13919, 13920, 
13874, 80646, 81204, 81229, 80671
29079, 13543, 13565, 13566, 13544, 79414, 79590, 79598, 79422, 13696, 13699, 13698, 13654, 81207, 81231, 81232, 
80673, 80647, 81205, 81230, 80672
29080, 79414, 79590, 79598, 79422, 79415, 79591, 79599, 79423, 81207, 81231, 81232, 80673, 81210, 81234, 81235, 
80676, 80650, 81208, 81233, 80675
29081, 79415, 79591, 79599, 79423, 79416, 79592, 79600, 79424, 81210, 81234, 81235, 80676, 81213, 81237, 81238, 
80679, 80653, 81211, 81236, 80678
29082, 79416, 79592, 79600, 79424, 79417, 79593, 79601, 79425, 81213, 81237, 81238, 80679, 81216, 81240, 81241, 
80682, 80656, 81214, 81239, 80681
29083, 79417, 79593, 79601, 79425, 79418, 79594, 79602, 79426, 81216, 81240, 81241, 80682, 81219, 81243, 81244, 
80685, 80659, 81217, 81242, 80684
29084, 79418, 79594, 79602, 79426, 79419, 79595, 79603, 79427, 81219, 81243, 81244, 80685, 81222, 81246, 81247, 
80688, 80662, 81220, 81245, 80687
29085, 79419, 79595, 79603, 79427, 79420, 79596, 79604, 79428, 81222, 81246, 81247, 80688, 81225, 81249, 81250, 
80691, 80665, 81223, 81248, 80690
29086, 79420, 79596, 79604, 79428, 79421, 79597, 79605, 79429, 81225, 81249, 81250, 80691, 81228, 81252, 81253, 
80694, 80668, 81226, 81251, 80693
29087, 79421, 79597, 79605, 79429, 13766, 13788, 13789, 13767, 81228, 81252, 81253, 80694, 13920, 13921, 13922, 
13876, 80671, 81229, 81254, 80696
29088, 13544, 13566, 13567, 13545, 79422, 79598, 79606, 79430, 13698, 13701, 13700, 13656, 81232, 81256, 81257, 
80698, 80672, 81230, 81255, 80697
29089, 79422, 79598, 79606, 79430, 79423, 79599, 79607, 79431, 81232, 81256, 81257, 80698, 81235, 81259, 81260, 
80701, 80675, 81233, 81258, 80700
29090, 79423, 79599, 79607, 79431, 79424, 79600, 79608, 79432, 81235, 81259, 81260, 80701, 81238, 81262, 81263, 
80704, 80678, 81236, 81261, 80703
29091, 79424, 79600, 79608, 79432, 79425, 79601, 79609, 79433, 81238, 81262, 81263, 80704, 81241, 81265, 81266, 
80707, 80681, 81239, 81264, 80706
29092, 79425, 79601, 79609, 79433, 79426, 79602, 79610, 79434, 81241, 81265, 81266, 80707, 81244, 81268, 81269, 
80710, 80684, 81242, 81267, 80709
29093, 79426, 79602, 79610, 79434, 79427, 79603, 79611, 79435, 81244, 81268, 81269, 80710, 81247, 81271, 81272, 
80713, 80687, 81245, 81270, 80712
29094, 79427, 79603, 79611, 79435, 79428, 79604, 79612, 79436, 81247, 81271, 81272, 80713, 81250, 81274, 81275, 
80716, 80690, 81248, 81273, 80715
29095, 79428, 79604, 79612, 79436, 79429, 79605, 79613, 79437, 81250, 81274, 81275, 80716, 81253, 81277, 81278, 
80719, 80693, 81251, 81276, 80718
29096, 79429, 79605, 79613, 79437, 13767, 13789, 13790, 13768, 81253, 81277, 81278, 80719, 13922, 13923, 13924, 
13878, 80696, 81254, 81279, 80721
29097, 13545, 13567, 1829, 1828, 79430, 79606, 13971, 13963, 13700, 13702, 1832, 13657, 81257, 81280, 14021, 
80722, 80697, 81255, 14022, 14005
29098, 79430, 79606, 13971, 13963, 79431, 79607, 13970, 13962, 81257, 81280, 14021, 80722, 81260, 81281, 14019, 
80723, 80700, 81258, 14020, 14003
29099, 79431, 79607, 13970, 13962, 79432, 79608, 13969, 13961, 81260, 81281, 14019, 80723, 81263, 81282, 14017, 
80724, 80703, 81261, 14018, 14001
29100, 79432, 79608, 13969, 13961, 79433, 79609, 13968, 13960, 81263, 81282, 14017, 80724, 81266, 81283, 14015, 
80725, 80706, 81264, 14016, 13999
29101, 79433, 79609, 13968, 13960, 79434, 79610, 13967, 13959, 81266, 81283, 14015, 80725, 81269, 81284, 14013, 
80726, 80709, 81267, 14014, 13997
29102, 79434, 79610, 13967, 13959, 79435, 79611, 13966, 13958, 81269, 81284, 14013, 80726, 81272, 81285, 14011, 
80727, 80712, 81270, 14012, 13995
29103, 79435, 79611, 13966, 13958, 79436, 79612, 13965, 13957, 81272, 81285, 14011, 80727, 81275, 81286, 14009, 
80728, 80715, 81273, 14010, 13993
29104, 79436, 79612, 13965, 13957, 79437, 79613, 13964, 13956, 81275, 81286, 14009, 80728, 81278, 81287, 14007, 
80729, 80718, 81276, 14008, 13991
29105, 79437, 79613, 13964, 13956, 13768, 13790, 1881, 1880, 81278, 81287, 14007, 80729, 13924, 13925, 1884, 
13880, 80721, 81279, 14006, 13989
29106, 1774, 59, 1855, 13546, 13276, 1793, 14199, 79438, 1778, 1878, 13703, 13659, 13335, 14581, 81288, 
80731, 13327, 1801, 14565, 80730
29107, 13276, 1793, 14199, 79438, 13275, 1794, 14200, 79439, 13335, 14581, 81288, 80731, 13334, 14582, 81289, 
80734, 13325, 1802, 14567, 80733
29108, 13275, 1794, 14200, 79439, 13274, 1795, 14201, 79440, 13334, 14582, 81289, 80734, 13333, 14583, 81290, 
80737, 13323, 1803, 14569, 80736
29109, 13274, 1795, 14201, 79440, 13273, 1796, 14202, 79441, 13333, 14583, 81290, 80737, 13332, 14584, 81291, 
80740, 13321, 1804, 14571, 80739
29110, 13273, 1796, 14202, 79441, 13272, 1797, 14203, 79442, 13332, 14584, 81291, 80740, 13331, 14585, 81292, 
80743, 13319, 1805, 14573, 80742
29111, 13272, 1797, 14203, 79442, 13271, 1798, 14204, 79443, 13331, 14585, 81292, 80743, 13330, 14586, 81293, 
80746, 13317, 1806, 14575, 80745
29112, 13271, 1798, 14204, 79443, 13270, 1799, 14205, 79444, 13330, 14586, 81293, 80746, 13329, 14587, 81294, 
80749, 13315, 1807, 14577, 80748
29113, 13270, 1799, 14205, 79444, 13269, 1800, 14206, 79445, 13329, 14587, 81294, 80749, 13328, 14588, 81295, 
80752, 13313, 1808, 14579, 80751
29114, 13269, 1800, 14206, 79445, 1753, 57, 1907, 13769, 13328, 14588, 81295, 80752, 1757, 1930, 13926, 
13881, 13311, 1809, 14580, 80754
29115, 13546, 1855, 1854, 13547, 79438, 14199, 14191, 79446, 13703, 1877, 13704, 13661, 81288, 14564, 81296, 
80756, 80730, 14565, 14548, 80755
29116, 79438, 14199, 14191, 79446, 79439, 14200, 14192, 79447, 81288, 14564, 81296, 80756, 81289, 14566, 81297, 
80759, 80733, 14567, 14550, 80758
29117, 79439, 14200, 14192, 79447, 79440, 14201, 14193, 79448, 81289, 14566, 81297, 80759, 81290, 14568, 81298, 
80762, 80736, 14569, 14552, 80761
29118, 79440, 14201, 14193, 79448, 79441, 14202, 14194, 79449, 81290, 14568, 81298, 80762, 81291, 14570, 81299, 
80765, 80739, 14571, 14554, 80764
29119, 79441, 14202, 14194, 79449, 79442, 14203, 14195, 79450, 81291, 14570, 81299, 80765, 81292, 14572, 81300, 
80768, 80742, 14573, 14556, 80767
29120, 79442, 14203, 14195, 79450, 79443, 14204, 14196, 79451, 81292, 14572, 81300, 80768, 81293, 14574, 81301, 
80771, 80745, 14575, 14558, 80770
29121, 79443, 14204, 14196, 79451, 79444, 14205, 14197, 79452, 81293, 14574, 81301, 80771, 81294, 14576, 81302, 
80774, 80748, 14577, 14560, 80773
29122, 79444, 14205, 14197, 79452, 79445, 14206, 14198, 79453, 81294, 14576, 81302, 80774, 81295, 14578, 81303, 
80777, 80751, 14579, 14562, 80776
29123, 79445, 14206, 14198, 79453, 13769, 1907, 1906, 13770, 81295, 14578, 81303, 80777, 13926, 1929, 13927, 
13883, 80754, 14580, 14563, 80779
29124, 13547, 1854, 1853, 13548, 79446, 14191, 14183, 79454, 13704, 1876, 13705, 13663, 81296, 14547, 81304, 
80781, 80755, 14548, 14531, 80780
29125, 79446, 14191, 14183, 79454, 79447, 14192, 14184, 79455, 81296, 14547, 81304, 80781, 81297, 14549, 81305, 
80784, 80758, 14550, 14533, 80783
29126, 79447, 14192, 14184, 79455, 79448, 14193, 14185, 79456, 81297, 14549, 81305, 80784, 81298, 14551, 81306, 
80787, 80761, 14552, 14535, 80786
29127, 79448, 14193, 14185, 79456, 79449, 14194, 14186, 79457, 81298, 14551, 81306, 80787, 81299, 14553, 81307, 
80790, 80764, 14554, 14537, 80789
29128, 79449, 14194, 14186, 79457, 79450, 14195, 14187, 79458, 81299, 14553, 81307, 80790, 81300, 14555, 81308, 
80793, 80767, 14556, 14539, 80792
29129, 79450, 14195, 14187, 79458, 79451, 14196, 14188, 79459, 81300, 14555, 81308, 80793, 81301, 14557, 81309, 
80796, 80770, 14558, 14541, 80795
29130, 79451, 14196, 14188, 79459, 79452, 14197, 14189, 79460, 81301, 14557, 81309, 80796, 81302, 14559, 81310, 
80799, 80773, 14560, 14543, 80798
29131, 79452, 14197, 14189, 79460, 79453, 14198, 14190, 79461, 81302, 14559, 81310, 80799, 81303, 14561, 81311, 
80802, 80776, 14562, 14545, 80801
29132, 79453, 14198, 14190, 79461, 13770, 1906, 1905, 13771, 81303, 14561, 81311, 80802, 13927, 1928, 13928, 
13885, 80779, 14563, 14546, 80804
29133, 13548, 1853, 1852, 13549, 79454, 14183, 14175, 79462, 13705, 1875, 13706, 13665, 81304, 14530, 81312, 
80806, 80780, 14531, 14514, 80805
29134, 79454, 14183, 14175, 79462, 79455, 14184, 14176, 79463, 81304, 14530, 81312, 80806, 81305, 14532, 81313, 
80809, 80783, 14533, 14516, 80808
29135, 79455, 14184, 14176, 79463, 79456, 14185, 14177, 79464, 81305, 14532, 81313, 80809, 81306, 14534, 81314, 
80812, 80786, 14535, 14518, 80811
29136, 79456, 14185, 14177, 79464, 79457, 14186, 14178, 79465, 81306, 14534, 81314, 80812, 81307, 14536, 81315, 
80815, 80789, 14537, 14520, 80814
29137, 79457, 14186, 14178, 79465, 79458, 14187, 14179, 79466, 81307, 14536, 81315, 80815, 81308, 14538, 81316, 
80818, 80792, 14539, 14522, 80817
29138, 79458, 14187, 14179, 79466, 79459, 14188, 14180, 79467, 81308, 14538, 81316, 80818, 81309, 14540, 81317, 
80821, 80795, 14541, 14524, 80820
29139, 79459, 14188, 14180, 79467, 79460, 14189, 14181, 79468, 81309, 14540, 81317, 80821, 81310, 14542, 81318, 
80824, 80798, 14543, 14526, 80823
29140, 79460, 14189, 14181, 79468, 79461, 14190, 14182, 79469, 81310, 14542, 81318, 80824, 81311, 14544, 81319, 
80827, 80801, 14545, 14528, 80826
29141, 79461, 14190, 14182, 79469, 13771, 1905, 1904, 13772, 81311, 14544, 81319, 80827, 13928, 1927, 13929, 
13887, 80804, 14546, 14529, 80829
29142, 13549, 1852, 1851, 13550, 79462, 14175, 14167, 79470, 13706, 1874, 13707, 13667, 81312, 14513, 81320, 
80831, 80805, 14514, 14497, 80830
29143, 79462, 14175, 14167, 79470, 79463, 14176, 14168, 79471, 81312, 14513, 81320, 80831, 81313, 14515, 81321, 
80834, 80808, 14516, 14499, 80833
29144, 79463, 14176, 14168, 79471, 79464, 14177, 14169, 79472, 81313, 14515, 81321, 80834, 81314, 14517, 81322, 
80837, 80811, 14518, 14501, 80836
29145, 79464, 14177, 14169, 79472, 79465, 14178, 14170, 79473, 81314, 14517, 81322, 80837, 81315, 14519, 81323, 
80840, 80814, 14520, 14503, 80839
29146, 79465, 14178, 14170, 79473, 79466, 14179, 14171, 79474, 81315, 14519, 81323, 80840, 81316, 14521, 81324, 
80843, 80817, 14522, 14505, 80842
29147, 79466, 14179, 14171, 79474, 79467, 14180, 14172, 79475, 81316, 14521, 81324, 80843, 81317, 14523, 81325, 
80846, 80820, 14524, 14507, 80845
29148, 79467, 14180, 14172, 79475, 79468, 14181, 14173, 79476, 81317, 14523, 81325, 80846, 81318, 14525, 81326, 
80849, 80823, 14526, 14509, 80848
29149, 79468, 14181, 14173, 79476, 79469, 14182, 14174, 79477, 81318, 14525, 81326, 80849, 81319, 14527, 81327, 
80852, 80826, 14528, 14511, 80851
29150, 79469, 14182, 14174, 79477, 13772, 1904, 1903, 13773, 81319, 14527, 81327, 80852, 13929, 1926, 13930, 
13889, 80829, 14529, 14512, 80854
29151, 13550, 1851, 1850, 13551, 79470, 14167, 14159, 79478, 13707, 1873, 13708, 13669, 81320, 14496, 81328, 
80856, 80830, 14497, 14480, 80855
29152, 79470, 14167, 14159, 79478, 79471, 14168, 14160, 79479, 81320, 14496, 81328, 80856, 81321, 14498, 81329, 
80859, 80833, 14499, 14482, 80858
29153, 79471, 14168, 14160, 79479, 79472, 14169, 14161, 79480, 81321, 14498, 81329, 80859, 81322, 14500, 81330, 
80862, 80836, 14501, 14484, 80861
29154, 79472, 14169, 14161, 79480, 79473, 14170, 14162, 79481, 81322, 14500, 81330, 80862, 81323, 14502, 81331, 
80865, 80839, 14503, 14486, 80864
29155, 79473, 14170, 14162, 79481, 79474, 14171, 14163, 79482, 81323, 14502, 81331, 80865, 81324, 14504, 81332, 
80868, 80842, 14505, 14488, 80867
29156, 79474, 14171, 14163, 79482, 79475, 14172, 14164, 79483, 81324, 14504, 81332, 80868, 81325, 14506, 81333, 
80871, 80845, 14507, 14490, 80870
29157, 79475, 14172, 14164, 79483, 79476, 14173, 14165, 79484, 81325, 14506, 81333, 80871, 81326, 14508, 81334, 
80874, 80848, 14509, 14492, 80873
29158, 79476, 14173, 14165, 79484, 79477, 14174, 14166, 79485, 81326, 14508, 81334, 80874, 81327, 14510, 81335, 
80877, 80851, 14511, 14494, 80876
29159, 79477, 14174, 14166, 79485, 13773, 1903, 1902, 13774, 81327, 14510, 81335, 80877, 13930, 1925, 13931, 
13891, 80854, 14512, 14495, 80879
29160, 13551, 1850, 1849, 13552, 79478, 14159, 14151, 79486, 13708, 1872, 13709, 13671, 81328, 14479, 81336, 
80881, 80855, 14480, 14463, 80880
29161, 79478, 14159, 14151, 79486, 79479, 14160, 14152, 79487, 81328, 14479, 81336, 80881, 81329, 14481, 81337, 
80884, 80858, 14482, 14465, 80883
29162, 79479, 14160, 14152, 79487, 79480, 14161, 14153, 79488, 81329, 14481, 81337, 80884, 81330, 14483, 81338, 
80887, 80861, 14484, 14467, 80886
29163, 79480, 14161, 14153, 79488, 79481, 14162, 14154, 79489, 81330, 14483, 81338, 80887, 81331, 14485, 81339, 
80890, 80864, 14486, 14469, 80889
29164, 79481, 14162, 14154, 79489, 79482, 14163, 14155, 79490, 81331, 14485, 81339, 80890, 81332, 14487, 81340, 
80893, 80867, 14488, 14471, 80892
29165, 79482, 14163, 14155, 79490, 79483, 14164, 14156, 79491, 81332, 14487, 81340, 80893, 81333, 14489, 81341, 
80896, 80870, 14490, 14473, 80895
29166, 79483, 14164, 14156, 79491, 79484, 14165, 14157, 79492, 81333, 14489, 81341, 80896, 81334, 14491, 81342, 
80899, 80873, 14492, 14475, 80898
29167, 79484, 14165, 14157, 79492, 79485, 14166, 14158, 79493, 81334, 14491, 81342, 80899, 81335, 14493, 81343, 
80902, 80876, 14494, 14477, 80901
29168, 79485, 14166, 14158, 79493, 13774, 1902, 1901, 13775, 81335, 14493, 81343, 80902, 13931, 1924, 13932, 
13893, 80879, 14495, 14478, 80904
29169, 13552, 1849, 1848, 13553, 79486, 14151, 14143, 79494, 13709, 1871, 13710, 13673, 81336, 14462, 81344, 
80906, 80880, 14463, 14446, 80905
29170, 79486, 14151, 14143, 79494, 79487, 14152, 14144, 79495, 81336, 14462, 81344, 80906, 81337, 14464, 81345, 
80909, 80883, 14465, 14448, 80908
29171, 79487, 14152, 14144, 79495, 79488, 14153, 14145, 79496, 81337, 14464, 81345, 80909, 81338, 14466, 81346, 
80912, 80886, 14467, 14450, 80911
29172, 79488, 14153, 14145, 79496, 79489, 14154, 14146, 79497, 81338, 14466, 81346, 80912, 81339, 14468, 81347, 
80915, 80889, 14469, 14452, 80914
29173, 79489, 14154, 14146, 79497, 79490, 14155, 14147, 79498, 81339, 14468, 81347, 80915, 81340, 14470, 81348, 
80918, 80892, 14471, 14454, 80917
29174, 79490, 14155, 14147, 79498, 79491, 14156, 14148, 79499, 81340, 14470, 81348, 80918, 81341, 14472, 81349, 
80921, 80895, 14473, 14456, 80920
29175, 79491, 14156, 14148, 79499, 79492, 14157, 14149, 79500, 81341, 14472, 81349, 80921, 81342, 14474, 81350, 
80924, 80898, 14475, 14458, 80923
29176, 79492, 14157, 14149, 79500, 79493, 14158, 14150, 79501, 81342, 14474, 81350, 80924, 81343, 14476, 81351, 
80927, 80901, 14477, 14460, 80926
29177, 79493, 14158, 14150, 79501, 13775, 1901, 1900, 13776, 81343, 14476, 81351, 80927, 13932, 1923, 13933, 
13895, 80904, 14478, 14461, 80929
29178, 13553, 1848, 1847, 13554, 79494, 14143, 14135, 79502, 13710, 1870, 13711, 13675, 81344, 14445, 81352, 
80931, 80905, 14446, 14429, 80930
29179, 79494, 14143, 14135, 79502, 79495, 14144, 14136, 79503, 81344, 14445, 81352, 80931, 81345, 14447, 81353, 
80934, 80908, 14448, 14431, 80933
29180, 79495, 14144, 14136, 79503, 79496, 14145, 14137, 79504, 81345, 14447, 81353, 80934, 81346, 14449, 81354, 
80937, 80911, 14450, 14433, 80936
29181, 79496, 14145, 14137, 79504, 79497, 14146, 14138, 79505, 81346, 14449, 81354, 80937, 81347, 14451, 81355, 
80940, 80914, 14452, 14435, 80939
29182, 79497, 14146, 14138, 79505, 79498, 14147, 14139, 79506, 81347, 14451, 81355, 80940, 81348, 14453, 81356, 
80943, 80917, 14454, 14437, 80942
29183, 79498, 14147, 14139, 79506, 79499, 14148, 14140, 79507, 81348, 14453, 81356, 80943, 81349, 14455, 81357, 
80946, 80920, 14456, 14439, 80945
29184, 79499, 14148, 14140, 79507, 79500, 14149, 14141, 79508, 81349, 14455, 81357, 80946, 81350, 14457, 81358, 
80949, 80923, 14458, 14441, 80948
29185, 79500, 14149, 14141, 79508, 79501, 14150, 14142, 79509, 81350, 14457, 81358, 80949, 81351, 14459, 81359, 
80952, 80926, 14460, 14443, 80951
29186, 79501, 14150, 14142, 79509, 13776, 1900, 1899, 13777, 81351, 14459, 81359, 80952, 13933, 1922, 13934, 
13897, 80929, 14461, 14444, 80954
29187, 13554, 1847, 1846, 13555, 79502, 14135, 14127, 79510, 13711, 1869, 13712, 13677, 81352, 14428, 81360, 
80956, 80930, 14429, 14412, 80955
29188, 79502, 14135, 14127, 79510, 79503, 14136, 14128, 79511, 81352, 14428, 81360, 80956, 81353, 14430, 81361, 
80959, 80933, 14431, 14414, 80958
29189, 79503, 14136, 14128, 79511, 79504, 14137, 14129, 79512, 81353, 14430, 81361, 80959, 81354, 14432, 81362, 
80962, 80936, 14433, 14416, 80961
29190, 79504, 14137, 14129, 79512, 79505, 14138, 14130, 79513, 81354, 14432, 81362, 80962, 81355, 14434, 81363, 
80965, 80939, 14435, 14418, 80964
29191, 79505, 14138, 14130, 79513, 79506, 14139, 14131, 79514, 81355, 14434, 81363, 80965, 81356, 14436, 81364, 
80968, 80942, 14437, 14420, 80967
29192, 79506, 14139, 14131, 79514, 79507, 14140, 14132, 79515, 81356, 14436, 81364, 80968, 81357, 14438, 81365, 
80971, 80945, 14439, 14422, 80970
29193, 79507, 14140, 14132, 79515, 79508, 14141, 14133, 79516, 81357, 14438, 81365, 80971, 81358, 14440, 81366, 
80974, 80948, 14441, 14424, 80973
29194, 79508, 14141, 14133, 79516, 79509, 14142, 14134, 79517, 81358, 14440, 81366, 80974, 81359, 14442, 81367, 
80977, 80951, 14443, 14426, 80976
29195, 79509, 14142, 14134, 79517, 13777, 1899, 1898, 13778, 81359, 14442, 81367, 80977, 13934, 1921, 13935, 
13899, 80954, 14444, 14427, 80979
29196, 13555, 1846, 1845, 13556, 79510, 14127, 14119, 79518, 13712, 1868, 13713, 13679, 81360, 14411, 81368, 
80981, 80955, 14412, 14395, 80980
29197, 79510, 14127, 14119, 79518, 79511, 14128, 14120, 79519, 81360, 14411, 81368, 80981, 81361, 14413, 81369, 
80984, 80958, 14414, 14397, 80983
29198, 79511, 14128, 14120, 79519, 79512, 14129, 14121, 79520, 81361, 14413, 81369, 80984, 81362, 14415, 81370, 
80987, 80961, 14416, 14399, 80986
29199, 79512, 14129, 14121, 79520, 79513, 14130, 14122, 79521, 81362, 14415, 81370, 80987, 81363, 14417, 81371, 
80990, 80964, 14418, 14401, 80989
29200, 79513, 14130, 14122, 79521, 79514, 14131, 14123, 79522, 81363, 14417, 81371, 80990, 81364, 14419, 81372, 
80993, 80967, 14420, 14403, 80992
29201, 79514, 14131, 14123, 79522, 79515, 14132, 14124, 79523, 81364, 14419, 81372, 80993, 81365, 14421, 81373, 
80996, 80970, 14422, 14405, 80995
29202, 79515, 14132, 14124, 79523, 79516, 14133, 14125, 79524, 81365, 14421, 81373, 80996, 81366, 14423, 81374, 
80999, 80973, 14424, 14407, 80998
29203, 79516, 14133, 14125, 79524, 79517, 14134, 14126, 79525, 81366, 14423, 81374, 80999, 81367, 14425, 81375, 
81002, 80976, 14426, 14409, 81001
29204, 79517, 14134, 14126, 79525, 13778, 1898, 1897, 13779, 81367, 14425, 81375, 81002, 13935, 1920, 13936, 
13901, 80979, 14427, 14410, 81004
29205, 13556, 1845, 1844, 13557, 79518, 14119, 14111, 79526, 13713, 1867, 13714, 13681, 81368, 14394, 81376, 
81006, 80980, 14395, 14378, 81005
29206, 79518, 14119, 14111, 79526, 79519, 14120, 14112, 79527, 81368, 14394, 81376, 81006, 81369, 14396, 81377, 
81009, 80983, 14397, 14380, 81008
29207, 79519, 14120, 14112, 79527, 79520, 14121, 14113, 79528, 81369, 14396, 81377, 81009, 81370, 14398, 81378, 
81012, 80986, 14399, 14382, 81011
29208, 79520, 14121, 14113, 79528, 79521, 14122, 14114, 79529, 81370, 14398, 81378, 81012, 81371, 14400, 81379, 
81015, 80989, 14401, 14384, 81014
29209, 79521, 14122, 14114, 79529, 79522, 14123, 14115, 79530, 81371, 14400, 81379, 81015, 81372, 14402, 81380, 
81018, 80992, 14403, 14386, 81017
29210, 79522, 14123, 14115, 79530, 79523, 14124, 14116, 79531, 81372, 14402, 81380, 81018, 81373, 14404, 81381, 
81021, 80995, 14405, 14388, 81020
29211, 79523, 14124, 14116, 79531, 79524, 14125, 14117, 79532, 81373, 14404, 81381, 81021, 81374, 14406, 81382, 
81024, 80998, 14407, 14390, 81023
29212, 79524, 14125, 14117, 79532, 79525, 14126, 14118, 79533, 81374, 14406, 81382, 81024, 81375, 14408, 81383, 
81027, 81001, 14409, 14392, 81026
29213, 79525, 14126, 14118, 79533, 13779, 1897, 1896, 13780, 81375, 14408, 81383, 81027, 13936, 1919, 13937, 
13903, 81004, 14410, 14393, 81029
29214, 13557, 1844, 1843, 13558, 79526, 14111, 14103, 79534, 13714, 1866, 13715, 13683, 81376, 14377, 81384, 
81031, 81005, 14378, 14361, 81030
29215, 79526, 14111, 14103, 79534, 79527, 14112, 14104, 79535, 81376, 14377, 81384, 81031, 81377, 14379, 81385, 
81034, 81008, 14380, 14363, 81033
29216, 79527, 14112, 14104, 79535, 79528, 14113, 14105, 79536, 81377, 14379, 81385, 81034, 81378, 14381, 81386, 
81037, 81011, 14382, 14365, 81036
29217, 79528, 14113, 14105, 79536, 79529, 14114, 14106, 79537, 81378, 14381, 81386, 81037, 81379, 14383, 81387, 
81040, 81014, 14384, 14367, 81039
29218, 79529, 14114, 14106, 79537, 79530, 14115, 14107, 79538, 81379, 14383, 81387, 81040, 81380, 14385, 81388, 
81043, 81017, 14386, 14369, 81042
29219, 79530, 14115, 14107, 79538, 79531, 14116, 14108, 79539, 81380, 14385, 81388, 81043, 81381, 14387, 81389, 
81046, 81020, 14388, 14371, 81045
