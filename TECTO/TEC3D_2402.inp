54609, 0.43478260869565, 1.3239130434783, 0.44444444444444
54610, 0.39130434782609, 1.3239130434783, 0.055555555555556
54611, 0.39130434782609, 1.3239130434783, 0.11111111111111
54612, 0.39130434782609, 1.3239130434783, 0.16666666666667
54613, 0.39130434782609, 1.3239130434783, 0.22222222222222
54614, 0.39130434782609, 1.3239130434783, 0.27777777777778
54615, 0.39130434782609, 1.3239130434783, 0.33333333333333
54616, 0.39130434782609, 1.3239130434783, 0.38888888888889
54617, 0.39130434782609, 1.3239130434783, 0.44444444444444
54618, 0.34782608695652, 1.3239130434783, 0.055555555555556
54619, 0.34782608695652, 1.3239130434783, 0.11111111111111
54620, 0.34782608695652, 1.3239130434783, 0.16666666666667
54621, 0.34782608695652, 1.3239130434783, 0.22222222222222
54622, 0.34782608695652, 1.3239130434783, 0.27777777777778
54623, 0.34782608695652, 1.3239130434783, 0.33333333333333
54624, 0.34782608695652, 1.3239130434783, 0.38888888888889
54625, 0.34782608695652, 1.3239130434783, 0.44444444444444
54626, 0.30434782608696, 1.3239130434783, 0.055555555555556
54627, 0.30434782608696, 1.3239130434783, 0.11111111111111
54628, 0.30434782608696, 1.3239130434783, 0.16666666666667
54629, 0.30434782608696, 1.3239130434783, 0.22222222222222
54630, 0.30434782608696, 1.3239130434783, 0.27777777777778
54631, 0.30434782608696, 1.3239130434783, 0.33333333333333
54632, 0.30434782608696, 1.3239130434783, 0.38888888888889
54633, 0.30434782608696, 1.3239130434783, 0.44444444444444
54634, 0.26086956521739, 1.3239130434783, 0.055555555555556
54635, 0.26086956521739, 1.3239130434783, 0.11111111111111
54636, 0.26086956521739, 1.3239130434783, 0.16666666666667
54637, 0.26086956521739, 1.3239130434783, 0.22222222222222
54638, 0.26086956521739, 1.3239130434783, 0.27777777777778
54639, 0.26086956521739, 1.3239130434783, 0.33333333333333
54640, 0.26086956521739, 1.3239130434783, 0.38888888888889
54641, 0.26086956521739, 1.3239130434783, 0.44444444444444
54642, 0.21739130434783, 1.3239130434783, 0.055555555555556
54643, 0.21739130434783, 1.3239130434783, 0.11111111111111
54644, 0.21739130434783, 1.3239130434783, 0.16666666666667
54645, 0.21739130434783, 1.3239130434783, 0.22222222222222
54646, 0.21739130434783, 1.3239130434783, 0.27777777777778
54647, 0.21739130434783, 1.3239130434783, 0.33333333333333
54648, 0.21739130434783, 1.3239130434783, 0.38888888888889
54649, 0.21739130434783, 1.3239130434783, 0.44444444444444
54650, 0.17391304347826, 1.3239130434783, 0.055555555555556
54651, 0.17391304347826, 1.3239130434783, 0.11111111111111
54652, 0.17391304347826, 1.3239130434783, 0.16666666666667
54653, 0.17391304347826, 1.3239130434783, 0.22222222222222
54654, 0.17391304347826, 1.3239130434783, 0.27777777777778
54655, 0.17391304347826, 1.3239130434783, 0.33333333333333
54656, 0.17391304347826, 1.3239130434783, 0.38888888888889
54657, 0.17391304347826, 1.3239130434783, 0.44444444444444
54658, 0.1304347826087, 1.3239130434783, 0.055555555555556
54659, 0.1304347826087, 1.3239130434783, 0.11111111111111
54660, 0.1304347826087, 1.3239130434783, 0.16666666666667
54661, 0.1304347826087, 1.3239130434783, 0.22222222222222
54662, 0.1304347826087, 1.3239130434783, 0.27777777777778
54663, 0.1304347826087, 1.3239130434783, 0.33333333333333
54664, 0.1304347826087, 1.3239130434783, 0.38888888888889
54665, 0.1304347826087, 1.3239130434783, 0.44444444444444
54666, 0.08695652173913, 1.3239130434783, 0.055555555555556
54667, 0.08695652173913, 1.3239130434783, 0.11111111111111
54668, 0.08695652173913, 1.3239130434783, 0.16666666666667
54669, 0.08695652173913, 1.3239130434783, 0.22222222222222
54670, 0.08695652173913, 1.3239130434783, 0.27777777777778
54671, 0.08695652173913, 1.3239130434783, 0.33333333333333
54672, 0.08695652173913, 1.3239130434783, 0.38888888888889
54673, 0.08695652173913, 1.3239130434783, 0.44444444444444
54674, 0.043478260869565, 1.3239130434783, 0.055555555555556
54675, 0.043478260869565, 1.3239130434783, 0.11111111111111
54676, 0.043478260869565, 1.3239130434783, 0.16666666666667
54677, 0.043478260869565, 1.3239130434783, 0.22222222222222
54678, 0.043478260869565, 1.3239130434783, 0.27777777777778
54679, 0.043478260869565, 1.3239130434783, 0.33333333333333
54680, 0.043478260869565, 1.3239130434783, 0.38888888888889
54681, 0.043478260869565, 1.3239130434783, 0.44444444444444
54682, 0.95652173913043, 1.425, 0.055555555555556
54683, 0.95652173913044, 1.425, 0.11111111111111
54684, 0.95652173913044, 1.425, 0.16666666666667
54685, 0.95652173913044, 1.425, 0.22222222222222
54686, 0.95652173913044, 1.425, 0.27777777777778
54687, 0.95652173913044, 1.425, 0.33333333333333
54688, 0.95652173913044, 1.425, 0.38888888888889
54689, 0.95652173913044, 1.425, 0.44444444444444
54690, 0.91304347826087, 1.425, 0.055555555555556
54691, 0.91304347826087, 1.425, 0.11111111111111
54692, 0.91304347826087, 1.425, 0.16666666666667
54693, 0.91304347826087, 1.425, 0.22222222222222
54694, 0.91304347826087, 1.425, 0.27777777777778
54695, 0.91304347826087, 1.425, 0.33333333333333
54696, 0.91304347826087, 1.425, 0.38888888888889
54697, 0.91304347826087, 1.425, 0.44444444444444
54698, 0.8695652173913, 1.425, 0.055555555555556
54699, 0.8695652173913, 1.425, 0.11111111111111
54700, 0.8695652173913, 1.425, 0.16666666666667
54701, 0.8695652173913, 1.425, 0.22222222222222
54702, 0.8695652173913, 1.425, 0.27777777777778
54703, 0.8695652173913, 1.425, 0.33333333333333
54704, 0.8695652173913, 1.425, 0.38888888888889
54705, 0.8695652173913, 1.425, 0.44444444444444
54706, 0.82608695652174, 1.425, 0.055555555555556
54707, 0.82608695652174, 1.425, 0.11111111111111
54708, 0.82608695652174, 1.425, 0.16666666666667
54709, 0.82608695652174, 1.425, 0.22222222222222
54710, 0.82608695652174, 1.425, 0.27777777777778
54711, 0.82608695652174, 1.425, 0.33333333333333
54712, 0.82608695652174, 1.425, 0.38888888888889
54713, 0.82608695652174, 1.425, 0.44444444444444
54714, 0.78260869565217, 1.425, 0.055555555555556
54715, 0.78260869565217, 1.425, 0.11111111111111
54716, 0.78260869565217, 1.425, 0.16666666666667
54717, 0.78260869565217, 1.425, 0.22222222222222
54718, 0.78260869565217, 1.425, 0.27777777777778
54719, 0.78260869565217, 1.425, 0.33333333333333
54720, 0.78260869565217, 1.425, 0.38888888888889
54721, 0.78260869565217, 1.425, 0.44444444444444
54722, 0.73913043478261, 1.425, 0.055555555555556
54723, 0.73913043478261, 1.425, 0.11111111111111
54724, 0.73913043478261, 1.425, 0.16666666666667
54725, 0.73913043478261, 1.425, 0.22222222222222
54726, 0.73913043478261, 1.425, 0.27777777777778
54727, 0.73913043478261, 1.425, 0.33333333333333
54728, 0.73913043478261, 1.425, 0.38888888888889
54729, 0.73913043478261, 1.425, 0.44444444444444
54730, 0.69565217391304, 1.425, 0.055555555555556
54731, 0.69565217391304, 1.425, 0.11111111111111
54732, 0.69565217391304, 1.425, 0.16666666666667
54733, 0.69565217391304, 1.425, 0.22222222222222
54734, 0.69565217391304, 1.425, 0.27777777777778
54735, 0.69565217391304, 1.425, 0.33333333333333
54736, 0.69565217391304, 1.425, 0.38888888888889
54737, 0.69565217391304, 1.425, 0.44444444444444
54738, 0.65217391304348, 1.425, 0.055555555555556
54739, 0.65217391304348, 1.425, 0.11111111111111
54740, 0.65217391304348, 1.425, 0.16666666666667
54741, 0.65217391304348, 1.425, 0.22222222222222
54742, 0.65217391304348, 1.425, 0.27777777777778
54743, 0.65217391304348, 1.425, 0.33333333333333
54744, 0.65217391304348, 1.425, 0.38888888888889
54745, 0.65217391304348, 1.425, 0.44444444444444
54746, 0.60869565217391, 1.425, 0.055555555555556
54747, 0.60869565217391, 1.425, 0.11111111111111
54748, 0.60869565217391, 1.425, 0.16666666666667
54749, 0.60869565217391, 1.425, 0.22222222222222
54750, 0.60869565217391, 1.425, 0.27777777777778
54751, 0.60869565217391, 1.425, 0.33333333333333
54752, 0.60869565217391, 1.425, 0.38888888888889
54753, 0.60869565217391, 1.425, 0.44444444444444
54754, 0.56521739130435, 1.425, 0.055555555555556
54755, 0.56521739130435, 1.425, 0.11111111111111
54756, 0.56521739130435, 1.425, 0.16666666666667
54757, 0.56521739130435, 1.425, 0.22222222222222
54758, 0.56521739130435, 1.425, 0.27777777777778
54759, 0.56521739130435, 1.425, 0.33333333333333
54760, 0.56521739130435, 1.425, 0.38888888888889
54761, 0.56521739130435, 1.425, 0.44444444444444
54762, 0.52173913043478, 1.425, 0.055555555555556
54763, 0.52173913043478, 1.425, 0.11111111111111
54764, 0.52173913043478, 1.425, 0.16666666666667
54765, 0.52173913043478, 1.425, 0.22222222222222
54766, 0.52173913043478, 1.425, 0.27777777777778
54767, 0.52173913043478, 1.425, 0.33333333333333
54768, 0.52173913043478, 1.425, 0.38888888888889
54769, 0.52173913043478, 1.425, 0.44444444444444
54770, 0.47826086956522, 1.425, 0.055555555555556
54771, 0.47826086956522, 1.425, 0.11111111111111
54772, 0.47826086956522, 1.425, 0.16666666666667
54773, 0.47826086956522, 1.425, 0.22222222222222
54774, 0.47826086956522, 1.425, 0.27777777777778
54775, 0.47826086956522, 1.425, 0.33333333333333
54776, 0.47826086956522, 1.425, 0.38888888888889
54777, 0.47826086956522, 1.425, 0.44444444444444
54778, 0.43478260869565, 1.425, 0.055555555555556
54779, 0.43478260869565, 1.425, 0.11111111111111
54780, 0.43478260869565, 1.425, 0.16666666666667
54781, 0.43478260869565, 1.425, 0.22222222222222
54782, 0.43478260869565, 1.425, 0.27777777777778
54783, 0.43478260869565, 1.425, 0.33333333333333
54784, 0.43478260869565, 1.425, 0.38888888888889
54785, 0.43478260869565, 1.425, 0.44444444444444
54786, 0.39130434782609, 1.425, 0.055555555555556
54787, 0.39130434782609, 1.425, 0.11111111111111
54788, 0.39130434782609, 1.425, 0.16666666666667
54789, 0.39130434782609, 1.425, 0.22222222222222
54790, 0.39130434782609, 1.425, 0.27777777777778
54791, 0.39130434782609, 1.425, 0.33333333333333
54792, 0.39130434782609, 1.425, 0.38888888888889
54793, 0.39130434782609, 1.425, 0.44444444444444
54794, 0.34782608695652, 1.425, 0.055555555555556
54795, 0.34782608695652, 1.425, 0.11111111111111
54796, 0.34782608695652, 1.425, 0.16666666666667
54797, 0.34782608695652, 1.425, 0.22222222222222
54798, 0.34782608695652, 1.425, 0.27777777777778
54799, 0.34782608695652, 1.425, 0.33333333333333
54800, 0.34782608695652, 1.425, 0.38888888888889
54801, 0.34782608695652, 1.425, 0.44444444444444
54802, 0.30434782608696, 1.425, 0.055555555555556
54803, 0.30434782608696, 1.425, 0.11111111111111
54804, 0.30434782608696, 1.425, 0.16666666666667
54805, 0.30434782608696, 1.425, 0.22222222222222
54806, 0.30434782608696, 1.425, 0.27777777777778
54807, 0.30434782608696, 1.425, 0.33333333333333
54808, 0.30434782608696, 1.425, 0.38888888888889
54809, 0.30434782608696, 1.425, 0.44444444444444
54810, 0.26086956521739, 1.425, 0.055555555555556
54811, 0.26086956521739, 1.425, 0.11111111111111
54812, 0.26086956521739, 1.425, 0.16666666666667
54813, 0.26086956521739, 1.425, 0.22222222222222
54814, 0.26086956521739, 1.425, 0.27777777777778
54815, 0.26086956521739, 1.425, 0.33333333333333
54816, 0.26086956521739, 1.425, 0.38888888888889
54817, 0.26086956521739, 1.425, 0.44444444444444
54818, 0.21739130434783, 1.425, 0.055555555555556
54819, 0.21739130434783, 1.425, 0.11111111111111
54820, 0.21739130434783, 1.425, 0.16666666666667
54821, 0.21739130434783, 1.425, 0.22222222222222
54822, 0.21739130434783, 1.425, 0.27777777777778
54823, 0.21739130434783, 1.425, 0.33333333333333
54824, 0.21739130434783, 1.425, 0.38888888888889
54825, 0.21739130434783, 1.425, 0.44444444444444
54826, 0.17391304347826, 1.425, 0.055555555555556
54827, 0.17391304347826, 1.425, 0.11111111111111
54828, 0.17391304347826, 1.425, 0.16666666666667
54829, 0.17391304347826, 1.425, 0.22222222222222
54830, 0.17391304347826, 1.425, 0.27777777777778
54831, 0.17391304347826, 1.425, 0.33333333333333
54832, 0.17391304347826, 1.425, 0.38888888888889
54833, 0.17391304347826, 1.425, 0.44444444444444
54834, 0.1304347826087, 1.425, 0.055555555555556
54835, 0.1304347826087, 1.425, 0.11111111111111
54836, 0.1304347826087, 1.425, 0.16666666666667
54837, 0.1304347826087, 1.425, 0.22222222222222
54838, 0.1304347826087, 1.425, 0.27777777777778
54839, 0.1304347826087, 1.425, 0.33333333333333
54840, 0.1304347826087, 1.425, 0.38888888888889
54841, 0.1304347826087, 1.425, 0.44444444444444
54842, 0.08695652173913, 1.425, 0.055555555555556
54843, 0.08695652173913, 1.425, 0.11111111111111
54844, 0.08695652173913, 1.425, 0.16666666666667
54845, 0.08695652173913, 1.425, 0.22222222222222
54846, 0.08695652173913, 1.425, 0.27777777777778
54847, 0.08695652173913, 1.425, 0.33333333333333
54848, 0.08695652173913, 1.425, 0.38888888888889
54849, 0.08695652173913, 1.425, 0.44444444444444
54850, 0.043478260869565, 1.425, 0.055555555555556
54851, 0.043478260869565, 1.425, 0.11111111111111
54852, 0.043478260869565, 1.425, 0.16666666666667
54853, 0.043478260869565, 1.425, 0.22222222222222
54854, 0.043478260869565, 1.425, 0.27777777777778
54855, 0.043478260869565, 1.425, 0.33333333333333
54856, 0.043478260869565, 1.425, 0.38888888888889
54857, 0.043478260869565, 1.425, 0.44444444444444
54858, 0.95652173913043, 1.425, 0.027777777777778
54859, 0.97826086956522, 1.425, 0.055555555555556
54860, 0.95652173913043, 1.4125, 0.055555555555556
54861, 0.95652173913043, 1.425, 0.083333333333333
54862, 0.97826086956522, 1.425, 0.11111111111111
54863, 0.95652173913044, 1.4125, 0.11111111111111
54864, 0.95652173913044, 1.425, 0.13888888888889
54865, 0.97826086956522, 1.425, 0.16666666666667
54866, 0.95652173913044, 1.4125, 0.16666666666667
54867, 0.95652173913044, 1.425, 0.19444444444444
54868, 0.97826086956522, 1.425, 0.22222222222222
54869, 0.95652173913043, 1.4125, 0.22222222222222
54870, 0.95652173913044, 1.425, 0.25
54871, 0.97826086956522, 1.425, 0.27777777777778
54872, 0.95652173913043, 1.4125, 0.27777777777778
54873, 0.95652173913044, 1.425, 0.30555555555556
54874, 0.97826086956522, 1.425, 0.33333333333333
54875, 0.95652173913043, 1.4125, 0.33333333333333
54876, 0.95652173913044, 1.425, 0.36111111111111
54877, 0.97826086956522, 1.425, 0.38888888888889
54878, 0.95652173913043, 1.4125, 0.38888888888889
54879, 0.95652173913044, 1.425, 0.41666666666667
54880, 0.97826086956522, 1.425, 0.44444444444444
54881, 0.95652173913043, 1.4125, 0.44444444444444
54882, 0.95652173913043, 1.425, 0.47222222222222
54883, 0.91304347826087, 1.425, 0.027777777777778
54884, 0.93478260869565, 1.425, 0.055555555555556
54885, 0.91304347826087, 1.4125, 0.055555555555556
54886, 0.91304347826087, 1.425, 0.083333333333333
54887, 0.93478260869565, 1.425, 0.11111111111111
54888, 0.91304347826087, 1.4125, 0.11111111111111
54889, 0.91304347826087, 1.425, 0.13888888888889
54890, 0.93478260869565, 1.425, 0.16666666666667
54891, 0.91304347826087, 1.4125, 0.16666666666667
54892, 0.91304347826087, 1.425, 0.19444444444444
54893, 0.93478260869565, 1.425, 0.22222222222222
54894, 0.91304347826087, 1.4125, 0.22222222222222
54895, 0.91304347826087, 1.425, 0.25
54896, 0.93478260869565, 1.425, 0.27777777777778
54897, 0.91304347826087, 1.4125, 0.27777777777778
54898, 0.91304347826087, 1.425, 0.30555555555556
54899, 0.93478260869565, 1.425, 0.33333333333333
54900, 0.91304347826087, 1.4125, 0.33333333333333
54901, 0.91304347826087, 1.425, 0.36111111111111
54902, 0.93478260869565, 1.425, 0.38888888888889
54903, 0.91304347826087, 1.4125, 0.38888888888889
54904, 0.91304347826087, 1.425, 0.41666666666667
54905, 0.93478260869565, 1.425, 0.44444444444444
54906, 0.91304347826087, 1.4125, 0.44444444444444
54907, 0.91304347826087, 1.425, 0.47222222222222
54908, 0.8695652173913, 1.425, 0.027777777777778
54909, 0.89130434782609, 1.425, 0.055555555555556
54910, 0.8695652173913, 1.4125, 0.055555555555556
54911, 0.8695652173913, 1.425, 0.083333333333333
54912, 0.89130434782609, 1.425, 0.11111111111111
54913, 0.8695652173913, 1.4125, 0.11111111111111
54914, 0.8695652173913, 1.425, 0.13888888888889
54915, 0.89130434782609, 1.425, 0.16666666666667
54916, 0.8695652173913, 1.4125, 0.16666666666667
54917, 0.8695652173913, 1.425, 0.19444444444444
54918, 0.89130434782609, 1.425, 0.22222222222222
54919, 0.8695652173913, 1.4125, 0.22222222222222
54920, 0.8695652173913, 1.425, 0.25
54921, 0.89130434782609, 1.425, 0.27777777777778
54922, 0.8695652173913, 1.4125, 0.27777777777778
54923, 0.8695652173913, 1.425, 0.30555555555556
54924, 0.89130434782609, 1.425, 0.33333333333333
54925, 0.8695652173913, 1.4125, 0.33333333333333
54926, 0.8695652173913, 1.425, 0.36111111111111
54927, 0.89130434782609, 1.425, 0.38888888888889
54928, 0.8695652173913, 1.4125, 0.38888888888889
54929, 0.8695652173913, 1.425, 0.41666666666667
54930, 0.89130434782609, 1.425, 0.44444444444444
54931, 0.8695652173913, 1.4125, 0.44444444444444
54932, 0.8695652173913, 1.425, 0.47222222222222
54933, 0.82608695652174, 1.425, 0.027777777777778
54934, 0.84782608695652, 1.425, 0.055555555555556
54935, 0.82608695652174, 1.4125, 0.055555555555556
54936, 0.82608695652174, 1.425, 0.083333333333333
54937, 0.84782608695652, 1.425, 0.11111111111111
54938, 0.82608695652174, 1.4125, 0.11111111111111
54939, 0.82608695652174, 1.425, 0.13888888888889
54940, 0.84782608695652, 1.425, 0.16666666666667
54941, 0.82608695652174, 1.4125, 0.16666666666667
54942, 0.82608695652174, 1.425, 0.19444444444444
54943, 0.84782608695652, 1.425, 0.22222222222222
54944, 0.82608695652174, 1.4125, 0.22222222222222
54945, 0.82608695652174, 1.425, 0.25
54946, 0.84782608695652, 1.425, 0.27777777777778
54947, 0.82608695652174, 1.4125, 0.27777777777778
54948, 0.82608695652174, 1.425, 0.30555555555556
54949, 0.84782608695652, 1.425, 0.33333333333333
54950, 0.82608695652174, 1.4125, 0.33333333333333
54951, 0.82608695652174, 1.425, 0.36111111111111
54952, 0.84782608695652, 1.425, 0.38888888888889
54953, 0.82608695652174, 1.4125, 0.38888888888889
54954, 0.82608695652174, 1.425, 0.41666666666667
54955, 0.84782608695652, 1.425, 0.44444444444444
54956, 0.82608695652174, 1.4125, 0.44444444444444
54957, 0.82608695652174, 1.425, 0.47222222222222
54958, 0.78260869565217, 1.425, 0.027777777777778
54959, 0.80434782608696, 1.425, 0.055555555555556
54960, 0.78260869565217, 1.4125, 0.055555555555556
54961, 0.78260869565217, 1.425, 0.083333333333333
54962, 0.80434782608696, 1.425, 0.11111111111111
54963, 0.78260869565217, 1.4125, 0.11111111111111
54964, 0.78260869565217, 1.425, 0.13888888888889
54965, 0.80434782608696, 1.425, 0.16666666666667
54966, 0.78260869565217, 1.4125, 0.16666666666667
54967, 0.78260869565217, 1.425, 0.19444444444444
54968, 0.80434782608696, 1.425, 0.22222222222222
54969, 0.78260869565217, 1.4125, 0.22222222222222
54970, 0.78260869565217, 1.425, 0.25
54971, 0.80434782608696, 1.425, 0.27777777777778
54972, 0.78260869565217, 1.4125, 0.27777777777778
54973, 0.78260869565217, 1.425, 0.30555555555556
54974, 0.80434782608696, 1.425, 0.33333333333333
54975, 0.78260869565217, 1.4125, 0.33333333333333
54976, 0.78260869565217, 1.425, 0.36111111111111
54977, 0.80434782608696, 1.425, 0.38888888888889
54978, 0.78260869565217, 1.4125, 0.38888888888889
54979, 0.78260869565217, 1.425, 0.41666666666667
54980, 0.80434782608696, 1.425, 0.44444444444444
54981, 0.78260869565217, 1.4125, 0.44444444444444
54982, 0.78260869565217, 1.425, 0.47222222222222
54983, 0.73913043478261, 1.425, 0.027777777777778
54984, 0.76086956521739, 1.425, 0.055555555555556
54985, 0.73913043478261, 1.4125, 0.055555555555556
54986, 0.73913043478261, 1.425, 0.083333333333333
54987, 0.76086956521739, 1.425, 0.11111111111111
54988, 0.73913043478261, 1.4125, 0.11111111111111
54989, 0.73913043478261, 1.425, 0.13888888888889
54990, 0.76086956521739, 1.425, 0.16666666666667
54991, 0.73913043478261, 1.4125, 0.16666666666667
54992, 0.73913043478261, 1.425, 0.19444444444444
54993, 0.76086956521739, 1.425, 0.22222222222222
54994, 0.73913043478261, 1.4125, 0.22222222222222
54995, 0.73913043478261, 1.425, 0.25
54996, 0.76086956521739, 1.425, 0.27777777777778
54997, 0.73913043478261, 1.4125, 0.27777777777778
54998, 0.73913043478261, 1.425, 0.30555555555556
54999, 0.76086956521739, 1.425, 0.33333333333333
55000, 0.73913043478261, 1.4125, 0.33333333333333
55001, 0.73913043478261, 1.425, 0.36111111111111
55002, 0.76086956521739, 1.425, 0.38888888888889
55003, 0.73913043478261, 1.4125, 0.38888888888889
55004, 0.73913043478261, 1.425, 0.41666666666667
55005, 0.76086956521739, 1.425, 0.44444444444444
55006, 0.73913043478261, 1.4125, 0.44444444444444
55007, 0.73913043478261, 1.425, 0.47222222222222
55008, 0.69565217391304, 1.425, 0.027777777777778
55009, 0.71739130434783, 1.425, 0.055555555555556
55010, 0.69565217391304, 1.4125, 0.055555555555556
55011, 0.69565217391304, 1.425, 0.083333333333333
55012, 0.71739130434783, 1.425, 0.11111111111111
55013, 0.69565217391304, 1.4125, 0.11111111111111
55014, 0.69565217391304, 1.425, 0.13888888888889
55015, 0.71739130434783, 1.425, 0.16666666666667
55016, 0.69565217391304, 1.4125, 0.16666666666667
55017, 0.69565217391304, 1.425, 0.19444444444444
55018, 0.71739130434783, 1.425, 0.22222222222222
55019, 0.69565217391304, 1.4125, 0.22222222222222
55020, 0.69565217391304, 1.425, 0.25
55021, 0.71739130434783, 1.425, 0.27777777777778
55022, 0.69565217391304, 1.4125, 0.27777777777778
55023, 0.69565217391304, 1.425, 0.30555555555556
55024, 0.71739130434783, 1.425, 0.33333333333333
55025, 0.69565217391304, 1.4125, 0.33333333333333
55026, 0.69565217391304, 1.425, 0.36111111111111
55027, 0.71739130434783, 1.425, 0.38888888888889
55028, 0.69565217391304, 1.4125, 0.38888888888889
55029, 0.69565217391304, 1.425, 0.41666666666667
55030, 0.71739130434783, 1.425, 0.44444444444444
55031, 0.69565217391304, 1.4125, 0.44444444444444
55032, 0.69565217391304, 1.425, 0.47222222222222
55033, 0.65217391304348, 1.425, 0.027777777777778
55034, 0.67391304347826, 1.425, 0.055555555555556
55035, 0.65217391304348, 1.4125, 0.055555555555556
55036, 0.65217391304348, 1.425, 0.083333333333333
55037, 0.67391304347826, 1.425, 0.11111111111111
55038, 0.65217391304348, 1.4125, 0.11111111111111
55039, 0.65217391304348, 1.425, 0.13888888888889
55040, 0.67391304347826, 1.425, 0.16666666666667
55041, 0.65217391304348, 1.4125, 0.16666666666667
55042, 0.65217391304348, 1.425, 0.19444444444444
55043, 0.67391304347826, 1.425, 0.22222222222222
55044, 0.65217391304348, 1.4125, 0.22222222222222
55045, 0.65217391304348, 1.425, 0.25
55046, 0.67391304347826, 1.425, 0.27777777777778
55047, 0.65217391304348, 1.4125, 0.27777777777778
55048, 0.65217391304348, 1.425, 0.30555555555556
55049, 0.67391304347826, 1.425, 0.33333333333333
55050, 0.65217391304348, 1.4125, 0.33333333333333
55051, 0.65217391304348, 1.425, 0.36111111111111
55052, 0.67391304347826, 1.425, 0.38888888888889
55053, 0.65217391304348, 1.4125, 0.38888888888889
55054, 0.65217391304348, 1.425, 0.41666666666667
55055, 0.67391304347826, 1.425, 0.44444444444444
55056, 0.65217391304348, 1.4125, 0.44444444444444
55057, 0.65217391304348, 1.425, 0.47222222222222
55058, 0.60869565217391, 1.425, 0.027777777777778
55059, 0.6304347826087, 1.425, 0.055555555555556
55060, 0.60869565217391, 1.4125, 0.055555555555556
55061, 0.60869565217391, 1.425, 0.083333333333333
55062, 0.6304347826087, 1.425, 0.11111111111111
55063, 0.60869565217391, 1.4125, 0.11111111111111
55064, 0.60869565217391, 1.425, 0.13888888888889
55065, 0.6304347826087, 1.425, 0.16666666666667
55066, 0.60869565217391, 1.4125, 0.16666666666667
55067, 0.60869565217391, 1.425, 0.19444444444444
55068, 0.6304347826087, 1.425, 0.22222222222222
55069, 0.60869565217391, 1.4125, 0.22222222222222
55070, 0.60869565217391, 1.425, 0.25
55071, 0.6304347826087, 1.425, 0.27777777777778
55072, 0.60869565217391, 1.4125, 0.27777777777778
55073, 0.60869565217391, 1.425, 0.30555555555556
55074, 0.6304347826087, 1.425, 0.33333333333333
55075, 0.60869565217391, 1.4125, 0.33333333333333
55076, 0.60869565217391, 1.425, 0.36111111111111
55077, 0.6304347826087, 1.425, 0.38888888888889
55078, 0.60869565217391, 1.4125, 0.38888888888889
55079, 0.60869565217391, 1.425, 0.41666666666667
55080, 0.6304347826087, 1.425, 0.44444444444444
55081, 0.60869565217391, 1.4125, 0.44444444444444
55082, 0.60869565217391, 1.425, 0.47222222222222
55083, 0.56521739130435, 1.425, 0.027777777777778
55084, 0.58695652173913, 1.425, 0.055555555555556
55085, 0.56521739130435, 1.4125, 0.055555555555556
55086, 0.56521739130435, 1.425, 0.083333333333333
55087, 0.58695652173913, 1.425, 0.11111111111111
55088, 0.56521739130435, 1.4125, 0.11111111111111
55089, 0.56521739130435, 1.425, 0.13888888888889
55090, 0.58695652173913, 1.425, 0.16666666666667
55091, 0.56521739130435, 1.4125, 0.16666666666667
55092, 0.56521739130435, 1.425, 0.19444444444444
55093, 0.58695652173913, 1.425, 0.22222222222222
55094, 0.56521739130435, 1.4125, 0.22222222222222
55095, 0.56521739130435, 1.425, 0.25
55096, 0.58695652173913, 1.425, 0.27777777777778
55097, 0.56521739130435, 1.4125, 0.27777777777778
55098, 0.56521739130435, 1.425, 0.30555555555556
55099, 0.58695652173913, 1.425, 0.33333333333333
55100, 0.56521739130435, 1.4125, 0.33333333333333
55101, 0.56521739130435, 1.425, 0.36111111111111
55102, 0.58695652173913, 1.425, 0.38888888888889
55103, 0.56521739130435, 1.4125, 0.38888888888889
55104, 0.56521739130435, 1.425, 0.41666666666667
55105, 0.58695652173913, 1.425, 0.44444444444444
55106, 0.56521739130435, 1.4125, 0.44444444444444
55107, 0.56521739130435, 1.425, 0.47222222222222
55108, 0.52173913043478, 1.425, 0.027777777777778
55109, 0.54347826086957, 1.425, 0.055555555555556
55110, 0.52173913043478, 1.4125, 0.055555555555556
55111, 0.52173913043478, 1.425, 0.083333333333333
55112, 0.54347826086957, 1.425, 0.11111111111111
55113, 0.52173913043478, 1.4125, 0.11111111111111
55114, 0.52173913043478, 1.425, 0.13888888888889
55115, 0.54347826086957, 1.425, 0.16666666666667
55116, 0.52173913043478, 1.4125, 0.16666666666667
55117, 0.52173913043478, 1.425, 0.19444444444444
55118, 0.54347826086956, 1.425, 0.22222222222222
55119, 0.52173913043478, 1.4125, 0.22222222222222
55120, 0.52173913043478, 1.425, 0.25
55121, 0.54347826086956, 1.425, 0.27777777777778
55122, 0.52173913043478, 1.4125, 0.27777777777778
55123, 0.52173913043478, 1.425, 0.30555555555556
55124, 0.54347826086956, 1.425, 0.33333333333333
55125, 0.52173913043478, 1.4125, 0.33333333333333
55126, 0.52173913043478, 1.425, 0.36111111111111
55127, 0.54347826086956, 1.425, 0.38888888888889
55128, 0.52173913043478, 1.4125, 0.38888888888889
55129, 0.52173913043478, 1.425, 0.41666666666667
55130, 0.54347826086956, 1.425, 0.44444444444444
55131, 0.52173913043478, 1.4125, 0.44444444444444
55132, 0.52173913043478, 1.425, 0.47222222222222
55133, 0.47826086956522, 1.425, 0.027777777777778
55134, 0.5, 1.425, 0.055555555555556
55135, 0.47826086956522, 1.4125, 0.055555555555556
55136, 0.47826086956522, 1.425, 0.083333333333333
55137, 0.5, 1.425, 0.11111111111111
55138, 0.47826086956522, 1.4125, 0.11111111111111
55139, 0.47826086956522, 1.425, 0.13888888888889
55140, 0.5, 1.425, 0.16666666666667
55141, 0.47826086956522, 1.4125, 0.16666666666667
55142, 0.47826086956522, 1.425, 0.19444444444444
55143, 0.5, 1.425, 0.22222222222222
55144, 0.47826086956522, 1.4125, 0.22222222222222
55145, 0.47826086956522, 1.425, 0.25
55146, 0.5, 1.425, 0.27777777777778
55147, 0.47826086956522, 1.4125, 0.27777777777778
55148, 0.47826086956522, 1.425, 0.30555555555556
55149, 0.5, 1.425, 0.33333333333333
55150, 0.47826086956522, 1.4125, 0.33333333333333
55151, 0.47826086956522, 1.425, 0.36111111111111
55152, 0.5, 1.425, 0.38888888888889
55153, 0.47826086956522, 1.4125, 0.38888888888889
55154, 0.47826086956522, 1.425, 0.41666666666667
55155, 0.5, 1.425, 0.44444444444444
55156, 0.47826086956522, 1.4125, 0.44444444444444
55157, 0.47826086956522, 1.425, 0.47222222222222
55158, 0.43478260869565, 1.425, 0.027777777777778
55159, 0.45652173913043, 1.425, 0.055555555555556
55160, 0.43478260869565, 1.4125, 0.055555555555556
55161, 0.43478260869565, 1.425, 0.083333333333333
55162, 0.45652173913043, 1.425, 0.11111111111111
55163, 0.43478260869565, 1.4125, 0.11111111111111
55164, 0.43478260869565, 1.425, 0.13888888888889
55165, 0.45652173913043, 1.425, 0.16666666666667
55166, 0.43478260869565, 1.4125, 0.16666666666667
55167, 0.43478260869565, 1.425, 0.19444444444444
55168, 0.45652173913043, 1.425, 0.22222222222222
55169, 0.43478260869565, 1.4125, 0.22222222222222
55170, 0.43478260869565, 1.425, 0.25
55171, 0.45652173913043, 1.425, 0.27777777777778
55172, 0.43478260869565, 1.4125, 0.27777777777778
55173, 0.43478260869565, 1.425, 0.30555555555556
55174, 0.45652173913043, 1.425, 0.33333333333333
55175, 0.43478260869565, 1.4125, 0.33333333333333
55176, 0.43478260869565, 1.425, 0.36111111111111
55177, 0.45652173913044, 1.425, 0.38888888888889
55178, 0.43478260869565, 1.4125, 0.38888888888889
55179, 0.43478260869565, 1.425, 0.41666666666667
55180, 0.45652173913043, 1.425, 0.44444444444444
55181, 0.43478260869565, 1.4125, 0.44444444444444
55182, 0.43478260869565, 1.425, 0.47222222222222
55183, 0.39130434782609, 1.425, 0.027777777777778
55184, 0.41304347826087, 1.425, 0.055555555555556
55185, 0.39130434782609, 1.4125, 0.055555555555556
55186, 0.39130434782609, 1.425, 0.083333333333333
55187, 0.41304347826087, 1.425, 0.11111111111111
55188, 0.39130434782609, 1.4125, 0.11111111111111
55189, 0.39130434782609, 1.425, 0.13888888888889
55190, 0.41304347826087, 1.425, 0.16666666666667
55191, 0.39130434782609, 1.4125, 0.16666666666667
55192, 0.39130434782609, 1.425, 0.19444444444444
55193, 0.41304347826087, 1.425, 0.22222222222222
55194, 0.39130434782609, 1.4125, 0.22222222222222
55195, 0.39130434782609, 1.425, 0.25
55196, 0.41304347826087, 1.425, 0.27777777777778
55197, 0.39130434782609, 1.4125, 0.27777777777778
55198, 0.39130434782609, 1.425, 0.30555555555556
55199, 0.41304347826087, 1.425, 0.33333333333333
55200, 0.39130434782609, 1.4125, 0.33333333333333
55201, 0.39130434782609, 1.425, 0.36111111111111
55202, 0.41304347826087, 1.425, 0.38888888888889
55203, 0.39130434782609, 1.4125, 0.38888888888889
55204, 0.39130434782609, 1.425, 0.41666666666667
55205, 0.41304347826087, 1.425, 0.44444444444444
55206, 0.39130434782609, 1.4125, 0.44444444444444
55207, 0.39130434782609, 1.425, 0.47222222222222
55208, 0.34782608695652, 1.425, 0.027777777777778
55209, 0.3695652173913, 1.425, 0.055555555555556
55210, 0.34782608695652, 1.4125, 0.055555555555556
55211, 0.34782608695652, 1.425, 0.083333333333333
55212, 0.3695652173913, 1.425, 0.11111111111111
55213, 0.34782608695652, 1.4125, 0.11111111111111
55214, 0.34782608695652, 1.425, 0.13888888888889
55215, 0.3695652173913, 1.425, 0.16666666666667
55216, 0.34782608695652, 1.4125, 0.16666666666667
55217, 0.34782608695652, 1.425, 0.19444444444444
55218, 0.3695652173913, 1.425, 0.22222222222222
55219, 0.34782608695652, 1.4125, 0.22222222222222
55220, 0.34782608695652, 1.425, 0.25
55221, 0.3695652173913, 1.425, 0.27777777777778
55222, 0.34782608695652, 1.4125, 0.27777777777778
55223, 0.34782608695652, 1.425, 0.30555555555556
55224, 0.3695652173913, 1.425, 0.33333333333333
55225, 0.34782608695652, 1.4125, 0.33333333333333
55226, 0.34782608695652, 1.425, 0.36111111111111
55227, 0.3695652173913, 1.425, 0.38888888888889
55228, 0.34782608695652, 1.4125, 0.38888888888889
55229, 0.34782608695652, 1.425, 0.41666666666667
55230, 0.3695652173913, 1.425, 0.44444444444444
55231, 0.34782608695652, 1.4125, 0.44444444444444
55232, 0.34782608695652, 1.425, 0.47222222222222
55233, 0.30434782608696, 1.425, 0.027777777777778
55234, 0.32608695652174, 1.425, 0.055555555555556
55235, 0.30434782608696, 1.4125, 0.055555555555556
55236, 0.30434782608696, 1.425, 0.083333333333333
55237, 0.32608695652174, 1.425, 0.11111111111111
55238, 0.30434782608696, 1.4125, 0.11111111111111
55239, 0.30434782608696, 1.425, 0.13888888888889
55240, 0.32608695652174, 1.425, 0.16666666666667
55241, 0.30434782608696, 1.4125, 0.16666666666667
55242, 0.30434782608696, 1.425, 0.19444444444444
55243, 0.32608695652174, 1.425, 0.22222222222222
55244, 0.30434782608696, 1.4125, 0.22222222222222
55245, 0.30434782608696, 1.425, 0.25
55246, 0.32608695652174, 1.425, 0.27777777777778
55247, 0.30434782608696, 1.4125, 0.27777777777778
55248, 0.30434782608696, 1.425, 0.30555555555556
55249, 0.32608695652174, 1.425, 0.33333333333333
55250, 0.30434782608696, 1.4125, 0.33333333333333
55251, 0.30434782608696, 1.425, 0.36111111111111
55252, 0.32608695652174, 1.425, 0.38888888888889
55253, 0.30434782608696, 1.4125, 0.38888888888889
55254, 0.30434782608696, 1.425, 0.41666666666667
55255, 0.32608695652174, 1.425, 0.44444444444444
55256, 0.30434782608696, 1.4125, 0.44444444444444
55257, 0.30434782608696, 1.425, 0.47222222222222
55258, 0.26086956521739, 1.425, 0.027777777777778
55259, 0.28260869565217, 1.425, 0.055555555555556
55260, 0.26086956521739, 1.4125, 0.055555555555556
55261, 0.26086956521739, 1.425, 0.083333333333333
55262, 0.28260869565217, 1.425, 0.11111111111111
55263, 0.26086956521739, 1.4125, 0.11111111111111
55264, 0.26086956521739, 1.425, 0.13888888888889
55265, 0.28260869565217, 1.425, 0.16666666666667
55266, 0.26086956521739, 1.4125, 0.16666666666667
55267, 0.26086956521739, 1.425, 0.19444444444444
55268, 0.28260869565217, 1.425, 0.22222222222222
55269, 0.26086956521739, 1.4125, 0.22222222222222
55270, 0.26086956521739, 1.425, 0.25
55271, 0.28260869565217, 1.425, 0.27777777777778
55272, 0.26086956521739, 1.4125, 0.27777777777778
55273, 0.26086956521739, 1.425, 0.30555555555556
55274, 0.28260869565217, 1.425, 0.33333333333333
55275, 0.26086956521739, 1.4125, 0.33333333333333
55276, 0.26086956521739, 1.425, 0.36111111111111
55277, 0.28260869565217, 1.425, 0.38888888888889
55278, 0.26086956521739, 1.4125, 0.38888888888889
55279, 0.26086956521739, 1.425, 0.41666666666667
55280, 0.28260869565217, 1.425, 0.44444444444444
55281, 0.26086956521739, 1.4125, 0.44444444444444
55282, 0.26086956521739, 1.425, 0.47222222222222
55283, 0.21739130434783, 1.425, 0.027777777777778
55284, 0.23913043478261, 1.425, 0.055555555555556
55285, 0.21739130434783, 1.4125, 0.055555555555556
55286, 0.21739130434783, 1.425, 0.083333333333333
55287, 0.23913043478261, 1.425, 0.11111111111111
55288, 0.21739130434783, 1.4125, 0.11111111111111
55289, 0.21739130434783, 1.425, 0.13888888888889
55290, 0.23913043478261, 1.425, 0.16666666666667
55291, 0.21739130434783, 1.4125, 0.16666666666667
55292, 0.21739130434783, 1.425, 0.19444444444444
55293, 0.23913043478261, 1.425, 0.22222222222222
55294, 0.21739130434783, 1.4125, 0.22222222222222
55295, 0.21739130434783, 1.425, 0.25
55296, 0.23913043478261, 1.425, 0.27777777777778
55297, 0.21739130434783, 1.4125, 0.27777777777778
55298, 0.21739130434783, 1.425, 0.30555555555556
55299, 0.23913043478261, 1.425, 0.33333333333333
55300, 0.21739130434783, 1.4125, 0.33333333333333
55301, 0.21739130434783, 1.425, 0.36111111111111
55302, 0.23913043478261, 1.425, 0.38888888888889
55303, 0.21739130434783, 1.4125, 0.38888888888889
55304, 0.21739130434783, 1.425, 0.41666666666667
55305, 0.23913043478261, 1.425, 0.44444444444444
55306, 0.21739130434783, 1.4125, 0.44444444444444
55307, 0.21739130434783, 1.425, 0.47222222222222
55308, 0.17391304347826, 1.425, 0.027777777777778
55309, 0.19565217391304, 1.425, 0.055555555555556
55310, 0.17391304347826, 1.4125, 0.055555555555556
55311, 0.17391304347826, 1.425, 0.083333333333333
55312, 0.19565217391304, 1.425, 0.11111111111111
55313, 0.17391304347826, 1.4125, 0.11111111111111
55314, 0.17391304347826, 1.425, 0.13888888888889
55315, 0.19565217391304, 1.425, 0.16666666666667
55316, 0.17391304347826, 1.4125, 0.16666666666667
55317, 0.17391304347826, 1.425, 0.19444444444444
55318, 0.19565217391304, 1.425, 0.22222222222222
55319, 0.17391304347826, 1.4125, 0.22222222222222
55320, 0.17391304347826, 1.425, 0.25
55321, 0.19565217391304, 1.425, 0.27777777777778
55322, 0.17391304347826, 1.4125, 0.27777777777778
55323, 0.17391304347826, 1.425, 0.30555555555556
55324, 0.19565217391304, 1.425, 0.33333333333333
55325, 0.17391304347826, 1.4125, 0.33333333333333
55326, 0.17391304347826, 1.425, 0.36111111111111
55327, 0.19565217391304, 1.425, 0.38888888888889
55328, 0.17391304347826, 1.4125, 0.38888888888889
55329, 0.17391304347826, 1.425, 0.41666666666667
55330, 0.19565217391304, 1.425, 0.44444444444444
55331, 0.17391304347826, 1.4125, 0.44444444444444
55332, 0.17391304347826, 1.425, 0.47222222222222
55333, 0.1304347826087, 1.425, 0.027777777777778
55334, 0.15217391304348, 1.425, 0.055555555555556
55335, 0.1304347826087, 1.4125, 0.055555555555556
55336, 0.1304347826087, 1.425, 0.083333333333333
55337, 0.15217391304348, 1.425, 0.11111111111111
55338, 0.1304347826087, 1.4125, 0.11111111111111
55339, 0.1304347826087, 1.425, 0.13888888888889
55340, 0.15217391304348, 1.425, 0.16666666666667
55341, 0.1304347826087, 1.4125, 0.16666666666667
55342, 0.1304347826087, 1.425, 0.19444444444444
55343, 0.15217391304348, 1.425, 0.22222222222222
55344, 0.1304347826087, 1.4125, 0.22222222222222
55345, 0.1304347826087, 1.425, 0.25
55346, 0.15217391304348, 1.425, 0.27777777777778
55347, 0.1304347826087, 1.4125, 0.27777777777778
55348, 0.1304347826087, 1.425, 0.30555555555556
55349, 0.15217391304348, 1.425, 0.33333333333333
55350, 0.1304347826087, 1.4125, 0.33333333333333
55351, 0.1304347826087, 1.425, 0.36111111111111
55352, 0.15217391304348, 1.425, 0.38888888888889
55353, 0.1304347826087, 1.4125, 0.38888888888889
55354, 0.1304347826087, 1.425, 0.41666666666667
55355, 0.15217391304348, 1.425, 0.44444444444444
55356, 0.1304347826087, 1.4125, 0.44444444444444
55357, 0.1304347826087, 1.425, 0.47222222222222
55358, 0.08695652173913, 1.425, 0.027777777777778
55359, 0.10869565217391, 1.425, 0.055555555555556
55360, 0.08695652173913, 1.4125, 0.055555555555556
55361, 0.08695652173913, 1.425, 0.083333333333333
55362, 0.10869565217391, 1.425, 0.11111111111111
55363, 0.08695652173913, 1.4125, 0.11111111111111
55364, 0.08695652173913, 1.425, 0.13888888888889
55365, 0.10869565217391, 1.425, 0.16666666666667
55366, 0.08695652173913, 1.4125, 0.16666666666667
55367, 0.08695652173913, 1.425, 0.19444444444444
55368, 0.10869565217391, 1.425, 0.22222222222222
55369, 0.08695652173913, 1.4125, 0.22222222222222
55370, 0.08695652173913, 1.425, 0.25
55371, 0.10869565217391, 1.425, 0.27777777777778
55372, 0.08695652173913, 1.4125, 0.27777777777778
55373, 0.08695652173913, 1.425, 0.30555555555556
55374, 0.10869565217391, 1.425, 0.33333333333333
55375, 0.08695652173913, 1.4125, 0.33333333333333
55376, 0.08695652173913, 1.425, 0.36111111111111
55377, 0.10869565217391, 1.425, 0.38888888888889
55378, 0.08695652173913, 1.4125, 0.38888888888889
55379, 0.08695652173913, 1.425, 0.41666666666667
55380, 0.10869565217391, 1.425, 0.44444444444444
55381, 0.08695652173913, 1.4125, 0.44444444444444
55382, 0.08695652173913, 1.425, 0.47222222222222
55383, 0.043478260869565, 1.425, 0.027777777777778
55384, 0.065217391304348, 1.425, 0.055555555555556
55385, 0.043478260869565, 1.4125, 0.055555555555556
55386, 0.043478260869565, 1.425, 0.083333333333333
55387, 0.065217391304348, 1.425, 0.11111111111111
55388, 0.043478260869565, 1.4125, 0.11111111111111
55389, 0.043478260869565, 1.425, 0.13888888888889
55390, 0.065217391304348, 1.425, 0.16666666666667
55391, 0.043478260869565, 1.4125, 0.16666666666667
55392, 0.043478260869565, 1.425, 0.19444444444444
55393, 0.065217391304348, 1.425, 0.22222222222222
55394, 0.043478260869565, 1.4125, 0.22222222222222
55395, 0.043478260869565, 1.425, 0.25
55396, 0.065217391304348, 1.425, 0.27777777777778
55397, 0.043478260869565, 1.4125, 0.27777777777778
55398, 0.043478260869565, 1.425, 0.30555555555556
55399, 0.065217391304348, 1.425, 0.33333333333333
55400, 0.043478260869565, 1.4125, 0.33333333333333
55401, 0.043478260869565, 1.425, 0.36111111111111
55402, 0.065217391304348, 1.425, 0.38888888888889
55403, 0.043478260869565, 1.4125, 0.38888888888889
55404, 0.043478260869565, 1.425, 0.41666666666667
55405, 0.065217391304348, 1.425, 0.44444444444444
55406, 0.043478260869565, 1.4125, 0.44444444444444
55407, 0.043478260869565, 1.425, 0.47222222222222
55408, 0.021739130434783, 1.425, 0.055555555555556
55409, 0.021739130434783, 1.425, 0.11111111111111
55410, 0.021739130434783, 1.425, 0.16666666666667
55411, 0.021739130434783, 1.425, 0.22222222222222
55412, 0.021739130434783, 1.425, 0.27777777777778
55413, 0.021739130434783, 1.425, 0.33333333333333
55414, 0.021739130434783, 1.425, 0.38888888888889
55415, 0.021739130434783, 1.425, 0.44444444444444
55416, 0.95652173913043, 1.4375, 0.055555555555556
55417, 0.95652173913044, 1.4375, 0.11111111111111
55418, 0.95652173913044, 1.4375, 0.16666666666667
55419, 0.95652173913043, 1.4375, 0.22222222222222
55420, 0.95652173913043, 1.4375, 0.27777777777778
55421, 0.95652173913043, 1.4375, 0.33333333333333
55422, 0.95652173913043, 1.4375, 0.38888888888889
55423, 0.95652173913043, 1.4375, 0.44444444444444
55424, 0.91304347826087, 1.4375, 0.055555555555556
55425, 0.91304347826087, 1.4375, 0.11111111111111
55426, 0.91304347826087, 1.4375, 0.16666666666667
55427, 0.91304347826087, 1.4375, 0.22222222222222
55428, 0.91304347826087, 1.4375, 0.27777777777778
55429, 0.91304347826087, 1.4375, 0.33333333333333
55430, 0.91304347826087, 1.4375, 0.38888888888889
55431, 0.91304347826087, 1.4375, 0.44444444444444
55432, 0.8695652173913, 1.4375, 0.055555555555556
55433, 0.8695652173913, 1.4375, 0.11111111111111
55434, 0.8695652173913, 1.4375, 0.16666666666667
55435, 0.8695652173913, 1.4375, 0.22222222222222
55436, 0.8695652173913, 1.4375, 0.27777777777778
55437, 0.8695652173913, 1.4375, 0.33333333333333
55438, 0.8695652173913, 1.4375, 0.38888888888889
55439, 0.8695652173913, 1.4375, 0.44444444444444
55440, 0.82608695652174, 1.4375, 0.055555555555556
55441, 0.82608695652174, 1.4375, 0.11111111111111
55442, 0.82608695652174, 1.4375, 0.16666666666667
55443, 0.82608695652174, 1.4375, 0.22222222222222
55444, 0.82608695652174, 1.4375, 0.27777777777778
55445, 0.82608695652174, 1.4375, 0.33333333333333
55446, 0.82608695652174, 1.4375, 0.38888888888889
55447, 0.82608695652174, 1.4375, 0.44444444444444
55448, 0.78260869565217, 1.4375, 0.055555555555556
55449, 0.78260869565217, 1.4375, 0.11111111111111
55450, 0.78260869565217, 1.4375, 0.16666666666667
55451, 0.78260869565217, 1.4375, 0.22222222222222
55452, 0.78260869565217, 1.4375, 0.27777777777778
55453, 0.78260869565217, 1.4375, 0.33333333333333
55454, 0.78260869565217, 1.4375, 0.38888888888889
55455, 0.78260869565217, 1.4375, 0.44444444444444
55456, 0.73913043478261, 1.4375, 0.055555555555556
55457, 0.73913043478261, 1.4375, 0.11111111111111
55458, 0.73913043478261, 1.4375, 0.16666666666667
55459, 0.73913043478261, 1.4375, 0.22222222222222
55460, 0.73913043478261, 1.4375, 0.27777777777778
55461, 0.73913043478261, 1.4375, 0.33333333333333
55462, 0.73913043478261, 1.4375, 0.38888888888889
55463, 0.73913043478261, 1.4375, 0.44444444444444
55464, 0.69565217391304, 1.4375, 0.055555555555556
55465, 0.69565217391304, 1.4375, 0.11111111111111
55466, 0.69565217391304, 1.4375, 0.16666666666667
55467, 0.69565217391304, 1.4375, 0.22222222222222
55468, 0.69565217391304, 1.4375, 0.27777777777778
55469, 0.69565217391304, 1.4375, 0.33333333333333
55470, 0.69565217391304, 1.4375, 0.38888888888889
55471, 0.69565217391304, 1.4375, 0.44444444444444
55472, 0.65217391304348, 1.4375, 0.055555555555556
55473, 0.65217391304348, 1.4375, 0.11111111111111
55474, 0.65217391304348, 1.4375, 0.16666666666667
55475, 0.65217391304348, 1.4375, 0.22222222222222
55476, 0.65217391304348, 1.4375, 0.27777777777778
55477, 0.65217391304348, 1.4375, 0.33333333333333
55478, 0.65217391304348, 1.4375, 0.38888888888889
55479, 0.65217391304348, 1.4375, 0.44444444444444
55480, 0.60869565217391, 1.4375, 0.055555555555556
55481, 0.60869565217391, 1.4375, 0.11111111111111
55482, 0.60869565217391, 1.4375, 0.16666666666667
55483, 0.60869565217391, 1.4375, 0.22222222222222
55484, 0.60869565217391, 1.4375, 0.27777777777778
55485, 0.60869565217391, 1.4375, 0.33333333333333
55486, 0.60869565217391, 1.4375, 0.38888888888889
55487, 0.60869565217391, 1.4375, 0.44444444444444
55488, 0.56521739130435, 1.4375, 0.055555555555556
55489, 0.56521739130435, 1.4375, 0.11111111111111
55490, 0.56521739130435, 1.4375, 0.16666666666667
55491, 0.56521739130435, 1.4375, 0.22222222222222
55492, 0.56521739130435, 1.4375, 0.27777777777778
55493, 0.56521739130435, 1.4375, 0.33333333333333
55494, 0.56521739130435, 1.4375, 0.38888888888889
55495, 0.56521739130435, 1.4375, 0.44444444444444
55496, 0.52173913043478, 1.4375, 0.055555555555556
55497, 0.52173913043478, 1.4375, 0.11111111111111
55498, 0.52173913043478, 1.4375, 0.16666666666667
55499, 0.52173913043478, 1.4375, 0.22222222222222
55500, 0.52173913043478, 1.4375, 0.27777777777778
55501, 0.52173913043478, 1.4375, 0.33333333333333
55502, 0.52173913043478, 1.4375, 0.38888888888889
55503, 0.52173913043478, 1.4375, 0.44444444444444
55504, 0.47826086956522, 1.4375, 0.055555555555556
55505, 0.47826086956522, 1.4375, 0.11111111111111
55506, 0.47826086956522, 1.4375, 0.16666666666667
55507, 0.47826086956522, 1.4375, 0.22222222222222
55508, 0.47826086956522, 1.4375, 0.27777777777778
55509, 0.47826086956522, 1.4375, 0.33333333333333
55510, 0.47826086956522, 1.4375, 0.38888888888889
55511, 0.47826086956522, 1.4375, 0.44444444444444
55512, 0.43478260869565, 1.4375, 0.055555555555556
55513, 0.43478260869565, 1.4375, 0.11111111111111
55514, 0.43478260869565, 1.4375, 0.16666666666667
55515, 0.43478260869565, 1.4375, 0.22222222222222
55516, 0.43478260869565, 1.4375, 0.27777777777778
55517, 0.43478260869565, 1.4375, 0.33333333333333
55518, 0.43478260869565, 1.4375, 0.38888888888889
55519, 0.43478260869565, 1.4375, 0.44444444444444
55520, 0.39130434782609, 1.4375, 0.055555555555556
55521, 0.39130434782609, 1.4375, 0.11111111111111
55522, 0.39130434782609, 1.4375, 0.16666666666667
55523, 0.39130434782609, 1.4375, 0.22222222222222
55524, 0.39130434782609, 1.4375, 0.27777777777778
55525, 0.39130434782609, 1.4375, 0.33333333333333
55526, 0.39130434782609, 1.4375, 0.38888888888889
55527, 0.39130434782609, 1.4375, 0.44444444444444
55528, 0.34782608695652, 1.4375, 0.055555555555556
55529, 0.34782608695652, 1.4375, 0.11111111111111
55530, 0.34782608695652, 1.4375, 0.16666666666667
55531, 0.34782608695652, 1.4375, 0.22222222222222
55532, 0.34782608695652, 1.4375, 0.27777777777778
55533, 0.34782608695652, 1.4375, 0.33333333333333
55534, 0.34782608695652, 1.4375, 0.38888888888889
55535, 0.34782608695652, 1.4375, 0.44444444444444
55536, 0.30434782608696, 1.4375, 0.055555555555556
55537, 0.30434782608696, 1.4375, 0.11111111111111
55538, 0.30434782608696, 1.4375, 0.16666666666667
55539, 0.30434782608696, 1.4375, 0.22222222222222
55540, 0.30434782608696, 1.4375, 0.27777777777778
55541, 0.30434782608696, 1.4375, 0.33333333333333
55542, 0.30434782608696, 1.4375, 0.38888888888889
55543, 0.30434782608696, 1.4375, 0.44444444444444
55544, 0.26086956521739, 1.4375, 0.055555555555556
55545, 0.26086956521739, 1.4375, 0.11111111111111
55546, 0.26086956521739, 1.4375, 0.16666666666667
55547, 0.26086956521739, 1.4375, 0.22222222222222
55548, 0.26086956521739, 1.4375, 0.27777777777778
55549, 0.26086956521739, 1.4375, 0.33333333333333
55550, 0.26086956521739, 1.4375, 0.38888888888889
55551, 0.26086956521739, 1.4375, 0.44444444444444
55552, 0.21739130434783, 1.4375, 0.055555555555556
55553, 0.21739130434783, 1.4375, 0.11111111111111
55554, 0.21739130434783, 1.4375, 0.16666666666667
55555, 0.21739130434783, 1.4375, 0.22222222222222
55556, 0.21739130434783, 1.4375, 0.27777777777778
55557, 0.21739130434783, 1.4375, 0.33333333333333
55558, 0.21739130434783, 1.4375, 0.38888888888889
55559, 0.21739130434783, 1.4375, 0.44444444444444
55560, 0.17391304347826, 1.4375, 0.055555555555556
55561, 0.17391304347826, 1.4375, 0.11111111111111
55562, 0.17391304347826, 1.4375, 0.16666666666667
55563, 0.17391304347826, 1.4375, 0.22222222222222
55564, 0.17391304347826, 1.4375, 0.27777777777778
55565, 0.17391304347826, 1.4375, 0.33333333333333
55566, 0.17391304347826, 1.4375, 0.38888888888889
55567, 0.17391304347826, 1.4375, 0.44444444444444
55568, 0.1304347826087, 1.4375, 0.055555555555556
55569, 0.1304347826087, 1.4375, 0.11111111111111
55570, 0.1304347826087, 1.4375, 0.16666666666667
55571, 0.1304347826087, 1.4375, 0.22222222222222
55572, 0.1304347826087, 1.4375, 0.27777777777778
55573, 0.1304347826087, 1.4375, 0.33333333333333
55574, 0.1304347826087, 1.4375, 0.38888888888889
55575, 0.1304347826087, 1.4375, 0.44444444444444
55576, 0.08695652173913, 1.4375, 0.055555555555556
55577, 0.08695652173913, 1.4375, 0.11111111111111
55578, 0.08695652173913, 1.4375, 0.16666666666667
55579, 0.08695652173913, 1.4375, 0.22222222222222
55580, 0.08695652173913, 1.4375, 0.27777777777778
55581, 0.08695652173913, 1.4375, 0.33333333333333
55582, 0.08695652173913, 1.4375, 0.38888888888889
55583, 0.08695652173913, 1.4375, 0.44444444444444
55584, 0.043478260869565, 1.4375, 0.055555555555556
55585, 0.043478260869565, 1.4375, 0.11111111111111
55586, 0.043478260869565, 1.4375, 0.16666666666667
55587, 0.043478260869565, 1.4375, 0.22222222222222
55588, 0.043478260869565, 1.4375, 0.27777777777778
55589, 0.043478260869565, 1.4375, 0.33333333333333
55590, 0.043478260869565, 1.4375, 0.38888888888889
55591, 0.043478260869565, 1.4375, 0.44444444444444
55592, 0.95652173913043, 1.4833333333333, 0.055555555555556
55593, 0.95652173913044, 1.4833333333333, 0.11111111111111
55594, 0.95652173913044, 1.4833333333333, 0.16666666666667
55595, 0.95652173913044, 1.4833333333333, 0.22222222222222
55596, 0.95652173913044, 1.4833333333333, 0.27777777777778
55597, 0.95652173913044, 1.4833333333333, 0.33333333333333
55598, 0.95652173913044, 1.4833333333333, 0.38888888888889
55599, 0.95652173913044, 1.4833333333333, 0.44444444444444
55600, 0.91304347826087, 1.4833333333333, 0.055555555555556
55601, 0.91304347826087, 1.4833333333333, 0.11111111111111
55602, 0.91304347826087, 1.4833333333333, 0.16666666666667
55603, 0.91304347826087, 1.4833333333333, 0.22222222222222
55604, 0.91304347826087, 1.4833333333333, 0.27777777777778
55605, 0.91304347826087, 1.4833333333333, 0.33333333333333
55606, 0.91304347826087, 1.4833333333333, 0.38888888888889
55607, 0.91304347826087, 1.4833333333333, 0.44444444444444
55608, 0.8695652173913, 1.4833333333333, 0.055555555555556
55609, 0.8695652173913, 1.4833333333333, 0.11111111111111
55610, 0.8695652173913, 1.4833333333333, 0.16666666666667
55611, 0.8695652173913, 1.4833333333333, 0.22222222222222
55612, 0.8695652173913, 1.4833333333333, 0.27777777777778
55613, 0.8695652173913, 1.4833333333333, 0.33333333333333
55614, 0.8695652173913, 1.4833333333333, 0.38888888888889
55615, 0.8695652173913, 1.4833333333333, 0.44444444444444
55616, 0.82608695652174, 1.4833333333333, 0.055555555555556
55617, 0.82608695652174, 1.4833333333333, 0.11111111111111
55618, 0.82608695652174, 1.4833333333333, 0.16666666666667
55619, 0.82608695652174, 1.4833333333333, 0.22222222222222
55620, 0.82608695652174, 1.4833333333333, 0.27777777777778
55621, 0.82608695652174, 1.4833333333333, 0.33333333333333
55622, 0.82608695652174, 1.4833333333333, 0.38888888888889
55623, 0.82608695652174, 1.4833333333333, 0.44444444444444
55624, 0.78260869565217, 1.4833333333333, 0.055555555555556
55625, 0.78260869565217, 1.4833333333333, 0.11111111111111
55626, 0.78260869565217, 1.4833333333333, 0.16666666666667
55627, 0.78260869565217, 1.4833333333333, 0.22222222222222
55628, 0.78260869565217, 1.4833333333333, 0.27777777777778
55629, 0.78260869565217, 1.4833333333333, 0.33333333333333
55630, 0.78260869565217, 1.4833333333333, 0.38888888888889
55631, 0.78260869565217, 1.4833333333333, 0.44444444444444
55632, 0.73913043478261, 1.4833333333333, 0.055555555555556
55633, 0.73913043478261, 1.4833333333333, 0.11111111111111
55634, 0.73913043478261, 1.4833333333333, 0.16666666666667
55635, 0.73913043478261, 1.4833333333333, 0.22222222222222
55636, 0.73913043478261, 1.4833333333333, 0.27777777777778
55637, 0.73913043478261, 1.4833333333333, 0.33333333333333
55638, 0.73913043478261, 1.4833333333333, 0.38888888888889
55639, 0.73913043478261, 1.4833333333333, 0.44444444444444
55640, 0.69565217391304, 1.4833333333333, 0.055555555555556
55641, 0.69565217391304, 1.4833333333333, 0.11111111111111
55642, 0.69565217391304, 1.4833333333333, 0.16666666666667
55643, 0.69565217391304, 1.4833333333333, 0.22222222222222
55644, 0.69565217391304, 1.4833333333333, 0.27777777777778
55645, 0.69565217391304, 1.4833333333333, 0.33333333333333
55646, 0.69565217391304, 1.4833333333333, 0.38888888888889
55647, 0.69565217391304, 1.4833333333333, 0.44444444444444
55648, 0.65217391304348, 1.4833333333333, 0.055555555555556
55649, 0.65217391304348, 1.4833333333333, 0.11111111111111
55650, 0.65217391304348, 1.4833333333333, 0.16666666666667
55651, 0.65217391304348, 1.4833333333333, 0.22222222222222
55652, 0.65217391304348, 1.4833333333333, 0.27777777777778
55653, 0.65217391304348, 1.4833333333333, 0.33333333333333
55654, 0.65217391304348, 1.4833333333333, 0.38888888888889
55655, 0.65217391304348, 1.4833333333333, 0.44444444444444
55656, 0.60869565217391, 1.4833333333333, 0.055555555555556
55657, 0.60869565217391, 1.4833333333333, 0.11111111111111
55658, 0.60869565217391, 1.4833333333333, 0.16666666666667
55659, 0.60869565217391, 1.4833333333333, 0.22222222222222
55660, 0.60869565217391, 1.4833333333333, 0.27777777777778
55661, 0.60869565217391, 1.4833333333333, 0.33333333333333
55662, 0.60869565217391, 1.4833333333333, 0.38888888888889
55663, 0.60869565217391, 1.4833333333333, 0.44444444444444
55664, 0.56521739130435, 1.4833333333333, 0.055555555555556
55665, 0.56521739130435, 1.4833333333333, 0.11111111111111
55666, 0.56521739130435, 1.4833333333333, 0.16666666666667
55667, 0.56521739130435, 1.4833333333333, 0.22222222222222
55668, 0.56521739130435, 1.4833333333333, 0.27777777777778
55669, 0.56521739130435, 1.4833333333333, 0.33333333333333
55670, 0.56521739130435, 1.4833333333333, 0.38888888888889
55671, 0.56521739130435, 1.4833333333333, 0.44444444444444
55672, 0.52173913043478, 1.4833333333333, 0.055555555555556
55673, 0.52173913043478, 1.4833333333333, 0.11111111111111
55674, 0.52173913043478, 1.4833333333333, 0.16666666666667
55675, 0.52173913043478, 1.4833333333333, 0.22222222222222
55676, 0.52173913043478, 1.4833333333333, 0.27777777777778
55677, 0.52173913043478, 1.4833333333333, 0.33333333333333
55678, 0.52173913043478, 1.4833333333333, 0.38888888888889
55679, 0.52173913043478, 1.4833333333333, 0.44444444444444
55680, 0.47826086956522, 1.4833333333333, 0.055555555555556
55681, 0.47826086956522, 1.4833333333333, 0.11111111111111
55682, 0.47826086956522, 1.4833333333333, 0.16666666666667
55683, 0.47826086956522, 1.4833333333333, 0.22222222222222
55684, 0.47826086956522, 1.4833333333333, 0.27777777777778
55685, 0.47826086956522, 1.4833333333333, 0.33333333333333
55686, 0.47826086956522, 1.4833333333333, 0.38888888888889
55687, 0.47826086956522, 1.4833333333333, 0.44444444444444
55688, 0.43478260869565, 1.4833333333333, 0.055555555555556
55689, 0.43478260869565, 1.4833333333333, 0.11111111111111
55690, 0.43478260869565, 1.4833333333333, 0.16666666666667
55691, 0.43478260869565, 1.4833333333333, 0.22222222222222
55692, 0.43478260869565, 1.4833333333333, 0.27777777777778
55693, 0.43478260869565, 1.4833333333333, 0.33333333333333
55694, 0.43478260869565, 1.4833333333333, 0.38888888888889
55695, 0.43478260869565, 1.4833333333333, 0.44444444444444
55696, 0.39130434782609, 1.4833333333333, 0.055555555555556
55697, 0.39130434782609, 1.4833333333333, 0.11111111111111
55698, 0.39130434782609, 1.4833333333333, 0.16666666666667
55699, 0.39130434782609, 1.4833333333333, 0.22222222222222
55700, 0.39130434782609, 1.4833333333333, 0.27777777777778
55701, 0.39130434782609, 1.4833333333333, 0.33333333333333
55702, 0.39130434782609, 1.4833333333333, 0.38888888888889
55703, 0.39130434782609, 1.4833333333333, 0.44444444444444
55704, 0.34782608695652, 1.4833333333333, 0.055555555555556
55705, 0.34782608695652, 1.4833333333333, 0.11111111111111
55706, 0.34782608695652, 1.4833333333333, 0.16666666666667
55707, 0.34782608695652, 1.4833333333333, 0.22222222222222
55708, 0.34782608695652, 1.4833333333333, 0.27777777777778
55709, 0.34782608695652, 1.4833333333333, 0.33333333333333
55710, 0.34782608695652, 1.4833333333333, 0.38888888888889
55711, 0.34782608695652, 1.4833333333333, 0.44444444444444
55712, 0.30434782608696, 1.4833333333333, 0.055555555555556
55713, 0.30434782608696, 1.4833333333333, 0.11111111111111
55714, 0.30434782608696, 1.4833333333333, 0.16666666666667
55715, 0.30434782608696, 1.4833333333333, 0.22222222222222
55716, 0.30434782608696, 1.4833333333333, 0.27777777777778
55717, 0.30434782608696, 1.4833333333333, 0.33333333333333
55718, 0.30434782608696, 1.4833333333333, 0.38888888888889
55719, 0.30434782608696, 1.4833333333333, 0.44444444444444
55720, 0.26086956521739, 1.4833333333333, 0.055555555555556
55721, 0.26086956521739, 1.4833333333333, 0.11111111111111
55722, 0.26086956521739, 1.4833333333333, 0.16666666666667
55723, 0.26086956521739, 1.4833333333333, 0.22222222222222
55724, 0.26086956521739, 1.4833333333333, 0.27777777777778
55725, 0.26086956521739, 1.4833333333333, 0.33333333333333
55726, 0.26086956521739, 1.4833333333333, 0.38888888888889
55727, 0.26086956521739, 1.4833333333333, 0.44444444444444
55728, 0.21739130434783, 1.4833333333333, 0.055555555555556
55729, 0.21739130434783, 1.4833333333333, 0.11111111111111
55730, 0.21739130434783, 1.4833333333333, 0.16666666666667
55731, 0.21739130434783, 1.4833333333333, 0.22222222222222
55732, 0.21739130434783, 1.4833333333333, 0.27777777777778
55733, 0.21739130434783, 1.4833333333333, 0.33333333333333
55734, 0.21739130434783, 1.4833333333333, 0.38888888888889
55735, 0.21739130434783, 1.4833333333333, 0.44444444444444
55736, 0.17391304347826, 1.4833333333333, 0.055555555555556
55737, 0.17391304347826, 1.4833333333333, 0.11111111111111
55738, 0.17391304347826, 1.4833333333333, 0.16666666666667
55739, 0.17391304347826, 1.4833333333333, 0.22222222222222
55740, 0.17391304347826, 1.4833333333333, 0.27777777777778
55741, 0.17391304347826, 1.4833333333333, 0.33333333333333
55742, 0.17391304347826, 1.4833333333333, 0.38888888888889
55743, 0.17391304347826, 1.4833333333333, 0.44444444444444
55744, 0.1304347826087, 1.4833333333333, 0.055555555555556
55745, 0.1304347826087, 1.4833333333333, 0.11111111111111
55746, 0.1304347826087, 1.4833333333333, 0.16666666666667
55747, 0.1304347826087, 1.4833333333333, 0.22222222222222
55748, 0.1304347826087, 1.4833333333333, 0.27777777777778
55749, 0.1304347826087, 1.4833333333333, 0.33333333333333
55750, 0.1304347826087, 1.4833333333333, 0.38888888888889
55751, 0.1304347826087, 1.4833333333333, 0.44444444444444
55752, 0.08695652173913, 1.4833333333333, 0.055555555555556
55753, 0.08695652173913, 1.4833333333333, 0.11111111111111
55754, 0.08695652173913, 1.4833333333333, 0.16666666666667
55755, 0.08695652173913, 1.4833333333333, 0.22222222222222
55756, 0.08695652173913, 1.4833333333333, 0.27777777777778
55757, 0.08695652173913, 1.4833333333333, 0.33333333333333
55758, 0.08695652173913, 1.4833333333333, 0.38888888888889
55759, 0.08695652173913, 1.4833333333333, 0.44444444444444
55760, 0.043478260869565, 1.4833333333333, 0.055555555555556
55761, 0.043478260869565, 1.4833333333333, 0.11111111111111
55762, 0.043478260869565, 1.4833333333333, 0.16666666666667
55763, 0.043478260869565, 1.4833333333333, 0.22222222222222
55764, 0.043478260869565, 1.4833333333333, 0.27777777777778
55765, 0.043478260869565, 1.4833333333333, 0.33333333333333
55766, 0.043478260869565, 1.4833333333333, 0.38888888888889
55767, 0.043478260869565, 1.4833333333333, 0.44444444444444
55768, 0.95652173913043, 1.5166666666667, 0.055555555555556
55769, 0.95652173913044, 1.5166666666667, 0.11111111111111
55770, 0.95652173913044, 1.5166666666667, 0.16666666666667
55771, 0.95652173913044, 1.5166666666667, 0.22222222222222
55772, 0.95652173913044, 1.5166666666667, 0.27777777777778
55773, 0.95652173913044, 1.5166666666667, 0.33333333333333
55774, 0.95652173913044, 1.5166666666667, 0.38888888888889
55775, 0.95652173913044, 1.5166666666667, 0.44444444444444
55776, 0.91304347826087, 1.5166666666667, 0.055555555555556
55777, 0.91304347826087, 1.5166666666667, 0.11111111111111
55778, 0.91304347826087, 1.5166666666667, 0.16666666666667
55779, 0.91304347826087, 1.5166666666667, 0.22222222222222
55780, 0.91304347826087, 1.5166666666667, 0.27777777777778
55781, 0.91304347826087, 1.5166666666667, 0.33333333333333
55782, 0.91304347826087, 1.5166666666667, 0.38888888888889
55783, 0.91304347826087, 1.5166666666667, 0.44444444444444
55784, 0.8695652173913, 1.5166666666667, 0.055555555555556
55785, 0.8695652173913, 1.5166666666667, 0.11111111111111
55786, 0.8695652173913, 1.5166666666667, 0.16666666666667
55787, 0.8695652173913, 1.5166666666667, 0.22222222222222
55788, 0.8695652173913, 1.5166666666667, 0.27777777777778
55789, 0.8695652173913, 1.5166666666667, 0.33333333333333
55790, 0.8695652173913, 1.5166666666667, 0.38888888888889
55791, 0.8695652173913, 1.5166666666667, 0.44444444444444
55792, 0.82608695652174, 1.5166666666667, 0.055555555555556
55793, 0.82608695652174, 1.5166666666667, 0.11111111111111
55794, 0.82608695652174, 1.5166666666667, 0.16666666666667
55795, 0.82608695652174, 1.5166666666667, 0.22222222222222
55796, 0.82608695652174, 1.5166666666667, 0.27777777777778
55797, 0.82608695652174, 1.5166666666667, 0.33333333333333
55798, 0.82608695652174, 1.5166666666667, 0.38888888888889
55799, 0.82608695652174, 1.5166666666667, 0.44444444444444
55800, 0.78260869565217, 1.5166666666667, 0.055555555555556
55801, 0.78260869565217, 1.5166666666667, 0.11111111111111
55802, 0.78260869565217, 1.5166666666667, 0.16666666666667
55803, 0.78260869565217, 1.5166666666667, 0.22222222222222
55804, 0.78260869565217, 1.5166666666667, 0.27777777777778
55805, 0.78260869565217, 1.5166666666667, 0.33333333333333
55806, 0.78260869565217, 1.5166666666667, 0.38888888888889
55807, 0.78260869565217, 1.5166666666667, 0.44444444444444
55808, 0.73913043478261, 1.5166666666667, 0.055555555555556
55809, 0.73913043478261, 1.5166666666667, 0.11111111111111
55810, 0.73913043478261, 1.5166666666667, 0.16666666666667
55811, 0.73913043478261, 1.5166666666667, 0.22222222222222
55812, 0.73913043478261, 1.5166666666667, 0.27777777777778
55813, 0.73913043478261, 1.5166666666667, 0.33333333333333
55814, 0.73913043478261, 1.5166666666667, 0.38888888888889
55815, 0.73913043478261, 1.5166666666667, 0.44444444444444
55816, 0.69565217391304, 1.5166666666667, 0.055555555555556
55817, 0.69565217391304, 1.5166666666667, 0.11111111111111
55818, 0.69565217391304, 1.5166666666667, 0.16666666666667
55819, 0.69565217391304, 1.5166666666667, 0.22222222222222
55820, 0.69565217391304, 1.5166666666667, 0.27777777777778
55821, 0.69565217391304, 1.5166666666667, 0.33333333333333
55822, 0.69565217391304, 1.5166666666667, 0.38888888888889
55823, 0.69565217391304, 1.5166666666667, 0.44444444444444
55824, 0.65217391304348, 1.5166666666667, 0.055555555555556
55825, 0.65217391304348, 1.5166666666667, 0.11111111111111
55826, 0.65217391304348, 1.5166666666667, 0.16666666666667
55827, 0.65217391304348, 1.5166666666667, 0.22222222222222
55828, 0.65217391304348, 1.5166666666667, 0.27777777777778
55829, 0.65217391304348, 1.5166666666667, 0.33333333333333
55830, 0.65217391304348, 1.5166666666667, 0.38888888888889
55831, 0.65217391304348, 1.5166666666667, 0.44444444444444
55832, 0.60869565217391, 1.5166666666667, 0.055555555555556
55833, 0.60869565217391, 1.5166666666667, 0.11111111111111
55834, 0.60869565217391, 1.5166666666667, 0.16666666666667
55835, 0.60869565217391, 1.5166666666667, 0.22222222222222
55836, 0.60869565217391, 1.5166666666667, 0.27777777777778
55837, 0.60869565217391, 1.5166666666667, 0.33333333333333
55838, 0.60869565217391, 1.5166666666667, 0.38888888888889
55839, 0.60869565217391, 1.5166666666667, 0.44444444444444
55840, 0.56521739130435, 1.5166666666667, 0.055555555555556
55841, 0.56521739130435, 1.5166666666667, 0.11111111111111
55842, 0.56521739130435, 1.5166666666667, 0.16666666666667
55843, 0.56521739130435, 1.5166666666667, 0.22222222222222
55844, 0.56521739130435, 1.5166666666667, 0.27777777777778
55845, 0.56521739130435, 1.5166666666667, 0.33333333333333
55846, 0.56521739130435, 1.5166666666667, 0.38888888888889
55847, 0.56521739130435, 1.5166666666667, 0.44444444444444
55848, 0.52173913043478, 1.5166666666667, 0.055555555555556
55849, 0.52173913043478, 1.5166666666667, 0.11111111111111
55850, 0.52173913043478, 1.5166666666667, 0.16666666666667
55851, 0.52173913043478, 1.5166666666667, 0.22222222222222
55852, 0.52173913043478, 1.5166666666667, 0.27777777777778
55853, 0.52173913043478, 1.5166666666667, 0.33333333333333
55854, 0.52173913043478, 1.5166666666667, 0.38888888888889
55855, 0.52173913043478, 1.5166666666667, 0.44444444444444
55856, 0.47826086956522, 1.5166666666667, 0.055555555555556
55857, 0.47826086956522, 1.5166666666667, 0.11111111111111
55858, 0.47826086956522, 1.5166666666667, 0.16666666666667
55859, 0.47826086956522, 1.5166666666667, 0.22222222222222
55860, 0.47826086956522, 1.5166666666667, 0.27777777777778
55861, 0.47826086956522, 1.5166666666667, 0.33333333333333
55862, 0.47826086956522, 1.5166666666667, 0.38888888888889
55863, 0.47826086956522, 1.5166666666667, 0.44444444444444
55864, 0.43478260869565, 1.5166666666667, 0.055555555555556
55865, 0.43478260869565, 1.5166666666667, 0.11111111111111
55866, 0.43478260869565, 1.5166666666667, 0.16666666666667
55867, 0.43478260869565, 1.5166666666667, 0.22222222222222
55868, 0.43478260869565, 1.5166666666667, 0.27777777777778
55869, 0.43478260869565, 1.5166666666667, 0.33333333333333
55870, 0.43478260869565, 1.5166666666667, 0.38888888888889
55871, 0.43478260869565, 1.5166666666667, 0.44444444444444
55872, 0.39130434782609, 1.5166666666667, 0.055555555555556
55873, 0.39130434782609, 1.5166666666667, 0.11111111111111
55874, 0.39130434782609, 1.5166666666667, 0.16666666666667
55875, 0.39130434782609, 1.5166666666667, 0.22222222222222
55876, 0.39130434782609, 1.5166666666667, 0.27777777777778
55877, 0.39130434782609, 1.5166666666667, 0.33333333333333
55878, 0.39130434782609, 1.5166666666667, 0.38888888888889
55879, 0.39130434782609, 1.5166666666667, 0.44444444444444
55880, 0.34782608695652, 1.5166666666667, 0.055555555555556
55881, 0.34782608695652, 1.5166666666667, 0.11111111111111
55882, 0.34782608695652, 1.5166666666667, 0.16666666666667
55883, 0.34782608695652, 1.5166666666667, 0.22222222222222
55884, 0.34782608695652, 1.5166666666667, 0.27777777777778
55885, 0.34782608695652, 1.5166666666667, 0.33333333333333
55886, 0.34782608695652, 1.5166666666667, 0.38888888888889
55887, 0.34782608695652, 1.5166666666667, 0.44444444444444
55888, 0.30434782608696, 1.5166666666667, 0.055555555555556
55889, 0.30434782608696, 1.5166666666667, 0.11111111111111
55890, 0.30434782608696, 1.5166666666667, 0.16666666666667
55891, 0.30434782608696, 1.5166666666667, 0.22222222222222
55892, 0.30434782608696, 1.5166666666667, 0.27777777777778
55893, 0.30434782608696, 1.5166666666667, 0.33333333333333
55894, 0.30434782608696, 1.5166666666667, 0.38888888888889
55895, 0.30434782608696, 1.5166666666667, 0.44444444444444
55896, 0.26086956521739, 1.5166666666667, 0.055555555555556
55897, 0.26086956521739, 1.5166666666667, 0.11111111111111
55898, 0.26086956521739, 1.5166666666667, 0.16666666666667
55899, 0.26086956521739, 1.5166666666667, 0.22222222222222
55900, 0.26086956521739, 1.5166666666667, 0.27777777777778
55901, 0.26086956521739, 1.5166666666667, 0.33333333333333
55902, 0.26086956521739, 1.5166666666667, 0.38888888888889
55903, 0.26086956521739, 1.5166666666667, 0.44444444444444
55904, 0.21739130434783, 1.5166666666667, 0.055555555555556
55905, 0.21739130434783, 1.5166666666667, 0.11111111111111
55906, 0.21739130434783, 1.5166666666667, 0.16666666666667
55907, 0.21739130434783, 1.5166666666667, 0.22222222222222
55908, 0.21739130434783, 1.5166666666667, 0.27777777777778
55909, 0.21739130434783, 1.5166666666667, 0.33333333333333
55910, 0.21739130434783, 1.5166666666667, 0.38888888888889
55911, 0.21739130434783, 1.5166666666667, 0.44444444444444
55912, 0.17391304347826, 1.5166666666667, 0.055555555555556
55913, 0.17391304347826, 1.5166666666667, 0.11111111111111
55914, 0.17391304347826, 1.5166666666667, 0.16666666666667
55915, 0.17391304347826, 1.5166666666667, 0.22222222222222
55916, 0.17391304347826, 1.5166666666667, 0.27777777777778
55917, 0.17391304347826, 1.5166666666667, 0.33333333333333
55918, 0.17391304347826, 1.5166666666667, 0.38888888888889
55919, 0.17391304347826, 1.5166666666667, 0.44444444444444
55920, 0.1304347826087, 1.5166666666667, 0.055555555555556
55921, 0.1304347826087, 1.5166666666667, 0.11111111111111
55922, 0.1304347826087, 1.5166666666667, 0.16666666666667
55923, 0.1304347826087, 1.5166666666667, 0.22222222222222
55924, 0.1304347826087, 1.5166666666667, 0.27777777777778
55925, 0.1304347826087, 1.5166666666667, 0.33333333333333
55926, 0.1304347826087, 1.5166666666667, 0.38888888888889
55927, 0.1304347826087, 1.5166666666667, 0.44444444444444
55928, 0.08695652173913, 1.5166666666667, 0.055555555555556
55929, 0.08695652173913, 1.5166666666667, 0.11111111111111
55930, 0.08695652173913, 1.5166666666667, 0.16666666666667
55931, 0.08695652173913, 1.5166666666667, 0.22222222222222
55932, 0.08695652173913, 1.5166666666667, 0.27777777777778
55933, 0.08695652173913, 1.5166666666667, 0.33333333333333
55934, 0.08695652173913, 1.5166666666667, 0.38888888888889
55935, 0.08695652173913, 1.5166666666667, 0.44444444444444
55936, 0.043478260869565, 1.5166666666667, 0.055555555555556
55937, 0.043478260869565, 1.5166666666667, 0.11111111111111
55938, 0.043478260869565, 1.5166666666667, 0.16666666666667
55939, 0.043478260869565, 1.5166666666667, 0.22222222222222
55940, 0.043478260869565, 1.5166666666667, 0.27777777777778
55941, 0.043478260869565, 1.5166666666667, 0.33333333333333
55942, 0.043478260869565, 1.5166666666667, 0.38888888888889
55943, 0.043478260869565, 1.5166666666667, 0.44444444444444
55944, 0.95652173913043, 1.4833333333333, 0.027777777777778
55945, 0.97826086956522, 1.4833333333333, 0.055555555555556
55946, 0.95652173913043, 1.4666666666667, 0.055555555555556
55947, 0.95652173913043, 1.4833333333333, 0.083333333333333
55948, 0.97826086956522, 1.4833333333333, 0.11111111111111
55949, 0.95652173913043, 1.4666666666667, 0.11111111111111
55950, 0.95652173913044, 1.4833333333333, 0.13888888888889
55951, 0.97826086956522, 1.4833333333333, 0.16666666666667
55952, 0.95652173913043, 1.4666666666667, 0.16666666666667
55953, 0.95652173913044, 1.4833333333333, 0.19444444444444
55954, 0.97826086956522, 1.4833333333333, 0.22222222222222
55955, 0.95652173913043, 1.4666666666667, 0.22222222222222
55956, 0.95652173913044, 1.4833333333333, 0.25
55957, 0.97826086956522, 1.4833333333333, 0.27777777777778
55958, 0.95652173913043, 1.4666666666667, 0.27777777777778
55959, 0.95652173913044, 1.4833333333333, 0.30555555555556
55960, 0.97826086956522, 1.4833333333333, 0.33333333333333
55961, 0.95652173913043, 1.4666666666667, 0.33333333333333
55962, 0.95652173913044, 1.4833333333333, 0.36111111111111
55963, 0.97826086956522, 1.4833333333333, 0.38888888888889
55964, 0.95652173913043, 1.4666666666667, 0.38888888888889
55965, 0.95652173913044, 1.4833333333333, 0.41666666666667
55966, 0.97826086956522, 1.4833333333333, 0.44444444444444
55967, 0.95652173913043, 1.4666666666667, 0.44444444444444
55968, 0.95652173913043, 1.4833333333333, 0.47222222222222
55969, 0.91304347826087, 1.4833333333333, 0.027777777777778
55970, 0.93478260869565, 1.4833333333333, 0.055555555555556
55971, 0.91304347826087, 1.4666666666667, 0.055555555555556
55972, 0.91304347826087, 1.4833333333333, 0.083333333333333
55973, 0.93478260869565, 1.4833333333333, 0.11111111111111
55974, 0.91304347826087, 1.4666666666667, 0.11111111111111
55975, 0.91304347826087, 1.4833333333333, 0.13888888888889
55976, 0.93478260869565, 1.4833333333333, 0.16666666666667
55977, 0.91304347826087, 1.4666666666667, 0.16666666666667
55978, 0.91304347826087, 1.4833333333333, 0.19444444444444
55979, 0.93478260869565, 1.4833333333333, 0.22222222222222
55980, 0.91304347826087, 1.4666666666667, 0.22222222222222
55981, 0.91304347826087, 1.4833333333333, 0.25
55982, 0.93478260869565, 1.4833333333333, 0.27777777777778
55983, 0.91304347826087, 1.4666666666667, 0.27777777777778
55984, 0.91304347826087, 1.4833333333333, 0.30555555555556
55985, 0.93478260869565, 1.4833333333333, 0.33333333333333
55986, 0.91304347826087, 1.4666666666667, 0.33333333333333
55987, 0.91304347826087, 1.4833333333333, 0.36111111111111
55988, 0.93478260869565, 1.4833333333333, 0.38888888888889
55989, 0.91304347826087, 1.4666666666667, 0.38888888888889
55990, 0.91304347826087, 1.4833333333333, 0.41666666666667
55991, 0.93478260869565, 1.4833333333333, 0.44444444444444
55992, 0.91304347826087, 1.4666666666667, 0.44444444444444
55993, 0.91304347826087, 1.4833333333333, 0.47222222222222
55994, 0.8695652173913, 1.4833333333333, 0.027777777777778
55995, 0.89130434782609, 1.4833333333333, 0.055555555555556
55996, 0.8695652173913, 1.4666666666667, 0.055555555555556
55997, 0.8695652173913, 1.4833333333333, 0.083333333333333
55998, 0.89130434782609, 1.4833333333333, 0.11111111111111
55999, 0.8695652173913, 1.4666666666667, 0.11111111111111
56000, 0.8695652173913, 1.4833333333333, 0.13888888888889
56001, 0.89130434782609, 1.4833333333333, 0.16666666666667
56002, 0.8695652173913, 1.4666666666667, 0.16666666666667
56003, 0.8695652173913, 1.4833333333333, 0.19444444444444
56004, 0.89130434782609, 1.4833333333333, 0.22222222222222
56005, 0.8695652173913, 1.4666666666667, 0.22222222222222
56006, 0.8695652173913, 1.4833333333333, 0.25
56007, 0.89130434782609, 1.4833333333333, 0.27777777777778
56008, 0.8695652173913, 1.4666666666667, 0.27777777777778
56009, 0.8695652173913, 1.4833333333333, 0.30555555555556
56010, 0.89130434782609, 1.4833333333333, 0.33333333333333
56011, 0.8695652173913, 1.4666666666667, 0.33333333333333
56012, 0.8695652173913, 1.4833333333333, 0.36111111111111
56013, 0.89130434782609, 1.4833333333333, 0.38888888888889
56014, 0.8695652173913, 1.4666666666667, 0.38888888888889
56015, 0.8695652173913, 1.4833333333333, 0.41666666666667
56016, 0.89130434782609, 1.4833333333333, 0.44444444444444
56017, 0.8695652173913, 1.4666666666667, 0.44444444444444
56018, 0.8695652173913, 1.4833333333333, 0.47222222222222
56019, 0.82608695652174, 1.4833333333333, 0.027777777777778
56020, 0.84782608695652, 1.4833333333333, 0.055555555555556
56021, 0.82608695652174, 1.4666666666667, 0.055555555555556
56022, 0.82608695652174, 1.4833333333333, 0.083333333333333
56023, 0.84782608695652, 1.4833333333333, 0.11111111111111
56024, 0.82608695652174, 1.4666666666667, 0.11111111111111
56025, 0.82608695652174, 1.4833333333333, 0.13888888888889
56026, 0.84782608695652, 1.4833333333333, 0.16666666666667
56027, 0.82608695652174, 1.4666666666667, 0.16666666666667
56028, 0.82608695652174, 1.4833333333333, 0.19444444444444
56029, 0.84782608695652, 1.4833333333333, 0.22222222222222
56030, 0.82608695652174, 1.4666666666667, 0.22222222222222
56031, 0.82608695652174, 1.4833333333333, 0.25
56032, 0.84782608695652, 1.4833333333333, 0.27777777777778
56033, 0.82608695652174, 1.4666666666667, 0.27777777777778
56034, 0.82608695652174, 1.4833333333333, 0.30555555555556
56035, 0.84782608695652, 1.4833333333333, 0.33333333333333
56036, 0.82608695652174, 1.4666666666667, 0.33333333333333
56037, 0.82608695652174, 1.4833333333333, 0.36111111111111
56038, 0.84782608695652, 1.4833333333333, 0.38888888888889
56039, 0.82608695652174, 1.4666666666667, 0.38888888888889
56040, 0.82608695652174, 1.4833333333333, 0.41666666666667
56041, 0.84782608695652, 1.4833333333333, 0.44444444444444
56042, 0.82608695652174, 1.4666666666667, 0.44444444444444
56043, 0.82608695652174, 1.4833333333333, 0.47222222222222
56044, 0.78260869565217, 1.4833333333333, 0.027777777777778
56045, 0.80434782608696, 1.4833333333333, 0.055555555555556
56046, 0.78260869565217, 1.4666666666667, 0.055555555555556
56047, 0.78260869565217, 1.4833333333333, 0.083333333333333
56048, 0.80434782608696, 1.4833333333333, 0.11111111111111
56049, 0.78260869565217, 1.4666666666667, 0.11111111111111
56050, 0.78260869565217, 1.4833333333333, 0.13888888888889
56051, 0.80434782608696, 1.4833333333333, 0.16666666666667
56052, 0.78260869565217, 1.4666666666667, 0.16666666666667
56053, 0.78260869565217, 1.4833333333333, 0.19444444444444
56054, 0.80434782608696, 1.4833333333333, 0.22222222222222
56055, 0.78260869565217, 1.4666666666667, 0.22222222222222
56056, 0.78260869565217, 1.4833333333333, 0.25
56057, 0.80434782608696, 1.4833333333333, 0.27777777777778
56058, 0.78260869565217, 1.4666666666667, 0.27777777777778
56059, 0.78260869565217, 1.4833333333333, 0.30555555555556
56060, 0.80434782608696, 1.4833333333333, 0.33333333333333
56061, 0.78260869565217, 1.4666666666667, 0.33333333333333
56062, 0.78260869565217, 1.4833333333333, 0.36111111111111
56063, 0.80434782608696, 1.4833333333333, 0.38888888888889
56064, 0.78260869565217, 1.4666666666667, 0.38888888888889
56065, 0.78260869565217, 1.4833333333333, 0.41666666666667
56066, 0.80434782608696, 1.4833333333333, 0.44444444444444
56067, 0.78260869565217, 1.4666666666667, 0.44444444444444
56068, 0.78260869565217, 1.4833333333333, 0.47222222222222
56069, 0.73913043478261, 1.4833333333333, 0.027777777777778
56070, 0.76086956521739, 1.4833333333333, 0.055555555555556
56071, 0.73913043478261, 1.4666666666667, 0.055555555555556
56072, 0.73913043478261, 1.4833333333333, 0.083333333333333
56073, 0.76086956521739, 1.4833333333333, 0.11111111111111
56074, 0.73913043478261, 1.4666666666667, 0.11111111111111
56075, 0.73913043478261, 1.4833333333333, 0.13888888888889
56076, 0.76086956521739, 1.4833333333333, 0.16666666666667
56077, 0.73913043478261, 1.4666666666667, 0.16666666666667
56078, 0.73913043478261, 1.4833333333333, 0.19444444444444
56079, 0.76086956521739, 1.4833333333333, 0.22222222222222
56080, 0.73913043478261, 1.4666666666667, 0.22222222222222
56081, 0.73913043478261, 1.4833333333333, 0.25
56082, 0.76086956521739, 1.4833333333333, 0.27777777777778
56083, 0.73913043478261, 1.4666666666667, 0.27777777777778
56084, 0.73913043478261, 1.4833333333333, 0.30555555555556
56085, 0.76086956521739, 1.4833333333333, 0.33333333333333
56086, 0.73913043478261, 1.4666666666667, 0.33333333333333
56087, 0.73913043478261, 1.4833333333333, 0.36111111111111
56088, 0.76086956521739, 1.4833333333333, 0.38888888888889
56089, 0.73913043478261, 1.4666666666667, 0.38888888888889
56090, 0.73913043478261, 1.4833333333333, 0.41666666666667
56091, 0.76086956521739, 1.4833333333333, 0.44444444444444
56092, 0.73913043478261, 1.4666666666667, 0.44444444444444
56093, 0.73913043478261, 1.4833333333333, 0.47222222222222
56094, 0.69565217391304, 1.4833333333333, 0.027777777777778
56095, 0.71739130434783, 1.4833333333333, 0.055555555555556
56096, 0.69565217391304, 1.4666666666667, 0.055555555555556
56097, 0.69565217391304, 1.4833333333333, 0.083333333333333
56098, 0.71739130434783, 1.4833333333333, 0.11111111111111
56099, 0.69565217391304, 1.4666666666667, 0.11111111111111
56100, 0.69565217391304, 1.4833333333333, 0.13888888888889
56101, 0.71739130434783, 1.4833333333333, 0.16666666666667
56102, 0.69565217391304, 1.4666666666667, 0.16666666666667
56103, 0.69565217391304, 1.4833333333333, 0.19444444444444
56104, 0.71739130434783, 1.4833333333333, 0.22222222222222
56105, 0.69565217391304, 1.4666666666667, 0.22222222222222
56106, 0.69565217391304, 1.4833333333333, 0.25
56107, 0.71739130434783, 1.4833333333333, 0.27777777777778
56108, 0.69565217391304, 1.4666666666667, 0.27777777777778
56109, 0.69565217391304, 1.4833333333333, 0.30555555555556
56110, 0.71739130434783, 1.4833333333333, 0.33333333333333
56111, 0.69565217391304, 1.4666666666667, 0.33333333333333
56112, 0.69565217391304, 1.4833333333333, 0.36111111111111
56113, 0.71739130434783, 1.4833333333333, 0.38888888888889
56114, 0.69565217391304, 1.4666666666667, 0.38888888888889
56115, 0.69565217391304, 1.4833333333333, 0.41666666666667
56116, 0.71739130434783, 1.4833333333333, 0.44444444444444
56117, 0.69565217391304, 1.4666666666667, 0.44444444444444
56118, 0.69565217391304, 1.4833333333333, 0.47222222222222
56119, 0.65217391304348, 1.4833333333333, 0.027777777777778
56120, 0.67391304347826, 1.4833333333333, 0.055555555555556
56121, 0.65217391304348, 1.4666666666667, 0.055555555555556
56122, 0.65217391304348, 1.4833333333333, 0.083333333333333
56123, 0.67391304347826, 1.4833333333333, 0.11111111111111
56124, 0.65217391304348, 1.4666666666667, 0.11111111111111
56125, 0.65217391304348, 1.4833333333333, 0.13888888888889
56126, 0.67391304347826, 1.4833333333333, 0.16666666666667
56127, 0.65217391304348, 1.4666666666667, 0.16666666666667
56128, 0.65217391304348, 1.4833333333333, 0.19444444444444
56129, 0.67391304347826, 1.4833333333333, 0.22222222222222
56130, 0.65217391304348, 1.4666666666667, 0.22222222222222
56131, 0.65217391304348, 1.4833333333333, 0.25
56132, 0.67391304347826, 1.4833333333333, 0.27777777777778
56133, 0.65217391304348, 1.4666666666667, 0.27777777777778
56134, 0.65217391304348, 1.4833333333333, 0.30555555555556
56135, 0.67391304347826, 1.4833333333333, 0.33333333333333
56136, 0.65217391304348, 1.4666666666667, 0.33333333333333
56137, 0.65217391304348, 1.4833333333333, 0.36111111111111
56138, 0.67391304347826, 1.4833333333333, 0.38888888888889
56139, 0.65217391304348, 1.4666666666667, 0.38888888888889
56140, 0.65217391304348, 1.4833333333333, 0.41666666666667
56141, 0.67391304347826, 1.4833333333333, 0.44444444444444
56142, 0.65217391304348, 1.4666666666667, 0.44444444444444
56143, 0.65217391304348, 1.4833333333333, 0.47222222222222
56144, 0.60869565217391, 1.4833333333333, 0.027777777777778
56145, 0.6304347826087, 1.4833333333333, 0.055555555555556
56146, 0.60869565217391, 1.4666666666667, 0.055555555555556
56147, 0.60869565217391, 1.4833333333333, 0.083333333333333
56148, 0.6304347826087, 1.4833333333333, 0.11111111111111
56149, 0.60869565217391, 1.4666666666667, 0.11111111111111
56150, 0.60869565217391, 1.4833333333333, 0.13888888888889
56151, 0.6304347826087, 1.4833333333333, 0.16666666666667
56152, 0.60869565217391, 1.4666666666667, 0.16666666666667
56153, 0.60869565217391, 1.4833333333333, 0.19444444444444
56154, 0.6304347826087, 1.4833333333333, 0.22222222222222
56155, 0.60869565217391, 1.4666666666667, 0.22222222222222
56156, 0.60869565217391, 1.4833333333333, 0.25
56157, 0.6304347826087, 1.4833333333333, 0.27777777777778
56158, 0.60869565217391, 1.4666666666667, 0.27777777777778
56159, 0.60869565217391, 1.4833333333333, 0.30555555555556
56160, 0.6304347826087, 1.4833333333333, 0.33333333333333
56161, 0.60869565217391, 1.4666666666667, 0.33333333333333
56162, 0.60869565217391, 1.4833333333333, 0.36111111111111
56163, 0.6304347826087, 1.4833333333333, 0.38888888888889
56164, 0.60869565217391, 1.4666666666667, 0.38888888888889
56165, 0.60869565217391, 1.4833333333333, 0.41666666666667
56166, 0.6304347826087, 1.4833333333333, 0.44444444444444
56167, 0.60869565217391, 1.4666666666667, 0.44444444444444
56168, 0.60869565217391, 1.4833333333333, 0.47222222222222
56169, 0.56521739130435, 1.4833333333333, 0.027777777777778
56170, 0.58695652173913, 1.4833333333333, 0.055555555555556
56171, 0.56521739130435, 1.4666666666667, 0.055555555555556
56172, 0.56521739130435, 1.4833333333333, 0.083333333333333
56173, 0.58695652173913, 1.4833333333333, 0.11111111111111
56174, 0.56521739130435, 1.4666666666667, 0.11111111111111
56175, 0.56521739130435, 1.4833333333333, 0.13888888888889
56176, 0.58695652173913, 1.4833333333333, 0.16666666666667
56177, 0.56521739130435, 1.4666666666667, 0.16666666666667
56178, 0.56521739130435, 1.4833333333333, 0.19444444444444
56179, 0.58695652173913, 1.4833333333333, 0.22222222222222
56180, 0.56521739130435, 1.4666666666667, 0.22222222222222
56181, 0.56521739130435, 1.4833333333333, 0.25
56182, 0.58695652173913, 1.4833333333333, 0.27777777777778
56183, 0.56521739130435, 1.4666666666667, 0.27777777777778
56184, 0.56521739130435, 1.4833333333333, 0.30555555555556
56185, 0.58695652173913, 1.4833333333333, 0.33333333333333
56186, 0.56521739130435, 1.4666666666667, 0.33333333333333
56187, 0.56521739130435, 1.4833333333333, 0.36111111111111
56188, 0.58695652173913, 1.4833333333333, 0.38888888888889
56189, 0.56521739130435, 1.4666666666667, 0.38888888888889
56190, 0.56521739130435, 1.4833333333333, 0.41666666666667
56191, 0.58695652173913, 1.4833333333333, 0.44444444444444
56192, 0.56521739130435, 1.4666666666667, 0.44444444444444
56193, 0.56521739130435, 1.4833333333333, 0.47222222222222
56194, 0.52173913043478, 1.4833333333333, 0.027777777777778
56195, 0.54347826086957, 1.4833333333333, 0.055555555555556
56196, 0.52173913043478, 1.4666666666667, 0.055555555555556
56197, 0.52173913043478, 1.4833333333333, 0.083333333333333
56198, 0.54347826086957, 1.4833333333333, 0.11111111111111
56199, 0.52173913043478, 1.4666666666667, 0.11111111111111
56200, 0.52173913043478, 1.4833333333333, 0.13888888888889
56201, 0.54347826086957, 1.4833333333333, 0.16666666666667
56202, 0.52173913043478, 1.4666666666667, 0.16666666666667
56203, 0.52173913043478, 1.4833333333333, 0.19444444444444
56204, 0.54347826086956, 1.4833333333333, 0.22222222222222
56205, 0.52173913043478, 1.4666666666667, 0.22222222222222
56206, 0.52173913043478, 1.4833333333333, 0.25
56207, 0.54347826086956, 1.4833333333333, 0.27777777777778
56208, 0.52173913043478, 1.4666666666667, 0.27777777777778
56209, 0.52173913043478, 1.4833333333333, 0.30555555555556
56210, 0.54347826086956, 1.4833333333333, 0.33333333333333
56211, 0.52173913043478, 1.4666666666667, 0.33333333333333
56212, 0.52173913043478, 1.4833333333333, 0.36111111111111
56213, 0.54347826086956, 1.4833333333333, 0.38888888888889
56214, 0.52173913043478, 1.4666666666667, 0.38888888888889
56215, 0.52173913043478, 1.4833333333333, 0.41666666666667
56216, 0.54347826086956, 1.4833333333333, 0.44444444444444
56217, 0.52173913043478, 1.4666666666667, 0.44444444444444
56218, 0.52173913043478, 1.4833333333333, 0.47222222222222
56219, 0.47826086956522, 1.4833333333333, 0.027777777777778
56220, 0.5, 1.4833333333333, 0.055555555555556
56221, 0.47826086956522, 1.4666666666667, 0.055555555555556
56222, 0.47826086956522, 1.4833333333333, 0.083333333333333
56223, 0.5, 1.4833333333333, 0.11111111111111
56224, 0.47826086956522, 1.4666666666667, 0.11111111111111
56225, 0.47826086956522, 1.4833333333333, 0.13888888888889
56226, 0.5, 1.4833333333333, 0.16666666666667
56227, 0.47826086956522, 1.4666666666667, 0.16666666666667
56228, 0.47826086956522, 1.4833333333333, 0.19444444444444
56229, 0.5, 1.4833333333333, 0.22222222222222
56230, 0.47826086956522, 1.4666666666667, 0.22222222222222
56231, 0.47826086956522, 1.4833333333333, 0.25
56232, 0.5, 1.4833333333333, 0.27777777777778
56233, 0.47826086956522, 1.4666666666667, 0.27777777777778
56234, 0.47826086956522, 1.4833333333333, 0.30555555555556
56235, 0.5, 1.4833333333333, 0.33333333333333
56236, 0.47826086956522, 1.4666666666667, 0.33333333333333
56237, 0.47826086956522, 1.4833333333333, 0.36111111111111
56238, 0.5, 1.4833333333333, 0.38888888888889
56239, 0.47826086956522, 1.4666666666667, 0.38888888888889
56240, 0.47826086956522, 1.4833333333333, 0.41666666666667
56241, 0.5, 1.4833333333333, 0.44444444444444
56242, 0.47826086956522, 1.4666666666667, 0.44444444444444
56243, 0.47826086956522, 1.4833333333333, 0.47222222222222
56244, 0.43478260869565, 1.4833333333333, 0.027777777777778
56245, 0.45652173913043, 1.4833333333333, 0.055555555555556
56246, 0.43478260869565, 1.4666666666667, 0.055555555555556
56247, 0.43478260869565, 1.4833333333333, 0.083333333333333
56248, 0.45652173913043, 1.4833333333333, 0.11111111111111
56249, 0.43478260869565, 1.4666666666667, 0.11111111111111
56250, 0.43478260869565, 1.4833333333333, 0.13888888888889
56251, 0.45652173913043, 1.4833333333333, 0.16666666666667
56252, 0.43478260869565, 1.4666666666667, 0.16666666666667
56253, 0.43478260869565, 1.4833333333333, 0.19444444444444
56254, 0.45652173913043, 1.4833333333333, 0.22222222222222
56255, 0.43478260869565, 1.4666666666667, 0.22222222222222
56256, 0.43478260869565, 1.4833333333333, 0.25
56257, 0.45652173913043, 1.4833333333333, 0.27777777777778
56258, 0.43478260869565, 1.4666666666667, 0.27777777777778
56259, 0.43478260869565, 1.4833333333333, 0.30555555555556
56260, 0.45652173913043, 1.4833333333333, 0.33333333333333
56261, 0.43478260869565, 1.4666666666667, 0.33333333333333
56262, 0.43478260869565, 1.4833333333333, 0.36111111111111
56263, 0.45652173913044, 1.4833333333333, 0.38888888888889
56264, 0.43478260869565, 1.4666666666667, 0.38888888888889
56265, 0.43478260869565, 1.4833333333333, 0.41666666666667
56266, 0.45652173913043, 1.4833333333333, 0.44444444444444
56267, 0.43478260869565, 1.4666666666667, 0.44444444444444
56268, 0.43478260869565, 1.4833333333333, 0.47222222222222
56269, 0.39130434782609, 1.4833333333333, 0.027777777777778
56270, 0.41304347826087, 1.4833333333333, 0.055555555555556
56271, 0.39130434782609, 1.4666666666667, 0.055555555555556
56272, 0.39130434782609, 1.4833333333333, 0.083333333333333
56273, 0.41304347826087, 1.4833333333333, 0.11111111111111
56274, 0.39130434782609, 1.4666666666667, 0.11111111111111
56275, 0.39130434782609, 1.4833333333333, 0.13888888888889
56276, 0.41304347826087, 1.4833333333333, 0.16666666666667
56277, 0.39130434782609, 1.4666666666667, 0.16666666666667
56278, 0.39130434782609, 1.4833333333333, 0.19444444444444
56279, 0.41304347826087, 1.4833333333333, 0.22222222222222
56280, 0.39130434782609, 1.4666666666667, 0.22222222222222
56281, 0.39130434782609, 1.4833333333333, 0.25
56282, 0.41304347826087, 1.4833333333333, 0.27777777777778
56283, 0.39130434782609, 1.4666666666667, 0.27777777777778
56284, 0.39130434782609, 1.4833333333333, 0.30555555555556
56285, 0.41304347826087, 1.4833333333333, 0.33333333333333
56286, 0.39130434782609, 1.4666666666667, 0.33333333333333
56287, 0.39130434782609, 1.4833333333333, 0.36111111111111
56288, 0.41304347826087, 1.4833333333333, 0.38888888888889
56289, 0.39130434782609, 1.4666666666667, 0.38888888888889
56290, 0.39130434782609, 1.4833333333333, 0.41666666666667
56291, 0.41304347826087, 1.4833333333333, 0.44444444444444
56292, 0.39130434782609, 1.4666666666667, 0.44444444444444
56293, 0.39130434782609, 1.4833333333333, 0.47222222222222
56294, 0.34782608695652, 1.4833333333333, 0.027777777777778
56295, 0.3695652173913, 1.4833333333333, 0.055555555555556
56296, 0.34782608695652, 1.4666666666667, 0.055555555555556
56297, 0.34782608695652, 1.4833333333333, 0.083333333333333
56298, 0.3695652173913, 1.4833333333333, 0.11111111111111
56299, 0.34782608695652, 1.4666666666667, 0.11111111111111
56300, 0.34782608695652, 1.4833333333333, 0.13888888888889
56301, 0.3695652173913, 1.4833333333333, 0.16666666666667
56302, 0.34782608695652, 1.4666666666667, 0.16666666666667
56303, 0.34782608695652, 1.4833333333333, 0.19444444444444
56304, 0.3695652173913, 1.4833333333333, 0.22222222222222
56305, 0.34782608695652, 1.4666666666667, 0.22222222222222
56306, 0.34782608695652, 1.4833333333333, 0.25
56307, 0.3695652173913, 1.4833333333333, 0.27777777777778
56308, 0.34782608695652, 1.4666666666667, 0.27777777777778
56309, 0.34782608695652, 1.4833333333333, 0.30555555555556
56310, 0.3695652173913, 1.4833333333333, 0.33333333333333
56311, 0.34782608695652, 1.4666666666667, 0.33333333333333
56312, 0.34782608695652, 1.4833333333333, 0.36111111111111
56313, 0.3695652173913, 1.4833333333333, 0.38888888888889
56314, 0.34782608695652, 1.4666666666667, 0.38888888888889
56315, 0.34782608695652, 1.4833333333333, 0.41666666666667
56316, 0.3695652173913, 1.4833333333333, 0.44444444444444
56317, 0.34782608695652, 1.4666666666667, 0.44444444444444
56318, 0.34782608695652, 1.4833333333333, 0.47222222222222
56319, 0.30434782608696, 1.4833333333333, 0.027777777777778
56320, 0.32608695652174, 1.4833333333333, 0.055555555555556
56321, 0.30434782608696, 1.4666666666667, 0.055555555555556
56322, 0.30434782608696, 1.4833333333333, 0.083333333333333
56323, 0.32608695652174, 1.4833333333333, 0.11111111111111
56324, 0.30434782608696, 1.4666666666667, 0.11111111111111
56325, 0.30434782608696, 1.4833333333333, 0.13888888888889
56326, 0.32608695652174, 1.4833333333333, 0.16666666666667
56327, 0.30434782608696, 1.4666666666667, 0.16666666666667
56328, 0.30434782608696, 1.4833333333333, 0.19444444444444
56329, 0.32608695652174, 1.4833333333333, 0.22222222222222
56330, 0.30434782608696, 1.4666666666667, 0.22222222222222
56331, 0.30434782608696, 1.4833333333333, 0.25
56332, 0.32608695652174, 1.4833333333333, 0.27777777777778
56333, 0.30434782608696, 1.4666666666667, 0.27777777777778
56334, 0.30434782608696, 1.4833333333333, 0.30555555555556
56335, 0.32608695652174, 1.4833333333333, 0.33333333333333
56336, 0.30434782608696, 1.4666666666667, 0.33333333333333
56337, 0.30434782608696, 1.4833333333333, 0.36111111111111
56338, 0.32608695652174, 1.4833333333333, 0.38888888888889
56339, 0.30434782608696, 1.4666666666667, 0.38888888888889
56340, 0.30434782608696, 1.4833333333333, 0.41666666666667
56341, 0.32608695652174, 1.4833333333333, 0.44444444444444
56342, 0.30434782608696, 1.4666666666667, 0.44444444444444
56343, 0.30434782608696, 1.4833333333333, 0.47222222222222
56344, 0.26086956521739, 1.4833333333333, 0.027777777777778
56345, 0.28260869565217, 1.4833333333333, 0.055555555555556
56346, 0.26086956521739, 1.4666666666667, 0.055555555555556
56347, 0.26086956521739, 1.4833333333333, 0.083333333333333
56348, 0.28260869565217, 1.4833333333333, 0.11111111111111
56349, 0.26086956521739, 1.4666666666667, 0.11111111111111
56350, 0.26086956521739, 1.4833333333333, 0.13888888888889
56351, 0.28260869565217, 1.4833333333333, 0.16666666666667
56352, 0.26086956521739, 1.4666666666667, 0.16666666666667
56353, 0.26086956521739, 1.4833333333333, 0.19444444444444
56354, 0.28260869565217, 1.4833333333333, 0.22222222222222
56355, 0.26086956521739, 1.4666666666667, 0.22222222222222
56356, 0.26086956521739, 1.4833333333333, 0.25
56357, 0.28260869565217, 1.4833333333333, 0.27777777777778
56358, 0.26086956521739, 1.4666666666667, 0.27777777777778
56359, 0.26086956521739, 1.4833333333333, 0.30555555555556
56360, 0.28260869565217, 1.4833333333333, 0.33333333333333
56361, 0.26086956521739, 1.4666666666667, 0.33333333333333
56362, 0.26086956521739, 1.4833333333333, 0.36111111111111
56363, 0.28260869565217, 1.4833333333333, 0.38888888888889
56364, 0.26086956521739, 1.4666666666667, 0.38888888888889
56365, 0.26086956521739, 1.4833333333333, 0.41666666666667
56366, 0.28260869565217, 1.4833333333333, 0.44444444444444
56367, 0.26086956521739, 1.4666666666667, 0.44444444444444
56368, 0.26086956521739, 1.4833333333333, 0.47222222222222
56369, 0.21739130434783, 1.4833333333333, 0.027777777777778
56370, 0.23913043478261, 1.4833333333333, 0.055555555555556
56371, 0.21739130434783, 1.4666666666667, 0.055555555555556
56372, 0.21739130434783, 1.4833333333333, 0.083333333333333
56373, 0.23913043478261, 1.4833333333333, 0.11111111111111
56374, 0.21739130434783, 1.4666666666667, 0.11111111111111
56375, 0.21739130434783, 1.4833333333333, 0.13888888888889
56376, 0.23913043478261, 1.4833333333333, 0.16666666666667
56377, 0.21739130434783, 1.4666666666667, 0.16666666666667
56378, 0.21739130434783, 1.4833333333333, 0.19444444444444
56379, 0.23913043478261, 1.4833333333333, 0.22222222222222
56380, 0.21739130434783, 1.4666666666667, 0.22222222222222
56381, 0.21739130434783, 1.4833333333333, 0.25
56382, 0.23913043478261, 1.4833333333333, 0.27777777777778
56383, 0.21739130434783, 1.4666666666667, 0.27777777777778
56384, 0.21739130434783, 1.4833333333333, 0.30555555555556
56385, 0.23913043478261, 1.4833333333333, 0.33333333333333
56386, 0.21739130434783, 1.4666666666667, 0.33333333333333
56387, 0.21739130434783, 1.4833333333333, 0.36111111111111
56388, 0.23913043478261, 1.4833333333333, 0.38888888888889
56389, 0.21739130434783, 1.4666666666667, 0.38888888888889
56390, 0.21739130434783, 1.4833333333333, 0.41666666666667
56391, 0.23913043478261, 1.4833333333333, 0.44444444444444
56392, 0.21739130434783, 1.4666666666667, 0.44444444444444
56393, 0.21739130434783, 1.4833333333333, 0.47222222222222
56394, 0.17391304347826, 1.4833333333333, 0.027777777777778
56395, 0.19565217391304, 1.4833333333333, 0.055555555555556
56396, 0.17391304347826, 1.4666666666667, 0.055555555555556
56397, 0.17391304347826, 1.4833333333333, 0.083333333333333
56398, 0.19565217391304, 1.4833333333333, 0.11111111111111
56399, 0.17391304347826, 1.4666666666667, 0.11111111111111
56400, 0.17391304347826, 1.4833333333333, 0.13888888888889
56401, 0.19565217391304, 1.4833333333333, 0.16666666666667
56402, 0.17391304347826, 1.4666666666667, 0.16666666666667
56403, 0.17391304347826, 1.4833333333333, 0.19444444444444
56404, 0.19565217391304, 1.4833333333333, 0.22222222222222
56405, 0.17391304347826, 1.4666666666667, 0.22222222222222
56406, 0.17391304347826, 1.4833333333333, 0.25
56407, 0.19565217391304, 1.4833333333333, 0.27777777777778
56408, 0.17391304347826, 1.4666666666667, 0.27777777777778
56409, 0.17391304347826, 1.4833333333333, 0.30555555555556
56410, 0.19565217391304, 1.4833333333333, 0.33333333333333
56411, 0.17391304347826, 1.4666666666667, 0.33333333333333
56412, 0.17391304347826, 1.4833333333333, 0.36111111111111
56413, 0.19565217391304, 1.4833333333333, 0.38888888888889
56414, 0.17391304347826, 1.4666666666667, 0.38888888888889
56415, 0.17391304347826, 1.4833333333333, 0.41666666666667
56416, 0.19565217391304, 1.4833333333333, 0.44444444444444
56417, 0.17391304347826, 1.4666666666667, 0.44444444444444
56418, 0.17391304347826, 1.4833333333333, 0.47222222222222
56419, 0.1304347826087, 1.4833333333333, 0.027777777777778
56420, 0.15217391304348, 1.4833333333333, 0.055555555555556
56421, 0.1304347826087, 1.4666666666667, 0.055555555555556
56422, 0.1304347826087, 1.4833333333333, 0.083333333333333
56423, 0.15217391304348, 1.4833333333333, 0.11111111111111
56424, 0.1304347826087, 1.4666666666667, 0.11111111111111
56425, 0.1304347826087, 1.4833333333333, 0.13888888888889
56426, 0.15217391304348, 1.4833333333333, 0.16666666666667
56427, 0.1304347826087, 1.4666666666667, 0.16666666666667
56428, 0.1304347826087, 1.4833333333333, 0.19444444444444
56429, 0.15217391304348, 1.4833333333333, 0.22222222222222
56430, 0.1304347826087, 1.4666666666667, 0.22222222222222
56431, 0.1304347826087, 1.4833333333333, 0.25
56432, 0.15217391304348, 1.4833333333333, 0.27777777777778
56433, 0.1304347826087, 1.4666666666667, 0.27777777777778
56434, 0.1304347826087, 1.4833333333333, 0.30555555555556
56435, 0.15217391304348, 1.4833333333333, 0.33333333333333
56436, 0.1304347826087, 1.4666666666667, 0.33333333333333
56437, 0.1304347826087, 1.4833333333333, 0.36111111111111
56438, 0.15217391304348, 1.4833333333333, 0.38888888888889
56439, 0.1304347826087, 1.4666666666667, 0.38888888888889
56440, 0.1304347826087, 1.4833333333333, 0.41666666666667
56441, 0.15217391304348, 1.4833333333333, 0.44444444444444
56442, 0.1304347826087, 1.4666666666667, 0.44444444444444
56443, 0.1304347826087, 1.4833333333333, 0.47222222222222
56444, 0.08695652173913, 1.4833333333333, 0.027777777777778
56445, 0.10869565217391, 1.4833333333333, 0.055555555555556
56446, 0.08695652173913, 1.4666666666667, 0.055555555555556
56447, 0.08695652173913, 1.4833333333333, 0.083333333333333
56448, 0.10869565217391, 1.4833333333333, 0.11111111111111
56449, 0.08695652173913, 1.4666666666667, 0.11111111111111
56450, 0.08695652173913, 1.4833333333333, 0.13888888888889
56451, 0.10869565217391, 1.4833333333333, 0.16666666666667
56452, 0.08695652173913, 1.4666666666667, 0.16666666666667
56453, 0.08695652173913, 1.4833333333333, 0.19444444444444
56454, 0.10869565217391, 1.4833333333333, 0.22222222222222
56455, 0.08695652173913, 1.4666666666667, 0.22222222222222
56456, 0.08695652173913, 1.4833333333333, 0.25
56457, 0.10869565217391, 1.4833333333333, 0.27777777777778
56458, 0.08695652173913, 1.4666666666667, 0.27777777777778
56459, 0.08695652173913, 1.4833333333333, 0.30555555555556
56460, 0.10869565217391, 1.4833333333333, 0.33333333333333
