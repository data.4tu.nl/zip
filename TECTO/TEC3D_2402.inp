67079, 1.895652173913, 1.0630434782609, 0.22222222222222
67080, 1.895652173913, 1.0369565217391, 0.19444444444444
67081, 1.8739130434783, 1.0369565217391, 0.16666666666667
67082, 1.895652173913, 1.0630434782609, 0.16666666666667
67083, 1.895652173913, 1.0369565217391, 0.13888888888889
67084, 1.8739130434783, 1.0369565217391, 0.11111111111111
67085, 1.895652173913, 1.0630434782609, 0.11111111111111
67086, 1.895652173913, 1.0369565217391, 0.083333333333333
67087, 1.8739130434783, 1.0369565217391, 0.055555555555556
67088, 1.895652173913, 1.0630434782609, 0.055555555555556
67089, 1.895652173913, 1.0369565217391, 0.027777777777778
67090, 1.9391304347826, 1.0369565217391, 0.47222222222222
67091, 1.9173913043478, 1.0369565217391, 0.44444444444444
67092, 1.9391304347826, 1.0630434782609, 0.44444444444444
67093, 1.9391304347826, 1.0369565217391, 0.41666666666667
67094, 1.9173913043478, 1.0369565217391, 0.38888888888889
67095, 1.9391304347826, 1.0630434782609, 0.38888888888889
67096, 1.9391304347826, 1.0369565217391, 0.36111111111111
67097, 1.9173913043478, 1.0369565217391, 0.33333333333333
67098, 1.9391304347826, 1.0630434782609, 0.33333333333333
67099, 1.9391304347826, 1.0369565217391, 0.30555555555556
67100, 1.9173913043478, 1.0369565217391, 0.27777777777778
67101, 1.9391304347826, 1.0630434782609, 0.27777777777778
67102, 1.9391304347826, 1.0369565217391, 0.25
67103, 1.9173913043478, 1.0369565217391, 0.22222222222222
67104, 1.9391304347826, 1.0630434782609, 0.22222222222222
67105, 1.9391304347826, 1.0369565217391, 0.19444444444444
67106, 1.9173913043478, 1.0369565217391, 0.16666666666667
67107, 1.9391304347826, 1.0630434782609, 0.16666666666667
67108, 1.9391304347826, 1.0369565217391, 0.13888888888889
67109, 1.9173913043478, 1.0369565217391, 0.11111111111111
67110, 1.9391304347826, 1.0630434782609, 0.11111111111111
67111, 1.9391304347826, 1.0369565217391, 0.083333333333333
67112, 1.9173913043478, 1.0369565217391, 0.055555555555556
67113, 1.9391304347826, 1.0630434782609, 0.055555555555556
67114, 1.9391304347826, 1.0369565217391, 0.027777777777778
67115, 1.9826086956522, 1.0369565217391, 0.47222222222222
67116, 1.9608695652174, 1.0369565217391, 0.44444444444444
67117, 1.9826086956522, 1.0630434782609, 0.44444444444444
67118, 1.9826086956522, 1.0369565217391, 0.41666666666667
67119, 1.9608695652174, 1.0369565217391, 0.38888888888889
67120, 1.9826086956522, 1.0630434782609, 0.38888888888889
67121, 1.9826086956522, 1.0369565217391, 0.36111111111111
67122, 1.9608695652174, 1.0369565217391, 0.33333333333333
67123, 1.9826086956522, 1.0630434782609, 0.33333333333333
67124, 1.9826086956522, 1.0369565217391, 0.30555555555556
67125, 1.9608695652174, 1.0369565217391, 0.27777777777778
67126, 1.9826086956522, 1.0630434782609, 0.27777777777778
67127, 1.9826086956522, 1.0369565217391, 0.25
67128, 1.9608695652174, 1.0369565217391, 0.22222222222222
67129, 1.9826086956522, 1.0630434782609, 0.22222222222222
67130, 1.9826086956522, 1.0369565217391, 0.19444444444444
67131, 1.9608695652174, 1.0369565217391, 0.16666666666667
67132, 1.9826086956522, 1.0630434782609, 0.16666666666667
67133, 1.9826086956522, 1.0369565217391, 0.13888888888889
67134, 1.9608695652174, 1.0369565217391, 0.11111111111111
67135, 1.9826086956522, 1.0630434782609, 0.11111111111111
67136, 1.9826086956522, 1.0369565217391, 0.083333333333333
67137, 1.9608695652174, 1.0369565217391, 0.055555555555556
67138, 1.9826086956522, 1.0630434782609, 0.055555555555556
67139, 1.9826086956522, 1.0369565217391, 0.027777777777778
67140, 2.0260869565217, 1.0369565217391, 0.47222222222222
67141, 2.004347826087, 1.0369565217391, 0.44444444444444
67142, 2.0260869565217, 1.0630434782609, 0.44444444444444
67143, 2.0260869565217, 1.0369565217391, 0.41666666666667
67144, 2.004347826087, 1.0369565217391, 0.38888888888889
67145, 2.0260869565217, 1.0630434782609, 0.38888888888889
67146, 2.0260869565217, 1.0369565217391, 0.36111111111111
67147, 2.004347826087, 1.0369565217391, 0.33333333333333
67148, 2.0260869565217, 1.0630434782609, 0.33333333333333
67149, 2.0260869565217, 1.0369565217391, 0.30555555555556
67150, 2.004347826087, 1.0369565217391, 0.27777777777778
67151, 2.0260869565217, 1.0630434782609, 0.27777777777778
67152, 2.0260869565217, 1.0369565217391, 0.25
67153, 2.004347826087, 1.0369565217391, 0.22222222222222
67154, 2.0260869565217, 1.0630434782609, 0.22222222222222
67155, 2.0260869565217, 1.0369565217391, 0.19444444444444
67156, 2.004347826087, 1.0369565217391, 0.16666666666667
67157, 2.0260869565217, 1.0630434782609, 0.16666666666667
67158, 2.0260869565217, 1.0369565217391, 0.13888888888889
67159, 2.004347826087, 1.0369565217391, 0.11111111111111
67160, 2.0260869565217, 1.0630434782609, 0.11111111111111
67161, 2.0260869565217, 1.0369565217391, 0.083333333333333
67162, 2.004347826087, 1.0369565217391, 0.055555555555556
67163, 2.0260869565217, 1.0630434782609, 0.055555555555556
67164, 2.0260869565217, 1.0369565217391, 0.027777777777778
67165, 2.0695652173913, 1.0369565217391, 0.47222222222222
67166, 2.0478260869565, 1.0369565217391, 0.44444444444444
67167, 2.0695652173913, 1.0630434782609, 0.44444444444444
67168, 2.0695652173913, 1.0369565217391, 0.41666666666667
67169, 2.0478260869565, 1.0369565217391, 0.38888888888889
67170, 2.0695652173913, 1.0630434782609, 0.38888888888889
67171, 2.0695652173913, 1.0369565217391, 0.36111111111111
67172, 2.0478260869565, 1.0369565217391, 0.33333333333333
67173, 2.0695652173913, 1.0630434782609, 0.33333333333333
67174, 2.0695652173913, 1.0369565217391, 0.30555555555556
67175, 2.0478260869565, 1.0369565217391, 0.27777777777778
67176, 2.0695652173913, 1.0630434782609, 0.27777777777778
67177, 2.0695652173913, 1.0369565217391, 0.25
67178, 2.0478260869565, 1.0369565217391, 0.22222222222222
67179, 2.0695652173913, 1.0630434782609, 0.22222222222222
67180, 2.0695652173913, 1.0369565217391, 0.19444444444444
67181, 2.0478260869565, 1.0369565217391, 0.16666666666667
67182, 2.0695652173913, 1.0630434782609, 0.16666666666667
67183, 2.0695652173913, 1.0369565217391, 0.13888888888889
67184, 2.0478260869565, 1.0369565217391, 0.11111111111111
67185, 2.0695652173913, 1.0630434782609, 0.11111111111111
67186, 2.0695652173913, 1.0369565217391, 0.083333333333333
67187, 2.0478260869565, 1.0369565217391, 0.055555555555556
67188, 2.0695652173913, 1.0630434782609, 0.055555555555556
67189, 2.0695652173913, 1.0369565217391, 0.027777777777778
67190, 2.1130434782609, 1.0369565217391, 0.47222222222222
67191, 2.0913043478261, 1.0369565217391, 0.44444444444444
67192, 2.1130434782609, 1.0630434782609, 0.44444444444444
67193, 2.1130434782609, 1.0369565217391, 0.41666666666667
67194, 2.0913043478261, 1.0369565217391, 0.38888888888889
67195, 2.1130434782609, 1.0630434782609, 0.38888888888889
67196, 2.1130434782609, 1.0369565217391, 0.36111111111111
67197, 2.0913043478261, 1.0369565217391, 0.33333333333333
67198, 2.1130434782609, 1.0630434782609, 0.33333333333333
67199, 2.1130434782609, 1.0369565217391, 0.30555555555556
67200, 2.0913043478261, 1.0369565217391, 0.27777777777778
67201, 2.1130434782609, 1.0630434782609, 0.27777777777778
67202, 2.1130434782609, 1.0369565217391, 0.25
67203, 2.0913043478261, 1.0369565217391, 0.22222222222222
67204, 2.1130434782609, 1.0630434782609, 0.22222222222222
67205, 2.1130434782609, 1.0369565217391, 0.19444444444444
67206, 2.0913043478261, 1.0369565217391, 0.16666666666667
67207, 2.1130434782609, 1.0630434782609, 0.16666666666667
67208, 2.1130434782609, 1.0369565217391, 0.13888888888889
67209, 2.0913043478261, 1.0369565217391, 0.11111111111111
67210, 2.1130434782609, 1.0630434782609, 0.11111111111111
67211, 2.1130434782609, 1.0369565217391, 0.083333333333333
67212, 2.0913043478261, 1.0369565217391, 0.055555555555556
67213, 2.1130434782609, 1.0630434782609, 0.055555555555556
67214, 2.1130434782609, 1.0369565217391, 0.027777777777778
67215, 2.1565217391304, 1.0369565217391, 0.47222222222222
67216, 2.1347826086957, 1.0369565217391, 0.44444444444444
67217, 2.1565217391304, 1.0630434782609, 0.44444444444444
67218, 2.1565217391304, 1.0369565217391, 0.41666666666667
67219, 2.1347826086957, 1.0369565217391, 0.38888888888889
67220, 2.1565217391304, 1.0630434782609, 0.38888888888889
67221, 2.1565217391304, 1.0369565217391, 0.36111111111111
67222, 2.1347826086957, 1.0369565217391, 0.33333333333333
67223, 2.1565217391304, 1.0630434782609, 0.33333333333333
67224, 2.1565217391304, 1.0369565217391, 0.30555555555556
67225, 2.1347826086957, 1.0369565217391, 0.27777777777778
67226, 2.1565217391304, 1.0630434782609, 0.27777777777778
67227, 2.1565217391304, 1.0369565217391, 0.25
67228, 2.1347826086957, 1.0369565217391, 0.22222222222222
67229, 2.1565217391304, 1.0630434782609, 0.22222222222222
67230, 2.1565217391304, 1.0369565217391, 0.19444444444444
67231, 2.1347826086957, 1.0369565217391, 0.16666666666667
67232, 2.1565217391304, 1.0630434782609, 0.16666666666667
67233, 2.1565217391304, 1.0369565217391, 0.13888888888889
67234, 2.1347826086957, 1.0369565217391, 0.11111111111111
67235, 2.1565217391304, 1.0630434782609, 0.11111111111111
67236, 2.1565217391304, 1.0369565217391, 0.083333333333333
67237, 2.1347826086957, 1.0369565217391, 0.055555555555556
67238, 2.1565217391304, 1.0630434782609, 0.055555555555556
67239, 2.1565217391304, 1.0369565217391, 0.027777777777778
67240, 2.1782608695652, 1.0369565217391, 0.44444444444444
67241, 2.1782608695652, 1.0369565217391, 0.38888888888889
67242, 2.1782608695652, 1.0369565217391, 0.33333333333333
67243, 2.1782608695652, 1.0369565217391, 0.27777777777778
67244, 2.1782608695652, 1.0369565217391, 0.22222222222222
67245, 2.1782608695652, 1.0369565217391, 0.16666666666667
67246, 2.1782608695652, 1.0369565217391, 0.11111111111111
67247, 2.1782608695652, 1.0369565217391, 0.055555555555556
67248, 1.2434782608696, 0.98478260869565, 0.47222222222222
67249, 1.2217391304348, 0.98478260869565, 0.44444444444444
67250, 1.2434782608696, 1.0108695652174, 0.44444444444444
67251, 1.2434782608696, 0.98478260869565, 0.41666666666667
67252, 1.2217391304348, 0.98478260869565, 0.38888888888889
67253, 1.2434782608696, 1.0108695652174, 0.38888888888889
67254, 1.2434782608696, 0.98478260869565, 0.36111111111111
67255, 1.2217391304348, 0.98478260869565, 0.33333333333333
67256, 1.2434782608696, 1.0108695652174, 0.33333333333333
67257, 1.2434782608696, 0.98478260869565, 0.30555555555556
67258, 1.2217391304348, 0.98478260869565, 0.27777777777778
67259, 1.2434782608696, 1.0108695652174, 0.27777777777778
67260, 1.2434782608696, 0.98478260869565, 0.25
67261, 1.2217391304348, 0.98478260869565, 0.22222222222222
67262, 1.2434782608696, 1.0108695652174, 0.22222222222222
67263, 1.2434782608696, 0.98478260869565, 0.19444444444444
67264, 1.2217391304348, 0.98478260869565, 0.16666666666667
67265, 1.2434782608696, 1.0108695652174, 0.16666666666667
67266, 1.2434782608696, 0.98478260869565, 0.13888888888889
67267, 1.2217391304348, 0.98478260869565, 0.11111111111111
67268, 1.2434782608696, 1.0108695652174, 0.11111111111111
67269, 1.2434782608696, 0.98478260869565, 0.083333333333333
67270, 1.2217391304348, 0.98478260869565, 0.055555555555556
67271, 1.2434782608696, 1.0108695652174, 0.055555555555556
67272, 1.2434782608696, 0.98478260869565, 0.027777777777778
67273, 1.2869565217391, 0.98478260869565, 0.47222222222222
67274, 1.2652173913043, 0.98478260869565, 0.44444444444444
67275, 1.2869565217391, 1.0108695652174, 0.44444444444444
67276, 1.2869565217391, 0.98478260869565, 0.41666666666667
67277, 1.2652173913043, 0.98478260869565, 0.38888888888889
67278, 1.2869565217391, 1.0108695652174, 0.38888888888889
67279, 1.2869565217391, 0.98478260869565, 0.36111111111111
67280, 1.2652173913043, 0.98478260869565, 0.33333333333333
67281, 1.2869565217391, 1.0108695652174, 0.33333333333333
67282, 1.2869565217391, 0.98478260869565, 0.30555555555556
67283, 1.2652173913043, 0.98478260869565, 0.27777777777778
67284, 1.2869565217391, 1.0108695652174, 0.27777777777778
67285, 1.2869565217391, 0.98478260869565, 0.25
67286, 1.2652173913043, 0.98478260869565, 0.22222222222222
67287, 1.2869565217391, 1.0108695652174, 0.22222222222222
67288, 1.2869565217391, 0.98478260869565, 0.19444444444444
67289, 1.2652173913043, 0.98478260869565, 0.16666666666667
67290, 1.2869565217391, 1.0108695652174, 0.16666666666667
67291, 1.2869565217391, 0.98478260869565, 0.13888888888889
67292, 1.2652173913043, 0.98478260869565, 0.11111111111111
67293, 1.2869565217391, 1.0108695652174, 0.11111111111111
67294, 1.2869565217391, 0.98478260869565, 0.083333333333333
67295, 1.2652173913043, 0.98478260869565, 0.055555555555556
67296, 1.2869565217391, 1.0108695652174, 0.055555555555556
67297, 1.2869565217391, 0.98478260869565, 0.027777777777778
67298, 1.3304347826087, 0.98478260869565, 0.47222222222222
67299, 1.3086956521739, 0.98478260869565, 0.44444444444444
67300, 1.3304347826087, 1.0108695652174, 0.44444444444444
67301, 1.3304347826087, 0.98478260869565, 0.41666666666667
67302, 1.3086956521739, 0.98478260869565, 0.38888888888889
67303, 1.3304347826087, 1.0108695652174, 0.38888888888889
67304, 1.3304347826087, 0.98478260869565, 0.36111111111111
67305, 1.3086956521739, 0.98478260869565, 0.33333333333333
67306, 1.3304347826087, 1.0108695652174, 0.33333333333333
67307, 1.3304347826087, 0.98478260869565, 0.30555555555556
67308, 1.3086956521739, 0.98478260869565, 0.27777777777778
67309, 1.3304347826087, 1.0108695652174, 0.27777777777778
67310, 1.3304347826087, 0.98478260869565, 0.25
67311, 1.3086956521739, 0.98478260869565, 0.22222222222222
67312, 1.3304347826087, 1.0108695652174, 0.22222222222222
67313, 1.3304347826087, 0.98478260869565, 0.19444444444444
67314, 1.3086956521739, 0.98478260869565, 0.16666666666667
67315, 1.3304347826087, 1.0108695652174, 0.16666666666667
67316, 1.3304347826087, 0.98478260869565, 0.13888888888889
67317, 1.3086956521739, 0.98478260869565, 0.11111111111111
67318, 1.3304347826087, 1.0108695652174, 0.11111111111111
67319, 1.3304347826087, 0.98478260869565, 0.083333333333333
67320, 1.3086956521739, 0.98478260869565, 0.055555555555556
67321, 1.3304347826087, 1.0108695652174, 0.055555555555556
67322, 1.3304347826087, 0.98478260869565, 0.027777777777778
67323, 1.3739130434783, 0.98478260869565, 0.47222222222222
67324, 1.3521739130435, 0.98478260869565, 0.44444444444444
67325, 1.3739130434783, 1.0108695652174, 0.44444444444444
67326, 1.3739130434783, 0.98478260869565, 0.41666666666667
67327, 1.3521739130435, 0.98478260869565, 0.38888888888889
67328, 1.3739130434783, 1.0108695652174, 0.38888888888889
67329, 1.3739130434783, 0.98478260869565, 0.36111111111111
67330, 1.3521739130435, 0.98478260869565, 0.33333333333333
67331, 1.3739130434783, 1.0108695652174, 0.33333333333333
67332, 1.3739130434783, 0.98478260869565, 0.30555555555556
67333, 1.3521739130435, 0.98478260869565, 0.27777777777778
67334, 1.3739130434783, 1.0108695652174, 0.27777777777778
67335, 1.3739130434783, 0.98478260869565, 0.25
67336, 1.3521739130435, 0.98478260869565, 0.22222222222222
67337, 1.3739130434783, 1.0108695652174, 0.22222222222222
67338, 1.3739130434783, 0.98478260869565, 0.19444444444444
67339, 1.3521739130435, 0.98478260869565, 0.16666666666667
67340, 1.3739130434783, 1.0108695652174, 0.16666666666667
67341, 1.3739130434783, 0.98478260869565, 0.13888888888889
67342, 1.3521739130435, 0.98478260869565, 0.11111111111111
67343, 1.3739130434783, 1.0108695652174, 0.11111111111111
67344, 1.3739130434783, 0.98478260869565, 0.083333333333333
67345, 1.3521739130435, 0.98478260869565, 0.055555555555556
67346, 1.3739130434783, 1.0108695652174, 0.055555555555556
67347, 1.3739130434783, 0.98478260869565, 0.027777777777778
67348, 1.4173913043478, 0.98478260869565, 0.47222222222222
67349, 1.395652173913, 0.98478260869565, 0.44444444444444
67350, 1.4173913043478, 1.0108695652174, 0.44444444444444
67351, 1.4173913043478, 0.98478260869565, 0.41666666666667
67352, 1.395652173913, 0.98478260869565, 0.38888888888889
67353, 1.4173913043478, 1.0108695652174, 0.38888888888889
67354, 1.4173913043478, 0.98478260869565, 0.36111111111111
67355, 1.395652173913, 0.98478260869565, 0.33333333333333
67356, 1.4173913043478, 1.0108695652174, 0.33333333333333
67357, 1.4173913043478, 0.98478260869565, 0.30555555555556
67358, 1.395652173913, 0.98478260869565, 0.27777777777778
67359, 1.4173913043478, 1.0108695652174, 0.27777777777778
67360, 1.4173913043478, 0.98478260869565, 0.25
67361, 1.395652173913, 0.98478260869565, 0.22222222222222
67362, 1.4173913043478, 1.0108695652174, 0.22222222222222
67363, 1.4173913043478, 0.98478260869565, 0.19444444444444
67364, 1.395652173913, 0.98478260869565, 0.16666666666667
67365, 1.4173913043478, 1.0108695652174, 0.16666666666667
67366, 1.4173913043478, 0.98478260869565, 0.13888888888889
67367, 1.395652173913, 0.98478260869565, 0.11111111111111
67368, 1.4173913043478, 1.0108695652174, 0.11111111111111
67369, 1.4173913043478, 0.98478260869565, 0.083333333333333
67370, 1.395652173913, 0.98478260869565, 0.055555555555556
67371, 1.4173913043478, 1.0108695652174, 0.055555555555556
67372, 1.4173913043478, 0.98478260869565, 0.027777777777778
67373, 1.4608695652174, 0.98478260869565, 0.47222222222222
67374, 1.4391304347826, 0.98478260869565, 0.44444444444444
67375, 1.4608695652174, 1.0108695652174, 0.44444444444444
67376, 1.4608695652174, 0.98478260869565, 0.41666666666667
67377, 1.4391304347826, 0.98478260869565, 0.38888888888889
67378, 1.4608695652174, 1.0108695652174, 0.38888888888889
67379, 1.4608695652174, 0.98478260869565, 0.36111111111111
67380, 1.4391304347826, 0.98478260869565, 0.33333333333333
67381, 1.4608695652174, 1.0108695652174, 0.33333333333333
67382, 1.4608695652174, 0.98478260869565, 0.30555555555556
67383, 1.4391304347826, 0.98478260869565, 0.27777777777778
67384, 1.4608695652174, 1.0108695652174, 0.27777777777778
67385, 1.4608695652174, 0.98478260869565, 0.25
67386, 1.4391304347826, 0.98478260869565, 0.22222222222222
67387, 1.4608695652174, 1.0108695652174, 0.22222222222222
67388, 1.4608695652174, 0.98478260869565, 0.19444444444444
67389, 1.4391304347826, 0.98478260869565, 0.16666666666667
67390, 1.4608695652174, 1.0108695652174, 0.16666666666667
67391, 1.4608695652174, 0.98478260869565, 0.13888888888889
67392, 1.4391304347826, 0.98478260869565, 0.11111111111111
67393, 1.4608695652174, 1.0108695652174, 0.11111111111111
67394, 1.4608695652174, 0.98478260869565, 0.083333333333333
67395, 1.4391304347826, 0.98478260869565, 0.055555555555556
67396, 1.4608695652174, 1.0108695652174, 0.055555555555556
67397, 1.4608695652174, 0.98478260869565, 0.027777777777778
67398, 1.504347826087, 0.98478260869565, 0.47222222222222
67399, 1.4826086956522, 0.98478260869565, 0.44444444444444
67400, 1.504347826087, 1.0108695652174, 0.44444444444444
67401, 1.504347826087, 0.98478260869565, 0.41666666666667
67402, 1.4826086956522, 0.98478260869565, 0.38888888888889
67403, 1.504347826087, 1.0108695652174, 0.38888888888889
67404, 1.504347826087, 0.98478260869565, 0.36111111111111
67405, 1.4826086956522, 0.98478260869565, 0.33333333333333
67406, 1.504347826087, 1.0108695652174, 0.33333333333333
67407, 1.504347826087, 0.98478260869565, 0.30555555555556
67408, 1.4826086956522, 0.98478260869565, 0.27777777777778
67409, 1.504347826087, 1.0108695652174, 0.27777777777778
67410, 1.504347826087, 0.98478260869565, 0.25
67411, 1.4826086956522, 0.98478260869565, 0.22222222222222
67412, 1.504347826087, 1.0108695652174, 0.22222222222222
67413, 1.504347826087, 0.98478260869565, 0.19444444444444
67414, 1.4826086956522, 0.98478260869565, 0.16666666666667
67415, 1.504347826087, 1.0108695652174, 0.16666666666667
67416, 1.504347826087, 0.98478260869565, 0.13888888888889
67417, 1.4826086956522, 0.98478260869565, 0.11111111111111
67418, 1.504347826087, 1.0108695652174, 0.11111111111111
67419, 1.504347826087, 0.98478260869565, 0.083333333333333
67420, 1.4826086956522, 0.98478260869565, 0.055555555555556
67421, 1.504347826087, 1.0108695652174, 0.055555555555556
67422, 1.504347826087, 0.98478260869565, 0.027777777777778
67423, 1.5478260869565, 0.98478260869565, 0.47222222222222
67424, 1.5260869565217, 0.98478260869565, 0.44444444444444
67425, 1.5478260869565, 1.0108695652174, 0.44444444444444
67426, 1.5478260869565, 0.98478260869565, 0.41666666666667
67427, 1.5260869565217, 0.98478260869565, 0.38888888888889
67428, 1.5478260869565, 1.0108695652174, 0.38888888888889
67429, 1.5478260869565, 0.98478260869565, 0.36111111111111
67430, 1.5260869565217, 0.98478260869565, 0.33333333333333
67431, 1.5478260869565, 1.0108695652174, 0.33333333333333
67432, 1.5478260869565, 0.98478260869565, 0.30555555555556
67433, 1.5260869565217, 0.98478260869565, 0.27777777777778
67434, 1.5478260869565, 1.0108695652174, 0.27777777777778
67435, 1.5478260869565, 0.98478260869565, 0.25
67436, 1.5260869565217, 0.98478260869565, 0.22222222222222
67437, 1.5478260869565, 1.0108695652174, 0.22222222222222
67438, 1.5478260869565, 0.98478260869565, 0.19444444444444
67439, 1.5260869565217, 0.98478260869565, 0.16666666666667
67440, 1.5478260869565, 1.0108695652174, 0.16666666666667
67441, 1.5478260869565, 0.98478260869565, 0.13888888888889
67442, 1.5260869565217, 0.98478260869565, 0.11111111111111
67443, 1.5478260869565, 1.0108695652174, 0.11111111111111
67444, 1.5478260869565, 0.98478260869565, 0.083333333333333
67445, 1.5260869565217, 0.98478260869565, 0.055555555555556
67446, 1.5478260869565, 1.0108695652174, 0.055555555555556
67447, 1.5478260869565, 0.98478260869565, 0.027777777777778
67448, 1.5913043478261, 0.98478260869565, 0.47222222222222
67449, 1.5695652173913, 0.98478260869565, 0.44444444444444
67450, 1.5913043478261, 1.0108695652174, 0.44444444444444
67451, 1.5913043478261, 0.98478260869565, 0.41666666666667
67452, 1.5695652173913, 0.98478260869565, 0.38888888888889
67453, 1.5913043478261, 1.0108695652174, 0.38888888888889
67454, 1.5913043478261, 0.98478260869565, 0.36111111111111
67455, 1.5695652173913, 0.98478260869565, 0.33333333333333
67456, 1.5913043478261, 1.0108695652174, 0.33333333333333
67457, 1.5913043478261, 0.98478260869565, 0.30555555555556
67458, 1.5695652173913, 0.98478260869565, 0.27777777777778
67459, 1.5913043478261, 1.0108695652174, 0.27777777777778
67460, 1.5913043478261, 0.98478260869565, 0.25
67461, 1.5695652173913, 0.98478260869565, 0.22222222222222
67462, 1.5913043478261, 1.0108695652174, 0.22222222222222
67463, 1.5913043478261, 0.98478260869565, 0.19444444444444
67464, 1.5695652173913, 0.98478260869565, 0.16666666666667
67465, 1.5913043478261, 1.0108695652174, 0.16666666666667
67466, 1.5913043478261, 0.98478260869565, 0.13888888888889
67467, 1.5695652173913, 0.98478260869565, 0.11111111111111
67468, 1.5913043478261, 1.0108695652174, 0.11111111111111
67469, 1.5913043478261, 0.98478260869565, 0.083333333333333
67470, 1.5695652173913, 0.98478260869565, 0.055555555555556
67471, 1.5913043478261, 1.0108695652174, 0.055555555555556
67472, 1.5913043478261, 0.98478260869565, 0.027777777777778
67473, 1.6347826086957, 0.98478260869565, 0.47222222222222
67474, 1.6130434782609, 0.98478260869565, 0.44444444444444
67475, 1.6347826086957, 1.0108695652174, 0.44444444444444
67476, 1.6347826086957, 0.98478260869565, 0.41666666666667
67477, 1.6130434782609, 0.98478260869565, 0.38888888888889
67478, 1.6347826086957, 1.0108695652174, 0.38888888888889
67479, 1.6347826086957, 0.98478260869565, 0.36111111111111
67480, 1.6130434782609, 0.98478260869565, 0.33333333333333
67481, 1.6347826086957, 1.0108695652174, 0.33333333333333
67482, 1.6347826086957, 0.98478260869565, 0.30555555555556
67483, 1.6130434782609, 0.98478260869565, 0.27777777777778
67484, 1.6347826086957, 1.0108695652174, 0.27777777777778
67485, 1.6347826086957, 0.98478260869565, 0.25
67486, 1.6130434782609, 0.98478260869565, 0.22222222222222
67487, 1.6347826086957, 1.0108695652174, 0.22222222222222
67488, 1.6347826086957, 0.98478260869565, 0.19444444444444
67489, 1.6130434782609, 0.98478260869565, 0.16666666666667
67490, 1.6347826086957, 1.0108695652174, 0.16666666666667
67491, 1.6347826086957, 0.98478260869565, 0.13888888888889
67492, 1.6130434782609, 0.98478260869565, 0.11111111111111
67493, 1.6347826086957, 1.0108695652174, 0.11111111111111
67494, 1.6347826086957, 0.98478260869565, 0.083333333333333
67495, 1.6130434782609, 0.98478260869565, 0.055555555555556
67496, 1.6347826086957, 1.0108695652174, 0.055555555555556
67497, 1.6347826086957, 0.98478260869565, 0.027777777777778
67498, 1.6782608695652, 0.98478260869565, 0.47222222222222
67499, 1.6565217391304, 0.98478260869565, 0.44444444444444
67500, 1.6782608695652, 1.0108695652174, 0.44444444444444
67501, 1.6782608695652, 0.98478260869565, 0.41666666666667
67502, 1.6565217391304, 0.98478260869565, 0.38888888888889
67503, 1.6782608695652, 1.0108695652174, 0.38888888888889
67504, 1.6782608695652, 0.98478260869565, 0.36111111111111
67505, 1.6565217391304, 0.98478260869565, 0.33333333333333
67506, 1.6782608695652, 1.0108695652174, 0.33333333333333
67507, 1.6782608695652, 0.98478260869565, 0.30555555555556
67508, 1.6565217391304, 0.98478260869565, 0.27777777777778
67509, 1.6782608695652, 1.0108695652174, 0.27777777777778
67510, 1.6782608695652, 0.98478260869565, 0.25
67511, 1.6565217391304, 0.98478260869565, 0.22222222222222
67512, 1.6782608695652, 1.0108695652174, 0.22222222222222
67513, 1.6782608695652, 0.98478260869565, 0.19444444444444
67514, 1.6565217391304, 0.98478260869565, 0.16666666666667
67515, 1.6782608695652, 1.0108695652174, 0.16666666666667
67516, 1.6782608695652, 0.98478260869565, 0.13888888888889
67517, 1.6565217391304, 0.98478260869565, 0.11111111111111
67518, 1.6782608695652, 1.0108695652174, 0.11111111111111
67519, 1.6782608695652, 0.98478260869565, 0.083333333333333
67520, 1.6565217391304, 0.98478260869565, 0.055555555555556
67521, 1.6782608695652, 1.0108695652174, 0.055555555555556
67522, 1.6782608695652, 0.98478260869565, 0.027777777777778
67523, 1.7217391304348, 0.98478260869565, 0.47222222222222
67524, 1.7, 0.98478260869565, 0.44444444444444
67525, 1.7217391304348, 1.0108695652174, 0.44444444444444
67526, 1.7217391304348, 0.98478260869565, 0.41666666666667
67527, 1.7, 0.98478260869565, 0.38888888888889
67528, 1.7217391304348, 1.0108695652174, 0.38888888888889
67529, 1.7217391304348, 0.98478260869565, 0.36111111111111
67530, 1.7, 0.98478260869565, 0.33333333333333
67531, 1.7217391304348, 1.0108695652174, 0.33333333333333
67532, 1.7217391304348, 0.98478260869565, 0.30555555555556
67533, 1.7, 0.98478260869565, 0.27777777777778
67534, 1.7217391304348, 1.0108695652174, 0.27777777777778
67535, 1.7217391304348, 0.98478260869565, 0.25
67536, 1.7, 0.98478260869565, 0.22222222222222
67537, 1.7217391304348, 1.0108695652174, 0.22222222222222
67538, 1.7217391304348, 0.98478260869565, 0.19444444444444
67539, 1.7, 0.98478260869565, 0.16666666666667
67540, 1.7217391304348, 1.0108695652174, 0.16666666666667
67541, 1.7217391304348, 0.98478260869565, 0.13888888888889
67542, 1.7, 0.98478260869565, 0.11111111111111
67543, 1.7217391304348, 1.0108695652174, 0.11111111111111
67544, 1.7217391304348, 0.98478260869565, 0.083333333333333
67545, 1.7, 0.98478260869565, 0.055555555555556
67546, 1.7217391304348, 1.0108695652174, 0.055555555555556
67547, 1.7217391304348, 0.98478260869565, 0.027777777777778
67548, 1.7652173913043, 0.98478260869565, 0.47222222222222
67549, 1.7434782608696, 0.98478260869565, 0.44444444444444
67550, 1.7652173913043, 1.0108695652174, 0.44444444444444
67551, 1.7652173913043, 0.98478260869565, 0.41666666666667
67552, 1.7434782608696, 0.98478260869565, 0.38888888888889
67553, 1.7652173913043, 1.0108695652174, 0.38888888888889
67554, 1.7652173913043, 0.98478260869565, 0.36111111111111
67555, 1.7434782608696, 0.98478260869565, 0.33333333333333
67556, 1.7652173913043, 1.0108695652174, 0.33333333333333
67557, 1.7652173913043, 0.98478260869565, 0.30555555555556
67558, 1.7434782608696, 0.98478260869565, 0.27777777777778
67559, 1.7652173913043, 1.0108695652174, 0.27777777777778
67560, 1.7652173913043, 0.98478260869565, 0.25
67561, 1.7434782608696, 0.98478260869565, 0.22222222222222
67562, 1.7652173913043, 1.0108695652174, 0.22222222222222
67563, 1.7652173913043, 0.98478260869565, 0.19444444444444
67564, 1.7434782608696, 0.98478260869565, 0.16666666666667
67565, 1.7652173913043, 1.0108695652174, 0.16666666666667
67566, 1.7652173913043, 0.98478260869565, 0.13888888888889
67567, 1.7434782608696, 0.98478260869565, 0.11111111111111
67568, 1.7652173913043, 1.0108695652174, 0.11111111111111
67569, 1.7652173913043, 0.98478260869565, 0.083333333333333
67570, 1.7434782608696, 0.98478260869565, 0.055555555555556
67571, 1.7652173913043, 1.0108695652174, 0.055555555555556
67572, 1.7652173913043, 0.98478260869565, 0.027777777777778
67573, 1.8086956521739, 0.98478260869565, 0.47222222222222
67574, 1.7869565217391, 0.98478260869565, 0.44444444444444
67575, 1.8086956521739, 1.0108695652174, 0.44444444444444
67576, 1.8086956521739, 0.98478260869565, 0.41666666666667
67577, 1.7869565217391, 0.98478260869565, 0.38888888888889
67578, 1.8086956521739, 1.0108695652174, 0.38888888888889
67579, 1.8086956521739, 0.98478260869565, 0.36111111111111
67580, 1.7869565217391, 0.98478260869565, 0.33333333333333
67581, 1.8086956521739, 1.0108695652174, 0.33333333333333
67582, 1.8086956521739, 0.98478260869565, 0.30555555555556
67583, 1.7869565217391, 0.98478260869565, 0.27777777777778
67584, 1.8086956521739, 1.0108695652174, 0.27777777777778
67585, 1.8086956521739, 0.98478260869565, 0.25
67586, 1.7869565217391, 0.98478260869565, 0.22222222222222
67587, 1.8086956521739, 1.0108695652174, 0.22222222222222
67588, 1.8086956521739, 0.98478260869565, 0.19444444444444
67589, 1.7869565217391, 0.98478260869565, 0.16666666666667
67590, 1.8086956521739, 1.0108695652174, 0.16666666666667
67591, 1.8086956521739, 0.98478260869565, 0.13888888888889
67592, 1.7869565217391, 0.98478260869565, 0.11111111111111
67593, 1.8086956521739, 1.0108695652174, 0.11111111111111
67594, 1.8086956521739, 0.98478260869565, 0.083333333333333
67595, 1.7869565217391, 0.98478260869565, 0.055555555555556
67596, 1.8086956521739, 1.0108695652174, 0.055555555555556
67597, 1.8086956521739, 0.98478260869565, 0.027777777777778
67598, 1.8521739130435, 0.98478260869565, 0.47222222222222
67599, 1.8304347826087, 0.98478260869565, 0.44444444444444
67600, 1.8521739130435, 1.0108695652174, 0.44444444444444
67601, 1.8521739130435, 0.98478260869565, 0.41666666666667
67602, 1.8304347826087, 0.98478260869565, 0.38888888888889
67603, 1.8521739130435, 1.0108695652174, 0.38888888888889
67604, 1.8521739130435, 0.98478260869565, 0.36111111111111
67605, 1.8304347826087, 0.98478260869565, 0.33333333333333
67606, 1.8521739130435, 1.0108695652174, 0.33333333333333
67607, 1.8521739130435, 0.98478260869565, 0.30555555555556
67608, 1.8304347826087, 0.98478260869565, 0.27777777777778
67609, 1.8521739130435, 1.0108695652174, 0.27777777777778
67610, 1.8521739130435, 0.98478260869565, 0.25
67611, 1.8304347826087, 0.98478260869565, 0.22222222222222
67612, 1.8521739130435, 1.0108695652174, 0.22222222222222
67613, 1.8521739130435, 0.98478260869565, 0.19444444444444
67614, 1.8304347826087, 0.98478260869565, 0.16666666666667
67615, 1.8521739130435, 1.0108695652174, 0.16666666666667
67616, 1.8521739130435, 0.98478260869565, 0.13888888888889
67617, 1.8304347826087, 0.98478260869565, 0.11111111111111
67618, 1.8521739130435, 1.0108695652174, 0.11111111111111
67619, 1.8521739130435, 0.98478260869565, 0.083333333333333
67620, 1.8304347826087, 0.98478260869565, 0.055555555555556
67621, 1.8521739130435, 1.0108695652174, 0.055555555555556
67622, 1.8521739130435, 0.98478260869565, 0.027777777777778
67623, 1.895652173913, 0.98478260869565, 0.47222222222222
67624, 1.8739130434783, 0.98478260869565, 0.44444444444444
67625, 1.895652173913, 1.0108695652174, 0.44444444444444
67626, 1.895652173913, 0.98478260869565, 0.41666666666667
67627, 1.8739130434783, 0.98478260869565, 0.38888888888889
67628, 1.895652173913, 1.0108695652174, 0.38888888888889
67629, 1.895652173913, 0.98478260869565, 0.36111111111111
67630, 1.8739130434783, 0.98478260869565, 0.33333333333333
67631, 1.895652173913, 1.0108695652174, 0.33333333333333
67632, 1.895652173913, 0.98478260869565, 0.30555555555556
67633, 1.8739130434783, 0.98478260869565, 0.27777777777778
67634, 1.895652173913, 1.0108695652174, 0.27777777777778
67635, 1.895652173913, 0.98478260869565, 0.25
67636, 1.8739130434783, 0.98478260869565, 0.22222222222222
67637, 1.895652173913, 1.0108695652174, 0.22222222222222
67638, 1.895652173913, 0.98478260869565, 0.19444444444444
67639, 1.8739130434783, 0.98478260869565, 0.16666666666667
67640, 1.895652173913, 1.0108695652174, 0.16666666666667
67641, 1.895652173913, 0.98478260869565, 0.13888888888889
67642, 1.8739130434783, 0.98478260869565, 0.11111111111111
67643, 1.895652173913, 1.0108695652174, 0.11111111111111
67644, 1.895652173913, 0.98478260869565, 0.083333333333333
67645, 1.8739130434783, 0.98478260869565, 0.055555555555556
67646, 1.895652173913, 1.0108695652174, 0.055555555555556
67647, 1.895652173913, 0.98478260869565, 0.027777777777778
67648, 1.9391304347826, 0.98478260869565, 0.47222222222222
67649, 1.9173913043478, 0.98478260869565, 0.44444444444444
67650, 1.9391304347826, 1.0108695652174, 0.44444444444444
67651, 1.9391304347826, 0.98478260869565, 0.41666666666667
67652, 1.9173913043478, 0.98478260869565, 0.38888888888889
67653, 1.9391304347826, 1.0108695652174, 0.38888888888889
67654, 1.9391304347826, 0.98478260869565, 0.36111111111111
67655, 1.9173913043478, 0.98478260869565, 0.33333333333333
67656, 1.9391304347826, 1.0108695652174, 0.33333333333333
67657, 1.9391304347826, 0.98478260869565, 0.30555555555556
67658, 1.9173913043478, 0.98478260869565, 0.27777777777778
67659, 1.9391304347826, 1.0108695652174, 0.27777777777778
67660, 1.9391304347826, 0.98478260869565, 0.25
67661, 1.9173913043478, 0.98478260869565, 0.22222222222222
67662, 1.9391304347826, 1.0108695652174, 0.22222222222222
67663, 1.9391304347826, 0.98478260869565, 0.19444444444444
67664, 1.9173913043478, 0.98478260869565, 0.16666666666667
67665, 1.9391304347826, 1.0108695652174, 0.16666666666667
67666, 1.9391304347826, 0.98478260869565, 0.13888888888889
67667, 1.9173913043478, 0.98478260869565, 0.11111111111111
67668, 1.9391304347826, 1.0108695652174, 0.11111111111111
67669, 1.9391304347826, 0.98478260869565, 0.083333333333333
67670, 1.9173913043478, 0.98478260869565, 0.055555555555556
67671, 1.9391304347826, 1.0108695652174, 0.055555555555556
67672, 1.9391304347826, 0.98478260869565, 0.027777777777778
67673, 1.9826086956522, 0.98478260869565, 0.47222222222222
67674, 1.9608695652174, 0.98478260869565, 0.44444444444444
67675, 1.9826086956522, 1.0108695652174, 0.44444444444444
67676, 1.9826086956522, 0.98478260869565, 0.41666666666667
67677, 1.9608695652174, 0.98478260869565, 0.38888888888889
67678, 1.9826086956522, 1.0108695652174, 0.38888888888889
67679, 1.9826086956522, 0.98478260869565, 0.36111111111111
67680, 1.9608695652174, 0.98478260869565, 0.33333333333333
67681, 1.9826086956522, 1.0108695652174, 0.33333333333333
67682, 1.9826086956522, 0.98478260869565, 0.30555555555556
67683, 1.9608695652174, 0.98478260869565, 0.27777777777778
67684, 1.9826086956522, 1.0108695652174, 0.27777777777778
67685, 1.9826086956522, 0.98478260869565, 0.25
67686, 1.9608695652174, 0.98478260869565, 0.22222222222222
67687, 1.9826086956522, 1.0108695652174, 0.22222222222222
67688, 1.9826086956522, 0.98478260869565, 0.19444444444444
67689, 1.9608695652174, 0.98478260869565, 0.16666666666667
67690, 1.9826086956522, 1.0108695652174, 0.16666666666667
67691, 1.9826086956522, 0.98478260869565, 0.13888888888889
67692, 1.9608695652174, 0.98478260869565, 0.11111111111111
67693, 1.9826086956522, 1.0108695652174, 0.11111111111111
67694, 1.9826086956522, 0.98478260869565, 0.083333333333333
67695, 1.9608695652174, 0.98478260869565, 0.055555555555556
67696, 1.9826086956522, 1.0108695652174, 0.055555555555556
67697, 1.9826086956522, 0.98478260869565, 0.027777777777778
67698, 2.0260869565217, 0.98478260869565, 0.47222222222222
67699, 2.004347826087, 0.98478260869565, 0.44444444444444
67700, 2.0260869565217, 1.0108695652174, 0.44444444444444
67701, 2.0260869565217, 0.98478260869565, 0.41666666666667
67702, 2.004347826087, 0.98478260869565, 0.38888888888889
67703, 2.0260869565217, 1.0108695652174, 0.38888888888889
67704, 2.0260869565217, 0.98478260869565, 0.36111111111111
67705, 2.004347826087, 0.98478260869565, 0.33333333333333
67706, 2.0260869565217, 1.0108695652174, 0.33333333333333
67707, 2.0260869565217, 0.98478260869565, 0.30555555555556
67708, 2.004347826087, 0.98478260869565, 0.27777777777778
67709, 2.0260869565217, 1.0108695652174, 0.27777777777778
67710, 2.0260869565217, 0.98478260869565, 0.25
67711, 2.004347826087, 0.98478260869565, 0.22222222222222
67712, 2.0260869565217, 1.0108695652174, 0.22222222222222
67713, 2.0260869565217, 0.98478260869565, 0.19444444444444
67714, 2.004347826087, 0.98478260869565, 0.16666666666667
67715, 2.0260869565217, 1.0108695652174, 0.16666666666667
67716, 2.0260869565217, 0.98478260869565, 0.13888888888889
67717, 2.004347826087, 0.98478260869565, 0.11111111111111
67718, 2.0260869565217, 1.0108695652174, 0.11111111111111
67719, 2.0260869565217, 0.98478260869565, 0.083333333333333
67720, 2.004347826087, 0.98478260869565, 0.055555555555556
67721, 2.0260869565217, 1.0108695652174, 0.055555555555556
67722, 2.0260869565217, 0.98478260869565, 0.027777777777778
67723, 2.0695652173913, 0.98478260869565, 0.47222222222222
67724, 2.0478260869565, 0.98478260869565, 0.44444444444444
67725, 2.0695652173913, 1.0108695652174, 0.44444444444444
67726, 2.0695652173913, 0.98478260869565, 0.41666666666667
67727, 2.0478260869565, 0.98478260869565, 0.38888888888889
67728, 2.0695652173913, 1.0108695652174, 0.38888888888889
67729, 2.0695652173913, 0.98478260869565, 0.36111111111111
67730, 2.0478260869565, 0.98478260869565, 0.33333333333333
67731, 2.0695652173913, 1.0108695652174, 0.33333333333333
67732, 2.0695652173913, 0.98478260869565, 0.30555555555556
67733, 2.0478260869565, 0.98478260869565, 0.27777777777778
67734, 2.0695652173913, 1.0108695652174, 0.27777777777778
67735, 2.0695652173913, 0.98478260869565, 0.25
67736, 2.0478260869565, 0.98478260869565, 0.22222222222222
67737, 2.0695652173913, 1.0108695652174, 0.22222222222222
67738, 2.0695652173913, 0.98478260869565, 0.19444444444444
67739, 2.0478260869565, 0.98478260869565, 0.16666666666667
67740, 2.0695652173913, 1.0108695652174, 0.16666666666667
67741, 2.0695652173913, 0.98478260869565, 0.13888888888889
67742, 2.0478260869565, 0.98478260869565, 0.11111111111111
67743, 2.0695652173913, 1.0108695652174, 0.11111111111111
67744, 2.0695652173913, 0.98478260869565, 0.083333333333333
67745, 2.0478260869565, 0.98478260869565, 0.055555555555556
67746, 2.0695652173913, 1.0108695652174, 0.055555555555556
67747, 2.0695652173913, 0.98478260869565, 0.027777777777778
67748, 2.1130434782609, 0.98478260869565, 0.47222222222222
67749, 2.0913043478261, 0.98478260869565, 0.44444444444444
67750, 2.1130434782609, 1.0108695652174, 0.44444444444444
67751, 2.1130434782609, 0.98478260869565, 0.41666666666667
67752, 2.0913043478261, 0.98478260869565, 0.38888888888889
67753, 2.1130434782609, 1.0108695652174, 0.38888888888889
67754, 2.1130434782609, 0.98478260869565, 0.36111111111111
67755, 2.0913043478261, 0.98478260869565, 0.33333333333333
67756, 2.1130434782609, 1.0108695652174, 0.33333333333333
67757, 2.1130434782609, 0.98478260869565, 0.30555555555556
67758, 2.0913043478261, 0.98478260869565, 0.27777777777778
67759, 2.1130434782609, 1.0108695652174, 0.27777777777778
67760, 2.1130434782609, 0.98478260869565, 0.25
67761, 2.0913043478261, 0.98478260869565, 0.22222222222222
67762, 2.1130434782609, 1.0108695652174, 0.22222222222222
67763, 2.1130434782609, 0.98478260869565, 0.19444444444444
67764, 2.0913043478261, 0.98478260869565, 0.16666666666667
67765, 2.1130434782609, 1.0108695652174, 0.16666666666667
67766, 2.1130434782609, 0.98478260869565, 0.13888888888889
67767, 2.0913043478261, 0.98478260869565, 0.11111111111111
67768, 2.1130434782609, 1.0108695652174, 0.11111111111111
67769, 2.1130434782609, 0.98478260869565, 0.083333333333333
67770, 2.0913043478261, 0.98478260869565, 0.055555555555556
67771, 2.1130434782609, 1.0108695652174, 0.055555555555556
67772, 2.1130434782609, 0.98478260869565, 0.027777777777778
67773, 2.1565217391304, 0.98478260869565, 0.47222222222222
67774, 2.1347826086957, 0.98478260869565, 0.44444444444444
67775, 2.1565217391304, 1.0108695652174, 0.44444444444444
67776, 2.1565217391304, 0.98478260869565, 0.41666666666667
67777, 2.1347826086957, 0.98478260869565, 0.38888888888889
67778, 2.1565217391304, 1.0108695652174, 0.38888888888889
67779, 2.1565217391304, 0.98478260869565, 0.36111111111111
67780, 2.1347826086957, 0.98478260869565, 0.33333333333333
67781, 2.1565217391304, 1.0108695652174, 0.33333333333333
67782, 2.1565217391304, 0.98478260869565, 0.30555555555556
67783, 2.1347826086957, 0.98478260869565, 0.27777777777778
67784, 2.1565217391304, 1.0108695652174, 0.27777777777778
67785, 2.1565217391304, 0.98478260869565, 0.25
67786, 2.1347826086957, 0.98478260869565, 0.22222222222222
67787, 2.1565217391304, 1.0108695652174, 0.22222222222222
67788, 2.1565217391304, 0.98478260869565, 0.19444444444444
67789, 2.1347826086957, 0.98478260869565, 0.16666666666667
67790, 2.1565217391304, 1.0108695652174, 0.16666666666667
67791, 2.1565217391304, 0.98478260869565, 0.13888888888889
67792, 2.1347826086957, 0.98478260869565, 0.11111111111111
67793, 2.1565217391304, 1.0108695652174, 0.11111111111111
67794, 2.1565217391304, 0.98478260869565, 0.083333333333333
67795, 2.1347826086957, 0.98478260869565, 0.055555555555556
67796, 2.1565217391304, 1.0108695652174, 0.055555555555556
67797, 2.1565217391304, 0.98478260869565, 0.027777777777778
67798, 2.1782608695652, 0.98478260869565, 0.44444444444444
67799, 2.1782608695652, 0.98478260869565, 0.38888888888889
67800, 2.1782608695652, 0.98478260869565, 0.33333333333333
67801, 2.1782608695652, 0.98478260869565, 0.27777777777778
67802, 2.1782608695652, 0.98478260869565, 0.22222222222222
67803, 2.1782608695652, 0.98478260869565, 0.16666666666667
67804, 2.1782608695652, 0.98478260869565, 0.11111111111111
67805, 2.1782608695652, 0.98478260869565, 0.055555555555556
67806, 1.2434782608696, 0.93260869565217, 0.47222222222222
67807, 1.2217391304348, 0.93260869565217, 0.44444444444444
67808, 1.2434782608696, 0.95869565217391, 0.44444444444444
67809, 1.2434782608696, 0.93260869565217, 0.41666666666667
67810, 1.2217391304348, 0.93260869565217, 0.38888888888889
67811, 1.2434782608696, 0.95869565217391, 0.38888888888889
67812, 1.2434782608696, 0.93260869565217, 0.36111111111111
67813, 1.2217391304348, 0.93260869565217, 0.33333333333333
67814, 1.2434782608696, 0.95869565217391, 0.33333333333333
67815, 1.2434782608696, 0.93260869565217, 0.30555555555556
67816, 1.2217391304348, 0.93260869565217, 0.27777777777778
67817, 1.2434782608696, 0.95869565217391, 0.27777777777778
67818, 1.2434782608696, 0.93260869565217, 0.25
67819, 1.2217391304348, 0.93260869565217, 0.22222222222222
67820, 1.2434782608696, 0.95869565217391, 0.22222222222222
67821, 1.2434782608696, 0.93260869565217, 0.19444444444444
67822, 1.2217391304348, 0.93260869565217, 0.16666666666667
67823, 1.2434782608696, 0.95869565217391, 0.16666666666667
67824, 1.2434782608696, 0.93260869565217, 0.13888888888889
67825, 1.2217391304348, 0.93260869565217, 0.11111111111111
67826, 1.2434782608696, 0.95869565217391, 0.11111111111111
67827, 1.2434782608696, 0.93260869565217, 0.083333333333333
67828, 1.2217391304348, 0.93260869565217, 0.055555555555556
67829, 1.2434782608696, 0.95869565217391, 0.055555555555556
67830, 1.2434782608696, 0.93260869565217, 0.027777777777778
67831, 1.2869565217391, 0.93260869565217, 0.47222222222222
67832, 1.2652173913043, 0.93260869565218, 0.44444444444444
67833, 1.2869565217391, 0.95869565217391, 0.44444444444444
67834, 1.2869565217391, 0.93260869565217, 0.41666666666667
67835, 1.2652173913043, 0.93260869565217, 0.38888888888889
67836, 1.2869565217391, 0.95869565217391, 0.38888888888889
67837, 1.2869565217391, 0.93260869565217, 0.36111111111111
67838, 1.2652173913043, 0.93260869565217, 0.33333333333333
67839, 1.2869565217391, 0.95869565217391, 0.33333333333333
67840, 1.2869565217391, 0.93260869565217, 0.30555555555556
67841, 1.2652173913043, 0.93260869565218, 0.27777777777778
67842, 1.2869565217391, 0.95869565217391, 0.27777777777778
67843, 1.2869565217391, 0.93260869565217, 0.25
67844, 1.2652173913043, 0.93260869565217, 0.22222222222222
67845, 1.2869565217391, 0.95869565217391, 0.22222222222222
67846, 1.2869565217391, 0.93260869565217, 0.19444444444444
67847, 1.2652173913043, 0.93260869565217, 0.16666666666667
67848, 1.2869565217391, 0.95869565217391, 0.16666666666667
67849, 1.2869565217391, 0.93260869565217, 0.13888888888889
67850, 1.2652173913043, 0.93260869565217, 0.11111111111111
67851, 1.2869565217391, 0.95869565217391, 0.11111111111111
67852, 1.2869565217391, 0.93260869565217, 0.083333333333333
67853, 1.2652173913043, 0.93260869565217, 0.055555555555556
67854, 1.2869565217391, 0.95869565217391, 0.055555555555556
67855, 1.2869565217391, 0.93260869565217, 0.027777777777778
67856, 1.3304347826087, 0.93260869565217, 0.47222222222222
67857, 1.3086956521739, 0.93260869565218, 0.44444444444444
67858, 1.3304347826087, 0.95869565217391, 0.44444444444444
67859, 1.3304347826087, 0.93260869565217, 0.41666666666667
67860, 1.3086956521739, 0.93260869565217, 0.38888888888889
67861, 1.3304347826087, 0.95869565217391, 0.38888888888889
67862, 1.3304347826087, 0.93260869565217, 0.36111111111111
67863, 1.3086956521739, 0.93260869565217, 0.33333333333333
67864, 1.3304347826087, 0.95869565217391, 0.33333333333333
67865, 1.3304347826087, 0.93260869565217, 0.30555555555556
67866, 1.3086956521739, 0.93260869565218, 0.27777777777778
67867, 1.3304347826087, 0.95869565217391, 0.27777777777778
67868, 1.3304347826087, 0.93260869565217, 0.25
67869, 1.3086956521739, 0.93260869565217, 0.22222222222222
67870, 1.3304347826087, 0.95869565217391, 0.22222222222222
67871, 1.3304347826087, 0.93260869565217, 0.19444444444444
67872, 1.3086956521739, 0.93260869565217, 0.16666666666667
67873, 1.3304347826087, 0.95869565217391, 0.16666666666667
67874, 1.3304347826087, 0.93260869565217, 0.13888888888889
67875, 1.3086956521739, 0.93260869565217, 0.11111111111111
67876, 1.3304347826087, 0.95869565217391, 0.11111111111111
67877, 1.3304347826087, 0.93260869565218, 0.083333333333333
67878, 1.3086956521739, 0.93260869565217, 0.055555555555556
67879, 1.3304347826087, 0.95869565217391, 0.055555555555556
67880, 1.3304347826087, 0.93260869565217, 0.027777777777778
67881, 1.3739130434783, 0.93260869565217, 0.47222222222222
67882, 1.3521739130435, 0.93260869565218, 0.44444444444444
67883, 1.3739130434783, 0.95869565217391, 0.44444444444444
67884, 1.3739130434783, 0.93260869565217, 0.41666666666667
67885, 1.3521739130435, 0.93260869565217, 0.38888888888889
67886, 1.3739130434783, 0.95869565217391, 0.38888888888889
67887, 1.3739130434783, 0.93260869565217, 0.36111111111111
67888, 1.3521739130435, 0.93260869565217, 0.33333333333333
67889, 1.3739130434783, 0.95869565217391, 0.33333333333333
67890, 1.3739130434783, 0.93260869565217, 0.30555555555556
67891, 1.3521739130435, 0.93260869565218, 0.27777777777778
67892, 1.3739130434783, 0.95869565217391, 0.27777777777778
67893, 1.3739130434783, 0.93260869565217, 0.25
67894, 1.3521739130435, 0.93260869565217, 0.22222222222222
67895, 1.3739130434783, 0.95869565217391, 0.22222222222222
67896, 1.3739130434783, 0.93260869565217, 0.19444444444444
67897, 1.3521739130435, 0.93260869565217, 0.16666666666667
67898, 1.3739130434783, 0.95869565217391, 0.16666666666667
67899, 1.3739130434783, 0.93260869565217, 0.13888888888889
67900, 1.3521739130435, 0.93260869565217, 0.11111111111111
67901, 1.3739130434783, 0.95869565217391, 0.11111111111111
67902, 1.3739130434783, 0.93260869565217, 0.083333333333333
67903, 1.3521739130435, 0.93260869565217, 0.055555555555556
67904, 1.3739130434783, 0.95869565217391, 0.055555555555556
67905, 1.3739130434783, 0.93260869565217, 0.027777777777778
67906, 1.4173913043478, 0.93260869565217, 0.47222222222222
67907, 1.395652173913, 0.93260869565218, 0.44444444444444
67908, 1.4173913043478, 0.95869565217391, 0.44444444444444
67909, 1.4173913043478, 0.93260869565217, 0.41666666666667
67910, 1.395652173913, 0.93260869565217, 0.38888888888889
67911, 1.4173913043478, 0.95869565217391, 0.38888888888889
67912, 1.4173913043478, 0.93260869565217, 0.36111111111111
67913, 1.395652173913, 0.93260869565217, 0.33333333333333
67914, 1.4173913043478, 0.95869565217391, 0.33333333333333
67915, 1.4173913043478, 0.93260869565217, 0.30555555555556
67916, 1.395652173913, 0.93260869565218, 0.27777777777778
67917, 1.4173913043478, 0.95869565217391, 0.27777777777778
67918, 1.4173913043478, 0.93260869565217, 0.25
67919, 1.395652173913, 0.93260869565217, 0.22222222222222
67920, 1.4173913043478, 0.95869565217391, 0.22222222222222
67921, 1.4173913043478, 0.93260869565217, 0.19444444444444
67922, 1.395652173913, 0.93260869565217, 0.16666666666667
67923, 1.4173913043478, 0.95869565217391, 0.16666666666667
67924, 1.4173913043478, 0.93260869565217, 0.13888888888889
67925, 1.395652173913, 0.93260869565217, 0.11111111111111
67926, 1.4173913043478, 0.95869565217391, 0.11111111111111
67927, 1.4173913043478, 0.93260869565217, 0.083333333333333
67928, 1.395652173913, 0.93260869565217, 0.055555555555556
67929, 1.4173913043478, 0.95869565217391, 0.055555555555556
67930, 1.4173913043478, 0.93260869565217, 0.027777777777778
67931, 1.4608695652174, 0.93260869565217, 0.47222222222222
67932, 1.4391304347826, 0.93260869565218, 0.44444444444444
67933, 1.4608695652174, 0.95869565217391, 0.44444444444444
67934, 1.4608695652174, 0.93260869565217, 0.41666666666667
67935, 1.4391304347826, 0.93260869565217, 0.38888888888889
67936, 1.4608695652174, 0.95869565217391, 0.38888888888889
67937, 1.4608695652174, 0.93260869565217, 0.36111111111111
67938, 1.4391304347826, 0.93260869565217, 0.33333333333333
67939, 1.4608695652174, 0.95869565217391, 0.33333333333333
67940, 1.4608695652174, 0.93260869565217, 0.30555555555556
67941, 1.4391304347826, 0.93260869565218, 0.27777777777778
67942, 1.4608695652174, 0.95869565217391, 0.27777777777778
67943, 1.4608695652174, 0.93260869565217, 0.25
67944, 1.4391304347826, 0.93260869565217, 0.22222222222222
67945, 1.4608695652174, 0.95869565217391, 0.22222222222222
67946, 1.4608695652174, 0.93260869565217, 0.19444444444444
67947, 1.4391304347826, 0.93260869565217, 0.16666666666667
67948, 1.4608695652174, 0.95869565217391, 0.16666666666667
67949, 1.4608695652174, 0.93260869565217, 0.13888888888889
67950, 1.4391304347826, 0.93260869565217, 0.11111111111111
67951, 1.4608695652174, 0.95869565217391, 0.11111111111111
67952, 1.4608695652174, 0.93260869565217, 0.083333333333333
67953, 1.4391304347826, 0.93260869565217, 0.055555555555556
67954, 1.4608695652174, 0.95869565217391, 0.055555555555556
67955, 1.4608695652174, 0.93260869565217, 0.027777777777778
67956, 1.504347826087, 0.93260869565217, 0.47222222222222
67957, 1.4826086956522, 0.93260869565217, 0.44444444444444
67958, 1.504347826087, 0.95869565217391, 0.44444444444444
67959, 1.504347826087, 0.93260869565217, 0.41666666666667
67960, 1.4826086956522, 0.93260869565217, 0.38888888888889
67961, 1.504347826087, 0.95869565217391, 0.38888888888889
67962, 1.504347826087, 0.93260869565217, 0.36111111111111
67963, 1.4826086956522, 0.93260869565217, 0.33333333333333
67964, 1.504347826087, 0.95869565217391, 0.33333333333333
67965, 1.504347826087, 0.93260869565217, 0.30555555555556
67966, 1.4826086956522, 0.93260869565217, 0.27777777777778
67967, 1.504347826087, 0.95869565217391, 0.27777777777778
67968, 1.504347826087, 0.93260869565217, 0.25
67969, 1.4826086956522, 0.93260869565217, 0.22222222222222
67970, 1.504347826087, 0.95869565217391, 0.22222222222222
67971, 1.504347826087, 0.93260869565217, 0.19444444444444
67972, 1.4826086956522, 0.93260869565217, 0.16666666666667
67973, 1.504347826087, 0.95869565217391, 0.16666666666667
67974, 1.504347826087, 0.93260869565217, 0.13888888888889
67975, 1.4826086956522, 0.93260869565217, 0.11111111111111
67976, 1.504347826087, 0.95869565217391, 0.11111111111111
67977, 1.504347826087, 0.93260869565217, 0.083333333333333
67978, 1.4826086956522, 0.93260869565217, 0.055555555555556
67979, 1.504347826087, 0.95869565217391, 0.055555555555556
67980, 1.504347826087, 0.93260869565217, 0.027777777777778
67981, 1.5478260869565, 0.93260869565217, 0.47222222222222
67982, 1.5260869565217, 0.93260869565217, 0.44444444444444
67983, 1.5478260869565, 0.95869565217391, 0.44444444444444
67984, 1.5478260869565, 0.93260869565217, 0.41666666666667
67985, 1.5260869565217, 0.93260869565217, 0.38888888888889
67986, 1.5478260869565, 0.95869565217391, 0.38888888888889
67987, 1.5478260869565, 0.93260869565217, 0.36111111111111
67988, 1.5260869565217, 0.93260869565217, 0.33333333333333
67989, 1.5478260869565, 0.95869565217391, 0.33333333333333
67990, 1.5478260869565, 0.93260869565217, 0.30555555555556
67991, 1.5260869565217, 0.93260869565217, 0.27777777777778
67992, 1.5478260869565, 0.95869565217391, 0.27777777777778
67993, 1.5478260869565, 0.93260869565217, 0.25
67994, 1.5260869565217, 0.93260869565217, 0.22222222222222
67995, 1.5478260869565, 0.95869565217391, 0.22222222222222
67996, 1.5478260869565, 0.93260869565217, 0.19444444444444
67997, 1.5260869565217, 0.93260869565217, 0.16666666666667
67998, 1.5478260869565, 0.95869565217391, 0.16666666666667
67999, 1.5478260869565, 0.93260869565218, 0.13888888888889
68000, 1.5260869565217, 0.93260869565217, 0.11111111111111
68001, 1.5478260869565, 0.95869565217391, 0.11111111111111
68002, 1.5478260869565, 0.93260869565217, 0.083333333333333
68003, 1.5260869565217, 0.93260869565217, 0.055555555555556
68004, 1.5478260869565, 0.95869565217391, 0.055555555555556
68005, 1.5478260869565, 0.93260869565217, 0.027777777777778
68006, 1.5913043478261, 0.93260869565217, 0.47222222222222
68007, 1.5695652173913, 0.93260869565218, 0.44444444444444
68008, 1.5913043478261, 0.95869565217391, 0.44444444444444
68009, 1.5913043478261, 0.93260869565217, 0.41666666666667
68010, 1.5695652173913, 0.93260869565217, 0.38888888888889
68011, 1.5913043478261, 0.95869565217391, 0.38888888888889
68012, 1.5913043478261, 0.93260869565217, 0.36111111111111
68013, 1.5695652173913, 0.93260869565217, 0.33333333333333
68014, 1.5913043478261, 0.95869565217391, 0.33333333333333
68015, 1.5913043478261, 0.93260869565218, 0.30555555555556
68016, 1.5695652173913, 0.93260869565218, 0.27777777777778
68017, 1.5913043478261, 0.95869565217391, 0.27777777777778
68018, 1.5913043478261, 0.93260869565218, 0.25
68019, 1.5695652173913, 0.93260869565217, 0.22222222222222
68020, 1.5913043478261, 0.95869565217391, 0.22222222222222
68021, 1.5913043478261, 0.93260869565218, 0.19444444444444
68022, 1.5695652173913, 0.93260869565218, 0.16666666666667
68023, 1.5913043478261, 0.95869565217391, 0.16666666666667
68024, 1.5913043478261, 0.93260869565218, 0.13888888888889
68025, 1.5695652173913, 0.93260869565218, 0.11111111111111
68026, 1.5913043478261, 0.95869565217391, 0.11111111111111
68027, 1.5913043478261, 0.93260869565217, 0.083333333333333
68028, 1.5695652173913, 0.93260869565217, 0.055555555555556
68029, 1.5913043478261, 0.95869565217391, 0.055555555555556
68030, 1.5913043478261, 0.93260869565217, 0.027777777777778
68031, 1.6347826086957, 0.93260869565217, 0.47222222222222
68032, 1.6130434782609, 0.93260869565218, 0.44444444444444
68033, 1.6347826086957, 0.95869565217391, 0.44444444444444
68034, 1.6347826086957, 0.93260869565217, 0.41666666666667
68035, 1.6130434782609, 0.93260869565217, 0.38888888888889
68036, 1.6347826086957, 0.95869565217391, 0.38888888888889
68037, 1.6347826086957, 0.93260869565217, 0.36111111111111
68038, 1.6130434782609, 0.93260869565217, 0.33333333333333
68039, 1.6347826086957, 0.95869565217391, 0.33333333333333
68040, 1.6347826086957, 0.93260869565217, 0.30555555555556
68041, 1.6130434782609, 0.93260869565218, 0.27777777777778
68042, 1.6347826086957, 0.95869565217391, 0.27777777777778
68043, 1.6347826086957, 0.93260869565217, 0.25
68044, 1.6130434782609, 0.93260869565217, 0.22222222222222
68045, 1.6347826086957, 0.95869565217391, 0.22222222222222
68046, 1.6347826086957, 0.93260869565217, 0.19444444444444
68047, 1.6130434782609, 0.93260869565217, 0.16666666666667
68048, 1.6347826086957, 0.95869565217391, 0.16666666666667
68049, 1.6347826086957, 0.93260869565217, 0.13888888888889
68050, 1.6130434782609, 0.93260869565218, 0.11111111111111
68051, 1.6347826086957, 0.95869565217391, 0.11111111111111
68052, 1.6347826086957, 0.93260869565218, 0.083333333333333
68053, 1.6130434782609, 0.93260869565218, 0.055555555555556
68054, 1.6347826086957, 0.95869565217391, 0.055555555555556
68055, 1.6347826086957, 0.93260869565217, 0.027777777777778
68056, 1.6782608695652, 0.93260869565217, 0.47222222222222
68057, 1.6565217391304, 0.93260869565218, 0.44444444444444
68058, 1.6782608695652, 0.95869565217391, 0.44444444444444
68059, 1.6782608695652, 0.93260869565217, 0.41666666666667
68060, 1.6565217391304, 0.93260869565217, 0.38888888888889
68061, 1.6782608695652, 0.95869565217391, 0.38888888888889
68062, 1.6782608695652, 0.93260869565217, 0.36111111111111
68063, 1.6565217391304, 0.93260869565217, 0.33333333333333
68064, 1.6782608695652, 0.95869565217391, 0.33333333333333
68065, 1.6782608695652, 0.93260869565217, 0.30555555555556
68066, 1.6565217391304, 0.93260869565218, 0.27777777777778
68067, 1.6782608695652, 0.95869565217391, 0.27777777777778
68068, 1.6782608695652, 0.93260869565217, 0.25
68069, 1.6565217391304, 0.93260869565217, 0.22222222222222
68070, 1.6782608695652, 0.95869565217391, 0.22222222222222
68071, 1.6782608695652, 0.93260869565217, 0.19444444444444
68072, 1.6565217391304, 0.93260869565217, 0.16666666666667
68073, 1.6782608695652, 0.95869565217391, 0.16666666666667
68074, 1.6782608695652, 0.93260869565217, 0.13888888888889
68075, 1.6565217391304, 0.93260869565217, 0.11111111111111
68076, 1.6782608695652, 0.95869565217391, 0.11111111111111
68077, 1.6782608695652, 0.93260869565217, 0.083333333333333
68078, 1.6565217391304, 0.93260869565218, 0.055555555555556
68079, 1.6782608695652, 0.95869565217391, 0.055555555555556
68080, 1.6782608695652, 0.93260869565217, 0.027777777777778
68081, 1.7217391304348, 0.93260869565217, 0.47222222222222
68082, 1.7, 0.93260869565218, 0.44444444444444
68083, 1.7217391304348, 0.95869565217391, 0.44444444444444
68084, 1.7217391304348, 0.93260869565217, 0.41666666666667
68085, 1.7, 0.93260869565217, 0.38888888888889
68086, 1.7217391304348, 0.95869565217391, 0.38888888888889
68087, 1.7217391304348, 0.93260869565217, 0.36111111111111
68088, 1.7, 0.93260869565217, 0.33333333333333
68089, 1.7217391304348, 0.95869565217391, 0.33333333333333
68090, 1.7217391304348, 0.93260869565217, 0.30555555555556
68091, 1.7, 0.93260869565218, 0.27777777777778
68092, 1.7217391304348, 0.95869565217391, 0.27777777777778
68093, 1.7217391304348, 0.93260869565217, 0.25
68094, 1.7, 0.93260869565217, 0.22222222222222
68095, 1.7217391304348, 0.95869565217391, 0.22222222222222
68096, 1.7217391304348, 0.93260869565217, 0.19444444444444
68097, 1.7, 0.93260869565217, 0.16666666666667
68098, 1.7217391304348, 0.95869565217391, 0.16666666666667
68099, 1.7217391304348, 0.93260869565217, 0.13888888888889
68100, 1.7, 0.93260869565217, 0.11111111111111
68101, 1.7217391304348, 0.95869565217391, 0.11111111111111
68102, 1.7217391304348, 0.93260869565217, 0.083333333333333
68103, 1.7, 0.93260869565217, 0.055555555555556
68104, 1.7217391304348, 0.95869565217391, 0.055555555555556
68105, 1.7217391304348, 0.93260869565217, 0.027777777777778
68106, 1.7652173913043, 0.93260869565217, 0.47222222222222
68107, 1.7434782608696, 0.93260869565218, 0.44444444444444
68108, 1.7652173913043, 0.95869565217391, 0.44444444444444
68109, 1.7652173913043, 0.93260869565217, 0.41666666666667
68110, 1.7434782608696, 0.93260869565217, 0.38888888888889
68111, 1.7652173913043, 0.95869565217391, 0.38888888888889
68112, 1.7652173913043, 0.93260869565217, 0.36111111111111
68113, 1.7434782608696, 0.93260869565217, 0.33333333333333
68114, 1.7652173913043, 0.95869565217391, 0.33333333333333
68115, 1.7652173913043, 0.93260869565217, 0.30555555555556
68116, 1.7434782608696, 0.93260869565218, 0.27777777777778
68117, 1.7652173913043, 0.95869565217391, 0.27777777777778
68118, 1.7652173913043, 0.93260869565217, 0.25
68119, 1.7434782608696, 0.93260869565217, 0.22222222222222
68120, 1.7652173913043, 0.95869565217391, 0.22222222222222
68121, 1.7652173913043, 0.93260869565217, 0.19444444444444
68122, 1.7434782608696, 0.93260869565217, 0.16666666666667
68123, 1.7652173913043, 0.95869565217391, 0.16666666666667
68124, 1.7652173913043, 0.93260869565217, 0.13888888888889
68125, 1.7434782608696, 0.93260869565217, 0.11111111111111
68126, 1.7652173913043, 0.95869565217391, 0.11111111111111
68127, 1.7652173913043, 0.93260869565217, 0.083333333333333
68128, 1.7434782608696, 0.93260869565217, 0.055555555555556
68129, 1.7652173913043, 0.95869565217391, 0.055555555555556
68130, 1.7652173913043, 0.93260869565217, 0.027777777777778
68131, 1.8086956521739, 0.93260869565217, 0.47222222222222
68132, 1.7869565217391, 0.93260869565218, 0.44444444444444
68133, 1.8086956521739, 0.95869565217391, 0.44444444444444
68134, 1.8086956521739, 0.93260869565217, 0.41666666666667
68135, 1.7869565217391, 0.93260869565217, 0.38888888888889
68136, 1.8086956521739, 0.95869565217391, 0.38888888888889
68137, 1.8086956521739, 0.93260869565217, 0.36111111111111
68138, 1.7869565217391, 0.93260869565217, 0.33333333333333
68139, 1.8086956521739, 0.95869565217391, 0.33333333333333
68140, 1.8086956521739, 0.93260869565217, 0.30555555555556
68141, 1.7869565217391, 0.93260869565218, 0.27777777777778
68142, 1.8086956521739, 0.95869565217391, 0.27777777777778
68143, 1.8086956521739, 0.93260869565217, 0.25
68144, 1.7869565217391, 0.93260869565217, 0.22222222222222
68145, 1.8086956521739, 0.95869565217391, 0.22222222222222
68146, 1.8086956521739, 0.93260869565217, 0.19444444444444
68147, 1.7869565217391, 0.93260869565217, 0.16666666666667
68148, 1.8086956521739, 0.95869565217391, 0.16666666666667
68149, 1.8086956521739, 0.93260869565218, 0.13888888888889
68150, 1.7869565217391, 0.93260869565217, 0.11111111111111
68151, 1.8086956521739, 0.95869565217391, 0.11111111111111
68152, 1.8086956521739, 0.93260869565217, 0.083333333333333
68153, 1.7869565217391, 0.93260869565217, 0.055555555555556
68154, 1.8086956521739, 0.95869565217391, 0.055555555555556
68155, 1.8086956521739, 0.93260869565217, 0.027777777777778
68156, 1.8521739130435, 0.93260869565217, 0.47222222222222
68157, 1.8304347826087, 0.93260869565217, 0.44444444444444
68158, 1.8521739130435, 0.95869565217391, 0.44444444444444
68159, 1.8521739130435, 0.93260869565217, 0.41666666666667
68160, 1.8304347826087, 0.93260869565217, 0.38888888888889
68161, 1.8521739130435, 0.95869565217391, 0.38888888888889
68162, 1.8521739130435, 0.93260869565217, 0.36111111111111
68163, 1.8304347826087, 0.93260869565217, 0.33333333333333
68164, 1.8521739130435, 0.95869565217391, 0.33333333333333
68165, 1.8521739130435, 0.93260869565217, 0.30555555555556
68166, 1.8304347826087, 0.93260869565218, 0.27777777777778
68167, 1.8521739130435, 0.95869565217391, 0.27777777777778
68168, 1.8521739130435, 0.93260869565217, 0.25
68169, 1.8304347826087, 0.93260869565217, 0.22222222222222
68170, 1.8521739130435, 0.95869565217391, 0.22222222222222
68171, 1.8521739130435, 0.93260869565217, 0.19444444444444
68172, 1.8304347826087, 0.93260869565218, 0.16666666666667
68173, 1.8521739130435, 0.95869565217391, 0.16666666666667
68174, 1.8521739130435, 0.93260869565218, 0.13888888888889
68175, 1.8304347826087, 0.93260869565218, 0.11111111111111
68176, 1.8521739130435, 0.95869565217391, 0.11111111111111
68177, 1.8521739130435, 0.93260869565217, 0.083333333333333
68178, 1.8304347826087, 0.93260869565217, 0.055555555555556
68179, 1.8521739130435, 0.95869565217391, 0.055555555555556
68180, 1.8521739130435, 0.93260869565217, 0.027777777777778
68181, 1.895652173913, 0.93260869565217, 0.47222222222222
68182, 1.8739130434783, 0.93260869565218, 0.44444444444444
68183, 1.895652173913, 0.95869565217391, 0.44444444444444
68184, 1.895652173913, 0.93260869565217, 0.41666666666667
68185, 1.8739130434783, 0.93260869565217, 0.38888888888889
68186, 1.895652173913, 0.95869565217391, 0.38888888888889
68187, 1.895652173913, 0.93260869565217, 0.36111111111111
68188, 1.8739130434783, 0.93260869565217, 0.33333333333333
68189, 1.895652173913, 0.95869565217391, 0.33333333333333
68190, 1.895652173913, 0.93260869565217, 0.30555555555556
68191, 1.8739130434783, 0.93260869565218, 0.27777777777778
68192, 1.895652173913, 0.95869565217391, 0.27777777777778
68193, 1.895652173913, 0.93260869565217, 0.25
68194, 1.8739130434783, 0.93260869565217, 0.22222222222222
68195, 1.895652173913, 0.95869565217391, 0.22222222222222
68196, 1.895652173913, 0.93260869565217, 0.19444444444444
68197, 1.8739130434783, 0.93260869565217, 0.16666666666667
68198, 1.895652173913, 0.95869565217391, 0.16666666666667
68199, 1.895652173913, 0.93260869565217, 0.13888888888889
68200, 1.8739130434783, 0.93260869565217, 0.11111111111111
68201, 1.895652173913, 0.95869565217391, 0.11111111111111
68202, 1.895652173913, 0.93260869565217, 0.083333333333333
68203, 1.8739130434783, 0.93260869565217, 0.055555555555556
68204, 1.895652173913, 0.95869565217391, 0.055555555555556
68205, 1.895652173913, 0.93260869565217, 0.027777777777778
68206, 1.9391304347826, 0.93260869565217, 0.47222222222222
68207, 1.9173913043478, 0.93260869565218, 0.44444444444444
68208, 1.9391304347826, 0.95869565217391, 0.44444444444444
68209, 1.9391304347826, 0.93260869565217, 0.41666666666667
68210, 1.9173913043478, 0.93260869565217, 0.38888888888889
68211, 1.9391304347826, 0.95869565217391, 0.38888888888889
68212, 1.9391304347826, 0.93260869565217, 0.36111111111111
68213, 1.9173913043478, 0.93260869565217, 0.33333333333333
68214, 1.9391304347826, 0.95869565217391, 0.33333333333333
68215, 1.9391304347826, 0.93260869565218, 0.30555555555556
68216, 1.9173913043478, 0.93260869565218, 0.27777777777778
68217, 1.9391304347826, 0.95869565217391, 0.27777777777778
68218, 1.9391304347826, 0.93260869565217, 0.25
68219, 1.9173913043478, 0.93260869565217, 0.22222222222222
68220, 1.9391304347826, 0.95869565217391, 0.22222222222222
68221, 1.9391304347826, 0.93260869565217, 0.19444444444444
68222, 1.9173913043478, 0.93260869565217, 0.16666666666667
68223, 1.9391304347826, 0.95869565217391, 0.16666666666667
68224, 1.9391304347826, 0.93260869565217, 0.13888888888889
68225, 1.9173913043478, 0.93260869565217, 0.11111111111111
68226, 1.9391304347826, 0.95869565217391, 0.11111111111111
68227, 1.9391304347826, 0.93260869565217, 0.083333333333333
68228, 1.9173913043478, 0.93260869565217, 0.055555555555556
68229, 1.9391304347826, 0.95869565217391, 0.055555555555556
68230, 1.9391304347826, 0.93260869565217, 0.027777777777778
68231, 1.9826086956522, 0.93260869565217, 0.47222222222222
68232, 1.9608695652174, 0.93260869565218, 0.44444444444444
68233, 1.9826086956522, 0.95869565217391, 0.44444444444444
68234, 1.9826086956522, 0.93260869565217, 0.41666666666667
68235, 1.9608695652174, 0.93260869565217, 0.38888888888889
68236, 1.9826086956522, 0.95869565217391, 0.38888888888889
68237, 1.9826086956522, 0.93260869565217, 0.36111111111111
68238, 1.9608695652174, 0.93260869565217, 0.33333333333333
68239, 1.9826086956522, 0.95869565217391, 0.33333333333333
68240, 1.9826086956522, 0.93260869565217, 0.30555555555556
68241, 1.9608695652174, 0.93260869565218, 0.27777777777778
68242, 1.9826086956522, 0.95869565217391, 0.27777777777778
68243, 1.9826086956522, 0.93260869565217, 0.25
68244, 1.9608695652174, 0.93260869565217, 0.22222222222222
68245, 1.9826086956522, 0.95869565217391, 0.22222222222222
68246, 1.9826086956522, 0.93260869565217, 0.19444444444444
68247, 1.9608695652174, 0.93260869565217, 0.16666666666667
68248, 1.9826086956522, 0.95869565217391, 0.16666666666667
68249, 1.9826086956522, 0.93260869565217, 0.13888888888889
68250, 1.9608695652174, 0.93260869565217, 0.11111111111111
68251, 1.9826086956522, 0.95869565217391, 0.11111111111111
68252, 1.9826086956522, 0.93260869565217, 0.083333333333333
68253, 1.9608695652174, 0.93260869565217, 0.055555555555556
68254, 1.9826086956522, 0.95869565217391, 0.055555555555556
68255, 1.9826086956522, 0.93260869565217, 0.027777777777778
68256, 2.0260869565217, 0.93260869565217, 0.47222222222222
68257, 2.004347826087, 0.93260869565218, 0.44444444444444
68258, 2.0260869565217, 0.95869565217391, 0.44444444444444
68259, 2.0260869565217, 0.93260869565217, 0.41666666666667
68260, 2.004347826087, 0.93260869565217, 0.38888888888889
68261, 2.0260869565217, 0.95869565217391, 0.38888888888889
68262, 2.0260869565217, 0.93260869565217, 0.36111111111111
68263, 2.004347826087, 0.93260869565217, 0.33333333333333
68264, 2.0260869565217, 0.95869565217391, 0.33333333333333
68265, 2.0260869565217, 0.93260869565217, 0.30555555555556
68266, 2.004347826087, 0.93260869565218, 0.27777777777778
68267, 2.0260869565217, 0.95869565217391, 0.27777777777778
68268, 2.0260869565217, 0.93260869565217, 0.25
68269, 2.004347826087, 0.93260869565217, 0.22222222222222
68270, 2.0260869565217, 0.95869565217391, 0.22222222222222
68271, 2.0260869565217, 0.93260869565217, 0.19444444444444
68272, 2.004347826087, 0.93260869565217, 0.16666666666667
68273, 2.0260869565217, 0.95869565217391, 0.16666666666667
68274, 2.0260869565217, 0.93260869565217, 0.13888888888889
68275, 2.004347826087, 0.93260869565217, 0.11111111111111
68276, 2.0260869565217, 0.95869565217391, 0.11111111111111
68277, 2.0260869565217, 0.93260869565217, 0.083333333333333
68278, 2.004347826087, 0.93260869565217, 0.055555555555556
68279, 2.0260869565217, 0.95869565217391, 0.055555555555556
68280, 2.0260869565217, 0.93260869565217, 0.027777777777778
68281, 2.0695652173913, 0.93260869565217, 0.47222222222222
68282, 2.0478260869565, 0.93260869565218, 0.44444444444444
68283, 2.0695652173913, 0.95869565217391, 0.44444444444444
68284, 2.0695652173913, 0.93260869565217, 0.41666666666667
68285, 2.0478260869565, 0.93260869565217, 0.38888888888889
68286, 2.0695652173913, 0.95869565217391, 0.38888888888889
68287, 2.0695652173913, 0.93260869565217, 0.36111111111111
68288, 2.0478260869565, 0.93260869565217, 0.33333333333333
68289, 2.0695652173913, 0.95869565217391, 0.33333333333333
68290, 2.0695652173913, 0.93260869565217, 0.30555555555556
68291, 2.0478260869565, 0.93260869565218, 0.27777777777778
68292, 2.0695652173913, 0.95869565217391, 0.27777777777778
68293, 2.0695652173913, 0.93260869565217, 0.25
68294, 2.0478260869565, 0.93260869565217, 0.22222222222222
68295, 2.0695652173913, 0.95869565217391, 0.22222222222222
68296, 2.0695652173913, 0.93260869565217, 0.19444444444444
68297, 2.0478260869565, 0.93260869565217, 0.16666666666667
68298, 2.0695652173913, 0.95869565217391, 0.16666666666667
68299, 2.0695652173913, 0.93260869565218, 0.13888888888889
68300, 2.0478260869565, 0.93260869565217, 0.11111111111111
68301, 2.0695652173913, 0.95869565217391, 0.11111111111111
68302, 2.0695652173913, 0.93260869565217, 0.083333333333333
68303, 2.0478260869565, 0.93260869565217, 0.055555555555556
68304, 2.0695652173913, 0.95869565217391, 0.055555555555556
68305, 2.0695652173913, 0.93260869565217, 0.027777777777778
68306, 2.1130434782609, 0.93260869565217, 0.47222222222222
68307, 2.0913043478261, 0.93260869565218, 0.44444444444444
68308, 2.1130434782609, 0.95869565217391, 0.44444444444444
68309, 2.1130434782609, 0.93260869565217, 0.41666666666667
68310, 2.0913043478261, 0.93260869565217, 0.38888888888889
68311, 2.1130434782609, 0.95869565217391, 0.38888888888889
68312, 2.1130434782609, 0.93260869565217, 0.36111111111111
68313, 2.0913043478261, 0.93260869565217, 0.33333333333333
68314, 2.1130434782609, 0.95869565217391, 0.33333333333333
68315, 2.1130434782609, 0.93260869565217, 0.30555555555556
68316, 2.0913043478261, 0.93260869565218, 0.27777777777778
68317, 2.1130434782609, 0.95869565217391, 0.27777777777778
68318, 2.1130434782609, 0.93260869565217, 0.25
68319, 2.0913043478261, 0.93260869565217, 0.22222222222222
68320, 2.1130434782609, 0.95869565217391, 0.22222222222222
68321, 2.1130434782609, 0.93260869565217, 0.19444444444444
68322, 2.0913043478261, 0.93260869565217, 0.16666666666667
68323, 2.1130434782609, 0.95869565217391, 0.16666666666667
68324, 2.1130434782609, 0.93260869565217, 0.13888888888889
68325, 2.0913043478261, 0.93260869565217, 0.11111111111111
68326, 2.1130434782609, 0.95869565217391, 0.11111111111111
68327, 2.1130434782609, 0.93260869565217, 0.083333333333333
68328, 2.0913043478261, 0.93260869565217, 0.055555555555556
68329, 2.1130434782609, 0.95869565217391, 0.055555555555556
68330, 2.1130434782609, 0.93260869565217, 0.027777777777778
68331, 2.1565217391304, 0.93260869565217, 0.47222222222222
68332, 2.1347826086957, 0.93260869565218, 0.44444444444444
68333, 2.1565217391304, 0.95869565217391, 0.44444444444444
68334, 2.1565217391304, 0.93260869565217, 0.41666666666667
68335, 2.1347826086957, 0.93260869565217, 0.38888888888889
68336, 2.1565217391304, 0.95869565217391, 0.38888888888889
68337, 2.1565217391304, 0.93260869565217, 0.36111111111111
68338, 2.1347826086957, 0.93260869565217, 0.33333333333333
68339, 2.1565217391304, 0.95869565217391, 0.33333333333333
68340, 2.1565217391304, 0.93260869565217, 0.30555555555556
68341, 2.1347826086957, 0.93260869565218, 0.27777777777778
68342, 2.1565217391304, 0.95869565217391, 0.27777777777778
68343, 2.1565217391304, 0.93260869565217, 0.25
68344, 2.1347826086957, 0.93260869565217, 0.22222222222222
68345, 2.1565217391304, 0.95869565217391, 0.22222222222222
68346, 2.1565217391304, 0.93260869565217, 0.19444444444444
68347, 2.1347826086957, 0.93260869565217, 0.16666666666667
68348, 2.1565217391304, 0.95869565217391, 0.16666666666667
68349, 2.1565217391304, 0.93260869565217, 0.13888888888889
68350, 2.1347826086957, 0.93260869565217, 0.11111111111111
68351, 2.1565217391304, 0.95869565217391, 0.11111111111111
68352, 2.1565217391304, 0.93260869565217, 0.083333333333333
68353, 2.1347826086957, 0.93260869565217, 0.055555555555556
68354, 2.1565217391304, 0.95869565217391, 0.055555555555556
68355, 2.1565217391304, 0.93260869565217, 0.027777777777778
68356, 2.1782608695652, 0.93260869565217, 0.44444444444444
68357, 2.1782608695652, 0.93260869565217, 0.38888888888889
68358, 2.1782608695652, 0.93260869565217, 0.33333333333333
68359, 2.1782608695652, 0.93260869565217, 0.27777777777778
68360, 2.1782608695652, 0.93260869565217, 0.22222222222222
68361, 2.1782608695652, 0.93260869565217, 0.16666666666667
68362, 2.1782608695652, 0.93260869565217, 0.11111111111111
68363, 2.1782608695652, 0.93260869565217, 0.055555555555556
68364, 1.2434782608696, 0.8804347826087, 0.47222222222222
68365, 1.2217391304348, 0.8804347826087, 0.44444444444444
68366, 1.2434782608696, 0.90652173913044, 0.44444444444444
68367, 1.2434782608696, 0.8804347826087, 0.41666666666667
68368, 1.2217391304348, 0.8804347826087, 0.38888888888889
68369, 1.2434782608696, 0.90652173913044, 0.38888888888889
68370, 1.2434782608696, 0.8804347826087, 0.36111111111111
68371, 1.2217391304348, 0.8804347826087, 0.33333333333333
68372, 1.2434782608696, 0.90652173913044, 0.33333333333333
68373, 1.2434782608696, 0.8804347826087, 0.30555555555556
68374, 1.2217391304348, 0.8804347826087, 0.27777777777778
68375, 1.2434782608696, 0.90652173913044, 0.27777777777778
68376, 1.2434782608696, 0.8804347826087, 0.25
68377, 1.2217391304348, 0.8804347826087, 0.22222222222222
68378, 1.2434782608696, 0.90652173913044, 0.22222222222222
68379, 1.2434782608696, 0.8804347826087, 0.19444444444444
68380, 1.2217391304348, 0.8804347826087, 0.16666666666667
68381, 1.2434782608696, 0.90652173913044, 0.16666666666667
68382, 1.2434782608696, 0.8804347826087, 0.13888888888889
68383, 1.2217391304348, 0.8804347826087, 0.11111111111111
68384, 1.2434782608696, 0.90652173913044, 0.11111111111111
68385, 1.2434782608696, 0.8804347826087, 0.083333333333333
68386, 1.2217391304348, 0.8804347826087, 0.055555555555556
68387, 1.2434782608696, 0.90652173913044, 0.055555555555556
68388, 1.2434782608696, 0.8804347826087, 0.027777777777778
68389, 1.2869565217391, 0.8804347826087, 0.47222222222222
68390, 1.2652173913043, 0.8804347826087, 0.44444444444444
68391, 1.2869565217391, 0.90652173913044, 0.44444444444444
68392, 1.2869565217391, 0.8804347826087, 0.41666666666667
68393, 1.2652173913043, 0.8804347826087, 0.38888888888889
68394, 1.2869565217391, 0.90652173913044, 0.38888888888889
68395, 1.2869565217391, 0.8804347826087, 0.36111111111111
68396, 1.2652173913043, 0.8804347826087, 0.33333333333333
68397, 1.2869565217391, 0.90652173913044, 0.33333333333333
68398, 1.2869565217391, 0.8804347826087, 0.30555555555556
68399, 1.2652173913043, 0.8804347826087, 0.27777777777778
68400, 1.2869565217391, 0.90652173913044, 0.27777777777778
68401, 1.2869565217391, 0.8804347826087, 0.25
68402, 1.2652173913043, 0.8804347826087, 0.22222222222222
68403, 1.2869565217391, 0.90652173913044, 0.22222222222222
68404, 1.2869565217391, 0.8804347826087, 0.19444444444444
68405, 1.2652173913043, 0.8804347826087, 0.16666666666667
68406, 1.2869565217391, 0.90652173913044, 0.16666666666667
68407, 1.2869565217391, 0.8804347826087, 0.13888888888889
68408, 1.2652173913043, 0.8804347826087, 0.11111111111111
68409, 1.2869565217391, 0.90652173913044, 0.11111111111111
68410, 1.2869565217391, 0.8804347826087, 0.083333333333333
68411, 1.2652173913043, 0.8804347826087, 0.055555555555556
68412, 1.2869565217391, 0.90652173913044, 0.055555555555556
68413, 1.2869565217391, 0.8804347826087, 0.027777777777778
68414, 1.3304347826087, 0.8804347826087, 0.47222222222222
68415, 1.3086956521739, 0.8804347826087, 0.44444444444444
68416, 1.3304347826087, 0.90652173913044, 0.44444444444444
68417, 1.3304347826087, 0.8804347826087, 0.41666666666667
68418, 1.3086956521739, 0.8804347826087, 0.38888888888889
68419, 1.3304347826087, 0.90652173913044, 0.38888888888889
68420, 1.3304347826087, 0.8804347826087, 0.36111111111111
68421, 1.3086956521739, 0.8804347826087, 0.33333333333333
68422, 1.3304347826087, 0.90652173913044, 0.33333333333333
68423, 1.3304347826087, 0.8804347826087, 0.30555555555556
68424, 1.3086956521739, 0.8804347826087, 0.27777777777778
68425, 1.3304347826087, 0.90652173913044, 0.27777777777778
68426, 1.3304347826087, 0.8804347826087, 0.25
68427, 1.3086956521739, 0.8804347826087, 0.22222222222222
68428, 1.3304347826087, 0.90652173913044, 0.22222222222222
68429, 1.3304347826087, 0.8804347826087, 0.19444444444444
68430, 1.3086956521739, 0.8804347826087, 0.16666666666667
68431, 1.3304347826087, 0.90652173913044, 0.16666666666667
68432, 1.3304347826087, 0.8804347826087, 0.13888888888889
68433, 1.3086956521739, 0.8804347826087, 0.11111111111111
68434, 1.3304347826087, 0.90652173913044, 0.11111111111111
68435, 1.3304347826087, 0.8804347826087, 0.083333333333333
68436, 1.3086956521739, 0.8804347826087, 0.055555555555556
68437, 1.3304347826087, 0.90652173913044, 0.055555555555556
68438, 1.3304347826087, 0.8804347826087, 0.027777777777778
68439, 1.3739130434783, 0.8804347826087, 0.47222222222222
68440, 1.3521739130435, 0.8804347826087, 0.44444444444444
68441, 1.3739130434783, 0.90652173913044, 0.44444444444444
68442, 1.3739130434783, 0.8804347826087, 0.41666666666667
68443, 1.3521739130435, 0.8804347826087, 0.38888888888889
68444, 1.3739130434783, 0.90652173913044, 0.38888888888889
68445, 1.3739130434783, 0.8804347826087, 0.36111111111111
68446, 1.3521739130435, 0.8804347826087, 0.33333333333333
68447, 1.3739130434783, 0.90652173913044, 0.33333333333333
68448, 1.3739130434783, 0.8804347826087, 0.30555555555556
68449, 1.3521739130435, 0.8804347826087, 0.27777777777778
68450, 1.3739130434783, 0.90652173913044, 0.27777777777778
68451, 1.3739130434783, 0.8804347826087, 0.25
68452, 1.3521739130435, 0.8804347826087, 0.22222222222222
68453, 1.3739130434783, 0.90652173913044, 0.22222222222222
68454, 1.3739130434783, 0.8804347826087, 0.19444444444444
68455, 1.3521739130435, 0.8804347826087, 0.16666666666667
68456, 1.3739130434783, 0.90652173913044, 0.16666666666667
68457, 1.3739130434783, 0.8804347826087, 0.13888888888889
68458, 1.3521739130435, 0.8804347826087, 0.11111111111111
68459, 1.3739130434783, 0.90652173913044, 0.11111111111111
68460, 1.3739130434783, 0.8804347826087, 0.083333333333333
68461, 1.3521739130435, 0.8804347826087, 0.055555555555556
68462, 1.3739130434783, 0.90652173913044, 0.055555555555556
68463, 1.3739130434783, 0.8804347826087, 0.027777777777778
68464, 1.4173913043478, 0.8804347826087, 0.47222222222222
68465, 1.395652173913, 0.8804347826087, 0.44444444444444
68466, 1.4173913043478, 0.90652173913044, 0.44444444444444
68467, 1.4173913043478, 0.8804347826087, 0.41666666666667
68468, 1.395652173913, 0.8804347826087, 0.38888888888889
68469, 1.4173913043478, 0.90652173913044, 0.38888888888889
68470, 1.4173913043478, 0.8804347826087, 0.36111111111111
68471, 1.395652173913, 0.8804347826087, 0.33333333333333
68472, 1.4173913043478, 0.90652173913044, 0.33333333333333
68473, 1.4173913043478, 0.8804347826087, 0.30555555555556
68474, 1.395652173913, 0.8804347826087, 0.27777777777778
68475, 1.4173913043478, 0.90652173913044, 0.27777777777778
68476, 1.4173913043478, 0.8804347826087, 0.25
68477, 1.395652173913, 0.8804347826087, 0.22222222222222
68478, 1.4173913043478, 0.90652173913044, 0.22222222222222
68479, 1.4173913043478, 0.8804347826087, 0.19444444444444
68480, 1.395652173913, 0.8804347826087, 0.16666666666667
68481, 1.4173913043478, 0.90652173913044, 0.16666666666667
68482, 1.4173913043478, 0.8804347826087, 0.13888888888889
68483, 1.395652173913, 0.8804347826087, 0.11111111111111
68484, 1.4173913043478, 0.90652173913044, 0.11111111111111
68485, 1.4173913043478, 0.8804347826087, 0.083333333333333
68486, 1.395652173913, 0.8804347826087, 0.055555555555556
68487, 1.4173913043478, 0.90652173913044, 0.055555555555556
68488, 1.4173913043478, 0.8804347826087, 0.027777777777778
68489, 1.4608695652174, 0.8804347826087, 0.47222222222222
68490, 1.4391304347826, 0.8804347826087, 0.44444444444444
68491, 1.4608695652174, 0.90652173913044, 0.44444444444444
68492, 1.4608695652174, 0.8804347826087, 0.41666666666667
68493, 1.4391304347826, 0.8804347826087, 0.38888888888889
68494, 1.4608695652174, 0.90652173913044, 0.38888888888889
68495, 1.4608695652174, 0.8804347826087, 0.36111111111111
68496, 1.4391304347826, 0.8804347826087, 0.33333333333333
68497, 1.4608695652174, 0.90652173913044, 0.33333333333333
68498, 1.4608695652174, 0.8804347826087, 0.30555555555556
68499, 1.4391304347826, 0.8804347826087, 0.27777777777778
68500, 1.4608695652174, 0.90652173913044, 0.27777777777778
68501, 1.4608695652174, 0.8804347826087, 0.25
68502, 1.4391304347826, 0.8804347826087, 0.22222222222222
68503, 1.4608695652174, 0.90652173913044, 0.22222222222222
68504, 1.4608695652174, 0.8804347826087, 0.19444444444444
68505, 1.4391304347826, 0.8804347826087, 0.16666666666667
68506, 1.4608695652174, 0.90652173913044, 0.16666666666667
68507, 1.4608695652174, 0.8804347826087, 0.13888888888889
68508, 1.4391304347826, 0.8804347826087, 0.11111111111111
68509, 1.4608695652174, 0.90652173913044, 0.11111111111111
68510, 1.4608695652174, 0.8804347826087, 0.083333333333333
68511, 1.4391304347826, 0.8804347826087, 0.055555555555556
68512, 1.4608695652174, 0.90652173913044, 0.055555555555556
68513, 1.4608695652174, 0.8804347826087, 0.027777777777778
68514, 1.504347826087, 0.8804347826087, 0.47222222222222
68515, 1.4826086956522, 0.8804347826087, 0.44444444444444
68516, 1.504347826087, 0.90652173913044, 0.44444444444444
68517, 1.504347826087, 0.8804347826087, 0.41666666666667
68518, 1.4826086956522, 0.8804347826087, 0.38888888888889
68519, 1.504347826087, 0.90652173913044, 0.38888888888889
68520, 1.504347826087, 0.8804347826087, 0.36111111111111
68521, 1.4826086956522, 0.8804347826087, 0.33333333333333
68522, 1.504347826087, 0.90652173913044, 0.33333333333333
68523, 1.504347826087, 0.8804347826087, 0.30555555555556
68524, 1.4826086956522, 0.8804347826087, 0.27777777777778
68525, 1.504347826087, 0.90652173913044, 0.27777777777778
68526, 1.504347826087, 0.8804347826087, 0.25
68527, 1.4826086956522, 0.8804347826087, 0.22222222222222
68528, 1.504347826087, 0.90652173913044, 0.22222222222222
68529, 1.504347826087, 0.8804347826087, 0.19444444444444
68530, 1.4826086956522, 0.8804347826087, 0.16666666666667
68531, 1.504347826087, 0.90652173913044, 0.16666666666667
68532, 1.504347826087, 0.8804347826087, 0.13888888888889
68533, 1.4826086956522, 0.8804347826087, 0.11111111111111
68534, 1.504347826087, 0.90652173913044, 0.11111111111111
68535, 1.504347826087, 0.8804347826087, 0.083333333333333
68536, 1.4826086956522, 0.8804347826087, 0.055555555555556
68537, 1.504347826087, 0.90652173913044, 0.055555555555556
68538, 1.504347826087, 0.8804347826087, 0.027777777777778
68539, 1.5478260869565, 0.8804347826087, 0.47222222222222
68540, 1.5260869565217, 0.8804347826087, 0.44444444444444
68541, 1.5478260869565, 0.90652173913044, 0.44444444444444
68542, 1.5478260869565, 0.8804347826087, 0.41666666666667
68543, 1.5260869565217, 0.8804347826087, 0.38888888888889
68544, 1.5478260869565, 0.90652173913044, 0.38888888888889
68545, 1.5478260869565, 0.8804347826087, 0.36111111111111
68546, 1.5260869565217, 0.8804347826087, 0.33333333333333
68547, 1.5478260869565, 0.90652173913044, 0.33333333333333
68548, 1.5478260869565, 0.8804347826087, 0.30555555555556
68549, 1.5260869565217, 0.8804347826087, 0.27777777777778
68550, 1.5478260869565, 0.90652173913044, 0.27777777777778
68551, 1.5478260869565, 0.8804347826087, 0.25
68552, 1.5260869565217, 0.8804347826087, 0.22222222222222
68553, 1.5478260869565, 0.90652173913044, 0.22222222222222
68554, 1.5478260869565, 0.8804347826087, 0.19444444444444
68555, 1.5260869565217, 0.8804347826087, 0.16666666666667
68556, 1.5478260869565, 0.90652173913044, 0.16666666666667
68557, 1.5478260869565, 0.8804347826087, 0.13888888888889
68558, 1.5260869565217, 0.8804347826087, 0.11111111111111
68559, 1.5478260869565, 0.90652173913044, 0.11111111111111
68560, 1.5478260869565, 0.8804347826087, 0.083333333333333
68561, 1.5260869565217, 0.8804347826087, 0.055555555555556
68562, 1.5478260869565, 0.90652173913044, 0.055555555555556
68563, 1.5478260869565, 0.8804347826087, 0.027777777777778
68564, 1.5913043478261, 0.8804347826087, 0.47222222222222
68565, 1.5695652173913, 0.8804347826087, 0.44444444444444
68566, 1.5913043478261, 0.90652173913044, 0.44444444444444
68567, 1.5913043478261, 0.8804347826087, 0.41666666666667
68568, 1.5695652173913, 0.8804347826087, 0.38888888888889
68569, 1.5913043478261, 0.90652173913044, 0.38888888888889
68570, 1.5913043478261, 0.8804347826087, 0.36111111111111
68571, 1.5695652173913, 0.8804347826087, 0.33333333333333
68572, 1.5913043478261, 0.90652173913044, 0.33333333333333
68573, 1.5913043478261, 0.8804347826087, 0.30555555555556
68574, 1.5695652173913, 0.8804347826087, 0.27777777777778
68575, 1.5913043478261, 0.90652173913044, 0.27777777777778
68576, 1.5913043478261, 0.8804347826087, 0.25
68577, 1.5695652173913, 0.8804347826087, 0.22222222222222
68578, 1.5913043478261, 0.90652173913044, 0.22222222222222
68579, 1.5913043478261, 0.8804347826087, 0.19444444444444
68580, 1.5695652173913, 0.8804347826087, 0.16666666666667
68581, 1.5913043478261, 0.90652173913044, 0.16666666666667
68582, 1.5913043478261, 0.8804347826087, 0.13888888888889
68583, 1.5695652173913, 0.8804347826087, 0.11111111111111
68584, 1.5913043478261, 0.90652173913044, 0.11111111111111
68585, 1.5913043478261, 0.8804347826087, 0.083333333333333
68586, 1.5695652173913, 0.8804347826087, 0.055555555555556
68587, 1.5913043478261, 0.90652173913044, 0.055555555555556
68588, 1.5913043478261, 0.8804347826087, 0.027777777777778
68589, 1.6347826086957, 0.8804347826087, 0.47222222222222
68590, 1.6130434782609, 0.8804347826087, 0.44444444444444
68591, 1.6347826086957, 0.90652173913044, 0.44444444444444
68592, 1.6347826086957, 0.8804347826087, 0.41666666666667
68593, 1.6130434782609, 0.8804347826087, 0.38888888888889
68594, 1.6347826086957, 0.90652173913044, 0.38888888888889
68595, 1.6347826086957, 0.8804347826087, 0.36111111111111
68596, 1.6130434782609, 0.8804347826087, 0.33333333333333
68597, 1.6347826086957, 0.90652173913044, 0.33333333333333
68598, 1.6347826086957, 0.8804347826087, 0.30555555555556
68599, 1.6130434782609, 0.8804347826087, 0.27777777777778
68600, 1.6347826086957, 0.90652173913044, 0.27777777777778
68601, 1.6347826086957, 0.8804347826087, 0.25
68602, 1.6130434782609, 0.8804347826087, 0.22222222222222
68603, 1.6347826086957, 0.90652173913044, 0.22222222222222
68604, 1.6347826086957, 0.8804347826087, 0.19444444444444
68605, 1.6130434782609, 0.8804347826087, 0.16666666666667
68606, 1.6347826086957, 0.90652173913044, 0.16666666666667
68607, 1.6347826086957, 0.8804347826087, 0.13888888888889
68608, 1.6130434782609, 0.8804347826087, 0.11111111111111
68609, 1.6347826086957, 0.90652173913044, 0.11111111111111
68610, 1.6347826086957, 0.8804347826087, 0.083333333333333
68611, 1.6130434782609, 0.8804347826087, 0.055555555555556
68612, 1.6347826086957, 0.90652173913044, 0.055555555555556
68613, 1.6347826086957, 0.8804347826087, 0.027777777777778
68614, 1.6782608695652, 0.8804347826087, 0.47222222222222
68615, 1.6565217391304, 0.8804347826087, 0.44444444444444
68616, 1.6782608695652, 0.90652173913044, 0.44444444444444
68617, 1.6782608695652, 0.8804347826087, 0.41666666666667
68618, 1.6565217391304, 0.8804347826087, 0.38888888888889
68619, 1.6782608695652, 0.90652173913044, 0.38888888888889
68620, 1.6782608695652, 0.8804347826087, 0.36111111111111
68621, 1.6565217391304, 0.8804347826087, 0.33333333333333
68622, 1.6782608695652, 0.90652173913044, 0.33333333333333
68623, 1.6782608695652, 0.8804347826087, 0.30555555555556
68624, 1.6565217391304, 0.8804347826087, 0.27777777777778
68625, 1.6782608695652, 0.90652173913044, 0.27777777777778
68626, 1.6782608695652, 0.8804347826087, 0.25
68627, 1.6565217391304, 0.8804347826087, 0.22222222222222
68628, 1.6782608695652, 0.90652173913044, 0.22222222222222
68629, 1.6782608695652, 0.8804347826087, 0.19444444444444
68630, 1.6565217391304, 0.8804347826087, 0.16666666666667
68631, 1.6782608695652, 0.90652173913044, 0.16666666666667
68632, 1.6782608695652, 0.8804347826087, 0.13888888888889
68633, 1.6565217391304, 0.8804347826087, 0.11111111111111
68634, 1.6782608695652, 0.90652173913044, 0.11111111111111
68635, 1.6782608695652, 0.8804347826087, 0.083333333333333
68636, 1.6565217391304, 0.8804347826087, 0.055555555555556
68637, 1.6782608695652, 0.90652173913044, 0.055555555555556
68638, 1.6782608695652, 0.8804347826087, 0.027777777777778
68639, 1.7217391304348, 0.8804347826087, 0.47222222222222
68640, 1.7, 0.8804347826087, 0.44444444444444
68641, 1.7217391304348, 0.90652173913044, 0.44444444444444
68642, 1.7217391304348, 0.8804347826087, 0.41666666666667
68643, 1.7, 0.8804347826087, 0.38888888888889
68644, 1.7217391304348, 0.90652173913044, 0.38888888888889
68645, 1.7217391304348, 0.8804347826087, 0.36111111111111
68646, 1.7, 0.8804347826087, 0.33333333333333
68647, 1.7217391304348, 0.90652173913044, 0.33333333333333
68648, 1.7217391304348, 0.8804347826087, 0.30555555555556
68649, 1.7, 0.8804347826087, 0.27777777777778
68650, 1.7217391304348, 0.90652173913044, 0.27777777777778
68651, 1.7217391304348, 0.8804347826087, 0.25
68652, 1.7, 0.8804347826087, 0.22222222222222
68653, 1.7217391304348, 0.90652173913044, 0.22222222222222
68654, 1.7217391304348, 0.8804347826087, 0.19444444444444
68655, 1.7, 0.8804347826087, 0.16666666666667
68656, 1.7217391304348, 0.90652173913044, 0.16666666666667
68657, 1.7217391304348, 0.8804347826087, 0.13888888888889
68658, 1.7, 0.8804347826087, 0.11111111111111
68659, 1.7217391304348, 0.90652173913044, 0.11111111111111
68660, 1.7217391304348, 0.8804347826087, 0.083333333333333
68661, 1.7, 0.8804347826087, 0.055555555555556
68662, 1.7217391304348, 0.90652173913044, 0.055555555555556
68663, 1.7217391304348, 0.8804347826087, 0.027777777777778
68664, 1.7652173913043, 0.8804347826087, 0.47222222222222
68665, 1.7434782608696, 0.8804347826087, 0.44444444444444
68666, 1.7652173913043, 0.90652173913044, 0.44444444444444
68667, 1.7652173913043, 0.8804347826087, 0.41666666666667
68668, 1.7434782608696, 0.8804347826087, 0.38888888888889
68669, 1.7652173913043, 0.90652173913044, 0.38888888888889
68670, 1.7652173913043, 0.8804347826087, 0.36111111111111
68671, 1.7434782608696, 0.8804347826087, 0.33333333333333
68672, 1.7652173913043, 0.90652173913044, 0.33333333333333
68673, 1.7652173913043, 0.8804347826087, 0.30555555555556
68674, 1.7434782608696, 0.8804347826087, 0.27777777777778
68675, 1.7652173913043, 0.90652173913044, 0.27777777777778
68676, 1.7652173913043, 0.8804347826087, 0.25
68677, 1.7434782608696, 0.8804347826087, 0.22222222222222
68678, 1.7652173913043, 0.90652173913044, 0.22222222222222
68679, 1.7652173913043, 0.8804347826087, 0.19444444444444
68680, 1.7434782608696, 0.8804347826087, 0.16666666666667
68681, 1.7652173913043, 0.90652173913044, 0.16666666666667
68682, 1.7652173913043, 0.8804347826087, 0.13888888888889
68683, 1.7434782608696, 0.8804347826087, 0.11111111111111
68684, 1.7652173913043, 0.90652173913044, 0.11111111111111
68685, 1.7652173913043, 0.8804347826087, 0.083333333333333
68686, 1.7434782608696, 0.8804347826087, 0.055555555555556
68687, 1.7652173913043, 0.90652173913044, 0.055555555555556
68688, 1.7652173913043, 0.8804347826087, 0.027777777777778
68689, 1.8086956521739, 0.8804347826087, 0.47222222222222
68690, 1.7869565217391, 0.8804347826087, 0.44444444444444
68691, 1.8086956521739, 0.90652173913044, 0.44444444444444
68692, 1.8086956521739, 0.8804347826087, 0.41666666666667
68693, 1.7869565217391, 0.8804347826087, 0.38888888888889
68694, 1.8086956521739, 0.90652173913044, 0.38888888888889
68695, 1.8086956521739, 0.8804347826087, 0.36111111111111
68696, 1.7869565217391, 0.8804347826087, 0.33333333333333
68697, 1.8086956521739, 0.90652173913044, 0.33333333333333
68698, 1.8086956521739, 0.8804347826087, 0.30555555555556
68699, 1.7869565217391, 0.8804347826087, 0.27777777777778
68700, 1.8086956521739, 0.90652173913044, 0.27777777777778
68701, 1.8086956521739, 0.8804347826087, 0.25
68702, 1.7869565217391, 0.8804347826087, 0.22222222222222
68703, 1.8086956521739, 0.90652173913044, 0.22222222222222
68704, 1.8086956521739, 0.8804347826087, 0.19444444444444
68705, 1.7869565217391, 0.8804347826087, 0.16666666666667
68706, 1.8086956521739, 0.90652173913044, 0.16666666666667
68707, 1.8086956521739, 0.8804347826087, 0.13888888888889
68708, 1.7869565217391, 0.8804347826087, 0.11111111111111
68709, 1.8086956521739, 0.90652173913044, 0.11111111111111
68710, 1.8086956521739, 0.8804347826087, 0.083333333333333
68711, 1.7869565217391, 0.8804347826087, 0.055555555555556
68712, 1.8086956521739, 0.90652173913044, 0.055555555555556
68713, 1.8086956521739, 0.8804347826087, 0.027777777777778
68714, 1.8521739130435, 0.8804347826087, 0.47222222222222
68715, 1.8304347826087, 0.8804347826087, 0.44444444444444
68716, 1.8521739130435, 0.90652173913044, 0.44444444444444
68717, 1.8521739130435, 0.8804347826087, 0.41666666666667
68718, 1.8304347826087, 0.8804347826087, 0.38888888888889
68719, 1.8521739130435, 0.90652173913044, 0.38888888888889
68720, 1.8521739130435, 0.8804347826087, 0.36111111111111
68721, 1.8304347826087, 0.8804347826087, 0.33333333333333
68722, 1.8521739130435, 0.90652173913044, 0.33333333333333
68723, 1.8521739130435, 0.8804347826087, 0.30555555555556
68724, 1.8304347826087, 0.8804347826087, 0.27777777777778
68725, 1.8521739130435, 0.90652173913044, 0.27777777777778
68726, 1.8521739130435, 0.8804347826087, 0.25
68727, 1.8304347826087, 0.8804347826087, 0.22222222222222
68728, 1.8521739130435, 0.90652173913044, 0.22222222222222
68729, 1.8521739130435, 0.8804347826087, 0.19444444444444
68730, 1.8304347826087, 0.8804347826087, 0.16666666666667
68731, 1.8521739130435, 0.90652173913044, 0.16666666666667
68732, 1.8521739130435, 0.8804347826087, 0.13888888888889
68733, 1.8304347826087, 0.8804347826087, 0.11111111111111
68734, 1.8521739130435, 0.90652173913044, 0.11111111111111
68735, 1.8521739130435, 0.8804347826087, 0.083333333333333
68736, 1.8304347826087, 0.8804347826087, 0.055555555555556
68737, 1.8521739130435, 0.90652173913044, 0.055555555555556
68738, 1.8521739130435, 0.8804347826087, 0.027777777777778
68739, 1.895652173913, 0.8804347826087, 0.47222222222222
68740, 1.8739130434783, 0.8804347826087, 0.44444444444444
68741, 1.895652173913, 0.90652173913044, 0.44444444444444
68742, 1.895652173913, 0.8804347826087, 0.41666666666667
68743, 1.8739130434783, 0.8804347826087, 0.38888888888889
68744, 1.895652173913, 0.90652173913044, 0.38888888888889
68745, 1.895652173913, 0.8804347826087, 0.36111111111111
68746, 1.8739130434783, 0.8804347826087, 0.33333333333333
68747, 1.895652173913, 0.90652173913044, 0.33333333333333
68748, 1.895652173913, 0.8804347826087, 0.30555555555556
68749, 1.8739130434783, 0.8804347826087, 0.27777777777778
68750, 1.895652173913, 0.90652173913044, 0.27777777777778
68751, 1.895652173913, 0.8804347826087, 0.25
68752, 1.8739130434783, 0.8804347826087, 0.22222222222222
68753, 1.895652173913, 0.90652173913044, 0.22222222222222
68754, 1.895652173913, 0.8804347826087, 0.19444444444444
68755, 1.8739130434783, 0.8804347826087, 0.16666666666667
68756, 1.895652173913, 0.90652173913044, 0.16666666666667
68757, 1.895652173913, 0.8804347826087, 0.13888888888889
68758, 1.8739130434783, 0.8804347826087, 0.11111111111111
68759, 1.895652173913, 0.90652173913044, 0.11111111111111
68760, 1.895652173913, 0.8804347826087, 0.083333333333333
68761, 1.8739130434783, 0.8804347826087, 0.055555555555556
68762, 1.895652173913, 0.90652173913044, 0.055555555555556
68763, 1.895652173913, 0.8804347826087, 0.027777777777778
68764, 1.9391304347826, 0.8804347826087, 0.47222222222222
68765, 1.9173913043478, 0.8804347826087, 0.44444444444444
68766, 1.9391304347826, 0.90652173913044, 0.44444444444444
68767, 1.9391304347826, 0.8804347826087, 0.41666666666667
68768, 1.9173913043478, 0.8804347826087, 0.38888888888889
68769, 1.9391304347826, 0.90652173913044, 0.38888888888889
68770, 1.9391304347826, 0.8804347826087, 0.36111111111111
68771, 1.9173913043478, 0.8804347826087, 0.33333333333333
68772, 1.9391304347826, 0.90652173913044, 0.33333333333333
68773, 1.9391304347826, 0.8804347826087, 0.30555555555556
68774, 1.9173913043478, 0.8804347826087, 0.27777777777778
68775, 1.9391304347826, 0.90652173913044, 0.27777777777778
68776, 1.9391304347826, 0.8804347826087, 0.25
68777, 1.9173913043478, 0.8804347826087, 0.22222222222222
68778, 1.9391304347826, 0.90652173913044, 0.22222222222222
68779, 1.9391304347826, 0.8804347826087, 0.19444444444444
68780, 1.9173913043478, 0.8804347826087, 0.16666666666667
68781, 1.9391304347826, 0.90652173913044, 0.16666666666667
68782, 1.9391304347826, 0.8804347826087, 0.13888888888889
68783, 1.9173913043478, 0.8804347826087, 0.11111111111111
68784, 1.9391304347826, 0.90652173913044, 0.11111111111111
68785, 1.9391304347826, 0.8804347826087, 0.083333333333333
68786, 1.9173913043478, 0.8804347826087, 0.055555555555556
68787, 1.9391304347826, 0.90652173913044, 0.055555555555556
68788, 1.9391304347826, 0.8804347826087, 0.027777777777778
68789, 1.9826086956522, 0.8804347826087, 0.47222222222222
68790, 1.9608695652174, 0.8804347826087, 0.44444444444444
68791, 1.9826086956522, 0.90652173913044, 0.44444444444444
68792, 1.9826086956522, 0.8804347826087, 0.41666666666667
68793, 1.9608695652174, 0.8804347826087, 0.38888888888889
68794, 1.9826086956522, 0.90652173913044, 0.38888888888889
68795, 1.9826086956522, 0.8804347826087, 0.36111111111111
68796, 1.9608695652174, 0.8804347826087, 0.33333333333333
68797, 1.9826086956522, 0.90652173913044, 0.33333333333333
68798, 1.9826086956522, 0.8804347826087, 0.30555555555556
68799, 1.9608695652174, 0.8804347826087, 0.27777777777778
68800, 1.9826086956522, 0.90652173913044, 0.27777777777778
