15212, 0.065217391304348, 1.4, 0.33333333333333
15213, 0.08695652173913, 1.4, 0.36111111111111
15214, 0.065217391304348, 1.4, 0.38888888888889
15215, 0.08695652173913, 1.4, 0.41666666666667
15216, 0.065217391304348, 1.4, 0.44444444444444
15217, 0.08695652173913, 1.4, 0.47222222222222
15218, 0.1304347826087, 1.4, 0.027777777777778
15219, 0.10869565217391, 1.4, 0.055555555555556
15220, 0.1304347826087, 1.4, 0.083333333333333
15221, 0.10869565217391, 1.4, 0.11111111111111
15222, 0.1304347826087, 1.4, 0.13888888888889
15223, 0.10869565217391, 1.4, 0.16666666666667
15224, 0.1304347826087, 1.4, 0.19444444444444
15225, 0.10869565217391, 1.4, 0.22222222222222
15226, 0.1304347826087, 1.4, 0.25
15227, 0.10869565217391, 1.4, 0.27777777777778
15228, 0.1304347826087, 1.4, 0.30555555555556
15229, 0.10869565217391, 1.4, 0.33333333333333
15230, 0.1304347826087, 1.4, 0.36111111111111
15231, 0.10869565217391, 1.4, 0.38888888888889
15232, 0.1304347826087, 1.4, 0.41666666666667
15233, 0.10869565217391, 1.4, 0.44444444444444
15234, 0.1304347826087, 1.4, 0.47222222222222
15235, 0.17391304347826, 1.4, 0.027777777777778
15236, 0.15217391304348, 1.4, 0.055555555555556
15237, 0.17391304347826, 1.4, 0.083333333333333
15238, 0.15217391304348, 1.4, 0.11111111111111
15239, 0.17391304347826, 1.4, 0.13888888888889
15240, 0.15217391304348, 1.4, 0.16666666666667
15241, 0.17391304347826, 1.4, 0.19444444444444
15242, 0.15217391304348, 1.4, 0.22222222222222
15243, 0.17391304347826, 1.4, 0.25
15244, 0.15217391304348, 1.4, 0.27777777777778
15245, 0.17391304347826, 1.4, 0.30555555555556
15246, 0.15217391304348, 1.4, 0.33333333333333
15247, 0.17391304347826, 1.4, 0.36111111111111
15248, 0.15217391304348, 1.4, 0.38888888888889
15249, 0.17391304347826, 1.4, 0.41666666666667
15250, 0.15217391304348, 1.4, 0.44444444444444
15251, 0.17391304347826, 1.4, 0.47222222222222
15252, 0.21739130434783, 1.4, 0.027777777777778
15253, 0.19565217391304, 1.4, 0.055555555555556
15254, 0.21739130434783, 1.4, 0.083333333333333
15255, 0.19565217391304, 1.4, 0.11111111111111
15256, 0.21739130434783, 1.4, 0.13888888888889
15257, 0.19565217391304, 1.4, 0.16666666666667
15258, 0.21739130434783, 1.4, 0.19444444444444
15259, 0.19565217391304, 1.4, 0.22222222222222
15260, 0.21739130434783, 1.4, 0.25
15261, 0.19565217391304, 1.4, 0.27777777777778
15262, 0.21739130434783, 1.4, 0.30555555555556
15263, 0.19565217391304, 1.4, 0.33333333333333
15264, 0.21739130434783, 1.4, 0.36111111111111
15265, 0.19565217391304, 1.4, 0.38888888888889
15266, 0.21739130434783, 1.4, 0.41666666666667
15267, 0.19565217391304, 1.4, 0.44444444444444
15268, 0.21739130434783, 1.4, 0.47222222222222
15269, 0.26086956521739, 1.4, 0.027777777777778
15270, 0.23913043478261, 1.4, 0.055555555555556
15271, 0.26086956521739, 1.4, 0.083333333333333
15272, 0.23913043478261, 1.4, 0.11111111111111
15273, 0.26086956521739, 1.4, 0.13888888888889
15274, 0.23913043478261, 1.4, 0.16666666666667
15275, 0.26086956521739, 1.4, 0.19444444444444
15276, 0.23913043478261, 1.4, 0.22222222222222
15277, 0.26086956521739, 1.4, 0.25
15278, 0.23913043478261, 1.4, 0.27777777777778
15279, 0.26086956521739, 1.4, 0.30555555555556
15280, 0.23913043478261, 1.4, 0.33333333333333
15281, 0.26086956521739, 1.4, 0.36111111111111
15282, 0.23913043478261, 1.4, 0.38888888888889
15283, 0.26086956521739, 1.4, 0.41666666666667
15284, 0.23913043478261, 1.4, 0.44444444444444
15285, 0.26086956521739, 1.4, 0.47222222222222
15286, 0.30434782608696, 1.4, 0.027777777777778
15287, 0.28260869565217, 1.4, 0.055555555555556
15288, 0.30434782608696, 1.4, 0.083333333333333
15289, 0.28260869565217, 1.4, 0.11111111111111
15290, 0.30434782608696, 1.4, 0.13888888888889
15291, 0.28260869565217, 1.4, 0.16666666666667
15292, 0.30434782608696, 1.4, 0.19444444444444
15293, 0.28260869565217, 1.4, 0.22222222222222
15294, 0.30434782608696, 1.4, 0.25
15295, 0.28260869565217, 1.4, 0.27777777777778
15296, 0.30434782608696, 1.4, 0.30555555555556
15297, 0.28260869565217, 1.4, 0.33333333333333
15298, 0.30434782608696, 1.4, 0.36111111111111
15299, 0.28260869565217, 1.4, 0.38888888888889
15300, 0.30434782608696, 1.4, 0.41666666666667
15301, 0.28260869565217, 1.4, 0.44444444444444
15302, 0.30434782608696, 1.4, 0.47222222222222
15303, 0.34782608695652, 1.4, 0.027777777777778
15304, 0.32608695652174, 1.4, 0.055555555555556
15305, 0.34782608695652, 1.4, 0.083333333333333
15306, 0.32608695652174, 1.4, 0.11111111111111
15307, 0.34782608695652, 1.4, 0.13888888888889
15308, 0.32608695652174, 1.4, 0.16666666666667
15309, 0.34782608695652, 1.4, 0.19444444444444
15310, 0.32608695652174, 1.4, 0.22222222222222
15311, 0.34782608695652, 1.4, 0.25
15312, 0.32608695652174, 1.4, 0.27777777777778
15313, 0.34782608695652, 1.4, 0.30555555555556
15314, 0.32608695652174, 1.4, 0.33333333333333
15315, 0.34782608695652, 1.4, 0.36111111111111
15316, 0.32608695652174, 1.4, 0.38888888888889
15317, 0.34782608695652, 1.4, 0.41666666666667
15318, 0.32608695652174, 1.4, 0.44444444444444
15319, 0.34782608695652, 1.4, 0.47222222222222
15320, 0.39130434782609, 1.4, 0.027777777777778
15321, 0.3695652173913, 1.4, 0.055555555555556
15322, 0.39130434782609, 1.4, 0.083333333333333
15323, 0.3695652173913, 1.4, 0.11111111111111
15324, 0.39130434782609, 1.4, 0.13888888888889
15325, 0.3695652173913, 1.4, 0.16666666666667
15326, 0.39130434782609, 1.4, 0.19444444444444
15327, 0.3695652173913, 1.4, 0.22222222222222
15328, 0.39130434782609, 1.4, 0.25
15329, 0.3695652173913, 1.4, 0.27777777777778
15330, 0.39130434782609, 1.4, 0.30555555555556
15331, 0.3695652173913, 1.4, 0.33333333333333
15332, 0.39130434782609, 1.4, 0.36111111111111
15333, 0.3695652173913, 1.4, 0.38888888888889
15334, 0.39130434782609, 1.4, 0.41666666666667
15335, 0.3695652173913, 1.4, 0.44444444444444
15336, 0.39130434782609, 1.4, 0.47222222222222
15337, 0.43478260869565, 1.4, 0.027777777777778
15338, 0.41304347826087, 1.4, 0.055555555555556
15339, 0.43478260869565, 1.4, 0.083333333333333
15340, 0.41304347826087, 1.4, 0.11111111111111
15341, 0.43478260869565, 1.4, 0.13888888888889
15342, 0.41304347826087, 1.4, 0.16666666666667
15343, 0.43478260869565, 1.4, 0.19444444444444
15344, 0.41304347826087, 1.4, 0.22222222222222
15345, 0.43478260869565, 1.4, 0.25
15346, 0.41304347826087, 1.4, 0.27777777777778
15347, 0.43478260869565, 1.4, 0.30555555555556
15348, 0.41304347826087, 1.4, 0.33333333333333
15349, 0.43478260869565, 1.4, 0.36111111111111
15350, 0.41304347826087, 1.4, 0.38888888888889
15351, 0.43478260869565, 1.4, 0.41666666666667
15352, 0.41304347826087, 1.4, 0.44444444444444
15353, 0.43478260869565, 1.4, 0.47222222222222
15354, 0.47826086956522, 1.4, 0.027777777777778
15355, 0.45652173913043, 1.4, 0.055555555555556
15356, 0.47826086956522, 1.4, 0.083333333333333
15357, 0.45652173913043, 1.4, 0.11111111111111
15358, 0.47826086956522, 1.4, 0.13888888888889
15359, 0.45652173913043, 1.4, 0.16666666666667
15360, 0.47826086956522, 1.4, 0.19444444444444
15361, 0.45652173913043, 1.4, 0.22222222222222
15362, 0.47826086956522, 1.4, 0.25
15363, 0.45652173913043, 1.4, 0.27777777777778
15364, 0.47826086956522, 1.4, 0.30555555555556
15365, 0.45652173913043, 1.4, 0.33333333333333
15366, 0.47826086956522, 1.4, 0.36111111111111
15367, 0.45652173913043, 1.4, 0.38888888888889
15368, 0.47826086956522, 1.4, 0.41666666666667
15369, 0.45652173913043, 1.4, 0.44444444444444
15370, 0.47826086956522, 1.4, 0.47222222222222
15371, 0.52173913043478, 1.4, 0.027777777777778
15372, 0.5, 1.4, 0.055555555555556
15373, 0.52173913043478, 1.4, 0.083333333333333
15374, 0.5, 1.4, 0.11111111111111
15375, 0.52173913043478, 1.4, 0.13888888888889
15376, 0.5, 1.4, 0.16666666666667
15377, 0.52173913043478, 1.4, 0.19444444444444
15378, 0.5, 1.4, 0.22222222222222
15379, 0.52173913043478, 1.4, 0.25
15380, 0.5, 1.4, 0.27777777777778
15381, 0.52173913043478, 1.4, 0.30555555555556
15382, 0.5, 1.4, 0.33333333333333
15383, 0.52173913043478, 1.4, 0.36111111111111
15384, 0.5, 1.4, 0.38888888888889
15385, 0.52173913043478, 1.4, 0.41666666666667
15386, 0.5, 1.4, 0.44444444444444
15387, 0.52173913043478, 1.4, 0.47222222222222
15388, 0.56521739130435, 1.4, 0.027777777777778
15389, 0.54347826086957, 1.4, 0.055555555555556
15390, 0.56521739130435, 1.4, 0.083333333333333
15391, 0.54347826086957, 1.4, 0.11111111111111
15392, 0.56521739130435, 1.4, 0.13888888888889
15393, 0.54347826086957, 1.4, 0.16666666666667
15394, 0.56521739130435, 1.4, 0.19444444444444
15395, 0.54347826086957, 1.4, 0.22222222222222
15396, 0.56521739130435, 1.4, 0.25
15397, 0.54347826086957, 1.4, 0.27777777777778
15398, 0.56521739130435, 1.4, 0.30555555555556
15399, 0.54347826086957, 1.4, 0.33333333333333
15400, 0.56521739130435, 1.4, 0.36111111111111
15401, 0.54347826086957, 1.4, 0.38888888888889
15402, 0.56521739130435, 1.4, 0.41666666666667
15403, 0.54347826086957, 1.4, 0.44444444444444
15404, 0.56521739130435, 1.4, 0.47222222222222
15405, 0.60869565217391, 1.4, 0.027777777777778
15406, 0.58695652173913, 1.4, 0.055555555555556
15407, 0.60869565217391, 1.4, 0.083333333333333
15408, 0.58695652173913, 1.4, 0.11111111111111
15409, 0.60869565217391, 1.4, 0.13888888888889
15410, 0.58695652173913, 1.4, 0.16666666666667
15411, 0.60869565217391, 1.4, 0.19444444444444
15412, 0.58695652173913, 1.4, 0.22222222222222
15413, 0.60869565217391, 1.4, 0.25
15414, 0.58695652173913, 1.4, 0.27777777777778
15415, 0.60869565217391, 1.4, 0.30555555555556
15416, 0.58695652173913, 1.4, 0.33333333333333
15417, 0.60869565217391, 1.4, 0.36111111111111
15418, 0.58695652173913, 1.4, 0.38888888888889
15419, 0.60869565217391, 1.4, 0.41666666666667
15420, 0.58695652173913, 1.4, 0.44444444444444
15421, 0.60869565217391, 1.4, 0.47222222222222
15422, 0.65217391304348, 1.4, 0.027777777777778
15423, 0.6304347826087, 1.4, 0.055555555555556
15424, 0.65217391304348, 1.4, 0.083333333333333
15425, 0.6304347826087, 1.4, 0.11111111111111
15426, 0.65217391304348, 1.4, 0.13888888888889
15427, 0.6304347826087, 1.4, 0.16666666666667
15428, 0.65217391304348, 1.4, 0.19444444444444
15429, 0.6304347826087, 1.4, 0.22222222222222
15430, 0.65217391304348, 1.4, 0.25
15431, 0.6304347826087, 1.4, 0.27777777777778
15432, 0.65217391304348, 1.4, 0.30555555555556
15433, 0.6304347826087, 1.4, 0.33333333333333
15434, 0.65217391304348, 1.4, 0.36111111111111
15435, 0.6304347826087, 1.4, 0.38888888888889
15436, 0.65217391304348, 1.4, 0.41666666666667
15437, 0.6304347826087, 1.4, 0.44444444444444
15438, 0.65217391304348, 1.4, 0.47222222222222
15439, 0.69565217391304, 1.4, 0.027777777777778
15440, 0.67391304347826, 1.4, 0.055555555555556
15441, 0.69565217391304, 1.4, 0.083333333333333
15442, 0.67391304347826, 1.4, 0.11111111111111
15443, 0.69565217391304, 1.4, 0.13888888888889
15444, 0.67391304347826, 1.4, 0.16666666666667
15445, 0.69565217391304, 1.4, 0.19444444444444
15446, 0.67391304347826, 1.4, 0.22222222222222
15447, 0.69565217391304, 1.4, 0.25
15448, 0.67391304347826, 1.4, 0.27777777777778
15449, 0.69565217391304, 1.4, 0.30555555555556
15450, 0.67391304347826, 1.4, 0.33333333333333
15451, 0.69565217391304, 1.4, 0.36111111111111
15452, 0.67391304347826, 1.4, 0.38888888888889
15453, 0.69565217391304, 1.4, 0.41666666666667
15454, 0.67391304347826, 1.4, 0.44444444444444
15455, 0.69565217391304, 1.4, 0.47222222222222
15456, 0.73913043478261, 1.4, 0.027777777777778
15457, 0.71739130434783, 1.4, 0.055555555555556
15458, 0.73913043478261, 1.4, 0.083333333333333
15459, 0.71739130434783, 1.4, 0.11111111111111
15460, 0.73913043478261, 1.4, 0.13888888888889
15461, 0.71739130434783, 1.4, 0.16666666666667
15462, 0.73913043478261, 1.4, 0.19444444444444
15463, 0.71739130434783, 1.4, 0.22222222222222
15464, 0.73913043478261, 1.4, 0.25
15465, 0.71739130434783, 1.4, 0.27777777777778
15466, 0.73913043478261, 1.4, 0.30555555555556
15467, 0.71739130434783, 1.4, 0.33333333333333
15468, 0.73913043478261, 1.4, 0.36111111111111
15469, 0.71739130434783, 1.4, 0.38888888888889
15470, 0.73913043478261, 1.4, 0.41666666666667
15471, 0.71739130434783, 1.4, 0.44444444444444
15472, 0.73913043478261, 1.4, 0.47222222222222
15473, 0.78260869565217, 1.4, 0.027777777777778
15474, 0.76086956521739, 1.4, 0.055555555555556
15475, 0.78260869565217, 1.4, 0.083333333333333
15476, 0.76086956521739, 1.4, 0.11111111111111
15477, 0.78260869565217, 1.4, 0.13888888888889
15478, 0.76086956521739, 1.4, 0.16666666666667
15479, 0.78260869565217, 1.4, 0.19444444444444
15480, 0.76086956521739, 1.4, 0.22222222222222
15481, 0.78260869565217, 1.4, 0.25
15482, 0.76086956521739, 1.4, 0.27777777777778
15483, 0.78260869565217, 1.4, 0.30555555555556
15484, 0.76086956521739, 1.4, 0.33333333333333
15485, 0.78260869565217, 1.4, 0.36111111111111
15486, 0.76086956521739, 1.4, 0.38888888888889
15487, 0.78260869565217, 1.4, 0.41666666666667
15488, 0.76086956521739, 1.4, 0.44444444444444
15489, 0.78260869565217, 1.4, 0.47222222222222
15490, 0.82608695652174, 1.4, 0.027777777777778
15491, 0.80434782608696, 1.4, 0.055555555555556
15492, 0.82608695652174, 1.4, 0.083333333333333
15493, 0.80434782608696, 1.4, 0.11111111111111
15494, 0.82608695652174, 1.4, 0.13888888888889
15495, 0.80434782608696, 1.4, 0.16666666666667
15496, 0.82608695652174, 1.4, 0.19444444444444
15497, 0.80434782608696, 1.4, 0.22222222222222
15498, 0.82608695652174, 1.4, 0.25
15499, 0.80434782608696, 1.4, 0.27777777777778
15500, 0.82608695652174, 1.4, 0.30555555555556
15501, 0.80434782608696, 1.4, 0.33333333333333
15502, 0.82608695652174, 1.4, 0.36111111111111
15503, 0.80434782608696, 1.4, 0.38888888888889
15504, 0.82608695652174, 1.4, 0.41666666666667
15505, 0.80434782608696, 1.4, 0.44444444444444
15506, 0.82608695652174, 1.4, 0.47222222222222
15507, 0.8695652173913, 1.4, 0.027777777777778
15508, 0.84782608695652, 1.4, 0.055555555555556
15509, 0.8695652173913, 1.4, 0.083333333333333
15510, 0.84782608695652, 1.4, 0.11111111111111
15511, 0.8695652173913, 1.4, 0.13888888888889
15512, 0.84782608695652, 1.4, 0.16666666666667
15513, 0.8695652173913, 1.4, 0.19444444444444
15514, 0.84782608695652, 1.4, 0.22222222222222
15515, 0.8695652173913, 1.4, 0.25
15516, 0.84782608695652, 1.4, 0.27777777777778
15517, 0.8695652173913, 1.4, 0.30555555555556
15518, 0.84782608695652, 1.4, 0.33333333333333
15519, 0.8695652173913, 1.4, 0.36111111111111
15520, 0.84782608695652, 1.4, 0.38888888888889
15521, 0.8695652173913, 1.4, 0.41666666666667
15522, 0.84782608695652, 1.4, 0.44444444444444
15523, 0.8695652173913, 1.4, 0.47222222222222
15524, 0.91304347826087, 1.4, 0.027777777777778
15525, 0.89130434782609, 1.4, 0.055555555555556
15526, 0.91304347826087, 1.4, 0.083333333333333
15527, 0.89130434782609, 1.4, 0.11111111111111
15528, 0.91304347826087, 1.4, 0.13888888888889
15529, 0.89130434782609, 1.4, 0.16666666666667
15530, 0.91304347826087, 1.4, 0.19444444444444
15531, 0.89130434782609, 1.4, 0.22222222222222
15532, 0.91304347826087, 1.4, 0.25
15533, 0.89130434782609, 1.4, 0.27777777777778
15534, 0.91304347826087, 1.4, 0.30555555555556
15535, 0.89130434782609, 1.4, 0.33333333333333
15536, 0.91304347826087, 1.4, 0.36111111111111
15537, 0.89130434782609, 1.4, 0.38888888888889
15538, 0.91304347826087, 1.4, 0.41666666666667
15539, 0.89130434782609, 1.4, 0.44444444444444
15540, 0.91304347826087, 1.4, 0.47222222222222
15541, 0.95652173913043, 1.4, 0.027777777777778
15542, 0.93478260869565, 1.4, 0.055555555555556
15543, 0.95652173913043, 1.4, 0.083333333333333
15544, 0.93478260869565, 1.4, 0.11111111111111
15545, 0.95652173913043, 1.4, 0.13888888888889
15546, 0.93478260869565, 1.4, 0.16666666666667
15547, 0.95652173913043, 1.4, 0.19444444444444
15548, 0.93478260869565, 1.4, 0.22222222222222
15549, 0.95652173913043, 1.4, 0.25
15550, 0.93478260869565, 1.4, 0.27777777777778
15551, 0.95652173913043, 1.4, 0.30555555555556
15552, 0.93478260869565, 1.4, 0.33333333333333
15553, 0.95652173913043, 1.4, 0.36111111111111
15554, 0.93478260869565, 1.4, 0.38888888888889
15555, 0.95652173913043, 1.4, 0.41666666666667
15556, 0.93478260869565, 1.4, 0.44444444444444
15557, 0.95652173913043, 1.4, 0.47222222222222
15558, 0.97826086956522, 1.4, 0.055555555555556
15559, 0.97826086956522, 1.4, 0.11111111111111
15560, 0.97826086956522, 1.4, 0.16666666666667
15561, 0.97826086956522, 1.4, 0.22222222222222
15562, 0.97826086956522, 1.4, 0.27777777777778
15563, 0.97826086956522, 1.4, 0.33333333333333
15564, 0.97826086956522, 1.4, 0.38888888888889
15565, 0.97826086956522, 1.4, 0.44444444444444
15566, 1.2434782608696, 1.425, 0.5
15567, 1.2869565217391, 1.425, 0.5
15568, 1.3304347826087, 1.425, 0.5
15569, 1.3739130434783, 1.425, 0.5
15570, 1.4173913043478, 1.425, 0.5
15571, 1.4608695652174, 1.425, 0.5
15572, 1.504347826087, 1.425, 0.5
15573, 1.5478260869565, 1.425, 0.5
15574, 1.5913043478261, 1.425, 0.5
15575, 1.6347826086957, 1.425, 0.5
15576, 1.6782608695652, 1.425, 0.5
15577, 1.7217391304348, 1.425, 0.5
15578, 1.7652173913043, 1.425, 0.5
15579, 1.8086956521739, 1.425, 0.5
15580, 1.8521739130435, 1.425, 0.5
15581, 1.895652173913, 1.425, 0.5
15582, 1.9391304347826, 1.425, 0.5
15583, 1.9826086956522, 1.425, 0.5
15584, 2.0260869565217, 1.425, 0.5
15585, 2.0695652173913, 1.425, 0.5
15586, 2.1130434782609, 1.425, 0.5
15587, 2.1565217391304, 1.425, 0.5
15588, 1.2217391304348, 1.425, 0.5
15589, 1.2434782608696, 1.4375, 0.5
15590, 1.2652173913043, 1.425, 0.5
15591, 1.2869565217391, 1.4375, 0.5
15592, 1.3086956521739, 1.425, 0.5
15593, 1.3304347826087, 1.4375, 0.5
15594, 1.3521739130435, 1.425, 0.5
15595, 1.3739130434783, 1.4375, 0.5
15596, 1.395652173913, 1.425, 0.5
15597, 1.4173913043478, 1.4375, 0.5
15598, 1.4391304347826, 1.425, 0.5
15599, 1.4608695652174, 1.4375, 0.5
15600, 1.4826086956522, 1.425, 0.5
15601, 1.504347826087, 1.4375, 0.5
15602, 1.5260869565217, 1.425, 0.5
15603, 1.5478260869565, 1.4375, 0.5
15604, 1.5695652173913, 1.425, 0.5
15605, 1.5913043478261, 1.4375, 0.5
15606, 1.6130434782609, 1.425, 0.5
15607, 1.6347826086957, 1.4375, 0.5
15608, 1.6565217391304, 1.425, 0.5
15609, 1.6782608695652, 1.4375, 0.5
15610, 1.7, 1.425, 0.5
15611, 1.7217391304348, 1.4375, 0.5
15612, 1.7434782608696, 1.425, 0.5
15613, 1.7652173913043, 1.4375, 0.5
15614, 1.7869565217391, 1.425, 0.5
15615, 1.8086956521739, 1.4375, 0.5
15616, 1.8304347826087, 1.425, 0.5
15617, 1.8521739130435, 1.4375, 0.5
15618, 1.8739130434783, 1.425, 0.5
15619, 1.895652173913, 1.4375, 0.5
15620, 1.9173913043478, 1.425, 0.5
15621, 1.9391304347826, 1.4375, 0.5
15622, 1.9608695652174, 1.425, 0.5
15623, 1.9826086956522, 1.4375, 0.5
15624, 2.004347826087, 1.425, 0.5
15625, 2.0260869565217, 1.4375, 0.5
15626, 2.0478260869565, 1.425, 0.5
15627, 2.0695652173913, 1.4375, 0.5
15628, 2.0913043478261, 1.425, 0.5
15629, 2.1130434782609, 1.4375, 0.5
15630, 2.1347826086957, 1.425, 0.5
15631, 2.1565217391304, 1.4375, 0.5
15632, 2.1782608695652, 1.425, 0.5
15633, 1.2434782608696, 1.4125, 0.5
15634, 1.2869565217391, 1.4125, 0.5
15635, 1.3304347826087, 1.4125, 0.5
15636, 1.3739130434783, 1.4125, 0.5
15637, 1.4173913043478, 1.4125, 0.5
15638, 1.4608695652174, 1.4125, 0.5
15639, 1.504347826087, 1.4125, 0.5
15640, 1.5478260869565, 1.4125, 0.5
15641, 1.5913043478261, 1.4125, 0.5
15642, 1.6347826086957, 1.4125, 0.5
15643, 1.6782608695652, 1.4125, 0.5
15644, 1.7217391304348, 1.4125, 0.5
15645, 1.7652173913043, 1.4125, 0.5
15646, 1.8086956521739, 1.4125, 0.5
15647, 1.8521739130435, 1.4125, 0.5
15648, 1.895652173913, 1.4125, 0.5
15649, 1.9391304347826, 1.4125, 0.5
15650, 1.9826086956522, 1.4125, 0.5
15651, 2.0260869565217, 1.4125, 0.5
15652, 2.0695652173913, 1.4125, 0.5
15653, 2.1130434782609, 1.4125, 0.5
15654, 2.1565217391304, 1.4125, 0.5
15655, 1.2434782608696, 1.425, 0
15656, 1.2869565217391, 1.425, 0
15657, 1.3304347826087, 1.425, 0
15658, 1.3739130434783, 1.425, 0
15659, 1.4173913043478, 1.425, 0
15660, 1.4608695652174, 1.425, 0
15661, 1.504347826087, 1.425, 0
15662, 1.5478260869565, 1.425, 0
15663, 1.5913043478261, 1.425, 0
15664, 1.6347826086957, 1.425, 0
15665, 1.6782608695652, 1.425, 0
15666, 1.7217391304348, 1.425, 0
15667, 1.7652173913043, 1.425, 0
15668, 1.8086956521739, 1.425, 0
15669, 1.8521739130435, 1.425, 0
15670, 1.895652173913, 1.425, 0
15671, 1.9391304347826, 1.425, 0
15672, 1.9826086956522, 1.425, 0
15673, 2.0260869565217, 1.425, 0
15674, 2.0695652173913, 1.425, 0
15675, 2.1130434782609, 1.425, 0
15676, 2.1565217391304, 1.425, 0
15677, 1.2434782608696, 1.4375, 0
15678, 1.2217391304348, 1.425, 0
15679, 1.2869565217391, 1.4375, 0
15680, 1.2652173913043, 1.425, 0
15681, 1.3304347826087, 1.4375, 0
15682, 1.3086956521739, 1.425, 0
15683, 1.3739130434783, 1.4375, 0
15684, 1.3521739130435, 1.425, 0
15685, 1.4173913043478, 1.4375, 0
15686, 1.395652173913, 1.425, 0
15687, 1.4608695652174, 1.4375, 0
15688, 1.4391304347826, 1.425, 0
15689, 1.504347826087, 1.4375, 0
15690, 1.4826086956522, 1.425, 0
15691, 1.5478260869565, 1.4375, 0
15692, 1.5260869565217, 1.425, 0
15693, 1.5913043478261, 1.4375, 0
15694, 1.5695652173913, 1.425, 0
15695, 1.6347826086957, 1.4375, 0
15696, 1.6130434782609, 1.425, 0
15697, 1.6782608695652, 1.4375, 0
15698, 1.6565217391304, 1.425, 0
15699, 1.7217391304348, 1.4375, 0
15700, 1.7, 1.425, 0
15701, 1.7652173913043, 1.4375, 0
15702, 1.7434782608696, 1.425, 0
15703, 1.8086956521739, 1.4375, 0
15704, 1.7869565217391, 1.425, 0
15705, 1.8521739130435, 1.4375, 0
15706, 1.8304347826087, 1.425, 0
15707, 1.895652173913, 1.4375, 0
15708, 1.8739130434783, 1.425, 0
15709, 1.9391304347826, 1.4375, 0
15710, 1.9173913043478, 1.425, 0
15711, 1.9826086956522, 1.4375, 0
15712, 1.9608695652174, 1.425, 0
15713, 2.0260869565217, 1.4375, 0
15714, 2.004347826087, 1.425, 0
15715, 2.0695652173913, 1.4375, 0
15716, 2.0478260869565, 1.425, 0
15717, 2.1130434782609, 1.4375, 0
15718, 2.0913043478261, 1.425, 0
15719, 2.1565217391304, 1.4375, 0
15720, 2.1347826086957, 1.425, 0
15721, 2.1782608695652, 1.425, 0
15722, 1.2434782608696, 1.4125, 0
15723, 1.2869565217391, 1.4125, 0
15724, 1.3304347826087, 1.4125, 0
15725, 1.3739130434783, 1.4125, 0
15726, 1.4173913043478, 1.4125, 0
15727, 1.4608695652174, 1.4125, 0
15728, 1.504347826087, 1.4125, 0
15729, 1.5478260869565, 1.4125, 0
15730, 1.5913043478261, 1.4125, 0
15731, 1.6347826086957, 1.4125, 0
15732, 1.6782608695652, 1.4125, 0
15733, 1.7217391304348, 1.4125, 0
15734, 1.7652173913043, 1.4125, 0
15735, 1.8086956521739, 1.4125, 0
15736, 1.8521739130435, 1.4125, 0
15737, 1.895652173913, 1.4125, 0
15738, 1.9391304347826, 1.4125, 0
15739, 1.9826086956522, 1.4125, 0
15740, 2.0260869565217, 1.4125, 0
15741, 2.0695652173913, 1.4125, 0
15742, 2.1130434782609, 1.4125, 0
15743, 2.1565217391304, 1.4125, 0
15744, 1.2, 1.425, 0.44444444444444
15745, 1.2, 1.425, 0.38888888888889
15746, 1.2, 1.425, 0.33333333333333
15747, 1.2, 1.425, 0.27777777777778
15748, 1.2, 1.425, 0.22222222222222
15749, 1.2, 1.425, 0.16666666666667
15750, 1.2, 1.425, 0.11111111111111
15751, 1.2, 1.425, 0.055555555555556
15752, 1.2, 1.4375, 0.44444444444444
15753, 1.2, 1.425, 0.47222222222222
15754, 1.2, 1.4375, 0.38888888888889
15755, 1.2, 1.425, 0.41666666666667
15756, 1.2, 1.4375, 0.33333333333333
15757, 1.2, 1.425, 0.36111111111111
15758, 1.2, 1.4375, 0.27777777777778
15759, 1.2, 1.425, 0.30555555555556
15760, 1.2, 1.4375, 0.22222222222222
15761, 1.2, 1.425, 0.25
15762, 1.2, 1.4375, 0.16666666666667
15763, 1.2, 1.425, 0.19444444444444
15764, 1.2, 1.4375, 0.11111111111111
15765, 1.2, 1.425, 0.13888888888889
15766, 1.2, 1.4375, 0.055555555555556
15767, 1.2, 1.425, 0.083333333333333
15768, 1.2, 1.425, 0.027777777777778
15769, 1.2, 1.4125, 0.44444444444444
15770, 1.2, 1.4125, 0.38888888888889
15771, 1.2, 1.4125, 0.33333333333333
15772, 1.2, 1.4125, 0.27777777777778
15773, 1.2, 1.4125, 0.22222222222222
15774, 1.2, 1.4125, 0.16666666666667
15775, 1.2, 1.4125, 0.11111111111111
15776, 1.2, 1.4125, 0.055555555555556
15777, 2.2, 1.425, 0.44444444444444
15778, 2.2, 1.425, 0.38888888888889
15779, 2.2, 1.425, 0.33333333333333
15780, 2.2, 1.425, 0.27777777777778
15781, 2.2, 1.425, 0.22222222222222
15782, 2.2, 1.425, 0.16666666666667
15783, 2.2, 1.425, 0.11111111111111
15784, 2.2, 1.425, 0.055555555555556
15785, 2.2, 1.425, 0.47222222222222
15786, 2.2, 1.4375, 0.44444444444444
15787, 2.2, 1.425, 0.41666666666667
15788, 2.2, 1.4375, 0.38888888888889
15789, 2.2, 1.425, 0.36111111111111
15790, 2.2, 1.4375, 0.33333333333333
15791, 2.2, 1.425, 0.30555555555556
15792, 2.2, 1.4375, 0.27777777777778
15793, 2.2, 1.425, 0.25
15794, 2.2, 1.4375, 0.22222222222222
15795, 2.2, 1.425, 0.19444444444444
15796, 2.2, 1.4375, 0.16666666666667
15797, 2.2, 1.425, 0.13888888888889
15798, 2.2, 1.4375, 0.11111111111111
15799, 2.2, 1.425, 0.083333333333333
15800, 2.2, 1.4375, 0.055555555555556
15801, 2.2, 1.425, 0.027777777777778
15802, 2.2, 1.4125, 0.44444444444444
15803, 2.2, 1.4125, 0.38888888888889
15804, 2.2, 1.4125, 0.33333333333333
15805, 2.2, 1.4125, 0.27777777777778
15806, 2.2, 1.4125, 0.22222222222222
15807, 2.2, 1.4125, 0.16666666666667
15808, 2.2, 1.4125, 0.11111111111111
15809, 2.2, 1.4125, 0.055555555555556
15810, 1.2434782608696, 1.45, 0.44444444444444
15811, 1.2434782608696, 1.45, 0.38888888888889
15812, 1.2434782608696, 1.45, 0.33333333333333
15813, 1.2434782608696, 1.45, 0.27777777777778
15814, 1.2434782608696, 1.45, 0.22222222222222
15815, 1.2434782608696, 1.45, 0.16666666666667
15816, 1.2434782608696, 1.45, 0.11111111111111
15817, 1.2434782608696, 1.45, 0.055555555555556
15818, 1.2869565217391, 1.45, 0.44444444444444
15819, 1.2869565217391, 1.45, 0.38888888888889
15820, 1.2869565217391, 1.45, 0.33333333333333
15821, 1.2869565217391, 1.45, 0.27777777777778
15822, 1.2869565217391, 1.45, 0.22222222222222
15823, 1.2869565217391, 1.45, 0.16666666666667
15824, 1.2869565217391, 1.45, 0.11111111111111
15825, 1.2869565217391, 1.45, 0.055555555555556
15826, 1.3304347826087, 1.45, 0.44444444444444
15827, 1.3304347826087, 1.45, 0.38888888888889
15828, 1.3304347826087, 1.45, 0.33333333333333
15829, 1.3304347826087, 1.45, 0.27777777777778
15830, 1.3304347826087, 1.45, 0.22222222222222
15831, 1.3304347826087, 1.45, 0.16666666666667
15832, 1.3304347826087, 1.45, 0.11111111111111
15833, 1.3304347826087, 1.45, 0.055555555555556
15834, 1.3739130434783, 1.45, 0.44444444444444
15835, 1.3739130434783, 1.45, 0.38888888888889
15836, 1.3739130434783, 1.45, 0.33333333333333
15837, 1.3739130434783, 1.45, 0.27777777777778
15838, 1.3739130434783, 1.45, 0.22222222222222
15839, 1.3739130434783, 1.45, 0.16666666666667
15840, 1.3739130434783, 1.45, 0.11111111111111
15841, 1.3739130434783, 1.45, 0.055555555555556
15842, 1.4173913043478, 1.45, 0.44444444444444
15843, 1.4173913043478, 1.45, 0.38888888888889
15844, 1.4173913043478, 1.45, 0.33333333333333
15845, 1.4173913043478, 1.45, 0.27777777777778
15846, 1.4173913043478, 1.45, 0.22222222222222
15847, 1.4173913043478, 1.45, 0.16666666666667
15848, 1.4173913043478, 1.45, 0.11111111111111
15849, 1.4173913043478, 1.45, 0.055555555555556
15850, 1.4608695652174, 1.45, 0.44444444444444
15851, 1.4608695652174, 1.45, 0.38888888888889
15852, 1.4608695652174, 1.45, 0.33333333333333
15853, 1.4608695652174, 1.45, 0.27777777777778
15854, 1.4608695652174, 1.45, 0.22222222222222
15855, 1.4608695652174, 1.45, 0.16666666666667
15856, 1.4608695652174, 1.45, 0.11111111111111
15857, 1.4608695652174, 1.45, 0.055555555555556
15858, 1.504347826087, 1.45, 0.44444444444444
15859, 1.504347826087, 1.45, 0.38888888888889
15860, 1.504347826087, 1.45, 0.33333333333333
15861, 1.504347826087, 1.45, 0.27777777777778
15862, 1.504347826087, 1.45, 0.22222222222222
15863, 1.504347826087, 1.45, 0.16666666666667
15864, 1.504347826087, 1.45, 0.11111111111111
15865, 1.504347826087, 1.45, 0.055555555555556
15866, 1.5478260869565, 1.45, 0.44444444444444
15867, 1.5478260869565, 1.45, 0.38888888888889
15868, 1.5478260869565, 1.45, 0.33333333333333
15869, 1.5478260869565, 1.45, 0.27777777777778
15870, 1.5478260869565, 1.45, 0.22222222222222
15871, 1.5478260869565, 1.45, 0.16666666666667
15872, 1.5478260869565, 1.45, 0.11111111111111
15873, 1.5478260869565, 1.45, 0.055555555555556
15874, 1.5913043478261, 1.45, 0.44444444444444
15875, 1.5913043478261, 1.45, 0.38888888888889
15876, 1.5913043478261, 1.45, 0.33333333333333
15877, 1.5913043478261, 1.45, 0.27777777777778
15878, 1.5913043478261, 1.45, 0.22222222222222
15879, 1.5913043478261, 1.45, 0.16666666666667
15880, 1.5913043478261, 1.45, 0.11111111111111
15881, 1.5913043478261, 1.45, 0.055555555555556
15882, 1.6347826086957, 1.45, 0.44444444444444
15883, 1.6347826086957, 1.45, 0.38888888888889
15884, 1.6347826086957, 1.45, 0.33333333333333
15885, 1.6347826086957, 1.45, 0.27777777777778
15886, 1.6347826086957, 1.45, 0.22222222222222
15887, 1.6347826086957, 1.45, 0.16666666666667
15888, 1.6347826086957, 1.45, 0.11111111111111
15889, 1.6347826086957, 1.45, 0.055555555555556
15890, 1.6782608695652, 1.45, 0.44444444444444
15891, 1.6782608695652, 1.45, 0.38888888888889
15892, 1.6782608695652, 1.45, 0.33333333333333
15893, 1.6782608695652, 1.45, 0.27777777777778
15894, 1.6782608695652, 1.45, 0.22222222222222
15895, 1.6782608695652, 1.45, 0.16666666666667
15896, 1.6782608695652, 1.45, 0.11111111111111
15897, 1.6782608695652, 1.45, 0.055555555555556
15898, 1.7217391304348, 1.45, 0.44444444444444
15899, 1.7217391304348, 1.45, 0.38888888888889
15900, 1.7217391304348, 1.45, 0.33333333333333
15901, 1.7217391304348, 1.45, 0.27777777777778
15902, 1.7217391304348, 1.45, 0.22222222222222
15903, 1.7217391304348, 1.45, 0.16666666666667
15904, 1.7217391304348, 1.45, 0.11111111111111
15905, 1.7217391304348, 1.45, 0.055555555555556
15906, 1.7652173913043, 1.45, 0.44444444444444
15907, 1.7652173913043, 1.45, 0.38888888888889
15908, 1.7652173913043, 1.45, 0.33333333333333
15909, 1.7652173913043, 1.45, 0.27777777777778
15910, 1.7652173913043, 1.45, 0.22222222222222
15911, 1.7652173913043, 1.45, 0.16666666666667
15912, 1.7652173913043, 1.45, 0.11111111111111
15913, 1.7652173913043, 1.45, 0.055555555555556
15914, 1.8086956521739, 1.45, 0.44444444444444
15915, 1.8086956521739, 1.45, 0.38888888888889
15916, 1.8086956521739, 1.45, 0.33333333333333
15917, 1.8086956521739, 1.45, 0.27777777777778
15918, 1.8086956521739, 1.45, 0.22222222222222
15919, 1.8086956521739, 1.45, 0.16666666666667
15920, 1.8086956521739, 1.45, 0.11111111111111
15921, 1.8086956521739, 1.45, 0.055555555555556
15922, 1.8521739130435, 1.45, 0.44444444444444
15923, 1.8521739130435, 1.45, 0.38888888888889
15924, 1.8521739130435, 1.45, 0.33333333333333
15925, 1.8521739130435, 1.45, 0.27777777777778
15926, 1.8521739130435, 1.45, 0.22222222222222
15927, 1.8521739130435, 1.45, 0.16666666666667
15928, 1.8521739130435, 1.45, 0.11111111111111
15929, 1.8521739130435, 1.45, 0.055555555555556
15930, 1.895652173913, 1.45, 0.44444444444444
15931, 1.895652173913, 1.45, 0.38888888888889
15932, 1.895652173913, 1.45, 0.33333333333333
15933, 1.895652173913, 1.45, 0.27777777777778
15934, 1.895652173913, 1.45, 0.22222222222222
15935, 1.895652173913, 1.45, 0.16666666666667
15936, 1.895652173913, 1.45, 0.11111111111111
15937, 1.895652173913, 1.45, 0.055555555555556
15938, 1.9391304347826, 1.45, 0.44444444444444
15939, 1.9391304347826, 1.45, 0.38888888888889
15940, 1.9391304347826, 1.45, 0.33333333333333
15941, 1.9391304347826, 1.45, 0.27777777777778
15942, 1.9391304347826, 1.45, 0.22222222222222
15943, 1.9391304347826, 1.45, 0.16666666666667
15944, 1.9391304347826, 1.45, 0.11111111111111
15945, 1.9391304347826, 1.45, 0.055555555555556
15946, 1.9826086956522, 1.45, 0.44444444444444
15947, 1.9826086956522, 1.45, 0.38888888888889
15948, 1.9826086956522, 1.45, 0.33333333333333
15949, 1.9826086956522, 1.45, 0.27777777777778
15950, 1.9826086956522, 1.45, 0.22222222222222
15951, 1.9826086956522, 1.45, 0.16666666666667
15952, 1.9826086956522, 1.45, 0.11111111111111
15953, 1.9826086956522, 1.45, 0.055555555555556
15954, 2.0260869565217, 1.45, 0.44444444444444
15955, 2.0260869565217, 1.45, 0.38888888888889
15956, 2.0260869565217, 1.45, 0.33333333333333
15957, 2.0260869565217, 1.45, 0.27777777777778
15958, 2.0260869565217, 1.45, 0.22222222222222
15959, 2.0260869565217, 1.45, 0.16666666666667
15960, 2.0260869565217, 1.45, 0.11111111111111
15961, 2.0260869565217, 1.45, 0.055555555555556
15962, 2.0695652173913, 1.45, 0.44444444444444
15963, 2.0695652173913, 1.45, 0.38888888888889
15964, 2.0695652173913, 1.45, 0.33333333333333
15965, 2.0695652173913, 1.45, 0.27777777777778
15966, 2.0695652173913, 1.45, 0.22222222222222
15967, 2.0695652173913, 1.45, 0.16666666666667
15968, 2.0695652173913, 1.45, 0.11111111111111
15969, 2.0695652173913, 1.45, 0.055555555555556
15970, 2.1130434782609, 1.45, 0.44444444444444
15971, 2.1130434782609, 1.45, 0.38888888888889
15972, 2.1130434782609, 1.45, 0.33333333333333
15973, 2.1130434782609, 1.45, 0.27777777777778
15974, 2.1130434782609, 1.45, 0.22222222222222
15975, 2.1130434782609, 1.45, 0.16666666666667
15976, 2.1130434782609, 1.45, 0.11111111111111
15977, 2.1130434782609, 1.45, 0.055555555555556
15978, 2.1565217391304, 1.45, 0.44444444444444
15979, 2.1565217391304, 1.45, 0.38888888888889
15980, 2.1565217391304, 1.45, 0.33333333333333
15981, 2.1565217391304, 1.45, 0.27777777777778
15982, 2.1565217391304, 1.45, 0.22222222222222
15983, 2.1565217391304, 1.45, 0.16666666666667
15984, 2.1565217391304, 1.45, 0.11111111111111
15985, 2.1565217391304, 1.45, 0.055555555555556
15986, 1.2434782608696, 1.45, 0.47222222222222
15987, 1.2217391304348, 1.45, 0.44444444444444
15988, 1.2434782608696, 1.45, 0.41666666666667
15989, 1.2217391304348, 1.45, 0.38888888888889
15990, 1.2434782608696, 1.45, 0.36111111111111
15991, 1.2217391304348, 1.45, 0.33333333333333
15992, 1.2434782608696, 1.45, 0.30555555555556
15993, 1.2217391304348, 1.45, 0.27777777777778
15994, 1.2434782608696, 1.45, 0.25
15995, 1.2217391304348, 1.45, 0.22222222222222
15996, 1.2434782608696, 1.45, 0.19444444444444
15997, 1.2217391304348, 1.45, 0.16666666666667
15998, 1.2434782608696, 1.45, 0.13888888888889
15999, 1.2217391304348, 1.45, 0.11111111111111
16000, 1.2434782608696, 1.45, 0.083333333333333
16001, 1.2217391304348, 1.45, 0.055555555555556
16002, 1.2434782608696, 1.45, 0.027777777777778
16003, 1.2869565217391, 1.45, 0.47222222222222
16004, 1.2652173913043, 1.45, 0.44444444444444
16005, 1.2869565217391, 1.45, 0.41666666666667
16006, 1.2652173913043, 1.45, 0.38888888888889
16007, 1.2869565217391, 1.45, 0.36111111111111
16008, 1.2652173913043, 1.45, 0.33333333333333
16009, 1.2869565217391, 1.45, 0.30555555555556
16010, 1.2652173913043, 1.45, 0.27777777777778
16011, 1.2869565217391, 1.45, 0.25
16012, 1.2652173913043, 1.45, 0.22222222222222
16013, 1.2869565217391, 1.45, 0.19444444444444
16014, 1.2652173913043, 1.45, 0.16666666666667
16015, 1.2869565217391, 1.45, 0.13888888888889
16016, 1.2652173913043, 1.45, 0.11111111111111
16017, 1.2869565217391, 1.45, 0.083333333333333
16018, 1.2652173913043, 1.45, 0.055555555555556
16019, 1.2869565217391, 1.45, 0.027777777777778
16020, 1.3304347826087, 1.45, 0.47222222222222
16021, 1.3086956521739, 1.45, 0.44444444444444
16022, 1.3304347826087, 1.45, 0.41666666666667
16023, 1.3086956521739, 1.45, 0.38888888888889
16024, 1.3304347826087, 1.45, 0.36111111111111
16025, 1.3086956521739, 1.45, 0.33333333333333
16026, 1.3304347826087, 1.45, 0.30555555555556
16027, 1.3086956521739, 1.45, 0.27777777777778
16028, 1.3304347826087, 1.45, 0.25
16029, 1.3086956521739, 1.45, 0.22222222222222
16030, 1.3304347826087, 1.45, 0.19444444444444
16031, 1.3086956521739, 1.45, 0.16666666666667
16032, 1.3304347826087, 1.45, 0.13888888888889
16033, 1.3086956521739, 1.45, 0.11111111111111
16034, 1.3304347826087, 1.45, 0.083333333333333
16035, 1.3086956521739, 1.45, 0.055555555555556
16036, 1.3304347826087, 1.45, 0.027777777777778
16037, 1.3739130434783, 1.45, 0.47222222222222
16038, 1.3521739130435, 1.45, 0.44444444444444
16039, 1.3739130434783, 1.45, 0.41666666666667
16040, 1.3521739130435, 1.45, 0.38888888888889
16041, 1.3739130434783, 1.45, 0.36111111111111
16042, 1.3521739130435, 1.45, 0.33333333333333
16043, 1.3739130434783, 1.45, 0.30555555555556
16044, 1.3521739130435, 1.45, 0.27777777777778
16045, 1.3739130434783, 1.45, 0.25
16046, 1.3521739130435, 1.45, 0.22222222222222
16047, 1.3739130434783, 1.45, 0.19444444444444
16048, 1.3521739130435, 1.45, 0.16666666666667
16049, 1.3739130434783, 1.45, 0.13888888888889
16050, 1.3521739130435, 1.45, 0.11111111111111
16051, 1.3739130434783, 1.45, 0.083333333333333
16052, 1.3521739130435, 1.45, 0.055555555555556
16053, 1.3739130434783, 1.45, 0.027777777777778
16054, 1.4173913043478, 1.45, 0.47222222222222
16055, 1.395652173913, 1.45, 0.44444444444444
16056, 1.4173913043478, 1.45, 0.41666666666667
16057, 1.395652173913, 1.45, 0.38888888888889
16058, 1.4173913043478, 1.45, 0.36111111111111
16059, 1.395652173913, 1.45, 0.33333333333333
16060, 1.4173913043478, 1.45, 0.30555555555556
16061, 1.395652173913, 1.45, 0.27777777777778
16062, 1.4173913043478, 1.45, 0.25
16063, 1.395652173913, 1.45, 0.22222222222222
16064, 1.4173913043478, 1.45, 0.19444444444444
16065, 1.395652173913, 1.45, 0.16666666666667
16066, 1.4173913043478, 1.45, 0.13888888888889
16067, 1.395652173913, 1.45, 0.11111111111111
16068, 1.4173913043478, 1.45, 0.083333333333333
16069, 1.395652173913, 1.45, 0.055555555555556
16070, 1.4173913043478, 1.45, 0.027777777777778
16071, 1.4608695652174, 1.45, 0.47222222222222
16072, 1.4391304347826, 1.45, 0.44444444444444
16073, 1.4608695652174, 1.45, 0.41666666666667
16074, 1.4391304347826, 1.45, 0.38888888888889
16075, 1.4608695652174, 1.45, 0.36111111111111
16076, 1.4391304347826, 1.45, 0.33333333333333
16077, 1.4608695652174, 1.45, 0.30555555555556
16078, 1.4391304347826, 1.45, 0.27777777777778
16079, 1.4608695652174, 1.45, 0.25
16080, 1.4391304347826, 1.45, 0.22222222222222
16081, 1.4608695652174, 1.45, 0.19444444444444
16082, 1.4391304347826, 1.45, 0.16666666666667
16083, 1.4608695652174, 1.45, 0.13888888888889
16084, 1.4391304347826, 1.45, 0.11111111111111
16085, 1.4608695652174, 1.45, 0.083333333333333
16086, 1.4391304347826, 1.45, 0.055555555555556
16087, 1.4608695652174, 1.45, 0.027777777777778
16088, 1.504347826087, 1.45, 0.47222222222222
16089, 1.4826086956522, 1.45, 0.44444444444444
16090, 1.504347826087, 1.45, 0.41666666666667
16091, 1.4826086956522, 1.45, 0.38888888888889
16092, 1.504347826087, 1.45, 0.36111111111111
16093, 1.4826086956522, 1.45, 0.33333333333333
16094, 1.504347826087, 1.45, 0.30555555555556
16095, 1.4826086956522, 1.45, 0.27777777777778
16096, 1.504347826087, 1.45, 0.25
16097, 1.4826086956522, 1.45, 0.22222222222222
16098, 1.504347826087, 1.45, 0.19444444444444
16099, 1.4826086956522, 1.45, 0.16666666666667
16100, 1.504347826087, 1.45, 0.13888888888889
16101, 1.4826086956522, 1.45, 0.11111111111111
16102, 1.504347826087, 1.45, 0.083333333333333
16103, 1.4826086956522, 1.45, 0.055555555555556
16104, 1.504347826087, 1.45, 0.027777777777778
16105, 1.5478260869565, 1.45, 0.47222222222222
16106, 1.5260869565217, 1.45, 0.44444444444444
16107, 1.5478260869565, 1.45, 0.41666666666667
16108, 1.5260869565217, 1.45, 0.38888888888889
16109, 1.5478260869565, 1.45, 0.36111111111111
16110, 1.5260869565217, 1.45, 0.33333333333333
16111, 1.5478260869565, 1.45, 0.30555555555556
16112, 1.5260869565217, 1.45, 0.27777777777778
16113, 1.5478260869565, 1.45, 0.25
16114, 1.5260869565217, 1.45, 0.22222222222222
16115, 1.5478260869565, 1.45, 0.19444444444444
16116, 1.5260869565217, 1.45, 0.16666666666667
16117, 1.5478260869565, 1.45, 0.13888888888889
16118, 1.5260869565217, 1.45, 0.11111111111111
16119, 1.5478260869565, 1.45, 0.083333333333333
16120, 1.5260869565217, 1.45, 0.055555555555556
16121, 1.5478260869565, 1.45, 0.027777777777778
16122, 1.5913043478261, 1.45, 0.47222222222222
16123, 1.5695652173913, 1.45, 0.44444444444444
16124, 1.5913043478261, 1.45, 0.41666666666667
16125, 1.5695652173913, 1.45, 0.38888888888889
16126, 1.5913043478261, 1.45, 0.36111111111111
16127, 1.5695652173913, 1.45, 0.33333333333333
16128, 1.5913043478261, 1.45, 0.30555555555556
16129, 1.5695652173913, 1.45, 0.27777777777778
16130, 1.5913043478261, 1.45, 0.25
16131, 1.5695652173913, 1.45, 0.22222222222222
16132, 1.5913043478261, 1.45, 0.19444444444444
16133, 1.5695652173913, 1.45, 0.16666666666667
16134, 1.5913043478261, 1.45, 0.13888888888889
16135, 1.5695652173913, 1.45, 0.11111111111111
16136, 1.5913043478261, 1.45, 0.083333333333333
16137, 1.5695652173913, 1.45, 0.055555555555556
16138, 1.5913043478261, 1.45, 0.027777777777778
16139, 1.6347826086957, 1.45, 0.47222222222222
16140, 1.6130434782609, 1.45, 0.44444444444444
16141, 1.6347826086957, 1.45, 0.41666666666667
16142, 1.6130434782609, 1.45, 0.38888888888889
16143, 1.6347826086957, 1.45, 0.36111111111111
16144, 1.6130434782609, 1.45, 0.33333333333333
16145, 1.6347826086957, 1.45, 0.30555555555556
16146, 1.6130434782609, 1.45, 0.27777777777778
16147, 1.6347826086957, 1.45, 0.25
16148, 1.6130434782609, 1.45, 0.22222222222222
16149, 1.6347826086957, 1.45, 0.19444444444444
16150, 1.6130434782609, 1.45, 0.16666666666667
16151, 1.6347826086957, 1.45, 0.13888888888889
16152, 1.6130434782609, 1.45, 0.11111111111111
16153, 1.6347826086957, 1.45, 0.083333333333333
16154, 1.6130434782609, 1.45, 0.055555555555556
16155, 1.6347826086957, 1.45, 0.027777777777778
16156, 1.6782608695652, 1.45, 0.47222222222222
16157, 1.6565217391304, 1.45, 0.44444444444444
16158, 1.6782608695652, 1.45, 0.41666666666667
16159, 1.6565217391304, 1.45, 0.38888888888889
16160, 1.6782608695652, 1.45, 0.36111111111111
16161, 1.6565217391304, 1.45, 0.33333333333333
16162, 1.6782608695652, 1.45, 0.30555555555556
16163, 1.6565217391304, 1.45, 0.27777777777778
16164, 1.6782608695652, 1.45, 0.25
16165, 1.6565217391304, 1.45, 0.22222222222222
16166, 1.6782608695652, 1.45, 0.19444444444444
16167, 1.6565217391304, 1.45, 0.16666666666667
16168, 1.6782608695652, 1.45, 0.13888888888889
16169, 1.6565217391304, 1.45, 0.11111111111111
16170, 1.6782608695652, 1.45, 0.083333333333333
16171, 1.6565217391304, 1.45, 0.055555555555556
16172, 1.6782608695652, 1.45, 0.027777777777778
16173, 1.7217391304348, 1.45, 0.47222222222222
16174, 1.7, 1.45, 0.44444444444444
16175, 1.7217391304348, 1.45, 0.41666666666667
16176, 1.7, 1.45, 0.38888888888889
16177, 1.7217391304348, 1.45, 0.36111111111111
16178, 1.7, 1.45, 0.33333333333333
16179, 1.7217391304348, 1.45, 0.30555555555556
16180, 1.7, 1.45, 0.27777777777778
16181, 1.7217391304348, 1.45, 0.25
16182, 1.7, 1.45, 0.22222222222222
16183, 1.7217391304348, 1.45, 0.19444444444444
16184, 1.7, 1.45, 0.16666666666667
16185, 1.7217391304348, 1.45, 0.13888888888889
16186, 1.7, 1.45, 0.11111111111111
16187, 1.7217391304348, 1.45, 0.083333333333333
16188, 1.7, 1.45, 0.055555555555556
16189, 1.7217391304348, 1.45, 0.027777777777778
16190, 1.7652173913043, 1.45, 0.47222222222222
16191, 1.7434782608696, 1.45, 0.44444444444444
16192, 1.7652173913043, 1.45, 0.41666666666667
16193, 1.7434782608696, 1.45, 0.38888888888889
16194, 1.7652173913043, 1.45, 0.36111111111111
16195, 1.7434782608696, 1.45, 0.33333333333333
16196, 1.7652173913043, 1.45, 0.30555555555556
16197, 1.7434782608696, 1.45, 0.27777777777778
16198, 1.7652173913043, 1.45, 0.25
16199, 1.7434782608696, 1.45, 0.22222222222222
16200, 1.7652173913043, 1.45, 0.19444444444444
16201, 1.7434782608696, 1.45, 0.16666666666667
16202, 1.7652173913043, 1.45, 0.13888888888889
16203, 1.7434782608696, 1.45, 0.11111111111111
16204, 1.7652173913043, 1.45, 0.083333333333333
16205, 1.7434782608696, 1.45, 0.055555555555556
16206, 1.7652173913043, 1.45, 0.027777777777778
16207, 1.8086956521739, 1.45, 0.47222222222222
16208, 1.7869565217391, 1.45, 0.44444444444444
16209, 1.8086956521739, 1.45, 0.41666666666667
16210, 1.7869565217391, 1.45, 0.38888888888889
16211, 1.8086956521739, 1.45, 0.36111111111111
16212, 1.7869565217391, 1.45, 0.33333333333333
16213, 1.8086956521739, 1.45, 0.30555555555556
16214, 1.7869565217391, 1.45, 0.27777777777778
16215, 1.8086956521739, 1.45, 0.25
16216, 1.7869565217391, 1.45, 0.22222222222222
16217, 1.8086956521739, 1.45, 0.19444444444444
16218, 1.7869565217391, 1.45, 0.16666666666667
16219, 1.8086956521739, 1.45, 0.13888888888889
16220, 1.7869565217391, 1.45, 0.11111111111111
16221, 1.8086956521739, 1.45, 0.083333333333333
16222, 1.7869565217391, 1.45, 0.055555555555556
16223, 1.8086956521739, 1.45, 0.027777777777778
16224, 1.8521739130435, 1.45, 0.47222222222222
16225, 1.8304347826087, 1.45, 0.44444444444444
16226, 1.8521739130435, 1.45, 0.41666666666667
16227, 1.8304347826087, 1.45, 0.38888888888889
16228, 1.8521739130435, 1.45, 0.36111111111111
16229, 1.8304347826087, 1.45, 0.33333333333333
16230, 1.8521739130435, 1.45, 0.30555555555556
16231, 1.8304347826087, 1.45, 0.27777777777778
16232, 1.8521739130435, 1.45, 0.25
16233, 1.8304347826087, 1.45, 0.22222222222222
16234, 1.8521739130435, 1.45, 0.19444444444444
16235, 1.8304347826087, 1.45, 0.16666666666667
16236, 1.8521739130435, 1.45, 0.13888888888889
16237, 1.8304347826087, 1.45, 0.11111111111111
16238, 1.8521739130435, 1.45, 0.083333333333333
16239, 1.8304347826087, 1.45, 0.055555555555556
16240, 1.8521739130435, 1.45, 0.027777777777778
16241, 1.895652173913, 1.45, 0.47222222222222
16242, 1.8739130434783, 1.45, 0.44444444444444
16243, 1.895652173913, 1.45, 0.41666666666667
16244, 1.8739130434783, 1.45, 0.38888888888889
16245, 1.895652173913, 1.45, 0.36111111111111
16246, 1.8739130434783, 1.45, 0.33333333333333
16247, 1.895652173913, 1.45, 0.30555555555556
16248, 1.8739130434783, 1.45, 0.27777777777778
16249, 1.895652173913, 1.45, 0.25
16250, 1.8739130434783, 1.45, 0.22222222222222
16251, 1.895652173913, 1.45, 0.19444444444444
16252, 1.8739130434783, 1.45, 0.16666666666667
16253, 1.895652173913, 1.45, 0.13888888888889
16254, 1.8739130434783, 1.45, 0.11111111111111
16255, 1.895652173913, 1.45, 0.083333333333333
16256, 1.8739130434783, 1.45, 0.055555555555556
16257, 1.895652173913, 1.45, 0.027777777777778
16258, 1.9391304347826, 1.45, 0.47222222222222
16259, 1.9173913043478, 1.45, 0.44444444444444
16260, 1.9391304347826, 1.45, 0.41666666666667
16261, 1.9173913043478, 1.45, 0.38888888888889
16262, 1.9391304347826, 1.45, 0.36111111111111
16263, 1.9173913043478, 1.45, 0.33333333333333
16264, 1.9391304347826, 1.45, 0.30555555555556
16265, 1.9173913043478, 1.45, 0.27777777777778
16266, 1.9391304347826, 1.45, 0.25
16267, 1.9173913043478, 1.45, 0.22222222222222
16268, 1.9391304347826, 1.45, 0.19444444444444
16269, 1.9173913043478, 1.45, 0.16666666666667
16270, 1.9391304347826, 1.45, 0.13888888888889
16271, 1.9173913043478, 1.45, 0.11111111111111
16272, 1.9391304347826, 1.45, 0.083333333333333
16273, 1.9173913043478, 1.45, 0.055555555555556
16274, 1.9391304347826, 1.45, 0.027777777777778
16275, 1.9826086956522, 1.45, 0.47222222222222
16276, 1.9608695652174, 1.45, 0.44444444444444
16277, 1.9826086956522, 1.45, 0.41666666666667
16278, 1.9608695652174, 1.45, 0.38888888888889
16279, 1.9826086956522, 1.45, 0.36111111111111
16280, 1.9608695652174, 1.45, 0.33333333333333
16281, 1.9826086956522, 1.45, 0.30555555555556
16282, 1.9608695652174, 1.45, 0.27777777777778
16283, 1.9826086956522, 1.45, 0.25
16284, 1.9608695652174, 1.45, 0.22222222222222
16285, 1.9826086956522, 1.45, 0.19444444444444
16286, 1.9608695652174, 1.45, 0.16666666666667
16287, 1.9826086956522, 1.45, 0.13888888888889
16288, 1.9608695652174, 1.45, 0.11111111111111
16289, 1.9826086956522, 1.45, 0.083333333333333
16290, 1.9608695652174, 1.45, 0.055555555555556
16291, 1.9826086956522, 1.45, 0.027777777777778
16292, 2.0260869565217, 1.45, 0.47222222222222
16293, 2.004347826087, 1.45, 0.44444444444444
16294, 2.0260869565217, 1.45, 0.41666666666667
16295, 2.004347826087, 1.45, 0.38888888888889
16296, 2.0260869565217, 1.45, 0.36111111111111
16297, 2.004347826087, 1.45, 0.33333333333333
16298, 2.0260869565217, 1.45, 0.30555555555556
16299, 2.004347826087, 1.45, 0.27777777777778
16300, 2.0260869565217, 1.45, 0.25
16301, 2.004347826087, 1.45, 0.22222222222222
16302, 2.0260869565217, 1.45, 0.19444444444444
16303, 2.004347826087, 1.45, 0.16666666666667
16304, 2.0260869565217, 1.45, 0.13888888888889
16305, 2.004347826087, 1.45, 0.11111111111111
16306, 2.0260869565217, 1.45, 0.083333333333333
16307, 2.004347826087, 1.45, 0.055555555555556
16308, 2.0260869565217, 1.45, 0.027777777777778
16309, 2.0695652173913, 1.45, 0.47222222222222
16310, 2.0478260869565, 1.45, 0.44444444444444
16311, 2.0695652173913, 1.45, 0.41666666666667
16312, 2.0478260869565, 1.45, 0.38888888888889
16313, 2.0695652173913, 1.45, 0.36111111111111
16314, 2.0478260869565, 1.45, 0.33333333333333
16315, 2.0695652173913, 1.45, 0.30555555555556
16316, 2.0478260869565, 1.45, 0.27777777777778
16317, 2.0695652173913, 1.45, 0.25
16318, 2.0478260869565, 1.45, 0.22222222222222
16319, 2.0695652173913, 1.45, 0.19444444444444
16320, 2.0478260869565, 1.45, 0.16666666666667
16321, 2.0695652173913, 1.45, 0.13888888888889
16322, 2.0478260869565, 1.45, 0.11111111111111
16323, 2.0695652173913, 1.45, 0.083333333333333
16324, 2.0478260869565, 1.45, 0.055555555555556
16325, 2.0695652173913, 1.45, 0.027777777777778
16326, 2.1130434782609, 1.45, 0.47222222222222
16327, 2.0913043478261, 1.45, 0.44444444444444
16328, 2.1130434782609, 1.45, 0.41666666666667
16329, 2.0913043478261, 1.45, 0.38888888888889
16330, 2.1130434782609, 1.45, 0.36111111111111
16331, 2.0913043478261, 1.45, 0.33333333333333
16332, 2.1130434782609, 1.45, 0.30555555555556
16333, 2.0913043478261, 1.45, 0.27777777777778
16334, 2.1130434782609, 1.45, 0.25
16335, 2.0913043478261, 1.45, 0.22222222222222
16336, 2.1130434782609, 1.45, 0.19444444444444
16337, 2.0913043478261, 1.45, 0.16666666666667
16338, 2.1130434782609, 1.45, 0.13888888888889
16339, 2.0913043478261, 1.45, 0.11111111111111
16340, 2.1130434782609, 1.45, 0.083333333333333
16341, 2.0913043478261, 1.45, 0.055555555555556
16342, 2.1130434782609, 1.45, 0.027777777777778
16343, 2.1565217391304, 1.45, 0.47222222222222
16344, 2.1347826086957, 1.45, 0.44444444444444
16345, 2.1565217391304, 1.45, 0.41666666666667
16346, 2.1347826086957, 1.45, 0.38888888888889
16347, 2.1565217391304, 1.45, 0.36111111111111
16348, 2.1347826086957, 1.45, 0.33333333333333
16349, 2.1565217391304, 1.45, 0.30555555555556
16350, 2.1347826086957, 1.45, 0.27777777777778
16351, 2.1565217391304, 1.45, 0.25
16352, 2.1347826086957, 1.45, 0.22222222222222
16353, 2.1565217391304, 1.45, 0.19444444444444
16354, 2.1347826086957, 1.45, 0.16666666666667
16355, 2.1565217391304, 1.45, 0.13888888888889
16356, 2.1347826086957, 1.45, 0.11111111111111
16357, 2.1565217391304, 1.45, 0.083333333333333
16358, 2.1347826086957, 1.45, 0.055555555555556
16359, 2.1565217391304, 1.45, 0.027777777777778
16360, 2.1782608695652, 1.45, 0.44444444444444
16361, 2.1782608695652, 1.45, 0.38888888888889
16362, 2.1782608695652, 1.45, 0.33333333333333
16363, 2.1782608695652, 1.45, 0.27777777777778
16364, 2.1782608695652, 1.45, 0.22222222222222
16365, 2.1782608695652, 1.45, 0.16666666666667
16366, 2.1782608695652, 1.45, 0.11111111111111
16367, 2.1782608695652, 1.45, 0.055555555555556
16368, 1.2434782608696, 1.4, 0.44444444444444
16369, 1.2434782608696, 1.4, 0.38888888888889
16370, 1.2434782608696, 1.4, 0.33333333333333
16371, 1.2434782608696, 1.4, 0.27777777777778
16372, 1.2434782608696, 1.4, 0.22222222222222
16373, 1.2434782608696, 1.4, 0.16666666666667
16374, 1.2434782608696, 1.4, 0.11111111111111
16375, 1.2434782608696, 1.4, 0.055555555555556
16376, 1.2869565217391, 1.4, 0.44444444444444
16377, 1.2869565217391, 1.4, 0.38888888888889
16378, 1.2869565217391, 1.4, 0.33333333333333
16379, 1.2869565217391, 1.4, 0.27777777777778
16380, 1.2869565217391, 1.4, 0.22222222222222
16381, 1.2869565217391, 1.4, 0.16666666666667
16382, 1.2869565217391, 1.4, 0.11111111111111
16383, 1.2869565217391, 1.4, 0.055555555555556
16384, 1.3304347826087, 1.4, 0.44444444444444
16385, 1.3304347826087, 1.4, 0.38888888888889
16386, 1.3304347826087, 1.4, 0.33333333333333
16387, 1.3304347826087, 1.4, 0.27777777777778
16388, 1.3304347826087, 1.4, 0.22222222222222
16389, 1.3304347826087, 1.4, 0.16666666666667
16390, 1.3304347826087, 1.4, 0.11111111111111
16391, 1.3304347826087, 1.4, 0.055555555555556
16392, 1.3739130434783, 1.4, 0.44444444444444
16393, 1.3739130434783, 1.4, 0.38888888888889
16394, 1.3739130434783, 1.4, 0.33333333333333
16395, 1.3739130434783, 1.4, 0.27777777777778
16396, 1.3739130434783, 1.4, 0.22222222222222
16397, 1.3739130434783, 1.4, 0.16666666666667
16398, 1.3739130434783, 1.4, 0.11111111111111
16399, 1.3739130434783, 1.4, 0.055555555555556
16400, 1.4173913043478, 1.4, 0.44444444444444
16401, 1.4173913043478, 1.4, 0.38888888888889
16402, 1.4173913043478, 1.4, 0.33333333333333
16403, 1.4173913043478, 1.4, 0.27777777777778
16404, 1.4173913043478, 1.4, 0.22222222222222
16405, 1.4173913043478, 1.4, 0.16666666666667
16406, 1.4173913043478, 1.4, 0.11111111111111
16407, 1.4173913043478, 1.4, 0.055555555555556
16408, 1.4608695652174, 1.4, 0.44444444444444
16409, 1.4608695652174, 1.4, 0.38888888888889
16410, 1.4608695652174, 1.4, 0.33333333333333
16411, 1.4608695652174, 1.4, 0.27777777777778
16412, 1.4608695652174, 1.4, 0.22222222222222
16413, 1.4608695652174, 1.4, 0.16666666666667
16414, 1.4608695652174, 1.4, 0.11111111111111
16415, 1.4608695652174, 1.4, 0.055555555555556
16416, 1.504347826087, 1.4, 0.44444444444444
16417, 1.504347826087, 1.4, 0.38888888888889
16418, 1.504347826087, 1.4, 0.33333333333333
16419, 1.504347826087, 1.4, 0.27777777777778
16420, 1.504347826087, 1.4, 0.22222222222222
16421, 1.504347826087, 1.4, 0.16666666666667
16422, 1.504347826087, 1.4, 0.11111111111111
16423, 1.504347826087, 1.4, 0.055555555555556
16424, 1.5478260869565, 1.4, 0.44444444444444
16425, 1.5478260869565, 1.4, 0.38888888888889
16426, 1.5478260869565, 1.4, 0.33333333333333
16427, 1.5478260869565, 1.4, 0.27777777777778
16428, 1.5478260869565, 1.4, 0.22222222222222
16429, 1.5478260869565, 1.4, 0.16666666666667
16430, 1.5478260869565, 1.4, 0.11111111111111
16431, 1.5478260869565, 1.4, 0.055555555555556
16432, 1.5913043478261, 1.4, 0.44444444444444
16433, 1.5913043478261, 1.4, 0.38888888888889
16434, 1.5913043478261, 1.4, 0.33333333333333
16435, 1.5913043478261, 1.4, 0.27777777777778
16436, 1.5913043478261, 1.4, 0.22222222222222
16437, 1.5913043478261, 1.4, 0.16666666666667
16438, 1.5913043478261, 1.4, 0.11111111111111
16439, 1.5913043478261, 1.4, 0.055555555555556
16440, 1.6347826086957, 1.4, 0.44444444444444
16441, 1.6347826086957, 1.4, 0.38888888888889
16442, 1.6347826086957, 1.4, 0.33333333333333
16443, 1.6347826086957, 1.4, 0.27777777777778
16444, 1.6347826086957, 1.4, 0.22222222222222
16445, 1.6347826086957, 1.4, 0.16666666666667
16446, 1.6347826086957, 1.4, 0.11111111111111
16447, 1.6347826086957, 1.4, 0.055555555555556
16448, 1.6782608695652, 1.4, 0.44444444444444
16449, 1.6782608695652, 1.4, 0.38888888888889
16450, 1.6782608695652, 1.4, 0.33333333333333
16451, 1.6782608695652, 1.4, 0.27777777777778
16452, 1.6782608695652, 1.4, 0.22222222222222
16453, 1.6782608695652, 1.4, 0.16666666666667
16454, 1.6782608695652, 1.4, 0.11111111111111
16455, 1.6782608695652, 1.4, 0.055555555555556
16456, 1.7217391304348, 1.4, 0.44444444444444
16457, 1.7217391304348, 1.4, 0.38888888888889
16458, 1.7217391304348, 1.4, 0.33333333333333
16459, 1.7217391304348, 1.4, 0.27777777777778
16460, 1.7217391304348, 1.4, 0.22222222222222
16461, 1.7217391304348, 1.4, 0.16666666666667
16462, 1.7217391304348, 1.4, 0.11111111111111
16463, 1.7217391304348, 1.4, 0.055555555555556
16464, 1.7652173913043, 1.4, 0.44444444444444
16465, 1.7652173913043, 1.4, 0.38888888888889
16466, 1.7652173913043, 1.4, 0.33333333333333
16467, 1.7652173913043, 1.4, 0.27777777777778
16468, 1.7652173913043, 1.4, 0.22222222222222
16469, 1.7652173913043, 1.4, 0.16666666666667
16470, 1.7652173913043, 1.4, 0.11111111111111
16471, 1.7652173913043, 1.4, 0.055555555555556
16472, 1.8086956521739, 1.4, 0.44444444444444
16473, 1.8086956521739, 1.4, 0.38888888888889
16474, 1.8086956521739, 1.4, 0.33333333333333
16475, 1.8086956521739, 1.4, 0.27777777777778
16476, 1.8086956521739, 1.4, 0.22222222222222
16477, 1.8086956521739, 1.4, 0.16666666666667
16478, 1.8086956521739, 1.4, 0.11111111111111
16479, 1.8086956521739, 1.4, 0.055555555555556
16480, 1.8521739130435, 1.4, 0.44444444444444
16481, 1.8521739130435, 1.4, 0.38888888888889
16482, 1.8521739130435, 1.4, 0.33333333333333
16483, 1.8521739130435, 1.4, 0.27777777777778
16484, 1.8521739130435, 1.4, 0.22222222222222
16485, 1.8521739130435, 1.4, 0.16666666666667
16486, 1.8521739130435, 1.4, 0.11111111111111
16487, 1.8521739130435, 1.4, 0.055555555555556
16488, 1.895652173913, 1.4, 0.44444444444444
16489, 1.895652173913, 1.4, 0.38888888888889
16490, 1.895652173913, 1.4, 0.33333333333333
16491, 1.895652173913, 1.4, 0.27777777777778
16492, 1.895652173913, 1.4, 0.22222222222222
16493, 1.895652173913, 1.4, 0.16666666666667
16494, 1.895652173913, 1.4, 0.11111111111111
16495, 1.895652173913, 1.4, 0.055555555555556
16496, 1.9391304347826, 1.4, 0.44444444444444
16497, 1.9391304347826, 1.4, 0.38888888888889
16498, 1.9391304347826, 1.4, 0.33333333333333
16499, 1.9391304347826, 1.4, 0.27777777777778
16500, 1.9391304347826, 1.4, 0.22222222222222
16501, 1.9391304347826, 1.4, 0.16666666666667
16502, 1.9391304347826, 1.4, 0.11111111111111
16503, 1.9391304347826, 1.4, 0.055555555555556
16504, 1.9826086956522, 1.4, 0.44444444444444
16505, 1.9826086956522, 1.4, 0.38888888888889
16506, 1.9826086956522, 1.4, 0.33333333333333
16507, 1.9826086956522, 1.4, 0.27777777777778
16508, 1.9826086956522, 1.4, 0.22222222222222
16509, 1.9826086956522, 1.4, 0.16666666666667
16510, 1.9826086956522, 1.4, 0.11111111111111
16511, 1.9826086956522, 1.4, 0.055555555555556
16512, 2.0260869565217, 1.4, 0.44444444444444
16513, 2.0260869565217, 1.4, 0.38888888888889
16514, 2.0260869565217, 1.4, 0.33333333333333
16515, 2.0260869565217, 1.4, 0.27777777777778
16516, 2.0260869565217, 1.4, 0.22222222222222
16517, 2.0260869565217, 1.4, 0.16666666666667
16518, 2.0260869565217, 1.4, 0.11111111111111
16519, 2.0260869565217, 1.4, 0.055555555555556
16520, 2.0695652173913, 1.4, 0.44444444444444
16521, 2.0695652173913, 1.4, 0.38888888888889
16522, 2.0695652173913, 1.4, 0.33333333333333
16523, 2.0695652173913, 1.4, 0.27777777777778
16524, 2.0695652173913, 1.4, 0.22222222222222
16525, 2.0695652173913, 1.4, 0.16666666666667
16526, 2.0695652173913, 1.4, 0.11111111111111
16527, 2.0695652173913, 1.4, 0.055555555555556
16528, 2.1130434782609, 1.4, 0.44444444444444
16529, 2.1130434782609, 1.4, 0.38888888888889
16530, 2.1130434782609, 1.4, 0.33333333333333
16531, 2.1130434782609, 1.4, 0.27777777777778
16532, 2.1130434782609, 1.4, 0.22222222222222
16533, 2.1130434782609, 1.4, 0.16666666666667
16534, 2.1130434782609, 1.4, 0.11111111111111
16535, 2.1130434782609, 1.4, 0.055555555555556
16536, 2.1565217391304, 1.4, 0.44444444444444
16537, 2.1565217391304, 1.4, 0.38888888888889
16538, 2.1565217391304, 1.4, 0.33333333333333
16539, 2.1565217391304, 1.4, 0.27777777777778
16540, 2.1565217391304, 1.4, 0.22222222222222
16541, 2.1565217391304, 1.4, 0.16666666666667
16542, 2.1565217391304, 1.4, 0.11111111111111
16543, 2.1565217391304, 1.4, 0.055555555555556
16544, 1.2217391304348, 1.4, 0.44444444444444
16545, 1.2434782608696, 1.4, 0.47222222222222
16546, 1.2217391304348, 1.4, 0.38888888888889
16547, 1.2434782608696, 1.4, 0.41666666666667
16548, 1.2217391304348, 1.4, 0.33333333333333
16549, 1.2434782608696, 1.4, 0.36111111111111
16550, 1.2217391304348, 1.4, 0.27777777777778
16551, 1.2434782608696, 1.4, 0.30555555555556
16552, 1.2217391304348, 1.4, 0.22222222222222
16553, 1.2434782608696, 1.4, 0.25
16554, 1.2217391304348, 1.4, 0.16666666666667
16555, 1.2434782608696, 1.4, 0.19444444444444
16556, 1.2217391304348, 1.4, 0.11111111111111
16557, 1.2434782608696, 1.4, 0.13888888888889
16558, 1.2217391304348, 1.4, 0.055555555555556
16559, 1.2434782608696, 1.4, 0.083333333333333
16560, 1.2434782608696, 1.4, 0.027777777777778
16561, 1.2652173913043, 1.4, 0.44444444444444
16562, 1.2869565217391, 1.4, 0.47222222222222
16563, 1.2652173913043, 1.4, 0.38888888888889
16564, 1.2869565217391, 1.4, 0.41666666666667
16565, 1.2652173913043, 1.4, 0.33333333333333
16566, 1.2869565217391, 1.4, 0.36111111111111
16567, 1.2652173913043, 1.4, 0.27777777777778
16568, 1.2869565217391, 1.4, 0.30555555555556
16569, 1.2652173913043, 1.4, 0.22222222222222
16570, 1.2869565217391, 1.4, 0.25
16571, 1.2652173913043, 1.4, 0.16666666666667
16572, 1.2869565217391, 1.4, 0.19444444444444
16573, 1.2652173913043, 1.4, 0.11111111111111
16574, 1.2869565217391, 1.4, 0.13888888888889
16575, 1.2652173913043, 1.4, 0.055555555555556
16576, 1.2869565217391, 1.4, 0.083333333333333
16577, 1.2869565217391, 1.4, 0.027777777777778
16578, 1.3086956521739, 1.4, 0.44444444444444
16579, 1.3304347826087, 1.4, 0.47222222222222
16580, 1.3086956521739, 1.4, 0.38888888888889
16581, 1.3304347826087, 1.4, 0.41666666666667
16582, 1.3086956521739, 1.4, 0.33333333333333
16583, 1.3304347826087, 1.4, 0.36111111111111
16584, 1.3086956521739, 1.4, 0.27777777777778
16585, 1.3304347826087, 1.4, 0.30555555555556
16586, 1.3086956521739, 1.4, 0.22222222222222
16587, 1.3304347826087, 1.4, 0.25
16588, 1.3086956521739, 1.4, 0.16666666666667
16589, 1.3304347826087, 1.4, 0.19444444444444
16590, 1.3086956521739, 1.4, 0.11111111111111
16591, 1.3304347826087, 1.4, 0.13888888888889
16592, 1.3086956521739, 1.4, 0.055555555555556
16593, 1.3304347826087, 1.4, 0.083333333333333
16594, 1.3304347826087, 1.4, 0.027777777777778
16595, 1.3521739130435, 1.4, 0.44444444444444
16596, 1.3739130434783, 1.4, 0.47222222222222
16597, 1.3521739130435, 1.4, 0.38888888888889
16598, 1.3739130434783, 1.4, 0.41666666666667
16599, 1.3521739130435, 1.4, 0.33333333333333
16600, 1.3739130434783, 1.4, 0.36111111111111
16601, 1.3521739130435, 1.4, 0.27777777777778
16602, 1.3739130434783, 1.4, 0.30555555555556
16603, 1.3521739130435, 1.4, 0.22222222222222
16604, 1.3739130434783, 1.4, 0.25
16605, 1.3521739130435, 1.4, 0.16666666666667
16606, 1.3739130434783, 1.4, 0.19444444444444
16607, 1.3521739130435, 1.4, 0.11111111111111
16608, 1.3739130434783, 1.4, 0.13888888888889
16609, 1.3521739130435, 1.4, 0.055555555555556
16610, 1.3739130434783, 1.4, 0.083333333333333
16611, 1.3739130434783, 1.4, 0.027777777777778
16612, 1.395652173913, 1.4, 0.44444444444444
16613, 1.4173913043478, 1.4, 0.47222222222222
16614, 1.395652173913, 1.4, 0.38888888888889
16615, 1.4173913043478, 1.4, 0.41666666666667
16616, 1.395652173913, 1.4, 0.33333333333333
16617, 1.4173913043478, 1.4, 0.36111111111111
16618, 1.395652173913, 1.4, 0.27777777777778
16619, 1.4173913043478, 1.4, 0.30555555555556
16620, 1.395652173913, 1.4, 0.22222222222222
16621, 1.4173913043478, 1.4, 0.25
16622, 1.395652173913, 1.4, 0.16666666666667
16623, 1.4173913043478, 1.4, 0.19444444444444
16624, 1.395652173913, 1.4, 0.11111111111111
16625, 1.4173913043478, 1.4, 0.13888888888889
16626, 1.395652173913, 1.4, 0.055555555555556
16627, 1.4173913043478, 1.4, 0.083333333333333
16628, 1.4173913043478, 1.4, 0.027777777777778
16629, 1.4391304347826, 1.4, 0.44444444444444
16630, 1.4608695652174, 1.4, 0.47222222222222
16631, 1.4391304347826, 1.4, 0.38888888888889
16632, 1.4608695652174, 1.4, 0.41666666666667
16633, 1.4391304347826, 1.4, 0.33333333333333
16634, 1.4608695652174, 1.4, 0.36111111111111
16635, 1.4391304347826, 1.4, 0.27777777777778
16636, 1.4608695652174, 1.4, 0.30555555555556
16637, 1.4391304347826, 1.4, 0.22222222222222
16638, 1.4608695652174, 1.4, 0.25
16639, 1.4391304347826, 1.4, 0.16666666666667
16640, 1.4608695652174, 1.4, 0.19444444444444
16641, 1.4391304347826, 1.4, 0.11111111111111
16642, 1.4608695652174, 1.4, 0.13888888888889
16643, 1.4391304347826, 1.4, 0.055555555555556
16644, 1.4608695652174, 1.4, 0.083333333333333
16645, 1.4608695652174, 1.4, 0.027777777777778
16646, 1.4826086956522, 1.4, 0.44444444444444
16647, 1.504347826087, 1.4, 0.47222222222222
16648, 1.4826086956522, 1.4, 0.38888888888889
16649, 1.504347826087, 1.4, 0.41666666666667
16650, 1.4826086956522, 1.4, 0.33333333333333
16651, 1.504347826087, 1.4, 0.36111111111111
16652, 1.4826086956522, 1.4, 0.27777777777778
16653, 1.504347826087, 1.4, 0.30555555555556
16654, 1.4826086956522, 1.4, 0.22222222222222
16655, 1.504347826087, 1.4, 0.25
16656, 1.4826086956522, 1.4, 0.16666666666667
16657, 1.504347826087, 1.4, 0.19444444444444
16658, 1.4826086956522, 1.4, 0.11111111111111
16659, 1.504347826087, 1.4, 0.13888888888889
16660, 1.4826086956522, 1.4, 0.055555555555556
16661, 1.504347826087, 1.4, 0.083333333333333
16662, 1.504347826087, 1.4, 0.027777777777778
16663, 1.5260869565217, 1.4, 0.44444444444444
16664, 1.5478260869565, 1.4, 0.47222222222222
16665, 1.5260869565217, 1.4, 0.38888888888889
16666, 1.5478260869565, 1.4, 0.41666666666667
16667, 1.5260869565217, 1.4, 0.33333333333333
16668, 1.5478260869565, 1.4, 0.36111111111111
16669, 1.5260869565217, 1.4, 0.27777777777778
16670, 1.5478260869565, 1.4, 0.30555555555556
16671, 1.5260869565217, 1.4, 0.22222222222222
16672, 1.5478260869565, 1.4, 0.25
16673, 1.5260869565217, 1.4, 0.16666666666667
16674, 1.5478260869565, 1.4, 0.19444444444444
16675, 1.5260869565217, 1.4, 0.11111111111111
16676, 1.5478260869565, 1.4, 0.13888888888889
16677, 1.5260869565217, 1.4, 0.055555555555556
16678, 1.5478260869565, 1.4, 0.083333333333333
16679, 1.5478260869565, 1.4, 0.027777777777778
16680, 1.5695652173913, 1.4, 0.44444444444444
16681, 1.5913043478261, 1.4, 0.47222222222222
16682, 1.5695652173913, 1.4, 0.38888888888889
16683, 1.5913043478261, 1.4, 0.41666666666667
16684, 1.5695652173913, 1.4, 0.33333333333333
16685, 1.5913043478261, 1.4, 0.36111111111111
16686, 1.5695652173913, 1.4, 0.27777777777778
16687, 1.5913043478261, 1.4, 0.30555555555556
16688, 1.5695652173913, 1.4, 0.22222222222222
16689, 1.5913043478261, 1.4, 0.25
16690, 1.5695652173913, 1.4, 0.16666666666667
16691, 1.5913043478261, 1.4, 0.19444444444444
16692, 1.5695652173913, 1.4, 0.11111111111111
16693, 1.5913043478261, 1.4, 0.13888888888889
16694, 1.5695652173913, 1.4, 0.055555555555556
16695, 1.5913043478261, 1.4, 0.083333333333333
16696, 1.5913043478261, 1.4, 0.027777777777778
16697, 1.6130434782609, 1.4, 0.44444444444444
16698, 1.6347826086957, 1.4, 0.47222222222222
16699, 1.6130434782609, 1.4, 0.38888888888889
16700, 1.6347826086957, 1.4, 0.41666666666667
16701, 1.6130434782609, 1.4, 0.33333333333333
16702, 1.6347826086957, 1.4, 0.36111111111111
16703, 1.6130434782609, 1.4, 0.27777777777778
16704, 1.6347826086957, 1.4, 0.30555555555556
16705, 1.6130434782609, 1.4, 0.22222222222222
16706, 1.6347826086957, 1.4, 0.25
16707, 1.6130434782609, 1.4, 0.16666666666667
16708, 1.6347826086957, 1.4, 0.19444444444444
16709, 1.6130434782609, 1.4, 0.11111111111111
16710, 1.6347826086957, 1.4, 0.13888888888889
16711, 1.6130434782609, 1.4, 0.055555555555556
16712, 1.6347826086957, 1.4, 0.083333333333333
16713, 1.6347826086957, 1.4, 0.027777777777778
16714, 1.6565217391304, 1.4, 0.44444444444444
16715, 1.6782608695652, 1.4, 0.47222222222222
16716, 1.6565217391304, 1.4, 0.38888888888889
16717, 1.6782608695652, 1.4, 0.41666666666667
16718, 1.6565217391304, 1.4, 0.33333333333333
16719, 1.6782608695652, 1.4, 0.36111111111111
16720, 1.6565217391304, 1.4, 0.27777777777778
16721, 1.6782608695652, 1.4, 0.30555555555556
16722, 1.6565217391304, 1.4, 0.22222222222222
16723, 1.6782608695652, 1.4, 0.25
16724, 1.6565217391304, 1.4, 0.16666666666667
16725, 1.6782608695652, 1.4, 0.19444444444444
16726, 1.6565217391304, 1.4, 0.11111111111111
16727, 1.6782608695652, 1.4, 0.13888888888889
16728, 1.6565217391304, 1.4, 0.055555555555556
16729, 1.6782608695652, 1.4, 0.083333333333333
16730, 1.6782608695652, 1.4, 0.027777777777778
16731, 1.7, 1.4, 0.44444444444444
16732, 1.7217391304348, 1.4, 0.47222222222222
16733, 1.7, 1.4, 0.38888888888889
16734, 1.7217391304348, 1.4, 0.41666666666667
16735, 1.7, 1.4, 0.33333333333333
16736, 1.7217391304348, 1.4, 0.36111111111111
16737, 1.7, 1.4, 0.27777777777778
16738, 1.7217391304348, 1.4, 0.30555555555556
16739, 1.7, 1.4, 0.22222222222222
16740, 1.7217391304348, 1.4, 0.25
16741, 1.7, 1.4, 0.16666666666667
16742, 1.7217391304348, 1.4, 0.19444444444444
16743, 1.7, 1.4, 0.11111111111111
16744, 1.7217391304348, 1.4, 0.13888888888889
16745, 1.7, 1.4, 0.055555555555556
16746, 1.7217391304348, 1.4, 0.083333333333333
16747, 1.7217391304348, 1.4, 0.027777777777778
16748, 1.7434782608696, 1.4, 0.44444444444444
16749, 1.7652173913043, 1.4, 0.47222222222222
16750, 1.7434782608696, 1.4, 0.38888888888889
16751, 1.7652173913043, 1.4, 0.41666666666667
16752, 1.7434782608696, 1.4, 0.33333333333333
16753, 1.7652173913043, 1.4, 0.36111111111111
16754, 1.7434782608696, 1.4, 0.27777777777778
16755, 1.7652173913043, 1.4, 0.30555555555556
16756, 1.7434782608696, 1.4, 0.22222222222222
16757, 1.7652173913043, 1.4, 0.25
16758, 1.7434782608696, 1.4, 0.16666666666667
16759, 1.7652173913043, 1.4, 0.19444444444444
16760, 1.7434782608696, 1.4, 0.11111111111111
16761, 1.7652173913043, 1.4, 0.13888888888889
16762, 1.7434782608696, 1.4, 0.055555555555556
16763, 1.7652173913043, 1.4, 0.083333333333333
16764, 1.7652173913043, 1.4, 0.027777777777778
16765, 1.7869565217391, 1.4, 0.44444444444444
16766, 1.8086956521739, 1.4, 0.47222222222222
16767, 1.7869565217391, 1.4, 0.38888888888889
16768, 1.8086956521739, 1.4, 0.41666666666667
16769, 1.7869565217391, 1.4, 0.33333333333333
16770, 1.8086956521739, 1.4, 0.36111111111111
16771, 1.7869565217391, 1.4, 0.27777777777778
16772, 1.8086956521739, 1.4, 0.30555555555556
16773, 1.7869565217391, 1.4, 0.22222222222222
16774, 1.8086956521739, 1.4, 0.25
16775, 1.7869565217391, 1.4, 0.16666666666667
16776, 1.8086956521739, 1.4, 0.19444444444444
16777, 1.7869565217391, 1.4, 0.11111111111111
16778, 1.8086956521739, 1.4, 0.13888888888889
16779, 1.7869565217391, 1.4, 0.055555555555556
16780, 1.8086956521739, 1.4, 0.083333333333333
16781, 1.8086956521739, 1.4, 0.027777777777778
16782, 1.8304347826087, 1.4, 0.44444444444444
16783, 1.8521739130435, 1.4, 0.47222222222222
16784, 1.8304347826087, 1.4, 0.38888888888889
16785, 1.8521739130435, 1.4, 0.41666666666667
16786, 1.8304347826087, 1.4, 0.33333333333333
16787, 1.8521739130435, 1.4, 0.36111111111111
16788, 1.8304347826087, 1.4, 0.27777777777778
16789, 1.8521739130435, 1.4, 0.30555555555556
16790, 1.8304347826087, 1.4, 0.22222222222222
16791, 1.8521739130435, 1.4, 0.25
16792, 1.8304347826087, 1.4, 0.16666666666667
16793, 1.8521739130435, 1.4, 0.19444444444444
16794, 1.8304347826087, 1.4, 0.11111111111111
16795, 1.8521739130435, 1.4, 0.13888888888889
16796, 1.8304347826087, 1.4, 0.055555555555556
16797, 1.8521739130435, 1.4, 0.083333333333333
16798, 1.8521739130435, 1.4, 0.027777777777778
16799, 1.8739130434783, 1.4, 0.44444444444444
16800, 1.895652173913, 1.4, 0.47222222222222
16801, 1.8739130434783, 1.4, 0.38888888888889
16802, 1.895652173913, 1.4, 0.41666666666667
16803, 1.8739130434783, 1.4, 0.33333333333333
16804, 1.895652173913, 1.4, 0.36111111111111
16805, 1.8739130434783, 1.4, 0.27777777777778
16806, 1.895652173913, 1.4, 0.30555555555556
16807, 1.8739130434783, 1.4, 0.22222222222222
16808, 1.895652173913, 1.4, 0.25
16809, 1.8739130434783, 1.4, 0.16666666666667
16810, 1.895652173913, 1.4, 0.19444444444444
16811, 1.8739130434783, 1.4, 0.11111111111111
16812, 1.895652173913, 1.4, 0.13888888888889
16813, 1.8739130434783, 1.4, 0.055555555555556
16814, 1.895652173913, 1.4, 0.083333333333333
16815, 1.895652173913, 1.4, 0.027777777777778
16816, 1.9173913043478, 1.4, 0.44444444444444
16817, 1.9391304347826, 1.4, 0.47222222222222
16818, 1.9173913043478, 1.4, 0.38888888888889
16819, 1.9391304347826, 1.4, 0.41666666666667
16820, 1.9173913043478, 1.4, 0.33333333333333
16821, 1.9391304347826, 1.4, 0.36111111111111
16822, 1.9173913043478, 1.4, 0.27777777777778
16823, 1.9391304347826, 1.4, 0.30555555555556
16824, 1.9173913043478, 1.4, 0.22222222222222
16825, 1.9391304347826, 1.4, 0.25
16826, 1.9173913043478, 1.4, 0.16666666666667
16827, 1.9391304347826, 1.4, 0.19444444444444
16828, 1.9173913043478, 1.4, 0.11111111111111
16829, 1.9391304347826, 1.4, 0.13888888888889
16830, 1.9173913043478, 1.4, 0.055555555555556
16831, 1.9391304347826, 1.4, 0.083333333333333
16832, 1.9391304347826, 1.4, 0.027777777777778
16833, 1.9608695652174, 1.4, 0.44444444444444
16834, 1.9826086956522, 1.4, 0.47222222222222
16835, 1.9608695652174, 1.4, 0.38888888888889
16836, 1.9826086956522, 1.4, 0.41666666666667
16837, 1.9608695652174, 1.4, 0.33333333333333
16838, 1.9826086956522, 1.4, 0.36111111111111
16839, 1.9608695652174, 1.4, 0.27777777777778
16840, 1.9826086956522, 1.4, 0.30555555555556
16841, 1.9608695652174, 1.4, 0.22222222222222
16842, 1.9826086956522, 1.4, 0.25
16843, 1.9608695652174, 1.4, 0.16666666666667
16844, 1.9826086956522, 1.4, 0.19444444444444
16845, 1.9608695652174, 1.4, 0.11111111111111
16846, 1.9826086956522, 1.4, 0.13888888888889
16847, 1.9608695652174, 1.4, 0.055555555555556
16848, 1.9826086956522, 1.4, 0.083333333333333
16849, 1.9826086956522, 1.4, 0.027777777777778
16850, 2.004347826087, 1.4, 0.44444444444444
16851, 2.0260869565217, 1.4, 0.47222222222222
16852, 2.004347826087, 1.4, 0.38888888888889
16853, 2.0260869565217, 1.4, 0.41666666666667
16854, 2.004347826087, 1.4, 0.33333333333333
16855, 2.0260869565217, 1.4, 0.36111111111111
16856, 2.004347826087, 1.4, 0.27777777777778
16857, 2.0260869565217, 1.4, 0.30555555555556
16858, 2.004347826087, 1.4, 0.22222222222222
16859, 2.0260869565217, 1.4, 0.25
16860, 2.004347826087, 1.4, 0.16666666666667
16861, 2.0260869565217, 1.4, 0.19444444444444
16862, 2.004347826087, 1.4, 0.11111111111111
16863, 2.0260869565217, 1.4, 0.13888888888889
16864, 2.004347826087, 1.4, 0.055555555555556
16865, 2.0260869565217, 1.4, 0.083333333333333
16866, 2.0260869565217, 1.4, 0.027777777777778
16867, 2.0478260869565, 1.4, 0.44444444444444
16868, 2.0695652173913, 1.4, 0.47222222222222
16869, 2.0478260869565, 1.4, 0.38888888888889
16870, 2.0695652173913, 1.4, 0.41666666666667
16871, 2.0478260869565, 1.4, 0.33333333333333
16872, 2.0695652173913, 1.4, 0.36111111111111
16873, 2.0478260869565, 1.4, 0.27777777777778
16874, 2.0695652173913, 1.4, 0.30555555555556
16875, 2.0478260869565, 1.4, 0.22222222222222
16876, 2.0695652173913, 1.4, 0.25
16877, 2.0478260869565, 1.4, 0.16666666666667
16878, 2.0695652173913, 1.4, 0.19444444444444
16879, 2.0478260869565, 1.4, 0.11111111111111
16880, 2.0695652173913, 1.4, 0.13888888888889
16881, 2.0478260869565, 1.4, 0.055555555555556
16882, 2.0695652173913, 1.4, 0.083333333333333
16883, 2.0695652173913, 1.4, 0.027777777777778
16884, 2.0913043478261, 1.4, 0.44444444444444
16885, 2.1130434782609, 1.4, 0.47222222222222
16886, 2.0913043478261, 1.4, 0.38888888888889
16887, 2.1130434782609, 1.4, 0.41666666666667
16888, 2.0913043478261, 1.4, 0.33333333333333
16889, 2.1130434782609, 1.4, 0.36111111111111
16890, 2.0913043478261, 1.4, 0.27777777777778
16891, 2.1130434782609, 1.4, 0.30555555555556
16892, 2.0913043478261, 1.4, 0.22222222222222
16893, 2.1130434782609, 1.4, 0.25
16894, 2.0913043478261, 1.4, 0.16666666666667
16895, 2.1130434782609, 1.4, 0.19444444444444
16896, 2.0913043478261, 1.4, 0.11111111111111
16897, 2.1130434782609, 1.4, 0.13888888888889
16898, 2.0913043478261, 1.4, 0.055555555555556
16899, 2.1130434782609, 1.4, 0.083333333333333
16900, 2.1130434782609, 1.4, 0.027777777777778
16901, 2.1347826086957, 1.4, 0.44444444444444
16902, 2.1565217391304, 1.4, 0.47222222222222
16903, 2.1347826086957, 1.4, 0.38888888888889
16904, 2.1565217391304, 1.4, 0.41666666666667
16905, 2.1347826086957, 1.4, 0.33333333333333
16906, 2.1565217391304, 1.4, 0.36111111111111
16907, 2.1347826086957, 1.4, 0.27777777777778
16908, 2.1565217391304, 1.4, 0.30555555555556
16909, 2.1347826086957, 1.4, 0.22222222222222
16910, 2.1565217391304, 1.4, 0.25
16911, 2.1347826086957, 1.4, 0.16666666666667
16912, 2.1565217391304, 1.4, 0.19444444444444
16913, 2.1347826086957, 1.4, 0.11111111111111
16914, 2.1565217391304, 1.4, 0.13888888888889
16915, 2.1347826086957, 1.4, 0.055555555555556
16916, 2.1565217391304, 1.4, 0.083333333333333
16917, 2.1565217391304, 1.4, 0.027777777777778
16918, 2.1782608695652, 1.4, 0.44444444444444
16919, 2.1782608695652, 1.4, 0.38888888888889
16920, 2.1782608695652, 1.4, 0.33333333333333
16921, 2.1782608695652, 1.4, 0.27777777777778
16922, 2.1782608695652, 1.4, 0.22222222222222
16923, 2.1782608695652, 1.4, 0.16666666666667
16924, 2.1782608695652, 1.4, 0.11111111111111
16925, 2.1782608695652, 1.4, 0.055555555555556
16926, 1.2434782608696, 1.4833333333333, 0.5
16927, 1.2434782608696, 1.5166666666667, 0.5
16928, 1.2869565217391, 1.4833333333333, 0.5
16929, 1.2869565217391, 1.5166666666667, 0.5
16930, 1.3304347826087, 1.4833333333333, 0.5
16931, 1.3304347826087, 1.5166666666667, 0.5
16932, 1.3739130434783, 1.4833333333333, 0.5
16933, 1.3739130434783, 1.5166666666667, 0.5
16934, 1.4173913043478, 1.4833333333333, 0.5
16935, 1.4173913043478, 1.5166666666667, 0.5
16936, 1.4608695652174, 1.4833333333333, 0.5
16937, 1.4608695652174, 1.5166666666667, 0.5
16938, 1.504347826087, 1.4833333333333, 0.5
16939, 1.504347826087, 1.5166666666667, 0.5
16940, 1.5478260869565, 1.4833333333333, 0.5
16941, 1.5478260869565, 1.5166666666667, 0.5
16942, 1.5913043478261, 1.4833333333333, 0.5
16943, 1.5913043478261, 1.5166666666667, 0.5
16944, 1.6347826086957, 1.4833333333333, 0.5
16945, 1.6347826086957, 1.5166666666667, 0.5
16946, 1.6782608695652, 1.4833333333333, 0.5
16947, 1.6782608695652, 1.5166666666667, 0.5
16948, 1.7217391304348, 1.4833333333333, 0.5
16949, 1.7217391304348, 1.5166666666667, 0.5
16950, 1.7652173913043, 1.4833333333333, 0.5
16951, 1.7652173913043, 1.5166666666667, 0.5
16952, 1.8086956521739, 1.4833333333333, 0.5
16953, 1.8086956521739, 1.5166666666667, 0.5
16954, 1.8521739130435, 1.4833333333333, 0.5
16955, 1.8521739130435, 1.5166666666667, 0.5
16956, 1.895652173913, 1.4833333333333, 0.5
16957, 1.895652173913, 1.5166666666667, 0.5
16958, 1.9391304347826, 1.4833333333333, 0.5
16959, 1.9391304347826, 1.5166666666667, 0.5
16960, 1.9826086956522, 1.4833333333333, 0.5
16961, 1.9826086956522, 1.5166666666667, 0.5
16962, 2.0260869565217, 1.4833333333333, 0.5
16963, 2.0260869565217, 1.5166666666667, 0.5
16964, 2.0695652173913, 1.4833333333333, 0.5
16965, 2.0695652173913, 1.5166666666667, 0.5
16966, 2.1130434782609, 1.4833333333333, 0.5
16967, 2.1130434782609, 1.5166666666667, 0.5
16968, 2.1565217391304, 1.4833333333333, 0.5
16969, 2.1565217391304, 1.5166666666667, 0.5
16970, 1.2434782608696, 1.4666666666667, 0.5
16971, 1.2217391304348, 1.4833333333333, 0.5
16972, 1.2434782608696, 1.5, 0.5
16973, 1.2217391304348, 1.5166666666667, 0.5
16974, 1.2434782608696, 1.5333333333333, 0.5
16975, 1.2869565217391, 1.4666666666667, 0.5
16976, 1.2652173913043, 1.4833333333333, 0.5
16977, 1.2869565217391, 1.5, 0.5
16978, 1.2652173913043, 1.5166666666667, 0.5
16979, 1.2869565217391, 1.5333333333333, 0.5
16980, 1.3304347826087, 1.4666666666667, 0.5
16981, 1.3086956521739, 1.4833333333333, 0.5
16982, 1.3304347826087, 1.5, 0.5
16983, 1.3086956521739, 1.5166666666667, 0.5
16984, 1.3304347826087, 1.5333333333333, 0.5
16985, 1.3739130434783, 1.4666666666667, 0.5
16986, 1.3521739130435, 1.4833333333333, 0.5
16987, 1.3739130434783, 1.5, 0.5
16988, 1.3521739130435, 1.5166666666667, 0.5
16989, 1.3739130434783, 1.5333333333333, 0.5
16990, 1.4173913043478, 1.4666666666667, 0.5
16991, 1.395652173913, 1.4833333333333, 0.5
16992, 1.4173913043478, 1.5, 0.5
16993, 1.395652173913, 1.5166666666667, 0.5
16994, 1.4173913043478, 1.5333333333333, 0.5
16995, 1.4608695652174, 1.4666666666667, 0.5
16996, 1.4391304347826, 1.4833333333333, 0.5
16997, 1.4608695652174, 1.5, 0.5
16998, 1.4391304347826, 1.5166666666667, 0.5
16999, 1.4608695652174, 1.5333333333333, 0.5
17000, 1.504347826087, 1.4666666666667, 0.5
17001, 1.4826086956522, 1.4833333333333, 0.5
17002, 1.504347826087, 1.5, 0.5
17003, 1.4826086956522, 1.5166666666667, 0.5
17004, 1.504347826087, 1.5333333333333, 0.5
17005, 1.5478260869565, 1.4666666666667, 0.5
17006, 1.5260869565217, 1.4833333333333, 0.5
17007, 1.5478260869565, 1.5, 0.5
17008, 1.5260869565217, 1.5166666666667, 0.5
17009, 1.5478260869565, 1.5333333333333, 0.5
17010, 1.5913043478261, 1.4666666666667, 0.5
17011, 1.5695652173913, 1.4833333333333, 0.5
17012, 1.5913043478261, 1.5, 0.5
17013, 1.5695652173913, 1.5166666666667, 0.5
17014, 1.5913043478261, 1.5333333333333, 0.5
17015, 1.6347826086957, 1.4666666666667, 0.5
17016, 1.6130434782609, 1.4833333333333, 0.5
17017, 1.6347826086957, 1.5, 0.5
17018, 1.6130434782609, 1.5166666666667, 0.5
17019, 1.6347826086957, 1.5333333333333, 0.5
17020, 1.6782608695652, 1.4666666666667, 0.5
17021, 1.6565217391304, 1.4833333333333, 0.5
17022, 1.6782608695652, 1.5, 0.5
17023, 1.6565217391304, 1.5166666666667, 0.5
17024, 1.6782608695652, 1.5333333333333, 0.5
17025, 1.7217391304348, 1.4666666666667, 0.5
17026, 1.7, 1.4833333333333, 0.5
17027, 1.7217391304348, 1.5, 0.5
17028, 1.7, 1.5166666666667, 0.5
17029, 1.7217391304348, 1.5333333333333, 0.5
17030, 1.7652173913043, 1.4666666666667, 0.5
17031, 1.7434782608696, 1.4833333333333, 0.5
17032, 1.7652173913043, 1.5, 0.5
17033, 1.7434782608696, 1.5166666666667, 0.5
17034, 1.7652173913043, 1.5333333333333, 0.5
17035, 1.8086956521739, 1.4666666666667, 0.5
17036, 1.7869565217391, 1.4833333333333, 0.5
17037, 1.8086956521739, 1.5, 0.5
17038, 1.7869565217391, 1.5166666666667, 0.5
17039, 1.8086956521739, 1.5333333333333, 0.5
17040, 1.8521739130435, 1.4666666666667, 0.5
17041, 1.8304347826087, 1.4833333333333, 0.5
17042, 1.8521739130435, 1.5, 0.5
17043, 1.8304347826087, 1.5166666666667, 0.5
17044, 1.8521739130435, 1.5333333333333, 0.5
17045, 1.895652173913, 1.4666666666667, 0.5
17046, 1.8739130434783, 1.4833333333333, 0.5
17047, 1.895652173913, 1.5, 0.5
17048, 1.8739130434783, 1.5166666666667, 0.5
17049, 1.895652173913, 1.5333333333333, 0.5
17050, 1.9391304347826, 1.4666666666667, 0.5
17051, 1.9173913043478, 1.4833333333333, 0.5
17052, 1.9391304347826, 1.5, 0.5
17053, 1.9173913043478, 1.5166666666667, 0.5
17054, 1.9391304347826, 1.5333333333333, 0.5
17055, 1.9826086956522, 1.4666666666667, 0.5
17056, 1.9608695652174, 1.4833333333333, 0.5
17057, 1.9826086956522, 1.5, 0.5
17058, 1.9608695652174, 1.5166666666667, 0.5
17059, 1.9826086956522, 1.5333333333333, 0.5
17060, 2.0260869565217, 1.4666666666667, 0.5
17061, 2.004347826087, 1.4833333333333, 0.5
17062, 2.0260869565217, 1.5, 0.5
17063, 2.004347826087, 1.5166666666667, 0.5
17064, 2.0260869565217, 1.5333333333333, 0.5
17065, 2.0695652173913, 1.4666666666667, 0.5
17066, 2.0478260869565, 1.4833333333333, 0.5
17067, 2.0695652173913, 1.5, 0.5
17068, 2.0478260869565, 1.5166666666667, 0.5
17069, 2.0695652173913, 1.5333333333333, 0.5
17070, 2.1130434782609, 1.4666666666667, 0.5
17071, 2.0913043478261, 1.4833333333333, 0.5
17072, 2.1130434782609, 1.5, 0.5
17073, 2.0913043478261, 1.5166666666667, 0.5
17074, 2.1130434782609, 1.5333333333333, 0.5
17075, 2.1565217391304, 1.4666666666667, 0.5
17076, 2.1347826086957, 1.4833333333333, 0.5
17077, 2.1565217391304, 1.5, 0.5
17078, 2.1347826086957, 1.5166666666667, 0.5
17079, 2.1565217391304, 1.5333333333333, 0.5
17080, 2.1782608695652, 1.4833333333333, 0.5
17081, 2.1782608695652, 1.5166666666667, 0.5
17082, 1.2434782608696, 1.4833333333333, 0
17083, 1.2434782608696, 1.5166666666667, 0
17084, 1.2869565217391, 1.4833333333333, 0
17085, 1.2869565217391, 1.5166666666667, 0
17086, 1.3304347826087, 1.4833333333333, 0
17087, 1.3304347826087, 1.5166666666667, 0
17088, 1.3739130434783, 1.4833333333333, 0
17089, 1.3739130434783, 1.5166666666667, 0
17090, 1.4173913043478, 1.4833333333333, 0
17091, 1.4173913043478, 1.5166666666667, 0
17092, 1.4608695652174, 1.4833333333333, 0
17093, 1.4608695652174, 1.5166666666667, 0
17094, 1.504347826087, 1.4833333333333, 0
17095, 1.504347826087, 1.5166666666667, 0
17096, 1.5478260869565, 1.4833333333333, 0
17097, 1.5478260869565, 1.5166666666667, 0
17098, 1.5913043478261, 1.4833333333333, 0
17099, 1.5913043478261, 1.5166666666667, 0
17100, 1.6347826086957, 1.4833333333333, 0
17101, 1.6347826086957, 1.5166666666667, 0
17102, 1.6782608695652, 1.4833333333333, 0
17103, 1.6782608695652, 1.5166666666667, 0
17104, 1.7217391304348, 1.4833333333333, 0
17105, 1.7217391304348, 1.5166666666667, 0
17106, 1.7652173913043, 1.4833333333333, 0
17107, 1.7652173913043, 1.5166666666667, 0
17108, 1.8086956521739, 1.4833333333333, 0
17109, 1.8086956521739, 1.5166666666667, 0
17110, 1.8521739130435, 1.4833333333333, 0
17111, 1.8521739130435, 1.5166666666667, 0
17112, 1.895652173913, 1.4833333333333, 0
17113, 1.895652173913, 1.5166666666667, 0
17114, 1.9391304347826, 1.4833333333333, 0
17115, 1.9391304347826, 1.5166666666667, 0
17116, 1.9826086956522, 1.4833333333333, 0
17117, 1.9826086956522, 1.5166666666667, 0
17118, 2.0260869565217, 1.4833333333333, 0
17119, 2.0260869565217, 1.5166666666667, 0
17120, 2.0695652173913, 1.4833333333333, 0
17121, 2.0695652173913, 1.5166666666667, 0
17122, 2.1130434782609, 1.4833333333333, 0
17123, 2.1130434782609, 1.5166666666667, 0
17124, 2.1565217391304, 1.4833333333333, 0
17125, 2.1565217391304, 1.5166666666667, 0
17126, 1.2217391304348, 1.4833333333333, 0
17127, 1.2434782608696, 1.4666666666667, 0
17128, 1.2217391304348, 1.5166666666667, 0
17129, 1.2434782608696, 1.5, 0
17130, 1.2434782608696, 1.5333333333333, 0
17131, 1.2652173913043, 1.4833333333333, 0
17132, 1.2869565217391, 1.4666666666667, 0
17133, 1.2652173913043, 1.5166666666667, 0
17134, 1.2869565217391, 1.5, 0
17135, 1.2869565217391, 1.5333333333333, 0
17136, 1.3086956521739, 1.4833333333333, 0
17137, 1.3304347826087, 1.4666666666667, 0
17138, 1.3086956521739, 1.5166666666667, 0
17139, 1.3304347826087, 1.5, 0
17140, 1.3304347826087, 1.5333333333333, 0
17141, 1.3521739130435, 1.4833333333333, 0
17142, 1.3739130434783, 1.4666666666667, 0
17143, 1.3521739130435, 1.5166666666667, 0
17144, 1.3739130434783, 1.5, 0
17145, 1.3739130434783, 1.5333333333333, 0
17146, 1.395652173913, 1.4833333333333, 0
17147, 1.4173913043478, 1.4666666666667, 0
17148, 1.395652173913, 1.5166666666667, 0
17149, 1.4173913043478, 1.5, 0
17150, 1.4173913043478, 1.5333333333333, 0
17151, 1.4391304347826, 1.4833333333333, 0
17152, 1.4608695652174, 1.4666666666667, 0
17153, 1.4391304347826, 1.5166666666667, 0
17154, 1.4608695652174, 1.5, 0
17155, 1.4608695652174, 1.5333333333333, 0
17156, 1.4826086956522, 1.4833333333333, 0
17157, 1.504347826087, 1.4666666666667, 0
17158, 1.4826086956522, 1.5166666666667, 0
17159, 1.504347826087, 1.5, 0
17160, 1.504347826087, 1.5333333333333, 0
17161, 1.5260869565217, 1.4833333333333, 0
17162, 1.5478260869565, 1.4666666666667, 0
17163, 1.5260869565217, 1.5166666666667, 0
17164, 1.5478260869565, 1.5, 0
17165, 1.5478260869565, 1.5333333333333, 0
17166, 1.5695652173913, 1.4833333333333, 0
17167, 1.5913043478261, 1.4666666666667, 0
17168, 1.5695652173913, 1.5166666666667, 0
17169, 1.5913043478261, 1.5, 0
17170, 1.5913043478261, 1.5333333333333, 0
17171, 1.6130434782609, 1.4833333333333, 0
17172, 1.6347826086957, 1.4666666666667, 0
17173, 1.6130434782609, 1.5166666666667, 0
17174, 1.6347826086957, 1.5, 0
17175, 1.6347826086957, 1.5333333333333, 0
17176, 1.6565217391304, 1.4833333333333, 0
17177, 1.6782608695652, 1.4666666666667, 0
17178, 1.6565217391304, 1.5166666666667, 0
17179, 1.6782608695652, 1.5, 0
17180, 1.6782608695652, 1.5333333333333, 0
17181, 1.7, 1.4833333333333, 0
17182, 1.7217391304348, 1.4666666666667, 0
17183, 1.7, 1.5166666666667, 0
17184, 1.7217391304348, 1.5, 0
17185, 1.7217391304348, 1.5333333333333, 0
17186, 1.7434782608696, 1.4833333333333, 0
17187, 1.7652173913043, 1.4666666666667, 0
17188, 1.7434782608696, 1.5166666666667, 0
17189, 1.7652173913043, 1.5, 0
17190, 1.7652173913043, 1.5333333333333, 0
17191, 1.7869565217391, 1.4833333333333, 0
17192, 1.8086956521739, 1.4666666666667, 0
17193, 1.7869565217391, 1.5166666666667, 0
17194, 1.8086956521739, 1.5, 0
17195, 1.8086956521739, 1.5333333333333, 0
17196, 1.8304347826087, 1.4833333333333, 0
17197, 1.8521739130435, 1.4666666666667, 0
17198, 1.8304347826087, 1.5166666666667, 0
17199, 1.8521739130435, 1.5, 0
17200, 1.8521739130435, 1.5333333333333, 0
17201, 1.8739130434783, 1.4833333333333, 0
17202, 1.895652173913, 1.4666666666667, 0
17203, 1.8739130434783, 1.5166666666667, 0
17204, 1.895652173913, 1.5, 0
17205, 1.895652173913, 1.5333333333333, 0
17206, 1.9173913043478, 1.4833333333333, 0
17207, 1.9391304347826, 1.4666666666667, 0
17208, 1.9173913043478, 1.5166666666667, 0
17209, 1.9391304347826, 1.5, 0
17210, 1.9391304347826, 1.5333333333333, 0
17211, 1.9608695652174, 1.4833333333333, 0
17212, 1.9826086956522, 1.4666666666667, 0
17213, 1.9608695652174, 1.5166666666667, 0
17214, 1.9826086956522, 1.5, 0
17215, 1.9826086956522, 1.5333333333333, 0
17216, 2.004347826087, 1.4833333333333, 0
17217, 2.0260869565217, 1.4666666666667, 0
17218, 2.004347826087, 1.5166666666667, 0
17219, 2.0260869565217, 1.5, 0
17220, 2.0260869565217, 1.5333333333333, 0
17221, 2.0478260869565, 1.4833333333333, 0
17222, 2.0695652173913, 1.4666666666667, 0
17223, 2.0478260869565, 1.5166666666667, 0
17224, 2.0695652173913, 1.5, 0
17225, 2.0695652173913, 1.5333333333333, 0
17226, 2.0913043478261, 1.4833333333333, 0
17227, 2.1130434782609, 1.4666666666667, 0
17228, 2.0913043478261, 1.5166666666667, 0
17229, 2.1130434782609, 1.5, 0
17230, 2.1130434782609, 1.5333333333333, 0
17231, 2.1347826086957, 1.4833333333333, 0
17232, 2.1565217391304, 1.4666666666667, 0
17233, 2.1347826086957, 1.5166666666667, 0
17234, 2.1565217391304, 1.5, 0
17235, 2.1565217391304, 1.5333333333333, 0
17236, 2.1782608695652, 1.4833333333333, 0
17237, 2.1782608695652, 1.5166666666667, 0
17238, 1.2434782608696, 1.55, 0.44444444444444
17239, 1.2434782608696, 1.55, 0.38888888888889
17240, 1.2434782608696, 1.55, 0.33333333333333
17241, 1.2434782608696, 1.55, 0.27777777777778
17242, 1.2434782608696, 1.55, 0.22222222222222
17243, 1.2434782608696, 1.55, 0.16666666666667
17244, 1.2434782608696, 1.55, 0.11111111111111
17245, 1.2434782608696, 1.55, 0.055555555555556
17246, 1.2869565217391, 1.55, 0.44444444444444
17247, 1.2869565217391, 1.55, 0.38888888888889
17248, 1.2869565217391, 1.55, 0.33333333333333
17249, 1.2869565217391, 1.55, 0.27777777777778
17250, 1.2869565217391, 1.55, 0.22222222222222
17251, 1.2869565217391, 1.55, 0.16666666666667
17252, 1.2869565217391, 1.55, 0.11111111111111
17253, 1.2869565217391, 1.55, 0.055555555555556
17254, 1.3304347826087, 1.55, 0.44444444444444
17255, 1.3304347826087, 1.55, 0.38888888888889
17256, 1.3304347826087, 1.55, 0.33333333333333
17257, 1.3304347826087, 1.55, 0.27777777777778
17258, 1.3304347826087, 1.55, 0.22222222222222
17259, 1.3304347826087, 1.55, 0.16666666666667
17260, 1.3304347826087, 1.55, 0.11111111111111
17261, 1.3304347826087, 1.55, 0.055555555555556
17262, 1.3739130434783, 1.55, 0.44444444444444
17263, 1.3739130434783, 1.55, 0.38888888888889
17264, 1.3739130434783, 1.55, 0.33333333333333
17265, 1.3739130434783, 1.55, 0.27777777777778
17266, 1.3739130434783, 1.55, 0.22222222222222
17267, 1.3739130434783, 1.55, 0.16666666666667
17268, 1.3739130434783, 1.55, 0.11111111111111
17269, 1.3739130434783, 1.55, 0.055555555555556
17270, 1.4173913043478, 1.55, 0.44444444444444
17271, 1.4173913043478, 1.55, 0.38888888888889
17272, 1.4173913043478, 1.55, 0.33333333333333
17273, 1.4173913043478, 1.55, 0.27777777777778
17274, 1.4173913043478, 1.55, 0.22222222222222
17275, 1.4173913043478, 1.55, 0.16666666666667
17276, 1.4173913043478, 1.55, 0.11111111111111
17277, 1.4173913043478, 1.55, 0.055555555555556
17278, 1.4608695652174, 1.55, 0.44444444444444
17279, 1.4608695652174, 1.55, 0.38888888888889
17280, 1.4608695652174, 1.55, 0.33333333333333
17281, 1.4608695652174, 1.55, 0.27777777777778
17282, 1.4608695652174, 1.55, 0.22222222222222
17283, 1.4608695652174, 1.55, 0.16666666666667
17284, 1.4608695652174, 1.55, 0.11111111111111
17285, 1.4608695652174, 1.55, 0.055555555555556
17286, 1.504347826087, 1.55, 0.44444444444444
17287, 1.504347826087, 1.55, 0.38888888888889
17288, 1.504347826087, 1.55, 0.33333333333333
17289, 1.504347826087, 1.55, 0.27777777777778
17290, 1.504347826087, 1.55, 0.22222222222222
17291, 1.504347826087, 1.55, 0.16666666666667
17292, 1.504347826087, 1.55, 0.11111111111111
17293, 1.504347826087, 1.55, 0.055555555555556
17294, 1.5478260869565, 1.55, 0.44444444444444
17295, 1.5478260869565, 1.55, 0.38888888888889
17296, 1.5478260869565, 1.55, 0.33333333333333
17297, 1.5478260869565, 1.55, 0.27777777777778
17298, 1.5478260869565, 1.55, 0.22222222222222
17299, 1.5478260869565, 1.55, 0.16666666666667
17300, 1.5478260869565, 1.55, 0.11111111111111
17301, 1.5478260869565, 1.55, 0.055555555555556
17302, 1.5913043478261, 1.55, 0.44444444444444
17303, 1.5913043478261, 1.55, 0.38888888888889
17304, 1.5913043478261, 1.55, 0.33333333333333
17305, 1.5913043478261, 1.55, 0.27777777777778
17306, 1.5913043478261, 1.55, 0.22222222222222
17307, 1.5913043478261, 1.55, 0.16666666666667
17308, 1.5913043478261, 1.55, 0.11111111111111
17309, 1.5913043478261, 1.55, 0.055555555555556
17310, 1.6347826086957, 1.55, 0.44444444444444
17311, 1.6347826086957, 1.55, 0.38888888888889
17312, 1.6347826086957, 1.55, 0.33333333333333
17313, 1.6347826086957, 1.55, 0.27777777777778
17314, 1.6347826086957, 1.55, 0.22222222222222
17315, 1.6347826086957, 1.55, 0.16666666666667
17316, 1.6347826086957, 1.55, 0.11111111111111
17317, 1.6347826086957, 1.55, 0.055555555555556
17318, 1.6782608695652, 1.55, 0.44444444444444
17319, 1.6782608695652, 1.55, 0.38888888888889
17320, 1.6782608695652, 1.55, 0.33333333333333
17321, 1.6782608695652, 1.55, 0.27777777777778
17322, 1.6782608695652, 1.55, 0.22222222222222
17323, 1.6782608695652, 1.55, 0.16666666666667
17324, 1.6782608695652, 1.55, 0.11111111111111
17325, 1.6782608695652, 1.55, 0.055555555555556
17326, 1.7217391304348, 1.55, 0.44444444444444
17327, 1.7217391304348, 1.55, 0.38888888888889
17328, 1.7217391304348, 1.55, 0.33333333333333
17329, 1.7217391304348, 1.55, 0.27777777777778
17330, 1.7217391304348, 1.55, 0.22222222222222
17331, 1.7217391304348, 1.55, 0.16666666666667
17332, 1.7217391304348, 1.55, 0.11111111111111
17333, 1.7217391304348, 1.55, 0.055555555555556
17334, 1.7652173913043, 1.55, 0.44444444444444
17335, 1.7652173913043, 1.55, 0.38888888888889
17336, 1.7652173913043, 1.55, 0.33333333333333
17337, 1.7652173913043, 1.55, 0.27777777777778
17338, 1.7652173913043, 1.55, 0.22222222222222
17339, 1.7652173913043, 1.55, 0.16666666666667
17340, 1.7652173913043, 1.55, 0.11111111111111
17341, 1.7652173913043, 1.55, 0.055555555555556
17342, 1.8086956521739, 1.55, 0.44444444444444
17343, 1.8086956521739, 1.55, 0.38888888888889
17344, 1.8086956521739, 1.55, 0.33333333333333
17345, 1.8086956521739, 1.55, 0.27777777777778
17346, 1.8086956521739, 1.55, 0.22222222222222
17347, 1.8086956521739, 1.55, 0.16666666666667
17348, 1.8086956521739, 1.55, 0.11111111111111
17349, 1.8086956521739, 1.55, 0.055555555555556
17350, 1.8521739130435, 1.55, 0.44444444444444
17351, 1.8521739130435, 1.55, 0.38888888888889
17352, 1.8521739130435, 1.55, 0.33333333333333
17353, 1.8521739130435, 1.55, 0.27777777777778
17354, 1.8521739130435, 1.55, 0.22222222222222
17355, 1.8521739130435, 1.55, 0.16666666666667
17356, 1.8521739130435, 1.55, 0.11111111111111
17357, 1.8521739130435, 1.55, 0.055555555555556
17358, 1.895652173913, 1.55, 0.44444444444444
17359, 1.895652173913, 1.55, 0.38888888888889
17360, 1.895652173913, 1.55, 0.33333333333333
17361, 1.895652173913, 1.55, 0.27777777777778
17362, 1.895652173913, 1.55, 0.22222222222222
17363, 1.895652173913, 1.55, 0.16666666666667
17364, 1.895652173913, 1.55, 0.11111111111111
17365, 1.895652173913, 1.55, 0.055555555555556
17366, 1.9391304347826, 1.55, 0.44444444444444
17367, 1.9391304347826, 1.55, 0.38888888888889
17368, 1.9391304347826, 1.55, 0.33333333333333
17369, 1.9391304347826, 1.55, 0.27777777777778
17370, 1.9391304347826, 1.55, 0.22222222222222
17371, 1.9391304347826, 1.55, 0.16666666666667
17372, 1.9391304347826, 1.55, 0.11111111111111
17373, 1.9391304347826, 1.55, 0.055555555555556
17374, 1.9826086956522, 1.55, 0.44444444444444
17375, 1.9826086956522, 1.55, 0.38888888888889
17376, 1.9826086956522, 1.55, 0.33333333333333
17377, 1.9826086956522, 1.55, 0.27777777777778
17378, 1.9826086956522, 1.55, 0.22222222222222
17379, 1.9826086956522, 1.55, 0.16666666666667
17380, 1.9826086956522, 1.55, 0.11111111111111
17381, 1.9826086956522, 1.55, 0.055555555555556
17382, 2.0260869565217, 1.55, 0.44444444444444
17383, 2.0260869565217, 1.55, 0.38888888888889
17384, 2.0260869565217, 1.55, 0.33333333333333
17385, 2.0260869565217, 1.55, 0.27777777777778
17386, 2.0260869565217, 1.55, 0.22222222222222
17387, 2.0260869565217, 1.55, 0.16666666666667
17388, 2.0260869565217, 1.55, 0.11111111111111
17389, 2.0260869565217, 1.55, 0.055555555555556
17390, 2.0695652173913, 1.55, 0.44444444444444
17391, 2.0695652173913, 1.55, 0.38888888888889
17392, 2.0695652173913, 1.55, 0.33333333333333
17393, 2.0695652173913, 1.55, 0.27777777777778
17394, 2.0695652173913, 1.55, 0.22222222222222
17395, 2.0695652173913, 1.55, 0.16666666666667
17396, 2.0695652173913, 1.55, 0.11111111111111
17397, 2.0695652173913, 1.55, 0.055555555555556
17398, 2.1130434782609, 1.55, 0.44444444444444
17399, 2.1130434782609, 1.55, 0.38888888888889
17400, 2.1130434782609, 1.55, 0.33333333333333
17401, 2.1130434782609, 1.55, 0.27777777777778
17402, 2.1130434782609, 1.55, 0.22222222222222
17403, 2.1130434782609, 1.55, 0.16666666666667
17404, 2.1130434782609, 1.55, 0.11111111111111
17405, 2.1130434782609, 1.55, 0.055555555555556
17406, 2.1565217391304, 1.55, 0.44444444444444
17407, 2.1565217391304, 1.55, 0.38888888888889
17408, 2.1565217391304, 1.55, 0.33333333333333
17409, 2.1565217391304, 1.55, 0.27777777777778
17410, 2.1565217391304, 1.55, 0.22222222222222
17411, 2.1565217391304, 1.55, 0.16666666666667
17412, 2.1565217391304, 1.55, 0.11111111111111
17413, 2.1565217391304, 1.55, 0.055555555555556
17414, 1.2434782608696, 1.55, 0.47222222222222
17415, 1.2217391304348, 1.55, 0.44444444444444
17416, 1.2434782608696, 1.55, 0.41666666666667
17417, 1.2217391304348, 1.55, 0.38888888888889
17418, 1.2434782608696, 1.55, 0.36111111111111
17419, 1.2217391304348, 1.55, 0.33333333333333
17420, 1.2434782608696, 1.55, 0.30555555555556
17421, 1.2217391304348, 1.55, 0.27777777777778
17422, 1.2434782608696, 1.55, 0.25
17423, 1.2217391304348, 1.55, 0.22222222222222
17424, 1.2434782608696, 1.55, 0.19444444444444
17425, 1.2217391304348, 1.55, 0.16666666666667
17426, 1.2434782608696, 1.55, 0.13888888888889
17427, 1.2217391304348, 1.55, 0.11111111111111
17428, 1.2434782608696, 1.55, 0.083333333333333
17429, 1.2217391304348, 1.55, 0.055555555555556
17430, 1.2434782608696, 1.55, 0.027777777777778
17431, 1.2869565217391, 1.55, 0.47222222222222
17432, 1.2652173913043, 1.55, 0.44444444444444
17433, 1.2869565217391, 1.55, 0.41666666666667
17434, 1.2652173913043, 1.55, 0.38888888888889
17435, 1.2869565217391, 1.55, 0.36111111111111
17436, 1.2652173913043, 1.55, 0.33333333333333
17437, 1.2869565217391, 1.55, 0.30555555555556
17438, 1.2652173913043, 1.55, 0.27777777777778
17439, 1.2869565217391, 1.55, 0.25
17440, 1.2652173913043, 1.55, 0.22222222222222
17441, 1.2869565217391, 1.55, 0.19444444444444
17442, 1.2652173913043, 1.55, 0.16666666666667
17443, 1.2869565217391, 1.55, 0.13888888888889
17444, 1.2652173913043, 1.55, 0.11111111111111
17445, 1.2869565217391, 1.55, 0.083333333333333
17446, 1.2652173913043, 1.55, 0.055555555555556
17447, 1.2869565217391, 1.55, 0.027777777777778
17448, 1.3304347826087, 1.55, 0.47222222222222
17449, 1.3086956521739, 1.55, 0.44444444444444
17450, 1.3304347826087, 1.55, 0.41666666666667
17451, 1.3086956521739, 1.55, 0.38888888888889
17452, 1.3304347826087, 1.55, 0.36111111111111
17453, 1.3086956521739, 1.55, 0.33333333333333
17454, 1.3304347826087, 1.55, 0.30555555555556
17455, 1.3086956521739, 1.55, 0.27777777777778
17456, 1.3304347826087, 1.55, 0.25
17457, 1.3086956521739, 1.55, 0.22222222222222
17458, 1.3304347826087, 1.55, 0.19444444444444
17459, 1.3086956521739, 1.55, 0.16666666666667
17460, 1.3304347826087, 1.55, 0.13888888888889
17461, 1.3086956521739, 1.55, 0.11111111111111
17462, 1.3304347826087, 1.55, 0.083333333333333
17463, 1.3086956521739, 1.55, 0.055555555555556
17464, 1.3304347826087, 1.55, 0.027777777777778
17465, 1.3739130434783, 1.55, 0.47222222222222
17466, 1.3521739130435, 1.55, 0.44444444444444
17467, 1.3739130434783, 1.55, 0.41666666666667
