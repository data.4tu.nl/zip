79274, 0.91304347826087, 1.65, 0.27777777777778
79275, 0.91304347826087, 1.65, 0.33333333333333
79276, 0.91304347826087, 1.65, 0.38888888888889
79277, 0.91304347826087, 1.65, 0.44444444444444
79278, 0.8695652173913, 1.65, 0.055555555555556
79279, 0.8695652173913, 1.65, 0.11111111111111
79280, 0.8695652173913, 1.65, 0.16666666666667
79281, 0.8695652173913, 1.65, 0.22222222222222
79282, 0.8695652173913, 1.65, 0.27777777777778
79283, 0.8695652173913, 1.65, 0.33333333333333
79284, 0.8695652173913, 1.65, 0.38888888888889
79285, 0.8695652173913, 1.65, 0.44444444444444
79286, 0.82608695652174, 1.65, 0.055555555555556
79287, 0.82608695652174, 1.65, 0.11111111111111
79288, 0.82608695652174, 1.65, 0.16666666666667
79289, 0.82608695652174, 1.65, 0.22222222222222
79290, 0.82608695652174, 1.65, 0.27777777777778
79291, 0.82608695652174, 1.65, 0.33333333333333
79292, 0.82608695652174, 1.65, 0.38888888888889
79293, 0.82608695652174, 1.65, 0.44444444444444
79294, 0.78260869565217, 1.65, 0.055555555555556
79295, 0.78260869565217, 1.65, 0.11111111111111
79296, 0.78260869565217, 1.65, 0.16666666666667
79297, 0.78260869565217, 1.65, 0.22222222222222
79298, 0.78260869565217, 1.65, 0.27777777777778
79299, 0.78260869565217, 1.65, 0.33333333333333
79300, 0.78260869565217, 1.65, 0.38888888888889
79301, 0.78260869565217, 1.65, 0.44444444444444
79302, 0.73913043478261, 1.65, 0.055555555555556
79303, 0.73913043478261, 1.65, 0.11111111111111
79304, 0.73913043478261, 1.65, 0.16666666666667
79305, 0.73913043478261, 1.65, 0.22222222222222
79306, 0.73913043478261, 1.65, 0.27777777777778
79307, 0.73913043478261, 1.65, 0.33333333333333
79308, 0.73913043478261, 1.65, 0.38888888888889
79309, 0.73913043478261, 1.65, 0.44444444444444
79310, 0.69565217391304, 1.65, 0.055555555555556
79311, 0.69565217391304, 1.65, 0.11111111111111
79312, 0.69565217391304, 1.65, 0.16666666666667
79313, 0.69565217391304, 1.65, 0.22222222222222
79314, 0.69565217391304, 1.65, 0.27777777777778
79315, 0.69565217391304, 1.65, 0.33333333333333
79316, 0.69565217391304, 1.65, 0.38888888888889
79317, 0.69565217391304, 1.65, 0.44444444444444
79318, 0.65217391304348, 1.65, 0.055555555555556
79319, 0.65217391304348, 1.65, 0.11111111111111
79320, 0.65217391304348, 1.65, 0.16666666666667
79321, 0.65217391304348, 1.65, 0.22222222222222
79322, 0.65217391304348, 1.65, 0.27777777777778
79323, 0.65217391304348, 1.65, 0.33333333333333
79324, 0.65217391304348, 1.65, 0.38888888888889
79325, 0.65217391304348, 1.65, 0.44444444444444
79326, 0.60869565217391, 1.65, 0.055555555555556
79327, 0.60869565217391, 1.65, 0.11111111111111
79328, 0.60869565217391, 1.65, 0.16666666666667
79329, 0.60869565217391, 1.65, 0.22222222222222
79330, 0.60869565217391, 1.65, 0.27777777777778
79331, 0.60869565217391, 1.65, 0.33333333333333
79332, 0.60869565217391, 1.65, 0.38888888888889
79333, 0.60869565217391, 1.65, 0.44444444444444
79334, 0.56521739130435, 1.65, 0.055555555555556
79335, 0.56521739130435, 1.65, 0.11111111111111
79336, 0.56521739130435, 1.65, 0.16666666666667
79337, 0.56521739130435, 1.65, 0.22222222222222
79338, 0.56521739130435, 1.65, 0.27777777777778
79339, 0.56521739130435, 1.65, 0.33333333333333
79340, 0.56521739130435, 1.65, 0.38888888888889
79341, 0.56521739130435, 1.65, 0.44444444444444
79342, 0.52173913043478, 1.65, 0.055555555555556
79343, 0.52173913043478, 1.65, 0.11111111111111
79344, 0.52173913043478, 1.65, 0.16666666666667
79345, 0.52173913043478, 1.65, 0.22222222222222
79346, 0.52173913043478, 1.65, 0.27777777777778
79347, 0.52173913043478, 1.65, 0.33333333333333
79348, 0.52173913043478, 1.65, 0.38888888888889
79349, 0.52173913043478, 1.65, 0.44444444444444
79350, 0.47826086956522, 1.65, 0.055555555555556
79351, 0.47826086956522, 1.65, 0.11111111111111
79352, 0.47826086956522, 1.65, 0.16666666666667
79353, 0.47826086956522, 1.65, 0.22222222222222
79354, 0.47826086956522, 1.65, 0.27777777777778
79355, 0.47826086956522, 1.65, 0.33333333333333
79356, 0.47826086956522, 1.65, 0.38888888888889
79357, 0.47826086956522, 1.65, 0.44444444444444
79358, 0.43478260869565, 1.65, 0.055555555555556
79359, 0.43478260869565, 1.65, 0.11111111111111
79360, 0.43478260869565, 1.65, 0.16666666666667
79361, 0.43478260869565, 1.65, 0.22222222222222
79362, 0.43478260869565, 1.65, 0.27777777777778
79363, 0.43478260869565, 1.65, 0.33333333333333
79364, 0.43478260869565, 1.65, 0.38888888888889
79365, 0.43478260869565, 1.65, 0.44444444444444
79366, 0.39130434782609, 1.65, 0.055555555555556
79367, 0.39130434782609, 1.65, 0.11111111111111
79368, 0.39130434782609, 1.65, 0.16666666666667
79369, 0.39130434782609, 1.65, 0.22222222222222
79370, 0.39130434782609, 1.65, 0.27777777777778
79371, 0.39130434782609, 1.65, 0.33333333333333
79372, 0.39130434782609, 1.65, 0.38888888888889
79373, 0.39130434782609, 1.65, 0.44444444444444
79374, 0.34782608695652, 1.65, 0.055555555555556
79375, 0.34782608695652, 1.65, 0.11111111111111
79376, 0.34782608695652, 1.65, 0.16666666666667
79377, 0.34782608695652, 1.65, 0.22222222222222
79378, 0.34782608695652, 1.65, 0.27777777777778
79379, 0.34782608695652, 1.65, 0.33333333333333
79380, 0.34782608695652, 1.65, 0.38888888888889
79381, 0.34782608695652, 1.65, 0.44444444444444
79382, 0.30434782608696, 1.65, 0.055555555555556
79383, 0.30434782608696, 1.65, 0.11111111111111
79384, 0.30434782608696, 1.65, 0.16666666666667
79385, 0.30434782608696, 1.65, 0.22222222222222
79386, 0.30434782608696, 1.65, 0.27777777777778
79387, 0.30434782608696, 1.65, 0.33333333333333
79388, 0.30434782608696, 1.65, 0.38888888888889
79389, 0.30434782608696, 1.65, 0.44444444444444
79390, 0.26086956521739, 1.65, 0.055555555555556
79391, 0.26086956521739, 1.65, 0.11111111111111
79392, 0.26086956521739, 1.65, 0.16666666666667
79393, 0.26086956521739, 1.65, 0.22222222222222
79394, 0.26086956521739, 1.65, 0.27777777777778
79395, 0.26086956521739, 1.65, 0.33333333333333
79396, 0.26086956521739, 1.65, 0.38888888888889
79397, 0.26086956521739, 1.65, 0.44444444444444
79398, 0.21739130434783, 1.65, 0.055555555555556
79399, 0.21739130434783, 1.65, 0.11111111111111
79400, 0.21739130434783, 1.65, 0.16666666666667
79401, 0.21739130434783, 1.65, 0.22222222222222
79402, 0.21739130434783, 1.65, 0.27777777777778
79403, 0.21739130434783, 1.65, 0.33333333333333
79404, 0.21739130434783, 1.65, 0.38888888888889
79405, 0.21739130434783, 1.65, 0.44444444444444
79406, 0.17391304347826, 1.65, 0.055555555555556
79407, 0.17391304347826, 1.65, 0.11111111111111
79408, 0.17391304347826, 1.65, 0.16666666666667
79409, 0.17391304347826, 1.65, 0.22222222222222
79410, 0.17391304347826, 1.65, 0.27777777777778
79411, 0.17391304347826, 1.65, 0.33333333333333
79412, 0.17391304347826, 1.65, 0.38888888888889
79413, 0.17391304347826, 1.65, 0.44444444444444
79414, 0.1304347826087, 1.65, 0.055555555555556
79415, 0.1304347826087, 1.65, 0.11111111111111
79416, 0.1304347826087, 1.65, 0.16666666666667
79417, 0.1304347826087, 1.65, 0.22222222222222
79418, 0.1304347826087, 1.65, 0.27777777777778
79419, 0.1304347826087, 1.65, 0.33333333333333
79420, 0.1304347826087, 1.65, 0.38888888888889
79421, 0.1304347826087, 1.65, 0.44444444444444
79422, 0.08695652173913, 1.65, 0.055555555555556
79423, 0.08695652173913, 1.65, 0.11111111111111
79424, 0.08695652173913, 1.65, 0.16666666666667
79425, 0.08695652173913, 1.65, 0.22222222222222
79426, 0.08695652173913, 1.65, 0.27777777777778
79427, 0.08695652173913, 1.65, 0.33333333333333
79428, 0.08695652173913, 1.65, 0.38888888888889
79429, 0.08695652173913, 1.65, 0.44444444444444
79430, 0.043478260869565, 1.65, 0.055555555555556
79431, 0.043478260869565, 1.65, 0.11111111111111
79432, 0.043478260869565, 1.65, 0.16666666666667
79433, 0.043478260869565, 1.65, 0.22222222222222
79434, 0.043478260869565, 1.65, 0.27777777777778
79435, 0.043478260869565, 1.65, 0.33333333333333
79436, 0.043478260869565, 1.65, 0.38888888888889
79437, 0.043478260869565, 1.65, 0.44444444444444
79438, 0.95652173913043, 1.7, 0.055555555555556
79439, 0.95652173913044, 1.7, 0.11111111111111
79440, 0.95652173913043, 1.7, 0.16666666666667
79441, 0.95652173913044, 1.7, 0.22222222222222
79442, 0.95652173913044, 1.7, 0.27777777777778
79443, 0.95652173913044, 1.7, 0.33333333333333
79444, 0.95652173913044, 1.7, 0.38888888888889
79445, 0.95652173913044, 1.7, 0.44444444444444
79446, 0.91304347826087, 1.7, 0.055555555555556
79447, 0.91304347826087, 1.7, 0.11111111111111
79448, 0.91304347826087, 1.7, 0.16666666666667
79449, 0.91304347826087, 1.7, 0.22222222222222
79450, 0.91304347826087, 1.7, 0.27777777777778
79451, 0.91304347826087, 1.7, 0.33333333333333
79452, 0.91304347826087, 1.7, 0.38888888888889
79453, 0.91304347826087, 1.7, 0.44444444444444
79454, 0.8695652173913, 1.7, 0.055555555555556
79455, 0.8695652173913, 1.7, 0.11111111111111
79456, 0.8695652173913, 1.7, 0.16666666666667
79457, 0.8695652173913, 1.7, 0.22222222222222
79458, 0.8695652173913, 1.7, 0.27777777777778
79459, 0.8695652173913, 1.7, 0.33333333333333
79460, 0.8695652173913, 1.7, 0.38888888888889
79461, 0.8695652173913, 1.7, 0.44444444444444
79462, 0.82608695652174, 1.7, 0.055555555555556
79463, 0.82608695652174, 1.7, 0.11111111111111
79464, 0.82608695652174, 1.7, 0.16666666666667
79465, 0.82608695652174, 1.7, 0.22222222222222
79466, 0.82608695652174, 1.7, 0.27777777777778
79467, 0.82608695652174, 1.7, 0.33333333333333
79468, 0.82608695652174, 1.7, 0.38888888888889
79469, 0.82608695652174, 1.7, 0.44444444444444
79470, 0.78260869565217, 1.7, 0.055555555555556
79471, 0.78260869565217, 1.7, 0.11111111111111
79472, 0.78260869565217, 1.7, 0.16666666666667
79473, 0.78260869565217, 1.7, 0.22222222222222
79474, 0.78260869565217, 1.7, 0.27777777777778
79475, 0.78260869565217, 1.7, 0.33333333333333
79476, 0.78260869565217, 1.7, 0.38888888888889
79477, 0.78260869565217, 1.7, 0.44444444444444
79478, 0.73913043478261, 1.7, 0.055555555555556
79479, 0.73913043478261, 1.7, 0.11111111111111
79480, 0.73913043478261, 1.7, 0.16666666666667
79481, 0.73913043478261, 1.7, 0.22222222222222
79482, 0.73913043478261, 1.7, 0.27777777777778
79483, 0.73913043478261, 1.7, 0.33333333333333
79484, 0.73913043478261, 1.7, 0.38888888888889
79485, 0.73913043478261, 1.7, 0.44444444444444
79486, 0.69565217391304, 1.7, 0.055555555555556
79487, 0.69565217391304, 1.7, 0.11111111111111
79488, 0.69565217391304, 1.7, 0.16666666666667
79489, 0.69565217391304, 1.7, 0.22222222222222
79490, 0.69565217391304, 1.7, 0.27777777777778
79491, 0.69565217391304, 1.7, 0.33333333333333
79492, 0.69565217391304, 1.7, 0.38888888888889
79493, 0.69565217391304, 1.7, 0.44444444444444
79494, 0.65217391304348, 1.7, 0.055555555555556
79495, 0.65217391304348, 1.7, 0.11111111111111
79496, 0.65217391304348, 1.7, 0.16666666666667
79497, 0.65217391304348, 1.7, 0.22222222222222
79498, 0.65217391304348, 1.7, 0.27777777777778
79499, 0.65217391304348, 1.7, 0.33333333333333
79500, 0.65217391304348, 1.7, 0.38888888888889
79501, 0.65217391304348, 1.7, 0.44444444444444
79502, 0.60869565217391, 1.7, 0.055555555555556
79503, 0.60869565217391, 1.7, 0.11111111111111
79504, 0.60869565217391, 1.7, 0.16666666666667
79505, 0.60869565217391, 1.7, 0.22222222222222
79506, 0.60869565217391, 1.7, 0.27777777777778
79507, 0.60869565217391, 1.7, 0.33333333333333
79508, 0.60869565217391, 1.7, 0.38888888888889
79509, 0.60869565217391, 1.7, 0.44444444444444
79510, 0.56521739130435, 1.7, 0.055555555555556
79511, 0.56521739130435, 1.7, 0.11111111111111
79512, 0.56521739130435, 1.7, 0.16666666666667
79513, 0.56521739130435, 1.7, 0.22222222222222
79514, 0.56521739130435, 1.7, 0.27777777777778
79515, 0.56521739130435, 1.7, 0.33333333333333
79516, 0.56521739130435, 1.7, 0.38888888888889
79517, 0.56521739130435, 1.7, 0.44444444444444
79518, 0.52173913043478, 1.7, 0.055555555555556
79519, 0.52173913043478, 1.7, 0.11111111111111
79520, 0.52173913043478, 1.7, 0.16666666666667
79521, 0.52173913043478, 1.7, 0.22222222222222
79522, 0.52173913043478, 1.7, 0.27777777777778
79523, 0.52173913043478, 1.7, 0.33333333333333
79524, 0.52173913043478, 1.7, 0.38888888888889
79525, 0.52173913043478, 1.7, 0.44444444444444
79526, 0.47826086956522, 1.7, 0.055555555555556
79527, 0.47826086956522, 1.7, 0.11111111111111
79528, 0.47826086956522, 1.7, 0.16666666666667
79529, 0.47826086956522, 1.7, 0.22222222222222
79530, 0.47826086956522, 1.7, 0.27777777777778
79531, 0.47826086956522, 1.7, 0.33333333333333
79532, 0.47826086956522, 1.7, 0.38888888888889
79533, 0.47826086956522, 1.7, 0.44444444444444
79534, 0.43478260869565, 1.7, 0.055555555555556
79535, 0.43478260869565, 1.7, 0.11111111111111
79536, 0.43478260869565, 1.7, 0.16666666666667
79537, 0.43478260869565, 1.7, 0.22222222222222
79538, 0.43478260869565, 1.7, 0.27777777777778
79539, 0.43478260869565, 1.7, 0.33333333333333
79540, 0.43478260869565, 1.7, 0.38888888888889
79541, 0.43478260869565, 1.7, 0.44444444444444
79542, 0.39130434782609, 1.7, 0.055555555555556
79543, 0.39130434782609, 1.7, 0.11111111111111
79544, 0.39130434782609, 1.7, 0.16666666666667
79545, 0.39130434782609, 1.7, 0.22222222222222
79546, 0.39130434782609, 1.7, 0.27777777777778
79547, 0.39130434782609, 1.7, 0.33333333333333
79548, 0.39130434782609, 1.7, 0.38888888888889
79549, 0.39130434782609, 1.7, 0.44444444444444
79550, 0.34782608695652, 1.7, 0.055555555555556
79551, 0.34782608695652, 1.7, 0.11111111111111
79552, 0.34782608695652, 1.7, 0.16666666666667
79553, 0.34782608695652, 1.7, 0.22222222222222
79554, 0.34782608695652, 1.7, 0.27777777777778
79555, 0.34782608695652, 1.7, 0.33333333333333
79556, 0.34782608695652, 1.7, 0.38888888888889
79557, 0.34782608695652, 1.7, 0.44444444444444
79558, 0.30434782608696, 1.7, 0.055555555555556
79559, 0.30434782608696, 1.7, 0.11111111111111
79560, 0.30434782608696, 1.7, 0.16666666666667
79561, 0.30434782608696, 1.7, 0.22222222222222
79562, 0.30434782608696, 1.7, 0.27777777777778
79563, 0.30434782608696, 1.7, 0.33333333333333
79564, 0.30434782608696, 1.7, 0.38888888888889
79565, 0.30434782608696, 1.7, 0.44444444444444
79566, 0.26086956521739, 1.7, 0.055555555555556
79567, 0.26086956521739, 1.7, 0.11111111111111
79568, 0.26086956521739, 1.7, 0.16666666666667
79569, 0.26086956521739, 1.7, 0.22222222222222
79570, 0.26086956521739, 1.7, 0.27777777777778
79571, 0.26086956521739, 1.7, 0.33333333333333
79572, 0.26086956521739, 1.7, 0.38888888888889
79573, 0.26086956521739, 1.7, 0.44444444444444
79574, 0.21739130434783, 1.7, 0.055555555555556
79575, 0.21739130434783, 1.7, 0.11111111111111
79576, 0.21739130434783, 1.7, 0.16666666666667
79577, 0.21739130434783, 1.7, 0.22222222222222
79578, 0.21739130434783, 1.7, 0.27777777777778
79579, 0.21739130434783, 1.7, 0.33333333333333
79580, 0.21739130434783, 1.7, 0.38888888888889
79581, 0.21739130434783, 1.7, 0.44444444444444
79582, 0.17391304347826, 1.7, 0.055555555555556
79583, 0.17391304347826, 1.7, 0.11111111111111
79584, 0.17391304347826, 1.7, 0.16666666666667
79585, 0.17391304347826, 1.7, 0.22222222222222
79586, 0.17391304347826, 1.7, 0.27777777777778
79587, 0.17391304347826, 1.7, 0.33333333333333
79588, 0.17391304347826, 1.7, 0.38888888888889
79589, 0.17391304347826, 1.7, 0.44444444444444
79590, 0.1304347826087, 1.7, 0.055555555555556
79591, 0.1304347826087, 1.7, 0.11111111111111
79592, 0.1304347826087, 1.7, 0.16666666666667
79593, 0.1304347826087, 1.7, 0.22222222222222
79594, 0.1304347826087, 1.7, 0.27777777777778
79595, 0.1304347826087, 1.7, 0.33333333333333
79596, 0.1304347826087, 1.7, 0.38888888888889
79597, 0.1304347826087, 1.7, 0.44444444444444
79598, 0.08695652173913, 1.7, 0.055555555555556
79599, 0.08695652173913, 1.7, 0.11111111111111
79600, 0.08695652173913, 1.7, 0.16666666666667
79601, 0.08695652173913, 1.7, 0.22222222222222
79602, 0.08695652173913, 1.7, 0.27777777777778
79603, 0.08695652173913, 1.7, 0.33333333333333
79604, 0.08695652173913, 1.7, 0.38888888888889
79605, 0.08695652173913, 1.7, 0.44444444444444
79606, 0.043478260869565, 1.7, 0.055555555555556
79607, 0.043478260869565, 1.7, 0.11111111111111
79608, 0.043478260869565, 1.7, 0.16666666666667
79609, 0.043478260869565, 1.7, 0.22222222222222
79610, 0.043478260869565, 1.7, 0.27777777777778
79611, 0.043478260869565, 1.7, 0.33333333333333
79612, 0.043478260869565, 1.7, 0.38888888888889
79613, 0.043478260869565, 1.7, 0.44444444444444
79614, 0.95652173913043, 1.6, 0.027777777777778
79615, 0.97826086956522, 1.6, 0.055555555555556
79616, 0.95652173913043, 1.575, 0.055555555555556
79617, 0.95652173913043, 1.6, 0.083333333333333
79618, 0.97826086956522, 1.6, 0.11111111111111
79619, 0.95652173913043, 1.575, 0.11111111111111
79620, 0.95652173913044, 1.6, 0.13888888888889
79621, 0.97826086956522, 1.6, 0.16666666666667
79622, 0.95652173913043, 1.575, 0.16666666666667
79623, 0.95652173913043, 1.6, 0.19444444444444
79624, 0.97826086956522, 1.6, 0.22222222222222
79625, 0.95652173913043, 1.575, 0.22222222222222
79626, 0.95652173913044, 1.6, 0.25
79627, 0.97826086956522, 1.6, 0.27777777777778
79628, 0.95652173913043, 1.575, 0.27777777777778
79629, 0.95652173913043, 1.6, 0.30555555555556
79630, 0.97826086956522, 1.6, 0.33333333333333
79631, 0.95652173913043, 1.575, 0.33333333333333
79632, 0.95652173913043, 1.6, 0.36111111111111
79633, 0.97826086956522, 1.6, 0.38888888888889
79634, 0.95652173913043, 1.575, 0.38888888888889
79635, 0.95652173913043, 1.6, 0.41666666666667
79636, 0.97826086956522, 1.6, 0.44444444444444
79637, 0.95652173913043, 1.575, 0.44444444444444
79638, 0.95652173913043, 1.6, 0.47222222222222
79639, 0.91304347826087, 1.6, 0.027777777777778
79640, 0.93478260869565, 1.6, 0.055555555555556
79641, 0.91304347826087, 1.575, 0.055555555555556
79642, 0.91304347826087, 1.6, 0.083333333333333
79643, 0.93478260869565, 1.6, 0.11111111111111
79644, 0.91304347826087, 1.575, 0.11111111111111
79645, 0.91304347826087, 1.6, 0.13888888888889
79646, 0.93478260869565, 1.6, 0.16666666666667
79647, 0.91304347826087, 1.575, 0.16666666666667
79648, 0.91304347826087, 1.6, 0.19444444444444
79649, 0.93478260869565, 1.6, 0.22222222222222
79650, 0.91304347826087, 1.575, 0.22222222222222
79651, 0.91304347826087, 1.6, 0.25
79652, 0.93478260869565, 1.6, 0.27777777777778
79653, 0.91304347826087, 1.575, 0.27777777777778
79654, 0.91304347826087, 1.6, 0.30555555555556
79655, 0.93478260869565, 1.6, 0.33333333333333
79656, 0.91304347826087, 1.575, 0.33333333333333
79657, 0.91304347826087, 1.6, 0.36111111111111
79658, 0.93478260869565, 1.6, 0.38888888888889
79659, 0.91304347826087, 1.575, 0.38888888888889
79660, 0.91304347826087, 1.6, 0.41666666666667
79661, 0.93478260869565, 1.6, 0.44444444444444
79662, 0.91304347826087, 1.575, 0.44444444444444
79663, 0.91304347826087, 1.6, 0.47222222222222
79664, 0.8695652173913, 1.6, 0.027777777777778
79665, 0.89130434782609, 1.6, 0.055555555555556
79666, 0.8695652173913, 1.575, 0.055555555555556
79667, 0.8695652173913, 1.6, 0.083333333333333
79668, 0.89130434782609, 1.6, 0.11111111111111
79669, 0.8695652173913, 1.575, 0.11111111111111
79670, 0.8695652173913, 1.6, 0.13888888888889
79671, 0.89130434782609, 1.6, 0.16666666666667
79672, 0.8695652173913, 1.575, 0.16666666666667
79673, 0.8695652173913, 1.6, 0.19444444444444
79674, 0.89130434782609, 1.6, 0.22222222222222
79675, 0.8695652173913, 1.575, 0.22222222222222
79676, 0.8695652173913, 1.6, 0.25
79677, 0.89130434782609, 1.6, 0.27777777777778
79678, 0.8695652173913, 1.575, 0.27777777777778
79679, 0.8695652173913, 1.6, 0.30555555555556
79680, 0.89130434782609, 1.6, 0.33333333333333
79681, 0.8695652173913, 1.575, 0.33333333333333
79682, 0.8695652173913, 1.6, 0.36111111111111
79683, 0.89130434782609, 1.6, 0.38888888888889
79684, 0.8695652173913, 1.575, 0.38888888888889
79685, 0.8695652173913, 1.6, 0.41666666666667
79686, 0.89130434782609, 1.6, 0.44444444444444
79687, 0.8695652173913, 1.575, 0.44444444444444
79688, 0.8695652173913, 1.6, 0.47222222222222
79689, 0.82608695652174, 1.6, 0.027777777777778
79690, 0.84782608695652, 1.6, 0.055555555555556
79691, 0.82608695652174, 1.575, 0.055555555555556
79692, 0.82608695652174, 1.6, 0.083333333333333
79693, 0.84782608695652, 1.6, 0.11111111111111
79694, 0.82608695652174, 1.575, 0.11111111111111
79695, 0.82608695652174, 1.6, 0.13888888888889
79696, 0.84782608695652, 1.6, 0.16666666666667
79697, 0.82608695652174, 1.575, 0.16666666666667
79698, 0.82608695652174, 1.6, 0.19444444444444
79699, 0.84782608695652, 1.6, 0.22222222222222
79700, 0.82608695652174, 1.575, 0.22222222222222
79701, 0.82608695652174, 1.6, 0.25
79702, 0.84782608695652, 1.6, 0.27777777777778
79703, 0.82608695652174, 1.575, 0.27777777777778
79704, 0.82608695652174, 1.6, 0.30555555555556
79705, 0.84782608695652, 1.6, 0.33333333333333
79706, 0.82608695652174, 1.575, 0.33333333333333
79707, 0.82608695652174, 1.6, 0.36111111111111
79708, 0.84782608695652, 1.6, 0.38888888888889
79709, 0.82608695652174, 1.575, 0.38888888888889
79710, 0.82608695652174, 1.6, 0.41666666666667
79711, 0.84782608695652, 1.6, 0.44444444444444
79712, 0.82608695652174, 1.575, 0.44444444444444
79713, 0.82608695652174, 1.6, 0.47222222222222
79714, 0.78260869565217, 1.6, 0.027777777777778
79715, 0.80434782608696, 1.6, 0.055555555555556
79716, 0.78260869565217, 1.575, 0.055555555555556
79717, 0.78260869565217, 1.6, 0.083333333333333
79718, 0.80434782608696, 1.6, 0.11111111111111
79719, 0.78260869565217, 1.575, 0.11111111111111
79720, 0.78260869565217, 1.6, 0.13888888888889
79721, 0.80434782608696, 1.6, 0.16666666666667
79722, 0.78260869565217, 1.575, 0.16666666666667
79723, 0.78260869565217, 1.6, 0.19444444444444
79724, 0.80434782608696, 1.6, 0.22222222222222
79725, 0.78260869565217, 1.575, 0.22222222222222
79726, 0.78260869565217, 1.6, 0.25
79727, 0.80434782608696, 1.6, 0.27777777777778
79728, 0.78260869565217, 1.575, 0.27777777777778
79729, 0.78260869565217, 1.6, 0.30555555555556
79730, 0.80434782608696, 1.6, 0.33333333333333
79731, 0.78260869565217, 1.575, 0.33333333333333
79732, 0.78260869565217, 1.6, 0.36111111111111
79733, 0.80434782608696, 1.6, 0.38888888888889
79734, 0.78260869565217, 1.575, 0.38888888888889
79735, 0.78260869565217, 1.6, 0.41666666666667
79736, 0.80434782608696, 1.6, 0.44444444444444
79737, 0.78260869565217, 1.575, 0.44444444444444
79738, 0.78260869565217, 1.6, 0.47222222222222
79739, 0.73913043478261, 1.6, 0.027777777777778
79740, 0.76086956521739, 1.6, 0.055555555555556
79741, 0.73913043478261, 1.575, 0.055555555555556
79742, 0.73913043478261, 1.6, 0.083333333333333
79743, 0.76086956521739, 1.6, 0.11111111111111
79744, 0.73913043478261, 1.575, 0.11111111111111
79745, 0.73913043478261, 1.6, 0.13888888888889
79746, 0.76086956521739, 1.6, 0.16666666666667
79747, 0.73913043478261, 1.575, 0.16666666666667
79748, 0.73913043478261, 1.6, 0.19444444444444
79749, 0.76086956521739, 1.6, 0.22222222222222
79750, 0.73913043478261, 1.575, 0.22222222222222
79751, 0.73913043478261, 1.6, 0.25
79752, 0.76086956521739, 1.6, 0.27777777777778
79753, 0.73913043478261, 1.575, 0.27777777777778
79754, 0.73913043478261, 1.6, 0.30555555555556
79755, 0.76086956521739, 1.6, 0.33333333333333
79756, 0.73913043478261, 1.575, 0.33333333333333
79757, 0.73913043478261, 1.6, 0.36111111111111
79758, 0.76086956521739, 1.6, 0.38888888888889
79759, 0.73913043478261, 1.575, 0.38888888888889
79760, 0.73913043478261, 1.6, 0.41666666666667
79761, 0.76086956521739, 1.6, 0.44444444444444
79762, 0.73913043478261, 1.575, 0.44444444444444
79763, 0.73913043478261, 1.6, 0.47222222222222
79764, 0.69565217391304, 1.6, 0.027777777777778
79765, 0.71739130434783, 1.6, 0.055555555555556
79766, 0.69565217391304, 1.575, 0.055555555555556
79767, 0.69565217391304, 1.6, 0.083333333333333
79768, 0.71739130434783, 1.6, 0.11111111111111
79769, 0.69565217391304, 1.575, 0.11111111111111
79770, 0.69565217391304, 1.6, 0.13888888888889
79771, 0.71739130434783, 1.6, 0.16666666666667
79772, 0.69565217391304, 1.575, 0.16666666666667
79773, 0.69565217391304, 1.6, 0.19444444444444
79774, 0.71739130434783, 1.6, 0.22222222222222
79775, 0.69565217391304, 1.575, 0.22222222222222
79776, 0.69565217391304, 1.6, 0.25
79777, 0.71739130434783, 1.6, 0.27777777777778
79778, 0.69565217391304, 1.575, 0.27777777777778
79779, 0.69565217391304, 1.6, 0.30555555555556
79780, 0.71739130434783, 1.6, 0.33333333333333
79781, 0.69565217391304, 1.575, 0.33333333333333
79782, 0.69565217391304, 1.6, 0.36111111111111
79783, 0.71739130434783, 1.6, 0.38888888888889
79784, 0.69565217391304, 1.575, 0.38888888888889
79785, 0.69565217391304, 1.6, 0.41666666666667
79786, 0.71739130434783, 1.6, 0.44444444444444
79787, 0.69565217391304, 1.575, 0.44444444444444
79788, 0.69565217391304, 1.6, 0.47222222222222
79789, 0.65217391304348, 1.6, 0.027777777777778
79790, 0.67391304347826, 1.6, 0.055555555555556
79791, 0.65217391304348, 1.575, 0.055555555555556
79792, 0.65217391304348, 1.6, 0.083333333333333
79793, 0.67391304347826, 1.6, 0.11111111111111
79794, 0.65217391304348, 1.575, 0.11111111111111
79795, 0.65217391304348, 1.6, 0.13888888888889
79796, 0.67391304347826, 1.6, 0.16666666666667
79797, 0.65217391304348, 1.575, 0.16666666666667
79798, 0.65217391304348, 1.6, 0.19444444444444
79799, 0.67391304347826, 1.6, 0.22222222222222
79800, 0.65217391304348, 1.575, 0.22222222222222
79801, 0.65217391304348, 1.6, 0.25
79802, 0.67391304347826, 1.6, 0.27777777777778
79803, 0.65217391304348, 1.575, 0.27777777777778
79804, 0.65217391304348, 1.6, 0.30555555555556
79805, 0.67391304347826, 1.6, 0.33333333333333
79806, 0.65217391304348, 1.575, 0.33333333333333
79807, 0.65217391304348, 1.6, 0.36111111111111
79808, 0.67391304347826, 1.6, 0.38888888888889
79809, 0.65217391304348, 1.575, 0.38888888888889
79810, 0.65217391304348, 1.6, 0.41666666666667
79811, 0.67391304347826, 1.6, 0.44444444444444
79812, 0.65217391304348, 1.575, 0.44444444444444
79813, 0.65217391304348, 1.6, 0.47222222222222
79814, 0.60869565217391, 1.6, 0.027777777777778
79815, 0.6304347826087, 1.6, 0.055555555555556
79816, 0.60869565217391, 1.575, 0.055555555555556
79817, 0.60869565217391, 1.6, 0.083333333333333
79818, 0.6304347826087, 1.6, 0.11111111111111
79819, 0.60869565217391, 1.575, 0.11111111111111
79820, 0.60869565217391, 1.6, 0.13888888888889
79821, 0.6304347826087, 1.6, 0.16666666666667
79822, 0.60869565217391, 1.575, 0.16666666666667
79823, 0.60869565217391, 1.6, 0.19444444444444
79824, 0.6304347826087, 1.6, 0.22222222222222
79825, 0.60869565217391, 1.575, 0.22222222222222
79826, 0.60869565217391, 1.6, 0.25
79827, 0.6304347826087, 1.6, 0.27777777777778
79828, 0.60869565217391, 1.575, 0.27777777777778
79829, 0.60869565217391, 1.6, 0.30555555555556
79830, 0.6304347826087, 1.6, 0.33333333333333
79831, 0.60869565217391, 1.575, 0.33333333333333
79832, 0.60869565217391, 1.6, 0.36111111111111
79833, 0.6304347826087, 1.6, 0.38888888888889
79834, 0.60869565217391, 1.575, 0.38888888888889
79835, 0.60869565217391, 1.6, 0.41666666666667
79836, 0.6304347826087, 1.6, 0.44444444444444
79837, 0.60869565217391, 1.575, 0.44444444444444
79838, 0.60869565217391, 1.6, 0.47222222222222
79839, 0.56521739130435, 1.6, 0.027777777777778
79840, 0.58695652173913, 1.6, 0.055555555555556
79841, 0.56521739130435, 1.575, 0.055555555555556
79842, 0.56521739130435, 1.6, 0.083333333333333
79843, 0.58695652173913, 1.6, 0.11111111111111
79844, 0.56521739130435, 1.575, 0.11111111111111
79845, 0.56521739130435, 1.6, 0.13888888888889
79846, 0.58695652173913, 1.6, 0.16666666666667
79847, 0.56521739130435, 1.575, 0.16666666666667
79848, 0.56521739130435, 1.6, 0.19444444444444
79849, 0.58695652173913, 1.6, 0.22222222222222
79850, 0.56521739130435, 1.575, 0.22222222222222
79851, 0.56521739130435, 1.6, 0.25
79852, 0.58695652173913, 1.6, 0.27777777777778
79853, 0.56521739130435, 1.575, 0.27777777777778
79854, 0.56521739130435, 1.6, 0.30555555555556
79855, 0.58695652173913, 1.6, 0.33333333333333
79856, 0.56521739130435, 1.575, 0.33333333333333
79857, 0.56521739130435, 1.6, 0.36111111111111
79858, 0.58695652173913, 1.6, 0.38888888888889
79859, 0.56521739130435, 1.575, 0.38888888888889
79860, 0.56521739130435, 1.6, 0.41666666666667
79861, 0.58695652173913, 1.6, 0.44444444444444
79862, 0.56521739130435, 1.575, 0.44444444444444
79863, 0.56521739130435, 1.6, 0.47222222222222
79864, 0.52173913043478, 1.6, 0.027777777777778
79865, 0.54347826086957, 1.6, 0.055555555555556
79866, 0.52173913043478, 1.575, 0.055555555555556
79867, 0.52173913043478, 1.6, 0.083333333333333
79868, 0.54347826086956, 1.6, 0.11111111111111
79869, 0.52173913043478, 1.575, 0.11111111111111
79870, 0.52173913043478, 1.6, 0.13888888888889
79871, 0.54347826086956, 1.6, 0.16666666666667
79872, 0.52173913043478, 1.575, 0.16666666666667
79873, 0.52173913043478, 1.6, 0.19444444444444
79874, 0.54347826086956, 1.6, 0.22222222222222
79875, 0.52173913043478, 1.575, 0.22222222222222
79876, 0.52173913043478, 1.6, 0.25
79877, 0.54347826086956, 1.6, 0.27777777777778
79878, 0.52173913043478, 1.575, 0.27777777777778
79879, 0.52173913043478, 1.6, 0.30555555555556
79880, 0.54347826086956, 1.6, 0.33333333333333
79881, 0.52173913043478, 1.575, 0.33333333333333
79882, 0.52173913043478, 1.6, 0.36111111111111
79883, 0.54347826086956, 1.6, 0.38888888888889
79884, 0.52173913043478, 1.575, 0.38888888888889
79885, 0.52173913043478, 1.6, 0.41666666666667
79886, 0.54347826086956, 1.6, 0.44444444444444
79887, 0.52173913043478, 1.575, 0.44444444444444
79888, 0.52173913043478, 1.6, 0.47222222222222
79889, 0.47826086956522, 1.6, 0.027777777777778
79890, 0.5, 1.6, 0.055555555555556
79891, 0.47826086956522, 1.575, 0.055555555555556
79892, 0.47826086956522, 1.6, 0.083333333333333
79893, 0.5, 1.6, 0.11111111111111
79894, 0.47826086956522, 1.575, 0.11111111111111
79895, 0.47826086956522, 1.6, 0.13888888888889
79896, 0.5, 1.6, 0.16666666666667
79897, 0.47826086956522, 1.575, 0.16666666666667
79898, 0.47826086956522, 1.6, 0.19444444444444
79899, 0.5, 1.6, 0.22222222222222
79900, 0.47826086956522, 1.575, 0.22222222222222
79901, 0.47826086956522, 1.6, 0.25
79902, 0.5, 1.6, 0.27777777777778
79903, 0.47826086956522, 1.575, 0.27777777777778
79904, 0.47826086956522, 1.6, 0.30555555555556
79905, 0.5, 1.6, 0.33333333333333
79906, 0.47826086956522, 1.575, 0.33333333333333
79907, 0.47826086956522, 1.6, 0.36111111111111
79908, 0.5, 1.6, 0.38888888888889
79909, 0.47826086956522, 1.575, 0.38888888888889
79910, 0.47826086956522, 1.6, 0.41666666666667
79911, 0.5, 1.6, 0.44444444444444
79912, 0.47826086956522, 1.575, 0.44444444444444
79913, 0.47826086956522, 1.6, 0.47222222222222
79914, 0.43478260869565, 1.6, 0.027777777777778
79915, 0.45652173913043, 1.6, 0.055555555555556
79916, 0.43478260869565, 1.575, 0.055555555555556
79917, 0.43478260869565, 1.6, 0.083333333333333
79918, 0.45652173913043, 1.6, 0.11111111111111
79919, 0.43478260869565, 1.575, 0.11111111111111
79920, 0.43478260869565, 1.6, 0.13888888888889
79921, 0.45652173913043, 1.6, 0.16666666666667
79922, 0.43478260869565, 1.575, 0.16666666666667
79923, 0.43478260869565, 1.6, 0.19444444444444
79924, 0.45652173913043, 1.6, 0.22222222222222
79925, 0.43478260869565, 1.575, 0.22222222222222
79926, 0.43478260869565, 1.6, 0.25
79927, 0.45652173913043, 1.6, 0.27777777777778
79928, 0.43478260869565, 1.575, 0.27777777777778
79929, 0.43478260869565, 1.6, 0.30555555555556
79930, 0.45652173913043, 1.6, 0.33333333333333
79931, 0.43478260869565, 1.575, 0.33333333333333
79932, 0.43478260869565, 1.6, 0.36111111111111
79933, 0.45652173913043, 1.6, 0.38888888888889
79934, 0.43478260869565, 1.575, 0.38888888888889
79935, 0.43478260869565, 1.6, 0.41666666666667
79936, 0.45652173913043, 1.6, 0.44444444444444
79937, 0.43478260869565, 1.575, 0.44444444444444
79938, 0.43478260869565, 1.6, 0.47222222222222
79939, 0.39130434782609, 1.6, 0.027777777777778
79940, 0.41304347826087, 1.6, 0.055555555555556
79941, 0.39130434782609, 1.575, 0.055555555555556
79942, 0.39130434782609, 1.6, 0.083333333333333
79943, 0.41304347826087, 1.6, 0.11111111111111
79944, 0.39130434782609, 1.575, 0.11111111111111
79945, 0.39130434782609, 1.6, 0.13888888888889
79946, 0.41304347826087, 1.6, 0.16666666666667
79947, 0.39130434782609, 1.575, 0.16666666666667
79948, 0.39130434782609, 1.6, 0.19444444444444
79949, 0.41304347826087, 1.6, 0.22222222222222
79950, 0.39130434782609, 1.575, 0.22222222222222
79951, 0.39130434782609, 1.6, 0.25
79952, 0.41304347826087, 1.6, 0.27777777777778
79953, 0.39130434782609, 1.575, 0.27777777777778
79954, 0.39130434782609, 1.6, 0.30555555555556
79955, 0.41304347826087, 1.6, 0.33333333333333
79956, 0.39130434782609, 1.575, 0.33333333333333
79957, 0.39130434782609, 1.6, 0.36111111111111
79958, 0.41304347826087, 1.6, 0.38888888888889
79959, 0.39130434782609, 1.575, 0.38888888888889
79960, 0.39130434782609, 1.6, 0.41666666666667
79961, 0.41304347826087, 1.6, 0.44444444444444
79962, 0.39130434782609, 1.575, 0.44444444444444
79963, 0.39130434782609, 1.6, 0.47222222222222
79964, 0.34782608695652, 1.6, 0.027777777777778
79965, 0.3695652173913, 1.6, 0.055555555555556
79966, 0.34782608695652, 1.575, 0.055555555555556
79967, 0.34782608695652, 1.6, 0.083333333333333
79968, 0.3695652173913, 1.6, 0.11111111111111
79969, 0.34782608695652, 1.575, 0.11111111111111
79970, 0.34782608695652, 1.6, 0.13888888888889
79971, 0.3695652173913, 1.6, 0.16666666666667
79972, 0.34782608695652, 1.575, 0.16666666666667
79973, 0.34782608695652, 1.6, 0.19444444444444
79974, 0.3695652173913, 1.6, 0.22222222222222
79975, 0.34782608695652, 1.575, 0.22222222222222
79976, 0.34782608695652, 1.6, 0.25
79977, 0.3695652173913, 1.6, 0.27777777777778
79978, 0.34782608695652, 1.575, 0.27777777777778
79979, 0.34782608695652, 1.6, 0.30555555555556
79980, 0.3695652173913, 1.6, 0.33333333333333
79981, 0.34782608695652, 1.575, 0.33333333333333
79982, 0.34782608695652, 1.6, 0.36111111111111
79983, 0.3695652173913, 1.6, 0.38888888888889
79984, 0.34782608695652, 1.575, 0.38888888888889
79985, 0.34782608695652, 1.6, 0.41666666666667
79986, 0.3695652173913, 1.6, 0.44444444444444
79987, 0.34782608695652, 1.575, 0.44444444444444
79988, 0.34782608695652, 1.6, 0.47222222222222
79989, 0.30434782608696, 1.6, 0.027777777777778
79990, 0.32608695652174, 1.6, 0.055555555555556
79991, 0.30434782608696, 1.575, 0.055555555555556
79992, 0.30434782608696, 1.6, 0.083333333333333
79993, 0.32608695652174, 1.6, 0.11111111111111
79994, 0.30434782608696, 1.575, 0.11111111111111
79995, 0.30434782608696, 1.6, 0.13888888888889
79996, 0.32608695652174, 1.6, 0.16666666666667
79997, 0.30434782608696, 1.575, 0.16666666666667
79998, 0.30434782608696, 1.6, 0.19444444444444
79999, 0.32608695652174, 1.6, 0.22222222222222
80000, 0.30434782608696, 1.575, 0.22222222222222
80001, 0.30434782608696, 1.6, 0.25
80002, 0.32608695652174, 1.6, 0.27777777777778
80003, 0.30434782608696, 1.575, 0.27777777777778
80004, 0.30434782608696, 1.6, 0.30555555555556
80005, 0.32608695652174, 1.6, 0.33333333333333
80006, 0.30434782608696, 1.575, 0.33333333333333
80007, 0.30434782608696, 1.6, 0.36111111111111
80008, 0.32608695652174, 1.6, 0.38888888888889
80009, 0.30434782608696, 1.575, 0.38888888888889
80010, 0.30434782608696, 1.6, 0.41666666666667
80011, 0.32608695652174, 1.6, 0.44444444444444
80012, 0.30434782608696, 1.575, 0.44444444444444
80013, 0.30434782608696, 1.6, 0.47222222222222
80014, 0.26086956521739, 1.6, 0.027777777777778
80015, 0.28260869565217, 1.6, 0.055555555555556
80016, 0.26086956521739, 1.575, 0.055555555555556
80017, 0.26086956521739, 1.6, 0.083333333333333
80018, 0.28260869565217, 1.6, 0.11111111111111
80019, 0.26086956521739, 1.575, 0.11111111111111
80020, 0.26086956521739, 1.6, 0.13888888888889
80021, 0.28260869565217, 1.6, 0.16666666666667
80022, 0.26086956521739, 1.575, 0.16666666666667
80023, 0.26086956521739, 1.6, 0.19444444444444
80024, 0.28260869565217, 1.6, 0.22222222222222
80025, 0.26086956521739, 1.575, 0.22222222222222
80026, 0.26086956521739, 1.6, 0.25
80027, 0.28260869565217, 1.6, 0.27777777777778
80028, 0.26086956521739, 1.575, 0.27777777777778
80029, 0.26086956521739, 1.6, 0.30555555555556
80030, 0.28260869565217, 1.6, 0.33333333333333
80031, 0.26086956521739, 1.575, 0.33333333333333
80032, 0.26086956521739, 1.6, 0.36111111111111
80033, 0.28260869565217, 1.6, 0.38888888888889
80034, 0.26086956521739, 1.575, 0.38888888888889
80035, 0.26086956521739, 1.6, 0.41666666666667
80036, 0.28260869565217, 1.6, 0.44444444444444
80037, 0.26086956521739, 1.575, 0.44444444444444
80038, 0.26086956521739, 1.6, 0.47222222222222
80039, 0.21739130434783, 1.6, 0.027777777777778
80040, 0.23913043478261, 1.6, 0.055555555555556
80041, 0.21739130434783, 1.575, 0.055555555555556
80042, 0.21739130434783, 1.6, 0.083333333333333
80043, 0.23913043478261, 1.6, 0.11111111111111
80044, 0.21739130434783, 1.575, 0.11111111111111
80045, 0.21739130434783, 1.6, 0.13888888888889
80046, 0.23913043478261, 1.6, 0.16666666666667
80047, 0.21739130434783, 1.575, 0.16666666666667
80048, 0.21739130434783, 1.6, 0.19444444444444
80049, 0.23913043478261, 1.6, 0.22222222222222
80050, 0.21739130434783, 1.575, 0.22222222222222
80051, 0.21739130434783, 1.6, 0.25
80052, 0.23913043478261, 1.6, 0.27777777777778
80053, 0.21739130434783, 1.575, 0.27777777777778
80054, 0.21739130434783, 1.6, 0.30555555555556
80055, 0.23913043478261, 1.6, 0.33333333333333
80056, 0.21739130434783, 1.575, 0.33333333333333
80057, 0.21739130434783, 1.6, 0.36111111111111
80058, 0.23913043478261, 1.6, 0.38888888888889
80059, 0.21739130434783, 1.575, 0.38888888888889
80060, 0.21739130434783, 1.6, 0.41666666666667
80061, 0.23913043478261, 1.6, 0.44444444444444
80062, 0.21739130434783, 1.575, 0.44444444444444
80063, 0.21739130434783, 1.6, 0.47222222222222
80064, 0.17391304347826, 1.6, 0.027777777777778
80065, 0.19565217391304, 1.6, 0.055555555555556
80066, 0.17391304347826, 1.575, 0.055555555555556
80067, 0.17391304347826, 1.6, 0.083333333333333
80068, 0.19565217391304, 1.6, 0.11111111111111
80069, 0.17391304347826, 1.575, 0.11111111111111
80070, 0.17391304347826, 1.6, 0.13888888888889
80071, 0.19565217391304, 1.6, 0.16666666666667
80072, 0.17391304347826, 1.575, 0.16666666666667
80073, 0.17391304347826, 1.6, 0.19444444444444
80074, 0.19565217391304, 1.6, 0.22222222222222
80075, 0.17391304347826, 1.575, 0.22222222222222
80076, 0.17391304347826, 1.6, 0.25
80077, 0.19565217391304, 1.6, 0.27777777777778
80078, 0.17391304347826, 1.575, 0.27777777777778
80079, 0.17391304347826, 1.6, 0.30555555555556
80080, 0.19565217391304, 1.6, 0.33333333333333
80081, 0.17391304347826, 1.575, 0.33333333333333
80082, 0.17391304347826, 1.6, 0.36111111111111
80083, 0.19565217391304, 1.6, 0.38888888888889
80084, 0.17391304347826, 1.575, 0.38888888888889
80085, 0.17391304347826, 1.6, 0.41666666666667
80086, 0.19565217391304, 1.6, 0.44444444444444
80087, 0.17391304347826, 1.575, 0.44444444444444
80088, 0.17391304347826, 1.6, 0.47222222222222
80089, 0.1304347826087, 1.6, 0.027777777777778
80090, 0.15217391304348, 1.6, 0.055555555555556
80091, 0.1304347826087, 1.575, 0.055555555555556
80092, 0.1304347826087, 1.6, 0.083333333333333
80093, 0.15217391304348, 1.6, 0.11111111111111
80094, 0.1304347826087, 1.575, 0.11111111111111
80095, 0.1304347826087, 1.6, 0.13888888888889
80096, 0.15217391304348, 1.6, 0.16666666666667
80097, 0.1304347826087, 1.575, 0.16666666666667
80098, 0.1304347826087, 1.6, 0.19444444444444
80099, 0.15217391304348, 1.6, 0.22222222222222
80100, 0.1304347826087, 1.575, 0.22222222222222
80101, 0.1304347826087, 1.6, 0.25
80102, 0.15217391304348, 1.6, 0.27777777777778
80103, 0.1304347826087, 1.575, 0.27777777777778
80104, 0.1304347826087, 1.6, 0.30555555555556
80105, 0.15217391304348, 1.6, 0.33333333333333
80106, 0.1304347826087, 1.575, 0.33333333333333
80107, 0.1304347826087, 1.6, 0.36111111111111
80108, 0.15217391304348, 1.6, 0.38888888888889
80109, 0.1304347826087, 1.575, 0.38888888888889
80110, 0.1304347826087, 1.6, 0.41666666666667
80111, 0.15217391304348, 1.6, 0.44444444444444
80112, 0.1304347826087, 1.575, 0.44444444444444
80113, 0.1304347826087, 1.6, 0.47222222222222
80114, 0.08695652173913, 1.6, 0.027777777777778
80115, 0.10869565217391, 1.6, 0.055555555555556
80116, 0.08695652173913, 1.575, 0.055555555555556
80117, 0.08695652173913, 1.6, 0.083333333333333
80118, 0.10869565217391, 1.6, 0.11111111111111
80119, 0.08695652173913, 1.575, 0.11111111111111
80120, 0.08695652173913, 1.6, 0.13888888888889
80121, 0.10869565217391, 1.6, 0.16666666666667
80122, 0.08695652173913, 1.575, 0.16666666666667
80123, 0.08695652173913, 1.6, 0.19444444444444
80124, 0.10869565217391, 1.6, 0.22222222222222
80125, 0.08695652173913, 1.575, 0.22222222222222
80126, 0.08695652173913, 1.6, 0.25
80127, 0.10869565217391, 1.6, 0.27777777777778
80128, 0.08695652173913, 1.575, 0.27777777777778
80129, 0.08695652173913, 1.6, 0.30555555555556
80130, 0.10869565217391, 1.6, 0.33333333333333
80131, 0.08695652173913, 1.575, 0.33333333333333
80132, 0.08695652173913, 1.6, 0.36111111111111
80133, 0.10869565217391, 1.6, 0.38888888888889
80134, 0.08695652173913, 1.575, 0.38888888888889
80135, 0.08695652173913, 1.6, 0.41666666666667
80136, 0.10869565217391, 1.6, 0.44444444444444
80137, 0.08695652173913, 1.575, 0.44444444444444
80138, 0.08695652173913, 1.6, 0.47222222222222
80139, 0.043478260869565, 1.6, 0.027777777777778
80140, 0.065217391304348, 1.6, 0.055555555555556
80141, 0.043478260869565, 1.575, 0.055555555555556
80142, 0.043478260869565, 1.6, 0.083333333333333
80143, 0.065217391304348, 1.6, 0.11111111111111
80144, 0.043478260869565, 1.575, 0.11111111111111
80145, 0.043478260869565, 1.6, 0.13888888888889
80146, 0.065217391304348, 1.6, 0.16666666666667
80147, 0.043478260869565, 1.575, 0.16666666666667
80148, 0.043478260869565, 1.6, 0.19444444444444
80149, 0.065217391304348, 1.6, 0.22222222222222
80150, 0.043478260869565, 1.575, 0.22222222222222
80151, 0.043478260869565, 1.6, 0.25
80152, 0.065217391304348, 1.6, 0.27777777777778
80153, 0.043478260869565, 1.575, 0.27777777777778
80154, 0.043478260869565, 1.6, 0.30555555555556
80155, 0.065217391304348, 1.6, 0.33333333333333
80156, 0.043478260869565, 1.575, 0.33333333333333
80157, 0.043478260869565, 1.6, 0.36111111111111
80158, 0.065217391304348, 1.6, 0.38888888888889
80159, 0.043478260869565, 1.575, 0.38888888888889
80160, 0.043478260869565, 1.6, 0.41666666666667
80161, 0.065217391304348, 1.6, 0.44444444444444
80162, 0.043478260869565, 1.575, 0.44444444444444
80163, 0.043478260869565, 1.6, 0.47222222222222
80164, 0.021739130434783, 1.6, 0.055555555555556
80165, 0.021739130434783, 1.6, 0.11111111111111
80166, 0.021739130434783, 1.6, 0.16666666666667
80167, 0.021739130434783, 1.6, 0.22222222222222
80168, 0.021739130434783, 1.6, 0.27777777777778
80169, 0.021739130434783, 1.6, 0.33333333333333
80170, 0.021739130434783, 1.6, 0.38888888888889
80171, 0.021739130434783, 1.6, 0.44444444444444
80172, 0.95652173913043, 1.65, 0.027777777777778
80173, 0.97826086956522, 1.65, 0.055555555555556
80174, 0.95652173913043, 1.625, 0.055555555555556
80175, 0.95652173913043, 1.65, 0.083333333333333
80176, 0.97826086956522, 1.65, 0.11111111111111
80177, 0.95652173913044, 1.625, 0.11111111111111
80178, 0.95652173913044, 1.65, 0.13888888888889
80179, 0.97826086956522, 1.65, 0.16666666666667
80180, 0.95652173913044, 1.625, 0.16666666666667
80181, 0.95652173913044, 1.65, 0.19444444444444
80182, 0.97826086956522, 1.65, 0.22222222222222
80183, 0.95652173913044, 1.625, 0.22222222222222
80184, 0.95652173913044, 1.65, 0.25
80185, 0.97826086956522, 1.65, 0.27777777777778
80186, 0.95652173913044, 1.625, 0.27777777777778
80187, 0.95652173913044, 1.65, 0.30555555555556
80188, 0.97826086956522, 1.65, 0.33333333333333
80189, 0.95652173913044, 1.625, 0.33333333333333
80190, 0.95652173913044, 1.65, 0.36111111111111
80191, 0.97826086956522, 1.65, 0.38888888888889
80192, 0.95652173913043, 1.625, 0.38888888888889
80193, 0.95652173913044, 1.65, 0.41666666666667
80194, 0.97826086956522, 1.65, 0.44444444444444
80195, 0.95652173913044, 1.625, 0.44444444444444
80196, 0.95652173913043, 1.65, 0.47222222222222
80197, 0.91304347826087, 1.65, 0.027777777777778
80198, 0.93478260869565, 1.65, 0.055555555555556
80199, 0.91304347826087, 1.625, 0.055555555555556
80200, 0.91304347826087, 1.65, 0.083333333333333
80201, 0.93478260869565, 1.65, 0.11111111111111
80202, 0.91304347826087, 1.625, 0.11111111111111
80203, 0.91304347826087, 1.65, 0.13888888888889
80204, 0.93478260869565, 1.65, 0.16666666666667
80205, 0.91304347826087, 1.625, 0.16666666666667
80206, 0.91304347826087, 1.65, 0.19444444444444
80207, 0.93478260869565, 1.65, 0.22222222222222
80208, 0.91304347826087, 1.625, 0.22222222222222
80209, 0.91304347826087, 1.65, 0.25
80210, 0.93478260869565, 1.65, 0.27777777777778
80211, 0.91304347826087, 1.625, 0.27777777777778
80212, 0.91304347826087, 1.65, 0.30555555555556
80213, 0.93478260869565, 1.65, 0.33333333333333
80214, 0.91304347826087, 1.625, 0.33333333333333
80215, 0.91304347826087, 1.65, 0.36111111111111
80216, 0.93478260869565, 1.65, 0.38888888888889
80217, 0.91304347826087, 1.625, 0.38888888888889
80218, 0.91304347826087, 1.65, 0.41666666666667
80219, 0.93478260869565, 1.65, 0.44444444444444
80220, 0.91304347826087, 1.625, 0.44444444444444
80221, 0.91304347826087, 1.65, 0.47222222222222
80222, 0.8695652173913, 1.65, 0.027777777777778
80223, 0.89130434782609, 1.65, 0.055555555555556
80224, 0.8695652173913, 1.625, 0.055555555555556
80225, 0.8695652173913, 1.65, 0.083333333333333
80226, 0.89130434782609, 1.65, 0.11111111111111
80227, 0.8695652173913, 1.625, 0.11111111111111
80228, 0.8695652173913, 1.65, 0.13888888888889
80229, 0.89130434782609, 1.65, 0.16666666666667
80230, 0.8695652173913, 1.625, 0.16666666666667
80231, 0.8695652173913, 1.65, 0.19444444444444
80232, 0.89130434782609, 1.65, 0.22222222222222
80233, 0.8695652173913, 1.625, 0.22222222222222
80234, 0.8695652173913, 1.65, 0.25
80235, 0.89130434782609, 1.65, 0.27777777777778
80236, 0.8695652173913, 1.625, 0.27777777777778
80237, 0.8695652173913, 1.65, 0.30555555555556
80238, 0.89130434782609, 1.65, 0.33333333333333
80239, 0.8695652173913, 1.625, 0.33333333333333
80240, 0.8695652173913, 1.65, 0.36111111111111
80241, 0.89130434782609, 1.65, 0.38888888888889
80242, 0.8695652173913, 1.625, 0.38888888888889
80243, 0.8695652173913, 1.65, 0.41666666666667
80244, 0.89130434782609, 1.65, 0.44444444444444
80245, 0.8695652173913, 1.625, 0.44444444444444
80246, 0.8695652173913, 1.65, 0.47222222222222
80247, 0.82608695652174, 1.65, 0.027777777777778
80248, 0.84782608695652, 1.65, 0.055555555555556
80249, 0.82608695652174, 1.625, 0.055555555555556
80250, 0.82608695652174, 1.65, 0.083333333333333
80251, 0.84782608695652, 1.65, 0.11111111111111
80252, 0.82608695652174, 1.625, 0.11111111111111
80253, 0.82608695652174, 1.65, 0.13888888888889
80254, 0.84782608695652, 1.65, 0.16666666666667
80255, 0.82608695652174, 1.625, 0.16666666666667
80256, 0.82608695652174, 1.65, 0.19444444444444
80257, 0.84782608695652, 1.65, 0.22222222222222
80258, 0.82608695652174, 1.625, 0.22222222222222
80259, 0.82608695652174, 1.65, 0.25
80260, 0.84782608695652, 1.65, 0.27777777777778
80261, 0.82608695652174, 1.625, 0.27777777777778
80262, 0.82608695652174, 1.65, 0.30555555555556
80263, 0.84782608695652, 1.65, 0.33333333333333
80264, 0.82608695652174, 1.625, 0.33333333333333
80265, 0.82608695652174, 1.65, 0.36111111111111
80266, 0.84782608695652, 1.65, 0.38888888888889
80267, 0.82608695652174, 1.625, 0.38888888888889
80268, 0.82608695652174, 1.65, 0.41666666666667
80269, 0.84782608695652, 1.65, 0.44444444444444
80270, 0.82608695652174, 1.625, 0.44444444444444
80271, 0.82608695652174, 1.65, 0.47222222222222
80272, 0.78260869565217, 1.65, 0.027777777777778
80273, 0.80434782608696, 1.65, 0.055555555555556
80274, 0.78260869565217, 1.625, 0.055555555555556
80275, 0.78260869565217, 1.65, 0.083333333333333
80276, 0.80434782608696, 1.65, 0.11111111111111
80277, 0.78260869565217, 1.625, 0.11111111111111
80278, 0.78260869565217, 1.65, 0.13888888888889
80279, 0.80434782608696, 1.65, 0.16666666666667
80280, 0.78260869565217, 1.625, 0.16666666666667
80281, 0.78260869565217, 1.65, 0.19444444444444
80282, 0.80434782608696, 1.65, 0.22222222222222
80283, 0.78260869565217, 1.625, 0.22222222222222
80284, 0.78260869565217, 1.65, 0.25
80285, 0.80434782608696, 1.65, 0.27777777777778
80286, 0.78260869565217, 1.625, 0.27777777777778
80287, 0.78260869565217, 1.65, 0.30555555555556
80288, 0.80434782608696, 1.65, 0.33333333333333
80289, 0.78260869565217, 1.625, 0.33333333333333
80290, 0.78260869565217, 1.65, 0.36111111111111
80291, 0.80434782608696, 1.65, 0.38888888888889
80292, 0.78260869565217, 1.625, 0.38888888888889
80293, 0.78260869565217, 1.65, 0.41666666666667
80294, 0.80434782608696, 1.65, 0.44444444444444
80295, 0.78260869565217, 1.625, 0.44444444444444
80296, 0.78260869565217, 1.65, 0.47222222222222
80297, 0.73913043478261, 1.65, 0.027777777777778
80298, 0.76086956521739, 1.65, 0.055555555555556
80299, 0.73913043478261, 1.625, 0.055555555555556
80300, 0.73913043478261, 1.65, 0.083333333333333
80301, 0.76086956521739, 1.65, 0.11111111111111
80302, 0.73913043478261, 1.625, 0.11111111111111
80303, 0.73913043478261, 1.65, 0.13888888888889
80304, 0.76086956521739, 1.65, 0.16666666666667
80305, 0.73913043478261, 1.625, 0.16666666666667
80306, 0.73913043478261, 1.65, 0.19444444444444
80307, 0.76086956521739, 1.65, 0.22222222222222
80308, 0.73913043478261, 1.625, 0.22222222222222
80309, 0.73913043478261, 1.65, 0.25
80310, 0.76086956521739, 1.65, 0.27777777777778
80311, 0.73913043478261, 1.625, 0.27777777777778
80312, 0.73913043478261, 1.65, 0.30555555555556
80313, 0.76086956521739, 1.65, 0.33333333333333
80314, 0.73913043478261, 1.625, 0.33333333333333
80315, 0.73913043478261, 1.65, 0.36111111111111
80316, 0.76086956521739, 1.65, 0.38888888888889
80317, 0.73913043478261, 1.625, 0.38888888888889
80318, 0.73913043478261, 1.65, 0.41666666666667
80319, 0.76086956521739, 1.65, 0.44444444444444
80320, 0.73913043478261, 1.625, 0.44444444444444
80321, 0.73913043478261, 1.65, 0.47222222222222
80322, 0.69565217391304, 1.65, 0.027777777777778
80323, 0.71739130434783, 1.65, 0.055555555555556
80324, 0.69565217391304, 1.625, 0.055555555555556
80325, 0.69565217391304, 1.65, 0.083333333333333
80326, 0.71739130434783, 1.65, 0.11111111111111
80327, 0.69565217391304, 1.625, 0.11111111111111
80328, 0.69565217391304, 1.65, 0.13888888888889
80329, 0.71739130434783, 1.65, 0.16666666666667
80330, 0.69565217391304, 1.625, 0.16666666666667
80331, 0.69565217391304, 1.65, 0.19444444444444
80332, 0.71739130434783, 1.65, 0.22222222222222
80333, 0.69565217391304, 1.625, 0.22222222222222
80334, 0.69565217391304, 1.65, 0.25
80335, 0.71739130434783, 1.65, 0.27777777777778
80336, 0.69565217391304, 1.625, 0.27777777777778
80337, 0.69565217391304, 1.65, 0.30555555555556
80338, 0.71739130434783, 1.65, 0.33333333333333
80339, 0.69565217391304, 1.625, 0.33333333333333
80340, 0.69565217391304, 1.65, 0.36111111111111
80341, 0.71739130434783, 1.65, 0.38888888888889
80342, 0.69565217391304, 1.625, 0.38888888888889
80343, 0.69565217391304, 1.65, 0.41666666666667
80344, 0.71739130434783, 1.65, 0.44444444444444
80345, 0.69565217391304, 1.625, 0.44444444444444
80346, 0.69565217391304, 1.65, 0.47222222222222
80347, 0.65217391304348, 1.65, 0.027777777777778
80348, 0.67391304347826, 1.65, 0.055555555555556
80349, 0.65217391304348, 1.625, 0.055555555555556
80350, 0.65217391304348, 1.65, 0.083333333333333
80351, 0.67391304347826, 1.65, 0.11111111111111
80352, 0.65217391304348, 1.625, 0.11111111111111
80353, 0.65217391304348, 1.65, 0.13888888888889
80354, 0.67391304347826, 1.65, 0.16666666666667
80355, 0.65217391304348, 1.625, 0.16666666666667
80356, 0.65217391304348, 1.65, 0.19444444444444
80357, 0.67391304347826, 1.65, 0.22222222222222
80358, 0.65217391304348, 1.625, 0.22222222222222
80359, 0.65217391304348, 1.65, 0.25
80360, 0.67391304347826, 1.65, 0.27777777777778
80361, 0.65217391304348, 1.625, 0.27777777777778
80362, 0.65217391304348, 1.65, 0.30555555555556
80363, 0.67391304347826, 1.65, 0.33333333333333
80364, 0.65217391304348, 1.625, 0.33333333333333
80365, 0.65217391304348, 1.65, 0.36111111111111
80366, 0.67391304347826, 1.65, 0.38888888888889
80367, 0.65217391304348, 1.625, 0.38888888888889
80368, 0.65217391304348, 1.65, 0.41666666666667
80369, 0.67391304347826, 1.65, 0.44444444444444
80370, 0.65217391304348, 1.625, 0.44444444444444
80371, 0.65217391304348, 1.65, 0.47222222222222
80372, 0.60869565217391, 1.65, 0.027777777777778
80373, 0.6304347826087, 1.65, 0.055555555555556
80374, 0.60869565217391, 1.625, 0.055555555555556
80375, 0.60869565217391, 1.65, 0.083333333333333
80376, 0.6304347826087, 1.65, 0.11111111111111
80377, 0.60869565217391, 1.625, 0.11111111111111
80378, 0.60869565217391, 1.65, 0.13888888888889
80379, 0.6304347826087, 1.65, 0.16666666666667
80380, 0.60869565217391, 1.625, 0.16666666666667
80381, 0.60869565217391, 1.65, 0.19444444444444
80382, 0.6304347826087, 1.65, 0.22222222222222
80383, 0.60869565217391, 1.625, 0.22222222222222
80384, 0.60869565217391, 1.65, 0.25
80385, 0.6304347826087, 1.65, 0.27777777777778
80386, 0.60869565217391, 1.625, 0.27777777777778
80387, 0.60869565217391, 1.65, 0.30555555555556
80388, 0.6304347826087, 1.65, 0.33333333333333
80389, 0.60869565217391, 1.625, 0.33333333333333
80390, 0.60869565217391, 1.65, 0.36111111111111
80391, 0.6304347826087, 1.65, 0.38888888888889
80392, 0.60869565217391, 1.625, 0.38888888888889
80393, 0.60869565217391, 1.65, 0.41666666666667
80394, 0.6304347826087, 1.65, 0.44444444444444
80395, 0.60869565217391, 1.625, 0.44444444444444
80396, 0.60869565217391, 1.65, 0.47222222222222
80397, 0.56521739130435, 1.65, 0.027777777777778
80398, 0.58695652173913, 1.65, 0.055555555555556
80399, 0.56521739130435, 1.625, 0.055555555555556
80400, 0.56521739130435, 1.65, 0.083333333333333
80401, 0.58695652173913, 1.65, 0.11111111111111
80402, 0.56521739130435, 1.625, 0.11111111111111
80403, 0.56521739130435, 1.65, 0.13888888888889
80404, 0.58695652173913, 1.65, 0.16666666666667
80405, 0.56521739130435, 1.625, 0.16666666666667
80406, 0.56521739130435, 1.65, 0.19444444444444
80407, 0.58695652173913, 1.65, 0.22222222222222
80408, 0.56521739130435, 1.625, 0.22222222222222
80409, 0.56521739130435, 1.65, 0.25
80410, 0.58695652173913, 1.65, 0.27777777777778
80411, 0.56521739130435, 1.625, 0.27777777777778
80412, 0.56521739130435, 1.65, 0.30555555555556
80413, 0.58695652173913, 1.65, 0.33333333333333
80414, 0.56521739130435, 1.625, 0.33333333333333
80415, 0.56521739130435, 1.65, 0.36111111111111
80416, 0.58695652173913, 1.65, 0.38888888888889
80417, 0.56521739130435, 1.625, 0.38888888888889
80418, 0.56521739130435, 1.65, 0.41666666666667
80419, 0.58695652173913, 1.65, 0.44444444444444
80420, 0.56521739130435, 1.625, 0.44444444444444
80421, 0.56521739130435, 1.65, 0.47222222222222
80422, 0.52173913043478, 1.65, 0.027777777777778
80423, 0.54347826086957, 1.65, 0.055555555555556
80424, 0.52173913043478, 1.625, 0.055555555555556
80425, 0.52173913043478, 1.65, 0.083333333333333
80426, 0.54347826086956, 1.65, 0.11111111111111
80427, 0.52173913043478, 1.625, 0.11111111111111
80428, 0.52173913043478, 1.65, 0.13888888888889
80429, 0.54347826086956, 1.65, 0.16666666666667
80430, 0.52173913043478, 1.625, 0.16666666666667
80431, 0.52173913043478, 1.65, 0.19444444444444
80432, 0.54347826086956, 1.65, 0.22222222222222
80433, 0.52173913043478, 1.625, 0.22222222222222
80434, 0.52173913043478, 1.65, 0.25
80435, 0.54347826086956, 1.65, 0.27777777777778
80436, 0.52173913043478, 1.625, 0.27777777777778
80437, 0.52173913043478, 1.65, 0.30555555555556
80438, 0.54347826086956, 1.65, 0.33333333333333
80439, 0.52173913043478, 1.625, 0.33333333333333
80440, 0.52173913043478, 1.65, 0.36111111111111
80441, 0.54347826086956, 1.65, 0.38888888888889
80442, 0.52173913043478, 1.625, 0.38888888888889
80443, 0.52173913043478, 1.65, 0.41666666666667
80444, 0.54347826086956, 1.65, 0.44444444444444
80445, 0.52173913043478, 1.625, 0.44444444444444
80446, 0.52173913043478, 1.65, 0.47222222222222
80447, 0.47826086956522, 1.65, 0.027777777777778
80448, 0.5, 1.65, 0.055555555555556
80449, 0.47826086956522, 1.625, 0.055555555555556
80450, 0.47826086956522, 1.65, 0.083333333333333
80451, 0.5, 1.65, 0.11111111111111
80452, 0.47826086956522, 1.625, 0.11111111111111
80453, 0.47826086956522, 1.65, 0.13888888888889
80454, 0.5, 1.65, 0.16666666666667
80455, 0.47826086956522, 1.625, 0.16666666666667
80456, 0.47826086956522, 1.65, 0.19444444444444
80457, 0.5, 1.65, 0.22222222222222
80458, 0.47826086956522, 1.625, 0.22222222222222
80459, 0.47826086956522, 1.65, 0.25
80460, 0.5, 1.65, 0.27777777777778
80461, 0.47826086956522, 1.625, 0.27777777777778
80462, 0.47826086956522, 1.65, 0.30555555555556
80463, 0.5, 1.65, 0.33333333333333
80464, 0.47826086956522, 1.625, 0.33333333333333
80465, 0.47826086956522, 1.65, 0.36111111111111
80466, 0.5, 1.65, 0.38888888888889
80467, 0.47826086956522, 1.625, 0.38888888888889
80468, 0.47826086956522, 1.65, 0.41666666666667
80469, 0.5, 1.65, 0.44444444444444
80470, 0.47826086956522, 1.625, 0.44444444444444
80471, 0.47826086956522, 1.65, 0.47222222222222
80472, 0.43478260869565, 1.65, 0.027777777777778
80473, 0.45652173913043, 1.65, 0.055555555555556
80474, 0.43478260869565, 1.625, 0.055555555555556
80475, 0.43478260869565, 1.65, 0.083333333333333
80476, 0.45652173913043, 1.65, 0.11111111111111
80477, 0.43478260869565, 1.625, 0.11111111111111
80478, 0.43478260869565, 1.65, 0.13888888888889
80479, 0.45652173913043, 1.65, 0.16666666666667
80480, 0.43478260869565, 1.625, 0.16666666666667
80481, 0.43478260869565, 1.65, 0.19444444444444
80482, 0.45652173913043, 1.65, 0.22222222222222
80483, 0.43478260869565, 1.625, 0.22222222222222
80484, 0.43478260869565, 1.65, 0.25
80485, 0.45652173913043, 1.65, 0.27777777777778
80486, 0.43478260869565, 1.625, 0.27777777777778
80487, 0.43478260869565, 1.65, 0.30555555555556
80488, 0.45652173913043, 1.65, 0.33333333333333
80489, 0.43478260869565, 1.625, 0.33333333333333
80490, 0.43478260869565, 1.65, 0.36111111111111
80491, 0.45652173913044, 1.65, 0.38888888888889
80492, 0.43478260869565, 1.625, 0.38888888888889
80493, 0.43478260869565, 1.65, 0.41666666666667
80494, 0.45652173913043, 1.65, 0.44444444444444
80495, 0.43478260869565, 1.625, 0.44444444444444
80496, 0.43478260869565, 1.65, 0.47222222222222
80497, 0.39130434782609, 1.65, 0.027777777777778
80498, 0.41304347826087, 1.65, 0.055555555555556
80499, 0.39130434782609, 1.625, 0.055555555555556
80500, 0.39130434782609, 1.65, 0.083333333333333
80501, 0.41304347826087, 1.65, 0.11111111111111
80502, 0.39130434782609, 1.625, 0.11111111111111
80503, 0.39130434782609, 1.65, 0.13888888888889
80504, 0.41304347826087, 1.65, 0.16666666666667
80505, 0.39130434782609, 1.625, 0.16666666666667
80506, 0.39130434782609, 1.65, 0.19444444444444
80507, 0.41304347826087, 1.65, 0.22222222222222
80508, 0.39130434782609, 1.625, 0.22222222222222
80509, 0.39130434782609, 1.65, 0.25
80510, 0.41304347826087, 1.65, 0.27777777777778
80511, 0.39130434782609, 1.625, 0.27777777777778
80512, 0.39130434782609, 1.65, 0.30555555555556
80513, 0.41304347826087, 1.65, 0.33333333333333
80514, 0.39130434782609, 1.625, 0.33333333333333
80515, 0.39130434782609, 1.65, 0.36111111111111
80516, 0.41304347826087, 1.65, 0.38888888888889
80517, 0.39130434782609, 1.625, 0.38888888888889
80518, 0.39130434782609, 1.65, 0.41666666666667
80519, 0.41304347826087, 1.65, 0.44444444444444
80520, 0.39130434782609, 1.625, 0.44444444444444
80521, 0.39130434782609, 1.65, 0.47222222222222
80522, 0.34782608695652, 1.65, 0.027777777777778
80523, 0.3695652173913, 1.65, 0.055555555555556
80524, 0.34782608695652, 1.625, 0.055555555555556
80525, 0.34782608695652, 1.65, 0.083333333333333
80526, 0.3695652173913, 1.65, 0.11111111111111
80527, 0.34782608695652, 1.625, 0.11111111111111
80528, 0.34782608695652, 1.65, 0.13888888888889
80529, 0.3695652173913, 1.65, 0.16666666666667
80530, 0.34782608695652, 1.625, 0.16666666666667
80531, 0.34782608695652, 1.65, 0.19444444444444
80532, 0.3695652173913, 1.65, 0.22222222222222
80533, 0.34782608695652, 1.625, 0.22222222222222
80534, 0.34782608695652, 1.65, 0.25
80535, 0.3695652173913, 1.65, 0.27777777777778
80536, 0.34782608695652, 1.625, 0.27777777777778
80537, 0.34782608695652, 1.65, 0.30555555555556
80538, 0.3695652173913, 1.65, 0.33333333333333
80539, 0.34782608695652, 1.625, 0.33333333333333
80540, 0.34782608695652, 1.65, 0.36111111111111
80541, 0.3695652173913, 1.65, 0.38888888888889
80542, 0.34782608695652, 1.625, 0.38888888888889
80543, 0.34782608695652, 1.65, 0.41666666666667
80544, 0.3695652173913, 1.65, 0.44444444444444
80545, 0.34782608695652, 1.625, 0.44444444444444
80546, 0.34782608695652, 1.65, 0.47222222222222
80547, 0.30434782608696, 1.65, 0.027777777777778
80548, 0.32608695652174, 1.65, 0.055555555555556
80549, 0.30434782608696, 1.625, 0.055555555555556
80550, 0.30434782608696, 1.65, 0.083333333333333
80551, 0.32608695652174, 1.65, 0.11111111111111
80552, 0.30434782608696, 1.625, 0.11111111111111
80553, 0.30434782608696, 1.65, 0.13888888888889
80554, 0.32608695652174, 1.65, 0.16666666666667
80555, 0.30434782608696, 1.625, 0.16666666666667
80556, 0.30434782608696, 1.65, 0.19444444444444
80557, 0.32608695652174, 1.65, 0.22222222222222
80558, 0.30434782608696, 1.625, 0.22222222222222
80559, 0.30434782608696, 1.65, 0.25
80560, 0.32608695652174, 1.65, 0.27777777777778
80561, 0.30434782608696, 1.625, 0.27777777777778
80562, 0.30434782608696, 1.65, 0.30555555555556
80563, 0.32608695652174, 1.65, 0.33333333333333
80564, 0.30434782608696, 1.625, 0.33333333333333
80565, 0.30434782608696, 1.65, 0.36111111111111
80566, 0.32608695652174, 1.65, 0.38888888888889
80567, 0.30434782608696, 1.625, 0.38888888888889
80568, 0.30434782608696, 1.65, 0.41666666666667
80569, 0.32608695652174, 1.65, 0.44444444444444
80570, 0.30434782608696, 1.625, 0.44444444444444
80571, 0.30434782608696, 1.65, 0.47222222222222
80572, 0.26086956521739, 1.65, 0.027777777777778
80573, 0.28260869565217, 1.65, 0.055555555555556
80574, 0.26086956521739, 1.625, 0.055555555555556
80575, 0.26086956521739, 1.65, 0.083333333333333
80576, 0.28260869565217, 1.65, 0.11111111111111
80577, 0.26086956521739, 1.625, 0.11111111111111
80578, 0.26086956521739, 1.65, 0.13888888888889
80579, 0.28260869565217, 1.65, 0.16666666666667
80580, 0.26086956521739, 1.625, 0.16666666666667
80581, 0.26086956521739, 1.65, 0.19444444444444
80582, 0.28260869565217, 1.65, 0.22222222222222
80583, 0.26086956521739, 1.625, 0.22222222222222
80584, 0.26086956521739, 1.65, 0.25
80585, 0.28260869565217, 1.65, 0.27777777777778
80586, 0.26086956521739, 1.625, 0.27777777777778
80587, 0.26086956521739, 1.65, 0.30555555555556
80588, 0.28260869565217, 1.65, 0.33333333333333
80589, 0.26086956521739, 1.625, 0.33333333333333
80590, 0.26086956521739, 1.65, 0.36111111111111
80591, 0.28260869565217, 1.65, 0.38888888888889
80592, 0.26086956521739, 1.625, 0.38888888888889
80593, 0.26086956521739, 1.65, 0.41666666666667
80594, 0.28260869565217, 1.65, 0.44444444444444
80595, 0.26086956521739, 1.625, 0.44444444444444
80596, 0.26086956521739, 1.65, 0.47222222222222
80597, 0.21739130434783, 1.65, 0.027777777777778
80598, 0.23913043478261, 1.65, 0.055555555555556
80599, 0.21739130434783, 1.625, 0.055555555555556
80600, 0.21739130434783, 1.65, 0.083333333333333
80601, 0.23913043478261, 1.65, 0.11111111111111
80602, 0.21739130434783, 1.625, 0.11111111111111
80603, 0.21739130434783, 1.65, 0.13888888888889
80604, 0.23913043478261, 1.65, 0.16666666666667
80605, 0.21739130434783, 1.625, 0.16666666666667
80606, 0.21739130434783, 1.65, 0.19444444444444
80607, 0.23913043478261, 1.65, 0.22222222222222
80608, 0.21739130434783, 1.625, 0.22222222222222
80609, 0.21739130434783, 1.65, 0.25
80610, 0.23913043478261, 1.65, 0.27777777777778
80611, 0.21739130434783, 1.625, 0.27777777777778
80612, 0.21739130434783, 1.65, 0.30555555555556
80613, 0.23913043478261, 1.65, 0.33333333333333
80614, 0.21739130434783, 1.625, 0.33333333333333
80615, 0.21739130434783, 1.65, 0.36111111111111
80616, 0.23913043478261, 1.65, 0.38888888888889
80617, 0.21739130434783, 1.625, 0.38888888888889
80618, 0.21739130434783, 1.65, 0.41666666666667
80619, 0.23913043478261, 1.65, 0.44444444444444
80620, 0.21739130434783, 1.625, 0.44444444444444
80621, 0.21739130434783, 1.65, 0.47222222222222
80622, 0.17391304347826, 1.65, 0.027777777777778
80623, 0.19565217391304, 1.65, 0.055555555555556
80624, 0.17391304347826, 1.625, 0.055555555555556
80625, 0.17391304347826, 1.65, 0.083333333333333
80626, 0.19565217391304, 1.65, 0.11111111111111
80627, 0.17391304347826, 1.625, 0.11111111111111
80628, 0.17391304347826, 1.65, 0.13888888888889
80629, 0.19565217391304, 1.65, 0.16666666666667
80630, 0.17391304347826, 1.625, 0.16666666666667
80631, 0.17391304347826, 1.65, 0.19444444444444
80632, 0.19565217391304, 1.65, 0.22222222222222
80633, 0.17391304347826, 1.625, 0.22222222222222
80634, 0.17391304347826, 1.65, 0.25
80635, 0.19565217391304, 1.65, 0.27777777777778
80636, 0.17391304347826, 1.625, 0.27777777777778
80637, 0.17391304347826, 1.65, 0.30555555555556
80638, 0.19565217391304, 1.65, 0.33333333333333
80639, 0.17391304347826, 1.625, 0.33333333333333
80640, 0.17391304347826, 1.65, 0.36111111111111
80641, 0.19565217391304, 1.65, 0.38888888888889
80642, 0.17391304347826, 1.625, 0.38888888888889
80643, 0.17391304347826, 1.65, 0.41666666666667
80644, 0.19565217391304, 1.65, 0.44444444444444
80645, 0.17391304347826, 1.625, 0.44444444444444
80646, 0.17391304347826, 1.65, 0.47222222222222
80647, 0.1304347826087, 1.65, 0.027777777777778
80648, 0.15217391304348, 1.65, 0.055555555555556
80649, 0.1304347826087, 1.625, 0.055555555555556
80650, 0.1304347826087, 1.65, 0.083333333333333
80651, 0.15217391304348, 1.65, 0.11111111111111
80652, 0.1304347826087, 1.625, 0.11111111111111
80653, 0.1304347826087, 1.65, 0.13888888888889
80654, 0.15217391304348, 1.65, 0.16666666666667
80655, 0.1304347826087, 1.625, 0.16666666666667
80656, 0.1304347826087, 1.65, 0.19444444444444
80657, 0.15217391304348, 1.65, 0.22222222222222
80658, 0.1304347826087, 1.625, 0.22222222222222
80659, 0.1304347826087, 1.65, 0.25
80660, 0.15217391304348, 1.65, 0.27777777777778
80661, 0.1304347826087, 1.625, 0.27777777777778
80662, 0.1304347826087, 1.65, 0.30555555555556
80663, 0.15217391304348, 1.65, 0.33333333333333
80664, 0.1304347826087, 1.625, 0.33333333333333
80665, 0.1304347826087, 1.65, 0.36111111111111
80666, 0.15217391304348, 1.65, 0.38888888888889
80667, 0.1304347826087, 1.625, 0.38888888888889
80668, 0.1304347826087, 1.65, 0.41666666666667
80669, 0.15217391304348, 1.65, 0.44444444444444
80670, 0.1304347826087, 1.625, 0.44444444444444
80671, 0.1304347826087, 1.65, 0.47222222222222
80672, 0.08695652173913, 1.65, 0.027777777777778
80673, 0.10869565217391, 1.65, 0.055555555555556
80674, 0.08695652173913, 1.625, 0.055555555555556
80675, 0.08695652173913, 1.65, 0.083333333333333
80676, 0.10869565217391, 1.65, 0.11111111111111
80677, 0.08695652173913, 1.625, 0.11111111111111
80678, 0.08695652173913, 1.65, 0.13888888888889
80679, 0.10869565217391, 1.65, 0.16666666666667
80680, 0.08695652173913, 1.625, 0.16666666666667
80681, 0.08695652173913, 1.65, 0.19444444444444
80682, 0.10869565217391, 1.65, 0.22222222222222
80683, 0.08695652173913, 1.625, 0.22222222222222
80684, 0.08695652173913, 1.65, 0.25
80685, 0.10869565217391, 1.65, 0.27777777777778
80686, 0.08695652173913, 1.625, 0.27777777777778
80687, 0.08695652173913, 1.65, 0.30555555555556
80688, 0.10869565217391, 1.65, 0.33333333333333
80689, 0.08695652173913, 1.625, 0.33333333333333
80690, 0.08695652173913, 1.65, 0.36111111111111
80691, 0.10869565217391, 1.65, 0.38888888888889
80692, 0.08695652173913, 1.625, 0.38888888888889
80693, 0.08695652173913, 1.65, 0.41666666666667
80694, 0.10869565217391, 1.65, 0.44444444444444
80695, 0.08695652173913, 1.625, 0.44444444444444
80696, 0.08695652173913, 1.65, 0.47222222222222
80697, 0.043478260869565, 1.65, 0.027777777777778
80698, 0.065217391304348, 1.65, 0.055555555555556
80699, 0.043478260869565, 1.625, 0.055555555555556
80700, 0.043478260869565, 1.65, 0.083333333333333
80701, 0.065217391304348, 1.65, 0.11111111111111
80702, 0.043478260869565, 1.625, 0.11111111111111
80703, 0.043478260869565, 1.65, 0.13888888888889
80704, 0.065217391304348, 1.65, 0.16666666666667
80705, 0.043478260869565, 1.625, 0.16666666666667
80706, 0.043478260869565, 1.65, 0.19444444444444
80707, 0.065217391304348, 1.65, 0.22222222222222
80708, 0.043478260869565, 1.625, 0.22222222222222
80709, 0.043478260869565, 1.65, 0.25
80710, 0.065217391304348, 1.65, 0.27777777777778
80711, 0.043478260869565, 1.625, 0.27777777777778
80712, 0.043478260869565, 1.65, 0.30555555555556
80713, 0.065217391304348, 1.65, 0.33333333333333
80714, 0.043478260869565, 1.625, 0.33333333333333
80715, 0.043478260869565, 1.65, 0.36111111111111
80716, 0.065217391304348, 1.65, 0.38888888888889
80717, 0.043478260869565, 1.625, 0.38888888888889
80718, 0.043478260869565, 1.65, 0.41666666666667
80719, 0.065217391304348, 1.65, 0.44444444444444
80720, 0.043478260869565, 1.625, 0.44444444444444
80721, 0.043478260869565, 1.65, 0.47222222222222
80722, 0.021739130434783, 1.65, 0.055555555555556
80723, 0.021739130434783, 1.65, 0.11111111111111
80724, 0.021739130434783, 1.65, 0.16666666666667
80725, 0.021739130434783, 1.65, 0.22222222222222
80726, 0.021739130434783, 1.65, 0.27777777777778
80727, 0.021739130434783, 1.65, 0.33333333333333
80728, 0.021739130434783, 1.65, 0.38888888888889
80729, 0.021739130434783, 1.65, 0.44444444444444
80730, 0.95652173913043, 1.7, 0.027777777777778
80731, 0.97826086956522, 1.7, 0.055555555555556
80732, 0.95652173913043, 1.675, 0.055555555555556
80733, 0.95652173913043, 1.7, 0.083333333333333
80734, 0.97826086956522, 1.7, 0.11111111111111
80735, 0.95652173913044, 1.675, 0.11111111111111
80736, 0.95652173913044, 1.7, 0.13888888888889
80737, 0.97826086956522, 1.7, 0.16666666666667
80738, 0.95652173913044, 1.675, 0.16666666666667
80739, 0.95652173913044, 1.7, 0.19444444444444
80740, 0.97826086956522, 1.7, 0.22222222222222
80741, 0.95652173913044, 1.675, 0.22222222222222
80742, 0.95652173913044, 1.7, 0.25
80743, 0.97826086956522, 1.7, 0.27777777777778
80744, 0.95652173913044, 1.675, 0.27777777777778
80745, 0.95652173913044, 1.7, 0.30555555555556
80746, 0.97826086956522, 1.7, 0.33333333333333
80747, 0.95652173913044, 1.675, 0.33333333333333
80748, 0.95652173913044, 1.7, 0.36111111111111
80749, 0.97826086956522, 1.7, 0.38888888888889
80750, 0.95652173913044, 1.675, 0.38888888888889
80751, 0.95652173913044, 1.7, 0.41666666666667
80752, 0.97826086956522, 1.7, 0.44444444444444
80753, 0.95652173913044, 1.675, 0.44444444444444
80754, 0.95652173913043, 1.7, 0.47222222222222
80755, 0.91304347826087, 1.7, 0.027777777777778
80756, 0.93478260869565, 1.7, 0.055555555555556
80757, 0.91304347826087, 1.675, 0.055555555555556
80758, 0.91304347826087, 1.7, 0.083333333333333
80759, 0.93478260869565, 1.7, 0.11111111111111
80760, 0.91304347826087, 1.675, 0.11111111111111
80761, 0.91304347826087, 1.7, 0.13888888888889
80762, 0.93478260869565, 1.7, 0.16666666666667
80763, 0.91304347826087, 1.675, 0.16666666666667
80764, 0.91304347826087, 1.7, 0.19444444444444
80765, 0.93478260869565, 1.7, 0.22222222222222
80766, 0.91304347826087, 1.675, 0.22222222222222
80767, 0.91304347826087, 1.7, 0.25
80768, 0.93478260869565, 1.7, 0.27777777777778
80769, 0.91304347826087, 1.675, 0.27777777777778
80770, 0.91304347826087, 1.7, 0.30555555555556
80771, 0.93478260869565, 1.7, 0.33333333333333
80772, 0.91304347826087, 1.675, 0.33333333333333
80773, 0.91304347826087, 1.7, 0.36111111111111
80774, 0.93478260869565, 1.7, 0.38888888888889
80775, 0.91304347826087, 1.675, 0.38888888888889
80776, 0.91304347826087, 1.7, 0.41666666666667
80777, 0.93478260869565, 1.7, 0.44444444444444
80778, 0.91304347826087, 1.675, 0.44444444444444
80779, 0.91304347826087, 1.7, 0.47222222222222
80780, 0.8695652173913, 1.7, 0.027777777777778
80781, 0.89130434782609, 1.7, 0.055555555555556
80782, 0.8695652173913, 1.675, 0.055555555555556
80783, 0.8695652173913, 1.7, 0.083333333333333
80784, 0.89130434782609, 1.7, 0.11111111111111
80785, 0.8695652173913, 1.675, 0.11111111111111
80786, 0.8695652173913, 1.7, 0.13888888888889
80787, 0.89130434782609, 1.7, 0.16666666666667
80788, 0.8695652173913, 1.675, 0.16666666666667
80789, 0.8695652173913, 1.7, 0.19444444444444
80790, 0.89130434782609, 1.7, 0.22222222222222
80791, 0.8695652173913, 1.675, 0.22222222222222
80792, 0.8695652173913, 1.7, 0.25
80793, 0.89130434782609, 1.7, 0.27777777777778
80794, 0.8695652173913, 1.675, 0.27777777777778
80795, 0.8695652173913, 1.7, 0.30555555555556
80796, 0.89130434782609, 1.7, 0.33333333333333
80797, 0.8695652173913, 1.675, 0.33333333333333
80798, 0.8695652173913, 1.7, 0.36111111111111
80799, 0.89130434782609, 1.7, 0.38888888888889
80800, 0.8695652173913, 1.675, 0.38888888888889
80801, 0.8695652173913, 1.7, 0.41666666666667
80802, 0.89130434782609, 1.7, 0.44444444444444
80803, 0.8695652173913, 1.675, 0.44444444444444
80804, 0.8695652173913, 1.7, 0.47222222222222
80805, 0.82608695652174, 1.7, 0.027777777777778
80806, 0.84782608695652, 1.7, 0.055555555555556
80807, 0.82608695652174, 1.675, 0.055555555555556
80808, 0.82608695652174, 1.7, 0.083333333333333
80809, 0.84782608695652, 1.7, 0.11111111111111
80810, 0.82608695652174, 1.675, 0.11111111111111
80811, 0.82608695652174, 1.7, 0.13888888888889
80812, 0.84782608695652, 1.7, 0.16666666666667
80813, 0.82608695652174, 1.675, 0.16666666666667
80814, 0.82608695652174, 1.7, 0.19444444444444
80815, 0.84782608695652, 1.7, 0.22222222222222
80816, 0.82608695652174, 1.675, 0.22222222222222
80817, 0.82608695652174, 1.7, 0.25
80818, 0.84782608695652, 1.7, 0.27777777777778
80819, 0.82608695652174, 1.675, 0.27777777777778
80820, 0.82608695652174, 1.7, 0.30555555555556
80821, 0.84782608695652, 1.7, 0.33333333333333
80822, 0.82608695652174, 1.675, 0.33333333333333
80823, 0.82608695652174, 1.7, 0.36111111111111
80824, 0.84782608695652, 1.7, 0.38888888888889
80825, 0.82608695652174, 1.675, 0.38888888888889
80826, 0.82608695652174, 1.7, 0.41666666666667
80827, 0.84782608695652, 1.7, 0.44444444444444
80828, 0.82608695652174, 1.675, 0.44444444444444
80829, 0.82608695652174, 1.7, 0.47222222222222
80830, 0.78260869565217, 1.7, 0.027777777777778
80831, 0.80434782608696, 1.7, 0.055555555555556
80832, 0.78260869565217, 1.675, 0.055555555555556
80833, 0.78260869565217, 1.7, 0.083333333333333
80834, 0.80434782608696, 1.7, 0.11111111111111
80835, 0.78260869565217, 1.675, 0.11111111111111
80836, 0.78260869565217, 1.7, 0.13888888888889
80837, 0.80434782608696, 1.7, 0.16666666666667
80838, 0.78260869565217, 1.675, 0.16666666666667
80839, 0.78260869565217, 1.7, 0.19444444444444
80840, 0.80434782608696, 1.7, 0.22222222222222
80841, 0.78260869565217, 1.675, 0.22222222222222
80842, 0.78260869565217, 1.7, 0.25
80843, 0.80434782608696, 1.7, 0.27777777777778
80844, 0.78260869565217, 1.675, 0.27777777777778
80845, 0.78260869565217, 1.7, 0.30555555555556
80846, 0.80434782608696, 1.7, 0.33333333333333
80847, 0.78260869565217, 1.675, 0.33333333333333
80848, 0.78260869565217, 1.7, 0.36111111111111
80849, 0.80434782608696, 1.7, 0.38888888888889
80850, 0.78260869565217, 1.675, 0.38888888888889
80851, 0.78260869565217, 1.7, 0.41666666666667
80852, 0.80434782608696, 1.7, 0.44444444444444
80853, 0.78260869565217, 1.675, 0.44444444444444
80854, 0.78260869565217, 1.7, 0.47222222222222
80855, 0.73913043478261, 1.7, 0.027777777777778
80856, 0.76086956521739, 1.7, 0.055555555555556
80857, 0.73913043478261, 1.675, 0.055555555555556
80858, 0.73913043478261, 1.7, 0.083333333333333
80859, 0.76086956521739, 1.7, 0.11111111111111
80860, 0.73913043478261, 1.675, 0.11111111111111
80861, 0.73913043478261, 1.7, 0.13888888888889
80862, 0.76086956521739, 1.7, 0.16666666666667
80863, 0.73913043478261, 1.675, 0.16666666666667
80864, 0.73913043478261, 1.7, 0.19444444444444
80865, 0.76086956521739, 1.7, 0.22222222222222
80866, 0.73913043478261, 1.675, 0.22222222222222
80867, 0.73913043478261, 1.7, 0.25
80868, 0.76086956521739, 1.7, 0.27777777777778
80869, 0.73913043478261, 1.675, 0.27777777777778
80870, 0.73913043478261, 1.7, 0.30555555555556
80871, 0.76086956521739, 1.7, 0.33333333333333
80872, 0.73913043478261, 1.675, 0.33333333333333
80873, 0.73913043478261, 1.7, 0.36111111111111
80874, 0.76086956521739, 1.7, 0.38888888888889
80875, 0.73913043478261, 1.675, 0.38888888888889
80876, 0.73913043478261, 1.7, 0.41666666666667
80877, 0.76086956521739, 1.7, 0.44444444444444
80878, 0.73913043478261, 1.675, 0.44444444444444
80879, 0.73913043478261, 1.7, 0.47222222222222
80880, 0.69565217391304, 1.7, 0.027777777777778
80881, 0.71739130434783, 1.7, 0.055555555555556
80882, 0.69565217391304, 1.675, 0.055555555555556
80883, 0.69565217391304, 1.7, 0.083333333333333
80884, 0.71739130434783, 1.7, 0.11111111111111
80885, 0.69565217391304, 1.675, 0.11111111111111
80886, 0.69565217391304, 1.7, 0.13888888888889
80887, 0.71739130434783, 1.7, 0.16666666666667
80888, 0.69565217391304, 1.675, 0.16666666666667
80889, 0.69565217391304, 1.7, 0.19444444444444
80890, 0.71739130434783, 1.7, 0.22222222222222
80891, 0.69565217391304, 1.675, 0.22222222222222
80892, 0.69565217391304, 1.7, 0.25
80893, 0.71739130434783, 1.7, 0.27777777777778
80894, 0.69565217391304, 1.675, 0.27777777777778
80895, 0.69565217391304, 1.7, 0.30555555555556
80896, 0.71739130434783, 1.7, 0.33333333333333
80897, 0.69565217391304, 1.675, 0.33333333333333
80898, 0.69565217391304, 1.7, 0.36111111111111
80899, 0.71739130434783, 1.7, 0.38888888888889
80900, 0.69565217391304, 1.675, 0.38888888888889
80901, 0.69565217391304, 1.7, 0.41666666666667
80902, 0.71739130434783, 1.7, 0.44444444444444
80903, 0.69565217391304, 1.675, 0.44444444444444
80904, 0.69565217391304, 1.7, 0.47222222222222
80905, 0.65217391304348, 1.7, 0.027777777777778
80906, 0.67391304347826, 1.7, 0.055555555555556
80907, 0.65217391304348, 1.675, 0.055555555555556
80908, 0.65217391304348, 1.7, 0.083333333333333
80909, 0.67391304347826, 1.7, 0.11111111111111
80910, 0.65217391304348, 1.675, 0.11111111111111
80911, 0.65217391304348, 1.7, 0.13888888888889
80912, 0.67391304347826, 1.7, 0.16666666666667
80913, 0.65217391304348, 1.675, 0.16666666666667
80914, 0.65217391304348, 1.7, 0.19444444444444
80915, 0.67391304347826, 1.7, 0.22222222222222
80916, 0.65217391304348, 1.675, 0.22222222222222
80917, 0.65217391304348, 1.7, 0.25
80918, 0.67391304347826, 1.7, 0.27777777777778
80919, 0.65217391304348, 1.675, 0.27777777777778
80920, 0.65217391304348, 1.7, 0.30555555555556
80921, 0.67391304347826, 1.7, 0.33333333333333
80922, 0.65217391304348, 1.675, 0.33333333333333
80923, 0.65217391304348, 1.7, 0.36111111111111
80924, 0.67391304347826, 1.7, 0.38888888888889
80925, 0.65217391304348, 1.675, 0.38888888888889
80926, 0.65217391304348, 1.7, 0.41666666666667
80927, 0.67391304347826, 1.7, 0.44444444444444
80928, 0.65217391304348, 1.675, 0.44444444444444
80929, 0.65217391304348, 1.7, 0.47222222222222
80930, 0.60869565217391, 1.7, 0.027777777777778
80931, 0.6304347826087, 1.7, 0.055555555555556
80932, 0.60869565217391, 1.675, 0.055555555555556
80933, 0.60869565217391, 1.7, 0.083333333333333
80934, 0.6304347826087, 1.7, 0.11111111111111
80935, 0.60869565217391, 1.675, 0.11111111111111
80936, 0.60869565217391, 1.7, 0.13888888888889
80937, 0.6304347826087, 1.7, 0.16666666666667
80938, 0.60869565217391, 1.675, 0.16666666666667
80939, 0.60869565217391, 1.7, 0.19444444444444
80940, 0.6304347826087, 1.7, 0.22222222222222
80941, 0.60869565217391, 1.675, 0.22222222222222
80942, 0.60869565217391, 1.7, 0.25
80943, 0.6304347826087, 1.7, 0.27777777777778
80944, 0.60869565217391, 1.675, 0.27777777777778
80945, 0.60869565217391, 1.7, 0.30555555555556
80946, 0.6304347826087, 1.7, 0.33333333333333
80947, 0.60869565217391, 1.675, 0.33333333333333
80948, 0.60869565217391, 1.7, 0.36111111111111
80949, 0.6304347826087, 1.7, 0.38888888888889
80950, 0.60869565217391, 1.675, 0.38888888888889
80951, 0.60869565217391, 1.7, 0.41666666666667
80952, 0.6304347826087, 1.7, 0.44444444444444
80953, 0.60869565217391, 1.675, 0.44444444444444
80954, 0.60869565217391, 1.7, 0.47222222222222
80955, 0.56521739130435, 1.7, 0.027777777777778
80956, 0.58695652173913, 1.7, 0.055555555555556
80957, 0.56521739130435, 1.675, 0.055555555555556
80958, 0.56521739130435, 1.7, 0.083333333333333
80959, 0.58695652173913, 1.7, 0.11111111111111
80960, 0.56521739130435, 1.675, 0.11111111111111
80961, 0.56521739130435, 1.7, 0.13888888888889
80962, 0.58695652173913, 1.7, 0.16666666666667
80963, 0.56521739130435, 1.675, 0.16666666666667
80964, 0.56521739130435, 1.7, 0.19444444444444
80965, 0.58695652173913, 1.7, 0.22222222222222
80966, 0.56521739130435, 1.675, 0.22222222222222
80967, 0.56521739130435, 1.7, 0.25
80968, 0.58695652173913, 1.7, 0.27777777777778
80969, 0.56521739130435, 1.675, 0.27777777777778
80970, 0.56521739130435, 1.7, 0.30555555555556
80971, 0.58695652173913, 1.7, 0.33333333333333
80972, 0.56521739130435, 1.675, 0.33333333333333
80973, 0.56521739130435, 1.7, 0.36111111111111
80974, 0.58695652173913, 1.7, 0.38888888888889
80975, 0.56521739130435, 1.675, 0.38888888888889
80976, 0.56521739130435, 1.7, 0.41666666666667
80977, 0.58695652173913, 1.7, 0.44444444444444
80978, 0.56521739130435, 1.675, 0.44444444444444
80979, 0.56521739130435, 1.7, 0.47222222222222
80980, 0.52173913043478, 1.7, 0.027777777777778
80981, 0.54347826086957, 1.7, 0.055555555555556
80982, 0.52173913043478, 1.675, 0.055555555555556
80983, 0.52173913043478, 1.7, 0.083333333333333
80984, 0.54347826086957, 1.7, 0.11111111111111
80985, 0.52173913043478, 1.675, 0.11111111111111
80986, 0.52173913043478, 1.7, 0.13888888888889
80987, 0.54347826086956, 1.7, 0.16666666666667
80988, 0.52173913043478, 1.675, 0.16666666666667
80989, 0.52173913043478, 1.7, 0.19444444444444
80990, 0.54347826086956, 1.7, 0.22222222222222
80991, 0.52173913043478, 1.675, 0.22222222222222
80992, 0.52173913043478, 1.7, 0.25
80993, 0.54347826086956, 1.7, 0.27777777777778
80994, 0.52173913043478, 1.675, 0.27777777777778
80995, 0.52173913043478, 1.7, 0.30555555555556
80996, 0.54347826086956, 1.7, 0.33333333333333
80997, 0.52173913043478, 1.675, 0.33333333333333
80998, 0.52173913043478, 1.7, 0.36111111111111
80999, 0.54347826086956, 1.7, 0.38888888888889
81000, 0.52173913043478, 1.675, 0.38888888888889
81001, 0.52173913043478, 1.7, 0.41666666666667
81002, 0.54347826086956, 1.7, 0.44444444444444
81003, 0.52173913043478, 1.675, 0.44444444444444
81004, 0.52173913043478, 1.7, 0.47222222222222
81005, 0.47826086956522, 1.7, 0.027777777777778
81006, 0.5, 1.7, 0.055555555555556
81007, 0.47826086956522, 1.675, 0.055555555555556
81008, 0.47826086956522, 1.7, 0.083333333333333
81009, 0.5, 1.7, 0.11111111111111
81010, 0.47826086956522, 1.675, 0.11111111111111
81011, 0.47826086956522, 1.7, 0.13888888888889
81012, 0.5, 1.7, 0.16666666666667
81013, 0.47826086956522, 1.675, 0.16666666666667
81014, 0.47826086956522, 1.7, 0.19444444444444
81015, 0.5, 1.7, 0.22222222222222
81016, 0.47826086956522, 1.675, 0.22222222222222
81017, 0.47826086956522, 1.7, 0.25
81018, 0.5, 1.7, 0.27777777777778
81019, 0.47826086956522, 1.675, 0.27777777777778
81020, 0.47826086956522, 1.7, 0.30555555555556
81021, 0.5, 1.7, 0.33333333333333
81022, 0.47826086956522, 1.675, 0.33333333333333
81023, 0.47826086956522, 1.7, 0.36111111111111
81024, 0.5, 1.7, 0.38888888888889
81025, 0.47826086956522, 1.675, 0.38888888888889
81026, 0.47826086956522, 1.7, 0.41666666666667
81027, 0.5, 1.7, 0.44444444444444
81028, 0.47826086956522, 1.675, 0.44444444444444
81029, 0.47826086956522, 1.7, 0.47222222222222
81030, 0.43478260869565, 1.7, 0.027777777777778
81031, 0.45652173913043, 1.7, 0.055555555555556
81032, 0.43478260869565, 1.675, 0.055555555555556
81033, 0.43478260869565, 1.7, 0.083333333333333
81034, 0.45652173913043, 1.7, 0.11111111111111
81035, 0.43478260869565, 1.675, 0.11111111111111
81036, 0.43478260869565, 1.7, 0.13888888888889
81037, 0.45652173913043, 1.7, 0.16666666666667
81038, 0.43478260869565, 1.675, 0.16666666666667
81039, 0.43478260869565, 1.7, 0.19444444444444
81040, 0.45652173913043, 1.7, 0.22222222222222
81041, 0.43478260869565, 1.675, 0.22222222222222
81042, 0.43478260869565, 1.7, 0.25
81043, 0.45652173913043, 1.7, 0.27777777777778
81044, 0.43478260869565, 1.675, 0.27777777777778
81045, 0.43478260869565, 1.7, 0.30555555555556
81046, 0.45652173913043, 1.7, 0.33333333333333
81047, 0.43478260869565, 1.675, 0.33333333333333
81048, 0.43478260869565, 1.7, 0.36111111111111
81049, 0.45652173913043, 1.7, 0.38888888888889
81050, 0.43478260869565, 1.675, 0.38888888888889
81051, 0.43478260869565, 1.7, 0.41666666666667
81052, 0.45652173913043, 1.7, 0.44444444444444
81053, 0.43478260869565, 1.675, 0.44444444444444
81054, 0.43478260869565, 1.7, 0.47222222222222
81055, 0.39130434782609, 1.7, 0.027777777777778
81056, 0.41304347826087, 1.7, 0.055555555555556
81057, 0.39130434782609, 1.675, 0.055555555555556
81058, 0.39130434782609, 1.7, 0.083333333333333
81059, 0.41304347826087, 1.7, 0.11111111111111
81060, 0.39130434782609, 1.675, 0.11111111111111
81061, 0.39130434782609, 1.7, 0.13888888888889
81062, 0.41304347826087, 1.7, 0.16666666666667
81063, 0.39130434782609, 1.675, 0.16666666666667
81064, 0.39130434782609, 1.7, 0.19444444444444
81065, 0.41304347826087, 1.7, 0.22222222222222
81066, 0.39130434782609, 1.675, 0.22222222222222
81067, 0.39130434782609, 1.7, 0.25
81068, 0.41304347826087, 1.7, 0.27777777777778
81069, 0.39130434782609, 1.675, 0.27777777777778
81070, 0.39130434782609, 1.7, 0.30555555555556
81071, 0.41304347826087, 1.7, 0.33333333333333
81072, 0.39130434782609, 1.675, 0.33333333333333
81073, 0.39130434782609, 1.7, 0.36111111111111
81074, 0.41304347826087, 1.7, 0.38888888888889
81075, 0.39130434782609, 1.675, 0.38888888888889
81076, 0.39130434782609, 1.7, 0.41666666666667
81077, 0.41304347826087, 1.7, 0.44444444444444
81078, 0.39130434782609, 1.675, 0.44444444444444
81079, 0.39130434782609, 1.7, 0.47222222222222
81080, 0.34782608695652, 1.7, 0.027777777777778
81081, 0.3695652173913, 1.7, 0.055555555555556
81082, 0.34782608695652, 1.675, 0.055555555555556
81083, 0.34782608695652, 1.7, 0.083333333333333
81084, 0.3695652173913, 1.7, 0.11111111111111
81085, 0.34782608695652, 1.675, 0.11111111111111
81086, 0.34782608695652, 1.7, 0.13888888888889
81087, 0.3695652173913, 1.7, 0.16666666666667
81088, 0.34782608695652, 1.675, 0.16666666666667
81089, 0.34782608695652, 1.7, 0.19444444444444
81090, 0.3695652173913, 1.7, 0.22222222222222
81091, 0.34782608695652, 1.675, 0.22222222222222
81092, 0.34782608695652, 1.7, 0.25
81093, 0.3695652173913, 1.7, 0.27777777777778
81094, 0.34782608695652, 1.675, 0.27777777777778
81095, 0.34782608695652, 1.7, 0.30555555555556
81096, 0.3695652173913, 1.7, 0.33333333333333
81097, 0.34782608695652, 1.675, 0.33333333333333
81098, 0.34782608695652, 1.7, 0.36111111111111
81099, 0.3695652173913, 1.7, 0.38888888888889
81100, 0.34782608695652, 1.675, 0.38888888888889
81101, 0.34782608695652, 1.7, 0.41666666666667
81102, 0.3695652173913, 1.7, 0.44444444444444
81103, 0.34782608695652, 1.675, 0.44444444444444
81104, 0.34782608695652, 1.7, 0.47222222222222
81105, 0.30434782608696, 1.7, 0.027777777777778
81106, 0.32608695652174, 1.7, 0.055555555555556
81107, 0.30434782608696, 1.675, 0.055555555555556
81108, 0.30434782608696, 1.7, 0.083333333333333
81109, 0.32608695652174, 1.7, 0.11111111111111
81110, 0.30434782608696, 1.675, 0.11111111111111
81111, 0.30434782608696, 1.7, 0.13888888888889
81112, 0.32608695652174, 1.7, 0.16666666666667
81113, 0.30434782608696, 1.675, 0.16666666666667
81114, 0.30434782608696, 1.7, 0.19444444444444
81115, 0.32608695652174, 1.7, 0.22222222222222
81116, 0.30434782608696, 1.675, 0.22222222222222
81117, 0.30434782608696, 1.7, 0.25
81118, 0.32608695652174, 1.7, 0.27777777777778
81119, 0.30434782608696, 1.675, 0.27777777777778
81120, 0.30434782608696, 1.7, 0.30555555555556
81121, 0.32608695652174, 1.7, 0.33333333333333
81122, 0.30434782608696, 1.675, 0.33333333333333
81123, 0.30434782608696, 1.7, 0.36111111111111
81124, 0.32608695652174, 1.7, 0.38888888888889
81125, 0.30434782608696, 1.675, 0.38888888888889
81126, 0.30434782608696, 1.7, 0.41666666666667
81127, 0.32608695652174, 1.7, 0.44444444444444
81128, 0.30434782608696, 1.675, 0.44444444444444
81129, 0.30434782608696, 1.7, 0.47222222222222
81130, 0.26086956521739, 1.7, 0.027777777777778
81131, 0.28260869565217, 1.7, 0.055555555555556
81132, 0.26086956521739, 1.675, 0.055555555555556
81133, 0.26086956521739, 1.7, 0.083333333333333
81134, 0.28260869565217, 1.7, 0.11111111111111
81135, 0.26086956521739, 1.675, 0.11111111111111
81136, 0.26086956521739, 1.7, 0.13888888888889
81137, 0.28260869565217, 1.7, 0.16666666666667
81138, 0.26086956521739, 1.675, 0.16666666666667
81139, 0.26086956521739, 1.7, 0.19444444444444
81140, 0.28260869565217, 1.7, 0.22222222222222
81141, 0.26086956521739, 1.675, 0.22222222222222
81142, 0.26086956521739, 1.7, 0.25
81143, 0.28260869565217, 1.7, 0.27777777777778
81144, 0.26086956521739, 1.675, 0.27777777777778
81145, 0.26086956521739, 1.7, 0.30555555555556
81146, 0.28260869565217, 1.7, 0.33333333333333
81147, 0.26086956521739, 1.675, 0.33333333333333
81148, 0.26086956521739, 1.7, 0.36111111111111
81149, 0.28260869565217, 1.7, 0.38888888888889
81150, 0.26086956521739, 1.675, 0.38888888888889
81151, 0.26086956521739, 1.7, 0.41666666666667
81152, 0.28260869565217, 1.7, 0.44444444444444
81153, 0.26086956521739, 1.675, 0.44444444444444
81154, 0.26086956521739, 1.7, 0.47222222222222
81155, 0.21739130434783, 1.7, 0.027777777777778
81156, 0.23913043478261, 1.7, 0.055555555555556
81157, 0.21739130434783, 1.675, 0.055555555555556
81158, 0.21739130434783, 1.7, 0.083333333333333
81159, 0.23913043478261, 1.7, 0.11111111111111
81160, 0.21739130434783, 1.675, 0.11111111111111
81161, 0.21739130434783, 1.7, 0.13888888888889
81162, 0.23913043478261, 1.7, 0.16666666666667
81163, 0.21739130434783, 1.675, 0.16666666666667
81164, 0.21739130434783, 1.7, 0.19444444444444
81165, 0.23913043478261, 1.7, 0.22222222222222
81166, 0.21739130434783, 1.675, 0.22222222222222
81167, 0.21739130434783, 1.7, 0.25
81168, 0.23913043478261, 1.7, 0.27777777777778
81169, 0.21739130434783, 1.675, 0.27777777777778
81170, 0.21739130434783, 1.7, 0.30555555555556
81171, 0.23913043478261, 1.7, 0.33333333333333
81172, 0.21739130434783, 1.675, 0.33333333333333
81173, 0.21739130434783, 1.7, 0.36111111111111
81174, 0.23913043478261, 1.7, 0.38888888888889
81175, 0.21739130434783, 1.675, 0.38888888888889
81176, 0.21739130434783, 1.7, 0.41666666666667
81177, 0.23913043478261, 1.7, 0.44444444444444
81178, 0.21739130434783, 1.675, 0.44444444444444
81179, 0.21739130434783, 1.7, 0.47222222222222
81180, 0.17391304347826, 1.7, 0.027777777777778
81181, 0.19565217391304, 1.7, 0.055555555555556
81182, 0.17391304347826, 1.675, 0.055555555555556
81183, 0.17391304347826, 1.7, 0.083333333333333
81184, 0.19565217391304, 1.7, 0.11111111111111
81185, 0.17391304347826, 1.675, 0.11111111111111
81186, 0.17391304347826, 1.7, 0.13888888888889
81187, 0.19565217391304, 1.7, 0.16666666666667
81188, 0.17391304347826, 1.675, 0.16666666666667
81189, 0.17391304347826, 1.7, 0.19444444444444
81190, 0.19565217391304, 1.7, 0.22222222222222
81191, 0.17391304347826, 1.675, 0.22222222222222
81192, 0.17391304347826, 1.7, 0.25
81193, 0.19565217391304, 1.7, 0.27777777777778
81194, 0.17391304347826, 1.675, 0.27777777777778
81195, 0.17391304347826, 1.7, 0.30555555555556
81196, 0.19565217391304, 1.7, 0.33333333333333
81197, 0.17391304347826, 1.675, 0.33333333333333
81198, 0.17391304347826, 1.7, 0.36111111111111
81199, 0.19565217391304, 1.7, 0.38888888888889
81200, 0.17391304347826, 1.675, 0.38888888888889
81201, 0.17391304347826, 1.7, 0.41666666666667
81202, 0.19565217391304, 1.7, 0.44444444444444
81203, 0.17391304347826, 1.675, 0.44444444444444
81204, 0.17391304347826, 1.7, 0.47222222222222
81205, 0.1304347826087, 1.7, 0.027777777777778
81206, 0.15217391304348, 1.7, 0.055555555555556
81207, 0.1304347826087, 1.675, 0.055555555555556
81208, 0.1304347826087, 1.7, 0.083333333333333
81209, 0.15217391304348, 1.7, 0.11111111111111
81210, 0.1304347826087, 1.675, 0.11111111111111
81211, 0.1304347826087, 1.7, 0.13888888888889
81212, 0.15217391304348, 1.7, 0.16666666666667
81213, 0.1304347826087, 1.675, 0.16666666666667
81214, 0.1304347826087, 1.7, 0.19444444444444
81215, 0.15217391304348, 1.7, 0.22222222222222
81216, 0.1304347826087, 1.675, 0.22222222222222
81217, 0.1304347826087, 1.7, 0.25
81218, 0.15217391304348, 1.7, 0.27777777777778
81219, 0.1304347826087, 1.675, 0.27777777777778
81220, 0.1304347826087, 1.7, 0.30555555555556
81221, 0.15217391304348, 1.7, 0.33333333333333
81222, 0.1304347826087, 1.675, 0.33333333333333
81223, 0.1304347826087, 1.7, 0.36111111111111
81224, 0.15217391304348, 1.7, 0.38888888888889
81225, 0.1304347826087, 1.675, 0.38888888888889
81226, 0.1304347826087, 1.7, 0.41666666666667
81227, 0.15217391304348, 1.7, 0.44444444444444
81228, 0.1304347826087, 1.675, 0.44444444444444
81229, 0.1304347826087, 1.7, 0.47222222222222
81230, 0.08695652173913, 1.7, 0.027777777777778
81231, 0.10869565217391, 1.7, 0.055555555555556
81232, 0.08695652173913, 1.675, 0.055555555555556
81233, 0.08695652173913, 1.7, 0.083333333333333
81234, 0.10869565217391, 1.7, 0.11111111111111
81235, 0.08695652173913, 1.675, 0.11111111111111
81236, 0.08695652173913, 1.7, 0.13888888888889
81237, 0.10869565217391, 1.7, 0.16666666666667
81238, 0.08695652173913, 1.675, 0.16666666666667
81239, 0.08695652173913, 1.7, 0.19444444444444
81240, 0.10869565217391, 1.7, 0.22222222222222
81241, 0.08695652173913, 1.675, 0.22222222222222
81242, 0.08695652173913, 1.7, 0.25
81243, 0.10869565217391, 1.7, 0.27777777777778
81244, 0.08695652173913, 1.675, 0.27777777777778
81245, 0.08695652173913, 1.7, 0.30555555555556
81246, 0.10869565217391, 1.7, 0.33333333333333
81247, 0.08695652173913, 1.675, 0.33333333333333
81248, 0.08695652173913, 1.7, 0.36111111111111
81249, 0.10869565217391, 1.7, 0.38888888888889
81250, 0.08695652173913, 1.675, 0.38888888888889
81251, 0.08695652173913, 1.7, 0.41666666666667
81252, 0.10869565217391, 1.7, 0.44444444444444
81253, 0.08695652173913, 1.675, 0.44444444444444
81254, 0.08695652173913, 1.7, 0.47222222222222
81255, 0.043478260869565, 1.7, 0.027777777777778
81256, 0.065217391304348, 1.7, 0.055555555555556
81257, 0.043478260869565, 1.675, 0.055555555555556
81258, 0.043478260869565, 1.7, 0.083333333333333
81259, 0.065217391304348, 1.7, 0.11111111111111
81260, 0.043478260869565, 1.675, 0.11111111111111
81261, 0.043478260869565, 1.7, 0.13888888888889
81262, 0.065217391304348, 1.7, 0.16666666666667
81263, 0.043478260869565, 1.675, 0.16666666666667
81264, 0.043478260869565, 1.7, 0.19444444444444
81265, 0.065217391304348, 1.7, 0.22222222222222
81266, 0.043478260869565, 1.675, 0.22222222222222
81267, 0.043478260869565, 1.7, 0.25
81268, 0.065217391304348, 1.7, 0.27777777777778
81269, 0.043478260869565, 1.675, 0.27777777777778
81270, 0.043478260869565, 1.7, 0.30555555555556
81271, 0.065217391304348, 1.7, 0.33333333333333
81272, 0.043478260869565, 1.675, 0.33333333333333
81273, 0.043478260869565, 1.7, 0.36111111111111
81274, 0.065217391304348, 1.7, 0.38888888888889
81275, 0.043478260869565, 1.675, 0.38888888888889
81276, 0.043478260869565, 1.7, 0.41666666666667
81277, 0.065217391304348, 1.7, 0.44444444444444
81278, 0.043478260869565, 1.675, 0.44444444444444
81279, 0.043478260869565, 1.7, 0.47222222222222
81280, 0.021739130434783, 1.7, 0.055555555555556
81281, 0.021739130434783, 1.7, 0.11111111111111
81282, 0.021739130434783, 1.7, 0.16666666666667
81283, 0.021739130434783, 1.7, 0.22222222222222
81284, 0.021739130434783, 1.7, 0.27777777777778
81285, 0.021739130434783, 1.7, 0.33333333333333
81286, 0.021739130434783, 1.7, 0.38888888888889
81287, 0.021739130434783, 1.7, 0.44444444444444
81288, 0.95652173913043, 1.725, 0.055555555555556
81289, 0.95652173913043, 1.725, 0.11111111111111
81290, 0.95652173913043, 1.725, 0.16666666666667
81291, 0.95652173913043, 1.725, 0.22222222222222
81292, 0.95652173913043, 1.725, 0.27777777777778
81293, 0.95652173913043, 1.725, 0.33333333333333
81294, 0.95652173913043, 1.725, 0.38888888888889
81295, 0.95652173913043, 1.725, 0.44444444444444
81296, 0.91304347826087, 1.725, 0.055555555555556
81297, 0.91304347826087, 1.725, 0.11111111111111
81298, 0.91304347826087, 1.725, 0.16666666666667
81299, 0.91304347826087, 1.725, 0.22222222222222
81300, 0.91304347826087, 1.725, 0.27777777777778
81301, 0.91304347826087, 1.725, 0.33333333333333
81302, 0.91304347826087, 1.725, 0.38888888888889
81303, 0.91304347826087, 1.725, 0.44444444444444
81304, 0.8695652173913, 1.725, 0.055555555555556
81305, 0.8695652173913, 1.725, 0.11111111111111
81306, 0.8695652173913, 1.725, 0.16666666666667
81307, 0.8695652173913, 1.725, 0.22222222222222
81308, 0.8695652173913, 1.725, 0.27777777777778
81309, 0.8695652173913, 1.725, 0.33333333333333
81310, 0.8695652173913, 1.725, 0.38888888888889
81311, 0.8695652173913, 1.725, 0.44444444444444
81312, 0.82608695652174, 1.725, 0.055555555555556
81313, 0.82608695652174, 1.725, 0.11111111111111
81314, 0.82608695652174, 1.725, 0.16666666666667
81315, 0.82608695652174, 1.725, 0.22222222222222
81316, 0.82608695652174, 1.725, 0.27777777777778
81317, 0.82608695652174, 1.725, 0.33333333333333
81318, 0.82608695652174, 1.725, 0.38888888888889
81319, 0.82608695652174, 1.725, 0.44444444444444
81320, 0.78260869565217, 1.725, 0.055555555555556
81321, 0.78260869565217, 1.725, 0.11111111111111
81322, 0.78260869565217, 1.725, 0.16666666666667
81323, 0.78260869565217, 1.725, 0.22222222222222
81324, 0.78260869565217, 1.725, 0.27777777777778
81325, 0.78260869565217, 1.725, 0.33333333333333
81326, 0.78260869565217, 1.725, 0.38888888888889
81327, 0.78260869565217, 1.725, 0.44444444444444
81328, 0.73913043478261, 1.725, 0.055555555555556
81329, 0.73913043478261, 1.725, 0.11111111111111
81330, 0.73913043478261, 1.725, 0.16666666666667
81331, 0.73913043478261, 1.725, 0.22222222222222
81332, 0.73913043478261, 1.725, 0.27777777777778
81333, 0.73913043478261, 1.725, 0.33333333333333
81334, 0.73913043478261, 1.725, 0.38888888888889
81335, 0.73913043478261, 1.725, 0.44444444444444
81336, 0.69565217391304, 1.725, 0.055555555555556
81337, 0.69565217391304, 1.725, 0.11111111111111
81338, 0.69565217391304, 1.725, 0.16666666666667
81339, 0.69565217391304, 1.725, 0.22222222222222
81340, 0.69565217391304, 1.725, 0.27777777777778
81341, 0.69565217391304, 1.725, 0.33333333333333
81342, 0.69565217391304, 1.725, 0.38888888888889
81343, 0.69565217391304, 1.725, 0.44444444444444
81344, 0.65217391304348, 1.725, 0.055555555555556
81345, 0.65217391304348, 1.725, 0.11111111111111
81346, 0.65217391304348, 1.725, 0.16666666666667
81347, 0.65217391304348, 1.725, 0.22222222222222
81348, 0.65217391304348, 1.725, 0.27777777777778
81349, 0.65217391304348, 1.725, 0.33333333333333
81350, 0.65217391304348, 1.725, 0.38888888888889
81351, 0.65217391304348, 1.725, 0.44444444444444
81352, 0.60869565217391, 1.725, 0.055555555555556
81353, 0.60869565217391, 1.725, 0.11111111111111
81354, 0.60869565217391, 1.725, 0.16666666666667
81355, 0.60869565217391, 1.725, 0.22222222222222
81356, 0.60869565217391, 1.725, 0.27777777777778
81357, 0.60869565217391, 1.725, 0.33333333333333
81358, 0.60869565217391, 1.725, 0.38888888888889
81359, 0.60869565217391, 1.725, 0.44444444444444
81360, 0.56521739130435, 1.725, 0.055555555555556
81361, 0.56521739130435, 1.725, 0.11111111111111
81362, 0.56521739130435, 1.725, 0.16666666666667
81363, 0.56521739130435, 1.725, 0.22222222222222
81364, 0.56521739130435, 1.725, 0.27777777777778
81365, 0.56521739130435, 1.725, 0.33333333333333
81366, 0.56521739130435, 1.725, 0.38888888888889
81367, 0.56521739130435, 1.725, 0.44444444444444
81368, 0.52173913043478, 1.725, 0.055555555555556
81369, 0.52173913043478, 1.725, 0.11111111111111
81370, 0.52173913043478, 1.725, 0.16666666666667
81371, 0.52173913043478, 1.725, 0.22222222222222
81372, 0.52173913043478, 1.725, 0.27777777777778
81373, 0.52173913043478, 1.725, 0.33333333333333
81374, 0.52173913043478, 1.725, 0.38888888888889
81375, 0.52173913043478, 1.725, 0.44444444444444
81376, 0.47826086956522, 1.725, 0.055555555555556
81377, 0.47826086956522, 1.725, 0.11111111111111
81378, 0.47826086956522, 1.725, 0.16666666666667
81379, 0.47826086956522, 1.725, 0.22222222222222
81380, 0.47826086956522, 1.725, 0.27777777777778
