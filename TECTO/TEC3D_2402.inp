24318, 0.28260869565217, 1.35, 0.44444444444444
24319, 0.30434782608696, 1.35, 0.41666666666667
24320, 0.30434782608696, 1.35, 0.47222222222222
24321, 0.32608695652174, 1.35, 0.055555555555556
24322, 0.34782608695652, 1.35, 0.027777777777778
24323, 0.32608695652174, 1.35, 0.11111111111111
24324, 0.34782608695652, 1.35, 0.083333333333333
24325, 0.32608695652174, 1.35, 0.16666666666667
24326, 0.34782608695652, 1.35, 0.13888888888889
24327, 0.32608695652174, 1.35, 0.22222222222222
24328, 0.34782608695652, 1.35, 0.19444444444444
24329, 0.32608695652174, 1.35, 0.27777777777778
24330, 0.34782608695652, 1.35, 0.25
24331, 0.32608695652174, 1.35, 0.33333333333333
24332, 0.34782608695652, 1.35, 0.30555555555556
24333, 0.32608695652174, 1.35, 0.38888888888889
24334, 0.34782608695652, 1.35, 0.36111111111111
24335, 0.32608695652174, 1.35, 0.44444444444444
24336, 0.34782608695652, 1.35, 0.41666666666667
24337, 0.34782608695652, 1.35, 0.47222222222222
24338, 0.3695652173913, 1.35, 0.055555555555556
24339, 0.39130434782609, 1.35, 0.027777777777778
24340, 0.3695652173913, 1.35, 0.11111111111111
24341, 0.39130434782609, 1.35, 0.083333333333333
24342, 0.3695652173913, 1.35, 0.16666666666667
24343, 0.39130434782609, 1.35, 0.13888888888889
24344, 0.3695652173913, 1.35, 0.22222222222222
24345, 0.39130434782609, 1.35, 0.19444444444444
24346, 0.3695652173913, 1.35, 0.27777777777778
24347, 0.39130434782609, 1.35, 0.25
24348, 0.3695652173913, 1.35, 0.33333333333333
24349, 0.39130434782609, 1.35, 0.30555555555556
24350, 0.3695652173913, 1.35, 0.38888888888889
24351, 0.39130434782609, 1.35, 0.36111111111111
24352, 0.3695652173913, 1.35, 0.44444444444444
24353, 0.39130434782609, 1.35, 0.41666666666667
24354, 0.39130434782609, 1.35, 0.47222222222222
24355, 0.41304347826087, 1.35, 0.055555555555556
24356, 0.43478260869565, 1.35, 0.027777777777778
24357, 0.41304347826087, 1.35, 0.11111111111111
24358, 0.43478260869565, 1.35, 0.083333333333333
24359, 0.41304347826087, 1.35, 0.16666666666667
24360, 0.43478260869565, 1.35, 0.13888888888889
24361, 0.41304347826087, 1.35, 0.22222222222222
24362, 0.43478260869565, 1.35, 0.19444444444444
24363, 0.41304347826087, 1.35, 0.27777777777778
24364, 0.43478260869565, 1.35, 0.25
24365, 0.41304347826087, 1.35, 0.33333333333333
24366, 0.43478260869565, 1.35, 0.30555555555556
24367, 0.41304347826087, 1.35, 0.38888888888889
24368, 0.43478260869565, 1.35, 0.36111111111111
24369, 0.41304347826087, 1.35, 0.44444444444444
24370, 0.43478260869565, 1.35, 0.41666666666667
24371, 0.43478260869565, 1.35, 0.47222222222222
24372, 0.45652173913043, 1.35, 0.055555555555556
24373, 0.47826086956522, 1.35, 0.027777777777778
24374, 0.45652173913043, 1.35, 0.11111111111111
24375, 0.47826086956522, 1.35, 0.083333333333333
24376, 0.45652173913043, 1.35, 0.16666666666667
24377, 0.47826086956522, 1.35, 0.13888888888889
24378, 0.45652173913043, 1.35, 0.22222222222222
24379, 0.47826086956522, 1.35, 0.19444444444444
24380, 0.45652173913043, 1.35, 0.27777777777778
24381, 0.47826086956522, 1.35, 0.25
24382, 0.45652173913043, 1.35, 0.33333333333333
24383, 0.47826086956522, 1.35, 0.30555555555556
24384, 0.45652173913043, 1.35, 0.38888888888889
24385, 0.47826086956522, 1.35, 0.36111111111111
24386, 0.45652173913043, 1.35, 0.44444444444444
24387, 0.47826086956522, 1.35, 0.41666666666667
24388, 0.47826086956522, 1.35, 0.47222222222222
24389, 0.5, 1.35, 0.055555555555556
24390, 0.52173913043478, 1.35, 0.027777777777778
24391, 0.5, 1.35, 0.11111111111111
24392, 0.52173913043478, 1.35, 0.083333333333333
24393, 0.5, 1.35, 0.16666666666667
24394, 0.52173913043478, 1.35, 0.13888888888889
24395, 0.5, 1.35, 0.22222222222222
24396, 0.52173913043478, 1.35, 0.19444444444444
24397, 0.5, 1.35, 0.27777777777778
24398, 0.52173913043478, 1.35, 0.25
24399, 0.5, 1.35, 0.33333333333333
24400, 0.52173913043478, 1.35, 0.30555555555556
24401, 0.5, 1.35, 0.38888888888889
24402, 0.52173913043478, 1.35, 0.36111111111111
24403, 0.5, 1.35, 0.44444444444444
24404, 0.52173913043478, 1.35, 0.41666666666667
24405, 0.52173913043478, 1.35, 0.47222222222222
24406, 0.54347826086957, 1.35, 0.055555555555556
24407, 0.56521739130435, 1.35, 0.027777777777778
24408, 0.54347826086957, 1.35, 0.11111111111111
24409, 0.56521739130435, 1.35, 0.083333333333333
24410, 0.54347826086957, 1.35, 0.16666666666667
24411, 0.56521739130435, 1.35, 0.13888888888889
24412, 0.54347826086957, 1.35, 0.22222222222222
24413, 0.56521739130435, 1.35, 0.19444444444444
24414, 0.54347826086957, 1.35, 0.27777777777778
24415, 0.56521739130435, 1.35, 0.25
24416, 0.54347826086957, 1.35, 0.33333333333333
24417, 0.56521739130435, 1.35, 0.30555555555556
24418, 0.54347826086957, 1.35, 0.38888888888889
24419, 0.56521739130435, 1.35, 0.36111111111111
24420, 0.54347826086957, 1.35, 0.44444444444444
24421, 0.56521739130435, 1.35, 0.41666666666667
24422, 0.56521739130435, 1.35, 0.47222222222222
24423, 0.58695652173913, 1.35, 0.055555555555556
24424, 0.60869565217391, 1.35, 0.027777777777778
24425, 0.58695652173913, 1.35, 0.11111111111111
24426, 0.60869565217391, 1.35, 0.083333333333333
24427, 0.58695652173913, 1.35, 0.16666666666667
24428, 0.60869565217391, 1.35, 0.13888888888889
24429, 0.58695652173913, 1.35, 0.22222222222222
24430, 0.60869565217391, 1.35, 0.19444444444444
24431, 0.58695652173913, 1.35, 0.27777777777778
24432, 0.60869565217391, 1.35, 0.25
24433, 0.58695652173913, 1.35, 0.33333333333333
24434, 0.60869565217391, 1.35, 0.30555555555556
24435, 0.58695652173913, 1.35, 0.38888888888889
24436, 0.60869565217391, 1.35, 0.36111111111111
24437, 0.58695652173913, 1.35, 0.44444444444444
24438, 0.60869565217391, 1.35, 0.41666666666667
24439, 0.60869565217391, 1.35, 0.47222222222222
24440, 0.6304347826087, 1.35, 0.055555555555556
24441, 0.65217391304348, 1.35, 0.027777777777778
24442, 0.6304347826087, 1.35, 0.11111111111111
24443, 0.65217391304348, 1.35, 0.083333333333333
24444, 0.6304347826087, 1.35, 0.16666666666667
24445, 0.65217391304348, 1.35, 0.13888888888889
24446, 0.6304347826087, 1.35, 0.22222222222222
24447, 0.65217391304348, 1.35, 0.19444444444444
24448, 0.6304347826087, 1.35, 0.27777777777778
24449, 0.65217391304348, 1.35, 0.25
24450, 0.6304347826087, 1.35, 0.33333333333333
24451, 0.65217391304348, 1.35, 0.30555555555556
24452, 0.6304347826087, 1.35, 0.38888888888889
24453, 0.65217391304348, 1.35, 0.36111111111111
24454, 0.6304347826087, 1.35, 0.44444444444444
24455, 0.65217391304348, 1.35, 0.41666666666667
24456, 0.65217391304348, 1.35, 0.47222222222222
24457, 0.67391304347826, 1.35, 0.055555555555556
24458, 0.69565217391304, 1.35, 0.027777777777778
24459, 0.67391304347826, 1.35, 0.11111111111111
24460, 0.69565217391304, 1.35, 0.083333333333333
24461, 0.67391304347826, 1.35, 0.16666666666667
24462, 0.69565217391304, 1.35, 0.13888888888889
24463, 0.67391304347826, 1.35, 0.22222222222222
24464, 0.69565217391304, 1.35, 0.19444444444444
24465, 0.67391304347826, 1.35, 0.27777777777778
24466, 0.69565217391304, 1.35, 0.25
24467, 0.67391304347826, 1.35, 0.33333333333333
24468, 0.69565217391304, 1.35, 0.30555555555556
24469, 0.67391304347826, 1.35, 0.38888888888889
24470, 0.69565217391304, 1.35, 0.36111111111111
24471, 0.67391304347826, 1.35, 0.44444444444444
24472, 0.69565217391304, 1.35, 0.41666666666667
24473, 0.69565217391304, 1.35, 0.47222222222222
24474, 0.71739130434783, 1.35, 0.055555555555556
24475, 0.73913043478261, 1.35, 0.027777777777778
24476, 0.71739130434783, 1.35, 0.11111111111111
24477, 0.73913043478261, 1.35, 0.083333333333333
24478, 0.71739130434783, 1.35, 0.16666666666667
24479, 0.73913043478261, 1.35, 0.13888888888889
24480, 0.71739130434783, 1.35, 0.22222222222222
24481, 0.73913043478261, 1.35, 0.19444444444444
24482, 0.71739130434783, 1.35, 0.27777777777778
24483, 0.73913043478261, 1.35, 0.25
24484, 0.71739130434783, 1.35, 0.33333333333333
24485, 0.73913043478261, 1.35, 0.30555555555556
24486, 0.71739130434783, 1.35, 0.38888888888889
24487, 0.73913043478261, 1.35, 0.36111111111111
24488, 0.71739130434783, 1.35, 0.44444444444444
24489, 0.73913043478261, 1.35, 0.41666666666667
24490, 0.73913043478261, 1.35, 0.47222222222222
24491, 0.76086956521739, 1.35, 0.055555555555556
24492, 0.78260869565217, 1.35, 0.027777777777778
24493, 0.76086956521739, 1.35, 0.11111111111111
24494, 0.78260869565217, 1.35, 0.083333333333333
24495, 0.76086956521739, 1.35, 0.16666666666667
24496, 0.78260869565217, 1.35, 0.13888888888889
24497, 0.76086956521739, 1.35, 0.22222222222222
24498, 0.78260869565217, 1.35, 0.19444444444444
24499, 0.76086956521739, 1.35, 0.27777777777778
24500, 0.78260869565217, 1.35, 0.25
24501, 0.76086956521739, 1.35, 0.33333333333333
24502, 0.78260869565217, 1.35, 0.30555555555556
24503, 0.76086956521739, 1.35, 0.38888888888889
24504, 0.78260869565217, 1.35, 0.36111111111111
24505, 0.76086956521739, 1.35, 0.44444444444444
24506, 0.78260869565217, 1.35, 0.41666666666667
24507, 0.78260869565217, 1.35, 0.47222222222222
24508, 0.80434782608696, 1.35, 0.055555555555556
24509, 0.82608695652174, 1.35, 0.027777777777778
24510, 0.80434782608696, 1.35, 0.11111111111111
24511, 0.82608695652174, 1.35, 0.083333333333333
24512, 0.80434782608696, 1.35, 0.16666666666667
24513, 0.82608695652174, 1.35, 0.13888888888889
24514, 0.80434782608696, 1.35, 0.22222222222222
24515, 0.82608695652174, 1.35, 0.19444444444444
24516, 0.80434782608696, 1.35, 0.27777777777778
24517, 0.82608695652174, 1.35, 0.25
24518, 0.80434782608696, 1.35, 0.33333333333333
24519, 0.82608695652174, 1.35, 0.30555555555556
24520, 0.80434782608696, 1.35, 0.38888888888889
24521, 0.82608695652174, 1.35, 0.36111111111111
24522, 0.80434782608696, 1.35, 0.44444444444444
24523, 0.82608695652174, 1.35, 0.41666666666667
24524, 0.82608695652174, 1.35, 0.47222222222222
24525, 0.84782608695652, 1.35, 0.055555555555556
24526, 0.8695652173913, 1.35, 0.027777777777778
24527, 0.84782608695652, 1.35, 0.11111111111111
24528, 0.8695652173913, 1.35, 0.083333333333333
24529, 0.84782608695652, 1.35, 0.16666666666667
24530, 0.8695652173913, 1.35, 0.13888888888889
24531, 0.84782608695652, 1.35, 0.22222222222222
24532, 0.8695652173913, 1.35, 0.19444444444444
24533, 0.84782608695652, 1.35, 0.27777777777778
24534, 0.8695652173913, 1.35, 0.25
24535, 0.84782608695652, 1.35, 0.33333333333333
24536, 0.8695652173913, 1.35, 0.30555555555556
24537, 0.84782608695652, 1.35, 0.38888888888889
24538, 0.8695652173913, 1.35, 0.36111111111111
24539, 0.84782608695652, 1.35, 0.44444444444444
24540, 0.8695652173913, 1.35, 0.41666666666667
24541, 0.8695652173913, 1.35, 0.47222222222222
24542, 0.89130434782609, 1.35, 0.055555555555556
24543, 0.91304347826087, 1.35, 0.027777777777778
24544, 0.89130434782609, 1.35, 0.11111111111111
24545, 0.91304347826087, 1.35, 0.083333333333333
24546, 0.89130434782609, 1.35, 0.16666666666667
24547, 0.91304347826087, 1.35, 0.13888888888889
24548, 0.89130434782609, 1.35, 0.22222222222222
24549, 0.91304347826087, 1.35, 0.19444444444444
24550, 0.89130434782609, 1.35, 0.27777777777778
24551, 0.91304347826087, 1.35, 0.25
24552, 0.89130434782609, 1.35, 0.33333333333333
24553, 0.91304347826087, 1.35, 0.30555555555556
24554, 0.89130434782609, 1.35, 0.38888888888889
24555, 0.91304347826087, 1.35, 0.36111111111111
24556, 0.89130434782609, 1.35, 0.44444444444444
24557, 0.91304347826087, 1.35, 0.41666666666667
24558, 0.91304347826087, 1.35, 0.47222222222222
24559, 0.93478260869565, 1.35, 0.055555555555556
24560, 0.95652173913043, 1.35, 0.027777777777778
24561, 0.93478260869565, 1.35, 0.11111111111111
24562, 0.95652173913043, 1.35, 0.083333333333333
24563, 0.93478260869565, 1.35, 0.16666666666667
24564, 0.95652173913043, 1.35, 0.13888888888889
24565, 0.93478260869565, 1.35, 0.22222222222222
24566, 0.95652173913043, 1.35, 0.19444444444444
24567, 0.93478260869565, 1.35, 0.27777777777778
24568, 0.95652173913043, 1.35, 0.25
24569, 0.93478260869565, 1.35, 0.33333333333333
24570, 0.95652173913043, 1.35, 0.30555555555556
24571, 0.93478260869565, 1.35, 0.38888888888889
24572, 0.95652173913043, 1.35, 0.36111111111111
24573, 0.93478260869565, 1.35, 0.44444444444444
24574, 0.95652173913043, 1.35, 0.41666666666667
24575, 0.95652173913043, 1.35, 0.47222222222222
24576, 0.97826086956522, 1.35, 0.055555555555556
24577, 0.97826086956522, 1.35, 0.11111111111111
24578, 0.97826086956522, 1.35, 0.16666666666667
24579, 0.97826086956522, 1.35, 0.22222222222222
24580, 0.97826086956522, 1.35, 0.27777777777778
24581, 0.97826086956522, 1.35, 0.33333333333333
24582, 0.97826086956522, 1.35, 0.38888888888889
24583, 0.97826086956522, 1.35, 0.44444444444444
24584, 1.2434782608696, 1.2978260869565, 0.5
24585, 1.2869565217391, 1.2978260869565, 0.5
24586, 1.3304347826087, 1.2978260869565, 0.5
24587, 1.3739130434783, 1.2978260869565, 0.5
24588, 1.4173913043478, 1.2978260869565, 0.5
24589, 1.4608695652174, 1.2978260869565, 0.5
24590, 1.504347826087, 1.2978260869565, 0.5
24591, 1.5478260869565, 1.2978260869565, 0.5
24592, 1.5913043478261, 1.2978260869565, 0.5
24593, 1.6347826086957, 1.2978260869565, 0.5
24594, 1.6782608695652, 1.2978260869565, 0.5
24595, 1.7217391304348, 1.2978260869565, 0.5
24596, 1.7652173913043, 1.2978260869565, 0.5
24597, 1.8086956521739, 1.2978260869565, 0.5
24598, 1.8521739130435, 1.2978260869565, 0.5
24599, 1.895652173913, 1.2978260869565, 0.5
24600, 1.9391304347826, 1.2978260869565, 0.5
24601, 1.9826086956522, 1.2978260869565, 0.5
24602, 2.0260869565217, 1.2978260869565, 0.5
24603, 2.0695652173913, 1.2978260869565, 0.5
24604, 2.1130434782609, 1.2978260869565, 0.5
24605, 2.1565217391304, 1.2978260869565, 0.5
24606, 1.2434782608696, 1.245652173913, 0.5
24607, 1.2869565217391, 1.245652173913, 0.5
24608, 1.3304347826087, 1.245652173913, 0.5
24609, 1.3739130434783, 1.245652173913, 0.5
24610, 1.4173913043478, 1.245652173913, 0.5
24611, 1.4608695652174, 1.245652173913, 0.5
24612, 1.504347826087, 1.245652173913, 0.5
24613, 1.5478260869565, 1.245652173913, 0.5
24614, 1.5913043478261, 1.245652173913, 0.5
24615, 1.6347826086957, 1.245652173913, 0.5
24616, 1.6782608695652, 1.245652173913, 0.5
24617, 1.7217391304348, 1.245652173913, 0.5
24618, 1.7652173913043, 1.245652173913, 0.5
24619, 1.8086956521739, 1.245652173913, 0.5
24620, 1.8521739130435, 1.245652173913, 0.5
24621, 1.895652173913, 1.245652173913, 0.5
24622, 1.9391304347826, 1.245652173913, 0.5
24623, 1.9826086956522, 1.245652173913, 0.5
24624, 2.0260869565217, 1.245652173913, 0.5
24625, 2.0695652173913, 1.245652173913, 0.5
24626, 2.1130434782609, 1.245652173913, 0.5
24627, 2.1565217391304, 1.245652173913, 0.5
24628, 1.2434782608696, 1.1934782608696, 0.5
24629, 1.2869565217391, 1.1934782608696, 0.5
24630, 1.3304347826087, 1.1934782608696, 0.5
24631, 1.3739130434783, 1.1934782608696, 0.5
24632, 1.4173913043478, 1.1934782608696, 0.5
24633, 1.4608695652174, 1.1934782608696, 0.5
24634, 1.504347826087, 1.1934782608696, 0.5
24635, 1.5478260869565, 1.1934782608696, 0.5
24636, 1.5913043478261, 1.1934782608696, 0.5
24637, 1.6347826086957, 1.1934782608696, 0.5
24638, 1.6782608695652, 1.1934782608696, 0.5
24639, 1.7217391304348, 1.1934782608696, 0.5
24640, 1.7652173913043, 1.1934782608696, 0.5
24641, 1.8086956521739, 1.1934782608696, 0.5
24642, 1.8521739130435, 1.1934782608696, 0.5
24643, 1.895652173913, 1.1934782608696, 0.5
24644, 1.9391304347826, 1.1934782608696, 0.5
24645, 1.9826086956522, 1.1934782608696, 0.5
24646, 2.0260869565217, 1.1934782608696, 0.5
24647, 2.0695652173913, 1.1934782608696, 0.5
24648, 2.1130434782609, 1.1934782608696, 0.5
24649, 2.1565217391304, 1.1934782608696, 0.5
24650, 1.2434782608696, 1.1413043478261, 0.5
24651, 1.2869565217391, 1.1413043478261, 0.5
24652, 1.3304347826087, 1.1413043478261, 0.5
24653, 1.3739130434783, 1.1413043478261, 0.5
24654, 1.4173913043478, 1.1413043478261, 0.5
24655, 1.4608695652174, 1.1413043478261, 0.5
24656, 1.504347826087, 1.1413043478261, 0.5
24657, 1.5478260869565, 1.1413043478261, 0.5
24658, 1.5913043478261, 1.1413043478261, 0.5
24659, 1.6347826086957, 1.1413043478261, 0.5
24660, 1.6782608695652, 1.1413043478261, 0.5
24661, 1.7217391304348, 1.1413043478261, 0.5
24662, 1.7652173913043, 1.1413043478261, 0.5
24663, 1.8086956521739, 1.1413043478261, 0.5
24664, 1.8521739130435, 1.1413043478261, 0.5
24665, 1.895652173913, 1.1413043478261, 0.5
24666, 1.9391304347826, 1.1413043478261, 0.5
24667, 1.9826086956522, 1.1413043478261, 0.5
24668, 2.0260869565217, 1.1413043478261, 0.5
24669, 2.0695652173913, 1.1413043478261, 0.5
24670, 2.1130434782609, 1.1413043478261, 0.5
24671, 2.1565217391304, 1.1413043478261, 0.5
24672, 1.2434782608696, 1.0891304347826, 0.5
24673, 1.2869565217391, 1.0891304347826, 0.5
24674, 1.3304347826087, 1.0891304347826, 0.5
24675, 1.3739130434783, 1.0891304347826, 0.5
24676, 1.4173913043478, 1.0891304347826, 0.5
24677, 1.4608695652174, 1.0891304347826, 0.5
24678, 1.504347826087, 1.0891304347826, 0.5
24679, 1.5478260869565, 1.0891304347826, 0.5
24680, 1.5913043478261, 1.0891304347826, 0.5
24681, 1.6347826086957, 1.0891304347826, 0.5
24682, 1.6782608695652, 1.0891304347826, 0.5
24683, 1.7217391304348, 1.0891304347826, 0.5
24684, 1.7652173913043, 1.0891304347826, 0.5
24685, 1.8086956521739, 1.0891304347826, 0.5
24686, 1.8521739130435, 1.0891304347826, 0.5
24687, 1.895652173913, 1.0891304347826, 0.5
24688, 1.9391304347826, 1.0891304347826, 0.5
24689, 1.9826086956522, 1.0891304347826, 0.5
24690, 2.0260869565217, 1.0891304347826, 0.5
24691, 2.0695652173913, 1.0891304347826, 0.5
24692, 2.1130434782609, 1.0891304347826, 0.5
24693, 2.1565217391304, 1.0891304347826, 0.5
24694, 1.2434782608696, 1.0369565217391, 0.5
24695, 1.2869565217391, 1.0369565217391, 0.5
24696, 1.3304347826087, 1.0369565217391, 0.5
24697, 1.3739130434783, 1.0369565217391, 0.5
24698, 1.4173913043478, 1.0369565217391, 0.5
24699, 1.4608695652174, 1.0369565217391, 0.5
24700, 1.504347826087, 1.0369565217391, 0.5
24701, 1.5478260869565, 1.0369565217391, 0.5
24702, 1.5913043478261, 1.0369565217391, 0.5
24703, 1.6347826086957, 1.0369565217391, 0.5
24704, 1.6782608695652, 1.0369565217391, 0.5
24705, 1.7217391304348, 1.0369565217391, 0.5
24706, 1.7652173913043, 1.0369565217391, 0.5
24707, 1.8086956521739, 1.0369565217391, 0.5
24708, 1.8521739130435, 1.0369565217391, 0.5
24709, 1.895652173913, 1.0369565217391, 0.5
24710, 1.9391304347826, 1.0369565217391, 0.5
24711, 1.9826086956522, 1.0369565217391, 0.5
24712, 2.0260869565217, 1.0369565217391, 0.5
24713, 2.0695652173913, 1.0369565217391, 0.5
24714, 2.1130434782609, 1.0369565217391, 0.5
24715, 2.1565217391304, 1.0369565217391, 0.5
24716, 1.2434782608696, 0.98478260869565, 0.5
24717, 1.2869565217391, 0.98478260869565, 0.5
24718, 1.3304347826087, 0.98478260869565, 0.5
24719, 1.3739130434783, 0.98478260869565, 0.5
24720, 1.4173913043478, 0.98478260869565, 0.5
24721, 1.4608695652174, 0.98478260869565, 0.5
24722, 1.504347826087, 0.98478260869565, 0.5
24723, 1.5478260869565, 0.98478260869565, 0.5
24724, 1.5913043478261, 0.98478260869565, 0.5
24725, 1.6347826086957, 0.98478260869565, 0.5
24726, 1.6782608695652, 0.98478260869565, 0.5
24727, 1.7217391304348, 0.98478260869565, 0.5
24728, 1.7652173913043, 0.98478260869565, 0.5
24729, 1.8086956521739, 0.98478260869565, 0.5
24730, 1.8521739130435, 0.98478260869565, 0.5
24731, 1.895652173913, 0.98478260869565, 0.5
24732, 1.9391304347826, 0.98478260869565, 0.5
24733, 1.9826086956522, 0.98478260869565, 0.5
24734, 2.0260869565217, 0.98478260869565, 0.5
24735, 2.0695652173913, 0.98478260869565, 0.5
24736, 2.1130434782609, 0.98478260869565, 0.5
24737, 2.1565217391304, 0.98478260869565, 0.5
24738, 1.2434782608696, 0.93260869565217, 0.5
24739, 1.2869565217391, 0.93260869565217, 0.5
24740, 1.3304347826087, 0.93260869565217, 0.5
24741, 1.3739130434783, 0.93260869565217, 0.5
24742, 1.4173913043478, 0.93260869565217, 0.5
24743, 1.4608695652174, 0.93260869565217, 0.5
24744, 1.504347826087, 0.93260869565217, 0.5
24745, 1.5478260869565, 0.93260869565217, 0.5
24746, 1.5913043478261, 0.93260869565217, 0.5
24747, 1.6347826086957, 0.93260869565217, 0.5
24748, 1.6782608695652, 0.93260869565217, 0.5
24749, 1.7217391304348, 0.93260869565217, 0.5
24750, 1.7652173913043, 0.93260869565217, 0.5
24751, 1.8086956521739, 0.93260869565217, 0.5
24752, 1.8521739130435, 0.93260869565217, 0.5
24753, 1.895652173913, 0.93260869565217, 0.5
24754, 1.9391304347826, 0.93260869565217, 0.5
24755, 1.9826086956522, 0.93260869565217, 0.5
24756, 2.0260869565217, 0.93260869565217, 0.5
24757, 2.0695652173913, 0.93260869565217, 0.5
24758, 2.1130434782609, 0.93260869565217, 0.5
24759, 2.1565217391304, 0.93260869565217, 0.5
24760, 1.2434782608696, 0.8804347826087, 0.5
24761, 1.2869565217391, 0.8804347826087, 0.5
24762, 1.3304347826087, 0.8804347826087, 0.5
24763, 1.3739130434783, 0.8804347826087, 0.5
24764, 1.4173913043478, 0.8804347826087, 0.5
24765, 1.4608695652174, 0.8804347826087, 0.5
24766, 1.504347826087, 0.8804347826087, 0.5
24767, 1.5478260869565, 0.8804347826087, 0.5
24768, 1.5913043478261, 0.8804347826087, 0.5
24769, 1.6347826086957, 0.8804347826087, 0.5
24770, 1.6782608695652, 0.8804347826087, 0.5
24771, 1.7217391304348, 0.8804347826087, 0.5
24772, 1.7652173913043, 0.8804347826087, 0.5
24773, 1.8086956521739, 0.8804347826087, 0.5
24774, 1.8521739130435, 0.8804347826087, 0.5
24775, 1.895652173913, 0.8804347826087, 0.5
24776, 1.9391304347826, 0.8804347826087, 0.5
24777, 1.9826086956522, 0.8804347826087, 0.5
24778, 2.0260869565217, 0.8804347826087, 0.5
24779, 2.0695652173913, 0.8804347826087, 0.5
24780, 2.1130434782609, 0.8804347826087, 0.5
24781, 2.1565217391304, 0.8804347826087, 0.5
24782, 1.2434782608696, 0.82826086956522, 0.5
24783, 1.2869565217391, 0.82826086956522, 0.5
24784, 1.3304347826087, 0.82826086956522, 0.5
24785, 1.3739130434783, 0.82826086956522, 0.5
24786, 1.4173913043478, 0.82826086956522, 0.5
24787, 1.4608695652174, 0.82826086956522, 0.5
24788, 1.504347826087, 0.82826086956522, 0.5
24789, 1.5478260869565, 0.82826086956522, 0.5
24790, 1.5913043478261, 0.82826086956522, 0.5
24791, 1.6347826086957, 0.82826086956522, 0.5
24792, 1.6782608695652, 0.82826086956522, 0.5
24793, 1.7217391304348, 0.82826086956522, 0.5
24794, 1.7652173913043, 0.82826086956522, 0.5
24795, 1.8086956521739, 0.82826086956522, 0.5
24796, 1.8521739130435, 0.82826086956522, 0.5
24797, 1.895652173913, 0.82826086956522, 0.5
24798, 1.9391304347826, 0.82826086956522, 0.5
24799, 1.9826086956522, 0.82826086956522, 0.5
24800, 2.0260869565217, 0.82826086956522, 0.5
24801, 2.0695652173913, 0.82826086956522, 0.5
24802, 2.1130434782609, 0.82826086956522, 0.5
24803, 2.1565217391304, 0.82826086956522, 0.5
24804, 1.2434782608696, 0.77608695652174, 0.5
24805, 1.2869565217391, 0.77608695652174, 0.5
24806, 1.3304347826087, 0.77608695652174, 0.5
24807, 1.3739130434783, 0.77608695652174, 0.5
24808, 1.4173913043478, 0.77608695652174, 0.5
24809, 1.4608695652174, 0.77608695652174, 0.5
24810, 1.504347826087, 0.77608695652174, 0.5
24811, 1.5478260869565, 0.77608695652174, 0.5
24812, 1.5913043478261, 0.77608695652174, 0.5
24813, 1.6347826086957, 0.77608695652174, 0.5
24814, 1.6782608695652, 0.77608695652174, 0.5
24815, 1.7217391304348, 0.77608695652174, 0.5
24816, 1.7652173913043, 0.77608695652174, 0.5
24817, 1.8086956521739, 0.77608695652174, 0.5
24818, 1.8521739130435, 0.77608695652174, 0.5
24819, 1.895652173913, 0.77608695652174, 0.5
24820, 1.9391304347826, 0.77608695652174, 0.5
24821, 1.9826086956522, 0.77608695652174, 0.5
24822, 2.0260869565217, 0.77608695652174, 0.5
24823, 2.0695652173913, 0.77608695652174, 0.5
24824, 2.1130434782609, 0.77608695652174, 0.5
24825, 2.1565217391304, 0.77608695652174, 0.5
24826, 1.2434782608696, 0.72391304347826, 0.5
24827, 1.2869565217391, 0.72391304347826, 0.5
24828, 1.3304347826087, 0.72391304347826, 0.5
24829, 1.3739130434783, 0.72391304347826, 0.5
24830, 1.4173913043478, 0.72391304347826, 0.5
24831, 1.4608695652174, 0.72391304347826, 0.5
24832, 1.504347826087, 0.72391304347826, 0.5
24833, 1.5478260869565, 0.72391304347826, 0.5
24834, 1.5913043478261, 0.72391304347826, 0.5
24835, 1.6347826086957, 0.72391304347826, 0.5
24836, 1.6782608695652, 0.72391304347826, 0.5
24837, 1.7217391304348, 0.72391304347826, 0.5
24838, 1.7652173913043, 0.72391304347826, 0.5
24839, 1.8086956521739, 0.72391304347826, 0.5
24840, 1.8521739130435, 0.72391304347826, 0.5
24841, 1.895652173913, 0.72391304347826, 0.5
24842, 1.9391304347826, 0.72391304347826, 0.5
24843, 1.9826086956522, 0.72391304347826, 0.5
24844, 2.0260869565217, 0.72391304347826, 0.5
24845, 2.0695652173913, 0.72391304347826, 0.5
24846, 2.1130434782609, 0.72391304347826, 0.5
24847, 2.1565217391304, 0.72391304347826, 0.5
24848, 1.2434782608696, 0.67173913043478, 0.5
24849, 1.2869565217391, 0.67173913043478, 0.5
24850, 1.3304347826087, 0.67173913043478, 0.5
24851, 1.3739130434783, 0.67173913043478, 0.5
24852, 1.4173913043478, 0.67173913043478, 0.5
24853, 1.4608695652174, 0.67173913043478, 0.5
24854, 1.504347826087, 0.67173913043478, 0.5
24855, 1.5478260869565, 0.67173913043478, 0.5
24856, 1.5913043478261, 0.67173913043478, 0.5
24857, 1.6347826086957, 0.67173913043478, 0.5
24858, 1.6782608695652, 0.67173913043478, 0.5
24859, 1.7217391304348, 0.67173913043478, 0.5
24860, 1.7652173913043, 0.67173913043478, 0.5
24861, 1.8086956521739, 0.67173913043478, 0.5
24862, 1.8521739130435, 0.67173913043478, 0.5
24863, 1.895652173913, 0.67173913043478, 0.5
24864, 1.9391304347826, 0.67173913043478, 0.5
24865, 1.9826086956522, 0.67173913043478, 0.5
24866, 2.0260869565217, 0.67173913043478, 0.5
24867, 2.0695652173913, 0.67173913043478, 0.5
24868, 2.1130434782609, 0.67173913043478, 0.5
24869, 2.1565217391304, 0.67173913043478, 0.5
24870, 1.2434782608696, 0.61956521739131, 0.5
24871, 1.2869565217391, 0.61956521739131, 0.5
24872, 1.3304347826087, 0.61956521739131, 0.5
24873, 1.3739130434783, 0.61956521739131, 0.5
24874, 1.4173913043478, 0.61956521739131, 0.5
24875, 1.4608695652174, 0.61956521739131, 0.5
24876, 1.504347826087, 0.6195652173913, 0.5
24877, 1.5478260869565, 0.61956521739131, 0.5
24878, 1.5913043478261, 0.61956521739131, 0.5
24879, 1.6347826086957, 0.61956521739131, 0.5
24880, 1.6782608695652, 0.61956521739131, 0.5
24881, 1.7217391304348, 0.61956521739131, 0.5
24882, 1.7652173913043, 0.61956521739131, 0.5
24883, 1.8086956521739, 0.61956521739131, 0.5
24884, 1.8521739130435, 0.61956521739131, 0.5
24885, 1.895652173913, 0.61956521739131, 0.5
24886, 1.9391304347826, 0.61956521739131, 0.5
24887, 1.9826086956522, 0.61956521739131, 0.5
24888, 2.0260869565217, 0.61956521739131, 0.5
24889, 2.0695652173913, 0.61956521739131, 0.5
24890, 2.1130434782609, 0.61956521739131, 0.5
24891, 2.1565217391304, 0.61956521739131, 0.5
24892, 1.2434782608696, 0.56739130434783, 0.5
24893, 1.2869565217391, 0.56739130434783, 0.5
24894, 1.3304347826087, 0.56739130434783, 0.5
24895, 1.3739130434783, 0.56739130434783, 0.5
24896, 1.4173913043478, 0.56739130434783, 0.5
24897, 1.4608695652174, 0.56739130434783, 0.5
24898, 1.504347826087, 0.56739130434783, 0.5
24899, 1.5478260869565, 0.56739130434783, 0.5
24900, 1.5913043478261, 0.56739130434783, 0.5
24901, 1.6347826086957, 0.56739130434783, 0.5
24902, 1.6782608695652, 0.56739130434783, 0.5
24903, 1.7217391304348, 0.56739130434783, 0.5
24904, 1.7652173913043, 0.56739130434783, 0.5
24905, 1.8086956521739, 0.56739130434783, 0.5
24906, 1.8521739130435, 0.56739130434783, 0.5
24907, 1.895652173913, 0.56739130434783, 0.5
24908, 1.9391304347826, 0.56739130434783, 0.5
24909, 1.9826086956522, 0.56739130434783, 0.5
24910, 2.0260869565217, 0.56739130434783, 0.5
24911, 2.0695652173913, 0.56739130434783, 0.5
24912, 2.1130434782609, 0.56739130434783, 0.5
24913, 2.1565217391304, 0.56739130434783, 0.5
24914, 1.2434782608696, 0.51521739130435, 0.5
24915, 1.2869565217391, 0.51521739130435, 0.5
24916, 1.3304347826087, 0.51521739130435, 0.5
24917, 1.3739130434783, 0.51521739130435, 0.5
24918, 1.4173913043478, 0.51521739130435, 0.5
24919, 1.4608695652174, 0.51521739130435, 0.5
24920, 1.504347826087, 0.51521739130435, 0.5
24921, 1.5478260869565, 0.51521739130435, 0.5
24922, 1.5913043478261, 0.51521739130435, 0.5
24923, 1.6347826086957, 0.51521739130435, 0.5
24924, 1.6782608695652, 0.51521739130435, 0.5
24925, 1.7217391304348, 0.51521739130435, 0.5
24926, 1.7652173913043, 0.51521739130435, 0.5
24927, 1.8086956521739, 0.51521739130435, 0.5
24928, 1.8521739130435, 0.51521739130435, 0.5
24929, 1.895652173913, 0.51521739130435, 0.5
24930, 1.9391304347826, 0.51521739130435, 0.5
24931, 1.9826086956522, 0.51521739130435, 0.5
24932, 2.0260869565217, 0.51521739130435, 0.5
24933, 2.0695652173913, 0.51521739130435, 0.5
24934, 2.1130434782609, 0.51521739130435, 0.5
24935, 2.1565217391304, 0.51521739130435, 0.5
24936, 1.2434782608696, 0.46304347826087, 0.5
24937, 1.2869565217391, 0.46304347826087, 0.5
24938, 1.3304347826087, 0.46304347826087, 0.5
24939, 1.3739130434783, 0.46304347826087, 0.5
24940, 1.4173913043478, 0.46304347826087, 0.5
24941, 1.4608695652174, 0.46304347826087, 0.5
24942, 1.504347826087, 0.46304347826087, 0.5
24943, 1.5478260869565, 0.46304347826087, 0.5
24944, 1.5913043478261, 0.46304347826087, 0.5
24945, 1.6347826086957, 0.46304347826087, 0.5
24946, 1.6782608695652, 0.46304347826087, 0.5
24947, 1.7217391304348, 0.46304347826087, 0.5
24948, 1.7652173913043, 0.46304347826087, 0.5
24949, 1.8086956521739, 0.46304347826087, 0.5
24950, 1.8521739130435, 0.46304347826087, 0.5
24951, 1.895652173913, 0.46304347826087, 0.5
24952, 1.9391304347826, 0.46304347826087, 0.5
24953, 1.9826086956522, 0.46304347826087, 0.5
24954, 2.0260869565217, 0.46304347826087, 0.5
24955, 2.0695652173913, 0.46304347826087, 0.5
24956, 2.1130434782609, 0.46304347826087, 0.5
24957, 2.1565217391304, 0.46304347826087, 0.5
24958, 1.2434782608696, 0.41086956521739, 0.5
24959, 1.2869565217391, 0.41086956521739, 0.5
24960, 1.3304347826087, 0.41086956521739, 0.5
24961, 1.3739130434783, 0.41086956521739, 0.5
24962, 1.4173913043478, 0.41086956521739, 0.5
24963, 1.4608695652174, 0.41086956521739, 0.5
24964, 1.504347826087, 0.41086956521739, 0.5
24965, 1.5478260869565, 0.41086956521739, 0.5
24966, 1.5913043478261, 0.41086956521739, 0.5
24967, 1.6347826086957, 0.41086956521739, 0.5
24968, 1.6782608695652, 0.41086956521739, 0.5
24969, 1.7217391304348, 0.41086956521739, 0.5
24970, 1.7652173913043, 0.41086956521739, 0.5
24971, 1.8086956521739, 0.41086956521739, 0.5
24972, 1.8521739130435, 0.41086956521739, 0.5
24973, 1.895652173913, 0.41086956521739, 0.5
24974, 1.9391304347826, 0.41086956521739, 0.5
24975, 1.9826086956522, 0.41086956521739, 0.5
24976, 2.0260869565217, 0.41086956521739, 0.5
24977, 2.0695652173913, 0.41086956521739, 0.5
24978, 2.1130434782609, 0.41086956521739, 0.5
24979, 2.1565217391304, 0.41086956521739, 0.5
24980, 1.2434782608696, 0.35869565217391, 0.5
24981, 1.2869565217391, 0.35869565217391, 0.5
24982, 1.3304347826087, 0.35869565217391, 0.5
24983, 1.3739130434783, 0.35869565217391, 0.5
24984, 1.4173913043478, 0.35869565217391, 0.5
24985, 1.4608695652174, 0.35869565217391, 0.5
24986, 1.504347826087, 0.35869565217391, 0.5
24987, 1.5478260869565, 0.35869565217391, 0.5
24988, 1.5913043478261, 0.35869565217391, 0.5
24989, 1.6347826086957, 0.35869565217391, 0.5
24990, 1.6782608695652, 0.35869565217391, 0.5
24991, 1.7217391304348, 0.35869565217391, 0.5
24992, 1.7652173913043, 0.35869565217391, 0.5
24993, 1.8086956521739, 0.35869565217391, 0.5
24994, 1.8521739130435, 0.35869565217391, 0.5
24995, 1.895652173913, 0.35869565217391, 0.5
24996, 1.9391304347826, 0.35869565217391, 0.5
24997, 1.9826086956522, 0.35869565217391, 0.5
24998, 2.0260869565217, 0.35869565217391, 0.5
24999, 2.0695652173913, 0.35869565217391, 0.5
25000, 2.1130434782609, 0.35869565217391, 0.5
25001, 2.1565217391304, 0.35869565217391, 0.5
25002, 1.2434782608696, 0.30652173913044, 0.5
25003, 1.2869565217391, 0.30652173913043, 0.5
25004, 1.3304347826087, 0.30652173913043, 0.5
25005, 1.3739130434783, 0.30652173913044, 0.5
25006, 1.4173913043478, 0.30652173913044, 0.5
25007, 1.4608695652174, 0.30652173913043, 0.5
25008, 1.504347826087, 0.30652173913044, 0.5
25009, 1.5478260869565, 0.30652173913044, 0.5
25010, 1.5913043478261, 0.30652173913044, 0.5
25011, 1.6347826086957, 0.30652173913043, 0.5
25012, 1.6782608695652, 0.30652173913043, 0.5
25013, 1.7217391304348, 0.30652173913043, 0.5
25014, 1.7652173913043, 0.30652173913043, 0.5
25015, 1.8086956521739, 0.30652173913044, 0.5
25016, 1.8521739130435, 0.30652173913043, 0.5
25017, 1.895652173913, 0.30652173913044, 0.5
25018, 1.9391304347826, 0.30652173913043, 0.5
25019, 1.9826086956522, 0.30652173913044, 0.5
25020, 2.0260869565217, 0.30652173913044, 0.5
25021, 2.0695652173913, 0.30652173913043, 0.5
25022, 2.1130434782609, 0.30652173913043, 0.5
25023, 2.1565217391304, 0.30652173913043, 0.5
25024, 1.2434782608696, 0.25434782608696, 0.5
25025, 1.2869565217391, 0.25434782608696, 0.5
25026, 1.3304347826087, 0.25434782608696, 0.5
25027, 1.3739130434783, 0.25434782608696, 0.5
25028, 1.4173913043478, 0.25434782608696, 0.5
25029, 1.4608695652174, 0.25434782608696, 0.5
25030, 1.504347826087, 0.25434782608696, 0.5
25031, 1.5478260869565, 0.25434782608696, 0.5
25032, 1.5913043478261, 0.25434782608696, 0.5
25033, 1.6347826086957, 0.25434782608696, 0.5
25034, 1.6782608695652, 0.25434782608696, 0.5
25035, 1.7217391304348, 0.25434782608696, 0.5
25036, 1.7652173913043, 0.25434782608696, 0.5
25037, 1.8086956521739, 0.25434782608696, 0.5
25038, 1.8521739130435, 0.25434782608696, 0.5
25039, 1.895652173913, 0.25434782608696, 0.5
25040, 1.9391304347826, 0.25434782608696, 0.5
25041, 1.9826086956522, 0.25434782608696, 0.5
25042, 2.0260869565217, 0.25434782608696, 0.5
25043, 2.0695652173913, 0.25434782608696, 0.5
25044, 2.1130434782609, 0.25434782608696, 0.5
25045, 2.1565217391304, 0.25434782608696, 0.5
25046, 1.2434782608696, 0.20217391304348, 0.5
25047, 1.2869565217391, 0.20217391304348, 0.5
25048, 1.3304347826087, 0.20217391304348, 0.5
25049, 1.3739130434783, 0.20217391304348, 0.5
25050, 1.4173913043478, 0.20217391304348, 0.5
25051, 1.4608695652174, 0.20217391304348, 0.5
25052, 1.504347826087, 0.20217391304348, 0.5
25053, 1.5478260869565, 0.20217391304348, 0.5
25054, 1.5913043478261, 0.20217391304348, 0.5
25055, 1.6347826086957, 0.20217391304348, 0.5
25056, 1.6782608695652, 0.20217391304348, 0.5
25057, 1.7217391304348, 0.20217391304348, 0.5
25058, 1.7652173913043, 0.20217391304348, 0.5
25059, 1.8086956521739, 0.20217391304348, 0.5
25060, 1.8521739130435, 0.20217391304348, 0.5
25061, 1.895652173913, 0.20217391304348, 0.5
25062, 1.9391304347826, 0.20217391304348, 0.5
25063, 1.9826086956522, 0.20217391304348, 0.5
25064, 2.0260869565217, 0.20217391304348, 0.5
25065, 2.0695652173913, 0.20217391304348, 0.5
25066, 2.1130434782609, 0.20217391304348, 0.5
25067, 2.1565217391304, 0.20217391304348, 0.5
25068, 1.2217391304348, 1.2978260869565, 0.5
25069, 1.2434782608696, 1.3239130434783, 0.5
25070, 1.2652173913043, 1.2978260869565, 0.5
25071, 1.2869565217391, 1.3239130434783, 0.5
25072, 1.3086956521739, 1.2978260869565, 0.5
25073, 1.3304347826087, 1.3239130434783, 0.5
25074, 1.3521739130435, 1.2978260869565, 0.5
25075, 1.3739130434783, 1.3239130434783, 0.5
25076, 1.395652173913, 1.2978260869565, 0.5
25077, 1.4173913043478, 1.3239130434783, 0.5
25078, 1.4391304347826, 1.2978260869565, 0.5
25079, 1.4608695652174, 1.3239130434783, 0.5
25080, 1.4826086956522, 1.2978260869565, 0.5
25081, 1.504347826087, 1.3239130434783, 0.5
25082, 1.5260869565217, 1.2978260869565, 0.5
25083, 1.5478260869565, 1.3239130434783, 0.5
25084, 1.5695652173913, 1.2978260869565, 0.5
25085, 1.5913043478261, 1.3239130434783, 0.5
25086, 1.6130434782609, 1.2978260869565, 0.5
25087, 1.6347826086957, 1.3239130434783, 0.5
25088, 1.6565217391304, 1.2978260869565, 0.5
25089, 1.6782608695652, 1.3239130434783, 0.5
25090, 1.7, 1.2978260869565, 0.5
25091, 1.7217391304348, 1.3239130434783, 0.5
25092, 1.7434782608696, 1.2978260869565, 0.5
25093, 1.7652173913043, 1.3239130434783, 0.5
25094, 1.7869565217391, 1.2978260869565, 0.5
25095, 1.8086956521739, 1.3239130434783, 0.5
25096, 1.8304347826087, 1.2978260869565, 0.5
25097, 1.8521739130435, 1.3239130434783, 0.5
25098, 1.8739130434783, 1.2978260869565, 0.5
25099, 1.895652173913, 1.3239130434783, 0.5
25100, 1.9173913043478, 1.2978260869565, 0.5
25101, 1.9391304347826, 1.3239130434783, 0.5
25102, 1.9608695652174, 1.2978260869565, 0.5
25103, 1.9826086956522, 1.3239130434783, 0.5
25104, 2.004347826087, 1.2978260869565, 0.5
25105, 2.0260869565217, 1.3239130434783, 0.5
25106, 2.0478260869565, 1.2978260869565, 0.5
25107, 2.0695652173913, 1.3239130434783, 0.5
25108, 2.0913043478261, 1.2978260869565, 0.5
25109, 2.1130434782609, 1.3239130434783, 0.5
25110, 2.1347826086957, 1.2978260869565, 0.5
25111, 2.1565217391304, 1.3239130434783, 0.5
25112, 2.1782608695652, 1.2978260869565, 0.5
25113, 1.2217391304348, 1.245652173913, 0.5
25114, 1.2434782608696, 1.2717391304348, 0.5
25115, 1.2652173913043, 1.245652173913, 0.5
25116, 1.2869565217391, 1.2717391304348, 0.5
25117, 1.3086956521739, 1.245652173913, 0.5
25118, 1.3304347826087, 1.2717391304348, 0.5
25119, 1.3521739130435, 1.245652173913, 0.5
25120, 1.3739130434783, 1.2717391304348, 0.5
25121, 1.395652173913, 1.245652173913, 0.5
25122, 1.4173913043478, 1.2717391304348, 0.5
25123, 1.4391304347826, 1.245652173913, 0.5
25124, 1.4608695652174, 1.2717391304348, 0.5
25125, 1.4826086956522, 1.245652173913, 0.5
25126, 1.504347826087, 1.2717391304348, 0.5
25127, 1.5260869565217, 1.245652173913, 0.5
25128, 1.5478260869565, 1.2717391304348, 0.5
25129, 1.5695652173913, 1.245652173913, 0.5
25130, 1.5913043478261, 1.2717391304348, 0.5
25131, 1.6130434782609, 1.245652173913, 0.5
25132, 1.6347826086957, 1.2717391304348, 0.5
25133, 1.6565217391304, 1.245652173913, 0.5
25134, 1.6782608695652, 1.2717391304348, 0.5
25135, 1.7, 1.245652173913, 0.5
25136, 1.7217391304348, 1.2717391304348, 0.5
25137, 1.7434782608696, 1.245652173913, 0.5
25138, 1.7652173913043, 1.2717391304348, 0.5
25139, 1.7869565217391, 1.245652173913, 0.5
25140, 1.8086956521739, 1.2717391304348, 0.5
25141, 1.8304347826087, 1.245652173913, 0.5
25142, 1.8521739130435, 1.2717391304348, 0.5
25143, 1.8739130434783, 1.245652173913, 0.5
25144, 1.895652173913, 1.2717391304348, 0.5
25145, 1.9173913043478, 1.245652173913, 0.5
25146, 1.9391304347826, 1.2717391304348, 0.5
25147, 1.9608695652174, 1.245652173913, 0.5
25148, 1.9826086956522, 1.2717391304348, 0.5
25149, 2.004347826087, 1.245652173913, 0.5
25150, 2.0260869565217, 1.2717391304348, 0.5
25151, 2.0478260869565, 1.245652173913, 0.5
25152, 2.0695652173913, 1.2717391304348, 0.5
25153, 2.0913043478261, 1.245652173913, 0.5
25154, 2.1130434782609, 1.2717391304348, 0.5
25155, 2.1347826086957, 1.245652173913, 0.5
25156, 2.1565217391304, 1.2717391304348, 0.5
25157, 2.1782608695652, 1.245652173913, 0.5
25158, 1.2217391304348, 1.1934782608696, 0.5
25159, 1.2434782608696, 1.2195652173913, 0.5
25160, 1.2652173913043, 1.1934782608696, 0.5
25161, 1.2869565217391, 1.2195652173913, 0.5
25162, 1.3086956521739, 1.1934782608696, 0.5
25163, 1.3304347826087, 1.2195652173913, 0.5
25164, 1.3521739130435, 1.1934782608696, 0.5
25165, 1.3739130434783, 1.2195652173913, 0.5
25166, 1.395652173913, 1.1934782608696, 0.5
25167, 1.4173913043478, 1.2195652173913, 0.5
25168, 1.4391304347826, 1.1934782608696, 0.5
25169, 1.4608695652174, 1.2195652173913, 0.5
25170, 1.4826086956522, 1.1934782608696, 0.5
25171, 1.504347826087, 1.2195652173913, 0.5
25172, 1.5260869565217, 1.1934782608696, 0.5
25173, 1.5478260869565, 1.2195652173913, 0.5
25174, 1.5695652173913, 1.1934782608696, 0.5
25175, 1.5913043478261, 1.2195652173913, 0.5
25176, 1.6130434782609, 1.1934782608696, 0.5
25177, 1.6347826086957, 1.2195652173913, 0.5
25178, 1.6565217391304, 1.1934782608696, 0.5
25179, 1.6782608695652, 1.2195652173913, 0.5
25180, 1.7, 1.1934782608696, 0.5
25181, 1.7217391304348, 1.2195652173913, 0.5
25182, 1.7434782608696, 1.1934782608696, 0.5
25183, 1.7652173913043, 1.2195652173913, 0.5
25184, 1.7869565217391, 1.1934782608696, 0.5
25185, 1.8086956521739, 1.2195652173913, 0.5
25186, 1.8304347826087, 1.1934782608696, 0.5
25187, 1.8521739130435, 1.2195652173913, 0.5
25188, 1.8739130434783, 1.1934782608696, 0.5
25189, 1.895652173913, 1.2195652173913, 0.5
25190, 1.9173913043478, 1.1934782608696, 0.5
25191, 1.9391304347826, 1.2195652173913, 0.5
25192, 1.9608695652174, 1.1934782608696, 0.5
25193, 1.9826086956522, 1.2195652173913, 0.5
25194, 2.004347826087, 1.1934782608696, 0.5
25195, 2.0260869565217, 1.2195652173913, 0.5
25196, 2.0478260869565, 1.1934782608696, 0.5
25197, 2.0695652173913, 1.2195652173913, 0.5
25198, 2.0913043478261, 1.1934782608696, 0.5
25199, 2.1130434782609, 1.2195652173913, 0.5
25200, 2.1347826086957, 1.1934782608696, 0.5
25201, 2.1565217391304, 1.2195652173913, 0.5
25202, 2.1782608695652, 1.1934782608696, 0.5
25203, 1.2217391304348, 1.1413043478261, 0.5
25204, 1.2434782608696, 1.1673913043478, 0.5
25205, 1.2652173913043, 1.1413043478261, 0.5
25206, 1.2869565217391, 1.1673913043478, 0.5
25207, 1.3086956521739, 1.1413043478261, 0.5
25208, 1.3304347826087, 1.1673913043478, 0.5
25209, 1.3521739130435, 1.1413043478261, 0.5
25210, 1.3739130434783, 1.1673913043478, 0.5
25211, 1.395652173913, 1.1413043478261, 0.5
25212, 1.4173913043478, 1.1673913043478, 0.5
25213, 1.4391304347826, 1.1413043478261, 0.5
25214, 1.4608695652174, 1.1673913043478, 0.5
25215, 1.4826086956522, 1.1413043478261, 0.5
25216, 1.504347826087, 1.1673913043478, 0.5
25217, 1.5260869565217, 1.1413043478261, 0.5
25218, 1.5478260869565, 1.1673913043478, 0.5
25219, 1.5695652173913, 1.1413043478261, 0.5
25220, 1.5913043478261, 1.1673913043478, 0.5
25221, 1.6130434782609, 1.1413043478261, 0.5
25222, 1.6347826086957, 1.1673913043478, 0.5
25223, 1.6565217391304, 1.1413043478261, 0.5
25224, 1.6782608695652, 1.1673913043478, 0.5
25225, 1.7, 1.1413043478261, 0.5
25226, 1.7217391304348, 1.1673913043478, 0.5
25227, 1.7434782608696, 1.1413043478261, 0.5
25228, 1.7652173913043, 1.1673913043478, 0.5
25229, 1.7869565217391, 1.1413043478261, 0.5
25230, 1.8086956521739, 1.1673913043478, 0.5
25231, 1.8304347826087, 1.1413043478261, 0.5
25232, 1.8521739130435, 1.1673913043478, 0.5
25233, 1.8739130434783, 1.1413043478261, 0.5
25234, 1.895652173913, 1.1673913043478, 0.5
25235, 1.9173913043478, 1.1413043478261, 0.5
25236, 1.9391304347826, 1.1673913043478, 0.5
25237, 1.9608695652174, 1.1413043478261, 0.5
25238, 1.9826086956522, 1.1673913043478, 0.5
25239, 2.004347826087, 1.1413043478261, 0.5
25240, 2.0260869565217, 1.1673913043478, 0.5
25241, 2.0478260869565, 1.1413043478261, 0.5
25242, 2.0695652173913, 1.1673913043478, 0.5
25243, 2.0913043478261, 1.1413043478261, 0.5
25244, 2.1130434782609, 1.1673913043478, 0.5
25245, 2.1347826086957, 1.1413043478261, 0.5
25246, 2.1565217391304, 1.1673913043478, 0.5
25247, 2.1782608695652, 1.1413043478261, 0.5
25248, 1.2217391304348, 1.0891304347826, 0.5
25249, 1.2434782608696, 1.1152173913043, 0.5
25250, 1.2652173913043, 1.0891304347826, 0.5
25251, 1.2869565217391, 1.1152173913043, 0.5
25252, 1.3086956521739, 1.0891304347826, 0.5
25253, 1.3304347826087, 1.1152173913043, 0.5
25254, 1.3521739130435, 1.0891304347826, 0.5
25255, 1.3739130434783, 1.1152173913043, 0.5
25256, 1.395652173913, 1.0891304347826, 0.5
25257, 1.4173913043478, 1.1152173913043, 0.5
25258, 1.4391304347826, 1.0891304347826, 0.5
25259, 1.4608695652174, 1.1152173913043, 0.5
25260, 1.4826086956522, 1.0891304347826, 0.5
25261, 1.504347826087, 1.1152173913043, 0.5
25262, 1.5260869565217, 1.0891304347826, 0.5
25263, 1.5478260869565, 1.1152173913043, 0.5
25264, 1.5695652173913, 1.0891304347826, 0.5
25265, 1.5913043478261, 1.1152173913043, 0.5
25266, 1.6130434782609, 1.0891304347826, 0.5
25267, 1.6347826086957, 1.1152173913043, 0.5
25268, 1.6565217391304, 1.0891304347826, 0.5
25269, 1.6782608695652, 1.1152173913043, 0.5
25270, 1.7, 1.0891304347826, 0.5
25271, 1.7217391304348, 1.1152173913043, 0.5
25272, 1.7434782608696, 1.0891304347826, 0.5
25273, 1.7652173913043, 1.1152173913043, 0.5
25274, 1.7869565217391, 1.0891304347826, 0.5
25275, 1.8086956521739, 1.1152173913043, 0.5
25276, 1.8304347826087, 1.0891304347826, 0.5
25277, 1.8521739130435, 1.1152173913043, 0.5
25278, 1.8739130434783, 1.0891304347826, 0.5
25279, 1.895652173913, 1.1152173913043, 0.5
25280, 1.9173913043478, 1.0891304347826, 0.5
25281, 1.9391304347826, 1.1152173913043, 0.5
25282, 1.9608695652174, 1.0891304347826, 0.5
25283, 1.9826086956522, 1.1152173913043, 0.5
25284, 2.004347826087, 1.0891304347826, 0.5
25285, 2.0260869565217, 1.1152173913043, 0.5
25286, 2.0478260869565, 1.0891304347826, 0.5
25287, 2.0695652173913, 1.1152173913043, 0.5
25288, 2.0913043478261, 1.0891304347826, 0.5
25289, 2.1130434782609, 1.1152173913043, 0.5
25290, 2.1347826086957, 1.0891304347826, 0.5
25291, 2.1565217391304, 1.1152173913043, 0.5
25292, 2.1782608695652, 1.0891304347826, 0.5
25293, 1.2217391304348, 1.0369565217391, 0.5
25294, 1.2434782608696, 1.0630434782609, 0.5
25295, 1.2652173913043, 1.0369565217391, 0.5
25296, 1.2869565217391, 1.0630434782609, 0.5
25297, 1.3086956521739, 1.0369565217391, 0.5
25298, 1.3304347826087, 1.0630434782609, 0.5
25299, 1.3521739130435, 1.0369565217391, 0.5
25300, 1.3739130434783, 1.0630434782609, 0.5
25301, 1.395652173913, 1.0369565217391, 0.5
25302, 1.4173913043478, 1.0630434782609, 0.5
25303, 1.4391304347826, 1.0369565217391, 0.5
25304, 1.4608695652174, 1.0630434782609, 0.5
25305, 1.4826086956522, 1.0369565217391, 0.5
25306, 1.504347826087, 1.0630434782609, 0.5
25307, 1.5260869565217, 1.0369565217391, 0.5
25308, 1.5478260869565, 1.0630434782609, 0.5
25309, 1.5695652173913, 1.0369565217391, 0.5
25310, 1.5913043478261, 1.0630434782609, 0.5
25311, 1.6130434782609, 1.0369565217391, 0.5
25312, 1.6347826086957, 1.0630434782609, 0.5
25313, 1.6565217391304, 1.0369565217391, 0.5
25314, 1.6782608695652, 1.0630434782609, 0.5
25315, 1.7, 1.0369565217391, 0.5
25316, 1.7217391304348, 1.0630434782609, 0.5
25317, 1.7434782608696, 1.0369565217391, 0.5
25318, 1.7652173913043, 1.0630434782609, 0.5
25319, 1.7869565217391, 1.0369565217391, 0.5
25320, 1.8086956521739, 1.0630434782609, 0.5
25321, 1.8304347826087, 1.0369565217391, 0.5
25322, 1.8521739130435, 1.0630434782609, 0.5
25323, 1.8739130434783, 1.0369565217391, 0.5
25324, 1.895652173913, 1.0630434782609, 0.5
25325, 1.9173913043478, 1.0369565217391, 0.5
25326, 1.9391304347826, 1.0630434782609, 0.5
25327, 1.9608695652174, 1.0369565217391, 0.5
25328, 1.9826086956522, 1.0630434782609, 0.5
25329, 2.004347826087, 1.0369565217391, 0.5
25330, 2.0260869565217, 1.0630434782609, 0.5
25331, 2.0478260869565, 1.0369565217391, 0.5
25332, 2.0695652173913, 1.0630434782609, 0.5
25333, 2.0913043478261, 1.0369565217391, 0.5
25334, 2.1130434782609, 1.0630434782609, 0.5
25335, 2.1347826086957, 1.0369565217391, 0.5
25336, 2.1565217391304, 1.0630434782609, 0.5
25337, 2.1782608695652, 1.0369565217391, 0.5
25338, 1.2217391304348, 0.98478260869565, 0.5
25339, 1.2434782608696, 1.0108695652174, 0.5
25340, 1.2652173913043, 0.98478260869565, 0.5
25341, 1.2869565217391, 1.0108695652174, 0.5
25342, 1.3086956521739, 0.98478260869565, 0.5
25343, 1.3304347826087, 1.0108695652174, 0.5
25344, 1.3521739130435, 0.98478260869565, 0.5
25345, 1.3739130434783, 1.0108695652174, 0.5
25346, 1.395652173913, 0.98478260869565, 0.5
25347, 1.4173913043478, 1.0108695652174, 0.5
25348, 1.4391304347826, 0.98478260869565, 0.5
25349, 1.4608695652174, 1.0108695652174, 0.5
25350, 1.4826086956522, 0.98478260869565, 0.5
25351, 1.504347826087, 1.0108695652174, 0.5
25352, 1.5260869565217, 0.98478260869565, 0.5
25353, 1.5478260869565, 1.0108695652174, 0.5
25354, 1.5695652173913, 0.98478260869565, 0.5
25355, 1.5913043478261, 1.0108695652174, 0.5
25356, 1.6130434782609, 0.98478260869565, 0.5
25357, 1.6347826086957, 1.0108695652174, 0.5
25358, 1.6565217391304, 0.98478260869565, 0.5
25359, 1.6782608695652, 1.0108695652174, 0.5
25360, 1.7, 0.98478260869565, 0.5
25361, 1.7217391304348, 1.0108695652174, 0.5
25362, 1.7434782608696, 0.98478260869565, 0.5
25363, 1.7652173913043, 1.0108695652174, 0.5
25364, 1.7869565217391, 0.98478260869565, 0.5
25365, 1.8086956521739, 1.0108695652174, 0.5
25366, 1.8304347826087, 0.98478260869565, 0.5
25367, 1.8521739130435, 1.0108695652174, 0.5
25368, 1.8739130434783, 0.98478260869565, 0.5
25369, 1.895652173913, 1.0108695652174, 0.5
25370, 1.9173913043478, 0.98478260869565, 0.5
25371, 1.9391304347826, 1.0108695652174, 0.5
25372, 1.9608695652174, 0.98478260869565, 0.5
25373, 1.9826086956522, 1.0108695652174, 0.5
25374, 2.004347826087, 0.98478260869565, 0.5
25375, 2.0260869565217, 1.0108695652174, 0.5
25376, 2.0478260869565, 0.98478260869565, 0.5
25377, 2.0695652173913, 1.0108695652174, 0.5
25378, 2.0913043478261, 0.98478260869565, 0.5
25379, 2.1130434782609, 1.0108695652174, 0.5
25380, 2.1347826086957, 0.98478260869565, 0.5
25381, 2.1565217391304, 1.0108695652174, 0.5
25382, 2.1782608695652, 0.98478260869565, 0.5
25383, 1.2217391304348, 0.93260869565217, 0.5
25384, 1.2434782608696, 0.95869565217391, 0.5
25385, 1.2652173913043, 0.93260869565217, 0.5
25386, 1.2869565217391, 0.95869565217391, 0.5
25387, 1.3086956521739, 0.93260869565217, 0.5
25388, 1.3304347826087, 0.95869565217391, 0.5
25389, 1.3521739130435, 0.93260869565217, 0.5
25390, 1.3739130434783, 0.95869565217391, 0.5
25391, 1.395652173913, 0.93260869565217, 0.5
25392, 1.4173913043478, 0.95869565217391, 0.5
25393, 1.4391304347826, 0.93260869565217, 0.5
25394, 1.4608695652174, 0.95869565217391, 0.5
25395, 1.4826086956522, 0.93260869565217, 0.5
25396, 1.504347826087, 0.95869565217391, 0.5
25397, 1.5260869565217, 0.93260869565217, 0.5
25398, 1.5478260869565, 0.95869565217391, 0.5
25399, 1.5695652173913, 0.93260869565217, 0.5
25400, 1.5913043478261, 0.95869565217391, 0.5
25401, 1.6130434782609, 0.93260869565217, 0.5
25402, 1.6347826086957, 0.95869565217391, 0.5
25403, 1.6565217391304, 0.93260869565217, 0.5
25404, 1.6782608695652, 0.95869565217391, 0.5
25405, 1.7, 0.93260869565217, 0.5
25406, 1.7217391304348, 0.95869565217391, 0.5
25407, 1.7434782608696, 0.93260869565217, 0.5
25408, 1.7652173913043, 0.95869565217391, 0.5
25409, 1.7869565217391, 0.93260869565217, 0.5
25410, 1.8086956521739, 0.95869565217391, 0.5
25411, 1.8304347826087, 0.93260869565217, 0.5
25412, 1.8521739130435, 0.95869565217391, 0.5
25413, 1.8739130434783, 0.93260869565217, 0.5
25414, 1.895652173913, 0.95869565217391, 0.5
25415, 1.9173913043478, 0.93260869565217, 0.5
25416, 1.9391304347826, 0.95869565217391, 0.5
25417, 1.9608695652174, 0.93260869565217, 0.5
25418, 1.9826086956522, 0.95869565217391, 0.5
25419, 2.004347826087, 0.93260869565217, 0.5
25420, 2.0260869565217, 0.95869565217391, 0.5
25421, 2.0478260869565, 0.93260869565217, 0.5
25422, 2.0695652173913, 0.95869565217391, 0.5
25423, 2.0913043478261, 0.93260869565217, 0.5
25424, 2.1130434782609, 0.95869565217391, 0.5
25425, 2.1347826086957, 0.93260869565217, 0.5
25426, 2.1565217391304, 0.95869565217391, 0.5
25427, 2.1782608695652, 0.93260869565217, 0.5
25428, 1.2217391304348, 0.8804347826087, 0.5
25429, 1.2434782608696, 0.90652173913044, 0.5
25430, 1.2652173913043, 0.8804347826087, 0.5
25431, 1.2869565217391, 0.90652173913044, 0.5
25432, 1.3086956521739, 0.8804347826087, 0.5
25433, 1.3304347826087, 0.90652173913044, 0.5
25434, 1.3521739130435, 0.8804347826087, 0.5
25435, 1.3739130434783, 0.90652173913044, 0.5
25436, 1.395652173913, 0.8804347826087, 0.5
25437, 1.4173913043478, 0.90652173913044, 0.5
25438, 1.4391304347826, 0.8804347826087, 0.5
25439, 1.4608695652174, 0.90652173913044, 0.5
25440, 1.4826086956522, 0.8804347826087, 0.5
25441, 1.504347826087, 0.90652173913044, 0.5
25442, 1.5260869565217, 0.8804347826087, 0.5
25443, 1.5478260869565, 0.90652173913044, 0.5
25444, 1.5695652173913, 0.8804347826087, 0.5
25445, 1.5913043478261, 0.90652173913044, 0.5
25446, 1.6130434782609, 0.8804347826087, 0.5
25447, 1.6347826086957, 0.90652173913044, 0.5
25448, 1.6565217391304, 0.8804347826087, 0.5
25449, 1.6782608695652, 0.90652173913044, 0.5
25450, 1.7, 0.8804347826087, 0.5
25451, 1.7217391304348, 0.90652173913044, 0.5
25452, 1.7434782608696, 0.8804347826087, 0.5
25453, 1.7652173913043, 0.90652173913044, 0.5
25454, 1.7869565217391, 0.8804347826087, 0.5
25455, 1.8086956521739, 0.90652173913044, 0.5
25456, 1.8304347826087, 0.8804347826087, 0.5
25457, 1.8521739130435, 0.90652173913044, 0.5
25458, 1.8739130434783, 0.8804347826087, 0.5
25459, 1.895652173913, 0.90652173913044, 0.5
25460, 1.9173913043478, 0.8804347826087, 0.5
25461, 1.9391304347826, 0.90652173913044, 0.5
25462, 1.9608695652174, 0.8804347826087, 0.5
25463, 1.9826086956522, 0.90652173913044, 0.5
25464, 2.004347826087, 0.8804347826087, 0.5
25465, 2.0260869565217, 0.90652173913044, 0.5
25466, 2.0478260869565, 0.8804347826087, 0.5
25467, 2.0695652173913, 0.90652173913044, 0.5
25468, 2.0913043478261, 0.8804347826087, 0.5
25469, 2.1130434782609, 0.90652173913044, 0.5
25470, 2.1347826086957, 0.8804347826087, 0.5
25471, 2.1565217391304, 0.90652173913044, 0.5
25472, 2.1782608695652, 0.8804347826087, 0.5
25473, 1.2217391304348, 0.82826086956522, 0.5
25474, 1.2434782608696, 0.85434782608696, 0.5
25475, 1.2652173913043, 0.82826086956522, 0.5
25476, 1.2869565217391, 0.85434782608696, 0.5
25477, 1.3086956521739, 0.82826086956522, 0.5
25478, 1.3304347826087, 0.85434782608696, 0.5
25479, 1.3521739130435, 0.82826086956522, 0.5
25480, 1.3739130434783, 0.85434782608696, 0.5
25481, 1.395652173913, 0.82826086956522, 0.5
25482, 1.4173913043478, 0.85434782608696, 0.5
25483, 1.4391304347826, 0.82826086956522, 0.5
25484, 1.4608695652174, 0.85434782608696, 0.5
25485, 1.4826086956522, 0.82826086956522, 0.5
25486, 1.504347826087, 0.85434782608696, 0.5
25487, 1.5260869565217, 0.82826086956522, 0.5
25488, 1.5478260869565, 0.85434782608696, 0.5
25489, 1.5695652173913, 0.82826086956522, 0.5
25490, 1.5913043478261, 0.85434782608696, 0.5
25491, 1.6130434782609, 0.82826086956522, 0.5
25492, 1.6347826086957, 0.85434782608696, 0.5
25493, 1.6565217391304, 0.82826086956522, 0.5
25494, 1.6782608695652, 0.85434782608696, 0.5
25495, 1.7, 0.82826086956522, 0.5
25496, 1.7217391304348, 0.85434782608696, 0.5
25497, 1.7434782608696, 0.82826086956522, 0.5
25498, 1.7652173913043, 0.85434782608696, 0.5
25499, 1.7869565217391, 0.82826086956522, 0.5
25500, 1.8086956521739, 0.85434782608696, 0.5
25501, 1.8304347826087, 0.82826086956522, 0.5
25502, 1.8521739130435, 0.85434782608696, 0.5
25503, 1.8739130434783, 0.82826086956522, 0.5
25504, 1.895652173913, 0.85434782608696, 0.5
25505, 1.9173913043478, 0.82826086956522, 0.5
25506, 1.9391304347826, 0.85434782608696, 0.5
25507, 1.9608695652174, 0.82826086956522, 0.5
25508, 1.9826086956522, 0.85434782608696, 0.5
25509, 2.004347826087, 0.82826086956522, 0.5
25510, 2.0260869565217, 0.85434782608696, 0.5
25511, 2.0478260869565, 0.82826086956522, 0.5
25512, 2.0695652173913, 0.85434782608696, 0.5
25513, 2.0913043478261, 0.82826086956522, 0.5
25514, 2.1130434782609, 0.85434782608696, 0.5
25515, 2.1347826086957, 0.82826086956522, 0.5
25516, 2.1565217391304, 0.85434782608696, 0.5
25517, 2.1782608695652, 0.82826086956522, 0.5
25518, 1.2217391304348, 0.77608695652174, 0.5
25519, 1.2434782608696, 0.80217391304348, 0.5
25520, 1.2652173913043, 0.77608695652174, 0.5
25521, 1.2869565217391, 0.80217391304348, 0.5
25522, 1.3086956521739, 0.77608695652174, 0.5
25523, 1.3304347826087, 0.80217391304348, 0.5
25524, 1.3521739130435, 0.77608695652174, 0.5
25525, 1.3739130434783, 0.80217391304348, 0.5
25526, 1.395652173913, 0.77608695652174, 0.5
25527, 1.4173913043478, 0.80217391304348, 0.5
25528, 1.4391304347826, 0.77608695652174, 0.5
25529, 1.4608695652174, 0.80217391304348, 0.5
25530, 1.4826086956522, 0.77608695652174, 0.5
25531, 1.504347826087, 0.80217391304348, 0.5
25532, 1.5260869565217, 0.77608695652174, 0.5
25533, 1.5478260869565, 0.80217391304348, 0.5
25534, 1.5695652173913, 0.77608695652174, 0.5
25535, 1.5913043478261, 0.80217391304348, 0.5
25536, 1.6130434782609, 0.77608695652174, 0.5
25537, 1.6347826086957, 0.80217391304348, 0.5
25538, 1.6565217391304, 0.77608695652174, 0.5
25539, 1.6782608695652, 0.80217391304348, 0.5
25540, 1.7, 0.77608695652174, 0.5
25541, 1.7217391304348, 0.80217391304348, 0.5
25542, 1.7434782608696, 0.77608695652174, 0.5
25543, 1.7652173913043, 0.80217391304348, 0.5
25544, 1.7869565217391, 0.77608695652174, 0.5
25545, 1.8086956521739, 0.80217391304348, 0.5
25546, 1.8304347826087, 0.77608695652174, 0.5
25547, 1.8521739130435, 0.80217391304348, 0.5
25548, 1.8739130434783, 0.77608695652174, 0.5
25549, 1.895652173913, 0.80217391304348, 0.5
25550, 1.9173913043478, 0.77608695652174, 0.5
25551, 1.9391304347826, 0.80217391304348, 0.5
25552, 1.9608695652174, 0.77608695652174, 0.5
25553, 1.9826086956522, 0.80217391304348, 0.5
25554, 2.004347826087, 0.77608695652174, 0.5
25555, 2.0260869565217, 0.80217391304348, 0.5
25556, 2.0478260869565, 0.77608695652174, 0.5
25557, 2.0695652173913, 0.80217391304348, 0.5
25558, 2.0913043478261, 0.77608695652174, 0.5
25559, 2.1130434782609, 0.80217391304348, 0.5
25560, 2.1347826086957, 0.77608695652174, 0.5
25561, 2.1565217391304, 0.80217391304348, 0.5
25562, 2.1782608695652, 0.77608695652174, 0.5
25563, 1.2217391304348, 0.72391304347826, 0.5
25564, 1.2434782608696, 0.75, 0.5
25565, 1.2652173913043, 0.72391304347826, 0.5
25566, 1.2869565217391, 0.75, 0.5
25567, 1.3086956521739, 0.72391304347826, 0.5
25568, 1.3304347826087, 0.75, 0.5
25569, 1.3521739130435, 0.72391304347826, 0.5
25570, 1.3739130434783, 0.75, 0.5
25571, 1.395652173913, 0.72391304347826, 0.5
25572, 1.4173913043478, 0.75, 0.5
25573, 1.4391304347826, 0.72391304347826, 0.5
25574, 1.4608695652174, 0.75, 0.5
25575, 1.4826086956522, 0.72391304347826, 0.5
25576, 1.504347826087, 0.75, 0.5
25577, 1.5260869565217, 0.72391304347826, 0.5
25578, 1.5478260869565, 0.75, 0.5
25579, 1.5695652173913, 0.72391304347826, 0.5
25580, 1.5913043478261, 0.75, 0.5
25581, 1.6130434782609, 0.72391304347826, 0.5
25582, 1.6347826086957, 0.75, 0.5
25583, 1.6565217391304, 0.72391304347826, 0.5
25584, 1.6782608695652, 0.75, 0.5
25585, 1.7, 0.72391304347826, 0.5
25586, 1.7217391304348, 0.75, 0.5
25587, 1.7434782608696, 0.72391304347826, 0.5
25588, 1.7652173913043, 0.75, 0.5
25589, 1.7869565217391, 0.72391304347826, 0.5
25590, 1.8086956521739, 0.75, 0.5
25591, 1.8304347826087, 0.72391304347826, 0.5
25592, 1.8521739130435, 0.75, 0.5
25593, 1.8739130434783, 0.72391304347826, 0.5
25594, 1.895652173913, 0.75, 0.5
25595, 1.9173913043478, 0.72391304347826, 0.5
25596, 1.9391304347826, 0.75, 0.5
25597, 1.9608695652174, 0.72391304347826, 0.5
25598, 1.9826086956522, 0.75, 0.5
25599, 2.004347826087, 0.72391304347826, 0.5
25600, 2.0260869565217, 0.75, 0.5
25601, 2.0478260869565, 0.72391304347826, 0.5
25602, 2.0695652173913, 0.75, 0.5
25603, 2.0913043478261, 0.72391304347826, 0.5
25604, 2.1130434782609, 0.75, 0.5
25605, 2.1347826086957, 0.72391304347826, 0.5
25606, 2.1565217391304, 0.75, 0.5
25607, 2.1782608695652, 0.72391304347826, 0.5
25608, 1.2217391304348, 0.67173913043478, 0.5
25609, 1.2434782608696, 0.69782608695652, 0.5
25610, 1.2652173913043, 0.67173913043478, 0.5
25611, 1.2869565217391, 0.69782608695652, 0.5
25612, 1.3086956521739, 0.67173913043478, 0.5
25613, 1.3304347826087, 0.69782608695652, 0.5
25614, 1.3521739130435, 0.67173913043478, 0.5
25615, 1.3739130434783, 0.69782608695652, 0.5
25616, 1.395652173913, 0.67173913043478, 0.5
25617, 1.4173913043478, 0.69782608695652, 0.5
25618, 1.4391304347826, 0.67173913043478, 0.5
25619, 1.4608695652174, 0.69782608695652, 0.5
25620, 1.4826086956522, 0.67173913043478, 0.5
25621, 1.504347826087, 0.69782608695652, 0.5
25622, 1.5260869565217, 0.67173913043478, 0.5
25623, 1.5478260869565, 0.69782608695652, 0.5
25624, 1.5695652173913, 0.67173913043478, 0.5
25625, 1.5913043478261, 0.69782608695652, 0.5
25626, 1.6130434782609, 0.67173913043478, 0.5
25627, 1.6347826086957, 0.69782608695652, 0.5
25628, 1.6565217391304, 0.67173913043478, 0.5
25629, 1.6782608695652, 0.69782608695652, 0.5
25630, 1.7, 0.67173913043478, 0.5
25631, 1.7217391304348, 0.69782608695652, 0.5
25632, 1.7434782608696, 0.67173913043478, 0.5
25633, 1.7652173913043, 0.69782608695652, 0.5
25634, 1.7869565217391, 0.67173913043478, 0.5
25635, 1.8086956521739, 0.69782608695652, 0.5
25636, 1.8304347826087, 0.67173913043478, 0.5
25637, 1.8521739130435, 0.69782608695652, 0.5
25638, 1.8739130434783, 0.67173913043478, 0.5
25639, 1.895652173913, 0.69782608695652, 0.5
25640, 1.9173913043478, 0.67173913043478, 0.5
25641, 1.9391304347826, 0.69782608695652, 0.5
25642, 1.9608695652174, 0.67173913043478, 0.5
25643, 1.9826086956522, 0.69782608695652, 0.5
25644, 2.004347826087, 0.67173913043478, 0.5
25645, 2.0260869565217, 0.69782608695652, 0.5
25646, 2.0478260869565, 0.67173913043478, 0.5
25647, 2.0695652173913, 0.69782608695652, 0.5
25648, 2.0913043478261, 0.67173913043478, 0.5
25649, 2.1130434782609, 0.69782608695652, 0.5
25650, 2.1347826086957, 0.67173913043478, 0.5
25651, 2.1565217391304, 0.69782608695652, 0.5
25652, 2.1782608695652, 0.67173913043478, 0.5
25653, 1.2217391304348, 0.61956521739131, 0.5
25654, 1.2434782608696, 0.64565217391304, 0.5
25655, 1.2652173913043, 0.61956521739131, 0.5
25656, 1.2869565217391, 0.64565217391304, 0.5
25657, 1.3086956521739, 0.61956521739131, 0.5
25658, 1.3304347826087, 0.64565217391304, 0.5
25659, 1.3521739130435, 0.61956521739131, 0.5
25660, 1.3739130434783, 0.64565217391304, 0.5
25661, 1.395652173913, 0.61956521739131, 0.5
25662, 1.4173913043478, 0.64565217391304, 0.5
25663, 1.4391304347826, 0.61956521739131, 0.5
25664, 1.4608695652174, 0.64565217391304, 0.5
25665, 1.4826086956522, 0.61956521739131, 0.5
25666, 1.504347826087, 0.64565217391304, 0.5
25667, 1.5260869565217, 0.61956521739131, 0.5
25668, 1.5478260869565, 0.64565217391304, 0.5
25669, 1.5695652173913, 0.61956521739131, 0.5
25670, 1.5913043478261, 0.64565217391304, 0.5
25671, 1.6130434782609, 0.61956521739131, 0.5
25672, 1.6347826086957, 0.64565217391304, 0.5
25673, 1.6565217391304, 0.61956521739131, 0.5
25674, 1.6782608695652, 0.64565217391304, 0.5
25675, 1.7, 0.61956521739131, 0.5
25676, 1.7217391304348, 0.64565217391304, 0.5
25677, 1.7434782608696, 0.61956521739131, 0.5
25678, 1.7652173913043, 0.64565217391304, 0.5
25679, 1.7869565217391, 0.61956521739131, 0.5
25680, 1.8086956521739, 0.64565217391304, 0.5
25681, 1.8304347826087, 0.61956521739131, 0.5
25682, 1.8521739130435, 0.64565217391304, 0.5
25683, 1.8739130434783, 0.61956521739131, 0.5
25684, 1.895652173913, 0.64565217391304, 0.5
25685, 1.9173913043478, 0.61956521739131, 0.5
25686, 1.9391304347826, 0.64565217391304, 0.5
25687, 1.9608695652174, 0.61956521739131, 0.5
25688, 1.9826086956522, 0.64565217391304, 0.5
25689, 2.004347826087, 0.61956521739131, 0.5
25690, 2.0260869565217, 0.64565217391304, 0.5
25691, 2.0478260869565, 0.61956521739131, 0.5
25692, 2.0695652173913, 0.64565217391304, 0.5
25693, 2.0913043478261, 0.61956521739131, 0.5
25694, 2.1130434782609, 0.64565217391304, 0.5
25695, 2.1347826086957, 0.61956521739131, 0.5
25696, 2.1565217391304, 0.64565217391304, 0.5
25697, 2.1782608695652, 0.61956521739131, 0.5
25698, 1.2217391304348, 0.56739130434783, 0.5
25699, 1.2434782608696, 0.59347826086957, 0.5
25700, 1.2652173913043, 0.56739130434783, 0.5
25701, 1.2869565217391, 0.59347826086957, 0.5
25702, 1.3086956521739, 0.56739130434783, 0.5
25703, 1.3304347826087, 0.59347826086957, 0.5
25704, 1.3521739130435, 0.56739130434783, 0.5
25705, 1.3739130434783, 0.59347826086957, 0.5
25706, 1.395652173913, 0.56739130434783, 0.5
25707, 1.4173913043478, 0.59347826086957, 0.5
25708, 1.4391304347826, 0.56739130434783, 0.5
25709, 1.4608695652174, 0.59347826086957, 0.5
25710, 1.4826086956522, 0.56739130434783, 0.5
25711, 1.504347826087, 0.59347826086957, 0.5
25712, 1.5260869565217, 0.56739130434783, 0.5
25713, 1.5478260869565, 0.59347826086957, 0.5
25714, 1.5695652173913, 0.56739130434783, 0.5
25715, 1.5913043478261, 0.59347826086957, 0.5
25716, 1.6130434782609, 0.56739130434783, 0.5
25717, 1.6347826086957, 0.59347826086957, 0.5
25718, 1.6565217391304, 0.56739130434783, 0.5
25719, 1.6782608695652, 0.59347826086957, 0.5
25720, 1.7, 0.56739130434783, 0.5
25721, 1.7217391304348, 0.59347826086957, 0.5
25722, 1.7434782608696, 0.56739130434783, 0.5
25723, 1.7652173913043, 0.59347826086957, 0.5
25724, 1.7869565217391, 0.56739130434783, 0.5
25725, 1.8086956521739, 0.59347826086957, 0.5
25726, 1.8304347826087, 0.56739130434783, 0.5
25727, 1.8521739130435, 0.59347826086957, 0.5
25728, 1.8739130434783, 0.56739130434783, 0.5
25729, 1.895652173913, 0.59347826086957, 0.5
25730, 1.9173913043478, 0.56739130434783, 0.5
25731, 1.9391304347826, 0.59347826086957, 0.5
25732, 1.9608695652174, 0.56739130434783, 0.5
25733, 1.9826086956522, 0.59347826086957, 0.5
25734, 2.004347826087, 0.56739130434783, 0.5
25735, 2.0260869565217, 0.59347826086957, 0.5
25736, 2.0478260869565, 0.56739130434783, 0.5
25737, 2.0695652173913, 0.59347826086957, 0.5
25738, 2.0913043478261, 0.56739130434783, 0.5
25739, 2.1130434782609, 0.59347826086957, 0.5
25740, 2.1347826086957, 0.56739130434783, 0.5
25741, 2.1565217391304, 0.59347826086957, 0.5
25742, 2.1782608695652, 0.56739130434783, 0.5
25743, 1.2217391304348, 0.51521739130435, 0.5
25744, 1.2434782608696, 0.54130434782609, 0.5
25745, 1.2652173913043, 0.51521739130435, 0.5
25746, 1.2869565217391, 0.54130434782609, 0.5
25747, 1.3086956521739, 0.51521739130435, 0.5
25748, 1.3304347826087, 0.54130434782609, 0.5
25749, 1.3521739130435, 0.51521739130435, 0.5
25750, 1.3739130434783, 0.54130434782609, 0.5
25751, 1.395652173913, 0.51521739130435, 0.5
25752, 1.4173913043478, 0.54130434782609, 0.5
25753, 1.4391304347826, 0.51521739130435, 0.5
25754, 1.4608695652174, 0.54130434782609, 0.5
25755, 1.4826086956522, 0.51521739130435, 0.5
25756, 1.504347826087, 0.54130434782609, 0.5
25757, 1.5260869565217, 0.51521739130435, 0.5
25758, 1.5478260869565, 0.54130434782609, 0.5
25759, 1.5695652173913, 0.51521739130435, 0.5
25760, 1.5913043478261, 0.54130434782609, 0.5
25761, 1.6130434782609, 0.51521739130435, 0.5
25762, 1.6347826086957, 0.54130434782609, 0.5
25763, 1.6565217391304, 0.51521739130435, 0.5
25764, 1.6782608695652, 0.54130434782609, 0.5
25765, 1.7, 0.51521739130435, 0.5
25766, 1.7217391304348, 0.54130434782609, 0.5
25767, 1.7434782608696, 0.51521739130435, 0.5
25768, 1.7652173913043, 0.54130434782609, 0.5
25769, 1.7869565217391, 0.51521739130435, 0.5
25770, 1.8086956521739, 0.54130434782609, 0.5
25771, 1.8304347826087, 0.51521739130435, 0.5
25772, 1.8521739130435, 0.54130434782609, 0.5
25773, 1.8739130434783, 0.51521739130435, 0.5
25774, 1.895652173913, 0.54130434782609, 0.5
25775, 1.9173913043478, 0.51521739130435, 0.5
25776, 1.9391304347826, 0.54130434782609, 0.5
25777, 1.9608695652174, 0.51521739130435, 0.5
25778, 1.9826086956522, 0.54130434782609, 0.5
25779, 2.004347826087, 0.51521739130435, 0.5
25780, 2.0260869565217, 0.54130434782609, 0.5
25781, 2.0478260869565, 0.51521739130435, 0.5
25782, 2.0695652173913, 0.54130434782609, 0.5
25783, 2.0913043478261, 0.51521739130435, 0.5
25784, 2.1130434782609, 0.54130434782609, 0.5
25785, 2.1347826086957, 0.51521739130435, 0.5
25786, 2.1565217391304, 0.54130434782609, 0.5
25787, 2.1782608695652, 0.51521739130435, 0.5
25788, 1.2217391304348, 0.46304347826087, 0.5
25789, 1.2434782608696, 0.48913043478261, 0.5
25790, 1.2652173913043, 0.46304347826087, 0.5
25791, 1.2869565217391, 0.48913043478261, 0.5
25792, 1.3086956521739, 0.46304347826087, 0.5
25793, 1.3304347826087, 0.48913043478261, 0.5
25794, 1.3521739130435, 0.46304347826087, 0.5
25795, 1.3739130434783, 0.48913043478261, 0.5
25796, 1.395652173913, 0.46304347826087, 0.5
25797, 1.4173913043478, 0.48913043478261, 0.5
25798, 1.4391304347826, 0.46304347826087, 0.5
25799, 1.4608695652174, 0.48913043478261, 0.5
25800, 1.4826086956522, 0.46304347826087, 0.5
25801, 1.504347826087, 0.48913043478261, 0.5
25802, 1.5260869565217, 0.46304347826087, 0.5
25803, 1.5478260869565, 0.48913043478261, 0.5
25804, 1.5695652173913, 0.46304347826087, 0.5
25805, 1.5913043478261, 0.48913043478261, 0.5
25806, 1.6130434782609, 0.46304347826087, 0.5
25807, 1.6347826086957, 0.48913043478261, 0.5
25808, 1.6565217391304, 0.46304347826087, 0.5
25809, 1.6782608695652, 0.48913043478261, 0.5
25810, 1.7, 0.46304347826087, 0.5
25811, 1.7217391304348, 0.48913043478261, 0.5
25812, 1.7434782608696, 0.46304347826087, 0.5
25813, 1.7652173913043, 0.48913043478261, 0.5
25814, 1.7869565217391, 0.46304347826087, 0.5
25815, 1.8086956521739, 0.48913043478261, 0.5
25816, 1.8304347826087, 0.46304347826087, 0.5
25817, 1.8521739130435, 0.48913043478261, 0.5
25818, 1.8739130434783, 0.46304347826087, 0.5
25819, 1.895652173913, 0.48913043478261, 0.5
25820, 1.9173913043478, 0.46304347826087, 0.5
25821, 1.9391304347826, 0.48913043478261, 0.5
25822, 1.9608695652174, 0.46304347826087, 0.5
25823, 1.9826086956522, 0.48913043478261, 0.5
25824, 2.004347826087, 0.46304347826087, 0.5
25825, 2.0260869565217, 0.48913043478261, 0.5
25826, 2.0478260869565, 0.46304347826087, 0.5
25827, 2.0695652173913, 0.48913043478261, 0.5
25828, 2.0913043478261, 0.46304347826087, 0.5
25829, 2.1130434782609, 0.48913043478261, 0.5
25830, 2.1347826086957, 0.46304347826087, 0.5
25831, 2.1565217391304, 0.48913043478261, 0.5
25832, 2.1782608695652, 0.46304347826087, 0.5
25833, 1.2217391304348, 0.41086956521739, 0.5
25834, 1.2434782608696, 0.43695652173913, 0.5
25835, 1.2652173913043, 0.41086956521739, 0.5
25836, 1.2869565217391, 0.43695652173913, 0.5
25837, 1.3086956521739, 0.41086956521739, 0.5
25838, 1.3304347826087, 0.43695652173913, 0.5
25839, 1.3521739130435, 0.41086956521739, 0.5
25840, 1.3739130434783, 0.43695652173913, 0.5
25841, 1.395652173913, 0.41086956521739, 0.5
25842, 1.4173913043478, 0.43695652173913, 0.5
25843, 1.4391304347826, 0.41086956521739, 0.5
25844, 1.4608695652174, 0.43695652173913, 0.5
25845, 1.4826086956522, 0.41086956521739, 0.5
25846, 1.504347826087, 0.43695652173913, 0.5
25847, 1.5260869565217, 0.41086956521739, 0.5
25848, 1.5478260869565, 0.43695652173913, 0.5
25849, 1.5695652173913, 0.41086956521739, 0.5
25850, 1.5913043478261, 0.43695652173913, 0.5
25851, 1.6130434782609, 0.41086956521739, 0.5
25852, 1.6347826086957, 0.43695652173913, 0.5
25853, 1.6565217391304, 0.41086956521739, 0.5
25854, 1.6782608695652, 0.43695652173913, 0.5
25855, 1.7, 0.41086956521739, 0.5
25856, 1.7217391304348, 0.43695652173913, 0.5
25857, 1.7434782608696, 0.41086956521739, 0.5
25858, 1.7652173913043, 0.43695652173913, 0.5
25859, 1.7869565217391, 0.41086956521739, 0.5
25860, 1.8086956521739, 0.43695652173913, 0.5
25861, 1.8304347826087, 0.41086956521739, 0.5
25862, 1.8521739130435, 0.43695652173913, 0.5
25863, 1.8739130434783, 0.41086956521739, 0.5
25864, 1.895652173913, 0.43695652173913, 0.5
25865, 1.9173913043478, 0.41086956521739, 0.5
25866, 1.9391304347826, 0.43695652173913, 0.5
25867, 1.9608695652174, 0.41086956521739, 0.5
25868, 1.9826086956522, 0.43695652173913, 0.5
25869, 2.004347826087, 0.41086956521739, 0.5
25870, 2.0260869565217, 0.43695652173913, 0.5
25871, 2.0478260869565, 0.41086956521739, 0.5
25872, 2.0695652173913, 0.43695652173913, 0.5
25873, 2.0913043478261, 0.41086956521739, 0.5
25874, 2.1130434782609, 0.43695652173913, 0.5
25875, 2.1347826086957, 0.41086956521739, 0.5
25876, 2.1565217391304, 0.43695652173913, 0.5
25877, 2.1782608695652, 0.41086956521739, 0.5
25878, 1.2217391304348, 0.35869565217391, 0.5
25879, 1.2434782608696, 0.38478260869565, 0.5
25880, 1.2652173913043, 0.35869565217391, 0.5
25881, 1.2869565217391, 0.38478260869565, 0.5
25882, 1.3086956521739, 0.35869565217391, 0.5
25883, 1.3304347826087, 0.38478260869565, 0.5
25884, 1.3521739130435, 0.35869565217391, 0.5
25885, 1.3739130434783, 0.38478260869565, 0.5
25886, 1.395652173913, 0.35869565217391, 0.5
25887, 1.4173913043478, 0.38478260869565, 0.5
25888, 1.4391304347826, 0.35869565217391, 0.5
25889, 1.4608695652174, 0.38478260869565, 0.5
25890, 1.4826086956522, 0.35869565217391, 0.5
25891, 1.504347826087, 0.38478260869565, 0.5
25892, 1.5260869565217, 0.35869565217391, 0.5
25893, 1.5478260869565, 0.38478260869565, 0.5
25894, 1.5695652173913, 0.35869565217391, 0.5
25895, 1.5913043478261, 0.38478260869565, 0.5
25896, 1.6130434782609, 0.35869565217391, 0.5
25897, 1.6347826086957, 0.38478260869565, 0.5
25898, 1.6565217391304, 0.35869565217391, 0.5
25899, 1.6782608695652, 0.38478260869565, 0.5
25900, 1.7, 0.35869565217391, 0.5
25901, 1.7217391304348, 0.38478260869565, 0.5
25902, 1.7434782608696, 0.35869565217391, 0.5
25903, 1.7652173913043, 0.38478260869565, 0.5
25904, 1.7869565217391, 0.35869565217391, 0.5
25905, 1.8086956521739, 0.38478260869565, 0.5
25906, 1.8304347826087, 0.35869565217391, 0.5
25907, 1.8521739130435, 0.38478260869565, 0.5
25908, 1.8739130434783, 0.35869565217391, 0.5
25909, 1.895652173913, 0.38478260869565, 0.5
25910, 1.9173913043478, 0.35869565217391, 0.5
25911, 1.9391304347826, 0.38478260869565, 0.5
25912, 1.9608695652174, 0.35869565217391, 0.5
25913, 1.9826086956522, 0.38478260869565, 0.5
25914, 2.004347826087, 0.35869565217391, 0.5
25915, 2.0260869565217, 0.38478260869565, 0.5
25916, 2.0478260869565, 0.35869565217391, 0.5
25917, 2.0695652173913, 0.38478260869565, 0.5
25918, 2.0913043478261, 0.35869565217391, 0.5
25919, 2.1130434782609, 0.38478260869565, 0.5
25920, 2.1347826086957, 0.35869565217391, 0.5
25921, 2.1565217391304, 0.38478260869565, 0.5
25922, 2.1782608695652, 0.35869565217391, 0.5
25923, 1.2217391304348, 0.30652173913044, 0.5
25924, 1.2434782608696, 0.33260869565217, 0.5
25925, 1.2652173913043, 0.30652173913044, 0.5
25926, 1.2869565217391, 0.33260869565217, 0.5
25927, 1.3086956521739, 0.30652173913043, 0.5
25928, 1.3304347826087, 0.33260869565217, 0.5
25929, 1.3521739130435, 0.30652173913044, 0.5
25930, 1.3739130434783, 0.33260869565217, 0.5
25931, 1.395652173913, 0.30652173913044, 0.5
25932, 1.4173913043478, 0.33260869565217, 0.5
25933, 1.4391304347826, 0.30652173913044, 0.5
25934, 1.4608695652174, 0.33260869565217, 0.5
25935, 1.4826086956522, 0.30652173913044, 0.5
25936, 1.504347826087, 0.33260869565217, 0.5
25937, 1.5260869565217, 0.30652173913044, 0.5
25938, 1.5478260869565, 0.33260869565217, 0.5
25939, 1.5695652173913, 0.30652173913044, 0.5
25940, 1.5913043478261, 0.33260869565217, 0.5
25941, 1.6130434782609, 0.30652173913044, 0.5
25942, 1.6347826086957, 0.33260869565217, 0.5
25943, 1.6565217391304, 0.30652173913043, 0.5
25944, 1.6782608695652, 0.33260869565217, 0.5
25945, 1.7, 0.30652173913043, 0.5
25946, 1.7217391304348, 0.33260869565217, 0.5
25947, 1.7434782608696, 0.30652173913043, 0.5
25948, 1.7652173913043, 0.33260869565217, 0.5
25949, 1.7869565217391, 0.30652173913044, 0.5
25950, 1.8086956521739, 0.33260869565217, 0.5
25951, 1.8304347826087, 0.30652173913044, 0.5
25952, 1.8521739130435, 0.33260869565217, 0.5
25953, 1.8739130434783, 0.30652173913043, 0.5
25954, 1.895652173913, 0.33260869565217, 0.5
25955, 1.9173913043478, 0.30652173913044, 0.5
25956, 1.9391304347826, 0.33260869565217, 0.5
25957, 1.9608695652174, 0.30652173913044, 0.5
25958, 1.9826086956522, 0.33260869565217, 0.5
25959, 2.004347826087, 0.30652173913044, 0.5
25960, 2.0260869565217, 0.33260869565217, 0.5
25961, 2.0478260869565, 0.30652173913044, 0.5
25962, 2.0695652173913, 0.33260869565217, 0.5
25963, 2.0913043478261, 0.30652173913043, 0.5
25964, 2.1130434782609, 0.33260869565217, 0.5
25965, 2.1347826086957, 0.30652173913043, 0.5
25966, 2.1565217391304, 0.33260869565217, 0.5
25967, 2.1782608695652, 0.30652173913044, 0.5
25968, 1.2217391304348, 0.25434782608696, 0.5
25969, 1.2434782608696, 0.2804347826087, 0.5
25970, 1.2652173913043, 0.25434782608696, 0.5
25971, 1.2869565217391, 0.2804347826087, 0.5
25972, 1.3086956521739, 0.25434782608696, 0.5
25973, 1.3304347826087, 0.2804347826087, 0.5
25974, 1.3521739130435, 0.25434782608696, 0.5
25975, 1.3739130434783, 0.2804347826087, 0.5
25976, 1.395652173913, 0.25434782608696, 0.5
25977, 1.4173913043478, 0.2804347826087, 0.5
25978, 1.4391304347826, 0.25434782608696, 0.5
25979, 1.4608695652174, 0.2804347826087, 0.5
25980, 1.4826086956522, 0.25434782608696, 0.5
25981, 1.504347826087, 0.2804347826087, 0.5
25982, 1.5260869565217, 0.25434782608696, 0.5
25983, 1.5478260869565, 0.2804347826087, 0.5
25984, 1.5695652173913, 0.25434782608696, 0.5
25985, 1.5913043478261, 0.2804347826087, 0.5
25986, 1.6130434782609, 0.25434782608696, 0.5
25987, 1.6347826086957, 0.2804347826087, 0.5
25988, 1.6565217391304, 0.25434782608696, 0.5
25989, 1.6782608695652, 0.2804347826087, 0.5
25990, 1.7, 0.25434782608696, 0.5
25991, 1.7217391304348, 0.2804347826087, 0.5
25992, 1.7434782608696, 0.25434782608696, 0.5
25993, 1.7652173913043, 0.2804347826087, 0.5
25994, 1.7869565217391, 0.25434782608696, 0.5
25995, 1.8086956521739, 0.2804347826087, 0.5
25996, 1.8304347826087, 0.25434782608696, 0.5
25997, 1.8521739130435, 0.2804347826087, 0.5
25998, 1.8739130434783, 0.25434782608696, 0.5
25999, 1.895652173913, 0.2804347826087, 0.5
26000, 1.9173913043478, 0.25434782608696, 0.5
26001, 1.9391304347826, 0.2804347826087, 0.5
26002, 1.9608695652174, 0.25434782608696, 0.5
26003, 1.9826086956522, 0.2804347826087, 0.5
26004, 2.004347826087, 0.25434782608696, 0.5
26005, 2.0260869565217, 0.2804347826087, 0.5
26006, 2.0478260869565, 0.25434782608696, 0.5
26007, 2.0695652173913, 0.2804347826087, 0.5
26008, 2.0913043478261, 0.25434782608696, 0.5
26009, 2.1130434782609, 0.2804347826087, 0.5
26010, 2.1347826086957, 0.25434782608696, 0.5
26011, 2.1565217391304, 0.2804347826087, 0.5
26012, 2.1782608695652, 0.25434782608696, 0.5
26013, 1.2217391304348, 0.20217391304348, 0.5
26014, 1.2434782608696, 0.22826086956522, 0.5
26015, 1.2652173913043, 0.20217391304348, 0.5
26016, 1.2869565217391, 0.22826086956522, 0.5
26017, 1.3086956521739, 0.20217391304348, 0.5
26018, 1.3304347826087, 0.22826086956522, 0.5
26019, 1.3521739130435, 0.20217391304348, 0.5
26020, 1.3739130434783, 0.22826086956522, 0.5
26021, 1.395652173913, 0.20217391304348, 0.5
26022, 1.4173913043478, 0.22826086956522, 0.5
26023, 1.4391304347826, 0.20217391304348, 0.5
26024, 1.4608695652174, 0.22826086956522, 0.5
26025, 1.4826086956522, 0.20217391304348, 0.5
26026, 1.504347826087, 0.22826086956522, 0.5
26027, 1.5260869565217, 0.20217391304348, 0.5
26028, 1.5478260869565, 0.22826086956522, 0.5
26029, 1.5695652173913, 0.20217391304348, 0.5
26030, 1.5913043478261, 0.22826086956522, 0.5
26031, 1.6130434782609, 0.20217391304348, 0.5
26032, 1.6347826086957, 0.22826086956522, 0.5
26033, 1.6565217391304, 0.20217391304348, 0.5
26034, 1.6782608695652, 0.22826086956522, 0.5
26035, 1.7, 0.20217391304348, 0.5
26036, 1.7217391304348, 0.22826086956522, 0.5
26037, 1.7434782608696, 0.20217391304348, 0.5
26038, 1.7652173913043, 0.22826086956522, 0.5
26039, 1.7869565217391, 0.20217391304348, 0.5
26040, 1.8086956521739, 0.22826086956522, 0.5
26041, 1.8304347826087, 0.20217391304348, 0.5
26042, 1.8521739130435, 0.22826086956522, 0.5
26043, 1.8739130434783, 0.20217391304348, 0.5
26044, 1.895652173913, 0.22826086956522, 0.5
26045, 1.9173913043478, 0.20217391304348, 0.5
26046, 1.9391304347826, 0.22826086956522, 0.5
26047, 1.9608695652174, 0.20217391304348, 0.5
26048, 1.9826086956522, 0.22826086956522, 0.5
26049, 2.004347826087, 0.20217391304348, 0.5
26050, 2.0260869565217, 0.22826086956522, 0.5
26051, 2.0478260869565, 0.20217391304348, 0.5
26052, 2.0695652173913, 0.22826086956522, 0.5
26053, 2.0913043478261, 0.20217391304348, 0.5
26054, 2.1130434782609, 0.22826086956522, 0.5
26055, 2.1347826086957, 0.20217391304348, 0.5
26056, 2.1565217391304, 0.22826086956522, 0.5
26057, 2.1782608695652, 0.20217391304348, 0.5
26058, 1.2434782608696, 0.17608695652174, 0.5
26059, 1.2869565217391, 0.17608695652174, 0.5
26060, 1.3304347826087, 0.17608695652174, 0.5
26061, 1.3739130434783, 0.17608695652174, 0.5
26062, 1.4173913043478, 0.17608695652174, 0.5
26063, 1.4608695652174, 0.17608695652174, 0.5
26064, 1.504347826087, 0.17608695652174, 0.5
26065, 1.5478260869565, 0.17608695652174, 0.5
26066, 1.5913043478261, 0.17608695652174, 0.5
26067, 1.6347826086957, 0.17608695652174, 0.5
26068, 1.6782608695652, 0.17608695652174, 0.5
26069, 1.7217391304348, 0.17608695652174, 0.5
26070, 1.7652173913043, 0.17608695652174, 0.5
26071, 1.8086956521739, 0.17608695652174, 0.5
26072, 1.8521739130435, 0.17608695652174, 0.5
26073, 1.895652173913, 0.17608695652174, 0.5
26074, 1.9391304347826, 0.17608695652174, 0.5
26075, 1.9826086956522, 0.17608695652174, 0.5
26076, 2.0260869565217, 0.17608695652174, 0.5
26077, 2.0695652173913, 0.17608695652174, 0.5
26078, 2.1130434782609, 0.17608695652174, 0.5
26079, 2.1565217391304, 0.17608695652174, 0.5
26080, 1.2434782608696, 1.2978260869565, 0
26081, 1.2869565217391, 1.2978260869565, 0
26082, 1.3304347826087, 1.2978260869565, 0
26083, 1.3739130434783, 1.2978260869565, 0
26084, 1.4173913043478, 1.2978260869565, 0
26085, 1.4608695652174, 1.2978260869565, 0
26086, 1.504347826087, 1.2978260869565, 0
26087, 1.5478260869565, 1.2978260869565, 0
26088, 1.5913043478261, 1.2978260869565, 0
26089, 1.6347826086957, 1.2978260869565, 0
26090, 1.6782608695652, 1.2978260869565, 0
26091, 1.7217391304348, 1.2978260869565, 0
26092, 1.7652173913043, 1.2978260869565, 0
26093, 1.8086956521739, 1.2978260869565, 0
26094, 1.8521739130435, 1.2978260869565, 0
26095, 1.895652173913, 1.2978260869565, 0
26096, 1.9391304347826, 1.2978260869565, 0
26097, 1.9826086956522, 1.2978260869565, 0
26098, 2.0260869565217, 1.2978260869565, 0
26099, 2.0695652173913, 1.2978260869565, 0
26100, 2.1130434782609, 1.2978260869565, 0
26101, 2.1565217391304, 1.2978260869565, 0
26102, 1.2434782608696, 1.245652173913, 0
26103, 1.2869565217391, 1.245652173913, 0
26104, 1.3304347826087, 1.245652173913, 0
26105, 1.3739130434783, 1.245652173913, 0
26106, 1.4173913043478, 1.245652173913, 0
26107, 1.4608695652174, 1.245652173913, 0
26108, 1.504347826087, 1.245652173913, 0
26109, 1.5478260869565, 1.245652173913, 0
26110, 1.5913043478261, 1.245652173913, 0
26111, 1.6347826086957, 1.245652173913, 0
26112, 1.6782608695652, 1.245652173913, 0
26113, 1.7217391304348, 1.245652173913, 0
26114, 1.7652173913043, 1.245652173913, 0
26115, 1.8086956521739, 1.245652173913, 0
26116, 1.8521739130435, 1.245652173913, 0
26117, 1.895652173913, 1.245652173913, 0
26118, 1.9391304347826, 1.245652173913, 0
26119, 1.9826086956522, 1.245652173913, 0
26120, 2.0260869565217, 1.245652173913, 0
26121, 2.0695652173913, 1.245652173913, 0
26122, 2.1130434782609, 1.245652173913, 0
26123, 2.1565217391304, 1.245652173913, 0
26124, 1.2434782608696, 1.1934782608696, 0
26125, 1.2869565217391, 1.1934782608696, 0
26126, 1.3304347826087, 1.1934782608696, 0
26127, 1.3739130434783, 1.1934782608696, 0
26128, 1.4173913043478, 1.1934782608696, 0
26129, 1.4608695652174, 1.1934782608696, 0
26130, 1.504347826087, 1.1934782608696, 0
26131, 1.5478260869565, 1.1934782608696, 0
26132, 1.5913043478261, 1.1934782608696, 0
26133, 1.6347826086957, 1.1934782608696, 0
26134, 1.6782608695652, 1.1934782608696, 0
26135, 1.7217391304348, 1.1934782608696, 0
26136, 1.7652173913043, 1.1934782608696, 0
26137, 1.8086956521739, 1.1934782608696, 0
26138, 1.8521739130435, 1.1934782608696, 0
26139, 1.895652173913, 1.1934782608696, 0
26140, 1.9391304347826, 1.1934782608696, 0
26141, 1.9826086956522, 1.1934782608696, 0
26142, 2.0260869565217, 1.1934782608696, 0
26143, 2.0695652173913, 1.1934782608696, 0
26144, 2.1130434782609, 1.1934782608696, 0
26145, 2.1565217391304, 1.1934782608696, 0
26146, 1.2434782608696, 1.1413043478261, 0
26147, 1.2869565217391, 1.1413043478261, 0
26148, 1.3304347826087, 1.1413043478261, 0
26149, 1.3739130434783, 1.1413043478261, 0
26150, 1.4173913043478, 1.1413043478261, 0
26151, 1.4608695652174, 1.1413043478261, 0
26152, 1.504347826087, 1.1413043478261, 0
26153, 1.5478260869565, 1.1413043478261, 0
26154, 1.5913043478261, 1.1413043478261, 0
26155, 1.6347826086957, 1.1413043478261, 0
26156, 1.6782608695652, 1.1413043478261, 0
26157, 1.7217391304348, 1.1413043478261, 0
26158, 1.7652173913043, 1.1413043478261, 0
26159, 1.8086956521739, 1.1413043478261, 0
26160, 1.8521739130435, 1.1413043478261, 0
26161, 1.895652173913, 1.1413043478261, 0
26162, 1.9391304347826, 1.1413043478261, 0
26163, 1.9826086956522, 1.1413043478261, 0
26164, 2.0260869565217, 1.1413043478261, 0
26165, 2.0695652173913, 1.1413043478261, 0
26166, 2.1130434782609, 1.1413043478261, 0
26167, 2.1565217391304, 1.1413043478261, 0
26168, 1.2434782608696, 1.0891304347826, 0
26169, 1.2869565217391, 1.0891304347826, 0
26170, 1.3304347826087, 1.0891304347826, 0
26171, 1.3739130434783, 1.0891304347826, 0
26172, 1.4173913043478, 1.0891304347826, 0
26173, 1.4608695652174, 1.0891304347826, 0
26174, 1.504347826087, 1.0891304347826, 0
26175, 1.5478260869565, 1.0891304347826, 0
26176, 1.5913043478261, 1.0891304347826, 0
26177, 1.6347826086957, 1.0891304347826, 0
26178, 1.6782608695652, 1.0891304347826, 0
26179, 1.7217391304348, 1.0891304347826, 0
26180, 1.7652173913043, 1.0891304347826, 0
26181, 1.8086956521739, 1.0891304347826, 0
26182, 1.8521739130435, 1.0891304347826, 0
26183, 1.895652173913, 1.0891304347826, 0
26184, 1.9391304347826, 1.0891304347826, 0
26185, 1.9826086956522, 1.0891304347826, 0
26186, 2.0260869565217, 1.0891304347826, 0
26187, 2.0695652173913, 1.0891304347826, 0
26188, 2.1130434782609, 1.0891304347826, 0
26189, 2.1565217391304, 1.0891304347826, 0
26190, 1.2434782608696, 1.0369565217391, 0
26191, 1.2869565217391, 1.0369565217391, 0
26192, 1.3304347826087, 1.0369565217391, 0
26193, 1.3739130434783, 1.0369565217391, 0
26194, 1.4173913043478, 1.0369565217391, 0
26195, 1.4608695652174, 1.0369565217391, 0
26196, 1.504347826087, 1.0369565217391, 0
26197, 1.5478260869565, 1.0369565217391, 0
26198, 1.5913043478261, 1.0369565217391, 0
26199, 1.6347826086957, 1.0369565217391, 0
26200, 1.6782608695652, 1.0369565217391, 0
26201, 1.7217391304348, 1.0369565217391, 0
26202, 1.7652173913043, 1.0369565217391, 0
26203, 1.8086956521739, 1.0369565217391, 0
26204, 1.8521739130435, 1.0369565217391, 0
26205, 1.895652173913, 1.0369565217391, 0
26206, 1.9391304347826, 1.0369565217391, 0
26207, 1.9826086956522, 1.0369565217391, 0
26208, 2.0260869565217, 1.0369565217391, 0
26209, 2.0695652173913, 1.0369565217391, 0
26210, 2.1130434782609, 1.0369565217391, 0
26211, 2.1565217391304, 1.0369565217391, 0
26212, 1.2434782608696, 0.98478260869565, 0
26213, 1.2869565217391, 0.98478260869565, 0
26214, 1.3304347826087, 0.98478260869565, 0
26215, 1.3739130434783, 0.98478260869565, 0
26216, 1.4173913043478, 0.98478260869565, 0
26217, 1.4608695652174, 0.98478260869565, 0
26218, 1.504347826087, 0.98478260869565, 0
26219, 1.5478260869565, 0.98478260869565, 0
26220, 1.5913043478261, 0.98478260869565, 0
26221, 1.6347826086957, 0.98478260869565, 0
26222, 1.6782608695652, 0.98478260869565, 0
26223, 1.7217391304348, 0.98478260869565, 0
26224, 1.7652173913043, 0.98478260869565, 0
26225, 1.8086956521739, 0.98478260869565, 0
26226, 1.8521739130435, 0.98478260869565, 0
26227, 1.895652173913, 0.98478260869565, 0
26228, 1.9391304347826, 0.98478260869565, 0
26229, 1.9826086956522, 0.98478260869565, 0
26230, 2.0260869565217, 0.98478260869565, 0
26231, 2.0695652173913, 0.98478260869565, 0
26232, 2.1130434782609, 0.98478260869565, 0
26233, 2.1565217391304, 0.98478260869565, 0
26234, 1.2434782608696, 0.93260869565217, 0
26235, 1.2869565217391, 0.93260869565217, 0
26236, 1.3304347826087, 0.93260869565217, 0
26237, 1.3739130434783, 0.93260869565217, 0
26238, 1.4173913043478, 0.93260869565217, 0
26239, 1.4608695652174, 0.93260869565217, 0
26240, 1.504347826087, 0.93260869565217, 0
26241, 1.5478260869565, 0.93260869565217, 0
26242, 1.5913043478261, 0.93260869565217, 0
26243, 1.6347826086957, 0.93260869565217, 0
26244, 1.6782608695652, 0.93260869565217, 0
26245, 1.7217391304348, 0.93260869565217, 0
26246, 1.7652173913043, 0.93260869565217, 0
26247, 1.8086956521739, 0.93260869565217, 0
26248, 1.8521739130435, 0.93260869565217, 0
26249, 1.895652173913, 0.93260869565217, 0
26250, 1.9391304347826, 0.93260869565217, 0
26251, 1.9826086956522, 0.93260869565217, 0
26252, 2.0260869565217, 0.93260869565217, 0
26253, 2.0695652173913, 0.93260869565217, 0
26254, 2.1130434782609, 0.93260869565217, 0
26255, 2.1565217391304, 0.93260869565217, 0
26256, 1.2434782608696, 0.8804347826087, 0
26257, 1.2869565217391, 0.8804347826087, 0
26258, 1.3304347826087, 0.8804347826087, 0
26259, 1.3739130434783, 0.8804347826087, 0
26260, 1.4173913043478, 0.8804347826087, 0
26261, 1.4608695652174, 0.8804347826087, 0
26262, 1.504347826087, 0.8804347826087, 0
26263, 1.5478260869565, 0.8804347826087, 0
26264, 1.5913043478261, 0.8804347826087, 0
26265, 1.6347826086957, 0.8804347826087, 0
26266, 1.6782608695652, 0.8804347826087, 0
26267, 1.7217391304348, 0.8804347826087, 0
26268, 1.7652173913043, 0.8804347826087, 0
26269, 1.8086956521739, 0.8804347826087, 0
26270, 1.8521739130435, 0.8804347826087, 0
26271, 1.895652173913, 0.8804347826087, 0
26272, 1.9391304347826, 0.8804347826087, 0
26273, 1.9826086956522, 0.8804347826087, 0
26274, 2.0260869565217, 0.8804347826087, 0
26275, 2.0695652173913, 0.8804347826087, 0
26276, 2.1130434782609, 0.8804347826087, 0
26277, 2.1565217391304, 0.8804347826087, 0
26278, 1.2434782608696, 0.82826086956522, 0
26279, 1.2869565217391, 0.82826086956522, 0
26280, 1.3304347826087, 0.82826086956522, 0
26281, 1.3739130434783, 0.82826086956522, 0
26282, 1.4173913043478, 0.82826086956522, 0
26283, 1.4608695652174, 0.82826086956522, 0
26284, 1.504347826087, 0.82826086956522, 0
26285, 1.5478260869565, 0.82826086956522, 0
26286, 1.5913043478261, 0.82826086956522, 0
26287, 1.6347826086957, 0.82826086956522, 0
26288, 1.6782608695652, 0.82826086956522, 0
26289, 1.7217391304348, 0.82826086956522, 0
26290, 1.7652173913043, 0.82826086956522, 0
26291, 1.8086956521739, 0.82826086956522, 0
26292, 1.8521739130435, 0.82826086956522, 0
26293, 1.895652173913, 0.82826086956522, 0
26294, 1.9391304347826, 0.82826086956522, 0
26295, 1.9826086956522, 0.82826086956522, 0
26296, 2.0260869565217, 0.82826086956522, 0
26297, 2.0695652173913, 0.82826086956522, 0
26298, 2.1130434782609, 0.82826086956522, 0
26299, 2.1565217391304, 0.82826086956522, 0
26300, 1.2434782608696, 0.77608695652174, 0
26301, 1.2869565217391, 0.77608695652174, 0
26302, 1.3304347826087, 0.77608695652174, 0
26303, 1.3739130434783, 0.77608695652174, 0
26304, 1.4173913043478, 0.77608695652174, 0
26305, 1.4608695652174, 0.77608695652174, 0
26306, 1.504347826087, 0.77608695652174, 0
26307, 1.5478260869565, 0.77608695652174, 0
26308, 1.5913043478261, 0.77608695652174, 0
26309, 1.6347826086957, 0.77608695652174, 0
26310, 1.6782608695652, 0.77608695652174, 0
26311, 1.7217391304348, 0.77608695652174, 0
26312, 1.7652173913043, 0.77608695652174, 0
26313, 1.8086956521739, 0.77608695652174, 0
26314, 1.8521739130435, 0.77608695652174, 0
26315, 1.895652173913, 0.77608695652174, 0
26316, 1.9391304347826, 0.77608695652174, 0
26317, 1.9826086956522, 0.77608695652174, 0
26318, 2.0260869565217, 0.77608695652174, 0
26319, 2.0695652173913, 0.77608695652174, 0
26320, 2.1130434782609, 0.77608695652174, 0
26321, 2.1565217391304, 0.77608695652174, 0
26322, 1.2434782608696, 0.72391304347826, 0
26323, 1.2869565217391, 0.72391304347826, 0
26324, 1.3304347826087, 0.72391304347826, 0
26325, 1.3739130434783, 0.72391304347826, 0
26326, 1.4173913043478, 0.72391304347826, 0
26327, 1.4608695652174, 0.72391304347826, 0
26328, 1.504347826087, 0.72391304347826, 0
26329, 1.5478260869565, 0.72391304347826, 0
26330, 1.5913043478261, 0.72391304347826, 0
26331, 1.6347826086957, 0.72391304347826, 0
26332, 1.6782608695652, 0.72391304347826, 0
26333, 1.7217391304348, 0.72391304347826, 0
26334, 1.7652173913043, 0.72391304347826, 0
26335, 1.8086956521739, 0.72391304347826, 0
26336, 1.8521739130435, 0.72391304347826, 0
26337, 1.895652173913, 0.72391304347826, 0
26338, 1.9391304347826, 0.72391304347826, 0
26339, 1.9826086956522, 0.72391304347826, 0
26340, 2.0260869565217, 0.72391304347826, 0
26341, 2.0695652173913, 0.72391304347826, 0
26342, 2.1130434782609, 0.72391304347826, 0
26343, 2.1565217391304, 0.72391304347826, 0
26344, 1.2434782608696, 0.67173913043478, 0
26345, 1.2869565217391, 0.67173913043478, 0
26346, 1.3304347826087, 0.67173913043478, 0
26347, 1.3739130434783, 0.67173913043478, 0
26348, 1.4173913043478, 0.67173913043478, 0
26349, 1.4608695652174, 0.67173913043478, 0
26350, 1.504347826087, 0.67173913043478, 0
26351, 1.5478260869565, 0.67173913043478, 0
26352, 1.5913043478261, 0.67173913043478, 0
26353, 1.6347826086957, 0.67173913043478, 0
26354, 1.6782608695652, 0.67173913043478, 0
26355, 1.7217391304348, 0.67173913043478, 0
26356, 1.7652173913043, 0.67173913043478, 0
26357, 1.8086956521739, 0.67173913043478, 0
26358, 1.8521739130435, 0.67173913043478, 0
26359, 1.895652173913, 0.67173913043478, 0
26360, 1.9391304347826, 0.67173913043478, 0
26361, 1.9826086956522, 0.67173913043478, 0
26362, 2.0260869565217, 0.67173913043478, 0
26363, 2.0695652173913, 0.67173913043478, 0
26364, 2.1130434782609, 0.67173913043478, 0
26365, 2.1565217391304, 0.67173913043478, 0
26366, 1.2434782608696, 0.61956521739131, 0
26367, 1.2869565217391, 0.61956521739131, 0
26368, 1.3304347826087, 0.61956521739131, 0
26369, 1.3739130434783, 0.61956521739131, 0
26370, 1.4173913043478, 0.61956521739131, 0
26371, 1.4608695652174, 0.61956521739131, 0
26372, 1.504347826087, 0.6195652173913, 0
26373, 1.5478260869565, 0.61956521739131, 0
26374, 1.5913043478261, 0.61956521739131, 0
26375, 1.6347826086957, 0.61956521739131, 0
26376, 1.6782608695652, 0.61956521739131, 0
26377, 1.7217391304348, 0.61956521739131, 0
26378, 1.7652173913043, 0.61956521739131, 0
26379, 1.8086956521739, 0.61956521739131, 0
26380, 1.8521739130435, 0.61956521739131, 0
26381, 1.895652173913, 0.61956521739131, 0
26382, 1.9391304347826, 0.61956521739131, 0
26383, 1.9826086956522, 0.61956521739131, 0
26384, 2.0260869565217, 0.61956521739131, 0
26385, 2.0695652173913, 0.61956521739131, 0
26386, 2.1130434782609, 0.61956521739131, 0
26387, 2.1565217391304, 0.61956521739131, 0
26388, 1.2434782608696, 0.56739130434783, 0
26389, 1.2869565217391, 0.56739130434783, 0
26390, 1.3304347826087, 0.56739130434783, 0
26391, 1.3739130434783, 0.56739130434783, 0
26392, 1.4173913043478, 0.56739130434783, 0
26393, 1.4608695652174, 0.56739130434783, 0
26394, 1.504347826087, 0.56739130434783, 0
26395, 1.5478260869565, 0.56739130434783, 0
26396, 1.5913043478261, 0.56739130434783, 0
26397, 1.6347826086957, 0.56739130434783, 0
26398, 1.6782608695652, 0.56739130434783, 0
26399, 1.7217391304348, 0.56739130434783, 0
26400, 1.7652173913043, 0.56739130434783, 0
26401, 1.8086956521739, 0.56739130434783, 0
26402, 1.8521739130435, 0.56739130434783, 0
26403, 1.895652173913, 0.56739130434783, 0
26404, 1.9391304347826, 0.56739130434783, 0
26405, 1.9826086956522, 0.56739130434783, 0
26406, 2.0260869565217, 0.56739130434783, 0
26407, 2.0695652173913, 0.56739130434783, 0
26408, 2.1130434782609, 0.56739130434783, 0
26409, 2.1565217391304, 0.56739130434783, 0
26410, 1.2434782608696, 0.51521739130435, 0
26411, 1.2869565217391, 0.51521739130435, 0
26412, 1.3304347826087, 0.51521739130435, 0
26413, 1.3739130434783, 0.51521739130435, 0
26414, 1.4173913043478, 0.51521739130435, 0
26415, 1.4608695652174, 0.51521739130435, 0
26416, 1.504347826087, 0.51521739130435, 0
26417, 1.5478260869565, 0.51521739130435, 0
26418, 1.5913043478261, 0.51521739130435, 0
26419, 1.6347826086957, 0.51521739130435, 0
26420, 1.6782608695652, 0.51521739130435, 0
26421, 1.7217391304348, 0.51521739130435, 0
26422, 1.7652173913043, 0.51521739130435, 0
26423, 1.8086956521739, 0.51521739130435, 0
26424, 1.8521739130435, 0.51521739130435, 0
26425, 1.895652173913, 0.51521739130435, 0
26426, 1.9391304347826, 0.51521739130435, 0
26427, 1.9826086956522, 0.51521739130435, 0
26428, 2.0260869565217, 0.51521739130435, 0
26429, 2.0695652173913, 0.51521739130435, 0
26430, 2.1130434782609, 0.51521739130435, 0
26431, 2.1565217391304, 0.51521739130435, 0
26432, 1.2434782608696, 0.46304347826087, 0
26433, 1.2869565217391, 0.46304347826087, 0
26434, 1.3304347826087, 0.46304347826087, 0
26435, 1.3739130434783, 0.46304347826087, 0
26436, 1.4173913043478, 0.46304347826087, 0
26437, 1.4608695652174, 0.46304347826087, 0
26438, 1.504347826087, 0.46304347826087, 0
26439, 1.5478260869565, 0.46304347826087, 0
26440, 1.5913043478261, 0.46304347826087, 0
26441, 1.6347826086957, 0.46304347826087, 0
26442, 1.6782608695652, 0.46304347826087, 0
26443, 1.7217391304348, 0.46304347826087, 0
26444, 1.7652173913043, 0.46304347826087, 0
26445, 1.8086956521739, 0.46304347826087, 0
26446, 1.8521739130435, 0.46304347826087, 0
26447, 1.895652173913, 0.46304347826087, 0
26448, 1.9391304347826, 0.46304347826087, 0
26449, 1.9826086956522, 0.46304347826087, 0
26450, 2.0260869565217, 0.46304347826087, 0
26451, 2.0695652173913, 0.46304347826087, 0
26452, 2.1130434782609, 0.46304347826087, 0
26453, 2.1565217391304, 0.46304347826087, 0
26454, 1.2434782608696, 0.41086956521739, 0
26455, 1.2869565217391, 0.41086956521739, 0
26456, 1.3304347826087, 0.41086956521739, 0
26457, 1.3739130434783, 0.41086956521739, 0
26458, 1.4173913043478, 0.41086956521739, 0
26459, 1.4608695652174, 0.41086956521739, 0
26460, 1.504347826087, 0.41086956521739, 0
26461, 1.5478260869565, 0.41086956521739, 0
26462, 1.5913043478261, 0.41086956521739, 0
26463, 1.6347826086957, 0.41086956521739, 0
26464, 1.6782608695652, 0.41086956521739, 0
26465, 1.7217391304348, 0.41086956521739, 0
26466, 1.7652173913043, 0.41086956521739, 0
26467, 1.8086956521739, 0.41086956521739, 0
26468, 1.8521739130435, 0.41086956521739, 0
26469, 1.895652173913, 0.41086956521739, 0
26470, 1.9391304347826, 0.41086956521739, 0
26471, 1.9826086956522, 0.41086956521739, 0
26472, 2.0260869565217, 0.41086956521739, 0
26473, 2.0695652173913, 0.41086956521739, 0
26474, 2.1130434782609, 0.41086956521739, 0
26475, 2.1565217391304, 0.41086956521739, 0
26476, 1.2434782608696, 0.35869565217391, 0
26477, 1.2869565217391, 0.35869565217391, 0
26478, 1.3304347826087, 0.35869565217391, 0
26479, 1.3739130434783, 0.35869565217391, 0
26480, 1.4173913043478, 0.35869565217391, 0
26481, 1.4608695652174, 0.35869565217391, 0
26482, 1.504347826087, 0.35869565217391, 0
26483, 1.5478260869565, 0.35869565217391, 0
26484, 1.5913043478261, 0.35869565217391, 0
26485, 1.6347826086957, 0.35869565217391, 0
26486, 1.6782608695652, 0.35869565217391, 0
26487, 1.7217391304348, 0.35869565217391, 0
26488, 1.7652173913043, 0.35869565217391, 0
26489, 1.8086956521739, 0.35869565217391, 0
26490, 1.8521739130435, 0.35869565217391, 0
26491, 1.895652173913, 0.35869565217391, 0
26492, 1.9391304347826, 0.35869565217391, 0
26493, 1.9826086956522, 0.35869565217391, 0
26494, 2.0260869565217, 0.35869565217391, 0
26495, 2.0695652173913, 0.35869565217391, 0
26496, 2.1130434782609, 0.35869565217391, 0
26497, 2.1565217391304, 0.35869565217391, 0
26498, 1.2434782608696, 0.30652173913044, 0
26499, 1.2869565217391, 0.30652173913043, 0
26500, 1.3304347826087, 0.30652173913043, 0
26501, 1.3739130434783, 0.30652173913044, 0
26502, 1.4173913043478, 0.30652173913044, 0
26503, 1.4608695652174, 0.30652173913043, 0
26504, 1.504347826087, 0.30652173913044, 0
26505, 1.5478260869565, 0.30652173913044, 0
26506, 1.5913043478261, 0.30652173913044, 0
26507, 1.6347826086957, 0.30652173913043, 0
26508, 1.6782608695652, 0.30652173913043, 0
26509, 1.7217391304348, 0.30652173913043, 0
26510, 1.7652173913043, 0.30652173913043, 0
26511, 1.8086956521739, 0.30652173913044, 0
26512, 1.8521739130435, 0.30652173913043, 0
26513, 1.895652173913, 0.30652173913044, 0
26514, 1.9391304347826, 0.30652173913043, 0
26515, 1.9826086956522, 0.30652173913044, 0
26516, 2.0260869565217, 0.30652173913044, 0
26517, 2.0695652173913, 0.30652173913043, 0
26518, 2.1130434782609, 0.30652173913043, 0
26519, 2.1565217391304, 0.30652173913043, 0
26520, 1.2434782608696, 0.25434782608696, 0
26521, 1.2869565217391, 0.25434782608696, 0
26522, 1.3304347826087, 0.25434782608696, 0
26523, 1.3739130434783, 0.25434782608696, 0
26524, 1.4173913043478, 0.25434782608696, 0
26525, 1.4608695652174, 0.25434782608696, 0
26526, 1.504347826087, 0.25434782608696, 0
26527, 1.5478260869565, 0.25434782608696, 0
26528, 1.5913043478261, 0.25434782608696, 0
26529, 1.6347826086957, 0.25434782608696, 0
26530, 1.6782608695652, 0.25434782608696, 0
26531, 1.7217391304348, 0.25434782608696, 0
26532, 1.7652173913043, 0.25434782608696, 0
26533, 1.8086956521739, 0.25434782608696, 0
26534, 1.8521739130435, 0.25434782608696, 0
26535, 1.895652173913, 0.25434782608696, 0
