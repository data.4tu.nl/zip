104553, 1.6782608695652, 1.1413043478261, -0.125
104554, 1.7, 1.1413043478261, -0.15
104555, 1.7217391304348, 1.1673913043478, -0.15
104556, 1.7217391304348, 1.1413043478261, -0.125
104557, 1.7434782608696, 1.1413043478261, -0.15
104558, 1.7652173913043, 1.1673913043478, -0.15
104559, 1.7652173913043, 1.1413043478261, -0.125
104560, 1.7869565217391, 1.1413043478261, -0.15
104561, 1.8086956521739, 1.1673913043478, -0.15
104562, 1.8086956521739, 1.1413043478261, -0.125
104563, 1.8304347826087, 1.1413043478261, -0.15
104564, 1.8521739130435, 1.1673913043478, -0.15
104565, 1.8521739130435, 1.1413043478261, -0.125
104566, 1.8739130434783, 1.1413043478261, -0.15
104567, 1.895652173913, 1.1673913043478, -0.15
104568, 1.895652173913, 1.1413043478261, -0.125
104569, 1.9173913043478, 1.1413043478261, -0.15
104570, 1.9391304347826, 1.1673913043478, -0.15
104571, 1.9391304347826, 1.1413043478261, -0.125
104572, 1.9608695652174, 1.1413043478261, -0.15
104573, 1.9826086956522, 1.1673913043478, -0.15
104574, 1.9826086956522, 1.1413043478261, -0.125
104575, 2.004347826087, 1.1413043478261, -0.15
104576, 2.0260869565217, 1.1673913043478, -0.15
104577, 2.0260869565217, 1.1413043478261, -0.125
104578, 2.0478260869565, 1.1413043478261, -0.15
104579, 2.0695652173913, 1.1673913043478, -0.15
104580, 2.0695652173913, 1.1413043478261, -0.125
104581, 2.0913043478261, 1.1413043478261, -0.15
104582, 2.1130434782609, 1.1673913043478, -0.15
104583, 2.1130434782609, 1.1413043478261, -0.125
104584, 2.1347826086957, 1.1413043478261, -0.15
104585, 2.1565217391304, 1.1673913043478, -0.15
104586, 2.1565217391304, 1.1413043478261, -0.125
104587, 2.1782608695652, 1.1413043478261, -0.15
104588, 1.2217391304348, 1.0891304347826, -0.15
104589, 1.2434782608696, 1.1152173913043, -0.15
104590, 1.2434782608696, 1.0891304347826, -0.125
104591, 1.2652173913043, 1.0891304347826, -0.15
104592, 1.2869565217391, 1.1152173913043, -0.15
104593, 1.2869565217391, 1.0891304347826, -0.125
104594, 1.3086956521739, 1.0891304347826, -0.15
104595, 1.3304347826087, 1.1152173913043, -0.15
104596, 1.3304347826087, 1.0891304347826, -0.125
104597, 1.3521739130435, 1.0891304347826, -0.15
104598, 1.3739130434783, 1.1152173913043, -0.15
104599, 1.3739130434783, 1.0891304347826, -0.125
104600, 1.395652173913, 1.0891304347826, -0.15
104601, 1.4173913043478, 1.1152173913043, -0.15
104602, 1.4173913043478, 1.0891304347826, -0.125
104603, 1.4391304347826, 1.0891304347826, -0.15
104604, 1.4608695652174, 1.1152173913043, -0.15
104605, 1.4608695652174, 1.0891304347826, -0.125
104606, 1.4826086956522, 1.0891304347826, -0.15
104607, 1.504347826087, 1.1152173913043, -0.15
104608, 1.504347826087, 1.0891304347826, -0.125
104609, 1.5260869565217, 1.0891304347826, -0.15
104610, 1.5478260869565, 1.1152173913043, -0.15
104611, 1.5478260869565, 1.0891304347826, -0.125
104612, 1.5695652173913, 1.0891304347826, -0.15
104613, 1.5913043478261, 1.1152173913043, -0.15
104614, 1.5913043478261, 1.0891304347826, -0.125
104615, 1.6130434782609, 1.0891304347826, -0.15
104616, 1.6347826086957, 1.1152173913043, -0.15
104617, 1.6347826086957, 1.0891304347826, -0.125
104618, 1.6565217391304, 1.0891304347826, -0.15
104619, 1.6782608695652, 1.1152173913043, -0.15
104620, 1.6782608695652, 1.0891304347826, -0.125
104621, 1.7, 1.0891304347826, -0.15
104622, 1.7217391304348, 1.1152173913043, -0.15
104623, 1.7217391304348, 1.0891304347826, -0.125
104624, 1.7434782608696, 1.0891304347826, -0.15
104625, 1.7652173913043, 1.1152173913043, -0.15
104626, 1.7652173913043, 1.0891304347826, -0.125
104627, 1.7869565217391, 1.0891304347826, -0.15
104628, 1.8086956521739, 1.1152173913043, -0.15
104629, 1.8086956521739, 1.0891304347826, -0.125
104630, 1.8304347826087, 1.0891304347826, -0.15
104631, 1.8521739130435, 1.1152173913043, -0.15
104632, 1.8521739130435, 1.0891304347826, -0.125
104633, 1.8739130434783, 1.0891304347826, -0.15
104634, 1.895652173913, 1.1152173913043, -0.15
104635, 1.895652173913, 1.0891304347826, -0.125
104636, 1.9173913043478, 1.0891304347826, -0.15
104637, 1.9391304347826, 1.1152173913043, -0.15
104638, 1.9391304347826, 1.0891304347826, -0.125
104639, 1.9608695652174, 1.0891304347826, -0.15
104640, 1.9826086956522, 1.1152173913043, -0.15
104641, 1.9826086956522, 1.0891304347826, -0.125
104642, 2.004347826087, 1.0891304347826, -0.15
104643, 2.0260869565217, 1.1152173913043, -0.15
104644, 2.0260869565217, 1.0891304347826, -0.125
104645, 2.0478260869565, 1.0891304347826, -0.15
104646, 2.0695652173913, 1.1152173913043, -0.15
104647, 2.0695652173913, 1.0891304347826, -0.125
104648, 2.0913043478261, 1.0891304347826, -0.15
104649, 2.1130434782609, 1.1152173913043, -0.15
104650, 2.1130434782609, 1.0891304347826, -0.125
104651, 2.1347826086957, 1.0891304347826, -0.15
104652, 2.1565217391304, 1.1152173913043, -0.15
104653, 2.1565217391304, 1.0891304347826, -0.125
104654, 2.1782608695652, 1.0891304347826, -0.15
104655, 1.2217391304348, 1.0369565217391, -0.15
104656, 1.2434782608696, 1.0630434782609, -0.15
104657, 1.2434782608696, 1.0369565217391, -0.125
104658, 1.2652173913043, 1.0369565217391, -0.15
104659, 1.2869565217391, 1.0630434782609, -0.15
104660, 1.2869565217391, 1.0369565217391, -0.125
104661, 1.3086956521739, 1.0369565217391, -0.15
104662, 1.3304347826087, 1.0630434782609, -0.15
104663, 1.3304347826087, 1.0369565217391, -0.125
104664, 1.3521739130435, 1.0369565217391, -0.15
104665, 1.3739130434783, 1.0630434782609, -0.15
104666, 1.3739130434783, 1.0369565217391, -0.125
104667, 1.395652173913, 1.0369565217391, -0.15
104668, 1.4173913043478, 1.0630434782609, -0.15
104669, 1.4173913043478, 1.0369565217391, -0.125
104670, 1.4391304347826, 1.0369565217391, -0.15
104671, 1.4608695652174, 1.0630434782609, -0.15
104672, 1.4608695652174, 1.0369565217391, -0.125
104673, 1.4826086956522, 1.0369565217391, -0.15
104674, 1.504347826087, 1.0630434782609, -0.15
104675, 1.504347826087, 1.0369565217391, -0.125
104676, 1.5260869565217, 1.0369565217391, -0.15
104677, 1.5478260869565, 1.0630434782609, -0.15
104678, 1.5478260869565, 1.0369565217391, -0.125
104679, 1.5695652173913, 1.0369565217391, -0.15
104680, 1.5913043478261, 1.0630434782609, -0.15
104681, 1.5913043478261, 1.0369565217391, -0.125
104682, 1.6130434782609, 1.0369565217391, -0.15
104683, 1.6347826086957, 1.0630434782609, -0.15
104684, 1.6347826086957, 1.0369565217391, -0.125
104685, 1.6565217391304, 1.0369565217391, -0.15
104686, 1.6782608695652, 1.0630434782609, -0.15
104687, 1.6782608695652, 1.0369565217391, -0.125
104688, 1.7, 1.0369565217391, -0.15
104689, 1.7217391304348, 1.0630434782609, -0.15
104690, 1.7217391304348, 1.0369565217391, -0.125
104691, 1.7434782608696, 1.0369565217391, -0.15
104692, 1.7652173913043, 1.0630434782609, -0.15
104693, 1.7652173913043, 1.0369565217391, -0.125
104694, 1.7869565217391, 1.0369565217391, -0.15
104695, 1.8086956521739, 1.0630434782609, -0.15
104696, 1.8086956521739, 1.0369565217391, -0.125
104697, 1.8304347826087, 1.0369565217391, -0.15
104698, 1.8521739130435, 1.0630434782609, -0.15
104699, 1.8521739130435, 1.0369565217391, -0.125
104700, 1.8739130434783, 1.0369565217391, -0.15
104701, 1.895652173913, 1.0630434782609, -0.15
104702, 1.895652173913, 1.0369565217391, -0.125
104703, 1.9173913043478, 1.0369565217391, -0.15
104704, 1.9391304347826, 1.0630434782609, -0.15
104705, 1.9391304347826, 1.0369565217391, -0.125
104706, 1.9608695652174, 1.0369565217391, -0.15
104707, 1.9826086956522, 1.0630434782609, -0.15
104708, 1.9826086956522, 1.0369565217391, -0.125
104709, 2.004347826087, 1.0369565217391, -0.15
104710, 2.0260869565217, 1.0630434782609, -0.15
104711, 2.0260869565217, 1.0369565217391, -0.125
104712, 2.0478260869565, 1.0369565217391, -0.15
104713, 2.0695652173913, 1.0630434782609, -0.15
104714, 2.0695652173913, 1.0369565217391, -0.125
104715, 2.0913043478261, 1.0369565217391, -0.15
104716, 2.1130434782609, 1.0630434782609, -0.15
104717, 2.1130434782609, 1.0369565217391, -0.125
104718, 2.1347826086957, 1.0369565217391, -0.15
104719, 2.1565217391304, 1.0630434782609, -0.15
104720, 2.1565217391304, 1.0369565217391, -0.125
104721, 2.1782608695652, 1.0369565217391, -0.15
104722, 1.2217391304348, 0.98478260869565, -0.15
104723, 1.2434782608696, 1.0108695652174, -0.15
104724, 1.2434782608696, 0.98478260869565, -0.125
104725, 1.2652173913043, 0.98478260869565, -0.15
104726, 1.2869565217391, 1.0108695652174, -0.15
104727, 1.2869565217391, 0.98478260869565, -0.125
104728, 1.3086956521739, 0.98478260869565, -0.15
104729, 1.3304347826087, 1.0108695652174, -0.15
104730, 1.3304347826087, 0.98478260869565, -0.125
104731, 1.3521739130435, 0.98478260869565, -0.15
104732, 1.3739130434783, 1.0108695652174, -0.15
104733, 1.3739130434783, 0.98478260869565, -0.125
104734, 1.395652173913, 0.98478260869565, -0.15
104735, 1.4173913043478, 1.0108695652174, -0.15
104736, 1.4173913043478, 0.98478260869565, -0.125
104737, 1.4391304347826, 0.98478260869565, -0.15
104738, 1.4608695652174, 1.0108695652174, -0.15
104739, 1.4608695652174, 0.98478260869565, -0.125
104740, 1.4826086956522, 0.98478260869565, -0.15
104741, 1.504347826087, 1.0108695652174, -0.15
104742, 1.504347826087, 0.98478260869565, -0.125
104743, 1.5260869565217, 0.98478260869565, -0.15
104744, 1.5478260869565, 1.0108695652174, -0.15
104745, 1.5478260869565, 0.98478260869565, -0.125
104746, 1.5695652173913, 0.98478260869565, -0.15
104747, 1.5913043478261, 1.0108695652174, -0.15
104748, 1.5913043478261, 0.98478260869565, -0.125
104749, 1.6130434782609, 0.98478260869565, -0.15
104750, 1.6347826086957, 1.0108695652174, -0.15
104751, 1.6347826086957, 0.98478260869565, -0.125
104752, 1.6565217391304, 0.98478260869565, -0.15
104753, 1.6782608695652, 1.0108695652174, -0.15
104754, 1.6782608695652, 0.98478260869565, -0.125
104755, 1.7, 0.98478260869565, -0.15
104756, 1.7217391304348, 1.0108695652174, -0.15
104757, 1.7217391304348, 0.98478260869565, -0.125
104758, 1.7434782608696, 0.98478260869565, -0.15
104759, 1.7652173913043, 1.0108695652174, -0.15
104760, 1.7652173913043, 0.98478260869565, -0.125
104761, 1.7869565217391, 0.98478260869565, -0.15
104762, 1.8086956521739, 1.0108695652174, -0.15
104763, 1.8086956521739, 0.98478260869565, -0.125
104764, 1.8304347826087, 0.98478260869565, -0.15
104765, 1.8521739130435, 1.0108695652174, -0.15
104766, 1.8521739130435, 0.98478260869565, -0.125
104767, 1.8739130434783, 0.98478260869565, -0.15
104768, 1.895652173913, 1.0108695652174, -0.15
104769, 1.895652173913, 0.98478260869565, -0.125
104770, 1.9173913043478, 0.98478260869565, -0.15
104771, 1.9391304347826, 1.0108695652174, -0.15
104772, 1.9391304347826, 0.98478260869565, -0.125
104773, 1.9608695652174, 0.98478260869565, -0.15
104774, 1.9826086956522, 1.0108695652174, -0.15
104775, 1.9826086956522, 0.98478260869565, -0.125
104776, 2.004347826087, 0.98478260869565, -0.15
104777, 2.0260869565217, 1.0108695652174, -0.15
104778, 2.0260869565217, 0.98478260869565, -0.125
104779, 2.0478260869565, 0.98478260869565, -0.15
104780, 2.0695652173913, 1.0108695652174, -0.15
104781, 2.0695652173913, 0.98478260869565, -0.125
104782, 2.0913043478261, 0.98478260869565, -0.15
104783, 2.1130434782609, 1.0108695652174, -0.15
104784, 2.1130434782609, 0.98478260869565, -0.125
104785, 2.1347826086957, 0.98478260869565, -0.15
104786, 2.1565217391304, 1.0108695652174, -0.15
104787, 2.1565217391304, 0.98478260869565, -0.125
104788, 2.1782608695652, 0.98478260869565, -0.15
104789, 1.2217391304348, 0.93260869565217, -0.15
104790, 1.2434782608696, 0.95869565217391, -0.15
104791, 1.2434782608696, 0.93260869565217, -0.125
104792, 1.2652173913043, 0.93260869565217, -0.15
104793, 1.2869565217391, 0.95869565217391, -0.15
104794, 1.2869565217391, 0.93260869565217, -0.125
104795, 1.3086956521739, 0.93260869565217, -0.15
104796, 1.3304347826087, 0.95869565217391, -0.15
104797, 1.3304347826087, 0.93260869565217, -0.125
104798, 1.3521739130435, 0.93260869565217, -0.15
104799, 1.3739130434783, 0.95869565217391, -0.15
104800, 1.3739130434783, 0.93260869565217, -0.125
104801, 1.395652173913, 0.93260869565217, -0.15
104802, 1.4173913043478, 0.95869565217391, -0.15
104803, 1.4173913043478, 0.93260869565217, -0.125
104804, 1.4391304347826, 0.93260869565217, -0.15
104805, 1.4608695652174, 0.95869565217391, -0.15
104806, 1.4608695652174, 0.93260869565217, -0.125
104807, 1.4826086956522, 0.93260869565217, -0.15
104808, 1.504347826087, 0.95869565217391, -0.15
104809, 1.504347826087, 0.93260869565217, -0.125
104810, 1.5260869565217, 0.93260869565217, -0.15
104811, 1.5478260869565, 0.95869565217391, -0.15
104812, 1.5478260869565, 0.93260869565217, -0.125
104813, 1.5695652173913, 0.93260869565217, -0.15
104814, 1.5913043478261, 0.95869565217391, -0.15
104815, 1.5913043478261, 0.93260869565217, -0.125
104816, 1.6130434782609, 0.93260869565217, -0.15
104817, 1.6347826086957, 0.95869565217391, -0.15
104818, 1.6347826086957, 0.93260869565217, -0.125
104819, 1.6565217391304, 0.93260869565217, -0.15
104820, 1.6782608695652, 0.95869565217391, -0.15
104821, 1.6782608695652, 0.93260869565217, -0.125
104822, 1.7, 0.93260869565217, -0.15
104823, 1.7217391304348, 0.95869565217391, -0.15
104824, 1.7217391304348, 0.93260869565217, -0.125
104825, 1.7434782608696, 0.93260869565217, -0.15
104826, 1.7652173913043, 0.95869565217391, -0.15
104827, 1.7652173913043, 0.93260869565217, -0.125
104828, 1.7869565217391, 0.93260869565217, -0.15
104829, 1.8086956521739, 0.95869565217391, -0.15
104830, 1.8086956521739, 0.93260869565217, -0.125
104831, 1.8304347826087, 0.93260869565217, -0.15
104832, 1.8521739130435, 0.95869565217391, -0.15
104833, 1.8521739130435, 0.93260869565218, -0.125
104834, 1.8739130434783, 0.93260869565217, -0.15
104835, 1.895652173913, 0.95869565217391, -0.15
104836, 1.895652173913, 0.93260869565217, -0.125
104837, 1.9173913043478, 0.93260869565217, -0.15
104838, 1.9391304347826, 0.95869565217391, -0.15
104839, 1.9391304347826, 0.93260869565218, -0.125
104840, 1.9608695652174, 0.93260869565217, -0.15
104841, 1.9826086956522, 0.95869565217391, -0.15
104842, 1.9826086956522, 0.93260869565217, -0.125
104843, 2.004347826087, 0.93260869565217, -0.15
104844, 2.0260869565217, 0.95869565217391, -0.15
104845, 2.0260869565217, 0.93260869565217, -0.125
104846, 2.0478260869565, 0.93260869565217, -0.15
104847, 2.0695652173913, 0.95869565217391, -0.15
104848, 2.0695652173913, 0.93260869565217, -0.125
104849, 2.0913043478261, 0.93260869565217, -0.15
104850, 2.1130434782609, 0.95869565217391, -0.15
104851, 2.1130434782609, 0.93260869565217, -0.125
104852, 2.1347826086957, 0.93260869565217, -0.15
104853, 2.1565217391304, 0.95869565217391, -0.15
104854, 2.1565217391304, 0.93260869565217, -0.125
104855, 2.1782608695652, 0.93260869565217, -0.15
104856, 1.2217391304348, 0.8804347826087, -0.15
104857, 1.2434782608696, 0.90652173913044, -0.15
104858, 1.2434782608696, 0.8804347826087, -0.125
104859, 1.2652173913043, 0.8804347826087, -0.15
104860, 1.2869565217391, 0.90652173913044, -0.15
104861, 1.2869565217391, 0.8804347826087, -0.125
104862, 1.3086956521739, 0.8804347826087, -0.15
104863, 1.3304347826087, 0.90652173913044, -0.15
104864, 1.3304347826087, 0.8804347826087, -0.125
104865, 1.3521739130435, 0.8804347826087, -0.15
104866, 1.3739130434783, 0.90652173913044, -0.15
104867, 1.3739130434783, 0.8804347826087, -0.125
104868, 1.395652173913, 0.8804347826087, -0.15
104869, 1.4173913043478, 0.90652173913044, -0.15
104870, 1.4173913043478, 0.8804347826087, -0.125
104871, 1.4391304347826, 0.8804347826087, -0.15
104872, 1.4608695652174, 0.90652173913044, -0.15
104873, 1.4608695652174, 0.8804347826087, -0.125
104874, 1.4826086956522, 0.8804347826087, -0.15
104875, 1.504347826087, 0.90652173913044, -0.15
104876, 1.504347826087, 0.8804347826087, -0.125
104877, 1.5260869565217, 0.8804347826087, -0.15
104878, 1.5478260869565, 0.90652173913044, -0.15
104879, 1.5478260869565, 0.8804347826087, -0.125
104880, 1.5695652173913, 0.8804347826087, -0.15
104881, 1.5913043478261, 0.90652173913044, -0.15
104882, 1.5913043478261, 0.8804347826087, -0.125
104883, 1.6130434782609, 0.8804347826087, -0.15
104884, 1.6347826086957, 0.90652173913044, -0.15
104885, 1.6347826086957, 0.8804347826087, -0.125
104886, 1.6565217391304, 0.8804347826087, -0.15
104887, 1.6782608695652, 0.90652173913044, -0.15
104888, 1.6782608695652, 0.8804347826087, -0.125
104889, 1.7, 0.8804347826087, -0.15
104890, 1.7217391304348, 0.90652173913044, -0.15
104891, 1.7217391304348, 0.8804347826087, -0.125
104892, 1.7434782608696, 0.8804347826087, -0.15
104893, 1.7652173913043, 0.90652173913044, -0.15
104894, 1.7652173913043, 0.8804347826087, -0.125
104895, 1.7869565217391, 0.8804347826087, -0.15
104896, 1.8086956521739, 0.90652173913044, -0.15
104897, 1.8086956521739, 0.8804347826087, -0.125
104898, 1.8304347826087, 0.8804347826087, -0.15
104899, 1.8521739130435, 0.90652173913044, -0.15
104900, 1.8521739130435, 0.8804347826087, -0.125
104901, 1.8739130434783, 0.8804347826087, -0.15
104902, 1.895652173913, 0.90652173913044, -0.15
104903, 1.895652173913, 0.8804347826087, -0.125
104904, 1.9173913043478, 0.8804347826087, -0.15
104905, 1.9391304347826, 0.90652173913044, -0.15
104906, 1.9391304347826, 0.8804347826087, -0.125
104907, 1.9608695652174, 0.8804347826087, -0.15
104908, 1.9826086956522, 0.90652173913044, -0.15
104909, 1.9826086956522, 0.8804347826087, -0.125
104910, 2.004347826087, 0.8804347826087, -0.15
104911, 2.0260869565217, 0.90652173913044, -0.15
104912, 2.0260869565217, 0.8804347826087, -0.125
104913, 2.0478260869565, 0.8804347826087, -0.15
104914, 2.0695652173913, 0.90652173913044, -0.15
104915, 2.0695652173913, 0.8804347826087, -0.125
104916, 2.0913043478261, 0.8804347826087, -0.15
104917, 2.1130434782609, 0.90652173913044, -0.15
104918, 2.1130434782609, 0.8804347826087, -0.125
104919, 2.1347826086957, 0.8804347826087, -0.15
104920, 2.1565217391304, 0.90652173913044, -0.15
104921, 2.1565217391304, 0.8804347826087, -0.125
104922, 2.1782608695652, 0.8804347826087, -0.15
104923, 1.2217391304348, 0.82826086956522, -0.15
104924, 1.2434782608696, 0.85434782608696, -0.15
104925, 1.2434782608696, 0.82826086956522, -0.125
104926, 1.2652173913043, 0.82826086956522, -0.15
104927, 1.2869565217391, 0.85434782608696, -0.15
104928, 1.2869565217391, 0.82826086956522, -0.125
104929, 1.3086956521739, 0.82826086956522, -0.15
104930, 1.3304347826087, 0.85434782608696, -0.15
104931, 1.3304347826087, 0.82826086956522, -0.125
104932, 1.3521739130435, 0.82826086956522, -0.15
104933, 1.3739130434783, 0.85434782608696, -0.15
104934, 1.3739130434783, 0.82826086956522, -0.125
104935, 1.395652173913, 0.82826086956522, -0.15
104936, 1.4173913043478, 0.85434782608696, -0.15
104937, 1.4173913043478, 0.82826086956522, -0.125
104938, 1.4391304347826, 0.82826086956522, -0.15
104939, 1.4608695652174, 0.85434782608696, -0.15
104940, 1.4608695652174, 0.82826086956522, -0.125
104941, 1.4826086956522, 0.82826086956522, -0.15
104942, 1.504347826087, 0.85434782608696, -0.15
104943, 1.504347826087, 0.82826086956522, -0.125
104944, 1.5260869565217, 0.82826086956522, -0.15
104945, 1.5478260869565, 0.85434782608696, -0.15
104946, 1.5478260869565, 0.82826086956522, -0.125
104947, 1.5695652173913, 0.82826086956522, -0.15
104948, 1.5913043478261, 0.85434782608696, -0.15
104949, 1.5913043478261, 0.82826086956522, -0.125
104950, 1.6130434782609, 0.82826086956522, -0.15
104951, 1.6347826086957, 0.85434782608696, -0.15
104952, 1.6347826086957, 0.82826086956522, -0.125
104953, 1.6565217391304, 0.82826086956522, -0.15
104954, 1.6782608695652, 0.85434782608696, -0.15
104955, 1.6782608695652, 0.82826086956522, -0.125
104956, 1.7, 0.82826086956522, -0.15
104957, 1.7217391304348, 0.85434782608696, -0.15
104958, 1.7217391304348, 0.82826086956522, -0.125
104959, 1.7434782608696, 0.82826086956522, -0.15
104960, 1.7652173913043, 0.85434782608696, -0.15
104961, 1.7652173913043, 0.82826086956522, -0.125
104962, 1.7869565217391, 0.82826086956522, -0.15
104963, 1.8086956521739, 0.85434782608696, -0.15
104964, 1.8086956521739, 0.82826086956522, -0.125
104965, 1.8304347826087, 0.82826086956522, -0.15
104966, 1.8521739130435, 0.85434782608696, -0.15
104967, 1.8521739130435, 0.82826086956522, -0.125
104968, 1.8739130434783, 0.82826086956522, -0.15
104969, 1.895652173913, 0.85434782608696, -0.15
104970, 1.895652173913, 0.82826086956522, -0.125
104971, 1.9173913043478, 0.82826086956522, -0.15
104972, 1.9391304347826, 0.85434782608696, -0.15
104973, 1.9391304347826, 0.82826086956522, -0.125
104974, 1.9608695652174, 0.82826086956522, -0.15
104975, 1.9826086956522, 0.85434782608696, -0.15
104976, 1.9826086956522, 0.82826086956522, -0.125
104977, 2.004347826087, 0.82826086956522, -0.15
104978, 2.0260869565217, 0.85434782608696, -0.15
104979, 2.0260869565217, 0.82826086956522, -0.125
104980, 2.0478260869565, 0.82826086956522, -0.15
104981, 2.0695652173913, 0.85434782608696, -0.15
104982, 2.0695652173913, 0.82826086956522, -0.125
104983, 2.0913043478261, 0.82826086956522, -0.15
104984, 2.1130434782609, 0.85434782608696, -0.15
104985, 2.1130434782609, 0.82826086956522, -0.125
104986, 2.1347826086957, 0.82826086956522, -0.15
104987, 2.1565217391304, 0.85434782608696, -0.15
104988, 2.1565217391304, 0.82826086956522, -0.125
104989, 2.1782608695652, 0.82826086956522, -0.15
104990, 1.2217391304348, 0.77608695652174, -0.15
104991, 1.2434782608696, 0.80217391304348, -0.15
104992, 1.2434782608696, 0.77608695652174, -0.125
104993, 1.2652173913043, 0.77608695652174, -0.15
104994, 1.2869565217391, 0.80217391304348, -0.15
104995, 1.2869565217391, 0.77608695652174, -0.125
104996, 1.3086956521739, 0.77608695652174, -0.15
104997, 1.3304347826087, 0.80217391304348, -0.15
104998, 1.3304347826087, 0.77608695652174, -0.125
104999, 1.3521739130435, 0.77608695652174, -0.15
105000, 1.3739130434783, 0.80217391304348, -0.15
105001, 1.3739130434783, 0.77608695652174, -0.125
105002, 1.395652173913, 0.77608695652174, -0.15
105003, 1.4173913043478, 0.80217391304348, -0.15
105004, 1.4173913043478, 0.77608695652174, -0.125
105005, 1.4391304347826, 0.77608695652174, -0.15
105006, 1.4608695652174, 0.80217391304348, -0.15
105007, 1.4608695652174, 0.77608695652174, -0.125
105008, 1.4826086956522, 0.77608695652174, -0.15
105009, 1.504347826087, 0.80217391304348, -0.15
105010, 1.504347826087, 0.77608695652174, -0.125
105011, 1.5260869565217, 0.77608695652174, -0.15
105012, 1.5478260869565, 0.80217391304348, -0.15
105013, 1.5478260869565, 0.77608695652174, -0.125
105014, 1.5695652173913, 0.77608695652174, -0.15
105015, 1.5913043478261, 0.80217391304348, -0.15
105016, 1.5913043478261, 0.77608695652174, -0.125
105017, 1.6130434782609, 0.77608695652174, -0.15
105018, 1.6347826086957, 0.80217391304348, -0.15
105019, 1.6347826086957, 0.77608695652174, -0.125
105020, 1.6565217391304, 0.77608695652174, -0.15
105021, 1.6782608695652, 0.80217391304348, -0.15
105022, 1.6782608695652, 0.77608695652174, -0.125
105023, 1.7, 0.77608695652174, -0.15
105024, 1.7217391304348, 0.80217391304348, -0.15
105025, 1.7217391304348, 0.77608695652174, -0.125
105026, 1.7434782608696, 0.77608695652174, -0.15
105027, 1.7652173913043, 0.80217391304348, -0.15
105028, 1.7652173913043, 0.77608695652174, -0.125
105029, 1.7869565217391, 0.77608695652174, -0.15
105030, 1.8086956521739, 0.80217391304348, -0.15
105031, 1.8086956521739, 0.77608695652174, -0.125
105032, 1.8304347826087, 0.77608695652174, -0.15
105033, 1.8521739130435, 0.80217391304348, -0.15
105034, 1.8521739130435, 0.77608695652174, -0.125
105035, 1.8739130434783, 0.77608695652174, -0.15
105036, 1.895652173913, 0.80217391304348, -0.15
105037, 1.895652173913, 0.77608695652174, -0.125
105038, 1.9173913043478, 0.77608695652174, -0.15
105039, 1.9391304347826, 0.80217391304348, -0.15
105040, 1.9391304347826, 0.77608695652174, -0.125
105041, 1.9608695652174, 0.77608695652174, -0.15
105042, 1.9826086956522, 0.80217391304348, -0.15
105043, 1.9826086956522, 0.77608695652174, -0.125
105044, 2.004347826087, 0.77608695652174, -0.15
105045, 2.0260869565217, 0.80217391304348, -0.15
105046, 2.0260869565217, 0.77608695652174, -0.125
105047, 2.0478260869565, 0.77608695652174, -0.15
105048, 2.0695652173913, 0.80217391304348, -0.15
105049, 2.0695652173913, 0.77608695652174, -0.125
105050, 2.0913043478261, 0.77608695652174, -0.15
105051, 2.1130434782609, 0.80217391304348, -0.15
105052, 2.1130434782609, 0.77608695652174, -0.125
105053, 2.1347826086957, 0.77608695652174, -0.15
105054, 2.1565217391304, 0.80217391304348, -0.15
105055, 2.1565217391304, 0.77608695652174, -0.125
105056, 2.1782608695652, 0.77608695652174, -0.15
105057, 1.2217391304348, 0.72391304347826, -0.15
105058, 1.2434782608696, 0.75, -0.15
105059, 1.2434782608696, 0.72391304347826, -0.125
105060, 1.2652173913043, 0.72391304347826, -0.15
105061, 1.2869565217391, 0.75, -0.15
105062, 1.2869565217391, 0.72391304347826, -0.125
105063, 1.3086956521739, 0.72391304347826, -0.15
105064, 1.3304347826087, 0.75, -0.15
105065, 1.3304347826087, 0.72391304347826, -0.125
105066, 1.3521739130435, 0.72391304347826, -0.15
105067, 1.3739130434783, 0.75, -0.15
105068, 1.3739130434783, 0.72391304347826, -0.125
105069, 1.395652173913, 0.72391304347826, -0.15
105070, 1.4173913043478, 0.75, -0.15
105071, 1.4173913043478, 0.72391304347826, -0.125
105072, 1.4391304347826, 0.72391304347826, -0.15
105073, 1.4608695652174, 0.75, -0.15
105074, 1.4608695652174, 0.72391304347826, -0.125
105075, 1.4826086956522, 0.72391304347826, -0.15
105076, 1.504347826087, 0.75, -0.15
105077, 1.504347826087, 0.72391304347826, -0.125
105078, 1.5260869565217, 0.72391304347826, -0.15
105079, 1.5478260869565, 0.75, -0.15
105080, 1.5478260869565, 0.72391304347826, -0.125
105081, 1.5695652173913, 0.72391304347826, -0.15
105082, 1.5913043478261, 0.75, -0.15
105083, 1.5913043478261, 0.72391304347826, -0.125
105084, 1.6130434782609, 0.72391304347826, -0.15
105085, 1.6347826086957, 0.75, -0.15
105086, 1.6347826086957, 0.72391304347826, -0.125
105087, 1.6565217391304, 0.72391304347826, -0.15
105088, 1.6782608695652, 0.75, -0.15
105089, 1.6782608695652, 0.72391304347826, -0.125
105090, 1.7, 0.72391304347826, -0.15
105091, 1.7217391304348, 0.75, -0.15
105092, 1.7217391304348, 0.72391304347826, -0.125
105093, 1.7434782608696, 0.72391304347826, -0.15
105094, 1.7652173913043, 0.75, -0.15
105095, 1.7652173913043, 0.72391304347826, -0.125
105096, 1.7869565217391, 0.72391304347826, -0.15
105097, 1.8086956521739, 0.75, -0.15
105098, 1.8086956521739, 0.72391304347826, -0.125
105099, 1.8304347826087, 0.72391304347826, -0.15
105100, 1.8521739130435, 0.75, -0.15
105101, 1.8521739130435, 0.72391304347826, -0.125
105102, 1.8739130434783, 0.72391304347826, -0.15
105103, 1.895652173913, 0.75, -0.15
105104, 1.895652173913, 0.72391304347826, -0.125
105105, 1.9173913043478, 0.72391304347826, -0.15
105106, 1.9391304347826, 0.75, -0.15
105107, 1.9391304347826, 0.72391304347826, -0.125
105108, 1.9608695652174, 0.72391304347826, -0.15
105109, 1.9826086956522, 0.75, -0.15
105110, 1.9826086956522, 0.72391304347826, -0.125
105111, 2.004347826087, 0.72391304347826, -0.15
105112, 2.0260869565217, 0.75, -0.15
105113, 2.0260869565217, 0.72391304347826, -0.125
105114, 2.0478260869565, 0.72391304347826, -0.15
105115, 2.0695652173913, 0.75, -0.15
105116, 2.0695652173913, 0.72391304347826, -0.125
105117, 2.0913043478261, 0.72391304347826, -0.15
105118, 2.1130434782609, 0.75, -0.15
105119, 2.1130434782609, 0.72391304347826, -0.125
105120, 2.1347826086957, 0.72391304347826, -0.15
105121, 2.1565217391304, 0.75, -0.15
105122, 2.1565217391304, 0.72391304347826, -0.125
105123, 2.1782608695652, 0.72391304347826, -0.15
105124, 1.2217391304348, 0.67173913043478, -0.15
105125, 1.2434782608696, 0.69782608695652, -0.15
105126, 1.2434782608696, 0.67173913043478, -0.125
105127, 1.2652173913043, 0.67173913043478, -0.15
105128, 1.2869565217391, 0.69782608695652, -0.15
105129, 1.2869565217391, 0.67173913043478, -0.125
105130, 1.3086956521739, 0.67173913043478, -0.15
105131, 1.3304347826087, 0.69782608695652, -0.15
105132, 1.3304347826087, 0.67173913043478, -0.125
105133, 1.3521739130435, 0.67173913043478, -0.15
105134, 1.3739130434783, 0.69782608695652, -0.15
105135, 1.3739130434783, 0.67173913043478, -0.125
105136, 1.395652173913, 0.67173913043478, -0.15
105137, 1.4173913043478, 0.69782608695652, -0.15
105138, 1.4173913043478, 0.67173913043478, -0.125
105139, 1.4391304347826, 0.67173913043478, -0.15
105140, 1.4608695652174, 0.69782608695652, -0.15
105141, 1.4608695652174, 0.67173913043478, -0.125
105142, 1.4826086956522, 0.67173913043478, -0.15
105143, 1.504347826087, 0.69782608695652, -0.15
105144, 1.504347826087, 0.67173913043478, -0.125
105145, 1.5260869565217, 0.67173913043478, -0.15
105146, 1.5478260869565, 0.69782608695652, -0.15
105147, 1.5478260869565, 0.67173913043478, -0.125
105148, 1.5695652173913, 0.67173913043478, -0.15
105149, 1.5913043478261, 0.69782608695652, -0.15
105150, 1.5913043478261, 0.67173913043478, -0.125
105151, 1.6130434782609, 0.67173913043478, -0.15
105152, 1.6347826086957, 0.69782608695652, -0.15
105153, 1.6347826086957, 0.67173913043478, -0.125
105154, 1.6565217391304, 0.67173913043478, -0.15
105155, 1.6782608695652, 0.69782608695652, -0.15
105156, 1.6782608695652, 0.67173913043478, -0.125
105157, 1.7, 0.67173913043478, -0.15
105158, 1.7217391304348, 0.69782608695652, -0.15
105159, 1.7217391304348, 0.67173913043478, -0.125
105160, 1.7434782608696, 0.67173913043478, -0.15
105161, 1.7652173913043, 0.69782608695652, -0.15
105162, 1.7652173913043, 0.67173913043478, -0.125
105163, 1.7869565217391, 0.67173913043478, -0.15
105164, 1.8086956521739, 0.69782608695652, -0.15
105165, 1.8086956521739, 0.67173913043478, -0.125
105166, 1.8304347826087, 0.67173913043478, -0.15
105167, 1.8521739130435, 0.69782608695652, -0.15
105168, 1.8521739130435, 0.67173913043478, -0.125
105169, 1.8739130434783, 0.67173913043478, -0.15
105170, 1.895652173913, 0.69782608695652, -0.15
105171, 1.895652173913, 0.67173913043478, -0.125
105172, 1.9173913043478, 0.67173913043478, -0.15
105173, 1.9391304347826, 0.69782608695652, -0.15
105174, 1.9391304347826, 0.67173913043478, -0.125
105175, 1.9608695652174, 0.67173913043478, -0.15
105176, 1.9826086956522, 0.69782608695652, -0.15
105177, 1.9826086956522, 0.67173913043478, -0.125
105178, 2.004347826087, 0.67173913043478, -0.15
105179, 2.0260869565217, 0.69782608695652, -0.15
105180, 2.0260869565217, 0.67173913043478, -0.125
105181, 2.0478260869565, 0.67173913043478, -0.15
105182, 2.0695652173913, 0.69782608695652, -0.15
105183, 2.0695652173913, 0.67173913043478, -0.125
105184, 2.0913043478261, 0.67173913043478, -0.15
105185, 2.1130434782609, 0.69782608695652, -0.15
105186, 2.1130434782609, 0.67173913043478, -0.125
105187, 2.1347826086957, 0.67173913043478, -0.15
105188, 2.1565217391304, 0.69782608695652, -0.15
105189, 2.1565217391304, 0.67173913043478, -0.125
105190, 2.1782608695652, 0.67173913043478, -0.15
105191, 1.2217391304348, 0.61956521739131, -0.15
105192, 1.2434782608696, 0.64565217391304, -0.15
105193, 1.2434782608696, 0.6195652173913, -0.125
105194, 1.2652173913043, 0.61956521739131, -0.15
105195, 1.2869565217391, 0.64565217391304, -0.15
105196, 1.2869565217391, 0.61956521739131, -0.125
105197, 1.3086956521739, 0.61956521739131, -0.15
105198, 1.3304347826087, 0.64565217391304, -0.15
105199, 1.3304347826087, 0.61956521739131, -0.125
105200, 1.3521739130435, 0.61956521739131, -0.15
105201, 1.3739130434783, 0.64565217391304, -0.15
105202, 1.3739130434783, 0.61956521739131, -0.125
105203, 1.395652173913, 0.61956521739131, -0.15
105204, 1.4173913043478, 0.64565217391304, -0.15
105205, 1.4173913043478, 0.61956521739131, -0.125
105206, 1.4391304347826, 0.61956521739131, -0.15
105207, 1.4608695652174, 0.64565217391304, -0.15
105208, 1.4608695652174, 0.6195652173913, -0.125
105209, 1.4826086956522, 0.61956521739131, -0.15
105210, 1.504347826087, 0.64565217391304, -0.15
105211, 1.504347826087, 0.61956521739131, -0.125
105212, 1.5260869565217, 0.61956521739131, -0.15
105213, 1.5478260869565, 0.64565217391304, -0.15
105214, 1.5478260869565, 0.61956521739131, -0.125
105215, 1.5695652173913, 0.61956521739131, -0.15
105216, 1.5913043478261, 0.64565217391304, -0.15
105217, 1.5913043478261, 0.6195652173913, -0.125
105218, 1.6130434782609, 0.61956521739131, -0.15
105219, 1.6347826086957, 0.64565217391304, -0.15
105220, 1.6347826086957, 0.61956521739131, -0.125
105221, 1.6565217391304, 0.61956521739131, -0.15
105222, 1.6782608695652, 0.64565217391304, -0.15
105223, 1.6782608695652, 0.61956521739131, -0.125
105224, 1.7, 0.61956521739131, -0.15
105225, 1.7217391304348, 0.64565217391304, -0.15
105226, 1.7217391304348, 0.61956521739131, -0.125
105227, 1.7434782608696, 0.61956521739131, -0.15
105228, 1.7652173913043, 0.64565217391304, -0.15
105229, 1.7652173913043, 0.61956521739131, -0.125
105230, 1.7869565217391, 0.61956521739131, -0.15
105231, 1.8086956521739, 0.64565217391304, -0.15
105232, 1.8086956521739, 0.61956521739131, -0.125
105233, 1.8304347826087, 0.61956521739131, -0.15
105234, 1.8521739130435, 0.64565217391304, -0.15
105235, 1.8521739130435, 0.61956521739131, -0.125
105236, 1.8739130434783, 0.61956521739131, -0.15
105237, 1.895652173913, 0.64565217391304, -0.15
105238, 1.895652173913, 0.61956521739131, -0.125
105239, 1.9173913043478, 0.61956521739131, -0.15
105240, 1.9391304347826, 0.64565217391304, -0.15
105241, 1.9391304347826, 0.61956521739131, -0.125
105242, 1.9608695652174, 0.61956521739131, -0.15
105243, 1.9826086956522, 0.64565217391304, -0.15
105244, 1.9826086956522, 0.61956521739131, -0.125
105245, 2.004347826087, 0.61956521739131, -0.15
105246, 2.0260869565217, 0.64565217391304, -0.15
105247, 2.0260869565217, 0.61956521739131, -0.125
105248, 2.0478260869565, 0.61956521739131, -0.15
105249, 2.0695652173913, 0.64565217391304, -0.15
105250, 2.0695652173913, 0.61956521739131, -0.125
105251, 2.0913043478261, 0.61956521739131, -0.15
105252, 2.1130434782609, 0.64565217391304, -0.15
105253, 2.1130434782609, 0.61956521739131, -0.125
105254, 2.1347826086957, 0.61956521739131, -0.15
105255, 2.1565217391304, 0.64565217391304, -0.15
105256, 2.1565217391304, 0.61956521739131, -0.125
105257, 2.1782608695652, 0.61956521739131, -0.15
105258, 1.2217391304348, 0.56739130434783, -0.15
105259, 1.2434782608696, 0.59347826086957, -0.15
105260, 1.2434782608696, 0.56739130434783, -0.125
105261, 1.2652173913043, 0.56739130434783, -0.15
105262, 1.2869565217391, 0.59347826086957, -0.15
105263, 1.2869565217391, 0.56739130434783, -0.125
105264, 1.3086956521739, 0.56739130434783, -0.15
105265, 1.3304347826087, 0.59347826086957, -0.15
105266, 1.3304347826087, 0.56739130434783, -0.125
105267, 1.3521739130435, 0.56739130434783, -0.15
105268, 1.3739130434783, 0.59347826086957, -0.15
105269, 1.3739130434783, 0.56739130434783, -0.125
105270, 1.395652173913, 0.56739130434783, -0.15
105271, 1.4173913043478, 0.59347826086957, -0.15
105272, 1.4173913043478, 0.56739130434783, -0.125
105273, 1.4391304347826, 0.56739130434783, -0.15
105274, 1.4608695652174, 0.59347826086957, -0.15
105275, 1.4608695652174, 0.56739130434783, -0.125
105276, 1.4826086956522, 0.56739130434783, -0.15
105277, 1.504347826087, 0.59347826086957, -0.15
105278, 1.504347826087, 0.56739130434783, -0.125
105279, 1.5260869565217, 0.56739130434783, -0.15
105280, 1.5478260869565, 0.59347826086957, -0.15
105281, 1.5478260869565, 0.56739130434783, -0.125
105282, 1.5695652173913, 0.56739130434783, -0.15
105283, 1.5913043478261, 0.59347826086957, -0.15
105284, 1.5913043478261, 0.56739130434783, -0.125
105285, 1.6130434782609, 0.56739130434783, -0.15
105286, 1.6347826086957, 0.59347826086957, -0.15
105287, 1.6347826086957, 0.56739130434783, -0.125
105288, 1.6565217391304, 0.56739130434783, -0.15
105289, 1.6782608695652, 0.59347826086957, -0.15
105290, 1.6782608695652, 0.56739130434783, -0.125
105291, 1.7, 0.56739130434783, -0.15
105292, 1.7217391304348, 0.59347826086957, -0.15
105293, 1.7217391304348, 0.56739130434783, -0.125
105294, 1.7434782608696, 0.56739130434783, -0.15
105295, 1.7652173913043, 0.59347826086957, -0.15
105296, 1.7652173913043, 0.56739130434783, -0.125
105297, 1.7869565217391, 0.56739130434783, -0.15
105298, 1.8086956521739, 0.59347826086957, -0.15
105299, 1.8086956521739, 0.56739130434783, -0.125
105300, 1.8304347826087, 0.56739130434783, -0.15
105301, 1.8521739130435, 0.59347826086957, -0.15
105302, 1.8521739130435, 0.56739130434783, -0.125
105303, 1.8739130434783, 0.56739130434783, -0.15
105304, 1.895652173913, 0.59347826086957, -0.15
105305, 1.895652173913, 0.56739130434783, -0.125
105306, 1.9173913043478, 0.56739130434783, -0.15
105307, 1.9391304347826, 0.59347826086957, -0.15
105308, 1.9391304347826, 0.56739130434783, -0.125
105309, 1.9608695652174, 0.56739130434783, -0.15
105310, 1.9826086956522, 0.59347826086957, -0.15
105311, 1.9826086956522, 0.56739130434783, -0.125
105312, 2.004347826087, 0.56739130434783, -0.15
105313, 2.0260869565217, 0.59347826086957, -0.15
105314, 2.0260869565217, 0.56739130434783, -0.125
105315, 2.0478260869565, 0.56739130434783, -0.15
105316, 2.0695652173913, 0.59347826086957, -0.15
105317, 2.0695652173913, 0.56739130434783, -0.125
105318, 2.0913043478261, 0.56739130434783, -0.15
105319, 2.1130434782609, 0.59347826086957, -0.15
105320, 2.1130434782609, 0.56739130434783, -0.125
105321, 2.1347826086957, 0.56739130434783, -0.15
105322, 2.1565217391304, 0.59347826086957, -0.15
105323, 2.1565217391304, 0.56739130434783, -0.125
105324, 2.1782608695652, 0.56739130434783, -0.15
105325, 1.2217391304348, 0.51521739130435, -0.15
105326, 1.2434782608696, 0.54130434782609, -0.15
105327, 1.2434782608696, 0.51521739130435, -0.125
105328, 1.2652173913043, 0.51521739130435, -0.15
105329, 1.2869565217391, 0.54130434782609, -0.15
105330, 1.2869565217391, 0.51521739130435, -0.125
105331, 1.3086956521739, 0.51521739130435, -0.15
105332, 1.3304347826087, 0.54130434782609, -0.15
105333, 1.3304347826087, 0.51521739130435, -0.125
105334, 1.3521739130435, 0.51521739130435, -0.15
105335, 1.3739130434783, 0.54130434782609, -0.15
105336, 1.3739130434783, 0.51521739130435, -0.125
105337, 1.395652173913, 0.51521739130435, -0.15
105338, 1.4173913043478, 0.54130434782609, -0.15
105339, 1.4173913043478, 0.51521739130435, -0.125
105340, 1.4391304347826, 0.51521739130435, -0.15
105341, 1.4608695652174, 0.54130434782609, -0.15
105342, 1.4608695652174, 0.51521739130435, -0.125
105343, 1.4826086956522, 0.51521739130435, -0.15
105344, 1.504347826087, 0.54130434782609, -0.15
105345, 1.504347826087, 0.51521739130435, -0.125
105346, 1.5260869565217, 0.51521739130435, -0.15
105347, 1.5478260869565, 0.54130434782609, -0.15
105348, 1.5478260869565, 0.51521739130435, -0.125
105349, 1.5695652173913, 0.51521739130435, -0.15
105350, 1.5913043478261, 0.54130434782609, -0.15
105351, 1.5913043478261, 0.51521739130435, -0.125
105352, 1.6130434782609, 0.51521739130435, -0.15
105353, 1.6347826086957, 0.54130434782609, -0.15
105354, 1.6347826086957, 0.51521739130435, -0.125
105355, 1.6565217391304, 0.51521739130435, -0.15
105356, 1.6782608695652, 0.54130434782609, -0.15
105357, 1.6782608695652, 0.51521739130435, -0.125
105358, 1.7, 0.51521739130435, -0.15
105359, 1.7217391304348, 0.54130434782609, -0.15
105360, 1.7217391304348, 0.51521739130435, -0.125
105361, 1.7434782608696, 0.51521739130435, -0.15
105362, 1.7652173913043, 0.54130434782609, -0.15
105363, 1.7652173913043, 0.51521739130435, -0.125
105364, 1.7869565217391, 0.51521739130435, -0.15
105365, 1.8086956521739, 0.54130434782609, -0.15
105366, 1.8086956521739, 0.51521739130435, -0.125
105367, 1.8304347826087, 0.51521739130435, -0.15
105368, 1.8521739130435, 0.54130434782609, -0.15
105369, 1.8521739130435, 0.51521739130435, -0.125
105370, 1.8739130434783, 0.51521739130435, -0.15
105371, 1.895652173913, 0.54130434782609, -0.15
105372, 1.895652173913, 0.51521739130435, -0.125
105373, 1.9173913043478, 0.51521739130435, -0.15
105374, 1.9391304347826, 0.54130434782609, -0.15
105375, 1.9391304347826, 0.51521739130435, -0.125
105376, 1.9608695652174, 0.51521739130435, -0.15
105377, 1.9826086956522, 0.54130434782609, -0.15
105378, 1.9826086956522, 0.51521739130435, -0.125
105379, 2.004347826087, 0.51521739130435, -0.15
105380, 2.0260869565217, 0.54130434782609, -0.15
105381, 2.0260869565217, 0.51521739130435, -0.125
105382, 2.0478260869565, 0.51521739130435, -0.15
105383, 2.0695652173913, 0.54130434782609, -0.15
105384, 2.0695652173913, 0.51521739130435, -0.125
105385, 2.0913043478261, 0.51521739130435, -0.15
105386, 2.1130434782609, 0.54130434782609, -0.15
105387, 2.1130434782609, 0.51521739130435, -0.125
105388, 2.1347826086957, 0.51521739130435, -0.15
105389, 2.1565217391304, 0.54130434782609, -0.15
105390, 2.1565217391304, 0.51521739130435, -0.125
105391, 2.1782608695652, 0.51521739130435, -0.15
105392, 1.2217391304348, 0.46304347826087, -0.15
105393, 1.2434782608696, 0.48913043478261, -0.15
105394, 1.2434782608696, 0.46304347826087, -0.125
105395, 1.2652173913043, 0.46304347826087, -0.15
105396, 1.2869565217391, 0.48913043478261, -0.15
105397, 1.2869565217391, 0.46304347826087, -0.125
105398, 1.3086956521739, 0.46304347826087, -0.15
105399, 1.3304347826087, 0.48913043478261, -0.15
105400, 1.3304347826087, 0.46304347826087, -0.125
105401, 1.3521739130435, 0.46304347826087, -0.15
105402, 1.3739130434783, 0.48913043478261, -0.15
105403, 1.3739130434783, 0.46304347826087, -0.125
105404, 1.395652173913, 0.46304347826087, -0.15
105405, 1.4173913043478, 0.48913043478261, -0.15
105406, 1.4173913043478, 0.46304347826087, -0.125
105407, 1.4391304347826, 0.46304347826087, -0.15
105408, 1.4608695652174, 0.48913043478261, -0.15
105409, 1.4608695652174, 0.46304347826087, -0.125
105410, 1.4826086956522, 0.46304347826087, -0.15
105411, 1.504347826087, 0.48913043478261, -0.15
105412, 1.504347826087, 0.46304347826087, -0.125
105413, 1.5260869565217, 0.46304347826087, -0.15
105414, 1.5478260869565, 0.48913043478261, -0.15
105415, 1.5478260869565, 0.46304347826087, -0.125
105416, 1.5695652173913, 0.46304347826087, -0.15
105417, 1.5913043478261, 0.48913043478261, -0.15
105418, 1.5913043478261, 0.46304347826087, -0.125
105419, 1.6130434782609, 0.46304347826087, -0.15
105420, 1.6347826086957, 0.48913043478261, -0.15
105421, 1.6347826086957, 0.46304347826087, -0.125
105422, 1.6565217391304, 0.46304347826087, -0.15
105423, 1.6782608695652, 0.48913043478261, -0.15
105424, 1.6782608695652, 0.46304347826087, -0.125
105425, 1.7, 0.46304347826087, -0.15
105426, 1.7217391304348, 0.48913043478261, -0.15
105427, 1.7217391304348, 0.46304347826087, -0.125
105428, 1.7434782608696, 0.46304347826087, -0.15
105429, 1.7652173913043, 0.48913043478261, -0.15
105430, 1.7652173913043, 0.46304347826087, -0.125
105431, 1.7869565217391, 0.46304347826087, -0.15
105432, 1.8086956521739, 0.48913043478261, -0.15
105433, 1.8086956521739, 0.46304347826087, -0.125
105434, 1.8304347826087, 0.46304347826087, -0.15
105435, 1.8521739130435, 0.48913043478261, -0.15
105436, 1.8521739130435, 0.46304347826087, -0.125
105437, 1.8739130434783, 0.46304347826087, -0.15
105438, 1.895652173913, 0.48913043478261, -0.15
105439, 1.895652173913, 0.46304347826087, -0.125
105440, 1.9173913043478, 0.46304347826087, -0.15
105441, 1.9391304347826, 0.48913043478261, -0.15
105442, 1.9391304347826, 0.46304347826087, -0.125
105443, 1.9608695652174, 0.46304347826087, -0.15
105444, 1.9826086956522, 0.48913043478261, -0.15
105445, 1.9826086956522, 0.46304347826087, -0.125
105446, 2.004347826087, 0.46304347826087, -0.15
105447, 2.0260869565217, 0.48913043478261, -0.15
105448, 2.0260869565217, 0.46304347826087, -0.125
105449, 2.0478260869565, 0.46304347826087, -0.15
105450, 2.0695652173913, 0.48913043478261, -0.15
105451, 2.0695652173913, 0.46304347826087, -0.125
105452, 2.0913043478261, 0.46304347826087, -0.15
105453, 2.1130434782609, 0.48913043478261, -0.15
105454, 2.1130434782609, 0.46304347826087, -0.125
105455, 2.1347826086957, 0.46304347826087, -0.15
105456, 2.1565217391304, 0.48913043478261, -0.15
105457, 2.1565217391304, 0.46304347826087, -0.125
105458, 2.1782608695652, 0.46304347826087, -0.15
105459, 1.2217391304348, 0.41086956521739, -0.15
105460, 1.2434782608696, 0.43695652173913, -0.15
105461, 1.2434782608696, 0.41086956521739, -0.125
105462, 1.2652173913043, 0.41086956521739, -0.15
105463, 1.2869565217391, 0.43695652173913, -0.15
105464, 1.2869565217391, 0.41086956521739, -0.125
105465, 1.3086956521739, 0.41086956521739, -0.15
105466, 1.3304347826087, 0.43695652173913, -0.15
105467, 1.3304347826087, 0.41086956521739, -0.125
105468, 1.3521739130435, 0.41086956521739, -0.15
105469, 1.3739130434783, 0.43695652173913, -0.15
105470, 1.3739130434783, 0.41086956521739, -0.125
105471, 1.395652173913, 0.41086956521739, -0.15
105472, 1.4173913043478, 0.43695652173913, -0.15
105473, 1.4173913043478, 0.41086956521739, -0.125
105474, 1.4391304347826, 0.41086956521739, -0.15
105475, 1.4608695652174, 0.43695652173913, -0.15
105476, 1.4608695652174, 0.41086956521739, -0.125
105477, 1.4826086956522, 0.41086956521739, -0.15
105478, 1.504347826087, 0.43695652173913, -0.15
105479, 1.504347826087, 0.41086956521739, -0.125
105480, 1.5260869565217, 0.41086956521739, -0.15
105481, 1.5478260869565, 0.43695652173913, -0.15
105482, 1.5478260869565, 0.41086956521739, -0.125
105483, 1.5695652173913, 0.41086956521739, -0.15
105484, 1.5913043478261, 0.43695652173913, -0.15
105485, 1.5913043478261, 0.41086956521739, -0.125
105486, 1.6130434782609, 0.41086956521739, -0.15
105487, 1.6347826086957, 0.43695652173913, -0.15
105488, 1.6347826086957, 0.41086956521739, -0.125
105489, 1.6565217391304, 0.41086956521739, -0.15
105490, 1.6782608695652, 0.43695652173913, -0.15
105491, 1.6782608695652, 0.41086956521739, -0.125
105492, 1.7, 0.41086956521739, -0.15
105493, 1.7217391304348, 0.43695652173913, -0.15
105494, 1.7217391304348, 0.41086956521739, -0.125
105495, 1.7434782608696, 0.41086956521739, -0.15
105496, 1.7652173913043, 0.43695652173913, -0.15
105497, 1.7652173913043, 0.41086956521739, -0.125
105498, 1.7869565217391, 0.41086956521739, -0.15
105499, 1.8086956521739, 0.43695652173913, -0.15
105500, 1.8086956521739, 0.41086956521739, -0.125
105501, 1.8304347826087, 0.41086956521739, -0.15
105502, 1.8521739130435, 0.43695652173913, -0.15
105503, 1.8521739130435, 0.41086956521739, -0.125
105504, 1.8739130434783, 0.41086956521739, -0.15
105505, 1.895652173913, 0.43695652173913, -0.15
105506, 1.895652173913, 0.41086956521739, -0.125
105507, 1.9173913043478, 0.41086956521739, -0.15
105508, 1.9391304347826, 0.43695652173913, -0.15
105509, 1.9391304347826, 0.41086956521739, -0.125
105510, 1.9608695652174, 0.41086956521739, -0.15
105511, 1.9826086956522, 0.43695652173913, -0.15
105512, 1.9826086956522, 0.41086956521739, -0.125
105513, 2.004347826087, 0.41086956521739, -0.15
105514, 2.0260869565217, 0.43695652173913, -0.15
105515, 2.0260869565217, 0.41086956521739, -0.125
105516, 2.0478260869565, 0.41086956521739, -0.15
105517, 2.0695652173913, 0.43695652173913, -0.15
105518, 2.0695652173913, 0.41086956521739, -0.125
105519, 2.0913043478261, 0.41086956521739, -0.15
105520, 2.1130434782609, 0.43695652173913, -0.15
105521, 2.1130434782609, 0.41086956521739, -0.125
105522, 2.1347826086957, 0.41086956521739, -0.15
105523, 2.1565217391304, 0.43695652173913, -0.15
105524, 2.1565217391304, 0.41086956521739, -0.125
105525, 2.1782608695652, 0.41086956521739, -0.15
105526, 1.2217391304348, 0.35869565217391, -0.15
105527, 1.2434782608696, 0.38478260869565, -0.15
105528, 1.2434782608696, 0.35869565217391, -0.125
105529, 1.2652173913043, 0.35869565217391, -0.15
105530, 1.2869565217391, 0.38478260869565, -0.15
105531, 1.2869565217391, 0.35869565217391, -0.125
105532, 1.3086956521739, 0.35869565217391, -0.15
105533, 1.3304347826087, 0.38478260869565, -0.15
105534, 1.3304347826087, 0.35869565217391, -0.125
105535, 1.3521739130435, 0.35869565217391, -0.15
105536, 1.3739130434783, 0.38478260869565, -0.15
105537, 1.3739130434783, 0.35869565217391, -0.125
105538, 1.395652173913, 0.35869565217391, -0.15
105539, 1.4173913043478, 0.38478260869565, -0.15
105540, 1.4173913043478, 0.35869565217391, -0.125
105541, 1.4391304347826, 0.35869565217391, -0.15
105542, 1.4608695652174, 0.38478260869565, -0.15
105543, 1.4608695652174, 0.35869565217391, -0.125
105544, 1.4826086956522, 0.35869565217391, -0.15
105545, 1.504347826087, 0.38478260869565, -0.15
105546, 1.504347826087, 0.35869565217391, -0.125
105547, 1.5260869565217, 0.35869565217391, -0.15
105548, 1.5478260869565, 0.38478260869565, -0.15
105549, 1.5478260869565, 0.35869565217391, -0.125
105550, 1.5695652173913, 0.35869565217391, -0.15
105551, 1.5913043478261, 0.38478260869565, -0.15
105552, 1.5913043478261, 0.35869565217391, -0.125
105553, 1.6130434782609, 0.35869565217391, -0.15
105554, 1.6347826086957, 0.38478260869565, -0.15
105555, 1.6347826086957, 0.35869565217391, -0.125
105556, 1.6565217391304, 0.35869565217391, -0.15
105557, 1.6782608695652, 0.38478260869565, -0.15
105558, 1.6782608695652, 0.35869565217391, -0.125
105559, 1.7, 0.35869565217391, -0.15
105560, 1.7217391304348, 0.38478260869565, -0.15
105561, 1.7217391304348, 0.35869565217391, -0.125
105562, 1.7434782608696, 0.35869565217391, -0.15
105563, 1.7652173913043, 0.38478260869565, -0.15
105564, 1.7652173913043, 0.35869565217391, -0.125
105565, 1.7869565217391, 0.35869565217391, -0.15
105566, 1.8086956521739, 0.38478260869565, -0.15
105567, 1.8086956521739, 0.35869565217391, -0.125
105568, 1.8304347826087, 0.35869565217391, -0.15
105569, 1.8521739130435, 0.38478260869565, -0.15
105570, 1.8521739130435, 0.35869565217391, -0.125
105571, 1.8739130434783, 0.35869565217391, -0.15
105572, 1.895652173913, 0.38478260869565, -0.15
105573, 1.895652173913, 0.35869565217391, -0.125
105574, 1.9173913043478, 0.35869565217391, -0.15
105575, 1.9391304347826, 0.38478260869565, -0.15
105576, 1.9391304347826, 0.35869565217391, -0.125
105577, 1.9608695652174, 0.35869565217391, -0.15
105578, 1.9826086956522, 0.38478260869565, -0.15
105579, 1.9826086956522, 0.35869565217391, -0.125
105580, 2.004347826087, 0.35869565217391, -0.15
105581, 2.0260869565217, 0.38478260869565, -0.15
105582, 2.0260869565217, 0.35869565217391, -0.125
105583, 2.0478260869565, 0.35869565217391, -0.15
105584, 2.0695652173913, 0.38478260869565, -0.15
105585, 2.0695652173913, 0.35869565217391, -0.125
105586, 2.0913043478261, 0.35869565217391, -0.15
105587, 2.1130434782609, 0.38478260869565, -0.15
105588, 2.1130434782609, 0.35869565217391, -0.125
105589, 2.1347826086957, 0.35869565217391, -0.15
105590, 2.1565217391304, 0.38478260869565, -0.15
105591, 2.1565217391304, 0.35869565217391, -0.125
105592, 2.1782608695652, 0.35869565217391, -0.15
105593, 1.2217391304348, 0.30652173913044, -0.15
105594, 1.2434782608696, 0.33260869565217, -0.15
105595, 1.2434782608696, 0.30652173913044, -0.125
105596, 1.2652173913043, 0.30652173913044, -0.15
105597, 1.2869565217391, 0.33260869565217, -0.15
105598, 1.2869565217391, 0.30652173913043, -0.125
105599, 1.3086956521739, 0.30652173913043, -0.15
105600, 1.3304347826087, 0.33260869565217, -0.15
105601, 1.3304347826087, 0.30652173913043, -0.125
105602, 1.3521739130435, 0.30652173913044, -0.15
105603, 1.3739130434783, 0.33260869565217, -0.15
105604, 1.3739130434783, 0.30652173913044, -0.125
105605, 1.395652173913, 0.30652173913044, -0.15
105606, 1.4173913043478, 0.33260869565217, -0.15
105607, 1.4173913043478, 0.30652173913044, -0.125
105608, 1.4391304347826, 0.30652173913044, -0.15
105609, 1.4608695652174, 0.33260869565217, -0.15
105610, 1.4608695652174, 0.30652173913043, -0.125
105611, 1.4826086956522, 0.30652173913044, -0.15
105612, 1.504347826087, 0.33260869565217, -0.15
105613, 1.504347826087, 0.30652173913044, -0.125
105614, 1.5260869565217, 0.30652173913044, -0.15
105615, 1.5478260869565, 0.33260869565217, -0.15
105616, 1.5478260869565, 0.30652173913044, -0.125
105617, 1.5695652173913, 0.30652173913044, -0.15
105618, 1.5913043478261, 0.33260869565217, -0.15
105619, 1.5913043478261, 0.30652173913044, -0.125
105620, 1.6130434782609, 0.30652173913044, -0.15
105621, 1.6347826086957, 0.33260869565217, -0.15
105622, 1.6347826086957, 0.30652173913043, -0.125
105623, 1.6565217391304, 0.30652173913043, -0.15
105624, 1.6782608695652, 0.33260869565217, -0.15
105625, 1.6782608695652, 0.30652173913043, -0.125
105626, 1.7, 0.30652173913043, -0.15
105627, 1.7217391304348, 0.33260869565217, -0.15
105628, 1.7217391304348, 0.30652173913043, -0.125
105629, 1.7434782608696, 0.30652173913043, -0.15
105630, 1.7652173913043, 0.33260869565217, -0.15
105631, 1.7652173913043, 0.30652173913043, -0.125
105632, 1.7869565217391, 0.30652173913044, -0.15
105633, 1.8086956521739, 0.33260869565217, -0.15
105634, 1.8086956521739, 0.30652173913044, -0.125
105635, 1.8304347826087, 0.30652173913044, -0.15
105636, 1.8521739130435, 0.33260869565217, -0.15
105637, 1.8521739130435, 0.30652173913043, -0.125
105638, 1.8739130434783, 0.30652173913043, -0.15
105639, 1.895652173913, 0.33260869565217, -0.15
105640, 1.895652173913, 0.30652173913044, -0.125
105641, 1.9173913043478, 0.30652173913044, -0.15
105642, 1.9391304347826, 0.33260869565217, -0.15
105643, 1.9391304347826, 0.30652173913043, -0.125
105644, 1.9608695652174, 0.30652173913044, -0.15
105645, 1.9826086956522, 0.33260869565217, -0.15
105646, 1.9826086956522, 0.30652173913044, -0.125
105647, 2.004347826087, 0.30652173913044, -0.15
105648, 2.0260869565217, 0.33260869565217, -0.15
105649, 2.0260869565217, 0.30652173913044, -0.125
105650, 2.0478260869565, 0.30652173913044, -0.15
105651, 2.0695652173913, 0.33260869565217, -0.15
105652, 2.0695652173913, 0.30652173913043, -0.125
105653, 2.0913043478261, 0.30652173913043, -0.15
105654, 2.1130434782609, 0.33260869565217, -0.15
105655, 2.1130434782609, 0.30652173913043, -0.125
105656, 2.1347826086957, 0.30652173913043, -0.15
105657, 2.1565217391304, 0.33260869565217, -0.15
105658, 2.1565217391304, 0.30652173913043, -0.125
105659, 2.1782608695652, 0.30652173913044, -0.15
105660, 1.2217391304348, 0.25434782608696, -0.15
105661, 1.2434782608696, 0.2804347826087, -0.15
105662, 1.2434782608696, 0.25434782608696, -0.125
105663, 1.2652173913043, 0.25434782608696, -0.15
105664, 1.2869565217391, 0.2804347826087, -0.15
105665, 1.2869565217391, 0.25434782608696, -0.125
105666, 1.3086956521739, 0.25434782608696, -0.15
105667, 1.3304347826087, 0.2804347826087, -0.15
105668, 1.3304347826087, 0.25434782608696, -0.125
105669, 1.3521739130435, 0.25434782608696, -0.15
105670, 1.3739130434783, 0.2804347826087, -0.15
105671, 1.3739130434783, 0.25434782608696, -0.125
105672, 1.395652173913, 0.25434782608696, -0.15
105673, 1.4173913043478, 0.2804347826087, -0.15
105674, 1.4173913043478, 0.25434782608696, -0.125
105675, 1.4391304347826, 0.25434782608696, -0.15
105676, 1.4608695652174, 0.2804347826087, -0.15
105677, 1.4608695652174, 0.25434782608696, -0.125
105678, 1.4826086956522, 0.25434782608696, -0.15
105679, 1.504347826087, 0.2804347826087, -0.15
105680, 1.504347826087, 0.25434782608696, -0.125
105681, 1.5260869565217, 0.25434782608696, -0.15
105682, 1.5478260869565, 0.2804347826087, -0.15
105683, 1.5478260869565, 0.25434782608696, -0.125
105684, 1.5695652173913, 0.25434782608696, -0.15
105685, 1.5913043478261, 0.2804347826087, -0.15
105686, 1.5913043478261, 0.25434782608696, -0.125
105687, 1.6130434782609, 0.25434782608696, -0.15
105688, 1.6347826086957, 0.2804347826087, -0.15
105689, 1.6347826086957, 0.25434782608696, -0.125
105690, 1.6565217391304, 0.25434782608696, -0.15
105691, 1.6782608695652, 0.2804347826087, -0.15
105692, 1.6782608695652, 0.25434782608696, -0.125
105693, 1.7, 0.25434782608696, -0.15
105694, 1.7217391304348, 0.2804347826087, -0.15
105695, 1.7217391304348, 0.25434782608696, -0.125
105696, 1.7434782608696, 0.25434782608696, -0.15
105697, 1.7652173913043, 0.2804347826087, -0.15
105698, 1.7652173913043, 0.25434782608696, -0.125
105699, 1.7869565217391, 0.25434782608696, -0.15
105700, 1.8086956521739, 0.2804347826087, -0.15
105701, 1.8086956521739, 0.25434782608696, -0.125
105702, 1.8304347826087, 0.25434782608696, -0.15
105703, 1.8521739130435, 0.2804347826087, -0.15
105704, 1.8521739130435, 0.25434782608696, -0.125
105705, 1.8739130434783, 0.25434782608696, -0.15
105706, 1.895652173913, 0.2804347826087, -0.15
105707, 1.895652173913, 0.25434782608696, -0.125
105708, 1.9173913043478, 0.25434782608696, -0.15
105709, 1.9391304347826, 0.2804347826087, -0.15
105710, 1.9391304347826, 0.25434782608696, -0.125
105711, 1.9608695652174, 0.25434782608696, -0.15
105712, 1.9826086956522, 0.2804347826087, -0.15
105713, 1.9826086956522, 0.25434782608696, -0.125
105714, 2.004347826087, 0.25434782608696, -0.15
105715, 2.0260869565217, 0.2804347826087, -0.15
105716, 2.0260869565217, 0.25434782608696, -0.125
105717, 2.0478260869565, 0.25434782608696, -0.15
105718, 2.0695652173913, 0.2804347826087, -0.15
105719, 2.0695652173913, 0.25434782608696, -0.125
105720, 2.0913043478261, 0.25434782608696, -0.15
105721, 2.1130434782609, 0.2804347826087, -0.15
105722, 2.1130434782609, 0.25434782608696, -0.125
105723, 2.1347826086957, 0.25434782608696, -0.15
105724, 2.1565217391304, 0.2804347826087, -0.15
105725, 2.1565217391304, 0.25434782608696, -0.125
105726, 2.1782608695652, 0.25434782608696, -0.15
105727, 1.2217391304348, 0.20217391304348, -0.15
105728, 1.2434782608696, 0.22826086956522, -0.15
105729, 1.2434782608696, 0.20217391304348, -0.125
105730, 1.2652173913043, 0.20217391304348, -0.15
105731, 1.2869565217391, 0.22826086956522, -0.15
105732, 1.2869565217391, 0.20217391304348, -0.125
105733, 1.3086956521739, 0.20217391304348, -0.15
105734, 1.3304347826087, 0.22826086956522, -0.15
105735, 1.3304347826087, 0.20217391304348, -0.125
105736, 1.3521739130435, 0.20217391304348, -0.15
105737, 1.3739130434783, 0.22826086956522, -0.15
105738, 1.3739130434783, 0.20217391304348, -0.125
105739, 1.395652173913, 0.20217391304348, -0.15
105740, 1.4173913043478, 0.22826086956522, -0.15
105741, 1.4173913043478, 0.20217391304348, -0.125
105742, 1.4391304347826, 0.20217391304348, -0.15
105743, 1.4608695652174, 0.22826086956522, -0.15
105744, 1.4608695652174, 0.20217391304348, -0.125
105745, 1.4826086956522, 0.20217391304348, -0.15
105746, 1.504347826087, 0.22826086956522, -0.15
105747, 1.504347826087, 0.20217391304348, -0.125
105748, 1.5260869565217, 0.20217391304348, -0.15
105749, 1.5478260869565, 0.22826086956522, -0.15
105750, 1.5478260869565, 0.20217391304348, -0.125
105751, 1.5695652173913, 0.20217391304348, -0.15
105752, 1.5913043478261, 0.22826086956522, -0.15
105753, 1.5913043478261, 0.20217391304348, -0.125
105754, 1.6130434782609, 0.20217391304348, -0.15
105755, 1.6347826086957, 0.22826086956522, -0.15
105756, 1.6347826086957, 0.20217391304348, -0.125
105757, 1.6565217391304, 0.20217391304348, -0.15
105758, 1.6782608695652, 0.22826086956522, -0.15
105759, 1.6782608695652, 0.20217391304348, -0.125
105760, 1.7, 0.20217391304348, -0.15
105761, 1.7217391304348, 0.22826086956522, -0.15
105762, 1.7217391304348, 0.20217391304348, -0.125
105763, 1.7434782608696, 0.20217391304348, -0.15
105764, 1.7652173913043, 0.22826086956522, -0.15
105765, 1.7652173913043, 0.20217391304348, -0.125
105766, 1.7869565217391, 0.20217391304348, -0.15
105767, 1.8086956521739, 0.22826086956522, -0.15
105768, 1.8086956521739, 0.20217391304348, -0.125
105769, 1.8304347826087, 0.20217391304348, -0.15
105770, 1.8521739130435, 0.22826086956522, -0.15
105771, 1.8521739130435, 0.20217391304348, -0.125
105772, 1.8739130434783, 0.20217391304348, -0.15
105773, 1.895652173913, 0.22826086956522, -0.15
105774, 1.895652173913, 0.20217391304348, -0.125
105775, 1.9173913043478, 0.20217391304348, -0.15
105776, 1.9391304347826, 0.22826086956522, -0.15
105777, 1.9391304347826, 0.20217391304348, -0.125
105778, 1.9608695652174, 0.20217391304348, -0.15
105779, 1.9826086956522, 0.22826086956522, -0.15
105780, 1.9826086956522, 0.20217391304348, -0.125
105781, 2.004347826087, 0.20217391304348, -0.15
105782, 2.0260869565217, 0.22826086956522, -0.15
105783, 2.0260869565217, 0.20217391304348, -0.125
105784, 2.0478260869565, 0.20217391304348, -0.15
105785, 2.0695652173913, 0.22826086956522, -0.15
105786, 2.0695652173913, 0.20217391304348, -0.125
105787, 2.0913043478261, 0.20217391304348, -0.15
105788, 2.1130434782609, 0.22826086956522, -0.15
105789, 2.1130434782609, 0.20217391304348, -0.125
105790, 2.1347826086957, 0.20217391304348, -0.15
105791, 2.1565217391304, 0.22826086956522, -0.15
105792, 2.1565217391304, 0.20217391304348, -0.125
105793, 2.1782608695652, 0.20217391304348, -0.15
105794, 1.2434782608696, 0.17608695652174, -0.15
105795, 1.2869565217391, 0.17608695652174, -0.15
105796, 1.3304347826087, 0.17608695652174, -0.15
105797, 1.3739130434783, 0.17608695652174, -0.15
105798, 1.4173913043478, 0.17608695652174, -0.15
105799, 1.4608695652174, 0.17608695652174, -0.15
105800, 1.504347826087, 0.17608695652174, -0.15
105801, 1.5478260869565, 0.17608695652174, -0.15
105802, 1.5913043478261, 0.17608695652174, -0.15
105803, 1.6347826086957, 0.17608695652174, -0.15
105804, 1.6782608695652, 0.17608695652174, -0.15
105805, 1.7217391304348, 0.17608695652174, -0.15
105806, 1.7652173913043, 0.17608695652174, -0.15
105807, 1.8086956521739, 0.17608695652174, -0.15
105808, 1.8521739130435, 0.17608695652174, -0.15
105809, 1.895652173913, 0.17608695652174, -0.15
105810, 1.9391304347826, 0.17608695652174, -0.15
105811, 1.9826086956522, 0.17608695652174, -0.15
105812, 2.0260869565217, 0.17608695652174, -0.15
105813, 2.0695652173913, 0.17608695652174, -0.15
105814, 2.1130434782609, 0.17608695652174, -0.15
105815, 2.1565217391304, 0.17608695652174, -0.15
105816, 1.2434782608696, 1.2978260869565, -0.175
105817, 1.2869565217391, 1.2978260869565, -0.175
105818, 1.3304347826087, 1.2978260869565, -0.175
105819, 1.3739130434783, 1.2978260869565, -0.175
105820, 1.4173913043478, 1.2978260869565, -0.175
105821, 1.4608695652174, 1.2978260869565, -0.175
105822, 1.504347826087, 1.2978260869565, -0.175
105823, 1.5478260869565, 1.2978260869565, -0.175
105824, 1.5913043478261, 1.2978260869565, -0.175
105825, 1.6347826086957, 1.2978260869565, -0.175
105826, 1.6782608695652, 1.2978260869565, -0.175
105827, 1.7217391304348, 1.2978260869565, -0.175
105828, 1.7652173913043, 1.2978260869565, -0.175
105829, 1.8086956521739, 1.2978260869565, -0.175
105830, 1.8521739130435, 1.2978260869565, -0.175
105831, 1.895652173913, 1.2978260869565, -0.175
105832, 1.9391304347826, 1.2978260869565, -0.175
105833, 1.9826086956522, 1.2978260869565, -0.175
105834, 2.0260869565217, 1.2978260869565, -0.175
105835, 2.0695652173913, 1.2978260869565, -0.175
105836, 2.1130434782609, 1.2978260869565, -0.175
105837, 2.1565217391304, 1.2978260869565, -0.175
105838, 1.2434782608696, 1.245652173913, -0.175
105839, 1.2869565217391, 1.245652173913, -0.175
105840, 1.3304347826087, 1.245652173913, -0.175
105841, 1.3739130434783, 1.245652173913, -0.175
105842, 1.4173913043478, 1.245652173913, -0.175
105843, 1.4608695652174, 1.245652173913, -0.175
105844, 1.504347826087, 1.245652173913, -0.175
105845, 1.5478260869565, 1.245652173913, -0.175
105846, 1.5913043478261, 1.245652173913, -0.175
105847, 1.6347826086957, 1.245652173913, -0.175
105848, 1.6782608695652, 1.245652173913, -0.175
105849, 1.7217391304348, 1.245652173913, -0.175
105850, 1.7652173913043, 1.245652173913, -0.175
105851, 1.8086956521739, 1.245652173913, -0.175
105852, 1.8521739130435, 1.245652173913, -0.175
105853, 1.895652173913, 1.245652173913, -0.175
105854, 1.9391304347826, 1.245652173913, -0.175
105855, 1.9826086956522, 1.245652173913, -0.175
105856, 2.0260869565217, 1.245652173913, -0.175
105857, 2.0695652173913, 1.245652173913, -0.175
105858, 2.1130434782609, 1.245652173913, -0.175
105859, 2.1565217391304, 1.245652173913, -0.175
105860, 1.2434782608696, 1.1934782608696, -0.175
105861, 1.2869565217391, 1.1934782608696, -0.175
105862, 1.3304347826087, 1.1934782608696, -0.175
105863, 1.3739130434783, 1.1934782608696, -0.175
105864, 1.4173913043478, 1.1934782608696, -0.175
105865, 1.4608695652174, 1.1934782608696, -0.175
105866, 1.504347826087, 1.1934782608696, -0.175
105867, 1.5478260869565, 1.1934782608696, -0.175
105868, 1.5913043478261, 1.1934782608696, -0.175
105869, 1.6347826086957, 1.1934782608696, -0.175
105870, 1.6782608695652, 1.1934782608696, -0.175
105871, 1.7217391304348, 1.1934782608696, -0.175
105872, 1.7652173913043, 1.1934782608696, -0.175
105873, 1.8086956521739, 1.1934782608696, -0.175
105874, 1.8521739130435, 1.1934782608696, -0.175
105875, 1.895652173913, 1.1934782608696, -0.175
105876, 1.9391304347826, 1.1934782608696, -0.175
105877, 1.9826086956522, 1.1934782608696, -0.175
105878, 2.0260869565217, 1.1934782608696, -0.175
105879, 2.0695652173913, 1.1934782608696, -0.175
105880, 2.1130434782609, 1.1934782608696, -0.175
105881, 2.1565217391304, 1.1934782608696, -0.175
105882, 1.2434782608696, 1.1413043478261, -0.175
105883, 1.2869565217391, 1.1413043478261, -0.175
105884, 1.3304347826087, 1.1413043478261, -0.175
105885, 1.3739130434783, 1.1413043478261, -0.175
105886, 1.4173913043478, 1.1413043478261, -0.175
105887, 1.4608695652174, 1.1413043478261, -0.175
105888, 1.504347826087, 1.1413043478261, -0.175
105889, 1.5478260869565, 1.1413043478261, -0.175
105890, 1.5913043478261, 1.1413043478261, -0.175
105891, 1.6347826086957, 1.1413043478261, -0.175
105892, 1.6782608695652, 1.1413043478261, -0.175
105893, 1.7217391304348, 1.1413043478261, -0.175
105894, 1.7652173913043, 1.1413043478261, -0.175
105895, 1.8086956521739, 1.1413043478261, -0.175
105896, 1.8521739130435, 1.1413043478261, -0.175
105897, 1.895652173913, 1.1413043478261, -0.175
105898, 1.9391304347826, 1.1413043478261, -0.175
105899, 1.9826086956522, 1.1413043478261, -0.175
105900, 2.0260869565217, 1.1413043478261, -0.175
105901, 2.0695652173913, 1.1413043478261, -0.175
105902, 2.1130434782609, 1.1413043478261, -0.175
105903, 2.1565217391304, 1.1413043478261, -0.175
105904, 1.2434782608696, 1.0891304347826, -0.175
105905, 1.2869565217391, 1.0891304347826, -0.175
105906, 1.3304347826087, 1.0891304347826, -0.175
105907, 1.3739130434783, 1.0891304347826, -0.175
105908, 1.4173913043478, 1.0891304347826, -0.175
105909, 1.4608695652174, 1.0891304347826, -0.175
105910, 1.504347826087, 1.0891304347826, -0.175
105911, 1.5478260869565, 1.0891304347826, -0.175
105912, 1.5913043478261, 1.0891304347826, -0.175
105913, 1.6347826086957, 1.0891304347826, -0.175
105914, 1.6782608695652, 1.0891304347826, -0.175
105915, 1.7217391304348, 1.0891304347826, -0.175
105916, 1.7652173913043, 1.0891304347826, -0.175
105917, 1.8086956521739, 1.0891304347826, -0.175
105918, 1.8521739130435, 1.0891304347826, -0.175
105919, 1.895652173913, 1.0891304347826, -0.175
105920, 1.9391304347826, 1.0891304347826, -0.175
105921, 1.9826086956522, 1.0891304347826, -0.175
105922, 2.0260869565217, 1.0891304347826, -0.175
105923, 2.0695652173913, 1.0891304347826, -0.175
105924, 2.1130434782609, 1.0891304347826, -0.175
105925, 2.1565217391304, 1.0891304347826, -0.175
105926, 1.2434782608696, 1.0369565217391, -0.175
105927, 1.2869565217391, 1.0369565217391, -0.175
105928, 1.3304347826087, 1.0369565217391, -0.175
105929, 1.3739130434783, 1.0369565217391, -0.175
105930, 1.4173913043478, 1.0369565217391, -0.175
105931, 1.4608695652174, 1.0369565217391, -0.175
105932, 1.504347826087, 1.0369565217391, -0.175
105933, 1.5478260869565, 1.0369565217391, -0.175
105934, 1.5913043478261, 1.0369565217391, -0.175
105935, 1.6347826086957, 1.0369565217391, -0.175
105936, 1.6782608695652, 1.0369565217391, -0.175
105937, 1.7217391304348, 1.0369565217391, -0.175
105938, 1.7652173913043, 1.0369565217391, -0.175
105939, 1.8086956521739, 1.0369565217391, -0.175
105940, 1.8521739130435, 1.0369565217391, -0.175
105941, 1.895652173913, 1.0369565217391, -0.175
105942, 1.9391304347826, 1.0369565217391, -0.175
105943, 1.9826086956522, 1.0369565217391, -0.175
105944, 2.0260869565217, 1.0369565217391, -0.175
105945, 2.0695652173913, 1.0369565217391, -0.175
105946, 2.1130434782609, 1.0369565217391, -0.175
105947, 2.1565217391304, 1.0369565217391, -0.175
105948, 1.2434782608696, 0.98478260869565, -0.175
105949, 1.2869565217391, 0.98478260869565, -0.175
105950, 1.3304347826087, 0.98478260869565, -0.175
105951, 1.3739130434783, 0.98478260869565, -0.175
105952, 1.4173913043478, 0.98478260869565, -0.175
105953, 1.4608695652174, 0.98478260869565, -0.175
105954, 1.504347826087, 0.98478260869565, -0.175
105955, 1.5478260869565, 0.98478260869565, -0.175
105956, 1.5913043478261, 0.98478260869565, -0.175
105957, 1.6347826086957, 0.98478260869565, -0.175
105958, 1.6782608695652, 0.98478260869565, -0.175
105959, 1.7217391304348, 0.98478260869565, -0.175
105960, 1.7652173913043, 0.98478260869565, -0.175
105961, 1.8086956521739, 0.98478260869565, -0.175
105962, 1.8521739130435, 0.98478260869565, -0.175
105963, 1.895652173913, 0.98478260869565, -0.175
105964, 1.9391304347826, 0.98478260869565, -0.175
105965, 1.9826086956522, 0.98478260869565, -0.175
105966, 2.0260869565217, 0.98478260869565, -0.175
105967, 2.0695652173913, 0.98478260869565, -0.175
105968, 2.1130434782609, 0.98478260869565, -0.175
105969, 2.1565217391304, 0.98478260869565, -0.175
105970, 1.2434782608696, 0.93260869565217, -0.175
105971, 1.2869565217391, 0.93260869565217, -0.175
105972, 1.3304347826087, 0.93260869565217, -0.175
105973, 1.3739130434783, 0.93260869565217, -0.175
105974, 1.4173913043478, 0.93260869565217, -0.175
105975, 1.4608695652174, 0.93260869565217, -0.175
105976, 1.504347826087, 0.93260869565217, -0.175
105977, 1.5478260869565, 0.93260869565217, -0.175
105978, 1.5913043478261, 0.93260869565217, -0.175
105979, 1.6347826086957, 0.93260869565217, -0.175
105980, 1.6782608695652, 0.93260869565217, -0.175
105981, 1.7217391304348, 0.93260869565217, -0.175
105982, 1.7652173913043, 0.93260869565217, -0.175
105983, 1.8086956521739, 0.93260869565217, -0.175
105984, 1.8521739130435, 0.93260869565217, -0.175
105985, 1.895652173913, 0.93260869565217, -0.175
105986, 1.9391304347826, 0.93260869565218, -0.175
105987, 1.9826086956522, 0.93260869565217, -0.175
105988, 2.0260869565217, 0.93260869565217, -0.175
105989, 2.0695652173913, 0.93260869565217, -0.175
105990, 2.1130434782609, 0.93260869565217, -0.175
105991, 2.1565217391304, 0.93260869565217, -0.175
105992, 1.2434782608696, 0.8804347826087, -0.175
105993, 1.2869565217391, 0.8804347826087, -0.175
105994, 1.3304347826087, 0.8804347826087, -0.175
105995, 1.3739130434783, 0.8804347826087, -0.175
105996, 1.4173913043478, 0.8804347826087, -0.175
105997, 1.4608695652174, 0.8804347826087, -0.175
105998, 1.504347826087, 0.8804347826087, -0.175
105999, 1.5478260869565, 0.8804347826087, -0.175
106000, 1.5913043478261, 0.8804347826087, -0.175
106001, 1.6347826086957, 0.8804347826087, -0.175
106002, 1.6782608695652, 0.8804347826087, -0.175
106003, 1.7217391304348, 0.8804347826087, -0.175
106004, 1.7652173913043, 0.8804347826087, -0.175
106005, 1.8086956521739, 0.8804347826087, -0.175
106006, 1.8521739130435, 0.8804347826087, -0.175
106007, 1.895652173913, 0.8804347826087, -0.175
106008, 1.9391304347826, 0.8804347826087, -0.175
106009, 1.9826086956522, 0.8804347826087, -0.175
106010, 2.0260869565217, 0.8804347826087, -0.175
106011, 2.0695652173913, 0.8804347826087, -0.175
106012, 2.1130434782609, 0.8804347826087, -0.175
106013, 2.1565217391304, 0.8804347826087, -0.175
106014, 1.2434782608696, 0.82826086956522, -0.175
106015, 1.2869565217391, 0.82826086956522, -0.175
106016, 1.3304347826087, 0.82826086956522, -0.175
106017, 1.3739130434783, 0.82826086956522, -0.175
106018, 1.4173913043478, 0.82826086956522, -0.175
106019, 1.4608695652174, 0.82826086956522, -0.175
106020, 1.504347826087, 0.82826086956522, -0.175
106021, 1.5478260869565, 0.82826086956522, -0.175
106022, 1.5913043478261, 0.82826086956522, -0.175
106023, 1.6347826086957, 0.82826086956522, -0.175
106024, 1.6782608695652, 0.82826086956522, -0.175
106025, 1.7217391304348, 0.82826086956522, -0.175
106026, 1.7652173913043, 0.82826086956522, -0.175
106027, 1.8086956521739, 0.82826086956522, -0.175
106028, 1.8521739130435, 0.82826086956522, -0.175
106029, 1.895652173913, 0.82826086956522, -0.175
106030, 1.9391304347826, 0.82826086956522, -0.175
106031, 1.9826086956522, 0.82826086956522, -0.175
106032, 2.0260869565217, 0.82826086956522, -0.175
106033, 2.0695652173913, 0.82826086956522, -0.175
106034, 2.1130434782609, 0.82826086956522, -0.175
106035, 2.1565217391304, 0.82826086956522, -0.175
106036, 1.2434782608696, 0.77608695652174, -0.175
106037, 1.2869565217391, 0.77608695652174, -0.175
106038, 1.3304347826087, 0.77608695652174, -0.175
106039, 1.3739130434783, 0.77608695652174, -0.175
106040, 1.4173913043478, 0.77608695652174, -0.175
106041, 1.4608695652174, 0.77608695652174, -0.175
106042, 1.504347826087, 0.77608695652174, -0.175
106043, 1.5478260869565, 0.77608695652174, -0.175
106044, 1.5913043478261, 0.77608695652174, -0.175
106045, 1.6347826086957, 0.77608695652174, -0.175
106046, 1.6782608695652, 0.77608695652174, -0.175
106047, 1.7217391304348, 0.77608695652174, -0.175
106048, 1.7652173913043, 0.77608695652174, -0.175
106049, 1.8086956521739, 0.77608695652174, -0.175
106050, 1.8521739130435, 0.77608695652174, -0.175
106051, 1.895652173913, 0.77608695652174, -0.175
106052, 1.9391304347826, 0.77608695652174, -0.175
106053, 1.9826086956522, 0.77608695652174, -0.175
106054, 2.0260869565217, 0.77608695652174, -0.175
106055, 2.0695652173913, 0.77608695652174, -0.175
106056, 2.1130434782609, 0.77608695652174, -0.175
106057, 2.1565217391304, 0.77608695652174, -0.175
106058, 1.2434782608696, 0.72391304347826, -0.175
106059, 1.2869565217391, 0.72391304347826, -0.175
106060, 1.3304347826087, 0.72391304347826, -0.175
106061, 1.3739130434783, 0.72391304347826, -0.175
106062, 1.4173913043478, 0.72391304347826, -0.175
106063, 1.4608695652174, 0.72391304347826, -0.175
106064, 1.504347826087, 0.72391304347826, -0.175
106065, 1.5478260869565, 0.72391304347826, -0.175
106066, 1.5913043478261, 0.72391304347826, -0.175
106067, 1.6347826086957, 0.72391304347826, -0.175
106068, 1.6782608695652, 0.72391304347826, -0.175
106069, 1.7217391304348, 0.72391304347826, -0.175
106070, 1.7652173913043, 0.72391304347826, -0.175
106071, 1.8086956521739, 0.72391304347826, -0.175
106072, 1.8521739130435, 0.72391304347826, -0.175
106073, 1.895652173913, 0.72391304347826, -0.175
106074, 1.9391304347826, 0.72391304347826, -0.175
106075, 1.9826086956522, 0.72391304347826, -0.175
106076, 2.0260869565217, 0.72391304347826, -0.175
106077, 2.0695652173913, 0.72391304347826, -0.175
106078, 2.1130434782609, 0.72391304347826, -0.175
106079, 2.1565217391304, 0.72391304347826, -0.175
106080, 1.2434782608696, 0.67173913043478, -0.175
106081, 1.2869565217391, 0.67173913043478, -0.175
106082, 1.3304347826087, 0.67173913043478, -0.175
106083, 1.3739130434783, 0.67173913043478, -0.175
106084, 1.4173913043478, 0.67173913043478, -0.175
106085, 1.4608695652174, 0.67173913043478, -0.175
106086, 1.504347826087, 0.67173913043478, -0.175
106087, 1.5478260869565, 0.67173913043478, -0.175
106088, 1.5913043478261, 0.67173913043478, -0.175
106089, 1.6347826086957, 0.67173913043478, -0.175
106090, 1.6782608695652, 0.67173913043478, -0.175
106091, 1.7217391304348, 0.67173913043478, -0.175
106092, 1.7652173913043, 0.67173913043478, -0.175
106093, 1.8086956521739, 0.67173913043478, -0.175
106094, 1.8521739130435, 0.67173913043478, -0.175
106095, 1.895652173913, 0.67173913043478, -0.175
106096, 1.9391304347826, 0.67173913043478, -0.175
106097, 1.9826086956522, 0.67173913043478, -0.175
106098, 2.0260869565217, 0.67173913043478, -0.175
106099, 2.0695652173913, 0.67173913043478, -0.175
106100, 2.1130434782609, 0.67173913043478, -0.175
106101, 2.1565217391304, 0.67173913043478, -0.175
106102, 1.2434782608696, 0.6195652173913, -0.175
106103, 1.2869565217391, 0.61956521739131, -0.175
106104, 1.3304347826087, 0.61956521739131, -0.175
106105, 1.3739130434783, 0.61956521739131, -0.175
106106, 1.4173913043478, 0.61956521739131, -0.175
106107, 1.4608695652174, 0.61956521739131, -0.175
106108, 1.504347826087, 0.61956521739131, -0.175
106109, 1.5478260869565, 0.61956521739131, -0.175
106110, 1.5913043478261, 0.61956521739131, -0.175
106111, 1.6347826086957, 0.61956521739131, -0.175
106112, 1.6782608695652, 0.61956521739131, -0.175
106113, 1.7217391304348, 0.61956521739131, -0.175
106114, 1.7652173913043, 0.61956521739131, -0.175
106115, 1.8086956521739, 0.61956521739131, -0.175
106116, 1.8521739130435, 0.61956521739131, -0.175
106117, 1.895652173913, 0.61956521739131, -0.175
106118, 1.9391304347826, 0.61956521739131, -0.175
106119, 1.9826086956522, 0.61956521739131, -0.175
106120, 2.0260869565217, 0.61956521739131, -0.175
106121, 2.0695652173913, 0.61956521739131, -0.175
106122, 2.1130434782609, 0.61956521739131, -0.175
106123, 2.1565217391304, 0.61956521739131, -0.175
106124, 1.2434782608696, 0.56739130434783, -0.175
106125, 1.2869565217391, 0.56739130434783, -0.175
106126, 1.3304347826087, 0.56739130434783, -0.175
106127, 1.3739130434783, 0.56739130434783, -0.175
106128, 1.4173913043478, 0.56739130434783, -0.175
106129, 1.4608695652174, 0.56739130434783, -0.175
106130, 1.504347826087, 0.56739130434783, -0.175
106131, 1.5478260869565, 0.56739130434783, -0.175
106132, 1.5913043478261, 0.56739130434783, -0.175
106133, 1.6347826086957, 0.56739130434783, -0.175
106134, 1.6782608695652, 0.56739130434783, -0.175
106135, 1.7217391304348, 0.56739130434783, -0.175
106136, 1.7652173913043, 0.56739130434783, -0.175
106137, 1.8086956521739, 0.56739130434783, -0.175
106138, 1.8521739130435, 0.56739130434783, -0.175
106139, 1.895652173913, 0.56739130434783, -0.175
106140, 1.9391304347826, 0.56739130434783, -0.175
106141, 1.9826086956522, 0.56739130434783, -0.175
106142, 2.0260869565217, 0.56739130434783, -0.175
106143, 2.0695652173913, 0.56739130434783, -0.175
106144, 2.1130434782609, 0.56739130434783, -0.175
106145, 2.1565217391304, 0.56739130434783, -0.175
106146, 1.2434782608696, 0.51521739130435, -0.175
106147, 1.2869565217391, 0.51521739130435, -0.175
106148, 1.3304347826087, 0.51521739130435, -0.175
106149, 1.3739130434783, 0.51521739130435, -0.175
106150, 1.4173913043478, 0.51521739130435, -0.175
106151, 1.4608695652174, 0.51521739130435, -0.175
106152, 1.504347826087, 0.51521739130435, -0.175
106153, 1.5478260869565, 0.51521739130435, -0.175
106154, 1.5913043478261, 0.51521739130435, -0.175
106155, 1.6347826086957, 0.51521739130435, -0.175
106156, 1.6782608695652, 0.51521739130435, -0.175
106157, 1.7217391304348, 0.51521739130435, -0.175
106158, 1.7652173913043, 0.51521739130435, -0.175
106159, 1.8086956521739, 0.51521739130435, -0.175
106160, 1.8521739130435, 0.51521739130435, -0.175
106161, 1.895652173913, 0.51521739130435, -0.175
106162, 1.9391304347826, 0.51521739130435, -0.175
106163, 1.9826086956522, 0.51521739130435, -0.175
106164, 2.0260869565217, 0.51521739130435, -0.175
106165, 2.0695652173913, 0.51521739130435, -0.175
106166, 2.1130434782609, 0.51521739130435, -0.175
106167, 2.1565217391304, 0.51521739130435, -0.175
106168, 1.2434782608696, 0.46304347826087, -0.175
106169, 1.2869565217391, 0.46304347826087, -0.175
106170, 1.3304347826087, 0.46304347826087, -0.175
106171, 1.3739130434783, 0.46304347826087, -0.175
106172, 1.4173913043478, 0.46304347826087, -0.175
106173, 1.4608695652174, 0.46304347826087, -0.175
106174, 1.504347826087, 0.46304347826087, -0.175
106175, 1.5478260869565, 0.46304347826087, -0.175
106176, 1.5913043478261, 0.46304347826087, -0.175
106177, 1.6347826086957, 0.46304347826087, -0.175
106178, 1.6782608695652, 0.46304347826087, -0.175
106179, 1.7217391304348, 0.46304347826087, -0.175
106180, 1.7652173913043, 0.46304347826087, -0.175
106181, 1.8086956521739, 0.46304347826087, -0.175
106182, 1.8521739130435, 0.46304347826087, -0.175
106183, 1.895652173913, 0.46304347826087, -0.175
106184, 1.9391304347826, 0.46304347826087, -0.175
106185, 1.9826086956522, 0.46304347826087, -0.175
106186, 2.0260869565217, 0.46304347826087, -0.175
106187, 2.0695652173913, 0.46304347826087, -0.175
106188, 2.1130434782609, 0.46304347826087, -0.175
106189, 2.1565217391304, 0.46304347826087, -0.175
106190, 1.2434782608696, 0.41086956521739, -0.175
106191, 1.2869565217391, 0.41086956521739, -0.175
106192, 1.3304347826087, 0.41086956521739, -0.175
106193, 1.3739130434783, 0.41086956521739, -0.175
106194, 1.4173913043478, 0.41086956521739, -0.175
106195, 1.4608695652174, 0.41086956521739, -0.175
106196, 1.504347826087, 0.41086956521739, -0.175
106197, 1.5478260869565, 0.41086956521739, -0.175
106198, 1.5913043478261, 0.41086956521739, -0.175
106199, 1.6347826086957, 0.41086956521739, -0.175
106200, 1.6782608695652, 0.41086956521739, -0.175
106201, 1.7217391304348, 0.41086956521739, -0.175
106202, 1.7652173913043, 0.41086956521739, -0.175
106203, 1.8086956521739, 0.41086956521739, -0.175
106204, 1.8521739130435, 0.41086956521739, -0.175
106205, 1.895652173913, 0.41086956521739, -0.175
106206, 1.9391304347826, 0.41086956521739, -0.175
106207, 1.9826086956522, 0.41086956521739, -0.175
106208, 2.0260869565217, 0.41086956521739, -0.175
106209, 2.0695652173913, 0.41086956521739, -0.175
106210, 2.1130434782609, 0.41086956521739, -0.175
106211, 2.1565217391304, 0.41086956521739, -0.175
106212, 1.2434782608696, 0.35869565217391, -0.175
106213, 1.2869565217391, 0.35869565217391, -0.175
106214, 1.3304347826087, 0.35869565217391, -0.175
106215, 1.3739130434783, 0.35869565217391, -0.175
106216, 1.4173913043478, 0.35869565217391, -0.175
106217, 1.4608695652174, 0.35869565217391, -0.175
106218, 1.504347826087, 0.35869565217391, -0.175
106219, 1.5478260869565, 0.35869565217391, -0.175
106220, 1.5913043478261, 0.35869565217391, -0.175
106221, 1.6347826086957, 0.35869565217391, -0.175
106222, 1.6782608695652, 0.35869565217391, -0.175
106223, 1.7217391304348, 0.35869565217391, -0.175
106224, 1.7652173913043, 0.35869565217391, -0.175
106225, 1.8086956521739, 0.35869565217391, -0.175
106226, 1.8521739130435, 0.35869565217391, -0.175
106227, 1.895652173913, 0.35869565217391, -0.175
106228, 1.9391304347826, 0.35869565217391, -0.175
106229, 1.9826086956522, 0.35869565217391, -0.175
106230, 2.0260869565217, 0.35869565217391, -0.175
106231, 2.0695652173913, 0.35869565217391, -0.175
106232, 2.1130434782609, 0.35869565217391, -0.175
106233, 2.1565217391304, 0.35869565217391, -0.175
106234, 1.2434782608696, 0.30652173913044, -0.175
106235, 1.2869565217391, 0.30652173913043, -0.175
106236, 1.3304347826087, 0.30652173913043, -0.175
106237, 1.3739130434783, 0.30652173913044, -0.175
106238, 1.4173913043478, 0.30652173913044, -0.175
106239, 1.4608695652174, 0.30652173913043, -0.175
106240, 1.504347826087, 0.30652173913044, -0.175
106241, 1.5478260869565, 0.30652173913044, -0.175
106242, 1.5913043478261, 0.30652173913044, -0.175
106243, 1.6347826086957, 0.30652173913043, -0.175
106244, 1.6782608695652, 0.30652173913043, -0.175
106245, 1.7217391304348, 0.30652173913043, -0.175
106246, 1.7652173913043, 0.30652173913043, -0.175
106247, 1.8086956521739, 0.30652173913044, -0.175
106248, 1.8521739130435, 0.30652173913043, -0.175
106249, 1.895652173913, 0.30652173913044, -0.175
106250, 1.9391304347826, 0.30652173913043, -0.175
106251, 1.9826086956522, 0.30652173913044, -0.175
106252, 2.0260869565217, 0.30652173913044, -0.175
106253, 2.0695652173913, 0.30652173913043, -0.175
106254, 2.1130434782609, 0.30652173913043, -0.175
106255, 2.1565217391304, 0.30652173913043, -0.175
106256, 1.2434782608696, 0.25434782608696, -0.175
106257, 1.2869565217391, 0.25434782608696, -0.175
106258, 1.3304347826087, 0.25434782608696, -0.175
106259, 1.3739130434783, 0.25434782608696, -0.175
106260, 1.4173913043478, 0.25434782608696, -0.175
106261, 1.4608695652174, 0.25434782608696, -0.175
106262, 1.504347826087, 0.25434782608696, -0.175
106263, 1.5478260869565, 0.25434782608696, -0.175
106264, 1.5913043478261, 0.25434782608696, -0.175
106265, 1.6347826086957, 0.25434782608696, -0.175
106266, 1.6782608695652, 0.25434782608696, -0.175
106267, 1.7217391304348, 0.25434782608696, -0.175
106268, 1.7652173913043, 0.25434782608696, -0.175
106269, 1.8086956521739, 0.25434782608696, -0.175
106270, 1.8521739130435, 0.25434782608696, -0.175
106271, 1.895652173913, 0.25434782608696, -0.175
106272, 1.9391304347826, 0.25434782608696, -0.175
106273, 1.9826086956522, 0.25434782608696, -0.175
106274, 2.0260869565217, 0.25434782608696, -0.175
106275, 2.0695652173913, 0.25434782608696, -0.175
106276, 2.1130434782609, 0.25434782608696, -0.175
106277, 2.1565217391304, 0.25434782608696, -0.175
106278, 1.2434782608696, 0.20217391304348, -0.175
106279, 1.2869565217391, 0.20217391304348, -0.175
106280, 1.3304347826087, 0.20217391304348, -0.175
106281, 1.3739130434783, 0.20217391304348, -0.175
106282, 1.4173913043478, 0.20217391304348, -0.175
106283, 1.4608695652174, 0.20217391304348, -0.175
106284, 1.504347826087, 0.20217391304348, -0.175
106285, 1.5478260869565, 0.20217391304348, -0.175
106286, 1.5913043478261, 0.20217391304348, -0.175
106287, 1.6347826086957, 0.20217391304348, -0.175
106288, 1.6782608695652, 0.20217391304348, -0.175
106289, 1.7217391304348, 0.20217391304348, -0.175
106290, 1.7652173913043, 0.20217391304348, -0.175
106291, 1.8086956521739, 0.20217391304348, -0.175
106292, 1.8521739130435, 0.20217391304348, -0.175
106293, 1.895652173913, 0.20217391304348, -0.175
106294, 1.9391304347826, 0.20217391304348, -0.175
106295, 1.9826086956522, 0.20217391304348, -0.175
106296, 2.0260869565217, 0.20217391304348, -0.175
106297, 2.0695652173913, 0.20217391304348, -0.175
106298, 2.1130434782609, 0.20217391304348, -0.175
106299, 2.1565217391304, 0.20217391304348, -0.175
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line15
109, 2, 131, 109
110, 109, 132, 110
111, 110, 133, 111
112, 111, 134, 112
113, 112, 135, 113
114, 113, 136, 114
115, 114, 137, 115
116, 115, 138, 116
117, 116, 139, 117
118, 117, 140, 118
119, 118, 141, 119
120, 119, 142, 120
121, 120, 143, 121
122, 121, 144, 122
123, 122, 145, 123
124, 123, 146, 124
125, 124, 147, 125
126, 125, 148, 126
127, 126, 149, 127
128, 127, 150, 128
129, 128, 151, 129
130, 129, 152, 130
131, 130, 153, 1
*ELEMENT, type=T3D3, ELSET=Line17
132, 1, 162, 154
133, 154, 163, 155
134, 155, 164, 156
135, 156, 165, 157
136, 157, 166, 158
137, 158, 167, 159
138, 159, 168, 160
139, 160, 169, 161
140, 161, 170, 3
*ELEMENT, type=T3D3, ELSET=Line19
141, 4, 193, 171
142, 171, 194, 172
143, 172, 195, 173
144, 173, 196, 174
145, 174, 197, 175
146, 175, 198, 176
147, 176, 199, 177
148, 177, 200, 178
149, 178, 201, 179
150, 179, 202, 180
151, 180, 203, 181
152, 181, 204, 182
153, 182, 205, 183
154, 183, 206, 184
155, 184, 207, 185
156, 185, 208, 186
157, 186, 209, 187
158, 187, 210, 188
159, 188, 211, 189
160, 189, 212, 190
161, 190, 213, 191
162, 191, 214, 192
163, 192, 215, 3
*ELEMENT, type=T3D3, ELSET=Line20
164, 2, 224, 216
165, 216, 225, 217
166, 217, 226, 218
167, 218, 227, 219
168, 219, 228, 220
169, 220, 229, 221
170, 221, 230, 222
171, 222, 231, 223
172, 223, 232, 4
*ELEMENT, type=T3D3, ELSET=Line71
173, 5, 255, 233
174, 233, 256, 234
175, 234, 257, 235
176, 235, 258, 236
177, 236, 259, 237
178, 237, 260, 238
179, 238, 261, 239
180, 239, 262, 240
181, 240, 263, 241
182, 241, 264, 242
183, 242, 265, 243
184, 243, 266, 244
185, 244, 267, 245
186, 245, 268, 246
187, 246, 269, 247
188, 247, 270, 248
189, 248, 271, 249
190, 249, 272, 250
191, 250, 273, 251
192, 251, 274, 252
193, 252, 275, 253
194, 253, 276, 254
195, 254, 277, 6
*ELEMENT, type=T3D3, ELSET=Line74
196, 7, 300, 278
197, 278, 301, 279
198, 279, 302, 280
199, 280, 303, 281
200, 281, 304, 282
201, 282, 305, 283
202, 283, 306, 284
203, 284, 307, 285
204, 285, 308, 286
205, 286, 309, 287
206, 287, 310, 288
207, 288, 311, 289
208, 289, 312, 290
209, 290, 313, 291
210, 291, 314, 292
211, 292, 315, 293
212, 293, 316, 294
213, 294, 317, 295
214, 295, 318, 296
215, 296, 319, 297
216, 297, 320, 298
217, 298, 321, 299
218, 299, 322, 8
*ELEMENT, type=T3D3, ELSET=Line75
219, 7, 331, 323
220, 323, 332, 324
221, 324, 333, 325
222, 325, 334, 326
223, 326, 335, 327
224, 327, 336, 328
225, 328, 337, 329
226, 329, 338, 330
227, 330, 339, 5
*ELEMENT, type=T3D3, ELSET=Line76
228, 8, 348, 340
229, 340, 349, 341
230, 341, 350, 342
231, 342, 351, 343
232, 343, 352, 344
233, 344, 353, 345
234, 345, 354, 346
235, 346, 355, 347
236, 347, 356, 6
*ELEMENT, type=T3D3, ELSET=Line249
237, 9, 358, 357
238, 357, 359, 10
*ELEMENT, type=T3D3, ELSET=Line250
239, 11, 361, 360
240, 360, 362, 12
*ELEMENT, type=T3D3, ELSET=Line251
241, 11, 365, 363
242, 363, 366, 364
243, 364, 367, 9
*ELEMENT, type=T3D3, ELSET=Line252
244, 12, 370, 368
245, 368, 371, 369
246, 369, 372, 10
*ELEMENT, type=T3D3, ELSET=Line253
247, 13, 374, 373
248, 373, 375, 14
*ELEMENT, type=T3D3, ELSET=Line254
249, 13, 384, 376
250, 376, 385, 377
251, 377, 386, 378
252, 378, 387, 379
253, 379, 388, 380
254, 380, 389, 381
255, 381, 390, 382
256, 382, 391, 383
257, 383, 392, 11
*ELEMENT, type=T3D3, ELSET=Line255
258, 14, 401, 393
259, 393, 402, 394
260, 394, 403, 395
261, 395, 404, 396
262, 396, 405, 397
263, 397, 406, 398
264, 398, 407, 399
265, 399, 408, 400
266, 400, 409, 12
*ELEMENT, type=T3D3, ELSET=Line256
267, 15, 411, 410
268, 410, 412, 16
*ELEMENT, type=T3D3, ELSET=Line257
269, 15, 421, 413
270, 413, 422, 414
271, 414, 423, 415
272, 415, 424, 416
273, 416, 425, 417
274, 417, 426, 418
275, 418, 427, 419
276, 419, 428, 420
277, 420, 429, 9
*ELEMENT, type=T3D3, ELSET=Line258
278, 16, 438, 430
279, 430, 439, 431
280, 431, 440, 432
281, 432, 441, 433
282, 433, 442, 434
283, 434, 443, 435
284, 435, 444, 436
285, 436, 445, 437
286, 437, 446, 10
*ELEMENT, type=T3D3, ELSET=Line259
287, 13, 449, 447
288, 447, 450, 448
289, 448, 451, 15
*ELEMENT, type=T3D3, ELSET=Line260
290, 14, 454, 452
291, 452, 455, 453
292, 453, 456, 16
*ELEMENT, type=T3D3, ELSET=Line261
293, 11, 460, 457
294, 457, 461, 458
295, 458, 462, 459
296, 459, 463, 17
*ELEMENT, type=T3D3, ELSET=Line262
297, 12, 467, 464
298, 464, 468, 465
299, 465, 469, 466
300, 466, 470, 18
*ELEMENT, type=T3D3, ELSET=Line263
301, 17, 472, 471
302, 471, 473, 18
*ELEMENT, type=T3D3, ELSET=Line264
303, 13, 477, 474
304, 474, 478, 475
305, 475, 479, 476
306, 476, 480, 19
*ELEMENT, type=T3D3, ELSET=Line265
307, 14, 484, 481
308, 481, 485, 482
309, 482, 486, 483
310, 483, 487, 20
*ELEMENT, type=T3D3, ELSET=Line266
311, 19, 489, 488
312, 488, 490, 20
*ELEMENT, type=T3D3, ELSET=Line267
313, 19, 499, 491
314, 491, 500, 492
315, 492, 501, 493
316, 493, 502, 494
317, 494, 503, 495
318, 495, 504, 496
319, 496, 505, 497
320, 497, 506, 498
321, 498, 507, 17
*ELEMENT, type=T3D3, ELSET=Line268
322, 20, 516, 508
323, 508, 517, 509
324, 509, 518, 510
325, 510, 519, 511
326, 511, 520, 512
327, 512, 521, 513
328, 513, 522, 514
329, 514, 523, 515
330, 515, 524, 18
*ELEMENT, type=T3D3, ELSET=Line269
331, 22, 533, 525
332, 525, 534, 526
333, 526, 535, 527
334, 527, 536, 528
335, 528, 537, 529
336, 529, 538, 530
337, 530, 539, 531
338, 531, 540, 532
339, 532, 541, 21
*ELEMENT, type=T3D3, ELSET=Line270
340, 21, 544, 542
341, 542, 545, 543
342, 543, 546, 23
*ELEMENT, type=T3D3, ELSET=Line271
343, 24, 555, 547
344, 547, 556, 548
345, 548, 557, 549
346, 549, 558, 550
347, 550, 559, 551
348, 551, 560, 552
349, 552, 561, 553
350, 553, 562, 554
351, 554, 563, 23
*ELEMENT, type=T3D3, ELSET=Line272
352, 22, 566, 564
353, 564, 567, 565
354, 565, 568, 24
*ELEMENT, type=T3D3, ELSET=Line273
355, 13, 591, 569
356, 569, 592, 570
357, 570, 593, 571
358, 571, 594, 572
359, 572, 595, 573
360, 573, 596, 574
361, 574, 597, 575
362, 575, 598, 576
363, 576, 599, 577
364, 577, 600, 578
365, 578, 601, 579
366, 579, 602, 580
367, 580, 603, 581
368, 581, 604, 582
369, 582, 605, 583
370, 583, 606, 584
371, 584, 607, 585
372, 585, 608, 586
373, 586, 609, 587
374, 587, 610, 588
375, 588, 611, 589
376, 589, 612, 590
377, 590, 613, 22
*ELEMENT, type=T3D3, ELSET=Line274
378, 11, 636, 614
379, 614, 637, 615
380, 615, 638, 616
381, 616, 639, 617
382, 617, 640, 618
383, 618, 641, 619
384, 619, 642, 620
385, 620, 643, 621
386, 621, 644, 622
387, 622, 645, 623
388, 623, 646, 624
389, 624, 647, 625
390, 625, 648, 626
391, 626, 649, 627
392, 627, 650, 628
393, 628, 651, 629
394, 629, 652, 630
395, 630, 653, 631
396, 631, 654, 632
397, 632, 655, 633
398, 633, 656, 634
399, 634, 657, 635
400, 635, 658, 21
*ELEMENT, type=T3D3, ELSET=Line275
401, 15, 681, 659
402, 659, 682, 660
403, 660, 683, 661
404, 661, 684, 662
405, 662, 685, 663
406, 663, 686, 664
407, 664, 687, 665
408, 665, 688, 666
409, 666, 689, 667
410, 667, 690, 668
411, 668, 691, 669
412, 669, 692, 670
413, 670, 693, 671
414, 671, 694, 672
415, 672, 695, 673
416, 673, 696, 674
417, 674, 697, 675
418, 675, 698, 676
419, 676, 699, 677
420, 677, 700, 678
421, 678, 701, 679
422, 679, 702, 680
423, 680, 703, 24
*ELEMENT, type=T3D3, ELSET=Line276
424, 9, 726, 704
425, 704, 727, 705
426, 705, 728, 706
427, 706, 729, 707
428, 707, 730, 708
429, 708, 731, 709
430, 709, 732, 710
431, 710, 733, 711
432, 711, 734, 712
433, 712, 735, 713
434, 713, 736, 714
435, 714, 737, 715
436, 715, 738, 716
437, 716, 739, 717
438, 717, 740, 718
439, 718, 741, 719
440, 719, 742, 720
441, 720, 743, 721
442, 721, 744, 722
443, 722, 745, 723
444, 723, 746, 724
445, 724, 747, 725
446, 725, 748, 23
*ELEMENT, type=T3D3, ELSET=Line277
447, 22, 752, 749
448, 749, 753, 750
449, 750, 754, 751
450, 751, 755, 25
*ELEMENT, type=T3D3, ELSET=Line278
451, 19, 778, 756
452, 756, 779, 757
453, 757, 780, 758
454, 758, 781, 759
455, 759, 782, 760
456, 760, 783, 761
457, 761, 784, 762
458, 762, 785, 763
459, 763, 786, 764
460, 764, 787, 765
461, 765, 788, 766
462, 766, 789, 767
463, 767, 790, 768
464, 768, 791, 769
465, 769, 792, 770
466, 770, 793, 771
467, 771, 794, 772
468, 772, 795, 773
469, 773, 796, 774
470, 774, 797, 775
471, 775, 798, 776
472, 776, 799, 777
473, 777, 800, 25
*ELEMENT, type=T3D3, ELSET=Line279
474, 21, 804, 801
475, 801, 805, 802
476, 802, 806, 803
477, 803, 807, 26
*ELEMENT, type=T3D3, ELSET=Line280
478, 25, 816, 808
479, 808, 817, 809
480, 809, 818, 810
481, 810, 819, 811
482, 811, 820, 812
483, 812, 821, 813
484, 813, 822, 814
485, 814, 823, 815
486, 815, 824, 26
*ELEMENT, type=T3D3, ELSET=Line281
487, 17, 847, 825
488, 825, 848, 826
489, 826, 849, 827
490, 827, 850, 828
491, 828, 851, 829
492, 829, 852, 830
493, 830, 853, 831
494, 831, 854, 832
495, 832, 855, 833
496, 833, 856, 834
497, 834, 857, 835
498, 835, 858, 836
499, 836, 859, 837
500, 837, 860, 838
501, 838, 861, 839
502, 839, 862, 840
503, 840, 863, 841
504, 841, 864, 842
505, 842, 865, 843
506, 843, 866, 844
507, 844, 867, 845
508, 845, 868, 846
509, 846, 869, 26
*ELEMENT, type=T3D3, ELSET=Line282
510, 21, 873, 870
511, 870, 874, 871
512, 871, 875, 872
513, 872, 876, 27
*ELEMENT, type=T3D3, ELSET=Line283
514, 26, 880, 877
515, 877, 881, 878
516, 878, 882, 879
517, 879, 883, 28
*ELEMENT, type=T3D3, ELSET=Line284
518, 27, 887, 884
519, 884, 888, 885
520, 885, 889, 886
521, 886, 890, 28
*ELEMENT, type=T3D3, ELSET=Line285
522, 22, 894, 891
523, 891, 895, 892
524, 892, 896, 893
525, 893, 897, 29
*ELEMENT, type=T3D3, ELSET=Line286
526, 25, 901, 898
527, 898, 902, 899
528, 899, 903, 900
529, 900, 904, 30
*ELEMENT, type=T3D3, ELSET=Line287
530, 29, 908, 905
531, 905, 909, 906
532, 906, 910, 907
533, 907, 911, 30
*ELEMENT, type=T3D3, ELSET=Line288
534, 29, 920, 912
535, 912, 921, 913
536, 913, 922, 914
537, 914, 923, 915
538, 915, 924, 916
539, 916, 925, 917
540, 917, 926, 918
541, 918, 927, 919
542, 919, 928, 27
*ELEMENT, type=T3D3, ELSET=Line289
543, 30, 937, 929
544, 929, 938, 930
545, 930, 939, 931
546, 931, 940, 932
547, 932, 941, 933
548, 933, 942, 934
549, 934, 943, 935
550, 935, 944, 936
551, 936, 945, 28
*ELEMENT, type=T3D3, ELSET=Line290
552, 31, 949, 946
553, 946, 950, 947
554, 947, 951, 948
555, 948, 952, 32
*ELEMENT, type=T3D3, ELSET=Line291
556, 27, 975, 953
557, 953, 976, 954
558, 954, 977, 955
559, 955, 978, 956
560, 956, 979, 957
561, 957, 980, 958
562, 958, 981, 959
563, 959, 982, 960
564, 960, 983, 961
565, 961, 984, 962
566, 962, 985, 963
567, 963, 986, 964
568, 964, 987, 965
569, 965, 988, 966
570, 966, 989, 967
571, 967, 990, 968
572, 968, 991, 969
573, 969, 992, 970
574, 970, 993, 971
575, 971, 994, 972
576, 972, 995, 973
577, 973, 996, 974
578, 974, 997, 31
*ELEMENT, type=T3D3, ELSET=Line292
579, 28, 1020, 998
580, 998, 1021, 999
581, 999, 1022, 1000
582, 1000, 1023, 1001
583, 1001, 1024, 1002
584, 1002, 1025, 1003
585, 1003, 1026, 1004
586, 1004, 1027, 1005
587, 1005, 1028, 1006
588, 1006, 1029, 1007
589, 1007, 1030, 1008
590, 1008, 1031, 1009
591, 1009, 1032, 1010
592, 1010, 1033, 1011
593, 1011, 1034, 1012
594, 1012, 1035, 1013
595, 1013, 1036, 1014
596, 1014, 1037, 1015
597, 1015, 1038, 1016
598, 1016, 1039, 1017
599, 1017, 1040, 1018
600, 1018, 1041, 1019
601, 1019, 1042, 32
*ELEMENT, type=T3D3, ELSET=Line293
602, 33, 1046, 1043
603, 1043, 1047, 1044
604, 1044, 1048, 1045
605, 1045, 1049, 34
*ELEMENT, type=T3D3, ELSET=Line294
606, 29, 1072, 1050
607, 1050, 1073, 1051
608, 1051, 1074, 1052
609, 1052, 1075, 1053
610, 1053, 1076, 1054
611, 1054, 1077, 1055
612, 1055, 1078, 1056
613, 1056, 1079, 1057
614, 1057, 1080, 1058
615, 1058, 1081, 1059
616, 1059, 1082, 1060
617, 1060, 1083, 1061
618, 1061, 1084, 1062
619, 1062, 1085, 1063
620, 1063, 1086, 1064
621, 1064, 1087, 1065
622, 1065, 1088, 1066
623, 1066, 1089, 1067
624, 1067, 1090, 1068
625, 1068, 1091, 1069
626, 1069, 1092, 1070
627, 1070, 1093, 1071
628, 1071, 1094, 33
*ELEMENT, type=T3D3, ELSET=Line295
629, 30, 1117, 1095
630, 1095, 1118, 1096
631, 1096, 1119, 1097
632, 1097, 1120, 1098
633, 1098, 1121, 1099
634, 1099, 1122, 1100
635, 1100, 1123, 1101
636, 1101, 1124, 1102
637, 1102, 1125, 1103
638, 1103, 1126, 1104
639, 1104, 1127, 1105
640, 1105, 1128, 1106
641, 1106, 1129, 1107
642, 1107, 1130, 1108
643, 1108, 1131, 1109
644, 1109, 1132, 1110
645, 1110, 1133, 1111
646, 1111, 1134, 1112
647, 1112, 1135, 1113
648, 1113, 1136, 1114
649, 1114, 1137, 1115
650, 1115, 1138, 1116
651, 1116, 1139, 34
*ELEMENT, type=T3D3, ELSET=Line296
652, 33, 1148, 1140
653, 1140, 1149, 1141
654, 1141, 1150, 1142
655, 1142, 1151, 1143
656, 1143, 1152, 1144
657, 1144, 1153, 1145
658, 1145, 1154, 1146
659, 1146, 1155, 1147
660, 1147, 1156, 31
*ELEMENT, type=T3D3, ELSET=Line297
661, 34, 1165, 1157
662, 1157, 1166, 1158
663, 1158, 1167, 1159
664, 1159, 1168, 1160
665, 1160, 1169, 1161
666, 1161, 1170, 1162
667, 1162, 1171, 1163
668, 1163, 1172, 1164
669, 1164, 1173, 32
*ELEMENT, type=T3D3, ELSET=Line298
670, 35, 1176, 1174
671, 1174, 1177, 1175
672, 1175, 1178, 27
*ELEMENT, type=T3D3, ELSET=Line299
673, 36, 1181, 1179
674, 1179, 1182, 1180
675, 1180, 1183, 31
*ELEMENT, type=T3D3, ELSET=Line300
676, 35, 1206, 1184
677, 1184, 1207, 1185
678, 1185, 1208, 1186
679, 1186, 1209, 1187
680, 1187, 1210, 1188
681, 1188, 1211, 1189
682, 1189, 1212, 1190
683, 1190, 1213, 1191
684, 1191, 1214, 1192
685, 1192, 1215, 1193
686, 1193, 1216, 1194
687, 1194, 1217, 1195
688, 1195, 1218, 1196
689, 1196, 1219, 1197
690, 1197, 1220, 1198
691, 1198, 1221, 1199
692, 1199, 1222, 1200
693, 1200, 1223, 1201
694, 1201, 1224, 1202
695, 1202, 1225, 1203
696, 1203, 1226, 1204
697, 1204, 1227, 1205
698, 1205, 1228, 36
*ELEMENT, type=T3D3, ELSET=Line301
699, 37, 1231, 1229
700, 1229, 1232, 1230
701, 1230, 1233, 29
*ELEMENT, type=T3D3, ELSET=Line302
702, 38, 1236, 1234
703, 1234, 1237, 1235
704, 1235, 1238, 33
*ELEMENT, type=T3D3, ELSET=Line303
705, 37, 1261, 1239
706, 1239, 1262, 1240
707, 1240, 1263, 1241
708, 1241, 1264, 1242
709, 1242, 1265, 1243
710, 1243, 1266, 1244
711, 1244, 1267, 1245
712, 1245, 1268, 1246
713, 1246, 1269, 1247
714, 1247, 1270, 1248
715, 1248, 1271, 1249
716, 1249, 1272, 1250
717, 1250, 1273, 1251
718, 1251, 1274, 1252
719, 1252, 1275, 1253
720, 1253, 1276, 1254
721, 1254, 1277, 1255
722, 1255, 1278, 1256
723, 1256, 1279, 1257
724, 1257, 1280, 1258
725, 1258, 1281, 1259
726, 1259, 1282, 1260
727, 1260, 1283, 38
*ELEMENT, type=T3D3, ELSET=Line304
728, 37, 1292, 1284
729, 1284, 1293, 1285
730, 1285, 1294, 1286
731, 1286, 1295, 1287
732, 1287, 1296, 1288
733, 1288, 1297, 1289
734, 1289, 1298, 1290
735, 1290, 1299, 1291
736, 1291, 1300, 35
*ELEMENT, type=T3D3, ELSET=Line305
737, 38, 1309, 1301
738, 1301, 1310, 1302
