21002, 11821, 55748, 55756, 11813, 11822, 55749, 55757, 11814, 56433, 56457, 56458, 12020, 56436, 56460, 56461, 
12022, 12021, 56434, 56459, 12004
21003, 11822, 55749, 55757, 11814, 11823, 55750, 55758, 11815, 56436, 56460, 56461, 12022, 56439, 56463, 56464, 
12024, 12023, 56437, 56462, 12006
21004, 11823, 55750, 55758, 11815, 11824, 55751, 55759, 11816, 56439, 56463, 56464, 12024, 56442, 56466, 56467, 
12026, 12025, 56440, 56465, 12008
21005, 11824, 55751, 55759, 11816, 1557, 11606, 11607, 1556, 56442, 56466, 56467, 12026, 11670, 11671, 11672, 
1579, 12027, 56443, 56468, 12010
21006, 1422, 11393, 11394, 1421, 11809, 55752, 55760, 11801, 11457, 11460, 11459, 1444, 56446, 56470, 56471, 
11995, 11994, 56444, 56469, 11977
21007, 11809, 55752, 55760, 11801, 11810, 55753, 55761, 11802, 56446, 56470, 56471, 11995, 56449, 56473, 56474, 
11997, 11996, 56447, 56472, 11979
21008, 11810, 55753, 55761, 11802, 11811, 55754, 55762, 11803, 56449, 56473, 56474, 11997, 56452, 56476, 56477, 
11999, 11998, 56450, 56475, 11981
21009, 11811, 55754, 55762, 11803, 11812, 55755, 55763, 11804, 56452, 56476, 56477, 11999, 56455, 56479, 56480, 
12001, 12000, 56453, 56478, 11983
21010, 11812, 55755, 55763, 11804, 11813, 55756, 55764, 11805, 56455, 56479, 56480, 12001, 56458, 56482, 56483, 
12003, 12002, 56456, 56481, 11985
21011, 11813, 55756, 55764, 11805, 11814, 55757, 55765, 11806, 56458, 56482, 56483, 12003, 56461, 56485, 56486, 
12005, 12004, 56459, 56484, 11987
21012, 11814, 55757, 55765, 11806, 11815, 55758, 55766, 11807, 56461, 56485, 56486, 12005, 56464, 56488, 56489, 
12007, 12006, 56462, 56487, 11989
21013, 11815, 55758, 55766, 11807, 11816, 55759, 55767, 11808, 56464, 56488, 56489, 12007, 56467, 56491, 56492, 
12009, 12008, 56465, 56490, 11991
21014, 11816, 55759, 55767, 11808, 1556, 11607, 11608, 1555, 56467, 56491, 56492, 12009, 11672, 11673, 11674, 
1578, 12010, 56468, 56493, 11993
21015, 1421, 11394, 1416, 47, 11801, 55760, 11750, 1645, 11459, 11461, 1418, 1443, 56471, 56494, 11774, 
11978, 11977, 56469, 11775, 1653
21016, 11801, 55760, 11750, 1645, 11802, 55761, 11749, 1646, 56471, 56494, 11774, 11978, 56474, 56495, 11772, 
11980, 11979, 56472, 11773, 1654
21017, 11802, 55761, 11749, 1646, 11803, 55762, 11748, 1647, 56474, 56495, 11772, 11980, 56477, 56496, 11770, 
11982, 11981, 56475, 11771, 1655
21018, 11803, 55762, 11748, 1647, 11804, 55763, 11747, 1648, 56477, 56496, 11770, 11982, 56480, 56497, 11768, 
11984, 11983, 56478, 11769, 1656
21019, 11804, 55763, 11747, 1648, 11805, 55764, 11746, 1649, 56480, 56497, 11768, 11984, 56483, 56498, 11766, 
11986, 11985, 56481, 11767, 1657
21020, 11805, 55764, 11746, 1649, 11806, 55765, 11745, 1650, 56483, 56498, 11766, 11986, 56486, 56499, 11764, 
11988, 11987, 56484, 11765, 1658
21021, 11806, 55765, 11745, 1650, 11807, 55766, 11744, 1651, 56486, 56499, 11764, 11988, 56489, 56500, 11762, 
11990, 11989, 56487, 11763, 1659
21022, 11807, 55766, 11744, 1651, 11808, 55767, 11743, 1652, 56489, 56500, 11762, 11990, 56492, 56501, 11760, 
11992, 11991, 56490, 11761, 1660
21023, 11808, 55767, 11743, 1652, 1555, 11608, 1550, 51, 56492, 56501, 11760, 11992, 11674, 11675, 1552, 
1577, 11993, 56493, 11759, 1661
21024, 1411, 1412, 11395, 11373, 11536, 11544, 55768, 55592, 1414, 11463, 11462, 11418, 11576, 56503, 56504, 
55945, 11561, 11578, 56502, 55944
21025, 11536, 11544, 55768, 55592, 11535, 11543, 55769, 55593, 11576, 56503, 56504, 55945, 11574, 56506, 56507, 
55948, 11560, 11577, 56505, 55947
21026, 11535, 11543, 55769, 55593, 11534, 11542, 55770, 55594, 11574, 56506, 56507, 55948, 11572, 56509, 56510, 
55951, 11558, 11575, 56508, 55950
21027, 11534, 11542, 55770, 55594, 11533, 11541, 55771, 55595, 11572, 56509, 56510, 55951, 11570, 56512, 56513, 
55954, 11556, 11573, 56511, 55953
21028, 11533, 11541, 55771, 55595, 11532, 11540, 55772, 55596, 11570, 56512, 56513, 55954, 11568, 56515, 56516, 
55957, 11554, 11571, 56514, 55956
21029, 11532, 11540, 55772, 55596, 11531, 11539, 55773, 55597, 11568, 56515, 56516, 55957, 11566, 56518, 56519, 
55960, 11552, 11569, 56517, 55959
21030, 11531, 11539, 55773, 55597, 11530, 11538, 55774, 55598, 11566, 56518, 56519, 55960, 11564, 56521, 56522, 
55963, 11550, 11567, 56520, 55962
21031, 11530, 11538, 55774, 55598, 11529, 11537, 55775, 55599, 11564, 56521, 56522, 55963, 11562, 56524, 56525, 
55966, 11548, 11565, 56523, 55965
21032, 11529, 11537, 55775, 55599, 1511, 1512, 11609, 11587, 11562, 56524, 56525, 55966, 1514, 11676, 11677, 
11631, 11546, 11563, 56526, 55968
21033, 11373, 11395, 11396, 11374, 55592, 55768, 55776, 55600, 11462, 11465, 11464, 11420, 56504, 56528, 56529, 
55970, 55944, 56502, 56527, 55969
21034, 55592, 55768, 55776, 55600, 55593, 55769, 55777, 55601, 56504, 56528, 56529, 55970, 56507, 56531, 56532, 
55973, 55947, 56505, 56530, 55972
21035, 55593, 55769, 55777, 55601, 55594, 55770, 55778, 55602, 56507, 56531, 56532, 55973, 56510, 56534, 56535, 
55976, 55950, 56508, 56533, 55975
21036, 55594, 55770, 55778, 55602, 55595, 55771, 55779, 55603, 56510, 56534, 56535, 55976, 56513, 56537, 56538, 
55979, 55953, 56511, 56536, 55978
21037, 55595, 55771, 55779, 55603, 55596, 55772, 55780, 55604, 56513, 56537, 56538, 55979, 56516, 56540, 56541, 
55982, 55956, 56514, 56539, 55981
21038, 55596, 55772, 55780, 55604, 55597, 55773, 55781, 55605, 56516, 56540, 56541, 55982, 56519, 56543, 56544, 
55985, 55959, 56517, 56542, 55984
21039, 55597, 55773, 55781, 55605, 55598, 55774, 55782, 55606, 56519, 56543, 56544, 55985, 56522, 56546, 56547, 
55988, 55962, 56520, 56545, 55987
21040, 55598, 55774, 55782, 55606, 55599, 55775, 55783, 55607, 56522, 56546, 56547, 55988, 56525, 56549, 56550, 
55991, 55965, 56523, 56548, 55990
21041, 55599, 55775, 55783, 55607, 11587, 11609, 11610, 11588, 56525, 56549, 56550, 55991, 11677, 11678, 11679, 
11633, 55968, 56526, 56551, 55993
21042, 11374, 11396, 11397, 11375, 55600, 55776, 55784, 55608, 11464, 11467, 11466, 11422, 56529, 56553, 56554, 
55995, 55969, 56527, 56552, 55994
21043, 55600, 55776, 55784, 55608, 55601, 55777, 55785, 55609, 56529, 56553, 56554, 55995, 56532, 56556, 56557, 
55998, 55972, 56530, 56555, 55997
21044, 55601, 55777, 55785, 55609, 55602, 55778, 55786, 55610, 56532, 56556, 56557, 55998, 56535, 56559, 56560, 
56001, 55975, 56533, 56558, 56000
21045, 55602, 55778, 55786, 55610, 55603, 55779, 55787, 55611, 56535, 56559, 56560, 56001, 56538, 56562, 56563, 
56004, 55978, 56536, 56561, 56003
21046, 55603, 55779, 55787, 55611, 55604, 55780, 55788, 55612, 56538, 56562, 56563, 56004, 56541, 56565, 56566, 
56007, 55981, 56539, 56564, 56006
21047, 55604, 55780, 55788, 55612, 55605, 55781, 55789, 55613, 56541, 56565, 56566, 56007, 56544, 56568, 56569, 
56010, 55984, 56542, 56567, 56009
21048, 55605, 55781, 55789, 55613, 55606, 55782, 55790, 55614, 56544, 56568, 56569, 56010, 56547, 56571, 56572, 
56013, 55987, 56545, 56570, 56012
21049, 55606, 55782, 55790, 55614, 55607, 55783, 55791, 55615, 56547, 56571, 56572, 56013, 56550, 56574, 56575, 
56016, 55990, 56548, 56573, 56015
21050, 55607, 55783, 55791, 55615, 11588, 11610, 11611, 11589, 56550, 56574, 56575, 56016, 11679, 11680, 11681, 
11635, 55993, 56551, 56576, 56018
21051, 11375, 11397, 11398, 11376, 55608, 55784, 55792, 55616, 11466, 11469, 11468, 11424, 56554, 56578, 56579, 
56020, 55994, 56552, 56577, 56019
21052, 55608, 55784, 55792, 55616, 55609, 55785, 55793, 55617, 56554, 56578, 56579, 56020, 56557, 56581, 56582, 
56023, 55997, 56555, 56580, 56022
21053, 55609, 55785, 55793, 55617, 55610, 55786, 55794, 55618, 56557, 56581, 56582, 56023, 56560, 56584, 56585, 
56026, 56000, 56558, 56583, 56025
21054, 55610, 55786, 55794, 55618, 55611, 55787, 55795, 55619, 56560, 56584, 56585, 56026, 56563, 56587, 56588, 
56029, 56003, 56561, 56586, 56028
21055, 55611, 55787, 55795, 55619, 55612, 55788, 55796, 55620, 56563, 56587, 56588, 56029, 56566, 56590, 56591, 
56032, 56006, 56564, 56589, 56031
21056, 55612, 55788, 55796, 55620, 55613, 55789, 55797, 55621, 56566, 56590, 56591, 56032, 56569, 56593, 56594, 
56035, 56009, 56567, 56592, 56034
21057, 55613, 55789, 55797, 55621, 55614, 55790, 55798, 55622, 56569, 56593, 56594, 56035, 56572, 56596, 56597, 
56038, 56012, 56570, 56595, 56037
21058, 55614, 55790, 55798, 55622, 55615, 55791, 55799, 55623, 56572, 56596, 56597, 56038, 56575, 56599, 56600, 
56041, 56015, 56573, 56598, 56040
21059, 55615, 55791, 55799, 55623, 11589, 11611, 11612, 11590, 56575, 56599, 56600, 56041, 11681, 11682, 11683, 
11637, 56018, 56576, 56601, 56043
21060, 11376, 11398, 11399, 11377, 55616, 55792, 55800, 55624, 11468, 11471, 11470, 11426, 56579, 56603, 56604, 
56045, 56019, 56577, 56602, 56044
21061, 55616, 55792, 55800, 55624, 55617, 55793, 55801, 55625, 56579, 56603, 56604, 56045, 56582, 56606, 56607, 
56048, 56022, 56580, 56605, 56047
21062, 55617, 55793, 55801, 55625, 55618, 55794, 55802, 55626, 56582, 56606, 56607, 56048, 56585, 56609, 56610, 
56051, 56025, 56583, 56608, 56050
21063, 55618, 55794, 55802, 55626, 55619, 55795, 55803, 55627, 56585, 56609, 56610, 56051, 56588, 56612, 56613, 
56054, 56028, 56586, 56611, 56053
21064, 55619, 55795, 55803, 55627, 55620, 55796, 55804, 55628, 56588, 56612, 56613, 56054, 56591, 56615, 56616, 
56057, 56031, 56589, 56614, 56056
21065, 55620, 55796, 55804, 55628, 55621, 55797, 55805, 55629, 56591, 56615, 56616, 56057, 56594, 56618, 56619, 
56060, 56034, 56592, 56617, 56059
21066, 55621, 55797, 55805, 55629, 55622, 55798, 55806, 55630, 56594, 56618, 56619, 56060, 56597, 56621, 56622, 
56063, 56037, 56595, 56620, 56062
21067, 55622, 55798, 55806, 55630, 55623, 55799, 55807, 55631, 56597, 56621, 56622, 56063, 56600, 56624, 56625, 
56066, 56040, 56598, 56623, 56065
21068, 55623, 55799, 55807, 55631, 11590, 11612, 11613, 11591, 56600, 56624, 56625, 56066, 11683, 11684, 11685, 
11639, 56043, 56601, 56626, 56068
21069, 11377, 11399, 11400, 11378, 55624, 55800, 55808, 55632, 11470, 11473, 11472, 11428, 56604, 56628, 56629, 
56070, 56044, 56602, 56627, 56069
21070, 55624, 55800, 55808, 55632, 55625, 55801, 55809, 55633, 56604, 56628, 56629, 56070, 56607, 56631, 56632, 
56073, 56047, 56605, 56630, 56072
21071, 55625, 55801, 55809, 55633, 55626, 55802, 55810, 55634, 56607, 56631, 56632, 56073, 56610, 56634, 56635, 
56076, 56050, 56608, 56633, 56075
21072, 55626, 55802, 55810, 55634, 55627, 55803, 55811, 55635, 56610, 56634, 56635, 56076, 56613, 56637, 56638, 
56079, 56053, 56611, 56636, 56078
21073, 55627, 55803, 55811, 55635, 55628, 55804, 55812, 55636, 56613, 56637, 56638, 56079, 56616, 56640, 56641, 
56082, 56056, 56614, 56639, 56081
21074, 55628, 55804, 55812, 55636, 55629, 55805, 55813, 55637, 56616, 56640, 56641, 56082, 56619, 56643, 56644, 
56085, 56059, 56617, 56642, 56084
21075, 55629, 55805, 55813, 55637, 55630, 55806, 55814, 55638, 56619, 56643, 56644, 56085, 56622, 56646, 56647, 
56088, 56062, 56620, 56645, 56087
21076, 55630, 55806, 55814, 55638, 55631, 55807, 55815, 55639, 56622, 56646, 56647, 56088, 56625, 56649, 56650, 
56091, 56065, 56623, 56648, 56090
21077, 55631, 55807, 55815, 55639, 11591, 11613, 11614, 11592, 56625, 56649, 56650, 56091, 11685, 11686, 11687, 
11641, 56068, 56626, 56651, 56093
21078, 11378, 11400, 11401, 11379, 55632, 55808, 55816, 55640, 11472, 11475, 11474, 11430, 56629, 56653, 56654, 
56095, 56069, 56627, 56652, 56094
21079, 55632, 55808, 55816, 55640, 55633, 55809, 55817, 55641, 56629, 56653, 56654, 56095, 56632, 56656, 56657, 
56098, 56072, 56630, 56655, 56097
21080, 55633, 55809, 55817, 55641, 55634, 55810, 55818, 55642, 56632, 56656, 56657, 56098, 56635, 56659, 56660, 
56101, 56075, 56633, 56658, 56100
21081, 55634, 55810, 55818, 55642, 55635, 55811, 55819, 55643, 56635, 56659, 56660, 56101, 56638, 56662, 56663, 
56104, 56078, 56636, 56661, 56103
21082, 55635, 55811, 55819, 55643, 55636, 55812, 55820, 55644, 56638, 56662, 56663, 56104, 56641, 56665, 56666, 
56107, 56081, 56639, 56664, 56106
21083, 55636, 55812, 55820, 55644, 55637, 55813, 55821, 55645, 56641, 56665, 56666, 56107, 56644, 56668, 56669, 
56110, 56084, 56642, 56667, 56109
21084, 55637, 55813, 55821, 55645, 55638, 55814, 55822, 55646, 56644, 56668, 56669, 56110, 56647, 56671, 56672, 
56113, 56087, 56645, 56670, 56112
21085, 55638, 55814, 55822, 55646, 55639, 55815, 55823, 55647, 56647, 56671, 56672, 56113, 56650, 56674, 56675, 
56116, 56090, 56648, 56673, 56115
21086, 55639, 55815, 55823, 55647, 11592, 11614, 11615, 11593, 56650, 56674, 56675, 56116, 11687, 11688, 11689, 
11643, 56093, 56651, 56676, 56118
21087, 11379, 11401, 11402, 11380, 55640, 55816, 55824, 55648, 11474, 11477, 11476, 11432, 56654, 56678, 56679, 
56120, 56094, 56652, 56677, 56119
21088, 55640, 55816, 55824, 55648, 55641, 55817, 55825, 55649, 56654, 56678, 56679, 56120, 56657, 56681, 56682, 
56123, 56097, 56655, 56680, 56122
21089, 55641, 55817, 55825, 55649, 55642, 55818, 55826, 55650, 56657, 56681, 56682, 56123, 56660, 56684, 56685, 
56126, 56100, 56658, 56683, 56125
21090, 55642, 55818, 55826, 55650, 55643, 55819, 55827, 55651, 56660, 56684, 56685, 56126, 56663, 56687, 56688, 
56129, 56103, 56661, 56686, 56128
21091, 55643, 55819, 55827, 55651, 55644, 55820, 55828, 55652, 56663, 56687, 56688, 56129, 56666, 56690, 56691, 
56132, 56106, 56664, 56689, 56131
21092, 55644, 55820, 55828, 55652, 55645, 55821, 55829, 55653, 56666, 56690, 56691, 56132, 56669, 56693, 56694, 
56135, 56109, 56667, 56692, 56134
21093, 55645, 55821, 55829, 55653, 55646, 55822, 55830, 55654, 56669, 56693, 56694, 56135, 56672, 56696, 56697, 
56138, 56112, 56670, 56695, 56137
21094, 55646, 55822, 55830, 55654, 55647, 55823, 55831, 55655, 56672, 56696, 56697, 56138, 56675, 56699, 56700, 
56141, 56115, 56673, 56698, 56140
21095, 55647, 55823, 55831, 55655, 11593, 11615, 11616, 11594, 56675, 56699, 56700, 56141, 11689, 11690, 11691, 
11645, 56118, 56676, 56701, 56143
21096, 11380, 11402, 11403, 11381, 55648, 55824, 55832, 55656, 11476, 11479, 11478, 11434, 56679, 56703, 56704, 
56145, 56119, 56677, 56702, 56144
21097, 55648, 55824, 55832, 55656, 55649, 55825, 55833, 55657, 56679, 56703, 56704, 56145, 56682, 56706, 56707, 
56148, 56122, 56680, 56705, 56147
21098, 55649, 55825, 55833, 55657, 55650, 55826, 55834, 55658, 56682, 56706, 56707, 56148, 56685, 56709, 56710, 
56151, 56125, 56683, 56708, 56150
21099, 55650, 55826, 55834, 55658, 55651, 55827, 55835, 55659, 56685, 56709, 56710, 56151, 56688, 56712, 56713, 
56154, 56128, 56686, 56711, 56153
21100, 55651, 55827, 55835, 55659, 55652, 55828, 55836, 55660, 56688, 56712, 56713, 56154, 56691, 56715, 56716, 
56157, 56131, 56689, 56714, 56156
21101, 55652, 55828, 55836, 55660, 55653, 55829, 55837, 55661, 56691, 56715, 56716, 56157, 56694, 56718, 56719, 
56160, 56134, 56692, 56717, 56159
21102, 55653, 55829, 55837, 55661, 55654, 55830, 55838, 55662, 56694, 56718, 56719, 56160, 56697, 56721, 56722, 
56163, 56137, 56695, 56720, 56162
21103, 55654, 55830, 55838, 55662, 55655, 55831, 55839, 55663, 56697, 56721, 56722, 56163, 56700, 56724, 56725, 
56166, 56140, 56698, 56723, 56165
21104, 55655, 55831, 55839, 55663, 11594, 11616, 11617, 11595, 56700, 56724, 56725, 56166, 11691, 11692, 11693, 
11647, 56143, 56701, 56726, 56168
21105, 11381, 11403, 11404, 11382, 55656, 55832, 55840, 55664, 11478, 11481, 11480, 11436, 56704, 56728, 56729, 
56170, 56144, 56702, 56727, 56169
21106, 55656, 55832, 55840, 55664, 55657, 55833, 55841, 55665, 56704, 56728, 56729, 56170, 56707, 56731, 56732, 
56173, 56147, 56705, 56730, 56172
21107, 55657, 55833, 55841, 55665, 55658, 55834, 55842, 55666, 56707, 56731, 56732, 56173, 56710, 56734, 56735, 
56176, 56150, 56708, 56733, 56175
21108, 55658, 55834, 55842, 55666, 55659, 55835, 55843, 55667, 56710, 56734, 56735, 56176, 56713, 56737, 56738, 
56179, 56153, 56711, 56736, 56178
21109, 55659, 55835, 55843, 55667, 55660, 55836, 55844, 55668, 56713, 56737, 56738, 56179, 56716, 56740, 56741, 
56182, 56156, 56714, 56739, 56181
21110, 55660, 55836, 55844, 55668, 55661, 55837, 55845, 55669, 56716, 56740, 56741, 56182, 56719, 56743, 56744, 
56185, 56159, 56717, 56742, 56184
21111, 55661, 55837, 55845, 55669, 55662, 55838, 55846, 55670, 56719, 56743, 56744, 56185, 56722, 56746, 56747, 
56188, 56162, 56720, 56745, 56187
21112, 55662, 55838, 55846, 55670, 55663, 55839, 55847, 55671, 56722, 56746, 56747, 56188, 56725, 56749, 56750, 
56191, 56165, 56723, 56748, 56190
21113, 55663, 55839, 55847, 55671, 11595, 11617, 11618, 11596, 56725, 56749, 56750, 56191, 11693, 11694, 11695, 
11649, 56168, 56726, 56751, 56193
21114, 11382, 11404, 11405, 11383, 55664, 55840, 55848, 55672, 11480, 11483, 11482, 11438, 56729, 56753, 56754, 
56195, 56169, 56727, 56752, 56194
21115, 55664, 55840, 55848, 55672, 55665, 55841, 55849, 55673, 56729, 56753, 56754, 56195, 56732, 56756, 56757, 
56198, 56172, 56730, 56755, 56197
21116, 55665, 55841, 55849, 55673, 55666, 55842, 55850, 55674, 56732, 56756, 56757, 56198, 56735, 56759, 56760, 
56201, 56175, 56733, 56758, 56200
21117, 55666, 55842, 55850, 55674, 55667, 55843, 55851, 55675, 56735, 56759, 56760, 56201, 56738, 56762, 56763, 
56204, 56178, 56736, 56761, 56203
21118, 55667, 55843, 55851, 55675, 55668, 55844, 55852, 55676, 56738, 56762, 56763, 56204, 56741, 56765, 56766, 
56207, 56181, 56739, 56764, 56206
21119, 55668, 55844, 55852, 55676, 55669, 55845, 55853, 55677, 56741, 56765, 56766, 56207, 56744, 56768, 56769, 
56210, 56184, 56742, 56767, 56209
21120, 55669, 55845, 55853, 55677, 55670, 55846, 55854, 55678, 56744, 56768, 56769, 56210, 56747, 56771, 56772, 
56213, 56187, 56745, 56770, 56212
21121, 55670, 55846, 55854, 55678, 55671, 55847, 55855, 55679, 56747, 56771, 56772, 56213, 56750, 56774, 56775, 
56216, 56190, 56748, 56773, 56215
21122, 55671, 55847, 55855, 55679, 11596, 11618, 11619, 11597, 56750, 56774, 56775, 56216, 11695, 11696, 11697, 
11651, 56193, 56751, 56776, 56218
21123, 11383, 11405, 11406, 11384, 55672, 55848, 55856, 55680, 11482, 11485, 11484, 11440, 56754, 56778, 56779, 
56220, 56194, 56752, 56777, 56219
21124, 55672, 55848, 55856, 55680, 55673, 55849, 55857, 55681, 56754, 56778, 56779, 56220, 56757, 56781, 56782, 
56223, 56197, 56755, 56780, 56222
21125, 55673, 55849, 55857, 55681, 55674, 55850, 55858, 55682, 56757, 56781, 56782, 56223, 56760, 56784, 56785, 
56226, 56200, 56758, 56783, 56225
21126, 55674, 55850, 55858, 55682, 55675, 55851, 55859, 55683, 56760, 56784, 56785, 56226, 56763, 56787, 56788, 
56229, 56203, 56761, 56786, 56228
21127, 55675, 55851, 55859, 55683, 55676, 55852, 55860, 55684, 56763, 56787, 56788, 56229, 56766, 56790, 56791, 
56232, 56206, 56764, 56789, 56231
21128, 55676, 55852, 55860, 55684, 55677, 55853, 55861, 55685, 56766, 56790, 56791, 56232, 56769, 56793, 56794, 
56235, 56209, 56767, 56792, 56234
21129, 55677, 55853, 55861, 55685, 55678, 55854, 55862, 55686, 56769, 56793, 56794, 56235, 56772, 56796, 56797, 
56238, 56212, 56770, 56795, 56237
21130, 55678, 55854, 55862, 55686, 55679, 55855, 55863, 55687, 56772, 56796, 56797, 56238, 56775, 56799, 56800, 
56241, 56215, 56773, 56798, 56240
21131, 55679, 55855, 55863, 55687, 11597, 11619, 11620, 11598, 56775, 56799, 56800, 56241, 11697, 11698, 11699, 
11653, 56218, 56776, 56801, 56243
21132, 11384, 11406, 11407, 11385, 55680, 55856, 55864, 55688, 11484, 11487, 11486, 11442, 56779, 56803, 56804, 
56245, 56219, 56777, 56802, 56244
21133, 55680, 55856, 55864, 55688, 55681, 55857, 55865, 55689, 56779, 56803, 56804, 56245, 56782, 56806, 56807, 
56248, 56222, 56780, 56805, 56247
21134, 55681, 55857, 55865, 55689, 55682, 55858, 55866, 55690, 56782, 56806, 56807, 56248, 56785, 56809, 56810, 
56251, 56225, 56783, 56808, 56250
21135, 55682, 55858, 55866, 55690, 55683, 55859, 55867, 55691, 56785, 56809, 56810, 56251, 56788, 56812, 56813, 
56254, 56228, 56786, 56811, 56253
21136, 55683, 55859, 55867, 55691, 55684, 55860, 55868, 55692, 56788, 56812, 56813, 56254, 56791, 56815, 56816, 
56257, 56231, 56789, 56814, 56256
21137, 55684, 55860, 55868, 55692, 55685, 55861, 55869, 55693, 56791, 56815, 56816, 56257, 56794, 56818, 56819, 
56260, 56234, 56792, 56817, 56259
21138, 55685, 55861, 55869, 55693, 55686, 55862, 55870, 55694, 56794, 56818, 56819, 56260, 56797, 56821, 56822, 
56263, 56237, 56795, 56820, 56262
21139, 55686, 55862, 55870, 55694, 55687, 55863, 55871, 55695, 56797, 56821, 56822, 56263, 56800, 56824, 56825, 
56266, 56240, 56798, 56823, 56265
21140, 55687, 55863, 55871, 55695, 11598, 11620, 11621, 11599, 56800, 56824, 56825, 56266, 11699, 11700, 11701, 
11655, 56243, 56801, 56826, 56268
21141, 11385, 11407, 11408, 11386, 55688, 55864, 55872, 55696, 11486, 11489, 11488, 11444, 56804, 56828, 56829, 
56270, 56244, 56802, 56827, 56269
21142, 55688, 55864, 55872, 55696, 55689, 55865, 55873, 55697, 56804, 56828, 56829, 56270, 56807, 56831, 56832, 
56273, 56247, 56805, 56830, 56272
21143, 55689, 55865, 55873, 55697, 55690, 55866, 55874, 55698, 56807, 56831, 56832, 56273, 56810, 56834, 56835, 
56276, 56250, 56808, 56833, 56275
21144, 55690, 55866, 55874, 55698, 55691, 55867, 55875, 55699, 56810, 56834, 56835, 56276, 56813, 56837, 56838, 
56279, 56253, 56811, 56836, 56278
21145, 55691, 55867, 55875, 55699, 55692, 55868, 55876, 55700, 56813, 56837, 56838, 56279, 56816, 56840, 56841, 
56282, 56256, 56814, 56839, 56281
21146, 55692, 55868, 55876, 55700, 55693, 55869, 55877, 55701, 56816, 56840, 56841, 56282, 56819, 56843, 56844, 
56285, 56259, 56817, 56842, 56284
21147, 55693, 55869, 55877, 55701, 55694, 55870, 55878, 55702, 56819, 56843, 56844, 56285, 56822, 56846, 56847, 
56288, 56262, 56820, 56845, 56287
21148, 55694, 55870, 55878, 55702, 55695, 55871, 55879, 55703, 56822, 56846, 56847, 56288, 56825, 56849, 56850, 
56291, 56265, 56823, 56848, 56290
21149, 55695, 55871, 55879, 55703, 11599, 11621, 11622, 11600, 56825, 56849, 56850, 56291, 11701, 11702, 11703, 
11657, 56268, 56826, 56851, 56293
21150, 11386, 11408, 11409, 11387, 55696, 55872, 55880, 55704, 11488, 11491, 11490, 11446, 56829, 56853, 56854, 
56295, 56269, 56827, 56852, 56294
21151, 55696, 55872, 55880, 55704, 55697, 55873, 55881, 55705, 56829, 56853, 56854, 56295, 56832, 56856, 56857, 
56298, 56272, 56830, 56855, 56297
21152, 55697, 55873, 55881, 55705, 55698, 55874, 55882, 55706, 56832, 56856, 56857, 56298, 56835, 56859, 56860, 
56301, 56275, 56833, 56858, 56300
21153, 55698, 55874, 55882, 55706, 55699, 55875, 55883, 55707, 56835, 56859, 56860, 56301, 56838, 56862, 56863, 
56304, 56278, 56836, 56861, 56303
21154, 55699, 55875, 55883, 55707, 55700, 55876, 55884, 55708, 56838, 56862, 56863, 56304, 56841, 56865, 56866, 
56307, 56281, 56839, 56864, 56306
21155, 55700, 55876, 55884, 55708, 55701, 55877, 55885, 55709, 56841, 56865, 56866, 56307, 56844, 56868, 56869, 
56310, 56284, 56842, 56867, 56309
21156, 55701, 55877, 55885, 55709, 55702, 55878, 55886, 55710, 56844, 56868, 56869, 56310, 56847, 56871, 56872, 
56313, 56287, 56845, 56870, 56312
21157, 55702, 55878, 55886, 55710, 55703, 55879, 55887, 55711, 56847, 56871, 56872, 56313, 56850, 56874, 56875, 
56316, 56290, 56848, 56873, 56315
21158, 55703, 55879, 55887, 55711, 11600, 11622, 11623, 11601, 56850, 56874, 56875, 56316, 11703, 11704, 11705, 
11659, 56293, 56851, 56876, 56318
21159, 11387, 11409, 11410, 11388, 55704, 55880, 55888, 55712, 11490, 11493, 11492, 11448, 56854, 56878, 56879, 
56320, 56294, 56852, 56877, 56319
21160, 55704, 55880, 55888, 55712, 55705, 55881, 55889, 55713, 56854, 56878, 56879, 56320, 56857, 56881, 56882, 
56323, 56297, 56855, 56880, 56322
21161, 55705, 55881, 55889, 55713, 55706, 55882, 55890, 55714, 56857, 56881, 56882, 56323, 56860, 56884, 56885, 
56326, 56300, 56858, 56883, 56325
21162, 55706, 55882, 55890, 55714, 55707, 55883, 55891, 55715, 56860, 56884, 56885, 56326, 56863, 56887, 56888, 
56329, 56303, 56861, 56886, 56328
21163, 55707, 55883, 55891, 55715, 55708, 55884, 55892, 55716, 56863, 56887, 56888, 56329, 56866, 56890, 56891, 
56332, 56306, 56864, 56889, 56331
21164, 55708, 55884, 55892, 55716, 55709, 55885, 55893, 55717, 56866, 56890, 56891, 56332, 56869, 56893, 56894, 
56335, 56309, 56867, 56892, 56334
21165, 55709, 55885, 55893, 55717, 55710, 55886, 55894, 55718, 56869, 56893, 56894, 56335, 56872, 56896, 56897, 
56338, 56312, 56870, 56895, 56337
21166, 55710, 55886, 55894, 55718, 55711, 55887, 55895, 55719, 56872, 56896, 56897, 56338, 56875, 56899, 56900, 
56341, 56315, 56873, 56898, 56340
21167, 55711, 55887, 55895, 55719, 11601, 11623, 11624, 11602, 56875, 56899, 56900, 56341, 11705, 11706, 11707, 
11661, 56318, 56876, 56901, 56343
21168, 11388, 11410, 11411, 11389, 55712, 55888, 55896, 55720, 11492, 11495, 11494, 11450, 56879, 56903, 56904, 
56345, 56319, 56877, 56902, 56344
21169, 55712, 55888, 55896, 55720, 55713, 55889, 55897, 55721, 56879, 56903, 56904, 56345, 56882, 56906, 56907, 
56348, 56322, 56880, 56905, 56347
21170, 55713, 55889, 55897, 55721, 55714, 55890, 55898, 55722, 56882, 56906, 56907, 56348, 56885, 56909, 56910, 
56351, 56325, 56883, 56908, 56350
21171, 55714, 55890, 55898, 55722, 55715, 55891, 55899, 55723, 56885, 56909, 56910, 56351, 56888, 56912, 56913, 
56354, 56328, 56886, 56911, 56353
21172, 55715, 55891, 55899, 55723, 55716, 55892, 55900, 55724, 56888, 56912, 56913, 56354, 56891, 56915, 56916, 
56357, 56331, 56889, 56914, 56356
21173, 55716, 55892, 55900, 55724, 55717, 55893, 55901, 55725, 56891, 56915, 56916, 56357, 56894, 56918, 56919, 
56360, 56334, 56892, 56917, 56359
21174, 55717, 55893, 55901, 55725, 55718, 55894, 55902, 55726, 56894, 56918, 56919, 56360, 56897, 56921, 56922, 
56363, 56337, 56895, 56920, 56362
21175, 55718, 55894, 55902, 55726, 55719, 55895, 55903, 55727, 56897, 56921, 56922, 56363, 56900, 56924, 56925, 
56366, 56340, 56898, 56923, 56365
21176, 55719, 55895, 55903, 55727, 11602, 11624, 11625, 11603, 56900, 56924, 56925, 56366, 11707, 11708, 11709, 
11663, 56343, 56901, 56926, 56368
21177, 11389, 11411, 11412, 11390, 55720, 55896, 55904, 55728, 11494, 11497, 11496, 11452, 56904, 56928, 56929, 
56370, 56344, 56902, 56927, 56369
21178, 55720, 55896, 55904, 55728, 55721, 55897, 55905, 55729, 56904, 56928, 56929, 56370, 56907, 56931, 56932, 
56373, 56347, 56905, 56930, 56372
21179, 55721, 55897, 55905, 55729, 55722, 55898, 55906, 55730, 56907, 56931, 56932, 56373, 56910, 56934, 56935, 
56376, 56350, 56908, 56933, 56375
21180, 55722, 55898, 55906, 55730, 55723, 55899, 55907, 55731, 56910, 56934, 56935, 56376, 56913, 56937, 56938, 
56379, 56353, 56911, 56936, 56378
21181, 55723, 55899, 55907, 55731, 55724, 55900, 55908, 55732, 56913, 56937, 56938, 56379, 56916, 56940, 56941, 
56382, 56356, 56914, 56939, 56381
21182, 55724, 55900, 55908, 55732, 55725, 55901, 55909, 55733, 56916, 56940, 56941, 56382, 56919, 56943, 56944, 
56385, 56359, 56917, 56942, 56384
21183, 55725, 55901, 55909, 55733, 55726, 55902, 55910, 55734, 56919, 56943, 56944, 56385, 56922, 56946, 56947, 
56388, 56362, 56920, 56945, 56387
21184, 55726, 55902, 55910, 55734, 55727, 55903, 55911, 55735, 56922, 56946, 56947, 56388, 56925, 56949, 56950, 
56391, 56365, 56923, 56948, 56390
21185, 55727, 55903, 55911, 55735, 11603, 11625, 11626, 11604, 56925, 56949, 56950, 56391, 11709, 11710, 11711, 
11665, 56368, 56926, 56951, 56393
21186, 11390, 11412, 11413, 11391, 55728, 55904, 55912, 55736, 11496, 11499, 11498, 11454, 56929, 56953, 56954, 
56395, 56369, 56927, 56952, 56394
21187, 55728, 55904, 55912, 55736, 55729, 55905, 55913, 55737, 56929, 56953, 56954, 56395, 56932, 56956, 56957, 
56398, 56372, 56930, 56955, 56397
21188, 55729, 55905, 55913, 55737, 55730, 55906, 55914, 55738, 56932, 56956, 56957, 56398, 56935, 56959, 56960, 
56401, 56375, 56933, 56958, 56400
21189, 55730, 55906, 55914, 55738, 55731, 55907, 55915, 55739, 56935, 56959, 56960, 56401, 56938, 56962, 56963, 
56404, 56378, 56936, 56961, 56403
21190, 55731, 55907, 55915, 55739, 55732, 55908, 55916, 55740, 56938, 56962, 56963, 56404, 56941, 56965, 56966, 
56407, 56381, 56939, 56964, 56406
21191, 55732, 55908, 55916, 55740, 55733, 55909, 55917, 55741, 56941, 56965, 56966, 56407, 56944, 56968, 56969, 
56410, 56384, 56942, 56967, 56409
21192, 55733, 55909, 55917, 55741, 55734, 55910, 55918, 55742, 56944, 56968, 56969, 56410, 56947, 56971, 56972, 
56413, 56387, 56945, 56970, 56412
21193, 55734, 55910, 55918, 55742, 55735, 55911, 55919, 55743, 56947, 56971, 56972, 56413, 56950, 56974, 56975, 
56416, 56390, 56948, 56973, 56415
21194, 55735, 55911, 55919, 55743, 11604, 11626, 11627, 11605, 56950, 56974, 56975, 56416, 11711, 11712, 11713, 
11667, 56393, 56951, 56976, 56418
21195, 11391, 11413, 11414, 11392, 55736, 55912, 55920, 55744, 11498, 11501, 11500, 11456, 56954, 56978, 56979, 
56420, 56394, 56952, 56977, 56419
21196, 55736, 55912, 55920, 55744, 55737, 55913, 55921, 55745, 56954, 56978, 56979, 56420, 56957, 56981, 56982, 
56423, 56397, 56955, 56980, 56422
21197, 55737, 55913, 55921, 55745, 55738, 55914, 55922, 55746, 56957, 56981, 56982, 56423, 56960, 56984, 56985, 
56426, 56400, 56958, 56983, 56425
21198, 55738, 55914, 55922, 55746, 55739, 55915, 55923, 55747, 56960, 56984, 56985, 56426, 56963, 56987, 56988, 
56429, 56403, 56961, 56986, 56428
21199, 55739, 55915, 55923, 55747, 55740, 55916, 55924, 55748, 56963, 56987, 56988, 56429, 56966, 56990, 56991, 
56432, 56406, 56964, 56989, 56431
21200, 55740, 55916, 55924, 55748, 55741, 55917, 55925, 55749, 56966, 56990, 56991, 56432, 56969, 56993, 56994, 
56435, 56409, 56967, 56992, 56434
21201, 55741, 55917, 55925, 55749, 55742, 55918, 55926, 55750, 56969, 56993, 56994, 56435, 56972, 56996, 56997, 
56438, 56412, 56970, 56995, 56437
21202, 55742, 55918, 55926, 55750, 55743, 55919, 55927, 55751, 56972, 56996, 56997, 56438, 56975, 56999, 57000, 
56441, 56415, 56973, 56998, 56440
21203, 55743, 55919, 55927, 55751, 11605, 11627, 11628, 11606, 56975, 56999, 57000, 56441, 11713, 11714, 11715, 
11669, 56418, 56976, 57001, 56443
21204, 11392, 11414, 11415, 11393, 55744, 55920, 55928, 55752, 11500, 11503, 11502, 11458, 56979, 57003, 57004, 
56445, 56419, 56977, 57002, 56444
21205, 55744, 55920, 55928, 55752, 55745, 55921, 55929, 55753, 56979, 57003, 57004, 56445, 56982, 57006, 57007, 
56448, 56422, 56980, 57005, 56447
21206, 55745, 55921, 55929, 55753, 55746, 55922, 55930, 55754, 56982, 57006, 57007, 56448, 56985, 57009, 57010, 
56451, 56425, 56983, 57008, 56450
21207, 55746, 55922, 55930, 55754, 55747, 55923, 55931, 55755, 56985, 57009, 57010, 56451, 56988, 57012, 57013, 
56454, 56428, 56986, 57011, 56453
21208, 55747, 55923, 55931, 55755, 55748, 55924, 55932, 55756, 56988, 57012, 57013, 56454, 56991, 57015, 57016, 
56457, 56431, 56989, 57014, 56456
21209, 55748, 55924, 55932, 55756, 55749, 55925, 55933, 55757, 56991, 57015, 57016, 56457, 56994, 57018, 57019, 
56460, 56434, 56992, 57017, 56459
21210, 55749, 55925, 55933, 55757, 55750, 55926, 55934, 55758, 56994, 57018, 57019, 56460, 56997, 57021, 57022, 
56463, 56437, 56995, 57020, 56462
21211, 55750, 55926, 55934, 55758, 55751, 55927, 55935, 55759, 56997, 57021, 57022, 56463, 57000, 57024, 57025, 
56466, 56440, 56998, 57023, 56465
21212, 55751, 55927, 55935, 55759, 11606, 11628, 11629, 11607, 57000, 57024, 57025, 56466, 11715, 11716, 11717, 
11671, 56443, 57001, 57026, 56468
21213, 11393, 11415, 11416, 11394, 55752, 55928, 55936, 55760, 11502, 11505, 11504, 11460, 57004, 57028, 57029, 
56470, 56444, 57002, 57027, 56469
21214, 55752, 55928, 55936, 55760, 55753, 55929, 55937, 55761, 57004, 57028, 57029, 56470, 57007, 57031, 57032, 
56473, 56447, 57005, 57030, 56472
21215, 55753, 55929, 55937, 55761, 55754, 55930, 55938, 55762, 57007, 57031, 57032, 56473, 57010, 57034, 57035, 
56476, 56450, 57008, 57033, 56475
21216, 55754, 55930, 55938, 55762, 55755, 55931, 55939, 55763, 57010, 57034, 57035, 56476, 57013, 57037, 57038, 
56479, 56453, 57011, 57036, 56478
21217, 55755, 55931, 55939, 55763, 55756, 55932, 55940, 55764, 57013, 57037, 57038, 56479, 57016, 57040, 57041, 
56482, 56456, 57014, 57039, 56481
21218, 55756, 55932, 55940, 55764, 55757, 55933, 55941, 55765, 57016, 57040, 57041, 56482, 57019, 57043, 57044, 
56485, 56459, 57017, 57042, 56484
21219, 55757, 55933, 55941, 55765, 55758, 55934, 55942, 55766, 57019, 57043, 57044, 56485, 57022, 57046, 57047, 
56488, 56462, 57020, 57045, 56487
21220, 55758, 55934, 55942, 55766, 55759, 55935, 55943, 55767, 57022, 57046, 57047, 56488, 57025, 57049, 57050, 
56491, 56465, 57023, 57048, 56490
21221, 55759, 55935, 55943, 55767, 11607, 11629, 11630, 11608, 57025, 57049, 57050, 56491, 11717, 11718, 11719, 
11673, 56468, 57026, 57051, 56493
21222, 11394, 11416, 1417, 1416, 55760, 55936, 11758, 11750, 11504, 11506, 1419, 11461, 57029, 57052, 11791, 
56494, 56469, 57027, 11792, 11775
21223, 55760, 55936, 11758, 11750, 55761, 55937, 11757, 11749, 57029, 57052, 11791, 56494, 57032, 57053, 11789, 
56495, 56472, 57030, 11790, 11773
21224, 55761, 55937, 11757, 11749, 55762, 55938, 11756, 11748, 57032, 57053, 11789, 56495, 57035, 57054, 11787, 
56496, 56475, 57033, 11788, 11771
21225, 55762, 55938, 11756, 11748, 55763, 55939, 11755, 11747, 57035, 57054, 11787, 56496, 57038, 57055, 11785, 
56497, 56478, 57036, 11786, 11769
21226, 55763, 55939, 11755, 11747, 55764, 55940, 11754, 11746, 57038, 57055, 11785, 56497, 57041, 57056, 11783, 
56498, 56481, 57039, 11784, 11767
21227, 55764, 55940, 11754, 11746, 55765, 55941, 11753, 11745, 57041, 57056, 11783, 56498, 57044, 57057, 11781, 
56499, 56484, 57042, 11782, 11765
21228, 55765, 55941, 11753, 11745, 55766, 55942, 11752, 11744, 57044, 57057, 11781, 56499, 57047, 57058, 11779, 
56500, 56487, 57045, 11780, 11763
21229, 55766, 55942, 11752, 11744, 55767, 55943, 11751, 11743, 57047, 57058, 11779, 56500, 57050, 57059, 11777, 
56501, 56490, 57048, 11778, 11761
21230, 55767, 55943, 11751, 11743, 11608, 11630, 1551, 1550, 57050, 57059, 11777, 56501, 11719, 11720, 1553, 
11675, 56493, 57051, 11776, 11759
21231, 1412, 46, 1487, 11395, 11544, 1533, 12527, 55768, 1415, 1510, 11507, 11463, 11586, 12909, 57060, 
56503, 11578, 1541, 12893, 56502
21232, 11544, 1533, 12527, 55768, 11543, 1534, 12528, 55769, 11586, 12909, 57060, 56503, 11585, 12910, 57061, 
56506, 11577, 1542, 12895, 56505
21233, 11543, 1534, 12528, 55769, 11542, 1535, 12529, 55770, 11585, 12910, 57061, 56506, 11584, 12911, 57062, 
56509, 11575, 1543, 12897, 56508
21234, 11542, 1535, 12529, 55770, 11541, 1536, 12530, 55771, 11584, 12911, 57062, 56509, 11583, 12912, 57063, 
56512, 11573, 1544, 12899, 56511
21235, 11541, 1536, 12530, 55771, 11540, 1537, 12531, 55772, 11583, 12912, 57063, 56512, 11582, 12913, 57064, 
56515, 11571, 1545, 12901, 56514
21236, 11540, 1537, 12531, 55772, 11539, 1538, 12532, 55773, 11582, 12913, 57064, 56515, 11581, 12914, 57065, 
56518, 11569, 1546, 12903, 56517
21237, 11539, 1538, 12532, 55773, 11538, 1539, 12533, 55774, 11581, 12914, 57065, 56518, 11580, 12915, 57066, 
56521, 11567, 1547, 12905, 56520
21238, 11538, 1539, 12533, 55774, 11537, 1540, 12534, 55775, 11580, 12915, 57066, 56521, 11579, 12916, 57067, 
56524, 11565, 1548, 12907, 56523
21239, 11537, 1540, 12534, 55775, 1512, 50, 1621, 11609, 11579, 12916, 57067, 56524, 1515, 1644, 11721, 
11676, 11563, 1549, 12908, 56526
21240, 11395, 1487, 1486, 11396, 55768, 12527, 12519, 55776, 11507, 1509, 11508, 11465, 57060, 12892, 57068, 
56528, 56502, 12893, 12876, 56527
21241, 55768, 12527, 12519, 55776, 55769, 12528, 12520, 55777, 57060, 12892, 57068, 56528, 57061, 12894, 57069, 
56531, 56505, 12895, 12878, 56530
21242, 55769, 12528, 12520, 55777, 55770, 12529, 12521, 55778, 57061, 12894, 57069, 56531, 57062, 12896, 57070, 
56534, 56508, 12897, 12880, 56533
21243, 55770, 12529, 12521, 55778, 55771, 12530, 12522, 55779, 57062, 12896, 57070, 56534, 57063, 12898, 57071, 
56537, 56511, 12899, 12882, 56536
21244, 55771, 12530, 12522, 55779, 55772, 12531, 12523, 55780, 57063, 12898, 57071, 56537, 57064, 12900, 57072, 
56540, 56514, 12901, 12884, 56539
21245, 55772, 12531, 12523, 55780, 55773, 12532, 12524, 55781, 57064, 12900, 57072, 56540, 57065, 12902, 57073, 
56543, 56517, 12903, 12886, 56542
21246, 55773, 12532, 12524, 55781, 55774, 12533, 12525, 55782, 57065, 12902, 57073, 56543, 57066, 12904, 57074, 
56546, 56520, 12905, 12888, 56545
21247, 55774, 12533, 12525, 55782, 55775, 12534, 12526, 55783, 57066, 12904, 57074, 56546, 57067, 12906, 57075, 
56549, 56523, 12907, 12890, 56548
21248, 55775, 12534, 12526, 55783, 11609, 1621, 1620, 11610, 57067, 12906, 57075, 56549, 11721, 1643, 11722, 
11678, 56526, 12908, 12891, 56551
21249, 11396, 1486, 1485, 11397, 55776, 12519, 12511, 55784, 11508, 1508, 11509, 11467, 57068, 12875, 57076, 
56553, 56527, 12876, 12859, 56552
21250, 55776, 12519, 12511, 55784, 55777, 12520, 12512, 55785, 57068, 12875, 57076, 56553, 57069, 12877, 57077, 
56556, 56530, 12878, 12861, 56555
21251, 55777, 12520, 12512, 55785, 55778, 12521, 12513, 55786, 57069, 12877, 57077, 56556, 57070, 12879, 57078, 
56559, 56533, 12880, 12863, 56558
21252, 55778, 12521, 12513, 55786, 55779, 12522, 12514, 55787, 57070, 12879, 57078, 56559, 57071, 12881, 57079, 
56562, 56536, 12882, 12865, 56561
21253, 55779, 12522, 12514, 55787, 55780, 12523, 12515, 55788, 57071, 12881, 57079, 56562, 57072, 12883, 57080, 
56565, 56539, 12884, 12867, 56564
21254, 55780, 12523, 12515, 55788, 55781, 12524, 12516, 55789, 57072, 12883, 57080, 56565, 57073, 12885, 57081, 
56568, 56542, 12886, 12869, 56567
21255, 55781, 12524, 12516, 55789, 55782, 12525, 12517, 55790, 57073, 12885, 57081, 56568, 57074, 12887, 57082, 
56571, 56545, 12888, 12871, 56570
21256, 55782, 12525, 12517, 55790, 55783, 12526, 12518, 55791, 57074, 12887, 57082, 56571, 57075, 12889, 57083, 
56574, 56548, 12890, 12873, 56573
21257, 55783, 12526, 12518, 55791, 11610, 1620, 1619, 11611, 57075, 12889, 57083, 56574, 11722, 1642, 11723, 
11680, 56551, 12891, 12874, 56576
21258, 11397, 1485, 1484, 11398, 55784, 12511, 12503, 55792, 11509, 1507, 11510, 11469, 57076, 12858, 57084, 
56578, 56552, 12859, 12842, 56577
21259, 55784, 12511, 12503, 55792, 55785, 12512, 12504, 55793, 57076, 12858, 57084, 56578, 57077, 12860, 57085, 
56581, 56555, 12861, 12844, 56580
21260, 55785, 12512, 12504, 55793, 55786, 12513, 12505, 55794, 57077, 12860, 57085, 56581, 57078, 12862, 57086, 
56584, 56558, 12863, 12846, 56583
21261, 55786, 12513, 12505, 55794, 55787, 12514, 12506, 55795, 57078, 12862, 57086, 56584, 57079, 12864, 57087, 
56587, 56561, 12865, 12848, 56586
21262, 55787, 12514, 12506, 55795, 55788, 12515, 12507, 55796, 57079, 12864, 57087, 56587, 57080, 12866, 57088, 
56590, 56564, 12867, 12850, 56589
21263, 55788, 12515, 12507, 55796, 55789, 12516, 12508, 55797, 57080, 12866, 57088, 56590, 57081, 12868, 57089, 
56593, 56567, 12869, 12852, 56592
21264, 55789, 12516, 12508, 55797, 55790, 12517, 12509, 55798, 57081, 12868, 57089, 56593, 57082, 12870, 57090, 
56596, 56570, 12871, 12854, 56595
21265, 55790, 12517, 12509, 55798, 55791, 12518, 12510, 55799, 57082, 12870, 57090, 56596, 57083, 12872, 57091, 
56599, 56573, 12873, 12856, 56598
21266, 55791, 12518, 12510, 55799, 11611, 1619, 1618, 11612, 57083, 12872, 57091, 56599, 11723, 1641, 11724, 
11682, 56576, 12874, 12857, 56601
21267, 11398, 1484, 1483, 11399, 55792, 12503, 12495, 55800, 11510, 1506, 11511, 11471, 57084, 12841, 57092, 
56603, 56577, 12842, 12825, 56602
21268, 55792, 12503, 12495, 55800, 55793, 12504, 12496, 55801, 57084, 12841, 57092, 56603, 57085, 12843, 57093, 
56606, 56580, 12844, 12827, 56605
21269, 55793, 12504, 12496, 55801, 55794, 12505, 12497, 55802, 57085, 12843, 57093, 56606, 57086, 12845, 57094, 
56609, 56583, 12846, 12829, 56608
21270, 55794, 12505, 12497, 55802, 55795, 12506, 12498, 55803, 57086, 12845, 57094, 56609, 57087, 12847, 57095, 
56612, 56586, 12848, 12831, 56611
21271, 55795, 12506, 12498, 55803, 55796, 12507, 12499, 55804, 57087, 12847, 57095, 56612, 57088, 12849, 57096, 
56615, 56589, 12850, 12833, 56614
21272, 55796, 12507, 12499, 55804, 55797, 12508, 12500, 55805, 57088, 12849, 57096, 56615, 57089, 12851, 57097, 
56618, 56592, 12852, 12835, 56617
21273, 55797, 12508, 12500, 55805, 55798, 12509, 12501, 55806, 57089, 12851, 57097, 56618, 57090, 12853, 57098, 
56621, 56595, 12854, 12837, 56620
21274, 55798, 12509, 12501, 55806, 55799, 12510, 12502, 55807, 57090, 12853, 57098, 56621, 57091, 12855, 57099, 
56624, 56598, 12856, 12839, 56623
21275, 55799, 12510, 12502, 55807, 11612, 1618, 1617, 11613, 57091, 12855, 57099, 56624, 11724, 1640, 11725, 
11684, 56601, 12857, 12840, 56626
21276, 11399, 1483, 1482, 11400, 55800, 12495, 12487, 55808, 11511, 1505, 11512, 11473, 57092, 12824, 57100, 
56628, 56602, 12825, 12808, 56627
21277, 55800, 12495, 12487, 55808, 55801, 12496, 12488, 55809, 57092, 12824, 57100, 56628, 57093, 12826, 57101, 
56631, 56605, 12827, 12810, 56630
21278, 55801, 12496, 12488, 55809, 55802, 12497, 12489, 55810, 57093, 12826, 57101, 56631, 57094, 12828, 57102, 
56634, 56608, 12829, 12812, 56633
21279, 55802, 12497, 12489, 55810, 55803, 12498, 12490, 55811, 57094, 12828, 57102, 56634, 57095, 12830, 57103, 
56637, 56611, 12831, 12814, 56636
21280, 55803, 12498, 12490, 55811, 55804, 12499, 12491, 55812, 57095, 12830, 57103, 56637, 57096, 12832, 57104, 
56640, 56614, 12833, 12816, 56639
21281, 55804, 12499, 12491, 55812, 55805, 12500, 12492, 55813, 57096, 12832, 57104, 56640, 57097, 12834, 57105, 
56643, 56617, 12835, 12818, 56642
21282, 55805, 12500, 12492, 55813, 55806, 12501, 12493, 55814, 57097, 12834, 57105, 56643, 57098, 12836, 57106, 
56646, 56620, 12837, 12820, 56645
21283, 55806, 12501, 12493, 55814, 55807, 12502, 12494, 55815, 57098, 12836, 57106, 56646, 57099, 12838, 57107, 
56649, 56623, 12839, 12822, 56648
21284, 55807, 12502, 12494, 55815, 11613, 1617, 1616, 11614, 57099, 12838, 57107, 56649, 11725, 1639, 11726, 
11686, 56626, 12840, 12823, 56651
21285, 11400, 1482, 1481, 11401, 55808, 12487, 12479, 55816, 11512, 1504, 11513, 11475, 57100, 12807, 57108, 
56653, 56627, 12808, 12791, 56652
21286, 55808, 12487, 12479, 55816, 55809, 12488, 12480, 55817, 57100, 12807, 57108, 56653, 57101, 12809, 57109, 
56656, 56630, 12810, 12793, 56655
21287, 55809, 12488, 12480, 55817, 55810, 12489, 12481, 55818, 57101, 12809, 57109, 56656, 57102, 12811, 57110, 
56659, 56633, 12812, 12795, 56658
21288, 55810, 12489, 12481, 55818, 55811, 12490, 12482, 55819, 57102, 12811, 57110, 56659, 57103, 12813, 57111, 
56662, 56636, 12814, 12797, 56661
21289, 55811, 12490, 12482, 55819, 55812, 12491, 12483, 55820, 57103, 12813, 57111, 56662, 57104, 12815, 57112, 
56665, 56639, 12816, 12799, 56664
21290, 55812, 12491, 12483, 55820, 55813, 12492, 12484, 55821, 57104, 12815, 57112, 56665, 57105, 12817, 57113, 
56668, 56642, 12818, 12801, 56667
21291, 55813, 12492, 12484, 55821, 55814, 12493, 12485, 55822, 57105, 12817, 57113, 56668, 57106, 12819, 57114, 
56671, 56645, 12820, 12803, 56670
21292, 55814, 12493, 12485, 55822, 55815, 12494, 12486, 55823, 57106, 12819, 57114, 56671, 57107, 12821, 57115, 
56674, 56648, 12822, 12805, 56673
21293, 55815, 12494, 12486, 55823, 11614, 1616, 1615, 11615, 57107, 12821, 57115, 56674, 11726, 1638, 11727, 
11688, 56651, 12823, 12806, 56676
21294, 11401, 1481, 1480, 11402, 55816, 12479, 12471, 55824, 11513, 1503, 11514, 11477, 57108, 12790, 57116, 
56678, 56652, 12791, 12774, 56677
21295, 55816, 12479, 12471, 55824, 55817, 12480, 12472, 55825, 57108, 12790, 57116, 56678, 57109, 12792, 57117, 
56681, 56655, 12793, 12776, 56680
21296, 55817, 12480, 12472, 55825, 55818, 12481, 12473, 55826, 57109, 12792, 57117, 56681, 57110, 12794, 57118, 
56684, 56658, 12795, 12778, 56683
21297, 55818, 12481, 12473, 55826, 55819, 12482, 12474, 55827, 57110, 12794, 57118, 56684, 57111, 12796, 57119, 
56687, 56661, 12797, 12780, 56686
21298, 55819, 12482, 12474, 55827, 55820, 12483, 12475, 55828, 57111, 12796, 57119, 56687, 57112, 12798, 57120, 
56690, 56664, 12799, 12782, 56689
21299, 55820, 12483, 12475, 55828, 55821, 12484, 12476, 55829, 57112, 12798, 57120, 56690, 57113, 12800, 57121, 
56693, 56667, 12801, 12784, 56692
21300, 55821, 12484, 12476, 55829, 55822, 12485, 12477, 55830, 57113, 12800, 57121, 56693, 57114, 12802, 57122, 
56696, 56670, 12803, 12786, 56695
21301, 55822, 12485, 12477, 55830, 55823, 12486, 12478, 55831, 57114, 12802, 57122, 56696, 57115, 12804, 57123, 
56699, 56673, 12805, 12788, 56698
21302, 55823, 12486, 12478, 55831, 11615, 1615, 1614, 11616, 57115, 12804, 57123, 56699, 11727, 1637, 11728, 
11690, 56676, 12806, 12789, 56701
21303, 11402, 1480, 1479, 11403, 55824, 12471, 12463, 55832, 11514, 1502, 11515, 11479, 57116, 12773, 57124, 
56703, 56677, 12774, 12757, 56702
21304, 55824, 12471, 12463, 55832, 55825, 12472, 12464, 55833, 57116, 12773, 57124, 56703, 57117, 12775, 57125, 
56706, 56680, 12776, 12759, 56705
21305, 55825, 12472, 12464, 55833, 55826, 12473, 12465, 55834, 57117, 12775, 57125, 56706, 57118, 12777, 57126, 
56709, 56683, 12778, 12761, 56708
21306, 55826, 12473, 12465, 55834, 55827, 12474, 12466, 55835, 57118, 12777, 57126, 56709, 57119, 12779, 57127, 
56712, 56686, 12780, 12763, 56711
21307, 55827, 12474, 12466, 55835, 55828, 12475, 12467, 55836, 57119, 12779, 57127, 56712, 57120, 12781, 57128, 
56715, 56689, 12782, 12765, 56714
21308, 55828, 12475, 12467, 55836, 55829, 12476, 12468, 55837, 57120, 12781, 57128, 56715, 57121, 12783, 57129, 
56718, 56692, 12784, 12767, 56717
21309, 55829, 12476, 12468, 55837, 55830, 12477, 12469, 55838, 57121, 12783, 57129, 56718, 57122, 12785, 57130, 
56721, 56695, 12786, 12769, 56720
21310, 55830, 12477, 12469, 55838, 55831, 12478, 12470, 55839, 57122, 12785, 57130, 56721, 57123, 12787, 57131, 
56724, 56698, 12788, 12771, 56723
21311, 55831, 12478, 12470, 55839, 11616, 1614, 1613, 11617, 57123, 12787, 57131, 56724, 11728, 1636, 11729, 
11692, 56701, 12789, 12772, 56726
21312, 11403, 1479, 1478, 11404, 55832, 12463, 12455, 55840, 11515, 1501, 11516, 11481, 57124, 12756, 57132, 
56728, 56702, 12757, 12740, 56727
21313, 55832, 12463, 12455, 55840, 55833, 12464, 12456, 55841, 57124, 12756, 57132, 56728, 57125, 12758, 57133, 
56731, 56705, 12759, 12742, 56730
21314, 55833, 12464, 12456, 55841, 55834, 12465, 12457, 55842, 57125, 12758, 57133, 56731, 57126, 12760, 57134, 
56734, 56708, 12761, 12744, 56733
21315, 55834, 12465, 12457, 55842, 55835, 12466, 12458, 55843, 57126, 12760, 57134, 56734, 57127, 12762, 57135, 
56737, 56711, 12763, 12746, 56736
21316, 55835, 12466, 12458, 55843, 55836, 12467, 12459, 55844, 57127, 12762, 57135, 56737, 57128, 12764, 57136, 
56740, 56714, 12765, 12748, 56739
21317, 55836, 12467, 12459, 55844, 55837, 12468, 12460, 55845, 57128, 12764, 57136, 56740, 57129, 12766, 57137, 
56743, 56717, 12767, 12750, 56742
21318, 55837, 12468, 12460, 55845, 55838, 12469, 12461, 55846, 57129, 12766, 57137, 56743, 57130, 12768, 57138, 
56746, 56720, 12769, 12752, 56745
21319, 55838, 12469, 12461, 55846, 55839, 12470, 12462, 55847, 57130, 12768, 57138, 56746, 57131, 12770, 57139, 
56749, 56723, 12771, 12754, 56748
21320, 55839, 12470, 12462, 55847, 11617, 1613, 1612, 11618, 57131, 12770, 57139, 56749, 11729, 1635, 11730, 
11694, 56726, 12772, 12755, 56751
21321, 11404, 1478, 1477, 11405, 55840, 12455, 12447, 55848, 11516, 1500, 11517, 11483, 57132, 12739, 57140, 
56753, 56727, 12740, 12723, 56752
21322, 55840, 12455, 12447, 55848, 55841, 12456, 12448, 55849, 57132, 12739, 57140, 56753, 57133, 12741, 57141, 
56756, 56730, 12742, 12725, 56755
21323, 55841, 12456, 12448, 55849, 55842, 12457, 12449, 55850, 57133, 12741, 57141, 56756, 57134, 12743, 57142, 
56759, 56733, 12744, 12727, 56758
21324, 55842, 12457, 12449, 55850, 55843, 12458, 12450, 55851, 57134, 12743, 57142, 56759, 57135, 12745, 57143, 
56762, 56736, 12746, 12729, 56761
21325, 55843, 12458, 12450, 55851, 55844, 12459, 12451, 55852, 57135, 12745, 57143, 56762, 57136, 12747, 57144, 
56765, 56739, 12748, 12731, 56764
21326, 55844, 12459, 12451, 55852, 55845, 12460, 12452, 55853, 57136, 12747, 57144, 56765, 57137, 12749, 57145, 
56768, 56742, 12750, 12733, 56767
21327, 55845, 12460, 12452, 55853, 55846, 12461, 12453, 55854, 57137, 12749, 57145, 56768, 57138, 12751, 57146, 
56771, 56745, 12752, 12735, 56770
21328, 55846, 12461, 12453, 55854, 55847, 12462, 12454, 55855, 57138, 12751, 57146, 56771, 57139, 12753, 57147, 
56774, 56748, 12754, 12737, 56773
21329, 55847, 12462, 12454, 55855, 11618, 1612, 1611, 11619, 57139, 12753, 57147, 56774, 11730, 1634, 11731, 
11696, 56751, 12755, 12738, 56776
21330, 11405, 1477, 1476, 11406, 55848, 12447, 12439, 55856, 11517, 1499, 11518, 11485, 57140, 12722, 57148, 
56778, 56752, 12723, 12706, 56777
21331, 55848, 12447, 12439, 55856, 55849, 12448, 12440, 55857, 57140, 12722, 57148, 56778, 57141, 12724, 57149, 
56781, 56755, 12725, 12708, 56780
21332, 55849, 12448, 12440, 55857, 55850, 12449, 12441, 55858, 57141, 12724, 57149, 56781, 57142, 12726, 57150, 
56784, 56758, 12727, 12710, 56783
21333, 55850, 12449, 12441, 55858, 55851, 12450, 12442, 55859, 57142, 12726, 57150, 56784, 57143, 12728, 57151, 
56787, 56761, 12729, 12712, 56786
21334, 55851, 12450, 12442, 55859, 55852, 12451, 12443, 55860, 57143, 12728, 57151, 56787, 57144, 12730, 57152, 
56790, 56764, 12731, 12714, 56789
21335, 55852, 12451, 12443, 55860, 55853, 12452, 12444, 55861, 57144, 12730, 57152, 56790, 57145, 12732, 57153, 
56793, 56767, 12733, 12716, 56792
21336, 55853, 12452, 12444, 55861, 55854, 12453, 12445, 55862, 57145, 12732, 57153, 56793, 57146, 12734, 57154, 
56796, 56770, 12735, 12718, 56795
21337, 55854, 12453, 12445, 55862, 55855, 12454, 12446, 55863, 57146, 12734, 57154, 56796, 57147, 12736, 57155, 
56799, 56773, 12737, 12720, 56798
21338, 55855, 12454, 12446, 55863, 11619, 1611, 1610, 11620, 57147, 12736, 57155, 56799, 11731, 1633, 11732, 
11698, 56776, 12738, 12721, 56801
21339, 11406, 1476, 1475, 11407, 55856, 12439, 12431, 55864, 11518, 1498, 11519, 11487, 57148, 12705, 57156, 
56803, 56777, 12706, 12689, 56802
21340, 55856, 12439, 12431, 55864, 55857, 12440, 12432, 55865, 57148, 12705, 57156, 56803, 57149, 12707, 57157, 
56806, 56780, 12708, 12691, 56805
21341, 55857, 12440, 12432, 55865, 55858, 12441, 12433, 55866, 57149, 12707, 57157, 56806, 57150, 12709, 57158, 
56809, 56783, 12710, 12693, 56808
21342, 55858, 12441, 12433, 55866, 55859, 12442, 12434, 55867, 57150, 12709, 57158, 56809, 57151, 12711, 57159, 
56812, 56786, 12712, 12695, 56811
21343, 55859, 12442, 12434, 55867, 55860, 12443, 12435, 55868, 57151, 12711, 57159, 56812, 57152, 12713, 57160, 
56815, 56789, 12714, 12697, 56814
21344, 55860, 12443, 12435, 55868, 55861, 12444, 12436, 55869, 57152, 12713, 57160, 56815, 57153, 12715, 57161, 
56818, 56792, 12716, 12699, 56817
21345, 55861, 12444, 12436, 55869, 55862, 12445, 12437, 55870, 57153, 12715, 57161, 56818, 57154, 12717, 57162, 
56821, 56795, 12718, 12701, 56820
21346, 55862, 12445, 12437, 55870, 55863, 12446, 12438, 55871, 57154, 12717, 57162, 56821, 57155, 12719, 57163, 
56824, 56798, 12720, 12703, 56823
21347, 55863, 12446, 12438, 55871, 11620, 1610, 1609, 11621, 57155, 12719, 57163, 56824, 11732, 1632, 11733, 
11700, 56801, 12721, 12704, 56826
21348, 11407, 1475, 1474, 11408, 55864, 12431, 12423, 55872, 11519, 1497, 11520, 11489, 57156, 12688, 57164, 
56828, 56802, 12689, 12672, 56827
21349, 55864, 12431, 12423, 55872, 55865, 12432, 12424, 55873, 57156, 12688, 57164, 56828, 57157, 12690, 57165, 
56831, 56805, 12691, 12674, 56830
21350, 55865, 12432, 12424, 55873, 55866, 12433, 12425, 55874, 57157, 12690, 57165, 56831, 57158, 12692, 57166, 
56834, 56808, 12693, 12676, 56833
21351, 55866, 12433, 12425, 55874, 55867, 12434, 12426, 55875, 57158, 12692, 57166, 56834, 57159, 12694, 57167, 
56837, 56811, 12695, 12678, 56836
21352, 55867, 12434, 12426, 55875, 55868, 12435, 12427, 55876, 57159, 12694, 57167, 56837, 57160, 12696, 57168, 
56840, 56814, 12697, 12680, 56839
21353, 55868, 12435, 12427, 55876, 55869, 12436, 12428, 55877, 57160, 12696, 57168, 56840, 57161, 12698, 57169, 
56843, 56817, 12699, 12682, 56842
21354, 55869, 12436, 12428, 55877, 55870, 12437, 12429, 55878, 57161, 12698, 57169, 56843, 57162, 12700, 57170, 
56846, 56820, 12701, 12684, 56845
21355, 55870, 12437, 12429, 55878, 55871, 12438, 12430, 55879, 57162, 12700, 57170, 56846, 57163, 12702, 57171, 
56849, 56823, 12703, 12686, 56848
21356, 55871, 12438, 12430, 55879, 11621, 1609, 1608, 11622, 57163, 12702, 57171, 56849, 11733, 1631, 11734, 
11702, 56826, 12704, 12687, 56851
21357, 11408, 1474, 1473, 11409, 55872, 12423, 12415, 55880, 11520, 1496, 11521, 11491, 57164, 12671, 57172, 
56853, 56827, 12672, 12655, 56852
21358, 55872, 12423, 12415, 55880, 55873, 12424, 12416, 55881, 57164, 12671, 57172, 56853, 57165, 12673, 57173, 
56856, 56830, 12674, 12657, 56855
21359, 55873, 12424, 12416, 55881, 55874, 12425, 12417, 55882, 57165, 12673, 57173, 56856, 57166, 12675, 57174, 
56859, 56833, 12676, 12659, 56858
21360, 55874, 12425, 12417, 55882, 55875, 12426, 12418, 55883, 57166, 12675, 57174, 56859, 57167, 12677, 57175, 
56862, 56836, 12678, 12661, 56861
21361, 55875, 12426, 12418, 55883, 55876, 12427, 12419, 55884, 57167, 12677, 57175, 56862, 57168, 12679, 57176, 
56865, 56839, 12680, 12663, 56864
21362, 55876, 12427, 12419, 55884, 55877, 12428, 12420, 55885, 57168, 12679, 57176, 56865, 57169, 12681, 57177, 
56868, 56842, 12682, 12665, 56867
21363, 55877, 12428, 12420, 55885, 55878, 12429, 12421, 55886, 57169, 12681, 57177, 56868, 57170, 12683, 57178, 
56871, 56845, 12684, 12667, 56870
21364, 55878, 12429, 12421, 55886, 55879, 12430, 12422, 55887, 57170, 12683, 57178, 56871, 57171, 12685, 57179, 
56874, 56848, 12686, 12669, 56873
21365, 55879, 12430, 12422, 55887, 11622, 1608, 1607, 11623, 57171, 12685, 57179, 56874, 11734, 1630, 11735, 
11704, 56851, 12687, 12670, 56876
21366, 11409, 1473, 1472, 11410, 55880, 12415, 12407, 55888, 11521, 1495, 11522, 11493, 57172, 12654, 57180, 
56878, 56852, 12655, 12638, 56877
21367, 55880, 12415, 12407, 55888, 55881, 12416, 12408, 55889, 57172, 12654, 57180, 56878, 57173, 12656, 57181, 
56881, 56855, 12657, 12640, 56880
21368, 55881, 12416, 12408, 55889, 55882, 12417, 12409, 55890, 57173, 12656, 57181, 56881, 57174, 12658, 57182, 
56884, 56858, 12659, 12642, 56883
21369, 55882, 12417, 12409, 55890, 55883, 12418, 12410, 55891, 57174, 12658, 57182, 56884, 57175, 12660, 57183, 
56887, 56861, 12661, 12644, 56886
21370, 55883, 12418, 12410, 55891, 55884, 12419, 12411, 55892, 57175, 12660, 57183, 56887, 57176, 12662, 57184, 
56890, 56864, 12663, 12646, 56889
21371, 55884, 12419, 12411, 55892, 55885, 12420, 12412, 55893, 57176, 12662, 57184, 56890, 57177, 12664, 57185, 
56893, 56867, 12665, 12648, 56892
21372, 55885, 12420, 12412, 55893, 55886, 12421, 12413, 55894, 57177, 12664, 57185, 56893, 57178, 12666, 57186, 
56896, 56870, 12667, 12650, 56895
21373, 55886, 12421, 12413, 55894, 55887, 12422, 12414, 55895, 57178, 12666, 57186, 56896, 57179, 12668, 57187, 
56899, 56873, 12669, 12652, 56898
21374, 55887, 12422, 12414, 55895, 11623, 1607, 1606, 11624, 57179, 12668, 57187, 56899, 11735, 1629, 11736, 
11706, 56876, 12670, 12653, 56901
21375, 11410, 1472, 1471, 11411, 55888, 12407, 12399, 55896, 11522, 1494, 11523, 11495, 57180, 12637, 57188, 
56903, 56877, 12638, 12621, 56902
21376, 55888, 12407, 12399, 55896, 55889, 12408, 12400, 55897, 57180, 12637, 57188, 56903, 57181, 12639, 57189, 
56906, 56880, 12640, 12623, 56905
21377, 55889, 12408, 12400, 55897, 55890, 12409, 12401, 55898, 57181, 12639, 57189, 56906, 57182, 12641, 57190, 
56909, 56883, 12642, 12625, 56908
21378, 55890, 12409, 12401, 55898, 55891, 12410, 12402, 55899, 57182, 12641, 57190, 56909, 57183, 12643, 57191, 
56912, 56886, 12644, 12627, 56911
21379, 55891, 12410, 12402, 55899, 55892, 12411, 12403, 55900, 57183, 12643, 57191, 56912, 57184, 12645, 57192, 
56915, 56889, 12646, 12629, 56914
21380, 55892, 12411, 12403, 55900, 55893, 12412, 12404, 55901, 57184, 12645, 57192, 56915, 57185, 12647, 57193, 
56918, 56892, 12648, 12631, 56917
21381, 55893, 12412, 12404, 55901, 55894, 12413, 12405, 55902, 57185, 12647, 57193, 56918, 57186, 12649, 57194, 
56921, 56895, 12650, 12633, 56920
21382, 55894, 12413, 12405, 55902, 55895, 12414, 12406, 55903, 57186, 12649, 57194, 56921, 57187, 12651, 57195, 
56924, 56898, 12652, 12635, 56923
21383, 55895, 12414, 12406, 55903, 11624, 1606, 1605, 11625, 57187, 12651, 57195, 56924, 11736, 1628, 11737, 
11708, 56901, 12653, 12636, 56926
21384, 11411, 1471, 1470, 11412, 55896, 12399, 12391, 55904, 11523, 1493, 11524, 11497, 57188, 12620, 57196, 
56928, 56902, 12621, 12604, 56927
21385, 55896, 12399, 12391, 55904, 55897, 12400, 12392, 55905, 57188, 12620, 57196, 56928, 57189, 12622, 57197, 
56931, 56905, 12623, 12606, 56930
21386, 55897, 12400, 12392, 55905, 55898, 12401, 12393, 55906, 57189, 12622, 57197, 56931, 57190, 12624, 57198, 
56934, 56908, 12625, 12608, 56933
21387, 55898, 12401, 12393, 55906, 55899, 12402, 12394, 55907, 57190, 12624, 57198, 56934, 57191, 12626, 57199, 
56937, 56911, 12627, 12610, 56936
21388, 55899, 12402, 12394, 55907, 55900, 12403, 12395, 55908, 57191, 12626, 57199, 56937, 57192, 12628, 57200, 
56940, 56914, 12629, 12612, 56939
21389, 55900, 12403, 12395, 55908, 55901, 12404, 12396, 55909, 57192, 12628, 57200, 56940, 57193, 12630, 57201, 
56943, 56917, 12631, 12614, 56942
21390, 55901, 12404, 12396, 55909, 55902, 12405, 12397, 55910, 57193, 12630, 57201, 56943, 57194, 12632, 57202, 
56946, 56920, 12633, 12616, 56945
21391, 55902, 12405, 12397, 55910, 55903, 12406, 12398, 55911, 57194, 12632, 57202, 56946, 57195, 12634, 57203, 
56949, 56923, 12635, 12618, 56948
21392, 55903, 12406, 12398, 55911, 11625, 1605, 1604, 11626, 57195, 12634, 57203, 56949, 11737, 1627, 11738, 
11710, 56926, 12636, 12619, 56951
21393, 11412, 1470, 1469, 11413, 55904, 12391, 12383, 55912, 11524, 1492, 11525, 11499, 57196, 12603, 57204, 
56953, 56927, 12604, 12587, 56952
21394, 55904, 12391, 12383, 55912, 55905, 12392, 12384, 55913, 57196, 12603, 57204, 56953, 57197, 12605, 57205, 
56956, 56930, 12606, 12589, 56955
21395, 55905, 12392, 12384, 55913, 55906, 12393, 12385, 55914, 57197, 12605, 57205, 56956, 57198, 12607, 57206, 
56959, 56933, 12608, 12591, 56958
21396, 55906, 12393, 12385, 55914, 55907, 12394, 12386, 55915, 57198, 12607, 57206, 56959, 57199, 12609, 57207, 
56962, 56936, 12610, 12593, 56961
21397, 55907, 12394, 12386, 55915, 55908, 12395, 12387, 55916, 57199, 12609, 57207, 56962, 57200, 12611, 57208, 
56965, 56939, 12612, 12595, 56964
21398, 55908, 12395, 12387, 55916, 55909, 12396, 12388, 55917, 57200, 12611, 57208, 56965, 57201, 12613, 57209, 
56968, 56942, 12614, 12597, 56967
21399, 55909, 12396, 12388, 55917, 55910, 12397, 12389, 55918, 57201, 12613, 57209, 56968, 57202, 12615, 57210, 
56971, 56945, 12616, 12599, 56970
21400, 55910, 12397, 12389, 55918, 55911, 12398, 12390, 55919, 57202, 12615, 57210, 56971, 57203, 12617, 57211, 
56974, 56948, 12618, 12601, 56973
21401, 55911, 12398, 12390, 55919, 11626, 1604, 1603, 11627, 57203, 12617, 57211, 56974, 11738, 1626, 11739, 
11712, 56951, 12619, 12602, 56976
21402, 11413, 1469, 1468, 11414, 55912, 12383, 12375, 55920, 11525, 1491, 11526, 11501, 57204, 12586, 57212, 
56978, 56952, 12587, 12570, 56977
21403, 55912, 12383, 12375, 55920, 55913, 12384, 12376, 55921, 57204, 12586, 57212, 56978, 57205, 12588, 57213, 
56981, 56955, 12589, 12572, 56980
21404, 55913, 12384, 12376, 55921, 55914, 12385, 12377, 55922, 57205, 12588, 57213, 56981, 57206, 12590, 57214, 
56984, 56958, 12591, 12574, 56983
21405, 55914, 12385, 12377, 55922, 55915, 12386, 12378, 55923, 57206, 12590, 57214, 56984, 57207, 12592, 57215, 
56987, 56961, 12593, 12576, 56986
21406, 55915, 12386, 12378, 55923, 55916, 12387, 12379, 55924, 57207, 12592, 57215, 56987, 57208, 12594, 57216, 
56990, 56964, 12595, 12578, 56989
21407, 55916, 12387, 12379, 55924, 55917, 12388, 12380, 55925, 57208, 12594, 57216, 56990, 57209, 12596, 57217, 
56993, 56967, 12597, 12580, 56992
21408, 55917, 12388, 12380, 55925, 55918, 12389, 12381, 55926, 57209, 12596, 57217, 56993, 57210, 12598, 57218, 
56996, 56970, 12599, 12582, 56995
21409, 55918, 12389, 12381, 55926, 55919, 12390, 12382, 55927, 57210, 12598, 57218, 56996, 57211, 12600, 57219, 
56999, 56973, 12601, 12584, 56998
21410, 55919, 12390, 12382, 55927, 11627, 1603, 1602, 11628, 57211, 12600, 57219, 56999, 11739, 1625, 11740, 
11714, 56976, 12602, 12585, 57001
21411, 11414, 1468, 1467, 11415, 55920, 12375, 12367, 55928, 11526, 1490, 11527, 11503, 57212, 12569, 57220, 
57003, 56977, 12570, 12553, 57002
21412, 55920, 12375, 12367, 55928, 55921, 12376, 12368, 55929, 57212, 12569, 57220, 57003, 57213, 12571, 57221, 
57006, 56980, 12572, 12555, 57005
21413, 55921, 12376, 12368, 55929, 55922, 12377, 12369, 55930, 57213, 12571, 57221, 57006, 57214, 12573, 57222, 
57009, 56983, 12574, 12557, 57008
21414, 55922, 12377, 12369, 55930, 55923, 12378, 12370, 55931, 57214, 12573, 57222, 57009, 57215, 12575, 57223, 
57012, 56986, 12576, 12559, 57011
21415, 55923, 12378, 12370, 55931, 55924, 12379, 12371, 55932, 57215, 12575, 57223, 57012, 57216, 12577, 57224, 
57015, 56989, 12578, 12561, 57014
21416, 55924, 12379, 12371, 55932, 55925, 12380, 12372, 55933, 57216, 12577, 57224, 57015, 57217, 12579, 57225, 
57018, 56992, 12580, 12563, 57017
21417, 55925, 12380, 12372, 55933, 55926, 12381, 12373, 55934, 57217, 12579, 57225, 57018, 57218, 12581, 57226, 
57021, 56995, 12582, 12565, 57020
21418, 55926, 12381, 12373, 55934, 55927, 12382, 12374, 55935, 57218, 12581, 57226, 57021, 57219, 12583, 57227, 
57024, 56998, 12584, 12567, 57023
21419, 55927, 12382, 12374, 55935, 11628, 1602, 1601, 11629, 57219, 12583, 57227, 57024, 11740, 1624, 11741, 
11716, 57001, 12585, 12568, 57026
21420, 11415, 1467, 1466, 11416, 55928, 12367, 12359, 55936, 11527, 1489, 11528, 11505, 57220, 12552, 57228, 
57028, 57002, 12553, 12536, 57027
21421, 55928, 12367, 12359, 55936, 55929, 12368, 12360, 55937, 57220, 12552, 57228, 57028, 57221, 12554, 57229, 
57031, 57005, 12555, 12538, 57030
21422, 55929, 12368, 12360, 55937, 55930, 12369, 12361, 55938, 57221, 12554, 57229, 57031, 57222, 12556, 57230, 
57034, 57008, 12557, 12540, 57033
21423, 55930, 12369, 12361, 55938, 55931, 12370, 12362, 55939, 57222, 12556, 57230, 57034, 57223, 12558, 57231, 
57037, 57011, 12559, 12542, 57036
21424, 55931, 12370, 12362, 55939, 55932, 12371, 12363, 55940, 57223, 12558, 57231, 57037, 57224, 12560, 57232, 
57040, 57014, 12561, 12544, 57039
21425, 55932, 12371, 12363, 55940, 55933, 12372, 12364, 55941, 57224, 12560, 57232, 57040, 57225, 12562, 57233, 
57043, 57017, 12563, 12546, 57042
21426, 55933, 12372, 12364, 55941, 55934, 12373, 12365, 55942, 57225, 12562, 57233, 57043, 57226, 12564, 57234, 
57046, 57020, 12565, 12548, 57045
21427, 55934, 12373, 12365, 55942, 55935, 12374, 12366, 55943, 57226, 12564, 57234, 57046, 57227, 12566, 57235, 
57049, 57023, 12567, 12550, 57048
21428, 55935, 12374, 12366, 55943, 11629, 1601, 1600, 11630, 57227, 12566, 57235, 57049, 11741, 1623, 11742, 
11718, 57026, 12568, 12551, 57051
21429, 11416, 1466, 48, 1417, 55936, 12359, 1662, 11758, 11528, 1488, 1420, 11506, 57228, 12535, 11800, 
57052, 57027, 12536, 1670, 11792
21430, 55936, 12359, 1662, 11758, 55937, 12360, 1663, 11757, 57228, 12535, 11800, 57052, 57229, 12537, 11799, 
57053, 57030, 12538, 1671, 11790
21431, 55937, 12360, 1663, 11757, 55938, 12361, 1664, 11756, 57229, 12537, 11799, 57053, 57230, 12539, 11798, 
57054, 57033, 12540, 1672, 11788
21432, 55938, 12361, 1664, 11756, 55939, 12362, 1665, 11755, 57230, 12539, 11798, 57054, 57231, 12541, 11797, 
57055, 57036, 12542, 1673, 11786
21433, 55939, 12362, 1665, 11755, 55940, 12363, 1666, 11754, 57231, 12541, 11797, 57055, 57232, 12543, 11796, 
57056, 57039, 12544, 1674, 11784
21434, 55940, 12363, 1666, 11754, 55941, 12364, 1667, 11753, 57232, 12543, 11796, 57056, 57233, 12545, 11795, 
57057, 57042, 12546, 1675, 11782
21435, 55941, 12364, 1667, 11753, 55942, 12365, 1668, 11752, 57233, 12545, 11795, 57057, 57234, 12547, 11794, 
57058, 57045, 12548, 1676, 11780
21436, 55942, 12365, 1668, 11752, 55943, 12366, 1669, 11751, 57234, 12547, 11794, 57058, 57235, 12549, 11793, 
57059, 57048, 12550, 1677, 11778
21437, 55943, 12366, 1669, 11751, 11630, 1600, 52, 1551, 57235, 12549, 11793, 57059, 11742, 1622, 1554, 
11720, 57051, 12551, 1678, 11776
*ELEMENT, type=C3D20, ELSET=Volume6
21438, 12917, 1679, 49, 1511, 57236, 12963, 1523, 11529, 12923, 1682, 1513, 12924, 57285, 12987, 11545, 
57286, 57284, 12988, 1532, 11546
21439, 57236, 12963, 1523, 11529, 57237, 12964, 1522, 11530, 57285, 12987, 11545, 57286, 57288, 12989, 11547, 
57289, 57287, 12990, 1531, 11548
21440, 57237, 12964, 1522, 11530, 57238, 12965, 1521, 11531, 57288, 12989, 11547, 57289, 57291, 12991, 11549, 
57292, 57290, 12992, 1530, 11550
21441, 57238, 12965, 1521, 11531, 57239, 12966, 1520, 11532, 57291, 12991, 11549, 57292, 57294, 12993, 11551, 
57295, 57293, 12994, 1529, 11552
21442, 57239, 12966, 1520, 11532, 57240, 12967, 1519, 11533, 57294, 12993, 11551, 57295, 57297, 12995, 11553, 
57298, 57296, 12996, 1528, 11554
21443, 57240, 12967, 1519, 11533, 57241, 12968, 1518, 11534, 57297, 12995, 11553, 57298, 57300, 12997, 11555, 
57301, 57299, 12998, 1527, 11556
21444, 57241, 12968, 1518, 11534, 57242, 12969, 1517, 11535, 57300, 12997, 11555, 57301, 57303, 12999, 11557, 
57304, 57302, 13000, 1526, 11558
21445, 57242, 12969, 1517, 11535, 57243, 12970, 1516, 11536, 57303, 12999, 11557, 57304, 57306, 13001, 11559, 
57307, 57305, 13002, 1525, 11560
21446, 57243, 12970, 1516, 11536, 12940, 1698, 45, 1411, 57306, 13001, 11559, 57307, 12947, 1701, 1413, 
12946, 57308, 13003, 1524, 11561
21447, 12918, 12917, 1511, 1512, 57244, 57236, 11529, 11537, 12925, 12924, 1514, 12926, 57310, 57286, 11562, 
57311, 57309, 57284, 11546, 11563
21448, 57244, 57236, 11529, 11537, 57245, 57237, 11530, 11538, 57310, 57286, 11562, 57311, 57313, 57289, 11564, 
57314, 57312, 57287, 11548, 11565
21449, 57245, 57237, 11530, 11538, 57246, 57238, 11531, 11539, 57313, 57289, 11564, 57314, 57316, 57292, 11566, 
57317, 57315, 57290, 11550, 11567
21450, 57246, 57238, 11531, 11539, 57247, 57239, 11532, 11540, 57316, 57292, 11566, 57317, 57319, 57295, 11568, 
57320, 57318, 57293, 11552, 11569
21451, 57247, 57239, 11532, 11540, 57248, 57240, 11533, 11541, 57319, 57295, 11568, 57320, 57322, 57298, 11570, 
57323, 57321, 57296, 11554, 11571
21452, 57248, 57240, 11533, 11541, 57249, 57241, 11534, 11542, 57322, 57298, 11570, 57323, 57325, 57301, 11572, 
57326, 57324, 57299, 11556, 11573
21453, 57249, 57241, 11534, 11542, 57250, 57242, 11535, 11543, 57325, 57301, 11572, 57326, 57328, 57304, 11574, 
57329, 57327, 57302, 11558, 11575
21454, 57250, 57242, 11535, 11543, 57251, 57243, 11536, 11544, 57328, 57304, 11574, 57329, 57331, 57307, 11576, 
57332, 57330, 57305, 11560, 11577
21455, 57251, 57243, 11536, 11544, 12941, 12940, 1411, 1412, 57331, 57307, 11576, 57332, 12949, 12946, 1414, 
12948, 57333, 57308, 11561, 11578
21456, 1686, 12918, 1512, 50, 13046, 57244, 11537, 1540, 12927, 12926, 1515, 1689, 57334, 57311, 11579, 
13071, 13070, 57309, 11563, 1549
21457, 13046, 57244, 11537, 1540, 13047, 57245, 11538, 1539, 57334, 57311, 11579, 13071, 57335, 57314, 11580, 
13073, 13072, 57312, 11565, 1548
21458, 13047, 57245, 11538, 1539, 13048, 57246, 11539, 1538, 57335, 57314, 11580, 13073, 57336, 57317, 11581, 
13075, 13074, 57315, 11567, 1547
21459, 13048, 57246, 11539, 1538, 13049, 57247, 11540, 1537, 57336, 57317, 11581, 13075, 57337, 57320, 11582, 
13077, 13076, 57318, 11569, 1546
21460, 13049, 57247, 11540, 1537, 13050, 57248, 11541, 1536, 57337, 57320, 11582, 13077, 57338, 57323, 11583, 
13079, 13078, 57321, 11571, 1545
21461, 13050, 57248, 11541, 1536, 13051, 57249, 11542, 1535, 57338, 57323, 11583, 13079, 57339, 57326, 11584, 
13081, 13080, 57324, 11573, 1544
21462, 13051, 57249, 11542, 1535, 13052, 57250, 11543, 1534, 57339, 57326, 11584, 13081, 57340, 57329, 11585, 
13083, 13082, 57327, 11575, 1543
21463, 13052, 57250, 11543, 1534, 13053, 57251, 11544, 1533, 57340, 57329, 11585, 13083, 57341, 57332, 11586, 
13085, 13084, 57330, 11577, 1542
21464, 13053, 57251, 11544, 1533, 1705, 12941, 1412, 46, 57341, 57332, 11586, 13085, 12950, 12948, 1415, 
1708, 13086, 57333, 11578, 1541
21465, 12919, 1680, 1679, 12917, 57252, 12971, 12963, 57236, 12928, 1683, 12923, 12929, 57343, 13004, 57285, 
57344, 57342, 13005, 12988, 57284
21466, 57252, 12971, 12963, 57236, 57253, 12972, 12964, 57237, 57343, 13004, 57285, 57344, 57346, 13006, 57288, 
57347, 57345, 13007, 12990, 57287
21467, 57253, 12972, 12964, 57237, 57254, 12973, 12965, 57238, 57346, 13006, 57288, 57347, 57349, 13008, 57291, 
57350, 57348, 13009, 12992, 57290
21468, 57254, 12973, 12965, 57238, 57255, 12974, 12966, 57239, 57349, 13008, 57291, 57350, 57352, 13010, 57294, 
57353, 57351, 13011, 12994, 57293
21469, 57255, 12974, 12966, 57239, 57256, 12975, 12967, 57240, 57352, 13010, 57294, 57353, 57355, 13012, 57297, 
57356, 57354, 13013, 12996, 57296
21470, 57256, 12975, 12967, 57240, 57257, 12976, 12968, 57241, 57355, 13012, 57297, 57356, 57358, 13014, 57300, 
57359, 57357, 13015, 12998, 57299
21471, 57257, 12976, 12968, 57241, 57258, 12977, 12969, 57242, 57358, 13014, 57300, 57359, 57361, 13016, 57303, 
57362, 57360, 13017, 13000, 57302
21472, 57258, 12977, 12969, 57242, 57259, 12978, 12970, 57243, 57361, 13016, 57303, 57362, 57364, 13018, 57306, 
57365, 57363, 13019, 13002, 57305
21473, 57259, 12978, 12970, 57243, 12942, 1699, 1698, 12940, 57364, 13018, 57306, 57365, 12952, 1702, 12947, 
12951, 57366, 13020, 13003, 57308
21474, 12920, 12919, 12917, 12918, 57260, 57252, 57236, 57244, 12930, 12929, 12925, 12931, 57368, 57344, 57310, 
57369, 57367, 57342, 57284, 57309
21475, 57260, 57252, 57236, 57244, 57261, 57253, 57237, 57245, 57368, 57344, 57310, 57369, 57371, 57347, 57313, 
57372, 57370, 57345, 57287, 57312
21476, 57261, 57253, 57237, 57245, 57262, 57254, 57238, 57246, 57371, 57347, 57313, 57372, 57374, 57350, 57316, 
57375, 57373, 57348, 57290, 57315
21477, 57262, 57254, 57238, 57246, 57263, 57255, 57239, 57247, 57374, 57350, 57316, 57375, 57377, 57353, 57319, 
57378, 57376, 57351, 57293, 57318
21478, 57263, 57255, 57239, 57247, 57264, 57256, 57240, 57248, 57377, 57353, 57319, 57378, 57380, 57356, 57322, 
57381, 57379, 57354, 57296, 57321
21479, 57264, 57256, 57240, 57248, 57265, 57257, 57241, 57249, 57380, 57356, 57322, 57381, 57383, 57359, 57325, 
57384, 57382, 57357, 57299, 57324
21480, 57265, 57257, 57241, 57249, 57266, 57258, 57242, 57250, 57383, 57359, 57325, 57384, 57386, 57362, 57328, 
57387, 57385, 57360, 57302, 57327
21481, 57266, 57258, 57242, 57250, 57267, 57259, 57243, 57251, 57386, 57362, 57328, 57387, 57389, 57365, 57331, 
57390, 57388, 57363, 57305, 57330
21482, 57267, 57259, 57243, 57251, 12943, 12942, 12940, 12941, 57389, 57365, 57331, 57390, 12954, 12951, 12949, 
12953, 57391, 57366, 57308, 57333
21483, 1687, 12920, 12918, 1686, 13054, 57260, 57244, 13046, 12932, 12931, 12927, 1690, 57392, 57369, 57334, 
13088, 13087, 57367, 57309, 13070
21484, 13054, 57260, 57244, 13046, 13055, 57261, 57245, 13047, 57392, 57369, 57334, 13088, 57393, 57372, 57335, 
13090, 13089, 57370, 57312, 13072
21485, 13055, 57261, 57245, 13047, 13056, 57262, 57246, 13048, 57393, 57372, 57335, 13090, 57394, 57375, 57336, 
13092, 13091, 57373, 57315, 13074
21486, 13056, 57262, 57246, 13048, 13057, 57263, 57247, 13049, 57394, 57375, 57336, 13092, 57395, 57378, 57337, 
13094, 13093, 57376, 57318, 13076
21487, 13057, 57263, 57247, 13049, 13058, 57264, 57248, 13050, 57395, 57378, 57337, 13094, 57396, 57381, 57338, 
13096, 13095, 57379, 57321, 13078
21488, 13058, 57264, 57248, 13050, 13059, 57265, 57249, 13051, 57396, 57381, 57338, 13096, 57397, 57384, 57339, 
13098, 13097, 57382, 57324, 13080
21489, 13059, 57265, 57249, 13051, 13060, 57266, 57250, 13052, 57397, 57384, 57339, 13098, 57398, 57387, 57340, 
13100, 13099, 57385, 57327, 13082
21490, 13060, 57266, 57250, 13052, 13061, 57267, 57251, 13053, 57398, 57387, 57340, 13100, 57399, 57390, 57341, 
13102, 13101, 57388, 57330, 13084
21491, 13061, 57267, 57251, 13053, 1706, 12943, 12941, 1705, 57399, 57390, 57341, 13102, 12955, 12953, 12950, 
1709, 13103, 57391, 57333, 13086
21492, 12921, 1681, 1680, 12919, 57268, 12979, 12971, 57252, 12933, 1684, 12928, 12934, 57401, 13021, 57343, 
57402, 57400, 13022, 13005, 57342
21493, 57268, 12979, 12971, 57252, 57269, 12980, 12972, 57253, 57401, 13021, 57343, 57402, 57404, 13023, 57346, 
57405, 57403, 13024, 13007, 57345
21494, 57269, 12980, 12972, 57253, 57270, 12981, 12973, 57254, 57404, 13023, 57346, 57405, 57407, 13025, 57349, 
57408, 57406, 13026, 13009, 57348
21495, 57270, 12981, 12973, 57254, 57271, 12982, 12974, 57255, 57407, 13025, 57349, 57408, 57410, 13027, 57352, 
57411, 57409, 13028, 13011, 57351
21496, 57271, 12982, 12974, 57255, 57272, 12983, 12975, 57256, 57410, 13027, 57352, 57411, 57413, 13029, 57355, 
57414, 57412, 13030, 13013, 57354
21497, 57272, 12983, 12975, 57256, 57273, 12984, 12976, 57257, 57413, 13029, 57355, 57414, 57416, 13031, 57358, 
57417, 57415, 13032, 13015, 57357
21498, 57273, 12984, 12976, 57257, 57274, 12985, 12977, 57258, 57416, 13031, 57358, 57417, 57419, 13033, 57361, 
57420, 57418, 13034, 13017, 57360
21499, 57274, 12985, 12977, 57258, 57275, 12986, 12978, 57259, 57419, 13033, 57361, 57420, 57422, 13035, 57364, 
57423, 57421, 13036, 13019, 57363
21500, 57275, 12986, 12978, 57259, 12944, 1700, 1699, 12942, 57422, 13035, 57364, 57423, 12957, 1703, 12952, 
12956, 57424, 13037, 13020, 57366
21501, 12922, 12921, 12919, 12920, 57276, 57268, 57252, 57260, 12935, 12934, 12930, 12936, 57426, 57402, 57368, 
57427, 57425, 57400, 57342, 57367
21502, 57276, 57268, 57252, 57260, 57277, 57269, 57253, 57261, 57426, 57402, 57368, 57427, 57429, 57405, 57371, 
57430, 57428, 57403, 57345, 57370
21503, 57277, 57269, 57253, 57261, 57278, 57270, 57254, 57262, 57429, 57405, 57371, 57430, 57432, 57408, 57374, 
57433, 57431, 57406, 57348, 57373
21504, 57278, 57270, 57254, 57262, 57279, 57271, 57255, 57263, 57432, 57408, 57374, 57433, 57435, 57411, 57377, 
57436, 57434, 57409, 57351, 57376
21505, 57279, 57271, 57255, 57263, 57280, 57272, 57256, 57264, 57435, 57411, 57377, 57436, 57438, 57414, 57380, 
57439, 57437, 57412, 57354, 57379
21506, 57280, 57272, 57256, 57264, 57281, 57273, 57257, 57265, 57438, 57414, 57380, 57439, 57441, 57417, 57383, 
57442, 57440, 57415, 57357, 57382
21507, 57281, 57273, 57257, 57265, 57282, 57274, 57258, 57266, 57441, 57417, 57383, 57442, 57444, 57420, 57386, 
57445, 57443, 57418, 57360, 57385
21508, 57282, 57274, 57258, 57266, 57283, 57275, 57259, 57267, 57444, 57420, 57386, 57445, 57447, 57423, 57389, 
57448, 57446, 57421, 57363, 57388
21509, 57283, 57275, 57259, 57267, 12945, 12944, 12942, 12943, 57447, 57423, 57389, 57448, 12959, 12956, 12954, 
12958, 57449, 57424, 57366, 57391
21510, 1688, 12922, 12920, 1687, 13062, 57276, 57260, 13054, 12937, 12936, 12932, 1691, 57450, 57427, 57392, 
13105, 13104, 57425, 57367, 13087
21511, 13062, 57276, 57260, 13054, 13063, 57277, 57261, 13055, 57450, 57427, 57392, 13105, 57451, 57430, 57393, 
13107, 13106, 57428, 57370, 13089
21512, 13063, 57277, 57261, 13055, 13064, 57278, 57262, 13056, 57451, 57430, 57393, 13107, 57452, 57433, 57394, 
13109, 13108, 57431, 57373, 13091
21513, 13064, 57278, 57262, 13056, 13065, 57279, 57263, 13057, 57452, 57433, 57394, 13109, 57453, 57436, 57395, 
13111, 13110, 57434, 57376, 13093
21514, 13065, 57279, 57263, 13057, 13066, 57280, 57264, 13058, 57453, 57436, 57395, 13111, 57454, 57439, 57396, 
13113, 13112, 57437, 57379, 13095
21515, 13066, 57280, 57264, 13058, 13067, 57281, 57265, 13059, 57454, 57439, 57396, 13113, 57455, 57442, 57397, 
13115, 13114, 57440, 57382, 13097
21516, 13067, 57281, 57265, 13059, 13068, 57282, 57266, 13060, 57455, 57442, 57397, 13115, 57456, 57445, 57398, 
13117, 13116, 57443, 57385, 13099
21517, 13068, 57282, 57266, 13060, 13069, 57283, 57267, 13061, 57456, 57445, 57398, 13117, 57457, 57448, 57399, 
13119, 13118, 57446, 57388, 13101
21518, 13069, 57283, 57267, 13061, 1707, 12945, 12943, 1706, 57457, 57448, 57399, 13119, 12960, 12958, 12955, 
1710, 13120, 57449, 57391, 13103
21519, 1693, 53, 1681, 12921, 13129, 1724, 12979, 57268, 1695, 1685, 12933, 12938, 13145, 13038, 57401, 
57458, 13146, 1733, 13022, 57400
21520, 13129, 1724, 12979, 57268, 13130, 1723, 12980, 57269, 13145, 13038, 57401, 57458, 13147, 13039, 57404, 
57459, 13148, 1732, 13024, 57403
21521, 13130, 1723, 12980, 57269, 13131, 1722, 12981, 57270, 13147, 13039, 57404, 57459, 13149, 13040, 57407, 
57460, 13150, 1731, 13026, 57406
21522, 13131, 1722, 12981, 57270, 13132, 1721, 12982, 57271, 13149, 13040, 57407, 57460, 13151, 13041, 57410, 
57461, 13152, 1730, 13028, 57409
21523, 13132, 1721, 12982, 57271, 13133, 1720, 12983, 57272, 13151, 13041, 57410, 57461, 13153, 13042, 57413, 
57462, 13154, 1729, 13030, 57412
21524, 13133, 1720, 12983, 57272, 13134, 1719, 12984, 57273, 13153, 13042, 57413, 57462, 13155, 13043, 57416, 
57463, 13156, 1728, 13032, 57415
21525, 13134, 1719, 12984, 57273, 13135, 1718, 12985, 57274, 13155, 13043, 57416, 57463, 13157, 13044, 57419, 
57464, 13158, 1727, 13034, 57418
21526, 13135, 1718, 12985, 57274, 13136, 1717, 12986, 57275, 13157, 13044, 57419, 57464, 13159, 13045, 57422, 
57465, 13160, 1726, 13036, 57421
21527, 13136, 1717, 12986, 57275, 1712, 55, 1700, 12944, 13159, 13045, 57422, 57465, 1714, 1704, 12957, 
12961, 13161, 1725, 13037, 57424
21528, 1694, 1693, 12921, 12922, 13137, 13129, 57268, 57276, 1696, 12938, 12935, 12939, 13162, 57458, 57426, 
57466, 13163, 13146, 57400, 57425
21529, 13137, 13129, 57268, 57276, 13138, 13130, 57269, 57277, 13162, 57458, 57426, 57466, 13164, 57459, 57429, 
57467, 13165, 13148, 57403, 57428
21530, 13138, 13130, 57269, 57277, 13139, 13131, 57270, 57278, 13164, 57459, 57429, 57467, 13166, 57460, 57432, 
57468, 13167, 13150, 57406, 57431
21531, 13139, 13131, 57270, 57278, 13140, 13132, 57271, 57279, 13166, 57460, 57432, 57468, 13168, 57461, 57435, 
57469, 13169, 13152, 57409, 57434
21532, 13140, 13132, 57271, 57279, 13141, 13133, 57272, 57280, 13168, 57461, 57435, 57469, 13170, 57462, 57438, 
57470, 13171, 13154, 57412, 57437
21533, 13141, 13133, 57272, 57280, 13142, 13134, 57273, 57281, 13170, 57462, 57438, 57470, 13172, 57463, 57441, 
57471, 13173, 13156, 57415, 57440
21534, 13142, 13134, 57273, 57281, 13143, 13135, 57274, 57282, 13172, 57463, 57441, 57471, 13174, 57464, 57444, 
57472, 13175, 13158, 57418, 57443
21535, 13143, 13135, 57274, 57282, 13144, 13136, 57275, 57283, 13174, 57464, 57444, 57472, 13176, 57465, 57447, 
57473, 13177, 13160, 57421, 57446
21536, 13144, 13136, 57275, 57283, 1713, 1712, 12944, 12945, 13176, 57465, 57447, 57473, 1715, 12961, 12959, 
12962, 13178, 13161, 57424, 57449
21537, 54, 1694, 12922, 1688, 1741, 13137, 57276, 13062, 1697, 12939, 12937, 1692, 13179, 57466, 57450, 
13121, 1750, 13163, 57425, 13104
21538, 1741, 13137, 57276, 13062, 1740, 13138, 57277, 13063, 13179, 57466, 57450, 13121, 13180, 57467, 57451, 
13122, 1749, 13165, 57428, 13106
21539, 1740, 13138, 57277, 13063, 1739, 13139, 57278, 13064, 13180, 57467, 57451, 13122, 13181, 57468, 57452, 
13123, 1748, 13167, 57431, 13108
21540, 1739, 13139, 57278, 13064, 1738, 13140, 57279, 13065, 13181, 57468, 57452, 13123, 13182, 57469, 57453, 
13124, 1747, 13169, 57434, 13110
21541, 1738, 13140, 57279, 13065, 1737, 13141, 57280, 13066, 13182, 57469, 57453, 13124, 13183, 57470, 57454, 
13125, 1746, 13171, 57437, 13112
21542, 1737, 13141, 57280, 13066, 1736, 13142, 57281, 13067, 13183, 57470, 57454, 13125, 13184, 57471, 57455, 
13126, 1745, 13173, 57440, 13114
21543, 1736, 13142, 57281, 13067, 1735, 13143, 57282, 13068, 13184, 57471, 57455, 13126, 13185, 57472, 57456, 
13127, 1744, 13175, 57443, 13116
21544, 1735, 13143, 57282, 13068, 1734, 13144, 57283, 13069, 13185, 57472, 57456, 13127, 13186, 57473, 57457, 
13128, 1743, 13177, 57446, 13118
21545, 1734, 13144, 57283, 13069, 56, 1713, 12945, 1707, 13186, 57473, 57457, 13128, 1716, 12962, 12960, 
1711, 1742, 13178, 57449, 13120
*ELEMENT, type=C3D20, ELSET=Volume7
21546, 16926, 2150, 53, 1693, 57474, 15810, 1724, 13129, 16970, 2172, 1695, 16971, 57827, 15987, 13145, 
57828, 57826, 15986, 1733, 13146
21547, 57474, 15810, 1724, 13129, 57475, 15811, 1723, 13130, 57827, 15987, 13145, 57828, 57830, 15989, 13147, 
57831, 57829, 15988, 1732, 13148
21548, 57475, 15811, 1723, 13130, 57476, 15812, 1722, 13131, 57830, 15989, 13147, 57831, 57833, 15991, 13149, 
57834, 57832, 15990, 1731, 13150
21549, 57476, 15812, 1722, 13131, 57477, 15813, 1721, 13132, 57833, 15991, 13149, 57834, 57836, 15993, 13151, 
57837, 57835, 15992, 1730, 13152
21550, 57477, 15813, 1721, 13132, 57478, 15814, 1720, 13133, 57836, 15993, 13151, 57837, 57839, 15995, 13153, 
57840, 57838, 15994, 1729, 13154
21551, 57478, 15814, 1720, 13133, 57479, 15815, 1719, 13134, 57839, 15995, 13153, 57840, 57842, 15997, 13155, 
57843, 57841, 15996, 1728, 13156
21552, 57479, 15815, 1719, 13134, 57480, 15816, 1718, 13135, 57842, 15997, 13155, 57843, 57845, 15999, 13157, 
57846, 57844, 15998, 1727, 13158
21553, 57480, 15816, 1718, 13135, 57481, 15817, 1717, 13136, 57845, 15999, 13157, 57846, 57848, 16001, 13159, 
57849, 57847, 16000, 1726, 13160
21554, 57481, 15817, 1717, 13136, 17082, 2246, 55, 1712, 57848, 16001, 13159, 57849, 17127, 2268, 1714, 
17126, 57850, 16002, 1725, 13161
21555, 16927, 16926, 1693, 1694, 57482, 57474, 13129, 13137, 16972, 16971, 1696, 16973, 57852, 57828, 13162, 
57853, 57851, 57826, 13146, 13163
21556, 57482, 57474, 13129, 13137, 57483, 57475, 13130, 13138, 57852, 57828, 13162, 57853, 57855, 57831, 13164, 
57856, 57854, 57829, 13148, 13165
21557, 57483, 57475, 13130, 13138, 57484, 57476, 13131, 13139, 57855, 57831, 13164, 57856, 57858, 57834, 13166, 
57859, 57857, 57832, 13150, 13167
21558, 57484, 57476, 13131, 13139, 57485, 57477, 13132, 13140, 57858, 57834, 13166, 57859, 57861, 57837, 13168, 
57862, 57860, 57835, 13152, 13169
21559, 57485, 57477, 13132, 13140, 57486, 57478, 13133, 13141, 57861, 57837, 13168, 57862, 57864, 57840, 13170, 
57865, 57863, 57838, 13154, 13171
21560, 57486, 57478, 13133, 13141, 57487, 57479, 13134, 13142, 57864, 57840, 13170, 57865, 57867, 57843, 13172, 
57868, 57866, 57841, 13156, 13173
21561, 57487, 57479, 13134, 13142, 57488, 57480, 13135, 13143, 57867, 57843, 13172, 57868, 57870, 57846, 13174, 
57871, 57869, 57844, 13158, 13175
21562, 57488, 57480, 13135, 13143, 57489, 57481, 13136, 13144, 57870, 57846, 13174, 57871, 57873, 57849, 13176, 
57874, 57872, 57847, 13160, 13177
21563, 57489, 57481, 13136, 13144, 17083, 17082, 1712, 1713, 57873, 57849, 13176, 57874, 17129, 17126, 1715, 
17128, 57875, 57850, 13161, 13178
21564, 2387, 16927, 1694, 54, 17238, 57482, 13137, 1741, 16974, 16973, 1697, 2409, 57876, 57853, 13179, 
17415, 17414, 57851, 13163, 1750
21565, 17238, 57482, 13137, 1741, 17239, 57483, 13138, 1740, 57876, 57853, 13179, 17415, 57877, 57856, 13180, 
17417, 17416, 57854, 13165, 1749
21566, 17239, 57483, 13138, 1740, 17240, 57484, 13139, 1739, 57877, 57856, 13180, 17417, 57878, 57859, 13181, 
17419, 17418, 57857, 13167, 1748
21567, 17240, 57484, 13139, 1739, 17241, 57485, 13140, 1738, 57878, 57859, 13181, 17419, 57879, 57862, 13182, 
17421, 17420, 57860, 13169, 1747
21568, 17241, 57485, 13140, 1738, 17242, 57486, 13141, 1737, 57879, 57862, 13182, 17421, 57880, 57865, 13183, 
17423, 17422, 57863, 13171, 1746
21569, 17242, 57486, 13141, 1737, 17243, 57487, 13142, 1736, 57880, 57865, 13183, 17423, 57881, 57868, 13184, 
17425, 17424, 57866, 13173, 1745
21570, 17243, 57487, 13142, 1736, 17244, 57488, 13143, 1735, 57881, 57868, 13184, 17425, 57882, 57871, 13185, 
17427, 17426, 57869, 13175, 1744
21571, 17244, 57488, 13143, 1735, 17245, 57489, 13144, 1734, 57882, 57871, 13185, 17427, 57883, 57874, 13186, 
17429, 17428, 57872, 13177, 1743
21572, 17245, 57489, 13144, 1734, 2437, 17083, 1713, 56, 57883, 57874, 13186, 17429, 17130, 17128, 1716, 
2459, 17430, 57875, 13178, 1742
21573, 16928, 2151, 2150, 16926, 57490, 15818, 15810, 57474, 16975, 2173, 16970, 16976, 57885, 16004, 57827, 
57886, 57884, 16003, 15986, 57826
21574, 57490, 15818, 15810, 57474, 57491, 15819, 15811, 57475, 57885, 16004, 57827, 57886, 57888, 16006, 57830, 
57889, 57887, 16005, 15988, 57829
21575, 57491, 15819, 15811, 57475, 57492, 15820, 15812, 57476, 57888, 16006, 57830, 57889, 57891, 16008, 57833, 
57892, 57890, 16007, 15990, 57832
21576, 57492, 15820, 15812, 57476, 57493, 15821, 15813, 57477, 57891, 16008, 57833, 57892, 57894, 16010, 57836, 
57895, 57893, 16009, 15992, 57835
21577, 57493, 15821, 15813, 57477, 57494, 15822, 15814, 57478, 57894, 16010, 57836, 57895, 57897, 16012, 57839, 
57898, 57896, 16011, 15994, 57838
21578, 57494, 15822, 15814, 57478, 57495, 15823, 15815, 57479, 57897, 16012, 57839, 57898, 57900, 16014, 57842, 
57901, 57899, 16013, 15996, 57841
21579, 57495, 15823, 15815, 57479, 57496, 15824, 15816, 57480, 57900, 16014, 57842, 57901, 57903, 16016, 57845, 
57904, 57902, 16015, 15998, 57844
21580, 57496, 15824, 15816, 57480, 57497, 15825, 15817, 57481, 57903, 16016, 57845, 57904, 57906, 16018, 57848, 
57907, 57905, 16017, 16000, 57847
21581, 57497, 15825, 15817, 57481, 17084, 2247, 2246, 17082, 57906, 16018, 57848, 57907, 17132, 2269, 17127, 
17131, 57908, 16019, 16002, 57850
21582, 16929, 16928, 16926, 16927, 57498, 57490, 57474, 57482, 16977, 16976, 16972, 16978, 57910, 57886, 57852, 
57911, 57909, 57884, 57826, 57851
21583, 57498, 57490, 57474, 57482, 57499, 57491, 57475, 57483, 57910, 57886, 57852, 57911, 57913, 57889, 57855, 
57914, 57912, 57887, 57829, 57854
21584, 57499, 57491, 57475, 57483, 57500, 57492, 57476, 57484, 57913, 57889, 57855, 57914, 57916, 57892, 57858, 
57917, 57915, 57890, 57832, 57857
21585, 57500, 57492, 57476, 57484, 57501, 57493, 57477, 57485, 57916, 57892, 57858, 57917, 57919, 57895, 57861, 
57920, 57918, 57893, 57835, 57860
21586, 57501, 57493, 57477, 57485, 57502, 57494, 57478, 57486, 57919, 57895, 57861, 57920, 57922, 57898, 57864, 
57923, 57921, 57896, 57838, 57863
21587, 57502, 57494, 57478, 57486, 57503, 57495, 57479, 57487, 57922, 57898, 57864, 57923, 57925, 57901, 57867, 
57926, 57924, 57899, 57841, 57866
21588, 57503, 57495, 57479, 57487, 57504, 57496, 57480, 57488, 57925, 57901, 57867, 57926, 57928, 57904, 57870, 
57929, 57927, 57902, 57844, 57869
21589, 57504, 57496, 57480, 57488, 57505, 57497, 57481, 57489, 57928, 57904, 57870, 57929, 57931, 57907, 57873, 
57932, 57930, 57905, 57847, 57872
21590, 57505, 57497, 57481, 57489, 17085, 17084, 17082, 17083, 57931, 57907, 57873, 57932, 17134, 17131, 17129, 
17133, 57933, 57908, 57850, 57875
21591, 2388, 16929, 16927, 2387, 17246, 57498, 57482, 17238, 16979, 16978, 16974, 2410, 57934, 57911, 57876, 
17432, 17431, 57909, 57851, 17414
21592, 17246, 57498, 57482, 17238, 17247, 57499, 57483, 17239, 57934, 57911, 57876, 17432, 57935, 57914, 57877, 
17434, 17433, 57912, 57854, 17416
21593, 17247, 57499, 57483, 17239, 17248, 57500, 57484, 17240, 57935, 57914, 57877, 17434, 57936, 57917, 57878, 
17436, 17435, 57915, 57857, 17418
21594, 17248, 57500, 57484, 17240, 17249, 57501, 57485, 17241, 57936, 57917, 57878, 17436, 57937, 57920, 57879, 
17438, 17437, 57918, 57860, 17420
21595, 17249, 57501, 57485, 17241, 17250, 57502, 57486, 17242, 57937, 57920, 57879, 17438, 57938, 57923, 57880, 
17440, 17439, 57921, 57863, 17422
21596, 17250, 57502, 57486, 17242, 17251, 57503, 57487, 17243, 57938, 57923, 57880, 17440, 57939, 57926, 57881, 
17442, 17441, 57924, 57866, 17424
21597, 17251, 57503, 57487, 17243, 17252, 57504, 57488, 17244, 57939, 57926, 57881, 17442, 57940, 57929, 57882, 
17444, 17443, 57927, 57869, 17426
21598, 17252, 57504, 57488, 17244, 17253, 57505, 57489, 17245, 57940, 57929, 57882, 17444, 57941, 57932, 57883, 
17446, 17445, 57930, 57872, 17428
21599, 17253, 57505, 57489, 17245, 2438, 17085, 17083, 2437, 57941, 57932, 57883, 17446, 17135, 17133, 17130, 
2460, 17447, 57933, 57875, 17430
21600, 16930, 2152, 2151, 16928, 57506, 15826, 15818, 57490, 16980, 2174, 16975, 16981, 57943, 16021, 57885, 
57944, 57942, 16020, 16003, 57884
21601, 57506, 15826, 15818, 57490, 57507, 15827, 15819, 57491, 57943, 16021, 57885, 57944, 57946, 16023, 57888, 
57947, 57945, 16022, 16005, 57887
21602, 57507, 15827, 15819, 57491, 57508, 15828, 15820, 57492, 57946, 16023, 57888, 57947, 57949, 16025, 57891, 
57950, 57948, 16024, 16007, 57890
21603, 57508, 15828, 15820, 57492, 57509, 15829, 15821, 57493, 57949, 16025, 57891, 57950, 57952, 16027, 57894, 
57953, 57951, 16026, 16009, 57893
21604, 57509, 15829, 15821, 57493, 57510, 15830, 15822, 57494, 57952, 16027, 57894, 57953, 57955, 16029, 57897, 
57956, 57954, 16028, 16011, 57896
21605, 57510, 15830, 15822, 57494, 57511, 15831, 15823, 57495, 57955, 16029, 57897, 57956, 57958, 16031, 57900, 
57959, 57957, 16030, 16013, 57899
21606, 57511, 15831, 15823, 57495, 57512, 15832, 15824, 57496, 57958, 16031, 57900, 57959, 57961, 16033, 57903, 
57962, 57960, 16032, 16015, 57902
21607, 57512, 15832, 15824, 57496, 57513, 15833, 15825, 57497, 57961, 16033, 57903, 57962, 57964, 16035, 57906, 
57965, 57963, 16034, 16017, 57905
21608, 57513, 15833, 15825, 57497, 17086, 2248, 2247, 17084, 57964, 16035, 57906, 57965, 17137, 2270, 17132, 
17136, 57966, 16036, 16019, 57908
21609, 16931, 16930, 16928, 16929, 57514, 57506, 57490, 57498, 16982, 16981, 16977, 16983, 57968, 57944, 57910, 
57969, 57967, 57942, 57884, 57909
21610, 57514, 57506, 57490, 57498, 57515, 57507, 57491, 57499, 57968, 57944, 57910, 57969, 57971, 57947, 57913, 
57972, 57970, 57945, 57887, 57912
21611, 57515, 57507, 57491, 57499, 57516, 57508, 57492, 57500, 57971, 57947, 57913, 57972, 57974, 57950, 57916, 
57975, 57973, 57948, 57890, 57915
21612, 57516, 57508, 57492, 57500, 57517, 57509, 57493, 57501, 57974, 57950, 57916, 57975, 57977, 57953, 57919, 
57978, 57976, 57951, 57893, 57918
21613, 57517, 57509, 57493, 57501, 57518, 57510, 57494, 57502, 57977, 57953, 57919, 57978, 57980, 57956, 57922, 
57981, 57979, 57954, 57896, 57921
21614, 57518, 57510, 57494, 57502, 57519, 57511, 57495, 57503, 57980, 57956, 57922, 57981, 57983, 57959, 57925, 
57984, 57982, 57957, 57899, 57924
21615, 57519, 57511, 57495, 57503, 57520, 57512, 57496, 57504, 57983, 57959, 57925, 57984, 57986, 57962, 57928, 
57987, 57985, 57960, 57902, 57927
21616, 57520, 57512, 57496, 57504, 57521, 57513, 57497, 57505, 57986, 57962, 57928, 57987, 57989, 57965, 57931, 
57990, 57988, 57963, 57905, 57930
21617, 57521, 57513, 57497, 57505, 17087, 17086, 17084, 17085, 57989, 57965, 57931, 57990, 17139, 17136, 17134, 
17138, 57991, 57966, 57908, 57933
21618, 2389, 16931, 16929, 2388, 17254, 57514, 57498, 17246, 16984, 16983, 16979, 2411, 57992, 57969, 57934, 
17449, 17448, 57967, 57909, 17431
21619, 17254, 57514, 57498, 17246, 17255, 57515, 57499, 17247, 57992, 57969, 57934, 17449, 57993, 57972, 57935, 
17451, 17450, 57970, 57912, 17433
21620, 17255, 57515, 57499, 17247, 17256, 57516, 57500, 17248, 57993, 57972, 57935, 17451, 57994, 57975, 57936, 
17453, 17452, 57973, 57915, 17435
21621, 17256, 57516, 57500, 17248, 17257, 57517, 57501, 17249, 57994, 57975, 57936, 17453, 57995, 57978, 57937, 
17455, 17454, 57976, 57918, 17437
21622, 17257, 57517, 57501, 17249, 17258, 57518, 57502, 17250, 57995, 57978, 57937, 17455, 57996, 57981, 57938, 
17457, 17456, 57979, 57921, 17439
21623, 17258, 57518, 57502, 17250, 17259, 57519, 57503, 17251, 57996, 57981, 57938, 17457, 57997, 57984, 57939, 
17459, 17458, 57982, 57924, 17441
21624, 17259, 57519, 57503, 17251, 17260, 57520, 57504, 17252, 57997, 57984, 57939, 17459, 57998, 57987, 57940, 
17461, 17460, 57985, 57927, 17443
21625, 17260, 57520, 57504, 17252, 17261, 57521, 57505, 17253, 57998, 57987, 57940, 17461, 57999, 57990, 57941, 
17463, 17462, 57988, 57930, 17445
21626, 17261, 57521, 57505, 17253, 2439, 17087, 17085, 2438, 57999, 57990, 57941, 17463, 17140, 17138, 17135, 
2461, 17464, 57991, 57933, 17447
21627, 16932, 2153, 2152, 16930, 57522, 15834, 15826, 57506, 16985, 2175, 16980, 16986, 58001, 16038, 57943, 
58002, 58000, 16037, 16020, 57942
21628, 57522, 15834, 15826, 57506, 57523, 15835, 15827, 57507, 58001, 16038, 57943, 58002, 58004, 16040, 57946, 
58005, 58003, 16039, 16022, 57945
21629, 57523, 15835, 15827, 57507, 57524, 15836, 15828, 57508, 58004, 16040, 57946, 58005, 58007, 16042, 57949, 
58008, 58006, 16041, 16024, 57948
21630, 57524, 15836, 15828, 57508, 57525, 15837, 15829, 57509, 58007, 16042, 57949, 58008, 58010, 16044, 57952, 
58011, 58009, 16043, 16026, 57951
21631, 57525, 15837, 15829, 57509, 57526, 15838, 15830, 57510, 58010, 16044, 57952, 58011, 58013, 16046, 57955, 
58014, 58012, 16045, 16028, 57954
21632, 57526, 15838, 15830, 57510, 57527, 15839, 15831, 57511, 58013, 16046, 57955, 58014, 58016, 16048, 57958, 
58017, 58015, 16047, 16030, 57957
21633, 57527, 15839, 15831, 57511, 57528, 15840, 15832, 57512, 58016, 16048, 57958, 58017, 58019, 16050, 57961, 
58020, 58018, 16049, 16032, 57960
21634, 57528, 15840, 15832, 57512, 57529, 15841, 15833, 57513, 58019, 16050, 57961, 58020, 58022, 16052, 57964, 
58023, 58021, 16051, 16034, 57963
21635, 57529, 15841, 15833, 57513, 17088, 2249, 2248, 17086, 58022, 16052, 57964, 58023, 17142, 2271, 17137, 
17141, 58024, 16053, 16036, 57966
21636, 16933, 16932, 16930, 16931, 57530, 57522, 57506, 57514, 16987, 16986, 16982, 16988, 58026, 58002, 57968, 
58027, 58025, 58000, 57942, 57967
21637, 57530, 57522, 57506, 57514, 57531, 57523, 57507, 57515, 58026, 58002, 57968, 58027, 58029, 58005, 57971, 
58030, 58028, 58003, 57945, 57970
21638, 57531, 57523, 57507, 57515, 57532, 57524, 57508, 57516, 58029, 58005, 57971, 58030, 58032, 58008, 57974, 
58033, 58031, 58006, 57948, 57973
21639, 57532, 57524, 57508, 57516, 57533, 57525, 57509, 57517, 58032, 58008, 57974, 58033, 58035, 58011, 57977, 
58036, 58034, 58009, 57951, 57976
21640, 57533, 57525, 57509, 57517, 57534, 57526, 57510, 57518, 58035, 58011, 57977, 58036, 58038, 58014, 57980, 
58039, 58037, 58012, 57954, 57979
21641, 57534, 57526, 57510, 57518, 57535, 57527, 57511, 57519, 58038, 58014, 57980, 58039, 58041, 58017, 57983, 
58042, 58040, 58015, 57957, 57982
21642, 57535, 57527, 57511, 57519, 57536, 57528, 57512, 57520, 58041, 58017, 57983, 58042, 58044, 58020, 57986, 
58045, 58043, 58018, 57960, 57985
21643, 57536, 57528, 57512, 57520, 57537, 57529, 57513, 57521, 58044, 58020, 57986, 58045, 58047, 58023, 57989, 
58048, 58046, 58021, 57963, 57988
21644, 57537, 57529, 57513, 57521, 17089, 17088, 17086, 17087, 58047, 58023, 57989, 58048, 17144, 17141, 17139, 
17143, 58049, 58024, 57966, 57991
21645, 2390, 16933, 16931, 2389, 17262, 57530, 57514, 17254, 16989, 16988, 16984, 2412, 58050, 58027, 57992, 
17466, 17465, 58025, 57967, 17448
21646, 17262, 57530, 57514, 17254, 17263, 57531, 57515, 17255, 58050, 58027, 57992, 17466, 58051, 58030, 57993, 
17468, 17467, 58028, 57970, 17450
21647, 17263, 57531, 57515, 17255, 17264, 57532, 57516, 17256, 58051, 58030, 57993, 17468, 58052, 58033, 57994, 
17470, 17469, 58031, 57973, 17452
21648, 17264, 57532, 57516, 17256, 17265, 57533, 57517, 17257, 58052, 58033, 57994, 17470, 58053, 58036, 57995, 
17472, 17471, 58034, 57976, 17454
21649, 17265, 57533, 57517, 17257, 17266, 57534, 57518, 17258, 58053, 58036, 57995, 17472, 58054, 58039, 57996, 
17474, 17473, 58037, 57979, 17456
21650, 17266, 57534, 57518, 17258, 17267, 57535, 57519, 17259, 58054, 58039, 57996, 17474, 58055, 58042, 57997, 
17476, 17475, 58040, 57982, 17458
21651, 17267, 57535, 57519, 17259, 17268, 57536, 57520, 17260, 58055, 58042, 57997, 17476, 58056, 58045, 57998, 
17478, 17477, 58043, 57985, 17460
21652, 17268, 57536, 57520, 17260, 17269, 57537, 57521, 17261, 58056, 58045, 57998, 17478, 58057, 58048, 57999, 
17480, 17479, 58046, 57988, 17462
21653, 17269, 57537, 57521, 17261, 2440, 17089, 17087, 2439, 58057, 58048, 57999, 17480, 17145, 17143, 17140, 
2462, 17481, 58049, 57991, 17464
21654, 16934, 2154, 2153, 16932, 57538, 15842, 15834, 57522, 16990, 2176, 16985, 16991, 58059, 16055, 58001, 
58060, 58058, 16054, 16037, 58000
21655, 57538, 15842, 15834, 57522, 57539, 15843, 15835, 57523, 58059, 16055, 58001, 58060, 58062, 16057, 58004, 
58063, 58061, 16056, 16039, 58003
21656, 57539, 15843, 15835, 57523, 57540, 15844, 15836, 57524, 58062, 16057, 58004, 58063, 58065, 16059, 58007, 
58066, 58064, 16058, 16041, 58006
21657, 57540, 15844, 15836, 57524, 57541, 15845, 15837, 57525, 58065, 16059, 58007, 58066, 58068, 16061, 58010, 
58069, 58067, 16060, 16043, 58009
21658, 57541, 15845, 15837, 57525, 57542, 15846, 15838, 57526, 58068, 16061, 58010, 58069, 58071, 16063, 58013, 
58072, 58070, 16062, 16045, 58012
21659, 57542, 15846, 15838, 57526, 57543, 15847, 15839, 57527, 58071, 16063, 58013, 58072, 58074, 16065, 58016, 
58075, 58073, 16064, 16047, 58015
21660, 57543, 15847, 15839, 57527, 57544, 15848, 15840, 57528, 58074, 16065, 58016, 58075, 58077, 16067, 58019, 
58078, 58076, 16066, 16049, 58018
21661, 57544, 15848, 15840, 57528, 57545, 15849, 15841, 57529, 58077, 16067, 58019, 58078, 58080, 16069, 58022, 
58081, 58079, 16068, 16051, 58021
21662, 57545, 15849, 15841, 57529, 17090, 2250, 2249, 17088, 58080, 16069, 58022, 58081, 17147, 2272, 17142, 
17146, 58082, 16070, 16053, 58024
21663, 16935, 16934, 16932, 16933, 57546, 57538, 57522, 57530, 16992, 16991, 16987, 16993, 58084, 58060, 58026, 
58085, 58083, 58058, 58000, 58025
21664, 57546, 57538, 57522, 57530, 57547, 57539, 57523, 57531, 58084, 58060, 58026, 58085, 58087, 58063, 58029, 
58088, 58086, 58061, 58003, 58028
21665, 57547, 57539, 57523, 57531, 57548, 57540, 57524, 57532, 58087, 58063, 58029, 58088, 58090, 58066, 58032, 
58091, 58089, 58064, 58006, 58031
21666, 57548, 57540, 57524, 57532, 57549, 57541, 57525, 57533, 58090, 58066, 58032, 58091, 58093, 58069, 58035, 
58094, 58092, 58067, 58009, 58034
21667, 57549, 57541, 57525, 57533, 57550, 57542, 57526, 57534, 58093, 58069, 58035, 58094, 58096, 58072, 58038, 
58097, 58095, 58070, 58012, 58037
21668, 57550, 57542, 57526, 57534, 57551, 57543, 57527, 57535, 58096, 58072, 58038, 58097, 58099, 58075, 58041, 
58100, 58098, 58073, 58015, 58040
21669, 57551, 57543, 57527, 57535, 57552, 57544, 57528, 57536, 58099, 58075, 58041, 58100, 58102, 58078, 58044, 
58103, 58101, 58076, 58018, 58043
21670, 57552, 57544, 57528, 57536, 57553, 57545, 57529, 57537, 58102, 58078, 58044, 58103, 58105, 58081, 58047, 
58106, 58104, 58079, 58021, 58046
21671, 57553, 57545, 57529, 57537, 17091, 17090, 17088, 17089, 58105, 58081, 58047, 58106, 17149, 17146, 17144, 
17148, 58107, 58082, 58024, 58049
21672, 2391, 16935, 16933, 2390, 17270, 57546, 57530, 17262, 16994, 16993, 16989, 2413, 58108, 58085, 58050, 
17483, 17482, 58083, 58025, 17465
21673, 17270, 57546, 57530, 17262, 17271, 57547, 57531, 17263, 58108, 58085, 58050, 17483, 58109, 58088, 58051, 
17485, 17484, 58086, 58028, 17467
21674, 17271, 57547, 57531, 17263, 17272, 57548, 57532, 17264, 58109, 58088, 58051, 17485, 58110, 58091, 58052, 
17487, 17486, 58089, 58031, 17469
21675, 17272, 57548, 57532, 17264, 17273, 57549, 57533, 17265, 58110, 58091, 58052, 17487, 58111, 58094, 58053, 
17489, 17488, 58092, 58034, 17471
21676, 17273, 57549, 57533, 17265, 17274, 57550, 57534, 17266, 58111, 58094, 58053, 17489, 58112, 58097, 58054, 
17491, 17490, 58095, 58037, 17473
21677, 17274, 57550, 57534, 17266, 17275, 57551, 57535, 17267, 58112, 58097, 58054, 17491, 58113, 58100, 58055, 
17493, 17492, 58098, 58040, 17475
21678, 17275, 57551, 57535, 17267, 17276, 57552, 57536, 17268, 58113, 58100, 58055, 17493, 58114, 58103, 58056, 
17495, 17494, 58101, 58043, 17477
21679, 17276, 57552, 57536, 17268, 17277, 57553, 57537, 17269, 58114, 58103, 58056, 17495, 58115, 58106, 58057, 
17497, 17496, 58104, 58046, 17479
21680, 17277, 57553, 57537, 17269, 2441, 17091, 17089, 2440, 58115, 58106, 58057, 17497, 17150, 17148, 17145, 
2463, 17498, 58107, 58049, 17481
21681, 16936, 2155, 2154, 16934, 57554, 15850, 15842, 57538, 16995, 2177, 16990, 16996, 58117, 16072, 58059, 
58118, 58116, 16071, 16054, 58058
21682, 57554, 15850, 15842, 57538, 57555, 15851, 15843, 57539, 58117, 16072, 58059, 58118, 58120, 16074, 58062, 
58121, 58119, 16073, 16056, 58061
21683, 57555, 15851, 15843, 57539, 57556, 15852, 15844, 57540, 58120, 16074, 58062, 58121, 58123, 16076, 58065, 
58124, 58122, 16075, 16058, 58064
21684, 57556, 15852, 15844, 57540, 57557, 15853, 15845, 57541, 58123, 16076, 58065, 58124, 58126, 16078, 58068, 
58127, 58125, 16077, 16060, 58067
21685, 57557, 15853, 15845, 57541, 57558, 15854, 15846, 57542, 58126, 16078, 58068, 58127, 58129, 16080, 58071, 
