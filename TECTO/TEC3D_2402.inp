10458, 1.2, -1.0408340855861e-16, 0.16666666666667
10459, 1.2, -0.016666666666667, 0.19444444444444
10460, 1.2, -1.0408340855861e-16, 0.11111111111111
10461, 1.2, -0.016666666666667, 0.13888888888889
10462, 1.2, -1.0408340855861e-16, 0.055555555555556
10463, 1.2, -0.016666666666667, 0.083333333333333
10464, 1.2, -0.016666666666667, 0.027777777777778
10465, 1.2, -0.033333333333333, 0.44444444444444
10466, 1.2, -0.033333333333333, 0.38888888888889
10467, 1.2, -0.033333333333333, 0.33333333333333
10468, 1.2, -0.033333333333333, 0.27777777777778
10469, 1.2, -0.033333333333333, 0.22222222222222
10470, 1.2, -0.033333333333333, 0.16666666666667
10471, 1.2, -0.033333333333333, 0.11111111111111
10472, 1.2, -0.033333333333333, 0.055555555555556
10473, 2.2, 0.016666666666667, 0.44444444444444
10474, 2.2, 0.016666666666667, 0.38888888888889
10475, 2.2, 0.016666666666667, 0.33333333333333
10476, 2.2, 0.016666666666667, 0.27777777777778
10477, 2.2, 0.016666666666667, 0.22222222222222
10478, 2.2, 0.016666666666667, 0.16666666666667
10479, 2.2, 0.016666666666667, 0.11111111111111
10480, 2.2, 0.016666666666667, 0.055555555555556
10481, 2.2, -0.016666666666667, 0.44444444444444
10482, 2.2, -0.016666666666667, 0.38888888888889
10483, 2.2, -0.016666666666667, 0.33333333333333
10484, 2.2, -0.016666666666667, 0.27777777777778
10485, 2.2, -0.016666666666667, 0.22222222222222
10486, 2.2, -0.016666666666667, 0.16666666666667
10487, 2.2, -0.016666666666667, 0.11111111111111
10488, 2.2, -0.016666666666667, 0.055555555555556
10489, 2.2, 0.016666666666667, 0.47222222222222
10490, 2.2, 0.033333333333333, 0.44444444444444
10491, 2.2, 0.016666666666667, 0.41666666666667
10492, 2.2, 0.033333333333333, 0.38888888888889
10493, 2.2, 0.016666666666667, 0.36111111111111
10494, 2.2, 0.033333333333333, 0.33333333333333
10495, 2.2, 0.016666666666667, 0.30555555555556
10496, 2.2, 0.033333333333333, 0.27777777777778
10497, 2.2, 0.016666666666667, 0.25
10498, 2.2, 0.033333333333333, 0.22222222222222
10499, 2.2, 0.016666666666667, 0.19444444444444
10500, 2.2, 0.033333333333333, 0.16666666666667
10501, 2.2, 0.016666666666667, 0.13888888888889
10502, 2.2, 0.033333333333333, 0.11111111111111
10503, 2.2, 0.016666666666667, 0.083333333333333
10504, 2.2, 0.033333333333333, 0.055555555555556
10505, 2.2, 0.016666666666667, 0.027777777777778
10506, 2.2, -0.016666666666667, 0.47222222222222
10507, 2.2, -8.3266726846887e-17, 0.44444444444444
10508, 2.2, -0.016666666666667, 0.41666666666667
10509, 2.2, -9.0205620750794e-17, 0.38888888888889
10510, 2.2, -0.016666666666667, 0.36111111111111
10511, 2.2, -9.0205620750794e-17, 0.33333333333333
10512, 2.2, -0.016666666666667, 0.30555555555556
10513, 2.2, -9.0205620750794e-17, 0.27777777777778
10514, 2.2, -0.016666666666667, 0.25
10515, 2.2, -9.0205620750794e-17, 0.22222222222222
10516, 2.2, -0.016666666666667, 0.19444444444444
10517, 2.2, -9.0205620750794e-17, 0.16666666666667
10518, 2.2, -0.016666666666667, 0.13888888888889
10519, 2.2, -9.0205620750794e-17, 0.11111111111111
10520, 2.2, -0.016666666666667, 0.083333333333333
10521, 2.2, -8.3266726846887e-17, 0.055555555555556
10522, 2.2, -0.016666666666667, 0.027777777777778
10523, 2.2, -0.033333333333333, 0.44444444444444
10524, 2.2, -0.033333333333333, 0.38888888888889
10525, 2.2, -0.033333333333333, 0.33333333333333
10526, 2.2, -0.033333333333333, 0.27777777777778
10527, 2.2, -0.033333333333333, 0.22222222222222
10528, 2.2, -0.033333333333333, 0.16666666666667
10529, 2.2, -0.033333333333333, 0.11111111111111
10530, 2.2, -0.033333333333333, 0.055555555555556
10531, 1.2434782608696, 0.05, 0.44444444444444
10532, 1.2434782608696, 0.05, 0.38888888888889
10533, 1.2434782608696, 0.05, 0.33333333333333
10534, 1.2434782608696, 0.05, 0.27777777777778
10535, 1.2434782608696, 0.05, 0.22222222222222
10536, 1.2434782608696, 0.05, 0.16666666666667
10537, 1.2434782608696, 0.05, 0.11111111111111
10538, 1.2434782608696, 0.05, 0.055555555555556
10539, 1.2869565217391, 0.05, 0.44444444444444
10540, 1.2869565217391, 0.05, 0.38888888888889
10541, 1.2869565217391, 0.05, 0.33333333333333
10542, 1.2869565217391, 0.05, 0.27777777777778
10543, 1.2869565217391, 0.05, 0.22222222222222
10544, 1.2869565217391, 0.05, 0.16666666666667
10545, 1.2869565217391, 0.05, 0.11111111111111
10546, 1.2869565217391, 0.05, 0.055555555555556
10547, 1.3304347826087, 0.05, 0.44444444444444
10548, 1.3304347826087, 0.05, 0.38888888888889
10549, 1.3304347826087, 0.05, 0.33333333333333
10550, 1.3304347826087, 0.05, 0.27777777777778
10551, 1.3304347826087, 0.05, 0.22222222222222
10552, 1.3304347826087, 0.05, 0.16666666666667
10553, 1.3304347826087, 0.05, 0.11111111111111
10554, 1.3304347826087, 0.05, 0.055555555555556
10555, 1.3739130434783, 0.05, 0.44444444444444
10556, 1.3739130434783, 0.05, 0.38888888888889
10557, 1.3739130434783, 0.05, 0.33333333333333
10558, 1.3739130434783, 0.05, 0.27777777777778
10559, 1.3739130434783, 0.05, 0.22222222222222
10560, 1.3739130434783, 0.05, 0.16666666666667
10561, 1.3739130434783, 0.05, 0.11111111111111
10562, 1.3739130434783, 0.05, 0.055555555555556
10563, 1.4173913043478, 0.05, 0.44444444444444
10564, 1.4173913043478, 0.05, 0.38888888888889
10565, 1.4173913043478, 0.05, 0.33333333333333
10566, 1.4173913043478, 0.05, 0.27777777777778
10567, 1.4173913043478, 0.05, 0.22222222222222
10568, 1.4173913043478, 0.05, 0.16666666666667
10569, 1.4173913043478, 0.05, 0.11111111111111
10570, 1.4173913043478, 0.05, 0.055555555555556
10571, 1.4608695652174, 0.05, 0.44444444444444
10572, 1.4608695652174, 0.05, 0.38888888888889
10573, 1.4608695652174, 0.05, 0.33333333333333
10574, 1.4608695652174, 0.05, 0.27777777777778
10575, 1.4608695652174, 0.05, 0.22222222222222
10576, 1.4608695652174, 0.05, 0.16666666666667
10577, 1.4608695652174, 0.05, 0.11111111111111
10578, 1.4608695652174, 0.05, 0.055555555555556
10579, 1.504347826087, 0.05, 0.44444444444444
10580, 1.504347826087, 0.05, 0.38888888888889
10581, 1.504347826087, 0.05, 0.33333333333333
10582, 1.504347826087, 0.05, 0.27777777777778
10583, 1.504347826087, 0.05, 0.22222222222222
10584, 1.504347826087, 0.05, 0.16666666666667
10585, 1.504347826087, 0.05, 0.11111111111111
10586, 1.504347826087, 0.05, 0.055555555555556
10587, 1.5478260869565, 0.05, 0.44444444444444
10588, 1.5478260869565, 0.05, 0.38888888888889
10589, 1.5478260869565, 0.05, 0.33333333333333
10590, 1.5478260869565, 0.05, 0.27777777777778
10591, 1.5478260869565, 0.05, 0.22222222222222
10592, 1.5478260869565, 0.05, 0.16666666666667
10593, 1.5478260869565, 0.05, 0.11111111111111
10594, 1.5478260869565, 0.05, 0.055555555555556
10595, 1.5913043478261, 0.05, 0.44444444444444
10596, 1.5913043478261, 0.05, 0.38888888888889
10597, 1.5913043478261, 0.05, 0.33333333333333
10598, 1.5913043478261, 0.05, 0.27777777777778
10599, 1.5913043478261, 0.05, 0.22222222222222
10600, 1.5913043478261, 0.05, 0.16666666666667
10601, 1.5913043478261, 0.05, 0.11111111111111
10602, 1.5913043478261, 0.05, 0.055555555555556
10603, 1.6347826086957, 0.05, 0.44444444444444
10604, 1.6347826086957, 0.05, 0.38888888888889
10605, 1.6347826086957, 0.05, 0.33333333333333
10606, 1.6347826086957, 0.05, 0.27777777777778
10607, 1.6347826086957, 0.05, 0.22222222222222
10608, 1.6347826086957, 0.05, 0.16666666666667
10609, 1.6347826086957, 0.05, 0.11111111111111
10610, 1.6347826086957, 0.05, 0.055555555555556
10611, 1.6782608695652, 0.05, 0.44444444444444
10612, 1.6782608695652, 0.05, 0.38888888888889
10613, 1.6782608695652, 0.05, 0.33333333333333
10614, 1.6782608695652, 0.05, 0.27777777777778
10615, 1.6782608695652, 0.05, 0.22222222222222
10616, 1.6782608695652, 0.05, 0.16666666666667
10617, 1.6782608695652, 0.05, 0.11111111111111
10618, 1.6782608695652, 0.05, 0.055555555555556
10619, 1.7217391304348, 0.05, 0.44444444444444
10620, 1.7217391304348, 0.05, 0.38888888888889
10621, 1.7217391304348, 0.05, 0.33333333333333
10622, 1.7217391304348, 0.05, 0.27777777777778
10623, 1.7217391304348, 0.05, 0.22222222222222
10624, 1.7217391304348, 0.05, 0.16666666666667
10625, 1.7217391304348, 0.05, 0.11111111111111
10626, 1.7217391304348, 0.05, 0.055555555555556
10627, 1.7652173913043, 0.05, 0.44444444444444
10628, 1.7652173913043, 0.05, 0.38888888888889
10629, 1.7652173913043, 0.05, 0.33333333333333
10630, 1.7652173913043, 0.05, 0.27777777777778
10631, 1.7652173913043, 0.05, 0.22222222222222
10632, 1.7652173913043, 0.05, 0.16666666666667
10633, 1.7652173913043, 0.05, 0.11111111111111
10634, 1.7652173913043, 0.05, 0.055555555555556
10635, 1.8086956521739, 0.05, 0.44444444444444
10636, 1.8086956521739, 0.05, 0.38888888888889
10637, 1.8086956521739, 0.05, 0.33333333333333
10638, 1.8086956521739, 0.05, 0.27777777777778
10639, 1.8086956521739, 0.05, 0.22222222222222
10640, 1.8086956521739, 0.05, 0.16666666666667
10641, 1.8086956521739, 0.05, 0.11111111111111
10642, 1.8086956521739, 0.05, 0.055555555555556
10643, 1.8521739130435, 0.05, 0.44444444444444
10644, 1.8521739130435, 0.05, 0.38888888888889
10645, 1.8521739130435, 0.05, 0.33333333333333
10646, 1.8521739130435, 0.05, 0.27777777777778
10647, 1.8521739130435, 0.05, 0.22222222222222
10648, 1.8521739130435, 0.05, 0.16666666666667
10649, 1.8521739130435, 0.05, 0.11111111111111
10650, 1.8521739130435, 0.05, 0.055555555555556
10651, 1.895652173913, 0.05, 0.44444444444444
10652, 1.895652173913, 0.05, 0.38888888888889
10653, 1.895652173913, 0.05, 0.33333333333333
10654, 1.895652173913, 0.05, 0.27777777777778
10655, 1.895652173913, 0.05, 0.22222222222222
10656, 1.895652173913, 0.05, 0.16666666666667
10657, 1.895652173913, 0.05, 0.11111111111111
10658, 1.895652173913, 0.05, 0.055555555555556
10659, 1.9391304347826, 0.05, 0.44444444444444
10660, 1.9391304347826, 0.05, 0.38888888888889
10661, 1.9391304347826, 0.05, 0.33333333333333
10662, 1.9391304347826, 0.05, 0.27777777777778
10663, 1.9391304347826, 0.05, 0.22222222222222
10664, 1.9391304347826, 0.05, 0.16666666666667
10665, 1.9391304347826, 0.05, 0.11111111111111
10666, 1.9391304347826, 0.05, 0.055555555555556
10667, 1.9826086956522, 0.05, 0.44444444444444
10668, 1.9826086956522, 0.05, 0.38888888888889
10669, 1.9826086956522, 0.05, 0.33333333333333
10670, 1.9826086956522, 0.05, 0.27777777777778
10671, 1.9826086956522, 0.05, 0.22222222222222
10672, 1.9826086956522, 0.05, 0.16666666666667
10673, 1.9826086956522, 0.05, 0.11111111111111
10674, 1.9826086956522, 0.05, 0.055555555555556
10675, 2.0260869565217, 0.05, 0.44444444444444
10676, 2.0260869565217, 0.05, 0.38888888888889
10677, 2.0260869565217, 0.05, 0.33333333333333
10678, 2.0260869565217, 0.05, 0.27777777777778
10679, 2.0260869565217, 0.05, 0.22222222222222
10680, 2.0260869565217, 0.05, 0.16666666666667
10681, 2.0260869565217, 0.05, 0.11111111111111
10682, 2.0260869565217, 0.05, 0.055555555555556
10683, 2.0695652173913, 0.05, 0.44444444444444
10684, 2.0695652173913, 0.05, 0.38888888888889
10685, 2.0695652173913, 0.05, 0.33333333333333
10686, 2.0695652173913, 0.05, 0.27777777777778
10687, 2.0695652173913, 0.05, 0.22222222222222
10688, 2.0695652173913, 0.05, 0.16666666666667
10689, 2.0695652173913, 0.05, 0.11111111111111
10690, 2.0695652173913, 0.05, 0.055555555555556
10691, 2.1130434782609, 0.05, 0.44444444444444
10692, 2.1130434782609, 0.05, 0.38888888888889
10693, 2.1130434782609, 0.05, 0.33333333333333
10694, 2.1130434782609, 0.05, 0.27777777777778
10695, 2.1130434782609, 0.05, 0.22222222222222
10696, 2.1130434782609, 0.05, 0.16666666666667
10697, 2.1130434782609, 0.05, 0.11111111111111
10698, 2.1130434782609, 0.05, 0.055555555555556
10699, 2.1565217391304, 0.05, 0.44444444444444
10700, 2.1565217391304, 0.05, 0.38888888888889
10701, 2.1565217391304, 0.05, 0.33333333333333
10702, 2.1565217391304, 0.05, 0.27777777777778
10703, 2.1565217391304, 0.05, 0.22222222222222
10704, 2.1565217391304, 0.05, 0.16666666666667
10705, 2.1565217391304, 0.05, 0.11111111111111
10706, 2.1565217391304, 0.05, 0.055555555555556
10707, 1.2434782608696, 0.05, 0.47222222222222
10708, 1.2217391304348, 0.05, 0.44444444444444
10709, 1.2434782608696, 0.05, 0.41666666666667
10710, 1.2217391304348, 0.05, 0.38888888888889
10711, 1.2434782608696, 0.05, 0.36111111111111
10712, 1.2217391304348, 0.05, 0.33333333333333
10713, 1.2434782608696, 0.05, 0.30555555555556
10714, 1.2217391304348, 0.05, 0.27777777777778
10715, 1.2434782608696, 0.05, 0.25
10716, 1.2217391304348, 0.05, 0.22222222222222
10717, 1.2434782608696, 0.05, 0.19444444444444
10718, 1.2217391304348, 0.05, 0.16666666666667
10719, 1.2434782608696, 0.05, 0.13888888888889
10720, 1.2217391304348, 0.05, 0.11111111111111
10721, 1.2434782608696, 0.05, 0.083333333333333
10722, 1.2217391304348, 0.05, 0.055555555555556
10723, 1.2434782608696, 0.05, 0.027777777777778
10724, 1.2869565217391, 0.05, 0.47222222222222
10725, 1.2652173913043, 0.05, 0.44444444444444
10726, 1.2869565217391, 0.05, 0.41666666666667
10727, 1.2652173913043, 0.05, 0.38888888888889
10728, 1.2869565217391, 0.05, 0.36111111111111
10729, 1.2652173913043, 0.05, 0.33333333333333
10730, 1.2869565217391, 0.05, 0.30555555555556
10731, 1.2652173913043, 0.05, 0.27777777777778
10732, 1.2869565217391, 0.05, 0.25
10733, 1.2652173913043, 0.05, 0.22222222222222
10734, 1.2869565217391, 0.05, 0.19444444444444
10735, 1.2652173913043, 0.05, 0.16666666666667
10736, 1.2869565217391, 0.05, 0.13888888888889
10737, 1.2652173913043, 0.05, 0.11111111111111
10738, 1.2869565217391, 0.05, 0.083333333333333
10739, 1.2652173913043, 0.05, 0.055555555555556
10740, 1.2869565217391, 0.05, 0.027777777777778
10741, 1.3304347826087, 0.05, 0.47222222222222
10742, 1.3086956521739, 0.05, 0.44444444444444
10743, 1.3304347826087, 0.05, 0.41666666666667
10744, 1.3086956521739, 0.05, 0.38888888888889
10745, 1.3304347826087, 0.05, 0.36111111111111
10746, 1.3086956521739, 0.05, 0.33333333333333
10747, 1.3304347826087, 0.05, 0.30555555555556
10748, 1.3086956521739, 0.05, 0.27777777777778
10749, 1.3304347826087, 0.05, 0.25
10750, 1.3086956521739, 0.05, 0.22222222222222
10751, 1.3304347826087, 0.05, 0.19444444444444
10752, 1.3086956521739, 0.05, 0.16666666666667
10753, 1.3304347826087, 0.05, 0.13888888888889
10754, 1.3086956521739, 0.05, 0.11111111111111
10755, 1.3304347826087, 0.05, 0.083333333333333
10756, 1.3086956521739, 0.05, 0.055555555555556
10757, 1.3304347826087, 0.05, 0.027777777777778
10758, 1.3739130434783, 0.05, 0.47222222222222
10759, 1.3521739130435, 0.05, 0.44444444444444
10760, 1.3739130434783, 0.05, 0.41666666666667
10761, 1.3521739130435, 0.05, 0.38888888888889
10762, 1.3739130434783, 0.05, 0.36111111111111
10763, 1.3521739130435, 0.05, 0.33333333333333
10764, 1.3739130434783, 0.05, 0.30555555555556
10765, 1.3521739130435, 0.05, 0.27777777777778
10766, 1.3739130434783, 0.05, 0.25
10767, 1.3521739130435, 0.05, 0.22222222222222
10768, 1.3739130434783, 0.05, 0.19444444444444
10769, 1.3521739130435, 0.05, 0.16666666666667
10770, 1.3739130434783, 0.05, 0.13888888888889
10771, 1.3521739130435, 0.05, 0.11111111111111
10772, 1.3739130434783, 0.05, 0.083333333333333
10773, 1.3521739130435, 0.05, 0.055555555555556
10774, 1.3739130434783, 0.05, 0.027777777777778
10775, 1.4173913043478, 0.05, 0.47222222222222
10776, 1.395652173913, 0.05, 0.44444444444444
10777, 1.4173913043478, 0.05, 0.41666666666667
10778, 1.395652173913, 0.05, 0.38888888888889
10779, 1.4173913043478, 0.05, 0.36111111111111
10780, 1.395652173913, 0.05, 0.33333333333333
10781, 1.4173913043478, 0.05, 0.30555555555556
10782, 1.395652173913, 0.05, 0.27777777777778
10783, 1.4173913043478, 0.05, 0.25
10784, 1.395652173913, 0.05, 0.22222222222222
10785, 1.4173913043478, 0.05, 0.19444444444444
10786, 1.395652173913, 0.05, 0.16666666666667
10787, 1.4173913043478, 0.05, 0.13888888888889
10788, 1.395652173913, 0.05, 0.11111111111111
10789, 1.4173913043478, 0.05, 0.083333333333333
10790, 1.395652173913, 0.05, 0.055555555555556
10791, 1.4173913043478, 0.05, 0.027777777777778
10792, 1.4608695652174, 0.05, 0.47222222222222
10793, 1.4391304347826, 0.05, 0.44444444444444
10794, 1.4608695652174, 0.05, 0.41666666666667
10795, 1.4391304347826, 0.05, 0.38888888888889
10796, 1.4608695652174, 0.05, 0.36111111111111
10797, 1.4391304347826, 0.05, 0.33333333333333
10798, 1.4608695652174, 0.05, 0.30555555555556
10799, 1.4391304347826, 0.05, 0.27777777777778
10800, 1.4608695652174, 0.05, 0.25
10801, 1.4391304347826, 0.05, 0.22222222222222
10802, 1.4608695652174, 0.05, 0.19444444444444
10803, 1.4391304347826, 0.05, 0.16666666666667
10804, 1.4608695652174, 0.05, 0.13888888888889
10805, 1.4391304347826, 0.05, 0.11111111111111
10806, 1.4608695652174, 0.05, 0.083333333333333
10807, 1.4391304347826, 0.05, 0.055555555555556
10808, 1.4608695652174, 0.05, 0.027777777777778
10809, 1.504347826087, 0.05, 0.47222222222222
10810, 1.4826086956522, 0.05, 0.44444444444444
10811, 1.504347826087, 0.05, 0.41666666666667
10812, 1.4826086956522, 0.05, 0.38888888888889
10813, 1.504347826087, 0.05, 0.36111111111111
10814, 1.4826086956522, 0.05, 0.33333333333333
10815, 1.504347826087, 0.05, 0.30555555555556
10816, 1.4826086956522, 0.05, 0.27777777777778
10817, 1.504347826087, 0.05, 0.25
10818, 1.4826086956522, 0.05, 0.22222222222222
10819, 1.504347826087, 0.05, 0.19444444444444
10820, 1.4826086956522, 0.05, 0.16666666666667
10821, 1.504347826087, 0.05, 0.13888888888889
10822, 1.4826086956522, 0.05, 0.11111111111111
10823, 1.504347826087, 0.05, 0.083333333333333
10824, 1.4826086956522, 0.05, 0.055555555555556
10825, 1.504347826087, 0.05, 0.027777777777778
10826, 1.5478260869565, 0.05, 0.47222222222222
10827, 1.5260869565217, 0.05, 0.44444444444444
10828, 1.5478260869565, 0.05, 0.41666666666667
10829, 1.5260869565217, 0.05, 0.38888888888889
10830, 1.5478260869565, 0.05, 0.36111111111111
10831, 1.5260869565217, 0.05, 0.33333333333333
10832, 1.5478260869565, 0.05, 0.30555555555556
10833, 1.5260869565217, 0.05, 0.27777777777778
10834, 1.5478260869565, 0.05, 0.25
10835, 1.5260869565217, 0.05, 0.22222222222222
10836, 1.5478260869565, 0.05, 0.19444444444444
10837, 1.5260869565217, 0.05, 0.16666666666667
10838, 1.5478260869565, 0.05, 0.13888888888889
10839, 1.5260869565217, 0.05, 0.11111111111111
10840, 1.5478260869565, 0.05, 0.083333333333333
10841, 1.5260869565217, 0.05, 0.055555555555556
10842, 1.5478260869565, 0.05, 0.027777777777778
10843, 1.5913043478261, 0.05, 0.47222222222222
10844, 1.5695652173913, 0.05, 0.44444444444444
10845, 1.5913043478261, 0.05, 0.41666666666667
10846, 1.5695652173913, 0.05, 0.38888888888889
10847, 1.5913043478261, 0.05, 0.36111111111111
10848, 1.5695652173913, 0.05, 0.33333333333333
10849, 1.5913043478261, 0.05, 0.30555555555556
10850, 1.5695652173913, 0.05, 0.27777777777778
10851, 1.5913043478261, 0.05, 0.25
10852, 1.5695652173913, 0.05, 0.22222222222222
10853, 1.5913043478261, 0.05, 0.19444444444444
10854, 1.5695652173913, 0.05, 0.16666666666667
10855, 1.5913043478261, 0.05, 0.13888888888889
10856, 1.5695652173913, 0.05, 0.11111111111111
10857, 1.5913043478261, 0.05, 0.083333333333333
10858, 1.5695652173913, 0.05, 0.055555555555556
10859, 1.5913043478261, 0.05, 0.027777777777778
10860, 1.6347826086957, 0.05, 0.47222222222222
10861, 1.6130434782609, 0.05, 0.44444444444444
10862, 1.6347826086957, 0.05, 0.41666666666667
10863, 1.6130434782609, 0.05, 0.38888888888889
10864, 1.6347826086957, 0.05, 0.36111111111111
10865, 1.6130434782609, 0.05, 0.33333333333333
10866, 1.6347826086957, 0.05, 0.30555555555556
10867, 1.6130434782609, 0.05, 0.27777777777778
10868, 1.6347826086957, 0.05, 0.25
10869, 1.6130434782609, 0.05, 0.22222222222222
10870, 1.6347826086957, 0.05, 0.19444444444444
10871, 1.6130434782609, 0.05, 0.16666666666667
10872, 1.6347826086957, 0.05, 0.13888888888889
10873, 1.6130434782609, 0.05, 0.11111111111111
10874, 1.6347826086957, 0.05, 0.083333333333333
10875, 1.6130434782609, 0.05, 0.055555555555556
10876, 1.6347826086957, 0.05, 0.027777777777778
10877, 1.6782608695652, 0.05, 0.47222222222222
10878, 1.6565217391304, 0.05, 0.44444444444444
10879, 1.6782608695652, 0.05, 0.41666666666667
10880, 1.6565217391304, 0.05, 0.38888888888889
10881, 1.6782608695652, 0.05, 0.36111111111111
10882, 1.6565217391304, 0.05, 0.33333333333333
10883, 1.6782608695652, 0.05, 0.30555555555556
10884, 1.6565217391304, 0.05, 0.27777777777778
10885, 1.6782608695652, 0.05, 0.25
10886, 1.6565217391304, 0.05, 0.22222222222222
10887, 1.6782608695652, 0.05, 0.19444444444444
10888, 1.6565217391304, 0.05, 0.16666666666667
10889, 1.6782608695652, 0.05, 0.13888888888889
10890, 1.6565217391304, 0.05, 0.11111111111111
10891, 1.6782608695652, 0.05, 0.083333333333333
10892, 1.6565217391304, 0.05, 0.055555555555556
10893, 1.6782608695652, 0.05, 0.027777777777778
10894, 1.7217391304348, 0.05, 0.47222222222222
10895, 1.7, 0.05, 0.44444444444444
10896, 1.7217391304348, 0.05, 0.41666666666667
10897, 1.7, 0.05, 0.38888888888889
10898, 1.7217391304348, 0.05, 0.36111111111111
10899, 1.7, 0.05, 0.33333333333333
10900, 1.7217391304348, 0.05, 0.30555555555556
10901, 1.7, 0.05, 0.27777777777778
10902, 1.7217391304348, 0.05, 0.25
10903, 1.7, 0.05, 0.22222222222222
10904, 1.7217391304348, 0.05, 0.19444444444444
10905, 1.7, 0.05, 0.16666666666667
10906, 1.7217391304348, 0.05, 0.13888888888889
10907, 1.7, 0.05, 0.11111111111111
10908, 1.7217391304348, 0.05, 0.083333333333333
10909, 1.7, 0.05, 0.055555555555556
10910, 1.7217391304348, 0.05, 0.027777777777778
10911, 1.7652173913043, 0.05, 0.47222222222222
10912, 1.7434782608696, 0.05, 0.44444444444444
10913, 1.7652173913043, 0.05, 0.41666666666667
10914, 1.7434782608696, 0.05, 0.38888888888889
10915, 1.7652173913043, 0.05, 0.36111111111111
10916, 1.7434782608696, 0.05, 0.33333333333333
10917, 1.7652173913043, 0.05, 0.30555555555556
10918, 1.7434782608696, 0.05, 0.27777777777778
10919, 1.7652173913043, 0.05, 0.25
10920, 1.7434782608696, 0.05, 0.22222222222222
10921, 1.7652173913043, 0.05, 0.19444444444444
10922, 1.7434782608696, 0.05, 0.16666666666667
10923, 1.7652173913043, 0.05, 0.13888888888889
10924, 1.7434782608696, 0.05, 0.11111111111111
10925, 1.7652173913043, 0.05, 0.083333333333333
10926, 1.7434782608696, 0.05, 0.055555555555556
10927, 1.7652173913043, 0.05, 0.027777777777778
10928, 1.8086956521739, 0.05, 0.47222222222222
10929, 1.7869565217391, 0.05, 0.44444444444444
10930, 1.8086956521739, 0.05, 0.41666666666667
10931, 1.7869565217391, 0.05, 0.38888888888889
10932, 1.8086956521739, 0.05, 0.36111111111111
10933, 1.7869565217391, 0.05, 0.33333333333333
10934, 1.8086956521739, 0.05, 0.30555555555556
10935, 1.7869565217391, 0.05, 0.27777777777778
10936, 1.8086956521739, 0.05, 0.25
10937, 1.7869565217391, 0.05, 0.22222222222222
10938, 1.8086956521739, 0.05, 0.19444444444444
10939, 1.7869565217391, 0.05, 0.16666666666667
10940, 1.8086956521739, 0.05, 0.13888888888889
10941, 1.7869565217391, 0.05, 0.11111111111111
10942, 1.8086956521739, 0.05, 0.083333333333333
10943, 1.7869565217391, 0.05, 0.055555555555556
10944, 1.8086956521739, 0.05, 0.027777777777778
10945, 1.8521739130435, 0.05, 0.47222222222222
10946, 1.8304347826087, 0.05, 0.44444444444444
10947, 1.8521739130435, 0.05, 0.41666666666667
10948, 1.8304347826087, 0.05, 0.38888888888889
10949, 1.8521739130435, 0.05, 0.36111111111111
10950, 1.8304347826087, 0.05, 0.33333333333333
10951, 1.8521739130435, 0.05, 0.30555555555556
10952, 1.8304347826087, 0.05, 0.27777777777778
10953, 1.8521739130435, 0.05, 0.25
10954, 1.8304347826087, 0.05, 0.22222222222222
10955, 1.8521739130435, 0.05, 0.19444444444444
10956, 1.8304347826087, 0.05, 0.16666666666667
10957, 1.8521739130435, 0.05, 0.13888888888889
10958, 1.8304347826087, 0.05, 0.11111111111111
10959, 1.8521739130435, 0.05, 0.083333333333333
10960, 1.8304347826087, 0.05, 0.055555555555556
10961, 1.8521739130435, 0.05, 0.027777777777778
10962, 1.895652173913, 0.05, 0.47222222222222
10963, 1.8739130434783, 0.05, 0.44444444444444
10964, 1.895652173913, 0.05, 0.41666666666667
10965, 1.8739130434783, 0.05, 0.38888888888889
10966, 1.895652173913, 0.05, 0.36111111111111
10967, 1.8739130434783, 0.05, 0.33333333333333
10968, 1.895652173913, 0.05, 0.30555555555556
10969, 1.8739130434783, 0.05, 0.27777777777778
10970, 1.895652173913, 0.05, 0.25
10971, 1.8739130434783, 0.05, 0.22222222222222
10972, 1.895652173913, 0.05, 0.19444444444444
10973, 1.8739130434783, 0.05, 0.16666666666667
10974, 1.895652173913, 0.05, 0.13888888888889
10975, 1.8739130434783, 0.05, 0.11111111111111
10976, 1.895652173913, 0.05, 0.083333333333333
10977, 1.8739130434783, 0.05, 0.055555555555556
10978, 1.895652173913, 0.05, 0.027777777777778
10979, 1.9391304347826, 0.05, 0.47222222222222
10980, 1.9173913043478, 0.05, 0.44444444444444
10981, 1.9391304347826, 0.05, 0.41666666666667
10982, 1.9173913043478, 0.05, 0.38888888888889
10983, 1.9391304347826, 0.05, 0.36111111111111
10984, 1.9173913043478, 0.05, 0.33333333333333
10985, 1.9391304347826, 0.05, 0.30555555555556
10986, 1.9173913043478, 0.05, 0.27777777777778
10987, 1.9391304347826, 0.05, 0.25
10988, 1.9173913043478, 0.05, 0.22222222222222
10989, 1.9391304347826, 0.05, 0.19444444444444
10990, 1.9173913043478, 0.05, 0.16666666666667
10991, 1.9391304347826, 0.05, 0.13888888888889
10992, 1.9173913043478, 0.05, 0.11111111111111
10993, 1.9391304347826, 0.05, 0.083333333333333
10994, 1.9173913043478, 0.05, 0.055555555555556
10995, 1.9391304347826, 0.05, 0.027777777777778
10996, 1.9826086956522, 0.05, 0.47222222222222
10997, 1.9608695652174, 0.05, 0.44444444444444
10998, 1.9826086956522, 0.05, 0.41666666666667
10999, 1.9608695652174, 0.05, 0.38888888888889
11000, 1.9826086956522, 0.05, 0.36111111111111
11001, 1.9608695652174, 0.05, 0.33333333333333
11002, 1.9826086956522, 0.05, 0.30555555555556
11003, 1.9608695652174, 0.05, 0.27777777777778
11004, 1.9826086956522, 0.05, 0.25
11005, 1.9608695652174, 0.05, 0.22222222222222
11006, 1.9826086956522, 0.05, 0.19444444444444
11007, 1.9608695652174, 0.05, 0.16666666666667
11008, 1.9826086956522, 0.05, 0.13888888888889
11009, 1.9608695652174, 0.05, 0.11111111111111
11010, 1.9826086956522, 0.05, 0.083333333333333
11011, 1.9608695652174, 0.05, 0.055555555555556
11012, 1.9826086956522, 0.05, 0.027777777777778
11013, 2.0260869565217, 0.05, 0.47222222222222
11014, 2.004347826087, 0.05, 0.44444444444444
11015, 2.0260869565217, 0.05, 0.41666666666667
11016, 2.004347826087, 0.05, 0.38888888888889
11017, 2.0260869565217, 0.05, 0.36111111111111
11018, 2.004347826087, 0.05, 0.33333333333333
11019, 2.0260869565217, 0.05, 0.30555555555556
11020, 2.004347826087, 0.05, 0.27777777777778
11021, 2.0260869565217, 0.05, 0.25
11022, 2.004347826087, 0.05, 0.22222222222222
11023, 2.0260869565217, 0.05, 0.19444444444444
11024, 2.004347826087, 0.05, 0.16666666666667
11025, 2.0260869565217, 0.05, 0.13888888888889
11026, 2.004347826087, 0.05, 0.11111111111111
11027, 2.0260869565217, 0.05, 0.083333333333333
11028, 2.004347826087, 0.05, 0.055555555555556
11029, 2.0260869565217, 0.05, 0.027777777777778
11030, 2.0695652173913, 0.05, 0.47222222222222
11031, 2.0478260869565, 0.05, 0.44444444444444
11032, 2.0695652173913, 0.05, 0.41666666666667
11033, 2.0478260869565, 0.05, 0.38888888888889
11034, 2.0695652173913, 0.05, 0.36111111111111
11035, 2.0478260869565, 0.05, 0.33333333333333
11036, 2.0695652173913, 0.05, 0.30555555555556
11037, 2.0478260869565, 0.05, 0.27777777777778
11038, 2.0695652173913, 0.05, 0.25
11039, 2.0478260869565, 0.05, 0.22222222222222
11040, 2.0695652173913, 0.05, 0.19444444444444
11041, 2.0478260869565, 0.05, 0.16666666666667
11042, 2.0695652173913, 0.05, 0.13888888888889
11043, 2.0478260869565, 0.05, 0.11111111111111
11044, 2.0695652173913, 0.05, 0.083333333333333
11045, 2.0478260869565, 0.05, 0.055555555555556
11046, 2.0695652173913, 0.05, 0.027777777777778
11047, 2.1130434782609, 0.05, 0.47222222222222
11048, 2.0913043478261, 0.05, 0.44444444444444
11049, 2.1130434782609, 0.05, 0.41666666666667
11050, 2.0913043478261, 0.05, 0.38888888888889
11051, 2.1130434782609, 0.05, 0.36111111111111
11052, 2.0913043478261, 0.05, 0.33333333333333
11053, 2.1130434782609, 0.05, 0.30555555555556
11054, 2.0913043478261, 0.05, 0.27777777777778
11055, 2.1130434782609, 0.05, 0.25
11056, 2.0913043478261, 0.05, 0.22222222222222
11057, 2.1130434782609, 0.05, 0.19444444444444
11058, 2.0913043478261, 0.05, 0.16666666666667
11059, 2.1130434782609, 0.05, 0.13888888888889
11060, 2.0913043478261, 0.05, 0.11111111111111
11061, 2.1130434782609, 0.05, 0.083333333333333
11062, 2.0913043478261, 0.05, 0.055555555555556
11063, 2.1130434782609, 0.05, 0.027777777777778
11064, 2.1565217391304, 0.05, 0.47222222222222
11065, 2.1347826086957, 0.05, 0.44444444444444
11066, 2.1565217391304, 0.05, 0.41666666666667
11067, 2.1347826086957, 0.05, 0.38888888888889
11068, 2.1565217391304, 0.05, 0.36111111111111
11069, 2.1347826086957, 0.05, 0.33333333333333
11070, 2.1565217391304, 0.05, 0.30555555555556
11071, 2.1347826086957, 0.05, 0.27777777777778
11072, 2.1565217391304, 0.05, 0.25
11073, 2.1347826086957, 0.05, 0.22222222222222
11074, 2.1565217391304, 0.05, 0.19444444444444
11075, 2.1347826086957, 0.05, 0.16666666666667
11076, 2.1565217391304, 0.05, 0.13888888888889
11077, 2.1347826086957, 0.05, 0.11111111111111
11078, 2.1565217391304, 0.05, 0.083333333333333
11079, 2.1347826086957, 0.05, 0.055555555555556
11080, 2.1565217391304, 0.05, 0.027777777777778
11081, 2.1782608695652, 0.05, 0.44444444444444
11082, 2.1782608695652, 0.05, 0.38888888888889
11083, 2.1782608695652, 0.05, 0.33333333333333
11084, 2.1782608695652, 0.05, 0.27777777777778
11085, 2.1782608695652, 0.05, 0.22222222222222
11086, 2.1782608695652, 0.05, 0.16666666666667
11087, 2.1782608695652, 0.05, 0.11111111111111
11088, 2.1782608695652, 0.05, 0.055555555555556
11089, 2.25, 0.016666666666667, 0.5
11090, 2.25, -0.016666666666667, 0.5
11091, 2.225, 0.016666666666667, 0.5
11092, 2.25, 0.033333333333333, 0.5
11093, 2.225, -0.016666666666667, 0.5
11094, 2.25, -1.1102230246252e-16, 0.5
11095, 2.25, -0.033333333333333, 0.5
11096, 2.275, 0.016666666666667, 0.5
11097, 2.275, -0.016666666666667, 0.5
11098, 2.25, 0.016666666666667, 0
11099, 2.25, -0.016666666666667, 0
11100, 2.25, 0.033333333333333, 0
11101, 2.225, 0.016666666666667, 0
11102, 2.25, -1.1102230246252e-16, 0
11103, 2.225, -0.016666666666667, 0
11104, 2.25, -0.033333333333333, 0
11105, 2.275, 0.016666666666667, 0
11106, 2.275, -0.016666666666667, 0
11107, 2.25, 0.05, 0.44444444444444
11108, 2.25, 0.05, 0.38888888888889
11109, 2.25, 0.05, 0.33333333333333
11110, 2.25, 0.05, 0.27777777777778
11111, 2.25, 0.05, 0.22222222222222
11112, 2.25, 0.05, 0.16666666666667
11113, 2.25, 0.05, 0.11111111111111
11114, 2.25, 0.05, 0.055555555555556
11115, 2.25, 0.05, 0.47222222222222
11116, 2.225, 0.05, 0.44444444444444
11117, 2.25, 0.05, 0.41666666666667
11118, 2.225, 0.05, 0.38888888888889
11119, 2.25, 0.05, 0.36111111111111
11120, 2.225, 0.05, 0.33333333333333
11121, 2.25, 0.05, 0.30555555555556
11122, 2.225, 0.05, 0.27777777777778
11123, 2.25, 0.05, 0.25
11124, 2.225, 0.05, 0.22222222222222
11125, 2.25, 0.05, 0.19444444444444
11126, 2.225, 0.05, 0.16666666666667
11127, 2.25, 0.05, 0.13888888888889
11128, 2.225, 0.05, 0.11111111111111
11129, 2.25, 0.05, 0.083333333333333
11130, 2.225, 0.05, 0.055555555555556
11131, 2.25, 0.05, 0.027777777777778
11132, 2.275, 0.05, 0.44444444444444
11133, 2.275, 0.05, 0.38888888888889
11134, 2.275, 0.05, 0.33333333333333
11135, 2.275, 0.05, 0.27777777777778
11136, 2.275, 0.05, 0.22222222222222
11137, 2.275, 0.05, 0.16666666666667
11138, 2.275, 0.05, 0.11111111111111
11139, 2.275, 0.05, 0.055555555555556
11140, 2.25, -0.05, 0.44444444444444
11141, 2.25, -0.05, 0.38888888888889
11142, 2.25, -0.05, 0.33333333333333
11143, 2.25, -0.05, 0.27777777777778
11144, 2.25, -0.05, 0.22222222222222
11145, 2.25, -0.05, 0.16666666666667
11146, 2.25, -0.05, 0.11111111111111
11147, 2.25, -0.05, 0.055555555555556
11148, 2.225, -0.05, 0.44444444444444
11149, 2.25, -0.05, 0.47222222222222
11150, 2.225, -0.05, 0.38888888888889
11151, 2.25, -0.05, 0.41666666666667
11152, 2.225, -0.05, 0.33333333333333
11153, 2.25, -0.05, 0.36111111111111
11154, 2.225, -0.05, 0.27777777777778
11155, 2.25, -0.05, 0.30555555555556
11156, 2.225, -0.05, 0.22222222222222
11157, 2.25, -0.05, 0.25
11158, 2.225, -0.05, 0.16666666666667
11159, 2.25, -0.05, 0.19444444444444
11160, 2.225, -0.05, 0.11111111111111
11161, 2.25, -0.05, 0.13888888888889
11162, 2.225, -0.05, 0.055555555555556
11163, 2.25, -0.05, 0.083333333333333
11164, 2.25, -0.05, 0.027777777777778
11165, 2.275, -0.05, 0.44444444444444
11166, 2.275, -0.05, 0.38888888888889
11167, 2.275, -0.05, 0.33333333333333
11168, 2.275, -0.05, 0.27777777777778
11169, 2.275, -0.05, 0.22222222222222
11170, 2.275, -0.05, 0.16666666666667
11171, 2.275, -0.05, 0.11111111111111
11172, 2.275, -0.05, 0.055555555555556
11173, 2.3, 0.016666666666667, 0.44444444444444
11174, 2.3, 0.016666666666667, 0.38888888888889
11175, 2.3, 0.016666666666667, 0.33333333333333
11176, 2.3, 0.016666666666667, 0.27777777777778
11177, 2.3, 0.016666666666667, 0.22222222222222
11178, 2.3, 0.016666666666667, 0.16666666666667
11179, 2.3, 0.016666666666667, 0.11111111111111
11180, 2.3, 0.016666666666667, 0.055555555555556
11181, 2.3, -0.016666666666667, 0.44444444444444
11182, 2.3, -0.016666666666667, 0.38888888888889
11183, 2.3, -0.016666666666667, 0.33333333333333
11184, 2.3, -0.016666666666667, 0.27777777777778
11185, 2.3, -0.016666666666667, 0.22222222222222
11186, 2.3, -0.016666666666667, 0.16666666666667
11187, 2.3, -0.016666666666667, 0.11111111111111
11188, 2.3, -0.016666666666667, 0.055555555555556
11189, 2.3, 0.016666666666667, 0.47222222222222
11190, 2.3, 0.033333333333333, 0.44444444444444
11191, 2.3, 0.016666666666667, 0.41666666666667
11192, 2.3, 0.033333333333333, 0.38888888888889
11193, 2.3, 0.016666666666667, 0.36111111111111
11194, 2.3, 0.033333333333333, 0.33333333333333
11195, 2.3, 0.016666666666667, 0.30555555555556
11196, 2.3, 0.033333333333333, 0.27777777777778
11197, 2.3, 0.016666666666667, 0.25
11198, 2.3, 0.033333333333333, 0.22222222222222
11199, 2.3, 0.016666666666667, 0.19444444444444
11200, 2.3, 0.033333333333333, 0.16666666666667
11201, 2.3, 0.016666666666667, 0.13888888888889
11202, 2.3, 0.033333333333333, 0.11111111111111
11203, 2.3, 0.016666666666667, 0.083333333333333
11204, 2.3, 0.033333333333333, 0.055555555555556
11205, 2.3, 0.016666666666667, 0.027777777777778
11206, 2.3, -0.016666666666667, 0.47222222222222
11207, 2.3, -1.3877787807814e-16, 0.44444444444444
11208, 2.3, -0.016666666666667, 0.41666666666667
11209, 2.3, -1.3183898417424e-16, 0.38888888888889
11210, 2.3, -0.016666666666667, 0.36111111111111
11211, 2.3, -1.3183898417424e-16, 0.33333333333333
11212, 2.3, -0.016666666666667, 0.30555555555556
11213, 2.3, -1.3183898417424e-16, 0.27777777777778
11214, 2.3, -0.016666666666667, 0.25
11215, 2.3, -1.3183898417424e-16, 0.22222222222222
11216, 2.3, -0.016666666666667, 0.19444444444444
11217, 2.3, -1.3183898417424e-16, 0.16666666666667
11218, 2.3, -0.016666666666667, 0.13888888888889
11219, 2.3, -1.3183898417424e-16, 0.11111111111111
11220, 2.3, -0.016666666666667, 0.083333333333333
11221, 2.3, -1.3877787807814e-16, 0.055555555555556
11222, 2.3, -0.016666666666667, 0.027777777777778
11223, 2.3, -0.033333333333333, 0.44444444444444
11224, 2.3, -0.033333333333333, 0.38888888888889
11225, 2.3, -0.033333333333333, 0.33333333333333
11226, 2.3, -0.033333333333333, 0.27777777777778
11227, 2.3, -0.033333333333333, 0.22222222222222
11228, 2.3, -0.033333333333333, 0.16666666666667
11229, 2.3, -0.033333333333333, 0.11111111111111
11230, 2.3, -0.033333333333333, 0.055555555555556
11231, 2.25, -0.1, 0.5
11232, 2.25, -0.15, 0.5
11233, 2.25, -0.2, 0.5
11234, 2.225, -0.1, 0.5
11235, 2.25, -0.075, 0.5
11236, 2.275, -0.1, 0.5
11237, 2.225, -0.15, 0.5
11238, 2.25, -0.125, 0.5
11239, 2.275, -0.15, 0.5
11240, 2.225, -0.2, 0.5
11241, 2.25, -0.175, 0.5
11242, 2.275, -0.2, 0.5
11243, 2.25, -0.225, 0.5
11244, 2.25, -0.1, 0
11245, 2.25, -0.15, 0
11246, 2.25, -0.2, 0
11247, 2.25, -0.075, 0
11248, 2.225, -0.1, 0
11249, 2.275, -0.1, 0
11250, 2.25, -0.125, 0
11251, 2.225, -0.15, 0
11252, 2.275, -0.15, 0
11253, 2.25, -0.175, 0
11254, 2.225, -0.2, 0
11255, 2.275, -0.2, 0
11256, 2.25, -0.225, 0
11257, 2.3, -0.1, 0.44444444444444
11258, 2.3, -0.1, 0.38888888888889
11259, 2.3, -0.1, 0.33333333333333
11260, 2.3, -0.1, 0.27777777777778
11261, 2.3, -0.1, 0.22222222222222
11262, 2.3, -0.1, 0.16666666666667
11263, 2.3, -0.1, 0.11111111111111
11264, 2.3, -0.1, 0.055555555555556
11265, 2.3, -0.15, 0.44444444444444
11266, 2.3, -0.15, 0.38888888888889
11267, 2.3, -0.15, 0.33333333333333
11268, 2.3, -0.15, 0.27777777777778
11269, 2.3, -0.15, 0.22222222222222
11270, 2.3, -0.15, 0.16666666666667
11271, 2.3, -0.15, 0.11111111111111
11272, 2.3, -0.15, 0.055555555555556
11273, 2.3, -0.2, 0.44444444444444
11274, 2.3, -0.2, 0.38888888888889
11275, 2.3, -0.2, 0.33333333333333
11276, 2.3, -0.2, 0.27777777777778
11277, 2.3, -0.2, 0.22222222222222
11278, 2.3, -0.2, 0.16666666666667
11279, 2.3, -0.2, 0.11111111111111
11280, 2.3, -0.2, 0.055555555555556
11281, 2.3, -0.1, 0.47222222222222
11282, 2.3, -0.075, 0.44444444444444
11283, 2.3, -0.1, 0.41666666666667
11284, 2.3, -0.075, 0.38888888888889
11285, 2.3, -0.1, 0.36111111111111
11286, 2.3, -0.075, 0.33333333333333
11287, 2.3, -0.1, 0.30555555555556
11288, 2.3, -0.075, 0.27777777777778
11289, 2.3, -0.1, 0.25
11290, 2.3, -0.075, 0.22222222222222
11291, 2.3, -0.1, 0.19444444444444
11292, 2.3, -0.075, 0.16666666666667
11293, 2.3, -0.1, 0.13888888888889
11294, 2.3, -0.075, 0.11111111111111
11295, 2.3, -0.1, 0.083333333333333
11296, 2.3, -0.075, 0.055555555555556
11297, 2.3, -0.1, 0.027777777777778
11298, 2.3, -0.15, 0.47222222222222
11299, 2.3, -0.125, 0.44444444444444
11300, 2.3, -0.15, 0.41666666666667
11301, 2.3, -0.125, 0.38888888888889
11302, 2.3, -0.15, 0.36111111111111
11303, 2.3, -0.125, 0.33333333333333
11304, 2.3, -0.15, 0.30555555555556
11305, 2.3, -0.125, 0.27777777777778
11306, 2.3, -0.15, 0.25
11307, 2.3, -0.125, 0.22222222222222
11308, 2.3, -0.15, 0.19444444444444
11309, 2.3, -0.125, 0.16666666666667
11310, 2.3, -0.15, 0.13888888888889
11311, 2.3, -0.125, 0.11111111111111
11312, 2.3, -0.15, 0.083333333333333
11313, 2.3, -0.125, 0.055555555555556
11314, 2.3, -0.15, 0.027777777777778
11315, 2.3, -0.2, 0.47222222222222
11316, 2.3, -0.175, 0.44444444444444
11317, 2.3, -0.2, 0.41666666666667
11318, 2.3, -0.175, 0.38888888888889
11319, 2.3, -0.2, 0.36111111111111
11320, 2.3, -0.175, 0.33333333333333
11321, 2.3, -0.2, 0.30555555555556
11322, 2.3, -0.175, 0.27777777777778
11323, 2.3, -0.2, 0.25
11324, 2.3, -0.175, 0.22222222222222
11325, 2.3, -0.2, 0.19444444444444
11326, 2.3, -0.175, 0.16666666666667
11327, 2.3, -0.2, 0.13888888888889
11328, 2.3, -0.175, 0.11111111111111
11329, 2.3, -0.2, 0.083333333333333
11330, 2.3, -0.175, 0.055555555555556
11331, 2.3, -0.2, 0.027777777777778
11332, 2.3, -0.225, 0.44444444444444
11333, 2.3, -0.225, 0.38888888888889
11334, 2.3, -0.225, 0.33333333333333
11335, 2.3, -0.225, 0.27777777777778
11336, 2.3, -0.225, 0.22222222222222
11337, 2.3, -0.225, 0.16666666666667
11338, 2.3, -0.225, 0.11111111111111
11339, 2.3, -0.225, 0.055555555555556
11340, 2.25, -0.25, 0.44444444444444
11341, 2.25, -0.25, 0.38888888888889
11342, 2.25, -0.25, 0.33333333333333
11343, 2.25, -0.25, 0.27777777777778
11344, 2.25, -0.25, 0.22222222222222
11345, 2.25, -0.25, 0.16666666666667
11346, 2.25, -0.25, 0.11111111111111
11347, 2.25, -0.25, 0.055555555555556
11348, 2.225, -0.25, 0.44444444444444
11349, 2.25, -0.25, 0.47222222222222
11350, 2.225, -0.25, 0.38888888888889
11351, 2.25, -0.25, 0.41666666666667
11352, 2.225, -0.25, 0.33333333333333
11353, 2.25, -0.25, 0.36111111111111
11354, 2.225, -0.25, 0.27777777777778
11355, 2.25, -0.25, 0.30555555555556
11356, 2.225, -0.25, 0.22222222222222
11357, 2.25, -0.25, 0.25
11358, 2.225, -0.25, 0.16666666666667
11359, 2.25, -0.25, 0.19444444444444
11360, 2.225, -0.25, 0.11111111111111
11361, 2.25, -0.25, 0.13888888888889
11362, 2.225, -0.25, 0.055555555555556
11363, 2.25, -0.25, 0.083333333333333
11364, 2.25, -0.25, 0.027777777777778
11365, 2.275, -0.25, 0.44444444444444
11366, 2.275, -0.25, 0.38888888888889
11367, 2.275, -0.25, 0.33333333333333
11368, 2.275, -0.25, 0.27777777777778
11369, 2.275, -0.25, 0.22222222222222
11370, 2.275, -0.25, 0.16666666666667
11371, 2.275, -0.25, 0.11111111111111
11372, 2.275, -0.25, 0.055555555555556
11373, 0.95652173913043, 1.4833333333333, 0
11374, 0.91304347826087, 1.4833333333333, 0
11375, 0.8695652173913, 1.4833333333333, 0
11376, 0.82608695652174, 1.4833333333333, 0
11377, 0.78260869565217, 1.4833333333333, 0
11378, 0.73913043478261, 1.4833333333333, 0
11379, 0.69565217391304, 1.4833333333333, 0
11380, 0.65217391304348, 1.4833333333333, 0
11381, 0.60869565217391, 1.4833333333333, 0
11382, 0.56521739130435, 1.4833333333333, 0
11383, 0.52173913043478, 1.4833333333333, 0
11384, 0.47826086956522, 1.4833333333333, 0
11385, 0.43478260869565, 1.4833333333333, 0
11386, 0.39130434782609, 1.4833333333333, 0
11387, 0.34782608695652, 1.4833333333333, 0
11388, 0.30434782608696, 1.4833333333333, 0
11389, 0.26086956521739, 1.4833333333333, 0
11390, 0.21739130434783, 1.4833333333333, 0
11391, 0.17391304347826, 1.4833333333333, 0
11392, 0.1304347826087, 1.4833333333333, 0
11393, 0.08695652173913, 1.4833333333333, 0
11394, 0.043478260869565, 1.4833333333333, 0
11395, 0.95652173913043, 1.5166666666667, 0
11396, 0.91304347826087, 1.5166666666667, 0
11397, 0.8695652173913, 1.5166666666667, 0
11398, 0.82608695652174, 1.5166666666667, 0
11399, 0.78260869565217, 1.5166666666667, 0
11400, 0.73913043478261, 1.5166666666667, 0
11401, 0.69565217391304, 1.5166666666667, 0
11402, 0.65217391304348, 1.5166666666667, 0
11403, 0.60869565217391, 1.5166666666667, 0
11404, 0.56521739130435, 1.5166666666667, 0
11405, 0.52173913043478, 1.5166666666667, 0
11406, 0.47826086956522, 1.5166666666667, 0
11407, 0.43478260869565, 1.5166666666667, 0
11408, 0.39130434782609, 1.5166666666667, 0
11409, 0.34782608695652, 1.5166666666667, 0
11410, 0.30434782608696, 1.5166666666667, 0
11411, 0.26086956521739, 1.5166666666667, 0
11412, 0.21739130434783, 1.5166666666667, 0
11413, 0.17391304347826, 1.5166666666667, 0
11414, 0.1304347826087, 1.5166666666667, 0
11415, 0.08695652173913, 1.5166666666667, 0
11416, 0.043478260869565, 1.5166666666667, 0
11417, 0.95652173913043, 1.4666666666667, 0
11418, 0.97826086956522, 1.4833333333333, 0
11419, 0.91304347826087, 1.4666666666667, 0
11420, 0.93478260869565, 1.4833333333333, 0
11421, 0.8695652173913, 1.4666666666667, 0
11422, 0.89130434782609, 1.4833333333333, 0
11423, 0.82608695652174, 1.4666666666667, 0
11424, 0.84782608695652, 1.4833333333333, 0
11425, 0.78260869565217, 1.4666666666667, 0
11426, 0.80434782608696, 1.4833333333333, 0
11427, 0.73913043478261, 1.4666666666667, 0
11428, 0.76086956521739, 1.4833333333333, 0
11429, 0.69565217391304, 1.4666666666667, 0
11430, 0.71739130434783, 1.4833333333333, 0
11431, 0.65217391304348, 1.4666666666667, 0
11432, 0.67391304347826, 1.4833333333333, 0
11433, 0.60869565217391, 1.4666666666667, 0
11434, 0.6304347826087, 1.4833333333333, 0
11435, 0.56521739130435, 1.4666666666667, 0
11436, 0.58695652173913, 1.4833333333333, 0
11437, 0.52173913043478, 1.4666666666667, 0
11438, 0.54347826086957, 1.4833333333333, 0
11439, 0.47826086956522, 1.4666666666667, 0
11440, 0.5, 1.4833333333333, 0
11441, 0.43478260869565, 1.4666666666667, 0
11442, 0.45652173913043, 1.4833333333333, 0
11443, 0.39130434782609, 1.4666666666667, 0
11444, 0.41304347826087, 1.4833333333333, 0
11445, 0.34782608695652, 1.4666666666667, 0
11446, 0.3695652173913, 1.4833333333333, 0
11447, 0.30434782608696, 1.4666666666667, 0
11448, 0.32608695652174, 1.4833333333333, 0
11449, 0.26086956521739, 1.4666666666667, 0
11450, 0.28260869565217, 1.4833333333333, 0
11451, 0.21739130434783, 1.4666666666667, 0
11452, 0.23913043478261, 1.4833333333333, 0
11453, 0.17391304347826, 1.4666666666667, 0
11454, 0.19565217391304, 1.4833333333333, 0
11455, 0.1304347826087, 1.4666666666667, 0
11456, 0.15217391304348, 1.4833333333333, 0
11457, 0.08695652173913, 1.4666666666667, 0
11458, 0.10869565217391, 1.4833333333333, 0
11459, 0.043478260869565, 1.4666666666667, 0
11460, 0.065217391304348, 1.4833333333333, 0
11461, 0.021739130434783, 1.4833333333333, 0
11462, 0.95652173913043, 1.5, 0
11463, 0.97826086956522, 1.5166666666667, 0
11464, 0.91304347826087, 1.5, 0
11465, 0.93478260869565, 1.5166666666667, 0
11466, 0.8695652173913, 1.5, 0
11467, 0.89130434782609, 1.5166666666667, 0
11468, 0.82608695652174, 1.5, 0
11469, 0.84782608695652, 1.5166666666667, 0
11470, 0.78260869565217, 1.5, 0
11471, 0.80434782608696, 1.5166666666667, 0
11472, 0.73913043478261, 1.5, 0
11473, 0.76086956521739, 1.5166666666667, 0
11474, 0.69565217391304, 1.5, 0
11475, 0.71739130434783, 1.5166666666667, 0
11476, 0.65217391304348, 1.5, 0
11477, 0.67391304347826, 1.5166666666667, 0
11478, 0.60869565217391, 1.5, 0
11479, 0.6304347826087, 1.5166666666667, 0
11480, 0.56521739130435, 1.5, 0
11481, 0.58695652173913, 1.5166666666667, 0
11482, 0.52173913043478, 1.5, 0
11483, 0.54347826086957, 1.5166666666667, 0
11484, 0.47826086956522, 1.5, 0
11485, 0.5, 1.5166666666667, 0
11486, 0.43478260869565, 1.5, 0
11487, 0.45652173913043, 1.5166666666667, 0
11488, 0.39130434782609, 1.5, 0
11489, 0.41304347826087, 1.5166666666667, 0
11490, 0.34782608695652, 1.5, 0
11491, 0.3695652173913, 1.5166666666667, 0
11492, 0.30434782608696, 1.5, 0
11493, 0.32608695652174, 1.5166666666667, 0
11494, 0.26086956521739, 1.5, 0
11495, 0.28260869565217, 1.5166666666667, 0
11496, 0.21739130434783, 1.5, 0
11497, 0.23913043478261, 1.5166666666667, 0
11498, 0.17391304347826, 1.5, 0
11499, 0.19565217391304, 1.5166666666667, 0
11500, 0.1304347826087, 1.5, 0
11501, 0.15217391304348, 1.5166666666667, 0
11502, 0.08695652173913, 1.5, 0
11503, 0.10869565217391, 1.5166666666667, 0
11504, 0.043478260869565, 1.5, 0
11505, 0.065217391304348, 1.5166666666667, 0
11506, 0.021739130434783, 1.5166666666667, 0
11507, 0.95652173913043, 1.5333333333333, 0
11508, 0.91304347826087, 1.5333333333333, 0
11509, 0.8695652173913, 1.5333333333333, 0
11510, 0.82608695652174, 1.5333333333333, 0
11511, 0.78260869565217, 1.5333333333333, 0
11512, 0.73913043478261, 1.5333333333333, 0
11513, 0.69565217391304, 1.5333333333333, 0
11514, 0.65217391304348, 1.5333333333333, 0
11515, 0.60869565217391, 1.5333333333333, 0
11516, 0.56521739130435, 1.5333333333333, 0
11517, 0.52173913043478, 1.5333333333333, 0
11518, 0.47826086956522, 1.5333333333333, 0
11519, 0.43478260869565, 1.5333333333333, 0
11520, 0.39130434782609, 1.5333333333333, 0
11521, 0.34782608695652, 1.5333333333333, 0
11522, 0.30434782608696, 1.5333333333333, 0
11523, 0.26086956521739, 1.5333333333333, 0
11524, 0.21739130434783, 1.5333333333333, 0
11525, 0.17391304347826, 1.5333333333333, 0
11526, 0.1304347826087, 1.5333333333333, 0
11527, 0.08695652173913, 1.5333333333333, 0
11528, 0.043478260869565, 1.5333333333333, 0
11529, 1, 1.4833333333333, 0.44444444444444
11530, 1, 1.4833333333333, 0.38888888888889
11531, 1, 1.4833333333333, 0.33333333333333
11532, 1, 1.4833333333333, 0.27777777777778
11533, 1, 1.4833333333333, 0.22222222222222
11534, 1, 1.4833333333333, 0.16666666666667
11535, 1, 1.4833333333333, 0.11111111111111
11536, 1, 1.4833333333333, 0.055555555555556
11537, 1, 1.5166666666667, 0.44444444444444
11538, 1, 1.5166666666667, 0.38888888888889
11539, 1, 1.5166666666667, 0.33333333333333
11540, 1, 1.5166666666667, 0.27777777777778
11541, 1, 1.5166666666667, 0.22222222222222
11542, 1, 1.5166666666667, 0.16666666666667
11543, 1, 1.5166666666667, 0.11111111111111
11544, 1, 1.5166666666667, 0.055555555555556
11545, 1, 1.4666666666667, 0.44444444444444
11546, 1, 1.4833333333333, 0.47222222222222
11547, 1, 1.4666666666667, 0.38888888888889
11548, 1, 1.4833333333333, 0.41666666666667
11549, 1, 1.4666666666667, 0.33333333333333
11550, 1, 1.4833333333333, 0.36111111111111
11551, 1, 1.4666666666667, 0.27777777777778
11552, 1, 1.4833333333333, 0.30555555555556
11553, 1, 1.4666666666667, 0.22222222222222
11554, 1, 1.4833333333333, 0.25
11555, 1, 1.4666666666667, 0.16666666666667
11556, 1, 1.4833333333333, 0.19444444444444
11557, 1, 1.4666666666667, 0.11111111111111
11558, 1, 1.4833333333333, 0.13888888888889
11559, 1, 1.4666666666667, 0.055555555555556
11560, 1, 1.4833333333333, 0.083333333333333
11561, 1, 1.4833333333333, 0.027777777777778
11562, 1, 1.5, 0.44444444444444
11563, 1, 1.5166666666667, 0.47222222222222
11564, 1, 1.5, 0.38888888888889
11565, 1, 1.5166666666667, 0.41666666666667
11566, 1, 1.5, 0.33333333333333
11567, 1, 1.5166666666667, 0.36111111111111
11568, 1, 1.5, 0.27777777777778
11569, 1, 1.5166666666667, 0.30555555555556
11570, 1, 1.5, 0.22222222222222
11571, 1, 1.5166666666667, 0.25
11572, 1, 1.5, 0.16666666666667
11573, 1, 1.5166666666667, 0.19444444444444
11574, 1, 1.5, 0.11111111111111
11575, 1, 1.5166666666667, 0.13888888888889
11576, 1, 1.5, 0.055555555555556
11577, 1, 1.5166666666667, 0.083333333333333
11578, 1, 1.5166666666667, 0.027777777777778
11579, 1, 1.5333333333333, 0.44444444444444
11580, 1, 1.5333333333333, 0.38888888888889
11581, 1, 1.5333333333333, 0.33333333333333
11582, 1, 1.5333333333333, 0.27777777777778
11583, 1, 1.5333333333333, 0.22222222222222
11584, 1, 1.5333333333333, 0.16666666666667
11585, 1, 1.5333333333333, 0.11111111111111
11586, 1, 1.5333333333333, 0.055555555555556
11587, 0.95652173913043, 1.4833333333333, 0.5
11588, 0.91304347826087, 1.4833333333333, 0.5
11589, 0.8695652173913, 1.4833333333333, 0.5
11590, 0.82608695652174, 1.4833333333333, 0.5
11591, 0.78260869565217, 1.4833333333333, 0.5
11592, 0.73913043478261, 1.4833333333333, 0.5
11593, 0.69565217391304, 1.4833333333333, 0.5
11594, 0.65217391304348, 1.4833333333333, 0.5
11595, 0.60869565217391, 1.4833333333333, 0.5
11596, 0.56521739130435, 1.4833333333333, 0.5
11597, 0.52173913043478, 1.4833333333333, 0.5
11598, 0.47826086956522, 1.4833333333333, 0.5
11599, 0.43478260869565, 1.4833333333333, 0.5
11600, 0.39130434782609, 1.4833333333333, 0.5
11601, 0.34782608695652, 1.4833333333333, 0.5
11602, 0.30434782608696, 1.4833333333333, 0.5
11603, 0.26086956521739, 1.4833333333333, 0.5
11604, 0.21739130434783, 1.4833333333333, 0.5
11605, 0.17391304347826, 1.4833333333333, 0.5
11606, 0.1304347826087, 1.4833333333333, 0.5
11607, 0.08695652173913, 1.4833333333333, 0.5
11608, 0.043478260869565, 1.4833333333333, 0.5
11609, 0.95652173913043, 1.5166666666667, 0.5
11610, 0.91304347826087, 1.5166666666667, 0.5
11611, 0.8695652173913, 1.5166666666667, 0.5
11612, 0.82608695652174, 1.5166666666667, 0.5
11613, 0.78260869565217, 1.5166666666667, 0.5
11614, 0.73913043478261, 1.5166666666667, 0.5
11615, 0.69565217391304, 1.5166666666667, 0.5
11616, 0.65217391304348, 1.5166666666667, 0.5
11617, 0.60869565217391, 1.5166666666667, 0.5
11618, 0.56521739130435, 1.5166666666667, 0.5
11619, 0.52173913043478, 1.5166666666667, 0.5
11620, 0.47826086956522, 1.5166666666667, 0.5
11621, 0.43478260869565, 1.5166666666667, 0.5
11622, 0.39130434782609, 1.5166666666667, 0.5
11623, 0.34782608695652, 1.5166666666667, 0.5
11624, 0.30434782608696, 1.5166666666667, 0.5
11625, 0.26086956521739, 1.5166666666667, 0.5
11626, 0.21739130434783, 1.5166666666667, 0.5
11627, 0.17391304347826, 1.5166666666667, 0.5
11628, 0.1304347826087, 1.5166666666667, 0.5
11629, 0.08695652173913, 1.5166666666667, 0.5
11630, 0.043478260869565, 1.5166666666667, 0.5
11631, 0.97826086956522, 1.4833333333333, 0.5
11632, 0.95652173913043, 1.4666666666667, 0.5
11633, 0.93478260869565, 1.4833333333333, 0.5
11634, 0.91304347826087, 1.4666666666667, 0.5
11635, 0.89130434782609, 1.4833333333333, 0.5
11636, 0.8695652173913, 1.4666666666667, 0.5
11637, 0.84782608695652, 1.4833333333333, 0.5
11638, 0.82608695652174, 1.4666666666667, 0.5
11639, 0.80434782608696, 1.4833333333333, 0.5
11640, 0.78260869565217, 1.4666666666667, 0.5
11641, 0.76086956521739, 1.4833333333333, 0.5
11642, 0.73913043478261, 1.4666666666667, 0.5
11643, 0.71739130434783, 1.4833333333333, 0.5
11644, 0.69565217391304, 1.4666666666667, 0.5
11645, 0.67391304347826, 1.4833333333333, 0.5
11646, 0.65217391304348, 1.4666666666667, 0.5
11647, 0.6304347826087, 1.4833333333333, 0.5
11648, 0.60869565217391, 1.4666666666667, 0.5
11649, 0.58695652173913, 1.4833333333333, 0.5
11650, 0.56521739130435, 1.4666666666667, 0.5
11651, 0.54347826086957, 1.4833333333333, 0.5
11652, 0.52173913043478, 1.4666666666667, 0.5
11653, 0.5, 1.4833333333333, 0.5
11654, 0.47826086956522, 1.4666666666667, 0.5
11655, 0.45652173913043, 1.4833333333333, 0.5
11656, 0.43478260869565, 1.4666666666667, 0.5
11657, 0.41304347826087, 1.4833333333333, 0.5
11658, 0.39130434782609, 1.4666666666667, 0.5
11659, 0.3695652173913, 1.4833333333333, 0.5
11660, 0.34782608695652, 1.4666666666667, 0.5
11661, 0.32608695652174, 1.4833333333333, 0.5
11662, 0.30434782608696, 1.4666666666667, 0.5
11663, 0.28260869565217, 1.4833333333333, 0.5
11664, 0.26086956521739, 1.4666666666667, 0.5
11665, 0.23913043478261, 1.4833333333333, 0.5
11666, 0.21739130434783, 1.4666666666667, 0.5
11667, 0.19565217391304, 1.4833333333333, 0.5
11668, 0.17391304347826, 1.4666666666667, 0.5
11669, 0.15217391304348, 1.4833333333333, 0.5
11670, 0.1304347826087, 1.4666666666667, 0.5
11671, 0.10869565217391, 1.4833333333333, 0.5
11672, 0.08695652173913, 1.4666666666667, 0.5
11673, 0.065217391304348, 1.4833333333333, 0.5
11674, 0.043478260869565, 1.4666666666667, 0.5
11675, 0.021739130434783, 1.4833333333333, 0.5
11676, 0.97826086956522, 1.5166666666667, 0.5
11677, 0.95652173913043, 1.5, 0.5
11678, 0.93478260869565, 1.5166666666667, 0.5
11679, 0.91304347826087, 1.5, 0.5
11680, 0.89130434782609, 1.5166666666667, 0.5
11681, 0.8695652173913, 1.5, 0.5
11682, 0.84782608695652, 1.5166666666667, 0.5
11683, 0.82608695652174, 1.5, 0.5
11684, 0.80434782608696, 1.5166666666667, 0.5
11685, 0.78260869565217, 1.5, 0.5
11686, 0.76086956521739, 1.5166666666667, 0.5
11687, 0.73913043478261, 1.5, 0.5
11688, 0.71739130434783, 1.5166666666667, 0.5
11689, 0.69565217391304, 1.5, 0.5
11690, 0.67391304347826, 1.5166666666667, 0.5
11691, 0.65217391304348, 1.5, 0.5
11692, 0.6304347826087, 1.5166666666667, 0.5
11693, 0.60869565217391, 1.5, 0.5
11694, 0.58695652173913, 1.5166666666667, 0.5
11695, 0.56521739130435, 1.5, 0.5
11696, 0.54347826086957, 1.5166666666667, 0.5
11697, 0.52173913043478, 1.5, 0.5
11698, 0.5, 1.5166666666667, 0.5
11699, 0.47826086956522, 1.5, 0.5
11700, 0.45652173913043, 1.5166666666667, 0.5
11701, 0.43478260869565, 1.5, 0.5
11702, 0.41304347826087, 1.5166666666667, 0.5
11703, 0.39130434782609, 1.5, 0.5
11704, 0.3695652173913, 1.5166666666667, 0.5
11705, 0.34782608695652, 1.5, 0.5
11706, 0.32608695652174, 1.5166666666667, 0.5
11707, 0.30434782608696, 1.5, 0.5
11708, 0.28260869565217, 1.5166666666667, 0.5
11709, 0.26086956521739, 1.5, 0.5
11710, 0.23913043478261, 1.5166666666667, 0.5
11711, 0.21739130434783, 1.5, 0.5
11712, 0.19565217391304, 1.5166666666667, 0.5
11713, 0.17391304347826, 1.5, 0.5
11714, 0.15217391304348, 1.5166666666667, 0.5
11715, 0.1304347826087, 1.5, 0.5
11716, 0.10869565217391, 1.5166666666667, 0.5
11717, 0.08695652173913, 1.5, 0.5
11718, 0.065217391304348, 1.5166666666667, 0.5
11719, 0.043478260869565, 1.5, 0.5
11720, 0.021739130434783, 1.5166666666667, 0.5
11721, 0.95652173913043, 1.5333333333333, 0.5
11722, 0.91304347826087, 1.5333333333333, 0.5
11723, 0.8695652173913, 1.5333333333333, 0.5
11724, 0.82608695652174, 1.5333333333333, 0.5
11725, 0.78260869565217, 1.5333333333333, 0.5
11726, 0.73913043478261, 1.5333333333333, 0.5
11727, 0.69565217391304, 1.5333333333333, 0.5
11728, 0.65217391304348, 1.5333333333333, 0.5
11729, 0.60869565217391, 1.5333333333333, 0.5
11730, 0.56521739130435, 1.5333333333333, 0.5
11731, 0.52173913043478, 1.5333333333333, 0.5
11732, 0.47826086956522, 1.5333333333333, 0.5
11733, 0.43478260869565, 1.5333333333333, 0.5
11734, 0.39130434782609, 1.5333333333333, 0.5
11735, 0.34782608695652, 1.5333333333333, 0.5
11736, 0.30434782608696, 1.5333333333333, 0.5
11737, 0.26086956521739, 1.5333333333333, 0.5
11738, 0.21739130434783, 1.5333333333333, 0.5
11739, 0.17391304347826, 1.5333333333333, 0.5
11740, 0.1304347826087, 1.5333333333333, 0.5
11741, 0.08695652173913, 1.5333333333333, 0.5
11742, 0.043478260869565, 1.5333333333333, 0.5
11743, 0, 1.4833333333333, 0.44444444444444
11744, 0, 1.4833333333333, 0.38888888888889
11745, 0, 1.4833333333333, 0.33333333333333
11746, 0, 1.4833333333333, 0.27777777777778
11747, 0, 1.4833333333333, 0.22222222222222
11748, 0, 1.4833333333333, 0.16666666666667
11749, 0, 1.4833333333333, 0.11111111111111
11750, 0, 1.4833333333333, 0.055555555555556
11751, 0, 1.5166666666667, 0.44444444444444
11752, 0, 1.5166666666667, 0.38888888888889
11753, 0, 1.5166666666667, 0.33333333333333
11754, 0, 1.5166666666667, 0.27777777777778
11755, 0, 1.5166666666667, 0.22222222222222
11756, 0, 1.5166666666667, 0.16666666666667
11757, 0, 1.5166666666667, 0.11111111111111
11758, 0, 1.5166666666667, 0.055555555555556
11759, 0, 1.4833333333333, 0.47222222222222
11760, 0, 1.4666666666667, 0.44444444444444
11761, 0, 1.4833333333333, 0.41666666666667
11762, 0, 1.4666666666667, 0.38888888888889
11763, 0, 1.4833333333333, 0.36111111111111
11764, 0, 1.4666666666667, 0.33333333333333
11765, 0, 1.4833333333333, 0.30555555555556
11766, 0, 1.4666666666667, 0.27777777777778
11767, 0, 1.4833333333333, 0.25
11768, 0, 1.4666666666667, 0.22222222222222
11769, 0, 1.4833333333333, 0.19444444444444
11770, 0, 1.4666666666667, 0.16666666666667
11771, 0, 1.4833333333333, 0.13888888888889
11772, 0, 1.4666666666667, 0.11111111111111
11773, 0, 1.4833333333333, 0.083333333333333
11774, 0, 1.4666666666667, 0.055555555555556
11775, 0, 1.4833333333333, 0.027777777777778
11776, 0, 1.5166666666667, 0.47222222222222
11777, 0, 1.5, 0.44444444444444
11778, 0, 1.5166666666667, 0.41666666666667
11779, 0, 1.5, 0.38888888888889
11780, 0, 1.5166666666667, 0.36111111111111
11781, 0, 1.5, 0.33333333333333
11782, 0, 1.5166666666667, 0.30555555555556
11783, 0, 1.5, 0.27777777777778
11784, 0, 1.5166666666667, 0.25
11785, 0, 1.5, 0.22222222222222
11786, 0, 1.5166666666667, 0.19444444444444
11787, 0, 1.5, 0.16666666666667
11788, 0, 1.5166666666667, 0.13888888888889
11789, 0, 1.5, 0.11111111111111
11790, 0, 1.5166666666667, 0.083333333333333
11791, 0, 1.5, 0.055555555555556
11792, 0, 1.5166666666667, 0.027777777777778
11793, 0, 1.5333333333333, 0.44444444444444
11794, 0, 1.5333333333333, 0.38888888888889
11795, 0, 1.5333333333333, 0.33333333333333
11796, 0, 1.5333333333333, 0.27777777777778
11797, 0, 1.5333333333333, 0.22222222222222
11798, 0, 1.5333333333333, 0.16666666666667
11799, 0, 1.5333333333333, 0.11111111111111
11800, 0, 1.5333333333333, 0.055555555555556
11801, 0.043478260869565, 1.45, 0.055555555555556
11802, 0.043478260869565, 1.45, 0.11111111111111
11803, 0.043478260869565, 1.45, 0.16666666666667
11804, 0.043478260869565, 1.45, 0.22222222222222
11805, 0.043478260869565, 1.45, 0.27777777777778
11806, 0.043478260869565, 1.45, 0.33333333333333
11807, 0.043478260869565, 1.45, 0.38888888888889
11808, 0.043478260869565, 1.45, 0.44444444444444
11809, 0.08695652173913, 1.45, 0.055555555555556
11810, 0.08695652173913, 1.45, 0.11111111111111
11811, 0.08695652173913, 1.45, 0.16666666666667
11812, 0.08695652173913, 1.45, 0.22222222222222
11813, 0.08695652173913, 1.45, 0.27777777777778
11814, 0.08695652173913, 1.45, 0.33333333333333
11815, 0.08695652173913, 1.45, 0.38888888888889
11816, 0.08695652173913, 1.45, 0.44444444444444
11817, 0.1304347826087, 1.45, 0.055555555555556
11818, 0.1304347826087, 1.45, 0.11111111111111
11819, 0.1304347826087, 1.45, 0.16666666666667
11820, 0.1304347826087, 1.45, 0.22222222222222
11821, 0.1304347826087, 1.45, 0.27777777777778
11822, 0.1304347826087, 1.45, 0.33333333333333
11823, 0.1304347826087, 1.45, 0.38888888888889
11824, 0.1304347826087, 1.45, 0.44444444444444
11825, 0.17391304347826, 1.45, 0.055555555555556
11826, 0.17391304347826, 1.45, 0.11111111111111
11827, 0.17391304347826, 1.45, 0.16666666666667
11828, 0.17391304347826, 1.45, 0.22222222222222
11829, 0.17391304347826, 1.45, 0.27777777777778
11830, 0.17391304347826, 1.45, 0.33333333333333
11831, 0.17391304347826, 1.45, 0.38888888888889
11832, 0.17391304347826, 1.45, 0.44444444444444
11833, 0.21739130434783, 1.45, 0.055555555555556
11834, 0.21739130434783, 1.45, 0.11111111111111
11835, 0.21739130434783, 1.45, 0.16666666666667
11836, 0.21739130434783, 1.45, 0.22222222222222
11837, 0.21739130434783, 1.45, 0.27777777777778
11838, 0.21739130434783, 1.45, 0.33333333333333
11839, 0.21739130434783, 1.45, 0.38888888888889
11840, 0.21739130434783, 1.45, 0.44444444444444
11841, 0.26086956521739, 1.45, 0.055555555555556
11842, 0.26086956521739, 1.45, 0.11111111111111
11843, 0.26086956521739, 1.45, 0.16666666666667
11844, 0.26086956521739, 1.45, 0.22222222222222
11845, 0.26086956521739, 1.45, 0.27777777777778
11846, 0.26086956521739, 1.45, 0.33333333333333
11847, 0.26086956521739, 1.45, 0.38888888888889
11848, 0.26086956521739, 1.45, 0.44444444444444
11849, 0.30434782608696, 1.45, 0.055555555555556
11850, 0.30434782608696, 1.45, 0.11111111111111
11851, 0.30434782608696, 1.45, 0.16666666666667
11852, 0.30434782608696, 1.45, 0.22222222222222
11853, 0.30434782608696, 1.45, 0.27777777777778
11854, 0.30434782608696, 1.45, 0.33333333333333
11855, 0.30434782608696, 1.45, 0.38888888888889
11856, 0.30434782608696, 1.45, 0.44444444444444
11857, 0.34782608695652, 1.45, 0.055555555555556
11858, 0.34782608695652, 1.45, 0.11111111111111
11859, 0.34782608695652, 1.45, 0.16666666666667
11860, 0.34782608695652, 1.45, 0.22222222222222
11861, 0.34782608695652, 1.45, 0.27777777777778
11862, 0.34782608695652, 1.45, 0.33333333333333
11863, 0.34782608695652, 1.45, 0.38888888888889
11864, 0.34782608695652, 1.45, 0.44444444444444
11865, 0.39130434782609, 1.45, 0.055555555555556
11866, 0.39130434782609, 1.45, 0.11111111111111
11867, 0.39130434782609, 1.45, 0.16666666666667
11868, 0.39130434782609, 1.45, 0.22222222222222
11869, 0.39130434782609, 1.45, 0.27777777777778
11870, 0.39130434782609, 1.45, 0.33333333333333
11871, 0.39130434782609, 1.45, 0.38888888888889
11872, 0.39130434782609, 1.45, 0.44444444444444
11873, 0.43478260869565, 1.45, 0.055555555555556
11874, 0.43478260869565, 1.45, 0.11111111111111
11875, 0.43478260869565, 1.45, 0.16666666666667
11876, 0.43478260869565, 1.45, 0.22222222222222
11877, 0.43478260869565, 1.45, 0.27777777777778
11878, 0.43478260869565, 1.45, 0.33333333333333
11879, 0.43478260869565, 1.45, 0.38888888888889
11880, 0.43478260869565, 1.45, 0.44444444444444
11881, 0.47826086956522, 1.45, 0.055555555555556
11882, 0.47826086956522, 1.45, 0.11111111111111
11883, 0.47826086956522, 1.45, 0.16666666666667
11884, 0.47826086956522, 1.45, 0.22222222222222
11885, 0.47826086956522, 1.45, 0.27777777777778
11886, 0.47826086956522, 1.45, 0.33333333333333
11887, 0.47826086956522, 1.45, 0.38888888888889
11888, 0.47826086956522, 1.45, 0.44444444444444
11889, 0.52173913043478, 1.45, 0.055555555555556
11890, 0.52173913043478, 1.45, 0.11111111111111
11891, 0.52173913043478, 1.45, 0.16666666666667
11892, 0.52173913043478, 1.45, 0.22222222222222
11893, 0.52173913043478, 1.45, 0.27777777777778
11894, 0.52173913043478, 1.45, 0.33333333333333
11895, 0.52173913043478, 1.45, 0.38888888888889
11896, 0.52173913043478, 1.45, 0.44444444444444
11897, 0.56521739130435, 1.45, 0.055555555555556
11898, 0.56521739130435, 1.45, 0.11111111111111
11899, 0.56521739130435, 1.45, 0.16666666666667
11900, 0.56521739130435, 1.45, 0.22222222222222
11901, 0.56521739130435, 1.45, 0.27777777777778
11902, 0.56521739130435, 1.45, 0.33333333333333
11903, 0.56521739130435, 1.45, 0.38888888888889
11904, 0.56521739130435, 1.45, 0.44444444444444
11905, 0.60869565217391, 1.45, 0.055555555555556
11906, 0.60869565217391, 1.45, 0.11111111111111
11907, 0.60869565217391, 1.45, 0.16666666666667
11908, 0.60869565217391, 1.45, 0.22222222222222
11909, 0.60869565217391, 1.45, 0.27777777777778
11910, 0.60869565217391, 1.45, 0.33333333333333
11911, 0.60869565217391, 1.45, 0.38888888888889
11912, 0.60869565217391, 1.45, 0.44444444444444
11913, 0.65217391304348, 1.45, 0.055555555555556
11914, 0.65217391304348, 1.45, 0.11111111111111
11915, 0.65217391304348, 1.45, 0.16666666666667
11916, 0.65217391304348, 1.45, 0.22222222222222
11917, 0.65217391304348, 1.45, 0.27777777777778
11918, 0.65217391304348, 1.45, 0.33333333333333
11919, 0.65217391304348, 1.45, 0.38888888888889
11920, 0.65217391304348, 1.45, 0.44444444444444
11921, 0.69565217391304, 1.45, 0.055555555555556
11922, 0.69565217391304, 1.45, 0.11111111111111
11923, 0.69565217391304, 1.45, 0.16666666666667
11924, 0.69565217391304, 1.45, 0.22222222222222
11925, 0.69565217391304, 1.45, 0.27777777777778
11926, 0.69565217391304, 1.45, 0.33333333333333
11927, 0.69565217391304, 1.45, 0.38888888888889
11928, 0.69565217391304, 1.45, 0.44444444444444
11929, 0.73913043478261, 1.45, 0.055555555555556
11930, 0.73913043478261, 1.45, 0.11111111111111
11931, 0.73913043478261, 1.45, 0.16666666666667
11932, 0.73913043478261, 1.45, 0.22222222222222
11933, 0.73913043478261, 1.45, 0.27777777777778
11934, 0.73913043478261, 1.45, 0.33333333333333
11935, 0.73913043478261, 1.45, 0.38888888888889
11936, 0.73913043478261, 1.45, 0.44444444444444
11937, 0.78260869565217, 1.45, 0.055555555555556
11938, 0.78260869565217, 1.45, 0.11111111111111
11939, 0.78260869565217, 1.45, 0.16666666666667
11940, 0.78260869565217, 1.45, 0.22222222222222
11941, 0.78260869565217, 1.45, 0.27777777777778
11942, 0.78260869565217, 1.45, 0.33333333333333
11943, 0.78260869565217, 1.45, 0.38888888888889
11944, 0.78260869565217, 1.45, 0.44444444444444
11945, 0.82608695652174, 1.45, 0.055555555555556
11946, 0.82608695652174, 1.45, 0.11111111111111
11947, 0.82608695652174, 1.45, 0.16666666666667
11948, 0.82608695652174, 1.45, 0.22222222222222
11949, 0.82608695652174, 1.45, 0.27777777777778
11950, 0.82608695652174, 1.45, 0.33333333333333
11951, 0.82608695652174, 1.45, 0.38888888888889
11952, 0.82608695652174, 1.45, 0.44444444444444
11953, 0.8695652173913, 1.45, 0.055555555555556
11954, 0.8695652173913, 1.45, 0.11111111111111
11955, 0.8695652173913, 1.45, 0.16666666666667
11956, 0.8695652173913, 1.45, 0.22222222222222
11957, 0.8695652173913, 1.45, 0.27777777777778
11958, 0.8695652173913, 1.45, 0.33333333333333
11959, 0.8695652173913, 1.45, 0.38888888888889
11960, 0.8695652173913, 1.45, 0.44444444444444
11961, 0.91304347826087, 1.45, 0.055555555555556
11962, 0.91304347826087, 1.45, 0.11111111111111
11963, 0.91304347826087, 1.45, 0.16666666666667
11964, 0.91304347826087, 1.45, 0.22222222222222
11965, 0.91304347826087, 1.45, 0.27777777777778
11966, 0.91304347826087, 1.45, 0.33333333333333
11967, 0.91304347826087, 1.45, 0.38888888888889
11968, 0.91304347826087, 1.45, 0.44444444444444
11969, 0.95652173913043, 1.45, 0.055555555555556
11970, 0.95652173913043, 1.45, 0.11111111111111
11971, 0.95652173913043, 1.45, 0.16666666666667
11972, 0.95652173913043, 1.45, 0.22222222222222
11973, 0.95652173913043, 1.45, 0.27777777777778
11974, 0.95652173913043, 1.45, 0.33333333333333
11975, 0.95652173913043, 1.45, 0.38888888888889
11976, 0.95652173913043, 1.45, 0.44444444444444
11977, 0.043478260869565, 1.45, 0.027777777777778
11978, 0.021739130434783, 1.45, 0.055555555555556
11979, 0.043478260869565, 1.45, 0.083333333333333
11980, 0.021739130434783, 1.45, 0.11111111111111
11981, 0.043478260869565, 1.45, 0.13888888888889
11982, 0.021739130434783, 1.45, 0.16666666666667
11983, 0.043478260869565, 1.45, 0.19444444444444
11984, 0.021739130434783, 1.45, 0.22222222222222
11985, 0.043478260869565, 1.45, 0.25
11986, 0.021739130434783, 1.45, 0.27777777777778
11987, 0.043478260869565, 1.45, 0.30555555555556
11988, 0.021739130434783, 1.45, 0.33333333333333
11989, 0.043478260869565, 1.45, 0.36111111111111
11990, 0.021739130434783, 1.45, 0.38888888888889
11991, 0.043478260869565, 1.45, 0.41666666666667
11992, 0.021739130434783, 1.45, 0.44444444444444
11993, 0.043478260869565, 1.45, 0.47222222222222
11994, 0.08695652173913, 1.45, 0.027777777777778
11995, 0.065217391304348, 1.45, 0.055555555555556
11996, 0.08695652173913, 1.45, 0.083333333333333
11997, 0.065217391304348, 1.45, 0.11111111111111
11998, 0.08695652173913, 1.45, 0.13888888888889
11999, 0.065217391304348, 1.45, 0.16666666666667
12000, 0.08695652173913, 1.45, 0.19444444444444
12001, 0.065217391304348, 1.45, 0.22222222222222
12002, 0.08695652173913, 1.45, 0.25
12003, 0.065217391304348, 1.45, 0.27777777777778
12004, 0.08695652173913, 1.45, 0.30555555555556
12005, 0.065217391304348, 1.45, 0.33333333333333
12006, 0.08695652173913, 1.45, 0.36111111111111
12007, 0.065217391304348, 1.45, 0.38888888888889
12008, 0.08695652173913, 1.45, 0.41666666666667
12009, 0.065217391304348, 1.45, 0.44444444444444
12010, 0.08695652173913, 1.45, 0.47222222222222
12011, 0.1304347826087, 1.45, 0.027777777777778
12012, 0.10869565217391, 1.45, 0.055555555555556
12013, 0.1304347826087, 1.45, 0.083333333333333
12014, 0.10869565217391, 1.45, 0.11111111111111
12015, 0.1304347826087, 1.45, 0.13888888888889
12016, 0.10869565217391, 1.45, 0.16666666666667
12017, 0.1304347826087, 1.45, 0.19444444444444
12018, 0.10869565217391, 1.45, 0.22222222222222
12019, 0.1304347826087, 1.45, 0.25
12020, 0.10869565217391, 1.45, 0.27777777777778
12021, 0.1304347826087, 1.45, 0.30555555555556
12022, 0.10869565217391, 1.45, 0.33333333333333
12023, 0.1304347826087, 1.45, 0.36111111111111
12024, 0.10869565217391, 1.45, 0.38888888888889
12025, 0.1304347826087, 1.45, 0.41666666666667
12026, 0.10869565217391, 1.45, 0.44444444444444
12027, 0.1304347826087, 1.45, 0.47222222222222
12028, 0.17391304347826, 1.45, 0.027777777777778
12029, 0.15217391304348, 1.45, 0.055555555555556
12030, 0.17391304347826, 1.45, 0.083333333333333
12031, 0.15217391304348, 1.45, 0.11111111111111
12032, 0.17391304347826, 1.45, 0.13888888888889
12033, 0.15217391304348, 1.45, 0.16666666666667
12034, 0.17391304347826, 1.45, 0.19444444444444
12035, 0.15217391304348, 1.45, 0.22222222222222
12036, 0.17391304347826, 1.45, 0.25
12037, 0.15217391304348, 1.45, 0.27777777777778
12038, 0.17391304347826, 1.45, 0.30555555555556
12039, 0.15217391304348, 1.45, 0.33333333333333
12040, 0.17391304347826, 1.45, 0.36111111111111
12041, 0.15217391304348, 1.45, 0.38888888888889
12042, 0.17391304347826, 1.45, 0.41666666666667
12043, 0.15217391304348, 1.45, 0.44444444444444
12044, 0.17391304347826, 1.45, 0.47222222222222
12045, 0.21739130434783, 1.45, 0.027777777777778
12046, 0.19565217391304, 1.45, 0.055555555555556
12047, 0.21739130434783, 1.45, 0.083333333333333
12048, 0.19565217391304, 1.45, 0.11111111111111
12049, 0.21739130434783, 1.45, 0.13888888888889
12050, 0.19565217391304, 1.45, 0.16666666666667
12051, 0.21739130434783, 1.45, 0.19444444444444
12052, 0.19565217391304, 1.45, 0.22222222222222
12053, 0.21739130434783, 1.45, 0.25
12054, 0.19565217391304, 1.45, 0.27777777777778
12055, 0.21739130434783, 1.45, 0.30555555555556
12056, 0.19565217391304, 1.45, 0.33333333333333
12057, 0.21739130434783, 1.45, 0.36111111111111
12058, 0.19565217391304, 1.45, 0.38888888888889
12059, 0.21739130434783, 1.45, 0.41666666666667
12060, 0.19565217391304, 1.45, 0.44444444444444
12061, 0.21739130434783, 1.45, 0.47222222222222
12062, 0.26086956521739, 1.45, 0.027777777777778
12063, 0.23913043478261, 1.45, 0.055555555555556
12064, 0.26086956521739, 1.45, 0.083333333333333
12065, 0.23913043478261, 1.45, 0.11111111111111
12066, 0.26086956521739, 1.45, 0.13888888888889
12067, 0.23913043478261, 1.45, 0.16666666666667
12068, 0.26086956521739, 1.45, 0.19444444444444
12069, 0.23913043478261, 1.45, 0.22222222222222
12070, 0.26086956521739, 1.45, 0.25
12071, 0.23913043478261, 1.45, 0.27777777777778
12072, 0.26086956521739, 1.45, 0.30555555555556
12073, 0.23913043478261, 1.45, 0.33333333333333
12074, 0.26086956521739, 1.45, 0.36111111111111
12075, 0.23913043478261, 1.45, 0.38888888888889
12076, 0.26086956521739, 1.45, 0.41666666666667
12077, 0.23913043478261, 1.45, 0.44444444444444
12078, 0.26086956521739, 1.45, 0.47222222222222
12079, 0.30434782608696, 1.45, 0.027777777777778
12080, 0.28260869565217, 1.45, 0.055555555555556
12081, 0.30434782608696, 1.45, 0.083333333333333
12082, 0.28260869565217, 1.45, 0.11111111111111
12083, 0.30434782608696, 1.45, 0.13888888888889
12084, 0.28260869565217, 1.45, 0.16666666666667
12085, 0.30434782608696, 1.45, 0.19444444444444
12086, 0.28260869565217, 1.45, 0.22222222222222
12087, 0.30434782608696, 1.45, 0.25
12088, 0.28260869565217, 1.45, 0.27777777777778
12089, 0.30434782608696, 1.45, 0.30555555555556
12090, 0.28260869565217, 1.45, 0.33333333333333
12091, 0.30434782608696, 1.45, 0.36111111111111
12092, 0.28260869565217, 1.45, 0.38888888888889
12093, 0.30434782608696, 1.45, 0.41666666666667
12094, 0.28260869565217, 1.45, 0.44444444444444
12095, 0.30434782608696, 1.45, 0.47222222222222
12096, 0.34782608695652, 1.45, 0.027777777777778
12097, 0.32608695652174, 1.45, 0.055555555555556
12098, 0.34782608695652, 1.45, 0.083333333333333
12099, 0.32608695652174, 1.45, 0.11111111111111
12100, 0.34782608695652, 1.45, 0.13888888888889
12101, 0.32608695652174, 1.45, 0.16666666666667
12102, 0.34782608695652, 1.45, 0.19444444444444
12103, 0.32608695652174, 1.45, 0.22222222222222
12104, 0.34782608695652, 1.45, 0.25
12105, 0.32608695652174, 1.45, 0.27777777777778
12106, 0.34782608695652, 1.45, 0.30555555555556
12107, 0.32608695652174, 1.45, 0.33333333333333
12108, 0.34782608695652, 1.45, 0.36111111111111
12109, 0.32608695652174, 1.45, 0.38888888888889
12110, 0.34782608695652, 1.45, 0.41666666666667
12111, 0.32608695652174, 1.45, 0.44444444444444
12112, 0.34782608695652, 1.45, 0.47222222222222
12113, 0.39130434782609, 1.45, 0.027777777777778
12114, 0.3695652173913, 1.45, 0.055555555555556
12115, 0.39130434782609, 1.45, 0.083333333333333
12116, 0.3695652173913, 1.45, 0.11111111111111
12117, 0.39130434782609, 1.45, 0.13888888888889
12118, 0.3695652173913, 1.45, 0.16666666666667
12119, 0.39130434782609, 1.45, 0.19444444444444
12120, 0.3695652173913, 1.45, 0.22222222222222
12121, 0.39130434782609, 1.45, 0.25
12122, 0.3695652173913, 1.45, 0.27777777777778
12123, 0.39130434782609, 1.45, 0.30555555555556
12124, 0.3695652173913, 1.45, 0.33333333333333
12125, 0.39130434782609, 1.45, 0.36111111111111
12126, 0.3695652173913, 1.45, 0.38888888888889
12127, 0.39130434782609, 1.45, 0.41666666666667
12128, 0.3695652173913, 1.45, 0.44444444444444
12129, 0.39130434782609, 1.45, 0.47222222222222
12130, 0.43478260869565, 1.45, 0.027777777777778
12131, 0.41304347826087, 1.45, 0.055555555555556
12132, 0.43478260869565, 1.45, 0.083333333333333
12133, 0.41304347826087, 1.45, 0.11111111111111
12134, 0.43478260869565, 1.45, 0.13888888888889
12135, 0.41304347826087, 1.45, 0.16666666666667
12136, 0.43478260869565, 1.45, 0.19444444444444
12137, 0.41304347826087, 1.45, 0.22222222222222
12138, 0.43478260869565, 1.45, 0.25
12139, 0.41304347826087, 1.45, 0.27777777777778
12140, 0.43478260869565, 1.45, 0.30555555555556
12141, 0.41304347826087, 1.45, 0.33333333333333
12142, 0.43478260869565, 1.45, 0.36111111111111
12143, 0.41304347826087, 1.45, 0.38888888888889
12144, 0.43478260869565, 1.45, 0.41666666666667
12145, 0.41304347826087, 1.45, 0.44444444444444
12146, 0.43478260869565, 1.45, 0.47222222222222
12147, 0.47826086956522, 1.45, 0.027777777777778
12148, 0.45652173913043, 1.45, 0.055555555555556
12149, 0.47826086956522, 1.45, 0.083333333333333
12150, 0.45652173913043, 1.45, 0.11111111111111
12151, 0.47826086956522, 1.45, 0.13888888888889
12152, 0.45652173913043, 1.45, 0.16666666666667
12153, 0.47826086956522, 1.45, 0.19444444444444
12154, 0.45652173913043, 1.45, 0.22222222222222
12155, 0.47826086956522, 1.45, 0.25
12156, 0.45652173913043, 1.45, 0.27777777777778
12157, 0.47826086956522, 1.45, 0.30555555555556
12158, 0.45652173913043, 1.45, 0.33333333333333
12159, 0.47826086956522, 1.45, 0.36111111111111
12160, 0.45652173913043, 1.45, 0.38888888888889
12161, 0.47826086956522, 1.45, 0.41666666666667
12162, 0.45652173913043, 1.45, 0.44444444444444
12163, 0.47826086956522, 1.45, 0.47222222222222
12164, 0.52173913043478, 1.45, 0.027777777777778
12165, 0.5, 1.45, 0.055555555555556
12166, 0.52173913043478, 1.45, 0.083333333333333
12167, 0.5, 1.45, 0.11111111111111
12168, 0.52173913043478, 1.45, 0.13888888888889
12169, 0.5, 1.45, 0.16666666666667
12170, 0.52173913043478, 1.45, 0.19444444444444
12171, 0.5, 1.45, 0.22222222222222
12172, 0.52173913043478, 1.45, 0.25
12173, 0.5, 1.45, 0.27777777777778
12174, 0.52173913043478, 1.45, 0.30555555555556
12175, 0.5, 1.45, 0.33333333333333
12176, 0.52173913043478, 1.45, 0.36111111111111
12177, 0.5, 1.45, 0.38888888888889
12178, 0.52173913043478, 1.45, 0.41666666666667
12179, 0.5, 1.45, 0.44444444444444
12180, 0.52173913043478, 1.45, 0.47222222222222
12181, 0.56521739130435, 1.45, 0.027777777777778
12182, 0.54347826086957, 1.45, 0.055555555555556
12183, 0.56521739130435, 1.45, 0.083333333333333
12184, 0.54347826086957, 1.45, 0.11111111111111
12185, 0.56521739130435, 1.45, 0.13888888888889
12186, 0.54347826086957, 1.45, 0.16666666666667
12187, 0.56521739130435, 1.45, 0.19444444444444
12188, 0.54347826086957, 1.45, 0.22222222222222
12189, 0.56521739130435, 1.45, 0.25
12190, 0.54347826086957, 1.45, 0.27777777777778
12191, 0.56521739130435, 1.45, 0.30555555555556
12192, 0.54347826086957, 1.45, 0.33333333333333
12193, 0.56521739130435, 1.45, 0.36111111111111
12194, 0.54347826086957, 1.45, 0.38888888888889
12195, 0.56521739130435, 1.45, 0.41666666666667
12196, 0.54347826086957, 1.45, 0.44444444444444
12197, 0.56521739130435, 1.45, 0.47222222222222
12198, 0.60869565217391, 1.45, 0.027777777777778
12199, 0.58695652173913, 1.45, 0.055555555555556
12200, 0.60869565217391, 1.45, 0.083333333333333
12201, 0.58695652173913, 1.45, 0.11111111111111
12202, 0.60869565217391, 1.45, 0.13888888888889
12203, 0.58695652173913, 1.45, 0.16666666666667
12204, 0.60869565217391, 1.45, 0.19444444444444
12205, 0.58695652173913, 1.45, 0.22222222222222
12206, 0.60869565217391, 1.45, 0.25
12207, 0.58695652173913, 1.45, 0.27777777777778
12208, 0.60869565217391, 1.45, 0.30555555555556
12209, 0.58695652173913, 1.45, 0.33333333333333
12210, 0.60869565217391, 1.45, 0.36111111111111
12211, 0.58695652173913, 1.45, 0.38888888888889
12212, 0.60869565217391, 1.45, 0.41666666666667
12213, 0.58695652173913, 1.45, 0.44444444444444
12214, 0.60869565217391, 1.45, 0.47222222222222
12215, 0.65217391304348, 1.45, 0.027777777777778
12216, 0.6304347826087, 1.45, 0.055555555555556
12217, 0.65217391304348, 1.45, 0.083333333333333
12218, 0.6304347826087, 1.45, 0.11111111111111
12219, 0.65217391304348, 1.45, 0.13888888888889
12220, 0.6304347826087, 1.45, 0.16666666666667
12221, 0.65217391304348, 1.45, 0.19444444444444
12222, 0.6304347826087, 1.45, 0.22222222222222
12223, 0.65217391304348, 1.45, 0.25
12224, 0.6304347826087, 1.45, 0.27777777777778
12225, 0.65217391304348, 1.45, 0.30555555555556
12226, 0.6304347826087, 1.45, 0.33333333333333
12227, 0.65217391304348, 1.45, 0.36111111111111
12228, 0.6304347826087, 1.45, 0.38888888888889
12229, 0.65217391304348, 1.45, 0.41666666666667
12230, 0.6304347826087, 1.45, 0.44444444444444
12231, 0.65217391304348, 1.45, 0.47222222222222
12232, 0.69565217391304, 1.45, 0.027777777777778
12233, 0.67391304347826, 1.45, 0.055555555555556
12234, 0.69565217391304, 1.45, 0.083333333333333
12235, 0.67391304347826, 1.45, 0.11111111111111
12236, 0.69565217391304, 1.45, 0.13888888888889
12237, 0.67391304347826, 1.45, 0.16666666666667
12238, 0.69565217391304, 1.45, 0.19444444444444
12239, 0.67391304347826, 1.45, 0.22222222222222
12240, 0.69565217391304, 1.45, 0.25
12241, 0.67391304347826, 1.45, 0.27777777777778
12242, 0.69565217391304, 1.45, 0.30555555555556
12243, 0.67391304347826, 1.45, 0.33333333333333
12244, 0.69565217391304, 1.45, 0.36111111111111
12245, 0.67391304347826, 1.45, 0.38888888888889
12246, 0.69565217391304, 1.45, 0.41666666666667
12247, 0.67391304347826, 1.45, 0.44444444444444
12248, 0.69565217391304, 1.45, 0.47222222222222
12249, 0.73913043478261, 1.45, 0.027777777777778
12250, 0.71739130434783, 1.45, 0.055555555555556
12251, 0.73913043478261, 1.45, 0.083333333333333
12252, 0.71739130434783, 1.45, 0.11111111111111
12253, 0.73913043478261, 1.45, 0.13888888888889
12254, 0.71739130434783, 1.45, 0.16666666666667
12255, 0.73913043478261, 1.45, 0.19444444444444
12256, 0.71739130434783, 1.45, 0.22222222222222
12257, 0.73913043478261, 1.45, 0.25
12258, 0.71739130434783, 1.45, 0.27777777777778
12259, 0.73913043478261, 1.45, 0.30555555555556
12260, 0.71739130434783, 1.45, 0.33333333333333
12261, 0.73913043478261, 1.45, 0.36111111111111
12262, 0.71739130434783, 1.45, 0.38888888888889
12263, 0.73913043478261, 1.45, 0.41666666666667
12264, 0.71739130434783, 1.45, 0.44444444444444
12265, 0.73913043478261, 1.45, 0.47222222222222
12266, 0.78260869565217, 1.45, 0.027777777777778
12267, 0.76086956521739, 1.45, 0.055555555555556
12268, 0.78260869565217, 1.45, 0.083333333333333
12269, 0.76086956521739, 1.45, 0.11111111111111
12270, 0.78260869565217, 1.45, 0.13888888888889
12271, 0.76086956521739, 1.45, 0.16666666666667
12272, 0.78260869565217, 1.45, 0.19444444444444
12273, 0.76086956521739, 1.45, 0.22222222222222
12274, 0.78260869565217, 1.45, 0.25
12275, 0.76086956521739, 1.45, 0.27777777777778
12276, 0.78260869565217, 1.45, 0.30555555555556
12277, 0.76086956521739, 1.45, 0.33333333333333
12278, 0.78260869565217, 1.45, 0.36111111111111
12279, 0.76086956521739, 1.45, 0.38888888888889
12280, 0.78260869565217, 1.45, 0.41666666666667
12281, 0.76086956521739, 1.45, 0.44444444444444
12282, 0.78260869565217, 1.45, 0.47222222222222
12283, 0.82608695652174, 1.45, 0.027777777777778
12284, 0.80434782608696, 1.45, 0.055555555555556
12285, 0.82608695652174, 1.45, 0.083333333333333
12286, 0.80434782608696, 1.45, 0.11111111111111
12287, 0.82608695652174, 1.45, 0.13888888888889
12288, 0.80434782608696, 1.45, 0.16666666666667
12289, 0.82608695652174, 1.45, 0.19444444444444
12290, 0.80434782608696, 1.45, 0.22222222222222
12291, 0.82608695652174, 1.45, 0.25
12292, 0.80434782608696, 1.45, 0.27777777777778
12293, 0.82608695652174, 1.45, 0.30555555555556
12294, 0.80434782608696, 1.45, 0.33333333333333
12295, 0.82608695652174, 1.45, 0.36111111111111
12296, 0.80434782608696, 1.45, 0.38888888888889
12297, 0.82608695652174, 1.45, 0.41666666666667
12298, 0.80434782608696, 1.45, 0.44444444444444
12299, 0.82608695652174, 1.45, 0.47222222222222
12300, 0.8695652173913, 1.45, 0.027777777777778
12301, 0.84782608695652, 1.45, 0.055555555555556
12302, 0.8695652173913, 1.45, 0.083333333333333
12303, 0.84782608695652, 1.45, 0.11111111111111
12304, 0.8695652173913, 1.45, 0.13888888888889
12305, 0.84782608695652, 1.45, 0.16666666666667
12306, 0.8695652173913, 1.45, 0.19444444444444
12307, 0.84782608695652, 1.45, 0.22222222222222
12308, 0.8695652173913, 1.45, 0.25
12309, 0.84782608695652, 1.45, 0.27777777777778
12310, 0.8695652173913, 1.45, 0.30555555555556
12311, 0.84782608695652, 1.45, 0.33333333333333
12312, 0.8695652173913, 1.45, 0.36111111111111
12313, 0.84782608695652, 1.45, 0.38888888888889
12314, 0.8695652173913, 1.45, 0.41666666666667
12315, 0.84782608695652, 1.45, 0.44444444444444
12316, 0.8695652173913, 1.45, 0.47222222222222
12317, 0.91304347826087, 1.45, 0.027777777777778
12318, 0.89130434782609, 1.45, 0.055555555555556
12319, 0.91304347826087, 1.45, 0.083333333333333
12320, 0.89130434782609, 1.45, 0.11111111111111
12321, 0.91304347826087, 1.45, 0.13888888888889
12322, 0.89130434782609, 1.45, 0.16666666666667
12323, 0.91304347826087, 1.45, 0.19444444444444
12324, 0.89130434782609, 1.45, 0.22222222222222
12325, 0.91304347826087, 1.45, 0.25
12326, 0.89130434782609, 1.45, 0.27777777777778
12327, 0.91304347826087, 1.45, 0.30555555555556
12328, 0.89130434782609, 1.45, 0.33333333333333
12329, 0.91304347826087, 1.45, 0.36111111111111
12330, 0.89130434782609, 1.45, 0.38888888888889
12331, 0.91304347826087, 1.45, 0.41666666666667
12332, 0.89130434782609, 1.45, 0.44444444444444
12333, 0.91304347826087, 1.45, 0.47222222222222
12334, 0.95652173913043, 1.45, 0.027777777777778
12335, 0.93478260869565, 1.45, 0.055555555555556
12336, 0.95652173913043, 1.45, 0.083333333333333
12337, 0.93478260869565, 1.45, 0.11111111111111
12338, 0.95652173913043, 1.45, 0.13888888888889
12339, 0.93478260869565, 1.45, 0.16666666666667
12340, 0.95652173913043, 1.45, 0.19444444444444
12341, 0.93478260869565, 1.45, 0.22222222222222
12342, 0.95652173913043, 1.45, 0.25
12343, 0.93478260869565, 1.45, 0.27777777777778
12344, 0.95652173913043, 1.45, 0.30555555555556
12345, 0.93478260869565, 1.45, 0.33333333333333
12346, 0.95652173913043, 1.45, 0.36111111111111
12347, 0.93478260869565, 1.45, 0.38888888888889
12348, 0.95652173913043, 1.45, 0.41666666666667
12349, 0.93478260869565, 1.45, 0.44444444444444
12350, 0.95652173913043, 1.45, 0.47222222222222
12351, 0.97826086956522, 1.45, 0.055555555555556
12352, 0.97826086956522, 1.45, 0.11111111111111
12353, 0.97826086956522, 1.45, 0.16666666666667
12354, 0.97826086956522, 1.45, 0.22222222222222
12355, 0.97826086956522, 1.45, 0.27777777777778
12356, 0.97826086956522, 1.45, 0.33333333333333
12357, 0.97826086956522, 1.45, 0.38888888888889
12358, 0.97826086956522, 1.45, 0.44444444444444
12359, 0.043478260869565, 1.55, 0.055555555555556
12360, 0.043478260869565, 1.55, 0.11111111111111
12361, 0.043478260869565, 1.55, 0.16666666666667
12362, 0.043478260869565, 1.55, 0.22222222222222
12363, 0.043478260869565, 1.55, 0.27777777777778
12364, 0.043478260869565, 1.55, 0.33333333333333
12365, 0.043478260869565, 1.55, 0.38888888888889
12366, 0.043478260869565, 1.55, 0.44444444444444
12367, 0.08695652173913, 1.55, 0.055555555555556
12368, 0.08695652173913, 1.55, 0.11111111111111
12369, 0.08695652173913, 1.55, 0.16666666666667
12370, 0.08695652173913, 1.55, 0.22222222222222
12371, 0.08695652173913, 1.55, 0.27777777777778
12372, 0.08695652173913, 1.55, 0.33333333333333
12373, 0.08695652173913, 1.55, 0.38888888888889
12374, 0.08695652173913, 1.55, 0.44444444444444
12375, 0.1304347826087, 1.55, 0.055555555555556
12376, 0.1304347826087, 1.55, 0.11111111111111
12377, 0.1304347826087, 1.55, 0.16666666666667
12378, 0.1304347826087, 1.55, 0.22222222222222
12379, 0.1304347826087, 1.55, 0.27777777777778
12380, 0.1304347826087, 1.55, 0.33333333333333
12381, 0.1304347826087, 1.55, 0.38888888888889
12382, 0.1304347826087, 1.55, 0.44444444444444
12383, 0.17391304347826, 1.55, 0.055555555555556
12384, 0.17391304347826, 1.55, 0.11111111111111
12385, 0.17391304347826, 1.55, 0.16666666666667
12386, 0.17391304347826, 1.55, 0.22222222222222
12387, 0.17391304347826, 1.55, 0.27777777777778
12388, 0.17391304347826, 1.55, 0.33333333333333
12389, 0.17391304347826, 1.55, 0.38888888888889
12390, 0.17391304347826, 1.55, 0.44444444444444
12391, 0.21739130434783, 1.55, 0.055555555555556
12392, 0.21739130434783, 1.55, 0.11111111111111
12393, 0.21739130434783, 1.55, 0.16666666666667
12394, 0.21739130434783, 1.55, 0.22222222222222
12395, 0.21739130434783, 1.55, 0.27777777777778
12396, 0.21739130434783, 1.55, 0.33333333333333
12397, 0.21739130434783, 1.55, 0.38888888888889
12398, 0.21739130434783, 1.55, 0.44444444444444
12399, 0.26086956521739, 1.55, 0.055555555555556
12400, 0.26086956521739, 1.55, 0.11111111111111
12401, 0.26086956521739, 1.55, 0.16666666666667
12402, 0.26086956521739, 1.55, 0.22222222222222
12403, 0.26086956521739, 1.55, 0.27777777777778
12404, 0.26086956521739, 1.55, 0.33333333333333
12405, 0.26086956521739, 1.55, 0.38888888888889
12406, 0.26086956521739, 1.55, 0.44444444444444
12407, 0.30434782608696, 1.55, 0.055555555555556
12408, 0.30434782608696, 1.55, 0.11111111111111
12409, 0.30434782608696, 1.55, 0.16666666666667
12410, 0.30434782608696, 1.55, 0.22222222222222
12411, 0.30434782608696, 1.55, 0.27777777777778
12412, 0.30434782608696, 1.55, 0.33333333333333
12413, 0.30434782608696, 1.55, 0.38888888888889
12414, 0.30434782608696, 1.55, 0.44444444444444
12415, 0.34782608695652, 1.55, 0.055555555555556
12416, 0.34782608695652, 1.55, 0.11111111111111
12417, 0.34782608695652, 1.55, 0.16666666666667
12418, 0.34782608695652, 1.55, 0.22222222222222
12419, 0.34782608695652, 1.55, 0.27777777777778
12420, 0.34782608695652, 1.55, 0.33333333333333
12421, 0.34782608695652, 1.55, 0.38888888888889
12422, 0.34782608695652, 1.55, 0.44444444444444
12423, 0.39130434782609, 1.55, 0.055555555555556
12424, 0.39130434782609, 1.55, 0.11111111111111
12425, 0.39130434782609, 1.55, 0.16666666666667
12426, 0.39130434782609, 1.55, 0.22222222222222
12427, 0.39130434782609, 1.55, 0.27777777777778
12428, 0.39130434782609, 1.55, 0.33333333333333
12429, 0.39130434782609, 1.55, 0.38888888888889
12430, 0.39130434782609, 1.55, 0.44444444444444
12431, 0.43478260869565, 1.55, 0.055555555555556
12432, 0.43478260869565, 1.55, 0.11111111111111
12433, 0.43478260869565, 1.55, 0.16666666666667
12434, 0.43478260869565, 1.55, 0.22222222222222
12435, 0.43478260869565, 1.55, 0.27777777777778
12436, 0.43478260869565, 1.55, 0.33333333333333
12437, 0.43478260869565, 1.55, 0.38888888888889
12438, 0.43478260869565, 1.55, 0.44444444444444
12439, 0.47826086956522, 1.55, 0.055555555555556
12440, 0.47826086956522, 1.55, 0.11111111111111
12441, 0.47826086956522, 1.55, 0.16666666666667
12442, 0.47826086956522, 1.55, 0.22222222222222
12443, 0.47826086956522, 1.55, 0.27777777777778
12444, 0.47826086956522, 1.55, 0.33333333333333
12445, 0.47826086956522, 1.55, 0.38888888888889
12446, 0.47826086956522, 1.55, 0.44444444444444
12447, 0.52173913043478, 1.55, 0.055555555555556
12448, 0.52173913043478, 1.55, 0.11111111111111
12449, 0.52173913043478, 1.55, 0.16666666666667
12450, 0.52173913043478, 1.55, 0.22222222222222
12451, 0.52173913043478, 1.55, 0.27777777777778
12452, 0.52173913043478, 1.55, 0.33333333333333
12453, 0.52173913043478, 1.55, 0.38888888888889
12454, 0.52173913043478, 1.55, 0.44444444444444
12455, 0.56521739130435, 1.55, 0.055555555555556
12456, 0.56521739130435, 1.55, 0.11111111111111
12457, 0.56521739130435, 1.55, 0.16666666666667
12458, 0.56521739130435, 1.55, 0.22222222222222
12459, 0.56521739130435, 1.55, 0.27777777777778
12460, 0.56521739130435, 1.55, 0.33333333333333
12461, 0.56521739130435, 1.55, 0.38888888888889
12462, 0.56521739130435, 1.55, 0.44444444444444
12463, 0.60869565217391, 1.55, 0.055555555555556
12464, 0.60869565217391, 1.55, 0.11111111111111
12465, 0.60869565217391, 1.55, 0.16666666666667
12466, 0.60869565217391, 1.55, 0.22222222222222
12467, 0.60869565217391, 1.55, 0.27777777777778
12468, 0.60869565217391, 1.55, 0.33333333333333
12469, 0.60869565217391, 1.55, 0.38888888888889
12470, 0.60869565217391, 1.55, 0.44444444444444
12471, 0.65217391304348, 1.55, 0.055555555555556
12472, 0.65217391304348, 1.55, 0.11111111111111
12473, 0.65217391304348, 1.55, 0.16666666666667
12474, 0.65217391304348, 1.55, 0.22222222222222
12475, 0.65217391304348, 1.55, 0.27777777777778
12476, 0.65217391304348, 1.55, 0.33333333333333
12477, 0.65217391304348, 1.55, 0.38888888888889
12478, 0.65217391304348, 1.55, 0.44444444444444
12479, 0.69565217391304, 1.55, 0.055555555555556
12480, 0.69565217391304, 1.55, 0.11111111111111
12481, 0.69565217391304, 1.55, 0.16666666666667
12482, 0.69565217391304, 1.55, 0.22222222222222
12483, 0.69565217391304, 1.55, 0.27777777777778
12484, 0.69565217391304, 1.55, 0.33333333333333
12485, 0.69565217391304, 1.55, 0.38888888888889
12486, 0.69565217391304, 1.55, 0.44444444444444
12487, 0.73913043478261, 1.55, 0.055555555555556
12488, 0.73913043478261, 1.55, 0.11111111111111
12489, 0.73913043478261, 1.55, 0.16666666666667
12490, 0.73913043478261, 1.55, 0.22222222222222
12491, 0.73913043478261, 1.55, 0.27777777777778
12492, 0.73913043478261, 1.55, 0.33333333333333
12493, 0.73913043478261, 1.55, 0.38888888888889
12494, 0.73913043478261, 1.55, 0.44444444444444
12495, 0.78260869565217, 1.55, 0.055555555555556
12496, 0.78260869565217, 1.55, 0.11111111111111
12497, 0.78260869565217, 1.55, 0.16666666666667
12498, 0.78260869565217, 1.55, 0.22222222222222
12499, 0.78260869565217, 1.55, 0.27777777777778
12500, 0.78260869565217, 1.55, 0.33333333333333
12501, 0.78260869565217, 1.55, 0.38888888888889
12502, 0.78260869565217, 1.55, 0.44444444444444
12503, 0.82608695652174, 1.55, 0.055555555555556
12504, 0.82608695652174, 1.55, 0.11111111111111
12505, 0.82608695652174, 1.55, 0.16666666666667
12506, 0.82608695652174, 1.55, 0.22222222222222
12507, 0.82608695652174, 1.55, 0.27777777777778
12508, 0.82608695652174, 1.55, 0.33333333333333
12509, 0.82608695652174, 1.55, 0.38888888888889
12510, 0.82608695652174, 1.55, 0.44444444444444
12511, 0.8695652173913, 1.55, 0.055555555555556
12512, 0.8695652173913, 1.55, 0.11111111111111
12513, 0.8695652173913, 1.55, 0.16666666666667
12514, 0.8695652173913, 1.55, 0.22222222222222
12515, 0.8695652173913, 1.55, 0.27777777777778
12516, 0.8695652173913, 1.55, 0.33333333333333
12517, 0.8695652173913, 1.55, 0.38888888888889
12518, 0.8695652173913, 1.55, 0.44444444444444
12519, 0.91304347826087, 1.55, 0.055555555555556
12520, 0.91304347826087, 1.55, 0.11111111111111
12521, 0.91304347826087, 1.55, 0.16666666666667
12522, 0.91304347826087, 1.55, 0.22222222222222
12523, 0.91304347826087, 1.55, 0.27777777777778
12524, 0.91304347826087, 1.55, 0.33333333333333
12525, 0.91304347826087, 1.55, 0.38888888888889
12526, 0.91304347826087, 1.55, 0.44444444444444
12527, 0.95652173913043, 1.55, 0.055555555555556
12528, 0.95652173913043, 1.55, 0.11111111111111
12529, 0.95652173913043, 1.55, 0.16666666666667
12530, 0.95652173913043, 1.55, 0.22222222222222
12531, 0.95652173913043, 1.55, 0.27777777777778
12532, 0.95652173913043, 1.55, 0.33333333333333
12533, 0.95652173913043, 1.55, 0.38888888888889
12534, 0.95652173913043, 1.55, 0.44444444444444
12535, 0.021739130434783, 1.55, 0.055555555555556
12536, 0.043478260869565, 1.55, 0.027777777777778
12537, 0.021739130434783, 1.55, 0.11111111111111
12538, 0.043478260869565, 1.55, 0.083333333333333
12539, 0.021739130434783, 1.55, 0.16666666666667
12540, 0.043478260869565, 1.55, 0.13888888888889
12541, 0.021739130434783, 1.55, 0.22222222222222
12542, 0.043478260869565, 1.55, 0.19444444444444
12543, 0.021739130434783, 1.55, 0.27777777777778
12544, 0.043478260869565, 1.55, 0.25
12545, 0.021739130434783, 1.55, 0.33333333333333
12546, 0.043478260869565, 1.55, 0.30555555555556
12547, 0.021739130434783, 1.55, 0.38888888888889
12548, 0.043478260869565, 1.55, 0.36111111111111
12549, 0.021739130434783, 1.55, 0.44444444444444
12550, 0.043478260869565, 1.55, 0.41666666666667
12551, 0.043478260869565, 1.55, 0.47222222222222
12552, 0.065217391304348, 1.55, 0.055555555555556
12553, 0.08695652173913, 1.55, 0.027777777777778
12554, 0.065217391304348, 1.55, 0.11111111111111
12555, 0.08695652173913, 1.55, 0.083333333333333
12556, 0.065217391304348, 1.55, 0.16666666666667
12557, 0.08695652173913, 1.55, 0.13888888888889
12558, 0.065217391304348, 1.55, 0.22222222222222
12559, 0.08695652173913, 1.55, 0.19444444444444
12560, 0.065217391304348, 1.55, 0.27777777777778
12561, 0.08695652173913, 1.55, 0.25
12562, 0.065217391304348, 1.55, 0.33333333333333
12563, 0.08695652173913, 1.55, 0.30555555555556
12564, 0.065217391304348, 1.55, 0.38888888888889
12565, 0.08695652173913, 1.55, 0.36111111111111
12566, 0.065217391304348, 1.55, 0.44444444444444
12567, 0.08695652173913, 1.55, 0.41666666666667
12568, 0.08695652173913, 1.55, 0.47222222222222
12569, 0.10869565217391, 1.55, 0.055555555555556
12570, 0.1304347826087, 1.55, 0.027777777777778
12571, 0.10869565217391, 1.55, 0.11111111111111
12572, 0.1304347826087, 1.55, 0.083333333333333
12573, 0.10869565217391, 1.55, 0.16666666666667
12574, 0.1304347826087, 1.55, 0.13888888888889
12575, 0.10869565217391, 1.55, 0.22222222222222
12576, 0.1304347826087, 1.55, 0.19444444444444
12577, 0.10869565217391, 1.55, 0.27777777777778
12578, 0.1304347826087, 1.55, 0.25
12579, 0.10869565217391, 1.55, 0.33333333333333
12580, 0.1304347826087, 1.55, 0.30555555555556
12581, 0.10869565217391, 1.55, 0.38888888888889
12582, 0.1304347826087, 1.55, 0.36111111111111
12583, 0.10869565217391, 1.55, 0.44444444444444
12584, 0.1304347826087, 1.55, 0.41666666666667
12585, 0.1304347826087, 1.55, 0.47222222222222
12586, 0.15217391304348, 1.55, 0.055555555555556
12587, 0.17391304347826, 1.55, 0.027777777777778
12588, 0.15217391304348, 1.55, 0.11111111111111
12589, 0.17391304347826, 1.55, 0.083333333333333
12590, 0.15217391304348, 1.55, 0.16666666666667
12591, 0.17391304347826, 1.55, 0.13888888888889
12592, 0.15217391304348, 1.55, 0.22222222222222
12593, 0.17391304347826, 1.55, 0.19444444444444
12594, 0.15217391304348, 1.55, 0.27777777777778
12595, 0.17391304347826, 1.55, 0.25
12596, 0.15217391304348, 1.55, 0.33333333333333
12597, 0.17391304347826, 1.55, 0.30555555555556
12598, 0.15217391304348, 1.55, 0.38888888888889
12599, 0.17391304347826, 1.55, 0.36111111111111
12600, 0.15217391304348, 1.55, 0.44444444444444
12601, 0.17391304347826, 1.55, 0.41666666666667
12602, 0.17391304347826, 1.55, 0.47222222222222
12603, 0.19565217391304, 1.55, 0.055555555555556
12604, 0.21739130434783, 1.55, 0.027777777777778
12605, 0.19565217391304, 1.55, 0.11111111111111
12606, 0.21739130434783, 1.55, 0.083333333333333
12607, 0.19565217391304, 1.55, 0.16666666666667
12608, 0.21739130434783, 1.55, 0.13888888888889
12609, 0.19565217391304, 1.55, 0.22222222222222
12610, 0.21739130434783, 1.55, 0.19444444444444
12611, 0.19565217391304, 1.55, 0.27777777777778
12612, 0.21739130434783, 1.55, 0.25
12613, 0.19565217391304, 1.55, 0.33333333333333
12614, 0.21739130434783, 1.55, 0.30555555555556
12615, 0.19565217391304, 1.55, 0.38888888888889
12616, 0.21739130434783, 1.55, 0.36111111111111
12617, 0.19565217391304, 1.55, 0.44444444444444
12618, 0.21739130434783, 1.55, 0.41666666666667
12619, 0.21739130434783, 1.55, 0.47222222222222
12620, 0.23913043478261, 1.55, 0.055555555555556
12621, 0.26086956521739, 1.55, 0.027777777777778
12622, 0.23913043478261, 1.55, 0.11111111111111
12623, 0.26086956521739, 1.55, 0.083333333333333
12624, 0.23913043478261, 1.55, 0.16666666666667
12625, 0.26086956521739, 1.55, 0.13888888888889
12626, 0.23913043478261, 1.55, 0.22222222222222
12627, 0.26086956521739, 1.55, 0.19444444444444
12628, 0.23913043478261, 1.55, 0.27777777777778
12629, 0.26086956521739, 1.55, 0.25
12630, 0.23913043478261, 1.55, 0.33333333333333
12631, 0.26086956521739, 1.55, 0.30555555555556
12632, 0.23913043478261, 1.55, 0.38888888888889
12633, 0.26086956521739, 1.55, 0.36111111111111
12634, 0.23913043478261, 1.55, 0.44444444444444
12635, 0.26086956521739, 1.55, 0.41666666666667
12636, 0.26086956521739, 1.55, 0.47222222222222
12637, 0.28260869565217, 1.55, 0.055555555555556
12638, 0.30434782608696, 1.55, 0.027777777777778
12639, 0.28260869565217, 1.55, 0.11111111111111
12640, 0.30434782608696, 1.55, 0.083333333333333
12641, 0.28260869565217, 1.55, 0.16666666666667
12642, 0.30434782608696, 1.55, 0.13888888888889
12643, 0.28260869565217, 1.55, 0.22222222222222
12644, 0.30434782608696, 1.55, 0.19444444444444
12645, 0.28260869565217, 1.55, 0.27777777777778
12646, 0.30434782608696, 1.55, 0.25
12647, 0.28260869565217, 1.55, 0.33333333333333
12648, 0.30434782608696, 1.55, 0.30555555555556
12649, 0.28260869565217, 1.55, 0.38888888888889
12650, 0.30434782608696, 1.55, 0.36111111111111
12651, 0.28260869565217, 1.55, 0.44444444444444
12652, 0.30434782608696, 1.55, 0.41666666666667
12653, 0.30434782608696, 1.55, 0.47222222222222
12654, 0.32608695652174, 1.55, 0.055555555555556
12655, 0.34782608695652, 1.55, 0.027777777777778
12656, 0.32608695652174, 1.55, 0.11111111111111
12657, 0.34782608695652, 1.55, 0.083333333333333
12658, 0.32608695652174, 1.55, 0.16666666666667
12659, 0.34782608695652, 1.55, 0.13888888888889
12660, 0.32608695652174, 1.55, 0.22222222222222
12661, 0.34782608695652, 1.55, 0.19444444444444
12662, 0.32608695652174, 1.55, 0.27777777777778
12663, 0.34782608695652, 1.55, 0.25
12664, 0.32608695652174, 1.55, 0.33333333333333
12665, 0.34782608695652, 1.55, 0.30555555555556
12666, 0.32608695652174, 1.55, 0.38888888888889
12667, 0.34782608695652, 1.55, 0.36111111111111
12668, 0.32608695652174, 1.55, 0.44444444444444
12669, 0.34782608695652, 1.55, 0.41666666666667
12670, 0.34782608695652, 1.55, 0.47222222222222
12671, 0.3695652173913, 1.55, 0.055555555555556
