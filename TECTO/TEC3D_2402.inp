83612, 1.504347826087, 1.7, 0.30555555555556
83613, 1.4826086956522, 1.7, 0.27777777777778
83614, 1.504347826087, 1.675, 0.27777777777778
83615, 1.504347826087, 1.7, 0.25
83616, 1.4826086956522, 1.7, 0.22222222222222
83617, 1.504347826087, 1.675, 0.22222222222222
83618, 1.504347826087, 1.7, 0.19444444444444
83619, 1.4826086956522, 1.7, 0.16666666666667
83620, 1.504347826087, 1.675, 0.16666666666667
83621, 1.504347826087, 1.7, 0.13888888888889
83622, 1.4826086956522, 1.7, 0.11111111111111
83623, 1.504347826087, 1.675, 0.11111111111111
83624, 1.504347826087, 1.7, 0.083333333333333
83625, 1.4826086956522, 1.7, 0.055555555555556
83626, 1.504347826087, 1.675, 0.055555555555556
83627, 1.504347826087, 1.7, 0.027777777777778
83628, 1.5478260869565, 1.7, 0.47222222222222
83629, 1.5260869565217, 1.7, 0.44444444444444
83630, 1.5478260869565, 1.675, 0.44444444444444
83631, 1.5478260869565, 1.7, 0.41666666666667
83632, 1.5260869565217, 1.7, 0.38888888888889
83633, 1.5478260869565, 1.675, 0.38888888888889
83634, 1.5478260869565, 1.7, 0.36111111111111
83635, 1.5260869565217, 1.7, 0.33333333333333
83636, 1.5478260869565, 1.675, 0.33333333333333
83637, 1.5478260869565, 1.7, 0.30555555555556
83638, 1.5260869565217, 1.7, 0.27777777777778
83639, 1.5478260869565, 1.675, 0.27777777777778
83640, 1.5478260869565, 1.7, 0.25
83641, 1.5260869565217, 1.7, 0.22222222222222
83642, 1.5478260869565, 1.675, 0.22222222222222
83643, 1.5478260869565, 1.7, 0.19444444444444
83644, 1.5260869565217, 1.7, 0.16666666666667
83645, 1.5478260869565, 1.675, 0.16666666666667
83646, 1.5478260869565, 1.7, 0.13888888888889
83647, 1.5260869565217, 1.7, 0.11111111111111
83648, 1.5478260869565, 1.675, 0.11111111111111
83649, 1.5478260869565, 1.7, 0.083333333333333
83650, 1.5260869565217, 1.7, 0.055555555555556
83651, 1.5478260869565, 1.675, 0.055555555555556
83652, 1.5478260869565, 1.7, 0.027777777777778
83653, 1.5913043478261, 1.7, 0.47222222222222
83654, 1.5695652173913, 1.7, 0.44444444444444
83655, 1.5913043478261, 1.675, 0.44444444444444
83656, 1.5913043478261, 1.7, 0.41666666666667
83657, 1.5695652173913, 1.7, 0.38888888888889
83658, 1.5913043478261, 1.675, 0.38888888888889
83659, 1.5913043478261, 1.7, 0.36111111111111
83660, 1.5695652173913, 1.7, 0.33333333333333
83661, 1.5913043478261, 1.675, 0.33333333333333
83662, 1.5913043478261, 1.7, 0.30555555555556
83663, 1.5695652173913, 1.7, 0.27777777777778
83664, 1.5913043478261, 1.675, 0.27777777777778
83665, 1.5913043478261, 1.7, 0.25
83666, 1.5695652173913, 1.7, 0.22222222222222
83667, 1.5913043478261, 1.675, 0.22222222222222
83668, 1.5913043478261, 1.7, 0.19444444444444
83669, 1.5695652173913, 1.7, 0.16666666666667
83670, 1.5913043478261, 1.675, 0.16666666666667
83671, 1.5913043478261, 1.7, 0.13888888888889
83672, 1.5695652173913, 1.7, 0.11111111111111
83673, 1.5913043478261, 1.675, 0.11111111111111
83674, 1.5913043478261, 1.7, 0.083333333333333
83675, 1.5695652173913, 1.7, 0.055555555555556
83676, 1.5913043478261, 1.675, 0.055555555555556
83677, 1.5913043478261, 1.7, 0.027777777777778
83678, 1.6347826086957, 1.7, 0.47222222222222
83679, 1.6130434782609, 1.7, 0.44444444444444
83680, 1.6347826086957, 1.675, 0.44444444444444
83681, 1.6347826086957, 1.7, 0.41666666666667
83682, 1.6130434782609, 1.7, 0.38888888888889
83683, 1.6347826086957, 1.675, 0.38888888888889
83684, 1.6347826086957, 1.7, 0.36111111111111
83685, 1.6130434782609, 1.7, 0.33333333333333
83686, 1.6347826086957, 1.675, 0.33333333333333
83687, 1.6347826086957, 1.7, 0.30555555555556
83688, 1.6130434782609, 1.7, 0.27777777777778
83689, 1.6347826086957, 1.675, 0.27777777777778
83690, 1.6347826086957, 1.7, 0.25
83691, 1.6130434782609, 1.7, 0.22222222222222
83692, 1.6347826086957, 1.675, 0.22222222222222
83693, 1.6347826086957, 1.7, 0.19444444444444
83694, 1.6130434782609, 1.7, 0.16666666666667
83695, 1.6347826086957, 1.675, 0.16666666666667
83696, 1.6347826086957, 1.7, 0.13888888888889
83697, 1.6130434782609, 1.7, 0.11111111111111
83698, 1.6347826086957, 1.675, 0.11111111111111
83699, 1.6347826086957, 1.7, 0.083333333333333
83700, 1.6130434782609, 1.7, 0.055555555555556
83701, 1.6347826086957, 1.675, 0.055555555555556
83702, 1.6347826086957, 1.7, 0.027777777777778
83703, 1.6782608695652, 1.7, 0.47222222222222
83704, 1.6565217391304, 1.7, 0.44444444444444
83705, 1.6782608695652, 1.675, 0.44444444444444
83706, 1.6782608695652, 1.7, 0.41666666666667
83707, 1.6565217391304, 1.7, 0.38888888888889
83708, 1.6782608695652, 1.675, 0.38888888888889
83709, 1.6782608695652, 1.7, 0.36111111111111
83710, 1.6565217391304, 1.7, 0.33333333333333
83711, 1.6782608695652, 1.675, 0.33333333333333
83712, 1.6782608695652, 1.7, 0.30555555555556
83713, 1.6565217391304, 1.7, 0.27777777777778
83714, 1.6782608695652, 1.675, 0.27777777777778
83715, 1.6782608695652, 1.7, 0.25
83716, 1.6565217391304, 1.7, 0.22222222222222
83717, 1.6782608695652, 1.675, 0.22222222222222
83718, 1.6782608695652, 1.7, 0.19444444444444
83719, 1.6565217391304, 1.7, 0.16666666666667
83720, 1.6782608695652, 1.675, 0.16666666666667
83721, 1.6782608695652, 1.7, 0.13888888888889
83722, 1.6565217391304, 1.7, 0.11111111111111
83723, 1.6782608695652, 1.675, 0.11111111111111
83724, 1.6782608695652, 1.7, 0.083333333333333
83725, 1.6565217391304, 1.7, 0.055555555555556
83726, 1.6782608695652, 1.675, 0.055555555555556
83727, 1.6782608695652, 1.7, 0.027777777777778
83728, 1.7217391304348, 1.7, 0.47222222222222
83729, 1.7, 1.7, 0.44444444444444
83730, 1.7217391304348, 1.675, 0.44444444444444
83731, 1.7217391304348, 1.7, 0.41666666666667
83732, 1.7, 1.7, 0.38888888888889
83733, 1.7217391304348, 1.675, 0.38888888888889
83734, 1.7217391304348, 1.7, 0.36111111111111
83735, 1.7, 1.7, 0.33333333333333
83736, 1.7217391304348, 1.675, 0.33333333333333
83737, 1.7217391304348, 1.7, 0.30555555555556
83738, 1.7, 1.7, 0.27777777777778
83739, 1.7217391304348, 1.675, 0.27777777777778
83740, 1.7217391304348, 1.7, 0.25
83741, 1.7, 1.7, 0.22222222222222
83742, 1.7217391304348, 1.675, 0.22222222222222
83743, 1.7217391304348, 1.7, 0.19444444444444
83744, 1.7, 1.7, 0.16666666666667
83745, 1.7217391304348, 1.675, 0.16666666666667
83746, 1.7217391304348, 1.7, 0.13888888888889
83747, 1.7, 1.7, 0.11111111111111
83748, 1.7217391304348, 1.675, 0.11111111111111
83749, 1.7217391304348, 1.7, 0.083333333333333
83750, 1.7, 1.7, 0.055555555555556
83751, 1.7217391304348, 1.675, 0.055555555555556
83752, 1.7217391304348, 1.7, 0.027777777777778
83753, 1.7652173913043, 1.7, 0.47222222222222
83754, 1.7434782608696, 1.7, 0.44444444444444
83755, 1.7652173913043, 1.675, 0.44444444444444
83756, 1.7652173913043, 1.7, 0.41666666666667
83757, 1.7434782608696, 1.7, 0.38888888888889
83758, 1.7652173913043, 1.675, 0.38888888888889
83759, 1.7652173913043, 1.7, 0.36111111111111
83760, 1.7434782608696, 1.7, 0.33333333333333
83761, 1.7652173913043, 1.675, 0.33333333333333
83762, 1.7652173913043, 1.7, 0.30555555555556
83763, 1.7434782608696, 1.7, 0.27777777777778
83764, 1.7652173913043, 1.675, 0.27777777777778
83765, 1.7652173913043, 1.7, 0.25
83766, 1.7434782608696, 1.7, 0.22222222222222
83767, 1.7652173913043, 1.675, 0.22222222222222
83768, 1.7652173913043, 1.7, 0.19444444444444
83769, 1.7434782608696, 1.7, 0.16666666666667
83770, 1.7652173913043, 1.675, 0.16666666666667
83771, 1.7652173913043, 1.7, 0.13888888888889
83772, 1.7434782608696, 1.7, 0.11111111111111
83773, 1.7652173913043, 1.675, 0.11111111111111
83774, 1.7652173913043, 1.7, 0.083333333333333
83775, 1.7434782608696, 1.7, 0.055555555555556
83776, 1.7652173913043, 1.675, 0.055555555555556
83777, 1.7652173913043, 1.7, 0.027777777777778
83778, 1.8086956521739, 1.7, 0.47222222222222
83779, 1.7869565217391, 1.7, 0.44444444444444
83780, 1.8086956521739, 1.675, 0.44444444444444
83781, 1.8086956521739, 1.7, 0.41666666666667
83782, 1.7869565217391, 1.7, 0.38888888888889
83783, 1.8086956521739, 1.675, 0.38888888888889
83784, 1.8086956521739, 1.7, 0.36111111111111
83785, 1.7869565217391, 1.7, 0.33333333333333
83786, 1.8086956521739, 1.675, 0.33333333333333
83787, 1.8086956521739, 1.7, 0.30555555555556
83788, 1.7869565217391, 1.7, 0.27777777777778
83789, 1.8086956521739, 1.675, 0.27777777777778
83790, 1.8086956521739, 1.7, 0.25
83791, 1.7869565217391, 1.7, 0.22222222222222
83792, 1.8086956521739, 1.675, 0.22222222222222
83793, 1.8086956521739, 1.7, 0.19444444444444
83794, 1.7869565217391, 1.7, 0.16666666666667
83795, 1.8086956521739, 1.675, 0.16666666666667
83796, 1.8086956521739, 1.7, 0.13888888888889
83797, 1.7869565217391, 1.7, 0.11111111111111
83798, 1.8086956521739, 1.675, 0.11111111111111
83799, 1.8086956521739, 1.7, 0.083333333333333
83800, 1.7869565217391, 1.7, 0.055555555555556
83801, 1.8086956521739, 1.675, 0.055555555555556
83802, 1.8086956521739, 1.7, 0.027777777777778
83803, 1.8521739130435, 1.7, 0.47222222222222
83804, 1.8304347826087, 1.7, 0.44444444444444
83805, 1.8521739130435, 1.675, 0.44444444444444
83806, 1.8521739130435, 1.7, 0.41666666666667
83807, 1.8304347826087, 1.7, 0.38888888888889
83808, 1.8521739130435, 1.675, 0.38888888888889
83809, 1.8521739130435, 1.7, 0.36111111111111
83810, 1.8304347826087, 1.7, 0.33333333333333
83811, 1.8521739130435, 1.675, 0.33333333333333
83812, 1.8521739130435, 1.7, 0.30555555555556
83813, 1.8304347826087, 1.7, 0.27777777777778
83814, 1.8521739130435, 1.675, 0.27777777777778
83815, 1.8521739130435, 1.7, 0.25
83816, 1.8304347826087, 1.7, 0.22222222222222
83817, 1.8521739130435, 1.675, 0.22222222222222
83818, 1.8521739130435, 1.7, 0.19444444444444
83819, 1.8304347826087, 1.7, 0.16666666666667
83820, 1.8521739130435, 1.675, 0.16666666666667
83821, 1.8521739130435, 1.7, 0.13888888888889
83822, 1.8304347826087, 1.7, 0.11111111111111
83823, 1.8521739130435, 1.675, 0.11111111111111
83824, 1.8521739130435, 1.7, 0.083333333333333
83825, 1.8304347826087, 1.7, 0.055555555555556
83826, 1.8521739130435, 1.675, 0.055555555555556
83827, 1.8521739130435, 1.7, 0.027777777777778
83828, 1.895652173913, 1.7, 0.47222222222222
83829, 1.8739130434783, 1.7, 0.44444444444444
83830, 1.895652173913, 1.675, 0.44444444444444
83831, 1.895652173913, 1.7, 0.41666666666667
83832, 1.8739130434783, 1.7, 0.38888888888889
83833, 1.895652173913, 1.675, 0.38888888888889
83834, 1.895652173913, 1.7, 0.36111111111111
83835, 1.8739130434783, 1.7, 0.33333333333333
83836, 1.895652173913, 1.675, 0.33333333333333
83837, 1.895652173913, 1.7, 0.30555555555556
83838, 1.8739130434783, 1.7, 0.27777777777778
83839, 1.895652173913, 1.675, 0.27777777777778
83840, 1.895652173913, 1.7, 0.25
83841, 1.8739130434783, 1.7, 0.22222222222222
83842, 1.895652173913, 1.675, 0.22222222222222
83843, 1.895652173913, 1.7, 0.19444444444444
83844, 1.8739130434783, 1.7, 0.16666666666667
83845, 1.895652173913, 1.675, 0.16666666666667
83846, 1.895652173913, 1.7, 0.13888888888889
83847, 1.8739130434783, 1.7, 0.11111111111111
83848, 1.895652173913, 1.675, 0.11111111111111
83849, 1.895652173913, 1.7, 0.083333333333333
83850, 1.8739130434783, 1.7, 0.055555555555556
83851, 1.895652173913, 1.675, 0.055555555555556
83852, 1.895652173913, 1.7, 0.027777777777778
83853, 1.9391304347826, 1.7, 0.47222222222222
83854, 1.9173913043478, 1.7, 0.44444444444444
83855, 1.9391304347826, 1.675, 0.44444444444444
83856, 1.9391304347826, 1.7, 0.41666666666667
83857, 1.9173913043478, 1.7, 0.38888888888889
83858, 1.9391304347826, 1.675, 0.38888888888889
83859, 1.9391304347826, 1.7, 0.36111111111111
83860, 1.9173913043478, 1.7, 0.33333333333333
83861, 1.9391304347826, 1.675, 0.33333333333333
83862, 1.9391304347826, 1.7, 0.30555555555556
83863, 1.9173913043478, 1.7, 0.27777777777778
83864, 1.9391304347826, 1.675, 0.27777777777778
83865, 1.9391304347826, 1.7, 0.25
83866, 1.9173913043478, 1.7, 0.22222222222222
83867, 1.9391304347826, 1.675, 0.22222222222222
83868, 1.9391304347826, 1.7, 0.19444444444444
83869, 1.9173913043478, 1.7, 0.16666666666667
83870, 1.9391304347826, 1.675, 0.16666666666667
83871, 1.9391304347826, 1.7, 0.13888888888889
83872, 1.9173913043478, 1.7, 0.11111111111111
83873, 1.9391304347826, 1.675, 0.11111111111111
83874, 1.9391304347826, 1.7, 0.083333333333333
83875, 1.9173913043478, 1.7, 0.055555555555556
83876, 1.9391304347826, 1.675, 0.055555555555556
83877, 1.9391304347826, 1.7, 0.027777777777778
83878, 1.9826086956522, 1.7, 0.47222222222222
83879, 1.9608695652174, 1.7, 0.44444444444444
83880, 1.9826086956522, 1.675, 0.44444444444444
83881, 1.9826086956522, 1.7, 0.41666666666667
83882, 1.9608695652174, 1.7, 0.38888888888889
83883, 1.9826086956522, 1.675, 0.38888888888889
83884, 1.9826086956522, 1.7, 0.36111111111111
83885, 1.9608695652174, 1.7, 0.33333333333333
83886, 1.9826086956522, 1.675, 0.33333333333333
83887, 1.9826086956522, 1.7, 0.30555555555556
83888, 1.9608695652174, 1.7, 0.27777777777778
83889, 1.9826086956522, 1.675, 0.27777777777778
83890, 1.9826086956522, 1.7, 0.25
83891, 1.9608695652174, 1.7, 0.22222222222222
83892, 1.9826086956522, 1.675, 0.22222222222222
83893, 1.9826086956522, 1.7, 0.19444444444444
83894, 1.9608695652174, 1.7, 0.16666666666667
83895, 1.9826086956522, 1.675, 0.16666666666667
83896, 1.9826086956522, 1.7, 0.13888888888889
83897, 1.9608695652174, 1.7, 0.11111111111111
83898, 1.9826086956522, 1.675, 0.11111111111111
83899, 1.9826086956522, 1.7, 0.083333333333333
83900, 1.9608695652174, 1.7, 0.055555555555556
83901, 1.9826086956522, 1.675, 0.055555555555556
83902, 1.9826086956522, 1.7, 0.027777777777778
83903, 2.0260869565217, 1.7, 0.47222222222222
83904, 2.004347826087, 1.7, 0.44444444444444
83905, 2.0260869565217, 1.675, 0.44444444444444
83906, 2.0260869565217, 1.7, 0.41666666666667
83907, 2.004347826087, 1.7, 0.38888888888889
83908, 2.0260869565217, 1.675, 0.38888888888889
83909, 2.0260869565217, 1.7, 0.36111111111111
83910, 2.004347826087, 1.7, 0.33333333333333
83911, 2.0260869565217, 1.675, 0.33333333333333
83912, 2.0260869565217, 1.7, 0.30555555555556
83913, 2.004347826087, 1.7, 0.27777777777778
83914, 2.0260869565217, 1.675, 0.27777777777778
83915, 2.0260869565217, 1.7, 0.25
83916, 2.004347826087, 1.7, 0.22222222222222
83917, 2.0260869565217, 1.675, 0.22222222222222
83918, 2.0260869565217, 1.7, 0.19444444444444
83919, 2.004347826087, 1.7, 0.16666666666667
83920, 2.0260869565217, 1.675, 0.16666666666667
83921, 2.0260869565217, 1.7, 0.13888888888889
83922, 2.004347826087, 1.7, 0.11111111111111
83923, 2.0260869565217, 1.675, 0.11111111111111
83924, 2.0260869565217, 1.7, 0.083333333333333
83925, 2.004347826087, 1.7, 0.055555555555556
83926, 2.0260869565217, 1.675, 0.055555555555556
83927, 2.0260869565217, 1.7, 0.027777777777778
83928, 2.0695652173913, 1.7, 0.47222222222222
83929, 2.0478260869565, 1.7, 0.44444444444444
83930, 2.0695652173913, 1.675, 0.44444444444444
83931, 2.0695652173913, 1.7, 0.41666666666667
83932, 2.0478260869565, 1.7, 0.38888888888889
83933, 2.0695652173913, 1.675, 0.38888888888889
83934, 2.0695652173913, 1.7, 0.36111111111111
83935, 2.0478260869565, 1.7, 0.33333333333333
83936, 2.0695652173913, 1.675, 0.33333333333333
83937, 2.0695652173913, 1.7, 0.30555555555556
83938, 2.0478260869565, 1.7, 0.27777777777778
83939, 2.0695652173913, 1.675, 0.27777777777778
83940, 2.0695652173913, 1.7, 0.25
83941, 2.0478260869565, 1.7, 0.22222222222222
83942, 2.0695652173913, 1.675, 0.22222222222222
83943, 2.0695652173913, 1.7, 0.19444444444444
83944, 2.0478260869565, 1.7, 0.16666666666667
83945, 2.0695652173913, 1.675, 0.16666666666667
83946, 2.0695652173913, 1.7, 0.13888888888889
83947, 2.0478260869565, 1.7, 0.11111111111111
83948, 2.0695652173913, 1.675, 0.11111111111111
83949, 2.0695652173913, 1.7, 0.083333333333333
83950, 2.0478260869565, 1.7, 0.055555555555556
83951, 2.0695652173913, 1.675, 0.055555555555556
83952, 2.0695652173913, 1.7, 0.027777777777778
83953, 2.1130434782609, 1.7, 0.47222222222222
83954, 2.0913043478261, 1.7, 0.44444444444444
83955, 2.1130434782609, 1.675, 0.44444444444444
83956, 2.1130434782609, 1.7, 0.41666666666667
83957, 2.0913043478261, 1.7, 0.38888888888889
83958, 2.1130434782609, 1.675, 0.38888888888889
83959, 2.1130434782609, 1.7, 0.36111111111111
83960, 2.0913043478261, 1.7, 0.33333333333333
83961, 2.1130434782609, 1.675, 0.33333333333333
83962, 2.1130434782609, 1.7, 0.30555555555556
83963, 2.0913043478261, 1.7, 0.27777777777778
83964, 2.1130434782609, 1.675, 0.27777777777778
83965, 2.1130434782609, 1.7, 0.25
83966, 2.0913043478261, 1.7, 0.22222222222222
83967, 2.1130434782609, 1.675, 0.22222222222222
83968, 2.1130434782609, 1.7, 0.19444444444444
83969, 2.0913043478261, 1.7, 0.16666666666667
83970, 2.1130434782609, 1.675, 0.16666666666667
83971, 2.1130434782609, 1.7, 0.13888888888889
83972, 2.0913043478261, 1.7, 0.11111111111111
83973, 2.1130434782609, 1.675, 0.11111111111111
83974, 2.1130434782609, 1.7, 0.083333333333333
83975, 2.0913043478261, 1.7, 0.055555555555556
83976, 2.1130434782609, 1.675, 0.055555555555556
83977, 2.1130434782609, 1.7, 0.027777777777778
83978, 2.1565217391304, 1.7, 0.47222222222222
83979, 2.1347826086957, 1.7, 0.44444444444444
83980, 2.1565217391304, 1.675, 0.44444444444444
83981, 2.1565217391304, 1.7, 0.41666666666667
83982, 2.1347826086957, 1.7, 0.38888888888889
83983, 2.1565217391304, 1.675, 0.38888888888889
83984, 2.1565217391304, 1.7, 0.36111111111111
83985, 2.1347826086957, 1.7, 0.33333333333333
83986, 2.1565217391304, 1.675, 0.33333333333333
83987, 2.1565217391304, 1.7, 0.30555555555556
83988, 2.1347826086957, 1.7, 0.27777777777778
83989, 2.1565217391304, 1.675, 0.27777777777778
83990, 2.1565217391304, 1.7, 0.25
83991, 2.1347826086957, 1.7, 0.22222222222222
83992, 2.1565217391304, 1.675, 0.22222222222222
83993, 2.1565217391304, 1.7, 0.19444444444444
83994, 2.1347826086957, 1.7, 0.16666666666667
83995, 2.1565217391304, 1.675, 0.16666666666667
83996, 2.1565217391304, 1.7, 0.13888888888889
83997, 2.1347826086957, 1.7, 0.11111111111111
83998, 2.1565217391304, 1.675, 0.11111111111111
83999, 2.1565217391304, 1.7, 0.083333333333333
84000, 2.1347826086957, 1.7, 0.055555555555556
84001, 2.1565217391304, 1.675, 0.055555555555556
84002, 2.1565217391304, 1.7, 0.027777777777778
84003, 2.1782608695652, 1.7, 0.44444444444444
84004, 2.1782608695652, 1.7, 0.38888888888889
84005, 2.1782608695652, 1.7, 0.33333333333333
84006, 2.1782608695652, 1.7, 0.27777777777778
84007, 2.1782608695652, 1.7, 0.22222222222222
84008, 2.1782608695652, 1.7, 0.16666666666667
84009, 2.1782608695652, 1.7, 0.11111111111111
84010, 2.1782608695652, 1.7, 0.055555555555556
84011, 1.2434782608696, 1.725, 0.44444444444444
84012, 1.2434782608696, 1.725, 0.38888888888889
84013, 1.2434782608696, 1.725, 0.33333333333333
84014, 1.2434782608696, 1.725, 0.27777777777778
84015, 1.2434782608696, 1.725, 0.22222222222222
84016, 1.2434782608696, 1.725, 0.16666666666667
84017, 1.2434782608696, 1.725, 0.11111111111111
84018, 1.2434782608696, 1.725, 0.055555555555556
84019, 1.2869565217391, 1.725, 0.44444444444444
84020, 1.2869565217391, 1.725, 0.38888888888889
84021, 1.2869565217391, 1.725, 0.33333333333333
84022, 1.2869565217391, 1.725, 0.27777777777778
84023, 1.2869565217391, 1.725, 0.22222222222222
84024, 1.2869565217391, 1.725, 0.16666666666667
84025, 1.2869565217391, 1.725, 0.11111111111111
84026, 1.2869565217391, 1.725, 0.055555555555556
84027, 1.3304347826087, 1.725, 0.44444444444444
84028, 1.3304347826087, 1.725, 0.38888888888889
84029, 1.3304347826087, 1.725, 0.33333333333333
84030, 1.3304347826087, 1.725, 0.27777777777778
84031, 1.3304347826087, 1.725, 0.22222222222222
84032, 1.3304347826087, 1.725, 0.16666666666667
84033, 1.3304347826087, 1.725, 0.11111111111111
84034, 1.3304347826087, 1.725, 0.055555555555556
84035, 1.3739130434783, 1.725, 0.44444444444444
84036, 1.3739130434783, 1.725, 0.38888888888889
84037, 1.3739130434783, 1.725, 0.33333333333333
84038, 1.3739130434783, 1.725, 0.27777777777778
84039, 1.3739130434783, 1.725, 0.22222222222222
84040, 1.3739130434783, 1.725, 0.16666666666667
84041, 1.3739130434783, 1.725, 0.11111111111111
84042, 1.3739130434783, 1.725, 0.055555555555556
84043, 1.4173913043478, 1.725, 0.44444444444444
84044, 1.4173913043478, 1.725, 0.38888888888889
84045, 1.4173913043478, 1.725, 0.33333333333333
84046, 1.4173913043478, 1.725, 0.27777777777778
84047, 1.4173913043478, 1.725, 0.22222222222222
84048, 1.4173913043478, 1.725, 0.16666666666667
84049, 1.4173913043478, 1.725, 0.11111111111111
84050, 1.4173913043478, 1.725, 0.055555555555556
84051, 1.4608695652174, 1.725, 0.44444444444444
84052, 1.4608695652174, 1.725, 0.38888888888889
84053, 1.4608695652174, 1.725, 0.33333333333333
84054, 1.4608695652174, 1.725, 0.27777777777778
84055, 1.4608695652174, 1.725, 0.22222222222222
84056, 1.4608695652174, 1.725, 0.16666666666667
84057, 1.4608695652174, 1.725, 0.11111111111111
84058, 1.4608695652174, 1.725, 0.055555555555556
84059, 1.504347826087, 1.725, 0.44444444444444
84060, 1.504347826087, 1.725, 0.38888888888889
84061, 1.504347826087, 1.725, 0.33333333333333
84062, 1.504347826087, 1.725, 0.27777777777778
84063, 1.504347826087, 1.725, 0.22222222222222
84064, 1.504347826087, 1.725, 0.16666666666667
84065, 1.504347826087, 1.725, 0.11111111111111
84066, 1.504347826087, 1.725, 0.055555555555556
84067, 1.5478260869565, 1.725, 0.44444444444444
84068, 1.5478260869565, 1.725, 0.38888888888889
84069, 1.5478260869565, 1.725, 0.33333333333333
84070, 1.5478260869565, 1.725, 0.27777777777778
84071, 1.5478260869565, 1.725, 0.22222222222222
84072, 1.5478260869565, 1.725, 0.16666666666667
84073, 1.5478260869565, 1.725, 0.11111111111111
84074, 1.5478260869565, 1.725, 0.055555555555556
84075, 1.5913043478261, 1.725, 0.44444444444444
84076, 1.5913043478261, 1.725, 0.38888888888889
84077, 1.5913043478261, 1.725, 0.33333333333333
84078, 1.5913043478261, 1.725, 0.27777777777778
84079, 1.5913043478261, 1.725, 0.22222222222222
84080, 1.5913043478261, 1.725, 0.16666666666667
84081, 1.5913043478261, 1.725, 0.11111111111111
84082, 1.5913043478261, 1.725, 0.055555555555556
84083, 1.6347826086957, 1.725, 0.44444444444444
84084, 1.6347826086957, 1.725, 0.38888888888889
84085, 1.6347826086957, 1.725, 0.33333333333333
84086, 1.6347826086957, 1.725, 0.27777777777778
84087, 1.6347826086957, 1.725, 0.22222222222222
84088, 1.6347826086957, 1.725, 0.16666666666667
84089, 1.6347826086957, 1.725, 0.11111111111111
84090, 1.6347826086957, 1.725, 0.055555555555556
84091, 1.6782608695652, 1.725, 0.44444444444444
84092, 1.6782608695652, 1.725, 0.38888888888889
84093, 1.6782608695652, 1.725, 0.33333333333333
84094, 1.6782608695652, 1.725, 0.27777777777778
84095, 1.6782608695652, 1.725, 0.22222222222222
84096, 1.6782608695652, 1.725, 0.16666666666667
84097, 1.6782608695652, 1.725, 0.11111111111111
84098, 1.6782608695652, 1.725, 0.055555555555556
84099, 1.7217391304348, 1.725, 0.44444444444444
84100, 1.7217391304348, 1.725, 0.38888888888889
84101, 1.7217391304348, 1.725, 0.33333333333333
84102, 1.7217391304348, 1.725, 0.27777777777778
84103, 1.7217391304348, 1.725, 0.22222222222222
84104, 1.7217391304348, 1.725, 0.16666666666667
84105, 1.7217391304348, 1.725, 0.11111111111111
84106, 1.7217391304348, 1.725, 0.055555555555556
84107, 1.7652173913043, 1.725, 0.44444444444444
84108, 1.7652173913043, 1.725, 0.38888888888889
84109, 1.7652173913043, 1.725, 0.33333333333333
84110, 1.7652173913043, 1.725, 0.27777777777778
84111, 1.7652173913043, 1.725, 0.22222222222222
84112, 1.7652173913043, 1.725, 0.16666666666667
84113, 1.7652173913043, 1.725, 0.11111111111111
84114, 1.7652173913043, 1.725, 0.055555555555556
84115, 1.8086956521739, 1.725, 0.44444444444444
84116, 1.8086956521739, 1.725, 0.38888888888889
84117, 1.8086956521739, 1.725, 0.33333333333333
84118, 1.8086956521739, 1.725, 0.27777777777778
84119, 1.8086956521739, 1.725, 0.22222222222222
84120, 1.8086956521739, 1.725, 0.16666666666667
84121, 1.8086956521739, 1.725, 0.11111111111111
84122, 1.8086956521739, 1.725, 0.055555555555556
84123, 1.8521739130435, 1.725, 0.44444444444444
84124, 1.8521739130435, 1.725, 0.38888888888889
84125, 1.8521739130435, 1.725, 0.33333333333333
84126, 1.8521739130435, 1.725, 0.27777777777778
84127, 1.8521739130435, 1.725, 0.22222222222222
84128, 1.8521739130435, 1.725, 0.16666666666667
84129, 1.8521739130435, 1.725, 0.11111111111111
84130, 1.8521739130435, 1.725, 0.055555555555556
84131, 1.895652173913, 1.725, 0.44444444444444
84132, 1.895652173913, 1.725, 0.38888888888889
84133, 1.895652173913, 1.725, 0.33333333333333
84134, 1.895652173913, 1.725, 0.27777777777778
84135, 1.895652173913, 1.725, 0.22222222222222
84136, 1.895652173913, 1.725, 0.16666666666667
84137, 1.895652173913, 1.725, 0.11111111111111
84138, 1.895652173913, 1.725, 0.055555555555556
84139, 1.9391304347826, 1.725, 0.44444444444444
84140, 1.9391304347826, 1.725, 0.38888888888889
84141, 1.9391304347826, 1.725, 0.33333333333333
84142, 1.9391304347826, 1.725, 0.27777777777778
84143, 1.9391304347826, 1.725, 0.22222222222222
84144, 1.9391304347826, 1.725, 0.16666666666667
84145, 1.9391304347826, 1.725, 0.11111111111111
84146, 1.9391304347826, 1.725, 0.055555555555556
84147, 1.9826086956522, 1.725, 0.44444444444444
84148, 1.9826086956522, 1.725, 0.38888888888889
84149, 1.9826086956522, 1.725, 0.33333333333333
84150, 1.9826086956522, 1.725, 0.27777777777778
84151, 1.9826086956522, 1.725, 0.22222222222222
84152, 1.9826086956522, 1.725, 0.16666666666667
84153, 1.9826086956522, 1.725, 0.11111111111111
84154, 1.9826086956522, 1.725, 0.055555555555556
84155, 2.0260869565217, 1.725, 0.44444444444444
84156, 2.0260869565217, 1.725, 0.38888888888889
84157, 2.0260869565217, 1.725, 0.33333333333333
84158, 2.0260869565217, 1.725, 0.27777777777778
84159, 2.0260869565217, 1.725, 0.22222222222222
84160, 2.0260869565217, 1.725, 0.16666666666667
84161, 2.0260869565217, 1.725, 0.11111111111111
84162, 2.0260869565217, 1.725, 0.055555555555556
84163, 2.0695652173913, 1.725, 0.44444444444444
84164, 2.0695652173913, 1.725, 0.38888888888889
84165, 2.0695652173913, 1.725, 0.33333333333333
84166, 2.0695652173913, 1.725, 0.27777777777778
84167, 2.0695652173913, 1.725, 0.22222222222222
84168, 2.0695652173913, 1.725, 0.16666666666667
84169, 2.0695652173913, 1.725, 0.11111111111111
84170, 2.0695652173913, 1.725, 0.055555555555556
84171, 2.1130434782609, 1.725, 0.44444444444444
84172, 2.1130434782609, 1.725, 0.38888888888889
84173, 2.1130434782609, 1.725, 0.33333333333333
84174, 2.1130434782609, 1.725, 0.27777777777778
84175, 2.1130434782609, 1.725, 0.22222222222222
84176, 2.1130434782609, 1.725, 0.16666666666667
84177, 2.1130434782609, 1.725, 0.11111111111111
84178, 2.1130434782609, 1.725, 0.055555555555556
84179, 2.1565217391304, 1.725, 0.44444444444444
84180, 2.1565217391304, 1.725, 0.38888888888889
84181, 2.1565217391304, 1.725, 0.33333333333333
84182, 2.1565217391304, 1.725, 0.27777777777778
84183, 2.1565217391304, 1.725, 0.22222222222222
84184, 2.1565217391304, 1.725, 0.16666666666667
84185, 2.1565217391304, 1.725, 0.11111111111111
84186, 2.1565217391304, 1.725, 0.055555555555556
84187, 0.95652173913043, -0.1, 0.055555555555556
84188, 0.95652173913043, -0.1, 0.11111111111111
84189, 0.95652173913043, -0.1, 0.16666666666667
84190, 0.95652173913043, -0.1, 0.22222222222222
84191, 0.95652173913043, -0.1, 0.27777777777778
84192, 0.95652173913043, -0.1, 0.33333333333333
84193, 0.95652173913043, -0.1, 0.38888888888889
84194, 0.95652173913043, -0.1, 0.44444444444444
84195, 0.91304347826087, -0.1, 0.055555555555556
84196, 0.91304347826087, -0.1, 0.11111111111111
84197, 0.91304347826087, -0.1, 0.16666666666667
84198, 0.91304347826087, -0.1, 0.22222222222222
84199, 0.91304347826087, -0.1, 0.27777777777778
84200, 0.91304347826087, -0.1, 0.33333333333333
84201, 0.91304347826087, -0.1, 0.38888888888889
84202, 0.91304347826087, -0.1, 0.44444444444444
84203, 0.8695652173913, -0.1, 0.055555555555556
84204, 0.8695652173913, -0.1, 0.11111111111111
84205, 0.8695652173913, -0.1, 0.16666666666667
84206, 0.8695652173913, -0.1, 0.22222222222222
84207, 0.8695652173913, -0.1, 0.27777777777778
84208, 0.8695652173913, -0.1, 0.33333333333333
84209, 0.8695652173913, -0.1, 0.38888888888889
84210, 0.8695652173913, -0.1, 0.44444444444444
84211, 0.82608695652174, -0.1, 0.055555555555556
84212, 0.82608695652174, -0.1, 0.11111111111111
84213, 0.82608695652174, -0.1, 0.16666666666667
84214, 0.82608695652174, -0.1, 0.22222222222222
84215, 0.82608695652174, -0.1, 0.27777777777778
84216, 0.82608695652174, -0.1, 0.33333333333333
84217, 0.82608695652174, -0.1, 0.38888888888889
84218, 0.82608695652174, -0.1, 0.44444444444444
84219, 0.78260869565217, -0.1, 0.055555555555556
84220, 0.78260869565217, -0.1, 0.11111111111111
84221, 0.78260869565217, -0.1, 0.16666666666667
84222, 0.78260869565217, -0.1, 0.22222222222222
84223, 0.78260869565217, -0.1, 0.27777777777778
84224, 0.78260869565217, -0.1, 0.33333333333333
84225, 0.78260869565217, -0.1, 0.38888888888889
84226, 0.78260869565217, -0.1, 0.44444444444444
84227, 0.73913043478261, -0.1, 0.055555555555556
84228, 0.73913043478261, -0.1, 0.11111111111111
84229, 0.73913043478261, -0.1, 0.16666666666667
84230, 0.73913043478261, -0.1, 0.22222222222222
84231, 0.73913043478261, -0.1, 0.27777777777778
84232, 0.73913043478261, -0.1, 0.33333333333333
84233, 0.73913043478261, -0.1, 0.38888888888889
84234, 0.73913043478261, -0.1, 0.44444444444444
84235, 0.69565217391304, -0.1, 0.055555555555556
84236, 0.69565217391304, -0.1, 0.11111111111111
84237, 0.69565217391304, -0.1, 0.16666666666667
84238, 0.69565217391304, -0.1, 0.22222222222222
84239, 0.69565217391304, -0.1, 0.27777777777778
84240, 0.69565217391304, -0.1, 0.33333333333333
84241, 0.69565217391304, -0.1, 0.38888888888889
84242, 0.69565217391304, -0.1, 0.44444444444444
84243, 0.65217391304348, -0.1, 0.055555555555556
84244, 0.65217391304348, -0.1, 0.11111111111111
84245, 0.65217391304348, -0.1, 0.16666666666667
84246, 0.65217391304348, -0.1, 0.22222222222222
84247, 0.65217391304348, -0.1, 0.27777777777778
84248, 0.65217391304348, -0.1, 0.33333333333333
84249, 0.65217391304348, -0.1, 0.38888888888889
84250, 0.65217391304348, -0.1, 0.44444444444444
84251, 0.60869565217391, -0.1, 0.055555555555556
84252, 0.60869565217391, -0.1, 0.11111111111111
84253, 0.60869565217391, -0.1, 0.16666666666667
84254, 0.60869565217391, -0.1, 0.22222222222222
84255, 0.60869565217391, -0.1, 0.27777777777778
84256, 0.60869565217391, -0.1, 0.33333333333333
84257, 0.60869565217391, -0.1, 0.38888888888889
84258, 0.60869565217391, -0.1, 0.44444444444444
84259, 0.56521739130435, -0.1, 0.055555555555556
84260, 0.56521739130435, -0.1, 0.11111111111111
84261, 0.56521739130435, -0.1, 0.16666666666667
84262, 0.56521739130435, -0.1, 0.22222222222222
84263, 0.56521739130435, -0.1, 0.27777777777778
84264, 0.56521739130435, -0.1, 0.33333333333333
84265, 0.56521739130435, -0.1, 0.38888888888889
84266, 0.56521739130435, -0.1, 0.44444444444444
84267, 0.52173913043478, -0.1, 0.055555555555556
84268, 0.52173913043478, -0.1, 0.11111111111111
84269, 0.52173913043478, -0.1, 0.16666666666667
84270, 0.52173913043478, -0.1, 0.22222222222222
84271, 0.52173913043478, -0.1, 0.27777777777778
84272, 0.52173913043478, -0.1, 0.33333333333333
84273, 0.52173913043478, -0.1, 0.38888888888889
84274, 0.52173913043478, -0.1, 0.44444444444444
84275, 0.47826086956522, -0.1, 0.055555555555556
84276, 0.47826086956522, -0.1, 0.11111111111111
84277, 0.47826086956522, -0.1, 0.16666666666667
84278, 0.47826086956522, -0.1, 0.22222222222222
84279, 0.47826086956522, -0.1, 0.27777777777778
84280, 0.47826086956522, -0.1, 0.33333333333333
84281, 0.47826086956522, -0.1, 0.38888888888889
84282, 0.47826086956522, -0.1, 0.44444444444444
84283, 0.43478260869565, -0.1, 0.055555555555556
84284, 0.43478260869565, -0.1, 0.11111111111111
84285, 0.43478260869565, -0.1, 0.16666666666667
84286, 0.43478260869565, -0.1, 0.22222222222222
84287, 0.43478260869565, -0.1, 0.27777777777778
84288, 0.43478260869565, -0.1, 0.33333333333333
84289, 0.43478260869565, -0.1, 0.38888888888889
84290, 0.43478260869565, -0.1, 0.44444444444444
84291, 0.39130434782609, -0.1, 0.055555555555556
84292, 0.39130434782609, -0.1, 0.11111111111111
84293, 0.39130434782609, -0.1, 0.16666666666667
84294, 0.39130434782609, -0.1, 0.22222222222222
84295, 0.39130434782609, -0.1, 0.27777777777778
84296, 0.39130434782609, -0.1, 0.33333333333333
84297, 0.39130434782609, -0.1, 0.38888888888889
84298, 0.39130434782609, -0.1, 0.44444444444444
84299, 0.34782608695652, -0.1, 0.055555555555556
84300, 0.34782608695652, -0.1, 0.11111111111111
84301, 0.34782608695652, -0.1, 0.16666666666667
84302, 0.34782608695652, -0.1, 0.22222222222222
84303, 0.34782608695652, -0.1, 0.27777777777778
84304, 0.34782608695652, -0.1, 0.33333333333333
84305, 0.34782608695652, -0.1, 0.38888888888889
84306, 0.34782608695652, -0.1, 0.44444444444444
84307, 0.30434782608696, -0.1, 0.055555555555556
84308, 0.30434782608696, -0.1, 0.11111111111111
84309, 0.30434782608696, -0.1, 0.16666666666667
84310, 0.30434782608696, -0.1, 0.22222222222222
84311, 0.30434782608696, -0.1, 0.27777777777778
84312, 0.30434782608696, -0.1, 0.33333333333333
84313, 0.30434782608696, -0.1, 0.38888888888889
84314, 0.30434782608696, -0.1, 0.44444444444444
84315, 0.26086956521739, -0.1, 0.055555555555556
84316, 0.26086956521739, -0.1, 0.11111111111111
84317, 0.26086956521739, -0.1, 0.16666666666667
84318, 0.26086956521739, -0.1, 0.22222222222222
84319, 0.26086956521739, -0.1, 0.27777777777778
84320, 0.26086956521739, -0.1, 0.33333333333333
84321, 0.26086956521739, -0.1, 0.38888888888889
84322, 0.26086956521739, -0.1, 0.44444444444444
84323, 0.21739130434783, -0.1, 0.055555555555556
84324, 0.21739130434783, -0.1, 0.11111111111111
84325, 0.21739130434783, -0.1, 0.16666666666667
84326, 0.21739130434783, -0.1, 0.22222222222222
84327, 0.21739130434783, -0.1, 0.27777777777778
84328, 0.21739130434783, -0.1, 0.33333333333333
84329, 0.21739130434783, -0.1, 0.38888888888889
84330, 0.21739130434783, -0.1, 0.44444444444444
84331, 0.17391304347826, -0.1, 0.055555555555556
84332, 0.17391304347826, -0.1, 0.11111111111111
84333, 0.17391304347826, -0.1, 0.16666666666667
84334, 0.17391304347826, -0.1, 0.22222222222222
84335, 0.17391304347826, -0.1, 0.27777777777778
84336, 0.17391304347826, -0.1, 0.33333333333333
84337, 0.17391304347826, -0.1, 0.38888888888889
84338, 0.17391304347826, -0.1, 0.44444444444444
84339, 0.1304347826087, -0.1, 0.055555555555556
84340, 0.1304347826087, -0.1, 0.11111111111111
84341, 0.1304347826087, -0.1, 0.16666666666667
84342, 0.1304347826087, -0.1, 0.22222222222222
84343, 0.1304347826087, -0.1, 0.27777777777778
84344, 0.1304347826087, -0.1, 0.33333333333333
84345, 0.1304347826087, -0.1, 0.38888888888889
84346, 0.1304347826087, -0.1, 0.44444444444444
84347, 0.08695652173913, -0.1, 0.055555555555556
84348, 0.08695652173913, -0.1, 0.11111111111111
84349, 0.08695652173913, -0.1, 0.16666666666667
84350, 0.08695652173913, -0.1, 0.22222222222222
84351, 0.08695652173913, -0.1, 0.27777777777778
84352, 0.08695652173913, -0.1, 0.33333333333333
84353, 0.08695652173913, -0.1, 0.38888888888889
84354, 0.08695652173913, -0.1, 0.44444444444444
84355, 0.043478260869565, -0.1, 0.055555555555556
84356, 0.043478260869565, -0.1, 0.11111111111111
84357, 0.043478260869565, -0.1, 0.16666666666667
84358, 0.043478260869565, -0.1, 0.22222222222222
84359, 0.043478260869565, -0.1, 0.27777777777778
84360, 0.043478260869565, -0.1, 0.33333333333333
84361, 0.043478260869565, -0.1, 0.38888888888889
84362, 0.043478260869565, -0.1, 0.44444444444444
84363, 0.95652173913043, -0.15, 0.055555555555556
84364, 0.95652173913044, -0.15, 0.11111111111111
84365, 0.95652173913044, -0.15, 0.16666666666667
84366, 0.95652173913044, -0.15, 0.22222222222222
84367, 0.95652173913044, -0.15, 0.27777777777778
84368, 0.95652173913043, -0.15, 0.33333333333333
84369, 0.95652173913044, -0.15, 0.38888888888889
84370, 0.95652173913044, -0.15, 0.44444444444444
84371, 0.91304347826087, -0.15, 0.055555555555556
84372, 0.91304347826087, -0.15, 0.11111111111111
84373, 0.91304347826087, -0.15, 0.16666666666667
84374, 0.91304347826087, -0.15, 0.22222222222222
84375, 0.91304347826087, -0.15, 0.27777777777778
84376, 0.91304347826087, -0.15, 0.33333333333333
84377, 0.91304347826087, -0.15, 0.38888888888889
84378, 0.91304347826087, -0.15, 0.44444444444444
84379, 0.8695652173913, -0.15, 0.055555555555556
84380, 0.8695652173913, -0.15, 0.11111111111111
84381, 0.8695652173913, -0.15, 0.16666666666667
84382, 0.8695652173913, -0.15, 0.22222222222222
84383, 0.8695652173913, -0.15, 0.27777777777778
84384, 0.8695652173913, -0.15, 0.33333333333333
84385, 0.8695652173913, -0.15, 0.38888888888889
84386, 0.8695652173913, -0.15, 0.44444444444444
84387, 0.82608695652174, -0.15, 0.055555555555556
84388, 0.82608695652174, -0.15, 0.11111111111111
84389, 0.82608695652174, -0.15, 0.16666666666667
84390, 0.82608695652174, -0.15, 0.22222222222222
84391, 0.82608695652174, -0.15, 0.27777777777778
84392, 0.82608695652174, -0.15, 0.33333333333333
84393, 0.82608695652174, -0.15, 0.38888888888889
84394, 0.82608695652174, -0.15, 0.44444444444444
84395, 0.78260869565217, -0.15, 0.055555555555556
84396, 0.78260869565217, -0.15, 0.11111111111111
84397, 0.78260869565217, -0.15, 0.16666666666667
84398, 0.78260869565217, -0.15, 0.22222222222222
84399, 0.78260869565217, -0.15, 0.27777777777778
84400, 0.78260869565217, -0.15, 0.33333333333333
84401, 0.78260869565217, -0.15, 0.38888888888889
84402, 0.78260869565217, -0.15, 0.44444444444444
84403, 0.73913043478261, -0.15, 0.055555555555556
84404, 0.73913043478261, -0.15, 0.11111111111111
84405, 0.73913043478261, -0.15, 0.16666666666667
84406, 0.73913043478261, -0.15, 0.22222222222222
84407, 0.73913043478261, -0.15, 0.27777777777778
84408, 0.73913043478261, -0.15, 0.33333333333333
84409, 0.73913043478261, -0.15, 0.38888888888889
84410, 0.73913043478261, -0.15, 0.44444444444444
84411, 0.69565217391304, -0.15, 0.055555555555556
84412, 0.69565217391304, -0.15, 0.11111111111111
84413, 0.69565217391304, -0.15, 0.16666666666667
84414, 0.69565217391304, -0.15, 0.22222222222222
84415, 0.69565217391304, -0.15, 0.27777777777778
84416, 0.69565217391304, -0.15, 0.33333333333333
84417, 0.69565217391304, -0.15, 0.38888888888889
84418, 0.69565217391304, -0.15, 0.44444444444444
84419, 0.65217391304348, -0.15, 0.055555555555556
84420, 0.65217391304348, -0.15, 0.11111111111111
84421, 0.65217391304348, -0.15, 0.16666666666667
84422, 0.65217391304348, -0.15, 0.22222222222222
84423, 0.65217391304348, -0.15, 0.27777777777778
84424, 0.65217391304348, -0.15, 0.33333333333333
84425, 0.65217391304348, -0.15, 0.38888888888889
84426, 0.65217391304348, -0.15, 0.44444444444444
84427, 0.60869565217391, -0.15, 0.055555555555556
84428, 0.60869565217391, -0.15, 0.11111111111111
84429, 0.60869565217391, -0.15, 0.16666666666667
84430, 0.60869565217391, -0.15, 0.22222222222222
84431, 0.60869565217391, -0.15, 0.27777777777778
84432, 0.60869565217391, -0.15, 0.33333333333333
84433, 0.60869565217391, -0.15, 0.38888888888889
84434, 0.60869565217391, -0.15, 0.44444444444444
84435, 0.56521739130435, -0.15, 0.055555555555556
84436, 0.56521739130435, -0.15, 0.11111111111111
84437, 0.56521739130435, -0.15, 0.16666666666667
84438, 0.56521739130435, -0.15, 0.22222222222222
84439, 0.56521739130435, -0.15, 0.27777777777778
84440, 0.56521739130435, -0.15, 0.33333333333333
84441, 0.56521739130435, -0.15, 0.38888888888889
84442, 0.56521739130435, -0.15, 0.44444444444444
84443, 0.52173913043478, -0.15, 0.055555555555556
84444, 0.52173913043478, -0.15, 0.11111111111111
84445, 0.52173913043478, -0.15, 0.16666666666667
84446, 0.52173913043478, -0.15, 0.22222222222222
84447, 0.52173913043478, -0.15, 0.27777777777778
84448, 0.52173913043478, -0.15, 0.33333333333333
84449, 0.52173913043478, -0.15, 0.38888888888889
84450, 0.52173913043478, -0.15, 0.44444444444444
84451, 0.47826086956522, -0.15, 0.055555555555556
84452, 0.47826086956522, -0.15, 0.11111111111111
84453, 0.47826086956522, -0.15, 0.16666666666667
84454, 0.47826086956522, -0.15, 0.22222222222222
84455, 0.47826086956522, -0.15, 0.27777777777778
84456, 0.47826086956522, -0.15, 0.33333333333333
84457, 0.47826086956522, -0.15, 0.38888888888889
84458, 0.47826086956522, -0.15, 0.44444444444444
84459, 0.43478260869565, -0.15, 0.055555555555556
84460, 0.43478260869565, -0.15, 0.11111111111111
84461, 0.43478260869565, -0.15, 0.16666666666667
84462, 0.43478260869565, -0.15, 0.22222222222222
84463, 0.43478260869565, -0.15, 0.27777777777778
84464, 0.43478260869565, -0.15, 0.33333333333333
84465, 0.43478260869565, -0.15, 0.38888888888889
84466, 0.43478260869565, -0.15, 0.44444444444444
84467, 0.39130434782609, -0.15, 0.055555555555556
84468, 0.39130434782609, -0.15, 0.11111111111111
84469, 0.39130434782609, -0.15, 0.16666666666667
84470, 0.39130434782609, -0.15, 0.22222222222222
84471, 0.39130434782609, -0.15, 0.27777777777778
84472, 0.39130434782609, -0.15, 0.33333333333333
84473, 0.39130434782609, -0.15, 0.38888888888889
84474, 0.39130434782609, -0.15, 0.44444444444444
84475, 0.34782608695652, -0.15, 0.055555555555556
84476, 0.34782608695652, -0.15, 0.11111111111111
84477, 0.34782608695652, -0.15, 0.16666666666667
84478, 0.34782608695652, -0.15, 0.22222222222222
84479, 0.34782608695652, -0.15, 0.27777777777778
84480, 0.34782608695652, -0.15, 0.33333333333333
84481, 0.34782608695652, -0.15, 0.38888888888889
84482, 0.34782608695652, -0.15, 0.44444444444444
84483, 0.30434782608696, -0.15, 0.055555555555556
84484, 0.30434782608696, -0.15, 0.11111111111111
84485, 0.30434782608696, -0.15, 0.16666666666667
84486, 0.30434782608696, -0.15, 0.22222222222222
84487, 0.30434782608696, -0.15, 0.27777777777778
84488, 0.30434782608696, -0.15, 0.33333333333333
84489, 0.30434782608696, -0.15, 0.38888888888889
84490, 0.30434782608696, -0.15, 0.44444444444444
84491, 0.26086956521739, -0.15, 0.055555555555556
84492, 0.26086956521739, -0.15, 0.11111111111111
84493, 0.26086956521739, -0.15, 0.16666666666667
84494, 0.26086956521739, -0.15, 0.22222222222222
84495, 0.26086956521739, -0.15, 0.27777777777778
84496, 0.26086956521739, -0.15, 0.33333333333333
84497, 0.26086956521739, -0.15, 0.38888888888889
84498, 0.26086956521739, -0.15, 0.44444444444444
84499, 0.21739130434783, -0.15, 0.055555555555556
84500, 0.21739130434783, -0.15, 0.11111111111111
84501, 0.21739130434783, -0.15, 0.16666666666667
84502, 0.21739130434783, -0.15, 0.22222222222222
84503, 0.21739130434783, -0.15, 0.27777777777778
84504, 0.21739130434783, -0.15, 0.33333333333333
84505, 0.21739130434783, -0.15, 0.38888888888889
84506, 0.21739130434783, -0.15, 0.44444444444444
84507, 0.17391304347826, -0.15, 0.055555555555556
84508, 0.17391304347826, -0.15, 0.11111111111111
84509, 0.17391304347826, -0.15, 0.16666666666667
84510, 0.17391304347826, -0.15, 0.22222222222222
84511, 0.17391304347826, -0.15, 0.27777777777778
84512, 0.17391304347826, -0.15, 0.33333333333333
84513, 0.17391304347826, -0.15, 0.38888888888889
84514, 0.17391304347826, -0.15, 0.44444444444444
84515, 0.1304347826087, -0.15, 0.055555555555556
84516, 0.1304347826087, -0.15, 0.11111111111111
84517, 0.1304347826087, -0.15, 0.16666666666667
84518, 0.1304347826087, -0.15, 0.22222222222222
84519, 0.1304347826087, -0.15, 0.27777777777778
84520, 0.1304347826087, -0.15, 0.33333333333333
84521, 0.1304347826087, -0.15, 0.38888888888889
84522, 0.1304347826087, -0.15, 0.44444444444444
84523, 0.08695652173913, -0.15, 0.055555555555556
84524, 0.08695652173913, -0.15, 0.11111111111111
84525, 0.08695652173913, -0.15, 0.16666666666667
84526, 0.08695652173913, -0.15, 0.22222222222222
84527, 0.08695652173913, -0.15, 0.27777777777778
84528, 0.08695652173913, -0.15, 0.33333333333333
84529, 0.08695652173913, -0.15, 0.38888888888889
84530, 0.08695652173913, -0.15, 0.44444444444444
84531, 0.043478260869565, -0.15, 0.055555555555556
84532, 0.043478260869565, -0.15, 0.11111111111111
84533, 0.043478260869565, -0.15, 0.16666666666667
84534, 0.043478260869565, -0.15, 0.22222222222222
84535, 0.043478260869565, -0.15, 0.27777777777778
84536, 0.043478260869565, -0.15, 0.33333333333333
84537, 0.043478260869565, -0.15, 0.38888888888889
84538, 0.043478260869565, -0.15, 0.44444444444444
84539, 0.95652173913043, -0.2, 0.055555555555556
84540, 0.95652173913044, -0.2, 0.11111111111111
84541, 0.95652173913043, -0.2, 0.16666666666667
84542, 0.95652173913044, -0.2, 0.22222222222222
84543, 0.95652173913044, -0.2, 0.27777777777778
84544, 0.95652173913043, -0.2, 0.33333333333333
84545, 0.95652173913044, -0.2, 0.38888888888889
84546, 0.95652173913044, -0.2, 0.44444444444444
84547, 0.91304347826087, -0.2, 0.055555555555556
84548, 0.91304347826087, -0.2, 0.11111111111111
84549, 0.91304347826087, -0.2, 0.16666666666667
84550, 0.91304347826087, -0.2, 0.22222222222222
84551, 0.91304347826087, -0.2, 0.27777777777778
84552, 0.91304347826087, -0.2, 0.33333333333333
84553, 0.91304347826087, -0.2, 0.38888888888889
84554, 0.91304347826087, -0.2, 0.44444444444444
84555, 0.8695652173913, -0.2, 0.055555555555556
84556, 0.8695652173913, -0.2, 0.11111111111111
84557, 0.8695652173913, -0.2, 0.16666666666667
84558, 0.8695652173913, -0.2, 0.22222222222222
84559, 0.8695652173913, -0.2, 0.27777777777778
84560, 0.8695652173913, -0.2, 0.33333333333333
84561, 0.8695652173913, -0.2, 0.38888888888889
84562, 0.8695652173913, -0.2, 0.44444444444444
84563, 0.82608695652174, -0.2, 0.055555555555556
84564, 0.82608695652174, -0.2, 0.11111111111111
84565, 0.82608695652174, -0.2, 0.16666666666667
84566, 0.82608695652174, -0.2, 0.22222222222222
84567, 0.82608695652174, -0.2, 0.27777777777778
84568, 0.82608695652174, -0.2, 0.33333333333333
84569, 0.82608695652174, -0.2, 0.38888888888889
84570, 0.82608695652174, -0.2, 0.44444444444444
84571, 0.78260869565217, -0.2, 0.055555555555556
84572, 0.78260869565217, -0.2, 0.11111111111111
84573, 0.78260869565217, -0.2, 0.16666666666667
84574, 0.78260869565217, -0.2, 0.22222222222222
84575, 0.78260869565217, -0.2, 0.27777777777778
84576, 0.78260869565217, -0.2, 0.33333333333333
84577, 0.78260869565217, -0.2, 0.38888888888889
84578, 0.78260869565217, -0.2, 0.44444444444444
84579, 0.73913043478261, -0.2, 0.055555555555556
84580, 0.73913043478261, -0.2, 0.11111111111111
84581, 0.73913043478261, -0.2, 0.16666666666667
84582, 0.73913043478261, -0.2, 0.22222222222222
84583, 0.73913043478261, -0.2, 0.27777777777778
84584, 0.73913043478261, -0.2, 0.33333333333333
84585, 0.73913043478261, -0.2, 0.38888888888889
84586, 0.73913043478261, -0.2, 0.44444444444444
84587, 0.69565217391304, -0.2, 0.055555555555556
84588, 0.69565217391304, -0.2, 0.11111111111111
84589, 0.69565217391304, -0.2, 0.16666666666667
84590, 0.69565217391304, -0.2, 0.22222222222222
84591, 0.69565217391304, -0.2, 0.27777777777778
84592, 0.69565217391304, -0.2, 0.33333333333333
84593, 0.69565217391304, -0.2, 0.38888888888889
84594, 0.69565217391304, -0.2, 0.44444444444444
84595, 0.65217391304348, -0.2, 0.055555555555556
84596, 0.65217391304348, -0.2, 0.11111111111111
84597, 0.65217391304348, -0.2, 0.16666666666667
84598, 0.65217391304348, -0.2, 0.22222222222222
84599, 0.65217391304348, -0.2, 0.27777777777778
84600, 0.65217391304348, -0.2, 0.33333333333333
84601, 0.65217391304348, -0.2, 0.38888888888889
84602, 0.65217391304348, -0.2, 0.44444444444444
84603, 0.60869565217391, -0.2, 0.055555555555556
84604, 0.60869565217391, -0.2, 0.11111111111111
84605, 0.60869565217391, -0.2, 0.16666666666667
84606, 0.60869565217391, -0.2, 0.22222222222222
84607, 0.60869565217391, -0.2, 0.27777777777778
84608, 0.60869565217391, -0.2, 0.33333333333333
84609, 0.60869565217391, -0.2, 0.38888888888889
84610, 0.60869565217391, -0.2, 0.44444444444444
84611, 0.56521739130435, -0.2, 0.055555555555556
84612, 0.56521739130435, -0.2, 0.11111111111111
84613, 0.56521739130435, -0.2, 0.16666666666667
84614, 0.56521739130435, -0.2, 0.22222222222222
84615, 0.56521739130435, -0.2, 0.27777777777778
84616, 0.56521739130435, -0.2, 0.33333333333333
84617, 0.56521739130435, -0.2, 0.38888888888889
84618, 0.56521739130435, -0.2, 0.44444444444444
84619, 0.52173913043478, -0.2, 0.055555555555556
84620, 0.52173913043478, -0.2, 0.11111111111111
84621, 0.52173913043478, -0.2, 0.16666666666667
84622, 0.52173913043478, -0.2, 0.22222222222222
84623, 0.52173913043478, -0.2, 0.27777777777778
84624, 0.52173913043478, -0.2, 0.33333333333333
84625, 0.52173913043478, -0.2, 0.38888888888889
84626, 0.52173913043478, -0.2, 0.44444444444444
84627, 0.47826086956522, -0.2, 0.055555555555556
84628, 0.47826086956522, -0.2, 0.11111111111111
84629, 0.47826086956522, -0.2, 0.16666666666667
84630, 0.47826086956522, -0.2, 0.22222222222222
84631, 0.47826086956522, -0.2, 0.27777777777778
84632, 0.47826086956522, -0.2, 0.33333333333333
84633, 0.47826086956522, -0.2, 0.38888888888889
84634, 0.47826086956522, -0.2, 0.44444444444444
84635, 0.43478260869565, -0.2, 0.055555555555556
84636, 0.43478260869565, -0.2, 0.11111111111111
84637, 0.43478260869565, -0.2, 0.16666666666667
84638, 0.43478260869565, -0.2, 0.22222222222222
84639, 0.43478260869565, -0.2, 0.27777777777778
84640, 0.43478260869565, -0.2, 0.33333333333333
84641, 0.43478260869565, -0.2, 0.38888888888889
84642, 0.43478260869565, -0.2, 0.44444444444444
84643, 0.39130434782609, -0.2, 0.055555555555556
84644, 0.39130434782609, -0.2, 0.11111111111111
84645, 0.39130434782609, -0.2, 0.16666666666667
84646, 0.39130434782609, -0.2, 0.22222222222222
84647, 0.39130434782609, -0.2, 0.27777777777778
84648, 0.39130434782609, -0.2, 0.33333333333333
84649, 0.39130434782609, -0.2, 0.38888888888889
84650, 0.39130434782609, -0.2, 0.44444444444444
84651, 0.34782608695652, -0.2, 0.055555555555556
84652, 0.34782608695652, -0.2, 0.11111111111111
84653, 0.34782608695652, -0.2, 0.16666666666667
84654, 0.34782608695652, -0.2, 0.22222222222222
84655, 0.34782608695652, -0.2, 0.27777777777778
84656, 0.34782608695652, -0.2, 0.33333333333333
84657, 0.34782608695652, -0.2, 0.38888888888889
84658, 0.34782608695652, -0.2, 0.44444444444444
84659, 0.30434782608696, -0.2, 0.055555555555556
84660, 0.30434782608696, -0.2, 0.11111111111111
84661, 0.30434782608696, -0.2, 0.16666666666667
84662, 0.30434782608696, -0.2, 0.22222222222222
84663, 0.30434782608696, -0.2, 0.27777777777778
84664, 0.30434782608696, -0.2, 0.33333333333333
84665, 0.30434782608696, -0.2, 0.38888888888889
84666, 0.30434782608696, -0.2, 0.44444444444444
84667, 0.26086956521739, -0.2, 0.055555555555556
84668, 0.26086956521739, -0.2, 0.11111111111111
84669, 0.26086956521739, -0.2, 0.16666666666667
84670, 0.26086956521739, -0.2, 0.22222222222222
84671, 0.26086956521739, -0.2, 0.27777777777778
84672, 0.26086956521739, -0.2, 0.33333333333333
84673, 0.26086956521739, -0.2, 0.38888888888889
84674, 0.26086956521739, -0.2, 0.44444444444444
84675, 0.21739130434783, -0.2, 0.055555555555556
84676, 0.21739130434783, -0.2, 0.11111111111111
84677, 0.21739130434783, -0.2, 0.16666666666667
84678, 0.21739130434783, -0.2, 0.22222222222222
84679, 0.21739130434783, -0.2, 0.27777777777778
84680, 0.21739130434783, -0.2, 0.33333333333333
84681, 0.21739130434783, -0.2, 0.38888888888889
84682, 0.21739130434783, -0.2, 0.44444444444444
84683, 0.17391304347826, -0.2, 0.055555555555556
84684, 0.17391304347826, -0.2, 0.11111111111111
84685, 0.17391304347826, -0.2, 0.16666666666667
84686, 0.17391304347826, -0.2, 0.22222222222222
84687, 0.17391304347826, -0.2, 0.27777777777778
84688, 0.17391304347826, -0.2, 0.33333333333333
84689, 0.17391304347826, -0.2, 0.38888888888889
84690, 0.17391304347826, -0.2, 0.44444444444444
84691, 0.1304347826087, -0.2, 0.055555555555556
84692, 0.1304347826087, -0.2, 0.11111111111111
84693, 0.1304347826087, -0.2, 0.16666666666667
84694, 0.1304347826087, -0.2, 0.22222222222222
84695, 0.1304347826087, -0.2, 0.27777777777778
84696, 0.1304347826087, -0.2, 0.33333333333333
84697, 0.1304347826087, -0.2, 0.38888888888889
84698, 0.1304347826087, -0.2, 0.44444444444444
84699, 0.08695652173913, -0.2, 0.055555555555556
84700, 0.08695652173913, -0.2, 0.11111111111111
84701, 0.08695652173913, -0.2, 0.16666666666667
84702, 0.08695652173913, -0.2, 0.22222222222222
84703, 0.08695652173913, -0.2, 0.27777777777778
84704, 0.08695652173913, -0.2, 0.33333333333333
84705, 0.08695652173913, -0.2, 0.38888888888889
84706, 0.08695652173913, -0.2, 0.44444444444444
84707, 0.043478260869565, -0.2, 0.055555555555556
84708, 0.043478260869565, -0.2, 0.11111111111111
84709, 0.043478260869565, -0.2, 0.16666666666667
84710, 0.043478260869565, -0.2, 0.22222222222222
84711, 0.043478260869565, -0.2, 0.27777777777778
84712, 0.043478260869565, -0.2, 0.33333333333333
84713, 0.043478260869565, -0.2, 0.38888888888889
84714, 0.043478260869565, -0.2, 0.44444444444444
84715, 0.95652173913043, -0.1, 0.027777777777778
84716, 0.97826086956522, -0.1, 0.055555555555556
84717, 0.95652173913043, -0.075, 0.055555555555556
84718, 0.95652173913043, -0.1, 0.083333333333333
84719, 0.97826086956522, -0.1, 0.11111111111111
84720, 0.95652173913043, -0.075, 0.11111111111111
84721, 0.95652173913043, -0.1, 0.13888888888889
84722, 0.97826086956522, -0.1, 0.16666666666667
84723, 0.95652173913043, -0.075, 0.16666666666667
84724, 0.95652173913043, -0.1, 0.19444444444444
84725, 0.97826086956522, -0.1, 0.22222222222222
84726, 0.95652173913043, -0.075, 0.22222222222222
84727, 0.95652173913043, -0.1, 0.25
84728, 0.97826086956522, -0.1, 0.27777777777778
84729, 0.95652173913043, -0.075, 0.27777777777778
84730, 0.95652173913043, -0.1, 0.30555555555556
84731, 0.97826086956522, -0.1, 0.33333333333333
84732, 0.95652173913043, -0.075, 0.33333333333333
84733, 0.95652173913043, -0.1, 0.36111111111111
84734, 0.97826086956522, -0.1, 0.38888888888889
84735, 0.95652173913043, -0.075, 0.38888888888889
84736, 0.95652173913043, -0.1, 0.41666666666667
84737, 0.97826086956522, -0.1, 0.44444444444444
84738, 0.95652173913043, -0.075, 0.44444444444444
84739, 0.95652173913043, -0.1, 0.47222222222222
84740, 0.91304347826087, -0.1, 0.027777777777778
84741, 0.93478260869565, -0.1, 0.055555555555556
84742, 0.91304347826087, -0.075, 0.055555555555556
84743, 0.91304347826087, -0.1, 0.083333333333333
84744, 0.93478260869565, -0.1, 0.11111111111111
84745, 0.91304347826087, -0.075, 0.11111111111111
84746, 0.91304347826087, -0.1, 0.13888888888889
84747, 0.93478260869565, -0.1, 0.16666666666667
84748, 0.91304347826087, -0.075, 0.16666666666667
84749, 0.91304347826087, -0.1, 0.19444444444444
84750, 0.93478260869565, -0.1, 0.22222222222222
84751, 0.91304347826087, -0.075, 0.22222222222222
84752, 0.91304347826087, -0.1, 0.25
84753, 0.93478260869565, -0.1, 0.27777777777778
84754, 0.91304347826087, -0.075, 0.27777777777778
84755, 0.91304347826087, -0.1, 0.30555555555556
84756, 0.93478260869565, -0.1, 0.33333333333333
84757, 0.91304347826087, -0.075, 0.33333333333333
84758, 0.91304347826087, -0.1, 0.36111111111111
84759, 0.93478260869565, -0.1, 0.38888888888889
84760, 0.91304347826087, -0.075, 0.38888888888889
84761, 0.91304347826087, -0.1, 0.41666666666667
84762, 0.93478260869565, -0.1, 0.44444444444444
84763, 0.91304347826087, -0.075, 0.44444444444444
84764, 0.91304347826087, -0.1, 0.47222222222222
84765, 0.8695652173913, -0.1, 0.027777777777778
84766, 0.89130434782609, -0.1, 0.055555555555556
84767, 0.8695652173913, -0.075, 0.055555555555556
84768, 0.8695652173913, -0.1, 0.083333333333333
84769, 0.89130434782609, -0.1, 0.11111111111111
84770, 0.8695652173913, -0.075, 0.11111111111111
84771, 0.8695652173913, -0.1, 0.13888888888889
84772, 0.89130434782609, -0.1, 0.16666666666667
84773, 0.8695652173913, -0.075, 0.16666666666667
84774, 0.8695652173913, -0.1, 0.19444444444444
84775, 0.89130434782609, -0.1, 0.22222222222222
84776, 0.8695652173913, -0.075, 0.22222222222222
84777, 0.8695652173913, -0.1, 0.25
84778, 0.89130434782609, -0.1, 0.27777777777778
84779, 0.8695652173913, -0.075, 0.27777777777778
84780, 0.8695652173913, -0.1, 0.30555555555556
84781, 0.89130434782609, -0.1, 0.33333333333333
84782, 0.8695652173913, -0.075, 0.33333333333333
84783, 0.8695652173913, -0.1, 0.36111111111111
84784, 0.89130434782609, -0.1, 0.38888888888889
84785, 0.8695652173913, -0.075, 0.38888888888889
84786, 0.8695652173913, -0.1, 0.41666666666667
84787, 0.89130434782609, -0.1, 0.44444444444444
84788, 0.8695652173913, -0.075, 0.44444444444444
84789, 0.8695652173913, -0.1, 0.47222222222222
84790, 0.82608695652174, -0.1, 0.027777777777778
84791, 0.84782608695652, -0.1, 0.055555555555556
84792, 0.82608695652174, -0.075, 0.055555555555556
84793, 0.82608695652174, -0.1, 0.083333333333333
84794, 0.84782608695652, -0.1, 0.11111111111111
84795, 0.82608695652174, -0.075, 0.11111111111111
84796, 0.82608695652174, -0.1, 0.13888888888889
84797, 0.84782608695652, -0.1, 0.16666666666667
84798, 0.82608695652174, -0.075, 0.16666666666667
84799, 0.82608695652174, -0.1, 0.19444444444444
84800, 0.84782608695652, -0.1, 0.22222222222222
84801, 0.82608695652174, -0.075, 0.22222222222222
84802, 0.82608695652174, -0.1, 0.25
84803, 0.84782608695652, -0.1, 0.27777777777778
84804, 0.82608695652174, -0.075, 0.27777777777778
84805, 0.82608695652174, -0.1, 0.30555555555556
84806, 0.84782608695652, -0.1, 0.33333333333333
84807, 0.82608695652174, -0.075, 0.33333333333333
84808, 0.82608695652174, -0.1, 0.36111111111111
84809, 0.84782608695652, -0.1, 0.38888888888889
84810, 0.82608695652174, -0.075, 0.38888888888889
84811, 0.82608695652174, -0.1, 0.41666666666667
84812, 0.84782608695652, -0.1, 0.44444444444444
84813, 0.82608695652174, -0.075, 0.44444444444444
84814, 0.82608695652174, -0.1, 0.47222222222222
84815, 0.78260869565217, -0.1, 0.027777777777778
84816, 0.80434782608696, -0.1, 0.055555555555556
84817, 0.78260869565217, -0.075, 0.055555555555556
84818, 0.78260869565217, -0.1, 0.083333333333333
84819, 0.80434782608696, -0.1, 0.11111111111111
84820, 0.78260869565217, -0.075, 0.11111111111111
84821, 0.78260869565217, -0.1, 0.13888888888889
84822, 0.80434782608696, -0.1, 0.16666666666667
84823, 0.78260869565217, -0.075, 0.16666666666667
84824, 0.78260869565217, -0.1, 0.19444444444444
84825, 0.80434782608696, -0.1, 0.22222222222222
84826, 0.78260869565217, -0.075, 0.22222222222222
84827, 0.78260869565217, -0.1, 0.25
84828, 0.80434782608696, -0.1, 0.27777777777778
84829, 0.78260869565217, -0.075, 0.27777777777778
84830, 0.78260869565217, -0.1, 0.30555555555556
84831, 0.80434782608696, -0.1, 0.33333333333333
84832, 0.78260869565217, -0.075, 0.33333333333333
84833, 0.78260869565217, -0.1, 0.36111111111111
84834, 0.80434782608696, -0.1, 0.38888888888889
84835, 0.78260869565217, -0.075, 0.38888888888889
84836, 0.78260869565217, -0.1, 0.41666666666667
84837, 0.80434782608696, -0.1, 0.44444444444444
84838, 0.78260869565217, -0.075, 0.44444444444444
84839, 0.78260869565217, -0.1, 0.47222222222222
84840, 0.73913043478261, -0.1, 0.027777777777778
84841, 0.76086956521739, -0.1, 0.055555555555556
84842, 0.73913043478261, -0.075, 0.055555555555556
84843, 0.73913043478261, -0.1, 0.083333333333333
84844, 0.76086956521739, -0.1, 0.11111111111111
84845, 0.73913043478261, -0.075, 0.11111111111111
84846, 0.73913043478261, -0.1, 0.13888888888889
84847, 0.76086956521739, -0.1, 0.16666666666667
84848, 0.73913043478261, -0.075, 0.16666666666667
84849, 0.73913043478261, -0.1, 0.19444444444444
84850, 0.76086956521739, -0.1, 0.22222222222222
84851, 0.73913043478261, -0.075, 0.22222222222222
84852, 0.73913043478261, -0.1, 0.25
84853, 0.76086956521739, -0.1, 0.27777777777778
84854, 0.73913043478261, -0.075, 0.27777777777778
84855, 0.73913043478261, -0.1, 0.30555555555556
84856, 0.76086956521739, -0.1, 0.33333333333333
84857, 0.73913043478261, -0.075, 0.33333333333333
84858, 0.73913043478261, -0.1, 0.36111111111111
84859, 0.76086956521739, -0.1, 0.38888888888889
84860, 0.73913043478261, -0.075, 0.38888888888889
84861, 0.73913043478261, -0.1, 0.41666666666667
84862, 0.76086956521739, -0.1, 0.44444444444444
84863, 0.73913043478261, -0.075, 0.44444444444444
84864, 0.73913043478261, -0.1, 0.47222222222222
84865, 0.69565217391304, -0.1, 0.027777777777778
84866, 0.71739130434783, -0.1, 0.055555555555556
84867, 0.69565217391304, -0.075, 0.055555555555556
84868, 0.69565217391304, -0.1, 0.083333333333333
84869, 0.71739130434783, -0.1, 0.11111111111111
84870, 0.69565217391304, -0.075, 0.11111111111111
84871, 0.69565217391304, -0.1, 0.13888888888889
84872, 0.71739130434783, -0.1, 0.16666666666667
84873, 0.69565217391304, -0.075, 0.16666666666667
84874, 0.69565217391304, -0.1, 0.19444444444444
84875, 0.71739130434783, -0.1, 0.22222222222222
84876, 0.69565217391304, -0.075, 0.22222222222222
84877, 0.69565217391304, -0.1, 0.25
84878, 0.71739130434783, -0.1, 0.27777777777778
84879, 0.69565217391304, -0.075, 0.27777777777778
84880, 0.69565217391304, -0.1, 0.30555555555556
84881, 0.71739130434783, -0.1, 0.33333333333333
84882, 0.69565217391304, -0.075, 0.33333333333333
84883, 0.69565217391304, -0.1, 0.36111111111111
84884, 0.71739130434783, -0.1, 0.38888888888889
84885, 0.69565217391304, -0.075, 0.38888888888889
84886, 0.69565217391304, -0.1, 0.41666666666667
84887, 0.71739130434783, -0.1, 0.44444444444444
84888, 0.69565217391304, -0.075, 0.44444444444444
84889, 0.69565217391304, -0.1, 0.47222222222222
84890, 0.65217391304348, -0.1, 0.027777777777778
84891, 0.67391304347826, -0.1, 0.055555555555556
84892, 0.65217391304348, -0.075, 0.055555555555556
84893, 0.65217391304348, -0.1, 0.083333333333333
84894, 0.67391304347826, -0.1, 0.11111111111111
84895, 0.65217391304348, -0.075, 0.11111111111111
84896, 0.65217391304348, -0.1, 0.13888888888889
84897, 0.67391304347826, -0.1, 0.16666666666667
84898, 0.65217391304348, -0.075, 0.16666666666667
84899, 0.65217391304348, -0.1, 0.19444444444444
84900, 0.67391304347826, -0.1, 0.22222222222222
84901, 0.65217391304348, -0.075, 0.22222222222222
84902, 0.65217391304348, -0.1, 0.25
84903, 0.67391304347826, -0.1, 0.27777777777778
84904, 0.65217391304348, -0.075, 0.27777777777778
84905, 0.65217391304348, -0.1, 0.30555555555556
84906, 0.67391304347826, -0.1, 0.33333333333333
84907, 0.65217391304348, -0.075, 0.33333333333333
84908, 0.65217391304348, -0.1, 0.36111111111111
84909, 0.67391304347826, -0.1, 0.38888888888889
84910, 0.65217391304348, -0.075, 0.38888888888889
84911, 0.65217391304348, -0.1, 0.41666666666667
84912, 0.67391304347826, -0.1, 0.44444444444444
84913, 0.65217391304348, -0.075, 0.44444444444444
84914, 0.65217391304348, -0.1, 0.47222222222222
84915, 0.60869565217391, -0.1, 0.027777777777778
84916, 0.6304347826087, -0.1, 0.055555555555556
84917, 0.60869565217391, -0.075, 0.055555555555556
84918, 0.60869565217391, -0.1, 0.083333333333333
84919, 0.6304347826087, -0.1, 0.11111111111111
84920, 0.60869565217391, -0.075, 0.11111111111111
84921, 0.60869565217391, -0.1, 0.13888888888889
84922, 0.6304347826087, -0.1, 0.16666666666667
84923, 0.60869565217391, -0.075, 0.16666666666667
84924, 0.60869565217391, -0.1, 0.19444444444444
84925, 0.6304347826087, -0.1, 0.22222222222222
84926, 0.60869565217391, -0.075, 0.22222222222222
84927, 0.60869565217391, -0.1, 0.25
84928, 0.6304347826087, -0.1, 0.27777777777778
84929, 0.60869565217391, -0.075, 0.27777777777778
84930, 0.60869565217391, -0.1, 0.30555555555556
84931, 0.6304347826087, -0.1, 0.33333333333333
84932, 0.60869565217391, -0.075, 0.33333333333333
84933, 0.60869565217391, -0.1, 0.36111111111111
84934, 0.6304347826087, -0.1, 0.38888888888889
84935, 0.60869565217391, -0.075, 0.38888888888889
84936, 0.60869565217391, -0.1, 0.41666666666667
84937, 0.6304347826087, -0.1, 0.44444444444444
84938, 0.60869565217391, -0.075, 0.44444444444444
84939, 0.60869565217391, -0.1, 0.47222222222222
84940, 0.56521739130435, -0.1, 0.027777777777778
84941, 0.58695652173913, -0.1, 0.055555555555556
84942, 0.56521739130435, -0.075, 0.055555555555556
84943, 0.56521739130435, -0.1, 0.083333333333333
84944, 0.58695652173913, -0.1, 0.11111111111111
84945, 0.56521739130435, -0.075, 0.11111111111111
84946, 0.56521739130435, -0.1, 0.13888888888889
84947, 0.58695652173913, -0.1, 0.16666666666667
84948, 0.56521739130435, -0.075, 0.16666666666667
84949, 0.56521739130435, -0.1, 0.19444444444444
84950, 0.58695652173913, -0.1, 0.22222222222222
84951, 0.56521739130435, -0.075, 0.22222222222222
84952, 0.56521739130435, -0.1, 0.25
84953, 0.58695652173913, -0.1, 0.27777777777778
84954, 0.56521739130435, -0.075, 0.27777777777778
84955, 0.56521739130435, -0.1, 0.30555555555556
84956, 0.58695652173913, -0.1, 0.33333333333333
84957, 0.56521739130435, -0.075, 0.33333333333333
84958, 0.56521739130435, -0.1, 0.36111111111111
84959, 0.58695652173913, -0.1, 0.38888888888889
84960, 0.56521739130435, -0.075, 0.38888888888889
84961, 0.56521739130435, -0.1, 0.41666666666667
84962, 0.58695652173913, -0.1, 0.44444444444444
84963, 0.56521739130435, -0.075, 0.44444444444444
84964, 0.56521739130435, -0.1, 0.47222222222222
84965, 0.52173913043478, -0.1, 0.027777777777778
84966, 0.54347826086957, -0.1, 0.055555555555556
84967, 0.52173913043478, -0.075, 0.055555555555556
84968, 0.52173913043478, -0.1, 0.083333333333333
84969, 0.54347826086956, -0.1, 0.11111111111111
84970, 0.52173913043478, -0.075, 0.11111111111111
84971, 0.52173913043478, -0.1, 0.13888888888889
84972, 0.54347826086956, -0.1, 0.16666666666667
84973, 0.52173913043478, -0.075, 0.16666666666667
84974, 0.52173913043478, -0.1, 0.19444444444444
84975, 0.54347826086956, -0.1, 0.22222222222222
84976, 0.52173913043478, -0.075, 0.22222222222222
84977, 0.52173913043478, -0.1, 0.25
84978, 0.54347826086956, -0.1, 0.27777777777778
84979, 0.52173913043478, -0.075, 0.27777777777778
84980, 0.52173913043478, -0.1, 0.30555555555556
84981, 0.54347826086956, -0.1, 0.33333333333333
84982, 0.52173913043478, -0.075, 0.33333333333333
84983, 0.52173913043478, -0.1, 0.36111111111111
84984, 0.54347826086956, -0.1, 0.38888888888889
84985, 0.52173913043478, -0.075, 0.38888888888889
84986, 0.52173913043478, -0.1, 0.41666666666667
84987, 0.54347826086956, -0.1, 0.44444444444444
84988, 0.52173913043478, -0.075, 0.44444444444444
84989, 0.52173913043478, -0.1, 0.47222222222222
84990, 0.47826086956522, -0.1, 0.027777777777778
84991, 0.5, -0.1, 0.055555555555556
84992, 0.47826086956522, -0.075, 0.055555555555556
84993, 0.47826086956522, -0.1, 0.083333333333333
84994, 0.5, -0.1, 0.11111111111111
84995, 0.47826086956522, -0.075, 0.11111111111111
84996, 0.47826086956522, -0.1, 0.13888888888889
84997, 0.5, -0.1, 0.16666666666667
84998, 0.47826086956522, -0.075, 0.16666666666667
84999, 0.47826086956522, -0.1, 0.19444444444444
85000, 0.5, -0.1, 0.22222222222222
85001, 0.47826086956522, -0.075, 0.22222222222222
85002, 0.47826086956522, -0.1, 0.25
85003, 0.5, -0.1, 0.27777777777778
85004, 0.47826086956522, -0.075, 0.27777777777778
85005, 0.47826086956522, -0.1, 0.30555555555556
85006, 0.5, -0.1, 0.33333333333333
85007, 0.47826086956522, -0.075, 0.33333333333333
85008, 0.47826086956522, -0.1, 0.36111111111111
85009, 0.5, -0.1, 0.38888888888889
85010, 0.47826086956522, -0.075, 0.38888888888889
85011, 0.47826086956522, -0.1, 0.41666666666667
85012, 0.5, -0.1, 0.44444444444444
85013, 0.47826086956522, -0.075, 0.44444444444444
85014, 0.47826086956522, -0.1, 0.47222222222222
85015, 0.43478260869565, -0.1, 0.027777777777778
85016, 0.45652173913043, -0.1, 0.055555555555556
85017, 0.43478260869565, -0.075, 0.055555555555556
85018, 0.43478260869565, -0.1, 0.083333333333333
85019, 0.45652173913044, -0.1, 0.11111111111111
85020, 0.43478260869565, -0.075, 0.11111111111111
85021, 0.43478260869565, -0.1, 0.13888888888889
85022, 0.45652173913043, -0.1, 0.16666666666667
85023, 0.43478260869565, -0.075, 0.16666666666667
85024, 0.43478260869565, -0.1, 0.19444444444444
85025, 0.45652173913043, -0.1, 0.22222222222222
85026, 0.43478260869565, -0.075, 0.22222222222222
85027, 0.43478260869565, -0.1, 0.25
85028, 0.45652173913043, -0.1, 0.27777777777778
85029, 0.43478260869565, -0.075, 0.27777777777778
85030, 0.43478260869565, -0.1, 0.30555555555556
85031, 0.45652173913043, -0.1, 0.33333333333333
85032, 0.43478260869565, -0.075, 0.33333333333333
85033, 0.43478260869565, -0.1, 0.36111111111111
85034, 0.45652173913044, -0.1, 0.38888888888889
85035, 0.43478260869565, -0.075, 0.38888888888889
85036, 0.43478260869565, -0.1, 0.41666666666667
85037, 0.45652173913043, -0.1, 0.44444444444444
85038, 0.43478260869565, -0.075, 0.44444444444444
85039, 0.43478260869565, -0.1, 0.47222222222222
85040, 0.39130434782609, -0.1, 0.027777777777778
85041, 0.41304347826087, -0.1, 0.055555555555556
85042, 0.39130434782609, -0.075, 0.055555555555556
85043, 0.39130434782609, -0.1, 0.083333333333333
85044, 0.41304347826087, -0.1, 0.11111111111111
85045, 0.39130434782609, -0.075, 0.11111111111111
85046, 0.39130434782609, -0.1, 0.13888888888889
85047, 0.41304347826087, -0.1, 0.16666666666667
85048, 0.39130434782609, -0.075, 0.16666666666667
85049, 0.39130434782609, -0.1, 0.19444444444444
85050, 0.41304347826087, -0.1, 0.22222222222222
85051, 0.39130434782609, -0.075, 0.22222222222222
85052, 0.39130434782609, -0.1, 0.25
85053, 0.41304347826087, -0.1, 0.27777777777778
85054, 0.39130434782609, -0.075, 0.27777777777778
85055, 0.39130434782609, -0.1, 0.30555555555556
85056, 0.41304347826087, -0.1, 0.33333333333333
85057, 0.39130434782609, -0.075, 0.33333333333333
85058, 0.39130434782609, -0.1, 0.36111111111111
85059, 0.41304347826087, -0.1, 0.38888888888889
85060, 0.39130434782609, -0.075, 0.38888888888889
85061, 0.39130434782609, -0.1, 0.41666666666667
85062, 0.41304347826087, -0.1, 0.44444444444444
85063, 0.39130434782609, -0.075, 0.44444444444444
85064, 0.39130434782609, -0.1, 0.47222222222222
85065, 0.34782608695652, -0.1, 0.027777777777778
85066, 0.3695652173913, -0.1, 0.055555555555556
85067, 0.34782608695652, -0.075, 0.055555555555556
85068, 0.34782608695652, -0.1, 0.083333333333333
85069, 0.3695652173913, -0.1, 0.11111111111111
85070, 0.34782608695652, -0.075, 0.11111111111111
85071, 0.34782608695652, -0.1, 0.13888888888889
85072, 0.3695652173913, -0.1, 0.16666666666667
85073, 0.34782608695652, -0.075, 0.16666666666667
85074, 0.34782608695652, -0.1, 0.19444444444444
85075, 0.3695652173913, -0.1, 0.22222222222222
85076, 0.34782608695652, -0.075, 0.22222222222222
85077, 0.34782608695652, -0.1, 0.25
85078, 0.3695652173913, -0.1, 0.27777777777778
85079, 0.34782608695652, -0.075, 0.27777777777778
85080, 0.34782608695652, -0.1, 0.30555555555556
85081, 0.3695652173913, -0.1, 0.33333333333333
85082, 0.34782608695652, -0.075, 0.33333333333333
85083, 0.34782608695652, -0.1, 0.36111111111111
85084, 0.3695652173913, -0.1, 0.38888888888889
85085, 0.34782608695652, -0.075, 0.38888888888889
85086, 0.34782608695652, -0.1, 0.41666666666667
85087, 0.3695652173913, -0.1, 0.44444444444444
85088, 0.34782608695652, -0.075, 0.44444444444444
85089, 0.34782608695652, -0.1, 0.47222222222222
85090, 0.30434782608696, -0.1, 0.027777777777778
85091, 0.32608695652174, -0.1, 0.055555555555556
85092, 0.30434782608696, -0.075, 0.055555555555556
85093, 0.30434782608696, -0.1, 0.083333333333333
85094, 0.32608695652174, -0.1, 0.11111111111111
85095, 0.30434782608696, -0.075, 0.11111111111111
85096, 0.30434782608696, -0.1, 0.13888888888889
85097, 0.32608695652174, -0.1, 0.16666666666667
85098, 0.30434782608696, -0.075, 0.16666666666667
85099, 0.30434782608696, -0.1, 0.19444444444444
85100, 0.32608695652174, -0.1, 0.22222222222222
85101, 0.30434782608696, -0.075, 0.22222222222222
85102, 0.30434782608696, -0.1, 0.25
85103, 0.32608695652174, -0.1, 0.27777777777778
85104, 0.30434782608696, -0.075, 0.27777777777778
85105, 0.30434782608696, -0.1, 0.30555555555556
85106, 0.32608695652174, -0.1, 0.33333333333333
85107, 0.30434782608696, -0.075, 0.33333333333333
85108, 0.30434782608696, -0.1, 0.36111111111111
85109, 0.32608695652174, -0.1, 0.38888888888889
85110, 0.30434782608696, -0.075, 0.38888888888889
85111, 0.30434782608696, -0.1, 0.41666666666667
85112, 0.32608695652174, -0.1, 0.44444444444444
85113, 0.30434782608696, -0.075, 0.44444444444444
85114, 0.30434782608696, -0.1, 0.47222222222222
85115, 0.26086956521739, -0.1, 0.027777777777778
85116, 0.28260869565217, -0.1, 0.055555555555556
85117, 0.26086956521739, -0.075, 0.055555555555556
85118, 0.26086956521739, -0.1, 0.083333333333333
85119, 0.28260869565217, -0.1, 0.11111111111111
85120, 0.26086956521739, -0.075, 0.11111111111111
85121, 0.26086956521739, -0.1, 0.13888888888889
85122, 0.28260869565217, -0.1, 0.16666666666667
85123, 0.26086956521739, -0.075, 0.16666666666667
85124, 0.26086956521739, -0.1, 0.19444444444444
85125, 0.28260869565217, -0.1, 0.22222222222222
85126, 0.26086956521739, -0.075, 0.22222222222222
85127, 0.26086956521739, -0.1, 0.25
85128, 0.28260869565217, -0.1, 0.27777777777778
85129, 0.26086956521739, -0.075, 0.27777777777778
85130, 0.26086956521739, -0.1, 0.30555555555556
85131, 0.28260869565217, -0.1, 0.33333333333333
85132, 0.26086956521739, -0.075, 0.33333333333333
85133, 0.26086956521739, -0.1, 0.36111111111111
85134, 0.28260869565217, -0.1, 0.38888888888889
85135, 0.26086956521739, -0.075, 0.38888888888889
85136, 0.26086956521739, -0.1, 0.41666666666667
85137, 0.28260869565217, -0.1, 0.44444444444444
85138, 0.26086956521739, -0.075, 0.44444444444444
85139, 0.26086956521739, -0.1, 0.47222222222222
85140, 0.21739130434783, -0.1, 0.027777777777778
85141, 0.23913043478261, -0.1, 0.055555555555556
85142, 0.21739130434783, -0.075, 0.055555555555556
85143, 0.21739130434783, -0.1, 0.083333333333333
85144, 0.23913043478261, -0.1, 0.11111111111111
85145, 0.21739130434783, -0.075, 0.11111111111111
85146, 0.21739130434783, -0.1, 0.13888888888889
85147, 0.23913043478261, -0.1, 0.16666666666667
85148, 0.21739130434783, -0.075, 0.16666666666667
85149, 0.21739130434783, -0.1, 0.19444444444444
85150, 0.23913043478261, -0.1, 0.22222222222222
85151, 0.21739130434783, -0.075, 0.22222222222222
85152, 0.21739130434783, -0.1, 0.25
85153, 0.23913043478261, -0.1, 0.27777777777778
85154, 0.21739130434783, -0.075, 0.27777777777778
85155, 0.21739130434783, -0.1, 0.30555555555556
85156, 0.23913043478261, -0.1, 0.33333333333333
85157, 0.21739130434783, -0.075, 0.33333333333333
85158, 0.21739130434783, -0.1, 0.36111111111111
85159, 0.23913043478261, -0.1, 0.38888888888889
85160, 0.21739130434783, -0.075, 0.38888888888889
85161, 0.21739130434783, -0.1, 0.41666666666667
85162, 0.23913043478261, -0.1, 0.44444444444444
85163, 0.21739130434783, -0.075, 0.44444444444444
85164, 0.21739130434783, -0.1, 0.47222222222222
85165, 0.17391304347826, -0.1, 0.027777777777778
85166, 0.19565217391304, -0.1, 0.055555555555556
85167, 0.17391304347826, -0.075, 0.055555555555556
85168, 0.17391304347826, -0.1, 0.083333333333333
85169, 0.19565217391304, -0.1, 0.11111111111111
85170, 0.17391304347826, -0.075, 0.11111111111111
85171, 0.17391304347826, -0.1, 0.13888888888889
85172, 0.19565217391304, -0.1, 0.16666666666667
85173, 0.17391304347826, -0.075, 0.16666666666667
85174, 0.17391304347826, -0.1, 0.19444444444444
85175, 0.19565217391304, -0.1, 0.22222222222222
85176, 0.17391304347826, -0.075, 0.22222222222222
85177, 0.17391304347826, -0.1, 0.25
85178, 0.19565217391304, -0.1, 0.27777777777778
85179, 0.17391304347826, -0.075, 0.27777777777778
85180, 0.17391304347826, -0.1, 0.30555555555556
85181, 0.19565217391304, -0.1, 0.33333333333333
85182, 0.17391304347826, -0.075, 0.33333333333333
85183, 0.17391304347826, -0.1, 0.36111111111111
85184, 0.19565217391304, -0.1, 0.38888888888889
85185, 0.17391304347826, -0.075, 0.38888888888889
85186, 0.17391304347826, -0.1, 0.41666666666667
85187, 0.19565217391304, -0.1, 0.44444444444444
85188, 0.17391304347826, -0.075, 0.44444444444444
85189, 0.17391304347826, -0.1, 0.47222222222222
85190, 0.1304347826087, -0.1, 0.027777777777778
85191, 0.15217391304348, -0.1, 0.055555555555556
85192, 0.1304347826087, -0.075, 0.055555555555556
85193, 0.1304347826087, -0.1, 0.083333333333333
85194, 0.15217391304348, -0.1, 0.11111111111111
85195, 0.1304347826087, -0.075, 0.11111111111111
85196, 0.1304347826087, -0.1, 0.13888888888889
85197, 0.15217391304348, -0.1, 0.16666666666667
85198, 0.1304347826087, -0.075, 0.16666666666667
85199, 0.1304347826087, -0.1, 0.19444444444444
85200, 0.15217391304348, -0.1, 0.22222222222222
85201, 0.1304347826087, -0.075, 0.22222222222222
85202, 0.1304347826087, -0.1, 0.25
85203, 0.15217391304348, -0.1, 0.27777777777778
85204, 0.1304347826087, -0.075, 0.27777777777778
85205, 0.1304347826087, -0.1, 0.30555555555556
85206, 0.15217391304348, -0.1, 0.33333333333333
85207, 0.1304347826087, -0.075, 0.33333333333333
85208, 0.1304347826087, -0.1, 0.36111111111111
85209, 0.15217391304348, -0.1, 0.38888888888889
85210, 0.1304347826087, -0.075, 0.38888888888889
85211, 0.1304347826087, -0.1, 0.41666666666667
85212, 0.15217391304348, -0.1, 0.44444444444444
85213, 0.1304347826087, -0.075, 0.44444444444444
85214, 0.1304347826087, -0.1, 0.47222222222222
85215, 0.08695652173913, -0.1, 0.027777777777778
85216, 0.10869565217391, -0.1, 0.055555555555556
85217, 0.08695652173913, -0.075, 0.055555555555556
85218, 0.08695652173913, -0.1, 0.083333333333333
85219, 0.10869565217391, -0.1, 0.11111111111111
85220, 0.08695652173913, -0.075, 0.11111111111111
85221, 0.08695652173913, -0.1, 0.13888888888889
85222, 0.10869565217391, -0.1, 0.16666666666667
85223, 0.08695652173913, -0.075, 0.16666666666667
85224, 0.08695652173913, -0.1, 0.19444444444444
85225, 0.10869565217391, -0.1, 0.22222222222222
85226, 0.08695652173913, -0.075, 0.22222222222222
85227, 0.08695652173913, -0.1, 0.25
85228, 0.10869565217391, -0.1, 0.27777777777778
85229, 0.08695652173913, -0.075, 0.27777777777778
85230, 0.08695652173913, -0.1, 0.30555555555556
85231, 0.10869565217391, -0.1, 0.33333333333333
85232, 0.08695652173913, -0.075, 0.33333333333333
85233, 0.08695652173913, -0.1, 0.36111111111111
85234, 0.10869565217391, -0.1, 0.38888888888889
85235, 0.08695652173913, -0.075, 0.38888888888889
85236, 0.08695652173913, -0.1, 0.41666666666667
85237, 0.10869565217391, -0.1, 0.44444444444444
85238, 0.08695652173913, -0.075, 0.44444444444444
85239, 0.08695652173913, -0.1, 0.47222222222222
85240, 0.043478260869565, -0.1, 0.027777777777778
85241, 0.065217391304348, -0.1, 0.055555555555556
85242, 0.043478260869565, -0.075, 0.055555555555556
85243, 0.043478260869565, -0.1, 0.083333333333333
85244, 0.065217391304348, -0.1, 0.11111111111111
85245, 0.043478260869565, -0.075, 0.11111111111111
85246, 0.043478260869565, -0.1, 0.13888888888889
85247, 0.065217391304348, -0.1, 0.16666666666667
85248, 0.043478260869565, -0.075, 0.16666666666667
85249, 0.043478260869565, -0.1, 0.19444444444444
85250, 0.065217391304348, -0.1, 0.22222222222222
85251, 0.043478260869565, -0.075, 0.22222222222222
85252, 0.043478260869565, -0.1, 0.25
85253, 0.065217391304348, -0.1, 0.27777777777778
85254, 0.043478260869565, -0.075, 0.27777777777778
85255, 0.043478260869565, -0.1, 0.30555555555556
85256, 0.065217391304348, -0.1, 0.33333333333333
85257, 0.043478260869565, -0.075, 0.33333333333333
85258, 0.043478260869565, -0.1, 0.36111111111111
85259, 0.065217391304348, -0.1, 0.38888888888889
85260, 0.043478260869565, -0.075, 0.38888888888889
85261, 0.043478260869565, -0.1, 0.41666666666667
85262, 0.065217391304348, -0.1, 0.44444444444444
85263, 0.043478260869565, -0.075, 0.44444444444444
85264, 0.043478260869565, -0.1, 0.47222222222222
85265, 0.021739130434783, -0.1, 0.055555555555556
85266, 0.021739130434783, -0.1, 0.11111111111111
85267, 0.021739130434783, -0.1, 0.16666666666667
85268, 0.021739130434783, -0.1, 0.22222222222222
85269, 0.021739130434783, -0.1, 0.27777777777778
85270, 0.021739130434783, -0.1, 0.33333333333333
85271, 0.021739130434783, -0.1, 0.38888888888889
85272, 0.021739130434783, -0.1, 0.44444444444444
85273, 0.95652173913043, -0.15, 0.027777777777778
85274, 0.97826086956522, -0.15, 0.055555555555556
85275, 0.95652173913043, -0.125, 0.055555555555556
85276, 0.95652173913043, -0.15, 0.083333333333333
85277, 0.97826086956522, -0.15, 0.11111111111111
85278, 0.95652173913044, -0.125, 0.11111111111111
85279, 0.95652173913044, -0.15, 0.13888888888889
85280, 0.97826086956522, -0.15, 0.16666666666667
85281, 0.95652173913043, -0.125, 0.16666666666667
85282, 0.95652173913044, -0.15, 0.19444444444444
85283, 0.97826086956522, -0.15, 0.22222222222222
85284, 0.95652173913043, -0.125, 0.22222222222222
85285, 0.95652173913044, -0.15, 0.25
85286, 0.97826086956522, -0.15, 0.27777777777778
85287, 0.95652173913043, -0.125, 0.27777777777778
85288, 0.95652173913044, -0.15, 0.30555555555556
85289, 0.97826086956522, -0.15, 0.33333333333333
85290, 0.95652173913043, -0.125, 0.33333333333333
85291, 0.95652173913044, -0.15, 0.36111111111111
85292, 0.97826086956522, -0.15, 0.38888888888889
85293, 0.95652173913043, -0.125, 0.38888888888889
85294, 0.95652173913044, -0.15, 0.41666666666667
85295, 0.97826086956522, -0.15, 0.44444444444444
85296, 0.95652173913043, -0.125, 0.44444444444444
85297, 0.95652173913043, -0.15, 0.47222222222222
85298, 0.91304347826087, -0.15, 0.027777777777778
85299, 0.93478260869565, -0.15, 0.055555555555556
85300, 0.91304347826087, -0.125, 0.055555555555556
85301, 0.91304347826087, -0.15, 0.083333333333333
85302, 0.93478260869565, -0.15, 0.11111111111111
85303, 0.91304347826087, -0.125, 0.11111111111111
85304, 0.91304347826087, -0.15, 0.13888888888889
85305, 0.93478260869565, -0.15, 0.16666666666667
85306, 0.91304347826087, -0.125, 0.16666666666667
85307, 0.91304347826087, -0.15, 0.19444444444444
85308, 0.93478260869565, -0.15, 0.22222222222222
85309, 0.91304347826087, -0.125, 0.22222222222222
85310, 0.91304347826087, -0.15, 0.25
85311, 0.93478260869565, -0.15, 0.27777777777778
85312, 0.91304347826087, -0.125, 0.27777777777778
85313, 0.91304347826087, -0.15, 0.30555555555556
85314, 0.93478260869565, -0.15, 0.33333333333333
85315, 0.91304347826087, -0.125, 0.33333333333333
85316, 0.91304347826087, -0.15, 0.36111111111111
85317, 0.93478260869565, -0.15, 0.38888888888889
85318, 0.91304347826087, -0.125, 0.38888888888889
85319, 0.91304347826087, -0.15, 0.41666666666667
85320, 0.93478260869565, -0.15, 0.44444444444444
85321, 0.91304347826087, -0.125, 0.44444444444444
85322, 0.91304347826087, -0.15, 0.47222222222222
85323, 0.8695652173913, -0.15, 0.027777777777778
85324, 0.89130434782609, -0.15, 0.055555555555556
85325, 0.8695652173913, -0.125, 0.055555555555556
85326, 0.8695652173913, -0.15, 0.083333333333333
85327, 0.89130434782609, -0.15, 0.11111111111111
85328, 0.8695652173913, -0.125, 0.11111111111111
85329, 0.8695652173913, -0.15, 0.13888888888889
85330, 0.89130434782609, -0.15, 0.16666666666667
85331, 0.8695652173913, -0.125, 0.16666666666667
85332, 0.8695652173913, -0.15, 0.19444444444444
85333, 0.89130434782609, -0.15, 0.22222222222222
85334, 0.8695652173913, -0.125, 0.22222222222222
85335, 0.8695652173913, -0.15, 0.25
85336, 0.89130434782609, -0.15, 0.27777777777778
85337, 0.8695652173913, -0.125, 0.27777777777778
85338, 0.8695652173913, -0.15, 0.30555555555556
85339, 0.89130434782609, -0.15, 0.33333333333333
85340, 0.8695652173913, -0.125, 0.33333333333333
85341, 0.8695652173913, -0.15, 0.36111111111111
85342, 0.89130434782609, -0.15, 0.38888888888889
85343, 0.8695652173913, -0.125, 0.38888888888889
85344, 0.8695652173913, -0.15, 0.41666666666667
85345, 0.89130434782609, -0.15, 0.44444444444444
85346, 0.8695652173913, -0.125, 0.44444444444444
85347, 0.8695652173913, -0.15, 0.47222222222222
85348, 0.82608695652174, -0.15, 0.027777777777778
85349, 0.84782608695652, -0.15, 0.055555555555556
85350, 0.82608695652174, -0.125, 0.055555555555556
85351, 0.82608695652174, -0.15, 0.083333333333333
85352, 0.84782608695652, -0.15, 0.11111111111111
85353, 0.82608695652174, -0.125, 0.11111111111111
85354, 0.82608695652174, -0.15, 0.13888888888889
85355, 0.84782608695652, -0.15, 0.16666666666667
85356, 0.82608695652174, -0.125, 0.16666666666667
85357, 0.82608695652174, -0.15, 0.19444444444444
85358, 0.84782608695652, -0.15, 0.22222222222222
85359, 0.82608695652174, -0.125, 0.22222222222222
85360, 0.82608695652174, -0.15, 0.25
85361, 0.84782608695652, -0.15, 0.27777777777778
85362, 0.82608695652174, -0.125, 0.27777777777778
85363, 0.82608695652174, -0.15, 0.30555555555556
85364, 0.84782608695652, -0.15, 0.33333333333333
85365, 0.82608695652174, -0.125, 0.33333333333333
85366, 0.82608695652174, -0.15, 0.36111111111111
85367, 0.84782608695652, -0.15, 0.38888888888889
85368, 0.82608695652174, -0.125, 0.38888888888889
85369, 0.82608695652174, -0.15, 0.41666666666667
85370, 0.84782608695652, -0.15, 0.44444444444444
85371, 0.82608695652174, -0.125, 0.44444444444444
85372, 0.82608695652174, -0.15, 0.47222222222222
85373, 0.78260869565217, -0.15, 0.027777777777778
85374, 0.80434782608696, -0.15, 0.055555555555556
85375, 0.78260869565217, -0.125, 0.055555555555556
85376, 0.78260869565217, -0.15, 0.083333333333333
85377, 0.80434782608696, -0.15, 0.11111111111111
85378, 0.78260869565217, -0.125, 0.11111111111111
85379, 0.78260869565217, -0.15, 0.13888888888889
85380, 0.80434782608696, -0.15, 0.16666666666667
85381, 0.78260869565217, -0.125, 0.16666666666667
85382, 0.78260869565217, -0.15, 0.19444444444444
85383, 0.80434782608696, -0.15, 0.22222222222222
85384, 0.78260869565217, -0.125, 0.22222222222222
85385, 0.78260869565217, -0.15, 0.25
85386, 0.80434782608696, -0.15, 0.27777777777778
85387, 0.78260869565217, -0.125, 0.27777777777778
85388, 0.78260869565217, -0.15, 0.30555555555556
85389, 0.80434782608696, -0.15, 0.33333333333333
85390, 0.78260869565217, -0.125, 0.33333333333333
85391, 0.78260869565217, -0.15, 0.36111111111111
85392, 0.80434782608696, -0.15, 0.38888888888889
85393, 0.78260869565217, -0.125, 0.38888888888889
85394, 0.78260869565217, -0.15, 0.41666666666667
85395, 0.80434782608696, -0.15, 0.44444444444444
85396, 0.78260869565217, -0.125, 0.44444444444444
85397, 0.78260869565217, -0.15, 0.47222222222222
85398, 0.73913043478261, -0.15, 0.027777777777778
85399, 0.76086956521739, -0.15, 0.055555555555556
85400, 0.73913043478261, -0.125, 0.055555555555556
85401, 0.73913043478261, -0.15, 0.083333333333333
85402, 0.76086956521739, -0.15, 0.11111111111111
85403, 0.73913043478261, -0.125, 0.11111111111111
85404, 0.73913043478261, -0.15, 0.13888888888889
85405, 0.76086956521739, -0.15, 0.16666666666667
85406, 0.73913043478261, -0.125, 0.16666666666667
85407, 0.73913043478261, -0.15, 0.19444444444444
85408, 0.76086956521739, -0.15, 0.22222222222222
85409, 0.73913043478261, -0.125, 0.22222222222222
85410, 0.73913043478261, -0.15, 0.25
85411, 0.76086956521739, -0.15, 0.27777777777778
85412, 0.73913043478261, -0.125, 0.27777777777778
85413, 0.73913043478261, -0.15, 0.30555555555556
85414, 0.76086956521739, -0.15, 0.33333333333333
85415, 0.73913043478261, -0.125, 0.33333333333333
85416, 0.73913043478261, -0.15, 0.36111111111111
85417, 0.76086956521739, -0.15, 0.38888888888889
85418, 0.73913043478261, -0.125, 0.38888888888889
85419, 0.73913043478261, -0.15, 0.41666666666667
85420, 0.76086956521739, -0.15, 0.44444444444444
85421, 0.73913043478261, -0.125, 0.44444444444444
85422, 0.73913043478261, -0.15, 0.47222222222222
85423, 0.69565217391304, -0.15, 0.027777777777778
85424, 0.71739130434783, -0.15, 0.055555555555556
85425, 0.69565217391304, -0.125, 0.055555555555556
85426, 0.69565217391304, -0.15, 0.083333333333333
85427, 0.71739130434783, -0.15, 0.11111111111111
85428, 0.69565217391304, -0.125, 0.11111111111111
85429, 0.69565217391304, -0.15, 0.13888888888889
85430, 0.71739130434783, -0.15, 0.16666666666667
85431, 0.69565217391304, -0.125, 0.16666666666667
85432, 0.69565217391304, -0.15, 0.19444444444444
85433, 0.71739130434783, -0.15, 0.22222222222222
85434, 0.69565217391304, -0.125, 0.22222222222222
85435, 0.69565217391304, -0.15, 0.25
85436, 0.71739130434783, -0.15, 0.27777777777778
85437, 0.69565217391304, -0.125, 0.27777777777778
85438, 0.69565217391304, -0.15, 0.30555555555556
85439, 0.71739130434783, -0.15, 0.33333333333333
85440, 0.69565217391304, -0.125, 0.33333333333333
85441, 0.69565217391304, -0.15, 0.36111111111111
85442, 0.71739130434783, -0.15, 0.38888888888889
85443, 0.69565217391304, -0.125, 0.38888888888889
85444, 0.69565217391304, -0.15, 0.41666666666667
85445, 0.71739130434783, -0.15, 0.44444444444444
85446, 0.69565217391304, -0.125, 0.44444444444444
85447, 0.69565217391304, -0.15, 0.47222222222222
85448, 0.65217391304348, -0.15, 0.027777777777778
85449, 0.67391304347826, -0.15, 0.055555555555556
85450, 0.65217391304348, -0.125, 0.055555555555556
85451, 0.65217391304348, -0.15, 0.083333333333333
85452, 0.67391304347826, -0.15, 0.11111111111111
85453, 0.65217391304348, -0.125, 0.11111111111111
85454, 0.65217391304348, -0.15, 0.13888888888889
85455, 0.67391304347826, -0.15, 0.16666666666667
85456, 0.65217391304348, -0.125, 0.16666666666667
85457, 0.65217391304348, -0.15, 0.19444444444444
85458, 0.67391304347826, -0.15, 0.22222222222222
85459, 0.65217391304348, -0.125, 0.22222222222222
85460, 0.65217391304348, -0.15, 0.25
85461, 0.67391304347826, -0.15, 0.27777777777778
85462, 0.65217391304348, -0.125, 0.27777777777778
85463, 0.65217391304348, -0.15, 0.30555555555556
85464, 0.67391304347826, -0.15, 0.33333333333333
85465, 0.65217391304348, -0.125, 0.33333333333333
85466, 0.65217391304348, -0.15, 0.36111111111111
85467, 0.67391304347826, -0.15, 0.38888888888889
85468, 0.65217391304348, -0.125, 0.38888888888889
85469, 0.65217391304348, -0.15, 0.41666666666667
85470, 0.67391304347826, -0.15, 0.44444444444444
85471, 0.65217391304348, -0.125, 0.44444444444444
85472, 0.65217391304348, -0.15, 0.47222222222222
85473, 0.60869565217391, -0.15, 0.027777777777778
85474, 0.6304347826087, -0.15, 0.055555555555556
85475, 0.60869565217391, -0.125, 0.055555555555556
85476, 0.60869565217391, -0.15, 0.083333333333333
85477, 0.6304347826087, -0.15, 0.11111111111111
85478, 0.60869565217391, -0.125, 0.11111111111111
85479, 0.60869565217391, -0.15, 0.13888888888889
85480, 0.6304347826087, -0.15, 0.16666666666667
85481, 0.60869565217391, -0.125, 0.16666666666667
85482, 0.60869565217391, -0.15, 0.19444444444444
85483, 0.6304347826087, -0.15, 0.22222222222222
85484, 0.60869565217391, -0.125, 0.22222222222222
85485, 0.60869565217391, -0.15, 0.25
85486, 0.6304347826087, -0.15, 0.27777777777778
85487, 0.60869565217391, -0.125, 0.27777777777778
85488, 0.60869565217391, -0.15, 0.30555555555556
85489, 0.6304347826087, -0.15, 0.33333333333333
85490, 0.60869565217391, -0.125, 0.33333333333333
85491, 0.60869565217391, -0.15, 0.36111111111111
85492, 0.6304347826087, -0.15, 0.38888888888889
85493, 0.60869565217391, -0.125, 0.38888888888889
85494, 0.60869565217391, -0.15, 0.41666666666667
85495, 0.6304347826087, -0.15, 0.44444444444444
85496, 0.60869565217391, -0.125, 0.44444444444444
85497, 0.60869565217391, -0.15, 0.47222222222222
85498, 0.56521739130435, -0.15, 0.027777777777778
85499, 0.58695652173913, -0.15, 0.055555555555556
85500, 0.56521739130435, -0.125, 0.055555555555556
85501, 0.56521739130435, -0.15, 0.083333333333333
85502, 0.58695652173913, -0.15, 0.11111111111111
85503, 0.56521739130435, -0.125, 0.11111111111111
85504, 0.56521739130435, -0.15, 0.13888888888889
85505, 0.58695652173913, -0.15, 0.16666666666667
85506, 0.56521739130435, -0.125, 0.16666666666667
85507, 0.56521739130435, -0.15, 0.19444444444444
85508, 0.58695652173913, -0.15, 0.22222222222222
85509, 0.56521739130435, -0.125, 0.22222222222222
85510, 0.56521739130435, -0.15, 0.25
85511, 0.58695652173913, -0.15, 0.27777777777778
85512, 0.56521739130435, -0.125, 0.27777777777778
85513, 0.56521739130435, -0.15, 0.30555555555556
85514, 0.58695652173913, -0.15, 0.33333333333333
85515, 0.56521739130435, -0.125, 0.33333333333333
85516, 0.56521739130435, -0.15, 0.36111111111111
85517, 0.58695652173913, -0.15, 0.38888888888889
85518, 0.56521739130435, -0.125, 0.38888888888889
85519, 0.56521739130435, -0.15, 0.41666666666667
85520, 0.58695652173913, -0.15, 0.44444444444444
85521, 0.56521739130435, -0.125, 0.44444444444444
85522, 0.56521739130435, -0.15, 0.47222222222222
85523, 0.52173913043478, -0.15, 0.027777777777778
85524, 0.54347826086957, -0.15, 0.055555555555556
85525, 0.52173913043478, -0.125, 0.055555555555556
85526, 0.52173913043478, -0.15, 0.083333333333333
85527, 0.54347826086957, -0.15, 0.11111111111111
85528, 0.52173913043478, -0.125, 0.11111111111111
85529, 0.52173913043478, -0.15, 0.13888888888889
85530, 0.54347826086957, -0.15, 0.16666666666667
85531, 0.52173913043478, -0.125, 0.16666666666667
85532, 0.52173913043478, -0.15, 0.19444444444444
85533, 0.54347826086956, -0.15, 0.22222222222222
85534, 0.52173913043478, -0.125, 0.22222222222222
85535, 0.52173913043478, -0.15, 0.25
85536, 0.54347826086956, -0.15, 0.27777777777778
85537, 0.52173913043478, -0.125, 0.27777777777778
85538, 0.52173913043478, -0.15, 0.30555555555556
85539, 0.54347826086956, -0.15, 0.33333333333333
85540, 0.52173913043478, -0.125, 0.33333333333333
85541, 0.52173913043478, -0.15, 0.36111111111111
85542, 0.54347826086956, -0.15, 0.38888888888889
85543, 0.52173913043478, -0.125, 0.38888888888889
85544, 0.52173913043478, -0.15, 0.41666666666667
85545, 0.54347826086956, -0.15, 0.44444444444444
85546, 0.52173913043478, -0.125, 0.44444444444444
85547, 0.52173913043478, -0.15, 0.47222222222222
85548, 0.47826086956522, -0.15, 0.027777777777778
85549, 0.5, -0.15, 0.055555555555556
85550, 0.47826086956522, -0.125, 0.055555555555556
85551, 0.47826086956522, -0.15, 0.083333333333333
85552, 0.5, -0.15, 0.11111111111111
85553, 0.47826086956522, -0.125, 0.11111111111111
85554, 0.47826086956522, -0.15, 0.13888888888889
85555, 0.5, -0.15, 0.16666666666667
85556, 0.47826086956522, -0.125, 0.16666666666667
85557, 0.47826086956522, -0.15, 0.19444444444444
85558, 0.5, -0.15, 0.22222222222222
85559, 0.47826086956522, -0.125, 0.22222222222222
85560, 0.47826086956522, -0.15, 0.25
85561, 0.5, -0.15, 0.27777777777778
85562, 0.47826086956522, -0.125, 0.27777777777778
85563, 0.47826086956522, -0.15, 0.30555555555556
85564, 0.5, -0.15, 0.33333333333333
85565, 0.47826086956522, -0.125, 0.33333333333333
85566, 0.47826086956522, -0.15, 0.36111111111111
85567, 0.5, -0.15, 0.38888888888889
85568, 0.47826086956522, -0.125, 0.38888888888889
85569, 0.47826086956522, -0.15, 0.41666666666667
85570, 0.5, -0.15, 0.44444444444444
85571, 0.47826086956522, -0.125, 0.44444444444444
85572, 0.47826086956522, -0.15, 0.47222222222222
85573, 0.43478260869565, -0.15, 0.027777777777778
85574, 0.45652173913043, -0.15, 0.055555555555556
85575, 0.43478260869565, -0.125, 0.055555555555556
85576, 0.43478260869565, -0.15, 0.083333333333333
85577, 0.45652173913043, -0.15, 0.11111111111111
85578, 0.43478260869565, -0.125, 0.11111111111111
85579, 0.43478260869565, -0.15, 0.13888888888889
85580, 0.45652173913043, -0.15, 0.16666666666667
85581, 0.43478260869565, -0.125, 0.16666666666667
85582, 0.43478260869565, -0.15, 0.19444444444444
85583, 0.45652173913043, -0.15, 0.22222222222222
85584, 0.43478260869565, -0.125, 0.22222222222222
85585, 0.43478260869565, -0.15, 0.25
85586, 0.45652173913043, -0.15, 0.27777777777778
85587, 0.43478260869565, -0.125, 0.27777777777778
85588, 0.43478260869565, -0.15, 0.30555555555556
85589, 0.45652173913043, -0.15, 0.33333333333333
85590, 0.43478260869565, -0.125, 0.33333333333333
85591, 0.43478260869565, -0.15, 0.36111111111111
85592, 0.45652173913044, -0.15, 0.38888888888889
85593, 0.43478260869565, -0.125, 0.38888888888889
85594, 0.43478260869565, -0.15, 0.41666666666667
85595, 0.45652173913043, -0.15, 0.44444444444444
85596, 0.43478260869565, -0.125, 0.44444444444444
85597, 0.43478260869565, -0.15, 0.47222222222222
85598, 0.39130434782609, -0.15, 0.027777777777778
85599, 0.41304347826087, -0.15, 0.055555555555556
85600, 0.39130434782609, -0.125, 0.055555555555556
85601, 0.39130434782609, -0.15, 0.083333333333333
85602, 0.41304347826087, -0.15, 0.11111111111111
85603, 0.39130434782609, -0.125, 0.11111111111111
85604, 0.39130434782609, -0.15, 0.13888888888889
85605, 0.41304347826087, -0.15, 0.16666666666667
85606, 0.39130434782609, -0.125, 0.16666666666667
85607, 0.39130434782609, -0.15, 0.19444444444444
85608, 0.41304347826087, -0.15, 0.22222222222222
85609, 0.39130434782609, -0.125, 0.22222222222222
85610, 0.39130434782609, -0.15, 0.25
85611, 0.41304347826087, -0.15, 0.27777777777778
85612, 0.39130434782609, -0.125, 0.27777777777778
85613, 0.39130434782609, -0.15, 0.30555555555556
85614, 0.41304347826087, -0.15, 0.33333333333333
85615, 0.39130434782609, -0.125, 0.33333333333333
85616, 0.39130434782609, -0.15, 0.36111111111111
85617, 0.41304347826087, -0.15, 0.38888888888889
85618, 0.39130434782609, -0.125, 0.38888888888889
85619, 0.39130434782609, -0.15, 0.41666666666667
85620, 0.41304347826087, -0.15, 0.44444444444444
85621, 0.39130434782609, -0.125, 0.44444444444444
85622, 0.39130434782609, -0.15, 0.47222222222222
85623, 0.34782608695652, -0.15, 0.027777777777778
85624, 0.3695652173913, -0.15, 0.055555555555556
85625, 0.34782608695652, -0.125, 0.055555555555556
85626, 0.34782608695652, -0.15, 0.083333333333333
85627, 0.3695652173913, -0.15, 0.11111111111111
85628, 0.34782608695652, -0.125, 0.11111111111111
85629, 0.34782608695652, -0.15, 0.13888888888889
85630, 0.3695652173913, -0.15, 0.16666666666667
85631, 0.34782608695652, -0.125, 0.16666666666667
85632, 0.34782608695652, -0.15, 0.19444444444444
85633, 0.3695652173913, -0.15, 0.22222222222222
85634, 0.34782608695652, -0.125, 0.22222222222222
85635, 0.34782608695652, -0.15, 0.25
85636, 0.3695652173913, -0.15, 0.27777777777778
85637, 0.34782608695652, -0.125, 0.27777777777778
85638, 0.34782608695652, -0.15, 0.30555555555556
85639, 0.3695652173913, -0.15, 0.33333333333333
85640, 0.34782608695652, -0.125, 0.33333333333333
85641, 0.34782608695652, -0.15, 0.36111111111111
85642, 0.3695652173913, -0.15, 0.38888888888889
85643, 0.34782608695652, -0.125, 0.38888888888889
85644, 0.34782608695652, -0.15, 0.41666666666667
85645, 0.3695652173913, -0.15, 0.44444444444444
85646, 0.34782608695652, -0.125, 0.44444444444444
85647, 0.34782608695652, -0.15, 0.47222222222222
85648, 0.30434782608696, -0.15, 0.027777777777778
85649, 0.32608695652174, -0.15, 0.055555555555556
85650, 0.30434782608696, -0.125, 0.055555555555556
85651, 0.30434782608696, -0.15, 0.083333333333333
85652, 0.32608695652174, -0.15, 0.11111111111111
85653, 0.30434782608696, -0.125, 0.11111111111111
85654, 0.30434782608696, -0.15, 0.13888888888889
85655, 0.32608695652174, -0.15, 0.16666666666667
85656, 0.30434782608696, -0.125, 0.16666666666667
85657, 0.30434782608696, -0.15, 0.19444444444444
85658, 0.32608695652174, -0.15, 0.22222222222222
85659, 0.30434782608696, -0.125, 0.22222222222222
85660, 0.30434782608696, -0.15, 0.25
85661, 0.32608695652174, -0.15, 0.27777777777778
85662, 0.30434782608696, -0.125, 0.27777777777778
85663, 0.30434782608696, -0.15, 0.30555555555556
85664, 0.32608695652174, -0.15, 0.33333333333333
85665, 0.30434782608696, -0.125, 0.33333333333333
85666, 0.30434782608696, -0.15, 0.36111111111111
85667, 0.32608695652174, -0.15, 0.38888888888889
85668, 0.30434782608696, -0.125, 0.38888888888889
85669, 0.30434782608696, -0.15, 0.41666666666667
85670, 0.32608695652174, -0.15, 0.44444444444444
85671, 0.30434782608696, -0.125, 0.44444444444444
85672, 0.30434782608696, -0.15, 0.47222222222222
85673, 0.26086956521739, -0.15, 0.027777777777778
85674, 0.28260869565217, -0.15, 0.055555555555556
85675, 0.26086956521739, -0.125, 0.055555555555556
85676, 0.26086956521739, -0.15, 0.083333333333333
85677, 0.28260869565217, -0.15, 0.11111111111111
85678, 0.26086956521739, -0.125, 0.11111111111111
85679, 0.26086956521739, -0.15, 0.13888888888889
85680, 0.28260869565217, -0.15, 0.16666666666667
85681, 0.26086956521739, -0.125, 0.16666666666667
85682, 0.26086956521739, -0.15, 0.19444444444444
85683, 0.28260869565217, -0.15, 0.22222222222222
85684, 0.26086956521739, -0.125, 0.22222222222222
85685, 0.26086956521739, -0.15, 0.25
85686, 0.28260869565217, -0.15, 0.27777777777778
85687, 0.26086956521739, -0.125, 0.27777777777778
85688, 0.26086956521739, -0.15, 0.30555555555556
85689, 0.28260869565217, -0.15, 0.33333333333333
85690, 0.26086956521739, -0.125, 0.33333333333333
85691, 0.26086956521739, -0.15, 0.36111111111111
85692, 0.28260869565217, -0.15, 0.38888888888889
85693, 0.26086956521739, -0.125, 0.38888888888889
85694, 0.26086956521739, -0.15, 0.41666666666667
85695, 0.28260869565217, -0.15, 0.44444444444444
85696, 0.26086956521739, -0.125, 0.44444444444444
85697, 0.26086956521739, -0.15, 0.47222222222222
85698, 0.21739130434783, -0.15, 0.027777777777778
85699, 0.23913043478261, -0.15, 0.055555555555556
