35910, 0.82608695652174, -0.016666666666667, 0.16666666666667
35911, 0.8695652173913, -0.016666666666667, 0.16666666666667
35912, 0.91304347826087, -0.016666666666667, 0.16666666666667
35913, 0.95652173913044, -0.016666666666667, 0.16666666666667
35914, 0.043478260869565, 0.016666666666667, 0.16666666666667
35915, 0.08695652173913, 0.016666666666667, 0.16666666666667
35916, 0.1304347826087, 0.016666666666667, 0.16666666666667
35917, 0.17391304347826, 0.016666666666667, 0.16666666666667
35918, 0.21739130434783, 0.016666666666667, 0.16666666666667
35919, 0.26086956521739, 0.016666666666667, 0.16666666666667
35920, 0.30434782608696, 0.016666666666667, 0.16666666666667
35921, 0.34782608695652, 0.016666666666667, 0.16666666666667
35922, 0.39130434782609, 0.016666666666667, 0.16666666666667
35923, 0.43478260869565, 0.016666666666667, 0.16666666666667
35924, 0.47826086956522, 0.016666666666667, 0.16666666666667
35925, 0.52173913043478, 0.016666666666667, 0.16666666666667
35926, 0.56521739130435, 0.016666666666667, 0.16666666666667
35927, 0.60869565217391, 0.016666666666667, 0.16666666666667
35928, 0.65217391304348, 0.016666666666667, 0.16666666666667
35929, 0.69565217391304, 0.016666666666667, 0.16666666666667
35930, 0.73913043478261, 0.016666666666667, 0.16666666666667
35931, 0.78260869565217, 0.016666666666667, 0.16666666666667
35932, 0.82608695652174, 0.016666666666667, 0.16666666666667
35933, 0.8695652173913, 0.016666666666667, 0.16666666666667
35934, 0.91304347826087, 0.016666666666667, 0.16666666666667
35935, 0.95652173913044, 0.016666666666667, 0.16666666666667
35936, 0.043478260869565, -0.016666666666667, 0.22222222222222
35937, 0.08695652173913, -0.016666666666667, 0.22222222222222
35938, 0.1304347826087, -0.016666666666667, 0.22222222222222
35939, 0.17391304347826, -0.016666666666667, 0.22222222222222
35940, 0.21739130434783, -0.016666666666667, 0.22222222222222
35941, 0.26086956521739, -0.016666666666667, 0.22222222222222
35942, 0.30434782608696, -0.016666666666667, 0.22222222222222
35943, 0.34782608695652, -0.016666666666667, 0.22222222222222
35944, 0.39130434782609, -0.016666666666667, 0.22222222222222
35945, 0.43478260869565, -0.016666666666667, 0.22222222222222
35946, 0.47826086956522, -0.016666666666667, 0.22222222222222
35947, 0.52173913043478, -0.016666666666667, 0.22222222222222
35948, 0.56521739130435, -0.016666666666667, 0.22222222222222
35949, 0.60869565217391, -0.016666666666667, 0.22222222222222
35950, 0.65217391304348, -0.016666666666667, 0.22222222222222
35951, 0.69565217391304, -0.016666666666667, 0.22222222222222
35952, 0.73913043478261, -0.016666666666667, 0.22222222222222
35953, 0.78260869565217, -0.016666666666667, 0.22222222222222
35954, 0.82608695652174, -0.016666666666667, 0.22222222222222
35955, 0.8695652173913, -0.016666666666667, 0.22222222222222
35956, 0.91304347826087, -0.016666666666667, 0.22222222222222
35957, 0.95652173913044, -0.016666666666667, 0.22222222222222
35958, 0.043478260869565, 0.016666666666667, 0.22222222222222
35959, 0.08695652173913, 0.016666666666667, 0.22222222222222
35960, 0.1304347826087, 0.016666666666667, 0.22222222222222
35961, 0.17391304347826, 0.016666666666667, 0.22222222222222
35962, 0.21739130434783, 0.016666666666667, 0.22222222222222
35963, 0.26086956521739, 0.016666666666667, 0.22222222222222
35964, 0.30434782608696, 0.016666666666667, 0.22222222222222
35965, 0.34782608695652, 0.016666666666667, 0.22222222222222
35966, 0.39130434782609, 0.016666666666667, 0.22222222222222
35967, 0.43478260869565, 0.016666666666667, 0.22222222222222
35968, 0.47826086956522, 0.016666666666667, 0.22222222222222
35969, 0.52173913043478, 0.016666666666667, 0.22222222222222
35970, 0.56521739130435, 0.016666666666667, 0.22222222222222
35971, 0.60869565217391, 0.016666666666667, 0.22222222222222
35972, 0.65217391304348, 0.016666666666667, 0.22222222222222
35973, 0.69565217391304, 0.016666666666667, 0.22222222222222
35974, 0.73913043478261, 0.016666666666667, 0.22222222222222
35975, 0.78260869565217, 0.016666666666667, 0.22222222222222
35976, 0.82608695652174, 0.016666666666667, 0.22222222222222
35977, 0.8695652173913, 0.016666666666667, 0.22222222222222
35978, 0.91304347826087, 0.016666666666667, 0.22222222222222
35979, 0.95652173913044, 0.016666666666667, 0.22222222222222
35980, 0.043478260869565, -0.016666666666667, 0.27777777777778
35981, 0.08695652173913, -0.016666666666667, 0.27777777777778
35982, 0.1304347826087, -0.016666666666667, 0.27777777777778
35983, 0.17391304347826, -0.016666666666667, 0.27777777777778
35984, 0.21739130434783, -0.016666666666667, 0.27777777777778
35985, 0.26086956521739, -0.016666666666667, 0.27777777777778
35986, 0.30434782608696, -0.016666666666667, 0.27777777777778
35987, 0.34782608695652, -0.016666666666667, 0.27777777777778
35988, 0.39130434782609, -0.016666666666667, 0.27777777777778
35989, 0.43478260869565, -0.016666666666667, 0.27777777777778
35990, 0.47826086956522, -0.016666666666667, 0.27777777777778
35991, 0.52173913043478, -0.016666666666667, 0.27777777777778
35992, 0.56521739130435, -0.016666666666667, 0.27777777777778
35993, 0.60869565217391, -0.016666666666667, 0.27777777777778
35994, 0.65217391304348, -0.016666666666667, 0.27777777777778
35995, 0.69565217391304, -0.016666666666667, 0.27777777777778
35996, 0.73913043478261, -0.016666666666667, 0.27777777777778
35997, 0.78260869565217, -0.016666666666667, 0.27777777777778
35998, 0.82608695652174, -0.016666666666667, 0.27777777777778
35999, 0.8695652173913, -0.016666666666667, 0.27777777777778
36000, 0.91304347826087, -0.016666666666667, 0.27777777777778
36001, 0.95652173913044, -0.016666666666667, 0.27777777777778
36002, 0.043478260869565, 0.016666666666667, 0.27777777777778
36003, 0.08695652173913, 0.016666666666667, 0.27777777777778
36004, 0.1304347826087, 0.016666666666667, 0.27777777777778
36005, 0.17391304347826, 0.016666666666667, 0.27777777777778
36006, 0.21739130434783, 0.016666666666667, 0.27777777777778
36007, 0.26086956521739, 0.016666666666667, 0.27777777777778
36008, 0.30434782608696, 0.016666666666667, 0.27777777777778
36009, 0.34782608695652, 0.016666666666667, 0.27777777777778
36010, 0.39130434782609, 0.016666666666667, 0.27777777777778
36011, 0.43478260869565, 0.016666666666667, 0.27777777777778
36012, 0.47826086956522, 0.016666666666667, 0.27777777777778
36013, 0.52173913043478, 0.016666666666667, 0.27777777777778
36014, 0.56521739130435, 0.016666666666667, 0.27777777777778
36015, 0.60869565217391, 0.016666666666667, 0.27777777777778
36016, 0.65217391304348, 0.016666666666667, 0.27777777777778
36017, 0.69565217391304, 0.016666666666667, 0.27777777777778
36018, 0.73913043478261, 0.016666666666667, 0.27777777777778
36019, 0.78260869565217, 0.016666666666667, 0.27777777777778
36020, 0.82608695652174, 0.016666666666667, 0.27777777777778
36021, 0.8695652173913, 0.016666666666667, 0.27777777777778
36022, 0.91304347826087, 0.016666666666667, 0.27777777777778
36023, 0.95652173913044, 0.016666666666667, 0.27777777777778
36024, 0.043478260869565, -0.016666666666667, 0.33333333333333
36025, 0.08695652173913, -0.016666666666667, 0.33333333333333
36026, 0.1304347826087, -0.016666666666667, 0.33333333333333
36027, 0.17391304347826, -0.016666666666667, 0.33333333333333
36028, 0.21739130434783, -0.016666666666667, 0.33333333333333
36029, 0.26086956521739, -0.016666666666667, 0.33333333333333
36030, 0.30434782608696, -0.016666666666667, 0.33333333333333
36031, 0.34782608695652, -0.016666666666667, 0.33333333333333
36032, 0.39130434782609, -0.016666666666667, 0.33333333333333
36033, 0.43478260869565, -0.016666666666667, 0.33333333333333
36034, 0.47826086956522, -0.016666666666667, 0.33333333333333
36035, 0.52173913043478, -0.016666666666667, 0.33333333333333
36036, 0.56521739130435, -0.016666666666667, 0.33333333333333
36037, 0.60869565217391, -0.016666666666667, 0.33333333333333
36038, 0.65217391304348, -0.016666666666667, 0.33333333333333
36039, 0.69565217391304, -0.016666666666667, 0.33333333333333
36040, 0.73913043478261, -0.016666666666667, 0.33333333333333
36041, 0.78260869565217, -0.016666666666667, 0.33333333333333
36042, 0.82608695652174, -0.016666666666667, 0.33333333333333
36043, 0.8695652173913, -0.016666666666667, 0.33333333333333
36044, 0.91304347826087, -0.016666666666667, 0.33333333333333
36045, 0.95652173913044, -0.016666666666667, 0.33333333333333
36046, 0.043478260869565, 0.016666666666667, 0.33333333333333
36047, 0.08695652173913, 0.016666666666667, 0.33333333333333
36048, 0.1304347826087, 0.016666666666667, 0.33333333333333
36049, 0.17391304347826, 0.016666666666667, 0.33333333333333
36050, 0.21739130434783, 0.016666666666667, 0.33333333333333
36051, 0.26086956521739, 0.016666666666667, 0.33333333333333
36052, 0.30434782608696, 0.016666666666667, 0.33333333333333
36053, 0.34782608695652, 0.016666666666667, 0.33333333333333
36054, 0.39130434782609, 0.016666666666667, 0.33333333333333
36055, 0.43478260869565, 0.016666666666667, 0.33333333333333
36056, 0.47826086956522, 0.016666666666667, 0.33333333333333
36057, 0.52173913043478, 0.016666666666667, 0.33333333333333
36058, 0.56521739130435, 0.016666666666667, 0.33333333333333
36059, 0.60869565217391, 0.016666666666667, 0.33333333333333
36060, 0.65217391304348, 0.016666666666667, 0.33333333333333
36061, 0.69565217391304, 0.016666666666667, 0.33333333333333
36062, 0.73913043478261, 0.016666666666667, 0.33333333333333
36063, 0.78260869565217, 0.016666666666667, 0.33333333333333
36064, 0.82608695652174, 0.016666666666667, 0.33333333333333
36065, 0.8695652173913, 0.016666666666667, 0.33333333333333
36066, 0.91304347826087, 0.016666666666667, 0.33333333333333
36067, 0.95652173913044, 0.016666666666667, 0.33333333333333
36068, 0.043478260869565, -0.016666666666667, 0.38888888888889
36069, 0.08695652173913, -0.016666666666667, 0.38888888888889
36070, 0.1304347826087, -0.016666666666667, 0.38888888888889
36071, 0.17391304347826, -0.016666666666667, 0.38888888888889
36072, 0.21739130434783, -0.016666666666667, 0.38888888888889
36073, 0.26086956521739, -0.016666666666667, 0.38888888888889
36074, 0.30434782608696, -0.016666666666667, 0.38888888888889
36075, 0.34782608695652, -0.016666666666667, 0.38888888888889
36076, 0.39130434782609, -0.016666666666667, 0.38888888888889
36077, 0.43478260869565, -0.016666666666667, 0.38888888888889
36078, 0.47826086956522, -0.016666666666667, 0.38888888888889
36079, 0.52173913043478, -0.016666666666667, 0.38888888888889
36080, 0.56521739130435, -0.016666666666667, 0.38888888888889
36081, 0.60869565217391, -0.016666666666667, 0.38888888888889
36082, 0.65217391304348, -0.016666666666667, 0.38888888888889
36083, 0.69565217391304, -0.016666666666667, 0.38888888888889
36084, 0.73913043478261, -0.016666666666667, 0.38888888888889
36085, 0.78260869565217, -0.016666666666667, 0.38888888888889
36086, 0.82608695652174, -0.016666666666667, 0.38888888888889
36087, 0.8695652173913, -0.016666666666667, 0.38888888888889
36088, 0.91304347826087, -0.016666666666667, 0.38888888888889
36089, 0.95652173913044, -0.016666666666667, 0.38888888888889
36090, 0.043478260869565, 0.016666666666667, 0.38888888888889
36091, 0.08695652173913, 0.016666666666667, 0.38888888888889
36092, 0.1304347826087, 0.016666666666667, 0.38888888888889
36093, 0.17391304347826, 0.016666666666667, 0.38888888888889
36094, 0.21739130434783, 0.016666666666667, 0.38888888888889
36095, 0.26086956521739, 0.016666666666667, 0.38888888888889
36096, 0.30434782608696, 0.016666666666667, 0.38888888888889
36097, 0.34782608695652, 0.016666666666667, 0.38888888888889
36098, 0.39130434782609, 0.016666666666667, 0.38888888888889
36099, 0.43478260869565, 0.016666666666667, 0.38888888888889
36100, 0.47826086956522, 0.016666666666667, 0.38888888888889
36101, 0.52173913043478, 0.016666666666667, 0.38888888888889
36102, 0.56521739130435, 0.016666666666667, 0.38888888888889
36103, 0.60869565217391, 0.016666666666667, 0.38888888888889
36104, 0.65217391304348, 0.016666666666667, 0.38888888888889
36105, 0.69565217391304, 0.016666666666667, 0.38888888888889
36106, 0.73913043478261, 0.016666666666667, 0.38888888888889
36107, 0.78260869565217, 0.016666666666667, 0.38888888888889
36108, 0.82608695652174, 0.016666666666667, 0.38888888888889
36109, 0.8695652173913, 0.016666666666667, 0.38888888888889
36110, 0.91304347826087, 0.016666666666667, 0.38888888888889
36111, 0.95652173913044, 0.016666666666667, 0.38888888888889
36112, 0.043478260869565, -0.016666666666667, 0.44444444444444
36113, 0.08695652173913, -0.016666666666667, 0.44444444444444
36114, 0.1304347826087, -0.016666666666667, 0.44444444444444
36115, 0.17391304347826, -0.016666666666667, 0.44444444444444
36116, 0.21739130434783, -0.016666666666667, 0.44444444444444
36117, 0.26086956521739, -0.016666666666667, 0.44444444444444
36118, 0.30434782608696, -0.016666666666667, 0.44444444444444
36119, 0.34782608695652, -0.016666666666667, 0.44444444444444
36120, 0.39130434782609, -0.016666666666667, 0.44444444444444
36121, 0.43478260869565, -0.016666666666667, 0.44444444444444
36122, 0.47826086956522, -0.016666666666667, 0.44444444444444
36123, 0.52173913043478, -0.016666666666667, 0.44444444444444
36124, 0.56521739130435, -0.016666666666667, 0.44444444444444
36125, 0.60869565217391, -0.016666666666667, 0.44444444444444
36126, 0.65217391304348, -0.016666666666667, 0.44444444444444
36127, 0.69565217391304, -0.016666666666667, 0.44444444444444
36128, 0.73913043478261, -0.016666666666667, 0.44444444444444
36129, 0.78260869565217, -0.016666666666667, 0.44444444444444
36130, 0.82608695652174, -0.016666666666667, 0.44444444444444
36131, 0.8695652173913, -0.016666666666667, 0.44444444444444
36132, 0.91304347826087, -0.016666666666667, 0.44444444444444
36133, 0.95652173913044, -0.016666666666667, 0.44444444444444
36134, 0.043478260869565, 0.016666666666667, 0.44444444444444
36135, 0.08695652173913, 0.016666666666667, 0.44444444444444
36136, 0.1304347826087, 0.016666666666667, 0.44444444444444
36137, 0.17391304347826, 0.016666666666667, 0.44444444444444
36138, 0.21739130434783, 0.016666666666667, 0.44444444444444
36139, 0.26086956521739, 0.016666666666667, 0.44444444444444
36140, 0.30434782608696, 0.016666666666667, 0.44444444444444
36141, 0.34782608695652, 0.016666666666667, 0.44444444444444
36142, 0.39130434782609, 0.016666666666667, 0.44444444444444
36143, 0.43478260869565, 0.016666666666667, 0.44444444444444
36144, 0.47826086956522, 0.016666666666667, 0.44444444444444
36145, 0.52173913043478, 0.016666666666667, 0.44444444444444
36146, 0.56521739130435, 0.016666666666667, 0.44444444444444
36147, 0.60869565217391, 0.016666666666667, 0.44444444444444
36148, 0.65217391304348, 0.016666666666667, 0.44444444444444
36149, 0.69565217391304, 0.016666666666667, 0.44444444444444
36150, 0.73913043478261, 0.016666666666667, 0.44444444444444
36151, 0.78260869565217, 0.016666666666667, 0.44444444444444
36152, 0.82608695652174, 0.016666666666667, 0.44444444444444
36153, 0.8695652173913, 0.016666666666667, 0.44444444444444
36154, 0.91304347826087, 0.016666666666667, 0.44444444444444
36155, 0.95652173913044, 0.016666666666667, 0.44444444444444
36156, 0.021739130434783, -0.016666666666667, 0.055555555555556
36157, 0.043478260869565, -0.033333333333333, 0.055555555555556
36158, 0.043478260869565, -0.016666666666667, 0.027777777777778
36159, 0.065217391304348, -0.016666666666667, 0.055555555555556
36160, 0.08695652173913, -0.033333333333333, 0.055555555555556
36161, 0.08695652173913, -0.016666666666667, 0.027777777777778
36162, 0.10869565217391, -0.016666666666667, 0.055555555555556
36163, 0.1304347826087, -0.033333333333333, 0.055555555555556
36164, 0.1304347826087, -0.016666666666667, 0.027777777777778
36165, 0.15217391304348, -0.016666666666667, 0.055555555555556
36166, 0.17391304347826, -0.033333333333333, 0.055555555555556
36167, 0.17391304347826, -0.016666666666667, 0.027777777777778
36168, 0.19565217391304, -0.016666666666667, 0.055555555555556
36169, 0.21739130434783, -0.033333333333333, 0.055555555555556
36170, 0.21739130434783, -0.016666666666667, 0.027777777777778
36171, 0.23913043478261, -0.016666666666667, 0.055555555555556
36172, 0.26086956521739, -0.033333333333333, 0.055555555555556
36173, 0.26086956521739, -0.016666666666667, 0.027777777777778
36174, 0.28260869565217, -0.016666666666667, 0.055555555555556
36175, 0.30434782608696, -0.033333333333333, 0.055555555555556
36176, 0.30434782608696, -0.016666666666667, 0.027777777777778
36177, 0.32608695652174, -0.016666666666667, 0.055555555555556
36178, 0.34782608695652, -0.033333333333333, 0.055555555555556
36179, 0.34782608695652, -0.016666666666667, 0.027777777777778
36180, 0.3695652173913, -0.016666666666667, 0.055555555555556
36181, 0.39130434782609, -0.033333333333333, 0.055555555555556
36182, 0.39130434782609, -0.016666666666667, 0.027777777777778
36183, 0.41304347826087, -0.016666666666667, 0.055555555555556
36184, 0.43478260869565, -0.033333333333333, 0.055555555555556
36185, 0.43478260869565, -0.016666666666667, 0.027777777777778
36186, 0.45652173913043, -0.016666666666667, 0.055555555555556
36187, 0.47826086956522, -0.033333333333333, 0.055555555555556
36188, 0.47826086956522, -0.016666666666667, 0.027777777777778
36189, 0.5, -0.016666666666667, 0.055555555555556
36190, 0.52173913043478, -0.033333333333333, 0.055555555555556
36191, 0.52173913043478, -0.016666666666667, 0.027777777777778
36192, 0.54347826086957, -0.016666666666667, 0.055555555555556
36193, 0.56521739130435, -0.033333333333333, 0.055555555555556
36194, 0.56521739130435, -0.016666666666667, 0.027777777777778
36195, 0.58695652173913, -0.016666666666667, 0.055555555555556
36196, 0.60869565217391, -0.033333333333333, 0.055555555555556
36197, 0.60869565217391, -0.016666666666667, 0.027777777777778
36198, 0.6304347826087, -0.016666666666667, 0.055555555555556
36199, 0.65217391304348, -0.033333333333333, 0.055555555555556
36200, 0.65217391304348, -0.016666666666667, 0.027777777777778
36201, 0.67391304347826, -0.016666666666667, 0.055555555555556
36202, 0.69565217391304, -0.033333333333333, 0.055555555555556
36203, 0.69565217391304, -0.016666666666667, 0.027777777777778
36204, 0.71739130434783, -0.016666666666667, 0.055555555555556
36205, 0.73913043478261, -0.033333333333333, 0.055555555555556
36206, 0.73913043478261, -0.016666666666667, 0.027777777777778
36207, 0.76086956521739, -0.016666666666667, 0.055555555555556
36208, 0.78260869565217, -0.033333333333333, 0.055555555555556
36209, 0.78260869565217, -0.016666666666667, 0.027777777777778
36210, 0.80434782608696, -0.016666666666667, 0.055555555555556
36211, 0.82608695652174, -0.033333333333333, 0.055555555555556
36212, 0.82608695652174, -0.016666666666667, 0.027777777777778
36213, 0.84782608695652, -0.016666666666667, 0.055555555555556
36214, 0.8695652173913, -0.033333333333333, 0.055555555555556
36215, 0.8695652173913, -0.016666666666667, 0.027777777777778
36216, 0.89130434782609, -0.016666666666667, 0.055555555555556
36217, 0.91304347826087, -0.033333333333333, 0.055555555555556
36218, 0.91304347826087, -0.016666666666667, 0.027777777777778
36219, 0.93478260869565, -0.016666666666667, 0.055555555555556
36220, 0.95652173913043, -0.033333333333333, 0.055555555555556
36221, 0.95652173913043, -0.016666666666667, 0.027777777777778
36222, 0.97826086956522, -0.016666666666667, 0.055555555555556
36223, 0.021739130434783, 0.016666666666667, 0.055555555555556
36224, 0.043478260869565, 5.7245874707235e-17, 0.055555555555556
36225, 0.043478260869565, 0.016666666666667, 0.027777777777778
36226, 0.065217391304348, 0.016666666666667, 0.055555555555556
36227, 0.08695652173913, 6.5919492087119e-17, 0.055555555555556
36228, 0.08695652173913, 0.016666666666667, 0.027777777777778
36229, 0.10869565217391, 0.016666666666667, 0.055555555555556
36230, 0.1304347826087, 5.7245874707235e-17, 0.055555555555556
36231, 0.1304347826087, 0.016666666666667, 0.027777777777778
36232, 0.15217391304348, 0.016666666666667, 0.055555555555556
36233, 0.17391304347826, 5.7245874707235e-17, 0.055555555555556
36234, 0.17391304347826, 0.016666666666667, 0.027777777777778
36235, 0.19565217391304, 0.016666666666667, 0.055555555555556
36236, 0.21739130434783, 5.3776427755281e-17, 0.055555555555556
36237, 0.21739130434783, 0.016666666666667, 0.027777777777778
36238, 0.23913043478261, 0.016666666666667, 0.055555555555556
36239, 0.26086956521739, 5.3776427755281e-17, 0.055555555555556
36240, 0.26086956521739, 0.016666666666667, 0.027777777777778
36241, 0.28260869565217, 0.016666666666667, 0.055555555555556
36242, 0.30434782608696, 5.8980598183211e-17, 0.055555555555556
36243, 0.30434782608696, 0.016666666666667, 0.027777777777778
36244, 0.32608695652174, 0.016666666666667, 0.055555555555556
36245, 0.34782608695652, 6.0715321659188e-17, 0.055555555555556
36246, 0.34782608695652, 0.016666666666667, 0.027777777777778
36247, 0.3695652173913, 0.016666666666667, 0.055555555555556
36248, 0.39130434782609, 5.5511151231258e-17, 0.055555555555556
36249, 0.39130434782609, 0.016666666666667, 0.027777777777778
36250, 0.41304347826087, 0.016666666666667, 0.055555555555556
36251, 0.43478260869565, 5.8980598183211e-17, 0.055555555555556
36252, 0.43478260869565, 0.016666666666667, 0.027777777777778
36253, 0.45652173913043, 0.016666666666667, 0.055555555555556
36254, 0.47826086956522, 5.7245874707235e-17, 0.055555555555556
36255, 0.47826086956522, 0.016666666666667, 0.027777777777778
36256, 0.5, 0.016666666666667, 0.055555555555556
36257, 0.52173913043478, 5.7245874707235e-17, 0.055555555555556
36258, 0.52173913043478, 0.016666666666667, 0.027777777777778
36259, 0.54347826086957, 0.016666666666667, 0.055555555555556
36260, 0.56521739130435, 6.0715321659188e-17, 0.055555555555556
36261, 0.56521739130435, 0.016666666666667, 0.027777777777778
36262, 0.58695652173913, 0.016666666666667, 0.055555555555556
36263, 0.60869565217391, 5.7245874707235e-17, 0.055555555555556
36264, 0.60869565217391, 0.016666666666667, 0.027777777777778
36265, 0.6304347826087, 0.016666666666667, 0.055555555555556
36266, 0.65217391304348, 5.8980598183211e-17, 0.055555555555556
36267, 0.65217391304348, 0.016666666666667, 0.027777777777778
36268, 0.67391304347826, 0.016666666666667, 0.055555555555556
36269, 0.69565217391304, 5.7245874707235e-17, 0.055555555555556
36270, 0.69565217391304, 0.016666666666667, 0.027777777777778
36271, 0.71739130434783, 0.016666666666667, 0.055555555555556
36272, 0.73913043478261, 5.7245874707235e-17, 0.055555555555556
36273, 0.73913043478261, 0.016666666666667, 0.027777777777778
36274, 0.76086956521739, 0.016666666666667, 0.055555555555556
36275, 0.78260869565217, 6.0715321659188e-17, 0.055555555555556
36276, 0.78260869565217, 0.016666666666667, 0.027777777777778
36277, 0.80434782608696, 0.016666666666667, 0.055555555555556
36278, 0.82608695652174, 5.8980598183211e-17, 0.055555555555556
36279, 0.82608695652174, 0.016666666666667, 0.027777777777778
36280, 0.84782608695652, 0.016666666666667, 0.055555555555556
36281, 0.8695652173913, 5.2041704279304e-17, 0.055555555555556
36282, 0.8695652173913, 0.016666666666667, 0.027777777777778
36283, 0.89130434782609, 0.016666666666667, 0.055555555555556
36284, 0.91304347826087, 5.8980598183211e-17, 0.055555555555556
36285, 0.91304347826087, 0.016666666666667, 0.027777777777778
36286, 0.93478260869565, 0.016666666666667, 0.055555555555556
36287, 0.95652173913044, 6.4184768611142e-17, 0.055555555555556
36288, 0.95652173913043, 0.016666666666667, 0.027777777777778
36289, 0.97826086956522, 0.016666666666667, 0.055555555555556
36290, 0.043478260869565, 0.033333333333333, 0.055555555555556
36291, 0.08695652173913, 0.033333333333333, 0.055555555555556
36292, 0.1304347826087, 0.033333333333333, 0.055555555555556
36293, 0.17391304347826, 0.033333333333333, 0.055555555555556
36294, 0.21739130434783, 0.033333333333333, 0.055555555555556
36295, 0.26086956521739, 0.033333333333333, 0.055555555555556
36296, 0.30434782608696, 0.033333333333333, 0.055555555555556
36297, 0.34782608695652, 0.033333333333333, 0.055555555555556
36298, 0.39130434782609, 0.033333333333333, 0.055555555555556
36299, 0.43478260869565, 0.033333333333333, 0.055555555555556
36300, 0.47826086956522, 0.033333333333333, 0.055555555555556
36301, 0.52173913043478, 0.033333333333333, 0.055555555555556
36302, 0.56521739130435, 0.033333333333333, 0.055555555555556
36303, 0.60869565217391, 0.033333333333333, 0.055555555555556
36304, 0.65217391304348, 0.033333333333333, 0.055555555555556
36305, 0.69565217391304, 0.033333333333333, 0.055555555555556
36306, 0.73913043478261, 0.033333333333333, 0.055555555555556
36307, 0.78260869565217, 0.033333333333333, 0.055555555555556
36308, 0.82608695652174, 0.033333333333333, 0.055555555555556
36309, 0.8695652173913, 0.033333333333333, 0.055555555555556
36310, 0.91304347826087, 0.033333333333333, 0.055555555555556
36311, 0.95652173913043, 0.033333333333333, 0.055555555555556
36312, 0.021739130434783, -0.016666666666667, 0.11111111111111
36313, 0.043478260869565, -0.033333333333333, 0.11111111111111
36314, 0.043478260869565, -0.016666666666667, 0.083333333333333
36315, 0.065217391304348, -0.016666666666667, 0.11111111111111
36316, 0.08695652173913, -0.033333333333333, 0.11111111111111
36317, 0.08695652173913, -0.016666666666667, 0.083333333333333
36318, 0.10869565217391, -0.016666666666667, 0.11111111111111
36319, 0.1304347826087, -0.033333333333333, 0.11111111111111
36320, 0.1304347826087, -0.016666666666667, 0.083333333333333
36321, 0.15217391304348, -0.016666666666667, 0.11111111111111
36322, 0.17391304347826, -0.033333333333333, 0.11111111111111
36323, 0.17391304347826, -0.016666666666667, 0.083333333333333
36324, 0.19565217391304, -0.016666666666667, 0.11111111111111
36325, 0.21739130434783, -0.033333333333333, 0.11111111111111
36326, 0.21739130434783, -0.016666666666667, 0.083333333333333
36327, 0.23913043478261, -0.016666666666667, 0.11111111111111
36328, 0.26086956521739, -0.033333333333333, 0.11111111111111
36329, 0.26086956521739, -0.016666666666667, 0.083333333333333
36330, 0.28260869565217, -0.016666666666667, 0.11111111111111
36331, 0.30434782608696, -0.033333333333333, 0.11111111111111
36332, 0.30434782608696, -0.016666666666667, 0.083333333333333
36333, 0.32608695652174, -0.016666666666667, 0.11111111111111
36334, 0.34782608695652, -0.033333333333333, 0.11111111111111
36335, 0.34782608695652, -0.016666666666667, 0.083333333333333
36336, 0.3695652173913, -0.016666666666667, 0.11111111111111
36337, 0.39130434782609, -0.033333333333333, 0.11111111111111
36338, 0.39130434782609, -0.016666666666667, 0.083333333333333
36339, 0.41304347826087, -0.016666666666667, 0.11111111111111
36340, 0.43478260869565, -0.033333333333333, 0.11111111111111
36341, 0.43478260869565, -0.016666666666667, 0.083333333333333
36342, 0.45652173913043, -0.016666666666667, 0.11111111111111
36343, 0.47826086956522, -0.033333333333333, 0.11111111111111
36344, 0.47826086956522, -0.016666666666667, 0.083333333333333
36345, 0.5, -0.016666666666667, 0.11111111111111
36346, 0.52173913043478, -0.033333333333333, 0.11111111111111
36347, 0.52173913043478, -0.016666666666667, 0.083333333333333
36348, 0.54347826086957, -0.016666666666667, 0.11111111111111
36349, 0.56521739130435, -0.033333333333333, 0.11111111111111
36350, 0.56521739130435, -0.016666666666667, 0.083333333333333
36351, 0.58695652173913, -0.016666666666667, 0.11111111111111
36352, 0.60869565217391, -0.033333333333333, 0.11111111111111
36353, 0.60869565217391, -0.016666666666667, 0.083333333333333
36354, 0.6304347826087, -0.016666666666667, 0.11111111111111
36355, 0.65217391304348, -0.033333333333333, 0.11111111111111
36356, 0.65217391304348, -0.016666666666667, 0.083333333333333
36357, 0.67391304347826, -0.016666666666667, 0.11111111111111
36358, 0.69565217391304, -0.033333333333333, 0.11111111111111
36359, 0.69565217391304, -0.016666666666667, 0.083333333333333
36360, 0.71739130434783, -0.016666666666667, 0.11111111111111
36361, 0.73913043478261, -0.033333333333333, 0.11111111111111
36362, 0.73913043478261, -0.016666666666667, 0.083333333333333
36363, 0.76086956521739, -0.016666666666667, 0.11111111111111
36364, 0.78260869565217, -0.033333333333333, 0.11111111111111
36365, 0.78260869565217, -0.016666666666667, 0.083333333333333
36366, 0.80434782608696, -0.016666666666667, 0.11111111111111
36367, 0.82608695652174, -0.033333333333333, 0.11111111111111
36368, 0.82608695652174, -0.016666666666667, 0.083333333333333
36369, 0.84782608695652, -0.016666666666667, 0.11111111111111
36370, 0.8695652173913, -0.033333333333333, 0.11111111111111
36371, 0.8695652173913, -0.016666666666667, 0.083333333333333
36372, 0.89130434782609, -0.016666666666667, 0.11111111111111
36373, 0.91304347826087, -0.033333333333333, 0.11111111111111
36374, 0.91304347826087, -0.016666666666667, 0.083333333333333
36375, 0.93478260869565, -0.016666666666667, 0.11111111111111
36376, 0.95652173913044, -0.033333333333333, 0.11111111111111
36377, 0.95652173913044, -0.016666666666667, 0.083333333333333
36378, 0.97826086956522, -0.016666666666667, 0.11111111111111
36379, 0.021739130434783, 0.016666666666667, 0.11111111111111
36380, 0.043478260869565, 6.2450045135165e-17, 0.11111111111111
36381, 0.043478260869565, 0.016666666666667, 0.083333333333333
36382, 0.065217391304348, 0.016666666666667, 0.11111111111111
36383, 0.08695652173913, 5.8980598183211e-17, 0.11111111111111
36384, 0.08695652173913, 0.016666666666667, 0.083333333333333
36385, 0.10869565217391, 0.016666666666667, 0.11111111111111
36386, 0.1304347826087, 5.7245874707235e-17, 0.11111111111111
36387, 0.1304347826087, 0.016666666666667, 0.083333333333333
36388, 0.15217391304348, 0.016666666666667, 0.11111111111111
36389, 0.17391304347826, 5.5511151231258e-17, 0.11111111111111
36390, 0.17391304347826, 0.016666666666667, 0.083333333333333
36391, 0.19565217391304, 0.016666666666667, 0.11111111111111
36392, 0.21739130434783, 5.5511151231258e-17, 0.11111111111111
36393, 0.21739130434783, 0.016666666666667, 0.083333333333333
36394, 0.23913043478261, 0.016666666666667, 0.11111111111111
36395, 0.26086956521739, 6.0715321659188e-17, 0.11111111111111
36396, 0.26086956521739, 0.016666666666667, 0.083333333333333
36397, 0.28260869565217, 0.016666666666667, 0.11111111111111
36398, 0.30434782608696, 5.5511151231258e-17, 0.11111111111111
36399, 0.30434782608696, 0.016666666666667, 0.083333333333333
36400, 0.32608695652174, 0.016666666666667, 0.11111111111111
36401, 0.34782608695652, 5.7245874707235e-17, 0.11111111111111
36402, 0.34782608695652, 0.016666666666667, 0.083333333333333
36403, 0.3695652173913, 0.016666666666667, 0.11111111111111
36404, 0.39130434782609, 5.7245874707235e-17, 0.11111111111111
36405, 0.39130434782609, 0.016666666666667, 0.083333333333333
36406, 0.41304347826087, 0.016666666666667, 0.11111111111111
36407, 0.43478260869565, 5.5511151231258e-17, 0.11111111111111
36408, 0.43478260869565, 0.016666666666667, 0.083333333333333
36409, 0.45652173913043, 0.016666666666667, 0.11111111111111
36410, 0.47826086956522, 5.5511151231258e-17, 0.11111111111111
36411, 0.47826086956522, 0.016666666666667, 0.083333333333333
36412, 0.5, 0.016666666666667, 0.11111111111111
36413, 0.52173913043478, 5.5511151231258e-17, 0.11111111111111
36414, 0.52173913043478, 0.016666666666667, 0.083333333333333
36415, 0.54347826086957, 0.016666666666667, 0.11111111111111
36416, 0.56521739130435, 5.8980598183211e-17, 0.11111111111111
36417, 0.56521739130435, 0.016666666666667, 0.083333333333333
36418, 0.58695652173913, 0.016666666666667, 0.11111111111111
36419, 0.60869565217391, 5.7245874707235e-17, 0.11111111111111
36420, 0.60869565217391, 0.016666666666667, 0.083333333333333
36421, 0.6304347826087, 0.016666666666667, 0.11111111111111
36422, 0.65217391304348, 5.5511151231258e-17, 0.11111111111111
36423, 0.65217391304348, 0.016666666666667, 0.083333333333333
36424, 0.67391304347826, 0.016666666666667, 0.11111111111111
36425, 0.69565217391304, 5.7245874707235e-17, 0.11111111111111
36426, 0.69565217391304, 0.016666666666667, 0.083333333333333
36427, 0.71739130434783, 0.016666666666667, 0.11111111111111
36428, 0.73913043478261, 5.5511151231258e-17, 0.11111111111111
36429, 0.73913043478261, 0.016666666666667, 0.083333333333333
36430, 0.76086956521739, 0.016666666666667, 0.11111111111111
36431, 0.78260869565217, 5.8980598183211e-17, 0.11111111111111
36432, 0.78260869565217, 0.016666666666667, 0.083333333333333
36433, 0.80434782608696, 0.016666666666667, 0.11111111111111
36434, 0.82608695652174, 5.3776427755281e-17, 0.11111111111111
36435, 0.82608695652174, 0.016666666666667, 0.083333333333333
36436, 0.84782608695652, 0.016666666666667, 0.11111111111111
36437, 0.8695652173913, 5.5511151231258e-17, 0.11111111111111
36438, 0.8695652173913, 0.016666666666667, 0.083333333333333
36439, 0.89130434782609, 0.016666666666667, 0.11111111111111
36440, 0.91304347826087, 5.8980598183211e-17, 0.11111111111111
36441, 0.91304347826087, 0.016666666666667, 0.083333333333333
36442, 0.93478260869565, 0.016666666666667, 0.11111111111111
36443, 0.95652173913044, 5.8980598183211e-17, 0.11111111111111
36444, 0.95652173913044, 0.016666666666667, 0.083333333333333
36445, 0.97826086956522, 0.016666666666667, 0.11111111111111
36446, 0.043478260869565, 0.033333333333333, 0.11111111111111
36447, 0.08695652173913, 0.033333333333333, 0.11111111111111
36448, 0.1304347826087, 0.033333333333333, 0.11111111111111
36449, 0.17391304347826, 0.033333333333333, 0.11111111111111
36450, 0.21739130434783, 0.033333333333333, 0.11111111111111
36451, 0.26086956521739, 0.033333333333333, 0.11111111111111
36452, 0.30434782608696, 0.033333333333333, 0.11111111111111
36453, 0.34782608695652, 0.033333333333333, 0.11111111111111
36454, 0.39130434782609, 0.033333333333333, 0.11111111111111
36455, 0.43478260869565, 0.033333333333333, 0.11111111111111
36456, 0.47826086956522, 0.033333333333333, 0.11111111111111
36457, 0.52173913043478, 0.033333333333333, 0.11111111111111
36458, 0.56521739130435, 0.033333333333333, 0.11111111111111
36459, 0.60869565217391, 0.033333333333333, 0.11111111111111
36460, 0.65217391304348, 0.033333333333333, 0.11111111111111
36461, 0.69565217391304, 0.033333333333333, 0.11111111111111
36462, 0.73913043478261, 0.033333333333333, 0.11111111111111
36463, 0.78260869565217, 0.033333333333333, 0.11111111111111
36464, 0.82608695652174, 0.033333333333333, 0.11111111111111
36465, 0.8695652173913, 0.033333333333333, 0.11111111111111
36466, 0.91304347826087, 0.033333333333333, 0.11111111111111
36467, 0.95652173913043, 0.033333333333333, 0.11111111111111
36468, 0.021739130434783, -0.016666666666667, 0.16666666666667
36469, 0.043478260869565, -0.033333333333333, 0.16666666666667
36470, 0.043478260869565, -0.016666666666667, 0.13888888888889
36471, 0.065217391304348, -0.016666666666667, 0.16666666666667
36472, 0.08695652173913, -0.033333333333333, 0.16666666666667
36473, 0.08695652173913, -0.016666666666667, 0.13888888888889
36474, 0.10869565217391, -0.016666666666667, 0.16666666666667
36475, 0.1304347826087, -0.033333333333333, 0.16666666666667
36476, 0.1304347826087, -0.016666666666667, 0.13888888888889
36477, 0.15217391304348, -0.016666666666667, 0.16666666666667
36478, 0.17391304347826, -0.033333333333333, 0.16666666666667
36479, 0.17391304347826, -0.016666666666667, 0.13888888888889
36480, 0.19565217391304, -0.016666666666667, 0.16666666666667
36481, 0.21739130434783, -0.033333333333333, 0.16666666666667
36482, 0.21739130434783, -0.016666666666667, 0.13888888888889
36483, 0.23913043478261, -0.016666666666667, 0.16666666666667
36484, 0.26086956521739, -0.033333333333333, 0.16666666666667
36485, 0.26086956521739, -0.016666666666667, 0.13888888888889
36486, 0.28260869565217, -0.016666666666667, 0.16666666666667
36487, 0.30434782608696, -0.033333333333333, 0.16666666666667
36488, 0.30434782608696, -0.016666666666667, 0.13888888888889
36489, 0.32608695652174, -0.016666666666667, 0.16666666666667
36490, 0.34782608695652, -0.033333333333333, 0.16666666666667
36491, 0.34782608695652, -0.016666666666667, 0.13888888888889
36492, 0.3695652173913, -0.016666666666667, 0.16666666666667
36493, 0.39130434782609, -0.033333333333333, 0.16666666666667
36494, 0.39130434782609, -0.016666666666667, 0.13888888888889
36495, 0.41304347826087, -0.016666666666667, 0.16666666666667
36496, 0.43478260869565, -0.033333333333333, 0.16666666666667
36497, 0.43478260869565, -0.016666666666667, 0.13888888888889
36498, 0.45652173913043, -0.016666666666667, 0.16666666666667
36499, 0.47826086956522, -0.033333333333333, 0.16666666666667
36500, 0.47826086956522, -0.016666666666667, 0.13888888888889
36501, 0.5, -0.016666666666667, 0.16666666666667
36502, 0.52173913043478, -0.033333333333333, 0.16666666666667
36503, 0.52173913043478, -0.016666666666667, 0.13888888888889
36504, 0.54347826086957, -0.016666666666667, 0.16666666666667
36505, 0.56521739130435, -0.033333333333333, 0.16666666666667
36506, 0.56521739130435, -0.016666666666667, 0.13888888888889
36507, 0.58695652173913, -0.016666666666667, 0.16666666666667
36508, 0.60869565217391, -0.033333333333333, 0.16666666666667
36509, 0.60869565217391, -0.016666666666667, 0.13888888888889
36510, 0.6304347826087, -0.016666666666667, 0.16666666666667
36511, 0.65217391304348, -0.033333333333333, 0.16666666666667
36512, 0.65217391304348, -0.016666666666667, 0.13888888888889
36513, 0.67391304347826, -0.016666666666667, 0.16666666666667
36514, 0.69565217391304, -0.033333333333333, 0.16666666666667
36515, 0.69565217391304, -0.016666666666667, 0.13888888888889
36516, 0.71739130434783, -0.016666666666667, 0.16666666666667
36517, 0.73913043478261, -0.033333333333333, 0.16666666666667
36518, 0.73913043478261, -0.016666666666667, 0.13888888888889
36519, 0.76086956521739, -0.016666666666667, 0.16666666666667
36520, 0.78260869565217, -0.033333333333333, 0.16666666666667
36521, 0.78260869565217, -0.016666666666667, 0.13888888888889
36522, 0.80434782608696, -0.016666666666667, 0.16666666666667
36523, 0.82608695652174, -0.033333333333333, 0.16666666666667
36524, 0.82608695652174, -0.016666666666667, 0.13888888888889
36525, 0.84782608695652, -0.016666666666667, 0.16666666666667
36526, 0.8695652173913, -0.033333333333333, 0.16666666666667
36527, 0.8695652173913, -0.016666666666667, 0.13888888888889
36528, 0.89130434782609, -0.016666666666667, 0.16666666666667
36529, 0.91304347826087, -0.033333333333333, 0.16666666666667
36530, 0.91304347826087, -0.016666666666667, 0.13888888888889
36531, 0.93478260869565, -0.016666666666667, 0.16666666666667
36532, 0.95652173913043, -0.033333333333333, 0.16666666666667
36533, 0.95652173913044, -0.016666666666667, 0.13888888888889
36534, 0.97826086956522, -0.016666666666667, 0.16666666666667
36535, 0.021739130434783, 0.016666666666667, 0.16666666666667
36536, 0.043478260869565, 7.1123662515049e-17, 0.16666666666667
36537, 0.043478260869565, 0.016666666666667, 0.13888888888889
36538, 0.065217391304348, 0.016666666666667, 0.16666666666667
36539, 0.08695652173913, 6.4184768611142e-17, 0.16666666666667
36540, 0.08695652173913, 0.016666666666667, 0.13888888888889
36541, 0.10869565217391, 0.016666666666667, 0.16666666666667
36542, 0.1304347826087, 6.0715321659188e-17, 0.16666666666667
36543, 0.1304347826087, 0.016666666666667, 0.13888888888889
36544, 0.15217391304348, 0.016666666666667, 0.16666666666667
36545, 0.17391304347826, 5.5511151231258e-17, 0.16666666666667
36546, 0.17391304347826, 0.016666666666667, 0.13888888888889
36547, 0.19565217391304, 0.016666666666667, 0.16666666666667
36548, 0.21739130434783, 6.5919492087119e-17, 0.16666666666667
36549, 0.21739130434783, 0.016666666666667, 0.13888888888889
36550, 0.23913043478261, 0.016666666666667, 0.16666666666667
36551, 0.26086956521739, 6.0715321659188e-17, 0.16666666666667
36552, 0.26086956521739, 0.016666666666667, 0.13888888888889
36553, 0.28260869565217, 0.016666666666667, 0.16666666666667
36554, 0.30434782608696, 6.0715321659188e-17, 0.16666666666667
36555, 0.30434782608696, 0.016666666666667, 0.13888888888889
36556, 0.32608695652174, 0.016666666666667, 0.16666666666667
36557, 0.34782608695652, 6.0715321659188e-17, 0.16666666666667
36558, 0.34782608695652, 0.016666666666667, 0.13888888888889
36559, 0.3695652173913, 0.016666666666667, 0.16666666666667
36560, 0.39130434782609, 6.4184768611142e-17, 0.16666666666667
36561, 0.39130434782609, 0.016666666666667, 0.13888888888889
36562, 0.41304347826087, 0.016666666666667, 0.16666666666667
36563, 0.43478260869565, 5.8980598183211e-17, 0.16666666666667
36564, 0.43478260869565, 0.016666666666667, 0.13888888888889
36565, 0.45652173913043, 0.016666666666667, 0.16666666666667
36566, 0.47826086956522, 6.4184768611142e-17, 0.16666666666667
36567, 0.47826086956522, 0.016666666666667, 0.13888888888889
36568, 0.5, 0.016666666666667, 0.16666666666667
36569, 0.52173913043478, 6.0715321659188e-17, 0.16666666666667
36570, 0.52173913043478, 0.016666666666667, 0.13888888888889
36571, 0.54347826086957, 0.016666666666667, 0.16666666666667
36572, 0.56521739130435, 6.0715321659188e-17, 0.16666666666667
36573, 0.56521739130435, 0.016666666666667, 0.13888888888889
36574, 0.58695652173913, 0.016666666666667, 0.16666666666667
36575, 0.60869565217391, 6.2450045135165e-17, 0.16666666666667
36576, 0.60869565217391, 0.016666666666667, 0.13888888888889
36577, 0.6304347826087, 0.016666666666667, 0.16666666666667
36578, 0.65217391304348, 6.4184768611142e-17, 0.16666666666667
36579, 0.65217391304348, 0.016666666666667, 0.13888888888889
36580, 0.67391304347826, 0.016666666666667, 0.16666666666667
36581, 0.69565217391304, 6.5919492087119e-17, 0.16666666666667
36582, 0.69565217391304, 0.016666666666667, 0.13888888888889
36583, 0.71739130434783, 0.016666666666667, 0.16666666666667
36584, 0.73913043478261, 6.2450045135165e-17, 0.16666666666667
36585, 0.73913043478261, 0.016666666666667, 0.13888888888889
36586, 0.76086956521739, 0.016666666666667, 0.16666666666667
36587, 0.78260869565217, 6.4184768611142e-17, 0.16666666666667
36588, 0.78260869565217, 0.016666666666667, 0.13888888888889
36589, 0.80434782608696, 0.016666666666667, 0.16666666666667
36590, 0.82608695652174, 6.0715321659188e-17, 0.16666666666667
36591, 0.82608695652174, 0.016666666666667, 0.13888888888889
36592, 0.84782608695652, 0.016666666666667, 0.16666666666667
36593, 0.8695652173913, 6.2450045135165e-17, 0.16666666666667
36594, 0.8695652173913, 0.016666666666667, 0.13888888888889
36595, 0.89130434782609, 0.016666666666667, 0.16666666666667
36596, 0.91304347826087, 6.2450045135165e-17, 0.16666666666667
36597, 0.91304347826087, 0.016666666666667, 0.13888888888889
36598, 0.93478260869565, 0.016666666666667, 0.16666666666667
36599, 0.95652173913044, 6.9388939039072e-17, 0.16666666666667
36600, 0.95652173913044, 0.016666666666667, 0.13888888888889
36601, 0.97826086956522, 0.016666666666667, 0.16666666666667
36602, 0.043478260869565, 0.033333333333333, 0.16666666666667
36603, 0.08695652173913, 0.033333333333333, 0.16666666666667
36604, 0.1304347826087, 0.033333333333333, 0.16666666666667
36605, 0.17391304347826, 0.033333333333333, 0.16666666666667
36606, 0.21739130434783, 0.033333333333333, 0.16666666666667
36607, 0.26086956521739, 0.033333333333333, 0.16666666666667
36608, 0.30434782608696, 0.033333333333333, 0.16666666666667
36609, 0.34782608695652, 0.033333333333333, 0.16666666666667
36610, 0.39130434782609, 0.033333333333333, 0.16666666666667
36611, 0.43478260869565, 0.033333333333333, 0.16666666666667
36612, 0.47826086956522, 0.033333333333333, 0.16666666666667
36613, 0.52173913043478, 0.033333333333333, 0.16666666666667
36614, 0.56521739130435, 0.033333333333333, 0.16666666666667
36615, 0.60869565217391, 0.033333333333333, 0.16666666666667
36616, 0.65217391304348, 0.033333333333333, 0.16666666666667
36617, 0.69565217391304, 0.033333333333333, 0.16666666666667
36618, 0.73913043478261, 0.033333333333333, 0.16666666666667
36619, 0.78260869565217, 0.033333333333333, 0.16666666666667
36620, 0.82608695652174, 0.033333333333333, 0.16666666666667
36621, 0.8695652173913, 0.033333333333333, 0.16666666666667
36622, 0.91304347826087, 0.033333333333333, 0.16666666666667
36623, 0.95652173913043, 0.033333333333333, 0.16666666666667
36624, 0.021739130434783, -0.016666666666667, 0.22222222222222
36625, 0.043478260869565, -0.033333333333333, 0.22222222222222
36626, 0.043478260869565, -0.016666666666667, 0.19444444444444
36627, 0.065217391304348, -0.016666666666667, 0.22222222222222
36628, 0.08695652173913, -0.033333333333333, 0.22222222222222
36629, 0.08695652173913, -0.016666666666667, 0.19444444444444
36630, 0.10869565217391, -0.016666666666667, 0.22222222222222
36631, 0.1304347826087, -0.033333333333333, 0.22222222222222
36632, 0.1304347826087, -0.016666666666667, 0.19444444444444
36633, 0.15217391304348, -0.016666666666667, 0.22222222222222
36634, 0.17391304347826, -0.033333333333333, 0.22222222222222
36635, 0.17391304347826, -0.016666666666667, 0.19444444444444
36636, 0.19565217391304, -0.016666666666667, 0.22222222222222
36637, 0.21739130434783, -0.033333333333333, 0.22222222222222
36638, 0.21739130434783, -0.016666666666667, 0.19444444444444
36639, 0.23913043478261, -0.016666666666667, 0.22222222222222
36640, 0.26086956521739, -0.033333333333333, 0.22222222222222
36641, 0.26086956521739, -0.016666666666667, 0.19444444444444
36642, 0.28260869565217, -0.016666666666667, 0.22222222222222
36643, 0.30434782608696, -0.033333333333333, 0.22222222222222
36644, 0.30434782608696, -0.016666666666667, 0.19444444444444
36645, 0.32608695652174, -0.016666666666667, 0.22222222222222
36646, 0.34782608695652, -0.033333333333333, 0.22222222222222
36647, 0.34782608695652, -0.016666666666667, 0.19444444444444
36648, 0.3695652173913, -0.016666666666667, 0.22222222222222
36649, 0.39130434782609, -0.033333333333333, 0.22222222222222
36650, 0.39130434782609, -0.016666666666667, 0.19444444444444
36651, 0.41304347826087, -0.016666666666667, 0.22222222222222
36652, 0.43478260869565, -0.033333333333333, 0.22222222222222
36653, 0.43478260869565, -0.016666666666667, 0.19444444444444
36654, 0.45652173913043, -0.016666666666667, 0.22222222222222
36655, 0.47826086956522, -0.033333333333333, 0.22222222222222
36656, 0.47826086956522, -0.016666666666667, 0.19444444444444
36657, 0.5, -0.016666666666667, 0.22222222222222
36658, 0.52173913043478, -0.033333333333333, 0.22222222222222
36659, 0.52173913043478, -0.016666666666667, 0.19444444444444
36660, 0.54347826086957, -0.016666666666667, 0.22222222222222
36661, 0.56521739130435, -0.033333333333333, 0.22222222222222
36662, 0.56521739130435, -0.016666666666667, 0.19444444444444
36663, 0.58695652173913, -0.016666666666667, 0.22222222222222
36664, 0.60869565217391, -0.033333333333333, 0.22222222222222
36665, 0.60869565217391, -0.016666666666667, 0.19444444444444
36666, 0.6304347826087, -0.016666666666667, 0.22222222222222
36667, 0.65217391304348, -0.033333333333333, 0.22222222222222
36668, 0.65217391304348, -0.016666666666667, 0.19444444444444
36669, 0.67391304347826, -0.016666666666667, 0.22222222222222
36670, 0.69565217391304, -0.033333333333333, 0.22222222222222
36671, 0.69565217391304, -0.016666666666667, 0.19444444444444
36672, 0.71739130434783, -0.016666666666667, 0.22222222222222
36673, 0.73913043478261, -0.033333333333333, 0.22222222222222
36674, 0.73913043478261, -0.016666666666667, 0.19444444444444
36675, 0.76086956521739, -0.016666666666667, 0.22222222222222
36676, 0.78260869565217, -0.033333333333333, 0.22222222222222
36677, 0.78260869565217, -0.016666666666667, 0.19444444444444
36678, 0.80434782608696, -0.016666666666667, 0.22222222222222
36679, 0.82608695652174, -0.033333333333333, 0.22222222222222
36680, 0.82608695652174, -0.016666666666667, 0.19444444444444
36681, 0.84782608695652, -0.016666666666667, 0.22222222222222
36682, 0.8695652173913, -0.033333333333333, 0.22222222222222
36683, 0.8695652173913, -0.016666666666667, 0.19444444444444
36684, 0.89130434782609, -0.016666666666667, 0.22222222222222
36685, 0.91304347826087, -0.033333333333333, 0.22222222222222
36686, 0.91304347826087, -0.016666666666667, 0.19444444444444
36687, 0.93478260869565, -0.016666666666667, 0.22222222222222
36688, 0.95652173913043, -0.033333333333333, 0.22222222222222
36689, 0.95652173913044, -0.016666666666667, 0.19444444444444
36690, 0.97826086956522, -0.016666666666667, 0.22222222222222
36691, 0.021739130434783, 0.016666666666667, 0.22222222222222
36692, 0.043478260869565, 5.8980598183211e-17, 0.22222222222222
36693, 0.043478260869565, 0.016666666666667, 0.19444444444444
36694, 0.065217391304348, 0.016666666666667, 0.22222222222222
36695, 0.08695652173913, 5.8980598183211e-17, 0.22222222222222
36696, 0.08695652173913, 0.016666666666667, 0.19444444444444
36697, 0.10869565217391, 0.016666666666667, 0.22222222222222
36698, 0.1304347826087, 5.7245874707235e-17, 0.22222222222222
36699, 0.1304347826087, 0.016666666666667, 0.19444444444444
36700, 0.15217391304348, 0.016666666666667, 0.22222222222222
36701, 0.17391304347826, 5.3776427755281e-17, 0.22222222222222
36702, 0.17391304347826, 0.016666666666667, 0.19444444444444
36703, 0.19565217391304, 0.016666666666667, 0.22222222222222
36704, 0.21739130434783, 5.5511151231258e-17, 0.22222222222222
36705, 0.21739130434783, 0.016666666666667, 0.19444444444444
36706, 0.23913043478261, 0.016666666666667, 0.22222222222222
36707, 0.26086956521739, 5.2041704279304e-17, 0.22222222222222
36708, 0.26086956521739, 0.016666666666667, 0.19444444444444
36709, 0.28260869565217, 0.016666666666667, 0.22222222222222
36710, 0.30434782608696, 5.5511151231258e-17, 0.22222222222222
36711, 0.30434782608696, 0.016666666666667, 0.19444444444444
36712, 0.32608695652174, 0.016666666666667, 0.22222222222222
36713, 0.34782608695652, 5.3776427755281e-17, 0.22222222222222
36714, 0.34782608695652, 0.016666666666667, 0.19444444444444
36715, 0.3695652173913, 0.016666666666667, 0.22222222222222
36716, 0.39130434782609, 5.8980598183211e-17, 0.22222222222222
36717, 0.39130434782609, 0.016666666666667, 0.19444444444444
36718, 0.41304347826087, 0.016666666666667, 0.22222222222222
36719, 0.43478260869565, 5.5511151231258e-17, 0.22222222222222
36720, 0.43478260869565, 0.016666666666667, 0.19444444444444
36721, 0.45652173913043, 0.016666666666667, 0.22222222222222
36722, 0.47826086956522, 5.3776427755281e-17, 0.22222222222222
36723, 0.47826086956522, 0.016666666666667, 0.19444444444444
36724, 0.5, 0.016666666666667, 0.22222222222222
36725, 0.52173913043478, 5.5511151231258e-17, 0.22222222222222
36726, 0.52173913043478, 0.016666666666667, 0.19444444444444
36727, 0.54347826086957, 0.016666666666667, 0.22222222222222
36728, 0.56521739130435, 5.7245874707235e-17, 0.22222222222222
36729, 0.56521739130435, 0.016666666666667, 0.19444444444444
36730, 0.58695652173913, 0.016666666666667, 0.22222222222222
36731, 0.60869565217391, 5.5511151231258e-17, 0.22222222222222
36732, 0.60869565217391, 0.016666666666667, 0.19444444444444
36733, 0.6304347826087, 0.016666666666667, 0.22222222222222
36734, 0.65217391304348, 5.5511151231258e-17, 0.22222222222222
36735, 0.65217391304348, 0.016666666666667, 0.19444444444444
36736, 0.67391304347826, 0.016666666666667, 0.22222222222222
36737, 0.69565217391304, 5.5511151231258e-17, 0.22222222222222
36738, 0.69565217391304, 0.016666666666667, 0.19444444444444
36739, 0.71739130434783, 0.016666666666667, 0.22222222222222
36740, 0.73913043478261, 5.5511151231258e-17, 0.22222222222222
36741, 0.73913043478261, 0.016666666666667, 0.19444444444444
36742, 0.76086956521739, 0.016666666666667, 0.22222222222222
36743, 0.78260869565217, 5.8980598183211e-17, 0.22222222222222
36744, 0.78260869565217, 0.016666666666667, 0.19444444444444
36745, 0.80434782608696, 0.016666666666667, 0.22222222222222
36746, 0.82608695652174, 5.2041704279304e-17, 0.22222222222222
36747, 0.82608695652174, 0.016666666666667, 0.19444444444444
36748, 0.84782608695652, 0.016666666666667, 0.22222222222222
36749, 0.8695652173913, 5.5511151231258e-17, 0.22222222222222
36750, 0.8695652173913, 0.016666666666667, 0.19444444444444
36751, 0.89130434782609, 0.016666666666667, 0.22222222222222
36752, 0.91304347826087, 5.5511151231258e-17, 0.22222222222222
36753, 0.91304347826087, 0.016666666666667, 0.19444444444444
36754, 0.93478260869565, 0.016666666666667, 0.22222222222222
36755, 0.95652173913044, 5.8980598183211e-17, 0.22222222222222
36756, 0.95652173913044, 0.016666666666667, 0.19444444444444
36757, 0.97826086956522, 0.016666666666667, 0.22222222222222
36758, 0.043478260869565, 0.033333333333333, 0.22222222222222
36759, 0.08695652173913, 0.033333333333333, 0.22222222222222
36760, 0.1304347826087, 0.033333333333333, 0.22222222222222
36761, 0.17391304347826, 0.033333333333333, 0.22222222222222
36762, 0.21739130434783, 0.033333333333333, 0.22222222222222
36763, 0.26086956521739, 0.033333333333333, 0.22222222222222
36764, 0.30434782608696, 0.033333333333333, 0.22222222222222
36765, 0.34782608695652, 0.033333333333333, 0.22222222222222
36766, 0.39130434782609, 0.033333333333333, 0.22222222222222
36767, 0.43478260869565, 0.033333333333333, 0.22222222222222
36768, 0.47826086956522, 0.033333333333333, 0.22222222222222
36769, 0.52173913043478, 0.033333333333333, 0.22222222222222
36770, 0.56521739130435, 0.033333333333333, 0.22222222222222
36771, 0.60869565217391, 0.033333333333333, 0.22222222222222
36772, 0.65217391304348, 0.033333333333333, 0.22222222222222
36773, 0.69565217391304, 0.033333333333333, 0.22222222222222
36774, 0.73913043478261, 0.033333333333333, 0.22222222222222
36775, 0.78260869565217, 0.033333333333333, 0.22222222222222
36776, 0.82608695652174, 0.033333333333333, 0.22222222222222
36777, 0.8695652173913, 0.033333333333333, 0.22222222222222
36778, 0.91304347826087, 0.033333333333333, 0.22222222222222
36779, 0.95652173913043, 0.033333333333333, 0.22222222222222
36780, 0.021739130434783, -0.016666666666667, 0.27777777777778
36781, 0.043478260869565, -0.033333333333333, 0.27777777777778
36782, 0.043478260869565, -0.016666666666667, 0.25
36783, 0.065217391304348, -0.016666666666667, 0.27777777777778
36784, 0.08695652173913, -0.033333333333333, 0.27777777777778
36785, 0.08695652173913, -0.016666666666667, 0.25
36786, 0.10869565217391, -0.016666666666667, 0.27777777777778
36787, 0.1304347826087, -0.033333333333333, 0.27777777777778
36788, 0.1304347826087, -0.016666666666667, 0.25
36789, 0.15217391304348, -0.016666666666667, 0.27777777777778
36790, 0.17391304347826, -0.033333333333333, 0.27777777777778
36791, 0.17391304347826, -0.016666666666667, 0.25
36792, 0.19565217391304, -0.016666666666667, 0.27777777777778
36793, 0.21739130434783, -0.033333333333333, 0.27777777777778
36794, 0.21739130434783, -0.016666666666667, 0.25
36795, 0.23913043478261, -0.016666666666667, 0.27777777777778
36796, 0.26086956521739, -0.033333333333333, 0.27777777777778
36797, 0.26086956521739, -0.016666666666667, 0.25
36798, 0.28260869565217, -0.016666666666667, 0.27777777777778
36799, 0.30434782608696, -0.033333333333333, 0.27777777777778
36800, 0.30434782608696, -0.016666666666667, 0.25
36801, 0.32608695652174, -0.016666666666667, 0.27777777777778
36802, 0.34782608695652, -0.033333333333333, 0.27777777777778
36803, 0.34782608695652, -0.016666666666667, 0.25
36804, 0.3695652173913, -0.016666666666667, 0.27777777777778
36805, 0.39130434782609, -0.033333333333333, 0.27777777777778
36806, 0.39130434782609, -0.016666666666667, 0.25
36807, 0.41304347826087, -0.016666666666667, 0.27777777777778
36808, 0.43478260869565, -0.033333333333333, 0.27777777777778
36809, 0.43478260869565, -0.016666666666667, 0.25
36810, 0.45652173913043, -0.016666666666667, 0.27777777777778
36811, 0.47826086956522, -0.033333333333333, 0.27777777777778
36812, 0.47826086956522, -0.016666666666667, 0.25
36813, 0.5, -0.016666666666667, 0.27777777777778
36814, 0.52173913043478, -0.033333333333333, 0.27777777777778
36815, 0.52173913043478, -0.016666666666667, 0.25
36816, 0.54347826086957, -0.016666666666667, 0.27777777777778
36817, 0.56521739130435, -0.033333333333333, 0.27777777777778
36818, 0.56521739130435, -0.016666666666667, 0.25
36819, 0.58695652173913, -0.016666666666667, 0.27777777777778
36820, 0.60869565217391, -0.033333333333333, 0.27777777777778
36821, 0.60869565217391, -0.016666666666667, 0.25
36822, 0.6304347826087, -0.016666666666667, 0.27777777777778
36823, 0.65217391304348, -0.033333333333333, 0.27777777777778
36824, 0.65217391304348, -0.016666666666667, 0.25
36825, 0.67391304347826, -0.016666666666667, 0.27777777777778
36826, 0.69565217391304, -0.033333333333333, 0.27777777777778
36827, 0.69565217391304, -0.016666666666667, 0.25
36828, 0.71739130434783, -0.016666666666667, 0.27777777777778
36829, 0.73913043478261, -0.033333333333333, 0.27777777777778
36830, 0.73913043478261, -0.016666666666667, 0.25
36831, 0.76086956521739, -0.016666666666667, 0.27777777777778
36832, 0.78260869565217, -0.033333333333333, 0.27777777777778
36833, 0.78260869565217, -0.016666666666667, 0.25
36834, 0.80434782608696, -0.016666666666667, 0.27777777777778
36835, 0.82608695652174, -0.033333333333333, 0.27777777777778
36836, 0.82608695652174, -0.016666666666667, 0.25
36837, 0.84782608695652, -0.016666666666667, 0.27777777777778
36838, 0.8695652173913, -0.033333333333333, 0.27777777777778
36839, 0.8695652173913, -0.016666666666667, 0.25
36840, 0.89130434782609, -0.016666666666667, 0.27777777777778
36841, 0.91304347826087, -0.033333333333333, 0.27777777777778
36842, 0.91304347826087, -0.016666666666667, 0.25
36843, 0.93478260869565, -0.016666666666667, 0.27777777777778
36844, 0.95652173913043, -0.033333333333333, 0.27777777777778
36845, 0.95652173913044, -0.016666666666667, 0.25
36846, 0.97826086956522, -0.016666666666667, 0.27777777777778
36847, 0.021739130434783, 0.016666666666667, 0.27777777777778
36848, 0.043478260869565, 6.0715321659188e-17, 0.27777777777778
36849, 0.043478260869565, 0.016666666666667, 0.25
36850, 0.065217391304348, 0.016666666666667, 0.27777777777778
36851, 0.08695652173913, 5.8980598183211e-17, 0.27777777777778
36852, 0.08695652173913, 0.016666666666667, 0.25
36853, 0.10869565217391, 0.016666666666667, 0.27777777777778
36854, 0.1304347826087, 5.7245874707235e-17, 0.27777777777778
36855, 0.1304347826087, 0.016666666666667, 0.25
36856, 0.15217391304348, 0.016666666666667, 0.27777777777778
36857, 0.17391304347826, 5.3776427755281e-17, 0.27777777777778
36858, 0.17391304347826, 0.016666666666667, 0.25
36859, 0.19565217391304, 0.016666666666667, 0.27777777777778
36860, 0.21739130434783, 5.0306980803327e-17, 0.27777777777778
36861, 0.21739130434783, 0.016666666666667, 0.25
36862, 0.23913043478261, 0.016666666666667, 0.27777777777778
36863, 0.26086956521739, 5.2041704279304e-17, 0.27777777777778
36864, 0.26086956521739, 0.016666666666667, 0.25
36865, 0.28260869565217, 0.016666666666667, 0.27777777777778
36866, 0.30434782608696, 5.5511151231258e-17, 0.27777777777778
36867, 0.30434782608696, 0.016666666666667, 0.25
36868, 0.32608695652174, 0.016666666666667, 0.27777777777778
36869, 0.34782608695652, 5.5511151231258e-17, 0.27777777777778
36870, 0.34782608695652, 0.016666666666667, 0.25
36871, 0.3695652173913, 0.016666666666667, 0.27777777777778
36872, 0.39130434782609, 5.5511151231258e-17, 0.27777777777778
36873, 0.39130434782609, 0.016666666666667, 0.25
36874, 0.41304347826087, 0.016666666666667, 0.27777777777778
36875, 0.43478260869565, 5.3776427755281e-17, 0.27777777777778
36876, 0.43478260869565, 0.016666666666667, 0.25
36877, 0.45652173913043, 0.016666666666667, 0.27777777777778
36878, 0.47826086956522, 5.5511151231258e-17, 0.27777777777778
36879, 0.47826086956522, 0.016666666666667, 0.25
36880, 0.5, 0.016666666666667, 0.27777777777778
36881, 0.52173913043478, 5.2041704279304e-17, 0.27777777777778
36882, 0.52173913043478, 0.016666666666667, 0.25
36883, 0.54347826086957, 0.016666666666667, 0.27777777777778
36884, 0.56521739130435, 5.5511151231258e-17, 0.27777777777778
36885, 0.56521739130435, 0.016666666666667, 0.25
36886, 0.58695652173913, 0.016666666666667, 0.27777777777778
36887, 0.60869565217391, 5.5511151231258e-17, 0.27777777777778
36888, 0.60869565217391, 0.016666666666667, 0.25
36889, 0.6304347826087, 0.016666666666667, 0.27777777777778
36890, 0.65217391304348, 5.5511151231258e-17, 0.27777777777778
36891, 0.65217391304348, 0.016666666666667, 0.25
36892, 0.67391304347826, 0.016666666666667, 0.27777777777778
36893, 0.69565217391304, 5.5511151231258e-17, 0.27777777777778
36894, 0.69565217391304, 0.016666666666667, 0.25
36895, 0.71739130434783, 0.016666666666667, 0.27777777777778
36896, 0.73913043478261, 5.7245874707235e-17, 0.27777777777778
36897, 0.73913043478261, 0.016666666666667, 0.25
36898, 0.76086956521739, 0.016666666666667, 0.27777777777778
36899, 0.78260869565217, 5.8980598183211e-17, 0.27777777777778
36900, 0.78260869565217, 0.016666666666667, 0.25
36901, 0.80434782608696, 0.016666666666667, 0.27777777777778
36902, 0.82608695652174, 5.5511151231258e-17, 0.27777777777778
36903, 0.82608695652174, 0.016666666666667, 0.25
36904, 0.84782608695652, 0.016666666666667, 0.27777777777778
36905, 0.8695652173913, 5.7245874707235e-17, 0.27777777777778
36906, 0.8695652173913, 0.016666666666667, 0.25
36907, 0.89130434782609, 0.016666666666667, 0.27777777777778
36908, 0.91304347826087, 5.7245874707235e-17, 0.27777777777778
36909, 0.91304347826087, 0.016666666666667, 0.25
36910, 0.93478260869565, 0.016666666666667, 0.27777777777778
36911, 0.95652173913044, 5.8980598183211e-17, 0.27777777777778
36912, 0.95652173913044, 0.016666666666667, 0.25
36913, 0.97826086956522, 0.016666666666667, 0.27777777777778
36914, 0.043478260869565, 0.033333333333333, 0.27777777777778
36915, 0.08695652173913, 0.033333333333333, 0.27777777777778
36916, 0.1304347826087, 0.033333333333333, 0.27777777777778
36917, 0.17391304347826, 0.033333333333333, 0.27777777777778
36918, 0.21739130434783, 0.033333333333333, 0.27777777777778
36919, 0.26086956521739, 0.033333333333333, 0.27777777777778
36920, 0.30434782608696, 0.033333333333333, 0.27777777777778
36921, 0.34782608695652, 0.033333333333333, 0.27777777777778
36922, 0.39130434782609, 0.033333333333333, 0.27777777777778
36923, 0.43478260869565, 0.033333333333333, 0.27777777777778
36924, 0.47826086956522, 0.033333333333333, 0.27777777777778
36925, 0.52173913043478, 0.033333333333333, 0.27777777777778
36926, 0.56521739130435, 0.033333333333333, 0.27777777777778
36927, 0.60869565217391, 0.033333333333333, 0.27777777777778
36928, 0.65217391304348, 0.033333333333333, 0.27777777777778
36929, 0.69565217391304, 0.033333333333333, 0.27777777777778
36930, 0.73913043478261, 0.033333333333333, 0.27777777777778
36931, 0.78260869565217, 0.033333333333333, 0.27777777777778
36932, 0.82608695652174, 0.033333333333333, 0.27777777777778
36933, 0.8695652173913, 0.033333333333333, 0.27777777777778
36934, 0.91304347826087, 0.033333333333333, 0.27777777777778
36935, 0.95652173913043, 0.033333333333333, 0.27777777777778
36936, 0.021739130434783, -0.016666666666667, 0.33333333333333
36937, 0.043478260869565, -0.033333333333333, 0.33333333333333
36938, 0.043478260869565, -0.016666666666667, 0.30555555555556
36939, 0.065217391304348, -0.016666666666667, 0.33333333333333
36940, 0.08695652173913, -0.033333333333333, 0.33333333333333
36941, 0.08695652173913, -0.016666666666667, 0.30555555555556
36942, 0.10869565217391, -0.016666666666667, 0.33333333333333
36943, 0.1304347826087, -0.033333333333333, 0.33333333333333
36944, 0.1304347826087, -0.016666666666667, 0.30555555555556
36945, 0.15217391304348, -0.016666666666667, 0.33333333333333
36946, 0.17391304347826, -0.033333333333333, 0.33333333333333
36947, 0.17391304347826, -0.016666666666667, 0.30555555555556
36948, 0.19565217391304, -0.016666666666667, 0.33333333333333
36949, 0.21739130434783, -0.033333333333333, 0.33333333333333
36950, 0.21739130434783, -0.016666666666667, 0.30555555555556
36951, 0.23913043478261, -0.016666666666667, 0.33333333333333
36952, 0.26086956521739, -0.033333333333333, 0.33333333333333
36953, 0.26086956521739, -0.016666666666667, 0.30555555555556
36954, 0.28260869565217, -0.016666666666667, 0.33333333333333
36955, 0.30434782608696, -0.033333333333333, 0.33333333333333
36956, 0.30434782608696, -0.016666666666667, 0.30555555555556
36957, 0.32608695652174, -0.016666666666667, 0.33333333333333
36958, 0.34782608695652, -0.033333333333333, 0.33333333333333
36959, 0.34782608695652, -0.016666666666667, 0.30555555555556
36960, 0.3695652173913, -0.016666666666667, 0.33333333333333
36961, 0.39130434782609, -0.033333333333333, 0.33333333333333
36962, 0.39130434782609, -0.016666666666667, 0.30555555555556
36963, 0.41304347826087, -0.016666666666667, 0.33333333333333
36964, 0.43478260869565, -0.033333333333333, 0.33333333333333
36965, 0.43478260869565, -0.016666666666667, 0.30555555555556
36966, 0.45652173913043, -0.016666666666667, 0.33333333333333
36967, 0.47826086956522, -0.033333333333333, 0.33333333333333
36968, 0.47826086956522, -0.016666666666667, 0.30555555555556
36969, 0.5, -0.016666666666667, 0.33333333333333
36970, 0.52173913043478, -0.033333333333333, 0.33333333333333
36971, 0.52173913043478, -0.016666666666667, 0.30555555555556
36972, 0.54347826086957, -0.016666666666667, 0.33333333333333
36973, 0.56521739130435, -0.033333333333333, 0.33333333333333
36974, 0.56521739130435, -0.016666666666667, 0.30555555555556
36975, 0.58695652173913, -0.016666666666667, 0.33333333333333
36976, 0.60869565217391, -0.033333333333333, 0.33333333333333
36977, 0.60869565217391, -0.016666666666667, 0.30555555555556
36978, 0.6304347826087, -0.016666666666667, 0.33333333333333
36979, 0.65217391304348, -0.033333333333333, 0.33333333333333
36980, 0.65217391304348, -0.016666666666667, 0.30555555555556
36981, 0.67391304347826, -0.016666666666667, 0.33333333333333
36982, 0.69565217391304, -0.033333333333333, 0.33333333333333
36983, 0.69565217391304, -0.016666666666667, 0.30555555555556
36984, 0.71739130434783, -0.016666666666667, 0.33333333333333
36985, 0.73913043478261, -0.033333333333333, 0.33333333333333
36986, 0.73913043478261, -0.016666666666667, 0.30555555555556
36987, 0.76086956521739, -0.016666666666667, 0.33333333333333
36988, 0.78260869565217, -0.033333333333333, 0.33333333333333
36989, 0.78260869565217, -0.016666666666667, 0.30555555555556
36990, 0.80434782608696, -0.016666666666667, 0.33333333333333
36991, 0.82608695652174, -0.033333333333333, 0.33333333333333
36992, 0.82608695652174, -0.016666666666667, 0.30555555555556
36993, 0.84782608695652, -0.016666666666667, 0.33333333333333
36994, 0.8695652173913, -0.033333333333333, 0.33333333333333
36995, 0.8695652173913, -0.016666666666667, 0.30555555555556
36996, 0.89130434782609, -0.016666666666667, 0.33333333333333
36997, 0.91304347826087, -0.033333333333333, 0.33333333333333
36998, 0.91304347826087, -0.016666666666667, 0.30555555555556
36999, 0.93478260869565, -0.016666666666667, 0.33333333333333
37000, 0.95652173913044, -0.033333333333333, 0.33333333333333
37001, 0.95652173913044, -0.016666666666667, 0.30555555555556
37002, 0.97826086956522, -0.016666666666667, 0.33333333333333
37003, 0.021739130434783, 0.016666666666667, 0.33333333333333
37004, 0.043478260869565, 6.2450045135165e-17, 0.33333333333333
37005, 0.043478260869565, 0.016666666666667, 0.30555555555556
37006, 0.065217391304348, 0.016666666666667, 0.33333333333333
37007, 0.08695652173913, 5.7245874707235e-17, 0.33333333333333
37008, 0.08695652173913, 0.016666666666667, 0.30555555555556
37009, 0.10869565217391, 0.016666666666667, 0.33333333333333
37010, 0.1304347826087, 5.2041704279304e-17, 0.33333333333333
37011, 0.1304347826087, 0.016666666666667, 0.30555555555556
37012, 0.15217391304348, 0.016666666666667, 0.33333333333333
37013, 0.17391304347826, 5.2041704279304e-17, 0.33333333333333
37014, 0.17391304347826, 0.016666666666667, 0.30555555555556
37015, 0.19565217391304, 0.016666666666667, 0.33333333333333
37016, 0.21739130434783, 5.3776427755281e-17, 0.33333333333333
37017, 0.21739130434783, 0.016666666666667, 0.30555555555556
37018, 0.23913043478261, 0.016666666666667, 0.33333333333333
37019, 0.26086956521739, 5.5511151231258e-17, 0.33333333333333
37020, 0.26086956521739, 0.016666666666667, 0.30555555555556
37021, 0.28260869565217, 0.016666666666667, 0.33333333333333
37022, 0.30434782608696, 5.5511151231258e-17, 0.33333333333333
37023, 0.30434782608696, 0.016666666666667, 0.30555555555556
37024, 0.32608695652174, 0.016666666666667, 0.33333333333333
37025, 0.34782608695652, 5.7245874707235e-17, 0.33333333333333
37026, 0.34782608695652, 0.016666666666667, 0.30555555555556
37027, 0.3695652173913, 0.016666666666667, 0.33333333333333
37028, 0.39130434782609, 5.5511151231258e-17, 0.33333333333333
37029, 0.39130434782609, 0.016666666666667, 0.30555555555556
37030, 0.41304347826087, 0.016666666666667, 0.33333333333333
37031, 0.43478260869565, 5.5511151231258e-17, 0.33333333333333
37032, 0.43478260869565, 0.016666666666667, 0.30555555555556
37033, 0.45652173913043, 0.016666666666667, 0.33333333333333
37034, 0.47826086956522, 5.5511151231258e-17, 0.33333333333333
37035, 0.47826086956522, 0.016666666666667, 0.30555555555556
37036, 0.5, 0.016666666666667, 0.33333333333333
37037, 0.52173913043478, 5.5511151231258e-17, 0.33333333333333
37038, 0.52173913043478, 0.016666666666667, 0.30555555555556
37039, 0.54347826086957, 0.016666666666667, 0.33333333333333
37040, 0.56521739130435, 5.5511151231258e-17, 0.33333333333333
37041, 0.56521739130435, 0.016666666666667, 0.30555555555556
37042, 0.58695652173913, 0.016666666666667, 0.33333333333333
37043, 0.60869565217391, 5.5511151231258e-17, 0.33333333333333
37044, 0.60869565217391, 0.016666666666667, 0.30555555555556
37045, 0.6304347826087, 0.016666666666667, 0.33333333333333
37046, 0.65217391304348, 5.5511151231258e-17, 0.33333333333333
37047, 0.65217391304348, 0.016666666666667, 0.30555555555556
37048, 0.67391304347826, 0.016666666666667, 0.33333333333333
37049, 0.69565217391304, 5.5511151231258e-17, 0.33333333333333
37050, 0.69565217391304, 0.016666666666667, 0.30555555555556
37051, 0.71739130434783, 0.016666666666667, 0.33333333333333
37052, 0.73913043478261, 5.5511151231258e-17, 0.33333333333333
37053, 0.73913043478261, 0.016666666666667, 0.30555555555556
37054, 0.76086956521739, 0.016666666666667, 0.33333333333333
37055, 0.78260869565217, 5.5511151231258e-17, 0.33333333333333
37056, 0.78260869565217, 0.016666666666667, 0.30555555555556
37057, 0.80434782608696, 0.016666666666667, 0.33333333333333
37058, 0.82608695652174, 5.3776427755281e-17, 0.33333333333333
37059, 0.82608695652174, 0.016666666666667, 0.30555555555556
37060, 0.84782608695652, 0.016666666666667, 0.33333333333333
37061, 0.8695652173913, 5.5511151231258e-17, 0.33333333333333
37062, 0.8695652173913, 0.016666666666667, 0.30555555555556
37063, 0.89130434782609, 0.016666666666667, 0.33333333333333
37064, 0.91304347826087, 5.7245874707235e-17, 0.33333333333333
37065, 0.91304347826087, 0.016666666666667, 0.30555555555556
37066, 0.93478260869565, 0.016666666666667, 0.33333333333333
37067, 0.95652173913044, 6.0715321659188e-17, 0.33333333333333
37068, 0.95652173913044, 0.016666666666667, 0.30555555555556
37069, 0.97826086956522, 0.016666666666667, 0.33333333333333
37070, 0.043478260869565, 0.033333333333333, 0.33333333333333
37071, 0.08695652173913, 0.033333333333333, 0.33333333333333
37072, 0.1304347826087, 0.033333333333333, 0.33333333333333
37073, 0.17391304347826, 0.033333333333333, 0.33333333333333
37074, 0.21739130434783, 0.033333333333333, 0.33333333333333
37075, 0.26086956521739, 0.033333333333333, 0.33333333333333
37076, 0.30434782608696, 0.033333333333333, 0.33333333333333
37077, 0.34782608695652, 0.033333333333333, 0.33333333333333
37078, 0.39130434782609, 0.033333333333333, 0.33333333333333
37079, 0.43478260869565, 0.033333333333333, 0.33333333333333
37080, 0.47826086956522, 0.033333333333333, 0.33333333333333
37081, 0.52173913043478, 0.033333333333333, 0.33333333333333
37082, 0.56521739130435, 0.033333333333333, 0.33333333333333
37083, 0.60869565217391, 0.033333333333333, 0.33333333333333
37084, 0.65217391304348, 0.033333333333333, 0.33333333333333
37085, 0.69565217391304, 0.033333333333333, 0.33333333333333
37086, 0.73913043478261, 0.033333333333333, 0.33333333333333
37087, 0.78260869565217, 0.033333333333333, 0.33333333333333
37088, 0.82608695652174, 0.033333333333333, 0.33333333333333
37089, 0.8695652173913, 0.033333333333333, 0.33333333333333
37090, 0.91304347826087, 0.033333333333333, 0.33333333333333
37091, 0.95652173913043, 0.033333333333333, 0.33333333333333
37092, 0.021739130434783, -0.016666666666667, 0.38888888888889
37093, 0.043478260869565, -0.033333333333333, 0.38888888888889
37094, 0.043478260869565, -0.016666666666667, 0.36111111111111
37095, 0.065217391304348, -0.016666666666667, 0.38888888888889
37096, 0.08695652173913, -0.033333333333333, 0.38888888888889
37097, 0.08695652173913, -0.016666666666667, 0.36111111111111
37098, 0.10869565217391, -0.016666666666667, 0.38888888888889
37099, 0.1304347826087, -0.033333333333333, 0.38888888888889
37100, 0.1304347826087, -0.016666666666667, 0.36111111111111
37101, 0.15217391304348, -0.016666666666667, 0.38888888888889
37102, 0.17391304347826, -0.033333333333333, 0.38888888888889
37103, 0.17391304347826, -0.016666666666667, 0.36111111111111
37104, 0.19565217391304, -0.016666666666667, 0.38888888888889
37105, 0.21739130434783, -0.033333333333333, 0.38888888888889
37106, 0.21739130434783, -0.016666666666667, 0.36111111111111
37107, 0.23913043478261, -0.016666666666667, 0.38888888888889
37108, 0.26086956521739, -0.033333333333333, 0.38888888888889
37109, 0.26086956521739, -0.016666666666667, 0.36111111111111
37110, 0.28260869565217, -0.016666666666667, 0.38888888888889
37111, 0.30434782608696, -0.033333333333333, 0.38888888888889
37112, 0.30434782608696, -0.016666666666667, 0.36111111111111
37113, 0.32608695652174, -0.016666666666667, 0.38888888888889
37114, 0.34782608695652, -0.033333333333333, 0.38888888888889
37115, 0.34782608695652, -0.016666666666667, 0.36111111111111
37116, 0.3695652173913, -0.016666666666667, 0.38888888888889
37117, 0.39130434782609, -0.033333333333333, 0.38888888888889
37118, 0.39130434782609, -0.016666666666667, 0.36111111111111
37119, 0.41304347826087, -0.016666666666667, 0.38888888888889
37120, 0.43478260869565, -0.033333333333333, 0.38888888888889
37121, 0.43478260869565, -0.016666666666667, 0.36111111111111
37122, 0.45652173913043, -0.016666666666667, 0.38888888888889
37123, 0.47826086956522, -0.033333333333333, 0.38888888888889
37124, 0.47826086956522, -0.016666666666667, 0.36111111111111
37125, 0.5, -0.016666666666667, 0.38888888888889
37126, 0.52173913043478, -0.033333333333333, 0.38888888888889
37127, 0.52173913043478, -0.016666666666667, 0.36111111111111
37128, 0.54347826086957, -0.016666666666667, 0.38888888888889
37129, 0.56521739130435, -0.033333333333333, 0.38888888888889
37130, 0.56521739130435, -0.016666666666667, 0.36111111111111
37131, 0.58695652173913, -0.016666666666667, 0.38888888888889
37132, 0.60869565217391, -0.033333333333333, 0.38888888888889
37133, 0.60869565217391, -0.016666666666667, 0.36111111111111
37134, 0.6304347826087, -0.016666666666667, 0.38888888888889
37135, 0.65217391304348, -0.033333333333333, 0.38888888888889
37136, 0.65217391304348, -0.016666666666667, 0.36111111111111
37137, 0.67391304347826, -0.016666666666667, 0.38888888888889
37138, 0.69565217391304, -0.033333333333333, 0.38888888888889
37139, 0.69565217391304, -0.016666666666667, 0.36111111111111
37140, 0.71739130434783, -0.016666666666667, 0.38888888888889
37141, 0.73913043478261, -0.033333333333333, 0.38888888888889
37142, 0.73913043478261, -0.016666666666667, 0.36111111111111
37143, 0.76086956521739, -0.016666666666667, 0.38888888888889
37144, 0.78260869565217, -0.033333333333333, 0.38888888888889
37145, 0.78260869565217, -0.016666666666667, 0.36111111111111
37146, 0.80434782608696, -0.016666666666667, 0.38888888888889
37147, 0.82608695652174, -0.033333333333333, 0.38888888888889
37148, 0.82608695652174, -0.016666666666667, 0.36111111111111
37149, 0.84782608695652, -0.016666666666667, 0.38888888888889
37150, 0.8695652173913, -0.033333333333333, 0.38888888888889
37151, 0.8695652173913, -0.016666666666667, 0.36111111111111
37152, 0.89130434782609, -0.016666666666667, 0.38888888888889
37153, 0.91304347826087, -0.033333333333333, 0.38888888888889
37154, 0.91304347826087, -0.016666666666667, 0.36111111111111
37155, 0.93478260869565, -0.016666666666667, 0.38888888888889
37156, 0.95652173913044, -0.033333333333333, 0.38888888888889
37157, 0.95652173913044, -0.016666666666667, 0.36111111111111
37158, 0.97826086956522, -0.016666666666667, 0.38888888888889
37159, 0.021739130434783, 0.016666666666667, 0.38888888888889
37160, 0.043478260869565, 6.0715321659188e-17, 0.38888888888889
37161, 0.043478260869565, 0.016666666666667, 0.36111111111111
37162, 0.065217391304348, 0.016666666666667, 0.38888888888889
37163, 0.08695652173913, 5.7245874707235e-17, 0.38888888888889
37164, 0.08695652173913, 0.016666666666667, 0.36111111111111
37165, 0.10869565217391, 0.016666666666667, 0.38888888888889
37166, 0.1304347826087, 5.5511151231258e-17, 0.38888888888889
37167, 0.1304347826087, 0.016666666666667, 0.36111111111111
37168, 0.15217391304348, 0.016666666666667, 0.38888888888889
37169, 0.17391304347826, 5.3776427755281e-17, 0.38888888888889
37170, 0.17391304347826, 0.016666666666667, 0.36111111111111
37171, 0.19565217391304, 0.016666666666667, 0.38888888888889
37172, 0.21739130434783, 5.5511151231258e-17, 0.38888888888889
37173, 0.21739130434783, 0.016666666666667, 0.36111111111111
37174, 0.23913043478261, 0.016666666666667, 0.38888888888889
37175, 0.26086956521739, 5.8980598183211e-17, 0.38888888888889
37176, 0.26086956521739, 0.016666666666667, 0.36111111111111
37177, 0.28260869565217, 0.016666666666667, 0.38888888888889
37178, 0.30434782608696, 5.7245874707235e-17, 0.38888888888889
37179, 0.30434782608696, 0.016666666666667, 0.36111111111111
37180, 0.32608695652174, 0.016666666666667, 0.38888888888889
37181, 0.34782608695652, 5.8980598183211e-17, 0.38888888888889
37182, 0.34782608695652, 0.016666666666667, 0.36111111111111
37183, 0.3695652173913, 0.016666666666667, 0.38888888888889
37184, 0.39130434782609, 5.8980598183211e-17, 0.38888888888889
37185, 0.39130434782609, 0.016666666666667, 0.36111111111111
37186, 0.41304347826087, 0.016666666666667, 0.38888888888889
37187, 0.43478260869565, 5.2041704279304e-17, 0.38888888888889
37188, 0.43478260869565, 0.016666666666667, 0.36111111111111
37189, 0.45652173913043, 0.016666666666667, 0.38888888888889
37190, 0.47826086956522, 5.3776427755281e-17, 0.38888888888889
37191, 0.47826086956522, 0.016666666666667, 0.36111111111111
37192, 0.5, 0.016666666666667, 0.38888888888889
37193, 0.52173913043478, 5.2041704279304e-17, 0.38888888888889
37194, 0.52173913043478, 0.016666666666667, 0.36111111111111
37195, 0.54347826086957, 0.016666666666667, 0.38888888888889
37196, 0.56521739130435, 5.3776427755281e-17, 0.38888888888889
37197, 0.56521739130435, 0.016666666666667, 0.36111111111111
37198, 0.58695652173913, 0.016666666666667, 0.38888888888889
37199, 0.60869565217391, 5.5511151231258e-17, 0.38888888888889
37200, 0.60869565217391, 0.016666666666667, 0.36111111111111
37201, 0.6304347826087, 0.016666666666667, 0.38888888888889
37202, 0.65217391304348, 5.3776427755281e-17, 0.38888888888889
37203, 0.65217391304348, 0.016666666666667, 0.36111111111111
37204, 0.67391304347826, 0.016666666666667, 0.38888888888889
37205, 0.69565217391304, 5.5511151231258e-17, 0.38888888888889
37206, 0.69565217391304, 0.016666666666667, 0.36111111111111
37207, 0.71739130434783, 0.016666666666667, 0.38888888888889
37208, 0.73913043478261, 5.3776427755281e-17, 0.38888888888889
37209, 0.73913043478261, 0.016666666666667, 0.36111111111111
37210, 0.76086956521739, 0.016666666666667, 0.38888888888889
37211, 0.78260869565217, 5.5511151231258e-17, 0.38888888888889
37212, 0.78260869565217, 0.016666666666667, 0.36111111111111
37213, 0.80434782608696, 0.016666666666667, 0.38888888888889
37214, 0.82608695652174, 5.7245874707235e-17, 0.38888888888889
37215, 0.82608695652174, 0.016666666666667, 0.36111111111111
37216, 0.84782608695652, 0.016666666666667, 0.38888888888889
37217, 0.8695652173913, 5.3776427755281e-17, 0.38888888888889
37218, 0.8695652173913, 0.016666666666667, 0.36111111111111
37219, 0.89130434782609, 0.016666666666667, 0.38888888888889
37220, 0.91304347826087, 5.7245874707235e-17, 0.38888888888889
37221, 0.91304347826087, 0.016666666666667, 0.36111111111111
37222, 0.93478260869565, 0.016666666666667, 0.38888888888889
37223, 0.95652173913044, 6.0715321659188e-17, 0.38888888888889
37224, 0.95652173913044, 0.016666666666667, 0.36111111111111
37225, 0.97826086956522, 0.016666666666667, 0.38888888888889
37226, 0.043478260869565, 0.033333333333333, 0.38888888888889
37227, 0.08695652173913, 0.033333333333333, 0.38888888888889
37228, 0.1304347826087, 0.033333333333333, 0.38888888888889
37229, 0.17391304347826, 0.033333333333333, 0.38888888888889
37230, 0.21739130434783, 0.033333333333333, 0.38888888888889
37231, 0.26086956521739, 0.033333333333333, 0.38888888888889
37232, 0.30434782608696, 0.033333333333333, 0.38888888888889
37233, 0.34782608695652, 0.033333333333333, 0.38888888888889
37234, 0.39130434782609, 0.033333333333333, 0.38888888888889
37235, 0.43478260869565, 0.033333333333333, 0.38888888888889
37236, 0.47826086956522, 0.033333333333333, 0.38888888888889
37237, 0.52173913043478, 0.033333333333333, 0.38888888888889
37238, 0.56521739130435, 0.033333333333333, 0.38888888888889
37239, 0.60869565217391, 0.033333333333333, 0.38888888888889
37240, 0.65217391304348, 0.033333333333333, 0.38888888888889
37241, 0.69565217391304, 0.033333333333333, 0.38888888888889
37242, 0.73913043478261, 0.033333333333333, 0.38888888888889
37243, 0.78260869565217, 0.033333333333333, 0.38888888888889
37244, 0.82608695652174, 0.033333333333333, 0.38888888888889
37245, 0.8695652173913, 0.033333333333333, 0.38888888888889
37246, 0.91304347826087, 0.033333333333333, 0.38888888888889
37247, 0.95652173913043, 0.033333333333333, 0.38888888888889
37248, 0.021739130434783, -0.016666666666667, 0.44444444444444
37249, 0.043478260869565, -0.033333333333333, 0.44444444444444
37250, 0.043478260869565, -0.016666666666667, 0.41666666666667
37251, 0.065217391304348, -0.016666666666667, 0.44444444444444
37252, 0.08695652173913, -0.033333333333333, 0.44444444444444
37253, 0.08695652173913, -0.016666666666667, 0.41666666666667
37254, 0.10869565217391, -0.016666666666667, 0.44444444444444
37255, 0.1304347826087, -0.033333333333333, 0.44444444444444
37256, 0.1304347826087, -0.016666666666667, 0.41666666666667
37257, 0.15217391304348, -0.016666666666667, 0.44444444444444
37258, 0.17391304347826, -0.033333333333333, 0.44444444444444
37259, 0.17391304347826, -0.016666666666667, 0.41666666666667
37260, 0.19565217391304, -0.016666666666667, 0.44444444444444
37261, 0.21739130434783, -0.033333333333333, 0.44444444444444
37262, 0.21739130434783, -0.016666666666667, 0.41666666666667
37263, 0.23913043478261, -0.016666666666667, 0.44444444444444
37264, 0.26086956521739, -0.033333333333333, 0.44444444444444
37265, 0.26086956521739, -0.016666666666667, 0.41666666666667
37266, 0.28260869565217, -0.016666666666667, 0.44444444444444
37267, 0.30434782608696, -0.033333333333333, 0.44444444444444
37268, 0.30434782608696, -0.016666666666667, 0.41666666666667
37269, 0.32608695652174, -0.016666666666667, 0.44444444444444
37270, 0.34782608695652, -0.033333333333333, 0.44444444444444
37271, 0.34782608695652, -0.016666666666667, 0.41666666666667
37272, 0.3695652173913, -0.016666666666667, 0.44444444444444
37273, 0.39130434782609, -0.033333333333333, 0.44444444444444
37274, 0.39130434782609, -0.016666666666667, 0.41666666666667
37275, 0.41304347826087, -0.016666666666667, 0.44444444444444
37276, 0.43478260869565, -0.033333333333333, 0.44444444444444
37277, 0.43478260869565, -0.016666666666667, 0.41666666666667
37278, 0.45652173913043, -0.016666666666667, 0.44444444444444
37279, 0.47826086956522, -0.033333333333333, 0.44444444444444
37280, 0.47826086956522, -0.016666666666667, 0.41666666666667
37281, 0.5, -0.016666666666667, 0.44444444444444
37282, 0.52173913043478, -0.033333333333333, 0.44444444444444
37283, 0.52173913043478, -0.016666666666667, 0.41666666666667
37284, 0.54347826086957, -0.016666666666667, 0.44444444444444
37285, 0.56521739130435, -0.033333333333333, 0.44444444444444
37286, 0.56521739130435, -0.016666666666667, 0.41666666666667
37287, 0.58695652173913, -0.016666666666667, 0.44444444444444
37288, 0.60869565217391, -0.033333333333333, 0.44444444444444
37289, 0.60869565217391, -0.016666666666667, 0.41666666666667
37290, 0.6304347826087, -0.016666666666667, 0.44444444444444
37291, 0.65217391304348, -0.033333333333333, 0.44444444444444
37292, 0.65217391304348, -0.016666666666667, 0.41666666666667
37293, 0.67391304347826, -0.016666666666667, 0.44444444444444
37294, 0.69565217391304, -0.033333333333333, 0.44444444444444
37295, 0.69565217391304, -0.016666666666667, 0.41666666666667
37296, 0.71739130434783, -0.016666666666667, 0.44444444444444
37297, 0.73913043478261, -0.033333333333333, 0.44444444444444
37298, 0.73913043478261, -0.016666666666667, 0.41666666666667
37299, 0.76086956521739, -0.016666666666667, 0.44444444444444
37300, 0.78260869565217, -0.033333333333333, 0.44444444444444
37301, 0.78260869565217, -0.016666666666667, 0.41666666666667
37302, 0.80434782608696, -0.016666666666667, 0.44444444444444
37303, 0.82608695652174, -0.033333333333333, 0.44444444444444
37304, 0.82608695652174, -0.016666666666667, 0.41666666666667
37305, 0.84782608695652, -0.016666666666667, 0.44444444444444
37306, 0.8695652173913, -0.033333333333333, 0.44444444444444
37307, 0.8695652173913, -0.016666666666667, 0.41666666666667
37308, 0.89130434782609, -0.016666666666667, 0.44444444444444
37309, 0.91304347826087, -0.033333333333333, 0.44444444444444
37310, 0.91304347826087, -0.016666666666667, 0.41666666666667
37311, 0.93478260869565, -0.016666666666667, 0.44444444444444
37312, 0.95652173913044, -0.033333333333333, 0.44444444444444
37313, 0.95652173913044, -0.016666666666667, 0.41666666666667
37314, 0.97826086956522, -0.016666666666667, 0.44444444444444
37315, 0.021739130434783, 0.016666666666667, 0.44444444444444
37316, 0.043478260869565, 5.8980598183211e-17, 0.44444444444444
37317, 0.043478260869565, 0.016666666666667, 0.41666666666667
37318, 0.065217391304348, 0.016666666666667, 0.44444444444444
37319, 0.08695652173913, 6.4184768611142e-17, 0.44444444444444
37320, 0.08695652173913, 0.016666666666667, 0.41666666666667
37321, 0.10869565217391, 0.016666666666667, 0.44444444444444
37322, 0.1304347826087, 5.8980598183211e-17, 0.44444444444444
37323, 0.1304347826087, 0.016666666666667, 0.41666666666667
37324, 0.15217391304348, 0.016666666666667, 0.44444444444444
37325, 0.17391304347826, 6.2450045135165e-17, 0.44444444444444
37326, 0.17391304347826, 0.016666666666667, 0.41666666666667
37327, 0.19565217391304, 0.016666666666667, 0.44444444444444
37328, 0.21739130434783, 5.3776427755281e-17, 0.44444444444444
37329, 0.21739130434783, 0.016666666666667, 0.41666666666667
37330, 0.23913043478261, 0.016666666666667, 0.44444444444444
37331, 0.26086956521739, 5.7245874707235e-17, 0.44444444444444
37332, 0.26086956521739, 0.016666666666667, 0.41666666666667
37333, 0.28260869565217, 0.016666666666667, 0.44444444444444
37334, 0.30434782608696, 6.2450045135165e-17, 0.44444444444444
37335, 0.30434782608696, 0.016666666666667, 0.41666666666667
37336, 0.32608695652174, 0.016666666666667, 0.44444444444444
37337, 0.34782608695652, 6.2450045135165e-17, 0.44444444444444
37338, 0.34782608695652, 0.016666666666667, 0.41666666666667
37339, 0.3695652173913, 0.016666666666667, 0.44444444444444
37340, 0.39130434782609, 5.7245874707235e-17, 0.44444444444444
37341, 0.39130434782609, 0.016666666666667, 0.41666666666667
37342, 0.41304347826087, 0.016666666666667, 0.44444444444444
37343, 0.43478260869565, 5.8980598183211e-17, 0.44444444444444
37344, 0.43478260869565, 0.016666666666667, 0.41666666666667
37345, 0.45652173913043, 0.016666666666667, 0.44444444444444
37346, 0.47826086956522, 6.2450045135165e-17, 0.44444444444444
37347, 0.47826086956522, 0.016666666666667, 0.41666666666667
37348, 0.5, 0.016666666666667, 0.44444444444444
37349, 0.52173913043478, 6.2450045135165e-17, 0.44444444444444
37350, 0.52173913043478, 0.016666666666667, 0.41666666666667
37351, 0.54347826086957, 0.016666666666667, 0.44444444444444
37352, 0.56521739130435, 6.0715321659188e-17, 0.44444444444444
37353, 0.56521739130435, 0.016666666666667, 0.41666666666667
37354, 0.58695652173913, 0.016666666666667, 0.44444444444444
37355, 0.60869565217391, 5.7245874707235e-17, 0.44444444444444
37356, 0.60869565217391, 0.016666666666667, 0.41666666666667
37357, 0.6304347826087, 0.016666666666667, 0.44444444444444
37358, 0.65217391304348, 6.0715321659188e-17, 0.44444444444444
37359, 0.65217391304348, 0.016666666666667, 0.41666666666667
37360, 0.67391304347826, 0.016666666666667, 0.44444444444444
37361, 0.69565217391304, 6.2450045135165e-17, 0.44444444444444
37362, 0.69565217391304, 0.016666666666667, 0.41666666666667
37363, 0.71739130434783, 0.016666666666667, 0.44444444444444
37364, 0.73913043478261, 6.2450045135165e-17, 0.44444444444444
37365, 0.73913043478261, 0.016666666666667, 0.41666666666667
37366, 0.76086956521739, 0.016666666666667, 0.44444444444444
37367, 0.78260869565217, 6.4184768611142e-17, 0.44444444444444
37368, 0.78260869565217, 0.016666666666667, 0.41666666666667
37369, 0.80434782608696, 0.016666666666667, 0.44444444444444
37370, 0.82608695652174, 6.2450045135165e-17, 0.44444444444444
37371, 0.82608695652174, 0.016666666666667, 0.41666666666667
37372, 0.84782608695652, 0.016666666666667, 0.44444444444444
37373, 0.8695652173913, 5.3776427755281e-17, 0.44444444444444
37374, 0.8695652173913, 0.016666666666667, 0.41666666666667
37375, 0.89130434782609, 0.016666666666667, 0.44444444444444
37376, 0.91304347826087, 6.0715321659188e-17, 0.44444444444444
37377, 0.91304347826087, 0.016666666666667, 0.41666666666667
37378, 0.93478260869565, 0.016666666666667, 0.44444444444444
37379, 0.95652173913044, 6.2450045135165e-17, 0.44444444444444
37380, 0.95652173913044, 0.016666666666667, 0.41666666666667
37381, 0.97826086956522, 0.016666666666667, 0.44444444444444
37382, 0.043478260869565, 0.033333333333333, 0.44444444444444
37383, 0.08695652173913, 0.033333333333333, 0.44444444444444
37384, 0.1304347826087, 0.033333333333333, 0.44444444444444
37385, 0.17391304347826, 0.033333333333333, 0.44444444444444
37386, 0.21739130434783, 0.033333333333333, 0.44444444444444
37387, 0.26086956521739, 0.033333333333333, 0.44444444444444
37388, 0.30434782608696, 0.033333333333333, 0.44444444444444
37389, 0.34782608695652, 0.033333333333333, 0.44444444444444
37390, 0.39130434782609, 0.033333333333333, 0.44444444444444
37391, 0.43478260869565, 0.033333333333333, 0.44444444444444
37392, 0.47826086956522, 0.033333333333333, 0.44444444444444
37393, 0.52173913043478, 0.033333333333333, 0.44444444444444
37394, 0.56521739130435, 0.033333333333333, 0.44444444444444
37395, 0.60869565217391, 0.033333333333333, 0.44444444444444
37396, 0.65217391304348, 0.033333333333333, 0.44444444444444
37397, 0.69565217391304, 0.033333333333333, 0.44444444444444
37398, 0.73913043478261, 0.033333333333333, 0.44444444444444
37399, 0.78260869565217, 0.033333333333333, 0.44444444444444
37400, 0.82608695652174, 0.033333333333333, 0.44444444444444
37401, 0.8695652173913, 0.033333333333333, 0.44444444444444
37402, 0.91304347826087, 0.033333333333333, 0.44444444444444
37403, 0.95652173913043, 0.033333333333333, 0.44444444444444
37404, 0.043478260869565, -0.016666666666667, 0.47222222222222
37405, 0.08695652173913, -0.016666666666667, 0.47222222222222
37406, 0.1304347826087, -0.016666666666667, 0.47222222222222
37407, 0.17391304347826, -0.016666666666667, 0.47222222222222
37408, 0.21739130434783, -0.016666666666667, 0.47222222222222
37409, 0.26086956521739, -0.016666666666667, 0.47222222222222
37410, 0.30434782608696, -0.016666666666667, 0.47222222222222
37411, 0.34782608695652, -0.016666666666667, 0.47222222222222
37412, 0.39130434782609, -0.016666666666667, 0.47222222222222
37413, 0.43478260869565, -0.016666666666667, 0.47222222222222
37414, 0.47826086956522, -0.016666666666667, 0.47222222222222
37415, 0.52173913043478, -0.016666666666667, 0.47222222222222
37416, 0.56521739130435, -0.016666666666667, 0.47222222222222
37417, 0.60869565217391, -0.016666666666667, 0.47222222222222
37418, 0.65217391304348, -0.016666666666667, 0.47222222222222
37419, 0.69565217391304, -0.016666666666667, 0.47222222222222
37420, 0.73913043478261, -0.016666666666667, 0.47222222222222
37421, 0.78260869565217, -0.016666666666667, 0.47222222222222
37422, 0.82608695652174, -0.016666666666667, 0.47222222222222
37423, 0.8695652173913, -0.016666666666667, 0.47222222222222
37424, 0.91304347826087, -0.016666666666667, 0.47222222222222
37425, 0.95652173913044, -0.016666666666667, 0.47222222222222
37426, 0.043478260869565, 0.016666666666667, 0.47222222222222
37427, 0.08695652173913, 0.016666666666667, 0.47222222222222
37428, 0.1304347826087, 0.016666666666667, 0.47222222222222
37429, 0.17391304347826, 0.016666666666667, 0.47222222222222
37430, 0.21739130434783, 0.016666666666667, 0.47222222222222
37431, 0.26086956521739, 0.016666666666667, 0.47222222222222
37432, 0.30434782608696, 0.016666666666667, 0.47222222222222
37433, 0.34782608695652, 0.016666666666667, 0.47222222222222
37434, 0.39130434782609, 0.016666666666667, 0.47222222222222
37435, 0.43478260869565, 0.016666666666667, 0.47222222222222
37436, 0.47826086956522, 0.016666666666667, 0.47222222222222
37437, 0.52173913043478, 0.016666666666667, 0.47222222222222
37438, 0.56521739130435, 0.016666666666667, 0.47222222222222
37439, 0.60869565217391, 0.016666666666667, 0.47222222222222
37440, 0.65217391304348, 0.016666666666667, 0.47222222222222
37441, 0.69565217391304, 0.016666666666667, 0.47222222222222
37442, 0.73913043478261, 0.016666666666667, 0.47222222222222
37443, 0.78260869565217, 0.016666666666667, 0.47222222222222
37444, 0.82608695652174, 0.016666666666667, 0.47222222222222
37445, 0.8695652173913, 0.016666666666667, 0.47222222222222
37446, 0.91304347826087, 0.016666666666667, 0.47222222222222
37447, 0.95652173913043, 0.016666666666667, 0.47222222222222
37448, 0.95652173913043, 0.125, 0.055555555555556
37449, 0.95652173913044, 0.125, 0.11111111111111
37450, 0.95652173913044, 0.125, 0.16666666666667
37451, 0.95652173913044, 0.125, 0.22222222222222
37452, 0.95652173913044, 0.125, 0.27777777777778
37453, 0.95652173913044, 0.125, 0.33333333333333
37454, 0.95652173913044, 0.125, 0.38888888888889
37455, 0.95652173913044, 0.125, 0.44444444444444
37456, 0.91304347826087, 0.125, 0.055555555555556
37457, 0.91304347826087, 0.125, 0.11111111111111
37458, 0.91304347826087, 0.125, 0.16666666666667
37459, 0.91304347826087, 0.125, 0.22222222222222
37460, 0.91304347826087, 0.125, 0.27777777777778
37461, 0.91304347826087, 0.125, 0.33333333333333
37462, 0.91304347826087, 0.125, 0.38888888888889
37463, 0.91304347826087, 0.125, 0.44444444444444
37464, 0.8695652173913, 0.125, 0.055555555555556
37465, 0.8695652173913, 0.125, 0.11111111111111
37466, 0.8695652173913, 0.125, 0.16666666666667
37467, 0.8695652173913, 0.125, 0.22222222222222
37468, 0.8695652173913, 0.125, 0.27777777777778
37469, 0.8695652173913, 0.125, 0.33333333333333
37470, 0.8695652173913, 0.125, 0.38888888888889
37471, 0.8695652173913, 0.125, 0.44444444444444
37472, 0.82608695652174, 0.125, 0.055555555555556
37473, 0.82608695652174, 0.125, 0.11111111111111
37474, 0.82608695652174, 0.125, 0.16666666666667
37475, 0.82608695652174, 0.125, 0.22222222222222
37476, 0.82608695652174, 0.125, 0.27777777777778
37477, 0.82608695652174, 0.125, 0.33333333333333
37478, 0.82608695652174, 0.125, 0.38888888888889
37479, 0.82608695652174, 0.125, 0.44444444444444
37480, 0.78260869565217, 0.125, 0.055555555555556
37481, 0.78260869565217, 0.125, 0.11111111111111
37482, 0.78260869565217, 0.125, 0.16666666666667
37483, 0.78260869565217, 0.125, 0.22222222222222
37484, 0.78260869565217, 0.125, 0.27777777777778
37485, 0.78260869565217, 0.125, 0.33333333333333
37486, 0.78260869565217, 0.125, 0.38888888888889
37487, 0.78260869565217, 0.125, 0.44444444444444
37488, 0.73913043478261, 0.125, 0.055555555555556
37489, 0.73913043478261, 0.125, 0.11111111111111
37490, 0.73913043478261, 0.125, 0.16666666666667
37491, 0.73913043478261, 0.125, 0.22222222222222
37492, 0.73913043478261, 0.125, 0.27777777777778
37493, 0.73913043478261, 0.125, 0.33333333333333
37494, 0.73913043478261, 0.125, 0.38888888888889
37495, 0.73913043478261, 0.125, 0.44444444444444
37496, 0.69565217391304, 0.125, 0.055555555555556
37497, 0.69565217391304, 0.125, 0.11111111111111
37498, 0.69565217391304, 0.125, 0.16666666666667
37499, 0.69565217391304, 0.125, 0.22222222222222
37500, 0.69565217391304, 0.125, 0.27777777777778
37501, 0.69565217391304, 0.125, 0.33333333333333
37502, 0.69565217391304, 0.125, 0.38888888888889
37503, 0.69565217391304, 0.125, 0.44444444444444
37504, 0.65217391304348, 0.125, 0.055555555555556
37505, 0.65217391304348, 0.125, 0.11111111111111
37506, 0.65217391304348, 0.125, 0.16666666666667
37507, 0.65217391304348, 0.125, 0.22222222222222
37508, 0.65217391304348, 0.125, 0.27777777777778
37509, 0.65217391304348, 0.125, 0.33333333333333
37510, 0.65217391304348, 0.125, 0.38888888888889
37511, 0.65217391304348, 0.125, 0.44444444444444
37512, 0.60869565217391, 0.125, 0.055555555555556
37513, 0.60869565217391, 0.125, 0.11111111111111
37514, 0.60869565217391, 0.125, 0.16666666666667
37515, 0.60869565217391, 0.125, 0.22222222222222
37516, 0.60869565217391, 0.125, 0.27777777777778
37517, 0.60869565217391, 0.125, 0.33333333333333
37518, 0.60869565217391, 0.125, 0.38888888888889
37519, 0.60869565217391, 0.125, 0.44444444444444
37520, 0.56521739130435, 0.125, 0.055555555555556
37521, 0.56521739130435, 0.125, 0.11111111111111
37522, 0.56521739130435, 0.125, 0.16666666666667
37523, 0.56521739130435, 0.125, 0.22222222222222
37524, 0.56521739130435, 0.125, 0.27777777777778
37525, 0.56521739130435, 0.125, 0.33333333333333
37526, 0.56521739130435, 0.125, 0.38888888888889
37527, 0.56521739130435, 0.125, 0.44444444444444
37528, 0.52173913043478, 0.125, 0.055555555555556
37529, 0.52173913043478, 0.125, 0.11111111111111
37530, 0.52173913043478, 0.125, 0.16666666666667
37531, 0.52173913043478, 0.125, 0.22222222222222
37532, 0.52173913043478, 0.125, 0.27777777777778
37533, 0.52173913043478, 0.125, 0.33333333333333
37534, 0.52173913043478, 0.125, 0.38888888888889
37535, 0.52173913043478, 0.125, 0.44444444444444
37536, 0.47826086956522, 0.125, 0.055555555555556
37537, 0.47826086956522, 0.125, 0.11111111111111
37538, 0.47826086956522, 0.125, 0.16666666666667
37539, 0.47826086956522, 0.125, 0.22222222222222
37540, 0.47826086956522, 0.125, 0.27777777777778
37541, 0.47826086956522, 0.125, 0.33333333333333
37542, 0.47826086956522, 0.125, 0.38888888888889
37543, 0.47826086956522, 0.125, 0.44444444444444
37544, 0.43478260869565, 0.125, 0.055555555555556
37545, 0.43478260869565, 0.125, 0.11111111111111
37546, 0.43478260869565, 0.125, 0.16666666666667
37547, 0.43478260869565, 0.125, 0.22222222222222
37548, 0.43478260869565, 0.125, 0.27777777777778
37549, 0.43478260869565, 0.125, 0.33333333333333
37550, 0.43478260869565, 0.125, 0.38888888888889
37551, 0.43478260869565, 0.125, 0.44444444444444
37552, 0.39130434782609, 0.125, 0.055555555555556
37553, 0.39130434782609, 0.125, 0.11111111111111
37554, 0.39130434782609, 0.125, 0.16666666666667
37555, 0.39130434782609, 0.125, 0.22222222222222
37556, 0.39130434782609, 0.125, 0.27777777777778
37557, 0.39130434782609, 0.125, 0.33333333333333
37558, 0.39130434782609, 0.125, 0.38888888888889
37559, 0.39130434782609, 0.125, 0.44444444444444
37560, 0.34782608695652, 0.125, 0.055555555555556
37561, 0.34782608695652, 0.125, 0.11111111111111
37562, 0.34782608695652, 0.125, 0.16666666666667
37563, 0.34782608695652, 0.125, 0.22222222222222
37564, 0.34782608695652, 0.125, 0.27777777777778
