33631, 1.2, 0.56739130434783, -0.175
33632, 1.2, 0.51521739130435, -0.175
33633, 1.2, 0.46304347826087, -0.175
33634, 1.2, 0.41086956521739, -0.175
33635, 1.2, 0.35869565217391, -0.175
33636, 1.2, 0.30652173913044, -0.175
33637, 1.2, 0.25434782608696, -0.175
33638, 1.2, 0.20217391304348, -0.175
33639, 2.2, 1.2978260869565, -0.05
33640, 2.2, 1.245652173913, -0.05
33641, 2.2, 1.1934782608696, -0.05
33642, 2.2, 1.1413043478261, -0.05
33643, 2.2, 1.0891304347826, -0.05
33644, 2.2, 1.0369565217391, -0.05
33645, 2.2, 0.98478260869565, -0.05
33646, 2.2, 0.93260869565217, -0.05
33647, 2.2, 0.8804347826087, -0.05
33648, 2.2, 0.82826086956522, -0.05
33649, 2.2, 0.77608695652174, -0.05
33650, 2.2, 0.72391304347826, -0.05
33651, 2.2, 0.67173913043478, -0.05
33652, 2.2, 0.61956521739131, -0.05
33653, 2.2, 0.56739130434783, -0.05
33654, 2.2, 0.51521739130435, -0.05
33655, 2.2, 0.46304347826087, -0.05
33656, 2.2, 0.41086956521739, -0.05
33657, 2.2, 0.35869565217391, -0.05
33658, 2.2, 0.30652173913043, -0.05
33659, 2.2, 0.25434782608696, -0.05
33660, 2.2, 0.20217391304348, -0.05
33661, 2.2, 1.2978260869565, -0.1
33662, 2.2, 1.245652173913, -0.1
33663, 2.2, 1.1934782608696, -0.1
33664, 2.2, 1.1413043478261, -0.1
33665, 2.2, 1.0891304347826, -0.1
33666, 2.2, 1.0369565217391, -0.1
33667, 2.2, 0.98478260869565, -0.1
33668, 2.2, 0.93260869565217, -0.1
33669, 2.2, 0.8804347826087, -0.1
33670, 2.2, 0.82826086956522, -0.1
33671, 2.2, 0.77608695652174, -0.1
33672, 2.2, 0.72391304347826, -0.1
33673, 2.2, 0.67173913043478, -0.1
33674, 2.2, 0.61956521739131, -0.1
33675, 2.2, 0.56739130434783, -0.1
33676, 2.2, 0.51521739130435, -0.1
33677, 2.2, 0.46304347826087, -0.1
33678, 2.2, 0.41086956521739, -0.1
33679, 2.2, 0.35869565217391, -0.1
33680, 2.2, 0.30652173913044, -0.1
33681, 2.2, 0.25434782608696, -0.1
33682, 2.2, 0.20217391304348, -0.1
33683, 2.2, 1.2978260869565, -0.15
33684, 2.2, 1.245652173913, -0.15
33685, 2.2, 1.1934782608696, -0.15
33686, 2.2, 1.1413043478261, -0.15
33687, 2.2, 1.0891304347826, -0.15
33688, 2.2, 1.0369565217391, -0.15
33689, 2.2, 0.98478260869565, -0.15
33690, 2.2, 0.93260869565217, -0.15
33691, 2.2, 0.8804347826087, -0.15
33692, 2.2, 0.82826086956522, -0.15
33693, 2.2, 0.77608695652174, -0.15
33694, 2.2, 0.72391304347826, -0.15
33695, 2.2, 0.67173913043478, -0.15
33696, 2.2, 0.61956521739131, -0.15
33697, 2.2, 0.56739130434783, -0.15
33698, 2.2, 0.51521739130435, -0.15
33699, 2.2, 0.46304347826087, -0.15
33700, 2.2, 0.41086956521739, -0.15
33701, 2.2, 0.35869565217391, -0.15
33702, 2.2, 0.30652173913044, -0.15
33703, 2.2, 0.25434782608696, -0.15
33704, 2.2, 0.20217391304348, -0.15
33705, 2.2, 1.2978260869565, -0.025
33706, 2.2, 1.3239130434783, -0.05
33707, 2.2, 1.245652173913, -0.025
33708, 2.2, 1.2717391304348, -0.05
33709, 2.2, 1.1934782608696, -0.025
33710, 2.2, 1.2195652173913, -0.05
33711, 2.2, 1.1413043478261, -0.025
33712, 2.2, 1.1673913043478, -0.05
33713, 2.2, 1.0891304347826, -0.025
33714, 2.2, 1.1152173913043, -0.05
33715, 2.2, 1.0369565217391, -0.025
33716, 2.2, 1.0630434782609, -0.05
33717, 2.2, 0.98478260869565, -0.025
33718, 2.2, 1.0108695652174, -0.05
33719, 2.2, 0.93260869565217, -0.025
33720, 2.2, 0.95869565217391, -0.05
33721, 2.2, 0.8804347826087, -0.025
33722, 2.2, 0.90652173913044, -0.05
33723, 2.2, 0.82826086956522, -0.025
33724, 2.2, 0.85434782608696, -0.05
33725, 2.2, 0.77608695652174, -0.025
33726, 2.2, 0.80217391304348, -0.05
33727, 2.2, 0.72391304347826, -0.025
33728, 2.2, 0.75, -0.05
33729, 2.2, 0.67173913043478, -0.025
33730, 2.2, 0.69782608695652, -0.05
33731, 2.2, 0.61956521739131, -0.025
33732, 2.2, 0.64565217391304, -0.05
33733, 2.2, 0.56739130434783, -0.025
33734, 2.2, 0.59347826086957, -0.05
33735, 2.2, 0.51521739130435, -0.025
33736, 2.2, 0.54130434782609, -0.05
33737, 2.2, 0.46304347826087, -0.025
33738, 2.2, 0.48913043478261, -0.05
33739, 2.2, 0.41086956521739, -0.025
33740, 2.2, 0.43695652173913, -0.05
33741, 2.2, 0.35869565217391, -0.025
33742, 2.2, 0.38478260869565, -0.05
33743, 2.2, 0.30652173913044, -0.025
33744, 2.2, 0.33260869565217, -0.05
33745, 2.2, 0.25434782608696, -0.025
33746, 2.2, 0.2804347826087, -0.05
33747, 2.2, 0.20217391304348, -0.025
33748, 2.2, 0.22826086956522, -0.05
33749, 2.2, 0.17608695652174, -0.05
33750, 2.2, 1.2978260869565, -0.075
33751, 2.2, 1.3239130434783, -0.1
33752, 2.2, 1.245652173913, -0.075
33753, 2.2, 1.2717391304348, -0.1
33754, 2.2, 1.1934782608696, -0.075
33755, 2.2, 1.2195652173913, -0.1
33756, 2.2, 1.1413043478261, -0.075
33757, 2.2, 1.1673913043478, -0.1
33758, 2.2, 1.0891304347826, -0.075
33759, 2.2, 1.1152173913043, -0.1
33760, 2.2, 1.0369565217391, -0.075
33761, 2.2, 1.0630434782609, -0.1
33762, 2.2, 0.98478260869565, -0.075
33763, 2.2, 1.0108695652174, -0.1
33764, 2.2, 0.93260869565217, -0.075
33765, 2.2, 0.95869565217391, -0.1
33766, 2.2, 0.8804347826087, -0.075
33767, 2.2, 0.90652173913044, -0.1
33768, 2.2, 0.82826086956522, -0.075
33769, 2.2, 0.85434782608696, -0.1
33770, 2.2, 0.77608695652174, -0.075
33771, 2.2, 0.80217391304348, -0.1
33772, 2.2, 0.72391304347826, -0.075
33773, 2.2, 0.75, -0.1
33774, 2.2, 0.67173913043478, -0.075
33775, 2.2, 0.69782608695652, -0.1
33776, 2.2, 0.61956521739131, -0.075
33777, 2.2, 0.64565217391304, -0.1
33778, 2.2, 0.56739130434783, -0.075
33779, 2.2, 0.59347826086957, -0.1
33780, 2.2, 0.51521739130435, -0.075
33781, 2.2, 0.54130434782609, -0.1
33782, 2.2, 0.46304347826087, -0.075
33783, 2.2, 0.48913043478261, -0.1
33784, 2.2, 0.41086956521739, -0.075
33785, 2.2, 0.43695652173913, -0.1
33786, 2.2, 0.35869565217391, -0.075
33787, 2.2, 0.38478260869565, -0.1
33788, 2.2, 0.30652173913044, -0.075
33789, 2.2, 0.33260869565217, -0.1
33790, 2.2, 0.25434782608696, -0.075
33791, 2.2, 0.2804347826087, -0.1
33792, 2.2, 0.20217391304348, -0.075
33793, 2.2, 0.22826086956522, -0.1
33794, 2.2, 0.17608695652174, -0.1
33795, 2.2, 1.2978260869565, -0.125
33796, 2.2, 1.3239130434783, -0.15
33797, 2.2, 1.245652173913, -0.125
33798, 2.2, 1.2717391304348, -0.15
33799, 2.2, 1.1934782608696, -0.125
33800, 2.2, 1.2195652173913, -0.15
33801, 2.2, 1.1413043478261, -0.125
33802, 2.2, 1.1673913043478, -0.15
33803, 2.2, 1.0891304347826, -0.125
33804, 2.2, 1.1152173913043, -0.15
33805, 2.2, 1.0369565217391, -0.125
33806, 2.2, 1.0630434782609, -0.15
33807, 2.2, 0.98478260869565, -0.125
33808, 2.2, 1.0108695652174, -0.15
33809, 2.2, 0.93260869565217, -0.125
33810, 2.2, 0.95869565217391, -0.15
33811, 2.2, 0.8804347826087, -0.125
33812, 2.2, 0.90652173913044, -0.15
33813, 2.2, 0.82826086956522, -0.125
33814, 2.2, 0.85434782608696, -0.15
33815, 2.2, 0.77608695652174, -0.125
33816, 2.2, 0.80217391304348, -0.15
33817, 2.2, 0.72391304347826, -0.125
33818, 2.2, 0.75, -0.15
33819, 2.2, 0.67173913043478, -0.125
33820, 2.2, 0.69782608695652, -0.15
33821, 2.2, 0.61956521739131, -0.125
33822, 2.2, 0.64565217391304, -0.15
33823, 2.2, 0.56739130434783, -0.125
33824, 2.2, 0.59347826086957, -0.15
33825, 2.2, 0.51521739130435, -0.125
33826, 2.2, 0.54130434782609, -0.15
33827, 2.2, 0.46304347826087, -0.125
33828, 2.2, 0.48913043478261, -0.15
33829, 2.2, 0.41086956521739, -0.125
33830, 2.2, 0.43695652173913, -0.15
33831, 2.2, 0.35869565217391, -0.125
33832, 2.2, 0.38478260869565, -0.15
33833, 2.2, 0.30652173913044, -0.125
33834, 2.2, 0.33260869565217, -0.15
33835, 2.2, 0.25434782608696, -0.125
33836, 2.2, 0.2804347826087, -0.15
33837, 2.2, 0.20217391304348, -0.125
33838, 2.2, 0.22826086956522, -0.15
33839, 2.2, 0.17608695652174, -0.15
33840, 2.2, 1.2978260869565, -0.175
33841, 2.2, 1.245652173913, -0.175
33842, 2.2, 1.1934782608696, -0.175
33843, 2.2, 1.1413043478261, -0.175
33844, 2.2, 1.0891304347826, -0.175
33845, 2.2, 1.0369565217391, -0.175
33846, 2.2, 0.98478260869565, -0.175
33847, 2.2, 0.93260869565217, -0.175
33848, 2.2, 0.8804347826087, -0.175
33849, 2.2, 0.82826086956522, -0.175
33850, 2.2, 0.77608695652174, -0.175
33851, 2.2, 0.72391304347826, -0.175
33852, 2.2, 0.67173913043478, -0.175
33853, 2.2, 0.61956521739131, -0.175
33854, 2.2, 0.56739130434783, -0.175
33855, 2.2, 0.51521739130435, -0.175
33856, 2.2, 0.46304347826087, -0.175
33857, 2.2, 0.41086956521739, -0.175
33858, 2.2, 0.35869565217391, -0.175
33859, 2.2, 0.30652173913044, -0.175
33860, 2.2, 0.25434782608696, -0.175
33861, 2.2, 0.20217391304348, -0.175
33862, 1.2434782608696, 1.35, -0.05
33863, 1.2869565217391, 1.35, -0.05
33864, 1.3304347826087, 1.35, -0.05
33865, 1.3739130434783, 1.35, -0.05
33866, 1.4173913043478, 1.35, -0.05
33867, 1.4608695652174, 1.35, -0.05
33868, 1.504347826087, 1.35, -0.05
33869, 1.5478260869565, 1.35, -0.05
33870, 1.5913043478261, 1.35, -0.05
33871, 1.6347826086957, 1.35, -0.05
33872, 1.6782608695652, 1.35, -0.05
33873, 1.7217391304348, 1.35, -0.05
33874, 1.7652173913043, 1.35, -0.05
33875, 1.8086956521739, 1.35, -0.05
33876, 1.8521739130435, 1.35, -0.05
33877, 1.895652173913, 1.35, -0.05
33878, 1.9391304347826, 1.35, -0.05
33879, 1.9826086956522, 1.35, -0.05
33880, 2.0260869565217, 1.35, -0.05
33881, 2.0695652173913, 1.35, -0.05
33882, 2.1130434782609, 1.35, -0.05
33883, 2.1565217391304, 1.35, -0.05
33884, 1.2434782608696, 1.35, -0.1
33885, 1.2869565217391, 1.35, -0.1
33886, 1.3304347826087, 1.35, -0.1
33887, 1.3739130434783, 1.35, -0.1
33888, 1.4173913043478, 1.35, -0.1
33889, 1.4608695652174, 1.35, -0.1
33890, 1.504347826087, 1.35, -0.1
33891, 1.5478260869565, 1.35, -0.1
33892, 1.5913043478261, 1.35, -0.1
33893, 1.6347826086957, 1.35, -0.1
33894, 1.6782608695652, 1.35, -0.1
33895, 1.7217391304348, 1.35, -0.1
33896, 1.7652173913043, 1.35, -0.1
33897, 1.8086956521739, 1.35, -0.1
33898, 1.8521739130435, 1.35, -0.1
33899, 1.895652173913, 1.35, -0.1
33900, 1.9391304347826, 1.35, -0.1
33901, 1.9826086956522, 1.35, -0.1
33902, 2.0260869565217, 1.35, -0.1
33903, 2.0695652173913, 1.35, -0.1
33904, 2.1130434782609, 1.35, -0.1
33905, 2.1565217391304, 1.35, -0.1
33906, 1.2434782608696, 1.35, -0.15
33907, 1.2869565217391, 1.35, -0.15
33908, 1.3304347826087, 1.35, -0.15
33909, 1.3739130434783, 1.35, -0.15
33910, 1.4173913043478, 1.35, -0.15
33911, 1.4608695652174, 1.35, -0.15
33912, 1.504347826087, 1.35, -0.15
33913, 1.5478260869565, 1.35, -0.15
33914, 1.5913043478261, 1.35, -0.15
33915, 1.6347826086957, 1.35, -0.15
33916, 1.6782608695652, 1.35, -0.15
33917, 1.7217391304348, 1.35, -0.15
33918, 1.7652173913043, 1.35, -0.15
33919, 1.8086956521739, 1.35, -0.15
33920, 1.8521739130435, 1.35, -0.15
33921, 1.895652173913, 1.35, -0.15
33922, 1.9391304347826, 1.35, -0.15
33923, 1.9826086956522, 1.35, -0.15
33924, 2.0260869565217, 1.35, -0.15
33925, 2.0695652173913, 1.35, -0.15
33926, 2.1130434782609, 1.35, -0.15
33927, 2.1565217391304, 1.35, -0.15
33928, 1.2434782608696, 1.35, -0.025
33929, 1.2217391304348, 1.35, -0.05
33930, 1.2869565217391, 1.35, -0.025
33931, 1.2652173913043, 1.35, -0.05
33932, 1.3304347826087, 1.35, -0.025
33933, 1.3086956521739, 1.35, -0.05
33934, 1.3739130434783, 1.35, -0.025
33935, 1.3521739130435, 1.35, -0.05
33936, 1.4173913043478, 1.35, -0.025
33937, 1.395652173913, 1.35, -0.05
33938, 1.4608695652174, 1.35, -0.025
33939, 1.4391304347826, 1.35, -0.05
33940, 1.504347826087, 1.35, -0.025
33941, 1.4826086956522, 1.35, -0.05
33942, 1.5478260869565, 1.35, -0.025
33943, 1.5260869565217, 1.35, -0.05
33944, 1.5913043478261, 1.35, -0.025
33945, 1.5695652173913, 1.35, -0.05
33946, 1.6347826086957, 1.35, -0.025
33947, 1.6130434782609, 1.35, -0.05
33948, 1.6782608695652, 1.35, -0.025
33949, 1.6565217391304, 1.35, -0.05
33950, 1.7217391304348, 1.35, -0.025
33951, 1.7, 1.35, -0.05
33952, 1.7652173913043, 1.35, -0.025
33953, 1.7434782608696, 1.35, -0.05
33954, 1.8086956521739, 1.35, -0.025
33955, 1.7869565217391, 1.35, -0.05
33956, 1.8521739130435, 1.35, -0.025
33957, 1.8304347826087, 1.35, -0.05
33958, 1.895652173913, 1.35, -0.025
33959, 1.8739130434783, 1.35, -0.05
33960, 1.9391304347826, 1.35, -0.025
33961, 1.9173913043478, 1.35, -0.05
33962, 1.9826086956522, 1.35, -0.025
33963, 1.9608695652174, 1.35, -0.05
33964, 2.0260869565217, 1.35, -0.025
33965, 2.004347826087, 1.35, -0.05
33966, 2.0695652173913, 1.35, -0.025
33967, 2.0478260869565, 1.35, -0.05
33968, 2.1130434782609, 1.35, -0.025
33969, 2.0913043478261, 1.35, -0.05
33970, 2.1565217391304, 1.35, -0.025
33971, 2.1347826086957, 1.35, -0.05
33972, 2.1782608695652, 1.35, -0.05
33973, 1.2434782608696, 1.35, -0.075
33974, 1.2217391304348, 1.35, -0.1
33975, 1.2869565217391, 1.35, -0.075
33976, 1.2652173913043, 1.35, -0.1
33977, 1.3304347826087, 1.35, -0.075
33978, 1.3086956521739, 1.35, -0.1
33979, 1.3739130434783, 1.35, -0.075
33980, 1.3521739130435, 1.35, -0.1
33981, 1.4173913043478, 1.35, -0.075
33982, 1.395652173913, 1.35, -0.1
33983, 1.4608695652174, 1.35, -0.075
33984, 1.4391304347826, 1.35, -0.1
33985, 1.504347826087, 1.35, -0.075
33986, 1.4826086956522, 1.35, -0.1
33987, 1.5478260869565, 1.35, -0.075
33988, 1.5260869565217, 1.35, -0.1
33989, 1.5913043478261, 1.35, -0.075
33990, 1.5695652173913, 1.35, -0.1
33991, 1.6347826086957, 1.35, -0.075
33992, 1.6130434782609, 1.35, -0.1
33993, 1.6782608695652, 1.35, -0.075
33994, 1.6565217391304, 1.35, -0.1
33995, 1.7217391304348, 1.35, -0.075
33996, 1.7, 1.35, -0.1
33997, 1.7652173913043, 1.35, -0.075
33998, 1.7434782608696, 1.35, -0.1
33999, 1.8086956521739, 1.35, -0.075
34000, 1.7869565217391, 1.35, -0.1
34001, 1.8521739130435, 1.35, -0.075
34002, 1.8304347826087, 1.35, -0.1
34003, 1.895652173913, 1.35, -0.075
34004, 1.8739130434783, 1.35, -0.1
34005, 1.9391304347826, 1.35, -0.075
34006, 1.9173913043478, 1.35, -0.1
34007, 1.9826086956522, 1.35, -0.075
34008, 1.9608695652174, 1.35, -0.1
34009, 2.0260869565217, 1.35, -0.075
34010, 2.004347826087, 1.35, -0.1
34011, 2.0695652173913, 1.35, -0.075
34012, 2.0478260869565, 1.35, -0.1
34013, 2.1130434782609, 1.35, -0.075
34014, 2.0913043478261, 1.35, -0.1
34015, 2.1565217391304, 1.35, -0.075
34016, 2.1347826086957, 1.35, -0.1
34017, 2.1782608695652, 1.35, -0.1
34018, 1.2434782608696, 1.35, -0.125
34019, 1.2217391304348, 1.35, -0.15
34020, 1.2869565217391, 1.35, -0.125
34021, 1.2652173913043, 1.35, -0.15
34022, 1.3304347826087, 1.35, -0.125
34023, 1.3086956521739, 1.35, -0.15
34024, 1.3739130434783, 1.35, -0.125
34025, 1.3521739130435, 1.35, -0.15
34026, 1.4173913043478, 1.35, -0.125
34027, 1.395652173913, 1.35, -0.15
34028, 1.4608695652174, 1.35, -0.125
34029, 1.4391304347826, 1.35, -0.15
34030, 1.504347826087, 1.35, -0.125
34031, 1.4826086956522, 1.35, -0.15
34032, 1.5478260869565, 1.35, -0.125
34033, 1.5260869565217, 1.35, -0.15
34034, 1.5913043478261, 1.35, -0.125
34035, 1.5695652173913, 1.35, -0.15
34036, 1.6347826086957, 1.35, -0.125
34037, 1.6130434782609, 1.35, -0.15
34038, 1.6782608695652, 1.35, -0.125
34039, 1.6565217391304, 1.35, -0.15
34040, 1.7217391304348, 1.35, -0.125
34041, 1.7, 1.35, -0.15
34042, 1.7652173913043, 1.35, -0.125
34043, 1.7434782608696, 1.35, -0.15
34044, 1.8086956521739, 1.35, -0.125
34045, 1.7869565217391, 1.35, -0.15
34046, 1.8521739130435, 1.35, -0.125
34047, 1.8304347826087, 1.35, -0.15
34048, 1.895652173913, 1.35, -0.125
34049, 1.8739130434783, 1.35, -0.15
34050, 1.9391304347826, 1.35, -0.125
34051, 1.9173913043478, 1.35, -0.15
34052, 1.9826086956522, 1.35, -0.125
34053, 1.9608695652174, 1.35, -0.15
34054, 2.0260869565217, 1.35, -0.125
34055, 2.004347826087, 1.35, -0.15
34056, 2.0695652173913, 1.35, -0.125
34057, 2.0478260869565, 1.35, -0.15
34058, 2.1130434782609, 1.35, -0.125
34059, 2.0913043478261, 1.35, -0.15
34060, 2.1565217391304, 1.35, -0.125
34061, 2.1347826086957, 1.35, -0.15
34062, 2.1782608695652, 1.35, -0.15
34063, 1.2434782608696, 1.35, -0.175
34064, 1.2869565217391, 1.35, -0.175
34065, 1.3304347826087, 1.35, -0.175
34066, 1.3739130434783, 1.35, -0.175
34067, 1.4173913043478, 1.35, -0.175
34068, 1.4608695652174, 1.35, -0.175
34069, 1.504347826087, 1.35, -0.175
34070, 1.5478260869565, 1.35, -0.175
34071, 1.5913043478261, 1.35, -0.175
34072, 1.6347826086957, 1.35, -0.175
34073, 1.6782608695652, 1.35, -0.175
34074, 1.7217391304348, 1.35, -0.175
34075, 1.7652173913043, 1.35, -0.175
34076, 1.8086956521739, 1.35, -0.175
34077, 1.8521739130435, 1.35, -0.175
34078, 1.895652173913, 1.35, -0.175
34079, 1.9391304347826, 1.35, -0.175
34080, 1.9826086956522, 1.35, -0.175
34081, 2.0260869565217, 1.35, -0.175
34082, 2.0695652173913, 1.35, -0.175
34083, 2.1130434782609, 1.35, -0.175
34084, 2.1565217391304, 1.35, -0.175
34085, 1.2434782608696, 0.15, -0.05
34086, 1.2869565217391, 0.15, -0.05
34087, 1.3304347826087, 0.15, -0.05
34088, 1.3739130434783, 0.15, -0.05
34089, 1.4173913043478, 0.15, -0.05
34090, 1.4608695652174, 0.15, -0.05
34091, 1.504347826087, 0.15, -0.05
34092, 1.5478260869565, 0.15, -0.05
34093, 1.5913043478261, 0.15, -0.05
34094, 1.6347826086957, 0.15, -0.05
34095, 1.6782608695652, 0.15, -0.05
34096, 1.7217391304348, 0.15, -0.05
34097, 1.7652173913043, 0.15, -0.05
34098, 1.8086956521739, 0.15, -0.05
34099, 1.8521739130435, 0.15, -0.05
34100, 1.895652173913, 0.15, -0.05
34101, 1.9391304347826, 0.15, -0.05
34102, 1.9826086956522, 0.15, -0.05
34103, 2.0260869565217, 0.15, -0.05
34104, 2.0695652173913, 0.15, -0.05
34105, 2.1130434782609, 0.15, -0.05
34106, 2.1565217391304, 0.15, -0.05
34107, 1.2434782608696, 0.15, -0.1
34108, 1.2869565217391, 0.15, -0.1
34109, 1.3304347826087, 0.15, -0.1
34110, 1.3739130434783, 0.15, -0.1
34111, 1.4173913043478, 0.15, -0.1
34112, 1.4608695652174, 0.15, -0.1
34113, 1.504347826087, 0.15, -0.1
34114, 1.5478260869565, 0.15, -0.1
34115, 1.5913043478261, 0.15, -0.1
34116, 1.6347826086957, 0.15, -0.1
34117, 1.6782608695652, 0.15, -0.1
34118, 1.7217391304348, 0.15, -0.1
34119, 1.7652173913043, 0.15, -0.1
34120, 1.8086956521739, 0.15, -0.1
34121, 1.8521739130435, 0.15, -0.1
34122, 1.895652173913, 0.15, -0.1
34123, 1.9391304347826, 0.15, -0.1
34124, 1.9826086956522, 0.15, -0.1
34125, 2.0260869565217, 0.15, -0.1
34126, 2.0695652173913, 0.15, -0.1
34127, 2.1130434782609, 0.15, -0.1
34128, 2.1565217391304, 0.15, -0.1
34129, 1.2434782608696, 0.15, -0.15
34130, 1.2869565217391, 0.15, -0.15
34131, 1.3304347826087, 0.15, -0.15
34132, 1.3739130434783, 0.15, -0.15
34133, 1.4173913043478, 0.15, -0.15
34134, 1.4608695652174, 0.15, -0.15
34135, 1.504347826087, 0.15, -0.15
34136, 1.5478260869565, 0.15, -0.15
34137, 1.5913043478261, 0.15, -0.15
34138, 1.6347826086957, 0.15, -0.15
34139, 1.6782608695652, 0.15, -0.15
34140, 1.7217391304348, 0.15, -0.15
34141, 1.7652173913043, 0.15, -0.15
34142, 1.8086956521739, 0.15, -0.15
34143, 1.8521739130435, 0.15, -0.15
34144, 1.895652173913, 0.15, -0.15
34145, 1.9391304347826, 0.15, -0.15
34146, 1.9826086956522, 0.15, -0.15
34147, 2.0260869565217, 0.15, -0.15
34148, 2.0695652173913, 0.15, -0.15
34149, 2.1130434782609, 0.15, -0.15
34150, 2.1565217391304, 0.15, -0.15
34151, 1.2217391304348, 0.15, -0.05
34152, 1.2434782608696, 0.15, -0.025
34153, 1.2652173913043, 0.15, -0.05
34154, 1.2869565217391, 0.15, -0.025
34155, 1.3086956521739, 0.15, -0.05
34156, 1.3304347826087, 0.15, -0.025
34157, 1.3521739130435, 0.15, -0.05
34158, 1.3739130434783, 0.15, -0.025
34159, 1.395652173913, 0.15, -0.05
34160, 1.4173913043478, 0.15, -0.025
34161, 1.4391304347826, 0.15, -0.05
34162, 1.4608695652174, 0.15, -0.025
34163, 1.4826086956522, 0.15, -0.05
34164, 1.504347826087, 0.15, -0.025
34165, 1.5260869565217, 0.15, -0.05
34166, 1.5478260869565, 0.15, -0.025
34167, 1.5695652173913, 0.15, -0.05
34168, 1.5913043478261, 0.15, -0.025
34169, 1.6130434782609, 0.15, -0.05
34170, 1.6347826086957, 0.15, -0.025
34171, 1.6565217391304, 0.15, -0.05
34172, 1.6782608695652, 0.15, -0.025
34173, 1.7, 0.15, -0.05
34174, 1.7217391304348, 0.15, -0.025
34175, 1.7434782608696, 0.15, -0.05
34176, 1.7652173913043, 0.15, -0.025
34177, 1.7869565217391, 0.15, -0.05
34178, 1.8086956521739, 0.15, -0.025
34179, 1.8304347826087, 0.15, -0.05
34180, 1.8521739130435, 0.15, -0.025
34181, 1.8739130434783, 0.15, -0.05
34182, 1.895652173913, 0.15, -0.025
34183, 1.9173913043478, 0.15, -0.05
34184, 1.9391304347826, 0.15, -0.025
34185, 1.9608695652174, 0.15, -0.05
34186, 1.9826086956522, 0.15, -0.025
34187, 2.004347826087, 0.15, -0.05
34188, 2.0260869565217, 0.15, -0.025
34189, 2.0478260869565, 0.15, -0.05
34190, 2.0695652173913, 0.15, -0.025
34191, 2.0913043478261, 0.15, -0.05
34192, 2.1130434782609, 0.15, -0.025
34193, 2.1347826086957, 0.15, -0.05
34194, 2.1565217391304, 0.15, -0.025
34195, 2.1782608695652, 0.15, -0.05
34196, 1.2217391304348, 0.15, -0.1
34197, 1.2434782608696, 0.15, -0.075
34198, 1.2652173913043, 0.15, -0.1
34199, 1.2869565217391, 0.15, -0.075
34200, 1.3086956521739, 0.15, -0.1
34201, 1.3304347826087, 0.15, -0.075
34202, 1.3521739130435, 0.15, -0.1
34203, 1.3739130434783, 0.15, -0.075
34204, 1.395652173913, 0.15, -0.1
34205, 1.4173913043478, 0.15, -0.075
34206, 1.4391304347826, 0.15, -0.1
34207, 1.4608695652174, 0.15, -0.075
34208, 1.4826086956522, 0.15, -0.1
34209, 1.504347826087, 0.15, -0.075
34210, 1.5260869565217, 0.15, -0.1
34211, 1.5478260869565, 0.15, -0.075
34212, 1.5695652173913, 0.15, -0.1
34213, 1.5913043478261, 0.15, -0.075
34214, 1.6130434782609, 0.15, -0.1
34215, 1.6347826086957, 0.15, -0.075
34216, 1.6565217391304, 0.15, -0.1
34217, 1.6782608695652, 0.15, -0.075
34218, 1.7, 0.15, -0.1
34219, 1.7217391304348, 0.15, -0.075
34220, 1.7434782608696, 0.15, -0.1
34221, 1.7652173913043, 0.15, -0.075
34222, 1.7869565217391, 0.15, -0.1
34223, 1.8086956521739, 0.15, -0.075
34224, 1.8304347826087, 0.15, -0.1
34225, 1.8521739130435, 0.15, -0.075
34226, 1.8739130434783, 0.15, -0.1
34227, 1.895652173913, 0.15, -0.075
34228, 1.9173913043478, 0.15, -0.1
34229, 1.9391304347826, 0.15, -0.075
34230, 1.9608695652174, 0.15, -0.1
34231, 1.9826086956522, 0.15, -0.075
34232, 2.004347826087, 0.15, -0.1
34233, 2.0260869565217, 0.15, -0.075
34234, 2.0478260869565, 0.15, -0.1
34235, 2.0695652173913, 0.15, -0.075
34236, 2.0913043478261, 0.15, -0.1
34237, 2.1130434782609, 0.15, -0.075
34238, 2.1347826086957, 0.15, -0.1
34239, 2.1565217391304, 0.15, -0.075
34240, 2.1782608695652, 0.15, -0.1
34241, 1.2217391304348, 0.15, -0.15
34242, 1.2434782608696, 0.15, -0.125
34243, 1.2652173913043, 0.15, -0.15
34244, 1.2869565217391, 0.15, -0.125
34245, 1.3086956521739, 0.15, -0.15
34246, 1.3304347826087, 0.15, -0.125
34247, 1.3521739130435, 0.15, -0.15
34248, 1.3739130434783, 0.15, -0.125
34249, 1.395652173913, 0.15, -0.15
34250, 1.4173913043478, 0.15, -0.125
34251, 1.4391304347826, 0.15, -0.15
34252, 1.4608695652174, 0.15, -0.125
34253, 1.4826086956522, 0.15, -0.15
34254, 1.504347826087, 0.15, -0.125
34255, 1.5260869565217, 0.15, -0.15
34256, 1.5478260869565, 0.15, -0.125
34257, 1.5695652173913, 0.15, -0.15
34258, 1.5913043478261, 0.15, -0.125
34259, 1.6130434782609, 0.15, -0.15
34260, 1.6347826086957, 0.15, -0.125
34261, 1.6565217391304, 0.15, -0.15
34262, 1.6782608695652, 0.15, -0.125
34263, 1.7, 0.15, -0.15
34264, 1.7217391304348, 0.15, -0.125
34265, 1.7434782608696, 0.15, -0.15
34266, 1.7652173913043, 0.15, -0.125
34267, 1.7869565217391, 0.15, -0.15
34268, 1.8086956521739, 0.15, -0.125
34269, 1.8304347826087, 0.15, -0.15
34270, 1.8521739130435, 0.15, -0.125
34271, 1.8739130434783, 0.15, -0.15
34272, 1.895652173913, 0.15, -0.125
34273, 1.9173913043478, 0.15, -0.15
34274, 1.9391304347826, 0.15, -0.125
34275, 1.9608695652174, 0.15, -0.15
34276, 1.9826086956522, 0.15, -0.125
34277, 2.004347826087, 0.15, -0.15
34278, 2.0260869565217, 0.15, -0.125
34279, 2.0478260869565, 0.15, -0.15
34280, 2.0695652173913, 0.15, -0.125
34281, 2.0913043478261, 0.15, -0.15
34282, 2.1130434782609, 0.15, -0.125
34283, 2.1347826086957, 0.15, -0.15
34284, 2.1565217391304, 0.15, -0.125
34285, 2.1782608695652, 0.15, -0.15
34286, 1.2434782608696, 0.15, -0.175
34287, 1.2869565217391, 0.15, -0.175
34288, 1.3304347826087, 0.15, -0.175
34289, 1.3739130434783, 0.15, -0.175
34290, 1.4173913043478, 0.15, -0.175
34291, 1.4608695652174, 0.15, -0.175
34292, 1.504347826087, 0.15, -0.175
34293, 1.5478260869565, 0.15, -0.175
34294, 1.5913043478261, 0.15, -0.175
34295, 1.6347826086957, 0.15, -0.175
34296, 1.6782608695652, 0.15, -0.175
34297, 1.7217391304348, 0.15, -0.175
34298, 1.7652173913043, 0.15, -0.175
34299, 1.8086956521739, 0.15, -0.175
34300, 1.8521739130435, 0.15, -0.175
34301, 1.895652173913, 0.15, -0.175
34302, 1.9391304347826, 0.15, -0.175
34303, 1.9826086956522, 0.15, -0.175
34304, 2.0260869565217, 0.15, -0.175
34305, 2.0695652173913, 0.15, -0.175
34306, 2.1130434782609, 0.15, -0.175
34307, 2.1565217391304, 0.15, -0.175
34308, 1.2434782608696, 1.2978260869565, -0.2
34309, 1.2869565217391, 1.2978260869565, -0.2
34310, 1.3304347826087, 1.2978260869565, -0.2
34311, 1.3739130434783, 1.2978260869565, -0.2
34312, 1.4173913043478, 1.2978260869565, -0.2
34313, 1.4608695652174, 1.2978260869565, -0.2
34314, 1.504347826087, 1.2978260869565, -0.2
34315, 1.5478260869565, 1.2978260869565, -0.2
34316, 1.5913043478261, 1.2978260869565, -0.2
34317, 1.6347826086957, 1.2978260869565, -0.2
34318, 1.6782608695652, 1.2978260869565, -0.2
34319, 1.7217391304348, 1.2978260869565, -0.2
34320, 1.7652173913043, 1.2978260869565, -0.2
34321, 1.8086956521739, 1.2978260869565, -0.2
34322, 1.8521739130435, 1.2978260869565, -0.2
34323, 1.895652173913, 1.2978260869565, -0.2
34324, 1.9391304347826, 1.2978260869565, -0.2
34325, 1.9826086956522, 1.2978260869565, -0.2
34326, 2.0260869565217, 1.2978260869565, -0.2
34327, 2.0695652173913, 1.2978260869565, -0.2
34328, 2.1130434782609, 1.2978260869565, -0.2
34329, 2.1565217391304, 1.2978260869565, -0.2
34330, 1.2434782608696, 1.245652173913, -0.2
34331, 1.2869565217391, 1.245652173913, -0.2
34332, 1.3304347826087, 1.245652173913, -0.2
34333, 1.3739130434783, 1.245652173913, -0.2
34334, 1.4173913043478, 1.245652173913, -0.2
34335, 1.4608695652174, 1.245652173913, -0.2
34336, 1.504347826087, 1.245652173913, -0.2
34337, 1.5478260869565, 1.245652173913, -0.2
34338, 1.5913043478261, 1.245652173913, -0.2
34339, 1.6347826086957, 1.245652173913, -0.2
34340, 1.6782608695652, 1.245652173913, -0.2
34341, 1.7217391304348, 1.245652173913, -0.2
34342, 1.7652173913043, 1.245652173913, -0.2
34343, 1.8086956521739, 1.245652173913, -0.2
34344, 1.8521739130435, 1.245652173913, -0.2
34345, 1.895652173913, 1.245652173913, -0.2
34346, 1.9391304347826, 1.245652173913, -0.2
34347, 1.9826086956522, 1.245652173913, -0.2
34348, 2.0260869565217, 1.245652173913, -0.2
34349, 2.0695652173913, 1.245652173913, -0.2
34350, 2.1130434782609, 1.245652173913, -0.2
34351, 2.1565217391304, 1.245652173913, -0.2
34352, 1.2434782608696, 1.1934782608696, -0.2
34353, 1.2869565217391, 1.1934782608696, -0.2
34354, 1.3304347826087, 1.1934782608696, -0.2
34355, 1.3739130434783, 1.1934782608696, -0.2
34356, 1.4173913043478, 1.1934782608696, -0.2
34357, 1.4608695652174, 1.1934782608696, -0.2
34358, 1.504347826087, 1.1934782608696, -0.2
34359, 1.5478260869565, 1.1934782608696, -0.2
34360, 1.5913043478261, 1.1934782608696, -0.2
34361, 1.6347826086957, 1.1934782608696, -0.2
34362, 1.6782608695652, 1.1934782608696, -0.2
34363, 1.7217391304348, 1.1934782608696, -0.2
34364, 1.7652173913043, 1.1934782608696, -0.2
34365, 1.8086956521739, 1.1934782608696, -0.2
34366, 1.8521739130435, 1.1934782608696, -0.2
34367, 1.895652173913, 1.1934782608696, -0.2
34368, 1.9391304347826, 1.1934782608696, -0.2
34369, 1.9826086956522, 1.1934782608696, -0.2
34370, 2.0260869565217, 1.1934782608696, -0.2
34371, 2.0695652173913, 1.1934782608696, -0.2
34372, 2.1130434782609, 1.1934782608696, -0.2
34373, 2.1565217391304, 1.1934782608696, -0.2
34374, 1.2434782608696, 1.1413043478261, -0.2
34375, 1.2869565217391, 1.1413043478261, -0.2
34376, 1.3304347826087, 1.1413043478261, -0.2
34377, 1.3739130434783, 1.1413043478261, -0.2
34378, 1.4173913043478, 1.1413043478261, -0.2
34379, 1.4608695652174, 1.1413043478261, -0.2
34380, 1.504347826087, 1.1413043478261, -0.2
34381, 1.5478260869565, 1.1413043478261, -0.2
34382, 1.5913043478261, 1.1413043478261, -0.2
34383, 1.6347826086957, 1.1413043478261, -0.2
34384, 1.6782608695652, 1.1413043478261, -0.2
34385, 1.7217391304348, 1.1413043478261, -0.2
34386, 1.7652173913043, 1.1413043478261, -0.2
34387, 1.8086956521739, 1.1413043478261, -0.2
34388, 1.8521739130435, 1.1413043478261, -0.2
34389, 1.895652173913, 1.1413043478261, -0.2
34390, 1.9391304347826, 1.1413043478261, -0.2
34391, 1.9826086956522, 1.1413043478261, -0.2
34392, 2.0260869565217, 1.1413043478261, -0.2
34393, 2.0695652173913, 1.1413043478261, -0.2
34394, 2.1130434782609, 1.1413043478261, -0.2
34395, 2.1565217391304, 1.1413043478261, -0.2
34396, 1.2434782608696, 1.0891304347826, -0.2
34397, 1.2869565217391, 1.0891304347826, -0.2
34398, 1.3304347826087, 1.0891304347826, -0.2
34399, 1.3739130434783, 1.0891304347826, -0.2
34400, 1.4173913043478, 1.0891304347826, -0.2
34401, 1.4608695652174, 1.0891304347826, -0.2
34402, 1.504347826087, 1.0891304347826, -0.2
34403, 1.5478260869565, 1.0891304347826, -0.2
34404, 1.5913043478261, 1.0891304347826, -0.2
34405, 1.6347826086957, 1.0891304347826, -0.2
34406, 1.6782608695652, 1.0891304347826, -0.2
34407, 1.7217391304348, 1.0891304347826, -0.2
34408, 1.7652173913043, 1.0891304347826, -0.2
34409, 1.8086956521739, 1.0891304347826, -0.2
34410, 1.8521739130435, 1.0891304347826, -0.2
34411, 1.895652173913, 1.0891304347826, -0.2
34412, 1.9391304347826, 1.0891304347826, -0.2
34413, 1.9826086956522, 1.0891304347826, -0.2
34414, 2.0260869565217, 1.0891304347826, -0.2
34415, 2.0695652173913, 1.0891304347826, -0.2
34416, 2.1130434782609, 1.0891304347826, -0.2
34417, 2.1565217391304, 1.0891304347826, -0.2
34418, 1.2434782608696, 1.0369565217391, -0.2
34419, 1.2869565217391, 1.0369565217391, -0.2
34420, 1.3304347826087, 1.0369565217391, -0.2
34421, 1.3739130434783, 1.0369565217391, -0.2
34422, 1.4173913043478, 1.0369565217391, -0.2
34423, 1.4608695652174, 1.0369565217391, -0.2
34424, 1.504347826087, 1.0369565217391, -0.2
34425, 1.5478260869565, 1.0369565217391, -0.2
34426, 1.5913043478261, 1.0369565217391, -0.2
34427, 1.6347826086957, 1.0369565217391, -0.2
34428, 1.6782608695652, 1.0369565217391, -0.2
34429, 1.7217391304348, 1.0369565217391, -0.2
34430, 1.7652173913043, 1.0369565217391, -0.2
34431, 1.8086956521739, 1.0369565217391, -0.2
34432, 1.8521739130435, 1.0369565217391, -0.2
34433, 1.895652173913, 1.0369565217391, -0.2
34434, 1.9391304347826, 1.0369565217391, -0.2
34435, 1.9826086956522, 1.0369565217391, -0.2
34436, 2.0260869565217, 1.0369565217391, -0.2
34437, 2.0695652173913, 1.0369565217391, -0.2
34438, 2.1130434782609, 1.0369565217391, -0.2
34439, 2.1565217391304, 1.0369565217391, -0.2
34440, 1.2434782608696, 0.98478260869565, -0.2
34441, 1.2869565217391, 0.98478260869565, -0.2
34442, 1.3304347826087, 0.98478260869565, -0.2
34443, 1.3739130434783, 0.98478260869565, -0.2
34444, 1.4173913043478, 0.98478260869565, -0.2
34445, 1.4608695652174, 0.98478260869565, -0.2
34446, 1.504347826087, 0.98478260869565, -0.2
34447, 1.5478260869565, 0.98478260869565, -0.2
34448, 1.5913043478261, 0.98478260869565, -0.2
34449, 1.6347826086957, 0.98478260869565, -0.2
34450, 1.6782608695652, 0.98478260869565, -0.2
34451, 1.7217391304348, 0.98478260869565, -0.2
34452, 1.7652173913043, 0.98478260869565, -0.2
34453, 1.8086956521739, 0.98478260869565, -0.2
34454, 1.8521739130435, 0.98478260869565, -0.2
34455, 1.895652173913, 0.98478260869565, -0.2
34456, 1.9391304347826, 0.98478260869565, -0.2
34457, 1.9826086956522, 0.98478260869565, -0.2
34458, 2.0260869565217, 0.98478260869565, -0.2
34459, 2.0695652173913, 0.98478260869565, -0.2
34460, 2.1130434782609, 0.98478260869565, -0.2
34461, 2.1565217391304, 0.98478260869565, -0.2
34462, 1.2434782608696, 0.93260869565217, -0.2
34463, 1.2869565217391, 0.93260869565217, -0.2
34464, 1.3304347826087, 0.93260869565217, -0.2
34465, 1.3739130434783, 0.93260869565217, -0.2
34466, 1.4173913043478, 0.93260869565217, -0.2
34467, 1.4608695652174, 0.93260869565217, -0.2
34468, 1.504347826087, 0.93260869565217, -0.2
34469, 1.5478260869565, 0.93260869565217, -0.2
34470, 1.5913043478261, 0.93260869565217, -0.2
34471, 1.6347826086957, 0.93260869565217, -0.2
34472, 1.6782608695652, 0.93260869565217, -0.2
34473, 1.7217391304348, 0.93260869565217, -0.2
34474, 1.7652173913043, 0.93260869565217, -0.2
34475, 1.8086956521739, 0.93260869565217, -0.2
34476, 1.8521739130435, 0.93260869565217, -0.2
34477, 1.895652173913, 0.93260869565217, -0.2
34478, 1.9391304347826, 0.93260869565217, -0.2
34479, 1.9826086956522, 0.93260869565217, -0.2
34480, 2.0260869565217, 0.93260869565217, -0.2
34481, 2.0695652173913, 0.93260869565217, -0.2
34482, 2.1130434782609, 0.93260869565217, -0.2
34483, 2.1565217391304, 0.93260869565217, -0.2
34484, 1.2434782608696, 0.8804347826087, -0.2
34485, 1.2869565217391, 0.8804347826087, -0.2
34486, 1.3304347826087, 0.8804347826087, -0.2
34487, 1.3739130434783, 0.8804347826087, -0.2
34488, 1.4173913043478, 0.8804347826087, -0.2
34489, 1.4608695652174, 0.8804347826087, -0.2
34490, 1.504347826087, 0.8804347826087, -0.2
34491, 1.5478260869565, 0.8804347826087, -0.2
34492, 1.5913043478261, 0.8804347826087, -0.2
34493, 1.6347826086957, 0.8804347826087, -0.2
34494, 1.6782608695652, 0.8804347826087, -0.2
34495, 1.7217391304348, 0.8804347826087, -0.2
34496, 1.7652173913043, 0.8804347826087, -0.2
34497, 1.8086956521739, 0.8804347826087, -0.2
34498, 1.8521739130435, 0.8804347826087, -0.2
34499, 1.895652173913, 0.8804347826087, -0.2
34500, 1.9391304347826, 0.8804347826087, -0.2
34501, 1.9826086956522, 0.8804347826087, -0.2
34502, 2.0260869565217, 0.8804347826087, -0.2
34503, 2.0695652173913, 0.8804347826087, -0.2
34504, 2.1130434782609, 0.8804347826087, -0.2
34505, 2.1565217391304, 0.8804347826087, -0.2
34506, 1.2434782608696, 0.82826086956522, -0.2
34507, 1.2869565217391, 0.82826086956522, -0.2
34508, 1.3304347826087, 0.82826086956522, -0.2
34509, 1.3739130434783, 0.82826086956522, -0.2
34510, 1.4173913043478, 0.82826086956522, -0.2
34511, 1.4608695652174, 0.82826086956522, -0.2
34512, 1.504347826087, 0.82826086956522, -0.2
34513, 1.5478260869565, 0.82826086956522, -0.2
34514, 1.5913043478261, 0.82826086956522, -0.2
34515, 1.6347826086957, 0.82826086956522, -0.2
34516, 1.6782608695652, 0.82826086956522, -0.2
34517, 1.7217391304348, 0.82826086956522, -0.2
34518, 1.7652173913043, 0.82826086956522, -0.2
34519, 1.8086956521739, 0.82826086956522, -0.2
34520, 1.8521739130435, 0.82826086956522, -0.2
34521, 1.895652173913, 0.82826086956522, -0.2
34522, 1.9391304347826, 0.82826086956522, -0.2
34523, 1.9826086956522, 0.82826086956522, -0.2
34524, 2.0260869565217, 0.82826086956522, -0.2
34525, 2.0695652173913, 0.82826086956522, -0.2
34526, 2.1130434782609, 0.82826086956522, -0.2
34527, 2.1565217391304, 0.82826086956522, -0.2
34528, 1.2434782608696, 0.77608695652174, -0.2
34529, 1.2869565217391, 0.77608695652174, -0.2
34530, 1.3304347826087, 0.77608695652174, -0.2
34531, 1.3739130434783, 0.77608695652174, -0.2
34532, 1.4173913043478, 0.77608695652174, -0.2
34533, 1.4608695652174, 0.77608695652174, -0.2
34534, 1.504347826087, 0.77608695652174, -0.2
34535, 1.5478260869565, 0.77608695652174, -0.2
34536, 1.5913043478261, 0.77608695652174, -0.2
34537, 1.6347826086957, 0.77608695652174, -0.2
34538, 1.6782608695652, 0.77608695652174, -0.2
34539, 1.7217391304348, 0.77608695652174, -0.2
34540, 1.7652173913043, 0.77608695652174, -0.2
34541, 1.8086956521739, 0.77608695652174, -0.2
34542, 1.8521739130435, 0.77608695652174, -0.2
34543, 1.895652173913, 0.77608695652174, -0.2
34544, 1.9391304347826, 0.77608695652174, -0.2
34545, 1.9826086956522, 0.77608695652174, -0.2
34546, 2.0260869565217, 0.77608695652174, -0.2
34547, 2.0695652173913, 0.77608695652174, -0.2
34548, 2.1130434782609, 0.77608695652174, -0.2
34549, 2.1565217391304, 0.77608695652174, -0.2
34550, 1.2434782608696, 0.72391304347826, -0.2
34551, 1.2869565217391, 0.72391304347826, -0.2
34552, 1.3304347826087, 0.72391304347826, -0.2
34553, 1.3739130434783, 0.72391304347826, -0.2
34554, 1.4173913043478, 0.72391304347826, -0.2
34555, 1.4608695652174, 0.72391304347826, -0.2
34556, 1.504347826087, 0.72391304347826, -0.2
34557, 1.5478260869565, 0.72391304347826, -0.2
34558, 1.5913043478261, 0.72391304347826, -0.2
34559, 1.6347826086957, 0.72391304347826, -0.2
34560, 1.6782608695652, 0.72391304347826, -0.2
34561, 1.7217391304348, 0.72391304347826, -0.2
34562, 1.7652173913043, 0.72391304347826, -0.2
34563, 1.8086956521739, 0.72391304347826, -0.2
34564, 1.8521739130435, 0.72391304347826, -0.2
34565, 1.895652173913, 0.72391304347826, -0.2
34566, 1.9391304347826, 0.72391304347826, -0.2
34567, 1.9826086956522, 0.72391304347826, -0.2
34568, 2.0260869565217, 0.72391304347826, -0.2
34569, 2.0695652173913, 0.72391304347826, -0.2
34570, 2.1130434782609, 0.72391304347826, -0.2
34571, 2.1565217391304, 0.72391304347826, -0.2
34572, 1.2434782608696, 0.67173913043478, -0.2
34573, 1.2869565217391, 0.67173913043478, -0.2
34574, 1.3304347826087, 0.67173913043478, -0.2
34575, 1.3739130434783, 0.67173913043478, -0.2
34576, 1.4173913043478, 0.67173913043478, -0.2
34577, 1.4608695652174, 0.67173913043478, -0.2
34578, 1.504347826087, 0.67173913043478, -0.2
34579, 1.5478260869565, 0.67173913043478, -0.2
34580, 1.5913043478261, 0.67173913043478, -0.2
34581, 1.6347826086957, 0.67173913043478, -0.2
34582, 1.6782608695652, 0.67173913043478, -0.2
34583, 1.7217391304348, 0.67173913043478, -0.2
34584, 1.7652173913043, 0.67173913043478, -0.2
34585, 1.8086956521739, 0.67173913043478, -0.2
34586, 1.8521739130435, 0.67173913043478, -0.2
34587, 1.895652173913, 0.67173913043478, -0.2
34588, 1.9391304347826, 0.67173913043478, -0.2
34589, 1.9826086956522, 0.67173913043478, -0.2
34590, 2.0260869565217, 0.67173913043478, -0.2
34591, 2.0695652173913, 0.67173913043478, -0.2
34592, 2.1130434782609, 0.67173913043478, -0.2
34593, 2.1565217391304, 0.67173913043478, -0.2
34594, 1.2434782608696, 0.61956521739131, -0.2
34595, 1.2869565217391, 0.61956521739131, -0.2
34596, 1.3304347826087, 0.61956521739131, -0.2
34597, 1.3739130434783, 0.61956521739131, -0.2
34598, 1.4173913043478, 0.61956521739131, -0.2
34599, 1.4608695652174, 0.61956521739131, -0.2
34600, 1.504347826087, 0.6195652173913, -0.2
34601, 1.5478260869565, 0.61956521739131, -0.2
34602, 1.5913043478261, 0.61956521739131, -0.2
34603, 1.6347826086957, 0.61956521739131, -0.2
34604, 1.6782608695652, 0.61956521739131, -0.2
34605, 1.7217391304348, 0.61956521739131, -0.2
34606, 1.7652173913043, 0.61956521739131, -0.2
34607, 1.8086956521739, 0.61956521739131, -0.2
34608, 1.8521739130435, 0.61956521739131, -0.2
34609, 1.895652173913, 0.61956521739131, -0.2
34610, 1.9391304347826, 0.61956521739131, -0.2
34611, 1.9826086956522, 0.61956521739131, -0.2
34612, 2.0260869565217, 0.61956521739131, -0.2
34613, 2.0695652173913, 0.61956521739131, -0.2
34614, 2.1130434782609, 0.61956521739131, -0.2
34615, 2.1565217391304, 0.61956521739131, -0.2
34616, 1.2434782608696, 0.56739130434783, -0.2
34617, 1.2869565217391, 0.56739130434783, -0.2
34618, 1.3304347826087, 0.56739130434783, -0.2
34619, 1.3739130434783, 0.56739130434783, -0.2
34620, 1.4173913043478, 0.56739130434783, -0.2
34621, 1.4608695652174, 0.56739130434783, -0.2
34622, 1.504347826087, 0.56739130434783, -0.2
34623, 1.5478260869565, 0.56739130434783, -0.2
34624, 1.5913043478261, 0.56739130434783, -0.2
34625, 1.6347826086957, 0.56739130434783, -0.2
34626, 1.6782608695652, 0.56739130434783, -0.2
34627, 1.7217391304348, 0.56739130434783, -0.2
34628, 1.7652173913043, 0.56739130434783, -0.2
34629, 1.8086956521739, 0.56739130434783, -0.2
34630, 1.8521739130435, 0.56739130434783, -0.2
34631, 1.895652173913, 0.56739130434783, -0.2
34632, 1.9391304347826, 0.56739130434783, -0.2
34633, 1.9826086956522, 0.56739130434783, -0.2
34634, 2.0260869565217, 0.56739130434783, -0.2
34635, 2.0695652173913, 0.56739130434783, -0.2
34636, 2.1130434782609, 0.56739130434783, -0.2
34637, 2.1565217391304, 0.56739130434783, -0.2
34638, 1.2434782608696, 0.51521739130435, -0.2
34639, 1.2869565217391, 0.51521739130435, -0.2
34640, 1.3304347826087, 0.51521739130435, -0.2
34641, 1.3739130434783, 0.51521739130435, -0.2
34642, 1.4173913043478, 0.51521739130435, -0.2
34643, 1.4608695652174, 0.51521739130435, -0.2
34644, 1.504347826087, 0.51521739130435, -0.2
34645, 1.5478260869565, 0.51521739130435, -0.2
34646, 1.5913043478261, 0.51521739130435, -0.2
34647, 1.6347826086957, 0.51521739130435, -0.2
34648, 1.6782608695652, 0.51521739130435, -0.2
34649, 1.7217391304348, 0.51521739130435, -0.2
34650, 1.7652173913043, 0.51521739130435, -0.2
34651, 1.8086956521739, 0.51521739130435, -0.2
34652, 1.8521739130435, 0.51521739130435, -0.2
34653, 1.895652173913, 0.51521739130435, -0.2
34654, 1.9391304347826, 0.51521739130435, -0.2
34655, 1.9826086956522, 0.51521739130435, -0.2
34656, 2.0260869565217, 0.51521739130435, -0.2
34657, 2.0695652173913, 0.51521739130435, -0.2
34658, 2.1130434782609, 0.51521739130435, -0.2
34659, 2.1565217391304, 0.51521739130435, -0.2
34660, 1.2434782608696, 0.46304347826087, -0.2
34661, 1.2869565217391, 0.46304347826087, -0.2
34662, 1.3304347826087, 0.46304347826087, -0.2
34663, 1.3739130434783, 0.46304347826087, -0.2
34664, 1.4173913043478, 0.46304347826087, -0.2
34665, 1.4608695652174, 0.46304347826087, -0.2
34666, 1.504347826087, 0.46304347826087, -0.2
34667, 1.5478260869565, 0.46304347826087, -0.2
34668, 1.5913043478261, 0.46304347826087, -0.2
34669, 1.6347826086957, 0.46304347826087, -0.2
34670, 1.6782608695652, 0.46304347826087, -0.2
34671, 1.7217391304348, 0.46304347826087, -0.2
34672, 1.7652173913043, 0.46304347826087, -0.2
34673, 1.8086956521739, 0.46304347826087, -0.2
34674, 1.8521739130435, 0.46304347826087, -0.2
34675, 1.895652173913, 0.46304347826087, -0.2
34676, 1.9391304347826, 0.46304347826087, -0.2
34677, 1.9826086956522, 0.46304347826087, -0.2
34678, 2.0260869565217, 0.46304347826087, -0.2
34679, 2.0695652173913, 0.46304347826087, -0.2
34680, 2.1130434782609, 0.46304347826087, -0.2
34681, 2.1565217391304, 0.46304347826087, -0.2
34682, 1.2434782608696, 0.41086956521739, -0.2
34683, 1.2869565217391, 0.41086956521739, -0.2
34684, 1.3304347826087, 0.41086956521739, -0.2
34685, 1.3739130434783, 0.41086956521739, -0.2
34686, 1.4173913043478, 0.41086956521739, -0.2
34687, 1.4608695652174, 0.41086956521739, -0.2
34688, 1.504347826087, 0.41086956521739, -0.2
34689, 1.5478260869565, 0.41086956521739, -0.2
34690, 1.5913043478261, 0.41086956521739, -0.2
34691, 1.6347826086957, 0.41086956521739, -0.2
34692, 1.6782608695652, 0.41086956521739, -0.2
34693, 1.7217391304348, 0.41086956521739, -0.2
34694, 1.7652173913043, 0.41086956521739, -0.2
34695, 1.8086956521739, 0.41086956521739, -0.2
34696, 1.8521739130435, 0.41086956521739, -0.2
34697, 1.895652173913, 0.41086956521739, -0.2
34698, 1.9391304347826, 0.41086956521739, -0.2
34699, 1.9826086956522, 0.41086956521739, -0.2
34700, 2.0260869565217, 0.41086956521739, -0.2
34701, 2.0695652173913, 0.41086956521739, -0.2
34702, 2.1130434782609, 0.41086956521739, -0.2
34703, 2.1565217391304, 0.41086956521739, -0.2
34704, 1.2434782608696, 0.35869565217391, -0.2
34705, 1.2869565217391, 0.35869565217391, -0.2
34706, 1.3304347826087, 0.35869565217391, -0.2
34707, 1.3739130434783, 0.35869565217391, -0.2
34708, 1.4173913043478, 0.35869565217391, -0.2
34709, 1.4608695652174, 0.35869565217391, -0.2
34710, 1.504347826087, 0.35869565217391, -0.2
34711, 1.5478260869565, 0.35869565217391, -0.2
34712, 1.5913043478261, 0.35869565217391, -0.2
34713, 1.6347826086957, 0.35869565217391, -0.2
34714, 1.6782608695652, 0.35869565217391, -0.2
34715, 1.7217391304348, 0.35869565217391, -0.2
34716, 1.7652173913043, 0.35869565217391, -0.2
34717, 1.8086956521739, 0.35869565217391, -0.2
34718, 1.8521739130435, 0.35869565217391, -0.2
34719, 1.895652173913, 0.35869565217391, -0.2
34720, 1.9391304347826, 0.35869565217391, -0.2
34721, 1.9826086956522, 0.35869565217391, -0.2
34722, 2.0260869565217, 0.35869565217391, -0.2
34723, 2.0695652173913, 0.35869565217391, -0.2
34724, 2.1130434782609, 0.35869565217391, -0.2
34725, 2.1565217391304, 0.35869565217391, -0.2
34726, 1.2434782608696, 0.30652173913044, -0.2
34727, 1.2869565217391, 0.30652173913043, -0.2
34728, 1.3304347826087, 0.30652173913043, -0.2
34729, 1.3739130434783, 0.30652173913044, -0.2
34730, 1.4173913043478, 0.30652173913044, -0.2
34731, 1.4608695652174, 0.30652173913043, -0.2
34732, 1.504347826087, 0.30652173913044, -0.2
34733, 1.5478260869565, 0.30652173913044, -0.2
34734, 1.5913043478261, 0.30652173913044, -0.2
34735, 1.6347826086957, 0.30652173913043, -0.2
34736, 1.6782608695652, 0.30652173913043, -0.2
34737, 1.7217391304348, 0.30652173913043, -0.2
34738, 1.7652173913043, 0.30652173913043, -0.2
34739, 1.8086956521739, 0.30652173913044, -0.2
34740, 1.8521739130435, 0.30652173913043, -0.2
34741, 1.895652173913, 0.30652173913044, -0.2
34742, 1.9391304347826, 0.30652173913043, -0.2
34743, 1.9826086956522, 0.30652173913044, -0.2
34744, 2.0260869565217, 0.30652173913044, -0.2
34745, 2.0695652173913, 0.30652173913043, -0.2
34746, 2.1130434782609, 0.30652173913043, -0.2
34747, 2.1565217391304, 0.30652173913043, -0.2
34748, 1.2434782608696, 0.25434782608696, -0.2
34749, 1.2869565217391, 0.25434782608696, -0.2
34750, 1.3304347826087, 0.25434782608696, -0.2
34751, 1.3739130434783, 0.25434782608696, -0.2
34752, 1.4173913043478, 0.25434782608696, -0.2
34753, 1.4608695652174, 0.25434782608696, -0.2
34754, 1.504347826087, 0.25434782608696, -0.2
34755, 1.5478260869565, 0.25434782608696, -0.2
34756, 1.5913043478261, 0.25434782608696, -0.2
34757, 1.6347826086957, 0.25434782608696, -0.2
34758, 1.6782608695652, 0.25434782608696, -0.2
34759, 1.7217391304348, 0.25434782608696, -0.2
34760, 1.7652173913043, 0.25434782608696, -0.2
34761, 1.8086956521739, 0.25434782608696, -0.2
34762, 1.8521739130435, 0.25434782608696, -0.2
34763, 1.895652173913, 0.25434782608696, -0.2
34764, 1.9391304347826, 0.25434782608696, -0.2
34765, 1.9826086956522, 0.25434782608696, -0.2
34766, 2.0260869565217, 0.25434782608696, -0.2
34767, 2.0695652173913, 0.25434782608696, -0.2
34768, 2.1130434782609, 0.25434782608696, -0.2
34769, 2.1565217391304, 0.25434782608696, -0.2
34770, 1.2434782608696, 0.20217391304348, -0.2
34771, 1.2869565217391, 0.20217391304348, -0.2
34772, 1.3304347826087, 0.20217391304348, -0.2
34773, 1.3739130434783, 0.20217391304348, -0.2
34774, 1.4173913043478, 0.20217391304348, -0.2
34775, 1.4608695652174, 0.20217391304348, -0.2
34776, 1.504347826087, 0.20217391304348, -0.2
34777, 1.5478260869565, 0.20217391304348, -0.2
34778, 1.5913043478261, 0.20217391304348, -0.2
34779, 1.6347826086957, 0.20217391304348, -0.2
34780, 1.6782608695652, 0.20217391304348, -0.2
34781, 1.7217391304348, 0.20217391304348, -0.2
34782, 1.7652173913043, 0.20217391304348, -0.2
34783, 1.8086956521739, 0.20217391304348, -0.2
34784, 1.8521739130435, 0.20217391304348, -0.2
34785, 1.895652173913, 0.20217391304348, -0.2
34786, 1.9391304347826, 0.20217391304348, -0.2
34787, 1.9826086956522, 0.20217391304348, -0.2
34788, 2.0260869565217, 0.20217391304348, -0.2
34789, 2.0695652173913, 0.20217391304348, -0.2
34790, 2.1130434782609, 0.20217391304348, -0.2
34791, 2.1565217391304, 0.20217391304348, -0.2
34792, 1.2434782608696, 1.3239130434783, -0.2
34793, 1.2217391304348, 1.2978260869565, -0.2
34794, 1.2869565217391, 1.3239130434783, -0.2
34795, 1.2652173913043, 1.2978260869565, -0.2
34796, 1.3304347826087, 1.3239130434783, -0.2
34797, 1.3086956521739, 1.2978260869565, -0.2
34798, 1.3739130434783, 1.3239130434783, -0.2
34799, 1.3521739130435, 1.2978260869565, -0.2
34800, 1.4173913043478, 1.3239130434783, -0.2
34801, 1.395652173913, 1.2978260869565, -0.2
34802, 1.4608695652174, 1.3239130434783, -0.2
34803, 1.4391304347826, 1.2978260869565, -0.2
34804, 1.504347826087, 1.3239130434783, -0.2
34805, 1.4826086956522, 1.2978260869565, -0.2
34806, 1.5478260869565, 1.3239130434783, -0.2
34807, 1.5260869565217, 1.2978260869565, -0.2
34808, 1.5913043478261, 1.3239130434783, -0.2
34809, 1.5695652173913, 1.2978260869565, -0.2
34810, 1.6347826086957, 1.3239130434783, -0.2
34811, 1.6130434782609, 1.2978260869565, -0.2
34812, 1.6782608695652, 1.3239130434783, -0.2
34813, 1.6565217391304, 1.2978260869565, -0.2
34814, 1.7217391304348, 1.3239130434783, -0.2
34815, 1.7, 1.2978260869565, -0.2
34816, 1.7652173913043, 1.3239130434783, -0.2
34817, 1.7434782608696, 1.2978260869565, -0.2
34818, 1.8086956521739, 1.3239130434783, -0.2
34819, 1.7869565217391, 1.2978260869565, -0.2
34820, 1.8521739130435, 1.3239130434783, -0.2
34821, 1.8304347826087, 1.2978260869565, -0.2
34822, 1.895652173913, 1.3239130434783, -0.2
34823, 1.8739130434783, 1.2978260869565, -0.2
34824, 1.9391304347826, 1.3239130434783, -0.2
34825, 1.9173913043478, 1.2978260869565, -0.2
34826, 1.9826086956522, 1.3239130434783, -0.2
34827, 1.9608695652174, 1.2978260869565, -0.2
34828, 2.0260869565217, 1.3239130434783, -0.2
34829, 2.004347826087, 1.2978260869565, -0.2
34830, 2.0695652173913, 1.3239130434783, -0.2
34831, 2.0478260869565, 1.2978260869565, -0.2
34832, 2.1130434782609, 1.3239130434783, -0.2
34833, 2.0913043478261, 1.2978260869565, -0.2
34834, 2.1565217391304, 1.3239130434783, -0.2
34835, 2.1347826086957, 1.2978260869565, -0.2
34836, 2.1782608695652, 1.2978260869565, -0.2
34837, 1.2434782608696, 1.2717391304348, -0.2
34838, 1.2217391304348, 1.245652173913, -0.2
34839, 1.2869565217391, 1.2717391304348, -0.2
34840, 1.2652173913043, 1.245652173913, -0.2
34841, 1.3304347826087, 1.2717391304348, -0.2
34842, 1.3086956521739, 1.245652173913, -0.2
34843, 1.3739130434783, 1.2717391304348, -0.2
34844, 1.3521739130435, 1.245652173913, -0.2
34845, 1.4173913043478, 1.2717391304348, -0.2
34846, 1.395652173913, 1.245652173913, -0.2
34847, 1.4608695652174, 1.2717391304348, -0.2
34848, 1.4391304347826, 1.245652173913, -0.2
34849, 1.504347826087, 1.2717391304348, -0.2
34850, 1.4826086956522, 1.245652173913, -0.2
34851, 1.5478260869565, 1.2717391304348, -0.2
34852, 1.5260869565217, 1.245652173913, -0.2
34853, 1.5913043478261, 1.2717391304348, -0.2
34854, 1.5695652173913, 1.245652173913, -0.2
34855, 1.6347826086957, 1.2717391304348, -0.2
34856, 1.6130434782609, 1.245652173913, -0.2
34857, 1.6782608695652, 1.2717391304348, -0.2
34858, 1.6565217391304, 1.245652173913, -0.2
34859, 1.7217391304348, 1.2717391304348, -0.2
34860, 1.7, 1.245652173913, -0.2
34861, 1.7652173913043, 1.2717391304348, -0.2
34862, 1.7434782608696, 1.245652173913, -0.2
34863, 1.8086956521739, 1.2717391304348, -0.2
34864, 1.7869565217391, 1.245652173913, -0.2
34865, 1.8521739130435, 1.2717391304348, -0.2
34866, 1.8304347826087, 1.245652173913, -0.2
34867, 1.895652173913, 1.2717391304348, -0.2
34868, 1.8739130434783, 1.245652173913, -0.2
34869, 1.9391304347826, 1.2717391304348, -0.2
34870, 1.9173913043478, 1.245652173913, -0.2
34871, 1.9826086956522, 1.2717391304348, -0.2
34872, 1.9608695652174, 1.245652173913, -0.2
34873, 2.0260869565217, 1.2717391304348, -0.2
34874, 2.004347826087, 1.245652173913, -0.2
34875, 2.0695652173913, 1.2717391304348, -0.2
34876, 2.0478260869565, 1.245652173913, -0.2
34877, 2.1130434782609, 1.2717391304348, -0.2
34878, 2.0913043478261, 1.245652173913, -0.2
34879, 2.1565217391304, 1.2717391304348, -0.2
34880, 2.1347826086957, 1.245652173913, -0.2
34881, 2.1782608695652, 1.245652173913, -0.2
34882, 1.2434782608696, 1.2195652173913, -0.2
34883, 1.2217391304348, 1.1934782608696, -0.2
34884, 1.2869565217391, 1.2195652173913, -0.2
34885, 1.2652173913043, 1.1934782608696, -0.2
34886, 1.3304347826087, 1.2195652173913, -0.2
34887, 1.3086956521739, 1.1934782608696, -0.2
34888, 1.3739130434783, 1.2195652173913, -0.2
34889, 1.3521739130435, 1.1934782608696, -0.2
34890, 1.4173913043478, 1.2195652173913, -0.2
34891, 1.395652173913, 1.1934782608696, -0.2
34892, 1.4608695652174, 1.2195652173913, -0.2
34893, 1.4391304347826, 1.1934782608696, -0.2
34894, 1.504347826087, 1.2195652173913, -0.2
34895, 1.4826086956522, 1.1934782608696, -0.2
34896, 1.5478260869565, 1.2195652173913, -0.2
34897, 1.5260869565217, 1.1934782608696, -0.2
34898, 1.5913043478261, 1.2195652173913, -0.2
34899, 1.5695652173913, 1.1934782608696, -0.2
34900, 1.6347826086957, 1.2195652173913, -0.2
34901, 1.6130434782609, 1.1934782608696, -0.2
34902, 1.6782608695652, 1.2195652173913, -0.2
34903, 1.6565217391304, 1.1934782608696, -0.2
34904, 1.7217391304348, 1.2195652173913, -0.2
34905, 1.7, 1.1934782608696, -0.2
34906, 1.7652173913043, 1.2195652173913, -0.2
34907, 1.7434782608696, 1.1934782608696, -0.2
34908, 1.8086956521739, 1.2195652173913, -0.2
34909, 1.7869565217391, 1.1934782608696, -0.2
34910, 1.8521739130435, 1.2195652173913, -0.2
34911, 1.8304347826087, 1.1934782608696, -0.2
34912, 1.895652173913, 1.2195652173913, -0.2
34913, 1.8739130434783, 1.1934782608696, -0.2
34914, 1.9391304347826, 1.2195652173913, -0.2
34915, 1.9173913043478, 1.1934782608696, -0.2
34916, 1.9826086956522, 1.2195652173913, -0.2
34917, 1.9608695652174, 1.1934782608696, -0.2
34918, 2.0260869565217, 1.2195652173913, -0.2
34919, 2.004347826087, 1.1934782608696, -0.2
34920, 2.0695652173913, 1.2195652173913, -0.2
34921, 2.0478260869565, 1.1934782608696, -0.2
34922, 2.1130434782609, 1.2195652173913, -0.2
34923, 2.0913043478261, 1.1934782608696, -0.2
34924, 2.1565217391304, 1.2195652173913, -0.2
34925, 2.1347826086957, 1.1934782608696, -0.2
34926, 2.1782608695652, 1.1934782608696, -0.2
34927, 1.2434782608696, 1.1673913043478, -0.2
34928, 1.2217391304348, 1.1413043478261, -0.2
34929, 1.2869565217391, 1.1673913043478, -0.2
34930, 1.2652173913043, 1.1413043478261, -0.2
34931, 1.3304347826087, 1.1673913043478, -0.2
34932, 1.3086956521739, 1.1413043478261, -0.2
34933, 1.3739130434783, 1.1673913043478, -0.2
34934, 1.3521739130435, 1.1413043478261, -0.2
34935, 1.4173913043478, 1.1673913043478, -0.2
34936, 1.395652173913, 1.1413043478261, -0.2
34937, 1.4608695652174, 1.1673913043478, -0.2
34938, 1.4391304347826, 1.1413043478261, -0.2
34939, 1.504347826087, 1.1673913043478, -0.2
34940, 1.4826086956522, 1.1413043478261, -0.2
34941, 1.5478260869565, 1.1673913043478, -0.2
34942, 1.5260869565217, 1.1413043478261, -0.2
34943, 1.5913043478261, 1.1673913043478, -0.2
34944, 1.5695652173913, 1.1413043478261, -0.2
34945, 1.6347826086957, 1.1673913043478, -0.2
34946, 1.6130434782609, 1.1413043478261, -0.2
34947, 1.6782608695652, 1.1673913043478, -0.2
34948, 1.6565217391304, 1.1413043478261, -0.2
34949, 1.7217391304348, 1.1673913043478, -0.2
34950, 1.7, 1.1413043478261, -0.2
34951, 1.7652173913043, 1.1673913043478, -0.2
34952, 1.7434782608696, 1.1413043478261, -0.2
34953, 1.8086956521739, 1.1673913043478, -0.2
34954, 1.7869565217391, 1.1413043478261, -0.2
34955, 1.8521739130435, 1.1673913043478, -0.2
34956, 1.8304347826087, 1.1413043478261, -0.2
34957, 1.895652173913, 1.1673913043478, -0.2
34958, 1.8739130434783, 1.1413043478261, -0.2
34959, 1.9391304347826, 1.1673913043478, -0.2
34960, 1.9173913043478, 1.1413043478261, -0.2
34961, 1.9826086956522, 1.1673913043478, -0.2
34962, 1.9608695652174, 1.1413043478261, -0.2
34963, 2.0260869565217, 1.1673913043478, -0.2
34964, 2.004347826087, 1.1413043478261, -0.2
34965, 2.0695652173913, 1.1673913043478, -0.2
34966, 2.0478260869565, 1.1413043478261, -0.2
34967, 2.1130434782609, 1.1673913043478, -0.2
34968, 2.0913043478261, 1.1413043478261, -0.2
34969, 2.1565217391304, 1.1673913043478, -0.2
34970, 2.1347826086957, 1.1413043478261, -0.2
34971, 2.1782608695652, 1.1413043478261, -0.2
34972, 1.2434782608696, 1.1152173913043, -0.2
34973, 1.2217391304348, 1.0891304347826, -0.2
34974, 1.2869565217391, 1.1152173913043, -0.2
34975, 1.2652173913043, 1.0891304347826, -0.2
34976, 1.3304347826087, 1.1152173913043, -0.2
34977, 1.3086956521739, 1.0891304347826, -0.2
34978, 1.3739130434783, 1.1152173913043, -0.2
34979, 1.3521739130435, 1.0891304347826, -0.2
34980, 1.4173913043478, 1.1152173913043, -0.2
34981, 1.395652173913, 1.0891304347826, -0.2
34982, 1.4608695652174, 1.1152173913043, -0.2
34983, 1.4391304347826, 1.0891304347826, -0.2
34984, 1.504347826087, 1.1152173913043, -0.2
34985, 1.4826086956522, 1.0891304347826, -0.2
34986, 1.5478260869565, 1.1152173913043, -0.2
34987, 1.5260869565217, 1.0891304347826, -0.2
34988, 1.5913043478261, 1.1152173913043, -0.2
34989, 1.5695652173913, 1.0891304347826, -0.2
34990, 1.6347826086957, 1.1152173913043, -0.2
34991, 1.6130434782609, 1.0891304347826, -0.2
34992, 1.6782608695652, 1.1152173913043, -0.2
34993, 1.6565217391304, 1.0891304347826, -0.2
34994, 1.7217391304348, 1.1152173913043, -0.2
34995, 1.7, 1.0891304347826, -0.2
34996, 1.7652173913043, 1.1152173913043, -0.2
34997, 1.7434782608696, 1.0891304347826, -0.2
34998, 1.8086956521739, 1.1152173913043, -0.2
34999, 1.7869565217391, 1.0891304347826, -0.2
35000, 1.8521739130435, 1.1152173913043, -0.2
35001, 1.8304347826087, 1.0891304347826, -0.2
35002, 1.895652173913, 1.1152173913043, -0.2
35003, 1.8739130434783, 1.0891304347826, -0.2
35004, 1.9391304347826, 1.1152173913043, -0.2
35005, 1.9173913043478, 1.0891304347826, -0.2
35006, 1.9826086956522, 1.1152173913043, -0.2
35007, 1.9608695652174, 1.0891304347826, -0.2
35008, 2.0260869565217, 1.1152173913043, -0.2
35009, 2.004347826087, 1.0891304347826, -0.2
35010, 2.0695652173913, 1.1152173913043, -0.2
35011, 2.0478260869565, 1.0891304347826, -0.2
35012, 2.1130434782609, 1.1152173913043, -0.2
35013, 2.0913043478261, 1.0891304347826, -0.2
35014, 2.1565217391304, 1.1152173913043, -0.2
35015, 2.1347826086957, 1.0891304347826, -0.2
35016, 2.1782608695652, 1.0891304347826, -0.2
35017, 1.2434782608696, 1.0630434782609, -0.2
35018, 1.2217391304348, 1.0369565217391, -0.2
35019, 1.2869565217391, 1.0630434782609, -0.2
35020, 1.2652173913043, 1.0369565217391, -0.2
35021, 1.3304347826087, 1.0630434782609, -0.2
35022, 1.3086956521739, 1.0369565217391, -0.2
35023, 1.3739130434783, 1.0630434782609, -0.2
35024, 1.3521739130435, 1.0369565217391, -0.2
35025, 1.4173913043478, 1.0630434782609, -0.2
35026, 1.395652173913, 1.0369565217391, -0.2
35027, 1.4608695652174, 1.0630434782609, -0.2
35028, 1.4391304347826, 1.0369565217391, -0.2
35029, 1.504347826087, 1.0630434782609, -0.2
35030, 1.4826086956522, 1.0369565217391, -0.2
35031, 1.5478260869565, 1.0630434782609, -0.2
35032, 1.5260869565217, 1.0369565217391, -0.2
35033, 1.5913043478261, 1.0630434782609, -0.2
35034, 1.5695652173913, 1.0369565217391, -0.2
35035, 1.6347826086957, 1.0630434782609, -0.2
35036, 1.6130434782609, 1.0369565217391, -0.2
35037, 1.6782608695652, 1.0630434782609, -0.2
35038, 1.6565217391304, 1.0369565217391, -0.2
35039, 1.7217391304348, 1.0630434782609, -0.2
35040, 1.7, 1.0369565217391, -0.2
35041, 1.7652173913043, 1.0630434782609, -0.2
35042, 1.7434782608696, 1.0369565217391, -0.2
35043, 1.8086956521739, 1.0630434782609, -0.2
35044, 1.7869565217391, 1.0369565217391, -0.2
35045, 1.8521739130435, 1.0630434782609, -0.2
35046, 1.8304347826087, 1.0369565217391, -0.2
35047, 1.895652173913, 1.0630434782609, -0.2
35048, 1.8739130434783, 1.0369565217391, -0.2
35049, 1.9391304347826, 1.0630434782609, -0.2
35050, 1.9173913043478, 1.0369565217391, -0.2
35051, 1.9826086956522, 1.0630434782609, -0.2
35052, 1.9608695652174, 1.0369565217391, -0.2
35053, 2.0260869565217, 1.0630434782609, -0.2
35054, 2.004347826087, 1.0369565217391, -0.2
35055, 2.0695652173913, 1.0630434782609, -0.2
35056, 2.0478260869565, 1.0369565217391, -0.2
35057, 2.1130434782609, 1.0630434782609, -0.2
35058, 2.0913043478261, 1.0369565217391, -0.2
35059, 2.1565217391304, 1.0630434782609, -0.2
35060, 2.1347826086957, 1.0369565217391, -0.2
35061, 2.1782608695652, 1.0369565217391, -0.2
35062, 1.2434782608696, 1.0108695652174, -0.2
35063, 1.2217391304348, 0.98478260869565, -0.2
35064, 1.2869565217391, 1.0108695652174, -0.2
35065, 1.2652173913043, 0.98478260869565, -0.2
35066, 1.3304347826087, 1.0108695652174, -0.2
35067, 1.3086956521739, 0.98478260869565, -0.2
35068, 1.3739130434783, 1.0108695652174, -0.2
35069, 1.3521739130435, 0.98478260869565, -0.2
35070, 1.4173913043478, 1.0108695652174, -0.2
35071, 1.395652173913, 0.98478260869565, -0.2
35072, 1.4608695652174, 1.0108695652174, -0.2
35073, 1.4391304347826, 0.98478260869565, -0.2
35074, 1.504347826087, 1.0108695652174, -0.2
35075, 1.4826086956522, 0.98478260869565, -0.2
35076, 1.5478260869565, 1.0108695652174, -0.2
35077, 1.5260869565217, 0.98478260869565, -0.2
35078, 1.5913043478261, 1.0108695652174, -0.2
35079, 1.5695652173913, 0.98478260869565, -0.2
35080, 1.6347826086957, 1.0108695652174, -0.2
35081, 1.6130434782609, 0.98478260869565, -0.2
35082, 1.6782608695652, 1.0108695652174, -0.2
35083, 1.6565217391304, 0.98478260869565, -0.2
35084, 1.7217391304348, 1.0108695652174, -0.2
35085, 1.7, 0.98478260869565, -0.2
35086, 1.7652173913043, 1.0108695652174, -0.2
35087, 1.7434782608696, 0.98478260869565, -0.2
35088, 1.8086956521739, 1.0108695652174, -0.2
35089, 1.7869565217391, 0.98478260869565, -0.2
35090, 1.8521739130435, 1.0108695652174, -0.2
35091, 1.8304347826087, 0.98478260869565, -0.2
35092, 1.895652173913, 1.0108695652174, -0.2
35093, 1.8739130434783, 0.98478260869565, -0.2
35094, 1.9391304347826, 1.0108695652174, -0.2
35095, 1.9173913043478, 0.98478260869565, -0.2
35096, 1.9826086956522, 1.0108695652174, -0.2
35097, 1.9608695652174, 0.98478260869565, -0.2
35098, 2.0260869565217, 1.0108695652174, -0.2
35099, 2.004347826087, 0.98478260869565, -0.2
35100, 2.0695652173913, 1.0108695652174, -0.2
35101, 2.0478260869565, 0.98478260869565, -0.2
35102, 2.1130434782609, 1.0108695652174, -0.2
35103, 2.0913043478261, 0.98478260869565, -0.2
35104, 2.1565217391304, 1.0108695652174, -0.2
35105, 2.1347826086957, 0.98478260869565, -0.2
35106, 2.1782608695652, 0.98478260869565, -0.2
35107, 1.2434782608696, 0.95869565217391, -0.2
35108, 1.2217391304348, 0.93260869565217, -0.2
35109, 1.2869565217391, 0.95869565217391, -0.2
35110, 1.2652173913043, 0.93260869565217, -0.2
35111, 1.3304347826087, 0.95869565217391, -0.2
35112, 1.3086956521739, 0.93260869565217, -0.2
35113, 1.3739130434783, 0.95869565217391, -0.2
35114, 1.3521739130435, 0.93260869565217, -0.2
35115, 1.4173913043478, 0.95869565217391, -0.2
35116, 1.395652173913, 0.93260869565217, -0.2
35117, 1.4608695652174, 0.95869565217391, -0.2
35118, 1.4391304347826, 0.93260869565217, -0.2
35119, 1.504347826087, 0.95869565217391, -0.2
35120, 1.4826086956522, 0.93260869565217, -0.2
35121, 1.5478260869565, 0.95869565217391, -0.2
35122, 1.5260869565217, 0.93260869565217, -0.2
35123, 1.5913043478261, 0.95869565217391, -0.2
35124, 1.5695652173913, 0.93260869565217, -0.2
35125, 1.6347826086957, 0.95869565217391, -0.2
35126, 1.6130434782609, 0.93260869565217, -0.2
35127, 1.6782608695652, 0.95869565217391, -0.2
35128, 1.6565217391304, 0.93260869565217, -0.2
35129, 1.7217391304348, 0.95869565217391, -0.2
35130, 1.7, 0.93260869565217, -0.2
35131, 1.7652173913043, 0.95869565217391, -0.2
35132, 1.7434782608696, 0.93260869565217, -0.2
35133, 1.8086956521739, 0.95869565217391, -0.2
35134, 1.7869565217391, 0.93260869565217, -0.2
35135, 1.8521739130435, 0.95869565217391, -0.2
35136, 1.8304347826087, 0.93260869565217, -0.2
35137, 1.895652173913, 0.95869565217391, -0.2
35138, 1.8739130434783, 0.93260869565217, -0.2
35139, 1.9391304347826, 0.95869565217391, -0.2
35140, 1.9173913043478, 0.93260869565217, -0.2
35141, 1.9826086956522, 0.95869565217391, -0.2
35142, 1.9608695652174, 0.93260869565217, -0.2
35143, 2.0260869565217, 0.95869565217391, -0.2
35144, 2.004347826087, 0.93260869565217, -0.2
35145, 2.0695652173913, 0.95869565217391, -0.2
35146, 2.0478260869565, 0.93260869565217, -0.2
35147, 2.1130434782609, 0.95869565217391, -0.2
35148, 2.0913043478261, 0.93260869565217, -0.2
35149, 2.1565217391304, 0.95869565217391, -0.2
35150, 2.1347826086957, 0.93260869565217, -0.2
35151, 2.1782608695652, 0.93260869565217, -0.2
35152, 1.2434782608696, 0.90652173913044, -0.2
35153, 1.2217391304348, 0.8804347826087, -0.2
35154, 1.2869565217391, 0.90652173913044, -0.2
35155, 1.2652173913043, 0.8804347826087, -0.2
35156, 1.3304347826087, 0.90652173913044, -0.2
35157, 1.3086956521739, 0.8804347826087, -0.2
35158, 1.3739130434783, 0.90652173913044, -0.2
35159, 1.3521739130435, 0.8804347826087, -0.2
35160, 1.4173913043478, 0.90652173913044, -0.2
35161, 1.395652173913, 0.8804347826087, -0.2
35162, 1.4608695652174, 0.90652173913044, -0.2
35163, 1.4391304347826, 0.8804347826087, -0.2
35164, 1.504347826087, 0.90652173913044, -0.2
35165, 1.4826086956522, 0.8804347826087, -0.2
35166, 1.5478260869565, 0.90652173913044, -0.2
35167, 1.5260869565217, 0.8804347826087, -0.2
35168, 1.5913043478261, 0.90652173913044, -0.2
35169, 1.5695652173913, 0.8804347826087, -0.2
35170, 1.6347826086957, 0.90652173913044, -0.2
35171, 1.6130434782609, 0.8804347826087, -0.2
35172, 1.6782608695652, 0.90652173913044, -0.2
35173, 1.6565217391304, 0.8804347826087, -0.2
35174, 1.7217391304348, 0.90652173913044, -0.2
35175, 1.7, 0.8804347826087, -0.2
35176, 1.7652173913043, 0.90652173913044, -0.2
35177, 1.7434782608696, 0.8804347826087, -0.2
35178, 1.8086956521739, 0.90652173913044, -0.2
35179, 1.7869565217391, 0.8804347826087, -0.2
35180, 1.8521739130435, 0.90652173913044, -0.2
35181, 1.8304347826087, 0.8804347826087, -0.2
35182, 1.895652173913, 0.90652173913044, -0.2
35183, 1.8739130434783, 0.8804347826087, -0.2
35184, 1.9391304347826, 0.90652173913044, -0.2
35185, 1.9173913043478, 0.8804347826087, -0.2
35186, 1.9826086956522, 0.90652173913044, -0.2
35187, 1.9608695652174, 0.8804347826087, -0.2
35188, 2.0260869565217, 0.90652173913044, -0.2
35189, 2.004347826087, 0.8804347826087, -0.2
35190, 2.0695652173913, 0.90652173913044, -0.2
35191, 2.0478260869565, 0.8804347826087, -0.2
35192, 2.1130434782609, 0.90652173913044, -0.2
35193, 2.0913043478261, 0.8804347826087, -0.2
35194, 2.1565217391304, 0.90652173913044, -0.2
35195, 2.1347826086957, 0.8804347826087, -0.2
35196, 2.1782608695652, 0.8804347826087, -0.2
35197, 1.2434782608696, 0.85434782608696, -0.2
35198, 1.2217391304348, 0.82826086956522, -0.2
35199, 1.2869565217391, 0.85434782608696, -0.2
35200, 1.2652173913043, 0.82826086956522, -0.2
35201, 1.3304347826087, 0.85434782608696, -0.2
35202, 1.3086956521739, 0.82826086956522, -0.2
35203, 1.3739130434783, 0.85434782608696, -0.2
35204, 1.3521739130435, 0.82826086956522, -0.2
35205, 1.4173913043478, 0.85434782608696, -0.2
35206, 1.395652173913, 0.82826086956522, -0.2
35207, 1.4608695652174, 0.85434782608696, -0.2
35208, 1.4391304347826, 0.82826086956522, -0.2
35209, 1.504347826087, 0.85434782608696, -0.2
35210, 1.4826086956522, 0.82826086956522, -0.2
35211, 1.5478260869565, 0.85434782608696, -0.2
35212, 1.5260869565217, 0.82826086956522, -0.2
35213, 1.5913043478261, 0.85434782608696, -0.2
35214, 1.5695652173913, 0.82826086956522, -0.2
35215, 1.6347826086957, 0.85434782608696, -0.2
35216, 1.6130434782609, 0.82826086956522, -0.2
35217, 1.6782608695652, 0.85434782608696, -0.2
35218, 1.6565217391304, 0.82826086956522, -0.2
35219, 1.7217391304348, 0.85434782608696, -0.2
35220, 1.7, 0.82826086956522, -0.2
35221, 1.7652173913043, 0.85434782608696, -0.2
35222, 1.7434782608696, 0.82826086956522, -0.2
35223, 1.8086956521739, 0.85434782608696, -0.2
35224, 1.7869565217391, 0.82826086956522, -0.2
35225, 1.8521739130435, 0.85434782608696, -0.2
35226, 1.8304347826087, 0.82826086956522, -0.2
35227, 1.895652173913, 0.85434782608696, -0.2
35228, 1.8739130434783, 0.82826086956522, -0.2
35229, 1.9391304347826, 0.85434782608696, -0.2
35230, 1.9173913043478, 0.82826086956522, -0.2
35231, 1.9826086956522, 0.85434782608696, -0.2
35232, 1.9608695652174, 0.82826086956522, -0.2
35233, 2.0260869565217, 0.85434782608696, -0.2
35234, 2.004347826087, 0.82826086956522, -0.2
35235, 2.0695652173913, 0.85434782608696, -0.2
35236, 2.0478260869565, 0.82826086956522, -0.2
35237, 2.1130434782609, 0.85434782608696, -0.2
35238, 2.0913043478261, 0.82826086956522, -0.2
35239, 2.1565217391304, 0.85434782608696, -0.2
35240, 2.1347826086957, 0.82826086956522, -0.2
35241, 2.1782608695652, 0.82826086956522, -0.2
35242, 1.2434782608696, 0.80217391304348, -0.2
35243, 1.2217391304348, 0.77608695652174, -0.2
35244, 1.2869565217391, 0.80217391304348, -0.2
35245, 1.2652173913043, 0.77608695652174, -0.2
35246, 1.3304347826087, 0.80217391304348, -0.2
35247, 1.3086956521739, 0.77608695652174, -0.2
35248, 1.3739130434783, 0.80217391304348, -0.2
35249, 1.3521739130435, 0.77608695652174, -0.2
35250, 1.4173913043478, 0.80217391304348, -0.2
35251, 1.395652173913, 0.77608695652174, -0.2
35252, 1.4608695652174, 0.80217391304348, -0.2
35253, 1.4391304347826, 0.77608695652174, -0.2
35254, 1.504347826087, 0.80217391304348, -0.2
35255, 1.4826086956522, 0.77608695652174, -0.2
35256, 1.5478260869565, 0.80217391304348, -0.2
35257, 1.5260869565217, 0.77608695652174, -0.2
35258, 1.5913043478261, 0.80217391304348, -0.2
35259, 1.5695652173913, 0.77608695652174, -0.2
35260, 1.6347826086957, 0.80217391304348, -0.2
35261, 1.6130434782609, 0.77608695652174, -0.2
35262, 1.6782608695652, 0.80217391304348, -0.2
35263, 1.6565217391304, 0.77608695652174, -0.2
35264, 1.7217391304348, 0.80217391304348, -0.2
35265, 1.7, 0.77608695652174, -0.2
35266, 1.7652173913043, 0.80217391304348, -0.2
35267, 1.7434782608696, 0.77608695652174, -0.2
35268, 1.8086956521739, 0.80217391304348, -0.2
35269, 1.7869565217391, 0.77608695652174, -0.2
35270, 1.8521739130435, 0.80217391304348, -0.2
35271, 1.8304347826087, 0.77608695652174, -0.2
35272, 1.895652173913, 0.80217391304348, -0.2
35273, 1.8739130434783, 0.77608695652174, -0.2
35274, 1.9391304347826, 0.80217391304348, -0.2
35275, 1.9173913043478, 0.77608695652174, -0.2
35276, 1.9826086956522, 0.80217391304348, -0.2
35277, 1.9608695652174, 0.77608695652174, -0.2
35278, 2.0260869565217, 0.80217391304348, -0.2
35279, 2.004347826087, 0.77608695652174, -0.2
35280, 2.0695652173913, 0.80217391304348, -0.2
35281, 2.0478260869565, 0.77608695652174, -0.2
35282, 2.1130434782609, 0.80217391304348, -0.2
35283, 2.0913043478261, 0.77608695652174, -0.2
35284, 2.1565217391304, 0.80217391304348, -0.2
35285, 2.1347826086957, 0.77608695652174, -0.2
35286, 2.1782608695652, 0.77608695652174, -0.2
35287, 1.2434782608696, 0.75, -0.2
35288, 1.2217391304348, 0.72391304347826, -0.2
35289, 1.2869565217391, 0.75, -0.2
35290, 1.2652173913043, 0.72391304347826, -0.2
35291, 1.3304347826087, 0.75, -0.2
35292, 1.3086956521739, 0.72391304347826, -0.2
35293, 1.3739130434783, 0.75, -0.2
35294, 1.3521739130435, 0.72391304347826, -0.2
35295, 1.4173913043478, 0.75, -0.2
35296, 1.395652173913, 0.72391304347826, -0.2
35297, 1.4608695652174, 0.75, -0.2
35298, 1.4391304347826, 0.72391304347826, -0.2
35299, 1.504347826087, 0.75, -0.2
35300, 1.4826086956522, 0.72391304347826, -0.2
35301, 1.5478260869565, 0.75, -0.2
35302, 1.5260869565217, 0.72391304347826, -0.2
35303, 1.5913043478261, 0.75, -0.2
35304, 1.5695652173913, 0.72391304347826, -0.2
35305, 1.6347826086957, 0.75, -0.2
35306, 1.6130434782609, 0.72391304347826, -0.2
35307, 1.6782608695652, 0.75, -0.2
35308, 1.6565217391304, 0.72391304347826, -0.2
35309, 1.7217391304348, 0.75, -0.2
35310, 1.7, 0.72391304347826, -0.2
35311, 1.7652173913043, 0.75, -0.2
35312, 1.7434782608696, 0.72391304347826, -0.2
35313, 1.8086956521739, 0.75, -0.2
35314, 1.7869565217391, 0.72391304347826, -0.2
35315, 1.8521739130435, 0.75, -0.2
35316, 1.8304347826087, 0.72391304347826, -0.2
35317, 1.895652173913, 0.75, -0.2
35318, 1.8739130434783, 0.72391304347826, -0.2
35319, 1.9391304347826, 0.75, -0.2
35320, 1.9173913043478, 0.72391304347826, -0.2
35321, 1.9826086956522, 0.75, -0.2
35322, 1.9608695652174, 0.72391304347826, -0.2
35323, 2.0260869565217, 0.75, -0.2
35324, 2.004347826087, 0.72391304347826, -0.2
35325, 2.0695652173913, 0.75, -0.2
35326, 2.0478260869565, 0.72391304347826, -0.2
35327, 2.1130434782609, 0.75, -0.2
35328, 2.0913043478261, 0.72391304347826, -0.2
35329, 2.1565217391304, 0.75, -0.2
35330, 2.1347826086957, 0.72391304347826, -0.2
35331, 2.1782608695652, 0.72391304347826, -0.2
35332, 1.2434782608696, 0.69782608695652, -0.2
35333, 1.2217391304348, 0.67173913043478, -0.2
35334, 1.2869565217391, 0.69782608695652, -0.2
35335, 1.2652173913043, 0.67173913043478, -0.2
35336, 1.3304347826087, 0.69782608695652, -0.2
35337, 1.3086956521739, 0.67173913043478, -0.2
35338, 1.3739130434783, 0.69782608695652, -0.2
35339, 1.3521739130435, 0.67173913043478, -0.2
35340, 1.4173913043478, 0.69782608695652, -0.2
35341, 1.395652173913, 0.67173913043478, -0.2
35342, 1.4608695652174, 0.69782608695652, -0.2
35343, 1.4391304347826, 0.67173913043478, -0.2
35344, 1.504347826087, 0.69782608695652, -0.2
35345, 1.4826086956522, 0.67173913043478, -0.2
35346, 1.5478260869565, 0.69782608695652, -0.2
35347, 1.5260869565217, 0.67173913043478, -0.2
35348, 1.5913043478261, 0.69782608695652, -0.2
35349, 1.5695652173913, 0.67173913043478, -0.2
35350, 1.6347826086957, 0.69782608695652, -0.2
35351, 1.6130434782609, 0.67173913043478, -0.2
35352, 1.6782608695652, 0.69782608695652, -0.2
35353, 1.6565217391304, 0.67173913043478, -0.2
35354, 1.7217391304348, 0.69782608695652, -0.2
35355, 1.7, 0.67173913043478, -0.2
35356, 1.7652173913043, 0.69782608695652, -0.2
35357, 1.7434782608696, 0.67173913043478, -0.2
35358, 1.8086956521739, 0.69782608695652, -0.2
35359, 1.7869565217391, 0.67173913043478, -0.2
35360, 1.8521739130435, 0.69782608695652, -0.2
35361, 1.8304347826087, 0.67173913043478, -0.2
35362, 1.895652173913, 0.69782608695652, -0.2
35363, 1.8739130434783, 0.67173913043478, -0.2
35364, 1.9391304347826, 0.69782608695652, -0.2
35365, 1.9173913043478, 0.67173913043478, -0.2
35366, 1.9826086956522, 0.69782608695652, -0.2
35367, 1.9608695652174, 0.67173913043478, -0.2
35368, 2.0260869565217, 0.69782608695652, -0.2
35369, 2.004347826087, 0.67173913043478, -0.2
35370, 2.0695652173913, 0.69782608695652, -0.2
35371, 2.0478260869565, 0.67173913043478, -0.2
35372, 2.1130434782609, 0.69782608695652, -0.2
35373, 2.0913043478261, 0.67173913043478, -0.2
35374, 2.1565217391304, 0.69782608695652, -0.2
35375, 2.1347826086957, 0.67173913043478, -0.2
35376, 2.1782608695652, 0.67173913043478, -0.2
35377, 1.2434782608696, 0.64565217391304, -0.2
35378, 1.2217391304348, 0.61956521739131, -0.2
35379, 1.2869565217391, 0.64565217391304, -0.2
35380, 1.2652173913043, 0.61956521739131, -0.2
35381, 1.3304347826087, 0.64565217391304, -0.2
35382, 1.3086956521739, 0.61956521739131, -0.2
35383, 1.3739130434783, 0.64565217391304, -0.2
35384, 1.3521739130435, 0.61956521739131, -0.2
35385, 1.4173913043478, 0.64565217391304, -0.2
35386, 1.395652173913, 0.61956521739131, -0.2
35387, 1.4608695652174, 0.64565217391304, -0.2
35388, 1.4391304347826, 0.61956521739131, -0.2
35389, 1.504347826087, 0.64565217391304, -0.2
35390, 1.4826086956522, 0.61956521739131, -0.2
35391, 1.5478260869565, 0.64565217391304, -0.2
35392, 1.5260869565217, 0.61956521739131, -0.2
35393, 1.5913043478261, 0.64565217391304, -0.2
35394, 1.5695652173913, 0.61956521739131, -0.2
35395, 1.6347826086957, 0.64565217391304, -0.2
35396, 1.6130434782609, 0.61956521739131, -0.2
35397, 1.6782608695652, 0.64565217391304, -0.2
35398, 1.6565217391304, 0.61956521739131, -0.2
35399, 1.7217391304348, 0.64565217391304, -0.2
35400, 1.7, 0.61956521739131, -0.2
35401, 1.7652173913043, 0.64565217391304, -0.2
35402, 1.7434782608696, 0.61956521739131, -0.2
35403, 1.8086956521739, 0.64565217391304, -0.2
35404, 1.7869565217391, 0.61956521739131, -0.2
35405, 1.8521739130435, 0.64565217391304, -0.2
35406, 1.8304347826087, 0.61956521739131, -0.2
35407, 1.895652173913, 0.64565217391304, -0.2
35408, 1.8739130434783, 0.61956521739131, -0.2
35409, 1.9391304347826, 0.64565217391304, -0.2
35410, 1.9173913043478, 0.61956521739131, -0.2
35411, 1.9826086956522, 0.64565217391304, -0.2
35412, 1.9608695652174, 0.61956521739131, -0.2
35413, 2.0260869565217, 0.64565217391304, -0.2
35414, 2.004347826087, 0.61956521739131, -0.2
35415, 2.0695652173913, 0.64565217391304, -0.2
35416, 2.0478260869565, 0.61956521739131, -0.2
35417, 2.1130434782609, 0.64565217391304, -0.2
35418, 2.0913043478261, 0.61956521739131, -0.2
35419, 2.1565217391304, 0.64565217391304, -0.2
35420, 2.1347826086957, 0.61956521739131, -0.2
35421, 2.1782608695652, 0.61956521739131, -0.2
35422, 1.2434782608696, 0.59347826086957, -0.2
35423, 1.2217391304348, 0.56739130434783, -0.2
35424, 1.2869565217391, 0.59347826086957, -0.2
35425, 1.2652173913043, 0.56739130434783, -0.2
35426, 1.3304347826087, 0.59347826086957, -0.2
35427, 1.3086956521739, 0.56739130434783, -0.2
35428, 1.3739130434783, 0.59347826086957, -0.2
35429, 1.3521739130435, 0.56739130434783, -0.2
35430, 1.4173913043478, 0.59347826086957, -0.2
35431, 1.395652173913, 0.56739130434783, -0.2
35432, 1.4608695652174, 0.59347826086957, -0.2
35433, 1.4391304347826, 0.56739130434783, -0.2
35434, 1.504347826087, 0.59347826086957, -0.2
35435, 1.4826086956522, 0.56739130434783, -0.2
35436, 1.5478260869565, 0.59347826086957, -0.2
35437, 1.5260869565217, 0.56739130434783, -0.2
35438, 1.5913043478261, 0.59347826086957, -0.2
35439, 1.5695652173913, 0.56739130434783, -0.2
35440, 1.6347826086957, 0.59347826086957, -0.2
35441, 1.6130434782609, 0.56739130434783, -0.2
35442, 1.6782608695652, 0.59347826086957, -0.2
35443, 1.6565217391304, 0.56739130434783, -0.2
35444, 1.7217391304348, 0.59347826086957, -0.2
35445, 1.7, 0.56739130434783, -0.2
35446, 1.7652173913043, 0.59347826086957, -0.2
35447, 1.7434782608696, 0.56739130434783, -0.2
35448, 1.8086956521739, 0.59347826086957, -0.2
35449, 1.7869565217391, 0.56739130434783, -0.2
35450, 1.8521739130435, 0.59347826086957, -0.2
35451, 1.8304347826087, 0.56739130434783, -0.2
35452, 1.895652173913, 0.59347826086957, -0.2
35453, 1.8739130434783, 0.56739130434783, -0.2
35454, 1.9391304347826, 0.59347826086957, -0.2
35455, 1.9173913043478, 0.56739130434783, -0.2
35456, 1.9826086956522, 0.59347826086957, -0.2
35457, 1.9608695652174, 0.56739130434783, -0.2
35458, 2.0260869565217, 0.59347826086957, -0.2
35459, 2.004347826087, 0.56739130434783, -0.2
35460, 2.0695652173913, 0.59347826086957, -0.2
35461, 2.0478260869565, 0.56739130434783, -0.2
35462, 2.1130434782609, 0.59347826086957, -0.2
35463, 2.0913043478261, 0.56739130434783, -0.2
35464, 2.1565217391304, 0.59347826086957, -0.2
35465, 2.1347826086957, 0.56739130434783, -0.2
35466, 2.1782608695652, 0.56739130434783, -0.2
35467, 1.2434782608696, 0.54130434782609, -0.2
35468, 1.2217391304348, 0.51521739130435, -0.2
35469, 1.2869565217391, 0.54130434782609, -0.2
35470, 1.2652173913043, 0.51521739130435, -0.2
35471, 1.3304347826087, 0.54130434782609, -0.2
35472, 1.3086956521739, 0.51521739130435, -0.2
35473, 1.3739130434783, 0.54130434782609, -0.2
35474, 1.3521739130435, 0.51521739130435, -0.2
35475, 1.4173913043478, 0.54130434782609, -0.2
35476, 1.395652173913, 0.51521739130435, -0.2
35477, 1.4608695652174, 0.54130434782609, -0.2
35478, 1.4391304347826, 0.51521739130435, -0.2
35479, 1.504347826087, 0.54130434782609, -0.2
35480, 1.4826086956522, 0.51521739130435, -0.2
35481, 1.5478260869565, 0.54130434782609, -0.2
35482, 1.5260869565217, 0.51521739130435, -0.2
35483, 1.5913043478261, 0.54130434782609, -0.2
35484, 1.5695652173913, 0.51521739130435, -0.2
35485, 1.6347826086957, 0.54130434782609, -0.2
35486, 1.6130434782609, 0.51521739130435, -0.2
35487, 1.6782608695652, 0.54130434782609, -0.2
35488, 1.6565217391304, 0.51521739130435, -0.2
35489, 1.7217391304348, 0.54130434782609, -0.2
35490, 1.7, 0.51521739130435, -0.2
35491, 1.7652173913043, 0.54130434782609, -0.2
35492, 1.7434782608696, 0.51521739130435, -0.2
35493, 1.8086956521739, 0.54130434782609, -0.2
35494, 1.7869565217391, 0.51521739130435, -0.2
35495, 1.8521739130435, 0.54130434782609, -0.2
35496, 1.8304347826087, 0.51521739130435, -0.2
35497, 1.895652173913, 0.54130434782609, -0.2
35498, 1.8739130434783, 0.51521739130435, -0.2
35499, 1.9391304347826, 0.54130434782609, -0.2
35500, 1.9173913043478, 0.51521739130435, -0.2
35501, 1.9826086956522, 0.54130434782609, -0.2
35502, 1.9608695652174, 0.51521739130435, -0.2
35503, 2.0260869565217, 0.54130434782609, -0.2
35504, 2.004347826087, 0.51521739130435, -0.2
35505, 2.0695652173913, 0.54130434782609, -0.2
35506, 2.0478260869565, 0.51521739130435, -0.2
35507, 2.1130434782609, 0.54130434782609, -0.2
35508, 2.0913043478261, 0.51521739130435, -0.2
35509, 2.1565217391304, 0.54130434782609, -0.2
35510, 2.1347826086957, 0.51521739130435, -0.2
35511, 2.1782608695652, 0.51521739130435, -0.2
35512, 1.2434782608696, 0.48913043478261, -0.2
35513, 1.2217391304348, 0.46304347826087, -0.2
35514, 1.2869565217391, 0.48913043478261, -0.2
35515, 1.2652173913043, 0.46304347826087, -0.2
35516, 1.3304347826087, 0.48913043478261, -0.2
35517, 1.3086956521739, 0.46304347826087, -0.2
35518, 1.3739130434783, 0.48913043478261, -0.2
35519, 1.3521739130435, 0.46304347826087, -0.2
35520, 1.4173913043478, 0.48913043478261, -0.2
35521, 1.395652173913, 0.46304347826087, -0.2
35522, 1.4608695652174, 0.48913043478261, -0.2
35523, 1.4391304347826, 0.46304347826087, -0.2
35524, 1.504347826087, 0.48913043478261, -0.2
35525, 1.4826086956522, 0.46304347826087, -0.2
35526, 1.5478260869565, 0.48913043478261, -0.2
35527, 1.5260869565217, 0.46304347826087, -0.2
35528, 1.5913043478261, 0.48913043478261, -0.2
35529, 1.5695652173913, 0.46304347826087, -0.2
35530, 1.6347826086957, 0.48913043478261, -0.2
35531, 1.6130434782609, 0.46304347826087, -0.2
35532, 1.6782608695652, 0.48913043478261, -0.2
35533, 1.6565217391304, 0.46304347826087, -0.2
35534, 1.7217391304348, 0.48913043478261, -0.2
35535, 1.7, 0.46304347826087, -0.2
35536, 1.7652173913043, 0.48913043478261, -0.2
35537, 1.7434782608696, 0.46304347826087, -0.2
35538, 1.8086956521739, 0.48913043478261, -0.2
35539, 1.7869565217391, 0.46304347826087, -0.2
35540, 1.8521739130435, 0.48913043478261, -0.2
35541, 1.8304347826087, 0.46304347826087, -0.2
35542, 1.895652173913, 0.48913043478261, -0.2
35543, 1.8739130434783, 0.46304347826087, -0.2
35544, 1.9391304347826, 0.48913043478261, -0.2
35545, 1.9173913043478, 0.46304347826087, -0.2
35546, 1.9826086956522, 0.48913043478261, -0.2
35547, 1.9608695652174, 0.46304347826087, -0.2
35548, 2.0260869565217, 0.48913043478261, -0.2
35549, 2.004347826087, 0.46304347826087, -0.2
35550, 2.0695652173913, 0.48913043478261, -0.2
35551, 2.0478260869565, 0.46304347826087, -0.2
35552, 2.1130434782609, 0.48913043478261, -0.2
35553, 2.0913043478261, 0.46304347826087, -0.2
35554, 2.1565217391304, 0.48913043478261, -0.2
35555, 2.1347826086957, 0.46304347826087, -0.2
35556, 2.1782608695652, 0.46304347826087, -0.2
35557, 1.2434782608696, 0.43695652173913, -0.2
35558, 1.2217391304348, 0.41086956521739, -0.2
35559, 1.2869565217391, 0.43695652173913, -0.2
35560, 1.2652173913043, 0.41086956521739, -0.2
35561, 1.3304347826087, 0.43695652173913, -0.2
35562, 1.3086956521739, 0.41086956521739, -0.2
35563, 1.3739130434783, 0.43695652173913, -0.2
35564, 1.3521739130435, 0.41086956521739, -0.2
35565, 1.4173913043478, 0.43695652173913, -0.2
35566, 1.395652173913, 0.41086956521739, -0.2
35567, 1.4608695652174, 0.43695652173913, -0.2
35568, 1.4391304347826, 0.41086956521739, -0.2
35569, 1.504347826087, 0.43695652173913, -0.2
35570, 1.4826086956522, 0.41086956521739, -0.2
35571, 1.5478260869565, 0.43695652173913, -0.2
35572, 1.5260869565217, 0.41086956521739, -0.2
35573, 1.5913043478261, 0.43695652173913, -0.2
35574, 1.5695652173913, 0.41086956521739, -0.2
35575, 1.6347826086957, 0.43695652173913, -0.2
35576, 1.6130434782609, 0.41086956521739, -0.2
35577, 1.6782608695652, 0.43695652173913, -0.2
35578, 1.6565217391304, 0.41086956521739, -0.2
35579, 1.7217391304348, 0.43695652173913, -0.2
35580, 1.7, 0.41086956521739, -0.2
35581, 1.7652173913043, 0.43695652173913, -0.2
35582, 1.7434782608696, 0.41086956521739, -0.2
35583, 1.8086956521739, 0.43695652173913, -0.2
35584, 1.7869565217391, 0.41086956521739, -0.2
35585, 1.8521739130435, 0.43695652173913, -0.2
35586, 1.8304347826087, 0.41086956521739, -0.2
35587, 1.895652173913, 0.43695652173913, -0.2
35588, 1.8739130434783, 0.41086956521739, -0.2
35589, 1.9391304347826, 0.43695652173913, -0.2
35590, 1.9173913043478, 0.41086956521739, -0.2
35591, 1.9826086956522, 0.43695652173913, -0.2
35592, 1.9608695652174, 0.41086956521739, -0.2
35593, 2.0260869565217, 0.43695652173913, -0.2
35594, 2.004347826087, 0.41086956521739, -0.2
35595, 2.0695652173913, 0.43695652173913, -0.2
35596, 2.0478260869565, 0.41086956521739, -0.2
35597, 2.1130434782609, 0.43695652173913, -0.2
35598, 2.0913043478261, 0.41086956521739, -0.2
35599, 2.1565217391304, 0.43695652173913, -0.2
35600, 2.1347826086957, 0.41086956521739, -0.2
35601, 2.1782608695652, 0.41086956521739, -0.2
35602, 1.2434782608696, 0.38478260869565, -0.2
35603, 1.2217391304348, 0.35869565217391, -0.2
35604, 1.2869565217391, 0.38478260869565, -0.2
35605, 1.2652173913043, 0.35869565217391, -0.2
35606, 1.3304347826087, 0.38478260869565, -0.2
35607, 1.3086956521739, 0.35869565217391, -0.2
35608, 1.3739130434783, 0.38478260869565, -0.2
35609, 1.3521739130435, 0.35869565217391, -0.2
35610, 1.4173913043478, 0.38478260869565, -0.2
35611, 1.395652173913, 0.35869565217391, -0.2
35612, 1.4608695652174, 0.38478260869565, -0.2
35613, 1.4391304347826, 0.35869565217391, -0.2
35614, 1.504347826087, 0.38478260869565, -0.2
35615, 1.4826086956522, 0.35869565217391, -0.2
35616, 1.5478260869565, 0.38478260869565, -0.2
35617, 1.5260869565217, 0.35869565217391, -0.2
35618, 1.5913043478261, 0.38478260869565, -0.2
35619, 1.5695652173913, 0.35869565217391, -0.2
35620, 1.6347826086957, 0.38478260869565, -0.2
35621, 1.6130434782609, 0.35869565217391, -0.2
35622, 1.6782608695652, 0.38478260869565, -0.2
35623, 1.6565217391304, 0.35869565217391, -0.2
35624, 1.7217391304348, 0.38478260869565, -0.2
35625, 1.7, 0.35869565217391, -0.2
35626, 1.7652173913043, 0.38478260869565, -0.2
35627, 1.7434782608696, 0.35869565217391, -0.2
35628, 1.8086956521739, 0.38478260869565, -0.2
35629, 1.7869565217391, 0.35869565217391, -0.2
35630, 1.8521739130435, 0.38478260869565, -0.2
35631, 1.8304347826087, 0.35869565217391, -0.2
35632, 1.895652173913, 0.38478260869565, -0.2
35633, 1.8739130434783, 0.35869565217391, -0.2
35634, 1.9391304347826, 0.38478260869565, -0.2
35635, 1.9173913043478, 0.35869565217391, -0.2
35636, 1.9826086956522, 0.38478260869565, -0.2
35637, 1.9608695652174, 0.35869565217391, -0.2
35638, 2.0260869565217, 0.38478260869565, -0.2
35639, 2.004347826087, 0.35869565217391, -0.2
35640, 2.0695652173913, 0.38478260869565, -0.2
35641, 2.0478260869565, 0.35869565217391, -0.2
35642, 2.1130434782609, 0.38478260869565, -0.2
35643, 2.0913043478261, 0.35869565217391, -0.2
35644, 2.1565217391304, 0.38478260869565, -0.2
35645, 2.1347826086957, 0.35869565217391, -0.2
35646, 2.1782608695652, 0.35869565217391, -0.2
35647, 1.2434782608696, 0.33260869565217, -0.2
35648, 1.2217391304348, 0.30652173913044, -0.2
35649, 1.2869565217391, 0.33260869565217, -0.2
35650, 1.2652173913043, 0.30652173913044, -0.2
35651, 1.3304347826087, 0.33260869565217, -0.2
35652, 1.3086956521739, 0.30652173913043, -0.2
35653, 1.3739130434783, 0.33260869565217, -0.2
35654, 1.3521739130435, 0.30652173913044, -0.2
35655, 1.4173913043478, 0.33260869565217, -0.2
35656, 1.395652173913, 0.30652173913044, -0.2
35657, 1.4608695652174, 0.33260869565217, -0.2
35658, 1.4391304347826, 0.30652173913044, -0.2
35659, 1.504347826087, 0.33260869565217, -0.2
35660, 1.4826086956522, 0.30652173913044, -0.2
35661, 1.5478260869565, 0.33260869565217, -0.2
35662, 1.5260869565217, 0.30652173913044, -0.2
35663, 1.5913043478261, 0.33260869565217, -0.2
35664, 1.5695652173913, 0.30652173913044, -0.2
35665, 1.6347826086957, 0.33260869565217, -0.2
35666, 1.6130434782609, 0.30652173913044, -0.2
35667, 1.6782608695652, 0.33260869565217, -0.2
35668, 1.6565217391304, 0.30652173913043, -0.2
35669, 1.7217391304348, 0.33260869565217, -0.2
35670, 1.7, 0.30652173913043, -0.2
35671, 1.7652173913043, 0.33260869565217, -0.2
35672, 1.7434782608696, 0.30652173913043, -0.2
35673, 1.8086956521739, 0.33260869565217, -0.2
35674, 1.7869565217391, 0.30652173913044, -0.2
35675, 1.8521739130435, 0.33260869565217, -0.2
35676, 1.8304347826087, 0.30652173913044, -0.2
35677, 1.895652173913, 0.33260869565217, -0.2
35678, 1.8739130434783, 0.30652173913043, -0.2
35679, 1.9391304347826, 0.33260869565217, -0.2
35680, 1.9173913043478, 0.30652173913044, -0.2
35681, 1.9826086956522, 0.33260869565217, -0.2
35682, 1.9608695652174, 0.30652173913044, -0.2
35683, 2.0260869565217, 0.33260869565217, -0.2
35684, 2.004347826087, 0.30652173913044, -0.2
35685, 2.0695652173913, 0.33260869565217, -0.2
35686, 2.0478260869565, 0.30652173913044, -0.2
35687, 2.1130434782609, 0.33260869565217, -0.2
35688, 2.0913043478261, 0.30652173913043, -0.2
35689, 2.1565217391304, 0.33260869565217, -0.2
35690, 2.1347826086957, 0.30652173913043, -0.2
35691, 2.1782608695652, 0.30652173913044, -0.2
35692, 1.2434782608696, 0.2804347826087, -0.2
35693, 1.2217391304348, 0.25434782608696, -0.2
35694, 1.2869565217391, 0.2804347826087, -0.2
35695, 1.2652173913043, 0.25434782608696, -0.2
35696, 1.3304347826087, 0.2804347826087, -0.2
35697, 1.3086956521739, 0.25434782608696, -0.2
35698, 1.3739130434783, 0.2804347826087, -0.2
35699, 1.3521739130435, 0.25434782608696, -0.2
35700, 1.4173913043478, 0.2804347826087, -0.2
35701, 1.395652173913, 0.25434782608696, -0.2
35702, 1.4608695652174, 0.2804347826087, -0.2
35703, 1.4391304347826, 0.25434782608696, -0.2
35704, 1.504347826087, 0.2804347826087, -0.2
35705, 1.4826086956522, 0.25434782608696, -0.2
35706, 1.5478260869565, 0.2804347826087, -0.2
35707, 1.5260869565217, 0.25434782608696, -0.2
35708, 1.5913043478261, 0.2804347826087, -0.2
35709, 1.5695652173913, 0.25434782608696, -0.2
35710, 1.6347826086957, 0.2804347826087, -0.2
35711, 1.6130434782609, 0.25434782608696, -0.2
35712, 1.6782608695652, 0.2804347826087, -0.2
35713, 1.6565217391304, 0.25434782608696, -0.2
35714, 1.7217391304348, 0.2804347826087, -0.2
35715, 1.7, 0.25434782608696, -0.2
35716, 1.7652173913043, 0.2804347826087, -0.2
35717, 1.7434782608696, 0.25434782608696, -0.2
35718, 1.8086956521739, 0.2804347826087, -0.2
35719, 1.7869565217391, 0.25434782608696, -0.2
35720, 1.8521739130435, 0.2804347826087, -0.2
35721, 1.8304347826087, 0.25434782608696, -0.2
35722, 1.895652173913, 0.2804347826087, -0.2
35723, 1.8739130434783, 0.25434782608696, -0.2
35724, 1.9391304347826, 0.2804347826087, -0.2
35725, 1.9173913043478, 0.25434782608696, -0.2
35726, 1.9826086956522, 0.2804347826087, -0.2
35727, 1.9608695652174, 0.25434782608696, -0.2
35728, 2.0260869565217, 0.2804347826087, -0.2
35729, 2.004347826087, 0.25434782608696, -0.2
35730, 2.0695652173913, 0.2804347826087, -0.2
35731, 2.0478260869565, 0.25434782608696, -0.2
35732, 2.1130434782609, 0.2804347826087, -0.2
35733, 2.0913043478261, 0.25434782608696, -0.2
35734, 2.1565217391304, 0.2804347826087, -0.2
35735, 2.1347826086957, 0.25434782608696, -0.2
35736, 2.1782608695652, 0.25434782608696, -0.2
35737, 1.2434782608696, 0.22826086956522, -0.2
35738, 1.2217391304348, 0.20217391304348, -0.2
35739, 1.2869565217391, 0.22826086956522, -0.2
35740, 1.2652173913043, 0.20217391304348, -0.2
35741, 1.3304347826087, 0.22826086956522, -0.2
35742, 1.3086956521739, 0.20217391304348, -0.2
35743, 1.3739130434783, 0.22826086956522, -0.2
35744, 1.3521739130435, 0.20217391304348, -0.2
35745, 1.4173913043478, 0.22826086956522, -0.2
35746, 1.395652173913, 0.20217391304348, -0.2
35747, 1.4608695652174, 0.22826086956522, -0.2
35748, 1.4391304347826, 0.20217391304348, -0.2
35749, 1.504347826087, 0.22826086956522, -0.2
35750, 1.4826086956522, 0.20217391304348, -0.2
35751, 1.5478260869565, 0.22826086956522, -0.2
35752, 1.5260869565217, 0.20217391304348, -0.2
35753, 1.5913043478261, 0.22826086956522, -0.2
35754, 1.5695652173913, 0.20217391304348, -0.2
35755, 1.6347826086957, 0.22826086956522, -0.2
35756, 1.6130434782609, 0.20217391304348, -0.2
35757, 1.6782608695652, 0.22826086956522, -0.2
35758, 1.6565217391304, 0.20217391304348, -0.2
35759, 1.7217391304348, 0.22826086956522, -0.2
35760, 1.7, 0.20217391304348, -0.2
35761, 1.7652173913043, 0.22826086956522, -0.2
35762, 1.7434782608696, 0.20217391304348, -0.2
35763, 1.8086956521739, 0.22826086956522, -0.2
35764, 1.7869565217391, 0.20217391304348, -0.2
35765, 1.8521739130435, 0.22826086956522, -0.2
35766, 1.8304347826087, 0.20217391304348, -0.2
35767, 1.895652173913, 0.22826086956522, -0.2
35768, 1.8739130434783, 0.20217391304348, -0.2
35769, 1.9391304347826, 0.22826086956522, -0.2
35770, 1.9173913043478, 0.20217391304348, -0.2
35771, 1.9826086956522, 0.22826086956522, -0.2
35772, 1.9608695652174, 0.20217391304348, -0.2
35773, 2.0260869565217, 0.22826086956522, -0.2
35774, 2.004347826087, 0.20217391304348, -0.2
35775, 2.0695652173913, 0.22826086956522, -0.2
35776, 2.0478260869565, 0.20217391304348, -0.2
35777, 2.1130434782609, 0.22826086956522, -0.2
35778, 2.0913043478261, 0.20217391304348, -0.2
35779, 2.1565217391304, 0.22826086956522, -0.2
35780, 2.1347826086957, 0.20217391304348, -0.2
35781, 2.1782608695652, 0.20217391304348, -0.2
35782, 1.2434782608696, 0.17608695652174, -0.2
35783, 1.2869565217391, 0.17608695652174, -0.2
35784, 1.3304347826087, 0.17608695652174, -0.2
35785, 1.3739130434783, 0.17608695652174, -0.2
35786, 1.4173913043478, 0.17608695652174, -0.2
35787, 1.4608695652174, 0.17608695652174, -0.2
35788, 1.504347826087, 0.17608695652174, -0.2
35789, 1.5478260869565, 0.17608695652174, -0.2
35790, 1.5913043478261, 0.17608695652174, -0.2
35791, 1.6347826086957, 0.17608695652174, -0.2
35792, 1.6782608695652, 0.17608695652174, -0.2
35793, 1.7217391304348, 0.17608695652174, -0.2
35794, 1.7652173913043, 0.17608695652174, -0.2
35795, 1.8086956521739, 0.17608695652174, -0.2
35796, 1.8521739130435, 0.17608695652174, -0.2
35797, 1.895652173913, 0.17608695652174, -0.2
35798, 1.9391304347826, 0.17608695652174, -0.2
35799, 1.9826086956522, 0.17608695652174, -0.2
35800, 2.0260869565217, 0.17608695652174, -0.2
35801, 2.0695652173913, 0.17608695652174, -0.2
35802, 2.1130434782609, 0.17608695652174, -0.2
35803, 2.1565217391304, 0.17608695652174, -0.2
35804, 0.043478260869565, -0.016666666666667, 0.055555555555556
35805, 0.08695652173913, -0.016666666666667, 0.055555555555556
35806, 0.1304347826087, -0.016666666666667, 0.055555555555556
35807, 0.17391304347826, -0.016666666666667, 0.055555555555556
35808, 0.21739130434783, -0.016666666666667, 0.055555555555556
35809, 0.26086956521739, -0.016666666666667, 0.055555555555556
35810, 0.30434782608696, -0.016666666666667, 0.055555555555556
35811, 0.34782608695652, -0.016666666666667, 0.055555555555556
35812, 0.39130434782609, -0.016666666666667, 0.055555555555556
35813, 0.43478260869565, -0.016666666666667, 0.055555555555556
35814, 0.47826086956522, -0.016666666666667, 0.055555555555556
35815, 0.52173913043478, -0.016666666666667, 0.055555555555556
35816, 0.56521739130435, -0.016666666666667, 0.055555555555556
35817, 0.60869565217391, -0.016666666666667, 0.055555555555556
35818, 0.65217391304348, -0.016666666666667, 0.055555555555556
35819, 0.69565217391304, -0.016666666666667, 0.055555555555556
35820, 0.73913043478261, -0.016666666666667, 0.055555555555556
35821, 0.78260869565217, -0.016666666666667, 0.055555555555556
35822, 0.82608695652174, -0.016666666666667, 0.055555555555556
35823, 0.8695652173913, -0.016666666666667, 0.055555555555556
35824, 0.91304347826087, -0.016666666666667, 0.055555555555556
35825, 0.95652173913044, -0.016666666666667, 0.055555555555556
35826, 0.043478260869565, 0.016666666666667, 0.055555555555556
35827, 0.08695652173913, 0.016666666666667, 0.055555555555556
35828, 0.1304347826087, 0.016666666666667, 0.055555555555556
35829, 0.17391304347826, 0.016666666666667, 0.055555555555556
35830, 0.21739130434783, 0.016666666666667, 0.055555555555556
35831, 0.26086956521739, 0.016666666666667, 0.055555555555556
35832, 0.30434782608696, 0.016666666666667, 0.055555555555556
35833, 0.34782608695652, 0.016666666666667, 0.055555555555556
35834, 0.39130434782609, 0.016666666666667, 0.055555555555556
35835, 0.43478260869565, 0.016666666666667, 0.055555555555556
35836, 0.47826086956522, 0.016666666666667, 0.055555555555556
35837, 0.52173913043478, 0.016666666666667, 0.055555555555556
35838, 0.56521739130435, 0.016666666666667, 0.055555555555556
35839, 0.60869565217391, 0.016666666666667, 0.055555555555556
35840, 0.65217391304348, 0.016666666666667, 0.055555555555556
35841, 0.69565217391304, 0.016666666666667, 0.055555555555556
35842, 0.73913043478261, 0.016666666666667, 0.055555555555556
35843, 0.78260869565217, 0.016666666666667, 0.055555555555556
35844, 0.82608695652174, 0.016666666666667, 0.055555555555556
35845, 0.8695652173913, 0.016666666666667, 0.055555555555556
35846, 0.91304347826087, 0.016666666666667, 0.055555555555556
35847, 0.95652173913044, 0.016666666666667, 0.055555555555556
35848, 0.043478260869565, -0.016666666666667, 0.11111111111111
35849, 0.08695652173913, -0.016666666666667, 0.11111111111111
35850, 0.1304347826087, -0.016666666666667, 0.11111111111111
35851, 0.17391304347826, -0.016666666666667, 0.11111111111111
35852, 0.21739130434783, -0.016666666666667, 0.11111111111111
35853, 0.26086956521739, -0.016666666666667, 0.11111111111111
35854, 0.30434782608696, -0.016666666666667, 0.11111111111111
35855, 0.34782608695652, -0.016666666666667, 0.11111111111111
35856, 0.39130434782609, -0.016666666666667, 0.11111111111111
35857, 0.43478260869565, -0.016666666666667, 0.11111111111111
35858, 0.47826086956522, -0.016666666666667, 0.11111111111111
35859, 0.52173913043478, -0.016666666666667, 0.11111111111111
35860, 0.56521739130435, -0.016666666666667, 0.11111111111111
35861, 0.60869565217391, -0.016666666666667, 0.11111111111111
35862, 0.65217391304348, -0.016666666666667, 0.11111111111111
35863, 0.69565217391304, -0.016666666666667, 0.11111111111111
35864, 0.73913043478261, -0.016666666666667, 0.11111111111111
35865, 0.78260869565217, -0.016666666666667, 0.11111111111111
35866, 0.82608695652174, -0.016666666666667, 0.11111111111111
35867, 0.8695652173913, -0.016666666666667, 0.11111111111111
35868, 0.91304347826087, -0.016666666666667, 0.11111111111111
35869, 0.95652173913044, -0.016666666666667, 0.11111111111111
35870, 0.043478260869565, 0.016666666666667, 0.11111111111111
35871, 0.08695652173913, 0.016666666666667, 0.11111111111111
35872, 0.1304347826087, 0.016666666666667, 0.11111111111111
35873, 0.17391304347826, 0.016666666666667, 0.11111111111111
35874, 0.21739130434783, 0.016666666666667, 0.11111111111111
35875, 0.26086956521739, 0.016666666666667, 0.11111111111111
35876, 0.30434782608696, 0.016666666666667, 0.11111111111111
35877, 0.34782608695652, 0.016666666666667, 0.11111111111111
35878, 0.39130434782609, 0.016666666666667, 0.11111111111111
35879, 0.43478260869565, 0.016666666666667, 0.11111111111111
35880, 0.47826086956522, 0.016666666666667, 0.11111111111111
35881, 0.52173913043478, 0.016666666666667, 0.11111111111111
35882, 0.56521739130435, 0.016666666666667, 0.11111111111111
35883, 0.60869565217391, 0.016666666666667, 0.11111111111111
35884, 0.65217391304348, 0.016666666666667, 0.11111111111111
35885, 0.69565217391304, 0.016666666666667, 0.11111111111111
35886, 0.73913043478261, 0.016666666666667, 0.11111111111111
35887, 0.78260869565217, 0.016666666666667, 0.11111111111111
35888, 0.82608695652174, 0.016666666666667, 0.11111111111111
35889, 0.8695652173913, 0.016666666666667, 0.11111111111111
35890, 0.91304347826087, 0.016666666666667, 0.11111111111111
35891, 0.95652173913044, 0.016666666666667, 0.11111111111111
35892, 0.043478260869565, -0.016666666666667, 0.16666666666667
35893, 0.08695652173913, -0.016666666666667, 0.16666666666667
35894, 0.1304347826087, -0.016666666666667, 0.16666666666667
35895, 0.17391304347826, -0.016666666666667, 0.16666666666667
35896, 0.21739130434783, -0.016666666666667, 0.16666666666667
35897, 0.26086956521739, -0.016666666666667, 0.16666666666667
35898, 0.30434782608696, -0.016666666666667, 0.16666666666667
35899, 0.34782608695652, -0.016666666666667, 0.16666666666667
35900, 0.39130434782609, -0.016666666666667, 0.16666666666667
35901, 0.43478260869565, -0.016666666666667, 0.16666666666667
35902, 0.47826086956522, -0.016666666666667, 0.16666666666667
35903, 0.52173913043478, -0.016666666666667, 0.16666666666667
35904, 0.56521739130435, -0.016666666666667, 0.16666666666667
35905, 0.60869565217391, -0.016666666666667, 0.16666666666667
35906, 0.65217391304348, -0.016666666666667, 0.16666666666667
35907, 0.69565217391304, -0.016666666666667, 0.16666666666667
35908, 0.73913043478261, -0.016666666666667, 0.16666666666667
35909, 0.78260869565217, -0.016666666666667, 0.16666666666667
