*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC3D_2402.inp
*NODE
1, 1, 0.15, 0
2, 0, 0.15, 0
3, 1, 0.15, 0.5
4, 0, 0.15, 0.5
5, 1.2, 0.15, 0.5
6, 2.2, 0.15, 0.5
7, 1.2, 0.15, 0
8, 2.2, 0.15, 0
9, 0, 0.05, 0.5
10, -0.1, 0.05, 0.5
11, 0, -0.05, 0.5
12, -0.1, -0.05, 0.5
13, 0, -0.05, 0
14, -0.1, -0.05, 0
15, 0, 0.05, 0
16, -0.1, 0.05, 0
17, 0, -0.25, 0.5
18, -0.1, -0.25, 0.5
19, 0, -0.25, 0
20, -0.1, -0.25, 0
21, 1, -0.05, 0.5
22, 1, -0.05, 0
23, 1, 0.05, 0.5
24, 1, 0.05, 0
25, 1, -0.25, 0
26, 1, -0.25, 0.5
27, 1.2, -0.05, 0.5
28, 1.2, -0.25, 0.5
29, 1.2, -0.05, 0
30, 1.2, -0.25, 0
31, 2.2, -0.05, 0.5
32, 2.2, -0.25, 0.5
33, 2.2, -0.05, 0
34, 2.2, -0.25, 0
35, 1.2, 0.05, 0.5
36, 2.2, 0.05, 0.5
37, 1.2, 0.05, 0
38, 2.2, 0.05, 0
39, 2.3, 0.05, 0.5
40, 2.3, -0.05, 0.5
41, 2.3, 0.05, 0
42, 2.3, -0.05, 0
43, 2.3, -0.25, 0.5
44, 2.3, -0.25, 0
45, 1, 1.45, 0
46, 1, 1.55, 0
47, 0, 1.45, 0
48, 0, 1.55, 0
49, 1, 1.45, 0.5
50, 1, 1.55, 0.5
51, 0, 1.45, 0.5
52, 0, 1.55, 0.5
53, 1.2, 1.45, 0.5
54, 1.2, 1.55, 0.5
55, 1.2, 1.45, 0
56, 1.2, 1.55, 0
57, 1, 1.75, 0.5
58, 1.2, 1.75, 0.5
59, 1, 1.75, 0
60, 1.2, 1.75, 0
61, 0, 1.75, 0
62, 0, 1.75, 0.5
63, -0.1, 1.55, 0.5
64, -0.1, 1.75, 0.5
65, -0.1, 1.55, 0
66, -0.1, 1.75, 0
67, 1, 1.4, 0
68, 0, 1.4, 0
69, 1, 1.4, 0.5
70, 0, 1.4, 0.5
71, 1.2, 1.4, 0.5
72, 2.2, 1.45, 0.5
73, 2.2, 1.4, 0.5
74, 1.2, 1.4, 0
75, 2.2, 1.45, 0
76, 2.2, 1.4, 0
77, 2.2, 1.55, 0.5
78, 2.2, 1.55, 0
79, 2.2, 1.75, 0.5
80, 2.2, 1.75, 0
81, 2.3, 1.55, 0.5
82, 2.3, 1.75, 0.5
83, 2.3, 1.55, 0
84, 2.3, 1.75, 0
85, 1, 0.1, 0
86, 0, 0.1, 0
87, 1, 0.1, 0.5
88, 0, 0.1, 0.5
89, 1, 1.35, 0
90, 0, 1.35, 0
91, 1, 1.35, 0.5
92, 0, 1.35, 0.5
93, 1.2, 1.35, 0.5
94, 2.2, 1.35, 0.5
95, 1.2, 1.35, 0
96, 2.2, 1.35, 0
97, 1.2, 0.1, 0.5
98, 2.2, 0.1, 0.5
99, 1.2, 0.1, 0
100, 2.2, 0.1, 0
101, 1, 0.15, -0.2
102, 1, 1.35, -0.2
103, 0, 0.15, -0.2
104, 0, 1.35, -0.2
105, 1.2, 1.35, -0.2
106, 1.2, 0.15, -0.2
107, 2.2, 1.35, -0.2
108, 2.2, 0.15, -0.2
109, 0.043478260869565, 0.15, 0
110, 0.08695652173913, 0.15, 0
111, 0.1304347826087, 0.15, 0
112, 0.17391304347826, 0.15, 0
113, 0.21739130434783, 0.15, 0
114, 0.26086956521739, 0.15, 0
115, 0.30434782608696, 0.15, 0
116, 0.34782608695652, 0.15, 0
117, 0.39130434782609, 0.15, 0
118, 0.43478260869565, 0.15, 0
119, 0.47826086956522, 0.15, 0
120, 0.52173913043478, 0.15, 0
121, 0.56521739130435, 0.15, 0
122, 0.60869565217391, 0.15, 0
123, 0.65217391304348, 0.15, 0
124, 0.69565217391304, 0.15, 0
125, 0.73913043478261, 0.15, 0
126, 0.78260869565217, 0.15, 0
127, 0.82608695652174, 0.15, 0
128, 0.8695652173913, 0.15, 0
129, 0.91304347826087, 0.15, 0
130, 0.95652173913043, 0.15, 0
131, 0.021739130434783, 0.15, 0
132, 0.065217391304348, 0.15, 0
133, 0.10869565217391, 0.15, 0
134, 0.15217391304348, 0.15, 0
135, 0.19565217391304, 0.15, 0
136, 0.23913043478261, 0.15, 0
137, 0.28260869565217, 0.15, 0
138, 0.32608695652174, 0.15, 0
139, 0.3695652173913, 0.15, 0
140, 0.41304347826087, 0.15, 0
141, 0.45652173913043, 0.15, 0
142, 0.5, 0.15, 0
143, 0.54347826086957, 0.15, 0
144, 0.58695652173913, 0.15, 0
145, 0.6304347826087, 0.15, 0
146, 0.67391304347826, 0.15, 0
147, 0.71739130434783, 0.15, 0
148, 0.76086956521739, 0.15, 0
149, 0.80434782608696, 0.15, 0
150, 0.84782608695652, 0.15, 0
151, 0.89130434782609, 0.15, 0
152, 0.93478260869565, 0.15, 0
153, 0.97826086956522, 0.15, 0
154, 1, 0.15, 0.055555555555556
155, 1, 0.15, 0.11111111111111
156, 1, 0.15, 0.16666666666667
157, 1, 0.15, 0.22222222222222
158, 1, 0.15, 0.27777777777778
159, 1, 0.15, 0.33333333333333
160, 1, 0.15, 0.38888888888889
161, 1, 0.15, 0.44444444444444
162, 1, 0.15, 0.027777777777778
163, 1, 0.15, 0.083333333333333
164, 1, 0.15, 0.13888888888889
165, 1, 0.15, 0.19444444444444
166, 1, 0.15, 0.25
167, 1, 0.15, 0.30555555555556
168, 1, 0.15, 0.36111111111111
169, 1, 0.15, 0.41666666666667
170, 1, 0.15, 0.47222222222222
171, 0.043478260869565, 0.15, 0.5
172, 0.08695652173913, 0.15, 0.5
173, 0.1304347826087, 0.15, 0.5
174, 0.17391304347826, 0.15, 0.5
175, 0.21739130434783, 0.15, 0.5
176, 0.26086956521739, 0.15, 0.5
177, 0.30434782608696, 0.15, 0.5
178, 0.34782608695652, 0.15, 0.5
179, 0.39130434782609, 0.15, 0.5
180, 0.43478260869565, 0.15, 0.5
181, 0.47826086956522, 0.15, 0.5
182, 0.52173913043478, 0.15, 0.5
183, 0.56521739130435, 0.15, 0.5
184, 0.60869565217391, 0.15, 0.5
185, 0.65217391304348, 0.15, 0.5
186, 0.69565217391304, 0.15, 0.5
187, 0.73913043478261, 0.15, 0.5
188, 0.78260869565217, 0.15, 0.5
189, 0.82608695652174, 0.15, 0.5
190, 0.8695652173913, 0.15, 0.5
191, 0.91304347826087, 0.15, 0.5
192, 0.95652173913043, 0.15, 0.5
193, 0.021739130434783, 0.15, 0.5
194, 0.065217391304348, 0.15, 0.5
195, 0.10869565217391, 0.15, 0.5
196, 0.15217391304348, 0.15, 0.5
197, 0.19565217391304, 0.15, 0.5
198, 0.23913043478261, 0.15, 0.5
199, 0.28260869565217, 0.15, 0.5
200, 0.32608695652174, 0.15, 0.5
201, 0.3695652173913, 0.15, 0.5
202, 0.41304347826087, 0.15, 0.5
203, 0.45652173913043, 0.15, 0.5
204, 0.5, 0.15, 0.5
205, 0.54347826086957, 0.15, 0.5
206, 0.58695652173913, 0.15, 0.5
207, 0.6304347826087, 0.15, 0.5
208, 0.67391304347826, 0.15, 0.5
209, 0.71739130434783, 0.15, 0.5
210, 0.76086956521739, 0.15, 0.5
211, 0.80434782608696, 0.15, 0.5
212, 0.84782608695652, 0.15, 0.5
213, 0.89130434782609, 0.15, 0.5
214, 0.93478260869565, 0.15, 0.5
215, 0.97826086956522, 0.15, 0.5
216, 0, 0.15, 0.055555555555556
217, 0, 0.15, 0.11111111111111
218, 0, 0.15, 0.16666666666667
219, 0, 0.15, 0.22222222222222
220, 0, 0.15, 0.27777777777778
221, 0, 0.15, 0.33333333333333
222, 0, 0.15, 0.38888888888889
223, 0, 0.15, 0.44444444444444
224, 0, 0.15, 0.027777777777778
225, 0, 0.15, 0.083333333333333
226, 0, 0.15, 0.13888888888889
227, 0, 0.15, 0.19444444444444
228, 0, 0.15, 0.25
229, 0, 0.15, 0.30555555555556
230, 0, 0.15, 0.36111111111111
231, 0, 0.15, 0.41666666666667
232, 0, 0.15, 0.47222222222222
233, 1.2434782608696, 0.15, 0.5
234, 1.2869565217391, 0.15, 0.5
235, 1.3304347826087, 0.15, 0.5
236, 1.3739130434783, 0.15, 0.5
237, 1.4173913043478, 0.15, 0.5
238, 1.4608695652174, 0.15, 0.5
239, 1.504347826087, 0.15, 0.5
240, 1.5478260869565, 0.15, 0.5
241, 1.5913043478261, 0.15, 0.5
242, 1.6347826086957, 0.15, 0.5
243, 1.6782608695652, 0.15, 0.5
244, 1.7217391304348, 0.15, 0.5
245, 1.7652173913043, 0.15, 0.5
246, 1.8086956521739, 0.15, 0.5
247, 1.8521739130435, 0.15, 0.5
248, 1.895652173913, 0.15, 0.5
249, 1.9391304347826, 0.15, 0.5
250, 1.9826086956522, 0.15, 0.5
251, 2.0260869565217, 0.15, 0.5
252, 2.0695652173913, 0.15, 0.5
253, 2.1130434782609, 0.15, 0.5
254, 2.1565217391304, 0.15, 0.5
255, 1.2217391304348, 0.15, 0.5
256, 1.2652173913043, 0.15, 0.5
257, 1.3086956521739, 0.15, 0.5
258, 1.3521739130435, 0.15, 0.5
259, 1.395652173913, 0.15, 0.5
260, 1.4391304347826, 0.15, 0.5
261, 1.4826086956522, 0.15, 0.5
262, 1.5260869565217, 0.15, 0.5
263, 1.5695652173913, 0.15, 0.5
264, 1.6130434782609, 0.15, 0.5
265, 1.6565217391304, 0.15, 0.5
266, 1.7, 0.15, 0.5
267, 1.7434782608696, 0.15, 0.5
268, 1.7869565217391, 0.15, 0.5
269, 1.8304347826087, 0.15, 0.5
270, 1.8739130434783, 0.15, 0.5
271, 1.9173913043478, 0.15, 0.5
272, 1.9608695652174, 0.15, 0.5
273, 2.004347826087, 0.15, 0.5
274, 2.0478260869565, 0.15, 0.5
275, 2.0913043478261, 0.15, 0.5
276, 2.1347826086957, 0.15, 0.5
277, 2.1782608695652, 0.15, 0.5
278, 1.2434782608696, 0.15, 0
279, 1.2869565217391, 0.15, 0
280, 1.3304347826087, 0.15, 0
281, 1.3739130434783, 0.15, 0
282, 1.4173913043478, 0.15, 0
283, 1.4608695652174, 0.15, 0
284, 1.504347826087, 0.15, 0
285, 1.5478260869565, 0.15, 0
286, 1.5913043478261, 0.15, 0
287, 1.6347826086957, 0.15, 0
288, 1.6782608695652, 0.15, 0
289, 1.7217391304348, 0.15, 0
290, 1.7652173913043, 0.15, 0
291, 1.8086956521739, 0.15, 0
292, 1.8521739130435, 0.15, 0
293, 1.895652173913, 0.15, 0
294, 1.9391304347826, 0.15, 0
295, 1.9826086956522, 0.15, 0
296, 2.0260869565217, 0.15, 0
297, 2.0695652173913, 0.15, 0
298, 2.1130434782609, 0.15, 0
299, 2.1565217391304, 0.15, 0
300, 1.2217391304348, 0.15, 0
301, 1.2652173913043, 0.15, 0
302, 1.3086956521739, 0.15, 0
303, 1.3521739130435, 0.15, 0
304, 1.395652173913, 0.15, 0
305, 1.4391304347826, 0.15, 0
306, 1.4826086956522, 0.15, 0
307, 1.5260869565217, 0.15, 0
308, 1.5695652173913, 0.15, 0
309, 1.6130434782609, 0.15, 0
310, 1.6565217391304, 0.15, 0
311, 1.7, 0.15, 0
312, 1.7434782608696, 0.15, 0
313, 1.7869565217391, 0.15, 0
314, 1.8304347826087, 0.15, 0
315, 1.8739130434783, 0.15, 0
316, 1.9173913043478, 0.15, 0
317, 1.9608695652174, 0.15, 0
318, 2.004347826087, 0.15, 0
319, 2.0478260869565, 0.15, 0
320, 2.0913043478261, 0.15, 0
321, 2.1347826086957, 0.15, 0
322, 2.1782608695652, 0.15, 0
323, 1.2, 0.15, 0.055555555555556
324, 1.2, 0.15, 0.11111111111111
325, 1.2, 0.15, 0.16666666666667
326, 1.2, 0.15, 0.22222222222222
327, 1.2, 0.15, 0.27777777777778
328, 1.2, 0.15, 0.33333333333333
329, 1.2, 0.15, 0.38888888888889
330, 1.2, 0.15, 0.44444444444444
331, 1.2, 0.15, 0.027777777777778
332, 1.2, 0.15, 0.083333333333333
333, 1.2, 0.15, 0.13888888888889
334, 1.2, 0.15, 0.19444444444444
335, 1.2, 0.15, 0.25
336, 1.2, 0.15, 0.30555555555556
337, 1.2, 0.15, 0.36111111111111
338, 1.2, 0.15, 0.41666666666667
339, 1.2, 0.15, 0.47222222222222
340, 2.2, 0.15, 0.055555555555556
341, 2.2, 0.15, 0.11111111111111
342, 2.2, 0.15, 0.16666666666667
343, 2.2, 0.15, 0.22222222222222
344, 2.2, 0.15, 0.27777777777778
345, 2.2, 0.15, 0.33333333333333
346, 2.2, 0.15, 0.38888888888889
347, 2.2, 0.15, 0.44444444444444
348, 2.2, 0.15, 0.027777777777778
349, 2.2, 0.15, 0.083333333333333
350, 2.2, 0.15, 0.13888888888889
351, 2.2, 0.15, 0.19444444444444
352, 2.2, 0.15, 0.25
353, 2.2, 0.15, 0.30555555555556
354, 2.2, 0.15, 0.36111111111111
355, 2.2, 0.15, 0.41666666666667
356, 2.2, 0.15, 0.47222222222222
357, -0.05, 0.05, 0.5
358, -0.025, 0.05, 0.5
359, -0.075, 0.05, 0.5
360, -0.05, -0.05, 0.5
361, -0.025, -0.05, 0.5
362, -0.075, -0.05, 0.5
363, 0, -0.016666666666667, 0.5
364, 0, 0.016666666666667, 0.5
365, 0, -0.033333333333333, 0.5
366, 0, 5.5511151231258e-17, 0.5
367, 0, 0.033333333333333, 0.5
368, -0.1, -0.016666666666667, 0.5
369, -0.1, 0.016666666666667, 0.5
370, -0.1, -0.033333333333333, 0.5
371, -0.1, 5.5511151231258e-17, 0.5
372, -0.1, 0.033333333333333, 0.5
373, -0.05, -0.05, 0
374, -0.025, -0.05, 0
375, -0.075, -0.05, 0
376, 0, -0.05, 0.055555555555556
377, 0, -0.05, 0.11111111111111
378, 0, -0.05, 0.16666666666667
379, 0, -0.05, 0.22222222222222
380, 0, -0.05, 0.27777777777778
381, 0, -0.05, 0.33333333333333
382, 0, -0.05, 0.38888888888889
383, 0, -0.05, 0.44444444444444
384, 0, -0.05, 0.027777777777778
385, 0, -0.05, 0.083333333333333
386, 0, -0.05, 0.13888888888889
387, 0, -0.05, 0.19444444444444
388, 0, -0.05, 0.25
389, 0, -0.05, 0.30555555555556
390, 0, -0.05, 0.36111111111111
391, 0, -0.05, 0.41666666666667
392, 0, -0.05, 0.47222222222222
393, -0.1, -0.05, 0.055555555555556
394, -0.1, -0.05, 0.11111111111111
395, -0.1, -0.05, 0.16666666666667
396, -0.1, -0.05, 0.22222222222222
397, -0.1, -0.05, 0.27777777777778
398, -0.1, -0.05, 0.33333333333333
399, -0.1, -0.05, 0.38888888888889
400, -0.1, -0.05, 0.44444444444444
401, -0.1, -0.05, 0.027777777777778
402, -0.1, -0.05, 0.083333333333333
403, -0.1, -0.05, 0.13888888888889
404, -0.1, -0.05, 0.19444444444444
405, -0.1, -0.05, 0.25
406, -0.1, -0.05, 0.30555555555556
407, -0.1, -0.05, 0.36111111111111
408, -0.1, -0.05, 0.41666666666667
409, -0.1, -0.05, 0.47222222222222
410, -0.05, 0.05, 0
411, -0.025, 0.05, 0
412, -0.075, 0.05, 0
413, 0, 0.05, 0.055555555555556
414, 0, 0.05, 0.11111111111111
415, 0, 0.05, 0.16666666666667
416, 0, 0.05, 0.22222222222222
417, 0, 0.05, 0.27777777777778
418, 0, 0.05, 0.33333333333333
419, 0, 0.05, 0.38888888888889
420, 0, 0.05, 0.44444444444444
421, 0, 0.05, 0.027777777777778
422, 0, 0.05, 0.083333333333333
423, 0, 0.05, 0.13888888888889
424, 0, 0.05, 0.19444444444444
425, 0, 0.05, 0.25
426, 0, 0.05, 0.30555555555556
427, 0, 0.05, 0.36111111111111
428, 0, 0.05, 0.41666666666667
429, 0, 0.05, 0.47222222222222
430, -0.1, 0.05, 0.055555555555556
431, -0.1, 0.05, 0.11111111111111
432, -0.1, 0.05, 0.16666666666667
433, -0.1, 0.05, 0.22222222222222
434, -0.1, 0.05, 0.27777777777778
435, -0.1, 0.05, 0.33333333333333
436, -0.1, 0.05, 0.38888888888889
437, -0.1, 0.05, 0.44444444444444
438, -0.1, 0.05, 0.027777777777778
439, -0.1, 0.05, 0.083333333333333
440, -0.1, 0.05, 0.13888888888889
441, -0.1, 0.05, 0.19444444444444
442, -0.1, 0.05, 0.25
443, -0.1, 0.05, 0.30555555555556
444, -0.1, 0.05, 0.36111111111111
445, -0.1, 0.05, 0.41666666666667
446, -0.1, 0.05, 0.47222222222222
447, 0, -0.016666666666667, 0
448, 0, 0.016666666666667, 0
449, 0, -0.033333333333333, 0
450, 0, 5.5511151231258e-17, 0
451, 0, 0.033333333333333, 0
452, -0.1, -0.016666666666667, 0
453, -0.1, 0.016666666666667, 0
454, -0.1, -0.033333333333333, 0
455, -0.1, 5.5511151231258e-17, 0
456, -0.1, 0.033333333333333, 0
457, 0, -0.1, 0.5
458, 0, -0.15, 0.5
459, 0, -0.2, 0.5
460, 0, -0.075, 0.5
461, 0, -0.125, 0.5
462, 0, -0.175, 0.5
463, 0, -0.225, 0.5
464, -0.1, -0.1, 0.5
465, -0.1, -0.15, 0.5
466, -0.1, -0.2, 0.5
467, -0.1, -0.075, 0.5
468, -0.1, -0.125, 0.5
469, -0.1, -0.175, 0.5
470, -0.1, -0.225, 0.5
471, -0.05, -0.25, 0.5
472, -0.025, -0.25, 0.5
473, -0.075, -0.25, 0.5
474, 0, -0.1, 0
475, 0, -0.15, 0
476, 0, -0.2, 0
477, 0, -0.075, 0
478, 0, -0.125, 0
479, 0, -0.175, 0
480, 0, -0.225, 0
481, -0.1, -0.1, 0
482, -0.1, -0.15, 0
483, -0.1, -0.2, 0
484, -0.1, -0.075, 0
485, -0.1, -0.125, 0
486, -0.1, -0.175, 0
487, -0.1, -0.225, 0
488, -0.05, -0.25, 0
489, -0.025, -0.25, 0
490, -0.075, -0.25, 0
491, 0, -0.25, 0.055555555555556
492, 0, -0.25, 0.11111111111111
493, 0, -0.25, 0.16666666666667
494, 0, -0.25, 0.22222222222222
495, 0, -0.25, 0.27777777777778
496, 0, -0.25, 0.33333333333333
497, 0, -0.25, 0.38888888888889
498, 0, -0.25, 0.44444444444444
499, 0, -0.25, 0.027777777777778
500, 0, -0.25, 0.083333333333333
501, 0, -0.25, 0.13888888888889
502, 0, -0.25, 0.19444444444444
503, 0, -0.25, 0.25
504, 0, -0.25, 0.30555555555556
505, 0, -0.25, 0.36111111111111
506, 0, -0.25, 0.41666666666667
507, 0, -0.25, 0.47222222222222
508, -0.1, -0.25, 0.055555555555556
509, -0.1, -0.25, 0.11111111111111
510, -0.1, -0.25, 0.16666666666667
511, -0.1, -0.25, 0.22222222222222
512, -0.1, -0.25, 0.27777777777778
513, -0.1, -0.25, 0.33333333333333
514, -0.1, -0.25, 0.38888888888889
515, -0.1, -0.25, 0.44444444444444
516, -0.1, -0.25, 0.027777777777778
517, -0.1, -0.25, 0.083333333333333
518, -0.1, -0.25, 0.13888888888889
519, -0.1, -0.25, 0.19444444444444
520, -0.1, -0.25, 0.25
521, -0.1, -0.25, 0.30555555555556
522, -0.1, -0.25, 0.36111111111111
523, -0.1, -0.25, 0.41666666666667
524, -0.1, -0.25, 0.47222222222222
525, 1, -0.05, 0.055555555555556
526, 1, -0.05, 0.11111111111111
527, 1, -0.05, 0.16666666666667
528, 1, -0.05, 0.22222222222222
529, 1, -0.05, 0.27777777777778
530, 1, -0.05, 0.33333333333333
531, 1, -0.05, 0.38888888888889
532, 1, -0.05, 0.44444444444444
533, 1, -0.05, 0.027777777777778
534, 1, -0.05, 0.083333333333333
535, 1, -0.05, 0.13888888888889
536, 1, -0.05, 0.19444444444444
537, 1, -0.05, 0.25
538, 1, -0.05, 0.30555555555556
539, 1, -0.05, 0.36111111111111
540, 1, -0.05, 0.41666666666667
541, 1, -0.05, 0.47222222222222
542, 1, -0.016666666666667, 0.5
543, 1, 0.016666666666667, 0.5
544, 1, -0.033333333333333, 0.5
545, 1, 5.5511151231258e-17, 0.5
546, 1, 0.033333333333333, 0.5
547, 1, 0.05, 0.055555555555556
548, 1, 0.05, 0.11111111111111
549, 1, 0.05, 0.16666666666667
550, 1, 0.05, 0.22222222222222
551, 1, 0.05, 0.27777777777778
552, 1, 0.05, 0.33333333333333
553, 1, 0.05, 0.38888888888889
554, 1, 0.05, 0.44444444444444
555, 1, 0.05, 0.027777777777778
556, 1, 0.05, 0.083333333333333
557, 1, 0.05, 0.13888888888889
558, 1, 0.05, 0.19444444444444
559, 1, 0.05, 0.25
560, 1, 0.05, 0.30555555555556
561, 1, 0.05, 0.36111111111111
562, 1, 0.05, 0.41666666666667
563, 1, 0.05, 0.47222222222222
564, 1, -0.016666666666667, 0
565, 1, 0.016666666666667, 0
566, 1, -0.033333333333333, 0
567, 1, 5.5511151231258e-17, 0
568, 1, 0.033333333333333, 0
569, 0.043478260869565, -0.05, 0
570, 0.08695652173913, -0.05, 0
571, 0.1304347826087, -0.05, 0
572, 0.17391304347826, -0.05, 0
573, 0.21739130434783, -0.05, 0
574, 0.26086956521739, -0.05, 0
575, 0.30434782608696, -0.05, 0
576, 0.34782608695652, -0.05, 0
577, 0.39130434782609, -0.05, 0
578, 0.43478260869565, -0.05, 0
579, 0.47826086956522, -0.05, 0
580, 0.52173913043478, -0.05, 0
581, 0.56521739130435, -0.05, 0
582, 0.60869565217391, -0.05, 0
583, 0.65217391304348, -0.05, 0
584, 0.69565217391304, -0.05, 0
585, 0.73913043478261, -0.05, 0
586, 0.78260869565217, -0.05, 0
587, 0.82608695652174, -0.05, 0
588, 0.8695652173913, -0.05, 0
589, 0.91304347826087, -0.05, 0
590, 0.95652173913043, -0.05, 0
591, 0.021739130434783, -0.05, 0
592, 0.065217391304348, -0.05, 0
593, 0.10869565217391, -0.05, 0
594, 0.15217391304348, -0.05, 0
595, 0.19565217391304, -0.05, 0
596, 0.23913043478261, -0.05, 0
597, 0.28260869565217, -0.05, 0
598, 0.32608695652174, -0.05, 0
599, 0.3695652173913, -0.05, 0
600, 0.41304347826087, -0.05, 0
601, 0.45652173913043, -0.05, 0
602, 0.5, -0.05, 0
603, 0.54347826086957, -0.05, 0
604, 0.58695652173913, -0.05, 0
605, 0.6304347826087, -0.05, 0
606, 0.67391304347826, -0.05, 0
607, 0.71739130434783, -0.05, 0
608, 0.76086956521739, -0.05, 0
609, 0.80434782608696, -0.05, 0
610, 0.84782608695652, -0.05, 0
611, 0.89130434782609, -0.05, 0
612, 0.93478260869565, -0.05, 0
613, 0.97826086956522, -0.05, 0
614, 0.043478260869565, -0.05, 0.5
615, 0.08695652173913, -0.05, 0.5
616, 0.1304347826087, -0.05, 0.5
617, 0.17391304347826, -0.05, 0.5
618, 0.21739130434783, -0.05, 0.5
619, 0.26086956521739, -0.05, 0.5
620, 0.30434782608696, -0.05, 0.5
621, 0.34782608695652, -0.05, 0.5
622, 0.39130434782609, -0.05, 0.5
623, 0.43478260869565, -0.05, 0.5
624, 0.47826086956522, -0.05, 0.5
625, 0.52173913043478, -0.05, 0.5
626, 0.56521739130435, -0.05, 0.5
627, 0.60869565217391, -0.05, 0.5
628, 0.65217391304348, -0.05, 0.5
629, 0.69565217391304, -0.05, 0.5
630, 0.73913043478261, -0.05, 0.5
631, 0.78260869565217, -0.05, 0.5
632, 0.82608695652174, -0.05, 0.5
633, 0.8695652173913, -0.05, 0.5
634, 0.91304347826087, -0.05, 0.5
635, 0.95652173913043, -0.05, 0.5
636, 0.021739130434783, -0.05, 0.5
637, 0.065217391304348, -0.05, 0.5
638, 0.10869565217391, -0.05, 0.5
639, 0.15217391304348, -0.05, 0.5
640, 0.19565217391304, -0.05, 0.5
641, 0.23913043478261, -0.05, 0.5
642, 0.28260869565217, -0.05, 0.5
643, 0.32608695652174, -0.05, 0.5
644, 0.3695652173913, -0.05, 0.5
645, 0.41304347826087, -0.05, 0.5
646, 0.45652173913043, -0.05, 0.5
647, 0.5, -0.05, 0.5
648, 0.54347826086957, -0.05, 0.5
649, 0.58695652173913, -0.05, 0.5
650, 0.6304347826087, -0.05, 0.5
651, 0.67391304347826, -0.05, 0.5
652, 0.71739130434783, -0.05, 0.5
653, 0.76086956521739, -0.05, 0.5
654, 0.80434782608696, -0.05, 0.5
655, 0.84782608695652, -0.05, 0.5
656, 0.89130434782609, -0.05, 0.5
657, 0.93478260869565, -0.05, 0.5
658, 0.97826086956522, -0.05, 0.5
659, 0.043478260869565, 0.05, 0
660, 0.08695652173913, 0.05, 0
661, 0.1304347826087, 0.05, 0
662, 0.17391304347826, 0.05, 0
663, 0.21739130434783, 0.05, 0
664, 0.26086956521739, 0.05, 0
665, 0.30434782608696, 0.05, 0
666, 0.34782608695652, 0.05, 0
667, 0.39130434782609, 0.05, 0
668, 0.43478260869565, 0.05, 0
669, 0.47826086956522, 0.05, 0
670, 0.52173913043478, 0.05, 0
671, 0.56521739130435, 0.05, 0
672, 0.60869565217391, 0.05, 0
673, 0.65217391304348, 0.05, 0
674, 0.69565217391304, 0.05, 0
675, 0.73913043478261, 0.05, 0
676, 0.78260869565217, 0.05, 0
677, 0.82608695652174, 0.05, 0
678, 0.8695652173913, 0.05, 0
679, 0.91304347826087, 0.05, 0
680, 0.95652173913043, 0.05, 0
681, 0.021739130434783, 0.05, 0
682, 0.065217391304348, 0.05, 0
683, 0.10869565217391, 0.05, 0
684, 0.15217391304348, 0.05, 0
685, 0.19565217391304, 0.05, 0
686, 0.23913043478261, 0.05, 0
687, 0.28260869565217, 0.05, 0
688, 0.32608695652174, 0.05, 0
689, 0.3695652173913, 0.05, 0
690, 0.41304347826087, 0.05, 0
691, 0.45652173913043, 0.05, 0
692, 0.5, 0.05, 0
693, 0.54347826086957, 0.05, 0
694, 0.58695652173913, 0.05, 0
695, 0.6304347826087, 0.05, 0
696, 0.67391304347826, 0.05, 0
697, 0.71739130434783, 0.05, 0
698, 0.76086956521739, 0.05, 0
699, 0.80434782608696, 0.05, 0
700, 0.84782608695652, 0.05, 0
701, 0.89130434782609, 0.05, 0
702, 0.93478260869565, 0.05, 0
703, 0.97826086956522, 0.05, 0
704, 0.043478260869565, 0.05, 0.5
705, 0.08695652173913, 0.05, 0.5
706, 0.1304347826087, 0.05, 0.5
707, 0.17391304347826, 0.05, 0.5
708, 0.21739130434783, 0.05, 0.5
709, 0.26086956521739, 0.05, 0.5
710, 0.30434782608696, 0.05, 0.5
711, 0.34782608695652, 0.05, 0.5
712, 0.39130434782609, 0.05, 0.5
713, 0.43478260869565, 0.05, 0.5
714, 0.47826086956522, 0.05, 0.5
715, 0.52173913043478, 0.05, 0.5
716, 0.56521739130435, 0.05, 0.5
717, 0.60869565217391, 0.05, 0.5
718, 0.65217391304348, 0.05, 0.5
719, 0.69565217391304, 0.05, 0.5
720, 0.73913043478261, 0.05, 0.5
721, 0.78260869565217, 0.05, 0.5
722, 0.82608695652174, 0.05, 0.5
723, 0.8695652173913, 0.05, 0.5
724, 0.91304347826087, 0.05, 0.5
725, 0.95652173913043, 0.05, 0.5
726, 0.021739130434783, 0.05, 0.5
727, 0.065217391304348, 0.05, 0.5
728, 0.10869565217391, 0.05, 0.5
729, 0.15217391304348, 0.05, 0.5
730, 0.19565217391304, 0.05, 0.5
731, 0.23913043478261, 0.05, 0.5
732, 0.28260869565217, 0.05, 0.5
733, 0.32608695652174, 0.05, 0.5
734, 0.3695652173913, 0.05, 0.5
735, 0.41304347826087, 0.05, 0.5
736, 0.45652173913043, 0.05, 0.5
737, 0.5, 0.05, 0.5
738, 0.54347826086957, 0.05, 0.5
739, 0.58695652173913, 0.05, 0.5
740, 0.6304347826087, 0.05, 0.5
741, 0.67391304347826, 0.05, 0.5
742, 0.71739130434783, 0.05, 0.5
743, 0.76086956521739, 0.05, 0.5
744, 0.80434782608696, 0.05, 0.5
745, 0.84782608695652, 0.05, 0.5
746, 0.89130434782609, 0.05, 0.5
747, 0.93478260869565, 0.05, 0.5
748, 0.97826086956522, 0.05, 0.5
749, 1, -0.1, 0
750, 1, -0.15, 0
751, 1, -0.2, 0
752, 1, -0.075, 0
753, 1, -0.125, 0
754, 1, -0.175, 0
755, 1, -0.225, 0
756, 0.043478260869565, -0.25, 0
757, 0.08695652173913, -0.25, 0
758, 0.1304347826087, -0.25, 0
759, 0.17391304347826, -0.25, 0
760, 0.21739130434783, -0.25, 0
761, 0.26086956521739, -0.25, 0
762, 0.30434782608696, -0.25, 0
763, 0.34782608695652, -0.25, 0
764, 0.39130434782609, -0.25, 0
765, 0.43478260869565, -0.25, 0
766, 0.47826086956522, -0.25, 0
767, 0.52173913043478, -0.25, 0
768, 0.56521739130435, -0.25, 0
769, 0.60869565217391, -0.25, 0
770, 0.65217391304348, -0.25, 0
771, 0.69565217391304, -0.25, 0
772, 0.73913043478261, -0.25, 0
773, 0.78260869565217, -0.25, 0
774, 0.82608695652174, -0.25, 0
775, 0.8695652173913, -0.25, 0
776, 0.91304347826087, -0.25, 0
777, 0.95652173913043, -0.25, 0
778, 0.021739130434783, -0.25, 0
779, 0.065217391304348, -0.25, 0
780, 0.10869565217391, -0.25, 0
781, 0.15217391304348, -0.25, 0
782, 0.19565217391304, -0.25, 0
783, 0.23913043478261, -0.25, 0
784, 0.28260869565217, -0.25, 0
785, 0.32608695652174, -0.25, 0
786, 0.3695652173913, -0.25, 0
787, 0.41304347826087, -0.25, 0
788, 0.45652173913043, -0.25, 0
789, 0.5, -0.25, 0
790, 0.54347826086957, -0.25, 0
791, 0.58695652173913, -0.25, 0
792, 0.6304347826087, -0.25, 0
793, 0.67391304347826, -0.25, 0
794, 0.71739130434783, -0.25, 0
795, 0.76086956521739, -0.25, 0
796, 0.80434782608696, -0.25, 0
797, 0.84782608695652, -0.25, 0
798, 0.89130434782609, -0.25, 0
799, 0.93478260869565, -0.25, 0
800, 0.97826086956522, -0.25, 0
801, 1, -0.1, 0.5
802, 1, -0.15, 0.5
803, 1, -0.2, 0.5
804, 1, -0.075, 0.5
805, 1, -0.125, 0.5
806, 1, -0.175, 0.5
807, 1, -0.225, 0.5
808, 1, -0.25, 0.055555555555556
809, 1, -0.25, 0.11111111111111
810, 1, -0.25, 0.16666666666667
811, 1, -0.25, 0.22222222222222
812, 1, -0.25, 0.27777777777778
813, 1, -0.25, 0.33333333333333
814, 1, -0.25, 0.38888888888889
815, 1, -0.25, 0.44444444444444
816, 1, -0.25, 0.027777777777778
817, 1, -0.25, 0.083333333333333
818, 1, -0.25, 0.13888888888889
819, 1, -0.25, 0.19444444444444
820, 1, -0.25, 0.25
821, 1, -0.25, 0.30555555555556
822, 1, -0.25, 0.36111111111111
823, 1, -0.25, 0.41666666666667
824, 1, -0.25, 0.47222222222222
825, 0.043478260869565, -0.25, 0.5
826, 0.08695652173913, -0.25, 0.5
827, 0.1304347826087, -0.25, 0.5
828, 0.17391304347826, -0.25, 0.5
829, 0.21739130434783, -0.25, 0.5
830, 0.26086956521739, -0.25, 0.5
831, 0.30434782608696, -0.25, 0.5
832, 0.34782608695652, -0.25, 0.5
833, 0.39130434782609, -0.25, 0.5
834, 0.43478260869565, -0.25, 0.5
835, 0.47826086956522, -0.25, 0.5
836, 0.52173913043478, -0.25, 0.5
837, 0.56521739130435, -0.25, 0.5
838, 0.60869565217391, -0.25, 0.5
839, 0.65217391304348, -0.25, 0.5
840, 0.69565217391304, -0.25, 0.5
841, 0.73913043478261, -0.25, 0.5
842, 0.78260869565217, -0.25, 0.5
843, 0.82608695652174, -0.25, 0.5
844, 0.8695652173913, -0.25, 0.5
845, 0.91304347826087, -0.25, 0.5
846, 0.95652173913043, -0.25, 0.5
847, 0.021739130434783, -0.25, 0.5
848, 0.065217391304348, -0.25, 0.5
849, 0.10869565217391, -0.25, 0.5
850, 0.15217391304348, -0.25, 0.5
851, 0.19565217391304, -0.25, 0.5
852, 0.23913043478261, -0.25, 0.5
853, 0.28260869565217, -0.25, 0.5
854, 0.32608695652174, -0.25, 0.5
855, 0.3695652173913, -0.25, 0.5
856, 0.41304347826087, -0.25, 0.5
857, 0.45652173913043, -0.25, 0.5
858, 0.5, -0.25, 0.5
859, 0.54347826086957, -0.25, 0.5
860, 0.58695652173913, -0.25, 0.5
861, 0.6304347826087, -0.25, 0.5
862, 0.67391304347826, -0.25, 0.5
863, 0.71739130434783, -0.25, 0.5
864, 0.76086956521739, -0.25, 0.5
865, 0.80434782608696, -0.25, 0.5
866, 0.84782608695652, -0.25, 0.5
867, 0.89130434782609, -0.25, 0.5
868, 0.93478260869565, -0.25, 0.5
869, 0.97826086956522, -0.25, 0.5
870, 1.05, -0.05, 0.5
871, 1.1, -0.05, 0.5
872, 1.15, -0.05, 0.5
873, 1.025, -0.05, 0.5
874, 1.075, -0.05, 0.5
875, 1.125, -0.05, 0.5
876, 1.175, -0.05, 0.5
877, 1.05, -0.25, 0.5
878, 1.1, -0.25, 0.5
879, 1.15, -0.25, 0.5
880, 1.025, -0.25, 0.5
881, 1.075, -0.25, 0.5
882, 1.125, -0.25, 0.5
883, 1.175, -0.25, 0.5
884, 1.2, -0.1, 0.5
885, 1.2, -0.15, 0.5
886, 1.2, -0.2, 0.5
887, 1.2, -0.075, 0.5
888, 1.2, -0.125, 0.5
889, 1.2, -0.175, 0.5
890, 1.2, -0.225, 0.5
891, 1.05, -0.05, 0
892, 1.1, -0.05, 0
893, 1.15, -0.05, 0
894, 1.025, -0.05, 0
895, 1.075, -0.05, 0
896, 1.125, -0.05, 0
897, 1.175, -0.05, 0
898, 1.05, -0.25, 0
899, 1.1, -0.25, 0
900, 1.15, -0.25, 0
901, 1.025, -0.25, 0
902, 1.075, -0.25, 0
903, 1.125, -0.25, 0
904, 1.175, -0.25, 0
905, 1.2, -0.1, 0
906, 1.2, -0.15, 0
907, 1.2, -0.2, 0
908, 1.2, -0.075, 0
909, 1.2, -0.125, 0
910, 1.2, -0.175, 0
911, 1.2, -0.225, 0
912, 1.2, -0.05, 0.055555555555556
913, 1.2, -0.05, 0.11111111111111
914, 1.2, -0.05, 0.16666666666667
915, 1.2, -0.05, 0.22222222222222
916, 1.2, -0.05, 0.27777777777778
917, 1.2, -0.05, 0.33333333333333
918, 1.2, -0.05, 0.38888888888889
919, 1.2, -0.05, 0.44444444444444
920, 1.2, -0.05, 0.027777777777778
921, 1.2, -0.05, 0.083333333333333
922, 1.2, -0.05, 0.13888888888889
923, 1.2, -0.05, 0.19444444444444
924, 1.2, -0.05, 0.25
925, 1.2, -0.05, 0.30555555555556
926, 1.2, -0.05, 0.36111111111111
927, 1.2, -0.05, 0.41666666666667
928, 1.2, -0.05, 0.47222222222222
929, 1.2, -0.25, 0.055555555555556
930, 1.2, -0.25, 0.11111111111111
931, 1.2, -0.25, 0.16666666666667
932, 1.2, -0.25, 0.22222222222222
933, 1.2, -0.25, 0.27777777777778
934, 1.2, -0.25, 0.33333333333333
935, 1.2, -0.25, 0.38888888888889
936, 1.2, -0.25, 0.44444444444444
937, 1.2, -0.25, 0.027777777777778
938, 1.2, -0.25, 0.083333333333333
939, 1.2, -0.25, 0.13888888888889
940, 1.2, -0.25, 0.19444444444444
941, 1.2, -0.25, 0.25
942, 1.2, -0.25, 0.30555555555556
943, 1.2, -0.25, 0.36111111111111
944, 1.2, -0.25, 0.41666666666667
945, 1.2, -0.25, 0.47222222222222
946, 2.2, -0.1, 0.5
947, 2.2, -0.15, 0.5
948, 2.2, -0.2, 0.5
949, 2.2, -0.075, 0.5
950, 2.2, -0.125, 0.5
951, 2.2, -0.175, 0.5
952, 2.2, -0.225, 0.5
953, 1.2434782608696, -0.05, 0.5
954, 1.2869565217391, -0.05, 0.5
955, 1.3304347826087, -0.05, 0.5
956, 1.3739130434783, -0.05, 0.5
957, 1.4173913043478, -0.05, 0.5
958, 1.4608695652174, -0.05, 0.5
959, 1.504347826087, -0.05, 0.5
960, 1.5478260869565, -0.05, 0.5
961, 1.5913043478261, -0.05, 0.5
962, 1.6347826086957, -0.05, 0.5
963, 1.6782608695652, -0.05, 0.5
964, 1.7217391304348, -0.05, 0.5
965, 1.7652173913043, -0.05, 0.5
966, 1.8086956521739, -0.05, 0.5
967, 1.8521739130435, -0.05, 0.5
968, 1.895652173913, -0.05, 0.5
969, 1.9391304347826, -0.05, 0.5
970, 1.9826086956522, -0.05, 0.5
971, 2.0260869565217, -0.05, 0.5
972, 2.0695652173913, -0.05, 0.5
973, 2.1130434782609, -0.05, 0.5
974, 2.1565217391304, -0.05, 0.5
975, 1.2217391304348, -0.05, 0.5
976, 1.2652173913043, -0.05, 0.5
977, 1.3086956521739, -0.05, 0.5
978, 1.3521739130435, -0.05, 0.5
979, 1.395652173913, -0.05, 0.5
980, 1.4391304347826, -0.05, 0.5
981, 1.4826086956522, -0.05, 0.5
982, 1.5260869565217, -0.05, 0.5
983, 1.5695652173913, -0.05, 0.5
984, 1.6130434782609, -0.05, 0.5
985, 1.6565217391304, -0.05, 0.5
986, 1.7, -0.05, 0.5
987, 1.7434782608696, -0.05, 0.5
988, 1.7869565217391, -0.05, 0.5
989, 1.8304347826087, -0.05, 0.5
990, 1.8739130434783, -0.05, 0.5
991, 1.9173913043478, -0.05, 0.5
992, 1.9608695652174, -0.05, 0.5
993, 2.004347826087, -0.05, 0.5
994, 2.0478260869565, -0.05, 0.5
995, 2.0913043478261, -0.05, 0.5
996, 2.1347826086957, -0.05, 0.5
997, 2.1782608695652, -0.05, 0.5
998, 1.2434782608696, -0.25, 0.5
999, 1.2869565217391, -0.25, 0.5
1000, 1.3304347826087, -0.25, 0.5
1001, 1.3739130434783, -0.25, 0.5
1002, 1.4173913043478, -0.25, 0.5
1003, 1.4608695652174, -0.25, 0.5
1004, 1.504347826087, -0.25, 0.5
1005, 1.5478260869565, -0.25, 0.5
1006, 1.5913043478261, -0.25, 0.5
1007, 1.6347826086957, -0.25, 0.5
1008, 1.6782608695652, -0.25, 0.5
1009, 1.7217391304348, -0.25, 0.5
1010, 1.7652173913043, -0.25, 0.5
1011, 1.8086956521739, -0.25, 0.5
1012, 1.8521739130435, -0.25, 0.5
1013, 1.895652173913, -0.25, 0.5
1014, 1.9391304347826, -0.25, 0.5
1015, 1.9826086956522, -0.25, 0.5
1016, 2.0260869565217, -0.25, 0.5
1017, 2.0695652173913, -0.25, 0.5
1018, 2.1130434782609, -0.25, 0.5
1019, 2.1565217391304, -0.25, 0.5
1020, 1.2217391304348, -0.25, 0.5
1021, 1.2652173913043, -0.25, 0.5
1022, 1.3086956521739, -0.25, 0.5
1023, 1.3521739130435, -0.25, 0.5
1024, 1.395652173913, -0.25, 0.5
1025, 1.4391304347826, -0.25, 0.5
1026, 1.4826086956522, -0.25, 0.5
1027, 1.5260869565217, -0.25, 0.5
1028, 1.5695652173913, -0.25, 0.5
1029, 1.6130434782609, -0.25, 0.5
1030, 1.6565217391304, -0.25, 0.5
1031, 1.7, -0.25, 0.5
1032, 1.7434782608696, -0.25, 0.5
1033, 1.7869565217391, -0.25, 0.5
1034, 1.8304347826087, -0.25, 0.5
1035, 1.8739130434783, -0.25, 0.5
1036, 1.9173913043478, -0.25, 0.5
1037, 1.9608695652174, -0.25, 0.5
1038, 2.004347826087, -0.25, 0.5
1039, 2.0478260869565, -0.25, 0.5
1040, 2.0913043478261, -0.25, 0.5
1041, 2.1347826086957, -0.25, 0.5
1042, 2.1782608695652, -0.25, 0.5
1043, 2.2, -0.1, 0
1044, 2.2, -0.15, 0
1045, 2.2, -0.2, 0
1046, 2.2, -0.075, 0
1047, 2.2, -0.125, 0
1048, 2.2, -0.175, 0
1049, 2.2, -0.225, 0
1050, 1.2434782608696, -0.05, 0
1051, 1.2869565217391, -0.05, 0
1052, 1.3304347826087, -0.05, 0
1053, 1.3739130434783, -0.05, 0
1054, 1.4173913043478, -0.05, 0
1055, 1.4608695652174, -0.05, 0
1056, 1.504347826087, -0.05, 0
1057, 1.5478260869565, -0.05, 0
1058, 1.5913043478261, -0.05, 0
1059, 1.6347826086957, -0.05, 0
1060, 1.6782608695652, -0.05, 0
1061, 1.7217391304348, -0.05, 0
1062, 1.7652173913043, -0.05, 0
1063, 1.8086956521739, -0.05, 0
1064, 1.8521739130435, -0.05, 0
1065, 1.895652173913, -0.05, 0
1066, 1.9391304347826, -0.05, 0
1067, 1.9826086956522, -0.05, 0
1068, 2.0260869565217, -0.05, 0
1069, 2.0695652173913, -0.05, 0
1070, 2.1130434782609, -0.05, 0
1071, 2.1565217391304, -0.05, 0
1072, 1.2217391304348, -0.05, 0
1073, 1.2652173913043, -0.05, 0
1074, 1.3086956521739, -0.05, 0
1075, 1.3521739130435, -0.05, 0
1076, 1.395652173913, -0.05, 0
1077, 1.4391304347826, -0.05, 0
1078, 1.4826086956522, -0.05, 0
1079, 1.5260869565217, -0.05, 0
1080, 1.5695652173913, -0.05, 0
1081, 1.6130434782609, -0.05, 0
1082, 1.6565217391304, -0.05, 0
1083, 1.7, -0.05, 0
1084, 1.7434782608696, -0.05, 0
1085, 1.7869565217391, -0.05, 0
1086, 1.8304347826087, -0.05, 0
1087, 1.8739130434783, -0.05, 0
1088, 1.9173913043478, -0.05, 0
1089, 1.9608695652174, -0.05, 0
1090, 2.004347826087, -0.05, 0
1091, 2.0478260869565, -0.05, 0
1092, 2.0913043478261, -0.05, 0
1093, 2.1347826086957, -0.05, 0
1094, 2.1782608695652, -0.05, 0
1095, 1.2434782608696, -0.25, 0
1096, 1.2869565217391, -0.25, 0
1097, 1.3304347826087, -0.25, 0
1098, 1.3739130434783, -0.25, 0
1099, 1.4173913043478, -0.25, 0
1100, 1.4608695652174, -0.25, 0
1101, 1.504347826087, -0.25, 0
1102, 1.5478260869565, -0.25, 0
1103, 1.5913043478261, -0.25, 0
1104, 1.6347826086957, -0.25, 0
1105, 1.6782608695652, -0.25, 0
1106, 1.7217391304348, -0.25, 0
1107, 1.7652173913043, -0.25, 0
1108, 1.8086956521739, -0.25, 0
1109, 1.8521739130435, -0.25, 0
1110, 1.895652173913, -0.25, 0
1111, 1.9391304347826, -0.25, 0
1112, 1.9826086956522, -0.25, 0
1113, 2.0260869565217, -0.25, 0
1114, 2.0695652173913, -0.25, 0
1115, 2.1130434782609, -0.25, 0
1116, 2.1565217391304, -0.25, 0
1117, 1.2217391304348, -0.25, 0
1118, 1.2652173913043, -0.25, 0
1119, 1.3086956521739, -0.25, 0
1120, 1.3521739130435, -0.25, 0
1121, 1.395652173913, -0.25, 0
1122, 1.4391304347826, -0.25, 0
1123, 1.4826086956522, -0.25, 0
1124, 1.5260869565217, -0.25, 0
1125, 1.5695652173913, -0.25, 0
1126, 1.6130434782609, -0.25, 0
1127, 1.6565217391304, -0.25, 0
1128, 1.7, -0.25, 0
1129, 1.7434782608696, -0.25, 0
1130, 1.7869565217391, -0.25, 0
1131, 1.8304347826087, -0.25, 0
1132, 1.8739130434783, -0.25, 0
1133, 1.9173913043478, -0.25, 0
1134, 1.9608695652174, -0.25, 0
1135, 2.004347826087, -0.25, 0
1136, 2.0478260869565, -0.25, 0
1137, 2.0913043478261, -0.25, 0
1138, 2.1347826086957, -0.25, 0
1139, 2.1782608695652, -0.25, 0
1140, 2.2, -0.05, 0.055555555555556
1141, 2.2, -0.05, 0.11111111111111
1142, 2.2, -0.05, 0.16666666666667
1143, 2.2, -0.05, 0.22222222222222
1144, 2.2, -0.05, 0.27777777777778
1145, 2.2, -0.05, 0.33333333333333
1146, 2.2, -0.05, 0.38888888888889
1147, 2.2, -0.05, 0.44444444444444
1148, 2.2, -0.05, 0.027777777777778
1149, 2.2, -0.05, 0.083333333333333
1150, 2.2, -0.05, 0.13888888888889
1151, 2.2, -0.05, 0.19444444444444
1152, 2.2, -0.05, 0.25
1153, 2.2, -0.05, 0.30555555555556
1154, 2.2, -0.05, 0.36111111111111
1155, 2.2, -0.05, 0.41666666666667
1156, 2.2, -0.05, 0.47222222222222
1157, 2.2, -0.25, 0.055555555555556
1158, 2.2, -0.25, 0.11111111111111
1159, 2.2, -0.25, 0.16666666666667
1160, 2.2, -0.25, 0.22222222222222
1161, 2.2, -0.25, 0.27777777777778
1162, 2.2, -0.25, 0.33333333333333
1163, 2.2, -0.25, 0.38888888888889
1164, 2.2, -0.25, 0.44444444444444
1165, 2.2, -0.25, 0.027777777777778
1166, 2.2, -0.25, 0.083333333333333
1167, 2.2, -0.25, 0.13888888888889
1168, 2.2, -0.25, 0.19444444444444
1169, 2.2, -0.25, 0.25
1170, 2.2, -0.25, 0.30555555555556
1171, 2.2, -0.25, 0.36111111111111
1172, 2.2, -0.25, 0.41666666666667
1173, 2.2, -0.25, 0.47222222222222
1174, 1.2, 0.016666666666667, 0.5
1175, 1.2, -0.016666666666667, 0.5
1176, 1.2, 0.033333333333333, 0.5
1177, 1.2, -9.7144514654701e-17, 0.5
1178, 1.2, -0.033333333333333, 0.5
1179, 2.2, 0.016666666666667, 0.5
1180, 2.2, -0.016666666666667, 0.5
1181, 2.2, 0.033333333333333, 0.5
1182, 2.2, -9.7144514654701e-17, 0.5
1183, 2.2, -0.033333333333333, 0.5
1184, 1.2434782608696, 0.05, 0.5
1185, 1.2869565217391, 0.05, 0.5
1186, 1.3304347826087, 0.05, 0.5
1187, 1.3739130434783, 0.05, 0.5
1188, 1.4173913043478, 0.05, 0.5
1189, 1.4608695652174, 0.05, 0.5
1190, 1.504347826087, 0.05, 0.5
1191, 1.5478260869565, 0.05, 0.5
1192, 1.5913043478261, 0.05, 0.5
1193, 1.6347826086957, 0.05, 0.5
1194, 1.6782608695652, 0.05, 0.5
1195, 1.7217391304348, 0.05, 0.5
1196, 1.7652173913043, 0.05, 0.5
1197, 1.8086956521739, 0.05, 0.5
1198, 1.8521739130435, 0.05, 0.5
1199, 1.895652173913, 0.05, 0.5
1200, 1.9391304347826, 0.05, 0.5
1201, 1.9826086956522, 0.05, 0.5
1202, 2.0260869565217, 0.05, 0.5
1203, 2.0695652173913, 0.05, 0.5
1204, 2.1130434782609, 0.05, 0.5
1205, 2.1565217391304, 0.05, 0.5
1206, 1.2217391304348, 0.05, 0.5
1207, 1.2652173913043, 0.05, 0.5
1208, 1.3086956521739, 0.05, 0.5
1209, 1.3521739130435, 0.05, 0.5
1210, 1.395652173913, 0.05, 0.5
1211, 1.4391304347826, 0.05, 0.5
1212, 1.4826086956522, 0.05, 0.5
1213, 1.5260869565217, 0.05, 0.5
1214, 1.5695652173913, 0.05, 0.5
1215, 1.6130434782609, 0.05, 0.5
1216, 1.6565217391304, 0.05, 0.5
1217, 1.7, 0.05, 0.5
1218, 1.7434782608696, 0.05, 0.5
1219, 1.7869565217391, 0.05, 0.5
1220, 1.8304347826087, 0.05, 0.5
1221, 1.8739130434783, 0.05, 0.5
1222, 1.9173913043478, 0.05, 0.5
1223, 1.9608695652174, 0.05, 0.5
1224, 2.004347826087, 0.05, 0.5
1225, 2.0478260869565, 0.05, 0.5
1226, 2.0913043478261, 0.05, 0.5
1227, 2.1347826086957, 0.05, 0.5
1228, 2.1782608695652, 0.05, 0.5
1229, 1.2, 0.016666666666667, 0
1230, 1.2, -0.016666666666667, 0
1231, 1.2, 0.033333333333333, 0
1232, 1.2, -9.7144514654701e-17, 0
1233, 1.2, -0.033333333333333, 0
1234, 2.2, 0.016666666666667, 0
1235, 2.2, -0.016666666666667, 0
1236, 2.2, 0.033333333333333, 0
1237, 2.2, -9.7144514654701e-17, 0
1238, 2.2, -0.033333333333333, 0
1239, 1.2434782608696, 0.05, 0
1240, 1.2869565217391, 0.05, 0
1241, 1.3304347826087, 0.05, 0
1242, 1.3739130434783, 0.05, 0
1243, 1.4173913043478, 0.05, 0
1244, 1.4608695652174, 0.05, 0
1245, 1.504347826087, 0.05, 0
1246, 1.5478260869565, 0.05, 0
1247, 1.5913043478261, 0.05, 0
1248, 1.6347826086957, 0.05, 0
1249, 1.6782608695652, 0.05, 0
1250, 1.7217391304348, 0.05, 0
1251, 1.7652173913043, 0.05, 0
1252, 1.8086956521739, 0.05, 0
1253, 1.8521739130435, 0.05, 0
1254, 1.895652173913, 0.05, 0
1255, 1.9391304347826, 0.05, 0
1256, 1.9826086956522, 0.05, 0
1257, 2.0260869565217, 0.05, 0
1258, 2.0695652173913, 0.05, 0
1259, 2.1130434782609, 0.05, 0
1260, 2.1565217391304, 0.05, 0
1261, 1.2217391304348, 0.05, 0
1262, 1.2652173913043, 0.05, 0
1263, 1.3086956521739, 0.05, 0
1264, 1.3521739130435, 0.05, 0
1265, 1.395652173913, 0.05, 0
1266, 1.4391304347826, 0.05, 0
1267, 1.4826086956522, 0.05, 0
1268, 1.5260869565217, 0.05, 0
1269, 1.5695652173913, 0.05, 0
1270, 1.6130434782609, 0.05, 0
1271, 1.6565217391304, 0.05, 0
1272, 1.7, 0.05, 0
1273, 1.7434782608696, 0.05, 0
1274, 1.7869565217391, 0.05, 0
1275, 1.8304347826087, 0.05, 0
1276, 1.8739130434783, 0.05, 0
1277, 1.9173913043478, 0.05, 0
1278, 1.9608695652174, 0.05, 0
1279, 2.004347826087, 0.05, 0
1280, 2.0478260869565, 0.05, 0
1281, 2.0913043478261, 0.05, 0
1282, 2.1347826086957, 0.05, 0
1283, 2.1782608695652, 0.05, 0
1284, 1.2, 0.05, 0.055555555555556
1285, 1.2, 0.05, 0.11111111111111
1286, 1.2, 0.05, 0.16666666666667
1287, 1.2, 0.05, 0.22222222222222
1288, 1.2, 0.05, 0.27777777777778
1289, 1.2, 0.05, 0.33333333333333
1290, 1.2, 0.05, 0.38888888888889
1291, 1.2, 0.05, 0.44444444444444
1292, 1.2, 0.05, 0.027777777777778
1293, 1.2, 0.05, 0.083333333333333
1294, 1.2, 0.05, 0.13888888888889
1295, 1.2, 0.05, 0.19444444444444
1296, 1.2, 0.05, 0.25
1297, 1.2, 0.05, 0.30555555555556
1298, 1.2, 0.05, 0.36111111111111
1299, 1.2, 0.05, 0.41666666666667
1300, 1.2, 0.05, 0.47222222222222
1301, 2.2, 0.05, 0.055555555555556
1302, 2.2, 0.05, 0.11111111111111
1303, 2.2, 0.05, 0.16666666666667
1304, 2.2, 0.05, 0.22222222222222
1305, 2.2, 0.05, 0.27777777777778
1306, 2.2, 0.05, 0.33333333333333
1307, 2.2, 0.05, 0.38888888888889
1308, 2.2, 0.05, 0.44444444444444
1309, 2.2, 0.05, 0.027777777777778
1310, 2.2, 0.05, 0.083333333333333
1311, 2.2, 0.05, 0.13888888888889
1312, 2.2, 0.05, 0.19444444444444
1313, 2.2, 0.05, 0.25
1314, 2.2, 0.05, 0.30555555555556
1315, 2.2, 0.05, 0.36111111111111
1316, 2.2, 0.05, 0.41666666666667
1317, 2.2, 0.05, 0.47222222222222
1318, 2.25, 0.05, 0.5
1319, 2.225, 0.05, 0.5
1320, 2.275, 0.05, 0.5
1321, 2.25, -0.05, 0.5
1322, 2.225, -0.05, 0.5
1323, 2.275, -0.05, 0.5
1324, 2.3, 0.016666666666667, 0.5
1325, 2.3, -0.016666666666667, 0.5
1326, 2.3, 0.033333333333333, 0.5
1327, 2.3, -9.7144514654701e-17, 0.5
1328, 2.3, -0.033333333333333, 0.5
1329, 2.25, 0.05, 0
1330, 2.225, 0.05, 0
1331, 2.275, 0.05, 0
1332, 2.25, -0.05, 0
1333, 2.225, -0.05, 0
1334, 2.275, -0.05, 0
1335, 2.3, 0.016666666666667, 0
1336, 2.3, -0.016666666666667, 0
1337, 2.3, 0.033333333333333, 0
1338, 2.3, -9.7144514654701e-17, 0
1339, 2.3, -0.033333333333333, 0
1340, 2.3, 0.05, 0.055555555555556
1341, 2.3, 0.05, 0.11111111111111
1342, 2.3, 0.05, 0.16666666666667
1343, 2.3, 0.05, 0.22222222222222
1344, 2.3, 0.05, 0.27777777777778
1345, 2.3, 0.05, 0.33333333333333
1346, 2.3, 0.05, 0.38888888888889
1347, 2.3, 0.05, 0.44444444444444
1348, 2.3, 0.05, 0.027777777777778
1349, 2.3, 0.05, 0.083333333333333
1350, 2.3, 0.05, 0.13888888888889
1351, 2.3, 0.05, 0.19444444444444
1352, 2.3, 0.05, 0.25
1353, 2.3, 0.05, 0.30555555555556
1354, 2.3, 0.05, 0.36111111111111
1355, 2.3, 0.05, 0.41666666666667
1356, 2.3, 0.05, 0.47222222222222
1357, 2.3, -0.05, 0.055555555555556
1358, 2.3, -0.05, 0.11111111111111
1359, 2.3, -0.05, 0.16666666666667
1360, 2.3, -0.05, 0.22222222222222
1361, 2.3, -0.05, 0.27777777777778
1362, 2.3, -0.05, 0.33333333333333
1363, 2.3, -0.05, 0.38888888888889
1364, 2.3, -0.05, 0.44444444444444
1365, 2.3, -0.05, 0.027777777777778
1366, 2.3, -0.05, 0.083333333333333
1367, 2.3, -0.05, 0.13888888888889
1368, 2.3, -0.05, 0.19444444444444
1369, 2.3, -0.05, 0.25
1370, 2.3, -0.05, 0.30555555555556
1371, 2.3, -0.05, 0.36111111111111
1372, 2.3, -0.05, 0.41666666666667
1373, 2.3, -0.05, 0.47222222222222
1374, 2.3, -0.1, 0.5
1375, 2.3, -0.15, 0.5
1376, 2.3, -0.2, 0.5
1377, 2.3, -0.075, 0.5
1378, 2.3, -0.125, 0.5
1379, 2.3, -0.175, 0.5
1380, 2.3, -0.225, 0.5
1381, 2.25, -0.25, 0.5
1382, 2.225, -0.25, 0.5
1383, 2.275, -0.25, 0.5
1384, 2.3, -0.1, 0
1385, 2.3, -0.15, 0
1386, 2.3, -0.2, 0
1387, 2.3, -0.075, 0
1388, 2.3, -0.125, 0
1389, 2.3, -0.175, 0
1390, 2.3, -0.225, 0
1391, 2.25, -0.25, 0
1392, 2.225, -0.25, 0
1393, 2.275, -0.25, 0
1394, 2.3, -0.25, 0.055555555555556
1395, 2.3, -0.25, 0.11111111111111
1396, 2.3, -0.25, 0.16666666666667
1397, 2.3, -0.25, 0.22222222222222
1398, 2.3, -0.25, 0.27777777777778
1399, 2.3, -0.25, 0.33333333333333
1400, 2.3, -0.25, 0.38888888888889
1401, 2.3, -0.25, 0.44444444444444
1402, 2.3, -0.25, 0.027777777777778
1403, 2.3, -0.25, 0.083333333333333
1404, 2.3, -0.25, 0.13888888888889
1405, 2.3, -0.25, 0.19444444444444
1406, 2.3, -0.25, 0.25
1407, 2.3, -0.25, 0.30555555555556
1408, 2.3, -0.25, 0.36111111111111
1409, 2.3, -0.25, 0.41666666666667
1410, 2.3, -0.25, 0.47222222222222
1411, 1, 1.4833333333333, 0
1412, 1, 1.5166666666667, 0
1413, 1, 1.4666666666667, 0
1414, 1, 1.5, 0
1415, 1, 1.5333333333333, 0
1416, 0, 1.4833333333333, 0
1417, 0, 1.5166666666667, 0
1418, 0, 1.4666666666667, 0
1419, 0, 1.5, 0
1420, 0, 1.5333333333333, 0
1421, 0.043478260869565, 1.45, 0
1422, 0.08695652173913, 1.45, 0
1423, 0.1304347826087, 1.45, 0
1424, 0.17391304347826, 1.45, 0
1425, 0.21739130434783, 1.45, 0
1426, 0.26086956521739, 1.45, 0
1427, 0.30434782608696, 1.45, 0
1428, 0.34782608695652, 1.45, 0
1429, 0.39130434782609, 1.45, 0
1430, 0.43478260869565, 1.45, 0
1431, 0.47826086956522, 1.45, 0
1432, 0.52173913043478, 1.45, 0
1433, 0.56521739130435, 1.45, 0
1434, 0.60869565217391, 1.45, 0
1435, 0.65217391304348, 1.45, 0
1436, 0.69565217391304, 1.45, 0
1437, 0.73913043478261, 1.45, 0
1438, 0.78260869565217, 1.45, 0
1439, 0.82608695652174, 1.45, 0
1440, 0.8695652173913, 1.45, 0
1441, 0.91304347826087, 1.45, 0
1442, 0.95652173913043, 1.45, 0
1443, 0.021739130434783, 1.45, 0
1444, 0.065217391304348, 1.45, 0
1445, 0.10869565217391, 1.45, 0
1446, 0.15217391304348, 1.45, 0
1447, 0.19565217391304, 1.45, 0
1448, 0.23913043478261, 1.45, 0
1449, 0.28260869565217, 1.45, 0
1450, 0.32608695652174, 1.45, 0
1451, 0.3695652173913, 1.45, 0
1452, 0.41304347826087, 1.45, 0
1453, 0.45652173913043, 1.45, 0
1454, 0.5, 1.45, 0
1455, 0.54347826086957, 1.45, 0
1456, 0.58695652173913, 1.45, 0
1457, 0.6304347826087, 1.45, 0
1458, 0.67391304347826, 1.45, 0
1459, 0.71739130434783, 1.45, 0
1460, 0.76086956521739, 1.45, 0
1461, 0.80434782608696, 1.45, 0
1462, 0.84782608695652, 1.45, 0
1463, 0.89130434782609, 1.45, 0
1464, 0.93478260869565, 1.45, 0
1465, 0.97826086956522, 1.45, 0
1466, 0.043478260869565, 1.55, 0
1467, 0.08695652173913, 1.55, 0
1468, 0.1304347826087, 1.55, 0
1469, 0.17391304347826, 1.55, 0
1470, 0.21739130434783, 1.55, 0
1471, 0.26086956521739, 1.55, 0
1472, 0.30434782608696, 1.55, 0
1473, 0.34782608695652, 1.55, 0
1474, 0.39130434782609, 1.55, 0
1475, 0.43478260869565, 1.55, 0
1476, 0.47826086956522, 1.55, 0
1477, 0.52173913043478, 1.55, 0
1478, 0.56521739130435, 1.55, 0
1479, 0.60869565217391, 1.55, 0
1480, 0.65217391304348, 1.55, 0
1481, 0.69565217391304, 1.55, 0
1482, 0.73913043478261, 1.55, 0
1483, 0.78260869565217, 1.55, 0
1484, 0.82608695652174, 1.55, 0
1485, 0.8695652173913, 1.55, 0
1486, 0.91304347826087, 1.55, 0
1487, 0.95652173913043, 1.55, 0
1488, 0.021739130434783, 1.55, 0
1489, 0.065217391304348, 1.55, 0
1490, 0.10869565217391, 1.55, 0
1491, 0.15217391304348, 1.55, 0
1492, 0.19565217391304, 1.55, 0
1493, 0.23913043478261, 1.55, 0
1494, 0.28260869565217, 1.55, 0
1495, 0.32608695652174, 1.55, 0
1496, 0.3695652173913, 1.55, 0
1497, 0.41304347826087, 1.55, 0
1498, 0.45652173913043, 1.55, 0
1499, 0.5, 1.55, 0
1500, 0.54347826086957, 1.55, 0
1501, 0.58695652173913, 1.55, 0
1502, 0.6304347826087, 1.55, 0
1503, 0.67391304347826, 1.55, 0
1504, 0.71739130434783, 1.55, 0
1505, 0.76086956521739, 1.55, 0
1506, 0.80434782608696, 1.55, 0
1507, 0.84782608695652, 1.55, 0
1508, 0.89130434782609, 1.55, 0
1509, 0.93478260869565, 1.55, 0
1510, 0.97826086956522, 1.55, 0
1511, 1, 1.4833333333333, 0.5
1512, 1, 1.5166666666667, 0.5
1513, 1, 1.4666666666667, 0.5
1514, 1, 1.5, 0.5
1515, 1, 1.5333333333333, 0.5
1516, 1, 1.45, 0.055555555555556
1517, 1, 1.45, 0.11111111111111
1518, 1, 1.45, 0.16666666666667
1519, 1, 1.45, 0.22222222222222
1520, 1, 1.45, 0.27777777777778
1521, 1, 1.45, 0.33333333333333
1522, 1, 1.45, 0.38888888888889
1523, 1, 1.45, 0.44444444444444
1524, 1, 1.45, 0.027777777777778
1525, 1, 1.45, 0.083333333333333
1526, 1, 1.45, 0.13888888888889
1527, 1, 1.45, 0.19444444444444
1528, 1, 1.45, 0.25
1529, 1, 1.45, 0.30555555555556
1530, 1, 1.45, 0.36111111111111
1531, 1, 1.45, 0.41666666666667
1532, 1, 1.45, 0.47222222222222
1533, 1, 1.55, 0.055555555555556
1534, 1, 1.55, 0.11111111111111
1535, 1, 1.55, 0.16666666666667
1536, 1, 1.55, 0.22222222222222
1537, 1, 1.55, 0.27777777777778
1538, 1, 1.55, 0.33333333333333
1539, 1, 1.55, 0.38888888888889
1540, 1, 1.55, 0.44444444444444
1541, 1, 1.55, 0.027777777777778
1542, 1, 1.55, 0.083333333333333
1543, 1, 1.55, 0.13888888888889
1544, 1, 1.55, 0.19444444444444
1545, 1, 1.55, 0.25
1546, 1, 1.55, 0.30555555555556
1547, 1, 1.55, 0.36111111111111
1548, 1, 1.55, 0.41666666666667
1549, 1, 1.55, 0.47222222222222
1550, 0, 1.4833333333333, 0.5
1551, 0, 1.5166666666667, 0.5
1552, 0, 1.4666666666667, 0.5
1553, 0, 1.5, 0.5
1554, 0, 1.5333333333333, 0.5
1555, 0.043478260869565, 1.45, 0.5
1556, 0.08695652173913, 1.45, 0.5
1557, 0.1304347826087, 1.45, 0.5
1558, 0.17391304347826, 1.45, 0.5
1559, 0.21739130434783, 1.45, 0.5
1560, 0.26086956521739, 1.45, 0.5
1561, 0.30434782608696, 1.45, 0.5
1562, 0.34782608695652, 1.45, 0.5
1563, 0.39130434782609, 1.45, 0.5
1564, 0.43478260869565, 1.45, 0.5
1565, 0.47826086956522, 1.45, 0.5
1566, 0.52173913043478, 1.45, 0.5
1567, 0.56521739130435, 1.45, 0.5
1568, 0.60869565217391, 1.45, 0.5
1569, 0.65217391304348, 1.45, 0.5
1570, 0.69565217391304, 1.45, 0.5
1571, 0.73913043478261, 1.45, 0.5
1572, 0.78260869565217, 1.45, 0.5
1573, 0.82608695652174, 1.45, 0.5
1574, 0.8695652173913, 1.45, 0.5
1575, 0.91304347826087, 1.45, 0.5
1576, 0.95652173913043, 1.45, 0.5
1577, 0.021739130434783, 1.45, 0.5
1578, 0.065217391304348, 1.45, 0.5
1579, 0.10869565217391, 1.45, 0.5
1580, 0.15217391304348, 1.45, 0.5
1581, 0.19565217391304, 1.45, 0.5
1582, 0.23913043478261, 1.45, 0.5
1583, 0.28260869565217, 1.45, 0.5
1584, 0.32608695652174, 1.45, 0.5
1585, 0.3695652173913, 1.45, 0.5
1586, 0.41304347826087, 1.45, 0.5
1587, 0.45652173913043, 1.45, 0.5
1588, 0.5, 1.45, 0.5
1589, 0.54347826086957, 1.45, 0.5
1590, 0.58695652173913, 1.45, 0.5
1591, 0.6304347826087, 1.45, 0.5
1592, 0.67391304347826, 1.45, 0.5
1593, 0.71739130434783, 1.45, 0.5
1594, 0.76086956521739, 1.45, 0.5
1595, 0.80434782608696, 1.45, 0.5
1596, 0.84782608695652, 1.45, 0.5
1597, 0.89130434782609, 1.45, 0.5
1598, 0.93478260869565, 1.45, 0.5
1599, 0.97826086956522, 1.45, 0.5
1600, 0.043478260869565, 1.55, 0.5
1601, 0.08695652173913, 1.55, 0.5
1602, 0.1304347826087, 1.55, 0.5
1603, 0.17391304347826, 1.55, 0.5
1604, 0.21739130434783, 1.55, 0.5
1605, 0.26086956521739, 1.55, 0.5
1606, 0.30434782608696, 1.55, 0.5
1607, 0.34782608695652, 1.55, 0.5
1608, 0.39130434782609, 1.55, 0.5
1609, 0.43478260869565, 1.55, 0.5
1610, 0.47826086956522, 1.55, 0.5
1611, 0.52173913043478, 1.55, 0.5
1612, 0.56521739130435, 1.55, 0.5
1613, 0.60869565217391, 1.55, 0.5
1614, 0.65217391304348, 1.55, 0.5
1615, 0.69565217391304, 1.55, 0.5
1616, 0.73913043478261, 1.55, 0.5
1617, 0.78260869565217, 1.55, 0.5
1618, 0.82608695652174, 1.55, 0.5
1619, 0.8695652173913, 1.55, 0.5
1620, 0.91304347826087, 1.55, 0.5
1621, 0.95652173913043, 1.55, 0.5
1622, 0.021739130434783, 1.55, 0.5
1623, 0.065217391304348, 1.55, 0.5
1624, 0.10869565217391, 1.55, 0.5
1625, 0.15217391304348, 1.55, 0.5
1626, 0.19565217391304, 1.55, 0.5
1627, 0.23913043478261, 1.55, 0.5
1628, 0.28260869565217, 1.55, 0.5
1629, 0.32608695652174, 1.55, 0.5
1630, 0.3695652173913, 1.55, 0.5
1631, 0.41304347826087, 1.55, 0.5
1632, 0.45652173913043, 1.55, 0.5
1633, 0.5, 1.55, 0.5
1634, 0.54347826086957, 1.55, 0.5
1635, 0.58695652173913, 1.55, 0.5
1636, 0.6304347826087, 1.55, 0.5
1637, 0.67391304347826, 1.55, 0.5
1638, 0.71739130434783, 1.55, 0.5
1639, 0.76086956521739, 1.55, 0.5
1640, 0.80434782608696, 1.55, 0.5
1641, 0.84782608695652, 1.55, 0.5
1642, 0.89130434782609, 1.55, 0.5
1643, 0.93478260869565, 1.55, 0.5
1644, 0.97826086956522, 1.55, 0.5
1645, 0, 1.45, 0.055555555555556
1646, 0, 1.45, 0.11111111111111
1647, 0, 1.45, 0.16666666666667
1648, 0, 1.45, 0.22222222222222
1649, 0, 1.45, 0.27777777777778
1650, 0, 1.45, 0.33333333333333
1651, 0, 1.45, 0.38888888888889
1652, 0, 1.45, 0.44444444444444
1653, 0, 1.45, 0.027777777777778
1654, 0, 1.45, 0.083333333333333
1655, 0, 1.45, 0.13888888888889
1656, 0, 1.45, 0.19444444444444
1657, 0, 1.45, 0.25
1658, 0, 1.45, 0.30555555555556
1659, 0, 1.45, 0.36111111111111
1660, 0, 1.45, 0.41666666666667
1661, 0, 1.45, 0.47222222222222
1662, 0, 1.55, 0.055555555555556
1663, 0, 1.55, 0.11111111111111
1664, 0, 1.55, 0.16666666666667
1665, 0, 1.55, 0.22222222222222
1666, 0, 1.55, 0.27777777777778
1667, 0, 1.55, 0.33333333333333
1668, 0, 1.55, 0.38888888888889
1669, 0, 1.55, 0.44444444444444
1670, 0, 1.55, 0.027777777777778
1671, 0, 1.55, 0.083333333333333
1672, 0, 1.55, 0.13888888888889
1673, 0, 1.55, 0.19444444444444
1674, 0, 1.55, 0.25
1675, 0, 1.55, 0.30555555555556
1676, 0, 1.55, 0.36111111111111
1677, 0, 1.55, 0.41666666666667
1678, 0, 1.55, 0.47222222222222
1679, 1.05, 1.45, 0.5
1680, 1.1, 1.45, 0.5
1681, 1.15, 1.45, 0.5
1682, 1.025, 1.45, 0.5
1683, 1.075, 1.45, 0.5
1684, 1.125, 1.45, 0.5
1685, 1.175, 1.45, 0.5
1686, 1.05, 1.55, 0.5
1687, 1.1, 1.55, 0.5
1688, 1.15, 1.55, 0.5
1689, 1.025, 1.55, 0.5
1690, 1.075, 1.55, 0.5
1691, 1.125, 1.55, 0.5
1692, 1.175, 1.55, 0.5
1693, 1.2, 1.4833333333333, 0.5
1694, 1.2, 1.5166666666667, 0.5
1695, 1.2, 1.4666666666667, 0.5
1696, 1.2, 1.5, 0.5
1697, 1.2, 1.5333333333333, 0.5
1698, 1.05, 1.45, 0
1699, 1.1, 1.45, 0
1700, 1.15, 1.45, 0
1701, 1.025, 1.45, 0
1702, 1.075, 1.45, 0
1703, 1.125, 1.45, 0
1704, 1.175, 1.45, 0
1705, 1.05, 1.55, 0
1706, 1.1, 1.55, 0
1707, 1.15, 1.55, 0
1708, 1.025, 1.55, 0
1709, 1.075, 1.55, 0
1710, 1.125, 1.55, 0
1711, 1.175, 1.55, 0
1712, 1.2, 1.4833333333333, 0
1713, 1.2, 1.5166666666667, 0
1714, 1.2, 1.4666666666667, 0
1715, 1.2, 1.5, 0
1716, 1.2, 1.5333333333333, 0
1717, 1.2, 1.45, 0.055555555555556
1718, 1.2, 1.45, 0.11111111111111
1719, 1.2, 1.45, 0.16666666666667
1720, 1.2, 1.45, 0.22222222222222
1721, 1.2, 1.45, 0.27777777777778
1722, 1.2, 1.45, 0.33333333333333
1723, 1.2, 1.45, 0.38888888888889
1724, 1.2, 1.45, 0.44444444444444
1725, 1.2, 1.45, 0.027777777777778
1726, 1.2, 1.45, 0.083333333333333
1727, 1.2, 1.45, 0.13888888888889
1728, 1.2, 1.45, 0.19444444444444
1729, 1.2, 1.45, 0.25
1730, 1.2, 1.45, 0.30555555555556
1731, 1.2, 1.45, 0.36111111111111
1732, 1.2, 1.45, 0.41666666666667
1733, 1.2, 1.45, 0.47222222222222
1734, 1.2, 1.55, 0.055555555555556
1735, 1.2, 1.55, 0.11111111111111
1736, 1.2, 1.55, 0.16666666666667
1737, 1.2, 1.55, 0.22222222222222
1738, 1.2, 1.55, 0.27777777777778
1739, 1.2, 1.55, 0.33333333333333
1740, 1.2, 1.55, 0.38888888888889
1741, 1.2, 1.55, 0.44444444444444
1742, 1.2, 1.55, 0.027777777777778
1743, 1.2, 1.55, 0.083333333333333
1744, 1.2, 1.55, 0.13888888888889
1745, 1.2, 1.55, 0.19444444444444
1746, 1.2, 1.55, 0.25
1747, 1.2, 1.55, 0.30555555555556
1748, 1.2, 1.55, 0.36111111111111
1749, 1.2, 1.55, 0.41666666666667
1750, 1.2, 1.55, 0.47222222222222
1751, 1, 1.6, 0.5
1752, 1, 1.65, 0.5
1753, 1, 1.7, 0.5
1754, 1, 1.575, 0.5
1755, 1, 1.625, 0.5
1756, 1, 1.675, 0.5
1757, 1, 1.725, 0.5
1758, 1.2, 1.6, 0.5
1759, 1.2, 1.65, 0.5
1760, 1.2, 1.7, 0.5
1761, 1.2, 1.575, 0.5
1762, 1.2, 1.625, 0.5
1763, 1.2, 1.675, 0.5
1764, 1.2, 1.725, 0.5
1765, 1.05, 1.75, 0.5
1766, 1.1, 1.75, 0.5
1767, 1.15, 1.75, 0.5
1768, 1.025, 1.75, 0.5
1769, 1.075, 1.75, 0.5
1770, 1.125, 1.75, 0.5
1771, 1.175, 1.75, 0.5
1772, 1, 1.6, 0
1773, 1, 1.65, 0
1774, 1, 1.7, 0
1775, 1, 1.575, 0
1776, 1, 1.625, 0
1777, 1, 1.675, 0
1778, 1, 1.725, 0
1779, 1.2, 1.6, 0
1780, 1.2, 1.65, 0
1781, 1.2, 1.7, 0
1782, 1.2, 1.575, 0
1783, 1.2, 1.625, 0
1784, 1.2, 1.675, 0
1785, 1.2, 1.725, 0
1786, 1.05, 1.75, 0
1787, 1.1, 1.75, 0
1788, 1.15, 1.75, 0
1789, 1.025, 1.75, 0
1790, 1.075, 1.75, 0
1791, 1.125, 1.75, 0
1792, 1.175, 1.75, 0
1793, 1, 1.75, 0.055555555555556
1794, 1, 1.75, 0.11111111111111
1795, 1, 1.75, 0.16666666666667
1796, 1, 1.75, 0.22222222222222
1797, 1, 1.75, 0.27777777777778
1798, 1, 1.75, 0.33333333333333
1799, 1, 1.75, 0.38888888888889
1800, 1, 1.75, 0.44444444444444
1801, 1, 1.75, 0.027777777777778
1802, 1, 1.75, 0.083333333333333
1803, 1, 1.75, 0.13888888888889
1804, 1, 1.75, 0.19444444444444
1805, 1, 1.75, 0.25
1806, 1, 1.75, 0.30555555555556
1807, 1, 1.75, 0.36111111111111
1808, 1, 1.75, 0.41666666666667
1809, 1, 1.75, 0.47222222222222
1810, 1.2, 1.75, 0.055555555555556
1811, 1.2, 1.75, 0.11111111111111
1812, 1.2, 1.75, 0.16666666666667
1813, 1.2, 1.75, 0.22222222222222
1814, 1.2, 1.75, 0.27777777777778
1815, 1.2, 1.75, 0.33333333333333
1816, 1.2, 1.75, 0.38888888888889
1817, 1.2, 1.75, 0.44444444444444
1818, 1.2, 1.75, 0.027777777777778
1819, 1.2, 1.75, 0.083333333333333
1820, 1.2, 1.75, 0.13888888888889
1821, 1.2, 1.75, 0.19444444444444
1822, 1.2, 1.75, 0.25
1823, 1.2, 1.75, 0.30555555555556
1824, 1.2, 1.75, 0.36111111111111
1825, 1.2, 1.75, 0.41666666666667
1826, 1.2, 1.75, 0.47222222222222
1827, 0, 1.6, 0
1828, 0, 1.65, 0
1829, 0, 1.7, 0
1830, 0, 1.575, 0
1831, 0, 1.625, 0
1832, 0, 1.675, 0
1833, 0, 1.725, 0
1834, 0.043478260869565, 1.75, 0
1835, 0.08695652173913, 1.75, 0
1836, 0.1304347826087, 1.75, 0
1837, 0.17391304347826, 1.75, 0
1838, 0.21739130434783, 1.75, 0
1839, 0.26086956521739, 1.75, 0
1840, 0.30434782608696, 1.75, 0
1841, 0.34782608695652, 1.75, 0
1842, 0.39130434782609, 1.75, 0
1843, 0.43478260869565, 1.75, 0
1844, 0.47826086956522, 1.75, 0
1845, 0.52173913043478, 1.75, 0
1846, 0.56521739130435, 1.75, 0
1847, 0.60869565217391, 1.75, 0
1848, 0.65217391304348, 1.75, 0
1849, 0.69565217391304, 1.75, 0
1850, 0.73913043478261, 1.75, 0
1851, 0.78260869565217, 1.75, 0
1852, 0.82608695652174, 1.75, 0
1853, 0.8695652173913, 1.75, 0
1854, 0.91304347826087, 1.75, 0
1855, 0.95652173913043, 1.75, 0
1856, 0.021739130434783, 1.75, 0
1857, 0.065217391304348, 1.75, 0
1858, 0.10869565217391, 1.75, 0
1859, 0.15217391304348, 1.75, 0
1860, 0.19565217391304, 1.75, 0
1861, 0.23913043478261, 1.75, 0
1862, 0.28260869565217, 1.75, 0
1863, 0.32608695652174, 1.75, 0
1864, 0.3695652173913, 1.75, 0
1865, 0.41304347826087, 1.75, 0
1866, 0.45652173913043, 1.75, 0
1867, 0.5, 1.75, 0
1868, 0.54347826086957, 1.75, 0
1869, 0.58695652173913, 1.75, 0
1870, 0.6304347826087, 1.75, 0
1871, 0.67391304347826, 1.75, 0
1872, 0.71739130434783, 1.75, 0
1873, 0.76086956521739, 1.75, 0
1874, 0.80434782608696, 1.75, 0
1875, 0.84782608695652, 1.75, 0
1876, 0.89130434782609, 1.75, 0
1877, 0.93478260869565, 1.75, 0
1878, 0.97826086956522, 1.75, 0
1879, 0, 1.6, 0.5
1880, 0, 1.65, 0.5
1881, 0, 1.7, 0.5
1882, 0, 1.575, 0.5
1883, 0, 1.625, 0.5
1884, 0, 1.675, 0.5
1885, 0, 1.725, 0.5
1886, 0.043478260869565, 1.75, 0.5
1887, 0.08695652173913, 1.75, 0.5
1888, 0.1304347826087, 1.75, 0.5
1889, 0.17391304347826, 1.75, 0.5
1890, 0.21739130434783, 1.75, 0.5
1891, 0.26086956521739, 1.75, 0.5
1892, 0.30434782608696, 1.75, 0.5
1893, 0.34782608695652, 1.75, 0.5
1894, 0.39130434782609, 1.75, 0.5
1895, 0.43478260869565, 1.75, 0.5
1896, 0.47826086956522, 1.75, 0.5
1897, 0.52173913043478, 1.75, 0.5
1898, 0.56521739130435, 1.75, 0.5
1899, 0.60869565217391, 1.75, 0.5
1900, 0.65217391304348, 1.75, 0.5
1901, 0.69565217391304, 1.75, 0.5
1902, 0.73913043478261, 1.75, 0.5
1903, 0.78260869565217, 1.75, 0.5
1904, 0.82608695652174, 1.75, 0.5
1905, 0.8695652173913, 1.75, 0.5
1906, 0.91304347826087, 1.75, 0.5
1907, 0.95652173913043, 1.75, 0.5
1908, 0.021739130434783, 1.75, 0.5
1909, 0.065217391304348, 1.75, 0.5
1910, 0.10869565217391, 1.75, 0.5
1911, 0.15217391304348, 1.75, 0.5
1912, 0.19565217391304, 1.75, 0.5
1913, 0.23913043478261, 1.75, 0.5
1914, 0.28260869565217, 1.75, 0.5
1915, 0.32608695652174, 1.75, 0.5
1916, 0.3695652173913, 1.75, 0.5
1917, 0.41304347826087, 1.75, 0.5
1918, 0.45652173913043, 1.75, 0.5
1919, 0.5, 1.75, 0.5
1920, 0.54347826086957, 1.75, 0.5
1921, 0.58695652173913, 1.75, 0.5
1922, 0.6304347826087, 1.75, 0.5
1923, 0.67391304347826, 1.75, 0.5
1924, 0.71739130434783, 1.75, 0.5
1925, 0.76086956521739, 1.75, 0.5
1926, 0.80434782608696, 1.75, 0.5
1927, 0.84782608695652, 1.75, 0.5
1928, 0.89130434782609, 1.75, 0.5
1929, 0.93478260869565, 1.75, 0.5
1930, 0.97826086956522, 1.75, 0.5
1931, 0, 1.75, 0.055555555555556
1932, 0, 1.75, 0.11111111111111
1933, 0, 1.75, 0.16666666666667
1934, 0, 1.75, 0.22222222222222
1935, 0, 1.75, 0.27777777777778
1936, 0, 1.75, 0.33333333333333
1937, 0, 1.75, 0.38888888888889
1938, 0, 1.75, 0.44444444444444
1939, 0, 1.75, 0.027777777777778
1940, 0, 1.75, 0.083333333333333
1941, 0, 1.75, 0.13888888888889
1942, 0, 1.75, 0.19444444444444
1943, 0, 1.75, 0.25
1944, 0, 1.75, 0.30555555555556
1945, 0, 1.75, 0.36111111111111
1946, 0, 1.75, 0.41666666666667
1947, 0, 1.75, 0.47222222222222
1948, -0.05, 1.55, 0.5
1949, -0.025, 1.55, 0.5
1950, -0.075, 1.55, 0.5
1951, -0.05, 1.75, 0.5
1952, -0.025, 1.75, 0.5
1953, -0.075, 1.75, 0.5
1954, -0.1, 1.6, 0.5
1955, -0.1, 1.65, 0.5
1956, -0.1, 1.7, 0.5
1957, -0.1, 1.575, 0.5
1958, -0.1, 1.625, 0.5
1959, -0.1, 1.675, 0.5
1960, -0.1, 1.725, 0.5
1961, -0.05, 1.55, 0
1962, -0.025, 1.55, 0
1963, -0.075, 1.55, 0
1964, -0.05, 1.75, 0
1965, -0.025, 1.75, 0
1966, -0.075, 1.75, 0
1967, -0.1, 1.6, 0
1968, -0.1, 1.65, 0
1969, -0.1, 1.7, 0
1970, -0.1, 1.575, 0
1971, -0.1, 1.625, 0
1972, -0.1, 1.675, 0
1973, -0.1, 1.725, 0
1974, -0.1, 1.55, 0.055555555555556
1975, -0.1, 1.55, 0.11111111111111
1976, -0.1, 1.55, 0.16666666666667
1977, -0.1, 1.55, 0.22222222222222
1978, -0.1, 1.55, 0.27777777777778
1979, -0.1, 1.55, 0.33333333333333
1980, -0.1, 1.55, 0.38888888888889
1981, -0.1, 1.55, 0.44444444444444
1982, -0.1, 1.55, 0.027777777777778
1983, -0.1, 1.55, 0.083333333333333
1984, -0.1, 1.55, 0.13888888888889
1985, -0.1, 1.55, 0.19444444444444
1986, -0.1, 1.55, 0.25
1987, -0.1, 1.55, 0.30555555555556
1988, -0.1, 1.55, 0.36111111111111
1989, -0.1, 1.55, 0.41666666666667
1990, -0.1, 1.55, 0.47222222222222
1991, -0.1, 1.75, 0.055555555555556
1992, -0.1, 1.75, 0.11111111111111
1993, -0.1, 1.75, 0.16666666666667
1994, -0.1, 1.75, 0.22222222222222
1995, -0.1, 1.75, 0.27777777777778
1996, -0.1, 1.75, 0.33333333333333
1997, -0.1, 1.75, 0.38888888888889
1998, -0.1, 1.75, 0.44444444444444
1999, -0.1, 1.75, 0.027777777777778
2000, -0.1, 1.75, 0.083333333333333
2001, -0.1, 1.75, 0.13888888888889
2002, -0.1, 1.75, 0.19444444444444
2003, -0.1, 1.75, 0.25
2004, -0.1, 1.75, 0.30555555555556
2005, -0.1, 1.75, 0.36111111111111
2006, -0.1, 1.75, 0.41666666666667
2007, -0.1, 1.75, 0.47222222222222
2008, 1, 1.425, 0
2009, 1, 1.4125, 0
2010, 1, 1.4375, 0
2011, 0, 1.425, 0
2012, 0, 1.4125, 0
2013, 0, 1.4375, 0
2014, 0.043478260869565, 1.4, 0
2015, 0.08695652173913, 1.4, 0
2016, 0.1304347826087, 1.4, 0
2017, 0.17391304347826, 1.4, 0
2018, 0.21739130434783, 1.4, 0
2019, 0.26086956521739, 1.4, 0
2020, 0.30434782608696, 1.4, 0
2021, 0.34782608695652, 1.4, 0
2022, 0.39130434782609, 1.4, 0
2023, 0.43478260869565, 1.4, 0
2024, 0.47826086956522, 1.4, 0
2025, 0.52173913043478, 1.4, 0
2026, 0.56521739130435, 1.4, 0
2027, 0.60869565217391, 1.4, 0
2028, 0.65217391304348, 1.4, 0
2029, 0.69565217391304, 1.4, 0
2030, 0.73913043478261, 1.4, 0
2031, 0.78260869565217, 1.4, 0
2032, 0.82608695652174, 1.4, 0
2033, 0.8695652173913, 1.4, 0
2034, 0.91304347826087, 1.4, 0
2035, 0.95652173913043, 1.4, 0
2036, 0.021739130434783, 1.4, 0
2037, 0.065217391304348, 1.4, 0
2038, 0.10869565217391, 1.4, 0
2039, 0.15217391304348, 1.4, 0
2040, 0.19565217391304, 1.4, 0
2041, 0.23913043478261, 1.4, 0
2042, 0.28260869565217, 1.4, 0
2043, 0.32608695652174, 1.4, 0
2044, 0.3695652173913, 1.4, 0
2045, 0.41304347826087, 1.4, 0
2046, 0.45652173913043, 1.4, 0
2047, 0.5, 1.4, 0
2048, 0.54347826086957, 1.4, 0
2049, 0.58695652173913, 1.4, 0
2050, 0.6304347826087, 1.4, 0
2051, 0.67391304347826, 1.4, 0
2052, 0.71739130434783, 1.4, 0
2053, 0.76086956521739, 1.4, 0
2054, 0.80434782608696, 1.4, 0
2055, 0.84782608695652, 1.4, 0
2056, 0.89130434782609, 1.4, 0
2057, 0.93478260869565, 1.4, 0
2058, 0.97826086956522, 1.4, 0
2059, 1, 1.425, 0.5
2060, 1, 1.4125, 0.5
2061, 1, 1.4375, 0.5
2062, 1, 1.4, 0.055555555555556
2063, 1, 1.4, 0.11111111111111
2064, 1, 1.4, 0.16666666666667
2065, 1, 1.4, 0.22222222222222
2066, 1, 1.4, 0.27777777777778
2067, 1, 1.4, 0.33333333333333
2068, 1, 1.4, 0.38888888888889
2069, 1, 1.4, 0.44444444444444
2070, 1, 1.4, 0.027777777777778
2071, 1, 1.4, 0.083333333333333
2072, 1, 1.4, 0.13888888888889
2073, 1, 1.4, 0.19444444444444
2074, 1, 1.4, 0.25
2075, 1, 1.4, 0.30555555555556
2076, 1, 1.4, 0.36111111111111
2077, 1, 1.4, 0.41666666666667
2078, 1, 1.4, 0.47222222222222
2079, 0, 1.425, 0.5
2080, 0, 1.4125, 0.5
2081, 0, 1.4375, 0.5
2082, 0.043478260869565, 1.4, 0.5
2083, 0.08695652173913, 1.4, 0.5
2084, 0.1304347826087, 1.4, 0.5
2085, 0.17391304347826, 1.4, 0.5
2086, 0.21739130434783, 1.4, 0.5
2087, 0.26086956521739, 1.4, 0.5
2088, 0.30434782608696, 1.4, 0.5
2089, 0.34782608695652, 1.4, 0.5
2090, 0.39130434782609, 1.4, 0.5
2091, 0.43478260869565, 1.4, 0.5
2092, 0.47826086956522, 1.4, 0.5
2093, 0.52173913043478, 1.4, 0.5
2094, 0.56521739130435, 1.4, 0.5
2095, 0.60869565217391, 1.4, 0.5
2096, 0.65217391304348, 1.4, 0.5
2097, 0.69565217391304, 1.4, 0.5
2098, 0.73913043478261, 1.4, 0.5
2099, 0.78260869565217, 1.4, 0.5
2100, 0.82608695652174, 1.4, 0.5
2101, 0.8695652173913, 1.4, 0.5
2102, 0.91304347826087, 1.4, 0.5
2103, 0.95652173913043, 1.4, 0.5
2104, 0.021739130434783, 1.4, 0.5
2105, 0.065217391304348, 1.4, 0.5
2106, 0.10869565217391, 1.4, 0.5
2107, 0.15217391304348, 1.4, 0.5
2108, 0.19565217391304, 1.4, 0.5
2109, 0.23913043478261, 1.4, 0.5
2110, 0.28260869565217, 1.4, 0.5
2111, 0.32608695652174, 1.4, 0.5
2112, 0.3695652173913, 1.4, 0.5
2113, 0.41304347826087, 1.4, 0.5
2114, 0.45652173913043, 1.4, 0.5
2115, 0.5, 1.4, 0.5
2116, 0.54347826086957, 1.4, 0.5
2117, 0.58695652173913, 1.4, 0.5
2118, 0.6304347826087, 1.4, 0.5
2119, 0.67391304347826, 1.4, 0.5
2120, 0.71739130434783, 1.4, 0.5
2121, 0.76086956521739, 1.4, 0.5
2122, 0.80434782608696, 1.4, 0.5
2123, 0.84782608695652, 1.4, 0.5
2124, 0.89130434782609, 1.4, 0.5
2125, 0.93478260869565, 1.4, 0.5
2126, 0.97826086956522, 1.4, 0.5
2127, 0, 1.4, 0.055555555555556
2128, 0, 1.4, 0.11111111111111
2129, 0, 1.4, 0.16666666666667
2130, 0, 1.4, 0.22222222222222
2131, 0, 1.4, 0.27777777777778
2132, 0, 1.4, 0.33333333333333
2133, 0, 1.4, 0.38888888888889
2134, 0, 1.4, 0.44444444444444
2135, 0, 1.4, 0.027777777777778
2136, 0, 1.4, 0.083333333333333
2137, 0, 1.4, 0.13888888888889
2138, 0, 1.4, 0.19444444444444
2139, 0, 1.4, 0.25
2140, 0, 1.4, 0.30555555555556
2141, 0, 1.4, 0.36111111111111
2142, 0, 1.4, 0.41666666666667
2143, 0, 1.4, 0.47222222222222
2144, 1.2, 1.425, 0.5
2145, 1.2, 1.4375, 0.5
2146, 1.2, 1.4125, 0.5
2147, 2.2, 1.425, 0.5
2148, 2.2, 1.4375, 0.5
2149, 2.2, 1.4125, 0.5
2150, 1.2434782608696, 1.45, 0.5
2151, 1.2869565217391, 1.45, 0.5
2152, 1.3304347826087, 1.45, 0.5
2153, 1.3739130434783, 1.45, 0.5
2154, 1.4173913043478, 1.45, 0.5
2155, 1.4608695652174, 1.45, 0.5
2156, 1.504347826087, 1.45, 0.5
2157, 1.5478260869565, 1.45, 0.5
2158, 1.5913043478261, 1.45, 0.5
2159, 1.6347826086957, 1.45, 0.5
2160, 1.6782608695652, 1.45, 0.5
2161, 1.7217391304348, 1.45, 0.5
2162, 1.7652173913043, 1.45, 0.5
2163, 1.8086956521739, 1.45, 0.5
2164, 1.8521739130435, 1.45, 0.5
2165, 1.895652173913, 1.45, 0.5
2166, 1.9391304347826, 1.45, 0.5
2167, 1.9826086956522, 1.45, 0.5
2168, 2.0260869565217, 1.45, 0.5
2169, 2.0695652173913, 1.45, 0.5
2170, 2.1130434782609, 1.45, 0.5
2171, 2.1565217391304, 1.45, 0.5
2172, 1.2217391304348, 1.45, 0.5
2173, 1.2652173913043, 1.45, 0.5
2174, 1.3086956521739, 1.45, 0.5
2175, 1.3521739130435, 1.45, 0.5
2176, 1.395652173913, 1.45, 0.5
2177, 1.4391304347826, 1.45, 0.5
2178, 1.4826086956522, 1.45, 0.5
2179, 1.5260869565217, 1.45, 0.5
2180, 1.5695652173913, 1.45, 0.5
2181, 1.6130434782609, 1.45, 0.5
2182, 1.6565217391304, 1.45, 0.5
2183, 1.7, 1.45, 0.5
2184, 1.7434782608696, 1.45, 0.5
2185, 1.7869565217391, 1.45, 0.5
2186, 1.8304347826087, 1.45, 0.5
2187, 1.8739130434783, 1.45, 0.5
2188, 1.9173913043478, 1.45, 0.5
2189, 1.9608695652174, 1.45, 0.5
2190, 2.004347826087, 1.45, 0.5
2191, 2.0478260869565, 1.45, 0.5
2192, 2.0913043478261, 1.45, 0.5
2193, 2.1347826086957, 1.45, 0.5
2194, 2.1782608695652, 1.45, 0.5
2195, 1.2434782608696, 1.4, 0.5
2196, 1.2869565217391, 1.4, 0.5
2197, 1.3304347826087, 1.4, 0.5
2198, 1.3739130434783, 1.4, 0.5
2199, 1.4173913043478, 1.4, 0.5
2200, 1.4608695652174, 1.4, 0.5
2201, 1.504347826087, 1.4, 0.5
2202, 1.5478260869565, 1.4, 0.5
2203, 1.5913043478261, 1.4, 0.5
2204, 1.6347826086957, 1.4, 0.5
2205, 1.6782608695652, 1.4, 0.5
2206, 1.7217391304348, 1.4, 0.5
2207, 1.7652173913043, 1.4, 0.5
2208, 1.8086956521739, 1.4, 0.5
2209, 1.8521739130435, 1.4, 0.5
2210, 1.895652173913, 1.4, 0.5
2211, 1.9391304347826, 1.4, 0.5
2212, 1.9826086956522, 1.4, 0.5
2213, 2.0260869565217, 1.4, 0.5
2214, 2.0695652173913, 1.4, 0.5
2215, 2.1130434782609, 1.4, 0.5
2216, 2.1565217391304, 1.4, 0.5
2217, 1.2217391304348, 1.4, 0.5
2218, 1.2652173913043, 1.4, 0.5
2219, 1.3086956521739, 1.4, 0.5
2220, 1.3521739130435, 1.4, 0.5
2221, 1.395652173913, 1.4, 0.5
2222, 1.4391304347826, 1.4, 0.5
2223, 1.4826086956522, 1.4, 0.5
2224, 1.5260869565217, 1.4, 0.5
2225, 1.5695652173913, 1.4, 0.5
2226, 1.6130434782609, 1.4, 0.5
2227, 1.6565217391304, 1.4, 0.5
2228, 1.7, 1.4, 0.5
2229, 1.7434782608696, 1.4, 0.5
2230, 1.7869565217391, 1.4, 0.5
2231, 1.8304347826087, 1.4, 0.5
2232, 1.8739130434783, 1.4, 0.5
2233, 1.9173913043478, 1.4, 0.5
2234, 1.9608695652174, 1.4, 0.5
2235, 2.004347826087, 1.4, 0.5
2236, 2.0478260869565, 1.4, 0.5
2237, 2.0913043478261, 1.4, 0.5
2238, 2.1347826086957, 1.4, 0.5
2239, 2.1782608695652, 1.4, 0.5
2240, 1.2, 1.425, 0
2241, 1.2, 1.4375, 0
2242, 1.2, 1.4125, 0
2243, 2.2, 1.425, 0
2244, 2.2, 1.4375, 0
2245, 2.2, 1.4125, 0
2246, 1.2434782608696, 1.45, 0
2247, 1.2869565217391, 1.45, 0
2248, 1.3304347826087, 1.45, 0
2249, 1.3739130434783, 1.45, 0
2250, 1.4173913043478, 1.45, 0
2251, 1.4608695652174, 1.45, 0
2252, 1.504347826087, 1.45, 0
2253, 1.5478260869565, 1.45, 0
2254, 1.5913043478261, 1.45, 0
2255, 1.6347826086957, 1.45, 0
2256, 1.6782608695652, 1.45, 0
2257, 1.7217391304348, 1.45, 0
2258, 1.7652173913043, 1.45, 0
2259, 1.8086956521739, 1.45, 0
2260, 1.8521739130435, 1.45, 0
2261, 1.895652173913, 1.45, 0
2262, 1.9391304347826, 1.45, 0
2263, 1.9826086956522, 1.45, 0
2264, 2.0260869565217, 1.45, 0
2265, 2.0695652173913, 1.45, 0
2266, 2.1130434782609, 1.45, 0
2267, 2.1565217391304, 1.45, 0
2268, 1.2217391304348, 1.45, 0
2269, 1.2652173913043, 1.45, 0
2270, 1.3086956521739, 1.45, 0
2271, 1.3521739130435, 1.45, 0
2272, 1.395652173913, 1.45, 0
2273, 1.4391304347826, 1.45, 0
2274, 1.4826086956522, 1.45, 0
2275, 1.5260869565217, 1.45, 0
2276, 1.5695652173913, 1.45, 0
2277, 1.6130434782609, 1.45, 0
2278, 1.6565217391304, 1.45, 0
2279, 1.7, 1.45, 0
2280, 1.7434782608696, 1.45, 0
2281, 1.7869565217391, 1.45, 0
2282, 1.8304347826087, 1.45, 0
2283, 1.8739130434783, 1.45, 0
2284, 1.9173913043478, 1.45, 0
2285, 1.9608695652174, 1.45, 0
2286, 2.004347826087, 1.45, 0
2287, 2.0478260869565, 1.45, 0
2288, 2.0913043478261, 1.45, 0
2289, 2.1347826086957, 1.45, 0
2290, 2.1782608695652, 1.45, 0
2291, 1.2434782608696, 1.4, 0
2292, 1.2869565217391, 1.4, 0
2293, 1.3304347826087, 1.4, 0
2294, 1.3739130434783, 1.4, 0
2295, 1.4173913043478, 1.4, 0
2296, 1.4608695652174, 1.4, 0
2297, 1.504347826087, 1.4, 0
2298, 1.5478260869565, 1.4, 0
2299, 1.5913043478261, 1.4, 0
2300, 1.6347826086957, 1.4, 0
2301, 1.6782608695652, 1.4, 0
2302, 1.7217391304348, 1.4, 0
2303, 1.7652173913043, 1.4, 0
2304, 1.8086956521739, 1.4, 0
2305, 1.8521739130435, 1.4, 0
2306, 1.895652173913, 1.4, 0
2307, 1.9391304347826, 1.4, 0
2308, 1.9826086956522, 1.4, 0
2309, 2.0260869565217, 1.4, 0
2310, 2.0695652173913, 1.4, 0
2311, 2.1130434782609, 1.4, 0
2312, 2.1565217391304, 1.4, 0
2313, 1.2217391304348, 1.4, 0
2314, 1.2652173913043, 1.4, 0
2315, 1.3086956521739, 1.4, 0
2316, 1.3521739130435, 1.4, 0
2317, 1.395652173913, 1.4, 0
2318, 1.4391304347826, 1.4, 0
2319, 1.4826086956522, 1.4, 0
2320, 1.5260869565217, 1.4, 0
2321, 1.5695652173913, 1.4, 0
2322, 1.6130434782609, 1.4, 0
2323, 1.6565217391304, 1.4, 0
2324, 1.7, 1.4, 0
2325, 1.7434782608696, 1.4, 0
2326, 1.7869565217391, 1.4, 0
2327, 1.8304347826087, 1.4, 0
2328, 1.8739130434783, 1.4, 0
2329, 1.9173913043478, 1.4, 0
2330, 1.9608695652174, 1.4, 0
2331, 2.004347826087, 1.4, 0
2332, 2.0478260869565, 1.4, 0
2333, 2.0913043478261, 1.4, 0
2334, 2.1347826086957, 1.4, 0
2335, 2.1782608695652, 1.4, 0
2336, 1.2, 1.4, 0.055555555555556
2337, 1.2, 1.4, 0.11111111111111
2338, 1.2, 1.4, 0.16666666666667
2339, 1.2, 1.4, 0.22222222222222
2340, 1.2, 1.4, 0.27777777777778
2341, 1.2, 1.4, 0.33333333333333
2342, 1.2, 1.4, 0.38888888888889
2343, 1.2, 1.4, 0.44444444444444
2344, 1.2, 1.4, 0.027777777777778
2345, 1.2, 1.4, 0.083333333333333
2346, 1.2, 1.4, 0.13888888888889
2347, 1.2, 1.4, 0.19444444444444
2348, 1.2, 1.4, 0.25
2349, 1.2, 1.4, 0.30555555555556
2350, 1.2, 1.4, 0.36111111111111
2351, 1.2, 1.4, 0.41666666666667
2352, 1.2, 1.4, 0.47222222222222
2353, 2.2, 1.45, 0.055555555555556
2354, 2.2, 1.45, 0.11111111111111
2355, 2.2, 1.45, 0.16666666666667
2356, 2.2, 1.45, 0.22222222222222
2357, 2.2, 1.45, 0.27777777777778
2358, 2.2, 1.45, 0.33333333333333
2359, 2.2, 1.45, 0.38888888888889
2360, 2.2, 1.45, 0.44444444444444
2361, 2.2, 1.45, 0.027777777777778
2362, 2.2, 1.45, 0.083333333333333
2363, 2.2, 1.45, 0.13888888888889
2364, 2.2, 1.45, 0.19444444444444
2365, 2.2, 1.45, 0.25
2366, 2.2, 1.45, 0.30555555555556
2367, 2.2, 1.45, 0.36111111111111
2368, 2.2, 1.45, 0.41666666666667
2369, 2.2, 1.45, 0.47222222222222
2370, 2.2, 1.4, 0.055555555555556
2371, 2.2, 1.4, 0.11111111111111
2372, 2.2, 1.4, 0.16666666666667
2373, 2.2, 1.4, 0.22222222222222
2374, 2.2, 1.4, 0.27777777777778
2375, 2.2, 1.4, 0.33333333333333
2376, 2.2, 1.4, 0.38888888888889
2377, 2.2, 1.4, 0.44444444444444
2378, 2.2, 1.4, 0.027777777777778
2379, 2.2, 1.4, 0.083333333333333
2380, 2.2, 1.4, 0.13888888888889
2381, 2.2, 1.4, 0.19444444444444
2382, 2.2, 1.4, 0.25
2383, 2.2, 1.4, 0.30555555555556
2384, 2.2, 1.4, 0.36111111111111
2385, 2.2, 1.4, 0.41666666666667
2386, 2.2, 1.4, 0.47222222222222
2387, 1.2434782608696, 1.55, 0.5
2388, 1.2869565217391, 1.55, 0.5
2389, 1.3304347826087, 1.55, 0.5
2390, 1.3739130434783, 1.55, 0.5
2391, 1.4173913043478, 1.55, 0.5
2392, 1.4608695652174, 1.55, 0.5
2393, 1.504347826087, 1.55, 0.5
2394, 1.5478260869565, 1.55, 0.5
2395, 1.5913043478261, 1.55, 0.5
2396, 1.6347826086957, 1.55, 0.5
2397, 1.6782608695652, 1.55, 0.5
2398, 1.7217391304348, 1.55, 0.5
2399, 1.7652173913043, 1.55, 0.5
2400, 1.8086956521739, 1.55, 0.5
2401, 1.8521739130435, 1.55, 0.5
2402, 1.895652173913, 1.55, 0.5
2403, 1.9391304347826, 1.55, 0.5
2404, 1.9826086956522, 1.55, 0.5
2405, 2.0260869565217, 1.55, 0.5
2406, 2.0695652173913, 1.55, 0.5
2407, 2.1130434782609, 1.55, 0.5
2408, 2.1565217391304, 1.55, 0.5
2409, 1.2217391304348, 1.55, 0.5
2410, 1.2652173913043, 1.55, 0.5
2411, 1.3086956521739, 1.55, 0.5
2412, 1.3521739130435, 1.55, 0.5
2413, 1.395652173913, 1.55, 0.5
2414, 1.4391304347826, 1.55, 0.5
2415, 1.4826086956522, 1.55, 0.5
2416, 1.5260869565217, 1.55, 0.5
2417, 1.5695652173913, 1.55, 0.5
2418, 1.6130434782609, 1.55, 0.5
2419, 1.6565217391304, 1.55, 0.5
2420, 1.7, 1.55, 0.5
2421, 1.7434782608696, 1.55, 0.5
2422, 1.7869565217391, 1.55, 0.5
2423, 1.8304347826087, 1.55, 0.5
2424, 1.8739130434783, 1.55, 0.5
2425, 1.9173913043478, 1.55, 0.5
2426, 1.9608695652174, 1.55, 0.5
2427, 2.004347826087, 1.55, 0.5
2428, 2.0478260869565, 1.55, 0.5
2429, 2.0913043478261, 1.55, 0.5
2430, 2.1347826086957, 1.55, 0.5
2431, 2.1782608695652, 1.55, 0.5
2432, 2.2, 1.4833333333333, 0.5
2433, 2.2, 1.5166666666667, 0.5
2434, 2.2, 1.4666666666667, 0.5
2435, 2.2, 1.5, 0.5
2436, 2.2, 1.5333333333333, 0.5
2437, 1.2434782608696, 1.55, 0
2438, 1.2869565217391, 1.55, 0
2439, 1.3304347826087, 1.55, 0
2440, 1.3739130434783, 1.55, 0
2441, 1.4173913043478, 1.55, 0
2442, 1.4608695652174, 1.55, 0
2443, 1.504347826087, 1.55, 0
2444, 1.5478260869565, 1.55, 0
2445, 1.5913043478261, 1.55, 0
2446, 1.6347826086957, 1.55, 0
2447, 1.6782608695652, 1.55, 0
2448, 1.7217391304348, 1.55, 0
2449, 1.7652173913043, 1.55, 0
2450, 1.8086956521739, 1.55, 0
2451, 1.8521739130435, 1.55, 0
2452, 1.895652173913, 1.55, 0
2453, 1.9391304347826, 1.55, 0
2454, 1.9826086956522, 1.55, 0
2455, 2.0260869565217, 1.55, 0
2456, 2.0695652173913, 1.55, 0
2457, 2.1130434782609, 1.55, 0
2458, 2.1565217391304, 1.55, 0
2459, 1.2217391304348, 1.55, 0
2460, 1.2652173913043, 1.55, 0
2461, 1.3086956521739, 1.55, 0
2462, 1.3521739130435, 1.55, 0
2463, 1.395652173913, 1.55, 0
2464, 1.4391304347826, 1.55, 0
2465, 1.4826086956522, 1.55, 0
2466, 1.5260869565217, 1.55, 0
2467, 1.5695652173913, 1.55, 0
2468, 1.6130434782609, 1.55, 0
2469, 1.6565217391304, 1.55, 0
2470, 1.7, 1.55, 0
2471, 1.7434782608696, 1.55, 0
2472, 1.7869565217391, 1.55, 0
2473, 1.8304347826087, 1.55, 0
2474, 1.8739130434783, 1.55, 0
2475, 1.9173913043478, 1.55, 0
2476, 1.9608695652174, 1.55, 0
2477, 2.004347826087, 1.55, 0
2478, 2.0478260869565, 1.55, 0
2479, 2.0913043478261, 1.55, 0
2480, 2.1347826086957, 1.55, 0
2481, 2.1782608695652, 1.55, 0
2482, 2.2, 1.4833333333333, 0
2483, 2.2, 1.5166666666667, 0
2484, 2.2, 1.4666666666667, 0
2485, 2.2, 1.5, 0
2486, 2.2, 1.5333333333333, 0
2487, 2.2, 1.55, 0.055555555555556
2488, 2.2, 1.55, 0.11111111111111
2489, 2.2, 1.55, 0.16666666666667
2490, 2.2, 1.55, 0.22222222222222
2491, 2.2, 1.55, 0.27777777777778
2492, 2.2, 1.55, 0.33333333333333
2493, 2.2, 1.55, 0.38888888888889
2494, 2.2, 1.55, 0.44444444444444
2495, 2.2, 1.55, 0.027777777777778
2496, 2.2, 1.55, 0.083333333333333
2497, 2.2, 1.55, 0.13888888888889
2498, 2.2, 1.55, 0.19444444444444
2499, 2.2, 1.55, 0.25
2500, 2.2, 1.55, 0.30555555555556
2501, 2.2, 1.55, 0.36111111111111
2502, 2.2, 1.55, 0.41666666666667
2503, 2.2, 1.55, 0.47222222222222
2504, 2.2, 1.6, 0.5
2505, 2.2, 1.65, 0.5
2506, 2.2, 1.7, 0.5
2507, 2.2, 1.575, 0.5
2508, 2.2, 1.625, 0.5
2509, 2.2, 1.675, 0.5
2510, 2.2, 1.725, 0.5
2511, 1.2434782608696, 1.75, 0.5
2512, 1.2869565217391, 1.75, 0.5
2513, 1.3304347826087, 1.75, 0.5
2514, 1.3739130434783, 1.75, 0.5
2515, 1.4173913043478, 1.75, 0.5
2516, 1.4608695652174, 1.75, 0.5
2517, 1.504347826087, 1.75, 0.5
2518, 1.5478260869565, 1.75, 0.5
2519, 1.5913043478261, 1.75, 0.5
2520, 1.6347826086957, 1.75, 0.5
2521, 1.6782608695652, 1.75, 0.5
2522, 1.7217391304348, 1.75, 0.5
2523, 1.7652173913043, 1.75, 0.5
2524, 1.8086956521739, 1.75, 0.5
2525, 1.8521739130435, 1.75, 0.5
2526, 1.895652173913, 1.75, 0.5
2527, 1.9391304347826, 1.75, 0.5
2528, 1.9826086956522, 1.75, 0.5
2529, 2.0260869565217, 1.75, 0.5
2530, 2.0695652173913, 1.75, 0.5
2531, 2.1130434782609, 1.75, 0.5
2532, 2.1565217391304, 1.75, 0.5
2533, 1.2217391304348, 1.75, 0.5
2534, 1.2652173913043, 1.75, 0.5
2535, 1.3086956521739, 1.75, 0.5
2536, 1.3521739130435, 1.75, 0.5
2537, 1.395652173913, 1.75, 0.5
2538, 1.4391304347826, 1.75, 0.5
2539, 1.4826086956522, 1.75, 0.5
2540, 1.5260869565217, 1.75, 0.5
2541, 1.5695652173913, 1.75, 0.5
2542, 1.6130434782609, 1.75, 0.5
2543, 1.6565217391304, 1.75, 0.5
2544, 1.7, 1.75, 0.5
2545, 1.7434782608696, 1.75, 0.5
2546, 1.7869565217391, 1.75, 0.5
2547, 1.8304347826087, 1.75, 0.5
2548, 1.8739130434783, 1.75, 0.5
2549, 1.9173913043478, 1.75, 0.5
2550, 1.9608695652174, 1.75, 0.5
2551, 2.004347826087, 1.75, 0.5
2552, 2.0478260869565, 1.75, 0.5
2553, 2.0913043478261, 1.75, 0.5
2554, 2.1347826086957, 1.75, 0.5
2555, 2.1782608695652, 1.75, 0.5
2556, 2.2, 1.6, 0
2557, 2.2, 1.65, 0
2558, 2.2, 1.7, 0
2559, 2.2, 1.575, 0
2560, 2.2, 1.625, 0
2561, 2.2, 1.675, 0
2562, 2.2, 1.725, 0
2563, 1.2434782608696, 1.75, 0
2564, 1.2869565217391, 1.75, 0
2565, 1.3304347826087, 1.75, 0
2566, 1.3739130434783, 1.75, 0
2567, 1.4173913043478, 1.75, 0
2568, 1.4608695652174, 1.75, 0
2569, 1.504347826087, 1.75, 0
2570, 1.5478260869565, 1.75, 0
2571, 1.5913043478261, 1.75, 0
2572, 1.6347826086957, 1.75, 0
2573, 1.6782608695652, 1.75, 0
2574, 1.7217391304348, 1.75, 0
2575, 1.7652173913043, 1.75, 0
2576, 1.8086956521739, 1.75, 0
2577, 1.8521739130435, 1.75, 0
2578, 1.895652173913, 1.75, 0
2579, 1.9391304347826, 1.75, 0
2580, 1.9826086956522, 1.75, 0
2581, 2.0260869565217, 1.75, 0
2582, 2.0695652173913, 1.75, 0
2583, 2.1130434782609, 1.75, 0
2584, 2.1565217391304, 1.75, 0
2585, 1.2217391304348, 1.75, 0
2586, 1.2652173913043, 1.75, 0
2587, 1.3086956521739, 1.75, 0
2588, 1.3521739130435, 1.75, 0
2589, 1.395652173913, 1.75, 0
2590, 1.4391304347826, 1.75, 0
2591, 1.4826086956522, 1.75, 0
2592, 1.5260869565217, 1.75, 0
2593, 1.5695652173913, 1.75, 0
2594, 1.6130434782609, 1.75, 0
2595, 1.6565217391304, 1.75, 0
2596, 1.7, 1.75, 0
2597, 1.7434782608696, 1.75, 0
2598, 1.7869565217391, 1.75, 0
2599, 1.8304347826087, 1.75, 0
2600, 1.8739130434783, 1.75, 0
2601, 1.9173913043478, 1.75, 0
2602, 1.9608695652174, 1.75, 0
2603, 2.004347826087, 1.75, 0
2604, 2.0478260869565, 1.75, 0
2605, 2.0913043478261, 1.75, 0
2606, 2.1347826086957, 1.75, 0
2607, 2.1782608695652, 1.75, 0
2608, 2.2, 1.75, 0.055555555555556
2609, 2.2, 1.75, 0.11111111111111
2610, 2.2, 1.75, 0.16666666666667
2611, 2.2, 1.75, 0.22222222222222
2612, 2.2, 1.75, 0.27777777777778
2613, 2.2, 1.75, 0.33333333333333
2614, 2.2, 1.75, 0.38888888888889
2615, 2.2, 1.75, 0.44444444444444
2616, 2.2, 1.75, 0.027777777777778
2617, 2.2, 1.75, 0.083333333333333
2618, 2.2, 1.75, 0.13888888888889
2619, 2.2, 1.75, 0.19444444444444
2620, 2.2, 1.75, 0.25
2621, 2.2, 1.75, 0.30555555555556
2622, 2.2, 1.75, 0.36111111111111
2623, 2.2, 1.75, 0.41666666666667
2624, 2.2, 1.75, 0.47222222222222
2625, 2.25, 1.55, 0.5
2626, 2.225, 1.55, 0.5
2627, 2.275, 1.55, 0.5
2628, 2.25, 1.75, 0.5
2629, 2.225, 1.75, 0.5
2630, 2.275, 1.75, 0.5
2631, 2.3, 1.6, 0.5
2632, 2.3, 1.65, 0.5
2633, 2.3, 1.7, 0.5
2634, 2.3, 1.575, 0.5
2635, 2.3, 1.625, 0.5
2636, 2.3, 1.675, 0.5
2637, 2.3, 1.725, 0.5
2638, 2.25, 1.55, 0
2639, 2.225, 1.55, 0
2640, 2.275, 1.55, 0
2641, 2.25, 1.75, 0
2642, 2.225, 1.75, 0
2643, 2.275, 1.75, 0
2644, 2.3, 1.6, 0
2645, 2.3, 1.65, 0
2646, 2.3, 1.7, 0
2647, 2.3, 1.575, 0
2648, 2.3, 1.625, 0
2649, 2.3, 1.675, 0
2650, 2.3, 1.725, 0
2651, 2.3, 1.55, 0.055555555555556
2652, 2.3, 1.55, 0.11111111111111
2653, 2.3, 1.55, 0.16666666666667
2654, 2.3, 1.55, 0.22222222222222
2655, 2.3, 1.55, 0.27777777777778
2656, 2.3, 1.55, 0.33333333333333
2657, 2.3, 1.55, 0.38888888888889
2658, 2.3, 1.55, 0.44444444444444
2659, 2.3, 1.55, 0.027777777777778
2660, 2.3, 1.55, 0.083333333333333
2661, 2.3, 1.55, 0.13888888888889
2662, 2.3, 1.55, 0.19444444444444
2663, 2.3, 1.55, 0.25
2664, 2.3, 1.55, 0.30555555555556
2665, 2.3, 1.55, 0.36111111111111
2666, 2.3, 1.55, 0.41666666666667
2667, 2.3, 1.55, 0.47222222222222
2668, 2.3, 1.75, 0.055555555555556
2669, 2.3, 1.75, 0.11111111111111
2670, 2.3, 1.75, 0.16666666666667
2671, 2.3, 1.75, 0.22222222222222
2672, 2.3, 1.75, 0.27777777777778
2673, 2.3, 1.75, 0.33333333333333
2674, 2.3, 1.75, 0.38888888888889
2675, 2.3, 1.75, 0.44444444444444
2676, 2.3, 1.75, 0.027777777777778
2677, 2.3, 1.75, 0.083333333333333
2678, 2.3, 1.75, 0.13888888888889
2679, 2.3, 1.75, 0.19444444444444
2680, 2.3, 1.75, 0.25
2681, 2.3, 1.75, 0.30555555555556
2682, 2.3, 1.75, 0.36111111111111
2683, 2.3, 1.75, 0.41666666666667
2684, 2.3, 1.75, 0.47222222222222
2685, 1, 0.125, 0
2686, 1, 0.1125, 0
2687, 1, 0.1375, 0
2688, 0, 0.125, 0
2689, 0, 0.1125, 0
2690, 0, 0.1375, 0
2691, 0.043478260869565, 0.1, 0
2692, 0.08695652173913, 0.1, 0
2693, 0.1304347826087, 0.1, 0
2694, 0.17391304347826, 0.1, 0
2695, 0.21739130434783, 0.1, 0
2696, 0.26086956521739, 0.1, 0
2697, 0.30434782608696, 0.1, 0
2698, 0.34782608695652, 0.1, 0
2699, 0.39130434782609, 0.1, 0
2700, 0.43478260869565, 0.1, 0
2701, 0.47826086956522, 0.1, 0
2702, 0.52173913043478, 0.1, 0
2703, 0.56521739130435, 0.1, 0
2704, 0.60869565217391, 0.1, 0
2705, 0.65217391304348, 0.1, 0
2706, 0.69565217391304, 0.1, 0
2707, 0.73913043478261, 0.1, 0
2708, 0.78260869565217, 0.1, 0
2709, 0.82608695652174, 0.1, 0
2710, 0.8695652173913, 0.1, 0
2711, 0.91304347826087, 0.1, 0
2712, 0.95652173913043, 0.1, 0
2713, 0.021739130434783, 0.1, 0
2714, 0.065217391304348, 0.1, 0
2715, 0.10869565217391, 0.1, 0
2716, 0.15217391304348, 0.1, 0
2717, 0.19565217391304, 0.1, 0
2718, 0.23913043478261, 0.1, 0
2719, 0.28260869565217, 0.1, 0
2720, 0.32608695652174, 0.1, 0
2721, 0.3695652173913, 0.1, 0
2722, 0.41304347826087, 0.1, 0
2723, 0.45652173913043, 0.1, 0
2724, 0.5, 0.1, 0
2725, 0.54347826086957, 0.1, 0
2726, 0.58695652173913, 0.1, 0
2727, 0.6304347826087, 0.1, 0
2728, 0.67391304347826, 0.1, 0
2729, 0.71739130434783, 0.1, 0
2730, 0.76086956521739, 0.1, 0
2731, 0.80434782608696, 0.1, 0
2732, 0.84782608695652, 0.1, 0
2733, 0.89130434782609, 0.1, 0
2734, 0.93478260869565, 0.1, 0
2735, 0.97826086956522, 0.1, 0
2736, 1, 0.125, 0.5
2737, 1, 0.1125, 0.5
2738, 1, 0.1375, 0.5
2739, 1, 0.1, 0.055555555555556
2740, 1, 0.1, 0.11111111111111
2741, 1, 0.1, 0.16666666666667
2742, 1, 0.1, 0.22222222222222
2743, 1, 0.1, 0.27777777777778
2744, 1, 0.1, 0.33333333333333
2745, 1, 0.1, 0.38888888888889
2746, 1, 0.1, 0.44444444444444
2747, 1, 0.1, 0.027777777777778
2748, 1, 0.1, 0.083333333333333
2749, 1, 0.1, 0.13888888888889
2750, 1, 0.1, 0.19444444444444
2751, 1, 0.1, 0.25
2752, 1, 0.1, 0.30555555555556
2753, 1, 0.1, 0.36111111111111
2754, 1, 0.1, 0.41666666666667
2755, 1, 0.1, 0.47222222222222
2756, 0, 0.125, 0.5
2757, 0, 0.1125, 0.5
2758, 0, 0.1375, 0.5
2759, 0.043478260869565, 0.1, 0.5
2760, 0.08695652173913, 0.1, 0.5
2761, 0.1304347826087, 0.1, 0.5
2762, 0.17391304347826, 0.1, 0.5
2763, 0.21739130434783, 0.1, 0.5
2764, 0.26086956521739, 0.1, 0.5
2765, 0.30434782608696, 0.1, 0.5
2766, 0.34782608695652, 0.1, 0.5
2767, 0.39130434782609, 0.1, 0.5
2768, 0.43478260869565, 0.1, 0.5
2769, 0.47826086956522, 0.1, 0.5
2770, 0.52173913043478, 0.1, 0.5
2771, 0.56521739130435, 0.1, 0.5
2772, 0.60869565217391, 0.1, 0.5
2773, 0.65217391304348, 0.1, 0.5
2774, 0.69565217391304, 0.1, 0.5
2775, 0.73913043478261, 0.1, 0.5
2776, 0.78260869565217, 0.1, 0.5
2777, 0.82608695652174, 0.1, 0.5
2778, 0.8695652173913, 0.1, 0.5
2779, 0.91304347826087, 0.1, 0.5
2780, 0.95652173913043, 0.1, 0.5
2781, 0.021739130434783, 0.1, 0.5
2782, 0.065217391304348, 0.1, 0.5
2783, 0.10869565217391, 0.1, 0.5
2784, 0.15217391304348, 0.1, 0.5
2785, 0.19565217391304, 0.1, 0.5
2786, 0.23913043478261, 0.1, 0.5
2787, 0.28260869565217, 0.1, 0.5
2788, 0.32608695652174, 0.1, 0.5
2789, 0.3695652173913, 0.1, 0.5
2790, 0.41304347826087, 0.1, 0.5
2791, 0.45652173913043, 0.1, 0.5
2792, 0.5, 0.1, 0.5
2793, 0.54347826086957, 0.1, 0.5
2794, 0.58695652173913, 0.1, 0.5
2795, 0.6304347826087, 0.1, 0.5
2796, 0.67391304347826, 0.1, 0.5
2797, 0.71739130434783, 0.1, 0.5
2798, 0.76086956521739, 0.1, 0.5
2799, 0.80434782608696, 0.1, 0.5
2800, 0.84782608695652, 0.1, 0.5
2801, 0.89130434782609, 0.1, 0.5
2802, 0.93478260869565, 0.1, 0.5
2803, 0.97826086956522, 0.1, 0.5
2804, 0, 0.1, 0.055555555555556
2805, 0, 0.1, 0.11111111111111
2806, 0, 0.1, 0.16666666666667
2807, 0, 0.1, 0.22222222222222
2808, 0, 0.1, 0.27777777777778
2809, 0, 0.1, 0.33333333333333
2810, 0, 0.1, 0.38888888888889
2811, 0, 0.1, 0.44444444444444
2812, 0, 0.1, 0.027777777777778
2813, 0, 0.1, 0.083333333333333
2814, 0, 0.1, 0.13888888888889
2815, 0, 0.1, 0.19444444444444
2816, 0, 0.1, 0.25
2817, 0, 0.1, 0.30555555555556
2818, 0, 0.1, 0.36111111111111
2819, 0, 0.1, 0.41666666666667
2820, 0, 0.1, 0.47222222222222
2821, 1, 0.20217391304348, 0
2822, 1, 0.25434782608696, 0
2823, 1, 0.30652173913043, 0
2824, 1, 0.35869565217391, 0
2825, 1, 0.41086956521739, 0
2826, 1, 0.46304347826087, 0
2827, 1, 0.51521739130435, 0
2828, 1, 0.56739130434783, 0
2829, 1, 0.6195652173913, 0
2830, 1, 0.67173913043478, 0
2831, 1, 0.72391304347826, 0
2832, 1, 0.77608695652174, 0
2833, 1, 0.82826086956522, 0
2834, 1, 0.88043478260869, 0
2835, 1, 0.93260869565217, 0
2836, 1, 0.98478260869565, 0
2837, 1, 1.0369565217391, 0
2838, 1, 1.0891304347826, 0
2839, 1, 1.1413043478261, 0
2840, 1, 1.1934782608696, 0
2841, 1, 1.245652173913, 0
2842, 1, 1.2978260869565, 0
2843, 1, 0.17608695652174, 0
2844, 1, 0.22826086956522, 0
2845, 1, 0.2804347826087, 0
2846, 1, 0.33260869565217, 0
2847, 1, 0.38478260869565, 0
2848, 1, 0.43695652173913, 0
2849, 1, 0.48913043478261, 0
2850, 1, 0.54130434782609, 0
2851, 1, 0.59347826086956, 0
2852, 1, 0.64565217391304, 0
2853, 1, 0.69782608695652, 0
2854, 1, 0.75, 0
2855, 1, 0.80217391304348, 0
2856, 1, 0.85434782608696, 0
2857, 1, 0.90652173913043, 0
2858, 1, 0.95869565217391, 0
2859, 1, 1.0108695652174, 0
2860, 1, 1.0630434782609, 0
2861, 1, 1.1152173913043, 0
2862, 1, 1.1673913043478, 0
2863, 1, 1.2195652173913, 0
2864, 1, 1.2717391304348, 0
2865, 1, 1.3239130434783, 0
2866, 0, 0.20217391304348, 0
2867, 0, 0.25434782608696, 0
2868, 0, 0.30652173913043, 0
2869, 0, 0.35869565217391, 0
2870, 0, 0.41086956521739, 0
2871, 0, 0.46304347826087, 0
2872, 0, 0.51521739130435, 0
2873, 0, 0.56739130434783, 0
2874, 0, 0.6195652173913, 0
2875, 0, 0.67173913043478, 0
2876, 0, 0.72391304347826, 0
2877, 0, 0.77608695652174, 0
2878, 0, 0.82826086956522, 0
2879, 0, 0.88043478260869, 0
2880, 0, 0.93260869565217, 0
2881, 0, 0.98478260869565, 0
2882, 0, 1.0369565217391, 0
2883, 0, 1.0891304347826, 0
2884, 0, 1.1413043478261, 0
2885, 0, 1.1934782608696, 0
2886, 0, 1.245652173913, 0
2887, 0, 1.2978260869565, 0
2888, 0, 0.17608695652174, 0
2889, 0, 0.22826086956522, 0
2890, 0, 0.2804347826087, 0
2891, 0, 0.33260869565217, 0
2892, 0, 0.38478260869565, 0
2893, 0, 0.43695652173913, 0
2894, 0, 0.48913043478261, 0
2895, 0, 0.54130434782609, 0
2896, 0, 0.59347826086956, 0
2897, 0, 0.64565217391304, 0
2898, 0, 0.69782608695652, 0
2899, 0, 0.75, 0
2900, 0, 0.80217391304348, 0
2901, 0, 0.85434782608696, 0
2902, 0, 0.90652173913043, 0
2903, 0, 0.95869565217391, 0
2904, 0, 1.0108695652174, 0
2905, 0, 1.0630434782609, 0
2906, 0, 1.1152173913043, 0
2907, 0, 1.1673913043478, 0
2908, 0, 1.2195652173913, 0
2909, 0, 1.2717391304348, 0
2910, 0, 1.3239130434783, 0
2911, 0.043478260869565, 1.35, 0
2912, 0.08695652173913, 1.35, 0
2913, 0.1304347826087, 1.35, 0
2914, 0.17391304347826, 1.35, 0
2915, 0.21739130434783, 1.35, 0
2916, 0.26086956521739, 1.35, 0
2917, 0.30434782608696, 1.35, 0
2918, 0.34782608695652, 1.35, 0
2919, 0.39130434782609, 1.35, 0
2920, 0.43478260869565, 1.35, 0
2921, 0.47826086956522, 1.35, 0
2922, 0.52173913043478, 1.35, 0
2923, 0.56521739130435, 1.35, 0
2924, 0.60869565217391, 1.35, 0
2925, 0.65217391304348, 1.35, 0
2926, 0.69565217391304, 1.35, 0
2927, 0.73913043478261, 1.35, 0
2928, 0.78260869565217, 1.35, 0
2929, 0.82608695652174, 1.35, 0
2930, 0.8695652173913, 1.35, 0
2931, 0.91304347826087, 1.35, 0
2932, 0.95652173913043, 1.35, 0
2933, 0.021739130434783, 1.35, 0
2934, 0.065217391304348, 1.35, 0
2935, 0.10869565217391, 1.35, 0
2936, 0.15217391304348, 1.35, 0
2937, 0.19565217391304, 1.35, 0
2938, 0.23913043478261, 1.35, 0
2939, 0.28260869565217, 1.35, 0
2940, 0.32608695652174, 1.35, 0
2941, 0.3695652173913, 1.35, 0
2942, 0.41304347826087, 1.35, 0
2943, 0.45652173913043, 1.35, 0
2944, 0.5, 1.35, 0
2945, 0.54347826086957, 1.35, 0
2946, 0.58695652173913, 1.35, 0
2947, 0.6304347826087, 1.35, 0
2948, 0.67391304347826, 1.35, 0
2949, 0.71739130434783, 1.35, 0
2950, 0.76086956521739, 1.35, 0
2951, 0.80434782608696, 1.35, 0
2952, 0.84782608695652, 1.35, 0
2953, 0.89130434782609, 1.35, 0
2954, 0.93478260869565, 1.35, 0
2955, 0.97826086956522, 1.35, 0
2956, 1, 0.20217391304348, 0.5
2957, 1, 0.25434782608696, 0.5
2958, 1, 0.30652173913043, 0.5
2959, 1, 0.35869565217391, 0.5
2960, 1, 0.41086956521739, 0.5
2961, 1, 0.46304347826087, 0.5
2962, 1, 0.51521739130435, 0.5
2963, 1, 0.56739130434783, 0.5
2964, 1, 0.6195652173913, 0.5
2965, 1, 0.67173913043478, 0.5
2966, 1, 0.72391304347826, 0.5
2967, 1, 0.77608695652174, 0.5
2968, 1, 0.82826086956522, 0.5
2969, 1, 0.88043478260869, 0.5
2970, 1, 0.93260869565217, 0.5
2971, 1, 0.98478260869565, 0.5
2972, 1, 1.0369565217391, 0.5
2973, 1, 1.0891304347826, 0.5
2974, 1, 1.1413043478261, 0.5
2975, 1, 1.1934782608696, 0.5
2976, 1, 1.245652173913, 0.5
2977, 1, 1.2978260869565, 0.5
2978, 1, 0.17608695652174, 0.5
2979, 1, 0.22826086956522, 0.5
2980, 1, 0.2804347826087, 0.5
2981, 1, 0.33260869565217, 0.5
2982, 1, 0.38478260869565, 0.5
2983, 1, 0.43695652173913, 0.5
2984, 1, 0.48913043478261, 0.5
2985, 1, 0.54130434782609, 0.5
2986, 1, 0.59347826086956, 0.5
2987, 1, 0.64565217391304, 0.5
2988, 1, 0.69782608695652, 0.5
2989, 1, 0.75, 0.5
2990, 1, 0.80217391304348, 0.5
2991, 1, 0.85434782608696, 0.5
2992, 1, 0.90652173913043, 0.5
2993, 1, 0.95869565217391, 0.5
2994, 1, 1.0108695652174, 0.5
2995, 1, 1.0630434782609, 0.5
2996, 1, 1.1152173913043, 0.5
2997, 1, 1.1673913043478, 0.5
2998, 1, 1.2195652173913, 0.5
2999, 1, 1.2717391304348, 0.5
3000, 1, 1.3239130434783, 0.5
3001, 1, 1.35, 0.055555555555556
3002, 1, 1.35, 0.11111111111111
3003, 1, 1.35, 0.16666666666667
3004, 1, 1.35, 0.22222222222222
3005, 1, 1.35, 0.27777777777778
3006, 1, 1.35, 0.33333333333333
3007, 1, 1.35, 0.38888888888889
3008, 1, 1.35, 0.44444444444444
3009, 1, 1.35, 0.027777777777778
3010, 1, 1.35, 0.083333333333333
3011, 1, 1.35, 0.13888888888889
3012, 1, 1.35, 0.19444444444444
3013, 1, 1.35, 0.25
3014, 1, 1.35, 0.30555555555556
3015, 1, 1.35, 0.36111111111111
3016, 1, 1.35, 0.41666666666667
3017, 1, 1.35, 0.47222222222222
3018, 0, 0.20217391304348, 0.5
3019, 0, 0.25434782608696, 0.5
3020, 0, 0.30652173913043, 0.5
3021, 0, 0.35869565217391, 0.5
3022, 0, 0.41086956521739, 0.5
3023, 0, 0.46304347826087, 0.5
3024, 0, 0.51521739130435, 0.5
3025, 0, 0.56739130434783, 0.5
3026, 0, 0.6195652173913, 0.5
3027, 0, 0.67173913043478, 0.5
3028, 0, 0.72391304347826, 0.5
3029, 0, 0.77608695652174, 0.5
3030, 0, 0.82826086956522, 0.5
3031, 0, 0.88043478260869, 0.5
3032, 0, 0.93260869565217, 0.5
3033, 0, 0.98478260869565, 0.5
3034, 0, 1.0369565217391, 0.5
3035, 0, 1.0891304347826, 0.5
3036, 0, 1.1413043478261, 0.5
3037, 0, 1.1934782608696, 0.5
3038, 0, 1.245652173913, 0.5
3039, 0, 1.2978260869565, 0.5
3040, 0, 0.17608695652174, 0.5
3041, 0, 0.22826086956522, 0.5
3042, 0, 0.2804347826087, 0.5
3043, 0, 0.33260869565217, 0.5
3044, 0, 0.38478260869565, 0.5
3045, 0, 0.43695652173913, 0.5
3046, 0, 0.48913043478261, 0.5
3047, 0, 0.54130434782609, 0.5
3048, 0, 0.59347826086956, 0.5
3049, 0, 0.64565217391304, 0.5
3050, 0, 0.69782608695652, 0.5
3051, 0, 0.75, 0.5
3052, 0, 0.80217391304348, 0.5
3053, 0, 0.85434782608696, 0.5
3054, 0, 0.90652173913043, 0.5
3055, 0, 0.95869565217391, 0.5
3056, 0, 1.0108695652174, 0.5
3057, 0, 1.0630434782609, 0.5
3058, 0, 1.1152173913043, 0.5
3059, 0, 1.1673913043478, 0.5
3060, 0, 1.2195652173913, 0.5
3061, 0, 1.2717391304348, 0.5
3062, 0, 1.3239130434783, 0.5
3063, 0.043478260869565, 1.35, 0.5
3064, 0.08695652173913, 1.35, 0.5
3065, 0.1304347826087, 1.35, 0.5
3066, 0.17391304347826, 1.35, 0.5
3067, 0.21739130434783, 1.35, 0.5
3068, 0.26086956521739, 1.35, 0.5
3069, 0.30434782608696, 1.35, 0.5
3070, 0.34782608695652, 1.35, 0.5
3071, 0.39130434782609, 1.35, 0.5
3072, 0.43478260869565, 1.35, 0.5
3073, 0.47826086956522, 1.35, 0.5
3074, 0.52173913043478, 1.35, 0.5
3075, 0.56521739130435, 1.35, 0.5
3076, 0.60869565217391, 1.35, 0.5
3077, 0.65217391304348, 1.35, 0.5
3078, 0.69565217391304, 1.35, 0.5
3079, 0.73913043478261, 1.35, 0.5
3080, 0.78260869565217, 1.35, 0.5
3081, 0.82608695652174, 1.35, 0.5
3082, 0.8695652173913, 1.35, 0.5
3083, 0.91304347826087, 1.35, 0.5
3084, 0.95652173913043, 1.35, 0.5
3085, 0.021739130434783, 1.35, 0.5
3086, 0.065217391304348, 1.35, 0.5
3087, 0.10869565217391, 1.35, 0.5
3088, 0.15217391304348, 1.35, 0.5
3089, 0.19565217391304, 1.35, 0.5
3090, 0.23913043478261, 1.35, 0.5
3091, 0.28260869565217, 1.35, 0.5
3092, 0.32608695652174, 1.35, 0.5
3093, 0.3695652173913, 1.35, 0.5
3094, 0.41304347826087, 1.35, 0.5
3095, 0.45652173913043, 1.35, 0.5
3096, 0.5, 1.35, 0.5
3097, 0.54347826086957, 1.35, 0.5
3098, 0.58695652173913, 1.35, 0.5
3099, 0.6304347826087, 1.35, 0.5
3100, 0.67391304347826, 1.35, 0.5
3101, 0.71739130434783, 1.35, 0.5
3102, 0.76086956521739, 1.35, 0.5
3103, 0.80434782608696, 1.35, 0.5
3104, 0.84782608695652, 1.35, 0.5
3105, 0.89130434782609, 1.35, 0.5
3106, 0.93478260869565, 1.35, 0.5
3107, 0.97826086956522, 1.35, 0.5
3108, 0, 1.35, 0.055555555555556
3109, 0, 1.35, 0.11111111111111
3110, 0, 1.35, 0.16666666666667
3111, 0, 1.35, 0.22222222222222
3112, 0, 1.35, 0.27777777777778
3113, 0, 1.35, 0.33333333333333
3114, 0, 1.35, 0.38888888888889
3115, 0, 1.35, 0.44444444444444
3116, 0, 1.35, 0.027777777777778
3117, 0, 1.35, 0.083333333333333
3118, 0, 1.35, 0.13888888888889
3119, 0, 1.35, 0.19444444444444
3120, 0, 1.35, 0.25
3121, 0, 1.35, 0.30555555555556
3122, 0, 1.35, 0.36111111111111
3123, 0, 1.35, 0.41666666666667
3124, 0, 1.35, 0.47222222222222
3125, 1.2, 1.2978260869565, 0.5
3126, 1.2, 1.245652173913, 0.5
3127, 1.2, 1.1934782608696, 0.5
3128, 1.2, 1.1413043478261, 0.5
3129, 1.2, 1.0891304347826, 0.5
3130, 1.2, 1.0369565217391, 0.5
3131, 1.2, 0.98478260869565, 0.5
3132, 1.2, 0.93260869565217, 0.5
3133, 1.2, 0.8804347826087, 0.5
3134, 1.2, 0.82826086956522, 0.5
3135, 1.2, 0.77608695652174, 0.5
3136, 1.2, 0.72391304347826, 0.5
3137, 1.2, 0.67173913043478, 0.5
3138, 1.2, 0.61956521739131, 0.5
3139, 1.2, 0.56739130434783, 0.5
3140, 1.2, 0.51521739130435, 0.5
3141, 1.2, 0.46304347826087, 0.5
3142, 1.2, 0.41086956521739, 0.5
3143, 1.2, 0.35869565217391, 0.5
3144, 1.2, 0.30652173913044, 0.5
3145, 1.2, 0.25434782608696, 0.5
3146, 1.2, 0.20217391304348, 0.5
3147, 1.2, 1.3239130434783, 0.5
3148, 1.2, 1.2717391304348, 0.5
3149, 1.2, 1.2195652173913, 0.5
3150, 1.2, 1.1673913043478, 0.5
3151, 1.2, 1.1152173913043, 0.5
3152, 1.2, 1.0630434782609, 0.5
3153, 1.2, 1.0108695652174, 0.5
3154, 1.2, 0.95869565217391, 0.5
3155, 1.2, 0.90652173913044, 0.5
3156, 1.2, 0.85434782608696, 0.5
3157, 1.2, 0.80217391304348, 0.5
3158, 1.2, 0.75, 0.5
3159, 1.2, 0.69782608695652, 0.5
3160, 1.2, 0.64565217391304, 0.5
3161, 1.2, 0.59347826086957, 0.5
3162, 1.2, 0.54130434782609, 0.5
3163, 1.2, 0.48913043478261, 0.5
3164, 1.2, 0.43695652173913, 0.5
3165, 1.2, 0.38478260869565, 0.5
3166, 1.2, 0.33260869565217, 0.5
3167, 1.2, 0.2804347826087, 0.5
3168, 1.2, 0.22826086956522, 0.5
3169, 1.2, 0.17608695652174, 0.5
3170, 2.2, 1.2978260869565, 0.5
3171, 2.2, 1.245652173913, 0.5
3172, 2.2, 1.1934782608696, 0.5
3173, 2.2, 1.1413043478261, 0.5
3174, 2.2, 1.0891304347826, 0.5
3175, 2.2, 1.0369565217391, 0.5
3176, 2.2, 0.98478260869565, 0.5
3177, 2.2, 0.93260869565217, 0.5
3178, 2.2, 0.8804347826087, 0.5
3179, 2.2, 0.82826086956522, 0.5
3180, 2.2, 0.77608695652174, 0.5
3181, 2.2, 0.72391304347826, 0.5
3182, 2.2, 0.67173913043478, 0.5
3183, 2.2, 0.61956521739131, 0.5
3184, 2.2, 0.56739130434783, 0.5
3185, 2.2, 0.51521739130435, 0.5
3186, 2.2, 0.46304347826087, 0.5
3187, 2.2, 0.41086956521739, 0.5
3188, 2.2, 0.35869565217391, 0.5
3189, 2.2, 0.30652173913044, 0.5
3190, 2.2, 0.25434782608696, 0.5
3191, 2.2, 0.20217391304348, 0.5
3192, 2.2, 1.3239130434783, 0.5
3193, 2.2, 1.2717391304348, 0.5
3194, 2.2, 1.2195652173913, 0.5
3195, 2.2, 1.1673913043478, 0.5
3196, 2.2, 1.1152173913043, 0.5
3197, 2.2, 1.0630434782609, 0.5
3198, 2.2, 1.0108695652174, 0.5
3199, 2.2, 0.95869565217391, 0.5
3200, 2.2, 0.90652173913044, 0.5
3201, 2.2, 0.85434782608696, 0.5
3202, 2.2, 0.80217391304348, 0.5
3203, 2.2, 0.75, 0.5
3204, 2.2, 0.69782608695652, 0.5
3205, 2.2, 0.64565217391304, 0.5
3206, 2.2, 0.59347826086957, 0.5
3207, 2.2, 0.54130434782609, 0.5
3208, 2.2, 0.48913043478261, 0.5
3209, 2.2, 0.43695652173913, 0.5
3210, 2.2, 0.38478260869565, 0.5
3211, 2.2, 0.33260869565217, 0.5
3212, 2.2, 0.2804347826087, 0.5
3213, 2.2, 0.22826086956522, 0.5
3214, 2.2, 0.17608695652174, 0.5
3215, 1.2434782608696, 1.35, 0.5
3216, 1.2869565217391, 1.35, 0.5
3217, 1.3304347826087, 1.35, 0.5
3218, 1.3739130434783, 1.35, 0.5
3219, 1.4173913043478, 1.35, 0.5
3220, 1.4608695652174, 1.35, 0.5
3221, 1.504347826087, 1.35, 0.5
3222, 1.5478260869565, 1.35, 0.5
3223, 1.5913043478261, 1.35, 0.5
3224, 1.6347826086957, 1.35, 0.5
3225, 1.6782608695652, 1.35, 0.5
3226, 1.7217391304348, 1.35, 0.5
3227, 1.7652173913043, 1.35, 0.5
3228, 1.8086956521739, 1.35, 0.5
3229, 1.8521739130435, 1.35, 0.5
3230, 1.895652173913, 1.35, 0.5
3231, 1.9391304347826, 1.35, 0.5
3232, 1.9826086956522, 1.35, 0.5
3233, 2.0260869565217, 1.35, 0.5
3234, 2.0695652173913, 1.35, 0.5
3235, 2.1130434782609, 1.35, 0.5
3236, 2.1565217391304, 1.35, 0.5
3237, 1.2217391304348, 1.35, 0.5
3238, 1.2652173913043, 1.35, 0.5
3239, 1.3086956521739, 1.35, 0.5
3240, 1.3521739130435, 1.35, 0.5
3241, 1.395652173913, 1.35, 0.5
3242, 1.4391304347826, 1.35, 0.5
3243, 1.4826086956522, 1.35, 0.5
3244, 1.5260869565217, 1.35, 0.5
3245, 1.5695652173913, 1.35, 0.5
3246, 1.6130434782609, 1.35, 0.5
3247, 1.6565217391304, 1.35, 0.5
3248, 1.7, 1.35, 0.5
3249, 1.7434782608696, 1.35, 0.5
3250, 1.7869565217391, 1.35, 0.5
3251, 1.8304347826087, 1.35, 0.5
3252, 1.8739130434783, 1.35, 0.5
3253, 1.9173913043478, 1.35, 0.5
3254, 1.9608695652174, 1.35, 0.5
3255, 2.004347826087, 1.35, 0.5
3256, 2.0478260869565, 1.35, 0.5
3257, 2.0913043478261, 1.35, 0.5
3258, 2.1347826086957, 1.35, 0.5
3259, 2.1782608695652, 1.35, 0.5
3260, 1.2, 1.2978260869565, 0
3261, 1.2, 1.245652173913, 0
3262, 1.2, 1.1934782608696, 0
3263, 1.2, 1.1413043478261, 0
3264, 1.2, 1.0891304347826, 0
3265, 1.2, 1.0369565217391, 0
3266, 1.2, 0.98478260869565, 0
3267, 1.2, 0.93260869565217, 0
3268, 1.2, 0.8804347826087, 0
3269, 1.2, 0.82826086956522, 0
3270, 1.2, 0.77608695652174, 0
3271, 1.2, 0.72391304347826, 0
3272, 1.2, 0.67173913043478, 0
3273, 1.2, 0.61956521739131, 0
3274, 1.2, 0.56739130434783, 0
3275, 1.2, 0.51521739130435, 0
3276, 1.2, 0.46304347826087, 0
3277, 1.2, 0.41086956521739, 0
3278, 1.2, 0.35869565217391, 0
3279, 1.2, 0.30652173913044, 0
3280, 1.2, 0.25434782608696, 0
3281, 1.2, 0.20217391304348, 0
3282, 1.2, 1.3239130434783, 0
3283, 1.2, 1.2717391304348, 0
3284, 1.2, 1.2195652173913, 0
3285, 1.2, 1.1673913043478, 0
3286, 1.2, 1.1152173913043, 0
3287, 1.2, 1.0630434782609, 0
3288, 1.2, 1.0108695652174, 0
3289, 1.2, 0.95869565217391, 0
3290, 1.2, 0.90652173913044, 0
3291, 1.2, 0.85434782608696, 0
3292, 1.2, 0.80217391304348, 0
3293, 1.2, 0.75, 0
3294, 1.2, 0.69782608695652, 0
3295, 1.2, 0.64565217391304, 0
3296, 1.2, 0.59347826086957, 0
