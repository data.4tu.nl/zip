3297, 1.2, 0.54130434782609, 0
3298, 1.2, 0.48913043478261, 0
3299, 1.2, 0.43695652173913, 0
3300, 1.2, 0.38478260869565, 0
3301, 1.2, 0.33260869565217, 0
3302, 1.2, 0.2804347826087, 0
3303, 1.2, 0.22826086956522, 0
3304, 1.2, 0.17608695652174, 0
3305, 2.2, 1.2978260869565, 0
3306, 2.2, 1.245652173913, 0
3307, 2.2, 1.1934782608696, 0
3308, 2.2, 1.1413043478261, 0
3309, 2.2, 1.0891304347826, 0
3310, 2.2, 1.0369565217391, 0
3311, 2.2, 0.98478260869565, 0
3312, 2.2, 0.93260869565217, 0
3313, 2.2, 0.8804347826087, 0
3314, 2.2, 0.82826086956522, 0
3315, 2.2, 0.77608695652174, 0
3316, 2.2, 0.72391304347826, 0
3317, 2.2, 0.67173913043478, 0
3318, 2.2, 0.61956521739131, 0
3319, 2.2, 0.56739130434783, 0
3320, 2.2, 0.51521739130435, 0
3321, 2.2, 0.46304347826087, 0
3322, 2.2, 0.41086956521739, 0
3323, 2.2, 0.35869565217391, 0
3324, 2.2, 0.30652173913044, 0
3325, 2.2, 0.25434782608696, 0
3326, 2.2, 0.20217391304348, 0
3327, 2.2, 1.3239130434783, 0
3328, 2.2, 1.2717391304348, 0
3329, 2.2, 1.2195652173913, 0
3330, 2.2, 1.1673913043478, 0
3331, 2.2, 1.1152173913043, 0
3332, 2.2, 1.0630434782609, 0
3333, 2.2, 1.0108695652174, 0
3334, 2.2, 0.95869565217391, 0
3335, 2.2, 0.90652173913044, 0
3336, 2.2, 0.85434782608696, 0
3337, 2.2, 0.80217391304348, 0
3338, 2.2, 0.75, 0
3339, 2.2, 0.69782608695652, 0
3340, 2.2, 0.64565217391304, 0
3341, 2.2, 0.59347826086957, 0
3342, 2.2, 0.54130434782609, 0
3343, 2.2, 0.48913043478261, 0
3344, 2.2, 0.43695652173913, 0
3345, 2.2, 0.38478260869565, 0
3346, 2.2, 0.33260869565217, 0
3347, 2.2, 0.2804347826087, 0
3348, 2.2, 0.22826086956522, 0
3349, 2.2, 0.17608695652174, 0
3350, 1.2434782608696, 1.35, 0
3351, 1.2869565217391, 1.35, 0
3352, 1.3304347826087, 1.35, 0
3353, 1.3739130434783, 1.35, 0
3354, 1.4173913043478, 1.35, 0
3355, 1.4608695652174, 1.35, 0
3356, 1.504347826087, 1.35, 0
3357, 1.5478260869565, 1.35, 0
3358, 1.5913043478261, 1.35, 0
3359, 1.6347826086957, 1.35, 0
3360, 1.6782608695652, 1.35, 0
3361, 1.7217391304348, 1.35, 0
3362, 1.7652173913043, 1.35, 0
3363, 1.8086956521739, 1.35, 0
3364, 1.8521739130435, 1.35, 0
3365, 1.895652173913, 1.35, 0
3366, 1.9391304347826, 1.35, 0
3367, 1.9826086956522, 1.35, 0
3368, 2.0260869565217, 1.35, 0
3369, 2.0695652173913, 1.35, 0
3370, 2.1130434782609, 1.35, 0
3371, 2.1565217391304, 1.35, 0
3372, 1.2217391304348, 1.35, 0
3373, 1.2652173913043, 1.35, 0
3374, 1.3086956521739, 1.35, 0
3375, 1.3521739130435, 1.35, 0
3376, 1.395652173913, 1.35, 0
3377, 1.4391304347826, 1.35, 0
3378, 1.4826086956522, 1.35, 0
3379, 1.5260869565217, 1.35, 0
3380, 1.5695652173913, 1.35, 0
3381, 1.6130434782609, 1.35, 0
3382, 1.6565217391304, 1.35, 0
3383, 1.7, 1.35, 0
3384, 1.7434782608696, 1.35, 0
3385, 1.7869565217391, 1.35, 0
3386, 1.8304347826087, 1.35, 0
3387, 1.8739130434783, 1.35, 0
3388, 1.9173913043478, 1.35, 0
3389, 1.9608695652174, 1.35, 0
3390, 2.004347826087, 1.35, 0
3391, 2.0478260869565, 1.35, 0
3392, 2.0913043478261, 1.35, 0
3393, 2.1347826086957, 1.35, 0
3394, 2.1782608695652, 1.35, 0
3395, 1.2, 1.35, 0.055555555555556
3396, 1.2, 1.35, 0.11111111111111
3397, 1.2, 1.35, 0.16666666666667
3398, 1.2, 1.35, 0.22222222222222
3399, 1.2, 1.35, 0.27777777777778
3400, 1.2, 1.35, 0.33333333333333
3401, 1.2, 1.35, 0.38888888888889
3402, 1.2, 1.35, 0.44444444444444
3403, 1.2, 1.35, 0.027777777777778
3404, 1.2, 1.35, 0.083333333333333
3405, 1.2, 1.35, 0.13888888888889
3406, 1.2, 1.35, 0.19444444444444
3407, 1.2, 1.35, 0.25
3408, 1.2, 1.35, 0.30555555555556
3409, 1.2, 1.35, 0.36111111111111
3410, 1.2, 1.35, 0.41666666666667
3411, 1.2, 1.35, 0.47222222222222
3412, 2.2, 1.35, 0.055555555555556
3413, 2.2, 1.35, 0.11111111111111
3414, 2.2, 1.35, 0.16666666666667
3415, 2.2, 1.35, 0.22222222222222
3416, 2.2, 1.35, 0.27777777777778
3417, 2.2, 1.35, 0.33333333333333
3418, 2.2, 1.35, 0.38888888888889
3419, 2.2, 1.35, 0.44444444444444
3420, 2.2, 1.35, 0.027777777777778
3421, 2.2, 1.35, 0.083333333333333
3422, 2.2, 1.35, 0.13888888888889
3423, 2.2, 1.35, 0.19444444444444
3424, 2.2, 1.35, 0.25
3425, 2.2, 1.35, 0.30555555555556
3426, 2.2, 1.35, 0.36111111111111
3427, 2.2, 1.35, 0.41666666666667
3428, 2.2, 1.35, 0.47222222222222
3429, 1.2, 0.125, 0.5
3430, 1.2, 0.1375, 0.5
3431, 1.2, 0.1125, 0.5
3432, 2.2, 0.125, 0.5
3433, 2.2, 0.1375, 0.5
3434, 2.2, 0.1125, 0.5
3435, 1.2434782608696, 0.1, 0.5
3436, 1.2869565217391, 0.1, 0.5
3437, 1.3304347826087, 0.1, 0.5
3438, 1.3739130434783, 0.1, 0.5
3439, 1.4173913043478, 0.1, 0.5
3440, 1.4608695652174, 0.1, 0.5
3441, 1.504347826087, 0.1, 0.5
3442, 1.5478260869565, 0.1, 0.5
3443, 1.5913043478261, 0.1, 0.5
3444, 1.6347826086957, 0.1, 0.5
3445, 1.6782608695652, 0.1, 0.5
3446, 1.7217391304348, 0.1, 0.5
3447, 1.7652173913043, 0.1, 0.5
3448, 1.8086956521739, 0.1, 0.5
3449, 1.8521739130435, 0.1, 0.5
3450, 1.895652173913, 0.1, 0.5
3451, 1.9391304347826, 0.1, 0.5
3452, 1.9826086956522, 0.1, 0.5
3453, 2.0260869565217, 0.1, 0.5
3454, 2.0695652173913, 0.1, 0.5
3455, 2.1130434782609, 0.1, 0.5
3456, 2.1565217391304, 0.1, 0.5
3457, 1.2217391304348, 0.1, 0.5
3458, 1.2652173913043, 0.1, 0.5
3459, 1.3086956521739, 0.1, 0.5
3460, 1.3521739130435, 0.1, 0.5
3461, 1.395652173913, 0.1, 0.5
3462, 1.4391304347826, 0.1, 0.5
3463, 1.4826086956522, 0.1, 0.5
3464, 1.5260869565217, 0.1, 0.5
3465, 1.5695652173913, 0.1, 0.5
3466, 1.6130434782609, 0.1, 0.5
3467, 1.6565217391304, 0.1, 0.5
3468, 1.7, 0.1, 0.5
3469, 1.7434782608696, 0.1, 0.5
3470, 1.7869565217391, 0.1, 0.5
3471, 1.8304347826087, 0.1, 0.5
3472, 1.8739130434783, 0.1, 0.5
3473, 1.9173913043478, 0.1, 0.5
3474, 1.9608695652174, 0.1, 0.5
3475, 2.004347826087, 0.1, 0.5
3476, 2.0478260869565, 0.1, 0.5
3477, 2.0913043478261, 0.1, 0.5
3478, 2.1347826086957, 0.1, 0.5
3479, 2.1782608695652, 0.1, 0.5
3480, 1.2, 0.125, 0
3481, 1.2, 0.1375, 0
3482, 1.2, 0.1125, 0
3483, 2.2, 0.125, 0
3484, 2.2, 0.1375, 0
3485, 2.2, 0.1125, 0
3486, 1.2434782608696, 0.1, 0
3487, 1.2869565217391, 0.1, 0
3488, 1.3304347826087, 0.1, 0
3489, 1.3739130434783, 0.1, 0
3490, 1.4173913043478, 0.1, 0
3491, 1.4608695652174, 0.1, 0
3492, 1.504347826087, 0.1, 0
3493, 1.5478260869565, 0.1, 0
3494, 1.5913043478261, 0.1, 0
3495, 1.6347826086957, 0.1, 0
3496, 1.6782608695652, 0.1, 0
3497, 1.7217391304348, 0.1, 0
3498, 1.7652173913043, 0.1, 0
3499, 1.8086956521739, 0.1, 0
3500, 1.8521739130435, 0.1, 0
3501, 1.895652173913, 0.1, 0
3502, 1.9391304347826, 0.1, 0
3503, 1.9826086956522, 0.1, 0
3504, 2.0260869565217, 0.1, 0
3505, 2.0695652173913, 0.1, 0
3506, 2.1130434782609, 0.1, 0
3507, 2.1565217391304, 0.1, 0
3508, 1.2217391304348, 0.1, 0
3509, 1.2652173913043, 0.1, 0
3510, 1.3086956521739, 0.1, 0
3511, 1.3521739130435, 0.1, 0
3512, 1.395652173913, 0.1, 0
3513, 1.4391304347826, 0.1, 0
3514, 1.4826086956522, 0.1, 0
3515, 1.5260869565217, 0.1, 0
3516, 1.5695652173913, 0.1, 0
3517, 1.6130434782609, 0.1, 0
3518, 1.6565217391304, 0.1, 0
3519, 1.7, 0.1, 0
3520, 1.7434782608696, 0.1, 0
3521, 1.7869565217391, 0.1, 0
3522, 1.8304347826087, 0.1, 0
3523, 1.8739130434783, 0.1, 0
3524, 1.9173913043478, 0.1, 0
3525, 1.9608695652174, 0.1, 0
3526, 2.004347826087, 0.1, 0
3527, 2.0478260869565, 0.1, 0
3528, 2.0913043478261, 0.1, 0
3529, 2.1347826086957, 0.1, 0
3530, 2.1782608695652, 0.1, 0
3531, 1.2, 0.1, 0.055555555555556
3532, 1.2, 0.1, 0.11111111111111
3533, 1.2, 0.1, 0.16666666666667
3534, 1.2, 0.1, 0.22222222222222
3535, 1.2, 0.1, 0.27777777777778
3536, 1.2, 0.1, 0.33333333333333
3537, 1.2, 0.1, 0.38888888888889
3538, 1.2, 0.1, 0.44444444444444
3539, 1.2, 0.1, 0.027777777777778
3540, 1.2, 0.1, 0.083333333333333
3541, 1.2, 0.1, 0.13888888888889
3542, 1.2, 0.1, 0.19444444444444
3543, 1.2, 0.1, 0.25
3544, 1.2, 0.1, 0.30555555555556
3545, 1.2, 0.1, 0.36111111111111
3546, 1.2, 0.1, 0.41666666666667
3547, 1.2, 0.1, 0.47222222222222
3548, 2.2, 0.1, 0.055555555555556
3549, 2.2, 0.1, 0.11111111111111
3550, 2.2, 0.1, 0.16666666666667
3551, 2.2, 0.1, 0.22222222222222
3552, 2.2, 0.1, 0.27777777777778
3553, 2.2, 0.1, 0.33333333333333
3554, 2.2, 0.1, 0.38888888888889
3555, 2.2, 0.1, 0.44444444444444
3556, 2.2, 0.1, 0.027777777777778
3557, 2.2, 0.1, 0.083333333333333
3558, 2.2, 0.1, 0.13888888888889
3559, 2.2, 0.1, 0.19444444444444
3560, 2.2, 0.1, 0.25
3561, 2.2, 0.1, 0.30555555555556
3562, 2.2, 0.1, 0.36111111111111
3563, 2.2, 0.1, 0.41666666666667
3564, 2.2, 0.1, 0.47222222222222
3565, 1.2, 0.075, 0.5
3566, 1.2, 0.0625, 0.5
3567, 1.2, 0.0875, 0.5
3568, 2.2, 0.075, 0.5
3569, 2.2, 0.0625, 0.5
3570, 2.2, 0.0875, 0.5
3571, 1.2, 0.075, 0
3572, 1.2, 0.0625, 0
3573, 1.2, 0.0875, 0
3574, 2.2, 0.075, 0
3575, 2.2, 0.0625, 0
3576, 2.2, 0.0875, 0
3577, 1, 0.075, 0
3578, 1, 0.0625, 0
3579, 1, 0.0875, 0
3580, 0, 0.075, 0
3581, 0, 0.0625, 0
3582, 0, 0.0875, 0
3583, 1, 0.075, 0.5
3584, 1, 0.0625, 0.5
3585, 1, 0.0875, 0.5
3586, 0, 0.075, 0.5
3587, 0, 0.0625, 0.5
3588, 0, 0.0875, 0.5
3589, 1, 1.375, 0
3590, 1, 1.3875, 0
3591, 1, 1.3625, 0
3592, 0, 1.375, 0
3593, 0, 1.3875, 0
3594, 0, 1.3625, 0
3595, 1, 1.375, 0.5
3596, 1, 1.3875, 0.5
3597, 1, 1.3625, 0.5
3598, 0, 1.375, 0.5
3599, 0, 1.3875, 0.5
3600, 0, 1.3625, 0.5
3601, 1.2, 1.375, 0.5
3602, 1.2, 1.3875, 0.5
3603, 1.2, 1.3625, 0.5
3604, 2.2, 1.375, 0.5
3605, 2.2, 1.3875, 0.5
3606, 2.2, 1.3625, 0.5
3607, 1.2, 1.375, 0
3608, 1.2, 1.3875, 0
3609, 1.2, 1.3625, 0
3610, 2.2, 1.375, 0
3611, 2.2, 1.3875, 0
3612, 2.2, 1.3625, 0
3613, 1, 0.15, -0.05
3614, 1, 0.15, -0.1
3615, 1, 0.15, -0.15
3616, 1, 0.15, -0.025
3617, 1, 0.15, -0.075
3618, 1, 0.15, -0.125
3619, 1, 0.15, -0.175
3620, 1, 1.35, -0.05
3621, 1, 1.35, -0.1
3622, 1, 1.35, -0.15
3623, 1, 1.35, -0.025
3624, 1, 1.35, -0.075
3625, 1, 1.35, -0.125
3626, 1, 1.35, -0.175
3627, 1, 0.20217391304348, -0.2
3628, 1, 0.25434782608696, -0.2
3629, 1, 0.30652173913043, -0.2
3630, 1, 0.35869565217391, -0.2
3631, 1, 0.41086956521739, -0.2
3632, 1, 0.46304347826087, -0.2
3633, 1, 0.51521739130435, -0.2
3634, 1, 0.56739130434783, -0.2
3635, 1, 0.6195652173913, -0.2
3636, 1, 0.67173913043478, -0.2
3637, 1, 0.72391304347826, -0.2
3638, 1, 0.77608695652174, -0.2
3639, 1, 0.82826086956522, -0.2
3640, 1, 0.88043478260869, -0.2
3641, 1, 0.93260869565217, -0.2
3642, 1, 0.98478260869565, -0.2
3643, 1, 1.0369565217391, -0.2
3644, 1, 1.0891304347826, -0.2
3645, 1, 1.1413043478261, -0.2
3646, 1, 1.1934782608696, -0.2
3647, 1, 1.245652173913, -0.2
3648, 1, 1.2978260869565, -0.2
3649, 1, 0.17608695652174, -0.2
3650, 1, 0.22826086956522, -0.2
3651, 1, 0.2804347826087, -0.2
3652, 1, 0.33260869565217, -0.2
3653, 1, 0.38478260869565, -0.2
3654, 1, 0.43695652173913, -0.2
3655, 1, 0.48913043478261, -0.2
3656, 1, 0.54130434782609, -0.2
3657, 1, 0.59347826086956, -0.2
3658, 1, 0.64565217391304, -0.2
3659, 1, 0.69782608695652, -0.2
3660, 1, 0.75, -0.2
3661, 1, 0.80217391304348, -0.2
3662, 1, 0.85434782608696, -0.2
3663, 1, 0.90652173913043, -0.2
3664, 1, 0.95869565217391, -0.2
3665, 1, 1.0108695652174, -0.2
3666, 1, 1.0630434782609, -0.2
3667, 1, 1.1152173913043, -0.2
3668, 1, 1.1673913043478, -0.2
3669, 1, 1.2195652173913, -0.2
3670, 1, 1.2717391304348, -0.2
3671, 1, 1.3239130434783, -0.2
3672, 0, 0.15, -0.05
3673, 0, 0.15, -0.1
3674, 0, 0.15, -0.15
3675, 0, 0.15, -0.025
3676, 0, 0.15, -0.075
3677, 0, 0.15, -0.125
3678, 0, 0.15, -0.175
3679, 0, 1.35, -0.05
3680, 0, 1.35, -0.1
3681, 0, 1.35, -0.15
3682, 0, 1.35, -0.025
3683, 0, 1.35, -0.075
3684, 0, 1.35, -0.125
3685, 0, 1.35, -0.175
3686, 0, 0.20217391304348, -0.2
3687, 0, 0.25434782608696, -0.2
3688, 0, 0.30652173913043, -0.2
3689, 0, 0.35869565217391, -0.2
3690, 0, 0.41086956521739, -0.2
3691, 0, 0.46304347826087, -0.2
3692, 0, 0.51521739130435, -0.2
3693, 0, 0.56739130434783, -0.2
3694, 0, 0.6195652173913, -0.2
3695, 0, 0.67173913043478, -0.2
3696, 0, 0.72391304347826, -0.2
3697, 0, 0.77608695652174, -0.2
3698, 0, 0.82826086956522, -0.2
3699, 0, 0.88043478260869, -0.2
3700, 0, 0.93260869565217, -0.2
3701, 0, 0.98478260869565, -0.2
3702, 0, 1.0369565217391, -0.2
3703, 0, 1.0891304347826, -0.2
3704, 0, 1.1413043478261, -0.2
3705, 0, 1.1934782608696, -0.2
3706, 0, 1.245652173913, -0.2
3707, 0, 1.2978260869565, -0.2
3708, 0, 0.17608695652174, -0.2
3709, 0, 0.22826086956522, -0.2
3710, 0, 0.2804347826087, -0.2
3711, 0, 0.33260869565217, -0.2
3712, 0, 0.38478260869565, -0.2
3713, 0, 0.43695652173913, -0.2
3714, 0, 0.48913043478261, -0.2
3715, 0, 0.54130434782609, -0.2
3716, 0, 0.59347826086956, -0.2
3717, 0, 0.64565217391304, -0.2
3718, 0, 0.69782608695652, -0.2
3719, 0, 0.75, -0.2
3720, 0, 0.80217391304348, -0.2
3721, 0, 0.85434782608696, -0.2
3722, 0, 0.90652173913043, -0.2
3723, 0, 0.95869565217391, -0.2
3724, 0, 1.0108695652174, -0.2
3725, 0, 1.0630434782609, -0.2
3726, 0, 1.1152173913043, -0.2
3727, 0, 1.1673913043478, -0.2
3728, 0, 1.2195652173913, -0.2
3729, 0, 1.2717391304348, -0.2
3730, 0, 1.3239130434783, -0.2
3731, 0.043478260869565, 0.15, -0.2
3732, 0.08695652173913, 0.15, -0.2
3733, 0.1304347826087, 0.15, -0.2
3734, 0.17391304347826, 0.15, -0.2
3735, 0.21739130434783, 0.15, -0.2
3736, 0.26086956521739, 0.15, -0.2
3737, 0.30434782608696, 0.15, -0.2
3738, 0.34782608695652, 0.15, -0.2
3739, 0.39130434782609, 0.15, -0.2
3740, 0.43478260869565, 0.15, -0.2
3741, 0.47826086956522, 0.15, -0.2
3742, 0.52173913043478, 0.15, -0.2
3743, 0.56521739130435, 0.15, -0.2
3744, 0.60869565217391, 0.15, -0.2
3745, 0.65217391304348, 0.15, -0.2
3746, 0.69565217391304, 0.15, -0.2
3747, 0.73913043478261, 0.15, -0.2
3748, 0.78260869565217, 0.15, -0.2
3749, 0.82608695652174, 0.15, -0.2
3750, 0.8695652173913, 0.15, -0.2
3751, 0.91304347826087, 0.15, -0.2
3752, 0.95652173913043, 0.15, -0.2
3753, 0.021739130434783, 0.15, -0.2
3754, 0.065217391304348, 0.15, -0.2
3755, 0.10869565217391, 0.15, -0.2
3756, 0.15217391304348, 0.15, -0.2
3757, 0.19565217391304, 0.15, -0.2
3758, 0.23913043478261, 0.15, -0.2
3759, 0.28260869565217, 0.15, -0.2
3760, 0.32608695652174, 0.15, -0.2
3761, 0.3695652173913, 0.15, -0.2
3762, 0.41304347826087, 0.15, -0.2
3763, 0.45652173913043, 0.15, -0.2
3764, 0.5, 0.15, -0.2
3765, 0.54347826086957, 0.15, -0.2
3766, 0.58695652173913, 0.15, -0.2
3767, 0.6304347826087, 0.15, -0.2
3768, 0.67391304347826, 0.15, -0.2
3769, 0.71739130434783, 0.15, -0.2
3770, 0.76086956521739, 0.15, -0.2
3771, 0.80434782608696, 0.15, -0.2
3772, 0.84782608695652, 0.15, -0.2
3773, 0.89130434782609, 0.15, -0.2
3774, 0.93478260869565, 0.15, -0.2
3775, 0.97826086956522, 0.15, -0.2
3776, 0.043478260869565, 1.35, -0.2
3777, 0.08695652173913, 1.35, -0.2
3778, 0.1304347826087, 1.35, -0.2
3779, 0.17391304347826, 1.35, -0.2
3780, 0.21739130434783, 1.35, -0.2
3781, 0.26086956521739, 1.35, -0.2
3782, 0.30434782608696, 1.35, -0.2
3783, 0.34782608695652, 1.35, -0.2
3784, 0.39130434782609, 1.35, -0.2
3785, 0.43478260869565, 1.35, -0.2
3786, 0.47826086956522, 1.35, -0.2
3787, 0.52173913043478, 1.35, -0.2
3788, 0.56521739130435, 1.35, -0.2
3789, 0.60869565217391, 1.35, -0.2
3790, 0.65217391304348, 1.35, -0.2
3791, 0.69565217391304, 1.35, -0.2
3792, 0.73913043478261, 1.35, -0.2
3793, 0.78260869565217, 1.35, -0.2
3794, 0.82608695652174, 1.35, -0.2
3795, 0.8695652173913, 1.35, -0.2
3796, 0.91304347826087, 1.35, -0.2
3797, 0.95652173913043, 1.35, -0.2
3798, 0.021739130434783, 1.35, -0.2
3799, 0.065217391304348, 1.35, -0.2
3800, 0.10869565217391, 1.35, -0.2
3801, 0.15217391304348, 1.35, -0.2
3802, 0.19565217391304, 1.35, -0.2
3803, 0.23913043478261, 1.35, -0.2
3804, 0.28260869565217, 1.35, -0.2
3805, 0.32608695652174, 1.35, -0.2
3806, 0.3695652173913, 1.35, -0.2
3807, 0.41304347826087, 1.35, -0.2
3808, 0.45652173913043, 1.35, -0.2
3809, 0.5, 1.35, -0.2
3810, 0.54347826086957, 1.35, -0.2
3811, 0.58695652173913, 1.35, -0.2
3812, 0.6304347826087, 1.35, -0.2
3813, 0.67391304347826, 1.35, -0.2
3814, 0.71739130434783, 1.35, -0.2
3815, 0.76086956521739, 1.35, -0.2
3816, 0.80434782608696, 1.35, -0.2
3817, 0.84782608695652, 1.35, -0.2
3818, 0.89130434782609, 1.35, -0.2
3819, 0.93478260869565, 1.35, -0.2
3820, 0.97826086956522, 1.35, -0.2
3821, 1.2, 1.35, -0.05
3822, 1.2, 1.35, -0.1
3823, 1.2, 1.35, -0.15
3824, 1.2, 1.35, -0.025
3825, 1.2, 1.35, -0.075
3826, 1.2, 1.35, -0.125
3827, 1.2, 1.35, -0.175
3828, 1.2, 0.15, -0.05
3829, 1.2, 0.15, -0.1
3830, 1.2, 0.15, -0.15
3831, 1.2, 0.15, -0.025
3832, 1.2, 0.15, -0.075
3833, 1.2, 0.15, -0.125
3834, 1.2, 0.15, -0.175
3835, 1.2, 1.2978260869565, -0.2
3836, 1.2, 1.245652173913, -0.2
3837, 1.2, 1.1934782608696, -0.2
3838, 1.2, 1.1413043478261, -0.2
3839, 1.2, 1.0891304347826, -0.2
3840, 1.2, 1.0369565217391, -0.2
3841, 1.2, 0.98478260869565, -0.2
3842, 1.2, 0.93260869565217, -0.2
3843, 1.2, 0.8804347826087, -0.2
3844, 1.2, 0.82826086956522, -0.2
3845, 1.2, 0.77608695652174, -0.2
3846, 1.2, 0.72391304347826, -0.2
3847, 1.2, 0.67173913043478, -0.2
3848, 1.2, 0.61956521739131, -0.2
3849, 1.2, 0.56739130434783, -0.2
3850, 1.2, 0.51521739130435, -0.2
3851, 1.2, 0.46304347826087, -0.2
3852, 1.2, 0.41086956521739, -0.2
3853, 1.2, 0.35869565217391, -0.2
3854, 1.2, 0.30652173913044, -0.2
3855, 1.2, 0.25434782608696, -0.2
3856, 1.2, 0.20217391304348, -0.2
3857, 1.2, 1.3239130434783, -0.2
3858, 1.2, 1.2717391304348, -0.2
3859, 1.2, 1.2195652173913, -0.2
3860, 1.2, 1.1673913043478, -0.2
3861, 1.2, 1.1152173913043, -0.2
3862, 1.2, 1.0630434782609, -0.2
3863, 1.2, 1.0108695652174, -0.2
3864, 1.2, 0.95869565217391, -0.2
3865, 1.2, 0.90652173913044, -0.2
3866, 1.2, 0.85434782608696, -0.2
3867, 1.2, 0.80217391304348, -0.2
3868, 1.2, 0.75, -0.2
3869, 1.2, 0.69782608695652, -0.2
3870, 1.2, 0.64565217391304, -0.2
3871, 1.2, 0.59347826086957, -0.2
3872, 1.2, 0.54130434782609, -0.2
3873, 1.2, 0.48913043478261, -0.2
3874, 1.2, 0.43695652173913, -0.2
3875, 1.2, 0.38478260869565, -0.2
3876, 1.2, 0.33260869565217, -0.2
3877, 1.2, 0.2804347826087, -0.2
3878, 1.2, 0.22826086956522, -0.2
3879, 1.2, 0.17608695652174, -0.2
3880, 2.2, 1.35, -0.05
3881, 2.2, 1.35, -0.1
3882, 2.2, 1.35, -0.15
3883, 2.2, 1.35, -0.025
3884, 2.2, 1.35, -0.075
3885, 2.2, 1.35, -0.125
3886, 2.2, 1.35, -0.175
3887, 2.2, 0.15, -0.05
3888, 2.2, 0.15, -0.1
3889, 2.2, 0.15, -0.15
3890, 2.2, 0.15, -0.025
3891, 2.2, 0.15, -0.075
3892, 2.2, 0.15, -0.125
3893, 2.2, 0.15, -0.175
3894, 2.2, 1.2978260869565, -0.2
3895, 2.2, 1.245652173913, -0.2
3896, 2.2, 1.1934782608696, -0.2
3897, 2.2, 1.1413043478261, -0.2
3898, 2.2, 1.0891304347826, -0.2
3899, 2.2, 1.0369565217391, -0.2
3900, 2.2, 0.98478260869565, -0.2
3901, 2.2, 0.93260869565217, -0.2
3902, 2.2, 0.8804347826087, -0.2
3903, 2.2, 0.82826086956522, -0.2
3904, 2.2, 0.77608695652174, -0.2
3905, 2.2, 0.72391304347826, -0.2
3906, 2.2, 0.67173913043478, -0.2
3907, 2.2, 0.61956521739131, -0.2
3908, 2.2, 0.56739130434783, -0.2
3909, 2.2, 0.51521739130435, -0.2
3910, 2.2, 0.46304347826087, -0.2
3911, 2.2, 0.41086956521739, -0.2
3912, 2.2, 0.35869565217391, -0.2
3913, 2.2, 0.30652173913044, -0.2
3914, 2.2, 0.25434782608696, -0.2
3915, 2.2, 0.20217391304348, -0.2
3916, 2.2, 1.3239130434783, -0.2
3917, 2.2, 1.2717391304348, -0.2
3918, 2.2, 1.2195652173913, -0.2
3919, 2.2, 1.1673913043478, -0.2
3920, 2.2, 1.1152173913043, -0.2
3921, 2.2, 1.0630434782609, -0.2
3922, 2.2, 1.0108695652174, -0.2
3923, 2.2, 0.95869565217391, -0.2
3924, 2.2, 0.90652173913044, -0.2
3925, 2.2, 0.85434782608696, -0.2
3926, 2.2, 0.80217391304348, -0.2
3927, 2.2, 0.75, -0.2
3928, 2.2, 0.69782608695652, -0.2
3929, 2.2, 0.64565217391304, -0.2
3930, 2.2, 0.59347826086957, -0.2
3931, 2.2, 0.54130434782609, -0.2
3932, 2.2, 0.48913043478261, -0.2
3933, 2.2, 0.43695652173913, -0.2
3934, 2.2, 0.38478260869565, -0.2
3935, 2.2, 0.33260869565217, -0.2
3936, 2.2, 0.2804347826087, -0.2
3937, 2.2, 0.22826086956522, -0.2
3938, 2.2, 0.17608695652174, -0.2
3939, 1.2434782608696, 1.35, -0.2
3940, 1.2869565217391, 1.35, -0.2
3941, 1.3304347826087, 1.35, -0.2
3942, 1.3739130434783, 1.35, -0.2
3943, 1.4173913043478, 1.35, -0.2
3944, 1.4608695652174, 1.35, -0.2
3945, 1.504347826087, 1.35, -0.2
3946, 1.5478260869565, 1.35, -0.2
3947, 1.5913043478261, 1.35, -0.2
3948, 1.6347826086957, 1.35, -0.2
3949, 1.6782608695652, 1.35, -0.2
3950, 1.7217391304348, 1.35, -0.2
3951, 1.7652173913043, 1.35, -0.2
3952, 1.8086956521739, 1.35, -0.2
3953, 1.8521739130435, 1.35, -0.2
3954, 1.895652173913, 1.35, -0.2
3955, 1.9391304347826, 1.35, -0.2
3956, 1.9826086956522, 1.35, -0.2
3957, 2.0260869565217, 1.35, -0.2
3958, 2.0695652173913, 1.35, -0.2
3959, 2.1130434782609, 1.35, -0.2
3960, 2.1565217391304, 1.35, -0.2
3961, 1.2217391304348, 1.35, -0.2
3962, 1.2652173913043, 1.35, -0.2
3963, 1.3086956521739, 1.35, -0.2
3964, 1.3521739130435, 1.35, -0.2
3965, 1.395652173913, 1.35, -0.2
3966, 1.4391304347826, 1.35, -0.2
3967, 1.4826086956522, 1.35, -0.2
3968, 1.5260869565217, 1.35, -0.2
3969, 1.5695652173913, 1.35, -0.2
3970, 1.6130434782609, 1.35, -0.2
3971, 1.6565217391304, 1.35, -0.2
3972, 1.7, 1.35, -0.2
3973, 1.7434782608696, 1.35, -0.2
3974, 1.7869565217391, 1.35, -0.2
3975, 1.8304347826087, 1.35, -0.2
3976, 1.8739130434783, 1.35, -0.2
3977, 1.9173913043478, 1.35, -0.2
3978, 1.9608695652174, 1.35, -0.2
3979, 2.004347826087, 1.35, -0.2
3980, 2.0478260869565, 1.35, -0.2
3981, 2.0913043478261, 1.35, -0.2
3982, 2.1347826086957, 1.35, -0.2
3983, 2.1782608695652, 1.35, -0.2
3984, 1.2434782608696, 0.15, -0.2
3985, 1.2869565217391, 0.15, -0.2
3986, 1.3304347826087, 0.15, -0.2
3987, 1.3739130434783, 0.15, -0.2
3988, 1.4173913043478, 0.15, -0.2
3989, 1.4608695652174, 0.15, -0.2
3990, 1.504347826087, 0.15, -0.2
3991, 1.5478260869565, 0.15, -0.2
3992, 1.5913043478261, 0.15, -0.2
3993, 1.6347826086957, 0.15, -0.2
3994, 1.6782608695652, 0.15, -0.2
3995, 1.7217391304348, 0.15, -0.2
3996, 1.7652173913043, 0.15, -0.2
3997, 1.8086956521739, 0.15, -0.2
3998, 1.8521739130435, 0.15, -0.2
3999, 1.895652173913, 0.15, -0.2
4000, 1.9391304347826, 0.15, -0.2
4001, 1.9826086956522, 0.15, -0.2
4002, 2.0260869565217, 0.15, -0.2
4003, 2.0695652173913, 0.15, -0.2
4004, 2.1130434782609, 0.15, -0.2
4005, 2.1565217391304, 0.15, -0.2
4006, 1.2217391304348, 0.15, -0.2
4007, 1.2652173913043, 0.15, -0.2
4008, 1.3086956521739, 0.15, -0.2
4009, 1.3521739130435, 0.15, -0.2
4010, 1.395652173913, 0.15, -0.2
4011, 1.4391304347826, 0.15, -0.2
4012, 1.4826086956522, 0.15, -0.2
4013, 1.5260869565217, 0.15, -0.2
4014, 1.5695652173913, 0.15, -0.2
4015, 1.6130434782609, 0.15, -0.2
4016, 1.6565217391304, 0.15, -0.2
4017, 1.7, 0.15, -0.2
4018, 1.7434782608696, 0.15, -0.2
4019, 1.7869565217391, 0.15, -0.2
4020, 1.8304347826087, 0.15, -0.2
4021, 1.8739130434783, 0.15, -0.2
4022, 1.9173913043478, 0.15, -0.2
4023, 1.9608695652174, 0.15, -0.2
4024, 2.004347826087, 0.15, -0.2
4025, 2.0478260869565, 0.15, -0.2
4026, 2.0913043478261, 0.15, -0.2
4027, 2.1347826086957, 0.15, -0.2
4028, 2.1782608695652, 0.15, -0.2
4029, 0.043478260869565, 0.15, 0.055555555555556
4030, 0.043478260869565, 0.15, 0.11111111111111
4031, 0.043478260869565, 0.15, 0.16666666666667
4032, 0.043478260869565, 0.15, 0.22222222222222
4033, 0.043478260869565, 0.15, 0.27777777777778
4034, 0.043478260869565, 0.15, 0.33333333333333
4035, 0.043478260869565, 0.15, 0.38888888888889
4036, 0.043478260869565, 0.15, 0.44444444444444
4037, 0.08695652173913, 0.15, 0.055555555555556
4038, 0.08695652173913, 0.15, 0.11111111111111
4039, 0.08695652173913, 0.15, 0.16666666666667
4040, 0.08695652173913, 0.15, 0.22222222222222
4041, 0.08695652173913, 0.15, 0.27777777777778
4042, 0.08695652173913, 0.15, 0.33333333333333
4043, 0.08695652173913, 0.15, 0.38888888888889
4044, 0.08695652173913, 0.15, 0.44444444444444
4045, 0.1304347826087, 0.15, 0.055555555555556
4046, 0.1304347826087, 0.15, 0.11111111111111
4047, 0.1304347826087, 0.15, 0.16666666666667
4048, 0.1304347826087, 0.15, 0.22222222222222
4049, 0.1304347826087, 0.15, 0.27777777777778
4050, 0.1304347826087, 0.15, 0.33333333333333
4051, 0.1304347826087, 0.15, 0.38888888888889
4052, 0.1304347826087, 0.15, 0.44444444444444
4053, 0.17391304347826, 0.15, 0.055555555555556
4054, 0.17391304347826, 0.15, 0.11111111111111
4055, 0.17391304347826, 0.15, 0.16666666666667
4056, 0.17391304347826, 0.15, 0.22222222222222
4057, 0.17391304347826, 0.15, 0.27777777777778
4058, 0.17391304347826, 0.15, 0.33333333333333
4059, 0.17391304347826, 0.15, 0.38888888888889
4060, 0.17391304347826, 0.15, 0.44444444444444
4061, 0.21739130434783, 0.15, 0.055555555555556
4062, 0.21739130434783, 0.15, 0.11111111111111
4063, 0.21739130434783, 0.15, 0.16666666666667
4064, 0.21739130434783, 0.15, 0.22222222222222
4065, 0.21739130434783, 0.15, 0.27777777777778
4066, 0.21739130434783, 0.15, 0.33333333333333
4067, 0.21739130434783, 0.15, 0.38888888888889
4068, 0.21739130434783, 0.15, 0.44444444444444
4069, 0.26086956521739, 0.15, 0.055555555555556
4070, 0.26086956521739, 0.15, 0.11111111111111
4071, 0.26086956521739, 0.15, 0.16666666666667
4072, 0.26086956521739, 0.15, 0.22222222222222
4073, 0.26086956521739, 0.15, 0.27777777777778
4074, 0.26086956521739, 0.15, 0.33333333333333
4075, 0.26086956521739, 0.15, 0.38888888888889
4076, 0.26086956521739, 0.15, 0.44444444444444
4077, 0.30434782608696, 0.15, 0.055555555555556
4078, 0.30434782608696, 0.15, 0.11111111111111
4079, 0.30434782608696, 0.15, 0.16666666666667
4080, 0.30434782608696, 0.15, 0.22222222222222
4081, 0.30434782608696, 0.15, 0.27777777777778
4082, 0.30434782608696, 0.15, 0.33333333333333
4083, 0.30434782608696, 0.15, 0.38888888888889
4084, 0.30434782608696, 0.15, 0.44444444444444
4085, 0.34782608695652, 0.15, 0.055555555555556
4086, 0.34782608695652, 0.15, 0.11111111111111
4087, 0.34782608695652, 0.15, 0.16666666666667
4088, 0.34782608695652, 0.15, 0.22222222222222
4089, 0.34782608695652, 0.15, 0.27777777777778
4090, 0.34782608695652, 0.15, 0.33333333333333
4091, 0.34782608695652, 0.15, 0.38888888888889
4092, 0.34782608695652, 0.15, 0.44444444444444
4093, 0.39130434782609, 0.15, 0.055555555555556
4094, 0.39130434782609, 0.15, 0.11111111111111
4095, 0.39130434782609, 0.15, 0.16666666666667
4096, 0.39130434782609, 0.15, 0.22222222222222
4097, 0.39130434782609, 0.15, 0.27777777777778
4098, 0.39130434782609, 0.15, 0.33333333333333
4099, 0.39130434782609, 0.15, 0.38888888888889
4100, 0.39130434782609, 0.15, 0.44444444444444
4101, 0.43478260869565, 0.15, 0.055555555555556
4102, 0.43478260869565, 0.15, 0.11111111111111
4103, 0.43478260869565, 0.15, 0.16666666666667
4104, 0.43478260869565, 0.15, 0.22222222222222
4105, 0.43478260869565, 0.15, 0.27777777777778
4106, 0.43478260869565, 0.15, 0.33333333333333
4107, 0.43478260869565, 0.15, 0.38888888888889
4108, 0.43478260869565, 0.15, 0.44444444444444
4109, 0.47826086956522, 0.15, 0.055555555555556
4110, 0.47826086956522, 0.15, 0.11111111111111
4111, 0.47826086956522, 0.15, 0.16666666666667
4112, 0.47826086956522, 0.15, 0.22222222222222
4113, 0.47826086956522, 0.15, 0.27777777777778
4114, 0.47826086956522, 0.15, 0.33333333333333
4115, 0.47826086956522, 0.15, 0.38888888888889
4116, 0.47826086956522, 0.15, 0.44444444444444
4117, 0.52173913043478, 0.15, 0.055555555555556
4118, 0.52173913043478, 0.15, 0.11111111111111
4119, 0.52173913043478, 0.15, 0.16666666666667
4120, 0.52173913043478, 0.15, 0.22222222222222
4121, 0.52173913043478, 0.15, 0.27777777777778
4122, 0.52173913043478, 0.15, 0.33333333333333
4123, 0.52173913043478, 0.15, 0.38888888888889
4124, 0.52173913043478, 0.15, 0.44444444444444
4125, 0.56521739130435, 0.15, 0.055555555555556
4126, 0.56521739130435, 0.15, 0.11111111111111
4127, 0.56521739130435, 0.15, 0.16666666666667
4128, 0.56521739130435, 0.15, 0.22222222222222
4129, 0.56521739130435, 0.15, 0.27777777777778
4130, 0.56521739130435, 0.15, 0.33333333333333
4131, 0.56521739130435, 0.15, 0.38888888888889
4132, 0.56521739130435, 0.15, 0.44444444444444
4133, 0.60869565217391, 0.15, 0.055555555555556
4134, 0.60869565217391, 0.15, 0.11111111111111
4135, 0.60869565217391, 0.15, 0.16666666666667
4136, 0.60869565217391, 0.15, 0.22222222222222
4137, 0.60869565217391, 0.15, 0.27777777777778
4138, 0.60869565217391, 0.15, 0.33333333333333
4139, 0.60869565217391, 0.15, 0.38888888888889
4140, 0.60869565217391, 0.15, 0.44444444444444
4141, 0.65217391304348, 0.15, 0.055555555555556
4142, 0.65217391304348, 0.15, 0.11111111111111
4143, 0.65217391304348, 0.15, 0.16666666666667
4144, 0.65217391304348, 0.15, 0.22222222222222
4145, 0.65217391304348, 0.15, 0.27777777777778
4146, 0.65217391304348, 0.15, 0.33333333333333
4147, 0.65217391304348, 0.15, 0.38888888888889
4148, 0.65217391304348, 0.15, 0.44444444444444
4149, 0.69565217391304, 0.15, 0.055555555555556
4150, 0.69565217391304, 0.15, 0.11111111111111
4151, 0.69565217391304, 0.15, 0.16666666666667
4152, 0.69565217391304, 0.15, 0.22222222222222
4153, 0.69565217391304, 0.15, 0.27777777777778
4154, 0.69565217391304, 0.15, 0.33333333333333
4155, 0.69565217391304, 0.15, 0.38888888888889
4156, 0.69565217391304, 0.15, 0.44444444444444
4157, 0.73913043478261, 0.15, 0.055555555555556
4158, 0.73913043478261, 0.15, 0.11111111111111
4159, 0.73913043478261, 0.15, 0.16666666666667
4160, 0.73913043478261, 0.15, 0.22222222222222
4161, 0.73913043478261, 0.15, 0.27777777777778
4162, 0.73913043478261, 0.15, 0.33333333333333
4163, 0.73913043478261, 0.15, 0.38888888888889
4164, 0.73913043478261, 0.15, 0.44444444444444
4165, 0.78260869565217, 0.15, 0.055555555555556
4166, 0.78260869565217, 0.15, 0.11111111111111
4167, 0.78260869565217, 0.15, 0.16666666666667
4168, 0.78260869565217, 0.15, 0.22222222222222
4169, 0.78260869565217, 0.15, 0.27777777777778
4170, 0.78260869565217, 0.15, 0.33333333333333
4171, 0.78260869565217, 0.15, 0.38888888888889
4172, 0.78260869565217, 0.15, 0.44444444444444
4173, 0.82608695652174, 0.15, 0.055555555555556
4174, 0.82608695652174, 0.15, 0.11111111111111
4175, 0.82608695652174, 0.15, 0.16666666666667
4176, 0.82608695652174, 0.15, 0.22222222222222
4177, 0.82608695652174, 0.15, 0.27777777777778
4178, 0.82608695652174, 0.15, 0.33333333333333
4179, 0.82608695652174, 0.15, 0.38888888888889
4180, 0.82608695652174, 0.15, 0.44444444444444
4181, 0.8695652173913, 0.15, 0.055555555555556
4182, 0.8695652173913, 0.15, 0.11111111111111
4183, 0.8695652173913, 0.15, 0.16666666666667
4184, 0.8695652173913, 0.15, 0.22222222222222
4185, 0.8695652173913, 0.15, 0.27777777777778
4186, 0.8695652173913, 0.15, 0.33333333333333
4187, 0.8695652173913, 0.15, 0.38888888888889
4188, 0.8695652173913, 0.15, 0.44444444444444
4189, 0.91304347826087, 0.15, 0.055555555555556
4190, 0.91304347826087, 0.15, 0.11111111111111
4191, 0.91304347826087, 0.15, 0.16666666666667
4192, 0.91304347826087, 0.15, 0.22222222222222
4193, 0.91304347826087, 0.15, 0.27777777777778
4194, 0.91304347826087, 0.15, 0.33333333333333
4195, 0.91304347826087, 0.15, 0.38888888888889
4196, 0.91304347826087, 0.15, 0.44444444444444
4197, 0.95652173913043, 0.15, 0.055555555555556
4198, 0.95652173913043, 0.15, 0.11111111111111
4199, 0.95652173913043, 0.15, 0.16666666666667
4200, 0.95652173913043, 0.15, 0.22222222222222
4201, 0.95652173913043, 0.15, 0.27777777777778
4202, 0.95652173913043, 0.15, 0.33333333333333
4203, 0.95652173913043, 0.15, 0.38888888888889
4204, 0.95652173913043, 0.15, 0.44444444444444
4205, 0.021739130434783, 0.15, 0.055555555555556
4206, 0.043478260869565, 0.15, 0.027777777777778
4207, 0.021739130434783, 0.15, 0.11111111111111
4208, 0.043478260869565, 0.15, 0.083333333333333
4209, 0.021739130434783, 0.15, 0.16666666666667
4210, 0.043478260869565, 0.15, 0.13888888888889
4211, 0.021739130434783, 0.15, 0.22222222222222
4212, 0.043478260869565, 0.15, 0.19444444444444
4213, 0.021739130434783, 0.15, 0.27777777777778
4214, 0.043478260869565, 0.15, 0.25
4215, 0.021739130434783, 0.15, 0.33333333333333
4216, 0.043478260869565, 0.15, 0.30555555555556
4217, 0.021739130434783, 0.15, 0.38888888888889
4218, 0.043478260869565, 0.15, 0.36111111111111
4219, 0.021739130434783, 0.15, 0.44444444444444
4220, 0.043478260869565, 0.15, 0.41666666666667
4221, 0.043478260869565, 0.15, 0.47222222222222
4222, 0.065217391304348, 0.15, 0.055555555555556
4223, 0.08695652173913, 0.15, 0.027777777777778
4224, 0.065217391304348, 0.15, 0.11111111111111
4225, 0.08695652173913, 0.15, 0.083333333333333
4226, 0.065217391304348, 0.15, 0.16666666666667
4227, 0.08695652173913, 0.15, 0.13888888888889
4228, 0.065217391304348, 0.15, 0.22222222222222
4229, 0.08695652173913, 0.15, 0.19444444444444
4230, 0.065217391304348, 0.15, 0.27777777777778
4231, 0.08695652173913, 0.15, 0.25
4232, 0.065217391304348, 0.15, 0.33333333333333
4233, 0.08695652173913, 0.15, 0.30555555555556
4234, 0.065217391304348, 0.15, 0.38888888888889
4235, 0.08695652173913, 0.15, 0.36111111111111
4236, 0.065217391304348, 0.15, 0.44444444444444
4237, 0.08695652173913, 0.15, 0.41666666666667
4238, 0.08695652173913, 0.15, 0.47222222222222
4239, 0.10869565217391, 0.15, 0.055555555555556
4240, 0.1304347826087, 0.15, 0.027777777777778
4241, 0.10869565217391, 0.15, 0.11111111111111
4242, 0.1304347826087, 0.15, 0.083333333333333
4243, 0.10869565217391, 0.15, 0.16666666666667
4244, 0.1304347826087, 0.15, 0.13888888888889
4245, 0.10869565217391, 0.15, 0.22222222222222
4246, 0.1304347826087, 0.15, 0.19444444444444
4247, 0.10869565217391, 0.15, 0.27777777777778
4248, 0.1304347826087, 0.15, 0.25
4249, 0.10869565217391, 0.15, 0.33333333333333
4250, 0.1304347826087, 0.15, 0.30555555555556
4251, 0.10869565217391, 0.15, 0.38888888888889
4252, 0.1304347826087, 0.15, 0.36111111111111
4253, 0.10869565217391, 0.15, 0.44444444444444
4254, 0.1304347826087, 0.15, 0.41666666666667
4255, 0.1304347826087, 0.15, 0.47222222222222
4256, 0.15217391304348, 0.15, 0.055555555555556
4257, 0.17391304347826, 0.15, 0.027777777777778
4258, 0.15217391304348, 0.15, 0.11111111111111
4259, 0.17391304347826, 0.15, 0.083333333333333
4260, 0.15217391304348, 0.15, 0.16666666666667
4261, 0.17391304347826, 0.15, 0.13888888888889
4262, 0.15217391304348, 0.15, 0.22222222222222
4263, 0.17391304347826, 0.15, 0.19444444444444
4264, 0.15217391304348, 0.15, 0.27777777777778
4265, 0.17391304347826, 0.15, 0.25
4266, 0.15217391304348, 0.15, 0.33333333333333
4267, 0.17391304347826, 0.15, 0.30555555555556
4268, 0.15217391304348, 0.15, 0.38888888888889
4269, 0.17391304347826, 0.15, 0.36111111111111
4270, 0.15217391304348, 0.15, 0.44444444444444
4271, 0.17391304347826, 0.15, 0.41666666666667
4272, 0.17391304347826, 0.15, 0.47222222222222
4273, 0.19565217391304, 0.15, 0.055555555555556
4274, 0.21739130434783, 0.15, 0.027777777777778
4275, 0.19565217391304, 0.15, 0.11111111111111
4276, 0.21739130434783, 0.15, 0.083333333333333
4277, 0.19565217391304, 0.15, 0.16666666666667
4278, 0.21739130434783, 0.15, 0.13888888888889
4279, 0.19565217391304, 0.15, 0.22222222222222
4280, 0.21739130434783, 0.15, 0.19444444444444
4281, 0.19565217391304, 0.15, 0.27777777777778
4282, 0.21739130434783, 0.15, 0.25
4283, 0.19565217391304, 0.15, 0.33333333333333
4284, 0.21739130434783, 0.15, 0.30555555555556
4285, 0.19565217391304, 0.15, 0.38888888888889
4286, 0.21739130434783, 0.15, 0.36111111111111
4287, 0.19565217391304, 0.15, 0.44444444444444
4288, 0.21739130434783, 0.15, 0.41666666666667
4289, 0.21739130434783, 0.15, 0.47222222222222
4290, 0.23913043478261, 0.15, 0.055555555555556
4291, 0.26086956521739, 0.15, 0.027777777777778
4292, 0.23913043478261, 0.15, 0.11111111111111
4293, 0.26086956521739, 0.15, 0.083333333333333
4294, 0.23913043478261, 0.15, 0.16666666666667
4295, 0.26086956521739, 0.15, 0.13888888888889
4296, 0.23913043478261, 0.15, 0.22222222222222
4297, 0.26086956521739, 0.15, 0.19444444444444
4298, 0.23913043478261, 0.15, 0.27777777777778
4299, 0.26086956521739, 0.15, 0.25
4300, 0.23913043478261, 0.15, 0.33333333333333
4301, 0.26086956521739, 0.15, 0.30555555555556
4302, 0.23913043478261, 0.15, 0.38888888888889
4303, 0.26086956521739, 0.15, 0.36111111111111
4304, 0.23913043478261, 0.15, 0.44444444444444
4305, 0.26086956521739, 0.15, 0.41666666666667
4306, 0.26086956521739, 0.15, 0.47222222222222
4307, 0.28260869565217, 0.15, 0.055555555555556
4308, 0.30434782608696, 0.15, 0.027777777777778
4309, 0.28260869565217, 0.15, 0.11111111111111
4310, 0.30434782608696, 0.15, 0.083333333333333
4311, 0.28260869565217, 0.15, 0.16666666666667
4312, 0.30434782608696, 0.15, 0.13888888888889
4313, 0.28260869565217, 0.15, 0.22222222222222
4314, 0.30434782608696, 0.15, 0.19444444444444
4315, 0.28260869565217, 0.15, 0.27777777777778
4316, 0.30434782608696, 0.15, 0.25
4317, 0.28260869565217, 0.15, 0.33333333333333
4318, 0.30434782608696, 0.15, 0.30555555555556
4319, 0.28260869565217, 0.15, 0.38888888888889
4320, 0.30434782608696, 0.15, 0.36111111111111
4321, 0.28260869565217, 0.15, 0.44444444444444
4322, 0.30434782608696, 0.15, 0.41666666666667
4323, 0.30434782608696, 0.15, 0.47222222222222
4324, 0.32608695652174, 0.15, 0.055555555555556
4325, 0.34782608695652, 0.15, 0.027777777777778
4326, 0.32608695652174, 0.15, 0.11111111111111
4327, 0.34782608695652, 0.15, 0.083333333333333
4328, 0.32608695652174, 0.15, 0.16666666666667
4329, 0.34782608695652, 0.15, 0.13888888888889
4330, 0.32608695652174, 0.15, 0.22222222222222
4331, 0.34782608695652, 0.15, 0.19444444444444
4332, 0.32608695652174, 0.15, 0.27777777777778
4333, 0.34782608695652, 0.15, 0.25
4334, 0.32608695652174, 0.15, 0.33333333333333
4335, 0.34782608695652, 0.15, 0.30555555555556
4336, 0.32608695652174, 0.15, 0.38888888888889
4337, 0.34782608695652, 0.15, 0.36111111111111
4338, 0.32608695652174, 0.15, 0.44444444444444
4339, 0.34782608695652, 0.15, 0.41666666666667
4340, 0.34782608695652, 0.15, 0.47222222222222
4341, 0.3695652173913, 0.15, 0.055555555555556
4342, 0.39130434782609, 0.15, 0.027777777777778
4343, 0.3695652173913, 0.15, 0.11111111111111
4344, 0.39130434782609, 0.15, 0.083333333333333
4345, 0.3695652173913, 0.15, 0.16666666666667
4346, 0.39130434782609, 0.15, 0.13888888888889
4347, 0.3695652173913, 0.15, 0.22222222222222
4348, 0.39130434782609, 0.15, 0.19444444444444
4349, 0.3695652173913, 0.15, 0.27777777777778
4350, 0.39130434782609, 0.15, 0.25
4351, 0.3695652173913, 0.15, 0.33333333333333
4352, 0.39130434782609, 0.15, 0.30555555555556
4353, 0.3695652173913, 0.15, 0.38888888888889
4354, 0.39130434782609, 0.15, 0.36111111111111
4355, 0.3695652173913, 0.15, 0.44444444444444
4356, 0.39130434782609, 0.15, 0.41666666666667
4357, 0.39130434782609, 0.15, 0.47222222222222
4358, 0.41304347826087, 0.15, 0.055555555555556
4359, 0.43478260869565, 0.15, 0.027777777777778
4360, 0.41304347826087, 0.15, 0.11111111111111
4361, 0.43478260869565, 0.15, 0.083333333333333
4362, 0.41304347826087, 0.15, 0.16666666666667
4363, 0.43478260869565, 0.15, 0.13888888888889
4364, 0.41304347826087, 0.15, 0.22222222222222
4365, 0.43478260869565, 0.15, 0.19444444444444
4366, 0.41304347826087, 0.15, 0.27777777777778
4367, 0.43478260869565, 0.15, 0.25
4368, 0.41304347826087, 0.15, 0.33333333333333
4369, 0.43478260869565, 0.15, 0.30555555555556
4370, 0.41304347826087, 0.15, 0.38888888888889
4371, 0.43478260869565, 0.15, 0.36111111111111
4372, 0.41304347826087, 0.15, 0.44444444444444
4373, 0.43478260869565, 0.15, 0.41666666666667
4374, 0.43478260869565, 0.15, 0.47222222222222
4375, 0.45652173913043, 0.15, 0.055555555555556
4376, 0.47826086956522, 0.15, 0.027777777777778
4377, 0.45652173913043, 0.15, 0.11111111111111
4378, 0.47826086956522, 0.15, 0.083333333333333
4379, 0.45652173913043, 0.15, 0.16666666666667
4380, 0.47826086956522, 0.15, 0.13888888888889
4381, 0.45652173913043, 0.15, 0.22222222222222
4382, 0.47826086956522, 0.15, 0.19444444444444
4383, 0.45652173913043, 0.15, 0.27777777777778
4384, 0.47826086956522, 0.15, 0.25
4385, 0.45652173913043, 0.15, 0.33333333333333
4386, 0.47826086956522, 0.15, 0.30555555555556
4387, 0.45652173913043, 0.15, 0.38888888888889
4388, 0.47826086956522, 0.15, 0.36111111111111
4389, 0.45652173913043, 0.15, 0.44444444444444
4390, 0.47826086956522, 0.15, 0.41666666666667
4391, 0.47826086956522, 0.15, 0.47222222222222
4392, 0.5, 0.15, 0.055555555555556
4393, 0.52173913043478, 0.15, 0.027777777777778
4394, 0.5, 0.15, 0.11111111111111
4395, 0.52173913043478, 0.15, 0.083333333333333
4396, 0.5, 0.15, 0.16666666666667
4397, 0.52173913043478, 0.15, 0.13888888888889
4398, 0.5, 0.15, 0.22222222222222
4399, 0.52173913043478, 0.15, 0.19444444444444
4400, 0.5, 0.15, 0.27777777777778
4401, 0.52173913043478, 0.15, 0.25
4402, 0.5, 0.15, 0.33333333333333
4403, 0.52173913043478, 0.15, 0.30555555555556
4404, 0.5, 0.15, 0.38888888888889
4405, 0.52173913043478, 0.15, 0.36111111111111
4406, 0.5, 0.15, 0.44444444444444
4407, 0.52173913043478, 0.15, 0.41666666666667
4408, 0.52173913043478, 0.15, 0.47222222222222
4409, 0.54347826086957, 0.15, 0.055555555555556
4410, 0.56521739130435, 0.15, 0.027777777777778
4411, 0.54347826086957, 0.15, 0.11111111111111
4412, 0.56521739130435, 0.15, 0.083333333333333
4413, 0.54347826086957, 0.15, 0.16666666666667
4414, 0.56521739130435, 0.15, 0.13888888888889
4415, 0.54347826086957, 0.15, 0.22222222222222
4416, 0.56521739130435, 0.15, 0.19444444444444
4417, 0.54347826086957, 0.15, 0.27777777777778
4418, 0.56521739130435, 0.15, 0.25
4419, 0.54347826086957, 0.15, 0.33333333333333
4420, 0.56521739130435, 0.15, 0.30555555555556
4421, 0.54347826086957, 0.15, 0.38888888888889
4422, 0.56521739130435, 0.15, 0.36111111111111
4423, 0.54347826086957, 0.15, 0.44444444444444
4424, 0.56521739130435, 0.15, 0.41666666666667
4425, 0.56521739130435, 0.15, 0.47222222222222
4426, 0.58695652173913, 0.15, 0.055555555555556
4427, 0.60869565217391, 0.15, 0.027777777777778
4428, 0.58695652173913, 0.15, 0.11111111111111
4429, 0.60869565217391, 0.15, 0.083333333333333
4430, 0.58695652173913, 0.15, 0.16666666666667
4431, 0.60869565217391, 0.15, 0.13888888888889
4432, 0.58695652173913, 0.15, 0.22222222222222
4433, 0.60869565217391, 0.15, 0.19444444444444
4434, 0.58695652173913, 0.15, 0.27777777777778
4435, 0.60869565217391, 0.15, 0.25
4436, 0.58695652173913, 0.15, 0.33333333333333
4437, 0.60869565217391, 0.15, 0.30555555555556
4438, 0.58695652173913, 0.15, 0.38888888888889
4439, 0.60869565217391, 0.15, 0.36111111111111
4440, 0.58695652173913, 0.15, 0.44444444444444
4441, 0.60869565217391, 0.15, 0.41666666666667
4442, 0.60869565217391, 0.15, 0.47222222222222
4443, 0.6304347826087, 0.15, 0.055555555555556
4444, 0.65217391304348, 0.15, 0.027777777777778
4445, 0.6304347826087, 0.15, 0.11111111111111
4446, 0.65217391304348, 0.15, 0.083333333333333
4447, 0.6304347826087, 0.15, 0.16666666666667
4448, 0.65217391304348, 0.15, 0.13888888888889
4449, 0.6304347826087, 0.15, 0.22222222222222
4450, 0.65217391304348, 0.15, 0.19444444444444
4451, 0.6304347826087, 0.15, 0.27777777777778
4452, 0.65217391304348, 0.15, 0.25
4453, 0.6304347826087, 0.15, 0.33333333333333
4454, 0.65217391304348, 0.15, 0.30555555555556
4455, 0.6304347826087, 0.15, 0.38888888888889
4456, 0.65217391304348, 0.15, 0.36111111111111
4457, 0.6304347826087, 0.15, 0.44444444444444
4458, 0.65217391304348, 0.15, 0.41666666666667
4459, 0.65217391304348, 0.15, 0.47222222222222
4460, 0.67391304347826, 0.15, 0.055555555555556
4461, 0.69565217391304, 0.15, 0.027777777777778
4462, 0.67391304347826, 0.15, 0.11111111111111
4463, 0.69565217391304, 0.15, 0.083333333333333
4464, 0.67391304347826, 0.15, 0.16666666666667
4465, 0.69565217391304, 0.15, 0.13888888888889
4466, 0.67391304347826, 0.15, 0.22222222222222
4467, 0.69565217391304, 0.15, 0.19444444444444
4468, 0.67391304347826, 0.15, 0.27777777777778
4469, 0.69565217391304, 0.15, 0.25
4470, 0.67391304347826, 0.15, 0.33333333333333
4471, 0.69565217391304, 0.15, 0.30555555555556
4472, 0.67391304347826, 0.15, 0.38888888888889
4473, 0.69565217391304, 0.15, 0.36111111111111
4474, 0.67391304347826, 0.15, 0.44444444444444
4475, 0.69565217391304, 0.15, 0.41666666666667
4476, 0.69565217391304, 0.15, 0.47222222222222
4477, 0.71739130434783, 0.15, 0.055555555555556
4478, 0.73913043478261, 0.15, 0.027777777777778
4479, 0.71739130434783, 0.15, 0.11111111111111
4480, 0.73913043478261, 0.15, 0.083333333333333
4481, 0.71739130434783, 0.15, 0.16666666666667
4482, 0.73913043478261, 0.15, 0.13888888888889
4483, 0.71739130434783, 0.15, 0.22222222222222
4484, 0.73913043478261, 0.15, 0.19444444444444
4485, 0.71739130434783, 0.15, 0.27777777777778
4486, 0.73913043478261, 0.15, 0.25
4487, 0.71739130434783, 0.15, 0.33333333333333
4488, 0.73913043478261, 0.15, 0.30555555555556
4489, 0.71739130434783, 0.15, 0.38888888888889
4490, 0.73913043478261, 0.15, 0.36111111111111
4491, 0.71739130434783, 0.15, 0.44444444444444
4492, 0.73913043478261, 0.15, 0.41666666666667
4493, 0.73913043478261, 0.15, 0.47222222222222
4494, 0.76086956521739, 0.15, 0.055555555555556
4495, 0.78260869565217, 0.15, 0.027777777777778
4496, 0.76086956521739, 0.15, 0.11111111111111
4497, 0.78260869565217, 0.15, 0.083333333333333
4498, 0.76086956521739, 0.15, 0.16666666666667
4499, 0.78260869565217, 0.15, 0.13888888888889
4500, 0.76086956521739, 0.15, 0.22222222222222
4501, 0.78260869565217, 0.15, 0.19444444444444
4502, 0.76086956521739, 0.15, 0.27777777777778
4503, 0.78260869565217, 0.15, 0.25
4504, 0.76086956521739, 0.15, 0.33333333333333
4505, 0.78260869565217, 0.15, 0.30555555555556
4506, 0.76086956521739, 0.15, 0.38888888888889
4507, 0.78260869565217, 0.15, 0.36111111111111
4508, 0.76086956521739, 0.15, 0.44444444444444
4509, 0.78260869565217, 0.15, 0.41666666666667
4510, 0.78260869565217, 0.15, 0.47222222222222
4511, 0.80434782608696, 0.15, 0.055555555555556
4512, 0.82608695652174, 0.15, 0.027777777777778
4513, 0.80434782608696, 0.15, 0.11111111111111
4514, 0.82608695652174, 0.15, 0.083333333333333
4515, 0.80434782608696, 0.15, 0.16666666666667
4516, 0.82608695652174, 0.15, 0.13888888888889
4517, 0.80434782608696, 0.15, 0.22222222222222
4518, 0.82608695652174, 0.15, 0.19444444444444
4519, 0.80434782608696, 0.15, 0.27777777777778
4520, 0.82608695652174, 0.15, 0.25
4521, 0.80434782608696, 0.15, 0.33333333333333
4522, 0.82608695652174, 0.15, 0.30555555555556
4523, 0.80434782608696, 0.15, 0.38888888888889
4524, 0.82608695652174, 0.15, 0.36111111111111
4525, 0.80434782608696, 0.15, 0.44444444444444
4526, 0.82608695652174, 0.15, 0.41666666666667
4527, 0.82608695652174, 0.15, 0.47222222222222
4528, 0.84782608695652, 0.15, 0.055555555555556
4529, 0.8695652173913, 0.15, 0.027777777777778
4530, 0.84782608695652, 0.15, 0.11111111111111
4531, 0.8695652173913, 0.15, 0.083333333333333
4532, 0.84782608695652, 0.15, 0.16666666666667
4533, 0.8695652173913, 0.15, 0.13888888888889
4534, 0.84782608695652, 0.15, 0.22222222222222
4535, 0.8695652173913, 0.15, 0.19444444444444
4536, 0.84782608695652, 0.15, 0.27777777777778
4537, 0.8695652173913, 0.15, 0.25
4538, 0.84782608695652, 0.15, 0.33333333333333
4539, 0.8695652173913, 0.15, 0.30555555555556
4540, 0.84782608695652, 0.15, 0.38888888888889
4541, 0.8695652173913, 0.15, 0.36111111111111
4542, 0.84782608695652, 0.15, 0.44444444444444
4543, 0.8695652173913, 0.15, 0.41666666666667
4544, 0.8695652173913, 0.15, 0.47222222222222
4545, 0.89130434782609, 0.15, 0.055555555555556
4546, 0.91304347826087, 0.15, 0.027777777777778
4547, 0.89130434782609, 0.15, 0.11111111111111
4548, 0.91304347826087, 0.15, 0.083333333333333
4549, 0.89130434782609, 0.15, 0.16666666666667
4550, 0.91304347826087, 0.15, 0.13888888888889
4551, 0.89130434782609, 0.15, 0.22222222222222
4552, 0.91304347826087, 0.15, 0.19444444444444
4553, 0.89130434782609, 0.15, 0.27777777777778
4554, 0.91304347826087, 0.15, 0.25
4555, 0.89130434782609, 0.15, 0.33333333333333
4556, 0.91304347826087, 0.15, 0.30555555555556
4557, 0.89130434782609, 0.15, 0.38888888888889
4558, 0.91304347826087, 0.15, 0.36111111111111
4559, 0.89130434782609, 0.15, 0.44444444444444
4560, 0.91304347826087, 0.15, 0.41666666666667
4561, 0.91304347826087, 0.15, 0.47222222222222
4562, 0.93478260869565, 0.15, 0.055555555555556
4563, 0.95652173913043, 0.15, 0.027777777777778
4564, 0.93478260869565, 0.15, 0.11111111111111
4565, 0.95652173913043, 0.15, 0.083333333333333
4566, 0.93478260869565, 0.15, 0.16666666666667
4567, 0.95652173913043, 0.15, 0.13888888888889
4568, 0.93478260869565, 0.15, 0.22222222222222
4569, 0.95652173913043, 0.15, 0.19444444444444
4570, 0.93478260869565, 0.15, 0.27777777777778
4571, 0.95652173913043, 0.15, 0.25
4572, 0.93478260869565, 0.15, 0.33333333333333
4573, 0.95652173913043, 0.15, 0.30555555555556
4574, 0.93478260869565, 0.15, 0.38888888888889
4575, 0.95652173913043, 0.15, 0.36111111111111
4576, 0.93478260869565, 0.15, 0.44444444444444
4577, 0.95652173913043, 0.15, 0.41666666666667
4578, 0.95652173913043, 0.15, 0.47222222222222
4579, 0.97826086956522, 0.15, 0.055555555555556
4580, 0.97826086956522, 0.15, 0.11111111111111
4581, 0.97826086956522, 0.15, 0.16666666666667
4582, 0.97826086956522, 0.15, 0.22222222222222
4583, 0.97826086956522, 0.15, 0.27777777777778
4584, 0.97826086956522, 0.15, 0.33333333333333
4585, 0.97826086956522, 0.15, 0.38888888888889
4586, 0.97826086956522, 0.15, 0.44444444444444
4587, 1.2434782608696, 0.15, 0.44444444444444
4588, 1.2434782608696, 0.15, 0.38888888888889
4589, 1.2434782608696, 0.15, 0.33333333333333
4590, 1.2434782608696, 0.15, 0.27777777777778
4591, 1.2434782608696, 0.15, 0.22222222222222
4592, 1.2434782608696, 0.15, 0.16666666666667
4593, 1.2434782608696, 0.15, 0.11111111111111
4594, 1.2434782608696, 0.15, 0.055555555555556
4595, 1.2869565217391, 0.15, 0.44444444444444
4596, 1.2869565217391, 0.15, 0.38888888888889
4597, 1.2869565217391, 0.15, 0.33333333333333
4598, 1.2869565217391, 0.15, 0.27777777777778
4599, 1.2869565217391, 0.15, 0.22222222222222
4600, 1.2869565217391, 0.15, 0.16666666666667
4601, 1.2869565217391, 0.15, 0.11111111111111
4602, 1.2869565217391, 0.15, 0.055555555555556
4603, 1.3304347826087, 0.15, 0.44444444444444
4604, 1.3304347826087, 0.15, 0.38888888888889
4605, 1.3304347826087, 0.15, 0.33333333333333
4606, 1.3304347826087, 0.15, 0.27777777777778
4607, 1.3304347826087, 0.15, 0.22222222222222
4608, 1.3304347826087, 0.15, 0.16666666666667
4609, 1.3304347826087, 0.15, 0.11111111111111
4610, 1.3304347826087, 0.15, 0.055555555555556
4611, 1.3739130434783, 0.15, 0.44444444444444
4612, 1.3739130434783, 0.15, 0.38888888888889
4613, 1.3739130434783, 0.15, 0.33333333333333
4614, 1.3739130434783, 0.15, 0.27777777777778
4615, 1.3739130434783, 0.15, 0.22222222222222
4616, 1.3739130434783, 0.15, 0.16666666666667
4617, 1.3739130434783, 0.15, 0.11111111111111
4618, 1.3739130434783, 0.15, 0.055555555555556
4619, 1.4173913043478, 0.15, 0.44444444444444
4620, 1.4173913043478, 0.15, 0.38888888888889
4621, 1.4173913043478, 0.15, 0.33333333333333
4622, 1.4173913043478, 0.15, 0.27777777777778
4623, 1.4173913043478, 0.15, 0.22222222222222
4624, 1.4173913043478, 0.15, 0.16666666666667
4625, 1.4173913043478, 0.15, 0.11111111111111
4626, 1.4173913043478, 0.15, 0.055555555555556
4627, 1.4608695652174, 0.15, 0.44444444444444
4628, 1.4608695652174, 0.15, 0.38888888888889
4629, 1.4608695652174, 0.15, 0.33333333333333
4630, 1.4608695652174, 0.15, 0.27777777777778
4631, 1.4608695652174, 0.15, 0.22222222222222
4632, 1.4608695652174, 0.15, 0.16666666666667
4633, 1.4608695652174, 0.15, 0.11111111111111
4634, 1.4608695652174, 0.15, 0.055555555555556
4635, 1.504347826087, 0.15, 0.44444444444444
4636, 1.504347826087, 0.15, 0.38888888888889
4637, 1.504347826087, 0.15, 0.33333333333333
4638, 1.504347826087, 0.15, 0.27777777777778
4639, 1.504347826087, 0.15, 0.22222222222222
4640, 1.504347826087, 0.15, 0.16666666666667
4641, 1.504347826087, 0.15, 0.11111111111111
4642, 1.504347826087, 0.15, 0.055555555555556
4643, 1.5478260869565, 0.15, 0.44444444444444
4644, 1.5478260869565, 0.15, 0.38888888888889
4645, 1.5478260869565, 0.15, 0.33333333333333
4646, 1.5478260869565, 0.15, 0.27777777777778
4647, 1.5478260869565, 0.15, 0.22222222222222
4648, 1.5478260869565, 0.15, 0.16666666666667
4649, 1.5478260869565, 0.15, 0.11111111111111
4650, 1.5478260869565, 0.15, 0.055555555555556
4651, 1.5913043478261, 0.15, 0.44444444444444
4652, 1.5913043478261, 0.15, 0.38888888888889
4653, 1.5913043478261, 0.15, 0.33333333333333
4654, 1.5913043478261, 0.15, 0.27777777777778
4655, 1.5913043478261, 0.15, 0.22222222222222
4656, 1.5913043478261, 0.15, 0.16666666666667
4657, 1.5913043478261, 0.15, 0.11111111111111
4658, 1.5913043478261, 0.15, 0.055555555555556
4659, 1.6347826086957, 0.15, 0.44444444444444
4660, 1.6347826086957, 0.15, 0.38888888888889
4661, 1.6347826086957, 0.15, 0.33333333333333
4662, 1.6347826086957, 0.15, 0.27777777777778
4663, 1.6347826086957, 0.15, 0.22222222222222
4664, 1.6347826086957, 0.15, 0.16666666666667
4665, 1.6347826086957, 0.15, 0.11111111111111
4666, 1.6347826086957, 0.15, 0.055555555555556
4667, 1.6782608695652, 0.15, 0.44444444444444
4668, 1.6782608695652, 0.15, 0.38888888888889
4669, 1.6782608695652, 0.15, 0.33333333333333
4670, 1.6782608695652, 0.15, 0.27777777777778
4671, 1.6782608695652, 0.15, 0.22222222222222
4672, 1.6782608695652, 0.15, 0.16666666666667
4673, 1.6782608695652, 0.15, 0.11111111111111
4674, 1.6782608695652, 0.15, 0.055555555555556
4675, 1.7217391304348, 0.15, 0.44444444444444
4676, 1.7217391304348, 0.15, 0.38888888888889
4677, 1.7217391304348, 0.15, 0.33333333333333
4678, 1.7217391304348, 0.15, 0.27777777777778
4679, 1.7217391304348, 0.15, 0.22222222222222
4680, 1.7217391304348, 0.15, 0.16666666666667
4681, 1.7217391304348, 0.15, 0.11111111111111
4682, 1.7217391304348, 0.15, 0.055555555555556
4683, 1.7652173913043, 0.15, 0.44444444444444
4684, 1.7652173913043, 0.15, 0.38888888888889
4685, 1.7652173913043, 0.15, 0.33333333333333
4686, 1.7652173913043, 0.15, 0.27777777777778
4687, 1.7652173913043, 0.15, 0.22222222222222
4688, 1.7652173913043, 0.15, 0.16666666666667
4689, 1.7652173913043, 0.15, 0.11111111111111
4690, 1.7652173913043, 0.15, 0.055555555555556
4691, 1.8086956521739, 0.15, 0.44444444444444
4692, 1.8086956521739, 0.15, 0.38888888888889
4693, 1.8086956521739, 0.15, 0.33333333333333
4694, 1.8086956521739, 0.15, 0.27777777777778
4695, 1.8086956521739, 0.15, 0.22222222222222
4696, 1.8086956521739, 0.15, 0.16666666666667
4697, 1.8086956521739, 0.15, 0.11111111111111
4698, 1.8086956521739, 0.15, 0.055555555555556
4699, 1.8521739130435, 0.15, 0.44444444444444
4700, 1.8521739130435, 0.15, 0.38888888888889
4701, 1.8521739130435, 0.15, 0.33333333333333
4702, 1.8521739130435, 0.15, 0.27777777777778
4703, 1.8521739130435, 0.15, 0.22222222222222
4704, 1.8521739130435, 0.15, 0.16666666666667
4705, 1.8521739130435, 0.15, 0.11111111111111
4706, 1.8521739130435, 0.15, 0.055555555555556
4707, 1.895652173913, 0.15, 0.44444444444444
4708, 1.895652173913, 0.15, 0.38888888888889
4709, 1.895652173913, 0.15, 0.33333333333333
4710, 1.895652173913, 0.15, 0.27777777777778
4711, 1.895652173913, 0.15, 0.22222222222222
4712, 1.895652173913, 0.15, 0.16666666666667
4713, 1.895652173913, 0.15, 0.11111111111111
4714, 1.895652173913, 0.15, 0.055555555555556
4715, 1.9391304347826, 0.15, 0.44444444444444
4716, 1.9391304347826, 0.15, 0.38888888888889
4717, 1.9391304347826, 0.15, 0.33333333333333
4718, 1.9391304347826, 0.15, 0.27777777777778
4719, 1.9391304347826, 0.15, 0.22222222222222
4720, 1.9391304347826, 0.15, 0.16666666666667
4721, 1.9391304347826, 0.15, 0.11111111111111
4722, 1.9391304347826, 0.15, 0.055555555555556
4723, 1.9826086956522, 0.15, 0.44444444444444
4724, 1.9826086956522, 0.15, 0.38888888888889
4725, 1.9826086956522, 0.15, 0.33333333333333
4726, 1.9826086956522, 0.15, 0.27777777777778
4727, 1.9826086956522, 0.15, 0.22222222222222
4728, 1.9826086956522, 0.15, 0.16666666666667
4729, 1.9826086956522, 0.15, 0.11111111111111
4730, 1.9826086956522, 0.15, 0.055555555555556
4731, 2.0260869565217, 0.15, 0.44444444444444
4732, 2.0260869565217, 0.15, 0.38888888888889
4733, 2.0260869565217, 0.15, 0.33333333333333
4734, 2.0260869565217, 0.15, 0.27777777777778
4735, 2.0260869565217, 0.15, 0.22222222222222
4736, 2.0260869565217, 0.15, 0.16666666666667
4737, 2.0260869565217, 0.15, 0.11111111111111
4738, 2.0260869565217, 0.15, 0.055555555555556
4739, 2.0695652173913, 0.15, 0.44444444444444
4740, 2.0695652173913, 0.15, 0.38888888888889
4741, 2.0695652173913, 0.15, 0.33333333333333
4742, 2.0695652173913, 0.15, 0.27777777777778
4743, 2.0695652173913, 0.15, 0.22222222222222
4744, 2.0695652173913, 0.15, 0.16666666666667
4745, 2.0695652173913, 0.15, 0.11111111111111
4746, 2.0695652173913, 0.15, 0.055555555555556
4747, 2.1130434782609, 0.15, 0.44444444444444
4748, 2.1130434782609, 0.15, 0.38888888888889
4749, 2.1130434782609, 0.15, 0.33333333333333
4750, 2.1130434782609, 0.15, 0.27777777777778
4751, 2.1130434782609, 0.15, 0.22222222222222
4752, 2.1130434782609, 0.15, 0.16666666666667
4753, 2.1130434782609, 0.15, 0.11111111111111
4754, 2.1130434782609, 0.15, 0.055555555555556
4755, 2.1565217391304, 0.15, 0.44444444444444
4756, 2.1565217391304, 0.15, 0.38888888888889
4757, 2.1565217391304, 0.15, 0.33333333333333
4758, 2.1565217391304, 0.15, 0.27777777777778
4759, 2.1565217391304, 0.15, 0.22222222222222
4760, 2.1565217391304, 0.15, 0.16666666666667
4761, 2.1565217391304, 0.15, 0.11111111111111
4762, 2.1565217391304, 0.15, 0.055555555555556
4763, 1.2217391304348, 0.15, 0.44444444444444
4764, 1.2434782608696, 0.15, 0.47222222222222
4765, 1.2217391304348, 0.15, 0.38888888888889
4766, 1.2434782608696, 0.15, 0.41666666666667
4767, 1.2217391304348, 0.15, 0.33333333333333
4768, 1.2434782608696, 0.15, 0.36111111111111
4769, 1.2217391304348, 0.15, 0.27777777777778
4770, 1.2434782608696, 0.15, 0.30555555555556
4771, 1.2217391304348, 0.15, 0.22222222222222
4772, 1.2434782608696, 0.15, 0.25
4773, 1.2217391304348, 0.15, 0.16666666666667
4774, 1.2434782608696, 0.15, 0.19444444444444
4775, 1.2217391304348, 0.15, 0.11111111111111
4776, 1.2434782608696, 0.15, 0.13888888888889
4777, 1.2217391304348, 0.15, 0.055555555555556
4778, 1.2434782608696, 0.15, 0.083333333333333
4779, 1.2434782608696, 0.15, 0.027777777777778
4780, 1.2652173913043, 0.15, 0.44444444444444
4781, 1.2869565217391, 0.15, 0.47222222222222
4782, 1.2652173913043, 0.15, 0.38888888888889
4783, 1.2869565217391, 0.15, 0.41666666666667
4784, 1.2652173913043, 0.15, 0.33333333333333
4785, 1.2869565217391, 0.15, 0.36111111111111
4786, 1.2652173913043, 0.15, 0.27777777777778
4787, 1.2869565217391, 0.15, 0.30555555555556
4788, 1.2652173913043, 0.15, 0.22222222222222
4789, 1.2869565217391, 0.15, 0.25
4790, 1.2652173913043, 0.15, 0.16666666666667
4791, 1.2869565217391, 0.15, 0.19444444444444
4792, 1.2652173913043, 0.15, 0.11111111111111
4793, 1.2869565217391, 0.15, 0.13888888888889
4794, 1.2652173913043, 0.15, 0.055555555555556
4795, 1.2869565217391, 0.15, 0.083333333333333
4796, 1.2869565217391, 0.15, 0.027777777777778
4797, 1.3086956521739, 0.15, 0.44444444444444
4798, 1.3304347826087, 0.15, 0.47222222222222
4799, 1.3086956521739, 0.15, 0.38888888888889
4800, 1.3304347826087, 0.15, 0.41666666666667
4801, 1.3086956521739, 0.15, 0.33333333333333
4802, 1.3304347826087, 0.15, 0.36111111111111
4803, 1.3086956521739, 0.15, 0.27777777777778
4804, 1.3304347826087, 0.15, 0.30555555555556
4805, 1.3086956521739, 0.15, 0.22222222222222
4806, 1.3304347826087, 0.15, 0.25
4807, 1.3086956521739, 0.15, 0.16666666666667
4808, 1.3304347826087, 0.15, 0.19444444444444
4809, 1.3086956521739, 0.15, 0.11111111111111
4810, 1.3304347826087, 0.15, 0.13888888888889
4811, 1.3086956521739, 0.15, 0.055555555555556
4812, 1.3304347826087, 0.15, 0.083333333333333
4813, 1.3304347826087, 0.15, 0.027777777777778
4814, 1.3521739130435, 0.15, 0.44444444444444
4815, 1.3739130434783, 0.15, 0.47222222222222
4816, 1.3521739130435, 0.15, 0.38888888888889
4817, 1.3739130434783, 0.15, 0.41666666666667
4818, 1.3521739130435, 0.15, 0.33333333333333
4819, 1.3739130434783, 0.15, 0.36111111111111
4820, 1.3521739130435, 0.15, 0.27777777777778
4821, 1.3739130434783, 0.15, 0.30555555555556
4822, 1.3521739130435, 0.15, 0.22222222222222
4823, 1.3739130434783, 0.15, 0.25
4824, 1.3521739130435, 0.15, 0.16666666666667
4825, 1.3739130434783, 0.15, 0.19444444444444
4826, 1.3521739130435, 0.15, 0.11111111111111
4827, 1.3739130434783, 0.15, 0.13888888888889
4828, 1.3521739130435, 0.15, 0.055555555555556
4829, 1.3739130434783, 0.15, 0.083333333333333
4830, 1.3739130434783, 0.15, 0.027777777777778
4831, 1.395652173913, 0.15, 0.44444444444444
4832, 1.4173913043478, 0.15, 0.47222222222222
4833, 1.395652173913, 0.15, 0.38888888888889
4834, 1.4173913043478, 0.15, 0.41666666666667
4835, 1.395652173913, 0.15, 0.33333333333333
4836, 1.4173913043478, 0.15, 0.36111111111111
4837, 1.395652173913, 0.15, 0.27777777777778
4838, 1.4173913043478, 0.15, 0.30555555555556
4839, 1.395652173913, 0.15, 0.22222222222222
4840, 1.4173913043478, 0.15, 0.25
4841, 1.395652173913, 0.15, 0.16666666666667
4842, 1.4173913043478, 0.15, 0.19444444444444
4843, 1.395652173913, 0.15, 0.11111111111111
4844, 1.4173913043478, 0.15, 0.13888888888889
4845, 1.395652173913, 0.15, 0.055555555555556
4846, 1.4173913043478, 0.15, 0.083333333333333
4847, 1.4173913043478, 0.15, 0.027777777777778
4848, 1.4391304347826, 0.15, 0.44444444444444
4849, 1.4608695652174, 0.15, 0.47222222222222
4850, 1.4391304347826, 0.15, 0.38888888888889
4851, 1.4608695652174, 0.15, 0.41666666666667
4852, 1.4391304347826, 0.15, 0.33333333333333
4853, 1.4608695652174, 0.15, 0.36111111111111
4854, 1.4391304347826, 0.15, 0.27777777777778
4855, 1.4608695652174, 0.15, 0.30555555555556
4856, 1.4391304347826, 0.15, 0.22222222222222
4857, 1.4608695652174, 0.15, 0.25
4858, 1.4391304347826, 0.15, 0.16666666666667
4859, 1.4608695652174, 0.15, 0.19444444444444
4860, 1.4391304347826, 0.15, 0.11111111111111
4861, 1.4608695652174, 0.15, 0.13888888888889
4862, 1.4391304347826, 0.15, 0.055555555555556
4863, 1.4608695652174, 0.15, 0.083333333333333
4864, 1.4608695652174, 0.15, 0.027777777777778
4865, 1.4826086956522, 0.15, 0.44444444444444
4866, 1.504347826087, 0.15, 0.47222222222222
4867, 1.4826086956522, 0.15, 0.38888888888889
4868, 1.504347826087, 0.15, 0.41666666666667
4869, 1.4826086956522, 0.15, 0.33333333333333
4870, 1.504347826087, 0.15, 0.36111111111111
4871, 1.4826086956522, 0.15, 0.27777777777778
4872, 1.504347826087, 0.15, 0.30555555555556
4873, 1.4826086956522, 0.15, 0.22222222222222
4874, 1.504347826087, 0.15, 0.25
4875, 1.4826086956522, 0.15, 0.16666666666667
4876, 1.504347826087, 0.15, 0.19444444444444
4877, 1.4826086956522, 0.15, 0.11111111111111
4878, 1.504347826087, 0.15, 0.13888888888889
4879, 1.4826086956522, 0.15, 0.055555555555556
4880, 1.504347826087, 0.15, 0.083333333333333
4881, 1.504347826087, 0.15, 0.027777777777778
4882, 1.5260869565217, 0.15, 0.44444444444444
4883, 1.5478260869565, 0.15, 0.47222222222222
4884, 1.5260869565217, 0.15, 0.38888888888889
4885, 1.5478260869565, 0.15, 0.41666666666667
4886, 1.5260869565217, 0.15, 0.33333333333333
4887, 1.5478260869565, 0.15, 0.36111111111111
4888, 1.5260869565217, 0.15, 0.27777777777778
4889, 1.5478260869565, 0.15, 0.30555555555556
4890, 1.5260869565217, 0.15, 0.22222222222222
4891, 1.5478260869565, 0.15, 0.25
4892, 1.5260869565217, 0.15, 0.16666666666667
4893, 1.5478260869565, 0.15, 0.19444444444444
4894, 1.5260869565217, 0.15, 0.11111111111111
4895, 1.5478260869565, 0.15, 0.13888888888889
4896, 1.5260869565217, 0.15, 0.055555555555556
4897, 1.5478260869565, 0.15, 0.083333333333333
4898, 1.5478260869565, 0.15, 0.027777777777778
4899, 1.5695652173913, 0.15, 0.44444444444444
4900, 1.5913043478261, 0.15, 0.47222222222222
4901, 1.5695652173913, 0.15, 0.38888888888889
4902, 1.5913043478261, 0.15, 0.41666666666667
4903, 1.5695652173913, 0.15, 0.33333333333333
4904, 1.5913043478261, 0.15, 0.36111111111111
4905, 1.5695652173913, 0.15, 0.27777777777778
4906, 1.5913043478261, 0.15, 0.30555555555556
4907, 1.5695652173913, 0.15, 0.22222222222222
4908, 1.5913043478261, 0.15, 0.25
4909, 1.5695652173913, 0.15, 0.16666666666667
4910, 1.5913043478261, 0.15, 0.19444444444444
4911, 1.5695652173913, 0.15, 0.11111111111111
4912, 1.5913043478261, 0.15, 0.13888888888889
4913, 1.5695652173913, 0.15, 0.055555555555556
4914, 1.5913043478261, 0.15, 0.083333333333333
4915, 1.5913043478261, 0.15, 0.027777777777778
4916, 1.6130434782609, 0.15, 0.44444444444444
4917, 1.6347826086957, 0.15, 0.47222222222222
4918, 1.6130434782609, 0.15, 0.38888888888889
4919, 1.6347826086957, 0.15, 0.41666666666667
4920, 1.6130434782609, 0.15, 0.33333333333333
4921, 1.6347826086957, 0.15, 0.36111111111111
4922, 1.6130434782609, 0.15, 0.27777777777778
4923, 1.6347826086957, 0.15, 0.30555555555556
4924, 1.6130434782609, 0.15, 0.22222222222222
4925, 1.6347826086957, 0.15, 0.25
4926, 1.6130434782609, 0.15, 0.16666666666667
4927, 1.6347826086957, 0.15, 0.19444444444444
4928, 1.6130434782609, 0.15, 0.11111111111111
4929, 1.6347826086957, 0.15, 0.13888888888889
4930, 1.6130434782609, 0.15, 0.055555555555556
4931, 1.6347826086957, 0.15, 0.083333333333333
4932, 1.6347826086957, 0.15, 0.027777777777778
4933, 1.6565217391304, 0.15, 0.44444444444444
4934, 1.6782608695652, 0.15, 0.47222222222222
4935, 1.6565217391304, 0.15, 0.38888888888889
4936, 1.6782608695652, 0.15, 0.41666666666667
4937, 1.6565217391304, 0.15, 0.33333333333333
4938, 1.6782608695652, 0.15, 0.36111111111111
4939, 1.6565217391304, 0.15, 0.27777777777778
4940, 1.6782608695652, 0.15, 0.30555555555556
4941, 1.6565217391304, 0.15, 0.22222222222222
4942, 1.6782608695652, 0.15, 0.25
4943, 1.6565217391304, 0.15, 0.16666666666667
4944, 1.6782608695652, 0.15, 0.19444444444444
4945, 1.6565217391304, 0.15, 0.11111111111111
4946, 1.6782608695652, 0.15, 0.13888888888889
4947, 1.6565217391304, 0.15, 0.055555555555556
4948, 1.6782608695652, 0.15, 0.083333333333333
4949, 1.6782608695652, 0.15, 0.027777777777778
4950, 1.7, 0.15, 0.44444444444444
4951, 1.7217391304348, 0.15, 0.47222222222222
4952, 1.7, 0.15, 0.38888888888889
4953, 1.7217391304348, 0.15, 0.41666666666667
4954, 1.7, 0.15, 0.33333333333333
4955, 1.7217391304348, 0.15, 0.36111111111111
4956, 1.7, 0.15, 0.27777777777778
4957, 1.7217391304348, 0.15, 0.30555555555556
4958, 1.7, 0.15, 0.22222222222222
4959, 1.7217391304348, 0.15, 0.25
4960, 1.7, 0.15, 0.16666666666667
4961, 1.7217391304348, 0.15, 0.19444444444444
4962, 1.7, 0.15, 0.11111111111111
4963, 1.7217391304348, 0.15, 0.13888888888889
4964, 1.7, 0.15, 0.055555555555556
4965, 1.7217391304348, 0.15, 0.083333333333333
4966, 1.7217391304348, 0.15, 0.027777777777778
4967, 1.7434782608696, 0.15, 0.44444444444444
4968, 1.7652173913043, 0.15, 0.47222222222222
4969, 1.7434782608696, 0.15, 0.38888888888889
4970, 1.7652173913043, 0.15, 0.41666666666667
4971, 1.7434782608696, 0.15, 0.33333333333333
4972, 1.7652173913043, 0.15, 0.36111111111111
4973, 1.7434782608696, 0.15, 0.27777777777778
4974, 1.7652173913043, 0.15, 0.30555555555556
4975, 1.7434782608696, 0.15, 0.22222222222222
4976, 1.7652173913043, 0.15, 0.25
4977, 1.7434782608696, 0.15, 0.16666666666667
4978, 1.7652173913043, 0.15, 0.19444444444444
4979, 1.7434782608696, 0.15, 0.11111111111111
4980, 1.7652173913043, 0.15, 0.13888888888889
4981, 1.7434782608696, 0.15, 0.055555555555556
4982, 1.7652173913043, 0.15, 0.083333333333333
4983, 1.7652173913043, 0.15, 0.027777777777778
4984, 1.7869565217391, 0.15, 0.44444444444444
4985, 1.8086956521739, 0.15, 0.47222222222222
4986, 1.7869565217391, 0.15, 0.38888888888889
4987, 1.8086956521739, 0.15, 0.41666666666667
4988, 1.7869565217391, 0.15, 0.33333333333333
4989, 1.8086956521739, 0.15, 0.36111111111111
4990, 1.7869565217391, 0.15, 0.27777777777778
4991, 1.8086956521739, 0.15, 0.30555555555556
4992, 1.7869565217391, 0.15, 0.22222222222222
4993, 1.8086956521739, 0.15, 0.25
4994, 1.7869565217391, 0.15, 0.16666666666667
4995, 1.8086956521739, 0.15, 0.19444444444444
4996, 1.7869565217391, 0.15, 0.11111111111111
4997, 1.8086956521739, 0.15, 0.13888888888889
4998, 1.7869565217391, 0.15, 0.055555555555556
4999, 1.8086956521739, 0.15, 0.083333333333333
5000, 1.8086956521739, 0.15, 0.027777777777778
5001, 1.8304347826087, 0.15, 0.44444444444444
5002, 1.8521739130435, 0.15, 0.47222222222222
5003, 1.8304347826087, 0.15, 0.38888888888889
5004, 1.8521739130435, 0.15, 0.41666666666667
5005, 1.8304347826087, 0.15, 0.33333333333333
5006, 1.8521739130435, 0.15, 0.36111111111111
5007, 1.8304347826087, 0.15, 0.27777777777778
5008, 1.8521739130435, 0.15, 0.30555555555556
5009, 1.8304347826087, 0.15, 0.22222222222222
5010, 1.8521739130435, 0.15, 0.25
5011, 1.8304347826087, 0.15, 0.16666666666667
5012, 1.8521739130435, 0.15, 0.19444444444444
5013, 1.8304347826087, 0.15, 0.11111111111111
5014, 1.8521739130435, 0.15, 0.13888888888889
5015, 1.8304347826087, 0.15, 0.055555555555556
5016, 1.8521739130435, 0.15, 0.083333333333333
5017, 1.8521739130435, 0.15, 0.027777777777778
5018, 1.8739130434783, 0.15, 0.44444444444444
5019, 1.895652173913, 0.15, 0.47222222222222
5020, 1.8739130434783, 0.15, 0.38888888888889
5021, 1.895652173913, 0.15, 0.41666666666667
5022, 1.8739130434783, 0.15, 0.33333333333333
5023, 1.895652173913, 0.15, 0.36111111111111
5024, 1.8739130434783, 0.15, 0.27777777777778
5025, 1.895652173913, 0.15, 0.30555555555556
5026, 1.8739130434783, 0.15, 0.22222222222222
5027, 1.895652173913, 0.15, 0.25
5028, 1.8739130434783, 0.15, 0.16666666666667
5029, 1.895652173913, 0.15, 0.19444444444444
5030, 1.8739130434783, 0.15, 0.11111111111111
5031, 1.895652173913, 0.15, 0.13888888888889
5032, 1.8739130434783, 0.15, 0.055555555555556
5033, 1.895652173913, 0.15, 0.083333333333333
5034, 1.895652173913, 0.15, 0.027777777777778
5035, 1.9173913043478, 0.15, 0.44444444444444
5036, 1.9391304347826, 0.15, 0.47222222222222
5037, 1.9173913043478, 0.15, 0.38888888888889
5038, 1.9391304347826, 0.15, 0.41666666666667
5039, 1.9173913043478, 0.15, 0.33333333333333
5040, 1.9391304347826, 0.15, 0.36111111111111
5041, 1.9173913043478, 0.15, 0.27777777777778
5042, 1.9391304347826, 0.15, 0.30555555555556
5043, 1.9173913043478, 0.15, 0.22222222222222
5044, 1.9391304347826, 0.15, 0.25
5045, 1.9173913043478, 0.15, 0.16666666666667
5046, 1.9391304347826, 0.15, 0.19444444444444
5047, 1.9173913043478, 0.15, 0.11111111111111
5048, 1.9391304347826, 0.15, 0.13888888888889
5049, 1.9173913043478, 0.15, 0.055555555555556
5050, 1.9391304347826, 0.15, 0.083333333333333
5051, 1.9391304347826, 0.15, 0.027777777777778
5052, 1.9608695652174, 0.15, 0.44444444444444
5053, 1.9826086956522, 0.15, 0.47222222222222
5054, 1.9608695652174, 0.15, 0.38888888888889
5055, 1.9826086956522, 0.15, 0.41666666666667
5056, 1.9608695652174, 0.15, 0.33333333333333
5057, 1.9826086956522, 0.15, 0.36111111111111
5058, 1.9608695652174, 0.15, 0.27777777777778
5059, 1.9826086956522, 0.15, 0.30555555555556
5060, 1.9608695652174, 0.15, 0.22222222222222
5061, 1.9826086956522, 0.15, 0.25
5062, 1.9608695652174, 0.15, 0.16666666666667
5063, 1.9826086956522, 0.15, 0.19444444444444
5064, 1.9608695652174, 0.15, 0.11111111111111
5065, 1.9826086956522, 0.15, 0.13888888888889
5066, 1.9608695652174, 0.15, 0.055555555555556
5067, 1.9826086956522, 0.15, 0.083333333333333
5068, 1.9826086956522, 0.15, 0.027777777777778
5069, 2.004347826087, 0.15, 0.44444444444444
5070, 2.0260869565217, 0.15, 0.47222222222222
5071, 2.004347826087, 0.15, 0.38888888888889
5072, 2.0260869565217, 0.15, 0.41666666666667
5073, 2.004347826087, 0.15, 0.33333333333333
5074, 2.0260869565217, 0.15, 0.36111111111111
5075, 2.004347826087, 0.15, 0.27777777777778
5076, 2.0260869565217, 0.15, 0.30555555555556
5077, 2.004347826087, 0.15, 0.22222222222222
5078, 2.0260869565217, 0.15, 0.25
5079, 2.004347826087, 0.15, 0.16666666666667
5080, 2.0260869565217, 0.15, 0.19444444444444
5081, 2.004347826087, 0.15, 0.11111111111111
5082, 2.0260869565217, 0.15, 0.13888888888889
5083, 2.004347826087, 0.15, 0.055555555555556
5084, 2.0260869565217, 0.15, 0.083333333333333
5085, 2.0260869565217, 0.15, 0.027777777777778
5086, 2.0478260869565, 0.15, 0.44444444444444
5087, 2.0695652173913, 0.15, 0.47222222222222
5088, 2.0478260869565, 0.15, 0.38888888888889
5089, 2.0695652173913, 0.15, 0.41666666666667
5090, 2.0478260869565, 0.15, 0.33333333333333
5091, 2.0695652173913, 0.15, 0.36111111111111
5092, 2.0478260869565, 0.15, 0.27777777777778
5093, 2.0695652173913, 0.15, 0.30555555555556
5094, 2.0478260869565, 0.15, 0.22222222222222
5095, 2.0695652173913, 0.15, 0.25
5096, 2.0478260869565, 0.15, 0.16666666666667
5097, 2.0695652173913, 0.15, 0.19444444444444
5098, 2.0478260869565, 0.15, 0.11111111111111
5099, 2.0695652173913, 0.15, 0.13888888888889
5100, 2.0478260869565, 0.15, 0.055555555555556
5101, 2.0695652173913, 0.15, 0.083333333333333
5102, 2.0695652173913, 0.15, 0.027777777777778
5103, 2.0913043478261, 0.15, 0.44444444444444
5104, 2.1130434782609, 0.15, 0.47222222222222
5105, 2.0913043478261, 0.15, 0.38888888888889
5106, 2.1130434782609, 0.15, 0.41666666666667
5107, 2.0913043478261, 0.15, 0.33333333333333
5108, 2.1130434782609, 0.15, 0.36111111111111
5109, 2.0913043478261, 0.15, 0.27777777777778
5110, 2.1130434782609, 0.15, 0.30555555555556
5111, 2.0913043478261, 0.15, 0.22222222222222
5112, 2.1130434782609, 0.15, 0.25
5113, 2.0913043478261, 0.15, 0.16666666666667
5114, 2.1130434782609, 0.15, 0.19444444444444
5115, 2.0913043478261, 0.15, 0.11111111111111
5116, 2.1130434782609, 0.15, 0.13888888888889
5117, 2.0913043478261, 0.15, 0.055555555555556
5118, 2.1130434782609, 0.15, 0.083333333333333
5119, 2.1130434782609, 0.15, 0.027777777777778
5120, 2.1347826086957, 0.15, 0.44444444444444
5121, 2.1565217391304, 0.15, 0.47222222222222
5122, 2.1347826086957, 0.15, 0.38888888888889
5123, 2.1565217391304, 0.15, 0.41666666666667
5124, 2.1347826086957, 0.15, 0.33333333333333
5125, 2.1565217391304, 0.15, 0.36111111111111
5126, 2.1347826086957, 0.15, 0.27777777777778
5127, 2.1565217391304, 0.15, 0.30555555555556
5128, 2.1347826086957, 0.15, 0.22222222222222
5129, 2.1565217391304, 0.15, 0.25
5130, 2.1347826086957, 0.15, 0.16666666666667
5131, 2.1565217391304, 0.15, 0.19444444444444
5132, 2.1347826086957, 0.15, 0.11111111111111
5133, 2.1565217391304, 0.15, 0.13888888888889
5134, 2.1347826086957, 0.15, 0.055555555555556
5135, 2.1565217391304, 0.15, 0.083333333333333
5136, 2.1565217391304, 0.15, 0.027777777777778
5137, 2.1782608695652, 0.15, 0.44444444444444
5138, 2.1782608695652, 0.15, 0.38888888888889
5139, 2.1782608695652, 0.15, 0.33333333333333
5140, 2.1782608695652, 0.15, 0.27777777777778
5141, 2.1782608695652, 0.15, 0.22222222222222
5142, 2.1782608695652, 0.15, 0.16666666666667
5143, 2.1782608695652, 0.15, 0.11111111111111
5144, 2.1782608695652, 0.15, 0.055555555555556
5145, -0.05, 0.016666666666667, 0.5
5146, -0.05, -0.016666666666667, 0.5
5147, -0.05, 0.033333333333333, 0.5
5148, -0.025, 0.016666666666667, 0.5
5149, -0.05, 5.5511151231258e-17, 0.5
5150, -0.025, -0.016666666666667, 0.5
5151, -0.05, -0.033333333333333, 0.5
5152, -0.075, 0.016666666666667, 0.5
5153, -0.075, -0.016666666666667, 0.5
5154, -0.05, -0.05, 0.44444444444444
5155, -0.05, -0.05, 0.38888888888889
5156, -0.05, -0.05, 0.33333333333333
5157, -0.05, -0.05, 0.27777777777778
5158, -0.05, -0.05, 0.22222222222222
5159, -0.05, -0.05, 0.16666666666667
5160, -0.05, -0.05, 0.11111111111111
5161, -0.05, -0.05, 0.055555555555556
5162, -0.05, -0.05, 0.47222222222222
5163, -0.025, -0.05, 0.44444444444444
5164, -0.05, -0.05, 0.41666666666667
5165, -0.025, -0.05, 0.38888888888889
5166, -0.05, -0.05, 0.36111111111111
5167, -0.025, -0.05, 0.33333333333333
5168, -0.05, -0.05, 0.30555555555556
5169, -0.025, -0.05, 0.27777777777778
5170, -0.05, -0.05, 0.25
5171, -0.025, -0.05, 0.22222222222222
5172, -0.05, -0.05, 0.19444444444444
5173, -0.025, -0.05, 0.16666666666667
5174, -0.05, -0.05, 0.13888888888889
5175, -0.025, -0.05, 0.11111111111111
5176, -0.05, -0.05, 0.083333333333333
5177, -0.025, -0.05, 0.055555555555556
5178, -0.05, -0.05, 0.027777777777778
5179, -0.075, -0.05, 0.44444444444444
5180, -0.075, -0.05, 0.38888888888889
5181, -0.075, -0.05, 0.33333333333333
5182, -0.075, -0.05, 0.27777777777778
5183, -0.075, -0.05, 0.22222222222222
5184, -0.075, -0.05, 0.16666666666667
5185, -0.075, -0.05, 0.11111111111111
5186, -0.075, -0.05, 0.055555555555556
5187, -0.05, 0.05, 0.44444444444444
5188, -0.05, 0.05, 0.38888888888889
5189, -0.05, 0.05, 0.33333333333333
5190, -0.05, 0.05, 0.27777777777778
5191, -0.05, 0.05, 0.22222222222222
5192, -0.05, 0.05, 0.16666666666667
5193, -0.05, 0.05, 0.11111111111111
5194, -0.05, 0.05, 0.055555555555556
5195, -0.025, 0.05, 0.44444444444444
5196, -0.05, 0.05, 0.47222222222222
5197, -0.025, 0.05, 0.38888888888889
5198, -0.05, 0.05, 0.41666666666667
5199, -0.025, 0.05, 0.33333333333333
5200, -0.05, 0.05, 0.36111111111111
5201, -0.025, 0.05, 0.27777777777778
5202, -0.05, 0.05, 0.30555555555556
5203, -0.025, 0.05, 0.22222222222222
5204, -0.05, 0.05, 0.25
5205, -0.025, 0.05, 0.16666666666667
5206, -0.05, 0.05, 0.19444444444444
5207, -0.025, 0.05, 0.11111111111111
5208, -0.05, 0.05, 0.13888888888889
5209, -0.025, 0.05, 0.055555555555556
5210, -0.05, 0.05, 0.083333333333333
5211, -0.05, 0.05, 0.027777777777778
5212, -0.075, 0.05, 0.44444444444444
5213, -0.075, 0.05, 0.38888888888889
5214, -0.075, 0.05, 0.33333333333333
5215, -0.075, 0.05, 0.27777777777778
5216, -0.075, 0.05, 0.22222222222222
5217, -0.075, 0.05, 0.16666666666667
5218, -0.075, 0.05, 0.11111111111111
5219, -0.075, 0.05, 0.055555555555556
5220, -0.05, 0.016666666666667, 0
5221, -0.05, -0.016666666666667, 0
5222, -0.025, 0.016666666666667, 0
5223, -0.05, 0.033333333333333, 0
5224, -0.025, -0.016666666666667, 0
5225, -0.05, 5.5511151231258e-17, 0
5226, -0.05, -0.033333333333333, 0
5227, -0.075, 0.016666666666667, 0
5228, -0.075, -0.016666666666667, 0
5229, 0, -0.016666666666667, 0.055555555555556
5230, 0, 0.016666666666667, 0.055555555555556
5231, 0, -0.016666666666667, 0.11111111111111
5232, 0, 0.016666666666667, 0.11111111111111
5233, 0, -0.016666666666667, 0.16666666666667
5234, 0, 0.016666666666667, 0.16666666666667
5235, 0, -0.016666666666667, 0.22222222222222
5236, 0, 0.016666666666667, 0.22222222222222
5237, 0, -0.016666666666667, 0.27777777777778
5238, 0, 0.016666666666667, 0.27777777777778
5239, 0, -0.016666666666667, 0.33333333333333
5240, 0, 0.016666666666667, 0.33333333333333
5241, 0, -0.016666666666667, 0.38888888888889
5242, 0, 0.016666666666667, 0.38888888888889
5243, 0, -0.016666666666667, 0.44444444444444
5244, 0, 0.016666666666667, 0.44444444444444
5245, 0, -0.016666666666667, 0.027777777777778
5246, 0, -0.033333333333333, 0.055555555555556
5247, 0, 0.016666666666667, 0.027777777777778
5248, 0, 5.5511151231258e-17, 0.055555555555556
5249, 0, 0.033333333333333, 0.055555555555556
5250, 0, -0.016666666666667, 0.083333333333333
5251, 0, -0.033333333333333, 0.11111111111111
5252, 0, 0.016666666666667, 0.083333333333333
5253, 0, 5.5511151231258e-17, 0.11111111111111
5254, 0, 0.033333333333333, 0.11111111111111
5255, 0, -0.016666666666667, 0.13888888888889
5256, 0, -0.033333333333333, 0.16666666666667
5257, 0, 0.016666666666667, 0.13888888888889
5258, 0, 6.2450045135165e-17, 0.16666666666667
5259, 0, 0.033333333333333, 0.16666666666667
5260, 0, -0.016666666666667, 0.19444444444444
5261, 0, -0.033333333333333, 0.22222222222222
5262, 0, 0.016666666666667, 0.19444444444444
5263, 0, 5.5511151231258e-17, 0.22222222222222
5264, 0, 0.033333333333333, 0.22222222222222
5265, 0, -0.016666666666667, 0.25
5266, 0, -0.033333333333333, 0.27777777777778
5267, 0, 0.016666666666667, 0.25
5268, 0, 5.5511151231258e-17, 0.27777777777778
5269, 0, 0.033333333333333, 0.27777777777778
5270, 0, -0.016666666666667, 0.30555555555556
5271, 0, -0.033333333333333, 0.33333333333333
5272, 0, 0.016666666666667, 0.30555555555556
5273, 0, 5.5511151231258e-17, 0.33333333333333
5274, 0, 0.033333333333333, 0.33333333333333
5275, 0, -0.016666666666667, 0.36111111111111
5276, 0, -0.033333333333333, 0.38888888888889
5277, 0, 0.016666666666667, 0.36111111111111
5278, 0, 5.5511151231258e-17, 0.38888888888889
5279, 0, 0.033333333333333, 0.38888888888889
5280, 0, -0.016666666666667, 0.41666666666667
5281, 0, -0.033333333333333, 0.44444444444444
5282, 0, 0.016666666666667, 0.41666666666667
5283, 0, 5.5511151231258e-17, 0.44444444444444
5284, 0, 0.033333333333333, 0.44444444444444
5285, 0, -0.016666666666667, 0.47222222222222
5286, 0, 0.016666666666667, 0.47222222222222
5287, -0.1, -0.016666666666667, 0.055555555555556
5288, -0.1, 0.016666666666667, 0.055555555555556
5289, -0.1, -0.016666666666667, 0.11111111111111
5290, -0.1, 0.016666666666667, 0.11111111111111
5291, -0.1, -0.016666666666667, 0.16666666666667
5292, -0.1, 0.016666666666667, 0.16666666666667
5293, -0.1, -0.016666666666667, 0.22222222222222
5294, -0.1, 0.016666666666667, 0.22222222222222
5295, -0.1, -0.016666666666667, 0.27777777777778
5296, -0.1, 0.016666666666667, 0.27777777777778
5297, -0.1, -0.016666666666667, 0.33333333333333
5298, -0.1, 0.016666666666667, 0.33333333333333
5299, -0.1, -0.016666666666667, 0.38888888888889
5300, -0.1, 0.016666666666667, 0.38888888888889
5301, -0.1, -0.016666666666667, 0.44444444444444
5302, -0.1, 0.016666666666667, 0.44444444444444
5303, -0.1, -0.033333333333333, 0.055555555555556
5304, -0.1, -0.016666666666667, 0.027777777777778
5305, -0.1, 5.5511151231258e-17, 0.055555555555556
5306, -0.1, 0.016666666666667, 0.027777777777778
5307, -0.1, 0.033333333333333, 0.055555555555556
5308, -0.1, -0.033333333333333, 0.11111111111111
5309, -0.1, -0.016666666666667, 0.083333333333333
5310, -0.1, 5.5511151231258e-17, 0.11111111111111
5311, -0.1, 0.016666666666667, 0.083333333333333
5312, -0.1, 0.033333333333333, 0.11111111111111
5313, -0.1, -0.033333333333333, 0.16666666666667
5314, -0.1, -0.016666666666667, 0.13888888888889
5315, -0.1, 6.2450045135165e-17, 0.16666666666667
5316, -0.1, 0.016666666666667, 0.13888888888889
5317, -0.1, 0.033333333333333, 0.16666666666667
5318, -0.1, -0.033333333333333, 0.22222222222222
5319, -0.1, -0.016666666666667, 0.19444444444444
5320, -0.1, 5.5511151231258e-17, 0.22222222222222
5321, -0.1, 0.016666666666667, 0.19444444444444
5322, -0.1, 0.033333333333333, 0.22222222222222
5323, -0.1, -0.033333333333333, 0.27777777777778
5324, -0.1, -0.016666666666667, 0.25
5325, -0.1, 5.5511151231258e-17, 0.27777777777778
5326, -0.1, 0.016666666666667, 0.25
5327, -0.1, 0.033333333333333, 0.27777777777778
5328, -0.1, -0.033333333333333, 0.33333333333333
5329, -0.1, -0.016666666666667, 0.30555555555556
5330, -0.1, 5.5511151231258e-17, 0.33333333333333
5331, -0.1, 0.016666666666667, 0.30555555555556
5332, -0.1, 0.033333333333333, 0.33333333333333
5333, -0.1, -0.033333333333333, 0.38888888888889
5334, -0.1, -0.016666666666667, 0.36111111111111
5335, -0.1, 5.5511151231258e-17, 0.38888888888889
5336, -0.1, 0.016666666666667, 0.36111111111111
5337, -0.1, 0.033333333333333, 0.38888888888889
5338, -0.1, -0.033333333333333, 0.44444444444444
5339, -0.1, -0.016666666666667, 0.41666666666667
5340, -0.1, 5.5511151231258e-17, 0.44444444444444
5341, -0.1, 0.016666666666667, 0.41666666666667
5342, -0.1, 0.033333333333333, 0.44444444444444
5343, -0.1, -0.016666666666667, 0.47222222222222
5344, -0.1, 0.016666666666667, 0.47222222222222
5345, -0.05, -0.1, 0.5
5346, -0.05, -0.15, 0.5
5347, -0.05, -0.2, 0.5
5348, -0.05, -0.075, 0.5
5349, -0.025, -0.1, 0.5
5350, -0.075, -0.1, 0.5
5351, -0.05, -0.125, 0.5
5352, -0.025, -0.15, 0.5
5353, -0.075, -0.15, 0.5
5354, -0.05, -0.175, 0.5
5355, -0.025, -0.2, 0.5
5356, -0.075, -0.2, 0.5
5357, -0.05, -0.225, 0.5
5358, -0.05, -0.1, 0
5359, -0.05, -0.15, 0
5360, -0.05, -0.2, 0
5361, -0.025, -0.1, 0
5362, -0.05, -0.075, 0
5363, -0.075, -0.1, 0
5364, -0.025, -0.15, 0
5365, -0.05, -0.125, 0
5366, -0.075, -0.15, 0
5367, -0.025, -0.2, 0
5368, -0.05, -0.175, 0
5369, -0.075, -0.2, 0
5370, -0.05, -0.225, 0
5371, 0, -0.1, 0.44444444444444
5372, 0, -0.1, 0.38888888888889
5373, 0, -0.1, 0.33333333333333
5374, 0, -0.1, 0.27777777777778
5375, 0, -0.1, 0.22222222222222
5376, 0, -0.1, 0.16666666666667
5377, 0, -0.1, 0.11111111111111
5378, 0, -0.1, 0.055555555555556
5379, 0, -0.15, 0.44444444444444
5380, 0, -0.15, 0.38888888888889
5381, 0, -0.15, 0.33333333333333
5382, 0, -0.15, 0.27777777777778
5383, 0, -0.15, 0.22222222222222
5384, 0, -0.15, 0.16666666666667
5385, 0, -0.15, 0.11111111111111
5386, 0, -0.15, 0.055555555555556
5387, 0, -0.2, 0.44444444444444
5388, 0, -0.2, 0.38888888888889
5389, 0, -0.2, 0.33333333333333
5390, 0, -0.2, 0.27777777777778
5391, 0, -0.2, 0.22222222222222
5392, 0, -0.2, 0.16666666666667
5393, 0, -0.2, 0.11111111111111
5394, 0, -0.2, 0.055555555555556
5395, 0, -0.1, 0.47222222222222
5396, 0, -0.075, 0.44444444444444
5397, 0, -0.1, 0.41666666666667
5398, 0, -0.075, 0.38888888888889
5399, 0, -0.1, 0.36111111111111
5400, 0, -0.075, 0.33333333333333
5401, 0, -0.1, 0.30555555555556
5402, 0, -0.075, 0.27777777777778
5403, 0, -0.1, 0.25
5404, 0, -0.075, 0.22222222222222
5405, 0, -0.1, 0.19444444444444
5406, 0, -0.075, 0.16666666666667
5407, 0, -0.1, 0.13888888888889
5408, 0, -0.075, 0.11111111111111
5409, 0, -0.1, 0.083333333333333
5410, 0, -0.075, 0.055555555555556
5411, 0, -0.1, 0.027777777777778
5412, 0, -0.15, 0.47222222222222
5413, 0, -0.125, 0.44444444444444
5414, 0, -0.15, 0.41666666666667
5415, 0, -0.125, 0.38888888888889
5416, 0, -0.15, 0.36111111111111
5417, 0, -0.125, 0.33333333333333
5418, 0, -0.15, 0.30555555555556
5419, 0, -0.125, 0.27777777777778
5420, 0, -0.15, 0.25
5421, 0, -0.125, 0.22222222222222
5422, 0, -0.15, 0.19444444444444
5423, 0, -0.125, 0.16666666666667
5424, 0, -0.15, 0.13888888888889
5425, 0, -0.125, 0.11111111111111
5426, 0, -0.15, 0.083333333333333
5427, 0, -0.125, 0.055555555555556
5428, 0, -0.15, 0.027777777777778
5429, 0, -0.2, 0.47222222222222
5430, 0, -0.175, 0.44444444444444
5431, 0, -0.2, 0.41666666666667
5432, 0, -0.175, 0.38888888888889
5433, 0, -0.2, 0.36111111111111
5434, 0, -0.175, 0.33333333333333
5435, 0, -0.2, 0.30555555555556
5436, 0, -0.175, 0.27777777777778
5437, 0, -0.2, 0.25
5438, 0, -0.175, 0.22222222222222
5439, 0, -0.2, 0.19444444444444
5440, 0, -0.175, 0.16666666666667
5441, 0, -0.2, 0.13888888888889
5442, 0, -0.175, 0.11111111111111
5443, 0, -0.2, 0.083333333333333
5444, 0, -0.175, 0.055555555555556
5445, 0, -0.2, 0.027777777777778
5446, 0, -0.225, 0.44444444444444
5447, 0, -0.225, 0.38888888888889
5448, 0, -0.225, 0.33333333333333
5449, 0, -0.225, 0.27777777777778
5450, 0, -0.225, 0.22222222222222
5451, 0, -0.225, 0.16666666666667
5452, 0, -0.225, 0.11111111111111
5453, 0, -0.225, 0.055555555555556
5454, -0.1, -0.1, 0.44444444444444
5455, -0.1, -0.1, 0.38888888888889
5456, -0.1, -0.1, 0.33333333333333
5457, -0.1, -0.1, 0.27777777777778
5458, -0.1, -0.1, 0.22222222222222
5459, -0.1, -0.1, 0.16666666666667
5460, -0.1, -0.1, 0.11111111111111
5461, -0.1, -0.1, 0.055555555555556
5462, -0.1, -0.15, 0.44444444444444
5463, -0.1, -0.15, 0.38888888888889
5464, -0.1, -0.15, 0.33333333333333
5465, -0.1, -0.15, 0.27777777777778
5466, -0.1, -0.15, 0.22222222222222
5467, -0.1, -0.15, 0.16666666666667
5468, -0.1, -0.15, 0.11111111111111
5469, -0.1, -0.15, 0.055555555555556
5470, -0.1, -0.2, 0.44444444444444
5471, -0.1, -0.2, 0.38888888888889
5472, -0.1, -0.2, 0.33333333333333
5473, -0.1, -0.2, 0.27777777777778
5474, -0.1, -0.2, 0.22222222222222
5475, -0.1, -0.2, 0.16666666666667
5476, -0.1, -0.2, 0.11111111111111
5477, -0.1, -0.2, 0.055555555555556
5478, -0.1, -0.075, 0.44444444444444
5479, -0.1, -0.1, 0.47222222222222
5480, -0.1, -0.075, 0.38888888888889
5481, -0.1, -0.1, 0.41666666666667
5482, -0.1, -0.075, 0.33333333333333
5483, -0.1, -0.1, 0.36111111111111
5484, -0.1, -0.075, 0.27777777777778
5485, -0.1, -0.1, 0.30555555555556
5486, -0.1, -0.075, 0.22222222222222
5487, -0.1, -0.1, 0.25
5488, -0.1, -0.075, 0.16666666666667
5489, -0.1, -0.1, 0.19444444444444
5490, -0.1, -0.075, 0.11111111111111
5491, -0.1, -0.1, 0.13888888888889
5492, -0.1, -0.075, 0.055555555555556
5493, -0.1, -0.1, 0.083333333333333
5494, -0.1, -0.1, 0.027777777777778
5495, -0.1, -0.125, 0.44444444444444
5496, -0.1, -0.15, 0.47222222222222
5497, -0.1, -0.125, 0.38888888888889
5498, -0.1, -0.15, 0.41666666666667
5499, -0.1, -0.125, 0.33333333333333
5500, -0.1, -0.15, 0.36111111111111
5501, -0.1, -0.125, 0.27777777777778
5502, -0.1, -0.15, 0.30555555555556
5503, -0.1, -0.125, 0.22222222222222
5504, -0.1, -0.15, 0.25
5505, -0.1, -0.125, 0.16666666666667
5506, -0.1, -0.15, 0.19444444444444
5507, -0.1, -0.125, 0.11111111111111
5508, -0.1, -0.15, 0.13888888888889
5509, -0.1, -0.125, 0.055555555555556
5510, -0.1, -0.15, 0.083333333333333
5511, -0.1, -0.15, 0.027777777777778
5512, -0.1, -0.175, 0.44444444444444
5513, -0.1, -0.2, 0.47222222222222
5514, -0.1, -0.175, 0.38888888888889
5515, -0.1, -0.2, 0.41666666666667
5516, -0.1, -0.175, 0.33333333333333
5517, -0.1, -0.2, 0.36111111111111
5518, -0.1, -0.175, 0.27777777777778
5519, -0.1, -0.2, 0.30555555555556
5520, -0.1, -0.175, 0.22222222222222
5521, -0.1, -0.2, 0.25
5522, -0.1, -0.175, 0.16666666666667
5523, -0.1, -0.2, 0.19444444444444
5524, -0.1, -0.175, 0.11111111111111
5525, -0.1, -0.2, 0.13888888888889
5526, -0.1, -0.175, 0.055555555555556
5527, -0.1, -0.2, 0.083333333333333
5528, -0.1, -0.2, 0.027777777777778
5529, -0.1, -0.225, 0.44444444444444
5530, -0.1, -0.225, 0.38888888888889
5531, -0.1, -0.225, 0.33333333333333
5532, -0.1, -0.225, 0.27777777777778
5533, -0.1, -0.225, 0.22222222222222
5534, -0.1, -0.225, 0.16666666666667
5535, -0.1, -0.225, 0.11111111111111
5536, -0.1, -0.225, 0.055555555555556
5537, -0.05, -0.25, 0.44444444444444
5538, -0.05, -0.25, 0.38888888888889
5539, -0.05, -0.25, 0.33333333333333
5540, -0.05, -0.25, 0.27777777777778
5541, -0.05, -0.25, 0.22222222222222
5542, -0.05, -0.25, 0.16666666666667
5543, -0.05, -0.25, 0.11111111111111
5544, -0.05, -0.25, 0.055555555555556
5545, -0.05, -0.25, 0.47222222222222
5546, -0.025, -0.25, 0.44444444444444
5547, -0.05, -0.25, 0.41666666666667
5548, -0.025, -0.25, 0.38888888888889
5549, -0.05, -0.25, 0.36111111111111
5550, -0.025, -0.25, 0.33333333333333
5551, -0.05, -0.25, 0.30555555555556
5552, -0.025, -0.25, 0.27777777777778
5553, -0.05, -0.25, 0.25
5554, -0.025, -0.25, 0.22222222222222
5555, -0.05, -0.25, 0.19444444444444
5556, -0.025, -0.25, 0.16666666666667
5557, -0.05, -0.25, 0.13888888888889
5558, -0.025, -0.25, 0.11111111111111
5559, -0.05, -0.25, 0.083333333333333
5560, -0.025, -0.25, 0.055555555555556
5561, -0.05, -0.25, 0.027777777777778
5562, -0.075, -0.25, 0.44444444444444
5563, -0.075, -0.25, 0.38888888888889
5564, -0.075, -0.25, 0.33333333333333
5565, -0.075, -0.25, 0.27777777777778
5566, -0.075, -0.25, 0.22222222222222
5567, -0.075, -0.25, 0.16666666666667
5568, -0.075, -0.25, 0.11111111111111
5569, -0.075, -0.25, 0.055555555555556
5570, 1, -0.016666666666667, 0.055555555555556
5571, 1, 0.016666666666667, 0.055555555555556
5572, 1, -0.016666666666667, 0.11111111111111
5573, 1, 0.016666666666667, 0.11111111111111
5574, 1, -0.016666666666667, 0.16666666666667
5575, 1, 0.016666666666667, 0.16666666666667
5576, 1, -0.016666666666667, 0.22222222222222
5577, 1, 0.016666666666667, 0.22222222222222
5578, 1, -0.016666666666667, 0.27777777777778
5579, 1, 0.016666666666667, 0.27777777777778
5580, 1, -0.016666666666667, 0.33333333333333
5581, 1, 0.016666666666667, 0.33333333333333
5582, 1, -0.016666666666667, 0.38888888888889
5583, 1, 0.016666666666667, 0.38888888888889
5584, 1, -0.016666666666667, 0.44444444444444
5585, 1, 0.016666666666667, 0.44444444444444
5586, 1, -0.016666666666667, 0.027777777777778
5587, 1, -0.033333333333333, 0.055555555555556
5588, 1, 0.016666666666667, 0.027777777777778
5589, 1, 5.5511151231258e-17, 0.055555555555556
5590, 1, 0.033333333333333, 0.055555555555556
5591, 1, -0.016666666666667, 0.083333333333333
5592, 1, -0.033333333333333, 0.11111111111111
5593, 1, 0.016666666666667, 0.083333333333333
5594, 1, 5.5511151231258e-17, 0.11111111111111
5595, 1, 0.033333333333333, 0.11111111111111
5596, 1, -0.016666666666667, 0.13888888888889
5597, 1, -0.033333333333333, 0.16666666666667
5598, 1, 0.016666666666667, 0.13888888888889
5599, 1, 6.2450045135165e-17, 0.16666666666667
5600, 1, 0.033333333333333, 0.16666666666667
5601, 1, -0.016666666666667, 0.19444444444444
5602, 1, -0.033333333333333, 0.22222222222222
5603, 1, 0.016666666666667, 0.19444444444444
5604, 1, 5.5511151231258e-17, 0.22222222222222
5605, 1, 0.033333333333333, 0.22222222222222
5606, 1, -0.016666666666667, 0.25
5607, 1, -0.033333333333333, 0.27777777777778
5608, 1, 0.016666666666667, 0.25
5609, 1, 5.5511151231258e-17, 0.27777777777778
5610, 1, 0.033333333333333, 0.27777777777778
5611, 1, -0.016666666666667, 0.30555555555556
5612, 1, -0.033333333333333, 0.33333333333333
5613, 1, 0.016666666666667, 0.30555555555556
5614, 1, 5.5511151231258e-17, 0.33333333333333
5615, 1, 0.033333333333333, 0.33333333333333
5616, 1, -0.016666666666667, 0.36111111111111
5617, 1, -0.033333333333333, 0.38888888888889
5618, 1, 0.016666666666667, 0.36111111111111
5619, 1, 5.5511151231258e-17, 0.38888888888889
5620, 1, 0.033333333333333, 0.38888888888889
5621, 1, -0.016666666666667, 0.41666666666667
5622, 1, -0.033333333333333, 0.44444444444444
5623, 1, 0.016666666666667, 0.41666666666667
5624, 1, 5.5511151231258e-17, 0.44444444444444
5625, 1, 0.033333333333333, 0.44444444444444
5626, 1, -0.016666666666667, 0.47222222222222
5627, 1, 0.016666666666667, 0.47222222222222
5628, 0.043478260869565, -0.05, 0.055555555555556
5629, 0.043478260869565, -0.05, 0.11111111111111
5630, 0.043478260869565, -0.05, 0.16666666666667
5631, 0.043478260869565, -0.05, 0.22222222222222
5632, 0.043478260869565, -0.05, 0.27777777777778
5633, 0.043478260869565, -0.05, 0.33333333333333
5634, 0.043478260869565, -0.05, 0.38888888888889
5635, 0.043478260869565, -0.05, 0.44444444444444
5636, 0.08695652173913, -0.05, 0.055555555555556
5637, 0.08695652173913, -0.05, 0.11111111111111
5638, 0.08695652173913, -0.05, 0.16666666666667
5639, 0.08695652173913, -0.05, 0.22222222222222
5640, 0.08695652173913, -0.05, 0.27777777777778
5641, 0.08695652173913, -0.05, 0.33333333333333
5642, 0.08695652173913, -0.05, 0.38888888888889
5643, 0.08695652173913, -0.05, 0.44444444444444
5644, 0.1304347826087, -0.05, 0.055555555555556
5645, 0.1304347826087, -0.05, 0.11111111111111
5646, 0.1304347826087, -0.05, 0.16666666666667
5647, 0.1304347826087, -0.05, 0.22222222222222
5648, 0.1304347826087, -0.05, 0.27777777777778
5649, 0.1304347826087, -0.05, 0.33333333333333
5650, 0.1304347826087, -0.05, 0.38888888888889
5651, 0.1304347826087, -0.05, 0.44444444444444
5652, 0.17391304347826, -0.05, 0.055555555555556
5653, 0.17391304347826, -0.05, 0.11111111111111
5654, 0.17391304347826, -0.05, 0.16666666666667
5655, 0.17391304347826, -0.05, 0.22222222222222
5656, 0.17391304347826, -0.05, 0.27777777777778
5657, 0.17391304347826, -0.05, 0.33333333333333
5658, 0.17391304347826, -0.05, 0.38888888888889
5659, 0.17391304347826, -0.05, 0.44444444444444
5660, 0.21739130434783, -0.05, 0.055555555555556
5661, 0.21739130434783, -0.05, 0.11111111111111
5662, 0.21739130434783, -0.05, 0.16666666666667
5663, 0.21739130434783, -0.05, 0.22222222222222
5664, 0.21739130434783, -0.05, 0.27777777777778
5665, 0.21739130434783, -0.05, 0.33333333333333
5666, 0.21739130434783, -0.05, 0.38888888888889
5667, 0.21739130434783, -0.05, 0.44444444444444
5668, 0.26086956521739, -0.05, 0.055555555555556
5669, 0.26086956521739, -0.05, 0.11111111111111
5670, 0.26086956521739, -0.05, 0.16666666666667
5671, 0.26086956521739, -0.05, 0.22222222222222
5672, 0.26086956521739, -0.05, 0.27777777777778
5673, 0.26086956521739, -0.05, 0.33333333333333
5674, 0.26086956521739, -0.05, 0.38888888888889
5675, 0.26086956521739, -0.05, 0.44444444444444
5676, 0.30434782608696, -0.05, 0.055555555555556
5677, 0.30434782608696, -0.05, 0.11111111111111
5678, 0.30434782608696, -0.05, 0.16666666666667
5679, 0.30434782608696, -0.05, 0.22222222222222
5680, 0.30434782608696, -0.05, 0.27777777777778
5681, 0.30434782608696, -0.05, 0.33333333333333
5682, 0.30434782608696, -0.05, 0.38888888888889
5683, 0.30434782608696, -0.05, 0.44444444444444
5684, 0.34782608695652, -0.05, 0.055555555555556
5685, 0.34782608695652, -0.05, 0.11111111111111
5686, 0.34782608695652, -0.05, 0.16666666666667
5687, 0.34782608695652, -0.05, 0.22222222222222
5688, 0.34782608695652, -0.05, 0.27777777777778
5689, 0.34782608695652, -0.05, 0.33333333333333
5690, 0.34782608695652, -0.05, 0.38888888888889
5691, 0.34782608695652, -0.05, 0.44444444444444
5692, 0.39130434782609, -0.05, 0.055555555555556
5693, 0.39130434782609, -0.05, 0.11111111111111
5694, 0.39130434782609, -0.05, 0.16666666666667
5695, 0.39130434782609, -0.05, 0.22222222222222
5696, 0.39130434782609, -0.05, 0.27777777777778
5697, 0.39130434782609, -0.05, 0.33333333333333
5698, 0.39130434782609, -0.05, 0.38888888888889
5699, 0.39130434782609, -0.05, 0.44444444444444
5700, 0.43478260869565, -0.05, 0.055555555555556
5701, 0.43478260869565, -0.05, 0.11111111111111
5702, 0.43478260869565, -0.05, 0.16666666666667
5703, 0.43478260869565, -0.05, 0.22222222222222
5704, 0.43478260869565, -0.05, 0.27777777777778
5705, 0.43478260869565, -0.05, 0.33333333333333
5706, 0.43478260869565, -0.05, 0.38888888888889
5707, 0.43478260869565, -0.05, 0.44444444444444
5708, 0.47826086956522, -0.05, 0.055555555555556
5709, 0.47826086956522, -0.05, 0.11111111111111
5710, 0.47826086956522, -0.05, 0.16666666666667
5711, 0.47826086956522, -0.05, 0.22222222222222
5712, 0.47826086956522, -0.05, 0.27777777777778
5713, 0.47826086956522, -0.05, 0.33333333333333
5714, 0.47826086956522, -0.05, 0.38888888888889
5715, 0.47826086956522, -0.05, 0.44444444444444
5716, 0.52173913043478, -0.05, 0.055555555555556
5717, 0.52173913043478, -0.05, 0.11111111111111
5718, 0.52173913043478, -0.05, 0.16666666666667
5719, 0.52173913043478, -0.05, 0.22222222222222
5720, 0.52173913043478, -0.05, 0.27777777777778
5721, 0.52173913043478, -0.05, 0.33333333333333
5722, 0.52173913043478, -0.05, 0.38888888888889
5723, 0.52173913043478, -0.05, 0.44444444444444
5724, 0.56521739130435, -0.05, 0.055555555555556
5725, 0.56521739130435, -0.05, 0.11111111111111
5726, 0.56521739130435, -0.05, 0.16666666666667
5727, 0.56521739130435, -0.05, 0.22222222222222
5728, 0.56521739130435, -0.05, 0.27777777777778
5729, 0.56521739130435, -0.05, 0.33333333333333
5730, 0.56521739130435, -0.05, 0.38888888888889
5731, 0.56521739130435, -0.05, 0.44444444444444
5732, 0.60869565217391, -0.05, 0.055555555555556
5733, 0.60869565217391, -0.05, 0.11111111111111
5734, 0.60869565217391, -0.05, 0.16666666666667
5735, 0.60869565217391, -0.05, 0.22222222222222
5736, 0.60869565217391, -0.05, 0.27777777777778
5737, 0.60869565217391, -0.05, 0.33333333333333
5738, 0.60869565217391, -0.05, 0.38888888888889
5739, 0.60869565217391, -0.05, 0.44444444444444
5740, 0.65217391304348, -0.05, 0.055555555555556
5741, 0.65217391304348, -0.05, 0.11111111111111
5742, 0.65217391304348, -0.05, 0.16666666666667
5743, 0.65217391304348, -0.05, 0.22222222222222
5744, 0.65217391304348, -0.05, 0.27777777777778
5745, 0.65217391304348, -0.05, 0.33333333333333
5746, 0.65217391304348, -0.05, 0.38888888888889
5747, 0.65217391304348, -0.05, 0.44444444444444
5748, 0.69565217391304, -0.05, 0.055555555555556
5749, 0.69565217391304, -0.05, 0.11111111111111
5750, 0.69565217391304, -0.05, 0.16666666666667
5751, 0.69565217391304, -0.05, 0.22222222222222
5752, 0.69565217391304, -0.05, 0.27777777777778
5753, 0.69565217391304, -0.05, 0.33333333333333
5754, 0.69565217391304, -0.05, 0.38888888888889
5755, 0.69565217391304, -0.05, 0.44444444444444
5756, 0.73913043478261, -0.05, 0.055555555555556
5757, 0.73913043478261, -0.05, 0.11111111111111
5758, 0.73913043478261, -0.05, 0.16666666666667
5759, 0.73913043478261, -0.05, 0.22222222222222
5760, 0.73913043478261, -0.05, 0.27777777777778
5761, 0.73913043478261, -0.05, 0.33333333333333
5762, 0.73913043478261, -0.05, 0.38888888888889
5763, 0.73913043478261, -0.05, 0.44444444444444
5764, 0.78260869565217, -0.05, 0.055555555555556
5765, 0.78260869565217, -0.05, 0.11111111111111
5766, 0.78260869565217, -0.05, 0.16666666666667
5767, 0.78260869565217, -0.05, 0.22222222222222
5768, 0.78260869565217, -0.05, 0.27777777777778
5769, 0.78260869565217, -0.05, 0.33333333333333
5770, 0.78260869565217, -0.05, 0.38888888888889
5771, 0.78260869565217, -0.05, 0.44444444444444
5772, 0.82608695652174, -0.05, 0.055555555555556
5773, 0.82608695652174, -0.05, 0.11111111111111
5774, 0.82608695652174, -0.05, 0.16666666666667
5775, 0.82608695652174, -0.05, 0.22222222222222
5776, 0.82608695652174, -0.05, 0.27777777777778
5777, 0.82608695652174, -0.05, 0.33333333333333
5778, 0.82608695652174, -0.05, 0.38888888888889
5779, 0.82608695652174, -0.05, 0.44444444444444
5780, 0.8695652173913, -0.05, 0.055555555555556
5781, 0.8695652173913, -0.05, 0.11111111111111
5782, 0.8695652173913, -0.05, 0.16666666666667
5783, 0.8695652173913, -0.05, 0.22222222222222
5784, 0.8695652173913, -0.05, 0.27777777777778
