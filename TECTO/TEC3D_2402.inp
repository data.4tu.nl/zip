47784, 0.065217391304348, 0.67173913043478, 0.16666666666667
47785, 0.043478260869565, 0.64565217391304, 0.16666666666667
47786, 0.043478260869565, 0.67173913043478, 0.19444444444444
47787, 0.065217391304348, 0.67173913043478, 0.22222222222222
47788, 0.043478260869565, 0.64565217391304, 0.22222222222222
47789, 0.043478260869565, 0.67173913043478, 0.25
47790, 0.065217391304348, 0.67173913043478, 0.27777777777778
47791, 0.043478260869565, 0.64565217391304, 0.27777777777778
47792, 0.043478260869565, 0.67173913043478, 0.30555555555556
47793, 0.065217391304348, 0.67173913043478, 0.33333333333333
47794, 0.043478260869565, 0.64565217391304, 0.33333333333333
47795, 0.043478260869565, 0.67173913043478, 0.36111111111111
47796, 0.065217391304348, 0.67173913043478, 0.38888888888889
47797, 0.043478260869565, 0.64565217391304, 0.38888888888889
47798, 0.043478260869565, 0.67173913043478, 0.41666666666667
47799, 0.065217391304348, 0.67173913043478, 0.44444444444444
47800, 0.043478260869565, 0.64565217391304, 0.44444444444444
47801, 0.043478260869565, 0.67173913043478, 0.47222222222222
47802, 0.021739130434783, 0.67173913043478, 0.055555555555556
47803, 0.021739130434783, 0.67173913043478, 0.11111111111111
47804, 0.021739130434783, 0.67173913043478, 0.16666666666667
47805, 0.021739130434783, 0.67173913043478, 0.22222222222222
47806, 0.021739130434783, 0.67173913043478, 0.27777777777778
47807, 0.021739130434783, 0.67173913043478, 0.33333333333333
47808, 0.021739130434783, 0.67173913043478, 0.38888888888889
47809, 0.021739130434783, 0.67173913043478, 0.44444444444444
47810, 0.95652173913043, 0.72391304347826, 0.027777777777778
47811, 0.97826086956522, 0.72391304347826, 0.055555555555556
47812, 0.95652173913043, 0.69782608695652, 0.055555555555556
47813, 0.95652173913043, 0.72391304347826, 0.083333333333333
47814, 0.97826086956522, 0.72391304347826, 0.11111111111111
47815, 0.95652173913044, 0.69782608695652, 0.11111111111111
47816, 0.95652173913044, 0.72391304347826, 0.13888888888889
47817, 0.97826086956522, 0.72391304347826, 0.16666666666667
47818, 0.95652173913044, 0.69782608695652, 0.16666666666667
47819, 0.95652173913044, 0.72391304347826, 0.19444444444444
47820, 0.97826086956522, 0.72391304347826, 0.22222222222222
47821, 0.95652173913044, 0.69782608695652, 0.22222222222222
47822, 0.95652173913044, 0.72391304347826, 0.25
47823, 0.97826086956522, 0.72391304347826, 0.27777777777778
47824, 0.95652173913044, 0.69782608695652, 0.27777777777778
47825, 0.95652173913044, 0.72391304347826, 0.30555555555556
47826, 0.97826086956522, 0.72391304347826, 0.33333333333333
47827, 0.95652173913044, 0.69782608695652, 0.33333333333333
47828, 0.95652173913044, 0.72391304347826, 0.36111111111111
47829, 0.97826086956522, 0.72391304347826, 0.38888888888889
47830, 0.95652173913044, 0.69782608695652, 0.38888888888889
47831, 0.95652173913044, 0.72391304347826, 0.41666666666667
47832, 0.97826086956522, 0.72391304347826, 0.44444444444444
47833, 0.95652173913044, 0.69782608695652, 0.44444444444444
47834, 0.95652173913043, 0.72391304347826, 0.47222222222222
47835, 0.91304347826087, 0.72391304347826, 0.027777777777778
47836, 0.93478260869565, 0.72391304347826, 0.055555555555556
47837, 0.91304347826087, 0.69782608695652, 0.055555555555556
47838, 0.91304347826087, 0.72391304347826, 0.083333333333333
47839, 0.93478260869565, 0.72391304347826, 0.11111111111111
47840, 0.91304347826087, 0.69782608695652, 0.11111111111111
47841, 0.91304347826087, 0.72391304347826, 0.13888888888889
47842, 0.93478260869565, 0.72391304347826, 0.16666666666667
47843, 0.91304347826087, 0.69782608695652, 0.16666666666667
47844, 0.91304347826087, 0.72391304347826, 0.19444444444444
47845, 0.93478260869565, 0.72391304347826, 0.22222222222222
47846, 0.91304347826087, 0.69782608695652, 0.22222222222222
47847, 0.91304347826087, 0.72391304347826, 0.25
47848, 0.93478260869565, 0.72391304347826, 0.27777777777778
47849, 0.91304347826087, 0.69782608695652, 0.27777777777778
47850, 0.91304347826087, 0.72391304347826, 0.30555555555556
47851, 0.93478260869565, 0.72391304347826, 0.33333333333333
47852, 0.91304347826087, 0.69782608695652, 0.33333333333333
47853, 0.91304347826087, 0.72391304347826, 0.36111111111111
47854, 0.93478260869565, 0.72391304347826, 0.38888888888889
47855, 0.91304347826087, 0.69782608695652, 0.38888888888889
47856, 0.91304347826087, 0.72391304347826, 0.41666666666667
47857, 0.93478260869565, 0.72391304347826, 0.44444444444444
47858, 0.91304347826087, 0.69782608695652, 0.44444444444444
47859, 0.91304347826087, 0.72391304347826, 0.47222222222222
47860, 0.8695652173913, 0.72391304347826, 0.027777777777778
47861, 0.89130434782609, 0.72391304347826, 0.055555555555556
47862, 0.8695652173913, 0.69782608695652, 0.055555555555556
47863, 0.8695652173913, 0.72391304347826, 0.083333333333333
47864, 0.89130434782609, 0.72391304347826, 0.11111111111111
47865, 0.8695652173913, 0.69782608695652, 0.11111111111111
47866, 0.8695652173913, 0.72391304347826, 0.13888888888889
47867, 0.89130434782609, 0.72391304347826, 0.16666666666667
47868, 0.8695652173913, 0.69782608695652, 0.16666666666667
47869, 0.8695652173913, 0.72391304347826, 0.19444444444444
47870, 0.89130434782609, 0.72391304347826, 0.22222222222222
47871, 0.8695652173913, 0.69782608695652, 0.22222222222222
47872, 0.8695652173913, 0.72391304347826, 0.25
47873, 0.89130434782609, 0.72391304347826, 0.27777777777778
47874, 0.8695652173913, 0.69782608695652, 0.27777777777778
47875, 0.8695652173913, 0.72391304347826, 0.30555555555556
47876, 0.89130434782609, 0.72391304347826, 0.33333333333333
47877, 0.8695652173913, 0.69782608695652, 0.33333333333333
47878, 0.8695652173913, 0.72391304347826, 0.36111111111111
47879, 0.89130434782609, 0.72391304347826, 0.38888888888889
47880, 0.8695652173913, 0.69782608695652, 0.38888888888889
47881, 0.8695652173913, 0.72391304347826, 0.41666666666667
47882, 0.89130434782609, 0.72391304347826, 0.44444444444444
47883, 0.8695652173913, 0.69782608695652, 0.44444444444444
47884, 0.8695652173913, 0.72391304347826, 0.47222222222222
47885, 0.82608695652174, 0.72391304347826, 0.027777777777778
47886, 0.84782608695652, 0.72391304347826, 0.055555555555556
47887, 0.82608695652174, 0.69782608695652, 0.055555555555556
47888, 0.82608695652174, 0.72391304347826, 0.083333333333333
47889, 0.84782608695652, 0.72391304347826, 0.11111111111111
47890, 0.82608695652174, 0.69782608695652, 0.11111111111111
47891, 0.82608695652174, 0.72391304347826, 0.13888888888889
47892, 0.84782608695652, 0.72391304347826, 0.16666666666667
47893, 0.82608695652174, 0.69782608695652, 0.16666666666667
47894, 0.82608695652174, 0.72391304347826, 0.19444444444444
47895, 0.84782608695652, 0.72391304347826, 0.22222222222222
47896, 0.82608695652174, 0.69782608695652, 0.22222222222222
47897, 0.82608695652174, 0.72391304347826, 0.25
47898, 0.84782608695652, 0.72391304347826, 0.27777777777778
47899, 0.82608695652174, 0.69782608695652, 0.27777777777778
47900, 0.82608695652174, 0.72391304347826, 0.30555555555556
47901, 0.84782608695652, 0.72391304347826, 0.33333333333333
47902, 0.82608695652174, 0.69782608695652, 0.33333333333333
47903, 0.82608695652174, 0.72391304347826, 0.36111111111111
47904, 0.84782608695652, 0.72391304347826, 0.38888888888889
47905, 0.82608695652174, 0.69782608695652, 0.38888888888889
47906, 0.82608695652174, 0.72391304347826, 0.41666666666667
47907, 0.84782608695652, 0.72391304347826, 0.44444444444444
47908, 0.82608695652174, 0.69782608695652, 0.44444444444444
47909, 0.82608695652174, 0.72391304347826, 0.47222222222222
47910, 0.78260869565217, 0.72391304347826, 0.027777777777778
47911, 0.80434782608696, 0.72391304347826, 0.055555555555556
47912, 0.78260869565217, 0.69782608695652, 0.055555555555556
47913, 0.78260869565217, 0.72391304347826, 0.083333333333333
47914, 0.80434782608696, 0.72391304347826, 0.11111111111111
47915, 0.78260869565217, 0.69782608695652, 0.11111111111111
47916, 0.78260869565217, 0.72391304347826, 0.13888888888889
47917, 0.80434782608696, 0.72391304347826, 0.16666666666667
47918, 0.78260869565217, 0.69782608695652, 0.16666666666667
47919, 0.78260869565217, 0.72391304347826, 0.19444444444444
47920, 0.80434782608696, 0.72391304347826, 0.22222222222222
47921, 0.78260869565217, 0.69782608695652, 0.22222222222222
47922, 0.78260869565217, 0.72391304347826, 0.25
47923, 0.80434782608696, 0.72391304347826, 0.27777777777778
47924, 0.78260869565217, 0.69782608695652, 0.27777777777778
47925, 0.78260869565217, 0.72391304347826, 0.30555555555556
47926, 0.80434782608696, 0.72391304347826, 0.33333333333333
47927, 0.78260869565217, 0.69782608695652, 0.33333333333333
47928, 0.78260869565217, 0.72391304347826, 0.36111111111111
47929, 0.80434782608696, 0.72391304347826, 0.38888888888889
47930, 0.78260869565217, 0.69782608695652, 0.38888888888889
47931, 0.78260869565217, 0.72391304347826, 0.41666666666667
47932, 0.80434782608696, 0.72391304347826, 0.44444444444444
47933, 0.78260869565217, 0.69782608695652, 0.44444444444444
47934, 0.78260869565217, 0.72391304347826, 0.47222222222222
47935, 0.73913043478261, 0.72391304347826, 0.027777777777778
47936, 0.76086956521739, 0.72391304347826, 0.055555555555556
47937, 0.73913043478261, 0.69782608695652, 0.055555555555556
47938, 0.73913043478261, 0.72391304347826, 0.083333333333333
47939, 0.76086956521739, 0.72391304347826, 0.11111111111111
47940, 0.73913043478261, 0.69782608695652, 0.11111111111111
47941, 0.73913043478261, 0.72391304347826, 0.13888888888889
47942, 0.76086956521739, 0.72391304347826, 0.16666666666667
47943, 0.73913043478261, 0.69782608695652, 0.16666666666667
47944, 0.73913043478261, 0.72391304347826, 0.19444444444444
47945, 0.76086956521739, 0.72391304347826, 0.22222222222222
47946, 0.73913043478261, 0.69782608695652, 0.22222222222222
47947, 0.73913043478261, 0.72391304347826, 0.25
47948, 0.76086956521739, 0.72391304347826, 0.27777777777778
47949, 0.73913043478261, 0.69782608695652, 0.27777777777778
47950, 0.73913043478261, 0.72391304347826, 0.30555555555556
47951, 0.76086956521739, 0.72391304347826, 0.33333333333333
47952, 0.73913043478261, 0.69782608695652, 0.33333333333333
47953, 0.73913043478261, 0.72391304347826, 0.36111111111111
47954, 0.76086956521739, 0.72391304347826, 0.38888888888889
47955, 0.73913043478261, 0.69782608695652, 0.38888888888889
47956, 0.73913043478261, 0.72391304347826, 0.41666666666667
47957, 0.76086956521739, 0.72391304347826, 0.44444444444444
47958, 0.73913043478261, 0.69782608695652, 0.44444444444444
47959, 0.73913043478261, 0.72391304347826, 0.47222222222222
47960, 0.69565217391304, 0.72391304347826, 0.027777777777778
47961, 0.71739130434783, 0.72391304347826, 0.055555555555556
47962, 0.69565217391304, 0.69782608695652, 0.055555555555556
47963, 0.69565217391304, 0.72391304347826, 0.083333333333333
47964, 0.71739130434783, 0.72391304347826, 0.11111111111111
47965, 0.69565217391304, 0.69782608695652, 0.11111111111111
47966, 0.69565217391304, 0.72391304347826, 0.13888888888889
47967, 0.71739130434783, 0.72391304347826, 0.16666666666667
47968, 0.69565217391304, 0.69782608695652, 0.16666666666667
47969, 0.69565217391304, 0.72391304347826, 0.19444444444444
47970, 0.71739130434783, 0.72391304347826, 0.22222222222222
47971, 0.69565217391304, 0.69782608695652, 0.22222222222222
47972, 0.69565217391304, 0.72391304347826, 0.25
47973, 0.71739130434783, 0.72391304347826, 0.27777777777778
47974, 0.69565217391304, 0.69782608695652, 0.27777777777778
47975, 0.69565217391304, 0.72391304347826, 0.30555555555556
47976, 0.71739130434783, 0.72391304347826, 0.33333333333333
47977, 0.69565217391304, 0.69782608695652, 0.33333333333333
47978, 0.69565217391304, 0.72391304347826, 0.36111111111111
47979, 0.71739130434783, 0.72391304347826, 0.38888888888889
47980, 0.69565217391304, 0.69782608695652, 0.38888888888889
47981, 0.69565217391304, 0.72391304347826, 0.41666666666667
47982, 0.71739130434783, 0.72391304347826, 0.44444444444444
47983, 0.69565217391304, 0.69782608695652, 0.44444444444444
47984, 0.69565217391304, 0.72391304347826, 0.47222222222222
47985, 0.65217391304348, 0.72391304347826, 0.027777777777778
47986, 0.67391304347826, 0.72391304347826, 0.055555555555556
47987, 0.65217391304348, 0.69782608695652, 0.055555555555556
47988, 0.65217391304348, 0.72391304347826, 0.083333333333333
47989, 0.67391304347826, 0.72391304347826, 0.11111111111111
47990, 0.65217391304348, 0.69782608695652, 0.11111111111111
47991, 0.65217391304348, 0.72391304347826, 0.13888888888889
47992, 0.67391304347826, 0.72391304347826, 0.16666666666667
47993, 0.65217391304348, 0.69782608695652, 0.16666666666667
47994, 0.65217391304348, 0.72391304347826, 0.19444444444444
47995, 0.67391304347826, 0.72391304347826, 0.22222222222222
47996, 0.65217391304348, 0.69782608695652, 0.22222222222222
47997, 0.65217391304348, 0.72391304347826, 0.25
47998, 0.67391304347826, 0.72391304347826, 0.27777777777778
47999, 0.65217391304348, 0.69782608695652, 0.27777777777778
48000, 0.65217391304348, 0.72391304347826, 0.30555555555556
48001, 0.67391304347826, 0.72391304347826, 0.33333333333333
48002, 0.65217391304348, 0.69782608695652, 0.33333333333333
48003, 0.65217391304348, 0.72391304347826, 0.36111111111111
48004, 0.67391304347826, 0.72391304347826, 0.38888888888889
48005, 0.65217391304348, 0.69782608695652, 0.38888888888889
48006, 0.65217391304348, 0.72391304347826, 0.41666666666667
48007, 0.67391304347826, 0.72391304347826, 0.44444444444444
48008, 0.65217391304348, 0.69782608695652, 0.44444444444444
48009, 0.65217391304348, 0.72391304347826, 0.47222222222222
48010, 0.60869565217391, 0.72391304347826, 0.027777777777778
48011, 0.6304347826087, 0.72391304347826, 0.055555555555556
48012, 0.60869565217391, 0.69782608695652, 0.055555555555556
48013, 0.60869565217391, 0.72391304347826, 0.083333333333333
48014, 0.6304347826087, 0.72391304347826, 0.11111111111111
48015, 0.60869565217391, 0.69782608695652, 0.11111111111111
48016, 0.60869565217391, 0.72391304347826, 0.13888888888889
48017, 0.6304347826087, 0.72391304347826, 0.16666666666667
48018, 0.60869565217391, 0.69782608695652, 0.16666666666667
48019, 0.60869565217391, 0.72391304347826, 0.19444444444444
48020, 0.6304347826087, 0.72391304347826, 0.22222222222222
48021, 0.60869565217391, 0.69782608695652, 0.22222222222222
48022, 0.60869565217391, 0.72391304347826, 0.25
48023, 0.6304347826087, 0.72391304347826, 0.27777777777778
48024, 0.60869565217391, 0.69782608695652, 0.27777777777778
48025, 0.60869565217391, 0.72391304347826, 0.30555555555556
48026, 0.6304347826087, 0.72391304347826, 0.33333333333333
48027, 0.60869565217391, 0.69782608695652, 0.33333333333333
48028, 0.60869565217391, 0.72391304347826, 0.36111111111111
48029, 0.6304347826087, 0.72391304347826, 0.38888888888889
48030, 0.60869565217391, 0.69782608695652, 0.38888888888889
48031, 0.60869565217391, 0.72391304347826, 0.41666666666667
48032, 0.6304347826087, 0.72391304347826, 0.44444444444444
48033, 0.60869565217391, 0.69782608695652, 0.44444444444444
48034, 0.60869565217391, 0.72391304347826, 0.47222222222222
48035, 0.56521739130435, 0.72391304347826, 0.027777777777778
48036, 0.58695652173913, 0.72391304347826, 0.055555555555556
48037, 0.56521739130435, 0.69782608695652, 0.055555555555556
48038, 0.56521739130435, 0.72391304347826, 0.083333333333333
48039, 0.58695652173913, 0.72391304347826, 0.11111111111111
48040, 0.56521739130435, 0.69782608695652, 0.11111111111111
48041, 0.56521739130435, 0.72391304347826, 0.13888888888889
48042, 0.58695652173913, 0.72391304347826, 0.16666666666667
48043, 0.56521739130435, 0.69782608695652, 0.16666666666667
48044, 0.56521739130435, 0.72391304347826, 0.19444444444444
48045, 0.58695652173913, 0.72391304347826, 0.22222222222222
48046, 0.56521739130435, 0.69782608695652, 0.22222222222222
48047, 0.56521739130435, 0.72391304347826, 0.25
48048, 0.58695652173913, 0.72391304347826, 0.27777777777778
48049, 0.56521739130435, 0.69782608695652, 0.27777777777778
48050, 0.56521739130435, 0.72391304347826, 0.30555555555556
48051, 0.58695652173913, 0.72391304347826, 0.33333333333333
48052, 0.56521739130435, 0.69782608695652, 0.33333333333333
48053, 0.56521739130435, 0.72391304347826, 0.36111111111111
48054, 0.58695652173913, 0.72391304347826, 0.38888888888889
48055, 0.56521739130435, 0.69782608695652, 0.38888888888889
48056, 0.56521739130435, 0.72391304347826, 0.41666666666667
48057, 0.58695652173913, 0.72391304347826, 0.44444444444444
48058, 0.56521739130435, 0.69782608695652, 0.44444444444444
48059, 0.56521739130435, 0.72391304347826, 0.47222222222222
48060, 0.52173913043478, 0.72391304347826, 0.027777777777778
48061, 0.54347826086957, 0.72391304347826, 0.055555555555556
48062, 0.52173913043478, 0.69782608695652, 0.055555555555556
48063, 0.52173913043478, 0.72391304347826, 0.083333333333333
48064, 0.54347826086957, 0.72391304347826, 0.11111111111111
48065, 0.52173913043478, 0.69782608695652, 0.11111111111111
48066, 0.52173913043478, 0.72391304347826, 0.13888888888889
48067, 0.54347826086957, 0.72391304347826, 0.16666666666667
48068, 0.52173913043478, 0.69782608695652, 0.16666666666667
48069, 0.52173913043478, 0.72391304347826, 0.19444444444444
48070, 0.54347826086956, 0.72391304347826, 0.22222222222222
48071, 0.52173913043478, 0.69782608695652, 0.22222222222222
48072, 0.52173913043478, 0.72391304347826, 0.25
48073, 0.54347826086956, 0.72391304347826, 0.27777777777778
48074, 0.52173913043478, 0.69782608695652, 0.27777777777778
48075, 0.52173913043478, 0.72391304347826, 0.30555555555556
48076, 0.54347826086956, 0.72391304347826, 0.33333333333333
48077, 0.52173913043478, 0.69782608695652, 0.33333333333333
48078, 0.52173913043478, 0.72391304347826, 0.36111111111111
48079, 0.54347826086956, 0.72391304347826, 0.38888888888889
48080, 0.52173913043478, 0.69782608695652, 0.38888888888889
48081, 0.52173913043478, 0.72391304347826, 0.41666666666667
48082, 0.54347826086956, 0.72391304347826, 0.44444444444444
48083, 0.52173913043478, 0.69782608695652, 0.44444444444444
48084, 0.52173913043478, 0.72391304347826, 0.47222222222222
48085, 0.47826086956522, 0.72391304347826, 0.027777777777778
48086, 0.5, 0.72391304347826, 0.055555555555556
48087, 0.47826086956522, 0.69782608695652, 0.055555555555556
48088, 0.47826086956522, 0.72391304347826, 0.083333333333333
48089, 0.5, 0.72391304347826, 0.11111111111111
48090, 0.47826086956522, 0.69782608695652, 0.11111111111111
48091, 0.47826086956522, 0.72391304347826, 0.13888888888889
48092, 0.5, 0.72391304347826, 0.16666666666667
48093, 0.47826086956522, 0.69782608695652, 0.16666666666667
48094, 0.47826086956522, 0.72391304347826, 0.19444444444444
48095, 0.5, 0.72391304347826, 0.22222222222222
48096, 0.47826086956522, 0.69782608695652, 0.22222222222222
48097, 0.47826086956522, 0.72391304347826, 0.25
48098, 0.5, 0.72391304347826, 0.27777777777778
48099, 0.47826086956522, 0.69782608695652, 0.27777777777778
48100, 0.47826086956522, 0.72391304347826, 0.30555555555556
48101, 0.5, 0.72391304347826, 0.33333333333333
48102, 0.47826086956522, 0.69782608695652, 0.33333333333333
48103, 0.47826086956522, 0.72391304347826, 0.36111111111111
48104, 0.5, 0.72391304347826, 0.38888888888889
48105, 0.47826086956522, 0.69782608695652, 0.38888888888889
48106, 0.47826086956522, 0.72391304347826, 0.41666666666667
48107, 0.5, 0.72391304347826, 0.44444444444444
48108, 0.47826086956522, 0.69782608695652, 0.44444444444444
48109, 0.47826086956522, 0.72391304347826, 0.47222222222222
48110, 0.43478260869565, 0.72391304347826, 0.027777777777778
48111, 0.45652173913043, 0.72391304347826, 0.055555555555556
48112, 0.43478260869565, 0.69782608695652, 0.055555555555556
48113, 0.43478260869565, 0.72391304347826, 0.083333333333333
48114, 0.45652173913043, 0.72391304347826, 0.11111111111111
48115, 0.43478260869565, 0.69782608695652, 0.11111111111111
48116, 0.43478260869565, 0.72391304347826, 0.13888888888889
48117, 0.45652173913043, 0.72391304347826, 0.16666666666667
48118, 0.43478260869565, 0.69782608695652, 0.16666666666667
48119, 0.43478260869565, 0.72391304347826, 0.19444444444444
48120, 0.45652173913043, 0.72391304347826, 0.22222222222222
48121, 0.43478260869565, 0.69782608695652, 0.22222222222222
48122, 0.43478260869565, 0.72391304347826, 0.25
48123, 0.45652173913043, 0.72391304347826, 0.27777777777778
48124, 0.43478260869565, 0.69782608695652, 0.27777777777778
48125, 0.43478260869565, 0.72391304347826, 0.30555555555556
48126, 0.45652173913043, 0.72391304347826, 0.33333333333333
48127, 0.43478260869565, 0.69782608695652, 0.33333333333333
48128, 0.43478260869565, 0.72391304347826, 0.36111111111111
48129, 0.45652173913043, 0.72391304347826, 0.38888888888889
48130, 0.43478260869565, 0.69782608695652, 0.38888888888889
48131, 0.43478260869565, 0.72391304347826, 0.41666666666667
48132, 0.45652173913043, 0.72391304347826, 0.44444444444444
48133, 0.43478260869565, 0.69782608695652, 0.44444444444444
48134, 0.43478260869565, 0.72391304347826, 0.47222222222222
48135, 0.39130434782609, 0.72391304347826, 0.027777777777778
48136, 0.41304347826087, 0.72391304347826, 0.055555555555556
48137, 0.39130434782609, 0.69782608695652, 0.055555555555556
48138, 0.39130434782609, 0.72391304347826, 0.083333333333333
48139, 0.41304347826087, 0.72391304347826, 0.11111111111111
48140, 0.39130434782609, 0.69782608695652, 0.11111111111111
48141, 0.39130434782609, 0.72391304347826, 0.13888888888889
48142, 0.41304347826087, 0.72391304347826, 0.16666666666667
48143, 0.39130434782609, 0.69782608695652, 0.16666666666667
48144, 0.39130434782609, 0.72391304347826, 0.19444444444444
48145, 0.41304347826087, 0.72391304347826, 0.22222222222222
48146, 0.39130434782609, 0.69782608695652, 0.22222222222222
48147, 0.39130434782609, 0.72391304347826, 0.25
48148, 0.41304347826087, 0.72391304347826, 0.27777777777778
48149, 0.39130434782609, 0.69782608695652, 0.27777777777778
48150, 0.39130434782609, 0.72391304347826, 0.30555555555556
48151, 0.41304347826087, 0.72391304347826, 0.33333333333333
48152, 0.39130434782609, 0.69782608695652, 0.33333333333333
48153, 0.39130434782609, 0.72391304347826, 0.36111111111111
48154, 0.41304347826087, 0.72391304347826, 0.38888888888889
48155, 0.39130434782609, 0.69782608695652, 0.38888888888889
48156, 0.39130434782609, 0.72391304347826, 0.41666666666667
48157, 0.41304347826087, 0.72391304347826, 0.44444444444444
48158, 0.39130434782609, 0.69782608695652, 0.44444444444444
48159, 0.39130434782609, 0.72391304347826, 0.47222222222222
48160, 0.34782608695652, 0.72391304347826, 0.027777777777778
48161, 0.3695652173913, 0.72391304347826, 0.055555555555556
48162, 0.34782608695652, 0.69782608695652, 0.055555555555556
48163, 0.34782608695652, 0.72391304347826, 0.083333333333333
48164, 0.3695652173913, 0.72391304347826, 0.11111111111111
48165, 0.34782608695652, 0.69782608695652, 0.11111111111111
48166, 0.34782608695652, 0.72391304347826, 0.13888888888889
48167, 0.3695652173913, 0.72391304347826, 0.16666666666667
48168, 0.34782608695652, 0.69782608695652, 0.16666666666667
48169, 0.34782608695652, 0.72391304347826, 0.19444444444444
48170, 0.3695652173913, 0.72391304347826, 0.22222222222222
48171, 0.34782608695652, 0.69782608695652, 0.22222222222222
48172, 0.34782608695652, 0.72391304347826, 0.25
48173, 0.3695652173913, 0.72391304347826, 0.27777777777778
48174, 0.34782608695652, 0.69782608695652, 0.27777777777778
48175, 0.34782608695652, 0.72391304347826, 0.30555555555556
48176, 0.3695652173913, 0.72391304347826, 0.33333333333333
48177, 0.34782608695652, 0.69782608695652, 0.33333333333333
48178, 0.34782608695652, 0.72391304347826, 0.36111111111111
48179, 0.3695652173913, 0.72391304347826, 0.38888888888889
48180, 0.34782608695652, 0.69782608695652, 0.38888888888889
48181, 0.34782608695652, 0.72391304347826, 0.41666666666667
48182, 0.3695652173913, 0.72391304347826, 0.44444444444444
48183, 0.34782608695652, 0.69782608695652, 0.44444444444444
48184, 0.34782608695652, 0.72391304347826, 0.47222222222222
48185, 0.30434782608696, 0.72391304347826, 0.027777777777778
48186, 0.32608695652174, 0.72391304347826, 0.055555555555556
48187, 0.30434782608696, 0.69782608695652, 0.055555555555556
48188, 0.30434782608696, 0.72391304347826, 0.083333333333333
48189, 0.32608695652174, 0.72391304347826, 0.11111111111111
48190, 0.30434782608696, 0.69782608695652, 0.11111111111111
48191, 0.30434782608696, 0.72391304347826, 0.13888888888889
48192, 0.32608695652174, 0.72391304347826, 0.16666666666667
48193, 0.30434782608696, 0.69782608695652, 0.16666666666667
48194, 0.30434782608696, 0.72391304347826, 0.19444444444444
48195, 0.32608695652174, 0.72391304347826, 0.22222222222222
48196, 0.30434782608696, 0.69782608695652, 0.22222222222222
48197, 0.30434782608696, 0.72391304347826, 0.25
48198, 0.32608695652174, 0.72391304347826, 0.27777777777778
48199, 0.30434782608696, 0.69782608695652, 0.27777777777778
48200, 0.30434782608696, 0.72391304347826, 0.30555555555556
48201, 0.32608695652174, 0.72391304347826, 0.33333333333333
48202, 0.30434782608696, 0.69782608695652, 0.33333333333333
48203, 0.30434782608696, 0.72391304347826, 0.36111111111111
48204, 0.32608695652174, 0.72391304347826, 0.38888888888889
48205, 0.30434782608696, 0.69782608695652, 0.38888888888889
48206, 0.30434782608696, 0.72391304347826, 0.41666666666667
48207, 0.32608695652174, 0.72391304347826, 0.44444444444444
48208, 0.30434782608696, 0.69782608695652, 0.44444444444444
48209, 0.30434782608696, 0.72391304347826, 0.47222222222222
48210, 0.26086956521739, 0.72391304347826, 0.027777777777778
48211, 0.28260869565217, 0.72391304347826, 0.055555555555556
48212, 0.26086956521739, 0.69782608695652, 0.055555555555556
48213, 0.26086956521739, 0.72391304347826, 0.083333333333333
48214, 0.28260869565217, 0.72391304347826, 0.11111111111111
48215, 0.26086956521739, 0.69782608695652, 0.11111111111111
48216, 0.26086956521739, 0.72391304347826, 0.13888888888889
48217, 0.28260869565217, 0.72391304347826, 0.16666666666667
48218, 0.26086956521739, 0.69782608695652, 0.16666666666667
48219, 0.26086956521739, 0.72391304347826, 0.19444444444444
48220, 0.28260869565217, 0.72391304347826, 0.22222222222222
48221, 0.26086956521739, 0.69782608695652, 0.22222222222222
48222, 0.26086956521739, 0.72391304347826, 0.25
48223, 0.28260869565217, 0.72391304347826, 0.27777777777778
48224, 0.26086956521739, 0.69782608695652, 0.27777777777778
48225, 0.26086956521739, 0.72391304347826, 0.30555555555556
48226, 0.28260869565217, 0.72391304347826, 0.33333333333333
48227, 0.26086956521739, 0.69782608695652, 0.33333333333333
48228, 0.26086956521739, 0.72391304347826, 0.36111111111111
48229, 0.28260869565217, 0.72391304347826, 0.38888888888889
48230, 0.26086956521739, 0.69782608695652, 0.38888888888889
48231, 0.26086956521739, 0.72391304347826, 0.41666666666667
48232, 0.28260869565217, 0.72391304347826, 0.44444444444444
48233, 0.26086956521739, 0.69782608695652, 0.44444444444444
48234, 0.26086956521739, 0.72391304347826, 0.47222222222222
48235, 0.21739130434783, 0.72391304347826, 0.027777777777778
48236, 0.23913043478261, 0.72391304347826, 0.055555555555556
48237, 0.21739130434783, 0.69782608695652, 0.055555555555556
48238, 0.21739130434783, 0.72391304347826, 0.083333333333333
48239, 0.23913043478261, 0.72391304347826, 0.11111111111111
48240, 0.21739130434783, 0.69782608695652, 0.11111111111111
48241, 0.21739130434783, 0.72391304347826, 0.13888888888889
48242, 0.23913043478261, 0.72391304347826, 0.16666666666667
48243, 0.21739130434783, 0.69782608695652, 0.16666666666667
48244, 0.21739130434783, 0.72391304347826, 0.19444444444444
48245, 0.23913043478261, 0.72391304347826, 0.22222222222222
48246, 0.21739130434783, 0.69782608695652, 0.22222222222222
48247, 0.21739130434783, 0.72391304347826, 0.25
48248, 0.23913043478261, 0.72391304347826, 0.27777777777778
48249, 0.21739130434783, 0.69782608695652, 0.27777777777778
48250, 0.21739130434783, 0.72391304347826, 0.30555555555556
48251, 0.23913043478261, 0.72391304347826, 0.33333333333333
48252, 0.21739130434783, 0.69782608695652, 0.33333333333333
48253, 0.21739130434783, 0.72391304347826, 0.36111111111111
48254, 0.23913043478261, 0.72391304347826, 0.38888888888889
48255, 0.21739130434783, 0.69782608695652, 0.38888888888889
48256, 0.21739130434783, 0.72391304347826, 0.41666666666667
48257, 0.23913043478261, 0.72391304347826, 0.44444444444444
48258, 0.21739130434783, 0.69782608695652, 0.44444444444444
48259, 0.21739130434783, 0.72391304347826, 0.47222222222222
48260, 0.17391304347826, 0.72391304347826, 0.027777777777778
48261, 0.19565217391304, 0.72391304347826, 0.055555555555556
48262, 0.17391304347826, 0.69782608695652, 0.055555555555556
48263, 0.17391304347826, 0.72391304347826, 0.083333333333333
48264, 0.19565217391304, 0.72391304347826, 0.11111111111111
48265, 0.17391304347826, 0.69782608695652, 0.11111111111111
48266, 0.17391304347826, 0.72391304347826, 0.13888888888889
48267, 0.19565217391304, 0.72391304347826, 0.16666666666667
48268, 0.17391304347826, 0.69782608695652, 0.16666666666667
48269, 0.17391304347826, 0.72391304347826, 0.19444444444444
48270, 0.19565217391304, 0.72391304347826, 0.22222222222222
48271, 0.17391304347826, 0.69782608695652, 0.22222222222222
48272, 0.17391304347826, 0.72391304347826, 0.25
48273, 0.19565217391304, 0.72391304347826, 0.27777777777778
48274, 0.17391304347826, 0.69782608695652, 0.27777777777778
48275, 0.17391304347826, 0.72391304347826, 0.30555555555556
48276, 0.19565217391304, 0.72391304347826, 0.33333333333333
48277, 0.17391304347826, 0.69782608695652, 0.33333333333333
48278, 0.17391304347826, 0.72391304347826, 0.36111111111111
48279, 0.19565217391304, 0.72391304347826, 0.38888888888889
48280, 0.17391304347826, 0.69782608695652, 0.38888888888889
48281, 0.17391304347826, 0.72391304347826, 0.41666666666667
48282, 0.19565217391304, 0.72391304347826, 0.44444444444444
48283, 0.17391304347826, 0.69782608695652, 0.44444444444444
48284, 0.17391304347826, 0.72391304347826, 0.47222222222222
48285, 0.1304347826087, 0.72391304347826, 0.027777777777778
48286, 0.15217391304348, 0.72391304347826, 0.055555555555556
48287, 0.1304347826087, 0.69782608695652, 0.055555555555556
48288, 0.1304347826087, 0.72391304347826, 0.083333333333333
48289, 0.15217391304348, 0.72391304347826, 0.11111111111111
48290, 0.1304347826087, 0.69782608695652, 0.11111111111111
48291, 0.1304347826087, 0.72391304347826, 0.13888888888889
48292, 0.15217391304348, 0.72391304347826, 0.16666666666667
48293, 0.1304347826087, 0.69782608695652, 0.16666666666667
48294, 0.1304347826087, 0.72391304347826, 0.19444444444444
48295, 0.15217391304348, 0.72391304347826, 0.22222222222222
48296, 0.1304347826087, 0.69782608695652, 0.22222222222222
48297, 0.1304347826087, 0.72391304347826, 0.25
48298, 0.15217391304348, 0.72391304347826, 0.27777777777778
48299, 0.1304347826087, 0.69782608695652, 0.27777777777778
48300, 0.1304347826087, 0.72391304347826, 0.30555555555556
48301, 0.15217391304348, 0.72391304347826, 0.33333333333333
48302, 0.1304347826087, 0.69782608695652, 0.33333333333333
48303, 0.1304347826087, 0.72391304347826, 0.36111111111111
48304, 0.15217391304348, 0.72391304347826, 0.38888888888889
48305, 0.1304347826087, 0.69782608695652, 0.38888888888889
48306, 0.1304347826087, 0.72391304347826, 0.41666666666667
48307, 0.15217391304348, 0.72391304347826, 0.44444444444444
48308, 0.1304347826087, 0.69782608695652, 0.44444444444444
48309, 0.1304347826087, 0.72391304347826, 0.47222222222222
48310, 0.08695652173913, 0.72391304347826, 0.027777777777778
48311, 0.10869565217391, 0.72391304347826, 0.055555555555556
48312, 0.08695652173913, 0.69782608695652, 0.055555555555556
48313, 0.08695652173913, 0.72391304347826, 0.083333333333333
48314, 0.10869565217391, 0.72391304347826, 0.11111111111111
48315, 0.08695652173913, 0.69782608695652, 0.11111111111111
48316, 0.08695652173913, 0.72391304347826, 0.13888888888889
48317, 0.10869565217391, 0.72391304347826, 0.16666666666667
48318, 0.08695652173913, 0.69782608695652, 0.16666666666667
48319, 0.08695652173913, 0.72391304347826, 0.19444444444444
48320, 0.10869565217391, 0.72391304347826, 0.22222222222222
48321, 0.08695652173913, 0.69782608695652, 0.22222222222222
48322, 0.08695652173913, 0.72391304347826, 0.25
48323, 0.10869565217391, 0.72391304347826, 0.27777777777778
48324, 0.08695652173913, 0.69782608695652, 0.27777777777778
48325, 0.08695652173913, 0.72391304347826, 0.30555555555556
48326, 0.10869565217391, 0.72391304347826, 0.33333333333333
48327, 0.08695652173913, 0.69782608695652, 0.33333333333333
48328, 0.08695652173913, 0.72391304347826, 0.36111111111111
48329, 0.10869565217391, 0.72391304347826, 0.38888888888889
48330, 0.08695652173913, 0.69782608695652, 0.38888888888889
48331, 0.08695652173913, 0.72391304347826, 0.41666666666667
48332, 0.10869565217391, 0.72391304347826, 0.44444444444444
48333, 0.08695652173913, 0.69782608695652, 0.44444444444444
48334, 0.08695652173913, 0.72391304347826, 0.47222222222222
48335, 0.043478260869565, 0.72391304347826, 0.027777777777778
48336, 0.065217391304348, 0.72391304347826, 0.055555555555556
48337, 0.043478260869565, 0.69782608695652, 0.055555555555556
48338, 0.043478260869565, 0.72391304347826, 0.083333333333333
48339, 0.065217391304348, 0.72391304347826, 0.11111111111111
48340, 0.043478260869565, 0.69782608695652, 0.11111111111111
48341, 0.043478260869565, 0.72391304347826, 0.13888888888889
48342, 0.065217391304348, 0.72391304347826, 0.16666666666667
48343, 0.043478260869565, 0.69782608695652, 0.16666666666667
48344, 0.043478260869565, 0.72391304347826, 0.19444444444444
48345, 0.065217391304348, 0.72391304347826, 0.22222222222222
48346, 0.043478260869565, 0.69782608695652, 0.22222222222222
48347, 0.043478260869565, 0.72391304347826, 0.25
48348, 0.065217391304348, 0.72391304347826, 0.27777777777778
48349, 0.043478260869565, 0.69782608695652, 0.27777777777778
48350, 0.043478260869565, 0.72391304347826, 0.30555555555556
48351, 0.065217391304348, 0.72391304347826, 0.33333333333333
48352, 0.043478260869565, 0.69782608695652, 0.33333333333333
48353, 0.043478260869565, 0.72391304347826, 0.36111111111111
48354, 0.065217391304348, 0.72391304347826, 0.38888888888889
48355, 0.043478260869565, 0.69782608695652, 0.38888888888889
48356, 0.043478260869565, 0.72391304347826, 0.41666666666667
48357, 0.065217391304348, 0.72391304347826, 0.44444444444444
48358, 0.043478260869565, 0.69782608695652, 0.44444444444444
48359, 0.043478260869565, 0.72391304347826, 0.47222222222222
48360, 0.021739130434783, 0.72391304347826, 0.055555555555556
48361, 0.021739130434783, 0.72391304347826, 0.11111111111111
48362, 0.021739130434783, 0.72391304347826, 0.16666666666667
48363, 0.021739130434783, 0.72391304347826, 0.22222222222222
48364, 0.021739130434783, 0.72391304347826, 0.27777777777778
48365, 0.021739130434783, 0.72391304347826, 0.33333333333333
48366, 0.021739130434783, 0.72391304347826, 0.38888888888889
48367, 0.021739130434783, 0.72391304347826, 0.44444444444444
48368, 0.95652173913043, 0.77608695652174, 0.027777777777778
48369, 0.97826086956522, 0.77608695652174, 0.055555555555556
48370, 0.95652173913043, 0.75, 0.055555555555556
48371, 0.95652173913043, 0.77608695652174, 0.083333333333333
48372, 0.97826086956522, 0.77608695652174, 0.11111111111111
48373, 0.95652173913044, 0.75, 0.11111111111111
48374, 0.95652173913044, 0.77608695652174, 0.13888888888889
48375, 0.97826086956522, 0.77608695652174, 0.16666666666667
48376, 0.95652173913044, 0.75, 0.16666666666667
48377, 0.95652173913044, 0.77608695652174, 0.19444444444444
48378, 0.97826086956522, 0.77608695652174, 0.22222222222222
48379, 0.95652173913044, 0.75, 0.22222222222222
48380, 0.95652173913044, 0.77608695652174, 0.25
48381, 0.97826086956522, 0.77608695652174, 0.27777777777778
48382, 0.95652173913044, 0.75, 0.27777777777778
48383, 0.95652173913044, 0.77608695652174, 0.30555555555556
48384, 0.97826086956522, 0.77608695652174, 0.33333333333333
48385, 0.95652173913044, 0.75, 0.33333333333333
48386, 0.95652173913044, 0.77608695652174, 0.36111111111111
48387, 0.97826086956522, 0.77608695652174, 0.38888888888889
48388, 0.95652173913044, 0.75, 0.38888888888889
48389, 0.95652173913044, 0.77608695652174, 0.41666666666667
48390, 0.97826086956522, 0.77608695652174, 0.44444444444444
48391, 0.95652173913044, 0.75, 0.44444444444444
48392, 0.95652173913043, 0.77608695652174, 0.47222222222222
48393, 0.91304347826087, 0.77608695652174, 0.027777777777778
48394, 0.93478260869565, 0.77608695652174, 0.055555555555556
48395, 0.91304347826087, 0.75, 0.055555555555556
48396, 0.91304347826087, 0.77608695652174, 0.083333333333333
48397, 0.93478260869565, 0.77608695652174, 0.11111111111111
48398, 0.91304347826087, 0.75, 0.11111111111111
48399, 0.91304347826087, 0.77608695652174, 0.13888888888889
48400, 0.93478260869565, 0.77608695652174, 0.16666666666667
48401, 0.91304347826087, 0.75, 0.16666666666667
48402, 0.91304347826087, 0.77608695652174, 0.19444444444444
48403, 0.93478260869565, 0.77608695652174, 0.22222222222222
48404, 0.91304347826087, 0.75, 0.22222222222222
48405, 0.91304347826087, 0.77608695652174, 0.25
48406, 0.93478260869565, 0.77608695652174, 0.27777777777778
48407, 0.91304347826087, 0.75, 0.27777777777778
48408, 0.91304347826087, 0.77608695652174, 0.30555555555556
48409, 0.93478260869565, 0.77608695652174, 0.33333333333333
48410, 0.91304347826087, 0.75, 0.33333333333333
48411, 0.91304347826087, 0.77608695652174, 0.36111111111111
48412, 0.93478260869565, 0.77608695652174, 0.38888888888889
48413, 0.91304347826087, 0.75, 0.38888888888889
48414, 0.91304347826087, 0.77608695652174, 0.41666666666667
48415, 0.93478260869565, 0.77608695652174, 0.44444444444444
48416, 0.91304347826087, 0.75, 0.44444444444444
48417, 0.91304347826087, 0.77608695652174, 0.47222222222222
48418, 0.8695652173913, 0.77608695652174, 0.027777777777778
48419, 0.89130434782609, 0.77608695652174, 0.055555555555556
48420, 0.8695652173913, 0.75, 0.055555555555556
48421, 0.8695652173913, 0.77608695652174, 0.083333333333333
48422, 0.89130434782609, 0.77608695652174, 0.11111111111111
48423, 0.8695652173913, 0.75, 0.11111111111111
48424, 0.8695652173913, 0.77608695652174, 0.13888888888889
48425, 0.89130434782609, 0.77608695652174, 0.16666666666667
48426, 0.8695652173913, 0.75, 0.16666666666667
48427, 0.8695652173913, 0.77608695652174, 0.19444444444444
48428, 0.89130434782609, 0.77608695652174, 0.22222222222222
48429, 0.8695652173913, 0.75, 0.22222222222222
48430, 0.8695652173913, 0.77608695652174, 0.25
48431, 0.89130434782609, 0.77608695652174, 0.27777777777778
48432, 0.8695652173913, 0.75, 0.27777777777778
48433, 0.8695652173913, 0.77608695652174, 0.30555555555556
48434, 0.89130434782609, 0.77608695652174, 0.33333333333333
48435, 0.8695652173913, 0.75, 0.33333333333333
48436, 0.8695652173913, 0.77608695652174, 0.36111111111111
48437, 0.89130434782609, 0.77608695652174, 0.38888888888889
48438, 0.8695652173913, 0.75, 0.38888888888889
48439, 0.8695652173913, 0.77608695652174, 0.41666666666667
48440, 0.89130434782609, 0.77608695652174, 0.44444444444444
48441, 0.8695652173913, 0.75, 0.44444444444444
48442, 0.8695652173913, 0.77608695652174, 0.47222222222222
48443, 0.82608695652174, 0.77608695652174, 0.027777777777778
48444, 0.84782608695652, 0.77608695652174, 0.055555555555556
48445, 0.82608695652174, 0.75, 0.055555555555556
48446, 0.82608695652174, 0.77608695652174, 0.083333333333333
48447, 0.84782608695652, 0.77608695652174, 0.11111111111111
48448, 0.82608695652174, 0.75, 0.11111111111111
48449, 0.82608695652174, 0.77608695652174, 0.13888888888889
48450, 0.84782608695652, 0.77608695652174, 0.16666666666667
48451, 0.82608695652174, 0.75, 0.16666666666667
48452, 0.82608695652174, 0.77608695652174, 0.19444444444444
48453, 0.84782608695652, 0.77608695652174, 0.22222222222222
48454, 0.82608695652174, 0.75, 0.22222222222222
48455, 0.82608695652174, 0.77608695652174, 0.25
48456, 0.84782608695652, 0.77608695652174, 0.27777777777778
48457, 0.82608695652174, 0.75, 0.27777777777778
48458, 0.82608695652174, 0.77608695652174, 0.30555555555556
48459, 0.84782608695652, 0.77608695652174, 0.33333333333333
48460, 0.82608695652174, 0.75, 0.33333333333333
48461, 0.82608695652174, 0.77608695652174, 0.36111111111111
48462, 0.84782608695652, 0.77608695652174, 0.38888888888889
48463, 0.82608695652174, 0.75, 0.38888888888889
48464, 0.82608695652174, 0.77608695652174, 0.41666666666667
48465, 0.84782608695652, 0.77608695652174, 0.44444444444444
48466, 0.82608695652174, 0.75, 0.44444444444444
48467, 0.82608695652174, 0.77608695652174, 0.47222222222222
48468, 0.78260869565217, 0.77608695652174, 0.027777777777778
48469, 0.80434782608696, 0.77608695652174, 0.055555555555556
48470, 0.78260869565217, 0.75, 0.055555555555556
48471, 0.78260869565217, 0.77608695652174, 0.083333333333333
48472, 0.80434782608696, 0.77608695652174, 0.11111111111111
48473, 0.78260869565217, 0.75, 0.11111111111111
48474, 0.78260869565217, 0.77608695652174, 0.13888888888889
48475, 0.80434782608696, 0.77608695652174, 0.16666666666667
48476, 0.78260869565217, 0.75, 0.16666666666667
48477, 0.78260869565217, 0.77608695652174, 0.19444444444444
48478, 0.80434782608696, 0.77608695652174, 0.22222222222222
48479, 0.78260869565217, 0.75, 0.22222222222222
48480, 0.78260869565217, 0.77608695652174, 0.25
48481, 0.80434782608696, 0.77608695652174, 0.27777777777778
48482, 0.78260869565217, 0.75, 0.27777777777778
48483, 0.78260869565217, 0.77608695652174, 0.30555555555556
48484, 0.80434782608696, 0.77608695652174, 0.33333333333333
48485, 0.78260869565217, 0.75, 0.33333333333333
48486, 0.78260869565217, 0.77608695652174, 0.36111111111111
48487, 0.80434782608696, 0.77608695652174, 0.38888888888889
48488, 0.78260869565217, 0.75, 0.38888888888889
48489, 0.78260869565217, 0.77608695652174, 0.41666666666667
48490, 0.80434782608696, 0.77608695652174, 0.44444444444444
48491, 0.78260869565217, 0.75, 0.44444444444444
48492, 0.78260869565217, 0.77608695652174, 0.47222222222222
48493, 0.73913043478261, 0.77608695652174, 0.027777777777778
48494, 0.76086956521739, 0.77608695652174, 0.055555555555556
48495, 0.73913043478261, 0.75, 0.055555555555556
48496, 0.73913043478261, 0.77608695652174, 0.083333333333333
48497, 0.76086956521739, 0.77608695652174, 0.11111111111111
48498, 0.73913043478261, 0.75, 0.11111111111111
48499, 0.73913043478261, 0.77608695652174, 0.13888888888889
48500, 0.76086956521739, 0.77608695652174, 0.16666666666667
48501, 0.73913043478261, 0.75, 0.16666666666667
48502, 0.73913043478261, 0.77608695652174, 0.19444444444444
48503, 0.76086956521739, 0.77608695652174, 0.22222222222222
48504, 0.73913043478261, 0.75, 0.22222222222222
48505, 0.73913043478261, 0.77608695652174, 0.25
48506, 0.76086956521739, 0.77608695652174, 0.27777777777778
48507, 0.73913043478261, 0.75, 0.27777777777778
48508, 0.73913043478261, 0.77608695652174, 0.30555555555556
48509, 0.76086956521739, 0.77608695652174, 0.33333333333333
48510, 0.73913043478261, 0.75, 0.33333333333333
48511, 0.73913043478261, 0.77608695652174, 0.36111111111111
48512, 0.76086956521739, 0.77608695652174, 0.38888888888889
48513, 0.73913043478261, 0.75, 0.38888888888889
48514, 0.73913043478261, 0.77608695652174, 0.41666666666667
48515, 0.76086956521739, 0.77608695652174, 0.44444444444444
48516, 0.73913043478261, 0.75, 0.44444444444444
48517, 0.73913043478261, 0.77608695652174, 0.47222222222222
48518, 0.69565217391304, 0.77608695652174, 0.027777777777778
48519, 0.71739130434783, 0.77608695652174, 0.055555555555556
48520, 0.69565217391304, 0.75, 0.055555555555556
48521, 0.69565217391304, 0.77608695652174, 0.083333333333333
48522, 0.71739130434783, 0.77608695652174, 0.11111111111111
48523, 0.69565217391304, 0.75, 0.11111111111111
48524, 0.69565217391304, 0.77608695652174, 0.13888888888889
48525, 0.71739130434783, 0.77608695652174, 0.16666666666667
48526, 0.69565217391304, 0.75, 0.16666666666667
48527, 0.69565217391304, 0.77608695652174, 0.19444444444444
48528, 0.71739130434783, 0.77608695652174, 0.22222222222222
48529, 0.69565217391304, 0.75, 0.22222222222222
48530, 0.69565217391304, 0.77608695652174, 0.25
48531, 0.71739130434783, 0.77608695652174, 0.27777777777778
48532, 0.69565217391304, 0.75, 0.27777777777778
48533, 0.69565217391304, 0.77608695652174, 0.30555555555556
48534, 0.71739130434783, 0.77608695652174, 0.33333333333333
48535, 0.69565217391304, 0.75, 0.33333333333333
48536, 0.69565217391304, 0.77608695652174, 0.36111111111111
48537, 0.71739130434783, 0.77608695652174, 0.38888888888889
48538, 0.69565217391304, 0.75, 0.38888888888889
48539, 0.69565217391304, 0.77608695652174, 0.41666666666667
48540, 0.71739130434783, 0.77608695652174, 0.44444444444444
48541, 0.69565217391304, 0.75, 0.44444444444444
48542, 0.69565217391304, 0.77608695652174, 0.47222222222222
48543, 0.65217391304348, 0.77608695652174, 0.027777777777778
48544, 0.67391304347826, 0.77608695652174, 0.055555555555556
48545, 0.65217391304348, 0.75, 0.055555555555556
48546, 0.65217391304348, 0.77608695652174, 0.083333333333333
48547, 0.67391304347826, 0.77608695652174, 0.11111111111111
48548, 0.65217391304348, 0.75, 0.11111111111111
48549, 0.65217391304348, 0.77608695652174, 0.13888888888889
48550, 0.67391304347826, 0.77608695652174, 0.16666666666667
48551, 0.65217391304348, 0.75, 0.16666666666667
48552, 0.65217391304348, 0.77608695652174, 0.19444444444444
48553, 0.67391304347826, 0.77608695652174, 0.22222222222222
48554, 0.65217391304348, 0.75, 0.22222222222222
48555, 0.65217391304348, 0.77608695652174, 0.25
48556, 0.67391304347826, 0.77608695652174, 0.27777777777778
48557, 0.65217391304348, 0.75, 0.27777777777778
48558, 0.65217391304348, 0.77608695652174, 0.30555555555556
48559, 0.67391304347826, 0.77608695652174, 0.33333333333333
48560, 0.65217391304348, 0.75, 0.33333333333333
48561, 0.65217391304348, 0.77608695652174, 0.36111111111111
48562, 0.67391304347826, 0.77608695652174, 0.38888888888889
48563, 0.65217391304348, 0.75, 0.38888888888889
48564, 0.65217391304348, 0.77608695652174, 0.41666666666667
48565, 0.67391304347826, 0.77608695652174, 0.44444444444444
48566, 0.65217391304348, 0.75, 0.44444444444444
48567, 0.65217391304348, 0.77608695652174, 0.47222222222222
48568, 0.60869565217391, 0.77608695652174, 0.027777777777778
48569, 0.6304347826087, 0.77608695652174, 0.055555555555556
48570, 0.60869565217391, 0.75, 0.055555555555556
48571, 0.60869565217391, 0.77608695652174, 0.083333333333333
48572, 0.6304347826087, 0.77608695652174, 0.11111111111111
48573, 0.60869565217391, 0.75, 0.11111111111111
48574, 0.60869565217391, 0.77608695652174, 0.13888888888889
48575, 0.6304347826087, 0.77608695652174, 0.16666666666667
48576, 0.60869565217391, 0.75, 0.16666666666667
48577, 0.60869565217391, 0.77608695652174, 0.19444444444444
48578, 0.6304347826087, 0.77608695652174, 0.22222222222222
48579, 0.60869565217391, 0.75, 0.22222222222222
48580, 0.60869565217391, 0.77608695652174, 0.25
48581, 0.6304347826087, 0.77608695652174, 0.27777777777778
48582, 0.60869565217391, 0.75, 0.27777777777778
48583, 0.60869565217391, 0.77608695652174, 0.30555555555556
48584, 0.6304347826087, 0.77608695652174, 0.33333333333333
48585, 0.60869565217391, 0.75, 0.33333333333333
48586, 0.60869565217391, 0.77608695652174, 0.36111111111111
48587, 0.6304347826087, 0.77608695652174, 0.38888888888889
48588, 0.60869565217391, 0.75, 0.38888888888889
48589, 0.60869565217391, 0.77608695652174, 0.41666666666667
48590, 0.6304347826087, 0.77608695652174, 0.44444444444444
48591, 0.60869565217391, 0.75, 0.44444444444444
48592, 0.60869565217391, 0.77608695652174, 0.47222222222222
48593, 0.56521739130435, 0.77608695652174, 0.027777777777778
48594, 0.58695652173913, 0.77608695652174, 0.055555555555556
48595, 0.56521739130435, 0.75, 0.055555555555556
48596, 0.56521739130435, 0.77608695652174, 0.083333333333333
48597, 0.58695652173913, 0.77608695652174, 0.11111111111111
48598, 0.56521739130435, 0.75, 0.11111111111111
48599, 0.56521739130435, 0.77608695652174, 0.13888888888889
48600, 0.58695652173913, 0.77608695652174, 0.16666666666667
48601, 0.56521739130435, 0.75, 0.16666666666667
48602, 0.56521739130435, 0.77608695652174, 0.19444444444444
48603, 0.58695652173913, 0.77608695652174, 0.22222222222222
48604, 0.56521739130435, 0.75, 0.22222222222222
48605, 0.56521739130435, 0.77608695652174, 0.25
48606, 0.58695652173913, 0.77608695652174, 0.27777777777778
48607, 0.56521739130435, 0.75, 0.27777777777778
48608, 0.56521739130435, 0.77608695652174, 0.30555555555556
48609, 0.58695652173913, 0.77608695652174, 0.33333333333333
48610, 0.56521739130435, 0.75, 0.33333333333333
48611, 0.56521739130435, 0.77608695652174, 0.36111111111111
48612, 0.58695652173913, 0.77608695652174, 0.38888888888889
48613, 0.56521739130435, 0.75, 0.38888888888889
48614, 0.56521739130435, 0.77608695652174, 0.41666666666667
48615, 0.58695652173913, 0.77608695652174, 0.44444444444444
48616, 0.56521739130435, 0.75, 0.44444444444444
48617, 0.56521739130435, 0.77608695652174, 0.47222222222222
48618, 0.52173913043478, 0.77608695652174, 0.027777777777778
48619, 0.54347826086957, 0.77608695652174, 0.055555555555556
48620, 0.52173913043478, 0.75, 0.055555555555556
48621, 0.52173913043478, 0.77608695652174, 0.083333333333333
48622, 0.54347826086956, 0.77608695652174, 0.11111111111111
48623, 0.52173913043478, 0.75, 0.11111111111111
48624, 0.52173913043478, 0.77608695652174, 0.13888888888889
48625, 0.54347826086957, 0.77608695652174, 0.16666666666667
48626, 0.52173913043478, 0.75, 0.16666666666667
48627, 0.52173913043478, 0.77608695652174, 0.19444444444444
48628, 0.54347826086956, 0.77608695652174, 0.22222222222222
48629, 0.52173913043478, 0.75, 0.22222222222222
48630, 0.52173913043478, 0.77608695652174, 0.25
48631, 0.54347826086956, 0.77608695652174, 0.27777777777778
48632, 0.52173913043478, 0.75, 0.27777777777778
48633, 0.52173913043478, 0.77608695652174, 0.30555555555556
48634, 0.54347826086956, 0.77608695652174, 0.33333333333333
48635, 0.52173913043478, 0.75, 0.33333333333333
48636, 0.52173913043478, 0.77608695652174, 0.36111111111111
48637, 0.54347826086956, 0.77608695652174, 0.38888888888889
48638, 0.52173913043478, 0.75, 0.38888888888889
48639, 0.52173913043478, 0.77608695652174, 0.41666666666667
48640, 0.54347826086956, 0.77608695652174, 0.44444444444444
48641, 0.52173913043478, 0.75, 0.44444444444444
48642, 0.52173913043478, 0.77608695652174, 0.47222222222222
48643, 0.47826086956522, 0.77608695652174, 0.027777777777778
48644, 0.5, 0.77608695652174, 0.055555555555556
48645, 0.47826086956522, 0.75, 0.055555555555556
48646, 0.47826086956522, 0.77608695652174, 0.083333333333333
48647, 0.5, 0.77608695652174, 0.11111111111111
48648, 0.47826086956522, 0.75, 0.11111111111111
48649, 0.47826086956522, 0.77608695652174, 0.13888888888889
48650, 0.5, 0.77608695652174, 0.16666666666667
48651, 0.47826086956522, 0.75, 0.16666666666667
48652, 0.47826086956522, 0.77608695652174, 0.19444444444444
48653, 0.5, 0.77608695652174, 0.22222222222222
48654, 0.47826086956522, 0.75, 0.22222222222222
48655, 0.47826086956522, 0.77608695652174, 0.25
48656, 0.5, 0.77608695652174, 0.27777777777778
48657, 0.47826086956522, 0.75, 0.27777777777778
48658, 0.47826086956522, 0.77608695652174, 0.30555555555556
48659, 0.5, 0.77608695652174, 0.33333333333333
48660, 0.47826086956522, 0.75, 0.33333333333333
48661, 0.47826086956522, 0.77608695652174, 0.36111111111111
48662, 0.5, 0.77608695652174, 0.38888888888889
48663, 0.47826086956522, 0.75, 0.38888888888889
48664, 0.47826086956522, 0.77608695652174, 0.41666666666667
48665, 0.5, 0.77608695652174, 0.44444444444444
48666, 0.47826086956522, 0.75, 0.44444444444444
48667, 0.47826086956522, 0.77608695652174, 0.47222222222222
48668, 0.43478260869565, 0.77608695652174, 0.027777777777778
48669, 0.45652173913043, 0.77608695652174, 0.055555555555556
48670, 0.43478260869565, 0.75, 0.055555555555556
48671, 0.43478260869565, 0.77608695652174, 0.083333333333333
48672, 0.45652173913043, 0.77608695652174, 0.11111111111111
48673, 0.43478260869565, 0.75, 0.11111111111111
48674, 0.43478260869565, 0.77608695652174, 0.13888888888889
48675, 0.45652173913043, 0.77608695652174, 0.16666666666667
48676, 0.43478260869565, 0.75, 0.16666666666667
48677, 0.43478260869565, 0.77608695652174, 0.19444444444444
48678, 0.45652173913043, 0.77608695652174, 0.22222222222222
48679, 0.43478260869565, 0.75, 0.22222222222222
48680, 0.43478260869565, 0.77608695652174, 0.25
48681, 0.45652173913043, 0.77608695652174, 0.27777777777778
48682, 0.43478260869565, 0.75, 0.27777777777778
48683, 0.43478260869565, 0.77608695652174, 0.30555555555556
48684, 0.45652173913043, 0.77608695652174, 0.33333333333333
48685, 0.43478260869565, 0.75, 0.33333333333333
48686, 0.43478260869565, 0.77608695652174, 0.36111111111111
48687, 0.45652173913043, 0.77608695652174, 0.38888888888889
48688, 0.43478260869565, 0.75, 0.38888888888889
48689, 0.43478260869565, 0.77608695652174, 0.41666666666667
48690, 0.45652173913043, 0.77608695652174, 0.44444444444444
48691, 0.43478260869565, 0.75, 0.44444444444444
48692, 0.43478260869565, 0.77608695652174, 0.47222222222222
48693, 0.39130434782609, 0.77608695652174, 0.027777777777778
48694, 0.41304347826087, 0.77608695652174, 0.055555555555556
48695, 0.39130434782609, 0.75, 0.055555555555556
48696, 0.39130434782609, 0.77608695652174, 0.083333333333333
48697, 0.41304347826087, 0.77608695652174, 0.11111111111111
48698, 0.39130434782609, 0.75, 0.11111111111111
48699, 0.39130434782609, 0.77608695652174, 0.13888888888889
48700, 0.41304347826087, 0.77608695652174, 0.16666666666667
48701, 0.39130434782609, 0.75, 0.16666666666667
48702, 0.39130434782609, 0.77608695652174, 0.19444444444444
48703, 0.41304347826087, 0.77608695652174, 0.22222222222222
48704, 0.39130434782609, 0.75, 0.22222222222222
48705, 0.39130434782609, 0.77608695652174, 0.25
48706, 0.41304347826087, 0.77608695652174, 0.27777777777778
48707, 0.39130434782609, 0.75, 0.27777777777778
48708, 0.39130434782609, 0.77608695652174, 0.30555555555556
48709, 0.41304347826087, 0.77608695652174, 0.33333333333333
48710, 0.39130434782609, 0.75, 0.33333333333333
48711, 0.39130434782609, 0.77608695652174, 0.36111111111111
48712, 0.41304347826087, 0.77608695652174, 0.38888888888889
48713, 0.39130434782609, 0.75, 0.38888888888889
48714, 0.39130434782609, 0.77608695652174, 0.41666666666667
48715, 0.41304347826087, 0.77608695652174, 0.44444444444444
48716, 0.39130434782609, 0.75, 0.44444444444444
48717, 0.39130434782609, 0.77608695652174, 0.47222222222222
48718, 0.34782608695652, 0.77608695652174, 0.027777777777778
48719, 0.3695652173913, 0.77608695652174, 0.055555555555556
48720, 0.34782608695652, 0.75, 0.055555555555556
48721, 0.34782608695652, 0.77608695652174, 0.083333333333333
48722, 0.3695652173913, 0.77608695652174, 0.11111111111111
48723, 0.34782608695652, 0.75, 0.11111111111111
48724, 0.34782608695652, 0.77608695652174, 0.13888888888889
48725, 0.3695652173913, 0.77608695652174, 0.16666666666667
48726, 0.34782608695652, 0.75, 0.16666666666667
48727, 0.34782608695652, 0.77608695652174, 0.19444444444444
48728, 0.3695652173913, 0.77608695652174, 0.22222222222222
48729, 0.34782608695652, 0.75, 0.22222222222222
48730, 0.34782608695652, 0.77608695652174, 0.25
48731, 0.3695652173913, 0.77608695652174, 0.27777777777778
48732, 0.34782608695652, 0.75, 0.27777777777778
48733, 0.34782608695652, 0.77608695652174, 0.30555555555556
48734, 0.3695652173913, 0.77608695652174, 0.33333333333333
48735, 0.34782608695652, 0.75, 0.33333333333333
48736, 0.34782608695652, 0.77608695652174, 0.36111111111111
48737, 0.3695652173913, 0.77608695652174, 0.38888888888889
48738, 0.34782608695652, 0.75, 0.38888888888889
48739, 0.34782608695652, 0.77608695652174, 0.41666666666667
48740, 0.3695652173913, 0.77608695652174, 0.44444444444444
48741, 0.34782608695652, 0.75, 0.44444444444444
48742, 0.34782608695652, 0.77608695652174, 0.47222222222222
48743, 0.30434782608696, 0.77608695652174, 0.027777777777778
48744, 0.32608695652174, 0.77608695652174, 0.055555555555556
48745, 0.30434782608696, 0.75, 0.055555555555556
48746, 0.30434782608696, 0.77608695652174, 0.083333333333333
48747, 0.32608695652174, 0.77608695652174, 0.11111111111111
48748, 0.30434782608696, 0.75, 0.11111111111111
48749, 0.30434782608696, 0.77608695652174, 0.13888888888889
48750, 0.32608695652174, 0.77608695652174, 0.16666666666667
48751, 0.30434782608696, 0.75, 0.16666666666667
48752, 0.30434782608696, 0.77608695652174, 0.19444444444444
48753, 0.32608695652174, 0.77608695652174, 0.22222222222222
48754, 0.30434782608696, 0.75, 0.22222222222222
48755, 0.30434782608696, 0.77608695652174, 0.25
48756, 0.32608695652174, 0.77608695652174, 0.27777777777778
48757, 0.30434782608696, 0.75, 0.27777777777778
48758, 0.30434782608696, 0.77608695652174, 0.30555555555556
48759, 0.32608695652174, 0.77608695652174, 0.33333333333333
48760, 0.30434782608696, 0.75, 0.33333333333333
48761, 0.30434782608696, 0.77608695652174, 0.36111111111111
48762, 0.32608695652174, 0.77608695652174, 0.38888888888889
48763, 0.30434782608696, 0.75, 0.38888888888889
48764, 0.30434782608696, 0.77608695652174, 0.41666666666667
48765, 0.32608695652174, 0.77608695652174, 0.44444444444444
48766, 0.30434782608696, 0.75, 0.44444444444444
48767, 0.30434782608696, 0.77608695652174, 0.47222222222222
48768, 0.26086956521739, 0.77608695652174, 0.027777777777778
48769, 0.28260869565217, 0.77608695652174, 0.055555555555556
48770, 0.26086956521739, 0.75, 0.055555555555556
48771, 0.26086956521739, 0.77608695652174, 0.083333333333333
48772, 0.28260869565217, 0.77608695652174, 0.11111111111111
48773, 0.26086956521739, 0.75, 0.11111111111111
48774, 0.26086956521739, 0.77608695652174, 0.13888888888889
48775, 0.28260869565217, 0.77608695652174, 0.16666666666667
48776, 0.26086956521739, 0.75, 0.16666666666667
48777, 0.26086956521739, 0.77608695652174, 0.19444444444444
48778, 0.28260869565217, 0.77608695652174, 0.22222222222222
48779, 0.26086956521739, 0.75, 0.22222222222222
48780, 0.26086956521739, 0.77608695652174, 0.25
48781, 0.28260869565217, 0.77608695652174, 0.27777777777778
48782, 0.26086956521739, 0.75, 0.27777777777778
48783, 0.26086956521739, 0.77608695652174, 0.30555555555556
48784, 0.28260869565217, 0.77608695652174, 0.33333333333333
48785, 0.26086956521739, 0.75, 0.33333333333333
48786, 0.26086956521739, 0.77608695652174, 0.36111111111111
48787, 0.28260869565217, 0.77608695652174, 0.38888888888889
48788, 0.26086956521739, 0.75, 0.38888888888889
48789, 0.26086956521739, 0.77608695652174, 0.41666666666667
48790, 0.28260869565217, 0.77608695652174, 0.44444444444444
48791, 0.26086956521739, 0.75, 0.44444444444444
48792, 0.26086956521739, 0.77608695652174, 0.47222222222222
48793, 0.21739130434783, 0.77608695652174, 0.027777777777778
48794, 0.23913043478261, 0.77608695652174, 0.055555555555556
48795, 0.21739130434783, 0.75, 0.055555555555556
48796, 0.21739130434783, 0.77608695652174, 0.083333333333333
48797, 0.23913043478261, 0.77608695652174, 0.11111111111111
48798, 0.21739130434783, 0.75, 0.11111111111111
48799, 0.21739130434783, 0.77608695652174, 0.13888888888889
48800, 0.23913043478261, 0.77608695652174, 0.16666666666667
48801, 0.21739130434783, 0.75, 0.16666666666667
48802, 0.21739130434783, 0.77608695652174, 0.19444444444444
48803, 0.23913043478261, 0.77608695652174, 0.22222222222222
48804, 0.21739130434783, 0.75, 0.22222222222222
48805, 0.21739130434783, 0.77608695652174, 0.25
48806, 0.23913043478261, 0.77608695652174, 0.27777777777778
48807, 0.21739130434783, 0.75, 0.27777777777778
48808, 0.21739130434783, 0.77608695652174, 0.30555555555556
48809, 0.23913043478261, 0.77608695652174, 0.33333333333333
48810, 0.21739130434783, 0.75, 0.33333333333333
48811, 0.21739130434783, 0.77608695652174, 0.36111111111111
48812, 0.23913043478261, 0.77608695652174, 0.38888888888889
48813, 0.21739130434783, 0.75, 0.38888888888889
48814, 0.21739130434783, 0.77608695652174, 0.41666666666667
48815, 0.23913043478261, 0.77608695652174, 0.44444444444444
48816, 0.21739130434783, 0.75, 0.44444444444444
48817, 0.21739130434783, 0.77608695652174, 0.47222222222222
48818, 0.17391304347826, 0.77608695652174, 0.027777777777778
48819, 0.19565217391304, 0.77608695652174, 0.055555555555556
48820, 0.17391304347826, 0.75, 0.055555555555556
48821, 0.17391304347826, 0.77608695652174, 0.083333333333333
48822, 0.19565217391304, 0.77608695652174, 0.11111111111111
48823, 0.17391304347826, 0.75, 0.11111111111111
48824, 0.17391304347826, 0.77608695652174, 0.13888888888889
48825, 0.19565217391304, 0.77608695652174, 0.16666666666667
48826, 0.17391304347826, 0.75, 0.16666666666667
48827, 0.17391304347826, 0.77608695652174, 0.19444444444444
48828, 0.19565217391304, 0.77608695652174, 0.22222222222222
48829, 0.17391304347826, 0.75, 0.22222222222222
48830, 0.17391304347826, 0.77608695652174, 0.25
48831, 0.19565217391304, 0.77608695652174, 0.27777777777778
48832, 0.17391304347826, 0.75, 0.27777777777778
48833, 0.17391304347826, 0.77608695652174, 0.30555555555556
48834, 0.19565217391304, 0.77608695652174, 0.33333333333333
48835, 0.17391304347826, 0.75, 0.33333333333333
48836, 0.17391304347826, 0.77608695652174, 0.36111111111111
48837, 0.19565217391304, 0.77608695652174, 0.38888888888889
48838, 0.17391304347826, 0.75, 0.38888888888889
48839, 0.17391304347826, 0.77608695652174, 0.41666666666667
48840, 0.19565217391304, 0.77608695652174, 0.44444444444444
48841, 0.17391304347826, 0.75, 0.44444444444444
48842, 0.17391304347826, 0.77608695652174, 0.47222222222222
48843, 0.1304347826087, 0.77608695652174, 0.027777777777778
48844, 0.15217391304348, 0.77608695652174, 0.055555555555556
48845, 0.1304347826087, 0.75, 0.055555555555556
48846, 0.1304347826087, 0.77608695652174, 0.083333333333333
48847, 0.15217391304348, 0.77608695652174, 0.11111111111111
48848, 0.1304347826087, 0.75, 0.11111111111111
48849, 0.1304347826087, 0.77608695652174, 0.13888888888889
48850, 0.15217391304348, 0.77608695652174, 0.16666666666667
48851, 0.1304347826087, 0.75, 0.16666666666667
48852, 0.1304347826087, 0.77608695652174, 0.19444444444444
48853, 0.15217391304348, 0.77608695652174, 0.22222222222222
48854, 0.1304347826087, 0.75, 0.22222222222222
48855, 0.1304347826087, 0.77608695652174, 0.25
48856, 0.15217391304348, 0.77608695652174, 0.27777777777778
48857, 0.1304347826087, 0.75, 0.27777777777778
48858, 0.1304347826087, 0.77608695652174, 0.30555555555556
48859, 0.15217391304348, 0.77608695652174, 0.33333333333333
48860, 0.1304347826087, 0.75, 0.33333333333333
48861, 0.1304347826087, 0.77608695652174, 0.36111111111111
48862, 0.15217391304348, 0.77608695652174, 0.38888888888889
48863, 0.1304347826087, 0.75, 0.38888888888889
48864, 0.1304347826087, 0.77608695652174, 0.41666666666667
48865, 0.15217391304348, 0.77608695652174, 0.44444444444444
48866, 0.1304347826087, 0.75, 0.44444444444444
48867, 0.1304347826087, 0.77608695652174, 0.47222222222222
48868, 0.08695652173913, 0.77608695652174, 0.027777777777778
48869, 0.10869565217391, 0.77608695652174, 0.055555555555556
48870, 0.08695652173913, 0.75, 0.055555555555556
48871, 0.08695652173913, 0.77608695652174, 0.083333333333333
48872, 0.10869565217391, 0.77608695652174, 0.11111111111111
48873, 0.08695652173913, 0.75, 0.11111111111111
48874, 0.08695652173913, 0.77608695652174, 0.13888888888889
48875, 0.10869565217391, 0.77608695652174, 0.16666666666667
48876, 0.08695652173913, 0.75, 0.16666666666667
48877, 0.08695652173913, 0.77608695652174, 0.19444444444444
48878, 0.10869565217391, 0.77608695652174, 0.22222222222222
48879, 0.08695652173913, 0.75, 0.22222222222222
48880, 0.08695652173913, 0.77608695652174, 0.25
48881, 0.10869565217391, 0.77608695652174, 0.27777777777778
48882, 0.08695652173913, 0.75, 0.27777777777778
48883, 0.08695652173913, 0.77608695652174, 0.30555555555556
48884, 0.10869565217391, 0.77608695652174, 0.33333333333333
48885, 0.08695652173913, 0.75, 0.33333333333333
48886, 0.08695652173913, 0.77608695652174, 0.36111111111111
48887, 0.10869565217391, 0.77608695652174, 0.38888888888889
48888, 0.08695652173913, 0.75, 0.38888888888889
48889, 0.08695652173913, 0.77608695652174, 0.41666666666667
48890, 0.10869565217391, 0.77608695652174, 0.44444444444444
48891, 0.08695652173913, 0.75, 0.44444444444444
48892, 0.08695652173913, 0.77608695652174, 0.47222222222222
48893, 0.043478260869565, 0.77608695652174, 0.027777777777778
48894, 0.065217391304348, 0.77608695652174, 0.055555555555556
48895, 0.043478260869565, 0.75, 0.055555555555556
48896, 0.043478260869565, 0.77608695652174, 0.083333333333333
48897, 0.065217391304348, 0.77608695652174, 0.11111111111111
48898, 0.043478260869565, 0.75, 0.11111111111111
48899, 0.043478260869565, 0.77608695652174, 0.13888888888889
48900, 0.065217391304348, 0.77608695652174, 0.16666666666667
48901, 0.043478260869565, 0.75, 0.16666666666667
48902, 0.043478260869565, 0.77608695652174, 0.19444444444444
48903, 0.065217391304348, 0.77608695652174, 0.22222222222222
48904, 0.043478260869565, 0.75, 0.22222222222222
48905, 0.043478260869565, 0.77608695652174, 0.25
48906, 0.065217391304348, 0.77608695652174, 0.27777777777778
48907, 0.043478260869565, 0.75, 0.27777777777778
48908, 0.043478260869565, 0.77608695652174, 0.30555555555556
48909, 0.065217391304348, 0.77608695652174, 0.33333333333333
48910, 0.043478260869565, 0.75, 0.33333333333333
48911, 0.043478260869565, 0.77608695652174, 0.36111111111111
48912, 0.065217391304348, 0.77608695652174, 0.38888888888889
48913, 0.043478260869565, 0.75, 0.38888888888889
48914, 0.043478260869565, 0.77608695652174, 0.41666666666667
48915, 0.065217391304348, 0.77608695652174, 0.44444444444444
48916, 0.043478260869565, 0.75, 0.44444444444444
48917, 0.043478260869565, 0.77608695652174, 0.47222222222222
48918, 0.021739130434783, 0.77608695652174, 0.055555555555556
48919, 0.021739130434783, 0.77608695652174, 0.11111111111111
48920, 0.021739130434783, 0.77608695652174, 0.16666666666667
48921, 0.021739130434783, 0.77608695652174, 0.22222222222222
48922, 0.021739130434783, 0.77608695652174, 0.27777777777778
48923, 0.021739130434783, 0.77608695652174, 0.33333333333333
48924, 0.021739130434783, 0.77608695652174, 0.38888888888889
48925, 0.021739130434783, 0.77608695652174, 0.44444444444444
48926, 0.95652173913043, 0.82826086956522, 0.027777777777778
48927, 0.97826086956522, 0.82826086956522, 0.055555555555556
48928, 0.95652173913043, 0.80217391304348, 0.055555555555556
48929, 0.95652173913043, 0.82826086956522, 0.083333333333333
48930, 0.97826086956522, 0.82826086956522, 0.11111111111111
48931, 0.95652173913044, 0.80217391304348, 0.11111111111111
48932, 0.95652173913044, 0.82826086956522, 0.13888888888889
48933, 0.97826086956522, 0.82826086956522, 0.16666666666667
48934, 0.95652173913044, 0.80217391304348, 0.16666666666667
48935, 0.95652173913044, 0.82826086956522, 0.19444444444444
48936, 0.97826086956522, 0.82826086956522, 0.22222222222222
48937, 0.95652173913044, 0.80217391304348, 0.22222222222222
48938, 0.95652173913044, 0.82826086956522, 0.25
48939, 0.97826086956522, 0.82826086956522, 0.27777777777778
48940, 0.95652173913044, 0.80217391304348, 0.27777777777778
48941, 0.95652173913044, 0.82826086956522, 0.30555555555556
48942, 0.97826086956522, 0.82826086956522, 0.33333333333333
48943, 0.95652173913044, 0.80217391304348, 0.33333333333333
48944, 0.95652173913044, 0.82826086956522, 0.36111111111111
48945, 0.97826086956522, 0.82826086956522, 0.38888888888889
48946, 0.95652173913044, 0.80217391304348, 0.38888888888889
48947, 0.95652173913044, 0.82826086956522, 0.41666666666667
48948, 0.97826086956522, 0.82826086956522, 0.44444444444444
48949, 0.95652173913044, 0.80217391304348, 0.44444444444444
48950, 0.95652173913043, 0.82826086956522, 0.47222222222222
48951, 0.91304347826087, 0.82826086956522, 0.027777777777778
48952, 0.93478260869565, 0.82826086956522, 0.055555555555556
48953, 0.91304347826087, 0.80217391304348, 0.055555555555556
48954, 0.91304347826087, 0.82826086956522, 0.083333333333333
48955, 0.93478260869565, 0.82826086956522, 0.11111111111111
48956, 0.91304347826087, 0.80217391304348, 0.11111111111111
48957, 0.91304347826087, 0.82826086956522, 0.13888888888889
48958, 0.93478260869565, 0.82826086956522, 0.16666666666667
48959, 0.91304347826087, 0.80217391304348, 0.16666666666667
48960, 0.91304347826087, 0.82826086956522, 0.19444444444444
48961, 0.93478260869565, 0.82826086956522, 0.22222222222222
48962, 0.91304347826087, 0.80217391304348, 0.22222222222222
48963, 0.91304347826087, 0.82826086956522, 0.25
48964, 0.93478260869565, 0.82826086956522, 0.27777777777778
48965, 0.91304347826087, 0.80217391304348, 0.27777777777778
48966, 0.91304347826087, 0.82826086956522, 0.30555555555556
48967, 0.93478260869565, 0.82826086956522, 0.33333333333333
48968, 0.91304347826087, 0.80217391304348, 0.33333333333333
48969, 0.91304347826087, 0.82826086956522, 0.36111111111111
48970, 0.93478260869565, 0.82826086956522, 0.38888888888889
48971, 0.91304347826087, 0.80217391304348, 0.38888888888889
48972, 0.91304347826087, 0.82826086956522, 0.41666666666667
48973, 0.93478260869565, 0.82826086956522, 0.44444444444444
48974, 0.91304347826087, 0.80217391304348, 0.44444444444444
48975, 0.91304347826087, 0.82826086956522, 0.47222222222222
48976, 0.8695652173913, 0.82826086956522, 0.027777777777778
48977, 0.89130434782609, 0.82826086956522, 0.055555555555556
48978, 0.8695652173913, 0.80217391304348, 0.055555555555556
48979, 0.8695652173913, 0.82826086956522, 0.083333333333333
48980, 0.89130434782609, 0.82826086956522, 0.11111111111111
48981, 0.8695652173913, 0.80217391304348, 0.11111111111111
48982, 0.8695652173913, 0.82826086956522, 0.13888888888889
48983, 0.89130434782609, 0.82826086956522, 0.16666666666667
48984, 0.8695652173913, 0.80217391304348, 0.16666666666667
48985, 0.8695652173913, 0.82826086956522, 0.19444444444444
48986, 0.89130434782609, 0.82826086956522, 0.22222222222222
48987, 0.8695652173913, 0.80217391304348, 0.22222222222222
48988, 0.8695652173913, 0.82826086956522, 0.25
48989, 0.89130434782609, 0.82826086956522, 0.27777777777778
48990, 0.8695652173913, 0.80217391304348, 0.27777777777778
48991, 0.8695652173913, 0.82826086956522, 0.30555555555556
48992, 0.89130434782609, 0.82826086956522, 0.33333333333333
48993, 0.8695652173913, 0.80217391304348, 0.33333333333333
48994, 0.8695652173913, 0.82826086956522, 0.36111111111111
48995, 0.89130434782609, 0.82826086956522, 0.38888888888889
48996, 0.8695652173913, 0.80217391304348, 0.38888888888889
48997, 0.8695652173913, 0.82826086956522, 0.41666666666667
48998, 0.89130434782609, 0.82826086956522, 0.44444444444444
48999, 0.8695652173913, 0.80217391304348, 0.44444444444444
49000, 0.8695652173913, 0.82826086956522, 0.47222222222222
49001, 0.82608695652174, 0.82826086956522, 0.027777777777778
49002, 0.84782608695652, 0.82826086956522, 0.055555555555556
49003, 0.82608695652174, 0.80217391304348, 0.055555555555556
49004, 0.82608695652174, 0.82826086956522, 0.083333333333333
49005, 0.84782608695652, 0.82826086956522, 0.11111111111111
49006, 0.82608695652174, 0.80217391304348, 0.11111111111111
49007, 0.82608695652174, 0.82826086956522, 0.13888888888889
49008, 0.84782608695652, 0.82826086956522, 0.16666666666667
49009, 0.82608695652174, 0.80217391304348, 0.16666666666667
49010, 0.82608695652174, 0.82826086956522, 0.19444444444444
49011, 0.84782608695652, 0.82826086956522, 0.22222222222222
49012, 0.82608695652174, 0.80217391304348, 0.22222222222222
49013, 0.82608695652174, 0.82826086956522, 0.25
49014, 0.84782608695652, 0.82826086956522, 0.27777777777778
49015, 0.82608695652174, 0.80217391304348, 0.27777777777778
49016, 0.82608695652174, 0.82826086956522, 0.30555555555556
49017, 0.84782608695652, 0.82826086956522, 0.33333333333333
49018, 0.82608695652174, 0.80217391304348, 0.33333333333333
49019, 0.82608695652174, 0.82826086956522, 0.36111111111111
49020, 0.84782608695652, 0.82826086956522, 0.38888888888889
49021, 0.82608695652174, 0.80217391304348, 0.38888888888889
49022, 0.82608695652174, 0.82826086956522, 0.41666666666667
49023, 0.84782608695652, 0.82826086956522, 0.44444444444444
49024, 0.82608695652174, 0.80217391304348, 0.44444444444444
49025, 0.82608695652174, 0.82826086956522, 0.47222222222222
49026, 0.78260869565217, 0.82826086956522, 0.027777777777778
49027, 0.80434782608696, 0.82826086956522, 0.055555555555556
49028, 0.78260869565217, 0.80217391304348, 0.055555555555556
49029, 0.78260869565217, 0.82826086956522, 0.083333333333333
49030, 0.80434782608696, 0.82826086956522, 0.11111111111111
49031, 0.78260869565217, 0.80217391304348, 0.11111111111111
49032, 0.78260869565217, 0.82826086956522, 0.13888888888889
49033, 0.80434782608696, 0.82826086956522, 0.16666666666667
49034, 0.78260869565217, 0.80217391304348, 0.16666666666667
49035, 0.78260869565217, 0.82826086956522, 0.19444444444444
49036, 0.80434782608696, 0.82826086956522, 0.22222222222222
49037, 0.78260869565217, 0.80217391304348, 0.22222222222222
49038, 0.78260869565217, 0.82826086956522, 0.25
49039, 0.80434782608696, 0.82826086956522, 0.27777777777778
49040, 0.78260869565217, 0.80217391304348, 0.27777777777778
49041, 0.78260869565217, 0.82826086956522, 0.30555555555556
49042, 0.80434782608696, 0.82826086956522, 0.33333333333333
49043, 0.78260869565217, 0.80217391304348, 0.33333333333333
49044, 0.78260869565217, 0.82826086956522, 0.36111111111111
49045, 0.80434782608696, 0.82826086956522, 0.38888888888889
49046, 0.78260869565217, 0.80217391304348, 0.38888888888889
49047, 0.78260869565217, 0.82826086956522, 0.41666666666667
49048, 0.80434782608696, 0.82826086956522, 0.44444444444444
49049, 0.78260869565217, 0.80217391304348, 0.44444444444444
49050, 0.78260869565217, 0.82826086956522, 0.47222222222222
49051, 0.73913043478261, 0.82826086956522, 0.027777777777778
49052, 0.76086956521739, 0.82826086956522, 0.055555555555556
49053, 0.73913043478261, 0.80217391304348, 0.055555555555556
49054, 0.73913043478261, 0.82826086956522, 0.083333333333333
49055, 0.76086956521739, 0.82826086956522, 0.11111111111111
49056, 0.73913043478261, 0.80217391304348, 0.11111111111111
49057, 0.73913043478261, 0.82826086956522, 0.13888888888889
49058, 0.76086956521739, 0.82826086956522, 0.16666666666667
49059, 0.73913043478261, 0.80217391304348, 0.16666666666667
49060, 0.73913043478261, 0.82826086956522, 0.19444444444444
49061, 0.76086956521739, 0.82826086956522, 0.22222222222222
49062, 0.73913043478261, 0.80217391304348, 0.22222222222222
49063, 0.73913043478261, 0.82826086956522, 0.25
49064, 0.76086956521739, 0.82826086956522, 0.27777777777778
49065, 0.73913043478261, 0.80217391304348, 0.27777777777778
49066, 0.73913043478261, 0.82826086956522, 0.30555555555556
49067, 0.76086956521739, 0.82826086956522, 0.33333333333333
49068, 0.73913043478261, 0.80217391304348, 0.33333333333333
49069, 0.73913043478261, 0.82826086956522, 0.36111111111111
49070, 0.76086956521739, 0.82826086956522, 0.38888888888889
49071, 0.73913043478261, 0.80217391304348, 0.38888888888889
49072, 0.73913043478261, 0.82826086956522, 0.41666666666667
49073, 0.76086956521739, 0.82826086956522, 0.44444444444444
49074, 0.73913043478261, 0.80217391304348, 0.44444444444444
49075, 0.73913043478261, 0.82826086956522, 0.47222222222222
49076, 0.69565217391304, 0.82826086956522, 0.027777777777778
49077, 0.71739130434783, 0.82826086956522, 0.055555555555556
49078, 0.69565217391304, 0.80217391304348, 0.055555555555556
49079, 0.69565217391304, 0.82826086956522, 0.083333333333333
49080, 0.71739130434783, 0.82826086956522, 0.11111111111111
49081, 0.69565217391304, 0.80217391304348, 0.11111111111111
49082, 0.69565217391304, 0.82826086956522, 0.13888888888889
49083, 0.71739130434783, 0.82826086956522, 0.16666666666667
49084, 0.69565217391304, 0.80217391304348, 0.16666666666667
49085, 0.69565217391304, 0.82826086956522, 0.19444444444444
49086, 0.71739130434783, 0.82826086956522, 0.22222222222222
49087, 0.69565217391304, 0.80217391304348, 0.22222222222222
49088, 0.69565217391304, 0.82826086956522, 0.25
49089, 0.71739130434783, 0.82826086956522, 0.27777777777778
49090, 0.69565217391304, 0.80217391304348, 0.27777777777778
49091, 0.69565217391304, 0.82826086956522, 0.30555555555556
49092, 0.71739130434783, 0.82826086956522, 0.33333333333333
49093, 0.69565217391304, 0.80217391304348, 0.33333333333333
49094, 0.69565217391304, 0.82826086956522, 0.36111111111111
49095, 0.71739130434783, 0.82826086956522, 0.38888888888889
49096, 0.69565217391304, 0.80217391304348, 0.38888888888889
49097, 0.69565217391304, 0.82826086956522, 0.41666666666667
49098, 0.71739130434783, 0.82826086956522, 0.44444444444444
49099, 0.69565217391304, 0.80217391304348, 0.44444444444444
49100, 0.69565217391304, 0.82826086956522, 0.47222222222222
49101, 0.65217391304348, 0.82826086956522, 0.027777777777778
49102, 0.67391304347826, 0.82826086956522, 0.055555555555556
49103, 0.65217391304348, 0.80217391304348, 0.055555555555556
49104, 0.65217391304348, 0.82826086956522, 0.083333333333333
49105, 0.67391304347826, 0.82826086956522, 0.11111111111111
49106, 0.65217391304348, 0.80217391304348, 0.11111111111111
49107, 0.65217391304348, 0.82826086956522, 0.13888888888889
49108, 0.67391304347826, 0.82826086956522, 0.16666666666667
49109, 0.65217391304348, 0.80217391304348, 0.16666666666667
49110, 0.65217391304348, 0.82826086956522, 0.19444444444444
49111, 0.67391304347826, 0.82826086956522, 0.22222222222222
49112, 0.65217391304348, 0.80217391304348, 0.22222222222222
49113, 0.65217391304348, 0.82826086956522, 0.25
49114, 0.67391304347826, 0.82826086956522, 0.27777777777778
49115, 0.65217391304348, 0.80217391304348, 0.27777777777778
49116, 0.65217391304348, 0.82826086956522, 0.30555555555556
49117, 0.67391304347826, 0.82826086956522, 0.33333333333333
49118, 0.65217391304348, 0.80217391304348, 0.33333333333333
49119, 0.65217391304348, 0.82826086956522, 0.36111111111111
49120, 0.67391304347826, 0.82826086956522, 0.38888888888889
49121, 0.65217391304348, 0.80217391304348, 0.38888888888889
49122, 0.65217391304348, 0.82826086956522, 0.41666666666667
49123, 0.67391304347826, 0.82826086956522, 0.44444444444444
49124, 0.65217391304348, 0.80217391304348, 0.44444444444444
49125, 0.65217391304348, 0.82826086956522, 0.47222222222222
49126, 0.60869565217391, 0.82826086956522, 0.027777777777778
49127, 0.6304347826087, 0.82826086956522, 0.055555555555556
49128, 0.60869565217391, 0.80217391304348, 0.055555555555556
49129, 0.60869565217391, 0.82826086956522, 0.083333333333333
49130, 0.6304347826087, 0.82826086956522, 0.11111111111111
49131, 0.60869565217391, 0.80217391304348, 0.11111111111111
49132, 0.60869565217391, 0.82826086956522, 0.13888888888889
49133, 0.6304347826087, 0.82826086956522, 0.16666666666667
49134, 0.60869565217391, 0.80217391304348, 0.16666666666667
49135, 0.60869565217391, 0.82826086956522, 0.19444444444444
49136, 0.6304347826087, 0.82826086956522, 0.22222222222222
49137, 0.60869565217391, 0.80217391304348, 0.22222222222222
49138, 0.60869565217391, 0.82826086956522, 0.25
49139, 0.6304347826087, 0.82826086956522, 0.27777777777778
49140, 0.60869565217391, 0.80217391304348, 0.27777777777778
49141, 0.60869565217391, 0.82826086956522, 0.30555555555556
49142, 0.6304347826087, 0.82826086956522, 0.33333333333333
49143, 0.60869565217391, 0.80217391304348, 0.33333333333333
49144, 0.60869565217391, 0.82826086956522, 0.36111111111111
49145, 0.6304347826087, 0.82826086956522, 0.38888888888889
49146, 0.60869565217391, 0.80217391304348, 0.38888888888889
49147, 0.60869565217391, 0.82826086956522, 0.41666666666667
49148, 0.6304347826087, 0.82826086956522, 0.44444444444444
49149, 0.60869565217391, 0.80217391304348, 0.44444444444444
49150, 0.60869565217391, 0.82826086956522, 0.47222222222222
49151, 0.56521739130435, 0.82826086956522, 0.027777777777778
49152, 0.58695652173913, 0.82826086956522, 0.055555555555556
49153, 0.56521739130435, 0.80217391304348, 0.055555555555556
49154, 0.56521739130435, 0.82826086956522, 0.083333333333333
49155, 0.58695652173913, 0.82826086956522, 0.11111111111111
49156, 0.56521739130435, 0.80217391304348, 0.11111111111111
49157, 0.56521739130435, 0.82826086956522, 0.13888888888889
49158, 0.58695652173913, 0.82826086956522, 0.16666666666667
49159, 0.56521739130435, 0.80217391304348, 0.16666666666667
49160, 0.56521739130435, 0.82826086956522, 0.19444444444444
49161, 0.58695652173913, 0.82826086956522, 0.22222222222222
49162, 0.56521739130435, 0.80217391304348, 0.22222222222222
49163, 0.56521739130435, 0.82826086956522, 0.25
49164, 0.58695652173913, 0.82826086956522, 0.27777777777778
49165, 0.56521739130435, 0.80217391304348, 0.27777777777778
49166, 0.56521739130435, 0.82826086956522, 0.30555555555556
49167, 0.58695652173913, 0.82826086956522, 0.33333333333333
49168, 0.56521739130435, 0.80217391304348, 0.33333333333333
49169, 0.56521739130435, 0.82826086956522, 0.36111111111111
49170, 0.58695652173913, 0.82826086956522, 0.38888888888889
49171, 0.56521739130435, 0.80217391304348, 0.38888888888889
49172, 0.56521739130435, 0.82826086956522, 0.41666666666667
49173, 0.58695652173913, 0.82826086956522, 0.44444444444444
49174, 0.56521739130435, 0.80217391304348, 0.44444444444444
49175, 0.56521739130435, 0.82826086956522, 0.47222222222222
49176, 0.52173913043478, 0.82826086956522, 0.027777777777778
49177, 0.54347826086957, 0.82826086956522, 0.055555555555556
49178, 0.52173913043478, 0.80217391304348, 0.055555555555556
49179, 0.52173913043478, 0.82826086956522, 0.083333333333333
49180, 0.54347826086957, 0.82826086956522, 0.11111111111111
49181, 0.52173913043478, 0.80217391304348, 0.11111111111111
49182, 0.52173913043478, 0.82826086956522, 0.13888888888889
49183, 0.54347826086957, 0.82826086956522, 0.16666666666667
49184, 0.52173913043478, 0.80217391304348, 0.16666666666667
49185, 0.52173913043478, 0.82826086956522, 0.19444444444444
49186, 0.54347826086956, 0.82826086956522, 0.22222222222222
49187, 0.52173913043478, 0.80217391304348, 0.22222222222222
49188, 0.52173913043478, 0.82826086956522, 0.25
49189, 0.54347826086956, 0.82826086956522, 0.27777777777778
49190, 0.52173913043478, 0.80217391304348, 0.27777777777778
49191, 0.52173913043478, 0.82826086956522, 0.30555555555556
49192, 0.54347826086956, 0.82826086956522, 0.33333333333333
49193, 0.52173913043478, 0.80217391304348, 0.33333333333333
49194, 0.52173913043478, 0.82826086956522, 0.36111111111111
49195, 0.54347826086956, 0.82826086956522, 0.38888888888889
49196, 0.52173913043478, 0.80217391304348, 0.38888888888889
49197, 0.52173913043478, 0.82826086956522, 0.41666666666667
49198, 0.54347826086956, 0.82826086956522, 0.44444444444444
49199, 0.52173913043478, 0.80217391304348, 0.44444444444444
49200, 0.52173913043478, 0.82826086956522, 0.47222222222222
49201, 0.47826086956522, 0.82826086956522, 0.027777777777778
49202, 0.5, 0.82826086956522, 0.055555555555556
49203, 0.47826086956522, 0.80217391304348, 0.055555555555556
49204, 0.47826086956522, 0.82826086956522, 0.083333333333333
49205, 0.5, 0.82826086956522, 0.11111111111111
49206, 0.47826086956522, 0.80217391304348, 0.11111111111111
49207, 0.47826086956522, 0.82826086956522, 0.13888888888889
49208, 0.5, 0.82826086956522, 0.16666666666667
49209, 0.47826086956522, 0.80217391304348, 0.16666666666667
49210, 0.47826086956522, 0.82826086956522, 0.19444444444444
49211, 0.5, 0.82826086956522, 0.22222222222222
49212, 0.47826086956522, 0.80217391304348, 0.22222222222222
49213, 0.47826086956522, 0.82826086956522, 0.25
49214, 0.5, 0.82826086956522, 0.27777777777778
49215, 0.47826086956522, 0.80217391304348, 0.27777777777778
49216, 0.47826086956522, 0.82826086956522, 0.30555555555556
49217, 0.5, 0.82826086956522, 0.33333333333333
49218, 0.47826086956522, 0.80217391304348, 0.33333333333333
49219, 0.47826086956522, 0.82826086956522, 0.36111111111111
49220, 0.5, 0.82826086956522, 0.38888888888889
49221, 0.47826086956522, 0.80217391304348, 0.38888888888889
49222, 0.47826086956522, 0.82826086956522, 0.41666666666667
49223, 0.5, 0.82826086956522, 0.44444444444444
49224, 0.47826086956522, 0.80217391304348, 0.44444444444444
49225, 0.47826086956522, 0.82826086956522, 0.47222222222222
49226, 0.43478260869565, 0.82826086956522, 0.027777777777778
49227, 0.45652173913043, 0.82826086956522, 0.055555555555556
49228, 0.43478260869565, 0.80217391304348, 0.055555555555556
49229, 0.43478260869565, 0.82826086956522, 0.083333333333333
49230, 0.45652173913043, 0.82826086956522, 0.11111111111111
49231, 0.43478260869565, 0.80217391304348, 0.11111111111111
49232, 0.43478260869565, 0.82826086956522, 0.13888888888889
49233, 0.45652173913043, 0.82826086956522, 0.16666666666667
49234, 0.43478260869565, 0.80217391304348, 0.16666666666667
49235, 0.43478260869565, 0.82826086956522, 0.19444444444444
49236, 0.45652173913043, 0.82826086956522, 0.22222222222222
49237, 0.43478260869565, 0.80217391304348, 0.22222222222222
49238, 0.43478260869565, 0.82826086956522, 0.25
49239, 0.45652173913043, 0.82826086956522, 0.27777777777778
49240, 0.43478260869565, 0.80217391304348, 0.27777777777778
49241, 0.43478260869565, 0.82826086956522, 0.30555555555556
49242, 0.45652173913043, 0.82826086956522, 0.33333333333333
49243, 0.43478260869565, 0.80217391304348, 0.33333333333333
49244, 0.43478260869565, 0.82826086956522, 0.36111111111111
49245, 0.45652173913044, 0.82826086956522, 0.38888888888889
49246, 0.43478260869565, 0.80217391304348, 0.38888888888889
49247, 0.43478260869565, 0.82826086956522, 0.41666666666667
49248, 0.45652173913043, 0.82826086956522, 0.44444444444444
49249, 0.43478260869565, 0.80217391304348, 0.44444444444444
49250, 0.43478260869565, 0.82826086956522, 0.47222222222222
49251, 0.39130434782609, 0.82826086956522, 0.027777777777778
49252, 0.41304347826087, 0.82826086956522, 0.055555555555556
49253, 0.39130434782609, 0.80217391304348, 0.055555555555556
49254, 0.39130434782609, 0.82826086956522, 0.083333333333333
49255, 0.41304347826087, 0.82826086956522, 0.11111111111111
49256, 0.39130434782609, 0.80217391304348, 0.11111111111111
49257, 0.39130434782609, 0.82826086956522, 0.13888888888889
49258, 0.41304347826087, 0.82826086956522, 0.16666666666667
49259, 0.39130434782609, 0.80217391304348, 0.16666666666667
49260, 0.39130434782609, 0.82826086956522, 0.19444444444444
49261, 0.41304347826087, 0.82826086956522, 0.22222222222222
49262, 0.39130434782609, 0.80217391304348, 0.22222222222222
49263, 0.39130434782609, 0.82826086956522, 0.25
49264, 0.41304347826087, 0.82826086956522, 0.27777777777778
49265, 0.39130434782609, 0.80217391304348, 0.27777777777778
49266, 0.39130434782609, 0.82826086956522, 0.30555555555556
49267, 0.41304347826087, 0.82826086956522, 0.33333333333333
49268, 0.39130434782609, 0.80217391304348, 0.33333333333333
49269, 0.39130434782609, 0.82826086956522, 0.36111111111111
49270, 0.41304347826087, 0.82826086956522, 0.38888888888889
49271, 0.39130434782609, 0.80217391304348, 0.38888888888889
49272, 0.39130434782609, 0.82826086956522, 0.41666666666667
49273, 0.41304347826087, 0.82826086956522, 0.44444444444444
49274, 0.39130434782609, 0.80217391304348, 0.44444444444444
49275, 0.39130434782609, 0.82826086956522, 0.47222222222222
49276, 0.34782608695652, 0.82826086956522, 0.027777777777778
49277, 0.3695652173913, 0.82826086956522, 0.055555555555556
49278, 0.34782608695652, 0.80217391304348, 0.055555555555556
49279, 0.34782608695652, 0.82826086956522, 0.083333333333333
49280, 0.3695652173913, 0.82826086956522, 0.11111111111111
49281, 0.34782608695652, 0.80217391304348, 0.11111111111111
49282, 0.34782608695652, 0.82826086956522, 0.13888888888889
49283, 0.3695652173913, 0.82826086956522, 0.16666666666667
49284, 0.34782608695652, 0.80217391304348, 0.16666666666667
49285, 0.34782608695652, 0.82826086956522, 0.19444444444444
49286, 0.3695652173913, 0.82826086956522, 0.22222222222222
49287, 0.34782608695652, 0.80217391304348, 0.22222222222222
49288, 0.34782608695652, 0.82826086956522, 0.25
49289, 0.3695652173913, 0.82826086956522, 0.27777777777778
49290, 0.34782608695652, 0.80217391304348, 0.27777777777778
49291, 0.34782608695652, 0.82826086956522, 0.30555555555556
49292, 0.3695652173913, 0.82826086956522, 0.33333333333333
49293, 0.34782608695652, 0.80217391304348, 0.33333333333333
49294, 0.34782608695652, 0.82826086956522, 0.36111111111111
49295, 0.3695652173913, 0.82826086956522, 0.38888888888889
49296, 0.34782608695652, 0.80217391304348, 0.38888888888889
49297, 0.34782608695652, 0.82826086956522, 0.41666666666667
49298, 0.3695652173913, 0.82826086956522, 0.44444444444444
49299, 0.34782608695652, 0.80217391304348, 0.44444444444444
49300, 0.34782608695652, 0.82826086956522, 0.47222222222222
49301, 0.30434782608696, 0.82826086956522, 0.027777777777778
49302, 0.32608695652174, 0.82826086956522, 0.055555555555556
49303, 0.30434782608696, 0.80217391304348, 0.055555555555556
49304, 0.30434782608696, 0.82826086956522, 0.083333333333333
49305, 0.32608695652174, 0.82826086956522, 0.11111111111111
49306, 0.30434782608696, 0.80217391304348, 0.11111111111111
49307, 0.30434782608696, 0.82826086956522, 0.13888888888889
49308, 0.32608695652174, 0.82826086956522, 0.16666666666667
49309, 0.30434782608696, 0.80217391304348, 0.16666666666667
49310, 0.30434782608696, 0.82826086956522, 0.19444444444444
49311, 0.32608695652174, 0.82826086956522, 0.22222222222222
49312, 0.30434782608696, 0.80217391304348, 0.22222222222222
49313, 0.30434782608696, 0.82826086956522, 0.25
49314, 0.32608695652174, 0.82826086956522, 0.27777777777778
49315, 0.30434782608696, 0.80217391304348, 0.27777777777778
49316, 0.30434782608696, 0.82826086956522, 0.30555555555556
49317, 0.32608695652174, 0.82826086956522, 0.33333333333333
49318, 0.30434782608696, 0.80217391304348, 0.33333333333333
49319, 0.30434782608696, 0.82826086956522, 0.36111111111111
49320, 0.32608695652174, 0.82826086956522, 0.38888888888889
49321, 0.30434782608696, 0.80217391304348, 0.38888888888889
49322, 0.30434782608696, 0.82826086956522, 0.41666666666667
49323, 0.32608695652174, 0.82826086956522, 0.44444444444444
49324, 0.30434782608696, 0.80217391304348, 0.44444444444444
49325, 0.30434782608696, 0.82826086956522, 0.47222222222222
49326, 0.26086956521739, 0.82826086956522, 0.027777777777778
49327, 0.28260869565217, 0.82826086956522, 0.055555555555556
49328, 0.26086956521739, 0.80217391304348, 0.055555555555556
49329, 0.26086956521739, 0.82826086956522, 0.083333333333333
49330, 0.28260869565217, 0.82826086956522, 0.11111111111111
49331, 0.26086956521739, 0.80217391304348, 0.11111111111111
49332, 0.26086956521739, 0.82826086956522, 0.13888888888889
49333, 0.28260869565217, 0.82826086956522, 0.16666666666667
49334, 0.26086956521739, 0.80217391304348, 0.16666666666667
49335, 0.26086956521739, 0.82826086956522, 0.19444444444444
49336, 0.28260869565217, 0.82826086956522, 0.22222222222222
49337, 0.26086956521739, 0.80217391304348, 0.22222222222222
49338, 0.26086956521739, 0.82826086956522, 0.25
49339, 0.28260869565217, 0.82826086956522, 0.27777777777778
49340, 0.26086956521739, 0.80217391304348, 0.27777777777778
49341, 0.26086956521739, 0.82826086956522, 0.30555555555556
49342, 0.28260869565217, 0.82826086956522, 0.33333333333333
49343, 0.26086956521739, 0.80217391304348, 0.33333333333333
49344, 0.26086956521739, 0.82826086956522, 0.36111111111111
49345, 0.28260869565217, 0.82826086956522, 0.38888888888889
49346, 0.26086956521739, 0.80217391304348, 0.38888888888889
49347, 0.26086956521739, 0.82826086956522, 0.41666666666667
49348, 0.28260869565217, 0.82826086956522, 0.44444444444444
49349, 0.26086956521739, 0.80217391304348, 0.44444444444444
49350, 0.26086956521739, 0.82826086956522, 0.47222222222222
49351, 0.21739130434783, 0.82826086956522, 0.027777777777778
49352, 0.23913043478261, 0.82826086956522, 0.055555555555556
49353, 0.21739130434783, 0.80217391304348, 0.055555555555556
49354, 0.21739130434783, 0.82826086956522, 0.083333333333333
49355, 0.23913043478261, 0.82826086956522, 0.11111111111111
49356, 0.21739130434783, 0.80217391304348, 0.11111111111111
49357, 0.21739130434783, 0.82826086956522, 0.13888888888889
49358, 0.23913043478261, 0.82826086956522, 0.16666666666667
49359, 0.21739130434783, 0.80217391304348, 0.16666666666667
49360, 0.21739130434783, 0.82826086956522, 0.19444444444444
49361, 0.23913043478261, 0.82826086956522, 0.22222222222222
49362, 0.21739130434783, 0.80217391304348, 0.22222222222222
49363, 0.21739130434783, 0.82826086956522, 0.25
49364, 0.23913043478261, 0.82826086956522, 0.27777777777778
49365, 0.21739130434783, 0.80217391304348, 0.27777777777778
49366, 0.21739130434783, 0.82826086956522, 0.30555555555556
49367, 0.23913043478261, 0.82826086956522, 0.33333333333333
49368, 0.21739130434783, 0.80217391304348, 0.33333333333333
49369, 0.21739130434783, 0.82826086956522, 0.36111111111111
49370, 0.23913043478261, 0.82826086956522, 0.38888888888889
49371, 0.21739130434783, 0.80217391304348, 0.38888888888889
49372, 0.21739130434783, 0.82826086956522, 0.41666666666667
49373, 0.23913043478261, 0.82826086956522, 0.44444444444444
49374, 0.21739130434783, 0.80217391304348, 0.44444444444444
49375, 0.21739130434783, 0.82826086956522, 0.47222222222222
49376, 0.17391304347826, 0.82826086956522, 0.027777777777778
49377, 0.19565217391304, 0.82826086956522, 0.055555555555556
49378, 0.17391304347826, 0.80217391304348, 0.055555555555556
49379, 0.17391304347826, 0.82826086956522, 0.083333333333333
49380, 0.19565217391304, 0.82826086956522, 0.11111111111111
49381, 0.17391304347826, 0.80217391304348, 0.11111111111111
49382, 0.17391304347826, 0.82826086956522, 0.13888888888889
49383, 0.19565217391304, 0.82826086956522, 0.16666666666667
49384, 0.17391304347826, 0.80217391304348, 0.16666666666667
49385, 0.17391304347826, 0.82826086956522, 0.19444444444444
49386, 0.19565217391304, 0.82826086956522, 0.22222222222222
49387, 0.17391304347826, 0.80217391304348, 0.22222222222222
49388, 0.17391304347826, 0.82826086956522, 0.25
49389, 0.19565217391304, 0.82826086956522, 0.27777777777778
49390, 0.17391304347826, 0.80217391304348, 0.27777777777778
49391, 0.17391304347826, 0.82826086956522, 0.30555555555556
49392, 0.19565217391304, 0.82826086956522, 0.33333333333333
49393, 0.17391304347826, 0.80217391304348, 0.33333333333333
49394, 0.17391304347826, 0.82826086956522, 0.36111111111111
49395, 0.19565217391304, 0.82826086956522, 0.38888888888889
49396, 0.17391304347826, 0.80217391304348, 0.38888888888889
49397, 0.17391304347826, 0.82826086956522, 0.41666666666667
49398, 0.19565217391304, 0.82826086956522, 0.44444444444444
49399, 0.17391304347826, 0.80217391304348, 0.44444444444444
49400, 0.17391304347826, 0.82826086956522, 0.47222222222222
49401, 0.1304347826087, 0.82826086956522, 0.027777777777778
49402, 0.15217391304348, 0.82826086956522, 0.055555555555556
49403, 0.1304347826087, 0.80217391304348, 0.055555555555556
49404, 0.1304347826087, 0.82826086956522, 0.083333333333333
49405, 0.15217391304348, 0.82826086956522, 0.11111111111111
49406, 0.1304347826087, 0.80217391304348, 0.11111111111111
49407, 0.1304347826087, 0.82826086956522, 0.13888888888889
49408, 0.15217391304348, 0.82826086956522, 0.16666666666667
49409, 0.1304347826087, 0.80217391304348, 0.16666666666667
49410, 0.1304347826087, 0.82826086956522, 0.19444444444444
49411, 0.15217391304348, 0.82826086956522, 0.22222222222222
49412, 0.1304347826087, 0.80217391304348, 0.22222222222222
49413, 0.1304347826087, 0.82826086956522, 0.25
49414, 0.15217391304348, 0.82826086956522, 0.27777777777778
49415, 0.1304347826087, 0.80217391304348, 0.27777777777778
49416, 0.1304347826087, 0.82826086956522, 0.30555555555556
49417, 0.15217391304348, 0.82826086956522, 0.33333333333333
49418, 0.1304347826087, 0.80217391304348, 0.33333333333333
49419, 0.1304347826087, 0.82826086956522, 0.36111111111111
49420, 0.15217391304348, 0.82826086956522, 0.38888888888889
49421, 0.1304347826087, 0.80217391304348, 0.38888888888889
49422, 0.1304347826087, 0.82826086956522, 0.41666666666667
49423, 0.15217391304348, 0.82826086956522, 0.44444444444444
49424, 0.1304347826087, 0.80217391304348, 0.44444444444444
49425, 0.1304347826087, 0.82826086956522, 0.47222222222222
49426, 0.08695652173913, 0.82826086956522, 0.027777777777778
49427, 0.10869565217391, 0.82826086956522, 0.055555555555556
49428, 0.08695652173913, 0.80217391304348, 0.055555555555556
49429, 0.08695652173913, 0.82826086956522, 0.083333333333333
49430, 0.10869565217391, 0.82826086956522, 0.11111111111111
49431, 0.08695652173913, 0.80217391304348, 0.11111111111111
49432, 0.08695652173913, 0.82826086956522, 0.13888888888889
49433, 0.10869565217391, 0.82826086956522, 0.16666666666667
49434, 0.08695652173913, 0.80217391304348, 0.16666666666667
49435, 0.08695652173913, 0.82826086956522, 0.19444444444444
49436, 0.10869565217391, 0.82826086956522, 0.22222222222222
49437, 0.08695652173913, 0.80217391304348, 0.22222222222222
49438, 0.08695652173913, 0.82826086956522, 0.25
49439, 0.10869565217391, 0.82826086956522, 0.27777777777778
49440, 0.08695652173913, 0.80217391304348, 0.27777777777778
49441, 0.08695652173913, 0.82826086956522, 0.30555555555556
49442, 0.10869565217391, 0.82826086956522, 0.33333333333333
49443, 0.08695652173913, 0.80217391304348, 0.33333333333333
49444, 0.08695652173913, 0.82826086956522, 0.36111111111111
49445, 0.10869565217391, 0.82826086956522, 0.38888888888889
49446, 0.08695652173913, 0.80217391304348, 0.38888888888889
49447, 0.08695652173913, 0.82826086956522, 0.41666666666667
49448, 0.10869565217391, 0.82826086956522, 0.44444444444444
49449, 0.08695652173913, 0.80217391304348, 0.44444444444444
49450, 0.08695652173913, 0.82826086956522, 0.47222222222222
49451, 0.043478260869565, 0.82826086956522, 0.027777777777778
49452, 0.065217391304348, 0.82826086956522, 0.055555555555556
49453, 0.043478260869565, 0.80217391304348, 0.055555555555556
49454, 0.043478260869565, 0.82826086956522, 0.083333333333333
49455, 0.065217391304348, 0.82826086956522, 0.11111111111111
49456, 0.043478260869565, 0.80217391304348, 0.11111111111111
49457, 0.043478260869565, 0.82826086956522, 0.13888888888889
49458, 0.065217391304348, 0.82826086956522, 0.16666666666667
49459, 0.043478260869565, 0.80217391304348, 0.16666666666667
49460, 0.043478260869565, 0.82826086956522, 0.19444444444444
49461, 0.065217391304348, 0.82826086956522, 0.22222222222222
49462, 0.043478260869565, 0.80217391304348, 0.22222222222222
49463, 0.043478260869565, 0.82826086956522, 0.25
49464, 0.065217391304348, 0.82826086956522, 0.27777777777778
49465, 0.043478260869565, 0.80217391304348, 0.27777777777778
49466, 0.043478260869565, 0.82826086956522, 0.30555555555556
49467, 0.065217391304348, 0.82826086956522, 0.33333333333333
49468, 0.043478260869565, 0.80217391304348, 0.33333333333333
49469, 0.043478260869565, 0.82826086956522, 0.36111111111111
49470, 0.065217391304348, 0.82826086956522, 0.38888888888889
49471, 0.043478260869565, 0.80217391304348, 0.38888888888889
49472, 0.043478260869565, 0.82826086956522, 0.41666666666667
49473, 0.065217391304348, 0.82826086956522, 0.44444444444444
49474, 0.043478260869565, 0.80217391304348, 0.44444444444444
49475, 0.043478260869565, 0.82826086956522, 0.47222222222222
49476, 0.021739130434783, 0.82826086956522, 0.055555555555556
49477, 0.021739130434783, 0.82826086956522, 0.11111111111111
49478, 0.021739130434783, 0.82826086956522, 0.16666666666667
49479, 0.021739130434783, 0.82826086956522, 0.22222222222222
49480, 0.021739130434783, 0.82826086956522, 0.27777777777778
49481, 0.021739130434783, 0.82826086956522, 0.33333333333333
49482, 0.021739130434783, 0.82826086956522, 0.38888888888889
49483, 0.021739130434783, 0.82826086956522, 0.44444444444444
49484, 0.95652173913043, 0.88043478260869, 0.027777777777778
49485, 0.97826086956522, 0.88043478260869, 0.055555555555556
49486, 0.95652173913043, 0.85434782608696, 0.055555555555556
49487, 0.95652173913043, 0.88043478260869, 0.083333333333333
49488, 0.97826086956522, 0.88043478260869, 0.11111111111111
49489, 0.95652173913044, 0.85434782608696, 0.11111111111111
49490, 0.95652173913044, 0.8804347826087, 0.13888888888889
49491, 0.97826086956522, 0.8804347826087, 0.16666666666667
49492, 0.95652173913044, 0.85434782608696, 0.16666666666667
49493, 0.95652173913044, 0.8804347826087, 0.19444444444444
49494, 0.97826086956522, 0.8804347826087, 0.22222222222222
49495, 0.95652173913044, 0.85434782608696, 0.22222222222222
49496, 0.95652173913044, 0.88043478260869, 0.25
49497, 0.97826086956522, 0.88043478260869, 0.27777777777778
49498, 0.95652173913044, 0.85434782608696, 0.27777777777778
49499, 0.95652173913044, 0.8804347826087, 0.30555555555556
