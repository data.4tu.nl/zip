25092, 24851, 24850, 24828, 24829, 62164, 62156, 61980, 61988, 25614, 25613, 25569, 25615, 70672, 70648, 70114, 
70673, 70671, 70646, 70088, 70113
25093, 62164, 62156, 61980, 61988, 62165, 62157, 61981, 61989, 70672, 70648, 70114, 70673, 70675, 70651, 70117, 
70676, 70674, 70649, 70091, 70116
25094, 62165, 62157, 61981, 61989, 62166, 62158, 61982, 61990, 70675, 70651, 70117, 70676, 70678, 70654, 70120, 
70679, 70677, 70652, 70094, 70119
25095, 62166, 62158, 61982, 61990, 62167, 62159, 61983, 61991, 70678, 70654, 70120, 70679, 70681, 70657, 70123, 
70682, 70680, 70655, 70097, 70122
25096, 62167, 62159, 61983, 61991, 62168, 62160, 61984, 61992, 70681, 70657, 70123, 70682, 70684, 70660, 70126, 
70685, 70683, 70658, 70100, 70125
25097, 62168, 62160, 61984, 61992, 62169, 62161, 61985, 61993, 70684, 70660, 70126, 70685, 70687, 70663, 70129, 
70688, 70686, 70661, 70103, 70128
25098, 62169, 62161, 61985, 61993, 62170, 62162, 61986, 61994, 70687, 70663, 70129, 70688, 70690, 70666, 70132, 
70691, 70689, 70664, 70106, 70131
25099, 62170, 62162, 61986, 61994, 62171, 62163, 61987, 61995, 70690, 70666, 70132, 70691, 70693, 70669, 70135, 
70694, 70692, 70667, 70109, 70134
25100, 62171, 62163, 61987, 61995, 26347, 26346, 26324, 26325, 70693, 70669, 70135, 70694, 27111, 27108, 27066, 
27110, 70695, 70670, 70112, 70137
25101, 24852, 24851, 24829, 24830, 62172, 62164, 61988, 61996, 25616, 25615, 25571, 25617, 70697, 70673, 70139, 
70698, 70696, 70671, 70113, 70138
25102, 62172, 62164, 61988, 61996, 62173, 62165, 61989, 61997, 70697, 70673, 70139, 70698, 70700, 70676, 70142, 
70701, 70699, 70674, 70116, 70141
25103, 62173, 62165, 61989, 61997, 62174, 62166, 61990, 61998, 70700, 70676, 70142, 70701, 70703, 70679, 70145, 
70704, 70702, 70677, 70119, 70144
25104, 62174, 62166, 61990, 61998, 62175, 62167, 61991, 61999, 70703, 70679, 70145, 70704, 70706, 70682, 70148, 
70707, 70705, 70680, 70122, 70147
25105, 62175, 62167, 61991, 61999, 62176, 62168, 61992, 62000, 70706, 70682, 70148, 70707, 70709, 70685, 70151, 
70710, 70708, 70683, 70125, 70150
25106, 62176, 62168, 61992, 62000, 62177, 62169, 61993, 62001, 70709, 70685, 70151, 70710, 70712, 70688, 70154, 
70713, 70711, 70686, 70128, 70153
25107, 62177, 62169, 61993, 62001, 62178, 62170, 61994, 62002, 70712, 70688, 70154, 70713, 70715, 70691, 70157, 
70716, 70714, 70689, 70131, 70156
25108, 62178, 62170, 61994, 62002, 62179, 62171, 61995, 62003, 70715, 70691, 70157, 70716, 70718, 70694, 70160, 
70719, 70717, 70692, 70134, 70159
25109, 62179, 62171, 61995, 62003, 26348, 26347, 26325, 26326, 70718, 70694, 70160, 70719, 27113, 27110, 27068, 
27112, 70720, 70695, 70137, 70162
25110, 24853, 24852, 24830, 24831, 62180, 62172, 61996, 62004, 25618, 25617, 25573, 25619, 70722, 70698, 70164, 
70723, 70721, 70696, 70138, 70163
25111, 62180, 62172, 61996, 62004, 62181, 62173, 61997, 62005, 70722, 70698, 70164, 70723, 70725, 70701, 70167, 
70726, 70724, 70699, 70141, 70166
25112, 62181, 62173, 61997, 62005, 62182, 62174, 61998, 62006, 70725, 70701, 70167, 70726, 70728, 70704, 70170, 
70729, 70727, 70702, 70144, 70169
25113, 62182, 62174, 61998, 62006, 62183, 62175, 61999, 62007, 70728, 70704, 70170, 70729, 70731, 70707, 70173, 
70732, 70730, 70705, 70147, 70172
25114, 62183, 62175, 61999, 62007, 62184, 62176, 62000, 62008, 70731, 70707, 70173, 70732, 70734, 70710, 70176, 
70735, 70733, 70708, 70150, 70175
25115, 62184, 62176, 62000, 62008, 62185, 62177, 62001, 62009, 70734, 70710, 70176, 70735, 70737, 70713, 70179, 
70738, 70736, 70711, 70153, 70178
25116, 62185, 62177, 62001, 62009, 62186, 62178, 62002, 62010, 70737, 70713, 70179, 70738, 70740, 70716, 70182, 
70741, 70739, 70714, 70156, 70181
25117, 62186, 62178, 62002, 62010, 62187, 62179, 62003, 62011, 70740, 70716, 70182, 70741, 70743, 70719, 70185, 
70744, 70742, 70717, 70159, 70184
25118, 62187, 62179, 62003, 62011, 26349, 26348, 26326, 26327, 70743, 70719, 70185, 70744, 27115, 27112, 27070, 
27114, 70745, 70720, 70162, 70187
25119, 24854, 24853, 24831, 24832, 62188, 62180, 62004, 62012, 25620, 25619, 25575, 25621, 70747, 70723, 70189, 
70748, 70746, 70721, 70163, 70188
25120, 62188, 62180, 62004, 62012, 62189, 62181, 62005, 62013, 70747, 70723, 70189, 70748, 70750, 70726, 70192, 
70751, 70749, 70724, 70166, 70191
25121, 62189, 62181, 62005, 62013, 62190, 62182, 62006, 62014, 70750, 70726, 70192, 70751, 70753, 70729, 70195, 
70754, 70752, 70727, 70169, 70194
25122, 62190, 62182, 62006, 62014, 62191, 62183, 62007, 62015, 70753, 70729, 70195, 70754, 70756, 70732, 70198, 
70757, 70755, 70730, 70172, 70197
25123, 62191, 62183, 62007, 62015, 62192, 62184, 62008, 62016, 70756, 70732, 70198, 70757, 70759, 70735, 70201, 
70760, 70758, 70733, 70175, 70200
25124, 62192, 62184, 62008, 62016, 62193, 62185, 62009, 62017, 70759, 70735, 70201, 70760, 70762, 70738, 70204, 
70763, 70761, 70736, 70178, 70203
25125, 62193, 62185, 62009, 62017, 62194, 62186, 62010, 62018, 70762, 70738, 70204, 70763, 70765, 70741, 70207, 
70766, 70764, 70739, 70181, 70206
25126, 62194, 62186, 62010, 62018, 62195, 62187, 62011, 62019, 70765, 70741, 70207, 70766, 70768, 70744, 70210, 
70769, 70767, 70742, 70184, 70209
25127, 62195, 62187, 62011, 62019, 26350, 26349, 26327, 26328, 70768, 70744, 70210, 70769, 27117, 27114, 27072, 
27116, 70770, 70745, 70187, 70212
25128, 24855, 24854, 24832, 24833, 62196, 62188, 62012, 62020, 25622, 25621, 25577, 25623, 70772, 70748, 70214, 
70773, 70771, 70746, 70188, 70213
25129, 62196, 62188, 62012, 62020, 62197, 62189, 62013, 62021, 70772, 70748, 70214, 70773, 70775, 70751, 70217, 
70776, 70774, 70749, 70191, 70216
25130, 62197, 62189, 62013, 62021, 62198, 62190, 62014, 62022, 70775, 70751, 70217, 70776, 70778, 70754, 70220, 
70779, 70777, 70752, 70194, 70219
25131, 62198, 62190, 62014, 62022, 62199, 62191, 62015, 62023, 70778, 70754, 70220, 70779, 70781, 70757, 70223, 
70782, 70780, 70755, 70197, 70222
25132, 62199, 62191, 62015, 62023, 62200, 62192, 62016, 62024, 70781, 70757, 70223, 70782, 70784, 70760, 70226, 
70785, 70783, 70758, 70200, 70225
25133, 62200, 62192, 62016, 62024, 62201, 62193, 62017, 62025, 70784, 70760, 70226, 70785, 70787, 70763, 70229, 
70788, 70786, 70761, 70203, 70228
25134, 62201, 62193, 62017, 62025, 62202, 62194, 62018, 62026, 70787, 70763, 70229, 70788, 70790, 70766, 70232, 
70791, 70789, 70764, 70206, 70231
25135, 62202, 62194, 62018, 62026, 62203, 62195, 62019, 62027, 70790, 70766, 70232, 70791, 70793, 70769, 70235, 
70794, 70792, 70767, 70209, 70234
25136, 62203, 62195, 62019, 62027, 26351, 26350, 26328, 26329, 70793, 70769, 70235, 70794, 27119, 27116, 27074, 
27118, 70795, 70770, 70212, 70237
25137, 24856, 24855, 24833, 24834, 62204, 62196, 62020, 62028, 25624, 25623, 25579, 25625, 70797, 70773, 70239, 
70798, 70796, 70771, 70213, 70238
25138, 62204, 62196, 62020, 62028, 62205, 62197, 62021, 62029, 70797, 70773, 70239, 70798, 70800, 70776, 70242, 
70801, 70799, 70774, 70216, 70241
25139, 62205, 62197, 62021, 62029, 62206, 62198, 62022, 62030, 70800, 70776, 70242, 70801, 70803, 70779, 70245, 
70804, 70802, 70777, 70219, 70244
25140, 62206, 62198, 62022, 62030, 62207, 62199, 62023, 62031, 70803, 70779, 70245, 70804, 70806, 70782, 70248, 
70807, 70805, 70780, 70222, 70247
25141, 62207, 62199, 62023, 62031, 62208, 62200, 62024, 62032, 70806, 70782, 70248, 70807, 70809, 70785, 70251, 
70810, 70808, 70783, 70225, 70250
25142, 62208, 62200, 62024, 62032, 62209, 62201, 62025, 62033, 70809, 70785, 70251, 70810, 70812, 70788, 70254, 
70813, 70811, 70786, 70228, 70253
25143, 62209, 62201, 62025, 62033, 62210, 62202, 62026, 62034, 70812, 70788, 70254, 70813, 70815, 70791, 70257, 
70816, 70814, 70789, 70231, 70256
25144, 62210, 62202, 62026, 62034, 62211, 62203, 62027, 62035, 70815, 70791, 70257, 70816, 70818, 70794, 70260, 
70819, 70817, 70792, 70234, 70259
25145, 62211, 62203, 62027, 62035, 26352, 26351, 26329, 26330, 70818, 70794, 70260, 70819, 27121, 27118, 27076, 
27120, 70820, 70795, 70237, 70262
25146, 24857, 24856, 24834, 24835, 62212, 62204, 62028, 62036, 25626, 25625, 25581, 25627, 70822, 70798, 70264, 
70823, 70821, 70796, 70238, 70263
25147, 62212, 62204, 62028, 62036, 62213, 62205, 62029, 62037, 70822, 70798, 70264, 70823, 70825, 70801, 70267, 
70826, 70824, 70799, 70241, 70266
25148, 62213, 62205, 62029, 62037, 62214, 62206, 62030, 62038, 70825, 70801, 70267, 70826, 70828, 70804, 70270, 
70829, 70827, 70802, 70244, 70269
25149, 62214, 62206, 62030, 62038, 62215, 62207, 62031, 62039, 70828, 70804, 70270, 70829, 70831, 70807, 70273, 
70832, 70830, 70805, 70247, 70272
25150, 62215, 62207, 62031, 62039, 62216, 62208, 62032, 62040, 70831, 70807, 70273, 70832, 70834, 70810, 70276, 
70835, 70833, 70808, 70250, 70275
25151, 62216, 62208, 62032, 62040, 62217, 62209, 62033, 62041, 70834, 70810, 70276, 70835, 70837, 70813, 70279, 
70838, 70836, 70811, 70253, 70278
25152, 62217, 62209, 62033, 62041, 62218, 62210, 62034, 62042, 70837, 70813, 70279, 70838, 70840, 70816, 70282, 
70841, 70839, 70814, 70256, 70281
25153, 62218, 62210, 62034, 62042, 62219, 62211, 62035, 62043, 70840, 70816, 70282, 70841, 70843, 70819, 70285, 
70844, 70842, 70817, 70259, 70284
25154, 62219, 62211, 62035, 62043, 26353, 26352, 26330, 26331, 70843, 70819, 70285, 70844, 27123, 27120, 27078, 
27122, 70845, 70820, 70262, 70287
25155, 24858, 24857, 24835, 24836, 62220, 62212, 62036, 62044, 25628, 25627, 25583, 25629, 70847, 70823, 70289, 
70848, 70846, 70821, 70263, 70288
25156, 62220, 62212, 62036, 62044, 62221, 62213, 62037, 62045, 70847, 70823, 70289, 70848, 70850, 70826, 70292, 
70851, 70849, 70824, 70266, 70291
25157, 62221, 62213, 62037, 62045, 62222, 62214, 62038, 62046, 70850, 70826, 70292, 70851, 70853, 70829, 70295, 
70854, 70852, 70827, 70269, 70294
25158, 62222, 62214, 62038, 62046, 62223, 62215, 62039, 62047, 70853, 70829, 70295, 70854, 70856, 70832, 70298, 
70857, 70855, 70830, 70272, 70297
25159, 62223, 62215, 62039, 62047, 62224, 62216, 62040, 62048, 70856, 70832, 70298, 70857, 70859, 70835, 70301, 
70860, 70858, 70833, 70275, 70300
25160, 62224, 62216, 62040, 62048, 62225, 62217, 62041, 62049, 70859, 70835, 70301, 70860, 70862, 70838, 70304, 
70863, 70861, 70836, 70278, 70303
25161, 62225, 62217, 62041, 62049, 62226, 62218, 62042, 62050, 70862, 70838, 70304, 70863, 70865, 70841, 70307, 
70866, 70864, 70839, 70281, 70306
25162, 62226, 62218, 62042, 62050, 62227, 62219, 62043, 62051, 70865, 70841, 70307, 70866, 70868, 70844, 70310, 
70869, 70867, 70842, 70284, 70309
25163, 62227, 62219, 62043, 62051, 26354, 26353, 26331, 26332, 70868, 70844, 70310, 70869, 27125, 27122, 27080, 
27124, 70870, 70845, 70287, 70312
25164, 24859, 24858, 24836, 24837, 62228, 62220, 62044, 62052, 25630, 25629, 25585, 25631, 70872, 70848, 70314, 
70873, 70871, 70846, 70288, 70313
25165, 62228, 62220, 62044, 62052, 62229, 62221, 62045, 62053, 70872, 70848, 70314, 70873, 70875, 70851, 70317, 
70876, 70874, 70849, 70291, 70316
25166, 62229, 62221, 62045, 62053, 62230, 62222, 62046, 62054, 70875, 70851, 70317, 70876, 70878, 70854, 70320, 
70879, 70877, 70852, 70294, 70319
25167, 62230, 62222, 62046, 62054, 62231, 62223, 62047, 62055, 70878, 70854, 70320, 70879, 70881, 70857, 70323, 
70882, 70880, 70855, 70297, 70322
25168, 62231, 62223, 62047, 62055, 62232, 62224, 62048, 62056, 70881, 70857, 70323, 70882, 70884, 70860, 70326, 
70885, 70883, 70858, 70300, 70325
25169, 62232, 62224, 62048, 62056, 62233, 62225, 62049, 62057, 70884, 70860, 70326, 70885, 70887, 70863, 70329, 
70888, 70886, 70861, 70303, 70328
25170, 62233, 62225, 62049, 62057, 62234, 62226, 62050, 62058, 70887, 70863, 70329, 70888, 70890, 70866, 70332, 
70891, 70889, 70864, 70306, 70331
25171, 62234, 62226, 62050, 62058, 62235, 62227, 62051, 62059, 70890, 70866, 70332, 70891, 70893, 70869, 70335, 
70894, 70892, 70867, 70309, 70334
25172, 62235, 62227, 62051, 62059, 26355, 26354, 26332, 26333, 70893, 70869, 70335, 70894, 27127, 27124, 27082, 
27126, 70895, 70870, 70312, 70337
25173, 24860, 24859, 24837, 24838, 62236, 62228, 62052, 62060, 25632, 25631, 25587, 25633, 70897, 70873, 70339, 
70898, 70896, 70871, 70313, 70338
25174, 62236, 62228, 62052, 62060, 62237, 62229, 62053, 62061, 70897, 70873, 70339, 70898, 70900, 70876, 70342, 
70901, 70899, 70874, 70316, 70341
25175, 62237, 62229, 62053, 62061, 62238, 62230, 62054, 62062, 70900, 70876, 70342, 70901, 70903, 70879, 70345, 
70904, 70902, 70877, 70319, 70344
25176, 62238, 62230, 62054, 62062, 62239, 62231, 62055, 62063, 70903, 70879, 70345, 70904, 70906, 70882, 70348, 
70907, 70905, 70880, 70322, 70347
25177, 62239, 62231, 62055, 62063, 62240, 62232, 62056, 62064, 70906, 70882, 70348, 70907, 70909, 70885, 70351, 
70910, 70908, 70883, 70325, 70350
25178, 62240, 62232, 62056, 62064, 62241, 62233, 62057, 62065, 70909, 70885, 70351, 70910, 70912, 70888, 70354, 
70913, 70911, 70886, 70328, 70353
25179, 62241, 62233, 62057, 62065, 62242, 62234, 62058, 62066, 70912, 70888, 70354, 70913, 70915, 70891, 70357, 
70916, 70914, 70889, 70331, 70356
25180, 62242, 62234, 62058, 62066, 62243, 62235, 62059, 62067, 70915, 70891, 70357, 70916, 70918, 70894, 70360, 
70919, 70917, 70892, 70334, 70359
25181, 62243, 62235, 62059, 62067, 26356, 26355, 26333, 26334, 70918, 70894, 70360, 70919, 27129, 27126, 27084, 
27128, 70920, 70895, 70337, 70362
25182, 24861, 24860, 24838, 24839, 62244, 62236, 62060, 62068, 25634, 25633, 25589, 25635, 70922, 70898, 70364, 
70923, 70921, 70896, 70338, 70363
25183, 62244, 62236, 62060, 62068, 62245, 62237, 62061, 62069, 70922, 70898, 70364, 70923, 70925, 70901, 70367, 
70926, 70924, 70899, 70341, 70366
25184, 62245, 62237, 62061, 62069, 62246, 62238, 62062, 62070, 70925, 70901, 70367, 70926, 70928, 70904, 70370, 
70929, 70927, 70902, 70344, 70369
25185, 62246, 62238, 62062, 62070, 62247, 62239, 62063, 62071, 70928, 70904, 70370, 70929, 70931, 70907, 70373, 
70932, 70930, 70905, 70347, 70372
25186, 62247, 62239, 62063, 62071, 62248, 62240, 62064, 62072, 70931, 70907, 70373, 70932, 70934, 70910, 70376, 
70935, 70933, 70908, 70350, 70375
25187, 62248, 62240, 62064, 62072, 62249, 62241, 62065, 62073, 70934, 70910, 70376, 70935, 70937, 70913, 70379, 
70938, 70936, 70911, 70353, 70378
25188, 62249, 62241, 62065, 62073, 62250, 62242, 62066, 62074, 70937, 70913, 70379, 70938, 70940, 70916, 70382, 
70941, 70939, 70914, 70356, 70381
25189, 62250, 62242, 62066, 62074, 62251, 62243, 62067, 62075, 70940, 70916, 70382, 70941, 70943, 70919, 70385, 
70944, 70942, 70917, 70359, 70384
25190, 62251, 62243, 62067, 62075, 26357, 26356, 26334, 26335, 70943, 70919, 70385, 70944, 27131, 27128, 27086, 
27130, 70945, 70920, 70362, 70387
25191, 24862, 24861, 24839, 24840, 62252, 62244, 62068, 62076, 25636, 25635, 25591, 25637, 70947, 70923, 70389, 
70948, 70946, 70921, 70363, 70388
25192, 62252, 62244, 62068, 62076, 62253, 62245, 62069, 62077, 70947, 70923, 70389, 70948, 70950, 70926, 70392, 
70951, 70949, 70924, 70366, 70391
25193, 62253, 62245, 62069, 62077, 62254, 62246, 62070, 62078, 70950, 70926, 70392, 70951, 70953, 70929, 70395, 
70954, 70952, 70927, 70369, 70394
25194, 62254, 62246, 62070, 62078, 62255, 62247, 62071, 62079, 70953, 70929, 70395, 70954, 70956, 70932, 70398, 
70957, 70955, 70930, 70372, 70397
25195, 62255, 62247, 62071, 62079, 62256, 62248, 62072, 62080, 70956, 70932, 70398, 70957, 70959, 70935, 70401, 
70960, 70958, 70933, 70375, 70400
25196, 62256, 62248, 62072, 62080, 62257, 62249, 62073, 62081, 70959, 70935, 70401, 70960, 70962, 70938, 70404, 
70963, 70961, 70936, 70378, 70403
25197, 62257, 62249, 62073, 62081, 62258, 62250, 62074, 62082, 70962, 70938, 70404, 70963, 70965, 70941, 70407, 
70966, 70964, 70939, 70381, 70406
25198, 62258, 62250, 62074, 62082, 62259, 62251, 62075, 62083, 70965, 70941, 70407, 70966, 70968, 70944, 70410, 
70969, 70967, 70942, 70384, 70409
25199, 62259, 62251, 62075, 62083, 26358, 26357, 26335, 26336, 70968, 70944, 70410, 70969, 27133, 27130, 27088, 
27132, 70970, 70945, 70387, 70412
25200, 24863, 24862, 24840, 24841, 62260, 62252, 62076, 62084, 25638, 25637, 25593, 25639, 70972, 70948, 70414, 
70973, 70971, 70946, 70388, 70413
25201, 62260, 62252, 62076, 62084, 62261, 62253, 62077, 62085, 70972, 70948, 70414, 70973, 70975, 70951, 70417, 
70976, 70974, 70949, 70391, 70416
25202, 62261, 62253, 62077, 62085, 62262, 62254, 62078, 62086, 70975, 70951, 70417, 70976, 70978, 70954, 70420, 
70979, 70977, 70952, 70394, 70419
25203, 62262, 62254, 62078, 62086, 62263, 62255, 62079, 62087, 70978, 70954, 70420, 70979, 70981, 70957, 70423, 
70982, 70980, 70955, 70397, 70422
25204, 62263, 62255, 62079, 62087, 62264, 62256, 62080, 62088, 70981, 70957, 70423, 70982, 70984, 70960, 70426, 
70985, 70983, 70958, 70400, 70425
25205, 62264, 62256, 62080, 62088, 62265, 62257, 62081, 62089, 70984, 70960, 70426, 70985, 70987, 70963, 70429, 
70988, 70986, 70961, 70403, 70428
25206, 62265, 62257, 62081, 62089, 62266, 62258, 62082, 62090, 70987, 70963, 70429, 70988, 70990, 70966, 70432, 
70991, 70989, 70964, 70406, 70431
25207, 62266, 62258, 62082, 62090, 62267, 62259, 62083, 62091, 70990, 70966, 70432, 70991, 70993, 70969, 70435, 
70994, 70992, 70967, 70409, 70434
25208, 62267, 62259, 62083, 62091, 26359, 26358, 26336, 26337, 70993, 70969, 70435, 70994, 27135, 27132, 27090, 
27134, 70995, 70970, 70412, 70437
25209, 24864, 24863, 24841, 24842, 62268, 62260, 62084, 62092, 25640, 25639, 25595, 25641, 70997, 70973, 70439, 
70998, 70996, 70971, 70413, 70438
25210, 62268, 62260, 62084, 62092, 62269, 62261, 62085, 62093, 70997, 70973, 70439, 70998, 71000, 70976, 70442, 
71001, 70999, 70974, 70416, 70441
25211, 62269, 62261, 62085, 62093, 62270, 62262, 62086, 62094, 71000, 70976, 70442, 71001, 71003, 70979, 70445, 
71004, 71002, 70977, 70419, 70444
25212, 62270, 62262, 62086, 62094, 62271, 62263, 62087, 62095, 71003, 70979, 70445, 71004, 71006, 70982, 70448, 
71007, 71005, 70980, 70422, 70447
25213, 62271, 62263, 62087, 62095, 62272, 62264, 62088, 62096, 71006, 70982, 70448, 71007, 71009, 70985, 70451, 
71010, 71008, 70983, 70425, 70450
25214, 62272, 62264, 62088, 62096, 62273, 62265, 62089, 62097, 71009, 70985, 70451, 71010, 71012, 70988, 70454, 
71013, 71011, 70986, 70428, 70453
25215, 62273, 62265, 62089, 62097, 62274, 62266, 62090, 62098, 71012, 70988, 70454, 71013, 71015, 70991, 70457, 
71016, 71014, 70989, 70431, 70456
25216, 62274, 62266, 62090, 62098, 62275, 62267, 62091, 62099, 71015, 70991, 70457, 71016, 71018, 70994, 70460, 
71019, 71017, 70992, 70434, 70459
25217, 62275, 62267, 62091, 62099, 26360, 26359, 26337, 26338, 71018, 70994, 70460, 71019, 27137, 27134, 27092, 
27136, 71020, 70995, 70437, 70462
25218, 24865, 24864, 24842, 24843, 62276, 62268, 62092, 62100, 25642, 25641, 25597, 25643, 71022, 70998, 70464, 
71023, 71021, 70996, 70438, 70463
25219, 62276, 62268, 62092, 62100, 62277, 62269, 62093, 62101, 71022, 70998, 70464, 71023, 71025, 71001, 70467, 
71026, 71024, 70999, 70441, 70466
25220, 62277, 62269, 62093, 62101, 62278, 62270, 62094, 62102, 71025, 71001, 70467, 71026, 71028, 71004, 70470, 
71029, 71027, 71002, 70444, 70469
25221, 62278, 62270, 62094, 62102, 62279, 62271, 62095, 62103, 71028, 71004, 70470, 71029, 71031, 71007, 70473, 
71032, 71030, 71005, 70447, 70472
25222, 62279, 62271, 62095, 62103, 62280, 62272, 62096, 62104, 71031, 71007, 70473, 71032, 71034, 71010, 70476, 
71035, 71033, 71008, 70450, 70475
25223, 62280, 62272, 62096, 62104, 62281, 62273, 62097, 62105, 71034, 71010, 70476, 71035, 71037, 71013, 70479, 
71038, 71036, 71011, 70453, 70478
25224, 62281, 62273, 62097, 62105, 62282, 62274, 62098, 62106, 71037, 71013, 70479, 71038, 71040, 71016, 70482, 
71041, 71039, 71014, 70456, 70481
25225, 62282, 62274, 62098, 62106, 62283, 62275, 62099, 62107, 71040, 71016, 70482, 71041, 71043, 71019, 70485, 
71044, 71042, 71017, 70459, 70484
25226, 62283, 62275, 62099, 62107, 26361, 26360, 26338, 26339, 71043, 71019, 70485, 71044, 27139, 27136, 27094, 
27138, 71045, 71020, 70462, 70487
25227, 24866, 24865, 24843, 24844, 62284, 62276, 62100, 62108, 25644, 25643, 25599, 25645, 71047, 71023, 70489, 
71048, 71046, 71021, 70463, 70488
25228, 62284, 62276, 62100, 62108, 62285, 62277, 62101, 62109, 71047, 71023, 70489, 71048, 71050, 71026, 70492, 
71051, 71049, 71024, 70466, 70491
25229, 62285, 62277, 62101, 62109, 62286, 62278, 62102, 62110, 71050, 71026, 70492, 71051, 71053, 71029, 70495, 
71054, 71052, 71027, 70469, 70494
25230, 62286, 62278, 62102, 62110, 62287, 62279, 62103, 62111, 71053, 71029, 70495, 71054, 71056, 71032, 70498, 
71057, 71055, 71030, 70472, 70497
25231, 62287, 62279, 62103, 62111, 62288, 62280, 62104, 62112, 71056, 71032, 70498, 71057, 71059, 71035, 70501, 
71060, 71058, 71033, 70475, 70500
25232, 62288, 62280, 62104, 62112, 62289, 62281, 62105, 62113, 71059, 71035, 70501, 71060, 71062, 71038, 70504, 
71063, 71061, 71036, 70478, 70503
25233, 62289, 62281, 62105, 62113, 62290, 62282, 62106, 62114, 71062, 71038, 70504, 71063, 71065, 71041, 70507, 
71066, 71064, 71039, 70481, 70506
25234, 62290, 62282, 62106, 62114, 62291, 62283, 62107, 62115, 71065, 71041, 70507, 71066, 71068, 71044, 70510, 
71069, 71067, 71042, 70484, 70509
25235, 62291, 62283, 62107, 62115, 26362, 26361, 26339, 26340, 71068, 71044, 70510, 71069, 27141, 27138, 27096, 
27140, 71070, 71045, 70487, 70512
25236, 24867, 24866, 24844, 24845, 62292, 62284, 62108, 62116, 25646, 25645, 25601, 25647, 71072, 71048, 70514, 
71073, 71071, 71046, 70488, 70513
25237, 62292, 62284, 62108, 62116, 62293, 62285, 62109, 62117, 71072, 71048, 70514, 71073, 71075, 71051, 70517, 
71076, 71074, 71049, 70491, 70516
25238, 62293, 62285, 62109, 62117, 62294, 62286, 62110, 62118, 71075, 71051, 70517, 71076, 71078, 71054, 70520, 
71079, 71077, 71052, 70494, 70519
25239, 62294, 62286, 62110, 62118, 62295, 62287, 62111, 62119, 71078, 71054, 70520, 71079, 71081, 71057, 70523, 
71082, 71080, 71055, 70497, 70522
25240, 62295, 62287, 62111, 62119, 62296, 62288, 62112, 62120, 71081, 71057, 70523, 71082, 71084, 71060, 70526, 
71085, 71083, 71058, 70500, 70525
25241, 62296, 62288, 62112, 62120, 62297, 62289, 62113, 62121, 71084, 71060, 70526, 71085, 71087, 71063, 70529, 
71088, 71086, 71061, 70503, 70528
25242, 62297, 62289, 62113, 62121, 62298, 62290, 62114, 62122, 71087, 71063, 70529, 71088, 71090, 71066, 70532, 
71091, 71089, 71064, 70506, 70531
25243, 62298, 62290, 62114, 62122, 62299, 62291, 62115, 62123, 71090, 71066, 70532, 71091, 71093, 71069, 70535, 
71094, 71092, 71067, 70509, 70534
25244, 62299, 62291, 62115, 62123, 26363, 26362, 26340, 26341, 71093, 71069, 70535, 71094, 27143, 27140, 27098, 
27142, 71095, 71070, 70512, 70537
25245, 24868, 24867, 24845, 24846, 62300, 62292, 62116, 62124, 25648, 25647, 25603, 25649, 71097, 71073, 70539, 
71098, 71096, 71071, 70513, 70538
25246, 62300, 62292, 62116, 62124, 62301, 62293, 62117, 62125, 71097, 71073, 70539, 71098, 71100, 71076, 70542, 
71101, 71099, 71074, 70516, 70541
25247, 62301, 62293, 62117, 62125, 62302, 62294, 62118, 62126, 71100, 71076, 70542, 71101, 71103, 71079, 70545, 
71104, 71102, 71077, 70519, 70544
25248, 62302, 62294, 62118, 62126, 62303, 62295, 62119, 62127, 71103, 71079, 70545, 71104, 71106, 71082, 70548, 
71107, 71105, 71080, 70522, 70547
25249, 62303, 62295, 62119, 62127, 62304, 62296, 62120, 62128, 71106, 71082, 70548, 71107, 71109, 71085, 70551, 
71110, 71108, 71083, 70525, 70550
25250, 62304, 62296, 62120, 62128, 62305, 62297, 62121, 62129, 71109, 71085, 70551, 71110, 71112, 71088, 70554, 
71113, 71111, 71086, 70528, 70553
25251, 62305, 62297, 62121, 62129, 62306, 62298, 62122, 62130, 71112, 71088, 70554, 71113, 71115, 71091, 70557, 
71116, 71114, 71089, 70531, 70556
25252, 62306, 62298, 62122, 62130, 62307, 62299, 62123, 62131, 71115, 71091, 70557, 71116, 71118, 71094, 70560, 
71119, 71117, 71092, 70534, 70559
25253, 62307, 62299, 62123, 62131, 26364, 26363, 26341, 26342, 71118, 71094, 70560, 71119, 27145, 27142, 27100, 
27144, 71120, 71095, 70537, 70562
25254, 24869, 24868, 24846, 24847, 62308, 62300, 62124, 62132, 25650, 25649, 25605, 25651, 71122, 71098, 70564, 
71123, 71121, 71096, 70538, 70563
25255, 62308, 62300, 62124, 62132, 62309, 62301, 62125, 62133, 71122, 71098, 70564, 71123, 71125, 71101, 70567, 
71126, 71124, 71099, 70541, 70566
25256, 62309, 62301, 62125, 62133, 62310, 62302, 62126, 62134, 71125, 71101, 70567, 71126, 71128, 71104, 70570, 
71129, 71127, 71102, 70544, 70569
25257, 62310, 62302, 62126, 62134, 62311, 62303, 62127, 62135, 71128, 71104, 70570, 71129, 71131, 71107, 70573, 
71132, 71130, 71105, 70547, 70572
25258, 62311, 62303, 62127, 62135, 62312, 62304, 62128, 62136, 71131, 71107, 70573, 71132, 71134, 71110, 70576, 
71135, 71133, 71108, 70550, 70575
25259, 62312, 62304, 62128, 62136, 62313, 62305, 62129, 62137, 71134, 71110, 70576, 71135, 71137, 71113, 70579, 
71138, 71136, 71111, 70553, 70578
25260, 62313, 62305, 62129, 62137, 62314, 62306, 62130, 62138, 71137, 71113, 70579, 71138, 71140, 71116, 70582, 
71141, 71139, 71114, 70556, 70581
25261, 62314, 62306, 62130, 62138, 62315, 62307, 62131, 62139, 71140, 71116, 70582, 71141, 71143, 71119, 70585, 
71144, 71142, 71117, 70559, 70584
25262, 62315, 62307, 62131, 62139, 26365, 26364, 26342, 26343, 71143, 71119, 70585, 71144, 27147, 27144, 27102, 
27146, 71145, 71120, 70562, 70587
25263, 3182, 24869, 24847, 3181, 28230, 62308, 62132, 28222, 25652, 25651, 25607, 3204, 71146, 71123, 70588, 
28515, 28514, 71121, 70563, 28497
25264, 28230, 62308, 62132, 28222, 28231, 62309, 62133, 28223, 71146, 71123, 70588, 28515, 71147, 71126, 70589, 
28517, 28516, 71124, 70566, 28499
25265, 28231, 62309, 62133, 28223, 28232, 62310, 62134, 28224, 71147, 71126, 70589, 28517, 71148, 71129, 70590, 
28519, 28518, 71127, 70569, 28501
25266, 28232, 62310, 62134, 28224, 28233, 62311, 62135, 28225, 71148, 71129, 70590, 28519, 71149, 71132, 70591, 
28521, 28520, 71130, 70572, 28503
25267, 28233, 62311, 62135, 28225, 28234, 62312, 62136, 28226, 71149, 71132, 70591, 28521, 71150, 71135, 70592, 
28523, 28522, 71133, 70575, 28505
25268, 28234, 62312, 62136, 28226, 28235, 62313, 62137, 28227, 71150, 71135, 70592, 28523, 71151, 71138, 70593, 
28525, 28524, 71136, 70578, 28507
25269, 28235, 62313, 62137, 28227, 28236, 62314, 62138, 28228, 71151, 71138, 70593, 28525, 71152, 71141, 70594, 
28527, 28526, 71139, 70581, 28509
25270, 28236, 62314, 62138, 28228, 28237, 62315, 62139, 28229, 71152, 71141, 70594, 28527, 71153, 71144, 70595, 
28529, 28528, 71142, 70584, 28511
25271, 28237, 62315, 62139, 28229, 3317, 26365, 26343, 3316, 71153, 71144, 70595, 28529, 27148, 27146, 27103, 
3339, 28530, 71145, 70587, 28513
25272, 24870, 3138, 3137, 24848, 62316, 27680, 27672, 62140, 25653, 3160, 25608, 25654, 71155, 27973, 70597, 
71156, 71154, 27974, 27957, 70596
25273, 62316, 27680, 27672, 62140, 62317, 27681, 27673, 62141, 71155, 27973, 70597, 71156, 71158, 27975, 70600, 
71159, 71157, 27976, 27959, 70599
25274, 62317, 27681, 27673, 62141, 62318, 27682, 27674, 62142, 71158, 27975, 70600, 71159, 71161, 27977, 70603, 
71162, 71160, 27978, 27961, 70602
25275, 62318, 27682, 27674, 62142, 62319, 27683, 27675, 62143, 71161, 27977, 70603, 71162, 71164, 27979, 70606, 
71165, 71163, 27980, 27963, 70605
25276, 62319, 27683, 27675, 62143, 62320, 27684, 27676, 62144, 71164, 27979, 70606, 71165, 71167, 27981, 70609, 
71168, 71166, 27982, 27965, 70608
25277, 62320, 27684, 27676, 62144, 62321, 27685, 27677, 62145, 71167, 27981, 70609, 71168, 71170, 27983, 70612, 
71171, 71169, 27984, 27967, 70611
25278, 62321, 27685, 27677, 62145, 62322, 27686, 27678, 62146, 71170, 27983, 70612, 71171, 71173, 27985, 70615, 
71174, 71172, 27986, 27969, 70614
25279, 62322, 27686, 27678, 62146, 62323, 27687, 27679, 62147, 71173, 27985, 70615, 71174, 71176, 27987, 70618, 
71177, 71175, 27988, 27971, 70617
25280, 62323, 27687, 27679, 62147, 26366, 3273, 3272, 26344, 71176, 27987, 70618, 71177, 27150, 3295, 27105, 
27149, 71178, 27989, 27972, 70620
25281, 24871, 24870, 24848, 24849, 62324, 62316, 62140, 62148, 25655, 25654, 25610, 25656, 71180, 71156, 70622, 
71181, 71179, 71154, 70596, 70621
25282, 62324, 62316, 62140, 62148, 62325, 62317, 62141, 62149, 71180, 71156, 70622, 71181, 71183, 71159, 70625, 
71184, 71182, 71157, 70599, 70624
25283, 62325, 62317, 62141, 62149, 62326, 62318, 62142, 62150, 71183, 71159, 70625, 71184, 71186, 71162, 70628, 
71187, 71185, 71160, 70602, 70627
25284, 62326, 62318, 62142, 62150, 62327, 62319, 62143, 62151, 71186, 71162, 70628, 71187, 71189, 71165, 70631, 
71190, 71188, 71163, 70605, 70630
25285, 62327, 62319, 62143, 62151, 62328, 62320, 62144, 62152, 71189, 71165, 70631, 71190, 71192, 71168, 70634, 
71193, 71191, 71166, 70608, 70633
25286, 62328, 62320, 62144, 62152, 62329, 62321, 62145, 62153, 71192, 71168, 70634, 71193, 71195, 71171, 70637, 
71196, 71194, 71169, 70611, 70636
25287, 62329, 62321, 62145, 62153, 62330, 62322, 62146, 62154, 71195, 71171, 70637, 71196, 71198, 71174, 70640, 
71199, 71197, 71172, 70614, 70639
25288, 62330, 62322, 62146, 62154, 62331, 62323, 62147, 62155, 71198, 71174, 70640, 71199, 71201, 71177, 70643, 
71202, 71200, 71175, 70617, 70642
25289, 62331, 62323, 62147, 62155, 26367, 26366, 26344, 26345, 71201, 71177, 70643, 71202, 27152, 27149, 27107, 
27151, 71203, 71178, 70620, 70645
25290, 24872, 24871, 24849, 24850, 62332, 62324, 62148, 62156, 25657, 25656, 25612, 25658, 71205, 71181, 70647, 
71206, 71204, 71179, 70621, 70646
25291, 62332, 62324, 62148, 62156, 62333, 62325, 62149, 62157, 71205, 71181, 70647, 71206, 71208, 71184, 70650, 
71209, 71207, 71182, 70624, 70649
25292, 62333, 62325, 62149, 62157, 62334, 62326, 62150, 62158, 71208, 71184, 70650, 71209, 71211, 71187, 70653, 
71212, 71210, 71185, 70627, 70652
25293, 62334, 62326, 62150, 62158, 62335, 62327, 62151, 62159, 71211, 71187, 70653, 71212, 71214, 71190, 70656, 
71215, 71213, 71188, 70630, 70655
25294, 62335, 62327, 62151, 62159, 62336, 62328, 62152, 62160, 71214, 71190, 70656, 71215, 71217, 71193, 70659, 
71218, 71216, 71191, 70633, 70658
25295, 62336, 62328, 62152, 62160, 62337, 62329, 62153, 62161, 71217, 71193, 70659, 71218, 71220, 71196, 70662, 
71221, 71219, 71194, 70636, 70661
25296, 62337, 62329, 62153, 62161, 62338, 62330, 62154, 62162, 71220, 71196, 70662, 71221, 71223, 71199, 70665, 
71224, 71222, 71197, 70639, 70664
25297, 62338, 62330, 62154, 62162, 62339, 62331, 62155, 62163, 71223, 71199, 70665, 71224, 71226, 71202, 70668, 
71227, 71225, 71200, 70642, 70667
25298, 62339, 62331, 62155, 62163, 26368, 26367, 26345, 26346, 71226, 71202, 70668, 71227, 27154, 27151, 27109, 
27153, 71228, 71203, 70645, 70670
25299, 24873, 24872, 24850, 24851, 62340, 62332, 62156, 62164, 25659, 25658, 25614, 25660, 71230, 71206, 70672, 
71231, 71229, 71204, 70646, 70671
25300, 62340, 62332, 62156, 62164, 62341, 62333, 62157, 62165, 71230, 71206, 70672, 71231, 71233, 71209, 70675, 
71234, 71232, 71207, 70649, 70674
25301, 62341, 62333, 62157, 62165, 62342, 62334, 62158, 62166, 71233, 71209, 70675, 71234, 71236, 71212, 70678, 
71237, 71235, 71210, 70652, 70677
25302, 62342, 62334, 62158, 62166, 62343, 62335, 62159, 62167, 71236, 71212, 70678, 71237, 71239, 71215, 70681, 
71240, 71238, 71213, 70655, 70680
25303, 62343, 62335, 62159, 62167, 62344, 62336, 62160, 62168, 71239, 71215, 70681, 71240, 71242, 71218, 70684, 
71243, 71241, 71216, 70658, 70683
25304, 62344, 62336, 62160, 62168, 62345, 62337, 62161, 62169, 71242, 71218, 70684, 71243, 71245, 71221, 70687, 
71246, 71244, 71219, 70661, 70686
25305, 62345, 62337, 62161, 62169, 62346, 62338, 62162, 62170, 71245, 71221, 70687, 71246, 71248, 71224, 70690, 
71249, 71247, 71222, 70664, 70689
25306, 62346, 62338, 62162, 62170, 62347, 62339, 62163, 62171, 71248, 71224, 70690, 71249, 71251, 71227, 70693, 
71252, 71250, 71225, 70667, 70692
25307, 62347, 62339, 62163, 62171, 26369, 26368, 26346, 26347, 71251, 71227, 70693, 71252, 27156, 27153, 27111, 
27155, 71253, 71228, 70670, 70695
25308, 24874, 24873, 24851, 24852, 62348, 62340, 62164, 62172, 25661, 25660, 25616, 25662, 71255, 71231, 70697, 
71256, 71254, 71229, 70671, 70696
25309, 62348, 62340, 62164, 62172, 62349, 62341, 62165, 62173, 71255, 71231, 70697, 71256, 71258, 71234, 70700, 
71259, 71257, 71232, 70674, 70699
25310, 62349, 62341, 62165, 62173, 62350, 62342, 62166, 62174, 71258, 71234, 70700, 71259, 71261, 71237, 70703, 
71262, 71260, 71235, 70677, 70702
25311, 62350, 62342, 62166, 62174, 62351, 62343, 62167, 62175, 71261, 71237, 70703, 71262, 71264, 71240, 70706, 
71265, 71263, 71238, 70680, 70705
25312, 62351, 62343, 62167, 62175, 62352, 62344, 62168, 62176, 71264, 71240, 70706, 71265, 71267, 71243, 70709, 
71268, 71266, 71241, 70683, 70708
25313, 62352, 62344, 62168, 62176, 62353, 62345, 62169, 62177, 71267, 71243, 70709, 71268, 71270, 71246, 70712, 
71271, 71269, 71244, 70686, 70711
25314, 62353, 62345, 62169, 62177, 62354, 62346, 62170, 62178, 71270, 71246, 70712, 71271, 71273, 71249, 70715, 
71274, 71272, 71247, 70689, 70714
25315, 62354, 62346, 62170, 62178, 62355, 62347, 62171, 62179, 71273, 71249, 70715, 71274, 71276, 71252, 70718, 
71277, 71275, 71250, 70692, 70717
25316, 62355, 62347, 62171, 62179, 26370, 26369, 26347, 26348, 71276, 71252, 70718, 71277, 27158, 27155, 27113, 
27157, 71278, 71253, 70695, 70720
25317, 24875, 24874, 24852, 24853, 62356, 62348, 62172, 62180, 25663, 25662, 25618, 25664, 71280, 71256, 70722, 
71281, 71279, 71254, 70696, 70721
25318, 62356, 62348, 62172, 62180, 62357, 62349, 62173, 62181, 71280, 71256, 70722, 71281, 71283, 71259, 70725, 
71284, 71282, 71257, 70699, 70724
25319, 62357, 62349, 62173, 62181, 62358, 62350, 62174, 62182, 71283, 71259, 70725, 71284, 71286, 71262, 70728, 
71287, 71285, 71260, 70702, 70727
25320, 62358, 62350, 62174, 62182, 62359, 62351, 62175, 62183, 71286, 71262, 70728, 71287, 71289, 71265, 70731, 
71290, 71288, 71263, 70705, 70730
25321, 62359, 62351, 62175, 62183, 62360, 62352, 62176, 62184, 71289, 71265, 70731, 71290, 71292, 71268, 70734, 
71293, 71291, 71266, 70708, 70733
25322, 62360, 62352, 62176, 62184, 62361, 62353, 62177, 62185, 71292, 71268, 70734, 71293, 71295, 71271, 70737, 
71296, 71294, 71269, 70711, 70736
25323, 62361, 62353, 62177, 62185, 62362, 62354, 62178, 62186, 71295, 71271, 70737, 71296, 71298, 71274, 70740, 
71299, 71297, 71272, 70714, 70739
25324, 62362, 62354, 62178, 62186, 62363, 62355, 62179, 62187, 71298, 71274, 70740, 71299, 71301, 71277, 70743, 
71302, 71300, 71275, 70717, 70742
25325, 62363, 62355, 62179, 62187, 26371, 26370, 26348, 26349, 71301, 71277, 70743, 71302, 27160, 27157, 27115, 
27159, 71303, 71278, 70720, 70745
25326, 24876, 24875, 24853, 24854, 62364, 62356, 62180, 62188, 25665, 25664, 25620, 25666, 71305, 71281, 70747, 
71306, 71304, 71279, 70721, 70746
25327, 62364, 62356, 62180, 62188, 62365, 62357, 62181, 62189, 71305, 71281, 70747, 71306, 71308, 71284, 70750, 
71309, 71307, 71282, 70724, 70749
25328, 62365, 62357, 62181, 62189, 62366, 62358, 62182, 62190, 71308, 71284, 70750, 71309, 71311, 71287, 70753, 
71312, 71310, 71285, 70727, 70752
25329, 62366, 62358, 62182, 62190, 62367, 62359, 62183, 62191, 71311, 71287, 70753, 71312, 71314, 71290, 70756, 
71315, 71313, 71288, 70730, 70755
25330, 62367, 62359, 62183, 62191, 62368, 62360, 62184, 62192, 71314, 71290, 70756, 71315, 71317, 71293, 70759, 
71318, 71316, 71291, 70733, 70758
25331, 62368, 62360, 62184, 62192, 62369, 62361, 62185, 62193, 71317, 71293, 70759, 71318, 71320, 71296, 70762, 
71321, 71319, 71294, 70736, 70761
25332, 62369, 62361, 62185, 62193, 62370, 62362, 62186, 62194, 71320, 71296, 70762, 71321, 71323, 71299, 70765, 
71324, 71322, 71297, 70739, 70764
25333, 62370, 62362, 62186, 62194, 62371, 62363, 62187, 62195, 71323, 71299, 70765, 71324, 71326, 71302, 70768, 
71327, 71325, 71300, 70742, 70767
25334, 62371, 62363, 62187, 62195, 26372, 26371, 26349, 26350, 71326, 71302, 70768, 71327, 27162, 27159, 27117, 
27161, 71328, 71303, 70745, 70770
25335, 24877, 24876, 24854, 24855, 62372, 62364, 62188, 62196, 25667, 25666, 25622, 25668, 71330, 71306, 70772, 
71331, 71329, 71304, 70746, 70771
25336, 62372, 62364, 62188, 62196, 62373, 62365, 62189, 62197, 71330, 71306, 70772, 71331, 71333, 71309, 70775, 
71334, 71332, 71307, 70749, 70774
25337, 62373, 62365, 62189, 62197, 62374, 62366, 62190, 62198, 71333, 71309, 70775, 71334, 71336, 71312, 70778, 
71337, 71335, 71310, 70752, 70777
25338, 62374, 62366, 62190, 62198, 62375, 62367, 62191, 62199, 71336, 71312, 70778, 71337, 71339, 71315, 70781, 
71340, 71338, 71313, 70755, 70780
25339, 62375, 62367, 62191, 62199, 62376, 62368, 62192, 62200, 71339, 71315, 70781, 71340, 71342, 71318, 70784, 
71343, 71341, 71316, 70758, 70783
25340, 62376, 62368, 62192, 62200, 62377, 62369, 62193, 62201, 71342, 71318, 70784, 71343, 71345, 71321, 70787, 
71346, 71344, 71319, 70761, 70786
25341, 62377, 62369, 62193, 62201, 62378, 62370, 62194, 62202, 71345, 71321, 70787, 71346, 71348, 71324, 70790, 
71349, 71347, 71322, 70764, 70789
25342, 62378, 62370, 62194, 62202, 62379, 62371, 62195, 62203, 71348, 71324, 70790, 71349, 71351, 71327, 70793, 
71352, 71350, 71325, 70767, 70792
25343, 62379, 62371, 62195, 62203, 26373, 26372, 26350, 26351, 71351, 71327, 70793, 71352, 27164, 27161, 27119, 
27163, 71353, 71328, 70770, 70795
25344, 24878, 24877, 24855, 24856, 62380, 62372, 62196, 62204, 25669, 25668, 25624, 25670, 71355, 71331, 70797, 
71356, 71354, 71329, 70771, 70796
25345, 62380, 62372, 62196, 62204, 62381, 62373, 62197, 62205, 71355, 71331, 70797, 71356, 71358, 71334, 70800, 
71359, 71357, 71332, 70774, 70799
25346, 62381, 62373, 62197, 62205, 62382, 62374, 62198, 62206, 71358, 71334, 70800, 71359, 71361, 71337, 70803, 
71362, 71360, 71335, 70777, 70802
25347, 62382, 62374, 62198, 62206, 62383, 62375, 62199, 62207, 71361, 71337, 70803, 71362, 71364, 71340, 70806, 
71365, 71363, 71338, 70780, 70805
25348, 62383, 62375, 62199, 62207, 62384, 62376, 62200, 62208, 71364, 71340, 70806, 71365, 71367, 71343, 70809, 
71368, 71366, 71341, 70783, 70808
25349, 62384, 62376, 62200, 62208, 62385, 62377, 62201, 62209, 71367, 71343, 70809, 71368, 71370, 71346, 70812, 
71371, 71369, 71344, 70786, 70811
25350, 62385, 62377, 62201, 62209, 62386, 62378, 62202, 62210, 71370, 71346, 70812, 71371, 71373, 71349, 70815, 
71374, 71372, 71347, 70789, 70814
25351, 62386, 62378, 62202, 62210, 62387, 62379, 62203, 62211, 71373, 71349, 70815, 71374, 71376, 71352, 70818, 
71377, 71375, 71350, 70792, 70817
25352, 62387, 62379, 62203, 62211, 26374, 26373, 26351, 26352, 71376, 71352, 70818, 71377, 27166, 27163, 27121, 
27165, 71378, 71353, 70795, 70820
25353, 24879, 24878, 24856, 24857, 62388, 62380, 62204, 62212, 25671, 25670, 25626, 25672, 71380, 71356, 70822, 
71381, 71379, 71354, 70796, 70821
25354, 62388, 62380, 62204, 62212, 62389, 62381, 62205, 62213, 71380, 71356, 70822, 71381, 71383, 71359, 70825, 
71384, 71382, 71357, 70799, 70824
25355, 62389, 62381, 62205, 62213, 62390, 62382, 62206, 62214, 71383, 71359, 70825, 71384, 71386, 71362, 70828, 
71387, 71385, 71360, 70802, 70827
25356, 62390, 62382, 62206, 62214, 62391, 62383, 62207, 62215, 71386, 71362, 70828, 71387, 71389, 71365, 70831, 
71390, 71388, 71363, 70805, 70830
25357, 62391, 62383, 62207, 62215, 62392, 62384, 62208, 62216, 71389, 71365, 70831, 71390, 71392, 71368, 70834, 
71393, 71391, 71366, 70808, 70833
25358, 62392, 62384, 62208, 62216, 62393, 62385, 62209, 62217, 71392, 71368, 70834, 71393, 71395, 71371, 70837, 
71396, 71394, 71369, 70811, 70836
25359, 62393, 62385, 62209, 62217, 62394, 62386, 62210, 62218, 71395, 71371, 70837, 71396, 71398, 71374, 70840, 
71399, 71397, 71372, 70814, 70839
25360, 62394, 62386, 62210, 62218, 62395, 62387, 62211, 62219, 71398, 71374, 70840, 71399, 71401, 71377, 70843, 
71402, 71400, 71375, 70817, 70842
25361, 62395, 62387, 62211, 62219, 26375, 26374, 26352, 26353, 71401, 71377, 70843, 71402, 27168, 27165, 27123, 
27167, 71403, 71378, 70820, 70845
25362, 24880, 24879, 24857, 24858, 62396, 62388, 62212, 62220, 25673, 25672, 25628, 25674, 71405, 71381, 70847, 
71406, 71404, 71379, 70821, 70846
25363, 62396, 62388, 62212, 62220, 62397, 62389, 62213, 62221, 71405, 71381, 70847, 71406, 71408, 71384, 70850, 
71409, 71407, 71382, 70824, 70849
25364, 62397, 62389, 62213, 62221, 62398, 62390, 62214, 62222, 71408, 71384, 70850, 71409, 71411, 71387, 70853, 
71412, 71410, 71385, 70827, 70852
25365, 62398, 62390, 62214, 62222, 62399, 62391, 62215, 62223, 71411, 71387, 70853, 71412, 71414, 71390, 70856, 
71415, 71413, 71388, 70830, 70855
25366, 62399, 62391, 62215, 62223, 62400, 62392, 62216, 62224, 71414, 71390, 70856, 71415, 71417, 71393, 70859, 
71418, 71416, 71391, 70833, 70858
25367, 62400, 62392, 62216, 62224, 62401, 62393, 62217, 62225, 71417, 71393, 70859, 71418, 71420, 71396, 70862, 
71421, 71419, 71394, 70836, 70861
25368, 62401, 62393, 62217, 62225, 62402, 62394, 62218, 62226, 71420, 71396, 70862, 71421, 71423, 71399, 70865, 
71424, 71422, 71397, 70839, 70864
25369, 62402, 62394, 62218, 62226, 62403, 62395, 62219, 62227, 71423, 71399, 70865, 71424, 71426, 71402, 70868, 
71427, 71425, 71400, 70842, 70867
25370, 62403, 62395, 62219, 62227, 26376, 26375, 26353, 26354, 71426, 71402, 70868, 71427, 27170, 27167, 27125, 
27169, 71428, 71403, 70845, 70870
25371, 24881, 24880, 24858, 24859, 62404, 62396, 62220, 62228, 25675, 25674, 25630, 25676, 71430, 71406, 70872, 
71431, 71429, 71404, 70846, 70871
25372, 62404, 62396, 62220, 62228, 62405, 62397, 62221, 62229, 71430, 71406, 70872, 71431, 71433, 71409, 70875, 
71434, 71432, 71407, 70849, 70874
25373, 62405, 62397, 62221, 62229, 62406, 62398, 62222, 62230, 71433, 71409, 70875, 71434, 71436, 71412, 70878, 
71437, 71435, 71410, 70852, 70877
25374, 62406, 62398, 62222, 62230, 62407, 62399, 62223, 62231, 71436, 71412, 70878, 71437, 71439, 71415, 70881, 
71440, 71438, 71413, 70855, 70880
25375, 62407, 62399, 62223, 62231, 62408, 62400, 62224, 62232, 71439, 71415, 70881, 71440, 71442, 71418, 70884, 
71443, 71441, 71416, 70858, 70883
25376, 62408, 62400, 62224, 62232, 62409, 62401, 62225, 62233, 71442, 71418, 70884, 71443, 71445, 71421, 70887, 
71446, 71444, 71419, 70861, 70886
25377, 62409, 62401, 62225, 62233, 62410, 62402, 62226, 62234, 71445, 71421, 70887, 71446, 71448, 71424, 70890, 
71449, 71447, 71422, 70864, 70889
25378, 62410, 62402, 62226, 62234, 62411, 62403, 62227, 62235, 71448, 71424, 70890, 71449, 71451, 71427, 70893, 
71452, 71450, 71425, 70867, 70892
25379, 62411, 62403, 62227, 62235, 26377, 26376, 26354, 26355, 71451, 71427, 70893, 71452, 27172, 27169, 27127, 
27171, 71453, 71428, 70870, 70895
25380, 24882, 24881, 24859, 24860, 62412, 62404, 62228, 62236, 25677, 25676, 25632, 25678, 71455, 71431, 70897, 
71456, 71454, 71429, 70871, 70896
25381, 62412, 62404, 62228, 62236, 62413, 62405, 62229, 62237, 71455, 71431, 70897, 71456, 71458, 71434, 70900, 
71459, 71457, 71432, 70874, 70899
25382, 62413, 62405, 62229, 62237, 62414, 62406, 62230, 62238, 71458, 71434, 70900, 71459, 71461, 71437, 70903, 
71462, 71460, 71435, 70877, 70902
25383, 62414, 62406, 62230, 62238, 62415, 62407, 62231, 62239, 71461, 71437, 70903, 71462, 71464, 71440, 70906, 
71465, 71463, 71438, 70880, 70905
25384, 62415, 62407, 62231, 62239, 62416, 62408, 62232, 62240, 71464, 71440, 70906, 71465, 71467, 71443, 70909, 
71468, 71466, 71441, 70883, 70908
25385, 62416, 62408, 62232, 62240, 62417, 62409, 62233, 62241, 71467, 71443, 70909, 71468, 71470, 71446, 70912, 
71471, 71469, 71444, 70886, 70911
25386, 62417, 62409, 62233, 62241, 62418, 62410, 62234, 62242, 71470, 71446, 70912, 71471, 71473, 71449, 70915, 
71474, 71472, 71447, 70889, 70914
25387, 62418, 62410, 62234, 62242, 62419, 62411, 62235, 62243, 71473, 71449, 70915, 71474, 71476, 71452, 70918, 
71477, 71475, 71450, 70892, 70917
25388, 62419, 62411, 62235, 62243, 26378, 26377, 26355, 26356, 71476, 71452, 70918, 71477, 27174, 27171, 27129, 
27173, 71478, 71453, 70895, 70920
25389, 24883, 24882, 24860, 24861, 62420, 62412, 62236, 62244, 25679, 25678, 25634, 25680, 71480, 71456, 70922, 
71481, 71479, 71454, 70896, 70921
25390, 62420, 62412, 62236, 62244, 62421, 62413, 62237, 62245, 71480, 71456, 70922, 71481, 71483, 71459, 70925, 
71484, 71482, 71457, 70899, 70924
25391, 62421, 62413, 62237, 62245, 62422, 62414, 62238, 62246, 71483, 71459, 70925, 71484, 71486, 71462, 70928, 
71487, 71485, 71460, 70902, 70927
25392, 62422, 62414, 62238, 62246, 62423, 62415, 62239, 62247, 71486, 71462, 70928, 71487, 71489, 71465, 70931, 
71490, 71488, 71463, 70905, 70930
25393, 62423, 62415, 62239, 62247, 62424, 62416, 62240, 62248, 71489, 71465, 70931, 71490, 71492, 71468, 70934, 
71493, 71491, 71466, 70908, 70933
25394, 62424, 62416, 62240, 62248, 62425, 62417, 62241, 62249, 71492, 71468, 70934, 71493, 71495, 71471, 70937, 
71496, 71494, 71469, 70911, 70936
25395, 62425, 62417, 62241, 62249, 62426, 62418, 62242, 62250, 71495, 71471, 70937, 71496, 71498, 71474, 70940, 
71499, 71497, 71472, 70914, 70939
25396, 62426, 62418, 62242, 62250, 62427, 62419, 62243, 62251, 71498, 71474, 70940, 71499, 71501, 71477, 70943, 
71502, 71500, 71475, 70917, 70942
25397, 62427, 62419, 62243, 62251, 26379, 26378, 26356, 26357, 71501, 71477, 70943, 71502, 27176, 27173, 27131, 
27175, 71503, 71478, 70920, 70945
25398, 24884, 24883, 24861, 24862, 62428, 62420, 62244, 62252, 25681, 25680, 25636, 25682, 71505, 71481, 70947, 
71506, 71504, 71479, 70921, 70946
25399, 62428, 62420, 62244, 62252, 62429, 62421, 62245, 62253, 71505, 71481, 70947, 71506, 71508, 71484, 70950, 
71509, 71507, 71482, 70924, 70949
25400, 62429, 62421, 62245, 62253, 62430, 62422, 62246, 62254, 71508, 71484, 70950, 71509, 71511, 71487, 70953, 
71512, 71510, 71485, 70927, 70952
25401, 62430, 62422, 62246, 62254, 62431, 62423, 62247, 62255, 71511, 71487, 70953, 71512, 71514, 71490, 70956, 
71515, 71513, 71488, 70930, 70955
25402, 62431, 62423, 62247, 62255, 62432, 62424, 62248, 62256, 71514, 71490, 70956, 71515, 71517, 71493, 70959, 
71518, 71516, 71491, 70933, 70958
25403, 62432, 62424, 62248, 62256, 62433, 62425, 62249, 62257, 71517, 71493, 70959, 71518, 71520, 71496, 70962, 
71521, 71519, 71494, 70936, 70961
25404, 62433, 62425, 62249, 62257, 62434, 62426, 62250, 62258, 71520, 71496, 70962, 71521, 71523, 71499, 70965, 
71524, 71522, 71497, 70939, 70964
25405, 62434, 62426, 62250, 62258, 62435, 62427, 62251, 62259, 71523, 71499, 70965, 71524, 71526, 71502, 70968, 
71527, 71525, 71500, 70942, 70967
25406, 62435, 62427, 62251, 62259, 26380, 26379, 26357, 26358, 71526, 71502, 70968, 71527, 27178, 27175, 27133, 
27177, 71528, 71503, 70945, 70970
25407, 24885, 24884, 24862, 24863, 62436, 62428, 62252, 62260, 25683, 25682, 25638, 25684, 71530, 71506, 70972, 
71531, 71529, 71504, 70946, 70971
25408, 62436, 62428, 62252, 62260, 62437, 62429, 62253, 62261, 71530, 71506, 70972, 71531, 71533, 71509, 70975, 
71534, 71532, 71507, 70949, 70974
25409, 62437, 62429, 62253, 62261, 62438, 62430, 62254, 62262, 71533, 71509, 70975, 71534, 71536, 71512, 70978, 
71537, 71535, 71510, 70952, 70977
25410, 62438, 62430, 62254, 62262, 62439, 62431, 62255, 62263, 71536, 71512, 70978, 71537, 71539, 71515, 70981, 
71540, 71538, 71513, 70955, 70980
25411, 62439, 62431, 62255, 62263, 62440, 62432, 62256, 62264, 71539, 71515, 70981, 71540, 71542, 71518, 70984, 
71543, 71541, 71516, 70958, 70983
25412, 62440, 62432, 62256, 62264, 62441, 62433, 62257, 62265, 71542, 71518, 70984, 71543, 71545, 71521, 70987, 
71546, 71544, 71519, 70961, 70986
25413, 62441, 62433, 62257, 62265, 62442, 62434, 62258, 62266, 71545, 71521, 70987, 71546, 71548, 71524, 70990, 
71549, 71547, 71522, 70964, 70989
25414, 62442, 62434, 62258, 62266, 62443, 62435, 62259, 62267, 71548, 71524, 70990, 71549, 71551, 71527, 70993, 
71552, 71550, 71525, 70967, 70992
25415, 62443, 62435, 62259, 62267, 26381, 26380, 26358, 26359, 71551, 71527, 70993, 71552, 27180, 27177, 27135, 
27179, 71553, 71528, 70970, 70995
25416, 24886, 24885, 24863, 24864, 62444, 62436, 62260, 62268, 25685, 25684, 25640, 25686, 71555, 71531, 70997, 
71556, 71554, 71529, 70971, 70996
25417, 62444, 62436, 62260, 62268, 62445, 62437, 62261, 62269, 71555, 71531, 70997, 71556, 71558, 71534, 71000, 
71559, 71557, 71532, 70974, 70999
25418, 62445, 62437, 62261, 62269, 62446, 62438, 62262, 62270, 71558, 71534, 71000, 71559, 71561, 71537, 71003, 
71562, 71560, 71535, 70977, 71002
25419, 62446, 62438, 62262, 62270, 62447, 62439, 62263, 62271, 71561, 71537, 71003, 71562, 71564, 71540, 71006, 
71565, 71563, 71538, 70980, 71005
25420, 62447, 62439, 62263, 62271, 62448, 62440, 62264, 62272, 71564, 71540, 71006, 71565, 71567, 71543, 71009, 
71568, 71566, 71541, 70983, 71008
25421, 62448, 62440, 62264, 62272, 62449, 62441, 62265, 62273, 71567, 71543, 71009, 71568, 71570, 71546, 71012, 
71571, 71569, 71544, 70986, 71011
25422, 62449, 62441, 62265, 62273, 62450, 62442, 62266, 62274, 71570, 71546, 71012, 71571, 71573, 71549, 71015, 
71574, 71572, 71547, 70989, 71014
25423, 62450, 62442, 62266, 62274, 62451, 62443, 62267, 62275, 71573, 71549, 71015, 71574, 71576, 71552, 71018, 
71577, 71575, 71550, 70992, 71017
25424, 62451, 62443, 62267, 62275, 26382, 26381, 26359, 26360, 71576, 71552, 71018, 71577, 27182, 27179, 27137, 
27181, 71578, 71553, 70995, 71020
25425, 24887, 24886, 24864, 24865, 62452, 62444, 62268, 62276, 25687, 25686, 25642, 25688, 71580, 71556, 71022, 
71581, 71579, 71554, 70996, 71021
25426, 62452, 62444, 62268, 62276, 62453, 62445, 62269, 62277, 71580, 71556, 71022, 71581, 71583, 71559, 71025, 
71584, 71582, 71557, 70999, 71024
25427, 62453, 62445, 62269, 62277, 62454, 62446, 62270, 62278, 71583, 71559, 71025, 71584, 71586, 71562, 71028, 
71587, 71585, 71560, 71002, 71027
25428, 62454, 62446, 62270, 62278, 62455, 62447, 62271, 62279, 71586, 71562, 71028, 71587, 71589, 71565, 71031, 
71590, 71588, 71563, 71005, 71030
25429, 62455, 62447, 62271, 62279, 62456, 62448, 62272, 62280, 71589, 71565, 71031, 71590, 71592, 71568, 71034, 
71593, 71591, 71566, 71008, 71033
25430, 62456, 62448, 62272, 62280, 62457, 62449, 62273, 62281, 71592, 71568, 71034, 71593, 71595, 71571, 71037, 
71596, 71594, 71569, 71011, 71036
25431, 62457, 62449, 62273, 62281, 62458, 62450, 62274, 62282, 71595, 71571, 71037, 71596, 71598, 71574, 71040, 
71599, 71597, 71572, 71014, 71039
25432, 62458, 62450, 62274, 62282, 62459, 62451, 62275, 62283, 71598, 71574, 71040, 71599, 71601, 71577, 71043, 
71602, 71600, 71575, 71017, 71042
25433, 62459, 62451, 62275, 62283, 26383, 26382, 26360, 26361, 71601, 71577, 71043, 71602, 27184, 27181, 27139, 
27183, 71603, 71578, 71020, 71045
25434, 24888, 24887, 24865, 24866, 62460, 62452, 62276, 62284, 25689, 25688, 25644, 25690, 71605, 71581, 71047, 
71606, 71604, 71579, 71021, 71046
25435, 62460, 62452, 62276, 62284, 62461, 62453, 62277, 62285, 71605, 71581, 71047, 71606, 71608, 71584, 71050, 
71609, 71607, 71582, 71024, 71049
25436, 62461, 62453, 62277, 62285, 62462, 62454, 62278, 62286, 71608, 71584, 71050, 71609, 71611, 71587, 71053, 
71612, 71610, 71585, 71027, 71052
25437, 62462, 62454, 62278, 62286, 62463, 62455, 62279, 62287, 71611, 71587, 71053, 71612, 71614, 71590, 71056, 
71615, 71613, 71588, 71030, 71055
25438, 62463, 62455, 62279, 62287, 62464, 62456, 62280, 62288, 71614, 71590, 71056, 71615, 71617, 71593, 71059, 
71618, 71616, 71591, 71033, 71058
25439, 62464, 62456, 62280, 62288, 62465, 62457, 62281, 62289, 71617, 71593, 71059, 71618, 71620, 71596, 71062, 
71621, 71619, 71594, 71036, 71061
25440, 62465, 62457, 62281, 62289, 62466, 62458, 62282, 62290, 71620, 71596, 71062, 71621, 71623, 71599, 71065, 
71624, 71622, 71597, 71039, 71064
25441, 62466, 62458, 62282, 62290, 62467, 62459, 62283, 62291, 71623, 71599, 71065, 71624, 71626, 71602, 71068, 
71627, 71625, 71600, 71042, 71067
25442, 62467, 62459, 62283, 62291, 26384, 26383, 26361, 26362, 71626, 71602, 71068, 71627, 27186, 27183, 27141, 
27185, 71628, 71603, 71045, 71070
25443, 24889, 24888, 24866, 24867, 62468, 62460, 62284, 62292, 25691, 25690, 25646, 25692, 71630, 71606, 71072, 
71631, 71629, 71604, 71046, 71071
25444, 62468, 62460, 62284, 62292, 62469, 62461, 62285, 62293, 71630, 71606, 71072, 71631, 71633, 71609, 71075, 
71634, 71632, 71607, 71049, 71074
25445, 62469, 62461, 62285, 62293, 62470, 62462, 62286, 62294, 71633, 71609, 71075, 71634, 71636, 71612, 71078, 
71637, 71635, 71610, 71052, 71077
25446, 62470, 62462, 62286, 62294, 62471, 62463, 62287, 62295, 71636, 71612, 71078, 71637, 71639, 71615, 71081, 
71640, 71638, 71613, 71055, 71080
25447, 62471, 62463, 62287, 62295, 62472, 62464, 62288, 62296, 71639, 71615, 71081, 71640, 71642, 71618, 71084, 
71643, 71641, 71616, 71058, 71083
25448, 62472, 62464, 62288, 62296, 62473, 62465, 62289, 62297, 71642, 71618, 71084, 71643, 71645, 71621, 71087, 
71646, 71644, 71619, 71061, 71086
25449, 62473, 62465, 62289, 62297, 62474, 62466, 62290, 62298, 71645, 71621, 71087, 71646, 71648, 71624, 71090, 
71649, 71647, 71622, 71064, 71089
25450, 62474, 62466, 62290, 62298, 62475, 62467, 62291, 62299, 71648, 71624, 71090, 71649, 71651, 71627, 71093, 
71652, 71650, 71625, 71067, 71092
25451, 62475, 62467, 62291, 62299, 26385, 26384, 26362, 26363, 71651, 71627, 71093, 71652, 27188, 27185, 27143, 
27187, 71653, 71628, 71070, 71095
25452, 24890, 24889, 24867, 24868, 62476, 62468, 62292, 62300, 25693, 25692, 25648, 25694, 71655, 71631, 71097, 
71656, 71654, 71629, 71071, 71096
25453, 62476, 62468, 62292, 62300, 62477, 62469, 62293, 62301, 71655, 71631, 71097, 71656, 71658, 71634, 71100, 
71659, 71657, 71632, 71074, 71099
25454, 62477, 62469, 62293, 62301, 62478, 62470, 62294, 62302, 71658, 71634, 71100, 71659, 71661, 71637, 71103, 
71662, 71660, 71635, 71077, 71102
25455, 62478, 62470, 62294, 62302, 62479, 62471, 62295, 62303, 71661, 71637, 71103, 71662, 71664, 71640, 71106, 
71665, 71663, 71638, 71080, 71105
25456, 62479, 62471, 62295, 62303, 62480, 62472, 62296, 62304, 71664, 71640, 71106, 71665, 71667, 71643, 71109, 
71668, 71666, 71641, 71083, 71108
25457, 62480, 62472, 62296, 62304, 62481, 62473, 62297, 62305, 71667, 71643, 71109, 71668, 71670, 71646, 71112, 
71671, 71669, 71644, 71086, 71111
25458, 62481, 62473, 62297, 62305, 62482, 62474, 62298, 62306, 71670, 71646, 71112, 71671, 71673, 71649, 71115, 
71674, 71672, 71647, 71089, 71114
25459, 62482, 62474, 62298, 62306, 62483, 62475, 62299, 62307, 71673, 71649, 71115, 71674, 71676, 71652, 71118, 
71677, 71675, 71650, 71092, 71117
25460, 62483, 62475, 62299, 62307, 26386, 26385, 26363, 26364, 71676, 71652, 71118, 71677, 27190, 27187, 27145, 
27189, 71678, 71653, 71095, 71120
25461, 24891, 24890, 24868, 24869, 62484, 62476, 62300, 62308, 25695, 25694, 25650, 25696, 71680, 71656, 71122, 
71681, 71679, 71654, 71096, 71121
25462, 62484, 62476, 62300, 62308, 62485, 62477, 62301, 62309, 71680, 71656, 71122, 71681, 71683, 71659, 71125, 
71684, 71682, 71657, 71099, 71124
25463, 62485, 62477, 62301, 62309, 62486, 62478, 62302, 62310, 71683, 71659, 71125, 71684, 71686, 71662, 71128, 
71687, 71685, 71660, 71102, 71127
25464, 62486, 62478, 62302, 62310, 62487, 62479, 62303, 62311, 71686, 71662, 71128, 71687, 71689, 71665, 71131, 
71690, 71688, 71663, 71105, 71130
25465, 62487, 62479, 62303, 62311, 62488, 62480, 62304, 62312, 71689, 71665, 71131, 71690, 71692, 71668, 71134, 
71693, 71691, 71666, 71108, 71133
25466, 62488, 62480, 62304, 62312, 62489, 62481, 62305, 62313, 71692, 71668, 71134, 71693, 71695, 71671, 71137, 
71696, 71694, 71669, 71111, 71136
25467, 62489, 62481, 62305, 62313, 62490, 62482, 62306, 62314, 71695, 71671, 71137, 71696, 71698, 71674, 71140, 
71699, 71697, 71672, 71114, 71139
25468, 62490, 62482, 62306, 62314, 62491, 62483, 62307, 62315, 71698, 71674, 71140, 71699, 71701, 71677, 71143, 
71702, 71700, 71675, 71117, 71142
25469, 62491, 62483, 62307, 62315, 26387, 26386, 26364, 26365, 71701, 71677, 71143, 71702, 27192, 27189, 27147, 
27191, 71703, 71678, 71120, 71145
25470, 3183, 24891, 24869, 3182, 28238, 62484, 62308, 28230, 25697, 25696, 25652, 3205, 71704, 71681, 71146, 
28532, 28531, 71679, 71121, 28514
25471, 28238, 62484, 62308, 28230, 28239, 62485, 62309, 28231, 71704, 71681, 71146, 28532, 71705, 71684, 71147, 
28534, 28533, 71682, 71124, 28516
25472, 28239, 62485, 62309, 28231, 28240, 62486, 62310, 28232, 71705, 71684, 71147, 28534, 71706, 71687, 71148, 
28536, 28535, 71685, 71127, 28518
25473, 28240, 62486, 62310, 28232, 28241, 62487, 62311, 28233, 71706, 71687, 71148, 28536, 71707, 71690, 71149, 
28538, 28537, 71688, 71130, 28520
25474, 28241, 62487, 62311, 28233, 28242, 62488, 62312, 28234, 71707, 71690, 71149, 28538, 71708, 71693, 71150, 
28540, 28539, 71691, 71133, 28522
25475, 28242, 62488, 62312, 28234, 28243, 62489, 62313, 28235, 71708, 71693, 71150, 28540, 71709, 71696, 71151, 
28542, 28541, 71694, 71136, 28524
25476, 28243, 62489, 62313, 28235, 28244, 62490, 62314, 28236, 71709, 71696, 71151, 28542, 71710, 71699, 71152, 
28544, 28543, 71697, 71139, 28526
25477, 28244, 62490, 62314, 28236, 28245, 62491, 62315, 28237, 71710, 71699, 71152, 28544, 71711, 71702, 71153, 
28546, 28545, 71700, 71142, 28528
25478, 28245, 62491, 62315, 28237, 3318, 26387, 26365, 3317, 71711, 71702, 71153, 28546, 27193, 27191, 27148, 
3340, 28547, 71703, 71145, 28530
25479, 24892, 3139, 3138, 24870, 62492, 27688, 27680, 62316, 25698, 3161, 25653, 25699, 71713, 27990, 71155, 
71714, 71712, 27991, 27974, 71154
25480, 62492, 27688, 27680, 62316, 62493, 27689, 27681, 62317, 71713, 27990, 71155, 71714, 71716, 27992, 71158, 
71717, 71715, 27993, 27976, 71157
25481, 62493, 27689, 27681, 62317, 62494, 27690, 27682, 62318, 71716, 27992, 71158, 71717, 71719, 27994, 71161, 
71720, 71718, 27995, 27978, 71160
25482, 62494, 27690, 27682, 62318, 62495, 27691, 27683, 62319, 71719, 27994, 71161, 71720, 71722, 27996, 71164, 
71723, 71721, 27997, 27980, 71163
25483, 62495, 27691, 27683, 62319, 62496, 27692, 27684, 62320, 71722, 27996, 71164, 71723, 71725, 27998, 71167, 
71726, 71724, 27999, 27982, 71166
25484, 62496, 27692, 27684, 62320, 62497, 27693, 27685, 62321, 71725, 27998, 71167, 71726, 71728, 28000, 71170, 
71729, 71727, 28001, 27984, 71169
25485, 62497, 27693, 27685, 62321, 62498, 27694, 27686, 62322, 71728, 28000, 71170, 71729, 71731, 28002, 71173, 
71732, 71730, 28003, 27986, 71172
25486, 62498, 27694, 27686, 62322, 62499, 27695, 27687, 62323, 71731, 28002, 71173, 71732, 71734, 28004, 71176, 
71735, 71733, 28005, 27988, 71175
25487, 62499, 27695, 27687, 62323, 26388, 3274, 3273, 26366, 71734, 28004, 71176, 71735, 27195, 3296, 27150, 
27194, 71736, 28006, 27989, 71178
25488, 24893, 24892, 24870, 24871, 62500, 62492, 62316, 62324, 25700, 25699, 25655, 25701, 71738, 71714, 71180, 
71739, 71737, 71712, 71154, 71179
25489, 62500, 62492, 62316, 62324, 62501, 62493, 62317, 62325, 71738, 71714, 71180, 71739, 71741, 71717, 71183, 
71742, 71740, 71715, 71157, 71182
25490, 62501, 62493, 62317, 62325, 62502, 62494, 62318, 62326, 71741, 71717, 71183, 71742, 71744, 71720, 71186, 
71745, 71743, 71718, 71160, 71185
25491, 62502, 62494, 62318, 62326, 62503, 62495, 62319, 62327, 71744, 71720, 71186, 71745, 71747, 71723, 71189, 
71748, 71746, 71721, 71163, 71188
25492, 62503, 62495, 62319, 62327, 62504, 62496, 62320, 62328, 71747, 71723, 71189, 71748, 71750, 71726, 71192, 
71751, 71749, 71724, 71166, 71191
25493, 62504, 62496, 62320, 62328, 62505, 62497, 62321, 62329, 71750, 71726, 71192, 71751, 71753, 71729, 71195, 
71754, 71752, 71727, 71169, 71194
25494, 62505, 62497, 62321, 62329, 62506, 62498, 62322, 62330, 71753, 71729, 71195, 71754, 71756, 71732, 71198, 
71757, 71755, 71730, 71172, 71197
25495, 62506, 62498, 62322, 62330, 62507, 62499, 62323, 62331, 71756, 71732, 71198, 71757, 71759, 71735, 71201, 
71760, 71758, 71733, 71175, 71200
25496, 62507, 62499, 62323, 62331, 26389, 26388, 26366, 26367, 71759, 71735, 71201, 71760, 27197, 27194, 27152, 
27196, 71761, 71736, 71178, 71203
25497, 24894, 24893, 24871, 24872, 62508, 62500, 62324, 62332, 25702, 25701, 25657, 25703, 71763, 71739, 71205, 
71764, 71762, 71737, 71179, 71204
25498, 62508, 62500, 62324, 62332, 62509, 62501, 62325, 62333, 71763, 71739, 71205, 71764, 71766, 71742, 71208, 
71767, 71765, 71740, 71182, 71207
25499, 62509, 62501, 62325, 62333, 62510, 62502, 62326, 62334, 71766, 71742, 71208, 71767, 71769, 71745, 71211, 
71770, 71768, 71743, 71185, 71210
25500, 62510, 62502, 62326, 62334, 62511, 62503, 62327, 62335, 71769, 71745, 71211, 71770, 71772, 71748, 71214, 
71773, 71771, 71746, 71188, 71213
25501, 62511, 62503, 62327, 62335, 62512, 62504, 62328, 62336, 71772, 71748, 71214, 71773, 71775, 71751, 71217, 
71776, 71774, 71749, 71191, 71216
25502, 62512, 62504, 62328, 62336, 62513, 62505, 62329, 62337, 71775, 71751, 71217, 71776, 71778, 71754, 71220, 
71779, 71777, 71752, 71194, 71219
25503, 62513, 62505, 62329, 62337, 62514, 62506, 62330, 62338, 71778, 71754, 71220, 71779, 71781, 71757, 71223, 
71782, 71780, 71755, 71197, 71222
25504, 62514, 62506, 62330, 62338, 62515, 62507, 62331, 62339, 71781, 71757, 71223, 71782, 71784, 71760, 71226, 
71785, 71783, 71758, 71200, 71225
25505, 62515, 62507, 62331, 62339, 26390, 26389, 26367, 26368, 71784, 71760, 71226, 71785, 27199, 27196, 27154, 
27198, 71786, 71761, 71203, 71228
25506, 24895, 24894, 24872, 24873, 62516, 62508, 62332, 62340, 25704, 25703, 25659, 25705, 71788, 71764, 71230, 
71789, 71787, 71762, 71204, 71229
25507, 62516, 62508, 62332, 62340, 62517, 62509, 62333, 62341, 71788, 71764, 71230, 71789, 71791, 71767, 71233, 
71792, 71790, 71765, 71207, 71232
25508, 62517, 62509, 62333, 62341, 62518, 62510, 62334, 62342, 71791, 71767, 71233, 71792, 71794, 71770, 71236, 
71795, 71793, 71768, 71210, 71235
25509, 62518, 62510, 62334, 62342, 62519, 62511, 62335, 62343, 71794, 71770, 71236, 71795, 71797, 71773, 71239, 
71798, 71796, 71771, 71213, 71238
25510, 62519, 62511, 62335, 62343, 62520, 62512, 62336, 62344, 71797, 71773, 71239, 71798, 71800, 71776, 71242, 
71801, 71799, 71774, 71216, 71241
25511, 62520, 62512, 62336, 62344, 62521, 62513, 62337, 62345, 71800, 71776, 71242, 71801, 71803, 71779, 71245, 
71804, 71802, 71777, 71219, 71244
25512, 62521, 62513, 62337, 62345, 62522, 62514, 62338, 62346, 71803, 71779, 71245, 71804, 71806, 71782, 71248, 
71807, 71805, 71780, 71222, 71247
25513, 62522, 62514, 62338, 62346, 62523, 62515, 62339, 62347, 71806, 71782, 71248, 71807, 71809, 71785, 71251, 
71810, 71808, 71783, 71225, 71250
25514, 62523, 62515, 62339, 62347, 26391, 26390, 26368, 26369, 71809, 71785, 71251, 71810, 27201, 27198, 27156, 
27200, 71811, 71786, 71228, 71253
25515, 24896, 24895, 24873, 24874, 62524, 62516, 62340, 62348, 25706, 25705, 25661, 25707, 71813, 71789, 71255, 
71814, 71812, 71787, 71229, 71254
25516, 62524, 62516, 62340, 62348, 62525, 62517, 62341, 62349, 71813, 71789, 71255, 71814, 71816, 71792, 71258, 
71817, 71815, 71790, 71232, 71257
25517, 62525, 62517, 62341, 62349, 62526, 62518, 62342, 62350, 71816, 71792, 71258, 71817, 71819, 71795, 71261, 
71820, 71818, 71793, 71235, 71260
25518, 62526, 62518, 62342, 62350, 62527, 62519, 62343, 62351, 71819, 71795, 71261, 71820, 71822, 71798, 71264, 
71823, 71821, 71796, 71238, 71263
25519, 62527, 62519, 62343, 62351, 62528, 62520, 62344, 62352, 71822, 71798, 71264, 71823, 71825, 71801, 71267, 
71826, 71824, 71799, 71241, 71266
25520, 62528, 62520, 62344, 62352, 62529, 62521, 62345, 62353, 71825, 71801, 71267, 71826, 71828, 71804, 71270, 
71829, 71827, 71802, 71244, 71269
25521, 62529, 62521, 62345, 62353, 62530, 62522, 62346, 62354, 71828, 71804, 71270, 71829, 71831, 71807, 71273, 
71832, 71830, 71805, 71247, 71272
25522, 62530, 62522, 62346, 62354, 62531, 62523, 62347, 62355, 71831, 71807, 71273, 71832, 71834, 71810, 71276, 
71835, 71833, 71808, 71250, 71275
25523, 62531, 62523, 62347, 62355, 26392, 26391, 26369, 26370, 71834, 71810, 71276, 71835, 27203, 27200, 27158, 
27202, 71836, 71811, 71253, 71278
25524, 24897, 24896, 24874, 24875, 62532, 62524, 62348, 62356, 25708, 25707, 25663, 25709, 71838, 71814, 71280, 
71839, 71837, 71812, 71254, 71279
25525, 62532, 62524, 62348, 62356, 62533, 62525, 62349, 62357, 71838, 71814, 71280, 71839, 71841, 71817, 71283, 
71842, 71840, 71815, 71257, 71282
25526, 62533, 62525, 62349, 62357, 62534, 62526, 62350, 62358, 71841, 71817, 71283, 71842, 71844, 71820, 71286, 
71845, 71843, 71818, 71260, 71285
25527, 62534, 62526, 62350, 62358, 62535, 62527, 62351, 62359, 71844, 71820, 71286, 71845, 71847, 71823, 71289, 
71848, 71846, 71821, 71263, 71288
25528, 62535, 62527, 62351, 62359, 62536, 62528, 62352, 62360, 71847, 71823, 71289, 71848, 71850, 71826, 71292, 
71851, 71849, 71824, 71266, 71291
25529, 62536, 62528, 62352, 62360, 62537, 62529, 62353, 62361, 71850, 71826, 71292, 71851, 71853, 71829, 71295, 
71854, 71852, 71827, 71269, 71294
25530, 62537, 62529, 62353, 62361, 62538, 62530, 62354, 62362, 71853, 71829, 71295, 71854, 71856, 71832, 71298, 
71857, 71855, 71830, 71272, 71297
25531, 62538, 62530, 62354, 62362, 62539, 62531, 62355, 62363, 71856, 71832, 71298, 71857, 71859, 71835, 71301, 
71860, 71858, 71833, 71275, 71300
25532, 62539, 62531, 62355, 62363, 26393, 26392, 26370, 26371, 71859, 71835, 71301, 71860, 27205, 27202, 27160, 
27204, 71861, 71836, 71278, 71303
25533, 24898, 24897, 24875, 24876, 62540, 62532, 62356, 62364, 25710, 25709, 25665, 25711, 71863, 71839, 71305, 
71864, 71862, 71837, 71279, 71304
25534, 62540, 62532, 62356, 62364, 62541, 62533, 62357, 62365, 71863, 71839, 71305, 71864, 71866, 71842, 71308, 
71867, 71865, 71840, 71282, 71307
25535, 62541, 62533, 62357, 62365, 62542, 62534, 62358, 62366, 71866, 71842, 71308, 71867, 71869, 71845, 71311, 
71870, 71868, 71843, 71285, 71310
25536, 62542, 62534, 62358, 62366, 62543, 62535, 62359, 62367, 71869, 71845, 71311, 71870, 71872, 71848, 71314, 
71873, 71871, 71846, 71288, 71313
25537, 62543, 62535, 62359, 62367, 62544, 62536, 62360, 62368, 71872, 71848, 71314, 71873, 71875, 71851, 71317, 
71876, 71874, 71849, 71291, 71316
25538, 62544, 62536, 62360, 62368, 62545, 62537, 62361, 62369, 71875, 71851, 71317, 71876, 71878, 71854, 71320, 
71879, 71877, 71852, 71294, 71319
25539, 62545, 62537, 62361, 62369, 62546, 62538, 62362, 62370, 71878, 71854, 71320, 71879, 71881, 71857, 71323, 
71882, 71880, 71855, 71297, 71322
25540, 62546, 62538, 62362, 62370, 62547, 62539, 62363, 62371, 71881, 71857, 71323, 71882, 71884, 71860, 71326, 
71885, 71883, 71858, 71300, 71325
25541, 62547, 62539, 62363, 62371, 26394, 26393, 26371, 26372, 71884, 71860, 71326, 71885, 27207, 27204, 27162, 
27206, 71886, 71861, 71303, 71328
25542, 24899, 24898, 24876, 24877, 62548, 62540, 62364, 62372, 25712, 25711, 25667, 25713, 71888, 71864, 71330, 
71889, 71887, 71862, 71304, 71329
25543, 62548, 62540, 62364, 62372, 62549, 62541, 62365, 62373, 71888, 71864, 71330, 71889, 71891, 71867, 71333, 
71892, 71890, 71865, 71307, 71332
25544, 62549, 62541, 62365, 62373, 62550, 62542, 62366, 62374, 71891, 71867, 71333, 71892, 71894, 71870, 71336, 
71895, 71893, 71868, 71310, 71335
25545, 62550, 62542, 62366, 62374, 62551, 62543, 62367, 62375, 71894, 71870, 71336, 71895, 71897, 71873, 71339, 
71898, 71896, 71871, 71313, 71338
25546, 62551, 62543, 62367, 62375, 62552, 62544, 62368, 62376, 71897, 71873, 71339, 71898, 71900, 71876, 71342, 
71901, 71899, 71874, 71316, 71341
25547, 62552, 62544, 62368, 62376, 62553, 62545, 62369, 62377, 71900, 71876, 71342, 71901, 71903, 71879, 71345, 
71904, 71902, 71877, 71319, 71344
25548, 62553, 62545, 62369, 62377, 62554, 62546, 62370, 62378, 71903, 71879, 71345, 71904, 71906, 71882, 71348, 
71907, 71905, 71880, 71322, 71347
25549, 62554, 62546, 62370, 62378, 62555, 62547, 62371, 62379, 71906, 71882, 71348, 71907, 71909, 71885, 71351, 
71910, 71908, 71883, 71325, 71350
25550, 62555, 62547, 62371, 62379, 26395, 26394, 26372, 26373, 71909, 71885, 71351, 71910, 27209, 27206, 27164, 
27208, 71911, 71886, 71328, 71353
25551, 24900, 24899, 24877, 24878, 62556, 62548, 62372, 62380, 25714, 25713, 25669, 25715, 71913, 71889, 71355, 
71914, 71912, 71887, 71329, 71354
25552, 62556, 62548, 62372, 62380, 62557, 62549, 62373, 62381, 71913, 71889, 71355, 71914, 71916, 71892, 71358, 
71917, 71915, 71890, 71332, 71357
25553, 62557, 62549, 62373, 62381, 62558, 62550, 62374, 62382, 71916, 71892, 71358, 71917, 71919, 71895, 71361, 
71920, 71918, 71893, 71335, 71360
25554, 62558, 62550, 62374, 62382, 62559, 62551, 62375, 62383, 71919, 71895, 71361, 71920, 71922, 71898, 71364, 
71923, 71921, 71896, 71338, 71363
25555, 62559, 62551, 62375, 62383, 62560, 62552, 62376, 62384, 71922, 71898, 71364, 71923, 71925, 71901, 71367, 
71926, 71924, 71899, 71341, 71366
25556, 62560, 62552, 62376, 62384, 62561, 62553, 62377, 62385, 71925, 71901, 71367, 71926, 71928, 71904, 71370, 
71929, 71927, 71902, 71344, 71369
25557, 62561, 62553, 62377, 62385, 62562, 62554, 62378, 62386, 71928, 71904, 71370, 71929, 71931, 71907, 71373, 
71932, 71930, 71905, 71347, 71372
25558, 62562, 62554, 62378, 62386, 62563, 62555, 62379, 62387, 71931, 71907, 71373, 71932, 71934, 71910, 71376, 
71935, 71933, 71908, 71350, 71375
25559, 62563, 62555, 62379, 62387, 26396, 26395, 26373, 26374, 71934, 71910, 71376, 71935, 27211, 27208, 27166, 
27210, 71936, 71911, 71353, 71378
25560, 24901, 24900, 24878, 24879, 62564, 62556, 62380, 62388, 25716, 25715, 25671, 25717, 71938, 71914, 71380, 
71939, 71937, 71912, 71354, 71379
25561, 62564, 62556, 62380, 62388, 62565, 62557, 62381, 62389, 71938, 71914, 71380, 71939, 71941, 71917, 71383, 
71942, 71940, 71915, 71357, 71382
25562, 62565, 62557, 62381, 62389, 62566, 62558, 62382, 62390, 71941, 71917, 71383, 71942, 71944, 71920, 71386, 
71945, 71943, 71918, 71360, 71385
25563, 62566, 62558, 62382, 62390, 62567, 62559, 62383, 62391, 71944, 71920, 71386, 71945, 71947, 71923, 71389, 
71948, 71946, 71921, 71363, 71388
25564, 62567, 62559, 62383, 62391, 62568, 62560, 62384, 62392, 71947, 71923, 71389, 71948, 71950, 71926, 71392, 
71951, 71949, 71924, 71366, 71391
25565, 62568, 62560, 62384, 62392, 62569, 62561, 62385, 62393, 71950, 71926, 71392, 71951, 71953, 71929, 71395, 
71954, 71952, 71927, 71369, 71394
25566, 62569, 62561, 62385, 62393, 62570, 62562, 62386, 62394, 71953, 71929, 71395, 71954, 71956, 71932, 71398, 
71957, 71955, 71930, 71372, 71397
25567, 62570, 62562, 62386, 62394, 62571, 62563, 62387, 62395, 71956, 71932, 71398, 71957, 71959, 71935, 71401, 
71960, 71958, 71933, 71375, 71400
25568, 62571, 62563, 62387, 62395, 26397, 26396, 26374, 26375, 71959, 71935, 71401, 71960, 27213, 27210, 27168, 
27212, 71961, 71936, 71378, 71403
25569, 24902, 24901, 24879, 24880, 62572, 62564, 62388, 62396, 25718, 25717, 25673, 25719, 71963, 71939, 71405, 
71964, 71962, 71937, 71379, 71404
25570, 62572, 62564, 62388, 62396, 62573, 62565, 62389, 62397, 71963, 71939, 71405, 71964, 71966, 71942, 71408, 
71967, 71965, 71940, 71382, 71407
25571, 62573, 62565, 62389, 62397, 62574, 62566, 62390, 62398, 71966, 71942, 71408, 71967, 71969, 71945, 71411, 
71970, 71968, 71943, 71385, 71410
25572, 62574, 62566, 62390, 62398, 62575, 62567, 62391, 62399, 71969, 71945, 71411, 71970, 71972, 71948, 71414, 
71973, 71971, 71946, 71388, 71413
25573, 62575, 62567, 62391, 62399, 62576, 62568, 62392, 62400, 71972, 71948, 71414, 71973, 71975, 71951, 71417, 
71976, 71974, 71949, 71391, 71416
25574, 62576, 62568, 62392, 62400, 62577, 62569, 62393, 62401, 71975, 71951, 71417, 71976, 71978, 71954, 71420, 
71979, 71977, 71952, 71394, 71419
25575, 62577, 62569, 62393, 62401, 62578, 62570, 62394, 62402, 71978, 71954, 71420, 71979, 71981, 71957, 71423, 
71982, 71980, 71955, 71397, 71422
25576, 62578, 62570, 62394, 62402, 62579, 62571, 62395, 62403, 71981, 71957, 71423, 71982, 71984, 71960, 71426, 
71985, 71983, 71958, 71400, 71425
25577, 62579, 62571, 62395, 62403, 26398, 26397, 26375, 26376, 71984, 71960, 71426, 71985, 27215, 27212, 27170, 
27214, 71986, 71961, 71403, 71428
25578, 24903, 24902, 24880, 24881, 62580, 62572, 62396, 62404, 25720, 25719, 25675, 25721, 71988, 71964, 71430, 
71989, 71987, 71962, 71404, 71429
25579, 62580, 62572, 62396, 62404, 62581, 62573, 62397, 62405, 71988, 71964, 71430, 71989, 71991, 71967, 71433, 
71992, 71990, 71965, 71407, 71432
25580, 62581, 62573, 62397, 62405, 62582, 62574, 62398, 62406, 71991, 71967, 71433, 71992, 71994, 71970, 71436, 
71995, 71993, 71968, 71410, 71435
25581, 62582, 62574, 62398, 62406, 62583, 62575, 62399, 62407, 71994, 71970, 71436, 71995, 71997, 71973, 71439, 
71998, 71996, 71971, 71413, 71438
25582, 62583, 62575, 62399, 62407, 62584, 62576, 62400, 62408, 71997, 71973, 71439, 71998, 72000, 71976, 71442, 
72001, 71999, 71974, 71416, 71441
25583, 62584, 62576, 62400, 62408, 62585, 62577, 62401, 62409, 72000, 71976, 71442, 72001, 72003, 71979, 71445, 
72004, 72002, 71977, 71419, 71444
25584, 62585, 62577, 62401, 62409, 62586, 62578, 62402, 62410, 72003, 71979, 71445, 72004, 72006, 71982, 71448, 
72007, 72005, 71980, 71422, 71447
25585, 62586, 62578, 62402, 62410, 62587, 62579, 62403, 62411, 72006, 71982, 71448, 72007, 72009, 71985, 71451, 
72010, 72008, 71983, 71425, 71450
25586, 62587, 62579, 62403, 62411, 26399, 26398, 26376, 26377, 72009, 71985, 71451, 72010, 27217, 27214, 27172, 
27216, 72011, 71986, 71428, 71453
25587, 24904, 24903, 24881, 24882, 62588, 62580, 62404, 62412, 25722, 25721, 25677, 25723, 72013, 71989, 71455, 
72014, 72012, 71987, 71429, 71454
25588, 62588, 62580, 62404, 62412, 62589, 62581, 62405, 62413, 72013, 71989, 71455, 72014, 72016, 71992, 71458, 
72017, 72015, 71990, 71432, 71457
25589, 62589, 62581, 62405, 62413, 62590, 62582, 62406, 62414, 72016, 71992, 71458, 72017, 72019, 71995, 71461, 
72020, 72018, 71993, 71435, 71460
25590, 62590, 62582, 62406, 62414, 62591, 62583, 62407, 62415, 72019, 71995, 71461, 72020, 72022, 71998, 71464, 
72023, 72021, 71996, 71438, 71463
25591, 62591, 62583, 62407, 62415, 62592, 62584, 62408, 62416, 72022, 71998, 71464, 72023, 72025, 72001, 71467, 
72026, 72024, 71999, 71441, 71466
25592, 62592, 62584, 62408, 62416, 62593, 62585, 62409, 62417, 72025, 72001, 71467, 72026, 72028, 72004, 71470, 
72029, 72027, 72002, 71444, 71469
25593, 62593, 62585, 62409, 62417, 62594, 62586, 62410, 62418, 72028, 72004, 71470, 72029, 72031, 72007, 71473, 
72032, 72030, 72005, 71447, 71472
25594, 62594, 62586, 62410, 62418, 62595, 62587, 62411, 62419, 72031, 72007, 71473, 72032, 72034, 72010, 71476, 
72035, 72033, 72008, 71450, 71475
25595, 62595, 62587, 62411, 62419, 26400, 26399, 26377, 26378, 72034, 72010, 71476, 72035, 27219, 27216, 27174, 
27218, 72036, 72011, 71453, 71478
25596, 24905, 24904, 24882, 24883, 62596, 62588, 62412, 62420, 25724, 25723, 25679, 25725, 72038, 72014, 71480, 
72039, 72037, 72012, 71454, 71479
25597, 62596, 62588, 62412, 62420, 62597, 62589, 62413, 62421, 72038, 72014, 71480, 72039, 72041, 72017, 71483, 
72042, 72040, 72015, 71457, 71482
25598, 62597, 62589, 62413, 62421, 62598, 62590, 62414, 62422, 72041, 72017, 71483, 72042, 72044, 72020, 71486, 
72045, 72043, 72018, 71460, 71485
25599, 62598, 62590, 62414, 62422, 62599, 62591, 62415, 62423, 72044, 72020, 71486, 72045, 72047, 72023, 71489, 
72048, 72046, 72021, 71463, 71488
25600, 62599, 62591, 62415, 62423, 62600, 62592, 62416, 62424, 72047, 72023, 71489, 72048, 72050, 72026, 71492, 
72051, 72049, 72024, 71466, 71491
25601, 62600, 62592, 62416, 62424, 62601, 62593, 62417, 62425, 72050, 72026, 71492, 72051, 72053, 72029, 71495, 
72054, 72052, 72027, 71469, 71494
25602, 62601, 62593, 62417, 62425, 62602, 62594, 62418, 62426, 72053, 72029, 71495, 72054, 72056, 72032, 71498, 
72057, 72055, 72030, 71472, 71497
25603, 62602, 62594, 62418, 62426, 62603, 62595, 62419, 62427, 72056, 72032, 71498, 72057, 72059, 72035, 71501, 
72060, 72058, 72033, 71475, 71500
25604, 62603, 62595, 62419, 62427, 26401, 26400, 26378, 26379, 72059, 72035, 71501, 72060, 27221, 27218, 27176, 
27220, 72061, 72036, 71478, 71503
25605, 24906, 24905, 24883, 24884, 62604, 62596, 62420, 62428, 25726, 25725, 25681, 25727, 72063, 72039, 71505, 
72064, 72062, 72037, 71479, 71504
25606, 62604, 62596, 62420, 62428, 62605, 62597, 62421, 62429, 72063, 72039, 71505, 72064, 72066, 72042, 71508, 
72067, 72065, 72040, 71482, 71507
25607, 62605, 62597, 62421, 62429, 62606, 62598, 62422, 62430, 72066, 72042, 71508, 72067, 72069, 72045, 71511, 
72070, 72068, 72043, 71485, 71510
25608, 62606, 62598, 62422, 62430, 62607, 62599, 62423, 62431, 72069, 72045, 71511, 72070, 72072, 72048, 71514, 
72073, 72071, 72046, 71488, 71513
25609, 62607, 62599, 62423, 62431, 62608, 62600, 62424, 62432, 72072, 72048, 71514, 72073, 72075, 72051, 71517, 
72076, 72074, 72049, 71491, 71516
25610, 62608, 62600, 62424, 62432, 62609, 62601, 62425, 62433, 72075, 72051, 71517, 72076, 72078, 72054, 71520, 
72079, 72077, 72052, 71494, 71519
25611, 62609, 62601, 62425, 62433, 62610, 62602, 62426, 62434, 72078, 72054, 71520, 72079, 72081, 72057, 71523, 
72082, 72080, 72055, 71497, 71522
25612, 62610, 62602, 62426, 62434, 62611, 62603, 62427, 62435, 72081, 72057, 71523, 72082, 72084, 72060, 71526, 
72085, 72083, 72058, 71500, 71525
25613, 62611, 62603, 62427, 62435, 26402, 26401, 26379, 26380, 72084, 72060, 71526, 72085, 27223, 27220, 27178, 
27222, 72086, 72061, 71503, 71528
25614, 24907, 24906, 24884, 24885, 62612, 62604, 62428, 62436, 25728, 25727, 25683, 25729, 72088, 72064, 71530, 
72089, 72087, 72062, 71504, 71529
25615, 62612, 62604, 62428, 62436, 62613, 62605, 62429, 62437, 72088, 72064, 71530, 72089, 72091, 72067, 71533, 
72092, 72090, 72065, 71507, 71532
25616, 62613, 62605, 62429, 62437, 62614, 62606, 62430, 62438, 72091, 72067, 71533, 72092, 72094, 72070, 71536, 
72095, 72093, 72068, 71510, 71535
25617, 62614, 62606, 62430, 62438, 62615, 62607, 62431, 62439, 72094, 72070, 71536, 72095, 72097, 72073, 71539, 
72098, 72096, 72071, 71513, 71538
25618, 62615, 62607, 62431, 62439, 62616, 62608, 62432, 62440, 72097, 72073, 71539, 72098, 72100, 72076, 71542, 
72101, 72099, 72074, 71516, 71541
25619, 62616, 62608, 62432, 62440, 62617, 62609, 62433, 62441, 72100, 72076, 71542, 72101, 72103, 72079, 71545, 
72104, 72102, 72077, 71519, 71544
25620, 62617, 62609, 62433, 62441, 62618, 62610, 62434, 62442, 72103, 72079, 71545, 72104, 72106, 72082, 71548, 
72107, 72105, 72080, 71522, 71547
25621, 62618, 62610, 62434, 62442, 62619, 62611, 62435, 62443, 72106, 72082, 71548, 72107, 72109, 72085, 71551, 
72110, 72108, 72083, 71525, 71550
25622, 62619, 62611, 62435, 62443, 26403, 26402, 26380, 26381, 72109, 72085, 71551, 72110, 27225, 27222, 27180, 
27224, 72111, 72086, 71528, 71553
25623, 24908, 24907, 24885, 24886, 62620, 62612, 62436, 62444, 25730, 25729, 25685, 25731, 72113, 72089, 71555, 
72114, 72112, 72087, 71529, 71554
25624, 62620, 62612, 62436, 62444, 62621, 62613, 62437, 62445, 72113, 72089, 71555, 72114, 72116, 72092, 71558, 
72117, 72115, 72090, 71532, 71557
25625, 62621, 62613, 62437, 62445, 62622, 62614, 62438, 62446, 72116, 72092, 71558, 72117, 72119, 72095, 71561, 
72120, 72118, 72093, 71535, 71560
25626, 62622, 62614, 62438, 62446, 62623, 62615, 62439, 62447, 72119, 72095, 71561, 72120, 72122, 72098, 71564, 
72123, 72121, 72096, 71538, 71563
25627, 62623, 62615, 62439, 62447, 62624, 62616, 62440, 62448, 72122, 72098, 71564, 72123, 72125, 72101, 71567, 
72126, 72124, 72099, 71541, 71566
25628, 62624, 62616, 62440, 62448, 62625, 62617, 62441, 62449, 72125, 72101, 71567, 72126, 72128, 72104, 71570, 
72129, 72127, 72102, 71544, 71569
25629, 62625, 62617, 62441, 62449, 62626, 62618, 62442, 62450, 72128, 72104, 71570, 72129, 72131, 72107, 71573, 
72132, 72130, 72105, 71547, 71572
25630, 62626, 62618, 62442, 62450, 62627, 62619, 62443, 62451, 72131, 72107, 71573, 72132, 72134, 72110, 71576, 
72135, 72133, 72108, 71550, 71575
25631, 62627, 62619, 62443, 62451, 26404, 26403, 26381, 26382, 72134, 72110, 71576, 72135, 27227, 27224, 27182, 
27226, 72136, 72111, 71553, 71578
25632, 24909, 24908, 24886, 24887, 62628, 62620, 62444, 62452, 25732, 25731, 25687, 25733, 72138, 72114, 71580, 
72139, 72137, 72112, 71554, 71579
25633, 62628, 62620, 62444, 62452, 62629, 62621, 62445, 62453, 72138, 72114, 71580, 72139, 72141, 72117, 71583, 
72142, 72140, 72115, 71557, 71582
25634, 62629, 62621, 62445, 62453, 62630, 62622, 62446, 62454, 72141, 72117, 71583, 72142, 72144, 72120, 71586, 
72145, 72143, 72118, 71560, 71585
25635, 62630, 62622, 62446, 62454, 62631, 62623, 62447, 62455, 72144, 72120, 71586, 72145, 72147, 72123, 71589, 
72148, 72146, 72121, 71563, 71588
25636, 62631, 62623, 62447, 62455, 62632, 62624, 62448, 62456, 72147, 72123, 71589, 72148, 72150, 72126, 71592, 
72151, 72149, 72124, 71566, 71591
25637, 62632, 62624, 62448, 62456, 62633, 62625, 62449, 62457, 72150, 72126, 71592, 72151, 72153, 72129, 71595, 
72154, 72152, 72127, 71569, 71594
25638, 62633, 62625, 62449, 62457, 62634, 62626, 62450, 62458, 72153, 72129, 71595, 72154, 72156, 72132, 71598, 
72157, 72155, 72130, 71572, 71597
25639, 62634, 62626, 62450, 62458, 62635, 62627, 62451, 62459, 72156, 72132, 71598, 72157, 72159, 72135, 71601, 
72160, 72158, 72133, 71575, 71600
25640, 62635, 62627, 62451, 62459, 26405, 26404, 26382, 26383, 72159, 72135, 71601, 72160, 27229, 27226, 27184, 
27228, 72161, 72136, 71578, 71603
25641, 24910, 24909, 24887, 24888, 62636, 62628, 62452, 62460, 25734, 25733, 25689, 25735, 72163, 72139, 71605, 
72164, 72162, 72137, 71579, 71604
25642, 62636, 62628, 62452, 62460, 62637, 62629, 62453, 62461, 72163, 72139, 71605, 72164, 72166, 72142, 71608, 
72167, 72165, 72140, 71582, 71607
25643, 62637, 62629, 62453, 62461, 62638, 62630, 62454, 62462, 72166, 72142, 71608, 72167, 72169, 72145, 71611, 
72170, 72168, 72143, 71585, 71610
25644, 62638, 62630, 62454, 62462, 62639, 62631, 62455, 62463, 72169, 72145, 71611, 72170, 72172, 72148, 71614, 
72173, 72171, 72146, 71588, 71613
25645, 62639, 62631, 62455, 62463, 62640, 62632, 62456, 62464, 72172, 72148, 71614, 72173, 72175, 72151, 71617, 
72176, 72174, 72149, 71591, 71616
25646, 62640, 62632, 62456, 62464, 62641, 62633, 62457, 62465, 72175, 72151, 71617, 72176, 72178, 72154, 71620, 
72179, 72177, 72152, 71594, 71619
25647, 62641, 62633, 62457, 62465, 62642, 62634, 62458, 62466, 72178, 72154, 71620, 72179, 72181, 72157, 71623, 
72182, 72180, 72155, 71597, 71622
25648, 62642, 62634, 62458, 62466, 62643, 62635, 62459, 62467, 72181, 72157, 71623, 72182, 72184, 72160, 71626, 
72185, 72183, 72158, 71600, 71625
25649, 62643, 62635, 62459, 62467, 26406, 26405, 26383, 26384, 72184, 72160, 71626, 72185, 27231, 27228, 27186, 
27230, 72186, 72161, 71603, 71628
25650, 24911, 24910, 24888, 24889, 62644, 62636, 62460, 62468, 25736, 25735, 25691, 25737, 72188, 72164, 71630, 
72189, 72187, 72162, 71604, 71629
25651, 62644, 62636, 62460, 62468, 62645, 62637, 62461, 62469, 72188, 72164, 71630, 72189, 72191, 72167, 71633, 
72192, 72190, 72165, 71607, 71632
25652, 62645, 62637, 62461, 62469, 62646, 62638, 62462, 62470, 72191, 72167, 71633, 72192, 72194, 72170, 71636, 
72195, 72193, 72168, 71610, 71635
25653, 62646, 62638, 62462, 62470, 62647, 62639, 62463, 62471, 72194, 72170, 71636, 72195, 72197, 72173, 71639, 
72198, 72196, 72171, 71613, 71638
25654, 62647, 62639, 62463, 62471, 62648, 62640, 62464, 62472, 72197, 72173, 71639, 72198, 72200, 72176, 71642, 
72201, 72199, 72174, 71616, 71641
25655, 62648, 62640, 62464, 62472, 62649, 62641, 62465, 62473, 72200, 72176, 71642, 72201, 72203, 72179, 71645, 
72204, 72202, 72177, 71619, 71644
25656, 62649, 62641, 62465, 62473, 62650, 62642, 62466, 62474, 72203, 72179, 71645, 72204, 72206, 72182, 71648, 
72207, 72205, 72180, 71622, 71647
25657, 62650, 62642, 62466, 62474, 62651, 62643, 62467, 62475, 72206, 72182, 71648, 72207, 72209, 72185, 71651, 
72210, 72208, 72183, 71625, 71650
25658, 62651, 62643, 62467, 62475, 26407, 26406, 26384, 26385, 72209, 72185, 71651, 72210, 27233, 27230, 27188, 
27232, 72211, 72186, 71628, 71653
25659, 24912, 24911, 24889, 24890, 62652, 62644, 62468, 62476, 25738, 25737, 25693, 25739, 72213, 72189, 71655, 
72214, 72212, 72187, 71629, 71654
25660, 62652, 62644, 62468, 62476, 62653, 62645, 62469, 62477, 72213, 72189, 71655, 72214, 72216, 72192, 71658, 
72217, 72215, 72190, 71632, 71657
25661, 62653, 62645, 62469, 62477, 62654, 62646, 62470, 62478, 72216, 72192, 71658, 72217, 72219, 72195, 71661, 
72220, 72218, 72193, 71635, 71660
25662, 62654, 62646, 62470, 62478, 62655, 62647, 62471, 62479, 72219, 72195, 71661, 72220, 72222, 72198, 71664, 
72223, 72221, 72196, 71638, 71663
25663, 62655, 62647, 62471, 62479, 62656, 62648, 62472, 62480, 72222, 72198, 71664, 72223, 72225, 72201, 71667, 
72226, 72224, 72199, 71641, 71666
25664, 62656, 62648, 62472, 62480, 62657, 62649, 62473, 62481, 72225, 72201, 71667, 72226, 72228, 72204, 71670, 
72229, 72227, 72202, 71644, 71669
25665, 62657, 62649, 62473, 62481, 62658, 62650, 62474, 62482, 72228, 72204, 71670, 72229, 72231, 72207, 71673, 
72232, 72230, 72205, 71647, 71672
25666, 62658, 62650, 62474, 62482, 62659, 62651, 62475, 62483, 72231, 72207, 71673, 72232, 72234, 72210, 71676, 
72235, 72233, 72208, 71650, 71675
25667, 62659, 62651, 62475, 62483, 26408, 26407, 26385, 26386, 72234, 72210, 71676, 72235, 27235, 27232, 27190, 
27234, 72236, 72211, 71653, 71678
25668, 24913, 24912, 24890, 24891, 62660, 62652, 62476, 62484, 25740, 25739, 25695, 25741, 72238, 72214, 71680, 
72239, 72237, 72212, 71654, 71679
25669, 62660, 62652, 62476, 62484, 62661, 62653, 62477, 62485, 72238, 72214, 71680, 72239, 72241, 72217, 71683, 
72242, 72240, 72215, 71657, 71682
25670, 62661, 62653, 62477, 62485, 62662, 62654, 62478, 62486, 72241, 72217, 71683, 72242, 72244, 72220, 71686, 
72245, 72243, 72218, 71660, 71685
25671, 62662, 62654, 62478, 62486, 62663, 62655, 62479, 62487, 72244, 72220, 71686, 72245, 72247, 72223, 71689, 
72248, 72246, 72221, 71663, 71688
25672, 62663, 62655, 62479, 62487, 62664, 62656, 62480, 62488, 72247, 72223, 71689, 72248, 72250, 72226, 71692, 
72251, 72249, 72224, 71666, 71691
25673, 62664, 62656, 62480, 62488, 62665, 62657, 62481, 62489, 72250, 72226, 71692, 72251, 72253, 72229, 71695, 
72254, 72252, 72227, 71669, 71694
25674, 62665, 62657, 62481, 62489, 62666, 62658, 62482, 62490, 72253, 72229, 71695, 72254, 72256, 72232, 71698, 
72257, 72255, 72230, 71672, 71697
25675, 62666, 62658, 62482, 62490, 62667, 62659, 62483, 62491, 72256, 72232, 71698, 72257, 72259, 72235, 71701, 
72260, 72258, 72233, 71675, 71700
25676, 62667, 62659, 62483, 62491, 26409, 26408, 26386, 26387, 72259, 72235, 71701, 72260, 27237, 27234, 27192, 
27236, 72261, 72236, 71678, 71703
25677, 3184, 24913, 24891, 3183, 28246, 62660, 62484, 28238, 25742, 25741, 25697, 3206, 72262, 72239, 71704, 
28549, 28548, 72237, 71679, 28531
25678, 28246, 62660, 62484, 28238, 28247, 62661, 62485, 28239, 72262, 72239, 71704, 28549, 72263, 72242, 71705, 
28551, 28550, 72240, 71682, 28533
25679, 28247, 62661, 62485, 28239, 28248, 62662, 62486, 28240, 72263, 72242, 71705, 28551, 72264, 72245, 71706, 
28553, 28552, 72243, 71685, 28535
25680, 28248, 62662, 62486, 28240, 28249, 62663, 62487, 28241, 72264, 72245, 71706, 28553, 72265, 72248, 71707, 
28555, 28554, 72246, 71688, 28537
25681, 28249, 62663, 62487, 28241, 28250, 62664, 62488, 28242, 72265, 72248, 71707, 28555, 72266, 72251, 71708, 
28557, 28556, 72249, 71691, 28539
25682, 28250, 62664, 62488, 28242, 28251, 62665, 62489, 28243, 72266, 72251, 71708, 28557, 72267, 72254, 71709, 
28559, 28558, 72252, 71694, 28541
25683, 28251, 62665, 62489, 28243, 28252, 62666, 62490, 28244, 72267, 72254, 71709, 28559, 72268, 72257, 71710, 
28561, 28560, 72255, 71697, 28543
25684, 28252, 62666, 62490, 28244, 28253, 62667, 62491, 28245, 72268, 72257, 71710, 28561, 72269, 72260, 71711, 
28563, 28562, 72258, 71700, 28545
25685, 28253, 62667, 62491, 28245, 3319, 26409, 26387, 3318, 72269, 72260, 71711, 28563, 27238, 27236, 27193, 
3341, 28564, 72261, 71703, 28547
25686, 24914, 3140, 3139, 24892, 62668, 27696, 27688, 62492, 25743, 3162, 25698, 25744, 72271, 28007, 71713, 
72272, 72270, 28008, 27991, 71712
25687, 62668, 27696, 27688, 62492, 62669, 27697, 27689, 62493, 72271, 28007, 71713, 72272, 72274, 28009, 71716, 
72275, 72273, 28010, 27993, 71715
25688, 62669, 27697, 27689, 62493, 62670, 27698, 27690, 62494, 72274, 28009, 71716, 72275, 72277, 28011, 71719, 
72278, 72276, 28012, 27995, 71718
25689, 62670, 27698, 27690, 62494, 62671, 27699, 27691, 62495, 72277, 28011, 71719, 72278, 72280, 28013, 71722, 
72281, 72279, 28014, 27997, 71721
25690, 62671, 27699, 27691, 62495, 62672, 27700, 27692, 62496, 72280, 28013, 71722, 72281, 72283, 28015, 71725, 
72284, 72282, 28016, 27999, 71724
25691, 62672, 27700, 27692, 62496, 62673, 27701, 27693, 62497, 72283, 28015, 71725, 72284, 72286, 28017, 71728, 
72287, 72285, 28018, 28001, 71727
25692, 62673, 27701, 27693, 62497, 62674, 27702, 27694, 62498, 72286, 28017, 71728, 72287, 72289, 28019, 71731, 
72290, 72288, 28020, 28003, 71730
25693, 62674, 27702, 27694, 62498, 62675, 27703, 27695, 62499, 72289, 28019, 71731, 72290, 72292, 28021, 71734, 
72293, 72291, 28022, 28005, 71733
25694, 62675, 27703, 27695, 62499, 26410, 3275, 3274, 26388, 72292, 28021, 71734, 72293, 27240, 3297, 27195, 
27239, 72294, 28023, 28006, 71736
25695, 24915, 24914, 24892, 24893, 62676, 62668, 62492, 62500, 25745, 25744, 25700, 25746, 72296, 72272, 71738, 
72297, 72295, 72270, 71712, 71737
25696, 62676, 62668, 62492, 62500, 62677, 62669, 62493, 62501, 72296, 72272, 71738, 72297, 72299, 72275, 71741, 
72300, 72298, 72273, 71715, 71740
25697, 62677, 62669, 62493, 62501, 62678, 62670, 62494, 62502, 72299, 72275, 71741, 72300, 72302, 72278, 71744, 
72303, 72301, 72276, 71718, 71743
25698, 62678, 62670, 62494, 62502, 62679, 62671, 62495, 62503, 72302, 72278, 71744, 72303, 72305, 72281, 71747, 
72306, 72304, 72279, 71721, 71746
25699, 62679, 62671, 62495, 62503, 62680, 62672, 62496, 62504, 72305, 72281, 71747, 72306, 72308, 72284, 71750, 
72309, 72307, 72282, 71724, 71749
25700, 62680, 62672, 62496, 62504, 62681, 62673, 62497, 62505, 72308, 72284, 71750, 72309, 72311, 72287, 71753, 
72312, 72310, 72285, 71727, 71752
25701, 62681, 62673, 62497, 62505, 62682, 62674, 62498, 62506, 72311, 72287, 71753, 72312, 72314, 72290, 71756, 
72315, 72313, 72288, 71730, 71755
25702, 62682, 62674, 62498, 62506, 62683, 62675, 62499, 62507, 72314, 72290, 71756, 72315, 72317, 72293, 71759, 
72318, 72316, 72291, 71733, 71758
25703, 62683, 62675, 62499, 62507, 26411, 26410, 26388, 26389, 72317, 72293, 71759, 72318, 27242, 27239, 27197, 
27241, 72319, 72294, 71736, 71761
25704, 24916, 24915, 24893, 24894, 62684, 62676, 62500, 62508, 25747, 25746, 25702, 25748, 72321, 72297, 71763, 
72322, 72320, 72295, 71737, 71762
25705, 62684, 62676, 62500, 62508, 62685, 62677, 62501, 62509, 72321, 72297, 71763, 72322, 72324, 72300, 71766, 
72325, 72323, 72298, 71740, 71765
25706, 62685, 62677, 62501, 62509, 62686, 62678, 62502, 62510, 72324, 72300, 71766, 72325, 72327, 72303, 71769, 
72328, 72326, 72301, 71743, 71768
25707, 62686, 62678, 62502, 62510, 62687, 62679, 62503, 62511, 72327, 72303, 71769, 72328, 72330, 72306, 71772, 
72331, 72329, 72304, 71746, 71771
25708, 62687, 62679, 62503, 62511, 62688, 62680, 62504, 62512, 72330, 72306, 71772, 72331, 72333, 72309, 71775, 
72334, 72332, 72307, 71749, 71774
25709, 62688, 62680, 62504, 62512, 62689, 62681, 62505, 62513, 72333, 72309, 71775, 72334, 72336, 72312, 71778, 
72337, 72335, 72310, 71752, 71777
25710, 62689, 62681, 62505, 62513, 62690, 62682, 62506, 62514, 72336, 72312, 71778, 72337, 72339, 72315, 71781, 
72340, 72338, 72313, 71755, 71780
25711, 62690, 62682, 62506, 62514, 62691, 62683, 62507, 62515, 72339, 72315, 71781, 72340, 72342, 72318, 71784, 
72343, 72341, 72316, 71758, 71783
25712, 62691, 62683, 62507, 62515, 26412, 26411, 26389, 26390, 72342, 72318, 71784, 72343, 27244, 27241, 27199, 
27243, 72344, 72319, 71761, 71786
25713, 24917, 24916, 24894, 24895, 62692, 62684, 62508, 62516, 25749, 25748, 25704, 25750, 72346, 72322, 71788, 
72347, 72345, 72320, 71762, 71787
25714, 62692, 62684, 62508, 62516, 62693, 62685, 62509, 62517, 72346, 72322, 71788, 72347, 72349, 72325, 71791, 
72350, 72348, 72323, 71765, 71790
25715, 62693, 62685, 62509, 62517, 62694, 62686, 62510, 62518, 72349, 72325, 71791, 72350, 72352, 72328, 71794, 
72353, 72351, 72326, 71768, 71793
25716, 62694, 62686, 62510, 62518, 62695, 62687, 62511, 62519, 72352, 72328, 71794, 72353, 72355, 72331, 71797, 
72356, 72354, 72329, 71771, 71796
25717, 62695, 62687, 62511, 62519, 62696, 62688, 62512, 62520, 72355, 72331, 71797, 72356, 72358, 72334, 71800, 
72359, 72357, 72332, 71774, 71799
25718, 62696, 62688, 62512, 62520, 62697, 62689, 62513, 62521, 72358, 72334, 71800, 72359, 72361, 72337, 71803, 
72362, 72360, 72335, 71777, 71802
25719, 62697, 62689, 62513, 62521, 62698, 62690, 62514, 62522, 72361, 72337, 71803, 72362, 72364, 72340, 71806, 
72365, 72363, 72338, 71780, 71805
25720, 62698, 62690, 62514, 62522, 62699, 62691, 62515, 62523, 72364, 72340, 71806, 72365, 72367, 72343, 71809, 
72368, 72366, 72341, 71783, 71808
25721, 62699, 62691, 62515, 62523, 26413, 26412, 26390, 26391, 72367, 72343, 71809, 72368, 27246, 27243, 27201, 
27245, 72369, 72344, 71786, 71811
25722, 24918, 24917, 24895, 24896, 62700, 62692, 62516, 62524, 25751, 25750, 25706, 25752, 72371, 72347, 71813, 
72372, 72370, 72345, 71787, 71812
25723, 62700, 62692, 62516, 62524, 62701, 62693, 62517, 62525, 72371, 72347, 71813, 72372, 72374, 72350, 71816, 
72375, 72373, 72348, 71790, 71815
25724, 62701, 62693, 62517, 62525, 62702, 62694, 62518, 62526, 72374, 72350, 71816, 72375, 72377, 72353, 71819, 
72378, 72376, 72351, 71793, 71818
25725, 62702, 62694, 62518, 62526, 62703, 62695, 62519, 62527, 72377, 72353, 71819, 72378, 72380, 72356, 71822, 
72381, 72379, 72354, 71796, 71821
25726, 62703, 62695, 62519, 62527, 62704, 62696, 62520, 62528, 72380, 72356, 71822, 72381, 72383, 72359, 71825, 
72384, 72382, 72357, 71799, 71824
25727, 62704, 62696, 62520, 62528, 62705, 62697, 62521, 62529, 72383, 72359, 71825, 72384, 72386, 72362, 71828, 
72387, 72385, 72360, 71802, 71827
25728, 62705, 62697, 62521, 62529, 62706, 62698, 62522, 62530, 72386, 72362, 71828, 72387, 72389, 72365, 71831, 
72390, 72388, 72363, 71805, 71830
25729, 62706, 62698, 62522, 62530, 62707, 62699, 62523, 62531, 72389, 72365, 71831, 72390, 72392, 72368, 71834, 
72393, 72391, 72366, 71808, 71833
25730, 62707, 62699, 62523, 62531, 26414, 26413, 26391, 26392, 72392, 72368, 71834, 72393, 27248, 27245, 27203, 
27247, 72394, 72369, 71811, 71836
25731, 24919, 24918, 24896, 24897, 62708, 62700, 62524, 62532, 25753, 25752, 25708, 25754, 72396, 72372, 71838, 
72397, 72395, 72370, 71812, 71837
25732, 62708, 62700, 62524, 62532, 62709, 62701, 62525, 62533, 72396, 72372, 71838, 72397, 72399, 72375, 71841, 
72400, 72398, 72373, 71815, 71840
25733, 62709, 62701, 62525, 62533, 62710, 62702, 62526, 62534, 72399, 72375, 71841, 72400, 72402, 72378, 71844, 
72403, 72401, 72376, 71818, 71843
25734, 62710, 62702, 62526, 62534, 62711, 62703, 62527, 62535, 72402, 72378, 71844, 72403, 72405, 72381, 71847, 
72406, 72404, 72379, 71821, 71846
25735, 62711, 62703, 62527, 62535, 62712, 62704, 62528, 62536, 72405, 72381, 71847, 72406, 72408, 72384, 71850, 
72409, 72407, 72382, 71824, 71849
25736, 62712, 62704, 62528, 62536, 62713, 62705, 62529, 62537, 72408, 72384, 71850, 72409, 72411, 72387, 71853, 
72412, 72410, 72385, 71827, 71852
25737, 62713, 62705, 62529, 62537, 62714, 62706, 62530, 62538, 72411, 72387, 71853, 72412, 72414, 72390, 71856, 
72415, 72413, 72388, 71830, 71855
25738, 62714, 62706, 62530, 62538, 62715, 62707, 62531, 62539, 72414, 72390, 71856, 72415, 72417, 72393, 71859, 
72418, 72416, 72391, 71833, 71858
25739, 62715, 62707, 62531, 62539, 26415, 26414, 26392, 26393, 72417, 72393, 71859, 72418, 27250, 27247, 27205, 
27249, 72419, 72394, 71836, 71861
25740, 24920, 24919, 24897, 24898, 62716, 62708, 62532, 62540, 25755, 25754, 25710, 25756, 72421, 72397, 71863, 
72422, 72420, 72395, 71837, 71862
25741, 62716, 62708, 62532, 62540, 62717, 62709, 62533, 62541, 72421, 72397, 71863, 72422, 72424, 72400, 71866, 
72425, 72423, 72398, 71840, 71865
25742, 62717, 62709, 62533, 62541, 62718, 62710, 62534, 62542, 72424, 72400, 71866, 72425, 72427, 72403, 71869, 
72428, 72426, 72401, 71843, 71868
25743, 62718, 62710, 62534, 62542, 62719, 62711, 62535, 62543, 72427, 72403, 71869, 72428, 72430, 72406, 71872, 
72431, 72429, 72404, 71846, 71871
25744, 62719, 62711, 62535, 62543, 62720, 62712, 62536, 62544, 72430, 72406, 71872, 72431, 72433, 72409, 71875, 
72434, 72432, 72407, 71849, 71874
25745, 62720, 62712, 62536, 62544, 62721, 62713, 62537, 62545, 72433, 72409, 71875, 72434, 72436, 72412, 71878, 
72437, 72435, 72410, 71852, 71877
25746, 62721, 62713, 62537, 62545, 62722, 62714, 62538, 62546, 72436, 72412, 71878, 72437, 72439, 72415, 71881, 
72440, 72438, 72413, 71855, 71880
25747, 62722, 62714, 62538, 62546, 62723, 62715, 62539, 62547, 72439, 72415, 71881, 72440, 72442, 72418, 71884, 
72443, 72441, 72416, 71858, 71883
25748, 62723, 62715, 62539, 62547, 26416, 26415, 26393, 26394, 72442, 72418, 71884, 72443, 27252, 27249, 27207, 
27251, 72444, 72419, 71861, 71886
25749, 24921, 24920, 24898, 24899, 62724, 62716, 62540, 62548, 25757, 25756, 25712, 25758, 72446, 72422, 71888, 
72447, 72445, 72420, 71862, 71887
25750, 62724, 62716, 62540, 62548, 62725, 62717, 62541, 62549, 72446, 72422, 71888, 72447, 72449, 72425, 71891, 
72450, 72448, 72423, 71865, 71890
25751, 62725, 62717, 62541, 62549, 62726, 62718, 62542, 62550, 72449, 72425, 71891, 72450, 72452, 72428, 71894, 
72453, 72451, 72426, 71868, 71893
25752, 62726, 62718, 62542, 62550, 62727, 62719, 62543, 62551, 72452, 72428, 71894, 72453, 72455, 72431, 71897, 
72456, 72454, 72429, 71871, 71896
25753, 62727, 62719, 62543, 62551, 62728, 62720, 62544, 62552, 72455, 72431, 71897, 72456, 72458, 72434, 71900, 
72459, 72457, 72432, 71874, 71899
25754, 62728, 62720, 62544, 62552, 62729, 62721, 62545, 62553, 72458, 72434, 71900, 72459, 72461, 72437, 71903, 
72462, 72460, 72435, 71877, 71902
25755, 62729, 62721, 62545, 62553, 62730, 62722, 62546, 62554, 72461, 72437, 71903, 72462, 72464, 72440, 71906, 
72465, 72463, 72438, 71880, 71905
25756, 62730, 62722, 62546, 62554, 62731, 62723, 62547, 62555, 72464, 72440, 71906, 72465, 72467, 72443, 71909, 
72468, 72466, 72441, 71883, 71908
25757, 62731, 62723, 62547, 62555, 26417, 26416, 26394, 26395, 72467, 72443, 71909, 72468, 27254, 27251, 27209, 
27253, 72469, 72444, 71886, 71911
25758, 24922, 24921, 24899, 24900, 62732, 62724, 62548, 62556, 25759, 25758, 25714, 25760, 72471, 72447, 71913, 
72472, 72470, 72445, 71887, 71912
25759, 62732, 62724, 62548, 62556, 62733, 62725, 62549, 62557, 72471, 72447, 71913, 72472, 72474, 72450, 71916, 
72475, 72473, 72448, 71890, 71915
25760, 62733, 62725, 62549, 62557, 62734, 62726, 62550, 62558, 72474, 72450, 71916, 72475, 72477, 72453, 71919, 
72478, 72476, 72451, 71893, 71918
25761, 62734, 62726, 62550, 62558, 62735, 62727, 62551, 62559, 72477, 72453, 71919, 72478, 72480, 72456, 71922, 
72481, 72479, 72454, 71896, 71921
25762, 62735, 62727, 62551, 62559, 62736, 62728, 62552, 62560, 72480, 72456, 71922, 72481, 72483, 72459, 71925, 
72484, 72482, 72457, 71899, 71924
25763, 62736, 62728, 62552, 62560, 62737, 62729, 62553, 62561, 72483, 72459, 71925, 72484, 72486, 72462, 71928, 
72487, 72485, 72460, 71902, 71927
25764, 62737, 62729, 62553, 62561, 62738, 62730, 62554, 62562, 72486, 72462, 71928, 72487, 72489, 72465, 71931, 
72490, 72488, 72463, 71905, 71930
25765, 62738, 62730, 62554, 62562, 62739, 62731, 62555, 62563, 72489, 72465, 71931, 72490, 72492, 72468, 71934, 
72493, 72491, 72466, 71908, 71933
25766, 62739, 62731, 62555, 62563, 26418, 26417, 26395, 26396, 72492, 72468, 71934, 72493, 27256, 27253, 27211, 
27255, 72494, 72469, 71911, 71936
25767, 24923, 24922, 24900, 24901, 62740, 62732, 62556, 62564, 25761, 25760, 25716, 25762, 72496, 72472, 71938, 
72497, 72495, 72470, 71912, 71937
25768, 62740, 62732, 62556, 62564, 62741, 62733, 62557, 62565, 72496, 72472, 71938, 72497, 72499, 72475, 71941, 
72500, 72498, 72473, 71915, 71940
25769, 62741, 62733, 62557, 62565, 62742, 62734, 62558, 62566, 72499, 72475, 71941, 72500, 72502, 72478, 71944, 
72503, 72501, 72476, 71918, 71943
25770, 62742, 62734, 62558, 62566, 62743, 62735, 62559, 62567, 72502, 72478, 71944, 72503, 72505, 72481, 71947, 
72506, 72504, 72479, 71921, 71946
25771, 62743, 62735, 62559, 62567, 62744, 62736, 62560, 62568, 72505, 72481, 71947, 72506, 72508, 72484, 71950, 
72509, 72507, 72482, 71924, 71949
