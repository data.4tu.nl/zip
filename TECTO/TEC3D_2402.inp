94201, 0.91304347826087, 0.82826086956522, -0.1
94202, 0.8695652173913, 0.82826086956522, -0.1
94203, 0.82608695652174, 0.82826086956522, -0.1
94204, 0.78260869565217, 0.82826086956522, -0.1
94205, 0.73913043478261, 0.82826086956522, -0.1
94206, 0.69565217391304, 0.82826086956522, -0.1
94207, 0.65217391304348, 0.82826086956522, -0.1
94208, 0.60869565217391, 0.82826086956522, -0.1
94209, 0.56521739130435, 0.82826086956522, -0.1
94210, 0.52173913043478, 0.82826086956522, -0.1
94211, 0.47826086956522, 0.82826086956522, -0.1
94212, 0.43478260869565, 0.82826086956522, -0.1
94213, 0.39130434782609, 0.82826086956522, -0.1
94214, 0.34782608695652, 0.82826086956522, -0.1
94215, 0.30434782608696, 0.82826086956522, -0.1
94216, 0.26086956521739, 0.82826086956522, -0.1
94217, 0.21739130434783, 0.82826086956522, -0.1
94218, 0.17391304347826, 0.82826086956522, -0.1
94219, 0.1304347826087, 0.82826086956522, -0.1
94220, 0.08695652173913, 0.82826086956522, -0.1
94221, 0.043478260869565, 0.82826086956522, -0.1
94222, 0.95652173913044, 0.8804347826087, -0.1
94223, 0.91304347826087, 0.8804347826087, -0.1
94224, 0.8695652173913, 0.8804347826087, -0.1
94225, 0.82608695652174, 0.8804347826087, -0.1
94226, 0.78260869565217, 0.8804347826087, -0.1
94227, 0.73913043478261, 0.88043478260869, -0.1
94228, 0.69565217391304, 0.8804347826087, -0.1
94229, 0.65217391304348, 0.8804347826087, -0.1
94230, 0.60869565217391, 0.8804347826087, -0.1
94231, 0.56521739130435, 0.88043478260869, -0.1
94232, 0.52173913043478, 0.88043478260869, -0.1
94233, 0.47826086956522, 0.8804347826087, -0.1
94234, 0.43478260869565, 0.88043478260869, -0.1
94235, 0.39130434782609, 0.8804347826087, -0.1
94236, 0.34782608695652, 0.8804347826087, -0.1
94237, 0.30434782608696, 0.88043478260869, -0.1
94238, 0.26086956521739, 0.8804347826087, -0.1
94239, 0.21739130434783, 0.88043478260869, -0.1
94240, 0.17391304347826, 0.8804347826087, -0.1
94241, 0.1304347826087, 0.8804347826087, -0.1
94242, 0.08695652173913, 0.8804347826087, -0.1
94243, 0.043478260869565, 0.88043478260869, -0.1
94244, 0.95652173913044, 0.93260869565217, -0.1
94245, 0.91304347826087, 0.93260869565217, -0.1
94246, 0.8695652173913, 0.93260869565217, -0.1
94247, 0.82608695652174, 0.93260869565217, -0.1
94248, 0.78260869565217, 0.93260869565217, -0.1
94249, 0.73913043478261, 0.93260869565217, -0.1
94250, 0.69565217391304, 0.93260869565217, -0.1
94251, 0.65217391304348, 0.93260869565217, -0.1
94252, 0.60869565217391, 0.93260869565217, -0.1
94253, 0.56521739130435, 0.93260869565217, -0.1
94254, 0.52173913043478, 0.93260869565217, -0.1
94255, 0.47826086956522, 0.93260869565217, -0.1
94256, 0.43478260869565, 0.93260869565217, -0.1
94257, 0.39130434782609, 0.93260869565217, -0.1
94258, 0.34782608695652, 0.93260869565217, -0.1
94259, 0.30434782608696, 0.93260869565217, -0.1
94260, 0.26086956521739, 0.93260869565217, -0.1
94261, 0.21739130434783, 0.93260869565217, -0.1
94262, 0.17391304347826, 0.93260869565217, -0.1
94263, 0.1304347826087, 0.93260869565217, -0.1
94264, 0.08695652173913, 0.93260869565217, -0.1
94265, 0.043478260869565, 0.93260869565217, -0.1
94266, 0.95652173913044, 0.98478260869565, -0.1
94267, 0.91304347826087, 0.98478260869565, -0.1
94268, 0.8695652173913, 0.98478260869565, -0.1
94269, 0.82608695652174, 0.98478260869565, -0.1
94270, 0.78260869565217, 0.98478260869565, -0.1
94271, 0.73913043478261, 0.98478260869565, -0.1
94272, 0.69565217391304, 0.98478260869565, -0.1
94273, 0.65217391304348, 0.98478260869565, -0.1
94274, 0.60869565217391, 0.98478260869565, -0.1
94275, 0.56521739130435, 0.98478260869565, -0.1
94276, 0.52173913043478, 0.98478260869565, -0.1
94277, 0.47826086956522, 0.98478260869565, -0.1
94278, 0.43478260869565, 0.98478260869565, -0.1
94279, 0.39130434782609, 0.98478260869565, -0.1
94280, 0.34782608695652, 0.98478260869565, -0.1
94281, 0.30434782608696, 0.98478260869565, -0.1
94282, 0.26086956521739, 0.98478260869565, -0.1
94283, 0.21739130434783, 0.98478260869565, -0.1
94284, 0.17391304347826, 0.98478260869565, -0.1
94285, 0.1304347826087, 0.98478260869565, -0.1
94286, 0.08695652173913, 0.98478260869565, -0.1
94287, 0.043478260869565, 0.98478260869565, -0.1
94288, 0.95652173913044, 1.0369565217391, -0.1
94289, 0.91304347826087, 1.0369565217391, -0.1
94290, 0.8695652173913, 1.0369565217391, -0.1
94291, 0.82608695652174, 1.0369565217391, -0.1
94292, 0.78260869565217, 1.0369565217391, -0.1
94293, 0.73913043478261, 1.0369565217391, -0.1
94294, 0.69565217391304, 1.0369565217391, -0.1
94295, 0.65217391304348, 1.0369565217391, -0.1
94296, 0.60869565217391, 1.0369565217391, -0.1
94297, 0.56521739130435, 1.0369565217391, -0.1
94298, 0.52173913043478, 1.0369565217391, -0.1
94299, 0.47826086956522, 1.0369565217391, -0.1
94300, 0.43478260869565, 1.0369565217391, -0.1
94301, 0.39130434782609, 1.0369565217391, -0.1
94302, 0.34782608695652, 1.0369565217391, -0.1
94303, 0.30434782608696, 1.0369565217391, -0.1
94304, 0.26086956521739, 1.0369565217391, -0.1
94305, 0.21739130434783, 1.0369565217391, -0.1
94306, 0.17391304347826, 1.0369565217391, -0.1
94307, 0.1304347826087, 1.0369565217391, -0.1
94308, 0.08695652173913, 1.0369565217391, -0.1
94309, 0.043478260869565, 1.0369565217391, -0.1
94310, 0.95652173913044, 1.0891304347826, -0.1
94311, 0.91304347826087, 1.0891304347826, -0.1
94312, 0.8695652173913, 1.0891304347826, -0.1
94313, 0.82608695652174, 1.0891304347826, -0.1
94314, 0.78260869565217, 1.0891304347826, -0.1
94315, 0.73913043478261, 1.0891304347826, -0.1
94316, 0.69565217391304, 1.0891304347826, -0.1
94317, 0.65217391304348, 1.0891304347826, -0.1
94318, 0.60869565217391, 1.0891304347826, -0.1
94319, 0.56521739130435, 1.0891304347826, -0.1
94320, 0.52173913043478, 1.0891304347826, -0.1
94321, 0.47826086956522, 1.0891304347826, -0.1
94322, 0.43478260869565, 1.0891304347826, -0.1
94323, 0.39130434782609, 1.0891304347826, -0.1
94324, 0.34782608695652, 1.0891304347826, -0.1
94325, 0.30434782608696, 1.0891304347826, -0.1
94326, 0.26086956521739, 1.0891304347826, -0.1
94327, 0.21739130434783, 1.0891304347826, -0.1
94328, 0.17391304347826, 1.0891304347826, -0.1
94329, 0.1304347826087, 1.0891304347826, -0.1
94330, 0.08695652173913, 1.0891304347826, -0.1
94331, 0.043478260869565, 1.0891304347826, -0.1
94332, 0.95652173913044, 1.1413043478261, -0.1
94333, 0.91304347826087, 1.1413043478261, -0.1
94334, 0.8695652173913, 1.1413043478261, -0.1
94335, 0.82608695652174, 1.1413043478261, -0.1
94336, 0.78260869565217, 1.1413043478261, -0.1
94337, 0.73913043478261, 1.1413043478261, -0.1
94338, 0.69565217391304, 1.1413043478261, -0.1
94339, 0.65217391304348, 1.1413043478261, -0.1
94340, 0.60869565217391, 1.1413043478261, -0.1
94341, 0.56521739130435, 1.1413043478261, -0.1
94342, 0.52173913043478, 1.1413043478261, -0.1
94343, 0.47826086956522, 1.1413043478261, -0.1
94344, 0.43478260869565, 1.1413043478261, -0.1
94345, 0.39130434782609, 1.1413043478261, -0.1
94346, 0.34782608695652, 1.1413043478261, -0.1
94347, 0.30434782608696, 1.1413043478261, -0.1
94348, 0.26086956521739, 1.1413043478261, -0.1
94349, 0.21739130434783, 1.1413043478261, -0.1
94350, 0.17391304347826, 1.1413043478261, -0.1
94351, 0.1304347826087, 1.1413043478261, -0.1
94352, 0.08695652173913, 1.1413043478261, -0.1
94353, 0.043478260869565, 1.1413043478261, -0.1
94354, 0.95652173913044, 1.1934782608696, -0.1
94355, 0.91304347826087, 1.1934782608696, -0.1
94356, 0.8695652173913, 1.1934782608696, -0.1
94357, 0.82608695652174, 1.1934782608696, -0.1
94358, 0.78260869565217, 1.1934782608696, -0.1
94359, 0.73913043478261, 1.1934782608696, -0.1
94360, 0.69565217391304, 1.1934782608696, -0.1
94361, 0.65217391304348, 1.1934782608696, -0.1
94362, 0.60869565217391, 1.1934782608696, -0.1
94363, 0.56521739130435, 1.1934782608696, -0.1
94364, 0.52173913043478, 1.1934782608696, -0.1
94365, 0.47826086956522, 1.1934782608696, -0.1
94366, 0.43478260869565, 1.1934782608696, -0.1
94367, 0.39130434782609, 1.1934782608696, -0.1
94368, 0.34782608695652, 1.1934782608696, -0.1
94369, 0.30434782608696, 1.1934782608696, -0.1
94370, 0.26086956521739, 1.1934782608696, -0.1
94371, 0.21739130434783, 1.1934782608696, -0.1
94372, 0.17391304347826, 1.1934782608696, -0.1
94373, 0.1304347826087, 1.1934782608696, -0.1
94374, 0.08695652173913, 1.1934782608696, -0.1
94375, 0.043478260869565, 1.1934782608696, -0.1
94376, 0.95652173913044, 1.245652173913, -0.1
94377, 0.91304347826087, 1.245652173913, -0.1
94378, 0.8695652173913, 1.245652173913, -0.1
94379, 0.82608695652174, 1.245652173913, -0.1
94380, 0.78260869565217, 1.245652173913, -0.1
94381, 0.73913043478261, 1.245652173913, -0.1
94382, 0.69565217391304, 1.245652173913, -0.1
94383, 0.65217391304348, 1.245652173913, -0.1
94384, 0.60869565217391, 1.245652173913, -0.1
94385, 0.56521739130435, 1.245652173913, -0.1
94386, 0.52173913043478, 1.245652173913, -0.1
94387, 0.47826086956522, 1.245652173913, -0.1
94388, 0.43478260869565, 1.245652173913, -0.1
94389, 0.39130434782609, 1.245652173913, -0.1
94390, 0.34782608695652, 1.245652173913, -0.1
94391, 0.30434782608696, 1.245652173913, -0.1
94392, 0.26086956521739, 1.245652173913, -0.1
94393, 0.21739130434783, 1.245652173913, -0.1
94394, 0.17391304347826, 1.245652173913, -0.1
94395, 0.1304347826087, 1.245652173913, -0.1
94396, 0.08695652173913, 1.245652173913, -0.1
94397, 0.043478260869565, 1.245652173913, -0.1
94398, 0.95652173913044, 1.2978260869565, -0.1
94399, 0.91304347826087, 1.2978260869565, -0.1
94400, 0.8695652173913, 1.2978260869565, -0.1
94401, 0.82608695652174, 1.2978260869565, -0.1
94402, 0.78260869565217, 1.2978260869565, -0.1
94403, 0.73913043478261, 1.2978260869565, -0.1
94404, 0.69565217391304, 1.2978260869565, -0.1
94405, 0.65217391304348, 1.2978260869565, -0.1
94406, 0.60869565217391, 1.2978260869565, -0.1
94407, 0.56521739130435, 1.2978260869565, -0.1
94408, 0.52173913043478, 1.2978260869565, -0.1
94409, 0.47826086956522, 1.2978260869565, -0.1
94410, 0.43478260869565, 1.2978260869565, -0.1
94411, 0.39130434782609, 1.2978260869565, -0.1
94412, 0.34782608695652, 1.2978260869565, -0.1
94413, 0.30434782608696, 1.2978260869565, -0.1
94414, 0.26086956521739, 1.2978260869565, -0.1
94415, 0.21739130434783, 1.2978260869565, -0.1
94416, 0.17391304347826, 1.2978260869565, -0.1
94417, 0.1304347826087, 1.2978260869565, -0.1
94418, 0.08695652173913, 1.2978260869565, -0.1
94419, 0.043478260869565, 1.2978260869565, -0.1
94420, 0.95652173913044, 0.20217391304348, -0.15
94421, 0.91304347826087, 0.20217391304348, -0.15
94422, 0.8695652173913, 0.20217391304348, -0.15
94423, 0.82608695652174, 0.20217391304348, -0.15
94424, 0.78260869565217, 0.20217391304348, -0.15
94425, 0.73913043478261, 0.20217391304348, -0.15
94426, 0.69565217391304, 0.20217391304348, -0.15
94427, 0.65217391304348, 0.20217391304348, -0.15
94428, 0.60869565217391, 0.20217391304348, -0.15
94429, 0.56521739130435, 0.20217391304348, -0.15
94430, 0.52173913043478, 0.20217391304348, -0.15
94431, 0.47826086956522, 0.20217391304348, -0.15
94432, 0.43478260869565, 0.20217391304348, -0.15
94433, 0.39130434782609, 0.20217391304348, -0.15
94434, 0.34782608695652, 0.20217391304348, -0.15
94435, 0.30434782608696, 0.20217391304348, -0.15
94436, 0.26086956521739, 0.20217391304348, -0.15
94437, 0.21739130434783, 0.20217391304348, -0.15
94438, 0.17391304347826, 0.20217391304348, -0.15
94439, 0.1304347826087, 0.20217391304348, -0.15
94440, 0.08695652173913, 0.20217391304348, -0.15
94441, 0.043478260869565, 0.20217391304348, -0.15
94442, 0.95652173913043, 0.25434782608696, -0.15
94443, 0.91304347826087, 0.25434782608696, -0.15
94444, 0.8695652173913, 0.25434782608696, -0.15
94445, 0.82608695652174, 0.25434782608696, -0.15
94446, 0.78260869565217, 0.25434782608696, -0.15
94447, 0.73913043478261, 0.25434782608696, -0.15
94448, 0.69565217391304, 0.25434782608696, -0.15
94449, 0.65217391304348, 0.25434782608696, -0.15
94450, 0.60869565217391, 0.25434782608696, -0.15
94451, 0.56521739130435, 0.25434782608696, -0.15
94452, 0.52173913043478, 0.25434782608696, -0.15
94453, 0.47826086956522, 0.25434782608696, -0.15
94454, 0.43478260869565, 0.25434782608696, -0.15
94455, 0.39130434782609, 0.25434782608696, -0.15
94456, 0.34782608695652, 0.25434782608696, -0.15
94457, 0.30434782608696, 0.25434782608696, -0.15
94458, 0.26086956521739, 0.25434782608696, -0.15
94459, 0.21739130434783, 0.25434782608696, -0.15
94460, 0.17391304347826, 0.25434782608696, -0.15
94461, 0.1304347826087, 0.25434782608696, -0.15
94462, 0.08695652173913, 0.25434782608696, -0.15
94463, 0.043478260869565, 0.25434782608696, -0.15
94464, 0.95652173913044, 0.30652173913043, -0.15
94465, 0.91304347826087, 0.30652173913043, -0.15
94466, 0.8695652173913, 0.30652173913043, -0.15
94467, 0.82608695652174, 0.30652173913043, -0.15
94468, 0.78260869565217, 0.30652173913043, -0.15
94469, 0.73913043478261, 0.30652173913043, -0.15
94470, 0.69565217391304, 0.30652173913043, -0.15
94471, 0.65217391304348, 0.30652173913043, -0.15
94472, 0.60869565217391, 0.30652173913043, -0.15
94473, 0.56521739130435, 0.30652173913043, -0.15
94474, 0.52173913043478, 0.30652173913043, -0.15
94475, 0.47826086956522, 0.30652173913043, -0.15
94476, 0.43478260869565, 0.30652173913043, -0.15
94477, 0.39130434782609, 0.30652173913043, -0.15
94478, 0.34782608695652, 0.30652173913043, -0.15
94479, 0.30434782608696, 0.30652173913043, -0.15
94480, 0.26086956521739, 0.30652173913043, -0.15
94481, 0.21739130434783, 0.30652173913043, -0.15
94482, 0.17391304347826, 0.30652173913043, -0.15
94483, 0.1304347826087, 0.30652173913043, -0.15
94484, 0.08695652173913, 0.30652173913043, -0.15
94485, 0.043478260869565, 0.30652173913043, -0.15
94486, 0.95652173913043, 0.35869565217391, -0.15
94487, 0.91304347826087, 0.35869565217391, -0.15
94488, 0.8695652173913, 0.35869565217391, -0.15
94489, 0.82608695652174, 0.35869565217391, -0.15
94490, 0.78260869565217, 0.35869565217391, -0.15
94491, 0.73913043478261, 0.35869565217391, -0.15
94492, 0.69565217391304, 0.35869565217391, -0.15
94493, 0.65217391304348, 0.35869565217391, -0.15
94494, 0.60869565217391, 0.35869565217391, -0.15
94495, 0.56521739130435, 0.35869565217391, -0.15
94496, 0.52173913043478, 0.35869565217391, -0.15
94497, 0.47826086956522, 0.35869565217391, -0.15
94498, 0.43478260869565, 0.35869565217391, -0.15
94499, 0.39130434782609, 0.35869565217391, -0.15
94500, 0.34782608695652, 0.35869565217391, -0.15
94501, 0.30434782608696, 0.35869565217391, -0.15
94502, 0.26086956521739, 0.35869565217391, -0.15
94503, 0.21739130434783, 0.35869565217391, -0.15
94504, 0.17391304347826, 0.35869565217391, -0.15
94505, 0.1304347826087, 0.35869565217391, -0.15
94506, 0.08695652173913, 0.35869565217391, -0.15
94507, 0.043478260869565, 0.35869565217391, -0.15
94508, 0.95652173913043, 0.41086956521739, -0.15
94509, 0.91304347826087, 0.41086956521739, -0.15
94510, 0.8695652173913, 0.41086956521739, -0.15
94511, 0.82608695652174, 0.41086956521739, -0.15
94512, 0.78260869565217, 0.41086956521739, -0.15
94513, 0.73913043478261, 0.41086956521739, -0.15
94514, 0.69565217391304, 0.41086956521739, -0.15
94515, 0.65217391304348, 0.41086956521739, -0.15
94516, 0.60869565217391, 0.41086956521739, -0.15
94517, 0.56521739130435, 0.41086956521739, -0.15
94518, 0.52173913043478, 0.41086956521739, -0.15
94519, 0.47826086956522, 0.41086956521739, -0.15
94520, 0.43478260869565, 0.41086956521739, -0.15
94521, 0.39130434782609, 0.41086956521739, -0.15
94522, 0.34782608695652, 0.41086956521739, -0.15
94523, 0.30434782608696, 0.41086956521739, -0.15
94524, 0.26086956521739, 0.41086956521739, -0.15
94525, 0.21739130434783, 0.41086956521739, -0.15
94526, 0.17391304347826, 0.41086956521739, -0.15
94527, 0.1304347826087, 0.41086956521739, -0.15
94528, 0.08695652173913, 0.41086956521739, -0.15
94529, 0.043478260869565, 0.41086956521739, -0.15
94530, 0.95652173913043, 0.46304347826087, -0.15
94531, 0.91304347826087, 0.46304347826087, -0.15
94532, 0.8695652173913, 0.46304347826087, -0.15
94533, 0.82608695652174, 0.46304347826087, -0.15
94534, 0.78260869565217, 0.46304347826087, -0.15
94535, 0.73913043478261, 0.46304347826087, -0.15
94536, 0.69565217391304, 0.46304347826087, -0.15
94537, 0.65217391304348, 0.46304347826087, -0.15
94538, 0.60869565217391, 0.46304347826087, -0.15
94539, 0.56521739130435, 0.46304347826087, -0.15
94540, 0.52173913043478, 0.46304347826087, -0.15
94541, 0.47826086956522, 0.46304347826087, -0.15
94542, 0.43478260869565, 0.46304347826087, -0.15
94543, 0.39130434782609, 0.46304347826087, -0.15
94544, 0.34782608695652, 0.46304347826087, -0.15
94545, 0.30434782608696, 0.46304347826087, -0.15
94546, 0.26086956521739, 0.46304347826087, -0.15
94547, 0.21739130434783, 0.46304347826087, -0.15
94548, 0.17391304347826, 0.46304347826087, -0.15
94549, 0.1304347826087, 0.46304347826087, -0.15
94550, 0.08695652173913, 0.46304347826087, -0.15
94551, 0.043478260869565, 0.46304347826087, -0.15
94552, 0.95652173913043, 0.51521739130435, -0.15
94553, 0.91304347826087, 0.51521739130435, -0.15
94554, 0.8695652173913, 0.51521739130435, -0.15
94555, 0.82608695652174, 0.51521739130435, -0.15
94556, 0.78260869565217, 0.51521739130435, -0.15
94557, 0.73913043478261, 0.51521739130435, -0.15
94558, 0.69565217391304, 0.51521739130435, -0.15
94559, 0.65217391304348, 0.51521739130435, -0.15
94560, 0.60869565217391, 0.51521739130435, -0.15
94561, 0.56521739130435, 0.51521739130435, -0.15
94562, 0.52173913043478, 0.51521739130435, -0.15
94563, 0.47826086956522, 0.51521739130435, -0.15
94564, 0.43478260869565, 0.51521739130435, -0.15
94565, 0.39130434782609, 0.51521739130435, -0.15
94566, 0.34782608695652, 0.51521739130435, -0.15
94567, 0.30434782608696, 0.51521739130435, -0.15
94568, 0.26086956521739, 0.51521739130435, -0.15
94569, 0.21739130434783, 0.51521739130435, -0.15
94570, 0.17391304347826, 0.51521739130435, -0.15
94571, 0.1304347826087, 0.51521739130435, -0.15
94572, 0.08695652173913, 0.51521739130435, -0.15
94573, 0.043478260869565, 0.51521739130435, -0.15
94574, 0.95652173913044, 0.56739130434783, -0.15
94575, 0.91304347826087, 0.56739130434783, -0.15
94576, 0.8695652173913, 0.56739130434783, -0.15
94577, 0.82608695652174, 0.56739130434783, -0.15
94578, 0.78260869565217, 0.56739130434783, -0.15
94579, 0.73913043478261, 0.56739130434783, -0.15
94580, 0.69565217391304, 0.56739130434783, -0.15
94581, 0.65217391304348, 0.56739130434783, -0.15
94582, 0.60869565217391, 0.56739130434783, -0.15
94583, 0.56521739130435, 0.56739130434783, -0.15
94584, 0.52173913043478, 0.56739130434783, -0.15
94585, 0.47826086956522, 0.56739130434783, -0.15
94586, 0.43478260869565, 0.56739130434783, -0.15
94587, 0.39130434782609, 0.56739130434783, -0.15
94588, 0.34782608695652, 0.56739130434783, -0.15
94589, 0.30434782608696, 0.56739130434783, -0.15
94590, 0.26086956521739, 0.56739130434783, -0.15
94591, 0.21739130434783, 0.56739130434783, -0.15
94592, 0.17391304347826, 0.56739130434783, -0.15
94593, 0.1304347826087, 0.56739130434783, -0.15
94594, 0.08695652173913, 0.56739130434783, -0.15
94595, 0.043478260869565, 0.56739130434783, -0.15
94596, 0.95652173913044, 0.6195652173913, -0.15
94597, 0.91304347826087, 0.6195652173913, -0.15
94598, 0.8695652173913, 0.6195652173913, -0.15
94599, 0.82608695652174, 0.6195652173913, -0.15
94600, 0.78260869565217, 0.6195652173913, -0.15
94601, 0.73913043478261, 0.6195652173913, -0.15
94602, 0.69565217391304, 0.6195652173913, -0.15
94603, 0.65217391304348, 0.6195652173913, -0.15
94604, 0.60869565217391, 0.6195652173913, -0.15
94605, 0.56521739130435, 0.6195652173913, -0.15
94606, 0.52173913043478, 0.6195652173913, -0.15
94607, 0.47826086956522, 0.6195652173913, -0.15
94608, 0.43478260869565, 0.6195652173913, -0.15
94609, 0.39130434782609, 0.6195652173913, -0.15
94610, 0.34782608695652, 0.6195652173913, -0.15
94611, 0.30434782608696, 0.6195652173913, -0.15
94612, 0.26086956521739, 0.6195652173913, -0.15
94613, 0.21739130434783, 0.6195652173913, -0.15
94614, 0.17391304347826, 0.6195652173913, -0.15
94615, 0.1304347826087, 0.6195652173913, -0.15
94616, 0.08695652173913, 0.6195652173913, -0.15
94617, 0.043478260869565, 0.6195652173913, -0.15
94618, 0.95652173913044, 0.67173913043478, -0.15
94619, 0.91304347826087, 0.67173913043478, -0.15
94620, 0.8695652173913, 0.67173913043478, -0.15
94621, 0.82608695652174, 0.67173913043478, -0.15
94622, 0.78260869565217, 0.67173913043478, -0.15
94623, 0.73913043478261, 0.67173913043478, -0.15
94624, 0.69565217391304, 0.67173913043478, -0.15
94625, 0.65217391304348, 0.67173913043478, -0.15
94626, 0.60869565217391, 0.67173913043478, -0.15
94627, 0.56521739130435, 0.67173913043478, -0.15
94628, 0.52173913043478, 0.67173913043478, -0.15
94629, 0.47826086956522, 0.67173913043478, -0.15
94630, 0.43478260869565, 0.67173913043478, -0.15
94631, 0.39130434782609, 0.67173913043478, -0.15
94632, 0.34782608695652, 0.67173913043478, -0.15
94633, 0.30434782608696, 0.67173913043478, -0.15
94634, 0.26086956521739, 0.67173913043478, -0.15
94635, 0.21739130434783, 0.67173913043478, -0.15
94636, 0.17391304347826, 0.67173913043478, -0.15
94637, 0.1304347826087, 0.67173913043478, -0.15
94638, 0.08695652173913, 0.67173913043478, -0.15
94639, 0.043478260869565, 0.67173913043478, -0.15
94640, 0.95652173913044, 0.72391304347826, -0.15
94641, 0.91304347826087, 0.72391304347826, -0.15
94642, 0.8695652173913, 0.72391304347826, -0.15
94643, 0.82608695652174, 0.72391304347826, -0.15
94644, 0.78260869565217, 0.72391304347826, -0.15
94645, 0.73913043478261, 0.72391304347826, -0.15
94646, 0.69565217391304, 0.72391304347826, -0.15
94647, 0.65217391304348, 0.72391304347826, -0.15
94648, 0.60869565217391, 0.72391304347826, -0.15
94649, 0.56521739130435, 0.72391304347826, -0.15
94650, 0.52173913043478, 0.72391304347826, -0.15
94651, 0.47826086956522, 0.72391304347826, -0.15
94652, 0.43478260869565, 0.72391304347826, -0.15
94653, 0.39130434782609, 0.72391304347826, -0.15
94654, 0.34782608695652, 0.72391304347826, -0.15
94655, 0.30434782608696, 0.72391304347826, -0.15
94656, 0.26086956521739, 0.72391304347826, -0.15
94657, 0.21739130434783, 0.72391304347826, -0.15
94658, 0.17391304347826, 0.72391304347826, -0.15
94659, 0.1304347826087, 0.72391304347826, -0.15
94660, 0.08695652173913, 0.72391304347826, -0.15
94661, 0.043478260869565, 0.72391304347826, -0.15
94662, 0.95652173913044, 0.77608695652174, -0.15
94663, 0.91304347826087, 0.77608695652174, -0.15
94664, 0.8695652173913, 0.77608695652174, -0.15
94665, 0.82608695652174, 0.77608695652174, -0.15
94666, 0.78260869565217, 0.77608695652174, -0.15
94667, 0.73913043478261, 0.77608695652174, -0.15
94668, 0.69565217391304, 0.77608695652174, -0.15
94669, 0.65217391304348, 0.77608695652174, -0.15
94670, 0.60869565217391, 0.77608695652174, -0.15
94671, 0.56521739130435, 0.77608695652174, -0.15
94672, 0.52173913043478, 0.77608695652174, -0.15
94673, 0.47826086956522, 0.77608695652174, -0.15
94674, 0.43478260869565, 0.77608695652174, -0.15
94675, 0.39130434782609, 0.77608695652174, -0.15
94676, 0.34782608695652, 0.77608695652174, -0.15
94677, 0.30434782608696, 0.77608695652174, -0.15
94678, 0.26086956521739, 0.77608695652174, -0.15
94679, 0.21739130434783, 0.77608695652174, -0.15
94680, 0.17391304347826, 0.77608695652174, -0.15
94681, 0.1304347826087, 0.77608695652174, -0.15
94682, 0.08695652173913, 0.77608695652174, -0.15
94683, 0.043478260869565, 0.77608695652174, -0.15
94684, 0.95652173913044, 0.82826086956522, -0.15
94685, 0.91304347826087, 0.82826086956522, -0.15
94686, 0.8695652173913, 0.82826086956522, -0.15
94687, 0.82608695652174, 0.82826086956522, -0.15
94688, 0.78260869565217, 0.82826086956522, -0.15
94689, 0.73913043478261, 0.82826086956522, -0.15
94690, 0.69565217391304, 0.82826086956522, -0.15
94691, 0.65217391304348, 0.82826086956522, -0.15
94692, 0.60869565217391, 0.82826086956522, -0.15
94693, 0.56521739130435, 0.82826086956522, -0.15
94694, 0.52173913043478, 0.82826086956522, -0.15
94695, 0.47826086956522, 0.82826086956522, -0.15
94696, 0.43478260869565, 0.82826086956522, -0.15
94697, 0.39130434782609, 0.82826086956522, -0.15
94698, 0.34782608695652, 0.82826086956522, -0.15
94699, 0.30434782608696, 0.82826086956522, -0.15
94700, 0.26086956521739, 0.82826086956522, -0.15
94701, 0.21739130434783, 0.82826086956522, -0.15
94702, 0.17391304347826, 0.82826086956522, -0.15
94703, 0.1304347826087, 0.82826086956522, -0.15
94704, 0.08695652173913, 0.82826086956522, -0.15
94705, 0.043478260869565, 0.82826086956522, -0.15
94706, 0.95652173913044, 0.88043478260869, -0.15
94707, 0.91304347826087, 0.88043478260869, -0.15
94708, 0.8695652173913, 0.88043478260869, -0.15
94709, 0.82608695652174, 0.8804347826087, -0.15
94710, 0.78260869565217, 0.8804347826087, -0.15
94711, 0.73913043478261, 0.88043478260869, -0.15
94712, 0.69565217391304, 0.88043478260869, -0.15
94713, 0.65217391304348, 0.8804347826087, -0.15
94714, 0.60869565217391, 0.88043478260869, -0.15
94715, 0.56521739130435, 0.88043478260869, -0.15
94716, 0.52173913043478, 0.88043478260869, -0.15
94717, 0.47826086956522, 0.88043478260869, -0.15
94718, 0.43478260869565, 0.88043478260869, -0.15
94719, 0.39130434782609, 0.88043478260869, -0.15
94720, 0.34782608695652, 0.8804347826087, -0.15
94721, 0.30434782608696, 0.8804347826087, -0.15
94722, 0.26086956521739, 0.88043478260869, -0.15
94723, 0.21739130434783, 0.88043478260869, -0.15
94724, 0.17391304347826, 0.88043478260869, -0.15
94725, 0.1304347826087, 0.88043478260869, -0.15
94726, 0.08695652173913, 0.8804347826087, -0.15
94727, 0.043478260869565, 0.88043478260869, -0.15
94728, 0.95652173913044, 0.93260869565217, -0.15
94729, 0.91304347826087, 0.93260869565217, -0.15
94730, 0.8695652173913, 0.93260869565217, -0.15
94731, 0.82608695652174, 0.93260869565217, -0.15
94732, 0.78260869565217, 0.93260869565217, -0.15
94733, 0.73913043478261, 0.93260869565217, -0.15
94734, 0.69565217391304, 0.93260869565217, -0.15
94735, 0.65217391304348, 0.93260869565217, -0.15
94736, 0.60869565217391, 0.93260869565217, -0.15
94737, 0.56521739130435, 0.93260869565217, -0.15
94738, 0.52173913043478, 0.93260869565217, -0.15
94739, 0.47826086956522, 0.93260869565217, -0.15
94740, 0.43478260869565, 0.93260869565217, -0.15
94741, 0.39130434782609, 0.93260869565217, -0.15
94742, 0.34782608695652, 0.93260869565217, -0.15
94743, 0.30434782608696, 0.93260869565217, -0.15
94744, 0.26086956521739, 0.93260869565217, -0.15
94745, 0.21739130434783, 0.93260869565217, -0.15
94746, 0.17391304347826, 0.93260869565217, -0.15
94747, 0.1304347826087, 0.93260869565217, -0.15
94748, 0.08695652173913, 0.93260869565217, -0.15
94749, 0.043478260869565, 0.93260869565217, -0.15
94750, 0.95652173913044, 0.98478260869565, -0.15
94751, 0.91304347826087, 0.98478260869565, -0.15
94752, 0.8695652173913, 0.98478260869565, -0.15
94753, 0.82608695652174, 0.98478260869565, -0.15
94754, 0.78260869565217, 0.98478260869565, -0.15
94755, 0.73913043478261, 0.98478260869565, -0.15
94756, 0.69565217391304, 0.98478260869565, -0.15
94757, 0.65217391304348, 0.98478260869565, -0.15
94758, 0.60869565217391, 0.98478260869565, -0.15
94759, 0.56521739130435, 0.98478260869565, -0.15
94760, 0.52173913043478, 0.98478260869565, -0.15
94761, 0.47826086956522, 0.98478260869565, -0.15
94762, 0.43478260869565, 0.98478260869565, -0.15
94763, 0.39130434782609, 0.98478260869565, -0.15
94764, 0.34782608695652, 0.98478260869565, -0.15
94765, 0.30434782608696, 0.98478260869565, -0.15
94766, 0.26086956521739, 0.98478260869565, -0.15
94767, 0.21739130434783, 0.98478260869565, -0.15
94768, 0.17391304347826, 0.98478260869565, -0.15
94769, 0.1304347826087, 0.98478260869565, -0.15
94770, 0.08695652173913, 0.98478260869565, -0.15
94771, 0.043478260869565, 0.98478260869565, -0.15
94772, 0.95652173913044, 1.0369565217391, -0.15
94773, 0.91304347826087, 1.0369565217391, -0.15
94774, 0.8695652173913, 1.0369565217391, -0.15
94775, 0.82608695652174, 1.0369565217391, -0.15
94776, 0.78260869565217, 1.0369565217391, -0.15
94777, 0.73913043478261, 1.0369565217391, -0.15
94778, 0.69565217391304, 1.0369565217391, -0.15
94779, 0.65217391304348, 1.0369565217391, -0.15
94780, 0.60869565217391, 1.0369565217391, -0.15
94781, 0.56521739130435, 1.0369565217391, -0.15
94782, 0.52173913043478, 1.0369565217391, -0.15
94783, 0.47826086956522, 1.0369565217391, -0.15
94784, 0.43478260869565, 1.0369565217391, -0.15
94785, 0.39130434782609, 1.0369565217391, -0.15
94786, 0.34782608695652, 1.0369565217391, -0.15
94787, 0.30434782608696, 1.0369565217391, -0.15
94788, 0.26086956521739, 1.0369565217391, -0.15
94789, 0.21739130434783, 1.0369565217391, -0.15
94790, 0.17391304347826, 1.0369565217391, -0.15
94791, 0.1304347826087, 1.0369565217391, -0.15
94792, 0.08695652173913, 1.0369565217391, -0.15
94793, 0.043478260869565, 1.0369565217391, -0.15
94794, 0.95652173913044, 1.0891304347826, -0.15
94795, 0.91304347826087, 1.0891304347826, -0.15
94796, 0.8695652173913, 1.0891304347826, -0.15
94797, 0.82608695652174, 1.0891304347826, -0.15
94798, 0.78260869565217, 1.0891304347826, -0.15
94799, 0.73913043478261, 1.0891304347826, -0.15
94800, 0.69565217391304, 1.0891304347826, -0.15
94801, 0.65217391304348, 1.0891304347826, -0.15
94802, 0.60869565217391, 1.0891304347826, -0.15
94803, 0.56521739130435, 1.0891304347826, -0.15
94804, 0.52173913043478, 1.0891304347826, -0.15
94805, 0.47826086956522, 1.0891304347826, -0.15
94806, 0.43478260869565, 1.0891304347826, -0.15
94807, 0.39130434782609, 1.0891304347826, -0.15
94808, 0.34782608695652, 1.0891304347826, -0.15
94809, 0.30434782608696, 1.0891304347826, -0.15
94810, 0.26086956521739, 1.0891304347826, -0.15
94811, 0.21739130434783, 1.0891304347826, -0.15
94812, 0.17391304347826, 1.0891304347826, -0.15
94813, 0.1304347826087, 1.0891304347826, -0.15
94814, 0.08695652173913, 1.0891304347826, -0.15
94815, 0.043478260869565, 1.0891304347826, -0.15
94816, 0.95652173913043, 1.1413043478261, -0.15
94817, 0.91304347826087, 1.1413043478261, -0.15
94818, 0.8695652173913, 1.1413043478261, -0.15
94819, 0.82608695652174, 1.1413043478261, -0.15
94820, 0.78260869565217, 1.1413043478261, -0.15
94821, 0.73913043478261, 1.1413043478261, -0.15
94822, 0.69565217391304, 1.1413043478261, -0.15
94823, 0.65217391304348, 1.1413043478261, -0.15
94824, 0.60869565217391, 1.1413043478261, -0.15
94825, 0.56521739130435, 1.1413043478261, -0.15
94826, 0.52173913043478, 1.1413043478261, -0.15
94827, 0.47826086956522, 1.1413043478261, -0.15
94828, 0.43478260869565, 1.1413043478261, -0.15
94829, 0.39130434782609, 1.1413043478261, -0.15
94830, 0.34782608695652, 1.1413043478261, -0.15
94831, 0.30434782608696, 1.1413043478261, -0.15
94832, 0.26086956521739, 1.1413043478261, -0.15
94833, 0.21739130434783, 1.1413043478261, -0.15
94834, 0.17391304347826, 1.1413043478261, -0.15
94835, 0.1304347826087, 1.1413043478261, -0.15
94836, 0.08695652173913, 1.1413043478261, -0.15
94837, 0.043478260869565, 1.1413043478261, -0.15
94838, 0.95652173913044, 1.1934782608696, -0.15
94839, 0.91304347826087, 1.1934782608696, -0.15
94840, 0.8695652173913, 1.1934782608696, -0.15
94841, 0.82608695652174, 1.1934782608696, -0.15
94842, 0.78260869565217, 1.1934782608696, -0.15
94843, 0.73913043478261, 1.1934782608696, -0.15
94844, 0.69565217391304, 1.1934782608696, -0.15
94845, 0.65217391304348, 1.1934782608696, -0.15
94846, 0.60869565217391, 1.1934782608696, -0.15
94847, 0.56521739130435, 1.1934782608696, -0.15
94848, 0.52173913043478, 1.1934782608696, -0.15
94849, 0.47826086956522, 1.1934782608696, -0.15
94850, 0.43478260869565, 1.1934782608696, -0.15
94851, 0.39130434782609, 1.1934782608696, -0.15
94852, 0.34782608695652, 1.1934782608696, -0.15
94853, 0.30434782608696, 1.1934782608696, -0.15
94854, 0.26086956521739, 1.1934782608696, -0.15
94855, 0.21739130434783, 1.1934782608696, -0.15
94856, 0.17391304347826, 1.1934782608696, -0.15
94857, 0.1304347826087, 1.1934782608696, -0.15
94858, 0.08695652173913, 1.1934782608696, -0.15
94859, 0.043478260869565, 1.1934782608696, -0.15
94860, 0.95652173913044, 1.245652173913, -0.15
94861, 0.91304347826087, 1.245652173913, -0.15
94862, 0.8695652173913, 1.245652173913, -0.15
94863, 0.82608695652174, 1.245652173913, -0.15
94864, 0.78260869565217, 1.245652173913, -0.15
94865, 0.73913043478261, 1.245652173913, -0.15
94866, 0.69565217391304, 1.245652173913, -0.15
94867, 0.65217391304348, 1.245652173913, -0.15
94868, 0.60869565217391, 1.245652173913, -0.15
94869, 0.56521739130435, 1.245652173913, -0.15
94870, 0.52173913043478, 1.245652173913, -0.15
94871, 0.47826086956522, 1.245652173913, -0.15
94872, 0.43478260869565, 1.245652173913, -0.15
94873, 0.39130434782609, 1.245652173913, -0.15
94874, 0.34782608695652, 1.245652173913, -0.15
94875, 0.30434782608696, 1.245652173913, -0.15
94876, 0.26086956521739, 1.245652173913, -0.15
94877, 0.21739130434783, 1.245652173913, -0.15
94878, 0.17391304347826, 1.245652173913, -0.15
94879, 0.1304347826087, 1.245652173913, -0.15
94880, 0.08695652173913, 1.245652173913, -0.15
94881, 0.043478260869565, 1.245652173913, -0.15
94882, 0.95652173913044, 1.2978260869565, -0.15
94883, 0.91304347826087, 1.2978260869565, -0.15
94884, 0.8695652173913, 1.2978260869565, -0.15
94885, 0.82608695652174, 1.2978260869565, -0.15
94886, 0.78260869565217, 1.2978260869565, -0.15
94887, 0.73913043478261, 1.2978260869565, -0.15
94888, 0.69565217391304, 1.2978260869565, -0.15
94889, 0.65217391304348, 1.2978260869565, -0.15
94890, 0.60869565217391, 1.2978260869565, -0.15
94891, 0.56521739130435, 1.2978260869565, -0.15
94892, 0.52173913043478, 1.2978260869565, -0.15
94893, 0.47826086956522, 1.2978260869565, -0.15
94894, 0.43478260869565, 1.2978260869565, -0.15
94895, 0.39130434782609, 1.2978260869565, -0.15
94896, 0.34782608695652, 1.2978260869565, -0.15
94897, 0.30434782608696, 1.2978260869565, -0.15
94898, 0.26086956521739, 1.2978260869565, -0.15
94899, 0.21739130434783, 1.2978260869565, -0.15
94900, 0.17391304347826, 1.2978260869565, -0.15
94901, 0.1304347826087, 1.2978260869565, -0.15
94902, 0.08695652173913, 1.2978260869565, -0.15
94903, 0.043478260869565, 1.2978260869565, -0.15
94904, 0.97826086956522, 0.20217391304348, -0.05
94905, 0.95652173913043, 0.17608695652174, -0.05
94906, 0.95652173913043, 0.20217391304348, -0.025
94907, 0.93478260869565, 0.20217391304348, -0.05
94908, 0.91304347826087, 0.17608695652174, -0.05
94909, 0.91304347826087, 0.20217391304348, -0.025
94910, 0.89130434782609, 0.20217391304348, -0.05
94911, 0.8695652173913, 0.17608695652174, -0.05
94912, 0.8695652173913, 0.20217391304348, -0.025
94913, 0.84782608695652, 0.20217391304348, -0.05
94914, 0.82608695652174, 0.17608695652174, -0.05
94915, 0.82608695652174, 0.20217391304348, -0.025
94916, 0.80434782608696, 0.20217391304348, -0.05
94917, 0.78260869565217, 0.17608695652174, -0.05
94918, 0.78260869565217, 0.20217391304348, -0.025
94919, 0.76086956521739, 0.20217391304348, -0.05
94920, 0.73913043478261, 0.17608695652174, -0.05
94921, 0.73913043478261, 0.20217391304348, -0.025
94922, 0.71739130434783, 0.20217391304348, -0.05
94923, 0.69565217391304, 0.17608695652174, -0.05
94924, 0.69565217391304, 0.20217391304348, -0.025
94925, 0.67391304347826, 0.20217391304348, -0.05
94926, 0.65217391304348, 0.17608695652174, -0.05
94927, 0.65217391304348, 0.20217391304348, -0.025
94928, 0.6304347826087, 0.20217391304348, -0.05
94929, 0.60869565217391, 0.17608695652174, -0.05
94930, 0.60869565217391, 0.20217391304348, -0.025
94931, 0.58695652173913, 0.20217391304348, -0.05
94932, 0.56521739130435, 0.17608695652174, -0.05
94933, 0.56521739130435, 0.20217391304348, -0.025
94934, 0.54347826086957, 0.20217391304348, -0.05
94935, 0.52173913043478, 0.17608695652174, -0.05
94936, 0.52173913043478, 0.20217391304348, -0.025
94937, 0.5, 0.20217391304348, -0.05
94938, 0.47826086956522, 0.17608695652174, -0.05
94939, 0.47826086956522, 0.20217391304348, -0.025
94940, 0.45652173913043, 0.20217391304348, -0.05
94941, 0.43478260869565, 0.17608695652174, -0.05
94942, 0.43478260869565, 0.20217391304348, -0.025
94943, 0.41304347826087, 0.20217391304348, -0.05
94944, 0.39130434782609, 0.17608695652174, -0.05
94945, 0.39130434782609, 0.20217391304348, -0.025
94946, 0.3695652173913, 0.20217391304348, -0.05
94947, 0.34782608695652, 0.17608695652174, -0.05
94948, 0.34782608695652, 0.20217391304348, -0.025
94949, 0.32608695652174, 0.20217391304348, -0.05
94950, 0.30434782608696, 0.17608695652174, -0.05
94951, 0.30434782608696, 0.20217391304348, -0.025
94952, 0.28260869565217, 0.20217391304348, -0.05
94953, 0.26086956521739, 0.17608695652174, -0.05
94954, 0.26086956521739, 0.20217391304348, -0.025
94955, 0.23913043478261, 0.20217391304348, -0.05
94956, 0.21739130434783, 0.17608695652174, -0.05
94957, 0.21739130434783, 0.20217391304348, -0.025
94958, 0.19565217391304, 0.20217391304348, -0.05
94959, 0.17391304347826, 0.17608695652174, -0.05
94960, 0.17391304347826, 0.20217391304348, -0.025
94961, 0.15217391304348, 0.20217391304348, -0.05
94962, 0.1304347826087, 0.17608695652174, -0.05
94963, 0.1304347826087, 0.20217391304348, -0.025
94964, 0.10869565217391, 0.20217391304348, -0.05
94965, 0.08695652173913, 0.17608695652174, -0.05
94966, 0.08695652173913, 0.20217391304348, -0.025
94967, 0.065217391304348, 0.20217391304348, -0.05
94968, 0.043478260869565, 0.17608695652174, -0.05
94969, 0.043478260869565, 0.20217391304348, -0.025
94970, 0.021739130434783, 0.20217391304348, -0.05
94971, 0.97826086956522, 0.25434782608696, -0.05
94972, 0.95652173913043, 0.22826086956522, -0.05
94973, 0.95652173913043, 0.25434782608696, -0.025
94974, 0.93478260869565, 0.25434782608696, -0.05
94975, 0.91304347826087, 0.22826086956522, -0.05
94976, 0.91304347826087, 0.25434782608696, -0.025
94977, 0.89130434782609, 0.25434782608696, -0.05
94978, 0.8695652173913, 0.22826086956522, -0.05
94979, 0.8695652173913, 0.25434782608696, -0.025
94980, 0.84782608695652, 0.25434782608696, -0.05
94981, 0.82608695652174, 0.22826086956522, -0.05
94982, 0.82608695652174, 0.25434782608696, -0.025
94983, 0.80434782608696, 0.25434782608696, -0.05
94984, 0.78260869565217, 0.22826086956522, -0.05
94985, 0.78260869565217, 0.25434782608696, -0.025
94986, 0.76086956521739, 0.25434782608696, -0.05
94987, 0.73913043478261, 0.22826086956522, -0.05
94988, 0.73913043478261, 0.25434782608696, -0.025
94989, 0.71739130434783, 0.25434782608696, -0.05
94990, 0.69565217391304, 0.22826086956522, -0.05
94991, 0.69565217391304, 0.25434782608696, -0.025
94992, 0.67391304347826, 0.25434782608696, -0.05
94993, 0.65217391304348, 0.22826086956522, -0.05
94994, 0.65217391304348, 0.25434782608696, -0.025
94995, 0.6304347826087, 0.25434782608696, -0.05
94996, 0.60869565217391, 0.22826086956522, -0.05
94997, 0.60869565217391, 0.25434782608696, -0.025
94998, 0.58695652173913, 0.25434782608696, -0.05
94999, 0.56521739130435, 0.22826086956522, -0.05
95000, 0.56521739130435, 0.25434782608696, -0.025
95001, 0.54347826086957, 0.25434782608696, -0.05
95002, 0.52173913043478, 0.22826086956522, -0.05
95003, 0.52173913043478, 0.25434782608696, -0.025
95004, 0.5, 0.25434782608696, -0.05
95005, 0.47826086956522, 0.22826086956522, -0.05
95006, 0.47826086956522, 0.25434782608696, -0.025
95007, 0.45652173913044, 0.25434782608696, -0.05
95008, 0.43478260869565, 0.22826086956522, -0.05
95009, 0.43478260869565, 0.25434782608696, -0.025
95010, 0.41304347826087, 0.25434782608696, -0.05
95011, 0.39130434782609, 0.22826086956522, -0.05
95012, 0.39130434782609, 0.25434782608696, -0.025
95013, 0.3695652173913, 0.25434782608696, -0.05
95014, 0.34782608695652, 0.22826086956522, -0.05
95015, 0.34782608695652, 0.25434782608696, -0.025
95016, 0.32608695652174, 0.25434782608696, -0.05
95017, 0.30434782608696, 0.22826086956522, -0.05
95018, 0.30434782608696, 0.25434782608696, -0.025
95019, 0.28260869565217, 0.25434782608696, -0.05
95020, 0.26086956521739, 0.22826086956522, -0.05
95021, 0.26086956521739, 0.25434782608696, -0.025
95022, 0.23913043478261, 0.25434782608696, -0.05
95023, 0.21739130434783, 0.22826086956522, -0.05
95024, 0.21739130434783, 0.25434782608696, -0.025
95025, 0.19565217391304, 0.25434782608696, -0.05
95026, 0.17391304347826, 0.22826086956522, -0.05
95027, 0.17391304347826, 0.25434782608696, -0.025
95028, 0.15217391304348, 0.25434782608696, -0.05
95029, 0.1304347826087, 0.22826086956522, -0.05
95030, 0.1304347826087, 0.25434782608696, -0.025
95031, 0.10869565217391, 0.25434782608696, -0.05
95032, 0.08695652173913, 0.22826086956522, -0.05
95033, 0.08695652173913, 0.25434782608696, -0.025
95034, 0.065217391304348, 0.25434782608696, -0.05
95035, 0.043478260869565, 0.22826086956522, -0.05
95036, 0.043478260869565, 0.25434782608696, -0.025
95037, 0.021739130434783, 0.25434782608696, -0.05
95038, 0.97826086956522, 0.30652173913043, -0.05
95039, 0.95652173913043, 0.2804347826087, -0.05
95040, 0.95652173913044, 0.30652173913043, -0.025
95041, 0.93478260869565, 0.30652173913043, -0.05
95042, 0.91304347826087, 0.2804347826087, -0.05
95043, 0.91304347826087, 0.30652173913043, -0.025
95044, 0.89130434782609, 0.30652173913043, -0.05
95045, 0.8695652173913, 0.2804347826087, -0.05
95046, 0.8695652173913, 0.30652173913043, -0.025
95047, 0.84782608695652, 0.30652173913043, -0.05
95048, 0.82608695652174, 0.2804347826087, -0.05
95049, 0.82608695652174, 0.30652173913043, -0.025
95050, 0.80434782608696, 0.30652173913043, -0.05
95051, 0.78260869565217, 0.2804347826087, -0.05
95052, 0.78260869565217, 0.30652173913043, -0.025
95053, 0.76086956521739, 0.30652173913043, -0.05
95054, 0.73913043478261, 0.2804347826087, -0.05
95055, 0.73913043478261, 0.30652173913043, -0.025
95056, 0.71739130434783, 0.30652173913043, -0.05
95057, 0.69565217391304, 0.2804347826087, -0.05
95058, 0.69565217391304, 0.30652173913043, -0.025
95059, 0.67391304347826, 0.30652173913043, -0.05
95060, 0.65217391304348, 0.2804347826087, -0.05
95061, 0.65217391304348, 0.30652173913043, -0.025
95062, 0.6304347826087, 0.30652173913043, -0.05
95063, 0.60869565217391, 0.2804347826087, -0.05
95064, 0.60869565217391, 0.30652173913043, -0.025
95065, 0.58695652173913, 0.30652173913043, -0.05
95066, 0.56521739130435, 0.2804347826087, -0.05
95067, 0.56521739130435, 0.30652173913043, -0.025
95068, 0.54347826086957, 0.30652173913043, -0.05
95069, 0.52173913043478, 0.2804347826087, -0.05
95070, 0.52173913043478, 0.30652173913043, -0.025
95071, 0.5, 0.30652173913043, -0.05
95072, 0.47826086956522, 0.2804347826087, -0.05
95073, 0.47826086956522, 0.30652173913043, -0.025
95074, 0.45652173913043, 0.30652173913043, -0.05
95075, 0.43478260869565, 0.2804347826087, -0.05
95076, 0.43478260869565, 0.30652173913043, -0.025
95077, 0.41304347826087, 0.30652173913043, -0.05
95078, 0.39130434782609, 0.2804347826087, -0.05
95079, 0.39130434782609, 0.30652173913043, -0.025
95080, 0.3695652173913, 0.30652173913043, -0.05
95081, 0.34782608695652, 0.2804347826087, -0.05
95082, 0.34782608695652, 0.30652173913043, -0.025
95083, 0.32608695652174, 0.30652173913043, -0.05
95084, 0.30434782608696, 0.2804347826087, -0.05
95085, 0.30434782608696, 0.30652173913043, -0.025
95086, 0.28260869565217, 0.30652173913043, -0.05
95087, 0.26086956521739, 0.2804347826087, -0.05
95088, 0.26086956521739, 0.30652173913043, -0.025
95089, 0.23913043478261, 0.30652173913043, -0.05
95090, 0.21739130434783, 0.2804347826087, -0.05
95091, 0.21739130434783, 0.30652173913043, -0.025
95092, 0.19565217391304, 0.30652173913043, -0.05
95093, 0.17391304347826, 0.2804347826087, -0.05
95094, 0.17391304347826, 0.30652173913043, -0.025
95095, 0.15217391304348, 0.30652173913043, -0.05
95096, 0.1304347826087, 0.2804347826087, -0.05
95097, 0.1304347826087, 0.30652173913043, -0.025
95098, 0.10869565217391, 0.30652173913043, -0.05
95099, 0.08695652173913, 0.2804347826087, -0.05
95100, 0.08695652173913, 0.30652173913043, -0.025
95101, 0.065217391304348, 0.30652173913043, -0.05
95102, 0.043478260869565, 0.2804347826087, -0.05
95103, 0.043478260869565, 0.30652173913043, -0.025
95104, 0.021739130434783, 0.30652173913043, -0.05
95105, 0.97826086956522, 0.35869565217391, -0.05
95106, 0.95652173913044, 0.33260869565217, -0.05
95107, 0.95652173913043, 0.35869565217391, -0.025
95108, 0.93478260869565, 0.35869565217391, -0.05
95109, 0.91304347826087, 0.33260869565217, -0.05
95110, 0.91304347826087, 0.35869565217391, -0.025
95111, 0.89130434782609, 0.35869565217391, -0.05
95112, 0.8695652173913, 0.33260869565217, -0.05
95113, 0.8695652173913, 0.35869565217391, -0.025
95114, 0.84782608695652, 0.35869565217391, -0.05
95115, 0.82608695652174, 0.33260869565217, -0.05
95116, 0.82608695652174, 0.35869565217391, -0.025
95117, 0.80434782608696, 0.35869565217391, -0.05
95118, 0.78260869565217, 0.33260869565217, -0.05
95119, 0.78260869565217, 0.35869565217391, -0.025
95120, 0.76086956521739, 0.35869565217391, -0.05
95121, 0.73913043478261, 0.33260869565217, -0.05
95122, 0.73913043478261, 0.35869565217391, -0.025
95123, 0.71739130434783, 0.35869565217391, -0.05
95124, 0.69565217391304, 0.33260869565217, -0.05
95125, 0.69565217391304, 0.35869565217391, -0.025
95126, 0.67391304347826, 0.35869565217391, -0.05
95127, 0.65217391304348, 0.33260869565217, -0.05
95128, 0.65217391304348, 0.35869565217391, -0.025
95129, 0.6304347826087, 0.35869565217391, -0.05
95130, 0.60869565217391, 0.33260869565217, -0.05
95131, 0.60869565217391, 0.35869565217391, -0.025
95132, 0.58695652173913, 0.35869565217391, -0.05
95133, 0.56521739130435, 0.33260869565217, -0.05
95134, 0.56521739130435, 0.35869565217391, -0.025
95135, 0.54347826086957, 0.35869565217391, -0.05
95136, 0.52173913043478, 0.33260869565217, -0.05
95137, 0.52173913043478, 0.35869565217391, -0.025
95138, 0.5, 0.35869565217391, -0.05
95139, 0.47826086956522, 0.33260869565217, -0.05
95140, 0.47826086956522, 0.35869565217391, -0.025
95141, 0.45652173913044, 0.35869565217391, -0.05
95142, 0.43478260869565, 0.33260869565217, -0.05
95143, 0.43478260869565, 0.35869565217391, -0.025
95144, 0.41304347826087, 0.35869565217391, -0.05
95145, 0.39130434782609, 0.33260869565217, -0.05
95146, 0.39130434782609, 0.35869565217391, -0.025
95147, 0.3695652173913, 0.35869565217391, -0.05
95148, 0.34782608695652, 0.33260869565217, -0.05
95149, 0.34782608695652, 0.35869565217391, -0.025
95150, 0.32608695652174, 0.35869565217391, -0.05
95151, 0.30434782608696, 0.33260869565217, -0.05
95152, 0.30434782608696, 0.35869565217391, -0.025
95153, 0.28260869565217, 0.35869565217391, -0.05
95154, 0.26086956521739, 0.33260869565217, -0.05
95155, 0.26086956521739, 0.35869565217391, -0.025
95156, 0.23913043478261, 0.35869565217391, -0.05
95157, 0.21739130434783, 0.33260869565217, -0.05
95158, 0.21739130434783, 0.35869565217391, -0.025
95159, 0.19565217391304, 0.35869565217391, -0.05
95160, 0.17391304347826, 0.33260869565217, -0.05
95161, 0.17391304347826, 0.35869565217391, -0.025
95162, 0.15217391304348, 0.35869565217391, -0.05
95163, 0.1304347826087, 0.33260869565217, -0.05
95164, 0.1304347826087, 0.35869565217391, -0.025
95165, 0.10869565217391, 0.35869565217391, -0.05
95166, 0.08695652173913, 0.33260869565217, -0.05
95167, 0.08695652173913, 0.35869565217391, -0.025
95168, 0.065217391304348, 0.35869565217391, -0.05
95169, 0.043478260869565, 0.33260869565217, -0.05
95170, 0.043478260869565, 0.35869565217391, -0.025
95171, 0.021739130434783, 0.35869565217391, -0.05
95172, 0.97826086956522, 0.41086956521739, -0.05
95173, 0.95652173913043, 0.38478260869565, -0.05
95174, 0.95652173913043, 0.41086956521739, -0.025
95175, 0.93478260869565, 0.41086956521739, -0.05
95176, 0.91304347826087, 0.38478260869565, -0.05
95177, 0.91304347826087, 0.41086956521739, -0.025
95178, 0.89130434782609, 0.41086956521739, -0.05
95179, 0.8695652173913, 0.38478260869565, -0.05
95180, 0.8695652173913, 0.41086956521739, -0.025
95181, 0.84782608695652, 0.41086956521739, -0.05
95182, 0.82608695652174, 0.38478260869565, -0.05
95183, 0.82608695652174, 0.41086956521739, -0.025
95184, 0.80434782608696, 0.41086956521739, -0.05
95185, 0.78260869565217, 0.38478260869565, -0.05
95186, 0.78260869565217, 0.41086956521739, -0.025
95187, 0.76086956521739, 0.41086956521739, -0.05
95188, 0.73913043478261, 0.38478260869565, -0.05
95189, 0.73913043478261, 0.41086956521739, -0.025
95190, 0.71739130434783, 0.41086956521739, -0.05
95191, 0.69565217391304, 0.38478260869565, -0.05
95192, 0.69565217391304, 0.41086956521739, -0.025
95193, 0.67391304347826, 0.41086956521739, -0.05
95194, 0.65217391304348, 0.38478260869565, -0.05
95195, 0.65217391304348, 0.41086956521739, -0.025
95196, 0.6304347826087, 0.41086956521739, -0.05
95197, 0.60869565217391, 0.38478260869565, -0.05
95198, 0.60869565217391, 0.41086956521739, -0.025
95199, 0.58695652173913, 0.41086956521739, -0.05
95200, 0.56521739130435, 0.38478260869565, -0.05
95201, 0.56521739130435, 0.41086956521739, -0.025
95202, 0.54347826086956, 0.41086956521739, -0.05
95203, 0.52173913043478, 0.38478260869565, -0.05
95204, 0.52173913043478, 0.41086956521739, -0.025
95205, 0.5, 0.41086956521739, -0.05
95206, 0.47826086956522, 0.38478260869565, -0.05
95207, 0.47826086956522, 0.41086956521739, -0.025
95208, 0.45652173913043, 0.41086956521739, -0.05
95209, 0.43478260869565, 0.38478260869565, -0.05
95210, 0.43478260869565, 0.41086956521739, -0.025
95211, 0.41304347826087, 0.41086956521739, -0.05
95212, 0.39130434782609, 0.38478260869565, -0.05
95213, 0.39130434782609, 0.41086956521739, -0.025
95214, 0.3695652173913, 0.41086956521739, -0.05
95215, 0.34782608695652, 0.38478260869565, -0.05
95216, 0.34782608695652, 0.41086956521739, -0.025
95217, 0.32608695652174, 0.41086956521739, -0.05
95218, 0.30434782608696, 0.38478260869565, -0.05
95219, 0.30434782608696, 0.41086956521739, -0.025
95220, 0.28260869565217, 0.41086956521739, -0.05
95221, 0.26086956521739, 0.38478260869565, -0.05
95222, 0.26086956521739, 0.41086956521739, -0.025
95223, 0.23913043478261, 0.41086956521739, -0.05
95224, 0.21739130434783, 0.38478260869565, -0.05
95225, 0.21739130434783, 0.41086956521739, -0.025
95226, 0.19565217391304, 0.41086956521739, -0.05
95227, 0.17391304347826, 0.38478260869565, -0.05
95228, 0.17391304347826, 0.41086956521739, -0.025
95229, 0.15217391304348, 0.41086956521739, -0.05
95230, 0.1304347826087, 0.38478260869565, -0.05
95231, 0.1304347826087, 0.41086956521739, -0.025
95232, 0.10869565217391, 0.41086956521739, -0.05
95233, 0.08695652173913, 0.38478260869565, -0.05
95234, 0.08695652173913, 0.41086956521739, -0.025
95235, 0.065217391304348, 0.41086956521739, -0.05
95236, 0.043478260869565, 0.38478260869565, -0.05
95237, 0.043478260869565, 0.41086956521739, -0.025
95238, 0.021739130434783, 0.41086956521739, -0.05
95239, 0.97826086956522, 0.46304347826087, -0.05
95240, 0.95652173913043, 0.43695652173913, -0.05
95241, 0.95652173913043, 0.46304347826087, -0.025
95242, 0.93478260869565, 0.46304347826087, -0.05
95243, 0.91304347826087, 0.43695652173913, -0.05
95244, 0.91304347826087, 0.46304347826087, -0.025
95245, 0.89130434782609, 0.46304347826087, -0.05
95246, 0.8695652173913, 0.43695652173913, -0.05
95247, 0.8695652173913, 0.46304347826087, -0.025
95248, 0.84782608695652, 0.46304347826087, -0.05
95249, 0.82608695652174, 0.43695652173913, -0.05
95250, 0.82608695652174, 0.46304347826087, -0.025
95251, 0.80434782608696, 0.46304347826087, -0.05
95252, 0.78260869565217, 0.43695652173913, -0.05
95253, 0.78260869565217, 0.46304347826087, -0.025
95254, 0.76086956521739, 0.46304347826087, -0.05
95255, 0.73913043478261, 0.43695652173913, -0.05
95256, 0.73913043478261, 0.46304347826087, -0.025
95257, 0.71739130434783, 0.46304347826087, -0.05
95258, 0.69565217391304, 0.43695652173913, -0.05
95259, 0.69565217391304, 0.46304347826087, -0.025
95260, 0.67391304347826, 0.46304347826087, -0.05
95261, 0.65217391304348, 0.43695652173913, -0.05
95262, 0.65217391304348, 0.46304347826087, -0.025
95263, 0.6304347826087, 0.46304347826087, -0.05
95264, 0.60869565217391, 0.43695652173913, -0.05
95265, 0.60869565217391, 0.46304347826087, -0.025
95266, 0.58695652173913, 0.46304347826087, -0.05
95267, 0.56521739130435, 0.43695652173913, -0.05
95268, 0.56521739130435, 0.46304347826087, -0.025
95269, 0.54347826086957, 0.46304347826087, -0.05
95270, 0.52173913043478, 0.43695652173913, -0.05
95271, 0.52173913043478, 0.46304347826087, -0.025
95272, 0.5, 0.46304347826087, -0.05
95273, 0.47826086956522, 0.43695652173913, -0.05
95274, 0.47826086956522, 0.46304347826087, -0.025
95275, 0.45652173913044, 0.46304347826087, -0.05
95276, 0.43478260869565, 0.43695652173913, -0.05
95277, 0.43478260869565, 0.46304347826087, -0.025
95278, 0.41304347826087, 0.46304347826087, -0.05
95279, 0.39130434782609, 0.43695652173913, -0.05
95280, 0.39130434782609, 0.46304347826087, -0.025
95281, 0.3695652173913, 0.46304347826087, -0.05
95282, 0.34782608695652, 0.43695652173913, -0.05
95283, 0.34782608695652, 0.46304347826087, -0.025
95284, 0.32608695652174, 0.46304347826087, -0.05
95285, 0.30434782608696, 0.43695652173913, -0.05
95286, 0.30434782608696, 0.46304347826087, -0.025
95287, 0.28260869565217, 0.46304347826087, -0.05
95288, 0.26086956521739, 0.43695652173913, -0.05
95289, 0.26086956521739, 0.46304347826087, -0.025
95290, 0.23913043478261, 0.46304347826087, -0.05
95291, 0.21739130434783, 0.43695652173913, -0.05
95292, 0.21739130434783, 0.46304347826087, -0.025
95293, 0.19565217391304, 0.46304347826087, -0.05
95294, 0.17391304347826, 0.43695652173913, -0.05
95295, 0.17391304347826, 0.46304347826087, -0.025
95296, 0.15217391304348, 0.46304347826087, -0.05
95297, 0.1304347826087, 0.43695652173913, -0.05
95298, 0.1304347826087, 0.46304347826087, -0.025
95299, 0.10869565217391, 0.46304347826087, -0.05
95300, 0.08695652173913, 0.43695652173913, -0.05
95301, 0.08695652173913, 0.46304347826087, -0.025
95302, 0.065217391304348, 0.46304347826087, -0.05
95303, 0.043478260869565, 0.43695652173913, -0.05
95304, 0.043478260869565, 0.46304347826087, -0.025
95305, 0.021739130434783, 0.46304347826087, -0.05
95306, 0.97826086956522, 0.51521739130435, -0.05
95307, 0.95652173913043, 0.48913043478261, -0.05
95308, 0.95652173913043, 0.51521739130435, -0.025
95309, 0.93478260869565, 0.51521739130435, -0.05
95310, 0.91304347826087, 0.48913043478261, -0.05
95311, 0.91304347826087, 0.51521739130435, -0.025
95312, 0.89130434782609, 0.51521739130435, -0.05
95313, 0.8695652173913, 0.48913043478261, -0.05
95314, 0.8695652173913, 0.51521739130435, -0.025
95315, 0.84782608695652, 0.51521739130435, -0.05
95316, 0.82608695652174, 0.48913043478261, -0.05
95317, 0.82608695652174, 0.51521739130435, -0.025
95318, 0.80434782608696, 0.51521739130435, -0.05
95319, 0.78260869565217, 0.48913043478261, -0.05
95320, 0.78260869565217, 0.51521739130435, -0.025
95321, 0.76086956521739, 0.51521739130435, -0.05
95322, 0.73913043478261, 0.48913043478261, -0.05
95323, 0.73913043478261, 0.51521739130435, -0.025
95324, 0.71739130434783, 0.51521739130435, -0.05
95325, 0.69565217391304, 0.48913043478261, -0.05
95326, 0.69565217391304, 0.51521739130435, -0.025
95327, 0.67391304347826, 0.51521739130435, -0.05
95328, 0.65217391304348, 0.48913043478261, -0.05
95329, 0.65217391304348, 0.51521739130435, -0.025
95330, 0.6304347826087, 0.51521739130435, -0.05
95331, 0.60869565217391, 0.48913043478261, -0.05
95332, 0.60869565217391, 0.51521739130435, -0.025
95333, 0.58695652173913, 0.51521739130435, -0.05
95334, 0.56521739130435, 0.48913043478261, -0.05
95335, 0.56521739130435, 0.51521739130435, -0.025
95336, 0.54347826086956, 0.51521739130435, -0.05
95337, 0.52173913043478, 0.48913043478261, -0.05
95338, 0.52173913043478, 0.51521739130435, -0.025
95339, 0.5, 0.51521739130435, -0.05
95340, 0.47826086956522, 0.48913043478261, -0.05
95341, 0.47826086956522, 0.51521739130435, -0.025
95342, 0.45652173913044, 0.51521739130435, -0.05
95343, 0.43478260869565, 0.48913043478261, -0.05
95344, 0.43478260869565, 0.51521739130435, -0.025
95345, 0.41304347826087, 0.51521739130435, -0.05
95346, 0.39130434782609, 0.48913043478261, -0.05
95347, 0.39130434782609, 0.51521739130435, -0.025
95348, 0.3695652173913, 0.51521739130435, -0.05
95349, 0.34782608695652, 0.48913043478261, -0.05
95350, 0.34782608695652, 0.51521739130435, -0.025
95351, 0.32608695652174, 0.51521739130435, -0.05
95352, 0.30434782608696, 0.48913043478261, -0.05
95353, 0.30434782608696, 0.51521739130435, -0.025
95354, 0.28260869565217, 0.51521739130435, -0.05
95355, 0.26086956521739, 0.48913043478261, -0.05
95356, 0.26086956521739, 0.51521739130435, -0.025
95357, 0.23913043478261, 0.51521739130435, -0.05
95358, 0.21739130434783, 0.48913043478261, -0.05
95359, 0.21739130434783, 0.51521739130435, -0.025
95360, 0.19565217391304, 0.51521739130435, -0.05
95361, 0.17391304347826, 0.48913043478261, -0.05
95362, 0.17391304347826, 0.51521739130435, -0.025
95363, 0.15217391304348, 0.51521739130435, -0.05
95364, 0.1304347826087, 0.48913043478261, -0.05
95365, 0.1304347826087, 0.51521739130435, -0.025
95366, 0.10869565217391, 0.51521739130435, -0.05
95367, 0.08695652173913, 0.48913043478261, -0.05
95368, 0.08695652173913, 0.51521739130435, -0.025
95369, 0.065217391304348, 0.51521739130435, -0.05
95370, 0.043478260869565, 0.48913043478261, -0.05
95371, 0.043478260869565, 0.51521739130435, -0.025
95372, 0.021739130434783, 0.51521739130435, -0.05
95373, 0.97826086956522, 0.56739130434783, -0.05
95374, 0.95652173913043, 0.54130434782609, -0.05
95375, 0.95652173913043, 0.56739130434783, -0.025
95376, 0.93478260869565, 0.56739130434783, -0.05
95377, 0.91304347826087, 0.54130434782609, -0.05
95378, 0.91304347826087, 0.56739130434783, -0.025
95379, 0.89130434782609, 0.56739130434783, -0.05
95380, 0.8695652173913, 0.54130434782609, -0.05
95381, 0.8695652173913, 0.56739130434783, -0.025
95382, 0.84782608695652, 0.56739130434783, -0.05
95383, 0.82608695652174, 0.54130434782609, -0.05
95384, 0.82608695652174, 0.56739130434783, -0.025
95385, 0.80434782608696, 0.56739130434783, -0.05
95386, 0.78260869565217, 0.54130434782609, -0.05
95387, 0.78260869565217, 0.56739130434783, -0.025
95388, 0.76086956521739, 0.56739130434783, -0.05
95389, 0.73913043478261, 0.54130434782609, -0.05
95390, 0.73913043478261, 0.56739130434783, -0.025
95391, 0.71739130434783, 0.56739130434783, -0.05
95392, 0.69565217391304, 0.54130434782609, -0.05
95393, 0.69565217391304, 0.56739130434783, -0.025
95394, 0.67391304347826, 0.56739130434783, -0.05
95395, 0.65217391304348, 0.54130434782609, -0.05
95396, 0.65217391304348, 0.56739130434783, -0.025
95397, 0.6304347826087, 0.56739130434783, -0.05
95398, 0.60869565217391, 0.54130434782609, -0.05
95399, 0.60869565217391, 0.56739130434783, -0.025
95400, 0.58695652173913, 0.56739130434783, -0.05
95401, 0.56521739130435, 0.54130434782609, -0.05
95402, 0.56521739130435, 0.56739130434783, -0.025
95403, 0.54347826086957, 0.56739130434783, -0.05
95404, 0.52173913043478, 0.54130434782609, -0.05
95405, 0.52173913043478, 0.56739130434783, -0.025
95406, 0.5, 0.56739130434783, -0.05
95407, 0.47826086956522, 0.54130434782609, -0.05
95408, 0.47826086956522, 0.56739130434783, -0.025
95409, 0.45652173913043, 0.56739130434783, -0.05
95410, 0.43478260869565, 0.54130434782609, -0.05
95411, 0.43478260869565, 0.56739130434783, -0.025
95412, 0.41304347826087, 0.56739130434783, -0.05
95413, 0.39130434782609, 0.54130434782609, -0.05
95414, 0.39130434782609, 0.56739130434783, -0.025
95415, 0.3695652173913, 0.56739130434783, -0.05
95416, 0.34782608695652, 0.54130434782609, -0.05
95417, 0.34782608695652, 0.56739130434783, -0.025
95418, 0.32608695652174, 0.56739130434783, -0.05
95419, 0.30434782608696, 0.54130434782609, -0.05
95420, 0.30434782608696, 0.56739130434783, -0.025
95421, 0.28260869565217, 0.56739130434783, -0.05
95422, 0.26086956521739, 0.54130434782609, -0.05
95423, 0.26086956521739, 0.56739130434783, -0.025
95424, 0.23913043478261, 0.56739130434783, -0.05
95425, 0.21739130434783, 0.54130434782609, -0.05
95426, 0.21739130434783, 0.56739130434783, -0.025
95427, 0.19565217391304, 0.56739130434783, -0.05
95428, 0.17391304347826, 0.54130434782609, -0.05
95429, 0.17391304347826, 0.56739130434783, -0.025
95430, 0.15217391304348, 0.56739130434783, -0.05
95431, 0.1304347826087, 0.54130434782609, -0.05
95432, 0.1304347826087, 0.56739130434783, -0.025
95433, 0.10869565217391, 0.56739130434783, -0.05
95434, 0.08695652173913, 0.54130434782609, -0.05
95435, 0.08695652173913, 0.56739130434783, -0.025
95436, 0.065217391304348, 0.56739130434783, -0.05
95437, 0.043478260869565, 0.54130434782609, -0.05
95438, 0.043478260869565, 0.56739130434783, -0.025
95439, 0.021739130434783, 0.56739130434783, -0.05
95440, 0.97826086956522, 0.6195652173913, -0.05
95441, 0.95652173913043, 0.59347826086956, -0.05
95442, 0.95652173913043, 0.6195652173913, -0.025
95443, 0.93478260869565, 0.6195652173913, -0.05
95444, 0.91304347826087, 0.59347826086956, -0.05
95445, 0.91304347826087, 0.6195652173913, -0.025
95446, 0.89130434782609, 0.6195652173913, -0.05
95447, 0.8695652173913, 0.59347826086956, -0.05
95448, 0.8695652173913, 0.6195652173913, -0.025
95449, 0.84782608695652, 0.6195652173913, -0.05
95450, 0.82608695652174, 0.59347826086956, -0.05
95451, 0.82608695652174, 0.6195652173913, -0.025
95452, 0.80434782608696, 0.6195652173913, -0.05
95453, 0.78260869565217, 0.59347826086956, -0.05
95454, 0.78260869565217, 0.6195652173913, -0.025
95455, 0.76086956521739, 0.6195652173913, -0.05
95456, 0.73913043478261, 0.59347826086956, -0.05
95457, 0.73913043478261, 0.6195652173913, -0.025
95458, 0.71739130434783, 0.6195652173913, -0.05
95459, 0.69565217391304, 0.59347826086956, -0.05
95460, 0.69565217391304, 0.6195652173913, -0.025
95461, 0.67391304347826, 0.6195652173913, -0.05
95462, 0.65217391304348, 0.59347826086956, -0.05
95463, 0.65217391304348, 0.6195652173913, -0.025
95464, 0.6304347826087, 0.6195652173913, -0.05
95465, 0.60869565217391, 0.59347826086956, -0.05
95466, 0.60869565217391, 0.6195652173913, -0.025
95467, 0.58695652173913, 0.6195652173913, -0.05
95468, 0.56521739130435, 0.59347826086956, -0.05
95469, 0.56521739130435, 0.6195652173913, -0.025
95470, 0.54347826086957, 0.6195652173913, -0.05
95471, 0.52173913043478, 0.59347826086956, -0.05
95472, 0.52173913043478, 0.6195652173913, -0.025
95473, 0.5, 0.6195652173913, -0.05
95474, 0.47826086956522, 0.59347826086956, -0.05
95475, 0.47826086956522, 0.6195652173913, -0.025
95476, 0.45652173913043, 0.6195652173913, -0.05
95477, 0.43478260869565, 0.59347826086956, -0.05
95478, 0.43478260869565, 0.6195652173913, -0.025
95479, 0.41304347826087, 0.6195652173913, -0.05
95480, 0.39130434782609, 0.59347826086956, -0.05
95481, 0.39130434782609, 0.6195652173913, -0.025
95482, 0.3695652173913, 0.6195652173913, -0.05
95483, 0.34782608695652, 0.59347826086956, -0.05
95484, 0.34782608695652, 0.6195652173913, -0.025
95485, 0.32608695652174, 0.6195652173913, -0.05
95486, 0.30434782608696, 0.59347826086956, -0.05
95487, 0.30434782608696, 0.6195652173913, -0.025
95488, 0.28260869565217, 0.6195652173913, -0.05
95489, 0.26086956521739, 0.59347826086956, -0.05
95490, 0.26086956521739, 0.6195652173913, -0.025
95491, 0.23913043478261, 0.6195652173913, -0.05
95492, 0.21739130434783, 0.59347826086956, -0.05
95493, 0.21739130434783, 0.6195652173913, -0.025
95494, 0.19565217391304, 0.6195652173913, -0.05
95495, 0.17391304347826, 0.59347826086956, -0.05
95496, 0.17391304347826, 0.6195652173913, -0.025
95497, 0.15217391304348, 0.6195652173913, -0.05
95498, 0.1304347826087, 0.59347826086956, -0.05
95499, 0.1304347826087, 0.6195652173913, -0.025
95500, 0.10869565217391, 0.6195652173913, -0.05
95501, 0.08695652173913, 0.59347826086956, -0.05
95502, 0.08695652173913, 0.6195652173913, -0.025
95503, 0.065217391304348, 0.6195652173913, -0.05
95504, 0.043478260869565, 0.59347826086956, -0.05
95505, 0.043478260869565, 0.6195652173913, -0.025
95506, 0.021739130434783, 0.6195652173913, -0.05
95507, 0.97826086956522, 0.67173913043478, -0.05
95508, 0.95652173913043, 0.64565217391304, -0.05
95509, 0.95652173913043, 0.67173913043478, -0.025
95510, 0.93478260869565, 0.67173913043478, -0.05
95511, 0.91304347826087, 0.64565217391304, -0.05
95512, 0.91304347826087, 0.67173913043478, -0.025
95513, 0.89130434782609, 0.67173913043478, -0.05
95514, 0.8695652173913, 0.64565217391304, -0.05
95515, 0.8695652173913, 0.67173913043478, -0.025
95516, 0.84782608695652, 0.67173913043478, -0.05
95517, 0.82608695652174, 0.64565217391304, -0.05
95518, 0.82608695652174, 0.67173913043478, -0.025
95519, 0.80434782608696, 0.67173913043478, -0.05
95520, 0.78260869565217, 0.64565217391304, -0.05
95521, 0.78260869565217, 0.67173913043478, -0.025
95522, 0.76086956521739, 0.67173913043478, -0.05
95523, 0.73913043478261, 0.64565217391304, -0.05
95524, 0.73913043478261, 0.67173913043478, -0.025
95525, 0.71739130434783, 0.67173913043478, -0.05
95526, 0.69565217391304, 0.64565217391304, -0.05
95527, 0.69565217391304, 0.67173913043478, -0.025
95528, 0.67391304347826, 0.67173913043478, -0.05
95529, 0.65217391304348, 0.64565217391304, -0.05
95530, 0.65217391304348, 0.67173913043478, -0.025
95531, 0.6304347826087, 0.67173913043478, -0.05
95532, 0.60869565217391, 0.64565217391304, -0.05
95533, 0.60869565217391, 0.67173913043478, -0.025
95534, 0.58695652173913, 0.67173913043478, -0.05
95535, 0.56521739130435, 0.64565217391304, -0.05
95536, 0.56521739130435, 0.67173913043478, -0.025
95537, 0.54347826086957, 0.67173913043478, -0.05
95538, 0.52173913043478, 0.64565217391304, -0.05
95539, 0.52173913043478, 0.67173913043478, -0.025
95540, 0.5, 0.67173913043478, -0.05
95541, 0.47826086956522, 0.64565217391304, -0.05
95542, 0.47826086956522, 0.67173913043478, -0.025
95543, 0.45652173913043, 0.67173913043478, -0.05
95544, 0.43478260869565, 0.64565217391304, -0.05
95545, 0.43478260869565, 0.67173913043478, -0.025
95546, 0.41304347826087, 0.67173913043478, -0.05
95547, 0.39130434782609, 0.64565217391304, -0.05
95548, 0.39130434782609, 0.67173913043478, -0.025
95549, 0.3695652173913, 0.67173913043478, -0.05
95550, 0.34782608695652, 0.64565217391304, -0.05
95551, 0.34782608695652, 0.67173913043478, -0.025
95552, 0.32608695652174, 0.67173913043478, -0.05
95553, 0.30434782608696, 0.64565217391304, -0.05
95554, 0.30434782608696, 0.67173913043478, -0.025
95555, 0.28260869565217, 0.67173913043478, -0.05
95556, 0.26086956521739, 0.64565217391304, -0.05
95557, 0.26086956521739, 0.67173913043478, -0.025
95558, 0.23913043478261, 0.67173913043478, -0.05
95559, 0.21739130434783, 0.64565217391304, -0.05
95560, 0.21739130434783, 0.67173913043478, -0.025
95561, 0.19565217391304, 0.67173913043478, -0.05
95562, 0.17391304347826, 0.64565217391304, -0.05
95563, 0.17391304347826, 0.67173913043478, -0.025
95564, 0.15217391304348, 0.67173913043478, -0.05
95565, 0.1304347826087, 0.64565217391304, -0.05
95566, 0.1304347826087, 0.67173913043478, -0.025
95567, 0.10869565217391, 0.67173913043478, -0.05
95568, 0.08695652173913, 0.64565217391304, -0.05
95569, 0.08695652173913, 0.67173913043478, -0.025
95570, 0.065217391304348, 0.67173913043478, -0.05
95571, 0.043478260869565, 0.64565217391304, -0.05
95572, 0.043478260869565, 0.67173913043478, -0.025
95573, 0.021739130434783, 0.67173913043478, -0.05
95574, 0.97826086956522, 0.72391304347826, -0.05
95575, 0.95652173913043, 0.69782608695652, -0.05
95576, 0.95652173913043, 0.72391304347826, -0.025
95577, 0.93478260869565, 0.72391304347826, -0.05
95578, 0.91304347826087, 0.69782608695652, -0.05
95579, 0.91304347826087, 0.72391304347826, -0.025
95580, 0.89130434782609, 0.72391304347826, -0.05
95581, 0.8695652173913, 0.69782608695652, -0.05
95582, 0.8695652173913, 0.72391304347826, -0.025
95583, 0.84782608695652, 0.72391304347826, -0.05
95584, 0.82608695652174, 0.69782608695652, -0.05
95585, 0.82608695652174, 0.72391304347826, -0.025
95586, 0.80434782608696, 0.72391304347826, -0.05
95587, 0.78260869565217, 0.69782608695652, -0.05
95588, 0.78260869565217, 0.72391304347826, -0.025
95589, 0.76086956521739, 0.72391304347826, -0.05
95590, 0.73913043478261, 0.69782608695652, -0.05
95591, 0.73913043478261, 0.72391304347826, -0.025
95592, 0.71739130434783, 0.72391304347826, -0.05
95593, 0.69565217391304, 0.69782608695652, -0.05
95594, 0.69565217391304, 0.72391304347826, -0.025
95595, 0.67391304347826, 0.72391304347826, -0.05
95596, 0.65217391304348, 0.69782608695652, -0.05
95597, 0.65217391304348, 0.72391304347826, -0.025
95598, 0.6304347826087, 0.72391304347826, -0.05
95599, 0.60869565217391, 0.69782608695652, -0.05
95600, 0.60869565217391, 0.72391304347826, -0.025
95601, 0.58695652173913, 0.72391304347826, -0.05
95602, 0.56521739130435, 0.69782608695652, -0.05
95603, 0.56521739130435, 0.72391304347826, -0.025
95604, 0.54347826086957, 0.72391304347826, -0.05
95605, 0.52173913043478, 0.69782608695652, -0.05
95606, 0.52173913043478, 0.72391304347826, -0.025
95607, 0.5, 0.72391304347826, -0.05
95608, 0.47826086956522, 0.69782608695652, -0.05
95609, 0.47826086956522, 0.72391304347826, -0.025
95610, 0.45652173913043, 0.72391304347826, -0.05
95611, 0.43478260869565, 0.69782608695652, -0.05
95612, 0.43478260869565, 0.72391304347826, -0.025
95613, 0.41304347826087, 0.72391304347826, -0.05
95614, 0.39130434782609, 0.69782608695652, -0.05
95615, 0.39130434782609, 0.72391304347826, -0.025
95616, 0.3695652173913, 0.72391304347826, -0.05
95617, 0.34782608695652, 0.69782608695652, -0.05
95618, 0.34782608695652, 0.72391304347826, -0.025
95619, 0.32608695652174, 0.72391304347826, -0.05
95620, 0.30434782608696, 0.69782608695652, -0.05
95621, 0.30434782608696, 0.72391304347826, -0.025
95622, 0.28260869565217, 0.72391304347826, -0.05
95623, 0.26086956521739, 0.69782608695652, -0.05
95624, 0.26086956521739, 0.72391304347826, -0.025
95625, 0.23913043478261, 0.72391304347826, -0.05
95626, 0.21739130434783, 0.69782608695652, -0.05
95627, 0.21739130434783, 0.72391304347826, -0.025
95628, 0.19565217391304, 0.72391304347826, -0.05
95629, 0.17391304347826, 0.69782608695652, -0.05
95630, 0.17391304347826, 0.72391304347826, -0.025
95631, 0.15217391304348, 0.72391304347826, -0.05
95632, 0.1304347826087, 0.69782608695652, -0.05
95633, 0.1304347826087, 0.72391304347826, -0.025
95634, 0.10869565217391, 0.72391304347826, -0.05
95635, 0.08695652173913, 0.69782608695652, -0.05
95636, 0.08695652173913, 0.72391304347826, -0.025
95637, 0.065217391304348, 0.72391304347826, -0.05
95638, 0.043478260869565, 0.69782608695652, -0.05
95639, 0.043478260869565, 0.72391304347826, -0.025
95640, 0.021739130434783, 0.72391304347826, -0.05
95641, 0.97826086956522, 0.77608695652174, -0.05
95642, 0.95652173913043, 0.75, -0.05
95643, 0.95652173913043, 0.77608695652174, -0.025
95644, 0.93478260869565, 0.77608695652174, -0.05
95645, 0.91304347826087, 0.75, -0.05
95646, 0.91304347826087, 0.77608695652174, -0.025
95647, 0.89130434782609, 0.77608695652174, -0.05
95648, 0.8695652173913, 0.75, -0.05
95649, 0.8695652173913, 0.77608695652174, -0.025
95650, 0.84782608695652, 0.77608695652174, -0.05
95651, 0.82608695652174, 0.75, -0.05
95652, 0.82608695652174, 0.77608695652174, -0.025
95653, 0.80434782608696, 0.77608695652174, -0.05
95654, 0.78260869565217, 0.75, -0.05
95655, 0.78260869565217, 0.77608695652174, -0.025
95656, 0.76086956521739, 0.77608695652174, -0.05
95657, 0.73913043478261, 0.75, -0.05
95658, 0.73913043478261, 0.77608695652174, -0.025
95659, 0.71739130434783, 0.77608695652174, -0.05
95660, 0.69565217391304, 0.75, -0.05
95661, 0.69565217391304, 0.77608695652174, -0.025
95662, 0.67391304347826, 0.77608695652174, -0.05
95663, 0.65217391304348, 0.75, -0.05
95664, 0.65217391304348, 0.77608695652174, -0.025
95665, 0.6304347826087, 0.77608695652174, -0.05
95666, 0.60869565217391, 0.75, -0.05
95667, 0.60869565217391, 0.77608695652174, -0.025
95668, 0.58695652173913, 0.77608695652174, -0.05
95669, 0.56521739130435, 0.75, -0.05
95670, 0.56521739130435, 0.77608695652174, -0.025
95671, 0.54347826086957, 0.77608695652174, -0.05
95672, 0.52173913043478, 0.75, -0.05
95673, 0.52173913043478, 0.77608695652174, -0.025
95674, 0.5, 0.77608695652174, -0.05
95675, 0.47826086956522, 0.75, -0.05
95676, 0.47826086956522, 0.77608695652174, -0.025
95677, 0.45652173913043, 0.77608695652174, -0.05
95678, 0.43478260869565, 0.75, -0.05
95679, 0.43478260869565, 0.77608695652174, -0.025
95680, 0.41304347826087, 0.77608695652174, -0.05
95681, 0.39130434782609, 0.75, -0.05
95682, 0.39130434782609, 0.77608695652174, -0.025
95683, 0.3695652173913, 0.77608695652174, -0.05
95684, 0.34782608695652, 0.75, -0.05
95685, 0.34782608695652, 0.77608695652174, -0.025
95686, 0.32608695652174, 0.77608695652174, -0.05
95687, 0.30434782608696, 0.75, -0.05
95688, 0.30434782608696, 0.77608695652174, -0.025
95689, 0.28260869565217, 0.77608695652174, -0.05
95690, 0.26086956521739, 0.75, -0.05
95691, 0.26086956521739, 0.77608695652174, -0.025
95692, 0.23913043478261, 0.77608695652174, -0.05
95693, 0.21739130434783, 0.75, -0.05
95694, 0.21739130434783, 0.77608695652174, -0.025
95695, 0.19565217391304, 0.77608695652174, -0.05
95696, 0.17391304347826, 0.75, -0.05
95697, 0.17391304347826, 0.77608695652174, -0.025
95698, 0.15217391304348, 0.77608695652174, -0.05
95699, 0.1304347826087, 0.75, -0.05
95700, 0.1304347826087, 0.77608695652174, -0.025
95701, 0.10869565217391, 0.77608695652174, -0.05
95702, 0.08695652173913, 0.75, -0.05
95703, 0.08695652173913, 0.77608695652174, -0.025
95704, 0.065217391304348, 0.77608695652174, -0.05
95705, 0.043478260869565, 0.75, -0.05
95706, 0.043478260869565, 0.77608695652174, -0.025
95707, 0.021739130434783, 0.77608695652174, -0.05
95708, 0.97826086956522, 0.82826086956522, -0.05
95709, 0.95652173913043, 0.80217391304348, -0.05
95710, 0.95652173913043, 0.82826086956522, -0.025
95711, 0.93478260869565, 0.82826086956522, -0.05
95712, 0.91304347826087, 0.80217391304348, -0.05
95713, 0.91304347826087, 0.82826086956522, -0.025
95714, 0.89130434782609, 0.82826086956522, -0.05
95715, 0.8695652173913, 0.80217391304348, -0.05
95716, 0.8695652173913, 0.82826086956522, -0.025
95717, 0.84782608695652, 0.82826086956522, -0.05
95718, 0.82608695652174, 0.80217391304348, -0.05
95719, 0.82608695652174, 0.82826086956522, -0.025
95720, 0.80434782608696, 0.82826086956522, -0.05
95721, 0.78260869565217, 0.80217391304348, -0.05
95722, 0.78260869565217, 0.82826086956522, -0.025
95723, 0.76086956521739, 0.82826086956522, -0.05
95724, 0.73913043478261, 0.80217391304348, -0.05
95725, 0.73913043478261, 0.82826086956522, -0.025
95726, 0.71739130434783, 0.82826086956522, -0.05
95727, 0.69565217391304, 0.80217391304348, -0.05
95728, 0.69565217391304, 0.82826086956522, -0.025
95729, 0.67391304347826, 0.82826086956522, -0.05
95730, 0.65217391304348, 0.80217391304348, -0.05
95731, 0.65217391304348, 0.82826086956522, -0.025
95732, 0.6304347826087, 0.82826086956522, -0.05
95733, 0.60869565217391, 0.80217391304348, -0.05
95734, 0.60869565217391, 0.82826086956522, -0.025
95735, 0.58695652173913, 0.82826086956522, -0.05
95736, 0.56521739130435, 0.80217391304348, -0.05
95737, 0.56521739130435, 0.82826086956522, -0.025
95738, 0.54347826086957, 0.82826086956522, -0.05
95739, 0.52173913043478, 0.80217391304348, -0.05
95740, 0.52173913043478, 0.82826086956522, -0.025
95741, 0.5, 0.82826086956522, -0.05
95742, 0.47826086956522, 0.80217391304348, -0.05
95743, 0.47826086956522, 0.82826086956522, -0.025
95744, 0.45652173913043, 0.82826086956522, -0.05
95745, 0.43478260869565, 0.80217391304348, -0.05
95746, 0.43478260869565, 0.82826086956522, -0.025
95747, 0.41304347826087, 0.82826086956522, -0.05
95748, 0.39130434782609, 0.80217391304348, -0.05
95749, 0.39130434782609, 0.82826086956522, -0.025
95750, 0.3695652173913, 0.82826086956522, -0.05
95751, 0.34782608695652, 0.80217391304348, -0.05
95752, 0.34782608695652, 0.82826086956522, -0.025
95753, 0.32608695652174, 0.82826086956522, -0.05
95754, 0.30434782608696, 0.80217391304348, -0.05
95755, 0.30434782608696, 0.82826086956522, -0.025
95756, 0.28260869565217, 0.82826086956522, -0.05
95757, 0.26086956521739, 0.80217391304348, -0.05
95758, 0.26086956521739, 0.82826086956522, -0.025
95759, 0.23913043478261, 0.82826086956522, -0.05
95760, 0.21739130434783, 0.80217391304348, -0.05
95761, 0.21739130434783, 0.82826086956522, -0.025
95762, 0.19565217391304, 0.82826086956522, -0.05
95763, 0.17391304347826, 0.80217391304348, -0.05
95764, 0.17391304347826, 0.82826086956522, -0.025
95765, 0.15217391304348, 0.82826086956522, -0.05
95766, 0.1304347826087, 0.80217391304348, -0.05
95767, 0.1304347826087, 0.82826086956522, -0.025
95768, 0.10869565217391, 0.82826086956522, -0.05
95769, 0.08695652173913, 0.80217391304348, -0.05
95770, 0.08695652173913, 0.82826086956522, -0.025
95771, 0.065217391304348, 0.82826086956522, -0.05
95772, 0.043478260869565, 0.80217391304348, -0.05
95773, 0.043478260869565, 0.82826086956522, -0.025
95774, 0.021739130434783, 0.82826086956522, -0.05
95775, 0.97826086956522, 0.88043478260869, -0.05
95776, 0.95652173913044, 0.85434782608696, -0.05
95777, 0.95652173913043, 0.88043478260869, -0.025
95778, 0.93478260869565, 0.88043478260869, -0.05
95779, 0.91304347826087, 0.85434782608696, -0.05
95780, 0.91304347826087, 0.8804347826087, -0.025
95781, 0.89130434782609, 0.8804347826087, -0.05
95782, 0.8695652173913, 0.85434782608696, -0.05
95783, 0.8695652173913, 0.8804347826087, -0.025
95784, 0.84782608695652, 0.8804347826087, -0.05
95785, 0.82608695652174, 0.85434782608696, -0.05
95786, 0.82608695652174, 0.8804347826087, -0.025
95787, 0.80434782608696, 0.8804347826087, -0.05
95788, 0.78260869565217, 0.85434782608696, -0.05
95789, 0.78260869565217, 0.88043478260869, -0.025
95790, 0.76086956521739, 0.88043478260869, -0.05
95791, 0.73913043478261, 0.85434782608696, -0.05
95792, 0.73913043478261, 0.88043478260869, -0.025
95793, 0.71739130434783, 0.8804347826087, -0.05
95794, 0.69565217391304, 0.85434782608696, -0.05
95795, 0.69565217391304, 0.8804347826087, -0.025
95796, 0.67391304347826, 0.8804347826087, -0.05
95797, 0.65217391304348, 0.85434782608696, -0.05
95798, 0.65217391304348, 0.8804347826087, -0.025
95799, 0.6304347826087, 0.8804347826087, -0.05
95800, 0.60869565217391, 0.85434782608696, -0.05
95801, 0.60869565217391, 0.88043478260869, -0.025
95802, 0.58695652173913, 0.88043478260869, -0.05
95803, 0.56521739130435, 0.85434782608696, -0.05
95804, 0.56521739130435, 0.88043478260869, -0.025
95805, 0.54347826086957, 0.8804347826087, -0.05
95806, 0.52173913043478, 0.85434782608696, -0.05
95807, 0.52173913043478, 0.8804347826087, -0.025
95808, 0.5, 0.8804347826087, -0.05
95809, 0.47826086956522, 0.85434782608696, -0.05
95810, 0.47826086956522, 0.8804347826087, -0.025
95811, 0.45652173913043, 0.8804347826087, -0.05
95812, 0.43478260869565, 0.85434782608696, -0.05
95813, 0.43478260869565, 0.88043478260869, -0.025
95814, 0.41304347826087, 0.88043478260869, -0.05
95815, 0.39130434782609, 0.85434782608696, -0.05
95816, 0.39130434782609, 0.88043478260869, -0.025
95817, 0.3695652173913, 0.8804347826087, -0.05
95818, 0.34782608695652, 0.85434782608696, -0.05
95819, 0.34782608695652, 0.8804347826087, -0.025
95820, 0.32608695652174, 0.8804347826087, -0.05
95821, 0.30434782608696, 0.85434782608696, -0.05
95822, 0.30434782608696, 0.88043478260869, -0.025
95823, 0.28260869565217, 0.8804347826087, -0.05
95824, 0.26086956521739, 0.85434782608696, -0.05
95825, 0.26086956521739, 0.8804347826087, -0.025
95826, 0.23913043478261, 0.8804347826087, -0.05
95827, 0.21739130434783, 0.85434782608696, -0.05
95828, 0.21739130434783, 0.88043478260869, -0.025
95829, 0.19565217391304, 0.88043478260869, -0.05
95830, 0.17391304347826, 0.85434782608696, -0.05
95831, 0.17391304347826, 0.88043478260869, -0.025
95832, 0.15217391304348, 0.88043478260869, -0.05
95833, 0.1304347826087, 0.85434782608696, -0.05
95834, 0.1304347826087, 0.88043478260869, -0.025
95835, 0.10869565217391, 0.8804347826087, -0.05
95836, 0.08695652173913, 0.85434782608696, -0.05
95837, 0.08695652173913, 0.8804347826087, -0.025
95838, 0.065217391304348, 0.8804347826087, -0.05
95839, 0.043478260869565, 0.85434782608696, -0.05
95840, 0.043478260869565, 0.88043478260869, -0.025
95841, 0.021739130434783, 0.88043478260869, -0.05
95842, 0.97826086956522, 0.93260869565217, -0.05
95843, 0.95652173913043, 0.90652173913043, -0.05
95844, 0.95652173913043, 0.93260869565217, -0.025
95845, 0.93478260869565, 0.93260869565217, -0.05
95846, 0.91304347826087, 0.90652173913043, -0.05
95847, 0.91304347826087, 0.93260869565217, -0.025
95848, 0.89130434782609, 0.93260869565217, -0.05
95849, 0.8695652173913, 0.90652173913043, -0.05
95850, 0.8695652173913, 0.93260869565217, -0.025
95851, 0.84782608695652, 0.93260869565217, -0.05
95852, 0.82608695652174, 0.90652173913043, -0.05
95853, 0.82608695652174, 0.93260869565217, -0.025
95854, 0.80434782608696, 0.93260869565217, -0.05
95855, 0.78260869565217, 0.90652173913043, -0.05
95856, 0.78260869565217, 0.93260869565217, -0.025
95857, 0.76086956521739, 0.93260869565217, -0.05
95858, 0.73913043478261, 0.90652173913043, -0.05
95859, 0.73913043478261, 0.93260869565217, -0.025
95860, 0.71739130434783, 0.93260869565217, -0.05
95861, 0.69565217391304, 0.90652173913043, -0.05
95862, 0.69565217391304, 0.93260869565217, -0.025
95863, 0.67391304347826, 0.93260869565217, -0.05
95864, 0.65217391304348, 0.90652173913043, -0.05
95865, 0.65217391304348, 0.93260869565217, -0.025
95866, 0.6304347826087, 0.93260869565217, -0.05
95867, 0.60869565217391, 0.90652173913043, -0.05
95868, 0.60869565217391, 0.93260869565217, -0.025
95869, 0.58695652173913, 0.93260869565217, -0.05
95870, 0.56521739130435, 0.90652173913043, -0.05
95871, 0.56521739130435, 0.93260869565217, -0.025
95872, 0.54347826086957, 0.93260869565217, -0.05
95873, 0.52173913043478, 0.90652173913043, -0.05
95874, 0.52173913043478, 0.93260869565217, -0.025
95875, 0.5, 0.93260869565217, -0.05
95876, 0.47826086956522, 0.90652173913043, -0.05
95877, 0.47826086956522, 0.93260869565217, -0.025
95878, 0.45652173913043, 0.93260869565217, -0.05
95879, 0.43478260869565, 0.90652173913043, -0.05
95880, 0.43478260869565, 0.93260869565217, -0.025
95881, 0.41304347826087, 0.93260869565217, -0.05
95882, 0.39130434782609, 0.90652173913043, -0.05
95883, 0.39130434782609, 0.93260869565217, -0.025
95884, 0.3695652173913, 0.93260869565217, -0.05
95885, 0.34782608695652, 0.90652173913043, -0.05
95886, 0.34782608695652, 0.93260869565217, -0.025
95887, 0.32608695652174, 0.93260869565217, -0.05
95888, 0.30434782608696, 0.90652173913043, -0.05
95889, 0.30434782608696, 0.93260869565217, -0.025
95890, 0.28260869565217, 0.93260869565217, -0.05
95891, 0.26086956521739, 0.90652173913043, -0.05
95892, 0.26086956521739, 0.93260869565217, -0.025
95893, 0.23913043478261, 0.93260869565217, -0.05
95894, 0.21739130434783, 0.90652173913043, -0.05
95895, 0.21739130434783, 0.93260869565217, -0.025
95896, 0.19565217391304, 0.93260869565217, -0.05
95897, 0.17391304347826, 0.90652173913043, -0.05
95898, 0.17391304347826, 0.93260869565217, -0.025
95899, 0.15217391304348, 0.93260869565217, -0.05
95900, 0.1304347826087, 0.90652173913043, -0.05
95901, 0.1304347826087, 0.93260869565217, -0.025
95902, 0.10869565217391, 0.93260869565217, -0.05
95903, 0.08695652173913, 0.90652173913043, -0.05
95904, 0.08695652173913, 0.93260869565217, -0.025
95905, 0.065217391304348, 0.93260869565217, -0.05
95906, 0.043478260869565, 0.90652173913043, -0.05
95907, 0.043478260869565, 0.93260869565217, -0.025
95908, 0.021739130434783, 0.93260869565217, -0.05
95909, 0.97826086956522, 0.98478260869565, -0.05
95910, 0.95652173913043, 0.95869565217391, -0.05
95911, 0.95652173913043, 0.98478260869565, -0.025
95912, 0.93478260869565, 0.98478260869565, -0.05
95913, 0.91304347826087, 0.95869565217391, -0.05
95914, 0.91304347826087, 0.98478260869565, -0.025
95915, 0.89130434782609, 0.98478260869565, -0.05
95916, 0.8695652173913, 0.95869565217391, -0.05
95917, 0.8695652173913, 0.98478260869565, -0.025
95918, 0.84782608695652, 0.98478260869565, -0.05
95919, 0.82608695652174, 0.95869565217391, -0.05
95920, 0.82608695652174, 0.98478260869565, -0.025
95921, 0.80434782608696, 0.98478260869565, -0.05
95922, 0.78260869565217, 0.95869565217391, -0.05
95923, 0.78260869565217, 0.98478260869565, -0.025
95924, 0.76086956521739, 0.98478260869565, -0.05
95925, 0.73913043478261, 0.95869565217391, -0.05
95926, 0.73913043478261, 0.98478260869565, -0.025
95927, 0.71739130434783, 0.98478260869565, -0.05
95928, 0.69565217391304, 0.95869565217391, -0.05
95929, 0.69565217391304, 0.98478260869565, -0.025
95930, 0.67391304347826, 0.98478260869565, -0.05
95931, 0.65217391304348, 0.95869565217391, -0.05
95932, 0.65217391304348, 0.98478260869565, -0.025
95933, 0.6304347826087, 0.98478260869565, -0.05
95934, 0.60869565217391, 0.95869565217391, -0.05
95935, 0.60869565217391, 0.98478260869565, -0.025
95936, 0.58695652173913, 0.98478260869565, -0.05
95937, 0.56521739130435, 0.95869565217391, -0.05
95938, 0.56521739130435, 0.98478260869565, -0.025
95939, 0.54347826086957, 0.98478260869565, -0.05
95940, 0.52173913043478, 0.95869565217391, -0.05
95941, 0.52173913043478, 0.98478260869565, -0.025
95942, 0.5, 0.98478260869565, -0.05
95943, 0.47826086956522, 0.95869565217391, -0.05
95944, 0.47826086956522, 0.98478260869565, -0.025
95945, 0.45652173913043, 0.98478260869565, -0.05
95946, 0.43478260869565, 0.95869565217391, -0.05
95947, 0.43478260869565, 0.98478260869565, -0.025
95948, 0.41304347826087, 0.98478260869565, -0.05
95949, 0.39130434782609, 0.95869565217391, -0.05
95950, 0.39130434782609, 0.98478260869565, -0.025
95951, 0.3695652173913, 0.98478260869565, -0.05
95952, 0.34782608695652, 0.95869565217391, -0.05
95953, 0.34782608695652, 0.98478260869565, -0.025
95954, 0.32608695652174, 0.98478260869565, -0.05
95955, 0.30434782608696, 0.95869565217391, -0.05
95956, 0.30434782608696, 0.98478260869565, -0.025
95957, 0.28260869565217, 0.98478260869565, -0.05
95958, 0.26086956521739, 0.95869565217391, -0.05
95959, 0.26086956521739, 0.98478260869565, -0.025
95960, 0.23913043478261, 0.98478260869565, -0.05
95961, 0.21739130434783, 0.95869565217391, -0.05
95962, 0.21739130434783, 0.98478260869565, -0.025
95963, 0.19565217391304, 0.98478260869565, -0.05
95964, 0.17391304347826, 0.95869565217391, -0.05
95965, 0.17391304347826, 0.98478260869565, -0.025
95966, 0.15217391304348, 0.98478260869565, -0.05
95967, 0.1304347826087, 0.95869565217391, -0.05
95968, 0.1304347826087, 0.98478260869565, -0.025
95969, 0.10869565217391, 0.98478260869565, -0.05
95970, 0.08695652173913, 0.95869565217391, -0.05
95971, 0.08695652173913, 0.98478260869565, -0.025
95972, 0.065217391304348, 0.98478260869565, -0.05
95973, 0.043478260869565, 0.95869565217391, -0.05
95974, 0.043478260869565, 0.98478260869565, -0.025
95975, 0.021739130434783, 0.98478260869565, -0.05
95976, 0.97826086956522, 1.0369565217391, -0.05
95977, 0.95652173913043, 1.0108695652174, -0.05
95978, 0.95652173913043, 1.0369565217391, -0.025
95979, 0.93478260869565, 1.0369565217391, -0.05
95980, 0.91304347826087, 1.0108695652174, -0.05
95981, 0.91304347826087, 1.0369565217391, -0.025
95982, 0.89130434782609, 1.0369565217391, -0.05
95983, 0.8695652173913, 1.0108695652174, -0.05
95984, 0.8695652173913, 1.0369565217391, -0.025
95985, 0.84782608695652, 1.0369565217391, -0.05
95986, 0.82608695652174, 1.0108695652174, -0.05
95987, 0.82608695652174, 1.0369565217391, -0.025
95988, 0.80434782608696, 1.0369565217391, -0.05
95989, 0.78260869565217, 1.0108695652174, -0.05
95990, 0.78260869565217, 1.0369565217391, -0.025
95991, 0.76086956521739, 1.0369565217391, -0.05
95992, 0.73913043478261, 1.0108695652174, -0.05
95993, 0.73913043478261, 1.0369565217391, -0.025
95994, 0.71739130434783, 1.0369565217391, -0.05
95995, 0.69565217391304, 1.0108695652174, -0.05
95996, 0.69565217391304, 1.0369565217391, -0.025
95997, 0.67391304347826, 1.0369565217391, -0.05
95998, 0.65217391304348, 1.0108695652174, -0.05
95999, 0.65217391304348, 1.0369565217391, -0.025
96000, 0.6304347826087, 1.0369565217391, -0.05
96001, 0.60869565217391, 1.0108695652174, -0.05
96002, 0.60869565217391, 1.0369565217391, -0.025
96003, 0.58695652173913, 1.0369565217391, -0.05
96004, 0.56521739130435, 1.0108695652174, -0.05
96005, 0.56521739130435, 1.0369565217391, -0.025
96006, 0.54347826086957, 1.0369565217391, -0.05
96007, 0.52173913043478, 1.0108695652174, -0.05
96008, 0.52173913043478, 1.0369565217391, -0.025
96009, 0.5, 1.0369565217391, -0.05
96010, 0.47826086956522, 1.0108695652174, -0.05
96011, 0.47826086956522, 1.0369565217391, -0.025
96012, 0.45652173913043, 1.0369565217391, -0.05
96013, 0.43478260869565, 1.0108695652174, -0.05
96014, 0.43478260869565, 1.0369565217391, -0.025
96015, 0.41304347826087, 1.0369565217391, -0.05
96016, 0.39130434782609, 1.0108695652174, -0.05
96017, 0.39130434782609, 1.0369565217391, -0.025
96018, 0.3695652173913, 1.0369565217391, -0.05
96019, 0.34782608695652, 1.0108695652174, -0.05
96020, 0.34782608695652, 1.0369565217391, -0.025
96021, 0.32608695652174, 1.0369565217391, -0.05
96022, 0.30434782608696, 1.0108695652174, -0.05
96023, 0.30434782608696, 1.0369565217391, -0.025
96024, 0.28260869565217, 1.0369565217391, -0.05
96025, 0.26086956521739, 1.0108695652174, -0.05
96026, 0.26086956521739, 1.0369565217391, -0.025
96027, 0.23913043478261, 1.0369565217391, -0.05
96028, 0.21739130434783, 1.0108695652174, -0.05
96029, 0.21739130434783, 1.0369565217391, -0.025
96030, 0.19565217391304, 1.0369565217391, -0.05
96031, 0.17391304347826, 1.0108695652174, -0.05
96032, 0.17391304347826, 1.0369565217391, -0.025
96033, 0.15217391304348, 1.0369565217391, -0.05
96034, 0.1304347826087, 1.0108695652174, -0.05
96035, 0.1304347826087, 1.0369565217391, -0.025
96036, 0.10869565217391, 1.0369565217391, -0.05
96037, 0.08695652173913, 1.0108695652174, -0.05
96038, 0.08695652173913, 1.0369565217391, -0.025
96039, 0.065217391304348, 1.0369565217391, -0.05
96040, 0.043478260869565, 1.0108695652174, -0.05
96041, 0.043478260869565, 1.0369565217391, -0.025
96042, 0.021739130434783, 1.0369565217391, -0.05
96043, 0.97826086956522, 1.0891304347826, -0.05
96044, 0.95652173913043, 1.0630434782609, -0.05
96045, 0.95652173913043, 1.0891304347826, -0.025
96046, 0.93478260869565, 1.0891304347826, -0.05
96047, 0.91304347826087, 1.0630434782609, -0.05
96048, 0.91304347826087, 1.0891304347826, -0.025
96049, 0.89130434782609, 1.0891304347826, -0.05
96050, 0.8695652173913, 1.0630434782609, -0.05
96051, 0.8695652173913, 1.0891304347826, -0.025
96052, 0.84782608695652, 1.0891304347826, -0.05
96053, 0.82608695652174, 1.0630434782609, -0.05
96054, 0.82608695652174, 1.0891304347826, -0.025
96055, 0.80434782608696, 1.0891304347826, -0.05
96056, 0.78260869565217, 1.0630434782609, -0.05
96057, 0.78260869565217, 1.0891304347826, -0.025
96058, 0.76086956521739, 1.0891304347826, -0.05
96059, 0.73913043478261, 1.0630434782609, -0.05
96060, 0.73913043478261, 1.0891304347826, -0.025
96061, 0.71739130434783, 1.0891304347826, -0.05
96062, 0.69565217391304, 1.0630434782609, -0.05
96063, 0.69565217391304, 1.0891304347826, -0.025
96064, 0.67391304347826, 1.0891304347826, -0.05
96065, 0.65217391304348, 1.0630434782609, -0.05
96066, 0.65217391304348, 1.0891304347826, -0.025
96067, 0.6304347826087, 1.0891304347826, -0.05
96068, 0.60869565217391, 1.0630434782609, -0.05
96069, 0.60869565217391, 1.0891304347826, -0.025
96070, 0.58695652173913, 1.0891304347826, -0.05
96071, 0.56521739130435, 1.0630434782609, -0.05
96072, 0.56521739130435, 1.0891304347826, -0.025
96073, 0.54347826086957, 1.0891304347826, -0.05
96074, 0.52173913043478, 1.0630434782609, -0.05
96075, 0.52173913043478, 1.0891304347826, -0.025
96076, 0.5, 1.0891304347826, -0.05
96077, 0.47826086956522, 1.0630434782609, -0.05
96078, 0.47826086956522, 1.0891304347826, -0.025
96079, 0.45652173913043, 1.0891304347826, -0.05
96080, 0.43478260869565, 1.0630434782609, -0.05
96081, 0.43478260869565, 1.0891304347826, -0.025
96082, 0.41304347826087, 1.0891304347826, -0.05
96083, 0.39130434782609, 1.0630434782609, -0.05
96084, 0.39130434782609, 1.0891304347826, -0.025
96085, 0.3695652173913, 1.0891304347826, -0.05
96086, 0.34782608695652, 1.0630434782609, -0.05
96087, 0.34782608695652, 1.0891304347826, -0.025
96088, 0.32608695652174, 1.0891304347826, -0.05
96089, 0.30434782608696, 1.0630434782609, -0.05
96090, 0.30434782608696, 1.0891304347826, -0.025
96091, 0.28260869565217, 1.0891304347826, -0.05
96092, 0.26086956521739, 1.0630434782609, -0.05
96093, 0.26086956521739, 1.0891304347826, -0.025
96094, 0.23913043478261, 1.0891304347826, -0.05
96095, 0.21739130434783, 1.0630434782609, -0.05
96096, 0.21739130434783, 1.0891304347826, -0.025
96097, 0.19565217391304, 1.0891304347826, -0.05
96098, 0.17391304347826, 1.0630434782609, -0.05
96099, 0.17391304347826, 1.0891304347826, -0.025
96100, 0.15217391304348, 1.0891304347826, -0.05
96101, 0.1304347826087, 1.0630434782609, -0.05
96102, 0.1304347826087, 1.0891304347826, -0.025
96103, 0.10869565217391, 1.0891304347826, -0.05
96104, 0.08695652173913, 1.0630434782609, -0.05
96105, 0.08695652173913, 1.0891304347826, -0.025
96106, 0.065217391304348, 1.0891304347826, -0.05
96107, 0.043478260869565, 1.0630434782609, -0.05
96108, 0.043478260869565, 1.0891304347826, -0.025
96109, 0.021739130434783, 1.0891304347826, -0.05
96110, 0.97826086956522, 1.1413043478261, -0.05
96111, 0.95652173913043, 1.1152173913043, -0.05
96112, 0.95652173913043, 1.1413043478261, -0.025
96113, 0.93478260869565, 1.1413043478261, -0.05
96114, 0.91304347826087, 1.1152173913043, -0.05
96115, 0.91304347826087, 1.1413043478261, -0.025
96116, 0.89130434782609, 1.1413043478261, -0.05
96117, 0.8695652173913, 1.1152173913043, -0.05
96118, 0.8695652173913, 1.1413043478261, -0.025
96119, 0.84782608695652, 1.1413043478261, -0.05
96120, 0.82608695652174, 1.1152173913043, -0.05
96121, 0.82608695652174, 1.1413043478261, -0.025
96122, 0.80434782608696, 1.1413043478261, -0.05
96123, 0.78260869565217, 1.1152173913043, -0.05
96124, 0.78260869565217, 1.1413043478261, -0.025
96125, 0.76086956521739, 1.1413043478261, -0.05
96126, 0.73913043478261, 1.1152173913043, -0.05
96127, 0.73913043478261, 1.1413043478261, -0.025
96128, 0.71739130434783, 1.1413043478261, -0.05
96129, 0.69565217391304, 1.1152173913043, -0.05
96130, 0.69565217391304, 1.1413043478261, -0.025
96131, 0.67391304347826, 1.1413043478261, -0.05
96132, 0.65217391304348, 1.1152173913043, -0.05
96133, 0.65217391304348, 1.1413043478261, -0.025
96134, 0.6304347826087, 1.1413043478261, -0.05
96135, 0.60869565217391, 1.1152173913043, -0.05
96136, 0.60869565217391, 1.1413043478261, -0.025
96137, 0.58695652173913, 1.1413043478261, -0.05
96138, 0.56521739130435, 1.1152173913043, -0.05
96139, 0.56521739130435, 1.1413043478261, -0.025
96140, 0.54347826086957, 1.1413043478261, -0.05
96141, 0.52173913043478, 1.1152173913043, -0.05
96142, 0.52173913043478, 1.1413043478261, -0.025
96143, 0.5, 1.1413043478261, -0.05
96144, 0.47826086956522, 1.1152173913043, -0.05
96145, 0.47826086956522, 1.1413043478261, -0.025
96146, 0.45652173913043, 1.1413043478261, -0.05
96147, 0.43478260869565, 1.1152173913043, -0.05
96148, 0.43478260869565, 1.1413043478261, -0.025
96149, 0.41304347826087, 1.1413043478261, -0.05
96150, 0.39130434782609, 1.1152173913043, -0.05
96151, 0.39130434782609, 1.1413043478261, -0.025
96152, 0.3695652173913, 1.1413043478261, -0.05
96153, 0.34782608695652, 1.1152173913043, -0.05
96154, 0.34782608695652, 1.1413043478261, -0.025
96155, 0.32608695652174, 1.1413043478261, -0.05
96156, 0.30434782608696, 1.1152173913043, -0.05
96157, 0.30434782608696, 1.1413043478261, -0.025
96158, 0.28260869565217, 1.1413043478261, -0.05
96159, 0.26086956521739, 1.1152173913043, -0.05
96160, 0.26086956521739, 1.1413043478261, -0.025
96161, 0.23913043478261, 1.1413043478261, -0.05
96162, 0.21739130434783, 1.1152173913043, -0.05
96163, 0.21739130434783, 1.1413043478261, -0.025
96164, 0.19565217391304, 1.1413043478261, -0.05
96165, 0.17391304347826, 1.1152173913043, -0.05
96166, 0.17391304347826, 1.1413043478261, -0.025
96167, 0.15217391304348, 1.1413043478261, -0.05
96168, 0.1304347826087, 1.1152173913043, -0.05
96169, 0.1304347826087, 1.1413043478261, -0.025
96170, 0.10869565217391, 1.1413043478261, -0.05
96171, 0.08695652173913, 1.1152173913043, -0.05
96172, 0.08695652173913, 1.1413043478261, -0.025
96173, 0.065217391304348, 1.1413043478261, -0.05
96174, 0.043478260869565, 1.1152173913043, -0.05
96175, 0.043478260869565, 1.1413043478261, -0.025
96176, 0.021739130434783, 1.1413043478261, -0.05
96177, 0.97826086956522, 1.1934782608696, -0.05
96178, 0.95652173913043, 1.1673913043478, -0.05
96179, 0.95652173913043, 1.1934782608696, -0.025
96180, 0.93478260869565, 1.1934782608696, -0.05
96181, 0.91304347826087, 1.1673913043478, -0.05
96182, 0.91304347826087, 1.1934782608696, -0.025
96183, 0.89130434782609, 1.1934782608696, -0.05
96184, 0.8695652173913, 1.1673913043478, -0.05
96185, 0.8695652173913, 1.1934782608696, -0.025
96186, 0.84782608695652, 1.1934782608696, -0.05
96187, 0.82608695652174, 1.1673913043478, -0.05
96188, 0.82608695652174, 1.1934782608696, -0.025
96189, 0.80434782608696, 1.1934782608696, -0.05
96190, 0.78260869565217, 1.1673913043478, -0.05
96191, 0.78260869565217, 1.1934782608696, -0.025
96192, 0.76086956521739, 1.1934782608696, -0.05
96193, 0.73913043478261, 1.1673913043478, -0.05
96194, 0.73913043478261, 1.1934782608696, -0.025
96195, 0.71739130434783, 1.1934782608696, -0.05
96196, 0.69565217391304, 1.1673913043478, -0.05
96197, 0.69565217391304, 1.1934782608696, -0.025
96198, 0.67391304347826, 1.1934782608696, -0.05
96199, 0.65217391304348, 1.1673913043478, -0.05
96200, 0.65217391304348, 1.1934782608696, -0.025
96201, 0.6304347826087, 1.1934782608696, -0.05
96202, 0.60869565217391, 1.1673913043478, -0.05
96203, 0.60869565217391, 1.1934782608696, -0.025
96204, 0.58695652173913, 1.1934782608696, -0.05
96205, 0.56521739130435, 1.1673913043478, -0.05
96206, 0.56521739130435, 1.1934782608696, -0.025
96207, 0.54347826086957, 1.1934782608696, -0.05
96208, 0.52173913043478, 1.1673913043478, -0.05
96209, 0.52173913043478, 1.1934782608696, -0.025
96210, 0.5, 1.1934782608696, -0.05
96211, 0.47826086956522, 1.1673913043478, -0.05
96212, 0.47826086956522, 1.1934782608696, -0.025
96213, 0.45652173913043, 1.1934782608696, -0.05
96214, 0.43478260869565, 1.1673913043478, -0.05
96215, 0.43478260869565, 1.1934782608696, -0.025
96216, 0.41304347826087, 1.1934782608696, -0.05
96217, 0.39130434782609, 1.1673913043478, -0.05
96218, 0.39130434782609, 1.1934782608696, -0.025
96219, 0.3695652173913, 1.1934782608696, -0.05
96220, 0.34782608695652, 1.1673913043478, -0.05
96221, 0.34782608695652, 1.1934782608696, -0.025
96222, 0.32608695652174, 1.1934782608696, -0.05
96223, 0.30434782608696, 1.1673913043478, -0.05
96224, 0.30434782608696, 1.1934782608696, -0.025
96225, 0.28260869565217, 1.1934782608696, -0.05
96226, 0.26086956521739, 1.1673913043478, -0.05
96227, 0.26086956521739, 1.1934782608696, -0.025
96228, 0.23913043478261, 1.1934782608696, -0.05
96229, 0.21739130434783, 1.1673913043478, -0.05
96230, 0.21739130434783, 1.1934782608696, -0.025
96231, 0.19565217391304, 1.1934782608696, -0.05
96232, 0.17391304347826, 1.1673913043478, -0.05
96233, 0.17391304347826, 1.1934782608696, -0.025
96234, 0.15217391304348, 1.1934782608696, -0.05
96235, 0.1304347826087, 1.1673913043478, -0.05
96236, 0.1304347826087, 1.1934782608696, -0.025
96237, 0.10869565217391, 1.1934782608696, -0.05
96238, 0.08695652173913, 1.1673913043478, -0.05
96239, 0.08695652173913, 1.1934782608696, -0.025
96240, 0.065217391304348, 1.1934782608696, -0.05
96241, 0.043478260869565, 1.1673913043478, -0.05
96242, 0.043478260869565, 1.1934782608696, -0.025
96243, 0.021739130434783, 1.1934782608696, -0.05
96244, 0.97826086956522, 1.245652173913, -0.05
96245, 0.95652173913043, 1.2195652173913, -0.05
96246, 0.95652173913043, 1.245652173913, -0.025
96247, 0.93478260869565, 1.245652173913, -0.05
96248, 0.91304347826087, 1.2195652173913, -0.05
96249, 0.91304347826087, 1.245652173913, -0.025
96250, 0.89130434782609, 1.245652173913, -0.05
96251, 0.8695652173913, 1.2195652173913, -0.05
96252, 0.8695652173913, 1.245652173913, -0.025
96253, 0.84782608695652, 1.245652173913, -0.05
96254, 0.82608695652174, 1.2195652173913, -0.05
96255, 0.82608695652174, 1.245652173913, -0.025
96256, 0.80434782608696, 1.245652173913, -0.05
96257, 0.78260869565217, 1.2195652173913, -0.05
96258, 0.78260869565217, 1.245652173913, -0.025
96259, 0.76086956521739, 1.245652173913, -0.05
96260, 0.73913043478261, 1.2195652173913, -0.05
96261, 0.73913043478261, 1.245652173913, -0.025
96262, 0.71739130434783, 1.245652173913, -0.05
96263, 0.69565217391304, 1.2195652173913, -0.05
