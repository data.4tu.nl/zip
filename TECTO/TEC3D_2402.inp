56461, 0.08695652173913, 1.4666666666667, 0.33333333333333
56462, 0.08695652173913, 1.4833333333333, 0.36111111111111
56463, 0.10869565217391, 1.4833333333333, 0.38888888888889
56464, 0.08695652173913, 1.4666666666667, 0.38888888888889
56465, 0.08695652173913, 1.4833333333333, 0.41666666666667
56466, 0.10869565217391, 1.4833333333333, 0.44444444444444
56467, 0.08695652173913, 1.4666666666667, 0.44444444444444
56468, 0.08695652173913, 1.4833333333333, 0.47222222222222
56469, 0.043478260869565, 1.4833333333333, 0.027777777777778
56470, 0.065217391304348, 1.4833333333333, 0.055555555555556
56471, 0.043478260869565, 1.4666666666667, 0.055555555555556
56472, 0.043478260869565, 1.4833333333333, 0.083333333333333
56473, 0.065217391304348, 1.4833333333333, 0.11111111111111
56474, 0.043478260869565, 1.4666666666667, 0.11111111111111
56475, 0.043478260869565, 1.4833333333333, 0.13888888888889
56476, 0.065217391304348, 1.4833333333333, 0.16666666666667
56477, 0.043478260869565, 1.4666666666667, 0.16666666666667
56478, 0.043478260869565, 1.4833333333333, 0.19444444444444
56479, 0.065217391304348, 1.4833333333333, 0.22222222222222
56480, 0.043478260869565, 1.4666666666667, 0.22222222222222
56481, 0.043478260869565, 1.4833333333333, 0.25
56482, 0.065217391304348, 1.4833333333333, 0.27777777777778
56483, 0.043478260869565, 1.4666666666667, 0.27777777777778
56484, 0.043478260869565, 1.4833333333333, 0.30555555555556
56485, 0.065217391304348, 1.4833333333333, 0.33333333333333
56486, 0.043478260869565, 1.4666666666667, 0.33333333333333
56487, 0.043478260869565, 1.4833333333333, 0.36111111111111
56488, 0.065217391304348, 1.4833333333333, 0.38888888888889
56489, 0.043478260869565, 1.4666666666667, 0.38888888888889
56490, 0.043478260869565, 1.4833333333333, 0.41666666666667
56491, 0.065217391304348, 1.4833333333333, 0.44444444444444
56492, 0.043478260869565, 1.4666666666667, 0.44444444444444
56493, 0.043478260869565, 1.4833333333333, 0.47222222222222
56494, 0.021739130434783, 1.4833333333333, 0.055555555555556
56495, 0.021739130434783, 1.4833333333333, 0.11111111111111
56496, 0.021739130434783, 1.4833333333333, 0.16666666666667
56497, 0.021739130434783, 1.4833333333333, 0.22222222222222
56498, 0.021739130434783, 1.4833333333333, 0.27777777777778
56499, 0.021739130434783, 1.4833333333333, 0.33333333333333
56500, 0.021739130434783, 1.4833333333333, 0.38888888888889
56501, 0.021739130434783, 1.4833333333333, 0.44444444444444
56502, 0.95652173913043, 1.5166666666667, 0.027777777777778
56503, 0.97826086956522, 1.5166666666667, 0.055555555555556
56504, 0.95652173913043, 1.5, 0.055555555555556
56505, 0.95652173913043, 1.5166666666667, 0.083333333333333
56506, 0.97826086956522, 1.5166666666667, 0.11111111111111
56507, 0.95652173913044, 1.5, 0.11111111111111
56508, 0.95652173913044, 1.5166666666667, 0.13888888888889
56509, 0.97826086956522, 1.5166666666667, 0.16666666666667
56510, 0.95652173913044, 1.5, 0.16666666666667
56511, 0.95652173913044, 1.5166666666667, 0.19444444444444
56512, 0.97826086956522, 1.5166666666667, 0.22222222222222
56513, 0.95652173913044, 1.5, 0.22222222222222
56514, 0.95652173913044, 1.5166666666667, 0.25
56515, 0.97826086956522, 1.5166666666667, 0.27777777777778
56516, 0.95652173913044, 1.5, 0.27777777777778
56517, 0.95652173913044, 1.5166666666667, 0.30555555555556
56518, 0.97826086956522, 1.5166666666667, 0.33333333333333
56519, 0.95652173913044, 1.5, 0.33333333333333
56520, 0.95652173913044, 1.5166666666667, 0.36111111111111
56521, 0.97826086956522, 1.5166666666667, 0.38888888888889
56522, 0.95652173913044, 1.5, 0.38888888888889
56523, 0.95652173913044, 1.5166666666667, 0.41666666666667
56524, 0.97826086956522, 1.5166666666667, 0.44444444444444
56525, 0.95652173913044, 1.5, 0.44444444444444
56526, 0.95652173913043, 1.5166666666667, 0.47222222222222
56527, 0.91304347826087, 1.5166666666667, 0.027777777777778
56528, 0.93478260869565, 1.5166666666667, 0.055555555555556
56529, 0.91304347826087, 1.5, 0.055555555555556
56530, 0.91304347826087, 1.5166666666667, 0.083333333333333
56531, 0.93478260869565, 1.5166666666667, 0.11111111111111
56532, 0.91304347826087, 1.5, 0.11111111111111
56533, 0.91304347826087, 1.5166666666667, 0.13888888888889
56534, 0.93478260869565, 1.5166666666667, 0.16666666666667
56535, 0.91304347826087, 1.5, 0.16666666666667
56536, 0.91304347826087, 1.5166666666667, 0.19444444444444
56537, 0.93478260869565, 1.5166666666667, 0.22222222222222
56538, 0.91304347826087, 1.5, 0.22222222222222
56539, 0.91304347826087, 1.5166666666667, 0.25
56540, 0.93478260869565, 1.5166666666667, 0.27777777777778
56541, 0.91304347826087, 1.5, 0.27777777777778
56542, 0.91304347826087, 1.5166666666667, 0.30555555555556
56543, 0.93478260869565, 1.5166666666667, 0.33333333333333
56544, 0.91304347826087, 1.5, 0.33333333333333
56545, 0.91304347826087, 1.5166666666667, 0.36111111111111
56546, 0.93478260869565, 1.5166666666667, 0.38888888888889
56547, 0.91304347826087, 1.5, 0.38888888888889
56548, 0.91304347826087, 1.5166666666667, 0.41666666666667
56549, 0.93478260869565, 1.5166666666667, 0.44444444444444
56550, 0.91304347826087, 1.5, 0.44444444444444
56551, 0.91304347826087, 1.5166666666667, 0.47222222222222
56552, 0.8695652173913, 1.5166666666667, 0.027777777777778
56553, 0.89130434782609, 1.5166666666667, 0.055555555555556
56554, 0.8695652173913, 1.5, 0.055555555555556
56555, 0.8695652173913, 1.5166666666667, 0.083333333333333
56556, 0.89130434782609, 1.5166666666667, 0.11111111111111
56557, 0.8695652173913, 1.5, 0.11111111111111
56558, 0.8695652173913, 1.5166666666667, 0.13888888888889
56559, 0.89130434782609, 1.5166666666667, 0.16666666666667
56560, 0.8695652173913, 1.5, 0.16666666666667
56561, 0.8695652173913, 1.5166666666667, 0.19444444444444
56562, 0.89130434782609, 1.5166666666667, 0.22222222222222
56563, 0.8695652173913, 1.5, 0.22222222222222
56564, 0.8695652173913, 1.5166666666667, 0.25
56565, 0.89130434782609, 1.5166666666667, 0.27777777777778
56566, 0.8695652173913, 1.5, 0.27777777777778
56567, 0.8695652173913, 1.5166666666667, 0.30555555555556
56568, 0.89130434782609, 1.5166666666667, 0.33333333333333
56569, 0.8695652173913, 1.5, 0.33333333333333
56570, 0.8695652173913, 1.5166666666667, 0.36111111111111
56571, 0.89130434782609, 1.5166666666667, 0.38888888888889
56572, 0.8695652173913, 1.5, 0.38888888888889
56573, 0.8695652173913, 1.5166666666667, 0.41666666666667
56574, 0.89130434782609, 1.5166666666667, 0.44444444444444
56575, 0.8695652173913, 1.5, 0.44444444444444
56576, 0.8695652173913, 1.5166666666667, 0.47222222222222
56577, 0.82608695652174, 1.5166666666667, 0.027777777777778
56578, 0.84782608695652, 1.5166666666667, 0.055555555555556
56579, 0.82608695652174, 1.5, 0.055555555555556
56580, 0.82608695652174, 1.5166666666667, 0.083333333333333
56581, 0.84782608695652, 1.5166666666667, 0.11111111111111
56582, 0.82608695652174, 1.5, 0.11111111111111
56583, 0.82608695652174, 1.5166666666667, 0.13888888888889
56584, 0.84782608695652, 1.5166666666667, 0.16666666666667
56585, 0.82608695652174, 1.5, 0.16666666666667
56586, 0.82608695652174, 1.5166666666667, 0.19444444444444
56587, 0.84782608695652, 1.5166666666667, 0.22222222222222
56588, 0.82608695652174, 1.5, 0.22222222222222
56589, 0.82608695652174, 1.5166666666667, 0.25
56590, 0.84782608695652, 1.5166666666667, 0.27777777777778
56591, 0.82608695652174, 1.5, 0.27777777777778
56592, 0.82608695652174, 1.5166666666667, 0.30555555555556
56593, 0.84782608695652, 1.5166666666667, 0.33333333333333
56594, 0.82608695652174, 1.5, 0.33333333333333
56595, 0.82608695652174, 1.5166666666667, 0.36111111111111
56596, 0.84782608695652, 1.5166666666667, 0.38888888888889
56597, 0.82608695652174, 1.5, 0.38888888888889
56598, 0.82608695652174, 1.5166666666667, 0.41666666666667
56599, 0.84782608695652, 1.5166666666667, 0.44444444444444
56600, 0.82608695652174, 1.5, 0.44444444444444
56601, 0.82608695652174, 1.5166666666667, 0.47222222222222
56602, 0.78260869565217, 1.5166666666667, 0.027777777777778
56603, 0.80434782608696, 1.5166666666667, 0.055555555555556
56604, 0.78260869565217, 1.5, 0.055555555555556
56605, 0.78260869565217, 1.5166666666667, 0.083333333333333
56606, 0.80434782608696, 1.5166666666667, 0.11111111111111
56607, 0.78260869565217, 1.5, 0.11111111111111
56608, 0.78260869565217, 1.5166666666667, 0.13888888888889
56609, 0.80434782608696, 1.5166666666667, 0.16666666666667
56610, 0.78260869565217, 1.5, 0.16666666666667
56611, 0.78260869565217, 1.5166666666667, 0.19444444444444
56612, 0.80434782608696, 1.5166666666667, 0.22222222222222
56613, 0.78260869565217, 1.5, 0.22222222222222
56614, 0.78260869565217, 1.5166666666667, 0.25
56615, 0.80434782608696, 1.5166666666667, 0.27777777777778
56616, 0.78260869565217, 1.5, 0.27777777777778
56617, 0.78260869565217, 1.5166666666667, 0.30555555555556
56618, 0.80434782608696, 1.5166666666667, 0.33333333333333
56619, 0.78260869565217, 1.5, 0.33333333333333
56620, 0.78260869565217, 1.5166666666667, 0.36111111111111
56621, 0.80434782608696, 1.5166666666667, 0.38888888888889
56622, 0.78260869565217, 1.5, 0.38888888888889
56623, 0.78260869565217, 1.5166666666667, 0.41666666666667
56624, 0.80434782608696, 1.5166666666667, 0.44444444444444
56625, 0.78260869565217, 1.5, 0.44444444444444
56626, 0.78260869565217, 1.5166666666667, 0.47222222222222
56627, 0.73913043478261, 1.5166666666667, 0.027777777777778
56628, 0.76086956521739, 1.5166666666667, 0.055555555555556
56629, 0.73913043478261, 1.5, 0.055555555555556
56630, 0.73913043478261, 1.5166666666667, 0.083333333333333
56631, 0.76086956521739, 1.5166666666667, 0.11111111111111
56632, 0.73913043478261, 1.5, 0.11111111111111
56633, 0.73913043478261, 1.5166666666667, 0.13888888888889
56634, 0.76086956521739, 1.5166666666667, 0.16666666666667
56635, 0.73913043478261, 1.5, 0.16666666666667
56636, 0.73913043478261, 1.5166666666667, 0.19444444444444
56637, 0.76086956521739, 1.5166666666667, 0.22222222222222
56638, 0.73913043478261, 1.5, 0.22222222222222
56639, 0.73913043478261, 1.5166666666667, 0.25
56640, 0.76086956521739, 1.5166666666667, 0.27777777777778
56641, 0.73913043478261, 1.5, 0.27777777777778
56642, 0.73913043478261, 1.5166666666667, 0.30555555555556
56643, 0.76086956521739, 1.5166666666667, 0.33333333333333
56644, 0.73913043478261, 1.5, 0.33333333333333
56645, 0.73913043478261, 1.5166666666667, 0.36111111111111
56646, 0.76086956521739, 1.5166666666667, 0.38888888888889
56647, 0.73913043478261, 1.5, 0.38888888888889
56648, 0.73913043478261, 1.5166666666667, 0.41666666666667
56649, 0.76086956521739, 1.5166666666667, 0.44444444444444
56650, 0.73913043478261, 1.5, 0.44444444444444
56651, 0.73913043478261, 1.5166666666667, 0.47222222222222
56652, 0.69565217391304, 1.5166666666667, 0.027777777777778
56653, 0.71739130434783, 1.5166666666667, 0.055555555555556
56654, 0.69565217391304, 1.5, 0.055555555555556
56655, 0.69565217391304, 1.5166666666667, 0.083333333333333
56656, 0.71739130434783, 1.5166666666667, 0.11111111111111
56657, 0.69565217391304, 1.5, 0.11111111111111
56658, 0.69565217391304, 1.5166666666667, 0.13888888888889
56659, 0.71739130434783, 1.5166666666667, 0.16666666666667
56660, 0.69565217391304, 1.5, 0.16666666666667
56661, 0.69565217391304, 1.5166666666667, 0.19444444444444
56662, 0.71739130434783, 1.5166666666667, 0.22222222222222
56663, 0.69565217391304, 1.5, 0.22222222222222
56664, 0.69565217391304, 1.5166666666667, 0.25
56665, 0.71739130434783, 1.5166666666667, 0.27777777777778
56666, 0.69565217391304, 1.5, 0.27777777777778
56667, 0.69565217391304, 1.5166666666667, 0.30555555555556
56668, 0.71739130434783, 1.5166666666667, 0.33333333333333
56669, 0.69565217391304, 1.5, 0.33333333333333
56670, 0.69565217391304, 1.5166666666667, 0.36111111111111
56671, 0.71739130434783, 1.5166666666667, 0.38888888888889
56672, 0.69565217391304, 1.5, 0.38888888888889
56673, 0.69565217391304, 1.5166666666667, 0.41666666666667
56674, 0.71739130434783, 1.5166666666667, 0.44444444444444
56675, 0.69565217391304, 1.5, 0.44444444444444
56676, 0.69565217391304, 1.5166666666667, 0.47222222222222
56677, 0.65217391304348, 1.5166666666667, 0.027777777777778
56678, 0.67391304347826, 1.5166666666667, 0.055555555555556
56679, 0.65217391304348, 1.5, 0.055555555555556
56680, 0.65217391304348, 1.5166666666667, 0.083333333333333
56681, 0.67391304347826, 1.5166666666667, 0.11111111111111
56682, 0.65217391304348, 1.5, 0.11111111111111
56683, 0.65217391304348, 1.5166666666667, 0.13888888888889
56684, 0.67391304347826, 1.5166666666667, 0.16666666666667
56685, 0.65217391304348, 1.5, 0.16666666666667
56686, 0.65217391304348, 1.5166666666667, 0.19444444444444
56687, 0.67391304347826, 1.5166666666667, 0.22222222222222
56688, 0.65217391304348, 1.5, 0.22222222222222
56689, 0.65217391304348, 1.5166666666667, 0.25
56690, 0.67391304347826, 1.5166666666667, 0.27777777777778
56691, 0.65217391304348, 1.5, 0.27777777777778
56692, 0.65217391304348, 1.5166666666667, 0.30555555555556
56693, 0.67391304347826, 1.5166666666667, 0.33333333333333
56694, 0.65217391304348, 1.5, 0.33333333333333
56695, 0.65217391304348, 1.5166666666667, 0.36111111111111
56696, 0.67391304347826, 1.5166666666667, 0.38888888888889
56697, 0.65217391304348, 1.5, 0.38888888888889
56698, 0.65217391304348, 1.5166666666667, 0.41666666666667
56699, 0.67391304347826, 1.5166666666667, 0.44444444444444
56700, 0.65217391304348, 1.5, 0.44444444444444
56701, 0.65217391304348, 1.5166666666667, 0.47222222222222
56702, 0.60869565217391, 1.5166666666667, 0.027777777777778
56703, 0.6304347826087, 1.5166666666667, 0.055555555555556
56704, 0.60869565217391, 1.5, 0.055555555555556
56705, 0.60869565217391, 1.5166666666667, 0.083333333333333
56706, 0.6304347826087, 1.5166666666667, 0.11111111111111
56707, 0.60869565217391, 1.5, 0.11111111111111
56708, 0.60869565217391, 1.5166666666667, 0.13888888888889
56709, 0.6304347826087, 1.5166666666667, 0.16666666666667
56710, 0.60869565217391, 1.5, 0.16666666666667
56711, 0.60869565217391, 1.5166666666667, 0.19444444444444
56712, 0.6304347826087, 1.5166666666667, 0.22222222222222
56713, 0.60869565217391, 1.5, 0.22222222222222
56714, 0.60869565217391, 1.5166666666667, 0.25
56715, 0.6304347826087, 1.5166666666667, 0.27777777777778
56716, 0.60869565217391, 1.5, 0.27777777777778
56717, 0.60869565217391, 1.5166666666667, 0.30555555555556
56718, 0.6304347826087, 1.5166666666667, 0.33333333333333
56719, 0.60869565217391, 1.5, 0.33333333333333
56720, 0.60869565217391, 1.5166666666667, 0.36111111111111
56721, 0.6304347826087, 1.5166666666667, 0.38888888888889
56722, 0.60869565217391, 1.5, 0.38888888888889
56723, 0.60869565217391, 1.5166666666667, 0.41666666666667
56724, 0.6304347826087, 1.5166666666667, 0.44444444444444
56725, 0.60869565217391, 1.5, 0.44444444444444
56726, 0.60869565217391, 1.5166666666667, 0.47222222222222
56727, 0.56521739130435, 1.5166666666667, 0.027777777777778
56728, 0.58695652173913, 1.5166666666667, 0.055555555555556
56729, 0.56521739130435, 1.5, 0.055555555555556
56730, 0.56521739130435, 1.5166666666667, 0.083333333333333
56731, 0.58695652173913, 1.5166666666667, 0.11111111111111
56732, 0.56521739130435, 1.5, 0.11111111111111
56733, 0.56521739130435, 1.5166666666667, 0.13888888888889
56734, 0.58695652173913, 1.5166666666667, 0.16666666666667
56735, 0.56521739130435, 1.5, 0.16666666666667
56736, 0.56521739130435, 1.5166666666667, 0.19444444444444
56737, 0.58695652173913, 1.5166666666667, 0.22222222222222
56738, 0.56521739130435, 1.5, 0.22222222222222
56739, 0.56521739130435, 1.5166666666667, 0.25
56740, 0.58695652173913, 1.5166666666667, 0.27777777777778
56741, 0.56521739130435, 1.5, 0.27777777777778
56742, 0.56521739130435, 1.5166666666667, 0.30555555555556
56743, 0.58695652173913, 1.5166666666667, 0.33333333333333
56744, 0.56521739130435, 1.5, 0.33333333333333
56745, 0.56521739130435, 1.5166666666667, 0.36111111111111
56746, 0.58695652173913, 1.5166666666667, 0.38888888888889
56747, 0.56521739130435, 1.5, 0.38888888888889
56748, 0.56521739130435, 1.5166666666667, 0.41666666666667
56749, 0.58695652173913, 1.5166666666667, 0.44444444444444
56750, 0.56521739130435, 1.5, 0.44444444444444
56751, 0.56521739130435, 1.5166666666667, 0.47222222222222
56752, 0.52173913043478, 1.5166666666667, 0.027777777777778
56753, 0.54347826086957, 1.5166666666667, 0.055555555555556
56754, 0.52173913043478, 1.5, 0.055555555555556
56755, 0.52173913043478, 1.5166666666667, 0.083333333333333
56756, 0.54347826086956, 1.5166666666667, 0.11111111111111
56757, 0.52173913043478, 1.5, 0.11111111111111
56758, 0.52173913043478, 1.5166666666667, 0.13888888888889
56759, 0.54347826086957, 1.5166666666667, 0.16666666666667
56760, 0.52173913043478, 1.5, 0.16666666666667
56761, 0.52173913043478, 1.5166666666667, 0.19444444444444
56762, 0.54347826086956, 1.5166666666667, 0.22222222222222
56763, 0.52173913043478, 1.5, 0.22222222222222
56764, 0.52173913043478, 1.5166666666667, 0.25
56765, 0.54347826086956, 1.5166666666667, 0.27777777777778
56766, 0.52173913043478, 1.5, 0.27777777777778
56767, 0.52173913043478, 1.5166666666667, 0.30555555555556
56768, 0.54347826086956, 1.5166666666667, 0.33333333333333
56769, 0.52173913043478, 1.5, 0.33333333333333
56770, 0.52173913043478, 1.5166666666667, 0.36111111111111
56771, 0.54347826086957, 1.5166666666667, 0.38888888888889
56772, 0.52173913043478, 1.5, 0.38888888888889
56773, 0.52173913043478, 1.5166666666667, 0.41666666666667
56774, 0.54347826086956, 1.5166666666667, 0.44444444444444
56775, 0.52173913043478, 1.5, 0.44444444444444
56776, 0.52173913043478, 1.5166666666667, 0.47222222222222
56777, 0.47826086956522, 1.5166666666667, 0.027777777777778
56778, 0.5, 1.5166666666667, 0.055555555555556
56779, 0.47826086956522, 1.5, 0.055555555555556
56780, 0.47826086956522, 1.5166666666667, 0.083333333333333
56781, 0.5, 1.5166666666667, 0.11111111111111
56782, 0.47826086956522, 1.5, 0.11111111111111
56783, 0.47826086956522, 1.5166666666667, 0.13888888888889
56784, 0.5, 1.5166666666667, 0.16666666666667
56785, 0.47826086956522, 1.5, 0.16666666666667
56786, 0.47826086956522, 1.5166666666667, 0.19444444444444
56787, 0.5, 1.5166666666667, 0.22222222222222
56788, 0.47826086956522, 1.5, 0.22222222222222
56789, 0.47826086956522, 1.5166666666667, 0.25
56790, 0.5, 1.5166666666667, 0.27777777777778
56791, 0.47826086956522, 1.5, 0.27777777777778
56792, 0.47826086956522, 1.5166666666667, 0.30555555555556
56793, 0.5, 1.5166666666667, 0.33333333333333
56794, 0.47826086956522, 1.5, 0.33333333333333
56795, 0.47826086956522, 1.5166666666667, 0.36111111111111
56796, 0.5, 1.5166666666667, 0.38888888888889
56797, 0.47826086956522, 1.5, 0.38888888888889
56798, 0.47826086956522, 1.5166666666667, 0.41666666666667
56799, 0.5, 1.5166666666667, 0.44444444444444
56800, 0.47826086956522, 1.5, 0.44444444444444
56801, 0.47826086956522, 1.5166666666667, 0.47222222222222
56802, 0.43478260869565, 1.5166666666667, 0.027777777777778
56803, 0.45652173913043, 1.5166666666667, 0.055555555555556
56804, 0.43478260869565, 1.5, 0.055555555555556
56805, 0.43478260869565, 1.5166666666667, 0.083333333333333
56806, 0.45652173913043, 1.5166666666667, 0.11111111111111
56807, 0.43478260869565, 1.5, 0.11111111111111
56808, 0.43478260869565, 1.5166666666667, 0.13888888888889
56809, 0.45652173913043, 1.5166666666667, 0.16666666666667
56810, 0.43478260869565, 1.5, 0.16666666666667
56811, 0.43478260869565, 1.5166666666667, 0.19444444444444
56812, 0.45652173913043, 1.5166666666667, 0.22222222222222
56813, 0.43478260869565, 1.5, 0.22222222222222
56814, 0.43478260869565, 1.5166666666667, 0.25
56815, 0.45652173913043, 1.5166666666667, 0.27777777777778
56816, 0.43478260869565, 1.5, 0.27777777777778
56817, 0.43478260869565, 1.5166666666667, 0.30555555555556
56818, 0.45652173913043, 1.5166666666667, 0.33333333333333
56819, 0.43478260869565, 1.5, 0.33333333333333
56820, 0.43478260869565, 1.5166666666667, 0.36111111111111
56821, 0.45652173913043, 1.5166666666667, 0.38888888888889
56822, 0.43478260869565, 1.5, 0.38888888888889
56823, 0.43478260869565, 1.5166666666667, 0.41666666666667
56824, 0.45652173913043, 1.5166666666667, 0.44444444444444
56825, 0.43478260869565, 1.5, 0.44444444444444
56826, 0.43478260869565, 1.5166666666667, 0.47222222222222
56827, 0.39130434782609, 1.5166666666667, 0.027777777777778
56828, 0.41304347826087, 1.5166666666667, 0.055555555555556
56829, 0.39130434782609, 1.5, 0.055555555555556
56830, 0.39130434782609, 1.5166666666667, 0.083333333333333
56831, 0.41304347826087, 1.5166666666667, 0.11111111111111
56832, 0.39130434782609, 1.5, 0.11111111111111
56833, 0.39130434782609, 1.5166666666667, 0.13888888888889
56834, 0.41304347826087, 1.5166666666667, 0.16666666666667
56835, 0.39130434782609, 1.5, 0.16666666666667
56836, 0.39130434782609, 1.5166666666667, 0.19444444444444
56837, 0.41304347826087, 1.5166666666667, 0.22222222222222
56838, 0.39130434782609, 1.5, 0.22222222222222
56839, 0.39130434782609, 1.5166666666667, 0.25
56840, 0.41304347826087, 1.5166666666667, 0.27777777777778
56841, 0.39130434782609, 1.5, 0.27777777777778
56842, 0.39130434782609, 1.5166666666667, 0.30555555555556
56843, 0.41304347826087, 1.5166666666667, 0.33333333333333
56844, 0.39130434782609, 1.5, 0.33333333333333
56845, 0.39130434782609, 1.5166666666667, 0.36111111111111
56846, 0.41304347826087, 1.5166666666667, 0.38888888888889
56847, 0.39130434782609, 1.5, 0.38888888888889
56848, 0.39130434782609, 1.5166666666667, 0.41666666666667
56849, 0.41304347826087, 1.5166666666667, 0.44444444444444
56850, 0.39130434782609, 1.5, 0.44444444444444
56851, 0.39130434782609, 1.5166666666667, 0.47222222222222
56852, 0.34782608695652, 1.5166666666667, 0.027777777777778
56853, 0.3695652173913, 1.5166666666667, 0.055555555555556
56854, 0.34782608695652, 1.5, 0.055555555555556
56855, 0.34782608695652, 1.5166666666667, 0.083333333333333
56856, 0.3695652173913, 1.5166666666667, 0.11111111111111
56857, 0.34782608695652, 1.5, 0.11111111111111
56858, 0.34782608695652, 1.5166666666667, 0.13888888888889
56859, 0.3695652173913, 1.5166666666667, 0.16666666666667
56860, 0.34782608695652, 1.5, 0.16666666666667
56861, 0.34782608695652, 1.5166666666667, 0.19444444444444
56862, 0.3695652173913, 1.5166666666667, 0.22222222222222
56863, 0.34782608695652, 1.5, 0.22222222222222
56864, 0.34782608695652, 1.5166666666667, 0.25
56865, 0.3695652173913, 1.5166666666667, 0.27777777777778
56866, 0.34782608695652, 1.5, 0.27777777777778
56867, 0.34782608695652, 1.5166666666667, 0.30555555555556
56868, 0.3695652173913, 1.5166666666667, 0.33333333333333
56869, 0.34782608695652, 1.5, 0.33333333333333
56870, 0.34782608695652, 1.5166666666667, 0.36111111111111
56871, 0.3695652173913, 1.5166666666667, 0.38888888888889
56872, 0.34782608695652, 1.5, 0.38888888888889
56873, 0.34782608695652, 1.5166666666667, 0.41666666666667
56874, 0.3695652173913, 1.5166666666667, 0.44444444444444
56875, 0.34782608695652, 1.5, 0.44444444444444
56876, 0.34782608695652, 1.5166666666667, 0.47222222222222
56877, 0.30434782608696, 1.5166666666667, 0.027777777777778
56878, 0.32608695652174, 1.5166666666667, 0.055555555555556
56879, 0.30434782608696, 1.5, 0.055555555555556
56880, 0.30434782608696, 1.5166666666667, 0.083333333333333
56881, 0.32608695652174, 1.5166666666667, 0.11111111111111
56882, 0.30434782608696, 1.5, 0.11111111111111
56883, 0.30434782608696, 1.5166666666667, 0.13888888888889
56884, 0.32608695652174, 1.5166666666667, 0.16666666666667
56885, 0.30434782608696, 1.5, 0.16666666666667
56886, 0.30434782608696, 1.5166666666667, 0.19444444444444
56887, 0.32608695652174, 1.5166666666667, 0.22222222222222
56888, 0.30434782608696, 1.5, 0.22222222222222
56889, 0.30434782608696, 1.5166666666667, 0.25
56890, 0.32608695652174, 1.5166666666667, 0.27777777777778
56891, 0.30434782608696, 1.5, 0.27777777777778
56892, 0.30434782608696, 1.5166666666667, 0.30555555555556
56893, 0.32608695652174, 1.5166666666667, 0.33333333333333
56894, 0.30434782608696, 1.5, 0.33333333333333
56895, 0.30434782608696, 1.5166666666667, 0.36111111111111
56896, 0.32608695652174, 1.5166666666667, 0.38888888888889
56897, 0.30434782608696, 1.5, 0.38888888888889
56898, 0.30434782608696, 1.5166666666667, 0.41666666666667
56899, 0.32608695652174, 1.5166666666667, 0.44444444444444
56900, 0.30434782608696, 1.5, 0.44444444444444
56901, 0.30434782608696, 1.5166666666667, 0.47222222222222
56902, 0.26086956521739, 1.5166666666667, 0.027777777777778
56903, 0.28260869565217, 1.5166666666667, 0.055555555555556
56904, 0.26086956521739, 1.5, 0.055555555555556
56905, 0.26086956521739, 1.5166666666667, 0.083333333333333
56906, 0.28260869565217, 1.5166666666667, 0.11111111111111
56907, 0.26086956521739, 1.5, 0.11111111111111
56908, 0.26086956521739, 1.5166666666667, 0.13888888888889
56909, 0.28260869565217, 1.5166666666667, 0.16666666666667
56910, 0.26086956521739, 1.5, 0.16666666666667
56911, 0.26086956521739, 1.5166666666667, 0.19444444444444
56912, 0.28260869565217, 1.5166666666667, 0.22222222222222
56913, 0.26086956521739, 1.5, 0.22222222222222
56914, 0.26086956521739, 1.5166666666667, 0.25
56915, 0.28260869565217, 1.5166666666667, 0.27777777777778
56916, 0.26086956521739, 1.5, 0.27777777777778
56917, 0.26086956521739, 1.5166666666667, 0.30555555555556
56918, 0.28260869565217, 1.5166666666667, 0.33333333333333
56919, 0.26086956521739, 1.5, 0.33333333333333
56920, 0.26086956521739, 1.5166666666667, 0.36111111111111
56921, 0.28260869565217, 1.5166666666667, 0.38888888888889
56922, 0.26086956521739, 1.5, 0.38888888888889
56923, 0.26086956521739, 1.5166666666667, 0.41666666666667
56924, 0.28260869565217, 1.5166666666667, 0.44444444444444
56925, 0.26086956521739, 1.5, 0.44444444444444
56926, 0.26086956521739, 1.5166666666667, 0.47222222222222
56927, 0.21739130434783, 1.5166666666667, 0.027777777777778
56928, 0.23913043478261, 1.5166666666667, 0.055555555555556
56929, 0.21739130434783, 1.5, 0.055555555555556
56930, 0.21739130434783, 1.5166666666667, 0.083333333333333
56931, 0.23913043478261, 1.5166666666667, 0.11111111111111
56932, 0.21739130434783, 1.5, 0.11111111111111
56933, 0.21739130434783, 1.5166666666667, 0.13888888888889
56934, 0.23913043478261, 1.5166666666667, 0.16666666666667
56935, 0.21739130434783, 1.5, 0.16666666666667
56936, 0.21739130434783, 1.5166666666667, 0.19444444444444
56937, 0.23913043478261, 1.5166666666667, 0.22222222222222
56938, 0.21739130434783, 1.5, 0.22222222222222
56939, 0.21739130434783, 1.5166666666667, 0.25
56940, 0.23913043478261, 1.5166666666667, 0.27777777777778
56941, 0.21739130434783, 1.5, 0.27777777777778
56942, 0.21739130434783, 1.5166666666667, 0.30555555555556
56943, 0.23913043478261, 1.5166666666667, 0.33333333333333
56944, 0.21739130434783, 1.5, 0.33333333333333
56945, 0.21739130434783, 1.5166666666667, 0.36111111111111
56946, 0.23913043478261, 1.5166666666667, 0.38888888888889
56947, 0.21739130434783, 1.5, 0.38888888888889
56948, 0.21739130434783, 1.5166666666667, 0.41666666666667
56949, 0.23913043478261, 1.5166666666667, 0.44444444444444
56950, 0.21739130434783, 1.5, 0.44444444444444
56951, 0.21739130434783, 1.5166666666667, 0.47222222222222
56952, 0.17391304347826, 1.5166666666667, 0.027777777777778
56953, 0.19565217391304, 1.5166666666667, 0.055555555555556
56954, 0.17391304347826, 1.5, 0.055555555555556
56955, 0.17391304347826, 1.5166666666667, 0.083333333333333
56956, 0.19565217391304, 1.5166666666667, 0.11111111111111
56957, 0.17391304347826, 1.5, 0.11111111111111
56958, 0.17391304347826, 1.5166666666667, 0.13888888888889
56959, 0.19565217391304, 1.5166666666667, 0.16666666666667
56960, 0.17391304347826, 1.5, 0.16666666666667
56961, 0.17391304347826, 1.5166666666667, 0.19444444444444
56962, 0.19565217391304, 1.5166666666667, 0.22222222222222
56963, 0.17391304347826, 1.5, 0.22222222222222
56964, 0.17391304347826, 1.5166666666667, 0.25
56965, 0.19565217391304, 1.5166666666667, 0.27777777777778
56966, 0.17391304347826, 1.5, 0.27777777777778
56967, 0.17391304347826, 1.5166666666667, 0.30555555555556
56968, 0.19565217391304, 1.5166666666667, 0.33333333333333
56969, 0.17391304347826, 1.5, 0.33333333333333
56970, 0.17391304347826, 1.5166666666667, 0.36111111111111
56971, 0.19565217391304, 1.5166666666667, 0.38888888888889
56972, 0.17391304347826, 1.5, 0.38888888888889
56973, 0.17391304347826, 1.5166666666667, 0.41666666666667
56974, 0.19565217391304, 1.5166666666667, 0.44444444444444
56975, 0.17391304347826, 1.5, 0.44444444444444
56976, 0.17391304347826, 1.5166666666667, 0.47222222222222
56977, 0.1304347826087, 1.5166666666667, 0.027777777777778
56978, 0.15217391304348, 1.5166666666667, 0.055555555555556
56979, 0.1304347826087, 1.5, 0.055555555555556
56980, 0.1304347826087, 1.5166666666667, 0.083333333333333
56981, 0.15217391304348, 1.5166666666667, 0.11111111111111
56982, 0.1304347826087, 1.5, 0.11111111111111
56983, 0.1304347826087, 1.5166666666667, 0.13888888888889
56984, 0.15217391304348, 1.5166666666667, 0.16666666666667
56985, 0.1304347826087, 1.5, 0.16666666666667
56986, 0.1304347826087, 1.5166666666667, 0.19444444444444
56987, 0.15217391304348, 1.5166666666667, 0.22222222222222
56988, 0.1304347826087, 1.5, 0.22222222222222
56989, 0.1304347826087, 1.5166666666667, 0.25
56990, 0.15217391304348, 1.5166666666667, 0.27777777777778
56991, 0.1304347826087, 1.5, 0.27777777777778
56992, 0.1304347826087, 1.5166666666667, 0.30555555555556
56993, 0.15217391304348, 1.5166666666667, 0.33333333333333
56994, 0.1304347826087, 1.5, 0.33333333333333
56995, 0.1304347826087, 1.5166666666667, 0.36111111111111
56996, 0.15217391304348, 1.5166666666667, 0.38888888888889
56997, 0.1304347826087, 1.5, 0.38888888888889
56998, 0.1304347826087, 1.5166666666667, 0.41666666666667
56999, 0.15217391304348, 1.5166666666667, 0.44444444444444
57000, 0.1304347826087, 1.5, 0.44444444444444
57001, 0.1304347826087, 1.5166666666667, 0.47222222222222
57002, 0.08695652173913, 1.5166666666667, 0.027777777777778
57003, 0.10869565217391, 1.5166666666667, 0.055555555555556
57004, 0.08695652173913, 1.5, 0.055555555555556
57005, 0.08695652173913, 1.5166666666667, 0.083333333333333
57006, 0.10869565217391, 1.5166666666667, 0.11111111111111
57007, 0.08695652173913, 1.5, 0.11111111111111
57008, 0.08695652173913, 1.5166666666667, 0.13888888888889
57009, 0.10869565217391, 1.5166666666667, 0.16666666666667
57010, 0.08695652173913, 1.5, 0.16666666666667
57011, 0.08695652173913, 1.5166666666667, 0.19444444444444
57012, 0.10869565217391, 1.5166666666667, 0.22222222222222
57013, 0.08695652173913, 1.5, 0.22222222222222
57014, 0.08695652173913, 1.5166666666667, 0.25
57015, 0.10869565217391, 1.5166666666667, 0.27777777777778
57016, 0.08695652173913, 1.5, 0.27777777777778
57017, 0.08695652173913, 1.5166666666667, 0.30555555555556
57018, 0.10869565217391, 1.5166666666667, 0.33333333333333
57019, 0.08695652173913, 1.5, 0.33333333333333
57020, 0.08695652173913, 1.5166666666667, 0.36111111111111
57021, 0.10869565217391, 1.5166666666667, 0.38888888888889
57022, 0.08695652173913, 1.5, 0.38888888888889
57023, 0.08695652173913, 1.5166666666667, 0.41666666666667
57024, 0.10869565217391, 1.5166666666667, 0.44444444444444
57025, 0.08695652173913, 1.5, 0.44444444444444
57026, 0.08695652173913, 1.5166666666667, 0.47222222222222
57027, 0.043478260869565, 1.5166666666667, 0.027777777777778
57028, 0.065217391304348, 1.5166666666667, 0.055555555555556
57029, 0.043478260869565, 1.5, 0.055555555555556
57030, 0.043478260869565, 1.5166666666667, 0.083333333333333
57031, 0.065217391304348, 1.5166666666667, 0.11111111111111
57032, 0.043478260869565, 1.5, 0.11111111111111
57033, 0.043478260869565, 1.5166666666667, 0.13888888888889
57034, 0.065217391304348, 1.5166666666667, 0.16666666666667
57035, 0.043478260869565, 1.5, 0.16666666666667
57036, 0.043478260869565, 1.5166666666667, 0.19444444444444
57037, 0.065217391304348, 1.5166666666667, 0.22222222222222
57038, 0.043478260869565, 1.5, 0.22222222222222
57039, 0.043478260869565, 1.5166666666667, 0.25
57040, 0.065217391304348, 1.5166666666667, 0.27777777777778
57041, 0.043478260869565, 1.5, 0.27777777777778
57042, 0.043478260869565, 1.5166666666667, 0.30555555555556
57043, 0.065217391304348, 1.5166666666667, 0.33333333333333
57044, 0.043478260869565, 1.5, 0.33333333333333
57045, 0.043478260869565, 1.5166666666667, 0.36111111111111
57046, 0.065217391304348, 1.5166666666667, 0.38888888888889
57047, 0.043478260869565, 1.5, 0.38888888888889
57048, 0.043478260869565, 1.5166666666667, 0.41666666666667
57049, 0.065217391304348, 1.5166666666667, 0.44444444444444
57050, 0.043478260869565, 1.5, 0.44444444444444
57051, 0.043478260869565, 1.5166666666667, 0.47222222222222
57052, 0.021739130434783, 1.5166666666667, 0.055555555555556
57053, 0.021739130434783, 1.5166666666667, 0.11111111111111
57054, 0.021739130434783, 1.5166666666667, 0.16666666666667
57055, 0.021739130434783, 1.5166666666667, 0.22222222222222
57056, 0.021739130434783, 1.5166666666667, 0.27777777777778
57057, 0.021739130434783, 1.5166666666667, 0.33333333333333
57058, 0.021739130434783, 1.5166666666667, 0.38888888888889
57059, 0.021739130434783, 1.5166666666667, 0.44444444444444
57060, 0.95652173913043, 1.5333333333333, 0.055555555555556
57061, 0.95652173913043, 1.5333333333333, 0.11111111111111
57062, 0.95652173913044, 1.5333333333333, 0.16666666666667
57063, 0.95652173913043, 1.5333333333333, 0.22222222222222
57064, 0.95652173913043, 1.5333333333333, 0.27777777777778
57065, 0.95652173913043, 1.5333333333333, 0.33333333333333
57066, 0.95652173913043, 1.5333333333333, 0.38888888888889
57067, 0.95652173913043, 1.5333333333333, 0.44444444444444
57068, 0.91304347826087, 1.5333333333333, 0.055555555555556
57069, 0.91304347826087, 1.5333333333333, 0.11111111111111
57070, 0.91304347826087, 1.5333333333333, 0.16666666666667
57071, 0.91304347826087, 1.5333333333333, 0.22222222222222
57072, 0.91304347826087, 1.5333333333333, 0.27777777777778
57073, 0.91304347826087, 1.5333333333333, 0.33333333333333
57074, 0.91304347826087, 1.5333333333333, 0.38888888888889
57075, 0.91304347826087, 1.5333333333333, 0.44444444444444
57076, 0.8695652173913, 1.5333333333333, 0.055555555555556
57077, 0.8695652173913, 1.5333333333333, 0.11111111111111
57078, 0.8695652173913, 1.5333333333333, 0.16666666666667
57079, 0.8695652173913, 1.5333333333333, 0.22222222222222
57080, 0.8695652173913, 1.5333333333333, 0.27777777777778
57081, 0.8695652173913, 1.5333333333333, 0.33333333333333
57082, 0.8695652173913, 1.5333333333333, 0.38888888888889
57083, 0.8695652173913, 1.5333333333333, 0.44444444444444
57084, 0.82608695652174, 1.5333333333333, 0.055555555555556
57085, 0.82608695652174, 1.5333333333333, 0.11111111111111
57086, 0.82608695652174, 1.5333333333333, 0.16666666666667
57087, 0.82608695652174, 1.5333333333333, 0.22222222222222
57088, 0.82608695652174, 1.5333333333333, 0.27777777777778
57089, 0.82608695652174, 1.5333333333333, 0.33333333333333
57090, 0.82608695652174, 1.5333333333333, 0.38888888888889
57091, 0.82608695652174, 1.5333333333333, 0.44444444444444
57092, 0.78260869565217, 1.5333333333333, 0.055555555555556
57093, 0.78260869565217, 1.5333333333333, 0.11111111111111
57094, 0.78260869565217, 1.5333333333333, 0.16666666666667
57095, 0.78260869565217, 1.5333333333333, 0.22222222222222
57096, 0.78260869565217, 1.5333333333333, 0.27777777777778
57097, 0.78260869565217, 1.5333333333333, 0.33333333333333
57098, 0.78260869565217, 1.5333333333333, 0.38888888888889
57099, 0.78260869565217, 1.5333333333333, 0.44444444444444
57100, 0.73913043478261, 1.5333333333333, 0.055555555555556
57101, 0.73913043478261, 1.5333333333333, 0.11111111111111
57102, 0.73913043478261, 1.5333333333333, 0.16666666666667
57103, 0.73913043478261, 1.5333333333333, 0.22222222222222
57104, 0.73913043478261, 1.5333333333333, 0.27777777777778
57105, 0.73913043478261, 1.5333333333333, 0.33333333333333
57106, 0.73913043478261, 1.5333333333333, 0.38888888888889
57107, 0.73913043478261, 1.5333333333333, 0.44444444444444
57108, 0.69565217391304, 1.5333333333333, 0.055555555555556
57109, 0.69565217391304, 1.5333333333333, 0.11111111111111
57110, 0.69565217391304, 1.5333333333333, 0.16666666666667
57111, 0.69565217391304, 1.5333333333333, 0.22222222222222
57112, 0.69565217391304, 1.5333333333333, 0.27777777777778
57113, 0.69565217391304, 1.5333333333333, 0.33333333333333
57114, 0.69565217391304, 1.5333333333333, 0.38888888888889
57115, 0.69565217391304, 1.5333333333333, 0.44444444444444
57116, 0.65217391304348, 1.5333333333333, 0.055555555555556
57117, 0.65217391304348, 1.5333333333333, 0.11111111111111
57118, 0.65217391304348, 1.5333333333333, 0.16666666666667
57119, 0.65217391304348, 1.5333333333333, 0.22222222222222
57120, 0.65217391304348, 1.5333333333333, 0.27777777777778
57121, 0.65217391304348, 1.5333333333333, 0.33333333333333
57122, 0.65217391304348, 1.5333333333333, 0.38888888888889
57123, 0.65217391304348, 1.5333333333333, 0.44444444444444
57124, 0.60869565217391, 1.5333333333333, 0.055555555555556
57125, 0.60869565217391, 1.5333333333333, 0.11111111111111
57126, 0.60869565217391, 1.5333333333333, 0.16666666666667
57127, 0.60869565217391, 1.5333333333333, 0.22222222222222
57128, 0.60869565217391, 1.5333333333333, 0.27777777777778
57129, 0.60869565217391, 1.5333333333333, 0.33333333333333
57130, 0.60869565217391, 1.5333333333333, 0.38888888888889
57131, 0.60869565217391, 1.5333333333333, 0.44444444444444
57132, 0.56521739130435, 1.5333333333333, 0.055555555555556
57133, 0.56521739130435, 1.5333333333333, 0.11111111111111
57134, 0.56521739130435, 1.5333333333333, 0.16666666666667
57135, 0.56521739130435, 1.5333333333333, 0.22222222222222
57136, 0.56521739130435, 1.5333333333333, 0.27777777777778
57137, 0.56521739130435, 1.5333333333333, 0.33333333333333
57138, 0.56521739130435, 1.5333333333333, 0.38888888888889
57139, 0.56521739130435, 1.5333333333333, 0.44444444444444
57140, 0.52173913043478, 1.5333333333333, 0.055555555555556
57141, 0.52173913043478, 1.5333333333333, 0.11111111111111
57142, 0.52173913043478, 1.5333333333333, 0.16666666666667
57143, 0.52173913043478, 1.5333333333333, 0.22222222222222
57144, 0.52173913043478, 1.5333333333333, 0.27777777777778
57145, 0.52173913043478, 1.5333333333333, 0.33333333333333
57146, 0.52173913043478, 1.5333333333333, 0.38888888888889
57147, 0.52173913043478, 1.5333333333333, 0.44444444444444
57148, 0.47826086956522, 1.5333333333333, 0.055555555555556
57149, 0.47826086956522, 1.5333333333333, 0.11111111111111
57150, 0.47826086956522, 1.5333333333333, 0.16666666666667
57151, 0.47826086956522, 1.5333333333333, 0.22222222222222
57152, 0.47826086956522, 1.5333333333333, 0.27777777777778
57153, 0.47826086956522, 1.5333333333333, 0.33333333333333
57154, 0.47826086956522, 1.5333333333333, 0.38888888888889
57155, 0.47826086956522, 1.5333333333333, 0.44444444444444
57156, 0.43478260869565, 1.5333333333333, 0.055555555555556
57157, 0.43478260869565, 1.5333333333333, 0.11111111111111
57158, 0.43478260869565, 1.5333333333333, 0.16666666666667
57159, 0.43478260869565, 1.5333333333333, 0.22222222222222
57160, 0.43478260869565, 1.5333333333333, 0.27777777777778
57161, 0.43478260869565, 1.5333333333333, 0.33333333333333
57162, 0.43478260869565, 1.5333333333333, 0.38888888888889
57163, 0.43478260869565, 1.5333333333333, 0.44444444444444
57164, 0.39130434782609, 1.5333333333333, 0.055555555555556
57165, 0.39130434782609, 1.5333333333333, 0.11111111111111
57166, 0.39130434782609, 1.5333333333333, 0.16666666666667
57167, 0.39130434782609, 1.5333333333333, 0.22222222222222
57168, 0.39130434782609, 1.5333333333333, 0.27777777777778
57169, 0.39130434782609, 1.5333333333333, 0.33333333333333
57170, 0.39130434782609, 1.5333333333333, 0.38888888888889
57171, 0.39130434782609, 1.5333333333333, 0.44444444444444
57172, 0.34782608695652, 1.5333333333333, 0.055555555555556
57173, 0.34782608695652, 1.5333333333333, 0.11111111111111
57174, 0.34782608695652, 1.5333333333333, 0.16666666666667
57175, 0.34782608695652, 1.5333333333333, 0.22222222222222
57176, 0.34782608695652, 1.5333333333333, 0.27777777777778
57177, 0.34782608695652, 1.5333333333333, 0.33333333333333
57178, 0.34782608695652, 1.5333333333333, 0.38888888888889
57179, 0.34782608695652, 1.5333333333333, 0.44444444444444
57180, 0.30434782608696, 1.5333333333333, 0.055555555555556
57181, 0.30434782608696, 1.5333333333333, 0.11111111111111
57182, 0.30434782608696, 1.5333333333333, 0.16666666666667
57183, 0.30434782608696, 1.5333333333333, 0.22222222222222
57184, 0.30434782608696, 1.5333333333333, 0.27777777777778
57185, 0.30434782608696, 1.5333333333333, 0.33333333333333
57186, 0.30434782608696, 1.5333333333333, 0.38888888888889
57187, 0.30434782608696, 1.5333333333333, 0.44444444444444
57188, 0.26086956521739, 1.5333333333333, 0.055555555555556
57189, 0.26086956521739, 1.5333333333333, 0.11111111111111
57190, 0.26086956521739, 1.5333333333333, 0.16666666666667
57191, 0.26086956521739, 1.5333333333333, 0.22222222222222
57192, 0.26086956521739, 1.5333333333333, 0.27777777777778
57193, 0.26086956521739, 1.5333333333333, 0.33333333333333
57194, 0.26086956521739, 1.5333333333333, 0.38888888888889
57195, 0.26086956521739, 1.5333333333333, 0.44444444444444
57196, 0.21739130434783, 1.5333333333333, 0.055555555555556
57197, 0.21739130434783, 1.5333333333333, 0.11111111111111
57198, 0.21739130434783, 1.5333333333333, 0.16666666666667
57199, 0.21739130434783, 1.5333333333333, 0.22222222222222
57200, 0.21739130434783, 1.5333333333333, 0.27777777777778
57201, 0.21739130434783, 1.5333333333333, 0.33333333333333
57202, 0.21739130434783, 1.5333333333333, 0.38888888888889
57203, 0.21739130434783, 1.5333333333333, 0.44444444444444
57204, 0.17391304347826, 1.5333333333333, 0.055555555555556
57205, 0.17391304347826, 1.5333333333333, 0.11111111111111
57206, 0.17391304347826, 1.5333333333333, 0.16666666666667
57207, 0.17391304347826, 1.5333333333333, 0.22222222222222
57208, 0.17391304347826, 1.5333333333333, 0.27777777777778
57209, 0.17391304347826, 1.5333333333333, 0.33333333333333
57210, 0.17391304347826, 1.5333333333333, 0.38888888888889
57211, 0.17391304347826, 1.5333333333333, 0.44444444444444
57212, 0.1304347826087, 1.5333333333333, 0.055555555555556
57213, 0.1304347826087, 1.5333333333333, 0.11111111111111
57214, 0.1304347826087, 1.5333333333333, 0.16666666666667
57215, 0.1304347826087, 1.5333333333333, 0.22222222222222
57216, 0.1304347826087, 1.5333333333333, 0.27777777777778
57217, 0.1304347826087, 1.5333333333333, 0.33333333333333
57218, 0.1304347826087, 1.5333333333333, 0.38888888888889
57219, 0.1304347826087, 1.5333333333333, 0.44444444444444
57220, 0.08695652173913, 1.5333333333333, 0.055555555555556
57221, 0.08695652173913, 1.5333333333333, 0.11111111111111
57222, 0.08695652173913, 1.5333333333333, 0.16666666666667
57223, 0.08695652173913, 1.5333333333333, 0.22222222222222
57224, 0.08695652173913, 1.5333333333333, 0.27777777777778
57225, 0.08695652173913, 1.5333333333333, 0.33333333333333
57226, 0.08695652173913, 1.5333333333333, 0.38888888888889
57227, 0.08695652173913, 1.5333333333333, 0.44444444444444
57228, 0.043478260869565, 1.5333333333333, 0.055555555555556
57229, 0.043478260869565, 1.5333333333333, 0.11111111111111
57230, 0.043478260869565, 1.5333333333333, 0.16666666666667
57231, 0.043478260869565, 1.5333333333333, 0.22222222222222
57232, 0.043478260869565, 1.5333333333333, 0.27777777777778
57233, 0.043478260869565, 1.5333333333333, 0.33333333333333
57234, 0.043478260869565, 1.5333333333333, 0.38888888888889
57235, 0.043478260869565, 1.5333333333333, 0.44444444444444
57236, 1.05, 1.4833333333333, 0.44444444444444
57237, 1.05, 1.4833333333333, 0.38888888888889
57238, 1.05, 1.4833333333333, 0.33333333333333
57239, 1.05, 1.4833333333333, 0.27777777777778
57240, 1.05, 1.4833333333333, 0.22222222222222
57241, 1.05, 1.4833333333333, 0.16666666666667
57242, 1.05, 1.4833333333333, 0.11111111111111
57243, 1.05, 1.4833333333333, 0.055555555555556
57244, 1.05, 1.5166666666667, 0.44444444444444
57245, 1.05, 1.5166666666667, 0.38888888888889
57246, 1.05, 1.5166666666667, 0.33333333333333
57247, 1.05, 1.5166666666667, 0.27777777777778
57248, 1.05, 1.5166666666667, 0.22222222222222
57249, 1.05, 1.5166666666667, 0.16666666666667
57250, 1.05, 1.5166666666667, 0.11111111111111
57251, 1.05, 1.5166666666667, 0.055555555555556
57252, 1.1, 1.4833333333333, 0.44444444444444
57253, 1.1, 1.4833333333333, 0.38888888888889
57254, 1.1, 1.4833333333333, 0.33333333333333
57255, 1.1, 1.4833333333333, 0.27777777777778
57256, 1.1, 1.4833333333333, 0.22222222222222
57257, 1.1, 1.4833333333333, 0.16666666666667
57258, 1.1, 1.4833333333333, 0.11111111111111
57259, 1.1, 1.4833333333333, 0.055555555555556
57260, 1.1, 1.5166666666667, 0.44444444444444
57261, 1.1, 1.5166666666667, 0.38888888888889
57262, 1.1, 1.5166666666667, 0.33333333333333
57263, 1.1, 1.5166666666667, 0.27777777777778
57264, 1.1, 1.5166666666667, 0.22222222222222
57265, 1.1, 1.5166666666667, 0.16666666666667
57266, 1.1, 1.5166666666667, 0.11111111111111
57267, 1.1, 1.5166666666667, 0.055555555555556
57268, 1.15, 1.4833333333333, 0.44444444444444
57269, 1.15, 1.4833333333333, 0.38888888888889
57270, 1.15, 1.4833333333333, 0.33333333333333
57271, 1.15, 1.4833333333333, 0.27777777777778
57272, 1.15, 1.4833333333333, 0.22222222222222
57273, 1.15, 1.4833333333333, 0.16666666666667
57274, 1.15, 1.4833333333333, 0.11111111111111
57275, 1.15, 1.4833333333333, 0.055555555555556
57276, 1.15, 1.5166666666667, 0.44444444444444
57277, 1.15, 1.5166666666667, 0.38888888888889
57278, 1.15, 1.5166666666667, 0.33333333333333
57279, 1.15, 1.5166666666667, 0.27777777777778
57280, 1.15, 1.5166666666667, 0.22222222222222
57281, 1.15, 1.5166666666667, 0.16666666666667
57282, 1.15, 1.5166666666667, 0.11111111111111
57283, 1.15, 1.5166666666667, 0.055555555555556
57284, 1.05, 1.4833333333333, 0.47222222222222
57285, 1.05, 1.4666666666667, 0.44444444444444
57286, 1.025, 1.4833333333333, 0.44444444444444
57287, 1.05, 1.4833333333333, 0.41666666666667
57288, 1.05, 1.4666666666667, 0.38888888888889
57289, 1.025, 1.4833333333333, 0.38888888888889
57290, 1.05, 1.4833333333333, 0.36111111111111
57291, 1.05, 1.4666666666667, 0.33333333333333
57292, 1.025, 1.4833333333333, 0.33333333333333
57293, 1.05, 1.4833333333333, 0.30555555555556
57294, 1.05, 1.4666666666667, 0.27777777777778
57295, 1.025, 1.4833333333333, 0.27777777777778
57296, 1.05, 1.4833333333333, 0.25
57297, 1.05, 1.4666666666667, 0.22222222222222
57298, 1.025, 1.4833333333333, 0.22222222222222
57299, 1.05, 1.4833333333333, 0.19444444444444
57300, 1.05, 1.4666666666667, 0.16666666666667
57301, 1.025, 1.4833333333333, 0.16666666666667
57302, 1.05, 1.4833333333333, 0.13888888888889
57303, 1.05, 1.4666666666667, 0.11111111111111
57304, 1.025, 1.4833333333333, 0.11111111111111
57305, 1.05, 1.4833333333333, 0.083333333333333
57306, 1.05, 1.4666666666667, 0.055555555555556
57307, 1.025, 1.4833333333333, 0.055555555555556
57308, 1.05, 1.4833333333333, 0.027777777777778
57309, 1.05, 1.5166666666667, 0.47222222222222
57310, 1.05, 1.5, 0.44444444444444
57311, 1.025, 1.5166666666667, 0.44444444444444
57312, 1.05, 1.5166666666667, 0.41666666666667
57313, 1.05, 1.5, 0.38888888888889
57314, 1.025, 1.5166666666667, 0.38888888888889
57315, 1.05, 1.5166666666667, 0.36111111111111
57316, 1.05, 1.5, 0.33333333333333
57317, 1.025, 1.5166666666667, 0.33333333333333
57318, 1.05, 1.5166666666667, 0.30555555555556
57319, 1.05, 1.5, 0.27777777777778
57320, 1.025, 1.5166666666667, 0.27777777777778
57321, 1.05, 1.5166666666667, 0.25
57322, 1.05, 1.5, 0.22222222222222
57323, 1.025, 1.5166666666667, 0.22222222222222
57324, 1.05, 1.5166666666667, 0.19444444444444
57325, 1.05, 1.5, 0.16666666666667
57326, 1.025, 1.5166666666667, 0.16666666666667
57327, 1.05, 1.5166666666667, 0.13888888888889
57328, 1.05, 1.5, 0.11111111111111
57329, 1.025, 1.5166666666667, 0.11111111111111
57330, 1.05, 1.5166666666667, 0.083333333333333
57331, 1.05, 1.5, 0.055555555555556
57332, 1.025, 1.5166666666667, 0.055555555555556
57333, 1.05, 1.5166666666667, 0.027777777777778
57334, 1.05, 1.5333333333333, 0.44444444444444
57335, 1.05, 1.5333333333333, 0.38888888888889
57336, 1.05, 1.5333333333333, 0.33333333333333
57337, 1.05, 1.5333333333333, 0.27777777777778
57338, 1.05, 1.5333333333333, 0.22222222222222
57339, 1.05, 1.5333333333333, 0.16666666666667
57340, 1.05, 1.5333333333333, 0.11111111111111
57341, 1.05, 1.5333333333333, 0.055555555555556
57342, 1.1, 1.4833333333333, 0.47222222222222
57343, 1.1, 1.4666666666667, 0.44444444444444
57344, 1.075, 1.4833333333333, 0.44444444444444
57345, 1.1, 1.4833333333333, 0.41666666666667
57346, 1.1, 1.4666666666667, 0.38888888888889
57347, 1.075, 1.4833333333333, 0.38888888888889
57348, 1.1, 1.4833333333333, 0.36111111111111
57349, 1.1, 1.4666666666667, 0.33333333333333
57350, 1.075, 1.4833333333333, 0.33333333333333
57351, 1.1, 1.4833333333333, 0.30555555555556
57352, 1.1, 1.4666666666667, 0.27777777777778
57353, 1.075, 1.4833333333333, 0.27777777777778
57354, 1.1, 1.4833333333333, 0.25
57355, 1.1, 1.4666666666667, 0.22222222222222
57356, 1.075, 1.4833333333333, 0.22222222222222
57357, 1.1, 1.4833333333333, 0.19444444444444
57358, 1.1, 1.4666666666667, 0.16666666666667
57359, 1.075, 1.4833333333333, 0.16666666666667
57360, 1.1, 1.4833333333333, 0.13888888888889
57361, 1.1, 1.4666666666667, 0.11111111111111
57362, 1.075, 1.4833333333333, 0.11111111111111
57363, 1.1, 1.4833333333333, 0.083333333333333
57364, 1.1, 1.4666666666667, 0.055555555555556
57365, 1.075, 1.4833333333333, 0.055555555555556
57366, 1.1, 1.4833333333333, 0.027777777777778
57367, 1.1, 1.5166666666667, 0.47222222222222
57368, 1.1, 1.5, 0.44444444444444
57369, 1.075, 1.5166666666667, 0.44444444444444
57370, 1.1, 1.5166666666667, 0.41666666666667
57371, 1.1, 1.5, 0.38888888888889
57372, 1.075, 1.5166666666667, 0.38888888888889
57373, 1.1, 1.5166666666667, 0.36111111111111
57374, 1.1, 1.5, 0.33333333333333
57375, 1.075, 1.5166666666667, 0.33333333333333
57376, 1.1, 1.5166666666667, 0.30555555555556
57377, 1.1, 1.5, 0.27777777777778
57378, 1.075, 1.5166666666667, 0.27777777777778
57379, 1.1, 1.5166666666667, 0.25
57380, 1.1, 1.5, 0.22222222222222
57381, 1.075, 1.5166666666667, 0.22222222222222
57382, 1.1, 1.5166666666667, 0.19444444444444
57383, 1.1, 1.5, 0.16666666666667
57384, 1.075, 1.5166666666667, 0.16666666666667
57385, 1.1, 1.5166666666667, 0.13888888888889
57386, 1.1, 1.5, 0.11111111111111
57387, 1.075, 1.5166666666667, 0.11111111111111
57388, 1.1, 1.5166666666667, 0.083333333333333
57389, 1.1, 1.5, 0.055555555555556
57390, 1.075, 1.5166666666667, 0.055555555555556
57391, 1.1, 1.5166666666667, 0.027777777777778
57392, 1.1, 1.5333333333333, 0.44444444444444
57393, 1.1, 1.5333333333333, 0.38888888888889
57394, 1.1, 1.5333333333333, 0.33333333333333
57395, 1.1, 1.5333333333333, 0.27777777777778
57396, 1.1, 1.5333333333333, 0.22222222222222
57397, 1.1, 1.5333333333333, 0.16666666666667
57398, 1.1, 1.5333333333333, 0.11111111111111
57399, 1.1, 1.5333333333333, 0.055555555555556
57400, 1.15, 1.4833333333333, 0.47222222222222
57401, 1.15, 1.4666666666667, 0.44444444444444
57402, 1.125, 1.4833333333333, 0.44444444444444
57403, 1.15, 1.4833333333333, 0.41666666666667
57404, 1.15, 1.4666666666667, 0.38888888888889
57405, 1.125, 1.4833333333333, 0.38888888888889
57406, 1.15, 1.4833333333333, 0.36111111111111
57407, 1.15, 1.4666666666667, 0.33333333333333
57408, 1.125, 1.4833333333333, 0.33333333333333
57409, 1.15, 1.4833333333333, 0.30555555555556
57410, 1.15, 1.4666666666667, 0.27777777777778
57411, 1.125, 1.4833333333333, 0.27777777777778
57412, 1.15, 1.4833333333333, 0.25
57413, 1.15, 1.4666666666667, 0.22222222222222
57414, 1.125, 1.4833333333333, 0.22222222222222
57415, 1.15, 1.4833333333333, 0.19444444444444
57416, 1.15, 1.4666666666667, 0.16666666666667
57417, 1.125, 1.4833333333333, 0.16666666666667
57418, 1.15, 1.4833333333333, 0.13888888888889
57419, 1.15, 1.4666666666667, 0.11111111111111
57420, 1.125, 1.4833333333333, 0.11111111111111
57421, 1.15, 1.4833333333333, 0.083333333333333
57422, 1.15, 1.4666666666667, 0.055555555555556
57423, 1.125, 1.4833333333333, 0.055555555555556
57424, 1.15, 1.4833333333333, 0.027777777777778
57425, 1.15, 1.5166666666667, 0.47222222222222
57426, 1.15, 1.5, 0.44444444444444
57427, 1.125, 1.5166666666667, 0.44444444444444
57428, 1.15, 1.5166666666667, 0.41666666666667
57429, 1.15, 1.5, 0.38888888888889
57430, 1.125, 1.5166666666667, 0.38888888888889
57431, 1.15, 1.5166666666667, 0.36111111111111
57432, 1.15, 1.5, 0.33333333333333
57433, 1.125, 1.5166666666667, 0.33333333333333
57434, 1.15, 1.5166666666667, 0.30555555555556
57435, 1.15, 1.5, 0.27777777777778
57436, 1.125, 1.5166666666667, 0.27777777777778
57437, 1.15, 1.5166666666667, 0.25
57438, 1.15, 1.5, 0.22222222222222
57439, 1.125, 1.5166666666667, 0.22222222222222
57440, 1.15, 1.5166666666667, 0.19444444444444
57441, 1.15, 1.5, 0.16666666666667
57442, 1.125, 1.5166666666667, 0.16666666666667
57443, 1.15, 1.5166666666667, 0.13888888888889
57444, 1.15, 1.5, 0.11111111111111
57445, 1.125, 1.5166666666667, 0.11111111111111
57446, 1.15, 1.5166666666667, 0.083333333333333
57447, 1.15, 1.5, 0.055555555555556
57448, 1.125, 1.5166666666667, 0.055555555555556
57449, 1.15, 1.5166666666667, 0.027777777777778
57450, 1.15, 1.5333333333333, 0.44444444444444
57451, 1.15, 1.5333333333333, 0.38888888888889
57452, 1.15, 1.5333333333333, 0.33333333333333
57453, 1.15, 1.5333333333333, 0.27777777777778
57454, 1.15, 1.5333333333333, 0.22222222222222
57455, 1.15, 1.5333333333333, 0.16666666666667
57456, 1.15, 1.5333333333333, 0.11111111111111
57457, 1.15, 1.5333333333333, 0.055555555555556
57458, 1.175, 1.4833333333333, 0.44444444444444
57459, 1.175, 1.4833333333333, 0.38888888888889
57460, 1.175, 1.4833333333333, 0.33333333333333
57461, 1.175, 1.4833333333333, 0.27777777777778
57462, 1.175, 1.4833333333333, 0.22222222222222
57463, 1.175, 1.4833333333333, 0.16666666666667
57464, 1.175, 1.4833333333333, 0.11111111111111
57465, 1.175, 1.4833333333333, 0.055555555555556
57466, 1.175, 1.5166666666667, 0.44444444444444
57467, 1.175, 1.5166666666667, 0.38888888888889
57468, 1.175, 1.5166666666667, 0.33333333333333
57469, 1.175, 1.5166666666667, 0.27777777777778
57470, 1.175, 1.5166666666667, 0.22222222222222
57471, 1.175, 1.5166666666667, 0.16666666666667
57472, 1.175, 1.5166666666667, 0.11111111111111
57473, 1.175, 1.5166666666667, 0.055555555555556
57474, 1.2434782608696, 1.4833333333333, 0.44444444444444
57475, 1.2434782608696, 1.4833333333333, 0.38888888888889
57476, 1.2434782608696, 1.4833333333333, 0.33333333333333
57477, 1.2434782608696, 1.4833333333333, 0.27777777777778
57478, 1.2434782608696, 1.4833333333333, 0.22222222222222
57479, 1.2434782608696, 1.4833333333333, 0.16666666666667
57480, 1.2434782608696, 1.4833333333333, 0.11111111111111
57481, 1.2434782608696, 1.4833333333333, 0.055555555555556
57482, 1.2434782608696, 1.5166666666667, 0.44444444444444
57483, 1.2434782608696, 1.5166666666667, 0.38888888888889
57484, 1.2434782608696, 1.5166666666667, 0.33333333333333
57485, 1.2434782608696, 1.5166666666667, 0.27777777777778
57486, 1.2434782608696, 1.5166666666667, 0.22222222222222
57487, 1.2434782608696, 1.5166666666667, 0.16666666666667
57488, 1.2434782608696, 1.5166666666667, 0.11111111111111
57489, 1.2434782608696, 1.5166666666667, 0.055555555555556
57490, 1.2869565217391, 1.4833333333333, 0.44444444444444
57491, 1.2869565217391, 1.4833333333333, 0.38888888888889
57492, 1.2869565217391, 1.4833333333333, 0.33333333333333
57493, 1.2869565217391, 1.4833333333333, 0.27777777777778
57494, 1.2869565217391, 1.4833333333333, 0.22222222222222
57495, 1.2869565217391, 1.4833333333333, 0.16666666666667
57496, 1.2869565217391, 1.4833333333333, 0.11111111111111
57497, 1.2869565217391, 1.4833333333333, 0.055555555555556
57498, 1.2869565217391, 1.5166666666667, 0.44444444444444
57499, 1.2869565217391, 1.5166666666667, 0.38888888888889
57500, 1.2869565217391, 1.5166666666667, 0.33333333333333
57501, 1.2869565217391, 1.5166666666667, 0.27777777777778
57502, 1.2869565217391, 1.5166666666667, 0.22222222222222
57503, 1.2869565217391, 1.5166666666667, 0.16666666666667
57504, 1.2869565217391, 1.5166666666667, 0.11111111111111
57505, 1.2869565217391, 1.5166666666667, 0.055555555555556
57506, 1.3304347826087, 1.4833333333333, 0.44444444444444
57507, 1.3304347826087, 1.4833333333333, 0.38888888888889
57508, 1.3304347826087, 1.4833333333333, 0.33333333333333
57509, 1.3304347826087, 1.4833333333333, 0.27777777777778
57510, 1.3304347826087, 1.4833333333333, 0.22222222222222
57511, 1.3304347826087, 1.4833333333333, 0.16666666666667
57512, 1.3304347826087, 1.4833333333333, 0.11111111111111
57513, 1.3304347826087, 1.4833333333333, 0.055555555555556
57514, 1.3304347826087, 1.5166666666667, 0.44444444444444
57515, 1.3304347826087, 1.5166666666667, 0.38888888888889
57516, 1.3304347826087, 1.5166666666667, 0.33333333333333
57517, 1.3304347826087, 1.5166666666667, 0.27777777777778
57518, 1.3304347826087, 1.5166666666667, 0.22222222222222
57519, 1.3304347826087, 1.5166666666667, 0.16666666666667
57520, 1.3304347826087, 1.5166666666667, 0.11111111111111
57521, 1.3304347826087, 1.5166666666667, 0.055555555555556
57522, 1.3739130434783, 1.4833333333333, 0.44444444444444
57523, 1.3739130434783, 1.4833333333333, 0.38888888888889
57524, 1.3739130434783, 1.4833333333333, 0.33333333333333
57525, 1.3739130434783, 1.4833333333333, 0.27777777777778
57526, 1.3739130434783, 1.4833333333333, 0.22222222222222
57527, 1.3739130434783, 1.4833333333333, 0.16666666666667
57528, 1.3739130434783, 1.4833333333333, 0.11111111111111
57529, 1.3739130434783, 1.4833333333333, 0.055555555555556
57530, 1.3739130434783, 1.5166666666667, 0.44444444444444
57531, 1.3739130434783, 1.5166666666667, 0.38888888888889
57532, 1.3739130434783, 1.5166666666667, 0.33333333333333
57533, 1.3739130434783, 1.5166666666667, 0.27777777777778
57534, 1.3739130434783, 1.5166666666667, 0.22222222222222
57535, 1.3739130434783, 1.5166666666667, 0.16666666666667
57536, 1.3739130434783, 1.5166666666667, 0.11111111111111
57537, 1.3739130434783, 1.5166666666667, 0.055555555555556
57538, 1.4173913043478, 1.4833333333333, 0.44444444444444
57539, 1.4173913043478, 1.4833333333333, 0.38888888888889
57540, 1.4173913043478, 1.4833333333333, 0.33333333333333
57541, 1.4173913043478, 1.4833333333333, 0.27777777777778
57542, 1.4173913043478, 1.4833333333333, 0.22222222222222
57543, 1.4173913043478, 1.4833333333333, 0.16666666666667
57544, 1.4173913043478, 1.4833333333333, 0.11111111111111
57545, 1.4173913043478, 1.4833333333333, 0.055555555555556
57546, 1.4173913043478, 1.5166666666667, 0.44444444444444
57547, 1.4173913043478, 1.5166666666667, 0.38888888888889
57548, 1.4173913043478, 1.5166666666667, 0.33333333333333
57549, 1.4173913043478, 1.5166666666667, 0.27777777777778
57550, 1.4173913043478, 1.5166666666667, 0.22222222222222
57551, 1.4173913043478, 1.5166666666667, 0.16666666666667
57552, 1.4173913043478, 1.5166666666667, 0.11111111111111
57553, 1.4173913043478, 1.5166666666667, 0.055555555555556
57554, 1.4608695652174, 1.4833333333333, 0.44444444444444
57555, 1.4608695652174, 1.4833333333333, 0.38888888888889
57556, 1.4608695652174, 1.4833333333333, 0.33333333333333
57557, 1.4608695652174, 1.4833333333333, 0.27777777777778
57558, 1.4608695652174, 1.4833333333333, 0.22222222222222
57559, 1.4608695652174, 1.4833333333333, 0.16666666666667
57560, 1.4608695652174, 1.4833333333333, 0.11111111111111
57561, 1.4608695652174, 1.4833333333333, 0.055555555555556
57562, 1.4608695652174, 1.5166666666667, 0.44444444444444
57563, 1.4608695652174, 1.5166666666667, 0.38888888888889
57564, 1.4608695652174, 1.5166666666667, 0.33333333333333
57565, 1.4608695652174, 1.5166666666667, 0.27777777777778
57566, 1.4608695652174, 1.5166666666667, 0.22222222222222
57567, 1.4608695652174, 1.5166666666667, 0.16666666666667
57568, 1.4608695652174, 1.5166666666667, 0.11111111111111
57569, 1.4608695652174, 1.5166666666667, 0.055555555555556
57570, 1.504347826087, 1.4833333333333, 0.44444444444444
57571, 1.504347826087, 1.4833333333333, 0.38888888888889
57572, 1.504347826087, 1.4833333333333, 0.33333333333333
57573, 1.504347826087, 1.4833333333333, 0.27777777777778
57574, 1.504347826087, 1.4833333333333, 0.22222222222222
57575, 1.504347826087, 1.4833333333333, 0.16666666666667
57576, 1.504347826087, 1.4833333333333, 0.11111111111111
57577, 1.504347826087, 1.4833333333333, 0.055555555555556
57578, 1.504347826087, 1.5166666666667, 0.44444444444444
57579, 1.504347826087, 1.5166666666667, 0.38888888888889
57580, 1.504347826087, 1.5166666666667, 0.33333333333333
57581, 1.504347826087, 1.5166666666667, 0.27777777777778
57582, 1.504347826087, 1.5166666666667, 0.22222222222222
57583, 1.504347826087, 1.5166666666667, 0.16666666666667
57584, 1.504347826087, 1.5166666666667, 0.11111111111111
57585, 1.504347826087, 1.5166666666667, 0.055555555555556
57586, 1.5478260869565, 1.4833333333333, 0.44444444444444
57587, 1.5478260869565, 1.4833333333333, 0.38888888888889
57588, 1.5478260869565, 1.4833333333333, 0.33333333333333
57589, 1.5478260869565, 1.4833333333333, 0.27777777777778
57590, 1.5478260869565, 1.4833333333333, 0.22222222222222
57591, 1.5478260869565, 1.4833333333333, 0.16666666666667
57592, 1.5478260869565, 1.4833333333333, 0.11111111111111
57593, 1.5478260869565, 1.4833333333333, 0.055555555555556
57594, 1.5478260869565, 1.5166666666667, 0.44444444444444
57595, 1.5478260869565, 1.5166666666667, 0.38888888888889
57596, 1.5478260869565, 1.5166666666667, 0.33333333333333
57597, 1.5478260869565, 1.5166666666667, 0.27777777777778
57598, 1.5478260869565, 1.5166666666667, 0.22222222222222
57599, 1.5478260869565, 1.5166666666667, 0.16666666666667
57600, 1.5478260869565, 1.5166666666667, 0.11111111111111
57601, 1.5478260869565, 1.5166666666667, 0.055555555555556
57602, 1.5913043478261, 1.4833333333333, 0.44444444444444
57603, 1.5913043478261, 1.4833333333333, 0.38888888888889
57604, 1.5913043478261, 1.4833333333333, 0.33333333333333
57605, 1.5913043478261, 1.4833333333333, 0.27777777777778
57606, 1.5913043478261, 1.4833333333333, 0.22222222222222
57607, 1.5913043478261, 1.4833333333333, 0.16666666666667
57608, 1.5913043478261, 1.4833333333333, 0.11111111111111
57609, 1.5913043478261, 1.4833333333333, 0.055555555555556
57610, 1.5913043478261, 1.5166666666667, 0.44444444444444
57611, 1.5913043478261, 1.5166666666667, 0.38888888888889
57612, 1.5913043478261, 1.5166666666667, 0.33333333333333
57613, 1.5913043478261, 1.5166666666667, 0.27777777777778
57614, 1.5913043478261, 1.5166666666667, 0.22222222222222
57615, 1.5913043478261, 1.5166666666667, 0.16666666666667
57616, 1.5913043478261, 1.5166666666667, 0.11111111111111
57617, 1.5913043478261, 1.5166666666667, 0.055555555555556
57618, 1.6347826086957, 1.4833333333333, 0.44444444444444
57619, 1.6347826086957, 1.4833333333333, 0.38888888888889
57620, 1.6347826086957, 1.4833333333333, 0.33333333333333
57621, 1.6347826086957, 1.4833333333333, 0.27777777777778
57622, 1.6347826086957, 1.4833333333333, 0.22222222222222
57623, 1.6347826086957, 1.4833333333333, 0.16666666666667
57624, 1.6347826086957, 1.4833333333333, 0.11111111111111
57625, 1.6347826086957, 1.4833333333333, 0.055555555555556
57626, 1.6347826086957, 1.5166666666667, 0.44444444444444
57627, 1.6347826086957, 1.5166666666667, 0.38888888888889
57628, 1.6347826086957, 1.5166666666667, 0.33333333333333
57629, 1.6347826086957, 1.5166666666667, 0.27777777777778
57630, 1.6347826086957, 1.5166666666667, 0.22222222222222
57631, 1.6347826086957, 1.5166666666667, 0.16666666666667
57632, 1.6347826086957, 1.5166666666667, 0.11111111111111
57633, 1.6347826086957, 1.5166666666667, 0.055555555555556
57634, 1.6782608695652, 1.4833333333333, 0.44444444444444
57635, 1.6782608695652, 1.4833333333333, 0.38888888888889
57636, 1.6782608695652, 1.4833333333333, 0.33333333333333
57637, 1.6782608695652, 1.4833333333333, 0.27777777777778
57638, 1.6782608695652, 1.4833333333333, 0.22222222222222
57639, 1.6782608695652, 1.4833333333333, 0.16666666666667
57640, 1.6782608695652, 1.4833333333333, 0.11111111111111
57641, 1.6782608695652, 1.4833333333333, 0.055555555555556
57642, 1.6782608695652, 1.5166666666667, 0.44444444444444
57643, 1.6782608695652, 1.5166666666667, 0.38888888888889
57644, 1.6782608695652, 1.5166666666667, 0.33333333333333
57645, 1.6782608695652, 1.5166666666667, 0.27777777777778
57646, 1.6782608695652, 1.5166666666667, 0.22222222222222
57647, 1.6782608695652, 1.5166666666667, 0.16666666666667
57648, 1.6782608695652, 1.5166666666667, 0.11111111111111
57649, 1.6782608695652, 1.5166666666667, 0.055555555555556
57650, 1.7217391304348, 1.4833333333333, 0.44444444444444
57651, 1.7217391304348, 1.4833333333333, 0.38888888888889
57652, 1.7217391304348, 1.4833333333333, 0.33333333333333
57653, 1.7217391304348, 1.4833333333333, 0.27777777777778
57654, 1.7217391304348, 1.4833333333333, 0.22222222222222
57655, 1.7217391304348, 1.4833333333333, 0.16666666666667
57656, 1.7217391304348, 1.4833333333333, 0.11111111111111
57657, 1.7217391304348, 1.4833333333333, 0.055555555555556
57658, 1.7217391304348, 1.5166666666667, 0.44444444444444
57659, 1.7217391304348, 1.5166666666667, 0.38888888888889
57660, 1.7217391304348, 1.5166666666667, 0.33333333333333
57661, 1.7217391304348, 1.5166666666667, 0.27777777777778
57662, 1.7217391304348, 1.5166666666667, 0.22222222222222
57663, 1.7217391304348, 1.5166666666667, 0.16666666666667
57664, 1.7217391304348, 1.5166666666667, 0.11111111111111
57665, 1.7217391304348, 1.5166666666667, 0.055555555555556
57666, 1.7652173913043, 1.4833333333333, 0.44444444444444
57667, 1.7652173913043, 1.4833333333333, 0.38888888888889
57668, 1.7652173913043, 1.4833333333333, 0.33333333333333
57669, 1.7652173913043, 1.4833333333333, 0.27777777777778
57670, 1.7652173913043, 1.4833333333333, 0.22222222222222
57671, 1.7652173913043, 1.4833333333333, 0.16666666666667
57672, 1.7652173913043, 1.4833333333333, 0.11111111111111
57673, 1.7652173913043, 1.4833333333333, 0.055555555555556
57674, 1.7652173913043, 1.5166666666667, 0.44444444444444
57675, 1.7652173913043, 1.5166666666667, 0.38888888888889
57676, 1.7652173913043, 1.5166666666667, 0.33333333333333
57677, 1.7652173913043, 1.5166666666667, 0.27777777777778
57678, 1.7652173913043, 1.5166666666667, 0.22222222222222
57679, 1.7652173913043, 1.5166666666667, 0.16666666666667
57680, 1.7652173913043, 1.5166666666667, 0.11111111111111
57681, 1.7652173913043, 1.5166666666667, 0.055555555555556
57682, 1.8086956521739, 1.4833333333333, 0.44444444444444
57683, 1.8086956521739, 1.4833333333333, 0.38888888888889
57684, 1.8086956521739, 1.4833333333333, 0.33333333333333
57685, 1.8086956521739, 1.4833333333333, 0.27777777777778
57686, 1.8086956521739, 1.4833333333333, 0.22222222222222
57687, 1.8086956521739, 1.4833333333333, 0.16666666666667
57688, 1.8086956521739, 1.4833333333333, 0.11111111111111
57689, 1.8086956521739, 1.4833333333333, 0.055555555555556
57690, 1.8086956521739, 1.5166666666667, 0.44444444444444
57691, 1.8086956521739, 1.5166666666667, 0.38888888888889
57692, 1.8086956521739, 1.5166666666667, 0.33333333333333
57693, 1.8086956521739, 1.5166666666667, 0.27777777777778
57694, 1.8086956521739, 1.5166666666667, 0.22222222222222
57695, 1.8086956521739, 1.5166666666667, 0.16666666666667
57696, 1.8086956521739, 1.5166666666667, 0.11111111111111
57697, 1.8086956521739, 1.5166666666667, 0.055555555555556
57698, 1.8521739130435, 1.4833333333333, 0.44444444444444
57699, 1.8521739130435, 1.4833333333333, 0.38888888888889
57700, 1.8521739130435, 1.4833333333333, 0.33333333333333
57701, 1.8521739130435, 1.4833333333333, 0.27777777777778
57702, 1.8521739130435, 1.4833333333333, 0.22222222222222
57703, 1.8521739130435, 1.4833333333333, 0.16666666666667
57704, 1.8521739130435, 1.4833333333333, 0.11111111111111
57705, 1.8521739130435, 1.4833333333333, 0.055555555555556
57706, 1.8521739130435, 1.5166666666667, 0.44444444444444
57707, 1.8521739130435, 1.5166666666667, 0.38888888888889
57708, 1.8521739130435, 1.5166666666667, 0.33333333333333
57709, 1.8521739130435, 1.5166666666667, 0.27777777777778
57710, 1.8521739130435, 1.5166666666667, 0.22222222222222
57711, 1.8521739130435, 1.5166666666667, 0.16666666666667
57712, 1.8521739130435, 1.5166666666667, 0.11111111111111
57713, 1.8521739130435, 1.5166666666667, 0.055555555555556
57714, 1.895652173913, 1.4833333333333, 0.44444444444444
57715, 1.895652173913, 1.4833333333333, 0.38888888888889
57716, 1.895652173913, 1.4833333333333, 0.33333333333333
57717, 1.895652173913, 1.4833333333333, 0.27777777777778
57718, 1.895652173913, 1.4833333333333, 0.22222222222222
57719, 1.895652173913, 1.4833333333333, 0.16666666666667
57720, 1.895652173913, 1.4833333333333, 0.11111111111111
57721, 1.895652173913, 1.4833333333333, 0.055555555555556
57722, 1.895652173913, 1.5166666666667, 0.44444444444444
57723, 1.895652173913, 1.5166666666667, 0.38888888888889
57724, 1.895652173913, 1.5166666666667, 0.33333333333333
57725, 1.895652173913, 1.5166666666667, 0.27777777777778
57726, 1.895652173913, 1.5166666666667, 0.22222222222222
57727, 1.895652173913, 1.5166666666667, 0.16666666666667
57728, 1.895652173913, 1.5166666666667, 0.11111111111111
57729, 1.895652173913, 1.5166666666667, 0.055555555555556
57730, 1.9391304347826, 1.4833333333333, 0.44444444444444
57731, 1.9391304347826, 1.4833333333333, 0.38888888888889
57732, 1.9391304347826, 1.4833333333333, 0.33333333333333
57733, 1.9391304347826, 1.4833333333333, 0.27777777777778
57734, 1.9391304347826, 1.4833333333333, 0.22222222222222
57735, 1.9391304347826, 1.4833333333333, 0.16666666666667
57736, 1.9391304347826, 1.4833333333333, 0.11111111111111
57737, 1.9391304347826, 1.4833333333333, 0.055555555555556
57738, 1.9391304347826, 1.5166666666667, 0.44444444444444
57739, 1.9391304347826, 1.5166666666667, 0.38888888888889
57740, 1.9391304347826, 1.5166666666667, 0.33333333333333
57741, 1.9391304347826, 1.5166666666667, 0.27777777777778
57742, 1.9391304347826, 1.5166666666667, 0.22222222222222
57743, 1.9391304347826, 1.5166666666667, 0.16666666666667
57744, 1.9391304347826, 1.5166666666667, 0.11111111111111
57745, 1.9391304347826, 1.5166666666667, 0.055555555555556
57746, 1.9826086956522, 1.4833333333333, 0.44444444444444
57747, 1.9826086956522, 1.4833333333333, 0.38888888888889
57748, 1.9826086956522, 1.4833333333333, 0.33333333333333
57749, 1.9826086956522, 1.4833333333333, 0.27777777777778
57750, 1.9826086956522, 1.4833333333333, 0.22222222222222
57751, 1.9826086956522, 1.4833333333333, 0.16666666666667
57752, 1.9826086956522, 1.4833333333333, 0.11111111111111
57753, 1.9826086956522, 1.4833333333333, 0.055555555555556
57754, 1.9826086956522, 1.5166666666667, 0.44444444444444
57755, 1.9826086956522, 1.5166666666667, 0.38888888888889
57756, 1.9826086956522, 1.5166666666667, 0.33333333333333
57757, 1.9826086956522, 1.5166666666667, 0.27777777777778
57758, 1.9826086956522, 1.5166666666667, 0.22222222222222
57759, 1.9826086956522, 1.5166666666667, 0.16666666666667
57760, 1.9826086956522, 1.5166666666667, 0.11111111111111
57761, 1.9826086956522, 1.5166666666667, 0.055555555555556
57762, 2.0260869565217, 1.4833333333333, 0.44444444444444
57763, 2.0260869565217, 1.4833333333333, 0.38888888888889
57764, 2.0260869565217, 1.4833333333333, 0.33333333333333
57765, 2.0260869565217, 1.4833333333333, 0.27777777777778
57766, 2.0260869565217, 1.4833333333333, 0.22222222222222
57767, 2.0260869565217, 1.4833333333333, 0.16666666666667
57768, 2.0260869565217, 1.4833333333333, 0.11111111111111
57769, 2.0260869565217, 1.4833333333333, 0.055555555555556
57770, 2.0260869565217, 1.5166666666667, 0.44444444444444
57771, 2.0260869565217, 1.5166666666667, 0.38888888888889
57772, 2.0260869565217, 1.5166666666667, 0.33333333333333
57773, 2.0260869565217, 1.5166666666667, 0.27777777777778
57774, 2.0260869565217, 1.5166666666667, 0.22222222222222
57775, 2.0260869565217, 1.5166666666667, 0.16666666666667
57776, 2.0260869565217, 1.5166666666667, 0.11111111111111
57777, 2.0260869565217, 1.5166666666667, 0.055555555555556
57778, 2.0695652173913, 1.4833333333333, 0.44444444444444
57779, 2.0695652173913, 1.4833333333333, 0.38888888888889
57780, 2.0695652173913, 1.4833333333333, 0.33333333333333
57781, 2.0695652173913, 1.4833333333333, 0.27777777777778
57782, 2.0695652173913, 1.4833333333333, 0.22222222222222
57783, 2.0695652173913, 1.4833333333333, 0.16666666666667
57784, 2.0695652173913, 1.4833333333333, 0.11111111111111
57785, 2.0695652173913, 1.4833333333333, 0.055555555555556
57786, 2.0695652173913, 1.5166666666667, 0.44444444444444
57787, 2.0695652173913, 1.5166666666667, 0.38888888888889
57788, 2.0695652173913, 1.5166666666667, 0.33333333333333
57789, 2.0695652173913, 1.5166666666667, 0.27777777777778
57790, 2.0695652173913, 1.5166666666667, 0.22222222222222
57791, 2.0695652173913, 1.5166666666667, 0.16666666666667
57792, 2.0695652173913, 1.5166666666667, 0.11111111111111
57793, 2.0695652173913, 1.5166666666667, 0.055555555555556
57794, 2.1130434782609, 1.4833333333333, 0.44444444444444
57795, 2.1130434782609, 1.4833333333333, 0.38888888888889
57796, 2.1130434782609, 1.4833333333333, 0.33333333333333
57797, 2.1130434782609, 1.4833333333333, 0.27777777777778
57798, 2.1130434782609, 1.4833333333333, 0.22222222222222
57799, 2.1130434782609, 1.4833333333333, 0.16666666666667
57800, 2.1130434782609, 1.4833333333333, 0.11111111111111
57801, 2.1130434782609, 1.4833333333333, 0.055555555555556
57802, 2.1130434782609, 1.5166666666667, 0.44444444444444
57803, 2.1130434782609, 1.5166666666667, 0.38888888888889
57804, 2.1130434782609, 1.5166666666667, 0.33333333333333
57805, 2.1130434782609, 1.5166666666667, 0.27777777777778
57806, 2.1130434782609, 1.5166666666667, 0.22222222222222
57807, 2.1130434782609, 1.5166666666667, 0.16666666666667
57808, 2.1130434782609, 1.5166666666667, 0.11111111111111
57809, 2.1130434782609, 1.5166666666667, 0.055555555555556
57810, 2.1565217391304, 1.4833333333333, 0.44444444444444
57811, 2.1565217391304, 1.4833333333333, 0.38888888888889
57812, 2.1565217391304, 1.4833333333333, 0.33333333333333
57813, 2.1565217391304, 1.4833333333333, 0.27777777777778
57814, 2.1565217391304, 1.4833333333333, 0.22222222222222
57815, 2.1565217391304, 1.4833333333333, 0.16666666666667
57816, 2.1565217391304, 1.4833333333333, 0.11111111111111
57817, 2.1565217391304, 1.4833333333333, 0.055555555555556
57818, 2.1565217391304, 1.5166666666667, 0.44444444444444
57819, 2.1565217391304, 1.5166666666667, 0.38888888888889
57820, 2.1565217391304, 1.5166666666667, 0.33333333333333
57821, 2.1565217391304, 1.5166666666667, 0.27777777777778
57822, 2.1565217391304, 1.5166666666667, 0.22222222222222
57823, 2.1565217391304, 1.5166666666667, 0.16666666666667
57824, 2.1565217391304, 1.5166666666667, 0.11111111111111
57825, 2.1565217391304, 1.5166666666667, 0.055555555555556
57826, 1.2434782608696, 1.4833333333333, 0.47222222222222
57827, 1.2434782608696, 1.4666666666667, 0.44444444444444
57828, 1.2217391304348, 1.4833333333333, 0.44444444444444
57829, 1.2434782608696, 1.4833333333333, 0.41666666666667
57830, 1.2434782608696, 1.4666666666667, 0.38888888888889
57831, 1.2217391304348, 1.4833333333333, 0.38888888888889
57832, 1.2434782608696, 1.4833333333333, 0.36111111111111
57833, 1.2434782608696, 1.4666666666667, 0.33333333333333
57834, 1.2217391304348, 1.4833333333333, 0.33333333333333
57835, 1.2434782608696, 1.4833333333333, 0.30555555555556
57836, 1.2434782608696, 1.4666666666667, 0.27777777777778
57837, 1.2217391304348, 1.4833333333333, 0.27777777777778
57838, 1.2434782608696, 1.4833333333333, 0.25
57839, 1.2434782608696, 1.4666666666667, 0.22222222222222
57840, 1.2217391304348, 1.4833333333333, 0.22222222222222
57841, 1.2434782608696, 1.4833333333333, 0.19444444444444
57842, 1.2434782608696, 1.4666666666667, 0.16666666666667
57843, 1.2217391304348, 1.4833333333333, 0.16666666666667
57844, 1.2434782608696, 1.4833333333333, 0.13888888888889
57845, 1.2434782608696, 1.4666666666667, 0.11111111111111
57846, 1.2217391304348, 1.4833333333333, 0.11111111111111
57847, 1.2434782608696, 1.4833333333333, 0.083333333333333
57848, 1.2434782608696, 1.4666666666667, 0.055555555555556
57849, 1.2217391304348, 1.4833333333333, 0.055555555555556
57850, 1.2434782608696, 1.4833333333333, 0.027777777777778
57851, 1.2434782608696, 1.5166666666667, 0.47222222222222
57852, 1.2434782608696, 1.5, 0.44444444444444
57853, 1.2217391304348, 1.5166666666667, 0.44444444444444
57854, 1.2434782608696, 1.5166666666667, 0.41666666666667
57855, 1.2434782608696, 1.5, 0.38888888888889
57856, 1.2217391304348, 1.5166666666667, 0.38888888888889
57857, 1.2434782608696, 1.5166666666667, 0.36111111111111
57858, 1.2434782608696, 1.5, 0.33333333333333
57859, 1.2217391304348, 1.5166666666667, 0.33333333333333
57860, 1.2434782608696, 1.5166666666667, 0.30555555555556
57861, 1.2434782608696, 1.5, 0.27777777777778
57862, 1.2217391304348, 1.5166666666667, 0.27777777777778
57863, 1.2434782608696, 1.5166666666667, 0.25
57864, 1.2434782608696, 1.5, 0.22222222222222
57865, 1.2217391304348, 1.5166666666667, 0.22222222222222
57866, 1.2434782608696, 1.5166666666667, 0.19444444444444
57867, 1.2434782608696, 1.5, 0.16666666666667
57868, 1.2217391304348, 1.5166666666667, 0.16666666666667
57869, 1.2434782608696, 1.5166666666667, 0.13888888888889
57870, 1.2434782608696, 1.5, 0.11111111111111
57871, 1.2217391304348, 1.5166666666667, 0.11111111111111
57872, 1.2434782608696, 1.5166666666667, 0.083333333333333
57873, 1.2434782608696, 1.5, 0.055555555555556
57874, 1.2217391304348, 1.5166666666667, 0.055555555555556
57875, 1.2434782608696, 1.5166666666667, 0.027777777777778
57876, 1.2434782608696, 1.5333333333333, 0.44444444444444
57877, 1.2434782608696, 1.5333333333333, 0.38888888888889
57878, 1.2434782608696, 1.5333333333333, 0.33333333333333
57879, 1.2434782608696, 1.5333333333333, 0.27777777777778
57880, 1.2434782608696, 1.5333333333333, 0.22222222222222
57881, 1.2434782608696, 1.5333333333333, 0.16666666666667
57882, 1.2434782608696, 1.5333333333333, 0.11111111111111
57883, 1.2434782608696, 1.5333333333333, 0.055555555555556
57884, 1.2869565217391, 1.4833333333333, 0.47222222222222
57885, 1.2869565217391, 1.4666666666667, 0.44444444444444
57886, 1.2652173913043, 1.4833333333333, 0.44444444444444
57887, 1.2869565217391, 1.4833333333333, 0.41666666666667
57888, 1.2869565217391, 1.4666666666667, 0.38888888888889
57889, 1.2652173913043, 1.4833333333333, 0.38888888888889
57890, 1.2869565217391, 1.4833333333333, 0.36111111111111
57891, 1.2869565217391, 1.4666666666667, 0.33333333333333
57892, 1.2652173913043, 1.4833333333333, 0.33333333333333
57893, 1.2869565217391, 1.4833333333333, 0.30555555555556
57894, 1.2869565217391, 1.4666666666667, 0.27777777777778
57895, 1.2652173913043, 1.4833333333333, 0.27777777777778
57896, 1.2869565217391, 1.4833333333333, 0.25
57897, 1.2869565217391, 1.4666666666667, 0.22222222222222
57898, 1.2652173913043, 1.4833333333333, 0.22222222222222
57899, 1.2869565217391, 1.4833333333333, 0.19444444444444
57900, 1.2869565217391, 1.4666666666667, 0.16666666666667
57901, 1.2652173913043, 1.4833333333333, 0.16666666666667
57902, 1.2869565217391, 1.4833333333333, 0.13888888888889
57903, 1.2869565217391, 1.4666666666667, 0.11111111111111
57904, 1.2652173913043, 1.4833333333333, 0.11111111111111
57905, 1.2869565217391, 1.4833333333333, 0.083333333333333
57906, 1.2869565217391, 1.4666666666667, 0.055555555555556
57907, 1.2652173913043, 1.4833333333333, 0.055555555555556
57908, 1.2869565217391, 1.4833333333333, 0.027777777777778
57909, 1.2869565217391, 1.5166666666667, 0.47222222222222
57910, 1.2869565217391, 1.5, 0.44444444444444
57911, 1.2652173913043, 1.5166666666667, 0.44444444444444
57912, 1.2869565217391, 1.5166666666667, 0.41666666666667
57913, 1.2869565217391, 1.5, 0.38888888888889
57914, 1.2652173913043, 1.5166666666667, 0.38888888888889
57915, 1.2869565217391, 1.5166666666667, 0.36111111111111
57916, 1.2869565217391, 1.5, 0.33333333333333
57917, 1.2652173913043, 1.5166666666667, 0.33333333333333
57918, 1.2869565217391, 1.5166666666667, 0.30555555555556
57919, 1.2869565217391, 1.5, 0.27777777777778
57920, 1.2652173913043, 1.5166666666667, 0.27777777777778
57921, 1.2869565217391, 1.5166666666667, 0.25
57922, 1.2869565217391, 1.5, 0.22222222222222
57923, 1.2652173913043, 1.5166666666667, 0.22222222222222
57924, 1.2869565217391, 1.5166666666667, 0.19444444444444
57925, 1.2869565217391, 1.5, 0.16666666666667
57926, 1.2652173913043, 1.5166666666667, 0.16666666666667
57927, 1.2869565217391, 1.5166666666667, 0.13888888888889
57928, 1.2869565217391, 1.5, 0.11111111111111
57929, 1.2652173913043, 1.5166666666667, 0.11111111111111
57930, 1.2869565217391, 1.5166666666667, 0.083333333333333
57931, 1.2869565217391, 1.5, 0.055555555555556
57932, 1.2652173913043, 1.5166666666667, 0.055555555555556
57933, 1.2869565217391, 1.5166666666667, 0.027777777777778
57934, 1.2869565217391, 1.5333333333333, 0.44444444444444
57935, 1.2869565217391, 1.5333333333333, 0.38888888888889
57936, 1.2869565217391, 1.5333333333333, 0.33333333333333
57937, 1.2869565217391, 1.5333333333333, 0.27777777777778
57938, 1.2869565217391, 1.5333333333333, 0.22222222222222
57939, 1.2869565217391, 1.5333333333333, 0.16666666666667
57940, 1.2869565217391, 1.5333333333333, 0.11111111111111
57941, 1.2869565217391, 1.5333333333333, 0.055555555555556
57942, 1.3304347826087, 1.4833333333333, 0.47222222222222
57943, 1.3304347826087, 1.4666666666667, 0.44444444444444
57944, 1.3086956521739, 1.4833333333333, 0.44444444444444
57945, 1.3304347826087, 1.4833333333333, 0.41666666666667
57946, 1.3304347826087, 1.4666666666667, 0.38888888888889
57947, 1.3086956521739, 1.4833333333333, 0.38888888888889
57948, 1.3304347826087, 1.4833333333333, 0.36111111111111
57949, 1.3304347826087, 1.4666666666667, 0.33333333333333
57950, 1.3086956521739, 1.4833333333333, 0.33333333333333
57951, 1.3304347826087, 1.4833333333333, 0.30555555555556
57952, 1.3304347826087, 1.4666666666667, 0.27777777777778
57953, 1.3086956521739, 1.4833333333333, 0.27777777777778
57954, 1.3304347826087, 1.4833333333333, 0.25
57955, 1.3304347826087, 1.4666666666667, 0.22222222222222
57956, 1.3086956521739, 1.4833333333333, 0.22222222222222
57957, 1.3304347826087, 1.4833333333333, 0.19444444444444
57958, 1.3304347826087, 1.4666666666667, 0.16666666666667
57959, 1.3086956521739, 1.4833333333333, 0.16666666666667
57960, 1.3304347826087, 1.4833333333333, 0.13888888888889
57961, 1.3304347826087, 1.4666666666667, 0.11111111111111
57962, 1.3086956521739, 1.4833333333333, 0.11111111111111
57963, 1.3304347826087, 1.4833333333333, 0.083333333333333
57964, 1.3304347826087, 1.4666666666667, 0.055555555555556
57965, 1.3086956521739, 1.4833333333333, 0.055555555555556
57966, 1.3304347826087, 1.4833333333333, 0.027777777777778
57967, 1.3304347826087, 1.5166666666667, 0.47222222222222
57968, 1.3304347826087, 1.5, 0.44444444444444
57969, 1.3086956521739, 1.5166666666667, 0.44444444444444
57970, 1.3304347826087, 1.5166666666667, 0.41666666666667
57971, 1.3304347826087, 1.5, 0.38888888888889
57972, 1.3086956521739, 1.5166666666667, 0.38888888888889
57973, 1.3304347826087, 1.5166666666667, 0.36111111111111
57974, 1.3304347826087, 1.5, 0.33333333333333
57975, 1.3086956521739, 1.5166666666667, 0.33333333333333
57976, 1.3304347826087, 1.5166666666667, 0.30555555555556
57977, 1.3304347826087, 1.5, 0.27777777777778
57978, 1.3086956521739, 1.5166666666667, 0.27777777777778
57979, 1.3304347826087, 1.5166666666667, 0.25
57980, 1.3304347826087, 1.5, 0.22222222222222
57981, 1.3086956521739, 1.5166666666667, 0.22222222222222
57982, 1.3304347826087, 1.5166666666667, 0.19444444444444
57983, 1.3304347826087, 1.5, 0.16666666666667
57984, 1.3086956521739, 1.5166666666667, 0.16666666666667
57985, 1.3304347826087, 1.5166666666667, 0.13888888888889
57986, 1.3304347826087, 1.5, 0.11111111111111
57987, 1.3086956521739, 1.5166666666667, 0.11111111111111
57988, 1.3304347826087, 1.5166666666667, 0.083333333333333
57989, 1.3304347826087, 1.5, 0.055555555555556
57990, 1.3086956521739, 1.5166666666667, 0.055555555555556
57991, 1.3304347826087, 1.5166666666667, 0.027777777777778
57992, 1.3304347826087, 1.5333333333333, 0.44444444444444
57993, 1.3304347826087, 1.5333333333333, 0.38888888888889
57994, 1.3304347826087, 1.5333333333333, 0.33333333333333
57995, 1.3304347826087, 1.5333333333333, 0.27777777777778
57996, 1.3304347826087, 1.5333333333333, 0.22222222222222
57997, 1.3304347826087, 1.5333333333333, 0.16666666666667
57998, 1.3304347826087, 1.5333333333333, 0.11111111111111
57999, 1.3304347826087, 1.5333333333333, 0.055555555555556
58000, 1.3739130434783, 1.4833333333333, 0.47222222222222
58001, 1.3739130434783, 1.4666666666667, 0.44444444444444
58002, 1.3521739130435, 1.4833333333333, 0.44444444444444
58003, 1.3739130434783, 1.4833333333333, 0.41666666666667
58004, 1.3739130434783, 1.4666666666667, 0.38888888888889
58005, 1.3521739130435, 1.4833333333333, 0.38888888888889
58006, 1.3739130434783, 1.4833333333333, 0.36111111111111
58007, 1.3739130434783, 1.4666666666667, 0.33333333333333
58008, 1.3521739130435, 1.4833333333333, 0.33333333333333
58009, 1.3739130434783, 1.4833333333333, 0.30555555555556
58010, 1.3739130434783, 1.4666666666667, 0.27777777777778
58011, 1.3521739130435, 1.4833333333333, 0.27777777777778
58012, 1.3739130434783, 1.4833333333333, 0.25
58013, 1.3739130434783, 1.4666666666667, 0.22222222222222
58014, 1.3521739130435, 1.4833333333333, 0.22222222222222
58015, 1.3739130434783, 1.4833333333333, 0.19444444444444
58016, 1.3739130434783, 1.4666666666667, 0.16666666666667
58017, 1.3521739130435, 1.4833333333333, 0.16666666666667
58018, 1.3739130434783, 1.4833333333333, 0.13888888888889
58019, 1.3739130434783, 1.4666666666667, 0.11111111111111
58020, 1.3521739130435, 1.4833333333333, 0.11111111111111
58021, 1.3739130434783, 1.4833333333333, 0.083333333333333
58022, 1.3739130434783, 1.4666666666667, 0.055555555555556
58023, 1.3521739130435, 1.4833333333333, 0.055555555555556
58024, 1.3739130434783, 1.4833333333333, 0.027777777777778
58025, 1.3739130434783, 1.5166666666667, 0.47222222222222
58026, 1.3739130434783, 1.5, 0.44444444444444
58027, 1.3521739130435, 1.5166666666667, 0.44444444444444
58028, 1.3739130434783, 1.5166666666667, 0.41666666666667
58029, 1.3739130434783, 1.5, 0.38888888888889
58030, 1.3521739130435, 1.5166666666667, 0.38888888888889
58031, 1.3739130434783, 1.5166666666667, 0.36111111111111
58032, 1.3739130434783, 1.5, 0.33333333333333
58033, 1.3521739130435, 1.5166666666667, 0.33333333333333
58034, 1.3739130434783, 1.5166666666667, 0.30555555555556
58035, 1.3739130434783, 1.5, 0.27777777777778
58036, 1.3521739130435, 1.5166666666667, 0.27777777777778
58037, 1.3739130434783, 1.5166666666667, 0.25
58038, 1.3739130434783, 1.5, 0.22222222222222
58039, 1.3521739130435, 1.5166666666667, 0.22222222222222
58040, 1.3739130434783, 1.5166666666667, 0.19444444444444
58041, 1.3739130434783, 1.5, 0.16666666666667
58042, 1.3521739130435, 1.5166666666667, 0.16666666666667
58043, 1.3739130434783, 1.5166666666667, 0.13888888888889
58044, 1.3739130434783, 1.5, 0.11111111111111
58045, 1.3521739130435, 1.5166666666667, 0.11111111111111
58046, 1.3739130434783, 1.5166666666667, 0.083333333333333
58047, 1.3739130434783, 1.5, 0.055555555555556
58048, 1.3521739130435, 1.5166666666667, 0.055555555555556
58049, 1.3739130434783, 1.5166666666667, 0.027777777777778
58050, 1.3739130434783, 1.5333333333333, 0.44444444444444
58051, 1.3739130434783, 1.5333333333333, 0.38888888888889
58052, 1.3739130434783, 1.5333333333333, 0.33333333333333
58053, 1.3739130434783, 1.5333333333333, 0.27777777777778
58054, 1.3739130434783, 1.5333333333333, 0.22222222222222
58055, 1.3739130434783, 1.5333333333333, 0.16666666666667
58056, 1.3739130434783, 1.5333333333333, 0.11111111111111
58057, 1.3739130434783, 1.5333333333333, 0.055555555555556
58058, 1.4173913043478, 1.4833333333333, 0.47222222222222
58059, 1.4173913043478, 1.4666666666667, 0.44444444444444
58060, 1.395652173913, 1.4833333333333, 0.44444444444444
58061, 1.4173913043478, 1.4833333333333, 0.41666666666667
58062, 1.4173913043478, 1.4666666666667, 0.38888888888889
58063, 1.395652173913, 1.4833333333333, 0.38888888888889
58064, 1.4173913043478, 1.4833333333333, 0.36111111111111
58065, 1.4173913043478, 1.4666666666667, 0.33333333333333
58066, 1.395652173913, 1.4833333333333, 0.33333333333333
58067, 1.4173913043478, 1.4833333333333, 0.30555555555556
58068, 1.4173913043478, 1.4666666666667, 0.27777777777778
58069, 1.395652173913, 1.4833333333333, 0.27777777777778
58070, 1.4173913043478, 1.4833333333333, 0.25
58071, 1.4173913043478, 1.4666666666667, 0.22222222222222
58072, 1.395652173913, 1.4833333333333, 0.22222222222222
58073, 1.4173913043478, 1.4833333333333, 0.19444444444444
58074, 1.4173913043478, 1.4666666666667, 0.16666666666667
58075, 1.395652173913, 1.4833333333333, 0.16666666666667
58076, 1.4173913043478, 1.4833333333333, 0.13888888888889
58077, 1.4173913043478, 1.4666666666667, 0.11111111111111
58078, 1.395652173913, 1.4833333333333, 0.11111111111111
58079, 1.4173913043478, 1.4833333333333, 0.083333333333333
58080, 1.4173913043478, 1.4666666666667, 0.055555555555556
58081, 1.395652173913, 1.4833333333333, 0.055555555555556
58082, 1.4173913043478, 1.4833333333333, 0.027777777777778
58083, 1.4173913043478, 1.5166666666667, 0.47222222222222
58084, 1.4173913043478, 1.5, 0.44444444444444
58085, 1.395652173913, 1.5166666666667, 0.44444444444444
58086, 1.4173913043478, 1.5166666666667, 0.41666666666667
58087, 1.4173913043478, 1.5, 0.38888888888889
58088, 1.395652173913, 1.5166666666667, 0.38888888888889
58089, 1.4173913043478, 1.5166666666667, 0.36111111111111
58090, 1.4173913043478, 1.5, 0.33333333333333
58091, 1.395652173913, 1.5166666666667, 0.33333333333333
58092, 1.4173913043478, 1.5166666666667, 0.30555555555556
58093, 1.4173913043478, 1.5, 0.27777777777778
58094, 1.395652173913, 1.5166666666667, 0.27777777777778
58095, 1.4173913043478, 1.5166666666667, 0.25
58096, 1.4173913043478, 1.5, 0.22222222222222
58097, 1.395652173913, 1.5166666666667, 0.22222222222222
58098, 1.4173913043478, 1.5166666666667, 0.19444444444444
58099, 1.4173913043478, 1.5, 0.16666666666667
58100, 1.395652173913, 1.5166666666667, 0.16666666666667
58101, 1.4173913043478, 1.5166666666667, 0.13888888888889
58102, 1.4173913043478, 1.5, 0.11111111111111
58103, 1.395652173913, 1.5166666666667, 0.11111111111111
58104, 1.4173913043478, 1.5166666666667, 0.083333333333333
58105, 1.4173913043478, 1.5, 0.055555555555556
58106, 1.395652173913, 1.5166666666667, 0.055555555555556
58107, 1.4173913043478, 1.5166666666667, 0.027777777777778
58108, 1.4173913043478, 1.5333333333333, 0.44444444444444
58109, 1.4173913043478, 1.5333333333333, 0.38888888888889
58110, 1.4173913043478, 1.5333333333333, 0.33333333333333
58111, 1.4173913043478, 1.5333333333333, 0.27777777777778
58112, 1.4173913043478, 1.5333333333333, 0.22222222222222
58113, 1.4173913043478, 1.5333333333333, 0.16666666666667
58114, 1.4173913043478, 1.5333333333333, 0.11111111111111
58115, 1.4173913043478, 1.5333333333333, 0.055555555555556
58116, 1.4608695652174, 1.4833333333333, 0.47222222222222
58117, 1.4608695652174, 1.4666666666667, 0.44444444444444
58118, 1.4391304347826, 1.4833333333333, 0.44444444444444
58119, 1.4608695652174, 1.4833333333333, 0.41666666666667
58120, 1.4608695652174, 1.4666666666667, 0.38888888888889
58121, 1.4391304347826, 1.4833333333333, 0.38888888888889
58122, 1.4608695652174, 1.4833333333333, 0.36111111111111
58123, 1.4608695652174, 1.4666666666667, 0.33333333333333
58124, 1.4391304347826, 1.4833333333333, 0.33333333333333
58125, 1.4608695652174, 1.4833333333333, 0.30555555555556
58126, 1.4608695652174, 1.4666666666667, 0.27777777777778
58127, 1.4391304347826, 1.4833333333333, 0.27777777777778
58128, 1.4608695652174, 1.4833333333333, 0.25
58129, 1.4608695652174, 1.4666666666667, 0.22222222222222
58130, 1.4391304347826, 1.4833333333333, 0.22222222222222
58131, 1.4608695652174, 1.4833333333333, 0.19444444444444
58132, 1.4608695652174, 1.4666666666667, 0.16666666666667
58133, 1.4391304347826, 1.4833333333333, 0.16666666666667
58134, 1.4608695652174, 1.4833333333333, 0.13888888888889
58135, 1.4608695652174, 1.4666666666667, 0.11111111111111
58136, 1.4391304347826, 1.4833333333333, 0.11111111111111
58137, 1.4608695652174, 1.4833333333333, 0.083333333333333
58138, 1.4608695652174, 1.4666666666667, 0.055555555555556
58139, 1.4391304347826, 1.4833333333333, 0.055555555555556
58140, 1.4608695652174, 1.4833333333333, 0.027777777777778
58141, 1.4608695652174, 1.5166666666667, 0.47222222222222
58142, 1.4608695652174, 1.5, 0.44444444444444
58143, 1.4391304347826, 1.5166666666667, 0.44444444444444
58144, 1.4608695652174, 1.5166666666667, 0.41666666666667
58145, 1.4608695652174, 1.5, 0.38888888888889
58146, 1.4391304347826, 1.5166666666667, 0.38888888888889
58147, 1.4608695652174, 1.5166666666667, 0.36111111111111
58148, 1.4608695652174, 1.5, 0.33333333333333
58149, 1.4391304347826, 1.5166666666667, 0.33333333333333
58150, 1.4608695652174, 1.5166666666667, 0.30555555555556
58151, 1.4608695652174, 1.5, 0.27777777777778
58152, 1.4391304347826, 1.5166666666667, 0.27777777777778
58153, 1.4608695652174, 1.5166666666667, 0.25
58154, 1.4608695652174, 1.5, 0.22222222222222
58155, 1.4391304347826, 1.5166666666667, 0.22222222222222
58156, 1.4608695652174, 1.5166666666667, 0.19444444444444
58157, 1.4608695652174, 1.5, 0.16666666666667
58158, 1.4391304347826, 1.5166666666667, 0.16666666666667
58159, 1.4608695652174, 1.5166666666667, 0.13888888888889
58160, 1.4608695652174, 1.5, 0.11111111111111
58161, 1.4391304347826, 1.5166666666667, 0.11111111111111
58162, 1.4608695652174, 1.5166666666667, 0.083333333333333
58163, 1.4608695652174, 1.5, 0.055555555555556
58164, 1.4391304347826, 1.5166666666667, 0.055555555555556
58165, 1.4608695652174, 1.5166666666667, 0.027777777777778
58166, 1.4608695652174, 1.5333333333333, 0.44444444444444
58167, 1.4608695652174, 1.5333333333333, 0.38888888888889
58168, 1.4608695652174, 1.5333333333333, 0.33333333333333
58169, 1.4608695652174, 1.5333333333333, 0.27777777777778
58170, 1.4608695652174, 1.5333333333333, 0.22222222222222
58171, 1.4608695652174, 1.5333333333333, 0.16666666666667
58172, 1.4608695652174, 1.5333333333333, 0.11111111111111
58173, 1.4608695652174, 1.5333333333333, 0.055555555555556
58174, 1.504347826087, 1.4833333333333, 0.47222222222222
58175, 1.504347826087, 1.4666666666667, 0.44444444444444
58176, 1.4826086956522, 1.4833333333333, 0.44444444444444
58177, 1.504347826087, 1.4833333333333, 0.41666666666667
58178, 1.504347826087, 1.4666666666667, 0.38888888888889
58179, 1.4826086956522, 1.4833333333333, 0.38888888888889
58180, 1.504347826087, 1.4833333333333, 0.36111111111111
58181, 1.504347826087, 1.4666666666667, 0.33333333333333
58182, 1.4826086956522, 1.4833333333333, 0.33333333333333
58183, 1.504347826087, 1.4833333333333, 0.30555555555556
58184, 1.504347826087, 1.4666666666667, 0.27777777777778
58185, 1.4826086956522, 1.4833333333333, 0.27777777777778
58186, 1.504347826087, 1.4833333333333, 0.25
58187, 1.504347826087, 1.4666666666667, 0.22222222222222
58188, 1.4826086956522, 1.4833333333333, 0.22222222222222
58189, 1.504347826087, 1.4833333333333, 0.19444444444444
58190, 1.504347826087, 1.4666666666667, 0.16666666666667
58191, 1.4826086956522, 1.4833333333333, 0.16666666666667
58192, 1.504347826087, 1.4833333333333, 0.13888888888889
58193, 1.504347826087, 1.4666666666667, 0.11111111111111
58194, 1.4826086956522, 1.4833333333333, 0.11111111111111
58195, 1.504347826087, 1.4833333333333, 0.083333333333333
58196, 1.504347826087, 1.4666666666667, 0.055555555555556
58197, 1.4826086956522, 1.4833333333333, 0.055555555555556
58198, 1.504347826087, 1.4833333333333, 0.027777777777778
58199, 1.504347826087, 1.5166666666667, 0.47222222222222
58200, 1.504347826087, 1.5, 0.44444444444444
58201, 1.4826086956522, 1.5166666666667, 0.44444444444444
58202, 1.504347826087, 1.5166666666667, 0.41666666666667
58203, 1.504347826087, 1.5, 0.38888888888889
58204, 1.4826086956522, 1.5166666666667, 0.38888888888889
58205, 1.504347826087, 1.5166666666667, 0.36111111111111
58206, 1.504347826087, 1.5, 0.33333333333333
58207, 1.4826086956522, 1.5166666666667, 0.33333333333333
58208, 1.504347826087, 1.5166666666667, 0.30555555555556
58209, 1.504347826087, 1.5, 0.27777777777778
58210, 1.4826086956522, 1.5166666666667, 0.27777777777778
58211, 1.504347826087, 1.5166666666667, 0.25
58212, 1.504347826087, 1.5, 0.22222222222222
58213, 1.4826086956522, 1.5166666666667, 0.22222222222222
58214, 1.504347826087, 1.5166666666667, 0.19444444444444
58215, 1.504347826087, 1.5, 0.16666666666667
58216, 1.4826086956522, 1.5166666666667, 0.16666666666667
58217, 1.504347826087, 1.5166666666667, 0.13888888888889
58218, 1.504347826087, 1.5, 0.11111111111111
58219, 1.4826086956522, 1.5166666666667, 0.11111111111111
58220, 1.504347826087, 1.5166666666667, 0.083333333333333
58221, 1.504347826087, 1.5, 0.055555555555556
58222, 1.4826086956522, 1.5166666666667, 0.055555555555556
58223, 1.504347826087, 1.5166666666667, 0.027777777777778
58224, 1.504347826087, 1.5333333333333, 0.44444444444444
58225, 1.504347826087, 1.5333333333333, 0.38888888888889
58226, 1.504347826087, 1.5333333333333, 0.33333333333333
58227, 1.504347826087, 1.5333333333333, 0.27777777777778
58228, 1.504347826087, 1.5333333333333, 0.22222222222222
58229, 1.504347826087, 1.5333333333333, 0.16666666666667
58230, 1.504347826087, 1.5333333333333, 0.11111111111111
58231, 1.504347826087, 1.5333333333333, 0.055555555555556
58232, 1.5478260869565, 1.4833333333333, 0.47222222222222
58233, 1.5478260869565, 1.4666666666667, 0.44444444444444
58234, 1.5260869565217, 1.4833333333333, 0.44444444444444
58235, 1.5478260869565, 1.4833333333333, 0.41666666666667
58236, 1.5478260869565, 1.4666666666667, 0.38888888888889
58237, 1.5260869565217, 1.4833333333333, 0.38888888888889
58238, 1.5478260869565, 1.4833333333333, 0.36111111111111
58239, 1.5478260869565, 1.4666666666667, 0.33333333333333
58240, 1.5260869565217, 1.4833333333333, 0.33333333333333
58241, 1.5478260869565, 1.4833333333333, 0.30555555555556
58242, 1.5478260869565, 1.4666666666667, 0.27777777777778
58243, 1.5260869565217, 1.4833333333333, 0.27777777777778
58244, 1.5478260869565, 1.4833333333333, 0.25
58245, 1.5478260869565, 1.4666666666667, 0.22222222222222
58246, 1.5260869565217, 1.4833333333333, 0.22222222222222
58247, 1.5478260869565, 1.4833333333333, 0.19444444444444
58248, 1.5478260869565, 1.4666666666667, 0.16666666666667
58249, 1.5260869565217, 1.4833333333333, 0.16666666666667
58250, 1.5478260869565, 1.4833333333333, 0.13888888888889
58251, 1.5478260869565, 1.4666666666667, 0.11111111111111
58252, 1.5260869565217, 1.4833333333333, 0.11111111111111
58253, 1.5478260869565, 1.4833333333333, 0.083333333333333
58254, 1.5478260869565, 1.4666666666667, 0.055555555555556
58255, 1.5260869565217, 1.4833333333333, 0.055555555555556
58256, 1.5478260869565, 1.4833333333333, 0.027777777777778
58257, 1.5478260869565, 1.5166666666667, 0.47222222222222
58258, 1.5478260869565, 1.5, 0.44444444444444
58259, 1.5260869565217, 1.5166666666667, 0.44444444444444
58260, 1.5478260869565, 1.5166666666667, 0.41666666666667
58261, 1.5478260869565, 1.5, 0.38888888888889
58262, 1.5260869565217, 1.5166666666667, 0.38888888888889
58263, 1.5478260869565, 1.5166666666667, 0.36111111111111
58264, 1.5478260869565, 1.5, 0.33333333333333
58265, 1.5260869565217, 1.5166666666667, 0.33333333333333
58266, 1.5478260869565, 1.5166666666667, 0.30555555555556
58267, 1.5478260869565, 1.5, 0.27777777777778
58268, 1.5260869565217, 1.5166666666667, 0.27777777777778
58269, 1.5478260869565, 1.5166666666667, 0.25
58270, 1.5478260869565, 1.5, 0.22222222222222
58271, 1.5260869565217, 1.5166666666667, 0.22222222222222
58272, 1.5478260869565, 1.5166666666667, 0.19444444444444
58273, 1.5478260869565, 1.5, 0.16666666666667
58274, 1.5260869565217, 1.5166666666667, 0.16666666666667
58275, 1.5478260869565, 1.5166666666667, 0.13888888888889
58276, 1.5478260869565, 1.5, 0.11111111111111
58277, 1.5260869565217, 1.5166666666667, 0.11111111111111
58278, 1.5478260869565, 1.5166666666667, 0.083333333333333
