52893, 0.8695652173913, 1.1673913043478, 0.22222222222222
52894, 0.8695652173913, 1.1934782608696, 0.25
52895, 0.89130434782609, 1.1934782608696, 0.27777777777778
52896, 0.8695652173913, 1.1673913043478, 0.27777777777778
52897, 0.8695652173913, 1.1934782608696, 0.30555555555556
52898, 0.89130434782609, 1.1934782608696, 0.33333333333333
52899, 0.8695652173913, 1.1673913043478, 0.33333333333333
52900, 0.8695652173913, 1.1934782608696, 0.36111111111111
52901, 0.89130434782609, 1.1934782608696, 0.38888888888889
52902, 0.8695652173913, 1.1673913043478, 0.38888888888889
52903, 0.8695652173913, 1.1934782608696, 0.41666666666667
52904, 0.89130434782609, 1.1934782608696, 0.44444444444444
52905, 0.8695652173913, 1.1673913043478, 0.44444444444444
52906, 0.8695652173913, 1.1934782608696, 0.47222222222222
52907, 0.82608695652174, 1.1934782608696, 0.027777777777778
52908, 0.84782608695652, 1.1934782608696, 0.055555555555556
52909, 0.82608695652174, 1.1673913043478, 0.055555555555556
52910, 0.82608695652174, 1.1934782608696, 0.083333333333333
52911, 0.84782608695652, 1.1934782608696, 0.11111111111111
52912, 0.82608695652174, 1.1673913043478, 0.11111111111111
52913, 0.82608695652174, 1.1934782608696, 0.13888888888889
52914, 0.84782608695652, 1.1934782608696, 0.16666666666667
52915, 0.82608695652174, 1.1673913043478, 0.16666666666667
52916, 0.82608695652174, 1.1934782608696, 0.19444444444444
52917, 0.84782608695652, 1.1934782608696, 0.22222222222222
52918, 0.82608695652174, 1.1673913043478, 0.22222222222222
52919, 0.82608695652174, 1.1934782608696, 0.25
52920, 0.84782608695652, 1.1934782608696, 0.27777777777778
52921, 0.82608695652174, 1.1673913043478, 0.27777777777778
52922, 0.82608695652174, 1.1934782608696, 0.30555555555556
52923, 0.84782608695652, 1.1934782608696, 0.33333333333333
52924, 0.82608695652174, 1.1673913043478, 0.33333333333333
52925, 0.82608695652174, 1.1934782608696, 0.36111111111111
52926, 0.84782608695652, 1.1934782608696, 0.38888888888889
52927, 0.82608695652174, 1.1673913043478, 0.38888888888889
52928, 0.82608695652174, 1.1934782608696, 0.41666666666667
52929, 0.84782608695652, 1.1934782608696, 0.44444444444444
52930, 0.82608695652174, 1.1673913043478, 0.44444444444444
52931, 0.82608695652174, 1.1934782608696, 0.47222222222222
52932, 0.78260869565217, 1.1934782608696, 0.027777777777778
52933, 0.80434782608696, 1.1934782608696, 0.055555555555556
52934, 0.78260869565217, 1.1673913043478, 0.055555555555556
52935, 0.78260869565217, 1.1934782608696, 0.083333333333333
52936, 0.80434782608696, 1.1934782608696, 0.11111111111111
52937, 0.78260869565217, 1.1673913043478, 0.11111111111111
52938, 0.78260869565217, 1.1934782608696, 0.13888888888889
52939, 0.80434782608696, 1.1934782608696, 0.16666666666667
52940, 0.78260869565217, 1.1673913043478, 0.16666666666667
52941, 0.78260869565217, 1.1934782608696, 0.19444444444444
52942, 0.80434782608696, 1.1934782608696, 0.22222222222222
52943, 0.78260869565217, 1.1673913043478, 0.22222222222222
52944, 0.78260869565217, 1.1934782608696, 0.25
52945, 0.80434782608696, 1.1934782608696, 0.27777777777778
52946, 0.78260869565217, 1.1673913043478, 0.27777777777778
52947, 0.78260869565217, 1.1934782608696, 0.30555555555556
52948, 0.80434782608696, 1.1934782608696, 0.33333333333333
52949, 0.78260869565217, 1.1673913043478, 0.33333333333333
52950, 0.78260869565217, 1.1934782608696, 0.36111111111111
52951, 0.80434782608696, 1.1934782608696, 0.38888888888889
52952, 0.78260869565217, 1.1673913043478, 0.38888888888889
52953, 0.78260869565217, 1.1934782608696, 0.41666666666667
52954, 0.80434782608696, 1.1934782608696, 0.44444444444444
52955, 0.78260869565217, 1.1673913043478, 0.44444444444444
52956, 0.78260869565217, 1.1934782608696, 0.47222222222222
52957, 0.73913043478261, 1.1934782608696, 0.027777777777778
52958, 0.76086956521739, 1.1934782608696, 0.055555555555556
52959, 0.73913043478261, 1.1673913043478, 0.055555555555556
52960, 0.73913043478261, 1.1934782608696, 0.083333333333333
52961, 0.76086956521739, 1.1934782608696, 0.11111111111111
52962, 0.73913043478261, 1.1673913043478, 0.11111111111111
52963, 0.73913043478261, 1.1934782608696, 0.13888888888889
52964, 0.76086956521739, 1.1934782608696, 0.16666666666667
52965, 0.73913043478261, 1.1673913043478, 0.16666666666667
52966, 0.73913043478261, 1.1934782608696, 0.19444444444444
52967, 0.76086956521739, 1.1934782608696, 0.22222222222222
52968, 0.73913043478261, 1.1673913043478, 0.22222222222222
52969, 0.73913043478261, 1.1934782608696, 0.25
52970, 0.76086956521739, 1.1934782608696, 0.27777777777778
52971, 0.73913043478261, 1.1673913043478, 0.27777777777778
52972, 0.73913043478261, 1.1934782608696, 0.30555555555556
52973, 0.76086956521739, 1.1934782608696, 0.33333333333333
52974, 0.73913043478261, 1.1673913043478, 0.33333333333333
52975, 0.73913043478261, 1.1934782608696, 0.36111111111111
52976, 0.76086956521739, 1.1934782608696, 0.38888888888889
52977, 0.73913043478261, 1.1673913043478, 0.38888888888889
52978, 0.73913043478261, 1.1934782608696, 0.41666666666667
52979, 0.76086956521739, 1.1934782608696, 0.44444444444444
52980, 0.73913043478261, 1.1673913043478, 0.44444444444444
52981, 0.73913043478261, 1.1934782608696, 0.47222222222222
52982, 0.69565217391304, 1.1934782608696, 0.027777777777778
52983, 0.71739130434783, 1.1934782608696, 0.055555555555556
52984, 0.69565217391304, 1.1673913043478, 0.055555555555556
52985, 0.69565217391304, 1.1934782608696, 0.083333333333333
52986, 0.71739130434783, 1.1934782608696, 0.11111111111111
52987, 0.69565217391304, 1.1673913043478, 0.11111111111111
52988, 0.69565217391304, 1.1934782608696, 0.13888888888889
52989, 0.71739130434783, 1.1934782608696, 0.16666666666667
52990, 0.69565217391304, 1.1673913043478, 0.16666666666667
52991, 0.69565217391304, 1.1934782608696, 0.19444444444444
52992, 0.71739130434783, 1.1934782608696, 0.22222222222222
52993, 0.69565217391304, 1.1673913043478, 0.22222222222222
52994, 0.69565217391304, 1.1934782608696, 0.25
52995, 0.71739130434783, 1.1934782608696, 0.27777777777778
52996, 0.69565217391304, 1.1673913043478, 0.27777777777778
52997, 0.69565217391304, 1.1934782608696, 0.30555555555556
52998, 0.71739130434783, 1.1934782608696, 0.33333333333333
52999, 0.69565217391304, 1.1673913043478, 0.33333333333333
53000, 0.69565217391304, 1.1934782608696, 0.36111111111111
53001, 0.71739130434783, 1.1934782608696, 0.38888888888889
53002, 0.69565217391304, 1.1673913043478, 0.38888888888889
53003, 0.69565217391304, 1.1934782608696, 0.41666666666667
53004, 0.71739130434783, 1.1934782608696, 0.44444444444444
53005, 0.69565217391304, 1.1673913043478, 0.44444444444444
53006, 0.69565217391304, 1.1934782608696, 0.47222222222222
53007, 0.65217391304348, 1.1934782608696, 0.027777777777778
53008, 0.67391304347826, 1.1934782608696, 0.055555555555556
53009, 0.65217391304348, 1.1673913043478, 0.055555555555556
53010, 0.65217391304348, 1.1934782608696, 0.083333333333333
53011, 0.67391304347826, 1.1934782608696, 0.11111111111111
53012, 0.65217391304348, 1.1673913043478, 0.11111111111111
53013, 0.65217391304348, 1.1934782608696, 0.13888888888889
53014, 0.67391304347826, 1.1934782608696, 0.16666666666667
53015, 0.65217391304348, 1.1673913043478, 0.16666666666667
53016, 0.65217391304348, 1.1934782608696, 0.19444444444444
53017, 0.67391304347826, 1.1934782608696, 0.22222222222222
53018, 0.65217391304348, 1.1673913043478, 0.22222222222222
53019, 0.65217391304348, 1.1934782608696, 0.25
53020, 0.67391304347826, 1.1934782608696, 0.27777777777778
53021, 0.65217391304348, 1.1673913043478, 0.27777777777778
53022, 0.65217391304348, 1.1934782608696, 0.30555555555556
53023, 0.67391304347826, 1.1934782608696, 0.33333333333333
53024, 0.65217391304348, 1.1673913043478, 0.33333333333333
53025, 0.65217391304348, 1.1934782608696, 0.36111111111111
53026, 0.67391304347826, 1.1934782608696, 0.38888888888889
53027, 0.65217391304348, 1.1673913043478, 0.38888888888889
53028, 0.65217391304348, 1.1934782608696, 0.41666666666667
53029, 0.67391304347826, 1.1934782608696, 0.44444444444444
53030, 0.65217391304348, 1.1673913043478, 0.44444444444444
53031, 0.65217391304348, 1.1934782608696, 0.47222222222222
53032, 0.60869565217391, 1.1934782608696, 0.027777777777778
53033, 0.6304347826087, 1.1934782608696, 0.055555555555556
53034, 0.60869565217391, 1.1673913043478, 0.055555555555556
53035, 0.60869565217391, 1.1934782608696, 0.083333333333333
53036, 0.6304347826087, 1.1934782608696, 0.11111111111111
53037, 0.60869565217391, 1.1673913043478, 0.11111111111111
53038, 0.60869565217391, 1.1934782608696, 0.13888888888889
53039, 0.6304347826087, 1.1934782608696, 0.16666666666667
53040, 0.60869565217391, 1.1673913043478, 0.16666666666667
53041, 0.60869565217391, 1.1934782608696, 0.19444444444444
53042, 0.6304347826087, 1.1934782608696, 0.22222222222222
53043, 0.60869565217391, 1.1673913043478, 0.22222222222222
53044, 0.60869565217391, 1.1934782608696, 0.25
53045, 0.6304347826087, 1.1934782608696, 0.27777777777778
53046, 0.60869565217391, 1.1673913043478, 0.27777777777778
53047, 0.60869565217391, 1.1934782608696, 0.30555555555556
53048, 0.6304347826087, 1.1934782608696, 0.33333333333333
53049, 0.60869565217391, 1.1673913043478, 0.33333333333333
53050, 0.60869565217391, 1.1934782608696, 0.36111111111111
53051, 0.6304347826087, 1.1934782608696, 0.38888888888889
53052, 0.60869565217391, 1.1673913043478, 0.38888888888889
53053, 0.60869565217391, 1.1934782608696, 0.41666666666667
53054, 0.6304347826087, 1.1934782608696, 0.44444444444444
53055, 0.60869565217391, 1.1673913043478, 0.44444444444444
53056, 0.60869565217391, 1.1934782608696, 0.47222222222222
53057, 0.56521739130435, 1.1934782608696, 0.027777777777778
53058, 0.58695652173913, 1.1934782608696, 0.055555555555556
53059, 0.56521739130435, 1.1673913043478, 0.055555555555556
53060, 0.56521739130435, 1.1934782608696, 0.083333333333333
53061, 0.58695652173913, 1.1934782608696, 0.11111111111111
53062, 0.56521739130435, 1.1673913043478, 0.11111111111111
53063, 0.56521739130435, 1.1934782608696, 0.13888888888889
53064, 0.58695652173913, 1.1934782608696, 0.16666666666667
53065, 0.56521739130435, 1.1673913043478, 0.16666666666667
53066, 0.56521739130435, 1.1934782608696, 0.19444444444444
53067, 0.58695652173913, 1.1934782608696, 0.22222222222222
53068, 0.56521739130435, 1.1673913043478, 0.22222222222222
53069, 0.56521739130435, 1.1934782608696, 0.25
53070, 0.58695652173913, 1.1934782608696, 0.27777777777778
53071, 0.56521739130435, 1.1673913043478, 0.27777777777778
53072, 0.56521739130435, 1.1934782608696, 0.30555555555556
53073, 0.58695652173913, 1.1934782608696, 0.33333333333333
53074, 0.56521739130435, 1.1673913043478, 0.33333333333333
53075, 0.56521739130435, 1.1934782608696, 0.36111111111111
53076, 0.58695652173913, 1.1934782608696, 0.38888888888889
53077, 0.56521739130435, 1.1673913043478, 0.38888888888889
53078, 0.56521739130435, 1.1934782608696, 0.41666666666667
53079, 0.58695652173913, 1.1934782608696, 0.44444444444444
53080, 0.56521739130435, 1.1673913043478, 0.44444444444444
53081, 0.56521739130435, 1.1934782608696, 0.47222222222222
53082, 0.52173913043478, 1.1934782608696, 0.027777777777778
53083, 0.54347826086956, 1.1934782608696, 0.055555555555556
53084, 0.52173913043478, 1.1673913043478, 0.055555555555556
53085, 0.52173913043478, 1.1934782608696, 0.083333333333333
53086, 0.54347826086956, 1.1934782608696, 0.11111111111111
53087, 0.52173913043478, 1.1673913043478, 0.11111111111111
53088, 0.52173913043478, 1.1934782608696, 0.13888888888889
53089, 0.54347826086957, 1.1934782608696, 0.16666666666667
53090, 0.52173913043478, 1.1673913043478, 0.16666666666667
53091, 0.52173913043478, 1.1934782608696, 0.19444444444444
53092, 0.54347826086957, 1.1934782608696, 0.22222222222222
53093, 0.52173913043478, 1.1673913043478, 0.22222222222222
53094, 0.52173913043478, 1.1934782608696, 0.25
53095, 0.54347826086956, 1.1934782608696, 0.27777777777778
53096, 0.52173913043478, 1.1673913043478, 0.27777777777778
53097, 0.52173913043478, 1.1934782608696, 0.30555555555556
53098, 0.54347826086956, 1.1934782608696, 0.33333333333333
53099, 0.52173913043478, 1.1673913043478, 0.33333333333333
53100, 0.52173913043478, 1.1934782608696, 0.36111111111111
53101, 0.54347826086956, 1.1934782608696, 0.38888888888889
53102, 0.52173913043478, 1.1673913043478, 0.38888888888889
53103, 0.52173913043478, 1.1934782608696, 0.41666666666667
53104, 0.54347826086956, 1.1934782608696, 0.44444444444444
53105, 0.52173913043478, 1.1673913043478, 0.44444444444444
53106, 0.52173913043478, 1.1934782608696, 0.47222222222222
53107, 0.47826086956522, 1.1934782608696, 0.027777777777778
53108, 0.5, 1.1934782608696, 0.055555555555556
53109, 0.47826086956522, 1.1673913043478, 0.055555555555556
53110, 0.47826086956522, 1.1934782608696, 0.083333333333333
53111, 0.5, 1.1934782608696, 0.11111111111111
53112, 0.47826086956522, 1.1673913043478, 0.11111111111111
53113, 0.47826086956522, 1.1934782608696, 0.13888888888889
53114, 0.5, 1.1934782608696, 0.16666666666667
53115, 0.47826086956522, 1.1673913043478, 0.16666666666667
53116, 0.47826086956522, 1.1934782608696, 0.19444444444444
53117, 0.5, 1.1934782608696, 0.22222222222222
53118, 0.47826086956522, 1.1673913043478, 0.22222222222222
53119, 0.47826086956522, 1.1934782608696, 0.25
53120, 0.5, 1.1934782608696, 0.27777777777778
53121, 0.47826086956522, 1.1673913043478, 0.27777777777778
53122, 0.47826086956522, 1.1934782608696, 0.30555555555556
53123, 0.5, 1.1934782608696, 0.33333333333333
53124, 0.47826086956522, 1.1673913043478, 0.33333333333333
53125, 0.47826086956522, 1.1934782608696, 0.36111111111111
53126, 0.5, 1.1934782608696, 0.38888888888889
53127, 0.47826086956522, 1.1673913043478, 0.38888888888889
53128, 0.47826086956522, 1.1934782608696, 0.41666666666667
53129, 0.5, 1.1934782608696, 0.44444444444444
53130, 0.47826086956522, 1.1673913043478, 0.44444444444444
53131, 0.47826086956522, 1.1934782608696, 0.47222222222222
53132, 0.43478260869565, 1.1934782608696, 0.027777777777778
53133, 0.45652173913043, 1.1934782608696, 0.055555555555556
53134, 0.43478260869565, 1.1673913043478, 0.055555555555556
53135, 0.43478260869565, 1.1934782608696, 0.083333333333333
53136, 0.45652173913043, 1.1934782608696, 0.11111111111111
53137, 0.43478260869565, 1.1673913043478, 0.11111111111111
53138, 0.43478260869565, 1.1934782608696, 0.13888888888889
53139, 0.45652173913043, 1.1934782608696, 0.16666666666667
53140, 0.43478260869565, 1.1673913043478, 0.16666666666667
53141, 0.43478260869565, 1.1934782608696, 0.19444444444444
53142, 0.45652173913043, 1.1934782608696, 0.22222222222222
53143, 0.43478260869565, 1.1673913043478, 0.22222222222222
53144, 0.43478260869565, 1.1934782608696, 0.25
53145, 0.45652173913043, 1.1934782608696, 0.27777777777778
53146, 0.43478260869565, 1.1673913043478, 0.27777777777778
53147, 0.43478260869565, 1.1934782608696, 0.30555555555556
53148, 0.45652173913043, 1.1934782608696, 0.33333333333333
53149, 0.43478260869565, 1.1673913043478, 0.33333333333333
53150, 0.43478260869565, 1.1934782608696, 0.36111111111111
53151, 0.45652173913044, 1.1934782608696, 0.38888888888889
53152, 0.43478260869565, 1.1673913043478, 0.38888888888889
53153, 0.43478260869565, 1.1934782608696, 0.41666666666667
53154, 0.45652173913043, 1.1934782608696, 0.44444444444444
53155, 0.43478260869565, 1.1673913043478, 0.44444444444444
53156, 0.43478260869565, 1.1934782608696, 0.47222222222222
53157, 0.39130434782609, 1.1934782608696, 0.027777777777778
53158, 0.41304347826087, 1.1934782608696, 0.055555555555556
53159, 0.39130434782609, 1.1673913043478, 0.055555555555556
53160, 0.39130434782609, 1.1934782608696, 0.083333333333333
53161, 0.41304347826087, 1.1934782608696, 0.11111111111111
53162, 0.39130434782609, 1.1673913043478, 0.11111111111111
53163, 0.39130434782609, 1.1934782608696, 0.13888888888889
53164, 0.41304347826087, 1.1934782608696, 0.16666666666667
53165, 0.39130434782609, 1.1673913043478, 0.16666666666667
53166, 0.39130434782609, 1.1934782608696, 0.19444444444444
53167, 0.41304347826087, 1.1934782608696, 0.22222222222222
53168, 0.39130434782609, 1.1673913043478, 0.22222222222222
53169, 0.39130434782609, 1.1934782608696, 0.25
53170, 0.41304347826087, 1.1934782608696, 0.27777777777778
53171, 0.39130434782609, 1.1673913043478, 0.27777777777778
53172, 0.39130434782609, 1.1934782608696, 0.30555555555556
53173, 0.41304347826087, 1.1934782608696, 0.33333333333333
53174, 0.39130434782609, 1.1673913043478, 0.33333333333333
53175, 0.39130434782609, 1.1934782608696, 0.36111111111111
53176, 0.41304347826087, 1.1934782608696, 0.38888888888889
53177, 0.39130434782609, 1.1673913043478, 0.38888888888889
53178, 0.39130434782609, 1.1934782608696, 0.41666666666667
53179, 0.41304347826087, 1.1934782608696, 0.44444444444444
53180, 0.39130434782609, 1.1673913043478, 0.44444444444444
53181, 0.39130434782609, 1.1934782608696, 0.47222222222222
53182, 0.34782608695652, 1.1934782608696, 0.027777777777778
53183, 0.3695652173913, 1.1934782608696, 0.055555555555556
53184, 0.34782608695652, 1.1673913043478, 0.055555555555556
53185, 0.34782608695652, 1.1934782608696, 0.083333333333333
53186, 0.3695652173913, 1.1934782608696, 0.11111111111111
53187, 0.34782608695652, 1.1673913043478, 0.11111111111111
53188, 0.34782608695652, 1.1934782608696, 0.13888888888889
53189, 0.3695652173913, 1.1934782608696, 0.16666666666667
53190, 0.34782608695652, 1.1673913043478, 0.16666666666667
53191, 0.34782608695652, 1.1934782608696, 0.19444444444444
53192, 0.3695652173913, 1.1934782608696, 0.22222222222222
53193, 0.34782608695652, 1.1673913043478, 0.22222222222222
53194, 0.34782608695652, 1.1934782608696, 0.25
53195, 0.3695652173913, 1.1934782608696, 0.27777777777778
53196, 0.34782608695652, 1.1673913043478, 0.27777777777778
53197, 0.34782608695652, 1.1934782608696, 0.30555555555556
53198, 0.3695652173913, 1.1934782608696, 0.33333333333333
53199, 0.34782608695652, 1.1673913043478, 0.33333333333333
53200, 0.34782608695652, 1.1934782608696, 0.36111111111111
53201, 0.3695652173913, 1.1934782608696, 0.38888888888889
53202, 0.34782608695652, 1.1673913043478, 0.38888888888889
53203, 0.34782608695652, 1.1934782608696, 0.41666666666667
53204, 0.3695652173913, 1.1934782608696, 0.44444444444444
53205, 0.34782608695652, 1.1673913043478, 0.44444444444444
53206, 0.34782608695652, 1.1934782608696, 0.47222222222222
53207, 0.30434782608696, 1.1934782608696, 0.027777777777778
53208, 0.32608695652174, 1.1934782608696, 0.055555555555556
53209, 0.30434782608696, 1.1673913043478, 0.055555555555556
53210, 0.30434782608696, 1.1934782608696, 0.083333333333333
53211, 0.32608695652174, 1.1934782608696, 0.11111111111111
53212, 0.30434782608696, 1.1673913043478, 0.11111111111111
53213, 0.30434782608696, 1.1934782608696, 0.13888888888889
53214, 0.32608695652174, 1.1934782608696, 0.16666666666667
53215, 0.30434782608696, 1.1673913043478, 0.16666666666667
53216, 0.30434782608696, 1.1934782608696, 0.19444444444444
53217, 0.32608695652174, 1.1934782608696, 0.22222222222222
53218, 0.30434782608696, 1.1673913043478, 0.22222222222222
53219, 0.30434782608696, 1.1934782608696, 0.25
53220, 0.32608695652174, 1.1934782608696, 0.27777777777778
53221, 0.30434782608696, 1.1673913043478, 0.27777777777778
53222, 0.30434782608696, 1.1934782608696, 0.30555555555556
53223, 0.32608695652174, 1.1934782608696, 0.33333333333333
53224, 0.30434782608696, 1.1673913043478, 0.33333333333333
53225, 0.30434782608696, 1.1934782608696, 0.36111111111111
53226, 0.32608695652174, 1.1934782608696, 0.38888888888889
53227, 0.30434782608696, 1.1673913043478, 0.38888888888889
53228, 0.30434782608696, 1.1934782608696, 0.41666666666667
53229, 0.32608695652174, 1.1934782608696, 0.44444444444444
53230, 0.30434782608696, 1.1673913043478, 0.44444444444444
53231, 0.30434782608696, 1.1934782608696, 0.47222222222222
53232, 0.26086956521739, 1.1934782608696, 0.027777777777778
53233, 0.28260869565217, 1.1934782608696, 0.055555555555556
53234, 0.26086956521739, 1.1673913043478, 0.055555555555556
53235, 0.26086956521739, 1.1934782608696, 0.083333333333333
53236, 0.28260869565217, 1.1934782608696, 0.11111111111111
53237, 0.26086956521739, 1.1673913043478, 0.11111111111111
53238, 0.26086956521739, 1.1934782608696, 0.13888888888889
53239, 0.28260869565217, 1.1934782608696, 0.16666666666667
53240, 0.26086956521739, 1.1673913043478, 0.16666666666667
53241, 0.26086956521739, 1.1934782608696, 0.19444444444444
53242, 0.28260869565217, 1.1934782608696, 0.22222222222222
53243, 0.26086956521739, 1.1673913043478, 0.22222222222222
53244, 0.26086956521739, 1.1934782608696, 0.25
53245, 0.28260869565217, 1.1934782608696, 0.27777777777778
53246, 0.26086956521739, 1.1673913043478, 0.27777777777778
53247, 0.26086956521739, 1.1934782608696, 0.30555555555556
53248, 0.28260869565217, 1.1934782608696, 0.33333333333333
53249, 0.26086956521739, 1.1673913043478, 0.33333333333333
53250, 0.26086956521739, 1.1934782608696, 0.36111111111111
53251, 0.28260869565217, 1.1934782608696, 0.38888888888889
53252, 0.26086956521739, 1.1673913043478, 0.38888888888889
53253, 0.26086956521739, 1.1934782608696, 0.41666666666667
53254, 0.28260869565217, 1.1934782608696, 0.44444444444444
53255, 0.26086956521739, 1.1673913043478, 0.44444444444444
53256, 0.26086956521739, 1.1934782608696, 0.47222222222222
53257, 0.21739130434783, 1.1934782608696, 0.027777777777778
53258, 0.23913043478261, 1.1934782608696, 0.055555555555556
53259, 0.21739130434783, 1.1673913043478, 0.055555555555556
53260, 0.21739130434783, 1.1934782608696, 0.083333333333333
53261, 0.23913043478261, 1.1934782608696, 0.11111111111111
53262, 0.21739130434783, 1.1673913043478, 0.11111111111111
53263, 0.21739130434783, 1.1934782608696, 0.13888888888889
53264, 0.23913043478261, 1.1934782608696, 0.16666666666667
53265, 0.21739130434783, 1.1673913043478, 0.16666666666667
53266, 0.21739130434783, 1.1934782608696, 0.19444444444444
53267, 0.23913043478261, 1.1934782608696, 0.22222222222222
53268, 0.21739130434783, 1.1673913043478, 0.22222222222222
53269, 0.21739130434783, 1.1934782608696, 0.25
53270, 0.23913043478261, 1.1934782608696, 0.27777777777778
53271, 0.21739130434783, 1.1673913043478, 0.27777777777778
53272, 0.21739130434783, 1.1934782608696, 0.30555555555556
53273, 0.23913043478261, 1.1934782608696, 0.33333333333333
53274, 0.21739130434783, 1.1673913043478, 0.33333333333333
53275, 0.21739130434783, 1.1934782608696, 0.36111111111111
53276, 0.23913043478261, 1.1934782608696, 0.38888888888889
53277, 0.21739130434783, 1.1673913043478, 0.38888888888889
53278, 0.21739130434783, 1.1934782608696, 0.41666666666667
53279, 0.23913043478261, 1.1934782608696, 0.44444444444444
53280, 0.21739130434783, 1.1673913043478, 0.44444444444444
53281, 0.21739130434783, 1.1934782608696, 0.47222222222222
53282, 0.17391304347826, 1.1934782608696, 0.027777777777778
53283, 0.19565217391304, 1.1934782608696, 0.055555555555556
53284, 0.17391304347826, 1.1673913043478, 0.055555555555556
53285, 0.17391304347826, 1.1934782608696, 0.083333333333333
53286, 0.19565217391304, 1.1934782608696, 0.11111111111111
53287, 0.17391304347826, 1.1673913043478, 0.11111111111111
53288, 0.17391304347826, 1.1934782608696, 0.13888888888889
53289, 0.19565217391304, 1.1934782608696, 0.16666666666667
53290, 0.17391304347826, 1.1673913043478, 0.16666666666667
53291, 0.17391304347826, 1.1934782608696, 0.19444444444444
53292, 0.19565217391304, 1.1934782608696, 0.22222222222222
53293, 0.17391304347826, 1.1673913043478, 0.22222222222222
53294, 0.17391304347826, 1.1934782608696, 0.25
53295, 0.19565217391304, 1.1934782608696, 0.27777777777778
53296, 0.17391304347826, 1.1673913043478, 0.27777777777778
53297, 0.17391304347826, 1.1934782608696, 0.30555555555556
53298, 0.19565217391304, 1.1934782608696, 0.33333333333333
53299, 0.17391304347826, 1.1673913043478, 0.33333333333333
53300, 0.17391304347826, 1.1934782608696, 0.36111111111111
53301, 0.19565217391304, 1.1934782608696, 0.38888888888889
53302, 0.17391304347826, 1.1673913043478, 0.38888888888889
53303, 0.17391304347826, 1.1934782608696, 0.41666666666667
53304, 0.19565217391304, 1.1934782608696, 0.44444444444444
53305, 0.17391304347826, 1.1673913043478, 0.44444444444444
53306, 0.17391304347826, 1.1934782608696, 0.47222222222222
53307, 0.1304347826087, 1.1934782608696, 0.027777777777778
53308, 0.15217391304348, 1.1934782608696, 0.055555555555556
53309, 0.1304347826087, 1.1673913043478, 0.055555555555556
53310, 0.1304347826087, 1.1934782608696, 0.083333333333333
53311, 0.15217391304348, 1.1934782608696, 0.11111111111111
53312, 0.1304347826087, 1.1673913043478, 0.11111111111111
53313, 0.1304347826087, 1.1934782608696, 0.13888888888889
53314, 0.15217391304348, 1.1934782608696, 0.16666666666667
53315, 0.1304347826087, 1.1673913043478, 0.16666666666667
53316, 0.1304347826087, 1.1934782608696, 0.19444444444444
53317, 0.15217391304348, 1.1934782608696, 0.22222222222222
53318, 0.1304347826087, 1.1673913043478, 0.22222222222222
53319, 0.1304347826087, 1.1934782608696, 0.25
53320, 0.15217391304348, 1.1934782608696, 0.27777777777778
53321, 0.1304347826087, 1.1673913043478, 0.27777777777778
53322, 0.1304347826087, 1.1934782608696, 0.30555555555556
53323, 0.15217391304348, 1.1934782608696, 0.33333333333333
53324, 0.1304347826087, 1.1673913043478, 0.33333333333333
53325, 0.1304347826087, 1.1934782608696, 0.36111111111111
53326, 0.15217391304348, 1.1934782608696, 0.38888888888889
53327, 0.1304347826087, 1.1673913043478, 0.38888888888889
53328, 0.1304347826087, 1.1934782608696, 0.41666666666667
53329, 0.15217391304348, 1.1934782608696, 0.44444444444444
53330, 0.1304347826087, 1.1673913043478, 0.44444444444444
53331, 0.1304347826087, 1.1934782608696, 0.47222222222222
53332, 0.08695652173913, 1.1934782608696, 0.027777777777778
53333, 0.10869565217391, 1.1934782608696, 0.055555555555556
53334, 0.08695652173913, 1.1673913043478, 0.055555555555556
53335, 0.08695652173913, 1.1934782608696, 0.083333333333333
53336, 0.10869565217391, 1.1934782608696, 0.11111111111111
53337, 0.08695652173913, 1.1673913043478, 0.11111111111111
53338, 0.08695652173913, 1.1934782608696, 0.13888888888889
53339, 0.10869565217391, 1.1934782608696, 0.16666666666667
53340, 0.08695652173913, 1.1673913043478, 0.16666666666667
53341, 0.08695652173913, 1.1934782608696, 0.19444444444444
53342, 0.10869565217391, 1.1934782608696, 0.22222222222222
53343, 0.08695652173913, 1.1673913043478, 0.22222222222222
53344, 0.08695652173913, 1.1934782608696, 0.25
53345, 0.10869565217391, 1.1934782608696, 0.27777777777778
53346, 0.08695652173913, 1.1673913043478, 0.27777777777778
53347, 0.08695652173913, 1.1934782608696, 0.30555555555556
53348, 0.10869565217391, 1.1934782608696, 0.33333333333333
53349, 0.08695652173913, 1.1673913043478, 0.33333333333333
53350, 0.08695652173913, 1.1934782608696, 0.36111111111111
53351, 0.10869565217391, 1.1934782608696, 0.38888888888889
53352, 0.08695652173913, 1.1673913043478, 0.38888888888889
53353, 0.08695652173913, 1.1934782608696, 0.41666666666667
53354, 0.10869565217391, 1.1934782608696, 0.44444444444444
53355, 0.08695652173913, 1.1673913043478, 0.44444444444444
53356, 0.08695652173913, 1.1934782608696, 0.47222222222222
53357, 0.043478260869565, 1.1934782608696, 0.027777777777778
53358, 0.065217391304348, 1.1934782608696, 0.055555555555556
53359, 0.043478260869565, 1.1673913043478, 0.055555555555556
53360, 0.043478260869565, 1.1934782608696, 0.083333333333333
53361, 0.065217391304348, 1.1934782608696, 0.11111111111111
53362, 0.043478260869565, 1.1673913043478, 0.11111111111111
53363, 0.043478260869565, 1.1934782608696, 0.13888888888889
53364, 0.065217391304348, 1.1934782608696, 0.16666666666667
53365, 0.043478260869565, 1.1673913043478, 0.16666666666667
53366, 0.043478260869565, 1.1934782608696, 0.19444444444444
53367, 0.065217391304348, 1.1934782608696, 0.22222222222222
53368, 0.043478260869565, 1.1673913043478, 0.22222222222222
53369, 0.043478260869565, 1.1934782608696, 0.25
53370, 0.065217391304348, 1.1934782608696, 0.27777777777778
53371, 0.043478260869565, 1.1673913043478, 0.27777777777778
53372, 0.043478260869565, 1.1934782608696, 0.30555555555556
53373, 0.065217391304348, 1.1934782608696, 0.33333333333333
53374, 0.043478260869565, 1.1673913043478, 0.33333333333333
53375, 0.043478260869565, 1.1934782608696, 0.36111111111111
53376, 0.065217391304348, 1.1934782608696, 0.38888888888889
53377, 0.043478260869565, 1.1673913043478, 0.38888888888889
53378, 0.043478260869565, 1.1934782608696, 0.41666666666667
53379, 0.065217391304348, 1.1934782608696, 0.44444444444444
53380, 0.043478260869565, 1.1673913043478, 0.44444444444444
53381, 0.043478260869565, 1.1934782608696, 0.47222222222222
53382, 0.021739130434783, 1.1934782608696, 0.055555555555556
53383, 0.021739130434783, 1.1934782608696, 0.11111111111111
53384, 0.021739130434783, 1.1934782608696, 0.16666666666667
53385, 0.021739130434783, 1.1934782608696, 0.22222222222222
53386, 0.021739130434783, 1.1934782608696, 0.27777777777778
53387, 0.021739130434783, 1.1934782608696, 0.33333333333333
53388, 0.021739130434783, 1.1934782608696, 0.38888888888889
53389, 0.021739130434783, 1.1934782608696, 0.44444444444444
53390, 0.95652173913043, 1.245652173913, 0.027777777777778
53391, 0.97826086956522, 1.245652173913, 0.055555555555556
53392, 0.95652173913043, 1.2195652173913, 0.055555555555556
53393, 0.95652173913043, 1.245652173913, 0.083333333333333
53394, 0.97826086956522, 1.245652173913, 0.11111111111111
53395, 0.95652173913043, 1.2195652173913, 0.11111111111111
53396, 0.95652173913044, 1.245652173913, 0.13888888888889
53397, 0.97826086956522, 1.245652173913, 0.16666666666667
53398, 0.95652173913044, 1.2195652173913, 0.16666666666667
53399, 0.95652173913044, 1.245652173913, 0.19444444444444
53400, 0.97826086956522, 1.245652173913, 0.22222222222222
53401, 0.95652173913044, 1.2195652173913, 0.22222222222222
53402, 0.95652173913044, 1.245652173913, 0.25
53403, 0.97826086956522, 1.245652173913, 0.27777777777778
53404, 0.95652173913044, 1.2195652173913, 0.27777777777778
53405, 0.95652173913044, 1.245652173913, 0.30555555555556
53406, 0.97826086956522, 1.245652173913, 0.33333333333333
53407, 0.95652173913044, 1.2195652173913, 0.33333333333333
53408, 0.95652173913044, 1.245652173913, 0.36111111111111
53409, 0.97826086956522, 1.245652173913, 0.38888888888889
53410, 0.95652173913044, 1.2195652173913, 0.38888888888889
53411, 0.95652173913044, 1.245652173913, 0.41666666666667
53412, 0.97826086956522, 1.245652173913, 0.44444444444444
53413, 0.95652173913044, 1.2195652173913, 0.44444444444444
53414, 0.95652173913043, 1.245652173913, 0.47222222222222
53415, 0.91304347826087, 1.245652173913, 0.027777777777778
53416, 0.93478260869565, 1.245652173913, 0.055555555555556
53417, 0.91304347826087, 1.2195652173913, 0.055555555555556
53418, 0.91304347826087, 1.245652173913, 0.083333333333333
53419, 0.93478260869565, 1.245652173913, 0.11111111111111
53420, 0.91304347826087, 1.2195652173913, 0.11111111111111
53421, 0.91304347826087, 1.245652173913, 0.13888888888889
53422, 0.93478260869565, 1.245652173913, 0.16666666666667
53423, 0.91304347826087, 1.2195652173913, 0.16666666666667
53424, 0.91304347826087, 1.245652173913, 0.19444444444444
53425, 0.93478260869565, 1.245652173913, 0.22222222222222
53426, 0.91304347826087, 1.2195652173913, 0.22222222222222
53427, 0.91304347826087, 1.245652173913, 0.25
53428, 0.93478260869565, 1.245652173913, 0.27777777777778
53429, 0.91304347826087, 1.2195652173913, 0.27777777777778
53430, 0.91304347826087, 1.245652173913, 0.30555555555556
53431, 0.93478260869565, 1.245652173913, 0.33333333333333
53432, 0.91304347826087, 1.2195652173913, 0.33333333333333
53433, 0.91304347826087, 1.245652173913, 0.36111111111111
53434, 0.93478260869565, 1.245652173913, 0.38888888888889
53435, 0.91304347826087, 1.2195652173913, 0.38888888888889
53436, 0.91304347826087, 1.245652173913, 0.41666666666667
53437, 0.93478260869565, 1.245652173913, 0.44444444444444
53438, 0.91304347826087, 1.2195652173913, 0.44444444444444
53439, 0.91304347826087, 1.245652173913, 0.47222222222222
53440, 0.8695652173913, 1.245652173913, 0.027777777777778
53441, 0.89130434782609, 1.245652173913, 0.055555555555556
53442, 0.8695652173913, 1.2195652173913, 0.055555555555556
53443, 0.8695652173913, 1.245652173913, 0.083333333333333
53444, 0.89130434782609, 1.245652173913, 0.11111111111111
53445, 0.8695652173913, 1.2195652173913, 0.11111111111111
53446, 0.8695652173913, 1.245652173913, 0.13888888888889
53447, 0.89130434782609, 1.245652173913, 0.16666666666667
53448, 0.8695652173913, 1.2195652173913, 0.16666666666667
53449, 0.8695652173913, 1.245652173913, 0.19444444444444
53450, 0.89130434782609, 1.245652173913, 0.22222222222222
53451, 0.8695652173913, 1.2195652173913, 0.22222222222222
53452, 0.8695652173913, 1.245652173913, 0.25
53453, 0.89130434782609, 1.245652173913, 0.27777777777778
53454, 0.8695652173913, 1.2195652173913, 0.27777777777778
53455, 0.8695652173913, 1.245652173913, 0.30555555555556
53456, 0.89130434782609, 1.245652173913, 0.33333333333333
53457, 0.8695652173913, 1.2195652173913, 0.33333333333333
53458, 0.8695652173913, 1.245652173913, 0.36111111111111
53459, 0.89130434782609, 1.245652173913, 0.38888888888889
53460, 0.8695652173913, 1.2195652173913, 0.38888888888889
53461, 0.8695652173913, 1.245652173913, 0.41666666666667
53462, 0.89130434782609, 1.245652173913, 0.44444444444444
53463, 0.8695652173913, 1.2195652173913, 0.44444444444444
53464, 0.8695652173913, 1.245652173913, 0.47222222222222
53465, 0.82608695652174, 1.245652173913, 0.027777777777778
53466, 0.84782608695652, 1.245652173913, 0.055555555555556
53467, 0.82608695652174, 1.2195652173913, 0.055555555555556
53468, 0.82608695652174, 1.245652173913, 0.083333333333333
53469, 0.84782608695652, 1.245652173913, 0.11111111111111
53470, 0.82608695652174, 1.2195652173913, 0.11111111111111
53471, 0.82608695652174, 1.245652173913, 0.13888888888889
53472, 0.84782608695652, 1.245652173913, 0.16666666666667
53473, 0.82608695652174, 1.2195652173913, 0.16666666666667
53474, 0.82608695652174, 1.245652173913, 0.19444444444444
53475, 0.84782608695652, 1.245652173913, 0.22222222222222
53476, 0.82608695652174, 1.2195652173913, 0.22222222222222
53477, 0.82608695652174, 1.245652173913, 0.25
53478, 0.84782608695652, 1.245652173913, 0.27777777777778
53479, 0.82608695652174, 1.2195652173913, 0.27777777777778
53480, 0.82608695652174, 1.245652173913, 0.30555555555556
53481, 0.84782608695652, 1.245652173913, 0.33333333333333
53482, 0.82608695652174, 1.2195652173913, 0.33333333333333
53483, 0.82608695652174, 1.245652173913, 0.36111111111111
53484, 0.84782608695652, 1.245652173913, 0.38888888888889
53485, 0.82608695652174, 1.2195652173913, 0.38888888888889
53486, 0.82608695652174, 1.245652173913, 0.41666666666667
53487, 0.84782608695652, 1.245652173913, 0.44444444444444
53488, 0.82608695652174, 1.2195652173913, 0.44444444444444
53489, 0.82608695652174, 1.245652173913, 0.47222222222222
53490, 0.78260869565217, 1.245652173913, 0.027777777777778
53491, 0.80434782608696, 1.245652173913, 0.055555555555556
53492, 0.78260869565217, 1.2195652173913, 0.055555555555556
53493, 0.78260869565217, 1.245652173913, 0.083333333333333
53494, 0.80434782608696, 1.245652173913, 0.11111111111111
53495, 0.78260869565217, 1.2195652173913, 0.11111111111111
53496, 0.78260869565217, 1.245652173913, 0.13888888888889
53497, 0.80434782608696, 1.245652173913, 0.16666666666667
53498, 0.78260869565217, 1.2195652173913, 0.16666666666667
53499, 0.78260869565217, 1.245652173913, 0.19444444444444
53500, 0.80434782608696, 1.245652173913, 0.22222222222222
53501, 0.78260869565217, 1.2195652173913, 0.22222222222222
53502, 0.78260869565217, 1.245652173913, 0.25
53503, 0.80434782608696, 1.245652173913, 0.27777777777778
53504, 0.78260869565217, 1.2195652173913, 0.27777777777778
53505, 0.78260869565217, 1.245652173913, 0.30555555555556
53506, 0.80434782608696, 1.245652173913, 0.33333333333333
53507, 0.78260869565217, 1.2195652173913, 0.33333333333333
53508, 0.78260869565217, 1.245652173913, 0.36111111111111
53509, 0.80434782608696, 1.245652173913, 0.38888888888889
53510, 0.78260869565217, 1.2195652173913, 0.38888888888889
53511, 0.78260869565217, 1.245652173913, 0.41666666666667
53512, 0.80434782608696, 1.245652173913, 0.44444444444444
53513, 0.78260869565217, 1.2195652173913, 0.44444444444444
53514, 0.78260869565217, 1.245652173913, 0.47222222222222
53515, 0.73913043478261, 1.245652173913, 0.027777777777778
53516, 0.76086956521739, 1.245652173913, 0.055555555555556
53517, 0.73913043478261, 1.2195652173913, 0.055555555555556
53518, 0.73913043478261, 1.245652173913, 0.083333333333333
53519, 0.76086956521739, 1.245652173913, 0.11111111111111
53520, 0.73913043478261, 1.2195652173913, 0.11111111111111
53521, 0.73913043478261, 1.245652173913, 0.13888888888889
53522, 0.76086956521739, 1.245652173913, 0.16666666666667
53523, 0.73913043478261, 1.2195652173913, 0.16666666666667
53524, 0.73913043478261, 1.245652173913, 0.19444444444444
53525, 0.76086956521739, 1.245652173913, 0.22222222222222
53526, 0.73913043478261, 1.2195652173913, 0.22222222222222
53527, 0.73913043478261, 1.245652173913, 0.25
53528, 0.76086956521739, 1.245652173913, 0.27777777777778
53529, 0.73913043478261, 1.2195652173913, 0.27777777777778
53530, 0.73913043478261, 1.245652173913, 0.30555555555556
53531, 0.76086956521739, 1.245652173913, 0.33333333333333
53532, 0.73913043478261, 1.2195652173913, 0.33333333333333
53533, 0.73913043478261, 1.245652173913, 0.36111111111111
53534, 0.76086956521739, 1.245652173913, 0.38888888888889
53535, 0.73913043478261, 1.2195652173913, 0.38888888888889
53536, 0.73913043478261, 1.245652173913, 0.41666666666667
53537, 0.76086956521739, 1.245652173913, 0.44444444444444
53538, 0.73913043478261, 1.2195652173913, 0.44444444444444
53539, 0.73913043478261, 1.245652173913, 0.47222222222222
53540, 0.69565217391304, 1.245652173913, 0.027777777777778
53541, 0.71739130434783, 1.245652173913, 0.055555555555556
53542, 0.69565217391304, 1.2195652173913, 0.055555555555556
53543, 0.69565217391304, 1.245652173913, 0.083333333333333
53544, 0.71739130434783, 1.245652173913, 0.11111111111111
53545, 0.69565217391304, 1.2195652173913, 0.11111111111111
53546, 0.69565217391304, 1.245652173913, 0.13888888888889
53547, 0.71739130434783, 1.245652173913, 0.16666666666667
53548, 0.69565217391304, 1.2195652173913, 0.16666666666667
53549, 0.69565217391304, 1.245652173913, 0.19444444444444
53550, 0.71739130434783, 1.245652173913, 0.22222222222222
53551, 0.69565217391304, 1.2195652173913, 0.22222222222222
53552, 0.69565217391304, 1.245652173913, 0.25
53553, 0.71739130434783, 1.245652173913, 0.27777777777778
53554, 0.69565217391304, 1.2195652173913, 0.27777777777778
53555, 0.69565217391304, 1.245652173913, 0.30555555555556
53556, 0.71739130434783, 1.245652173913, 0.33333333333333
53557, 0.69565217391304, 1.2195652173913, 0.33333333333333
53558, 0.69565217391304, 1.245652173913, 0.36111111111111
53559, 0.71739130434783, 1.245652173913, 0.38888888888889
53560, 0.69565217391304, 1.2195652173913, 0.38888888888889
53561, 0.69565217391304, 1.245652173913, 0.41666666666667
53562, 0.71739130434783, 1.245652173913, 0.44444444444444
53563, 0.69565217391304, 1.2195652173913, 0.44444444444444
53564, 0.69565217391304, 1.245652173913, 0.47222222222222
53565, 0.65217391304348, 1.245652173913, 0.027777777777778
53566, 0.67391304347826, 1.245652173913, 0.055555555555556
53567, 0.65217391304348, 1.2195652173913, 0.055555555555556
53568, 0.65217391304348, 1.245652173913, 0.083333333333333
53569, 0.67391304347826, 1.245652173913, 0.11111111111111
53570, 0.65217391304348, 1.2195652173913, 0.11111111111111
53571, 0.65217391304348, 1.245652173913, 0.13888888888889
53572, 0.67391304347826, 1.245652173913, 0.16666666666667
53573, 0.65217391304348, 1.2195652173913, 0.16666666666667
53574, 0.65217391304348, 1.245652173913, 0.19444444444444
53575, 0.67391304347826, 1.245652173913, 0.22222222222222
53576, 0.65217391304348, 1.2195652173913, 0.22222222222222
53577, 0.65217391304348, 1.245652173913, 0.25
53578, 0.67391304347826, 1.245652173913, 0.27777777777778
53579, 0.65217391304348, 1.2195652173913, 0.27777777777778
53580, 0.65217391304348, 1.245652173913, 0.30555555555556
53581, 0.67391304347826, 1.245652173913, 0.33333333333333
53582, 0.65217391304348, 1.2195652173913, 0.33333333333333
53583, 0.65217391304348, 1.245652173913, 0.36111111111111
53584, 0.67391304347826, 1.245652173913, 0.38888888888889
53585, 0.65217391304348, 1.2195652173913, 0.38888888888889
53586, 0.65217391304348, 1.245652173913, 0.41666666666667
53587, 0.67391304347826, 1.245652173913, 0.44444444444444
53588, 0.65217391304348, 1.2195652173913, 0.44444444444444
53589, 0.65217391304348, 1.245652173913, 0.47222222222222
53590, 0.60869565217391, 1.245652173913, 0.027777777777778
53591, 0.6304347826087, 1.245652173913, 0.055555555555556
53592, 0.60869565217391, 1.2195652173913, 0.055555555555556
53593, 0.60869565217391, 1.245652173913, 0.083333333333333
53594, 0.6304347826087, 1.245652173913, 0.11111111111111
53595, 0.60869565217391, 1.2195652173913, 0.11111111111111
53596, 0.60869565217391, 1.245652173913, 0.13888888888889
53597, 0.6304347826087, 1.245652173913, 0.16666666666667
53598, 0.60869565217391, 1.2195652173913, 0.16666666666667
53599, 0.60869565217391, 1.245652173913, 0.19444444444444
53600, 0.6304347826087, 1.245652173913, 0.22222222222222
53601, 0.60869565217391, 1.2195652173913, 0.22222222222222
53602, 0.60869565217391, 1.245652173913, 0.25
53603, 0.6304347826087, 1.245652173913, 0.27777777777778
53604, 0.60869565217391, 1.2195652173913, 0.27777777777778
53605, 0.60869565217391, 1.245652173913, 0.30555555555556
53606, 0.6304347826087, 1.245652173913, 0.33333333333333
53607, 0.60869565217391, 1.2195652173913, 0.33333333333333
53608, 0.60869565217391, 1.245652173913, 0.36111111111111
53609, 0.6304347826087, 1.245652173913, 0.38888888888889
53610, 0.60869565217391, 1.2195652173913, 0.38888888888889
53611, 0.60869565217391, 1.245652173913, 0.41666666666667
53612, 0.6304347826087, 1.245652173913, 0.44444444444444
53613, 0.60869565217391, 1.2195652173913, 0.44444444444444
53614, 0.60869565217391, 1.245652173913, 0.47222222222222
53615, 0.56521739130435, 1.245652173913, 0.027777777777778
53616, 0.58695652173913, 1.245652173913, 0.055555555555556
53617, 0.56521739130435, 1.2195652173913, 0.055555555555556
53618, 0.56521739130435, 1.245652173913, 0.083333333333333
53619, 0.58695652173913, 1.245652173913, 0.11111111111111
53620, 0.56521739130435, 1.2195652173913, 0.11111111111111
53621, 0.56521739130435, 1.245652173913, 0.13888888888889
53622, 0.58695652173913, 1.245652173913, 0.16666666666667
53623, 0.56521739130435, 1.2195652173913, 0.16666666666667
53624, 0.56521739130435, 1.245652173913, 0.19444444444444
53625, 0.58695652173913, 1.245652173913, 0.22222222222222
53626, 0.56521739130435, 1.2195652173913, 0.22222222222222
53627, 0.56521739130435, 1.245652173913, 0.25
53628, 0.58695652173913, 1.245652173913, 0.27777777777778
53629, 0.56521739130435, 1.2195652173913, 0.27777777777778
53630, 0.56521739130435, 1.245652173913, 0.30555555555556
53631, 0.58695652173913, 1.245652173913, 0.33333333333333
53632, 0.56521739130435, 1.2195652173913, 0.33333333333333
53633, 0.56521739130435, 1.245652173913, 0.36111111111111
53634, 0.58695652173913, 1.245652173913, 0.38888888888889
53635, 0.56521739130435, 1.2195652173913, 0.38888888888889
53636, 0.56521739130435, 1.245652173913, 0.41666666666667
53637, 0.58695652173913, 1.245652173913, 0.44444444444444
53638, 0.56521739130435, 1.2195652173913, 0.44444444444444
53639, 0.56521739130435, 1.245652173913, 0.47222222222222
53640, 0.52173913043478, 1.245652173913, 0.027777777777778
53641, 0.54347826086957, 1.245652173913, 0.055555555555556
53642, 0.52173913043478, 1.2195652173913, 0.055555555555556
53643, 0.52173913043478, 1.245652173913, 0.083333333333333
53644, 0.54347826086957, 1.245652173913, 0.11111111111111
53645, 0.52173913043478, 1.2195652173913, 0.11111111111111
53646, 0.52173913043478, 1.245652173913, 0.13888888888889
53647, 0.54347826086956, 1.245652173913, 0.16666666666667
53648, 0.52173913043478, 1.2195652173913, 0.16666666666667
53649, 0.52173913043478, 1.245652173913, 0.19444444444444
53650, 0.54347826086956, 1.245652173913, 0.22222222222222
53651, 0.52173913043478, 1.2195652173913, 0.22222222222222
53652, 0.52173913043478, 1.245652173913, 0.25
53653, 0.54347826086956, 1.245652173913, 0.27777777777778
53654, 0.52173913043478, 1.2195652173913, 0.27777777777778
53655, 0.52173913043478, 1.245652173913, 0.30555555555556
53656, 0.54347826086956, 1.245652173913, 0.33333333333333
53657, 0.52173913043478, 1.2195652173913, 0.33333333333333
53658, 0.52173913043478, 1.245652173913, 0.36111111111111
53659, 0.54347826086956, 1.245652173913, 0.38888888888889
53660, 0.52173913043478, 1.2195652173913, 0.38888888888889
53661, 0.52173913043478, 1.245652173913, 0.41666666666667
53662, 0.54347826086956, 1.245652173913, 0.44444444444444
53663, 0.52173913043478, 1.2195652173913, 0.44444444444444
53664, 0.52173913043478, 1.245652173913, 0.47222222222222
53665, 0.47826086956522, 1.245652173913, 0.027777777777778
53666, 0.5, 1.245652173913, 0.055555555555556
53667, 0.47826086956522, 1.2195652173913, 0.055555555555556
53668, 0.47826086956522, 1.245652173913, 0.083333333333333
53669, 0.5, 1.245652173913, 0.11111111111111
53670, 0.47826086956522, 1.2195652173913, 0.11111111111111
53671, 0.47826086956522, 1.245652173913, 0.13888888888889
53672, 0.5, 1.245652173913, 0.16666666666667
53673, 0.47826086956522, 1.2195652173913, 0.16666666666667
53674, 0.47826086956522, 1.245652173913, 0.19444444444444
53675, 0.5, 1.245652173913, 0.22222222222222
53676, 0.47826086956522, 1.2195652173913, 0.22222222222222
53677, 0.47826086956522, 1.245652173913, 0.25
53678, 0.5, 1.245652173913, 0.27777777777778
53679, 0.47826086956522, 1.2195652173913, 0.27777777777778
53680, 0.47826086956522, 1.245652173913, 0.30555555555556
53681, 0.5, 1.245652173913, 0.33333333333333
53682, 0.47826086956522, 1.2195652173913, 0.33333333333333
53683, 0.47826086956522, 1.245652173913, 0.36111111111111
53684, 0.5, 1.245652173913, 0.38888888888889
53685, 0.47826086956522, 1.2195652173913, 0.38888888888889
53686, 0.47826086956522, 1.245652173913, 0.41666666666667
53687, 0.5, 1.245652173913, 0.44444444444444
53688, 0.47826086956522, 1.2195652173913, 0.44444444444444
53689, 0.47826086956522, 1.245652173913, 0.47222222222222
53690, 0.43478260869565, 1.245652173913, 0.027777777777778
53691, 0.45652173913043, 1.245652173913, 0.055555555555556
53692, 0.43478260869565, 1.2195652173913, 0.055555555555556
53693, 0.43478260869565, 1.245652173913, 0.083333333333333
53694, 0.45652173913043, 1.245652173913, 0.11111111111111
53695, 0.43478260869565, 1.2195652173913, 0.11111111111111
53696, 0.43478260869565, 1.245652173913, 0.13888888888889
53697, 0.45652173913043, 1.245652173913, 0.16666666666667
53698, 0.43478260869565, 1.2195652173913, 0.16666666666667
53699, 0.43478260869565, 1.245652173913, 0.19444444444444
53700, 0.45652173913043, 1.245652173913, 0.22222222222222
53701, 0.43478260869565, 1.2195652173913, 0.22222222222222
53702, 0.43478260869565, 1.245652173913, 0.25
53703, 0.45652173913043, 1.245652173913, 0.27777777777778
53704, 0.43478260869565, 1.2195652173913, 0.27777777777778
53705, 0.43478260869565, 1.245652173913, 0.30555555555556
53706, 0.45652173913043, 1.245652173913, 0.33333333333333
53707, 0.43478260869565, 1.2195652173913, 0.33333333333333
53708, 0.43478260869565, 1.245652173913, 0.36111111111111
53709, 0.45652173913044, 1.245652173913, 0.38888888888889
53710, 0.43478260869565, 1.2195652173913, 0.38888888888889
53711, 0.43478260869565, 1.245652173913, 0.41666666666667
53712, 0.45652173913043, 1.245652173913, 0.44444444444444
53713, 0.43478260869565, 1.2195652173913, 0.44444444444444
53714, 0.43478260869565, 1.245652173913, 0.47222222222222
53715, 0.39130434782609, 1.245652173913, 0.027777777777778
53716, 0.41304347826087, 1.245652173913, 0.055555555555556
53717, 0.39130434782609, 1.2195652173913, 0.055555555555556
53718, 0.39130434782609, 1.245652173913, 0.083333333333333
53719, 0.41304347826087, 1.245652173913, 0.11111111111111
53720, 0.39130434782609, 1.2195652173913, 0.11111111111111
53721, 0.39130434782609, 1.245652173913, 0.13888888888889
53722, 0.41304347826087, 1.245652173913, 0.16666666666667
53723, 0.39130434782609, 1.2195652173913, 0.16666666666667
53724, 0.39130434782609, 1.245652173913, 0.19444444444444
53725, 0.41304347826087, 1.245652173913, 0.22222222222222
53726, 0.39130434782609, 1.2195652173913, 0.22222222222222
53727, 0.39130434782609, 1.245652173913, 0.25
53728, 0.41304347826087, 1.245652173913, 0.27777777777778
53729, 0.39130434782609, 1.2195652173913, 0.27777777777778
53730, 0.39130434782609, 1.245652173913, 0.30555555555556
53731, 0.41304347826087, 1.245652173913, 0.33333333333333
53732, 0.39130434782609, 1.2195652173913, 0.33333333333333
53733, 0.39130434782609, 1.245652173913, 0.36111111111111
53734, 0.41304347826087, 1.245652173913, 0.38888888888889
53735, 0.39130434782609, 1.2195652173913, 0.38888888888889
53736, 0.39130434782609, 1.245652173913, 0.41666666666667
53737, 0.41304347826087, 1.245652173913, 0.44444444444444
53738, 0.39130434782609, 1.2195652173913, 0.44444444444444
53739, 0.39130434782609, 1.245652173913, 0.47222222222222
53740, 0.34782608695652, 1.245652173913, 0.027777777777778
53741, 0.3695652173913, 1.245652173913, 0.055555555555556
53742, 0.34782608695652, 1.2195652173913, 0.055555555555556
53743, 0.34782608695652, 1.245652173913, 0.083333333333333
53744, 0.3695652173913, 1.245652173913, 0.11111111111111
53745, 0.34782608695652, 1.2195652173913, 0.11111111111111
53746, 0.34782608695652, 1.245652173913, 0.13888888888889
53747, 0.3695652173913, 1.245652173913, 0.16666666666667
53748, 0.34782608695652, 1.2195652173913, 0.16666666666667
53749, 0.34782608695652, 1.245652173913, 0.19444444444444
53750, 0.3695652173913, 1.245652173913, 0.22222222222222
53751, 0.34782608695652, 1.2195652173913, 0.22222222222222
53752, 0.34782608695652, 1.245652173913, 0.25
53753, 0.3695652173913, 1.245652173913, 0.27777777777778
53754, 0.34782608695652, 1.2195652173913, 0.27777777777778
53755, 0.34782608695652, 1.245652173913, 0.30555555555556
53756, 0.3695652173913, 1.245652173913, 0.33333333333333
53757, 0.34782608695652, 1.2195652173913, 0.33333333333333
53758, 0.34782608695652, 1.245652173913, 0.36111111111111
53759, 0.3695652173913, 1.245652173913, 0.38888888888889
53760, 0.34782608695652, 1.2195652173913, 0.38888888888889
53761, 0.34782608695652, 1.245652173913, 0.41666666666667
53762, 0.3695652173913, 1.245652173913, 0.44444444444444
53763, 0.34782608695652, 1.2195652173913, 0.44444444444444
53764, 0.34782608695652, 1.245652173913, 0.47222222222222
53765, 0.30434782608696, 1.245652173913, 0.027777777777778
53766, 0.32608695652174, 1.245652173913, 0.055555555555556
53767, 0.30434782608696, 1.2195652173913, 0.055555555555556
53768, 0.30434782608696, 1.245652173913, 0.083333333333333
53769, 0.32608695652174, 1.245652173913, 0.11111111111111
53770, 0.30434782608696, 1.2195652173913, 0.11111111111111
53771, 0.30434782608696, 1.245652173913, 0.13888888888889
53772, 0.32608695652174, 1.245652173913, 0.16666666666667
53773, 0.30434782608696, 1.2195652173913, 0.16666666666667
53774, 0.30434782608696, 1.245652173913, 0.19444444444444
53775, 0.32608695652174, 1.245652173913, 0.22222222222222
53776, 0.30434782608696, 1.2195652173913, 0.22222222222222
53777, 0.30434782608696, 1.245652173913, 0.25
53778, 0.32608695652174, 1.245652173913, 0.27777777777778
53779, 0.30434782608696, 1.2195652173913, 0.27777777777778
53780, 0.30434782608696, 1.245652173913, 0.30555555555556
53781, 0.32608695652174, 1.245652173913, 0.33333333333333
53782, 0.30434782608696, 1.2195652173913, 0.33333333333333
53783, 0.30434782608696, 1.245652173913, 0.36111111111111
53784, 0.32608695652174, 1.245652173913, 0.38888888888889
53785, 0.30434782608696, 1.2195652173913, 0.38888888888889
53786, 0.30434782608696, 1.245652173913, 0.41666666666667
53787, 0.32608695652174, 1.245652173913, 0.44444444444444
53788, 0.30434782608696, 1.2195652173913, 0.44444444444444
53789, 0.30434782608696, 1.245652173913, 0.47222222222222
53790, 0.26086956521739, 1.245652173913, 0.027777777777778
53791, 0.28260869565217, 1.245652173913, 0.055555555555556
53792, 0.26086956521739, 1.2195652173913, 0.055555555555556
53793, 0.26086956521739, 1.245652173913, 0.083333333333333
53794, 0.28260869565217, 1.245652173913, 0.11111111111111
53795, 0.26086956521739, 1.2195652173913, 0.11111111111111
53796, 0.26086956521739, 1.245652173913, 0.13888888888889
53797, 0.28260869565217, 1.245652173913, 0.16666666666667
53798, 0.26086956521739, 1.2195652173913, 0.16666666666667
53799, 0.26086956521739, 1.245652173913, 0.19444444444444
53800, 0.28260869565217, 1.245652173913, 0.22222222222222
53801, 0.26086956521739, 1.2195652173913, 0.22222222222222
53802, 0.26086956521739, 1.245652173913, 0.25
53803, 0.28260869565217, 1.245652173913, 0.27777777777778
53804, 0.26086956521739, 1.2195652173913, 0.27777777777778
53805, 0.26086956521739, 1.245652173913, 0.30555555555556
53806, 0.28260869565217, 1.245652173913, 0.33333333333333
53807, 0.26086956521739, 1.2195652173913, 0.33333333333333
53808, 0.26086956521739, 1.245652173913, 0.36111111111111
53809, 0.28260869565217, 1.245652173913, 0.38888888888889
53810, 0.26086956521739, 1.2195652173913, 0.38888888888889
53811, 0.26086956521739, 1.245652173913, 0.41666666666667
53812, 0.28260869565217, 1.245652173913, 0.44444444444444
53813, 0.26086956521739, 1.2195652173913, 0.44444444444444
53814, 0.26086956521739, 1.245652173913, 0.47222222222222
53815, 0.21739130434783, 1.245652173913, 0.027777777777778
53816, 0.23913043478261, 1.245652173913, 0.055555555555556
53817, 0.21739130434783, 1.2195652173913, 0.055555555555556
53818, 0.21739130434783, 1.245652173913, 0.083333333333333
53819, 0.23913043478261, 1.245652173913, 0.11111111111111
53820, 0.21739130434783, 1.2195652173913, 0.11111111111111
53821, 0.21739130434783, 1.245652173913, 0.13888888888889
53822, 0.23913043478261, 1.245652173913, 0.16666666666667
53823, 0.21739130434783, 1.2195652173913, 0.16666666666667
53824, 0.21739130434783, 1.245652173913, 0.19444444444444
53825, 0.23913043478261, 1.245652173913, 0.22222222222222
53826, 0.21739130434783, 1.2195652173913, 0.22222222222222
53827, 0.21739130434783, 1.245652173913, 0.25
53828, 0.23913043478261, 1.245652173913, 0.27777777777778
53829, 0.21739130434783, 1.2195652173913, 0.27777777777778
53830, 0.21739130434783, 1.245652173913, 0.30555555555556
53831, 0.23913043478261, 1.245652173913, 0.33333333333333
53832, 0.21739130434783, 1.2195652173913, 0.33333333333333
53833, 0.21739130434783, 1.245652173913, 0.36111111111111
53834, 0.23913043478261, 1.245652173913, 0.38888888888889
53835, 0.21739130434783, 1.2195652173913, 0.38888888888889
53836, 0.21739130434783, 1.245652173913, 0.41666666666667
53837, 0.23913043478261, 1.245652173913, 0.44444444444444
53838, 0.21739130434783, 1.2195652173913, 0.44444444444444
53839, 0.21739130434783, 1.245652173913, 0.47222222222222
53840, 0.17391304347826, 1.245652173913, 0.027777777777778
53841, 0.19565217391304, 1.245652173913, 0.055555555555556
53842, 0.17391304347826, 1.2195652173913, 0.055555555555556
53843, 0.17391304347826, 1.245652173913, 0.083333333333333
53844, 0.19565217391304, 1.245652173913, 0.11111111111111
53845, 0.17391304347826, 1.2195652173913, 0.11111111111111
53846, 0.17391304347826, 1.245652173913, 0.13888888888889
53847, 0.19565217391304, 1.245652173913, 0.16666666666667
53848, 0.17391304347826, 1.2195652173913, 0.16666666666667
53849, 0.17391304347826, 1.245652173913, 0.19444444444444
53850, 0.19565217391304, 1.245652173913, 0.22222222222222
53851, 0.17391304347826, 1.2195652173913, 0.22222222222222
53852, 0.17391304347826, 1.245652173913, 0.25
53853, 0.19565217391304, 1.245652173913, 0.27777777777778
53854, 0.17391304347826, 1.2195652173913, 0.27777777777778
53855, 0.17391304347826, 1.245652173913, 0.30555555555556
53856, 0.19565217391304, 1.245652173913, 0.33333333333333
53857, 0.17391304347826, 1.2195652173913, 0.33333333333333
53858, 0.17391304347826, 1.245652173913, 0.36111111111111
53859, 0.19565217391304, 1.245652173913, 0.38888888888889
53860, 0.17391304347826, 1.2195652173913, 0.38888888888889
53861, 0.17391304347826, 1.245652173913, 0.41666666666667
53862, 0.19565217391304, 1.245652173913, 0.44444444444444
53863, 0.17391304347826, 1.2195652173913, 0.44444444444444
53864, 0.17391304347826, 1.245652173913, 0.47222222222222
53865, 0.1304347826087, 1.245652173913, 0.027777777777778
53866, 0.15217391304348, 1.245652173913, 0.055555555555556
53867, 0.1304347826087, 1.2195652173913, 0.055555555555556
53868, 0.1304347826087, 1.245652173913, 0.083333333333333
53869, 0.15217391304348, 1.245652173913, 0.11111111111111
53870, 0.1304347826087, 1.2195652173913, 0.11111111111111
53871, 0.1304347826087, 1.245652173913, 0.13888888888889
53872, 0.15217391304348, 1.245652173913, 0.16666666666667
53873, 0.1304347826087, 1.2195652173913, 0.16666666666667
53874, 0.1304347826087, 1.245652173913, 0.19444444444444
53875, 0.15217391304348, 1.245652173913, 0.22222222222222
53876, 0.1304347826087, 1.2195652173913, 0.22222222222222
53877, 0.1304347826087, 1.245652173913, 0.25
53878, 0.15217391304348, 1.245652173913, 0.27777777777778
53879, 0.1304347826087, 1.2195652173913, 0.27777777777778
53880, 0.1304347826087, 1.245652173913, 0.30555555555556
53881, 0.15217391304348, 1.245652173913, 0.33333333333333
53882, 0.1304347826087, 1.2195652173913, 0.33333333333333
53883, 0.1304347826087, 1.245652173913, 0.36111111111111
53884, 0.15217391304348, 1.245652173913, 0.38888888888889
53885, 0.1304347826087, 1.2195652173913, 0.38888888888889
53886, 0.1304347826087, 1.245652173913, 0.41666666666667
53887, 0.15217391304348, 1.245652173913, 0.44444444444444
53888, 0.1304347826087, 1.2195652173913, 0.44444444444444
53889, 0.1304347826087, 1.245652173913, 0.47222222222222
53890, 0.08695652173913, 1.245652173913, 0.027777777777778
53891, 0.10869565217391, 1.245652173913, 0.055555555555556
53892, 0.08695652173913, 1.2195652173913, 0.055555555555556
53893, 0.08695652173913, 1.245652173913, 0.083333333333333
53894, 0.10869565217391, 1.245652173913, 0.11111111111111
53895, 0.08695652173913, 1.2195652173913, 0.11111111111111
53896, 0.08695652173913, 1.245652173913, 0.13888888888889
53897, 0.10869565217391, 1.245652173913, 0.16666666666667
53898, 0.08695652173913, 1.2195652173913, 0.16666666666667
53899, 0.08695652173913, 1.245652173913, 0.19444444444444
53900, 0.10869565217391, 1.245652173913, 0.22222222222222
53901, 0.08695652173913, 1.2195652173913, 0.22222222222222
53902, 0.08695652173913, 1.245652173913, 0.25
53903, 0.10869565217391, 1.245652173913, 0.27777777777778
53904, 0.08695652173913, 1.2195652173913, 0.27777777777778
53905, 0.08695652173913, 1.245652173913, 0.30555555555556
53906, 0.10869565217391, 1.245652173913, 0.33333333333333
53907, 0.08695652173913, 1.2195652173913, 0.33333333333333
53908, 0.08695652173913, 1.245652173913, 0.36111111111111
53909, 0.10869565217391, 1.245652173913, 0.38888888888889
53910, 0.08695652173913, 1.2195652173913, 0.38888888888889
53911, 0.08695652173913, 1.245652173913, 0.41666666666667
53912, 0.10869565217391, 1.245652173913, 0.44444444444444
53913, 0.08695652173913, 1.2195652173913, 0.44444444444444
53914, 0.08695652173913, 1.245652173913, 0.47222222222222
53915, 0.043478260869565, 1.245652173913, 0.027777777777778
53916, 0.065217391304348, 1.245652173913, 0.055555555555556
53917, 0.043478260869565, 1.2195652173913, 0.055555555555556
53918, 0.043478260869565, 1.245652173913, 0.083333333333333
53919, 0.065217391304348, 1.245652173913, 0.11111111111111
53920, 0.043478260869565, 1.2195652173913, 0.11111111111111
53921, 0.043478260869565, 1.245652173913, 0.13888888888889
53922, 0.065217391304348, 1.245652173913, 0.16666666666667
53923, 0.043478260869565, 1.2195652173913, 0.16666666666667
53924, 0.043478260869565, 1.245652173913, 0.19444444444444
53925, 0.065217391304348, 1.245652173913, 0.22222222222222
53926, 0.043478260869565, 1.2195652173913, 0.22222222222222
53927, 0.043478260869565, 1.245652173913, 0.25
53928, 0.065217391304348, 1.245652173913, 0.27777777777778
53929, 0.043478260869565, 1.2195652173913, 0.27777777777778
53930, 0.043478260869565, 1.245652173913, 0.30555555555556
53931, 0.065217391304348, 1.245652173913, 0.33333333333333
53932, 0.043478260869565, 1.2195652173913, 0.33333333333333
53933, 0.043478260869565, 1.245652173913, 0.36111111111111
53934, 0.065217391304348, 1.245652173913, 0.38888888888889
53935, 0.043478260869565, 1.2195652173913, 0.38888888888889
53936, 0.043478260869565, 1.245652173913, 0.41666666666667
53937, 0.065217391304348, 1.245652173913, 0.44444444444444
53938, 0.043478260869565, 1.2195652173913, 0.44444444444444
53939, 0.043478260869565, 1.245652173913, 0.47222222222222
53940, 0.021739130434783, 1.245652173913, 0.055555555555556
53941, 0.021739130434783, 1.245652173913, 0.11111111111111
53942, 0.021739130434783, 1.245652173913, 0.16666666666667
53943, 0.021739130434783, 1.245652173913, 0.22222222222222
53944, 0.021739130434783, 1.245652173913, 0.27777777777778
53945, 0.021739130434783, 1.245652173913, 0.33333333333333
53946, 0.021739130434783, 1.245652173913, 0.38888888888889
53947, 0.021739130434783, 1.245652173913, 0.44444444444444
53948, 0.95652173913043, 1.2978260869565, 0.027777777777778
53949, 0.97826086956522, 1.2978260869565, 0.055555555555556
53950, 0.95652173913043, 1.2717391304348, 0.055555555555556
53951, 0.95652173913043, 1.2978260869565, 0.083333333333333
53952, 0.97826086956522, 1.2978260869565, 0.11111111111111
53953, 0.95652173913044, 1.2717391304348, 0.11111111111111
53954, 0.95652173913044, 1.2978260869565, 0.13888888888889
53955, 0.97826086956522, 1.2978260869565, 0.16666666666667
53956, 0.95652173913044, 1.2717391304348, 0.16666666666667
53957, 0.95652173913044, 1.2978260869565, 0.19444444444444
53958, 0.97826086956522, 1.2978260869565, 0.22222222222222
53959, 0.95652173913044, 1.2717391304348, 0.22222222222222
53960, 0.95652173913044, 1.2978260869565, 0.25
53961, 0.97826086956522, 1.2978260869565, 0.27777777777778
53962, 0.95652173913044, 1.2717391304348, 0.27777777777778
53963, 0.95652173913044, 1.2978260869565, 0.30555555555556
53964, 0.97826086956522, 1.2978260869565, 0.33333333333333
53965, 0.95652173913044, 1.2717391304348, 0.33333333333333
53966, 0.95652173913044, 1.2978260869565, 0.36111111111111
53967, 0.97826086956522, 1.2978260869565, 0.38888888888889
53968, 0.95652173913044, 1.2717391304348, 0.38888888888889
53969, 0.95652173913044, 1.2978260869565, 0.41666666666667
53970, 0.97826086956522, 1.2978260869565, 0.44444444444444
53971, 0.95652173913044, 1.2717391304348, 0.44444444444444
53972, 0.95652173913043, 1.2978260869565, 0.47222222222222
53973, 0.91304347826087, 1.2978260869565, 0.027777777777778
53974, 0.93478260869565, 1.2978260869565, 0.055555555555556
53975, 0.91304347826087, 1.2717391304348, 0.055555555555556
53976, 0.91304347826087, 1.2978260869565, 0.083333333333333
53977, 0.93478260869565, 1.2978260869565, 0.11111111111111
53978, 0.91304347826087, 1.2717391304348, 0.11111111111111
53979, 0.91304347826087, 1.2978260869565, 0.13888888888889
53980, 0.93478260869565, 1.2978260869565, 0.16666666666667
53981, 0.91304347826087, 1.2717391304348, 0.16666666666667
53982, 0.91304347826087, 1.2978260869565, 0.19444444444444
53983, 0.93478260869565, 1.2978260869565, 0.22222222222222
53984, 0.91304347826087, 1.2717391304348, 0.22222222222222
53985, 0.91304347826087, 1.2978260869565, 0.25
53986, 0.93478260869565, 1.2978260869565, 0.27777777777778
53987, 0.91304347826087, 1.2717391304348, 0.27777777777778
53988, 0.91304347826087, 1.2978260869565, 0.30555555555556
53989, 0.93478260869565, 1.2978260869565, 0.33333333333333
53990, 0.91304347826087, 1.2717391304348, 0.33333333333333
53991, 0.91304347826087, 1.2978260869565, 0.36111111111111
53992, 0.93478260869565, 1.2978260869565, 0.38888888888889
53993, 0.91304347826087, 1.2717391304348, 0.38888888888889
53994, 0.91304347826087, 1.2978260869565, 0.41666666666667
53995, 0.93478260869565, 1.2978260869565, 0.44444444444444
53996, 0.91304347826087, 1.2717391304348, 0.44444444444444
53997, 0.91304347826087, 1.2978260869565, 0.47222222222222
53998, 0.8695652173913, 1.2978260869565, 0.027777777777778
53999, 0.89130434782609, 1.2978260869565, 0.055555555555556
54000, 0.8695652173913, 1.2717391304348, 0.055555555555556
54001, 0.8695652173913, 1.2978260869565, 0.083333333333333
54002, 0.89130434782609, 1.2978260869565, 0.11111111111111
54003, 0.8695652173913, 1.2717391304348, 0.11111111111111
54004, 0.8695652173913, 1.2978260869565, 0.13888888888889
54005, 0.89130434782609, 1.2978260869565, 0.16666666666667
54006, 0.8695652173913, 1.2717391304348, 0.16666666666667
54007, 0.8695652173913, 1.2978260869565, 0.19444444444444
54008, 0.89130434782609, 1.2978260869565, 0.22222222222222
54009, 0.8695652173913, 1.2717391304348, 0.22222222222222
54010, 0.8695652173913, 1.2978260869565, 0.25
54011, 0.89130434782609, 1.2978260869565, 0.27777777777778
54012, 0.8695652173913, 1.2717391304348, 0.27777777777778
54013, 0.8695652173913, 1.2978260869565, 0.30555555555556
54014, 0.89130434782609, 1.2978260869565, 0.33333333333333
54015, 0.8695652173913, 1.2717391304348, 0.33333333333333
54016, 0.8695652173913, 1.2978260869565, 0.36111111111111
54017, 0.89130434782609, 1.2978260869565, 0.38888888888889
54018, 0.8695652173913, 1.2717391304348, 0.38888888888889
54019, 0.8695652173913, 1.2978260869565, 0.41666666666667
54020, 0.89130434782609, 1.2978260869565, 0.44444444444444
54021, 0.8695652173913, 1.2717391304348, 0.44444444444444
54022, 0.8695652173913, 1.2978260869565, 0.47222222222222
54023, 0.82608695652174, 1.2978260869565, 0.027777777777778
54024, 0.84782608695652, 1.2978260869565, 0.055555555555556
54025, 0.82608695652174, 1.2717391304348, 0.055555555555556
54026, 0.82608695652174, 1.2978260869565, 0.083333333333333
54027, 0.84782608695652, 1.2978260869565, 0.11111111111111
54028, 0.82608695652174, 1.2717391304348, 0.11111111111111
54029, 0.82608695652174, 1.2978260869565, 0.13888888888889
54030, 0.84782608695652, 1.2978260869565, 0.16666666666667
54031, 0.82608695652174, 1.2717391304348, 0.16666666666667
54032, 0.82608695652174, 1.2978260869565, 0.19444444444444
54033, 0.84782608695652, 1.2978260869565, 0.22222222222222
54034, 0.82608695652174, 1.2717391304348, 0.22222222222222
54035, 0.82608695652174, 1.2978260869565, 0.25
54036, 0.84782608695652, 1.2978260869565, 0.27777777777778
54037, 0.82608695652174, 1.2717391304348, 0.27777777777778
54038, 0.82608695652174, 1.2978260869565, 0.30555555555556
54039, 0.84782608695652, 1.2978260869565, 0.33333333333333
54040, 0.82608695652174, 1.2717391304348, 0.33333333333333
54041, 0.82608695652174, 1.2978260869565, 0.36111111111111
54042, 0.84782608695652, 1.2978260869565, 0.38888888888889
54043, 0.82608695652174, 1.2717391304348, 0.38888888888889
54044, 0.82608695652174, 1.2978260869565, 0.41666666666667
54045, 0.84782608695652, 1.2978260869565, 0.44444444444444
54046, 0.82608695652174, 1.2717391304348, 0.44444444444444
54047, 0.82608695652174, 1.2978260869565, 0.47222222222222
54048, 0.78260869565217, 1.2978260869565, 0.027777777777778
54049, 0.80434782608696, 1.2978260869565, 0.055555555555556
54050, 0.78260869565217, 1.2717391304348, 0.055555555555556
54051, 0.78260869565217, 1.2978260869565, 0.083333333333333
54052, 0.80434782608696, 1.2978260869565, 0.11111111111111
54053, 0.78260869565217, 1.2717391304348, 0.11111111111111
54054, 0.78260869565217, 1.2978260869565, 0.13888888888889
54055, 0.80434782608696, 1.2978260869565, 0.16666666666667
54056, 0.78260869565217, 1.2717391304348, 0.16666666666667
54057, 0.78260869565217, 1.2978260869565, 0.19444444444444
54058, 0.80434782608696, 1.2978260869565, 0.22222222222222
54059, 0.78260869565217, 1.2717391304348, 0.22222222222222
54060, 0.78260869565217, 1.2978260869565, 0.25
54061, 0.80434782608696, 1.2978260869565, 0.27777777777778
54062, 0.78260869565217, 1.2717391304348, 0.27777777777778
54063, 0.78260869565217, 1.2978260869565, 0.30555555555556
54064, 0.80434782608696, 1.2978260869565, 0.33333333333333
54065, 0.78260869565217, 1.2717391304348, 0.33333333333333
54066, 0.78260869565217, 1.2978260869565, 0.36111111111111
54067, 0.80434782608696, 1.2978260869565, 0.38888888888889
54068, 0.78260869565217, 1.2717391304348, 0.38888888888889
54069, 0.78260869565217, 1.2978260869565, 0.41666666666667
54070, 0.80434782608696, 1.2978260869565, 0.44444444444444
54071, 0.78260869565217, 1.2717391304348, 0.44444444444444
54072, 0.78260869565217, 1.2978260869565, 0.47222222222222
54073, 0.73913043478261, 1.2978260869565, 0.027777777777778
54074, 0.76086956521739, 1.2978260869565, 0.055555555555556
54075, 0.73913043478261, 1.2717391304348, 0.055555555555556
54076, 0.73913043478261, 1.2978260869565, 0.083333333333333
54077, 0.76086956521739, 1.2978260869565, 0.11111111111111
54078, 0.73913043478261, 1.2717391304348, 0.11111111111111
54079, 0.73913043478261, 1.2978260869565, 0.13888888888889
54080, 0.76086956521739, 1.2978260869565, 0.16666666666667
54081, 0.73913043478261, 1.2717391304348, 0.16666666666667
54082, 0.73913043478261, 1.2978260869565, 0.19444444444444
54083, 0.76086956521739, 1.2978260869565, 0.22222222222222
54084, 0.73913043478261, 1.2717391304348, 0.22222222222222
54085, 0.73913043478261, 1.2978260869565, 0.25
54086, 0.76086956521739, 1.2978260869565, 0.27777777777778
54087, 0.73913043478261, 1.2717391304348, 0.27777777777778
54088, 0.73913043478261, 1.2978260869565, 0.30555555555556
54089, 0.76086956521739, 1.2978260869565, 0.33333333333333
54090, 0.73913043478261, 1.2717391304348, 0.33333333333333
54091, 0.73913043478261, 1.2978260869565, 0.36111111111111
54092, 0.76086956521739, 1.2978260869565, 0.38888888888889
54093, 0.73913043478261, 1.2717391304348, 0.38888888888889
54094, 0.73913043478261, 1.2978260869565, 0.41666666666667
54095, 0.76086956521739, 1.2978260869565, 0.44444444444444
54096, 0.73913043478261, 1.2717391304348, 0.44444444444444
54097, 0.73913043478261, 1.2978260869565, 0.47222222222222
54098, 0.69565217391304, 1.2978260869565, 0.027777777777778
54099, 0.71739130434783, 1.2978260869565, 0.055555555555556
54100, 0.69565217391304, 1.2717391304348, 0.055555555555556
54101, 0.69565217391304, 1.2978260869565, 0.083333333333333
54102, 0.71739130434783, 1.2978260869565, 0.11111111111111
54103, 0.69565217391304, 1.2717391304348, 0.11111111111111
54104, 0.69565217391304, 1.2978260869565, 0.13888888888889
54105, 0.71739130434783, 1.2978260869565, 0.16666666666667
54106, 0.69565217391304, 1.2717391304348, 0.16666666666667
54107, 0.69565217391304, 1.2978260869565, 0.19444444444444
54108, 0.71739130434783, 1.2978260869565, 0.22222222222222
54109, 0.69565217391304, 1.2717391304348, 0.22222222222222
54110, 0.69565217391304, 1.2978260869565, 0.25
54111, 0.71739130434783, 1.2978260869565, 0.27777777777778
54112, 0.69565217391304, 1.2717391304348, 0.27777777777778
54113, 0.69565217391304, 1.2978260869565, 0.30555555555556
54114, 0.71739130434783, 1.2978260869565, 0.33333333333333
54115, 0.69565217391304, 1.2717391304348, 0.33333333333333
54116, 0.69565217391304, 1.2978260869565, 0.36111111111111
54117, 0.71739130434783, 1.2978260869565, 0.38888888888889
54118, 0.69565217391304, 1.2717391304348, 0.38888888888889
54119, 0.69565217391304, 1.2978260869565, 0.41666666666667
54120, 0.71739130434783, 1.2978260869565, 0.44444444444444
54121, 0.69565217391304, 1.2717391304348, 0.44444444444444
54122, 0.69565217391304, 1.2978260869565, 0.47222222222222
54123, 0.65217391304348, 1.2978260869565, 0.027777777777778
54124, 0.67391304347826, 1.2978260869565, 0.055555555555556
54125, 0.65217391304348, 1.2717391304348, 0.055555555555556
54126, 0.65217391304348, 1.2978260869565, 0.083333333333333
54127, 0.67391304347826, 1.2978260869565, 0.11111111111111
54128, 0.65217391304348, 1.2717391304348, 0.11111111111111
54129, 0.65217391304348, 1.2978260869565, 0.13888888888889
54130, 0.67391304347826, 1.2978260869565, 0.16666666666667
54131, 0.65217391304348, 1.2717391304348, 0.16666666666667
54132, 0.65217391304348, 1.2978260869565, 0.19444444444444
54133, 0.67391304347826, 1.2978260869565, 0.22222222222222
54134, 0.65217391304348, 1.2717391304348, 0.22222222222222
54135, 0.65217391304348, 1.2978260869565, 0.25
54136, 0.67391304347826, 1.2978260869565, 0.27777777777778
54137, 0.65217391304348, 1.2717391304348, 0.27777777777778
54138, 0.65217391304348, 1.2978260869565, 0.30555555555556
54139, 0.67391304347826, 1.2978260869565, 0.33333333333333
54140, 0.65217391304348, 1.2717391304348, 0.33333333333333
54141, 0.65217391304348, 1.2978260869565, 0.36111111111111
54142, 0.67391304347826, 1.2978260869565, 0.38888888888889
54143, 0.65217391304348, 1.2717391304348, 0.38888888888889
54144, 0.65217391304348, 1.2978260869565, 0.41666666666667
54145, 0.67391304347826, 1.2978260869565, 0.44444444444444
54146, 0.65217391304348, 1.2717391304348, 0.44444444444444
54147, 0.65217391304348, 1.2978260869565, 0.47222222222222
54148, 0.60869565217391, 1.2978260869565, 0.027777777777778
54149, 0.6304347826087, 1.2978260869565, 0.055555555555556
54150, 0.60869565217391, 1.2717391304348, 0.055555555555556
54151, 0.60869565217391, 1.2978260869565, 0.083333333333333
54152, 0.6304347826087, 1.2978260869565, 0.11111111111111
54153, 0.60869565217391, 1.2717391304348, 0.11111111111111
54154, 0.60869565217391, 1.2978260869565, 0.13888888888889
54155, 0.6304347826087, 1.2978260869565, 0.16666666666667
54156, 0.60869565217391, 1.2717391304348, 0.16666666666667
54157, 0.60869565217391, 1.2978260869565, 0.19444444444444
54158, 0.6304347826087, 1.2978260869565, 0.22222222222222
54159, 0.60869565217391, 1.2717391304348, 0.22222222222222
54160, 0.60869565217391, 1.2978260869565, 0.25
54161, 0.6304347826087, 1.2978260869565, 0.27777777777778
54162, 0.60869565217391, 1.2717391304348, 0.27777777777778
54163, 0.60869565217391, 1.2978260869565, 0.30555555555556
54164, 0.6304347826087, 1.2978260869565, 0.33333333333333
54165, 0.60869565217391, 1.2717391304348, 0.33333333333333
54166, 0.60869565217391, 1.2978260869565, 0.36111111111111
54167, 0.6304347826087, 1.2978260869565, 0.38888888888889
54168, 0.60869565217391, 1.2717391304348, 0.38888888888889
54169, 0.60869565217391, 1.2978260869565, 0.41666666666667
54170, 0.6304347826087, 1.2978260869565, 0.44444444444444
54171, 0.60869565217391, 1.2717391304348, 0.44444444444444
54172, 0.60869565217391, 1.2978260869565, 0.47222222222222
54173, 0.56521739130435, 1.2978260869565, 0.027777777777778
54174, 0.58695652173913, 1.2978260869565, 0.055555555555556
54175, 0.56521739130435, 1.2717391304348, 0.055555555555556
54176, 0.56521739130435, 1.2978260869565, 0.083333333333333
54177, 0.58695652173913, 1.2978260869565, 0.11111111111111
54178, 0.56521739130435, 1.2717391304348, 0.11111111111111
54179, 0.56521739130435, 1.2978260869565, 0.13888888888889
54180, 0.58695652173913, 1.2978260869565, 0.16666666666667
54181, 0.56521739130435, 1.2717391304348, 0.16666666666667
54182, 0.56521739130435, 1.2978260869565, 0.19444444444444
54183, 0.58695652173913, 1.2978260869565, 0.22222222222222
54184, 0.56521739130435, 1.2717391304348, 0.22222222222222
54185, 0.56521739130435, 1.2978260869565, 0.25
54186, 0.58695652173913, 1.2978260869565, 0.27777777777778
54187, 0.56521739130435, 1.2717391304348, 0.27777777777778
54188, 0.56521739130435, 1.2978260869565, 0.30555555555556
54189, 0.58695652173913, 1.2978260869565, 0.33333333333333
54190, 0.56521739130435, 1.2717391304348, 0.33333333333333
54191, 0.56521739130435, 1.2978260869565, 0.36111111111111
54192, 0.58695652173913, 1.2978260869565, 0.38888888888889
54193, 0.56521739130435, 1.2717391304348, 0.38888888888889
54194, 0.56521739130435, 1.2978260869565, 0.41666666666667
54195, 0.58695652173913, 1.2978260869565, 0.44444444444444
54196, 0.56521739130435, 1.2717391304348, 0.44444444444444
54197, 0.56521739130435, 1.2978260869565, 0.47222222222222
54198, 0.52173913043478, 1.2978260869565, 0.027777777777778
54199, 0.54347826086957, 1.2978260869565, 0.055555555555556
54200, 0.52173913043478, 1.2717391304348, 0.055555555555556
54201, 0.52173913043478, 1.2978260869565, 0.083333333333333
54202, 0.54347826086957, 1.2978260869565, 0.11111111111111
54203, 0.52173913043478, 1.2717391304348, 0.11111111111111
54204, 0.52173913043478, 1.2978260869565, 0.13888888888889
54205, 0.54347826086956, 1.2978260869565, 0.16666666666667
54206, 0.52173913043478, 1.2717391304348, 0.16666666666667
54207, 0.52173913043478, 1.2978260869565, 0.19444444444444
54208, 0.54347826086956, 1.2978260869565, 0.22222222222222
54209, 0.52173913043478, 1.2717391304348, 0.22222222222222
54210, 0.52173913043478, 1.2978260869565, 0.25
54211, 0.54347826086956, 1.2978260869565, 0.27777777777778
54212, 0.52173913043478, 1.2717391304348, 0.27777777777778
54213, 0.52173913043478, 1.2978260869565, 0.30555555555556
54214, 0.54347826086956, 1.2978260869565, 0.33333333333333
54215, 0.52173913043478, 1.2717391304348, 0.33333333333333
54216, 0.52173913043478, 1.2978260869565, 0.36111111111111
54217, 0.54347826086956, 1.2978260869565, 0.38888888888889
54218, 0.52173913043478, 1.2717391304348, 0.38888888888889
54219, 0.52173913043478, 1.2978260869565, 0.41666666666667
54220, 0.54347826086956, 1.2978260869565, 0.44444444444444
54221, 0.52173913043478, 1.2717391304348, 0.44444444444444
54222, 0.52173913043478, 1.2978260869565, 0.47222222222222
54223, 0.47826086956522, 1.2978260869565, 0.027777777777778
54224, 0.5, 1.2978260869565, 0.055555555555556
54225, 0.47826086956522, 1.2717391304348, 0.055555555555556
54226, 0.47826086956522, 1.2978260869565, 0.083333333333333
54227, 0.5, 1.2978260869565, 0.11111111111111
54228, 0.47826086956522, 1.2717391304348, 0.11111111111111
54229, 0.47826086956522, 1.2978260869565, 0.13888888888889
54230, 0.5, 1.2978260869565, 0.16666666666667
54231, 0.47826086956522, 1.2717391304348, 0.16666666666667
54232, 0.47826086956522, 1.2978260869565, 0.19444444444444
54233, 0.5, 1.2978260869565, 0.22222222222222
54234, 0.47826086956522, 1.2717391304348, 0.22222222222222
54235, 0.47826086956522, 1.2978260869565, 0.25
54236, 0.5, 1.2978260869565, 0.27777777777778
54237, 0.47826086956522, 1.2717391304348, 0.27777777777778
54238, 0.47826086956522, 1.2978260869565, 0.30555555555556
54239, 0.5, 1.2978260869565, 0.33333333333333
54240, 0.47826086956522, 1.2717391304348, 0.33333333333333
54241, 0.47826086956522, 1.2978260869565, 0.36111111111111
54242, 0.5, 1.2978260869565, 0.38888888888889
54243, 0.47826086956522, 1.2717391304348, 0.38888888888889
54244, 0.47826086956522, 1.2978260869565, 0.41666666666667
54245, 0.5, 1.2978260869565, 0.44444444444444
54246, 0.47826086956522, 1.2717391304348, 0.44444444444444
54247, 0.47826086956522, 1.2978260869565, 0.47222222222222
54248, 0.43478260869565, 1.2978260869565, 0.027777777777778
54249, 0.45652173913043, 1.2978260869565, 0.055555555555556
54250, 0.43478260869565, 1.2717391304348, 0.055555555555556
54251, 0.43478260869565, 1.2978260869565, 0.083333333333333
54252, 0.45652173913043, 1.2978260869565, 0.11111111111111
54253, 0.43478260869565, 1.2717391304348, 0.11111111111111
54254, 0.43478260869565, 1.2978260869565, 0.13888888888889
54255, 0.45652173913043, 1.2978260869565, 0.16666666666667
54256, 0.43478260869565, 1.2717391304348, 0.16666666666667
54257, 0.43478260869565, 1.2978260869565, 0.19444444444444
54258, 0.45652173913043, 1.2978260869565, 0.22222222222222
54259, 0.43478260869565, 1.2717391304348, 0.22222222222222
54260, 0.43478260869565, 1.2978260869565, 0.25
54261, 0.45652173913043, 1.2978260869565, 0.27777777777778
54262, 0.43478260869565, 1.2717391304348, 0.27777777777778
54263, 0.43478260869565, 1.2978260869565, 0.30555555555556
54264, 0.45652173913043, 1.2978260869565, 0.33333333333333
54265, 0.43478260869565, 1.2717391304348, 0.33333333333333
54266, 0.43478260869565, 1.2978260869565, 0.36111111111111
54267, 0.45652173913044, 1.2978260869565, 0.38888888888889
54268, 0.43478260869565, 1.2717391304348, 0.38888888888889
54269, 0.43478260869565, 1.2978260869565, 0.41666666666667
54270, 0.45652173913043, 1.2978260869565, 0.44444444444444
54271, 0.43478260869565, 1.2717391304348, 0.44444444444444
54272, 0.43478260869565, 1.2978260869565, 0.47222222222222
54273, 0.39130434782609, 1.2978260869565, 0.027777777777778
54274, 0.41304347826087, 1.2978260869565, 0.055555555555556
54275, 0.39130434782609, 1.2717391304348, 0.055555555555556
54276, 0.39130434782609, 1.2978260869565, 0.083333333333333
54277, 0.41304347826087, 1.2978260869565, 0.11111111111111
54278, 0.39130434782609, 1.2717391304348, 0.11111111111111
54279, 0.39130434782609, 1.2978260869565, 0.13888888888889
54280, 0.41304347826087, 1.2978260869565, 0.16666666666667
54281, 0.39130434782609, 1.2717391304348, 0.16666666666667
54282, 0.39130434782609, 1.2978260869565, 0.19444444444444
54283, 0.41304347826087, 1.2978260869565, 0.22222222222222
54284, 0.39130434782609, 1.2717391304348, 0.22222222222222
54285, 0.39130434782609, 1.2978260869565, 0.25
54286, 0.41304347826087, 1.2978260869565, 0.27777777777778
54287, 0.39130434782609, 1.2717391304348, 0.27777777777778
54288, 0.39130434782609, 1.2978260869565, 0.30555555555556
54289, 0.41304347826087, 1.2978260869565, 0.33333333333333
54290, 0.39130434782609, 1.2717391304348, 0.33333333333333
54291, 0.39130434782609, 1.2978260869565, 0.36111111111111
54292, 0.41304347826087, 1.2978260869565, 0.38888888888889
54293, 0.39130434782609, 1.2717391304348, 0.38888888888889
54294, 0.39130434782609, 1.2978260869565, 0.41666666666667
54295, 0.41304347826087, 1.2978260869565, 0.44444444444444
54296, 0.39130434782609, 1.2717391304348, 0.44444444444444
54297, 0.39130434782609, 1.2978260869565, 0.47222222222222
54298, 0.34782608695652, 1.2978260869565, 0.027777777777778
54299, 0.3695652173913, 1.2978260869565, 0.055555555555556
54300, 0.34782608695652, 1.2717391304348, 0.055555555555556
54301, 0.34782608695652, 1.2978260869565, 0.083333333333333
54302, 0.3695652173913, 1.2978260869565, 0.11111111111111
54303, 0.34782608695652, 1.2717391304348, 0.11111111111111
54304, 0.34782608695652, 1.2978260869565, 0.13888888888889
54305, 0.3695652173913, 1.2978260869565, 0.16666666666667
54306, 0.34782608695652, 1.2717391304348, 0.16666666666667
54307, 0.34782608695652, 1.2978260869565, 0.19444444444444
54308, 0.3695652173913, 1.2978260869565, 0.22222222222222
54309, 0.34782608695652, 1.2717391304348, 0.22222222222222
54310, 0.34782608695652, 1.2978260869565, 0.25
54311, 0.3695652173913, 1.2978260869565, 0.27777777777778
54312, 0.34782608695652, 1.2717391304348, 0.27777777777778
54313, 0.34782608695652, 1.2978260869565, 0.30555555555556
54314, 0.3695652173913, 1.2978260869565, 0.33333333333333
54315, 0.34782608695652, 1.2717391304348, 0.33333333333333
54316, 0.34782608695652, 1.2978260869565, 0.36111111111111
54317, 0.3695652173913, 1.2978260869565, 0.38888888888889
54318, 0.34782608695652, 1.2717391304348, 0.38888888888889
54319, 0.34782608695652, 1.2978260869565, 0.41666666666667
54320, 0.3695652173913, 1.2978260869565, 0.44444444444444
54321, 0.34782608695652, 1.2717391304348, 0.44444444444444
54322, 0.34782608695652, 1.2978260869565, 0.47222222222222
54323, 0.30434782608696, 1.2978260869565, 0.027777777777778
54324, 0.32608695652174, 1.2978260869565, 0.055555555555556
54325, 0.30434782608696, 1.2717391304348, 0.055555555555556
54326, 0.30434782608696, 1.2978260869565, 0.083333333333333
54327, 0.32608695652174, 1.2978260869565, 0.11111111111111
54328, 0.30434782608696, 1.2717391304348, 0.11111111111111
54329, 0.30434782608696, 1.2978260869565, 0.13888888888889
54330, 0.32608695652174, 1.2978260869565, 0.16666666666667
54331, 0.30434782608696, 1.2717391304348, 0.16666666666667
54332, 0.30434782608696, 1.2978260869565, 0.19444444444444
54333, 0.32608695652174, 1.2978260869565, 0.22222222222222
54334, 0.30434782608696, 1.2717391304348, 0.22222222222222
54335, 0.30434782608696, 1.2978260869565, 0.25
54336, 0.32608695652174, 1.2978260869565, 0.27777777777778
54337, 0.30434782608696, 1.2717391304348, 0.27777777777778
54338, 0.30434782608696, 1.2978260869565, 0.30555555555556
54339, 0.32608695652174, 1.2978260869565, 0.33333333333333
54340, 0.30434782608696, 1.2717391304348, 0.33333333333333
54341, 0.30434782608696, 1.2978260869565, 0.36111111111111
54342, 0.32608695652174, 1.2978260869565, 0.38888888888889
54343, 0.30434782608696, 1.2717391304348, 0.38888888888889
54344, 0.30434782608696, 1.2978260869565, 0.41666666666667
54345, 0.32608695652174, 1.2978260869565, 0.44444444444444
54346, 0.30434782608696, 1.2717391304348, 0.44444444444444
54347, 0.30434782608696, 1.2978260869565, 0.47222222222222
54348, 0.26086956521739, 1.2978260869565, 0.027777777777778
54349, 0.28260869565217, 1.2978260869565, 0.055555555555556
54350, 0.26086956521739, 1.2717391304348, 0.055555555555556
54351, 0.26086956521739, 1.2978260869565, 0.083333333333333
54352, 0.28260869565217, 1.2978260869565, 0.11111111111111
54353, 0.26086956521739, 1.2717391304348, 0.11111111111111
54354, 0.26086956521739, 1.2978260869565, 0.13888888888889
54355, 0.28260869565217, 1.2978260869565, 0.16666666666667
54356, 0.26086956521739, 1.2717391304348, 0.16666666666667
54357, 0.26086956521739, 1.2978260869565, 0.19444444444444
54358, 0.28260869565217, 1.2978260869565, 0.22222222222222
54359, 0.26086956521739, 1.2717391304348, 0.22222222222222
54360, 0.26086956521739, 1.2978260869565, 0.25
54361, 0.28260869565217, 1.2978260869565, 0.27777777777778
54362, 0.26086956521739, 1.2717391304348, 0.27777777777778
54363, 0.26086956521739, 1.2978260869565, 0.30555555555556
54364, 0.28260869565217, 1.2978260869565, 0.33333333333333
54365, 0.26086956521739, 1.2717391304348, 0.33333333333333
54366, 0.26086956521739, 1.2978260869565, 0.36111111111111
54367, 0.28260869565217, 1.2978260869565, 0.38888888888889
54368, 0.26086956521739, 1.2717391304348, 0.38888888888889
54369, 0.26086956521739, 1.2978260869565, 0.41666666666667
54370, 0.28260869565217, 1.2978260869565, 0.44444444444444
54371, 0.26086956521739, 1.2717391304348, 0.44444444444444
54372, 0.26086956521739, 1.2978260869565, 0.47222222222222
54373, 0.21739130434783, 1.2978260869565, 0.027777777777778
54374, 0.23913043478261, 1.2978260869565, 0.055555555555556
54375, 0.21739130434783, 1.2717391304348, 0.055555555555556
54376, 0.21739130434783, 1.2978260869565, 0.083333333333333
54377, 0.23913043478261, 1.2978260869565, 0.11111111111111
54378, 0.21739130434783, 1.2717391304348, 0.11111111111111
54379, 0.21739130434783, 1.2978260869565, 0.13888888888889
54380, 0.23913043478261, 1.2978260869565, 0.16666666666667
54381, 0.21739130434783, 1.2717391304348, 0.16666666666667
54382, 0.21739130434783, 1.2978260869565, 0.19444444444444
54383, 0.23913043478261, 1.2978260869565, 0.22222222222222
54384, 0.21739130434783, 1.2717391304348, 0.22222222222222
54385, 0.21739130434783, 1.2978260869565, 0.25
54386, 0.23913043478261, 1.2978260869565, 0.27777777777778
54387, 0.21739130434783, 1.2717391304348, 0.27777777777778
54388, 0.21739130434783, 1.2978260869565, 0.30555555555556
54389, 0.23913043478261, 1.2978260869565, 0.33333333333333
54390, 0.21739130434783, 1.2717391304348, 0.33333333333333
54391, 0.21739130434783, 1.2978260869565, 0.36111111111111
54392, 0.23913043478261, 1.2978260869565, 0.38888888888889
54393, 0.21739130434783, 1.2717391304348, 0.38888888888889
54394, 0.21739130434783, 1.2978260869565, 0.41666666666667
54395, 0.23913043478261, 1.2978260869565, 0.44444444444444
54396, 0.21739130434783, 1.2717391304348, 0.44444444444444
54397, 0.21739130434783, 1.2978260869565, 0.47222222222222
54398, 0.17391304347826, 1.2978260869565, 0.027777777777778
54399, 0.19565217391304, 1.2978260869565, 0.055555555555556
54400, 0.17391304347826, 1.2717391304348, 0.055555555555556
54401, 0.17391304347826, 1.2978260869565, 0.083333333333333
54402, 0.19565217391304, 1.2978260869565, 0.11111111111111
54403, 0.17391304347826, 1.2717391304348, 0.11111111111111
54404, 0.17391304347826, 1.2978260869565, 0.13888888888889
54405, 0.19565217391304, 1.2978260869565, 0.16666666666667
54406, 0.17391304347826, 1.2717391304348, 0.16666666666667
54407, 0.17391304347826, 1.2978260869565, 0.19444444444444
54408, 0.19565217391304, 1.2978260869565, 0.22222222222222
54409, 0.17391304347826, 1.2717391304348, 0.22222222222222
54410, 0.17391304347826, 1.2978260869565, 0.25
54411, 0.19565217391304, 1.2978260869565, 0.27777777777778
54412, 0.17391304347826, 1.2717391304348, 0.27777777777778
54413, 0.17391304347826, 1.2978260869565, 0.30555555555556
54414, 0.19565217391304, 1.2978260869565, 0.33333333333333
54415, 0.17391304347826, 1.2717391304348, 0.33333333333333
54416, 0.17391304347826, 1.2978260869565, 0.36111111111111
54417, 0.19565217391304, 1.2978260869565, 0.38888888888889
54418, 0.17391304347826, 1.2717391304348, 0.38888888888889
54419, 0.17391304347826, 1.2978260869565, 0.41666666666667
54420, 0.19565217391304, 1.2978260869565, 0.44444444444444
54421, 0.17391304347826, 1.2717391304348, 0.44444444444444
54422, 0.17391304347826, 1.2978260869565, 0.47222222222222
54423, 0.1304347826087, 1.2978260869565, 0.027777777777778
54424, 0.15217391304348, 1.2978260869565, 0.055555555555556
54425, 0.1304347826087, 1.2717391304348, 0.055555555555556
54426, 0.1304347826087, 1.2978260869565, 0.083333333333333
54427, 0.15217391304348, 1.2978260869565, 0.11111111111111
54428, 0.1304347826087, 1.2717391304348, 0.11111111111111
54429, 0.1304347826087, 1.2978260869565, 0.13888888888889
54430, 0.15217391304348, 1.2978260869565, 0.16666666666667
54431, 0.1304347826087, 1.2717391304348, 0.16666666666667
54432, 0.1304347826087, 1.2978260869565, 0.19444444444444
54433, 0.15217391304348, 1.2978260869565, 0.22222222222222
54434, 0.1304347826087, 1.2717391304348, 0.22222222222222
54435, 0.1304347826087, 1.2978260869565, 0.25
54436, 0.15217391304348, 1.2978260869565, 0.27777777777778
54437, 0.1304347826087, 1.2717391304348, 0.27777777777778
54438, 0.1304347826087, 1.2978260869565, 0.30555555555556
54439, 0.15217391304348, 1.2978260869565, 0.33333333333333
54440, 0.1304347826087, 1.2717391304348, 0.33333333333333
54441, 0.1304347826087, 1.2978260869565, 0.36111111111111
54442, 0.15217391304348, 1.2978260869565, 0.38888888888889
54443, 0.1304347826087, 1.2717391304348, 0.38888888888889
54444, 0.1304347826087, 1.2978260869565, 0.41666666666667
54445, 0.15217391304348, 1.2978260869565, 0.44444444444444
54446, 0.1304347826087, 1.2717391304348, 0.44444444444444
54447, 0.1304347826087, 1.2978260869565, 0.47222222222222
54448, 0.08695652173913, 1.2978260869565, 0.027777777777778
54449, 0.10869565217391, 1.2978260869565, 0.055555555555556
54450, 0.08695652173913, 1.2717391304348, 0.055555555555556
54451, 0.08695652173913, 1.2978260869565, 0.083333333333333
54452, 0.10869565217391, 1.2978260869565, 0.11111111111111
54453, 0.08695652173913, 1.2717391304348, 0.11111111111111
54454, 0.08695652173913, 1.2978260869565, 0.13888888888889
54455, 0.10869565217391, 1.2978260869565, 0.16666666666667
54456, 0.08695652173913, 1.2717391304348, 0.16666666666667
54457, 0.08695652173913, 1.2978260869565, 0.19444444444444
54458, 0.10869565217391, 1.2978260869565, 0.22222222222222
54459, 0.08695652173913, 1.2717391304348, 0.22222222222222
54460, 0.08695652173913, 1.2978260869565, 0.25
54461, 0.10869565217391, 1.2978260869565, 0.27777777777778
54462, 0.08695652173913, 1.2717391304348, 0.27777777777778
54463, 0.08695652173913, 1.2978260869565, 0.30555555555556
54464, 0.10869565217391, 1.2978260869565, 0.33333333333333
54465, 0.08695652173913, 1.2717391304348, 0.33333333333333
54466, 0.08695652173913, 1.2978260869565, 0.36111111111111
54467, 0.10869565217391, 1.2978260869565, 0.38888888888889
54468, 0.08695652173913, 1.2717391304348, 0.38888888888889
54469, 0.08695652173913, 1.2978260869565, 0.41666666666667
54470, 0.10869565217391, 1.2978260869565, 0.44444444444444
54471, 0.08695652173913, 1.2717391304348, 0.44444444444444
54472, 0.08695652173913, 1.2978260869565, 0.47222222222222
54473, 0.043478260869565, 1.2978260869565, 0.027777777777778
54474, 0.065217391304348, 1.2978260869565, 0.055555555555556
54475, 0.043478260869565, 1.2717391304348, 0.055555555555556
54476, 0.043478260869565, 1.2978260869565, 0.083333333333333
54477, 0.065217391304348, 1.2978260869565, 0.11111111111111
54478, 0.043478260869565, 1.2717391304348, 0.11111111111111
54479, 0.043478260869565, 1.2978260869565, 0.13888888888889
54480, 0.065217391304348, 1.2978260869565, 0.16666666666667
54481, 0.043478260869565, 1.2717391304348, 0.16666666666667
54482, 0.043478260869565, 1.2978260869565, 0.19444444444444
54483, 0.065217391304348, 1.2978260869565, 0.22222222222222
54484, 0.043478260869565, 1.2717391304348, 0.22222222222222
54485, 0.043478260869565, 1.2978260869565, 0.25
54486, 0.065217391304348, 1.2978260869565, 0.27777777777778
54487, 0.043478260869565, 1.2717391304348, 0.27777777777778
54488, 0.043478260869565, 1.2978260869565, 0.30555555555556
54489, 0.065217391304348, 1.2978260869565, 0.33333333333333
54490, 0.043478260869565, 1.2717391304348, 0.33333333333333
54491, 0.043478260869565, 1.2978260869565, 0.36111111111111
54492, 0.065217391304348, 1.2978260869565, 0.38888888888889
54493, 0.043478260869565, 1.2717391304348, 0.38888888888889
54494, 0.043478260869565, 1.2978260869565, 0.41666666666667
54495, 0.065217391304348, 1.2978260869565, 0.44444444444444
54496, 0.043478260869565, 1.2717391304348, 0.44444444444444
54497, 0.043478260869565, 1.2978260869565, 0.47222222222222
54498, 0.021739130434783, 1.2978260869565, 0.055555555555556
54499, 0.021739130434783, 1.2978260869565, 0.11111111111111
54500, 0.021739130434783, 1.2978260869565, 0.16666666666667
54501, 0.021739130434783, 1.2978260869565, 0.22222222222222
54502, 0.021739130434783, 1.2978260869565, 0.27777777777778
54503, 0.021739130434783, 1.2978260869565, 0.33333333333333
54504, 0.021739130434783, 1.2978260869565, 0.38888888888889
54505, 0.021739130434783, 1.2978260869565, 0.44444444444444
54506, 0.95652173913043, 1.3239130434783, 0.055555555555556
54507, 0.95652173913043, 1.3239130434783, 0.11111111111111
54508, 0.95652173913043, 1.3239130434783, 0.16666666666667
54509, 0.95652173913043, 1.3239130434783, 0.22222222222222
54510, 0.95652173913043, 1.3239130434783, 0.27777777777778
54511, 0.95652173913043, 1.3239130434783, 0.33333333333333
54512, 0.95652173913043, 1.3239130434783, 0.38888888888889
54513, 0.95652173913043, 1.3239130434783, 0.44444444444444
54514, 0.91304347826087, 1.3239130434783, 0.055555555555556
54515, 0.91304347826087, 1.3239130434783, 0.11111111111111
54516, 0.91304347826087, 1.3239130434783, 0.16666666666667
54517, 0.91304347826087, 1.3239130434783, 0.22222222222222
54518, 0.91304347826087, 1.3239130434783, 0.27777777777778
54519, 0.91304347826087, 1.3239130434783, 0.33333333333333
54520, 0.91304347826087, 1.3239130434783, 0.38888888888889
54521, 0.91304347826087, 1.3239130434783, 0.44444444444444
54522, 0.8695652173913, 1.3239130434783, 0.055555555555556
54523, 0.8695652173913, 1.3239130434783, 0.11111111111111
54524, 0.8695652173913, 1.3239130434783, 0.16666666666667
54525, 0.8695652173913, 1.3239130434783, 0.22222222222222
54526, 0.8695652173913, 1.3239130434783, 0.27777777777778
54527, 0.8695652173913, 1.3239130434783, 0.33333333333333
54528, 0.8695652173913, 1.3239130434783, 0.38888888888889
54529, 0.8695652173913, 1.3239130434783, 0.44444444444444
54530, 0.82608695652174, 1.3239130434783, 0.055555555555556
54531, 0.82608695652174, 1.3239130434783, 0.11111111111111
54532, 0.82608695652174, 1.3239130434783, 0.16666666666667
54533, 0.82608695652174, 1.3239130434783, 0.22222222222222
54534, 0.82608695652174, 1.3239130434783, 0.27777777777778
54535, 0.82608695652174, 1.3239130434783, 0.33333333333333
54536, 0.82608695652174, 1.3239130434783, 0.38888888888889
54537, 0.82608695652174, 1.3239130434783, 0.44444444444444
54538, 0.78260869565217, 1.3239130434783, 0.055555555555556
54539, 0.78260869565217, 1.3239130434783, 0.11111111111111
54540, 0.78260869565217, 1.3239130434783, 0.16666666666667
54541, 0.78260869565217, 1.3239130434783, 0.22222222222222
54542, 0.78260869565217, 1.3239130434783, 0.27777777777778
54543, 0.78260869565217, 1.3239130434783, 0.33333333333333
54544, 0.78260869565217, 1.3239130434783, 0.38888888888889
54545, 0.78260869565217, 1.3239130434783, 0.44444444444444
54546, 0.73913043478261, 1.3239130434783, 0.055555555555556
54547, 0.73913043478261, 1.3239130434783, 0.11111111111111
54548, 0.73913043478261, 1.3239130434783, 0.16666666666667
54549, 0.73913043478261, 1.3239130434783, 0.22222222222222
54550, 0.73913043478261, 1.3239130434783, 0.27777777777778
54551, 0.73913043478261, 1.3239130434783, 0.33333333333333
54552, 0.73913043478261, 1.3239130434783, 0.38888888888889
54553, 0.73913043478261, 1.3239130434783, 0.44444444444444
54554, 0.69565217391304, 1.3239130434783, 0.055555555555556
54555, 0.69565217391304, 1.3239130434783, 0.11111111111111
54556, 0.69565217391304, 1.3239130434783, 0.16666666666667
54557, 0.69565217391304, 1.3239130434783, 0.22222222222222
54558, 0.69565217391304, 1.3239130434783, 0.27777777777778
54559, 0.69565217391304, 1.3239130434783, 0.33333333333333
54560, 0.69565217391304, 1.3239130434783, 0.38888888888889
54561, 0.69565217391304, 1.3239130434783, 0.44444444444444
54562, 0.65217391304348, 1.3239130434783, 0.055555555555556
54563, 0.65217391304348, 1.3239130434783, 0.11111111111111
54564, 0.65217391304348, 1.3239130434783, 0.16666666666667
54565, 0.65217391304348, 1.3239130434783, 0.22222222222222
54566, 0.65217391304348, 1.3239130434783, 0.27777777777778
54567, 0.65217391304348, 1.3239130434783, 0.33333333333333
54568, 0.65217391304348, 1.3239130434783, 0.38888888888889
54569, 0.65217391304348, 1.3239130434783, 0.44444444444444
54570, 0.60869565217391, 1.3239130434783, 0.055555555555556
54571, 0.60869565217391, 1.3239130434783, 0.11111111111111
54572, 0.60869565217391, 1.3239130434783, 0.16666666666667
54573, 0.60869565217391, 1.3239130434783, 0.22222222222222
54574, 0.60869565217391, 1.3239130434783, 0.27777777777778
54575, 0.60869565217391, 1.3239130434783, 0.33333333333333
54576, 0.60869565217391, 1.3239130434783, 0.38888888888889
54577, 0.60869565217391, 1.3239130434783, 0.44444444444444
54578, 0.56521739130435, 1.3239130434783, 0.055555555555556
54579, 0.56521739130435, 1.3239130434783, 0.11111111111111
54580, 0.56521739130435, 1.3239130434783, 0.16666666666667
54581, 0.56521739130435, 1.3239130434783, 0.22222222222222
54582, 0.56521739130435, 1.3239130434783, 0.27777777777778
54583, 0.56521739130435, 1.3239130434783, 0.33333333333333
54584, 0.56521739130435, 1.3239130434783, 0.38888888888889
54585, 0.56521739130435, 1.3239130434783, 0.44444444444444
54586, 0.52173913043478, 1.3239130434783, 0.055555555555556
54587, 0.52173913043478, 1.3239130434783, 0.11111111111111
54588, 0.52173913043478, 1.3239130434783, 0.16666666666667
54589, 0.52173913043478, 1.3239130434783, 0.22222222222222
54590, 0.52173913043478, 1.3239130434783, 0.27777777777778
54591, 0.52173913043478, 1.3239130434783, 0.33333333333333
54592, 0.52173913043478, 1.3239130434783, 0.38888888888889
54593, 0.52173913043478, 1.3239130434783, 0.44444444444444
54594, 0.47826086956522, 1.3239130434783, 0.055555555555556
54595, 0.47826086956522, 1.3239130434783, 0.11111111111111
54596, 0.47826086956522, 1.3239130434783, 0.16666666666667
54597, 0.47826086956522, 1.3239130434783, 0.22222222222222
54598, 0.47826086956522, 1.3239130434783, 0.27777777777778
54599, 0.47826086956522, 1.3239130434783, 0.33333333333333
54600, 0.47826086956522, 1.3239130434783, 0.38888888888889
54601, 0.47826086956522, 1.3239130434783, 0.44444444444444
54602, 0.43478260869565, 1.3239130434783, 0.055555555555556
54603, 0.43478260869565, 1.3239130434783, 0.11111111111111
54604, 0.43478260869565, 1.3239130434783, 0.16666666666667
54605, 0.43478260869565, 1.3239130434783, 0.22222222222222
54606, 0.43478260869565, 1.3239130434783, 0.27777777777778
54607, 0.43478260869565, 1.3239130434783, 0.33333333333333
54608, 0.43478260869565, 1.3239130434783, 0.38888888888889
