*Heading
 C:\Archive\Programming\MATLAB\TOTEM_M\TECTO\TEC_2401_2D_test.inp
*NODE
1, 1, 1.35, 0
2, 1, 1.55, 0
3, 1.2, 1.25, 0
4, 2.2, 1.25, 0
5, 0, 0, 0
6, 1, 0, 0
7, 1, 1.2, 0
8, 0, 1.2, 0
9, 1.2, 1.35, 0
10, 1.2, 1.2, 0
11, 1.2, 0, 0
12, 2.2, 1.2, 0
13, 2.2, 0, 0
14, 1.2, -0.15, 0
15, 2.2, -0.15, 0
16, 0, -0.15, 0
17, -0.1, -0.15, 0
18, 0, -0.35, 0
19, 1.2, -0.35, 0
20, 2.2, -0.35, 0
21, 2.3, -0.15, 0
22, 2.3, -0.35, 0
23, 1.2, 1.55, 0
24, -0.1, -0.35, 0
25, 1, 1.25, 0
26, 0, 1.25, 0
27, 1.2, -0.05, 0
28, 2.2, -0.05, 0
29, 0, -0.05, 0
30, 1, -0.05, 0
31, 1, -0.15, 0
32, -0.1, -0.05, 0
33, 1, -0.35, 0
34, 2.3, -0.05, 0
35, 0, 1.35, 0
36, 2.2, 1.35, 0
37, 0, 1.55, 0
38, 2.2, 1.55, 0
39, 2.3, 1.55, 0
40, 2.3, 1.35, 0
41, -0.1, 1.35, 0
42, -0.1, 1.55, 0
43, 1, 1.4, 0
44, 1, 1.45, 0
45, 1, 1.5, 0
46, 1, 1.375, 0
47, 1, 1.425, 0
48, 1, 1.475, 0
49, 1, 1.525, 0
50, 1.24, 1.25, 0
51, 1.28, 1.25, 0
52, 1.32, 1.25, 0
53, 1.36, 1.25, 0
54, 1.4, 1.25, 0
55, 1.44, 1.25, 0
56, 1.48, 1.25, 0
57, 1.52, 1.25, 0
58, 1.56, 1.25, 0
59, 1.6, 1.25, 0
60, 1.64, 1.25, 0
61, 1.68, 1.25, 0
62, 1.72, 1.25, 0
63, 1.76, 1.25, 0
64, 1.8, 1.25, 0
65, 1.84, 1.25, 0
66, 1.88, 1.25, 0
67, 1.92, 1.25, 0
68, 1.96, 1.25, 0
69, 2, 1.25, 0
70, 2.04, 1.25, 0
71, 2.08, 1.25, 0
72, 2.12, 1.25, 0
73, 2.16, 1.25, 0
74, 1.22, 1.25, 0
75, 1.26, 1.25, 0
76, 1.3, 1.25, 0
77, 1.34, 1.25, 0
78, 1.38, 1.25, 0
79, 1.42, 1.25, 0
80, 1.46, 1.25, 0
81, 1.5, 1.25, 0
82, 1.54, 1.25, 0
83, 1.58, 1.25, 0
84, 1.62, 1.25, 0
85, 1.66, 1.25, 0
86, 1.7, 1.25, 0
87, 1.74, 1.25, 0
88, 1.78, 1.25, 0
89, 1.82, 1.25, 0
90, 1.86, 1.25, 0
91, 1.9, 1.25, 0
92, 1.94, 1.25, 0
93, 1.98, 1.25, 0
94, 2.02, 1.25, 0
95, 2.06, 1.25, 0
96, 2.1, 1.25, 0
97, 2.14, 1.25, 0
98, 2.18, 1.25, 0
99, 0.04, 0, 0
100, 0.08, 0, 0
101, 0.12, 0, 0
102, 0.16, 0, 0
103, 0.2, 0, 0
104, 0.24, 0, 0
105, 0.28, 0, 0
106, 0.32, 0, 0
107, 0.36, 0, 0
108, 0.4, 0, 0
109, 0.44, 0, 0
110, 0.48, 0, 0
111, 0.52, 0, 0
112, 0.56, 0, 0
113, 0.6, 0, 0
114, 0.64, 0, 0
115, 0.68, 0, 0
116, 0.72, 0, 0
117, 0.76, 0, 0
118, 0.8, 0, 0
119, 0.84, 0, 0
120, 0.88, 0, 0
121, 0.92, 0, 0
122, 0.96, 0, 0
123, 0.02, 0, 0
124, 0.06, 0, 0
125, 0.1, 0, 0
126, 0.14, 0, 0
127, 0.18, 0, 0
128, 0.22, 0, 0
129, 0.26, 0, 0
130, 0.3, 0, 0
131, 0.34, 0, 0
132, 0.38, 0, 0
133, 0.42, 0, 0
134, 0.46, 0, 0
135, 0.5, 0, 0
136, 0.54, 0, 0
137, 0.58, 0, 0
138, 0.62, 0, 0
139, 0.66, 0, 0
140, 0.7, 0, 0
141, 0.74, 0, 0
142, 0.78, 0, 0
143, 0.82, 0, 0
144, 0.86, 0, 0
145, 0.9, 0, 0
146, 0.94, 0, 0
147, 0.98, 0, 0
148, 1, 0.048, 0
149, 1, 0.096, 0
150, 1, 0.144, 0
151, 1, 0.192, 0
152, 1, 0.24, 0
153, 1, 0.288, 0
154, 1, 0.336, 0
155, 1, 0.384, 0
156, 1, 0.432, 0
157, 1, 0.48, 0
158, 1, 0.528, 0
159, 1, 0.576, 0
160, 1, 0.624, 0
161, 1, 0.672, 0
162, 1, 0.72, 0
163, 1, 0.768, 0
164, 1, 0.816, 0
165, 1, 0.864, 0
166, 1, 0.912, 0
167, 1, 0.96, 0
168, 1, 1.008, 0
169, 1, 1.056, 0
170, 1, 1.104, 0
171, 1, 1.152, 0
172, 1, 0.024, 0
173, 1, 0.072, 0
174, 1, 0.12, 0
175, 1, 0.168, 0
176, 1, 0.216, 0
177, 1, 0.264, 0
178, 1, 0.312, 0
179, 1, 0.36, 0
180, 1, 0.408, 0
181, 1, 0.456, 0
182, 1, 0.504, 0
183, 1, 0.552, 0
184, 1, 0.6, 0
185, 1, 0.648, 0
186, 1, 0.696, 0
187, 1, 0.744, 0
188, 1, 0.792, 0
189, 1, 0.84, 0
190, 1, 0.888, 0
191, 1, 0.936, 0
192, 1, 0.984, 0
193, 1, 1.032, 0
194, 1, 1.08, 0
195, 1, 1.128, 0
196, 1, 1.176, 0
197, 0.96, 1.2, 0
198, 0.92, 1.2, 0
199, 0.88, 1.2, 0
200, 0.84, 1.2, 0
201, 0.8, 1.2, 0
202, 0.76, 1.2, 0
203, 0.72, 1.2, 0
204, 0.68, 1.2, 0
205, 0.64, 1.2, 0
206, 0.6, 1.2, 0
207, 0.56, 1.2, 0
208, 0.52, 1.2, 0
209, 0.48, 1.2, 0
210, 0.44, 1.2, 0
211, 0.4, 1.2, 0
212, 0.36, 1.2, 0
213, 0.32, 1.2, 0
214, 0.28, 1.2, 0
215, 0.24, 1.2, 0
216, 0.2, 1.2, 0
217, 0.16, 1.2, 0
218, 0.12, 1.2, 0
219, 0.08, 1.2, 0
220, 0.04, 1.2, 0
221, 0.98, 1.2, 0
222, 0.94, 1.2, 0
223, 0.9, 1.2, 0
224, 0.86, 1.2, 0
225, 0.82, 1.2, 0
226, 0.78, 1.2, 0
227, 0.74, 1.2, 0
228, 0.7, 1.2, 0
229, 0.66, 1.2, 0
230, 0.62, 1.2, 0
231, 0.58, 1.2, 0
232, 0.54, 1.2, 0
233, 0.5, 1.2, 0
234, 0.46, 1.2, 0
235, 0.42, 1.2, 0
236, 0.38, 1.2, 0
237, 0.34, 1.2, 0
238, 0.3, 1.2, 0
239, 0.26, 1.2, 0
240, 0.22, 1.2, 0
241, 0.18, 1.2, 0
242, 0.14, 1.2, 0
243, 0.1, 1.2, 0
244, 0.06, 1.2, 0
245, 0.02, 1.2, 0
246, 0, 1.152, 0
247, 0, 1.104, 0
248, 0, 1.056, 0
249, 0, 1.008, 0
250, 0, 0.96, 0
251, 0, 0.912, 0
252, 0, 0.864, 0
253, 0, 0.816, 0
254, 0, 0.768, 0
255, 0, 0.72, 0
256, 0, 0.672, 0
257, 0, 0.624, 0
258, 0, 0.576, 0
259, 0, 0.528, 0
260, 0, 0.48, 0
261, 0, 0.432, 0
262, 0, 0.384, 0
263, 0, 0.336, 0
264, 0, 0.288, 0
265, 0, 0.24, 0
266, 0, 0.192, 0
267, 0, 0.144, 0
268, 0, 0.096, 0
269, 0, 0.048, 0
270, 0, 1.176, 0
271, 0, 1.128, 0
272, 0, 1.08, 0
273, 0, 1.032, 0
274, 0, 0.984, 0
275, 0, 0.936, 0
276, 0, 0.888, 0
277, 0, 0.84, 0
278, 0, 0.792, 0
279, 0, 0.744, 0
280, 0, 0.696, 0
281, 0, 0.648, 0
282, 0, 0.6, 0
283, 0, 0.552, 0
284, 0, 0.504, 0
285, 0, 0.456, 0
286, 0, 0.408, 0
287, 0, 0.36, 0
288, 0, 0.312, 0
289, 0, 0.264, 0
290, 0, 0.216, 0
291, 0, 0.168, 0
292, 0, 0.12, 0
293, 0, 0.072, 0
294, 0, 0.024, 0
295, 1.05, 1.35, 0
296, 1.1, 1.35, 0
297, 1.15, 1.35, 0
298, 1.025, 1.35, 0
299, 1.075, 1.35, 0
300, 1.125, 1.35, 0
301, 1.175, 1.35, 0
302, 1.2, 1.2833333333333, 0
303, 1.2, 1.3166666666667, 0
304, 1.2, 1.2666666666667, 0
305, 1.2, 1.3, 0
306, 1.2, 1.3333333333333, 0
307, 1.2, 1.152, 0
308, 1.2, 1.104, 0
309, 1.2, 1.056, 0
310, 1.2, 1.008, 0
311, 1.2, 0.96, 0
312, 1.2, 0.912, 0
313, 1.2, 0.864, 0
314, 1.2, 0.816, 0
315, 1.2, 0.768, 0
316, 1.2, 0.72, 0
317, 1.2, 0.672, 0
318, 1.2, 0.624, 0
319, 1.2, 0.576, 0
320, 1.2, 0.528, 0
321, 1.2, 0.48, 0
322, 1.2, 0.432, 0
323, 1.2, 0.384, 0
324, 1.2, 0.336, 0
325, 1.2, 0.288, 0
326, 1.2, 0.24, 0
327, 1.2, 0.192, 0
328, 1.2, 0.144, 0
329, 1.2, 0.096, 0
330, 1.2, 0.048, 0
331, 1.2, 1.176, 0
332, 1.2, 1.128, 0
333, 1.2, 1.08, 0
334, 1.2, 1.032, 0
335, 1.2, 0.984, 0
336, 1.2, 0.936, 0
337, 1.2, 0.888, 0
338, 1.2, 0.84, 0
339, 1.2, 0.792, 0
340, 1.2, 0.744, 0
341, 1.2, 0.696, 0
342, 1.2, 0.648, 0
343, 1.2, 0.6, 0
344, 1.2, 0.552, 0
345, 1.2, 0.504, 0
346, 1.2, 0.456, 0
347, 1.2, 0.408, 0
348, 1.2, 0.36, 0
349, 1.2, 0.312, 0
350, 1.2, 0.264, 0
351, 1.2, 0.216, 0
352, 1.2, 0.168, 0
353, 1.2, 0.12, 0
354, 1.2, 0.072, 0
355, 1.2, 0.024, 0
356, 2.2, 1.152, 0
357, 2.2, 1.104, 0
358, 2.2, 1.056, 0
359, 2.2, 1.008, 0
360, 2.2, 0.96, 0
361, 2.2, 0.912, 0
362, 2.2, 0.864, 0
363, 2.2, 0.816, 0
364, 2.2, 0.768, 0
365, 2.2, 0.72, 0
366, 2.2, 0.672, 0
367, 2.2, 0.624, 0
368, 2.2, 0.576, 0
369, 2.2, 0.528, 0
370, 2.2, 0.48, 0
371, 2.2, 0.432, 0
372, 2.2, 0.384, 0
373, 2.2, 0.336, 0
374, 2.2, 0.288, 0
375, 2.2, 0.24, 0
376, 2.2, 0.192, 0
377, 2.2, 0.144, 0
378, 2.2, 0.096, 0
379, 2.2, 0.048, 0
380, 2.2, 1.176, 0
381, 2.2, 1.128, 0
382, 2.2, 1.08, 0
383, 2.2, 1.032, 0
384, 2.2, 0.984, 0
385, 2.2, 0.936, 0
386, 2.2, 0.888, 0
387, 2.2, 0.84, 0
388, 2.2, 0.792, 0
389, 2.2, 0.744, 0
390, 2.2, 0.696, 0
391, 2.2, 0.648, 0
392, 2.2, 0.6, 0
393, 2.2, 0.552, 0
394, 2.2, 0.504, 0
395, 2.2, 0.456, 0
396, 2.2, 0.408, 0
397, 2.2, 0.36, 0
398, 2.2, 0.312, 0
399, 2.2, 0.264, 0
400, 2.2, 0.216, 0
401, 2.2, 0.168, 0
402, 2.2, 0.12, 0
403, 2.2, 0.072, 0
404, 2.2, 0.024, 0
405, 1.24, 1.2, 0
406, 1.28, 1.2, 0
407, 1.32, 1.2, 0
408, 1.36, 1.2, 0
409, 1.4, 1.2, 0
410, 1.44, 1.2, 0
411, 1.48, 1.2, 0
412, 1.52, 1.2, 0
413, 1.56, 1.2, 0
414, 1.6, 1.2, 0
415, 1.64, 1.2, 0
416, 1.68, 1.2, 0
417, 1.72, 1.2, 0
418, 1.76, 1.2, 0
419, 1.8, 1.2, 0
420, 1.84, 1.2, 0
421, 1.88, 1.2, 0
422, 1.92, 1.2, 0
423, 1.96, 1.2, 0
424, 2, 1.2, 0
425, 2.04, 1.2, 0
426, 2.08, 1.2, 0
427, 2.12, 1.2, 0
428, 2.16, 1.2, 0
429, 1.22, 1.2, 0
430, 1.26, 1.2, 0
431, 1.3, 1.2, 0
432, 1.34, 1.2, 0
433, 1.38, 1.2, 0
434, 1.42, 1.2, 0
435, 1.46, 1.2, 0
436, 1.5, 1.2, 0
437, 1.54, 1.2, 0
438, 1.58, 1.2, 0
439, 1.62, 1.2, 0
440, 1.66, 1.2, 0
441, 1.7, 1.2, 0
442, 1.74, 1.2, 0
443, 1.78, 1.2, 0
444, 1.82, 1.2, 0
445, 1.86, 1.2, 0
446, 1.9, 1.2, 0
447, 1.94, 1.2, 0
448, 1.98, 1.2, 0
449, 2.02, 1.2, 0
450, 2.06, 1.2, 0
451, 2.1, 1.2, 0
452, 2.14, 1.2, 0
453, 2.18, 1.2, 0
454, 1.24, 0, 0
455, 1.28, 0, 0
456, 1.32, 0, 0
457, 1.36, 0, 0
458, 1.4, 0, 0
459, 1.44, 0, 0
460, 1.48, 0, 0
461, 1.52, 0, 0
462, 1.56, 0, 0
463, 1.6, 0, 0
464, 1.64, 0, 0
465, 1.68, 0, 0
466, 1.72, 0, 0
467, 1.76, 0, 0
468, 1.8, 0, 0
469, 1.84, 0, 0
470, 1.88, 0, 0
471, 1.92, 0, 0
472, 1.96, 0, 0
473, 2, 0, 0
474, 2.04, 0, 0
475, 2.08, 0, 0
476, 2.12, 0, 0
477, 2.16, 0, 0
478, 1.22, 0, 0
479, 1.26, 0, 0
480, 1.3, 0, 0
481, 1.34, 0, 0
482, 1.38, 0, 0
483, 1.42, 0, 0
484, 1.46, 0, 0
485, 1.5, 0, 0
486, 1.54, 0, 0
487, 1.58, 0, 0
488, 1.62, 0, 0
489, 1.66, 0, 0
490, 1.7, 0, 0
491, 1.74, 0, 0
492, 1.78, 0, 0
493, 1.82, 0, 0
494, 1.86, 0, 0
495, 1.9, 0, 0
496, 1.94, 0, 0
497, 1.98, 0, 0
498, 2.02, 0, 0
499, 2.06, 0, 0
500, 2.1, 0, 0
501, 2.14, 0, 0
502, 2.18, 0, 0
503, 1.24, -0.15, 0
504, 1.28, -0.15, 0
505, 1.32, -0.15, 0
506, 1.36, -0.15, 0
507, 1.4, -0.15, 0
508, 1.44, -0.15, 0
509, 1.48, -0.15, 0
510, 1.52, -0.15, 0
511, 1.56, -0.15, 0
512, 1.6, -0.15, 0
513, 1.64, -0.15, 0
514, 1.68, -0.15, 0
515, 1.72, -0.15, 0
516, 1.76, -0.15, 0
517, 1.8, -0.15, 0
518, 1.84, -0.15, 0
519, 1.88, -0.15, 0
520, 1.92, -0.15, 0
521, 1.96, -0.15, 0
522, 2, -0.15, 0
523, 2.04, -0.15, 0
524, 2.08, -0.15, 0
525, 2.12, -0.15, 0
526, 2.16, -0.15, 0
527, 1.22, -0.15, 0
528, 1.26, -0.15, 0
529, 1.3, -0.15, 0
530, 1.34, -0.15, 0
531, 1.38, -0.15, 0
532, 1.42, -0.15, 0
533, 1.46, -0.15, 0
534, 1.5, -0.15, 0
535, 1.54, -0.15, 0
536, 1.58, -0.15, 0
537, 1.62, -0.15, 0
538, 1.66, -0.15, 0
539, 1.7, -0.15, 0
540, 1.74, -0.15, 0
541, 1.78, -0.15, 0
542, 1.82, -0.15, 0
543, 1.86, -0.15, 0
544, 1.9, -0.15, 0
545, 1.94, -0.15, 0
546, 1.98, -0.15, 0
547, 2.02, -0.15, 0
548, 2.06, -0.15, 0
549, 2.1, -0.15, 0
550, 2.14, -0.15, 0
551, 2.18, -0.15, 0
552, -0.033333333333333, -0.15, 0
553, -0.066666666666667, -0.15, 0
554, -0.016666666666667, -0.15, 0
555, -0.05, -0.15, 0
556, -0.083333333333333, -0.15, 0
557, 0, -0.2, 0
558, 0, -0.25, 0
559, 0, -0.3, 0
560, 0, -0.175, 0
561, 0, -0.225, 0
562, 0, -0.275, 0
563, 0, -0.325, 0
564, 1.2, -0.2, 0
565, 1.2, -0.25, 0
566, 1.2, -0.3, 0
567, 1.2, -0.175, 0
568, 1.2, -0.225, 0
569, 1.2, -0.275, 0
570, 1.2, -0.325, 0
571, 2.2, -0.2, 0
572, 2.2, -0.25, 0
573, 2.2, -0.3, 0
574, 2.2, -0.175, 0
575, 2.2, -0.225, 0
576, 2.2, -0.275, 0
577, 2.2, -0.325, 0
578, 1.24, -0.35, 0
579, 1.28, -0.35, 0
580, 1.32, -0.35, 0
581, 1.36, -0.35, 0
582, 1.4, -0.35, 0
583, 1.44, -0.35, 0
584, 1.48, -0.35, 0
585, 1.52, -0.35, 0
586, 1.56, -0.35, 0
587, 1.6, -0.35, 0
588, 1.64, -0.35, 0
589, 1.68, -0.35, 0
590, 1.72, -0.35, 0
591, 1.76, -0.35, 0
592, 1.8, -0.35, 0
593, 1.84, -0.35, 0
594, 1.88, -0.35, 0
595, 1.92, -0.35, 0
596, 1.96, -0.35, 0
597, 2, -0.35, 0
598, 2.04, -0.35, 0
599, 2.08, -0.35, 0
600, 2.12, -0.35, 0
601, 2.16, -0.35, 0
602, 1.22, -0.35, 0
603, 1.26, -0.35, 0
604, 1.3, -0.35, 0
605, 1.34, -0.35, 0
606, 1.38, -0.35, 0
607, 1.42, -0.35, 0
608, 1.46, -0.35, 0
609, 1.5, -0.35, 0
610, 1.54, -0.35, 0
611, 1.58, -0.35, 0
612, 1.62, -0.35, 0
613, 1.66, -0.35, 0
614, 1.7, -0.35, 0
615, 1.74, -0.35, 0
616, 1.78, -0.35, 0
617, 1.82, -0.35, 0
618, 1.86, -0.35, 0
619, 1.9, -0.35, 0
620, 1.94, -0.35, 0
621, 1.98, -0.35, 0
622, 2.02, -0.35, 0
623, 2.06, -0.35, 0
624, 2.1, -0.35, 0
625, 2.14, -0.35, 0
626, 2.18, -0.35, 0
627, 2.3, -0.2, 0
628, 2.3, -0.25, 0
629, 2.3, -0.3, 0
630, 2.3, -0.175, 0
631, 2.3, -0.225, 0
632, 2.3, -0.275, 0
633, 2.3, -0.325, 0
634, 2.2333333333333, -0.15, 0
635, 2.2666666666667, -0.15, 0
636, 2.2166666666667, -0.15, 0
637, 2.25, -0.15, 0
638, 2.2833333333333, -0.15, 0
639, 2.2333333333333, -0.35, 0
640, 2.2666666666667, -0.35, 0
641, 2.2166666666667, -0.35, 0
642, 2.25, -0.35, 0
643, 2.2833333333333, -0.35, 0
644, 1.05, 1.55, 0
645, 1.1, 1.55, 0
646, 1.15, 1.55, 0
647, 1.025, 1.55, 0
648, 1.075, 1.55, 0
649, 1.125, 1.55, 0
650, 1.175, 1.55, 0
651, 1.2, 1.4, 0
652, 1.2, 1.45, 0
653, 1.2, 1.5, 0
654, 1.2, 1.375, 0
655, 1.2, 1.425, 0
656, 1.2, 1.475, 0
657, 1.2, 1.525, 0
658, -0.1, -0.3, 0
659, -0.1, -0.25, 0
660, -0.1, -0.2, 0
661, -0.1, -0.325, 0
662, -0.1, -0.275, 0
663, -0.1, -0.225, 0
664, -0.1, -0.175, 0
665, -0.033333333333333, -0.35, 0
666, -0.066666666666667, -0.35, 0
667, -0.016666666666667, -0.35, 0
668, -0.05, -0.35, 0
669, -0.083333333333333, -0.35, 0
670, 1.2, 1.225, 0
671, 1.2, 1.2375, 0
672, 1.2, 1.2125, 0
673, 2.2, 1.225, 0
674, 2.2, 1.2375, 0
675, 2.2, 1.2125, 0
676, 1, 1.2833333333333, 0
677, 1, 1.3166666666667, 0
678, 1, 1.2666666666667, 0
679, 1, 1.3, 0
680, 1, 1.3333333333333, 0
681, 0.96, 1.25, 0
682, 0.92, 1.25, 0
683, 0.88, 1.25, 0
684, 0.84, 1.25, 0
685, 0.8, 1.25, 0
686, 0.76, 1.25, 0
687, 0.72, 1.25, 0
688, 0.68, 1.25, 0
689, 0.64, 1.25, 0
690, 0.6, 1.25, 0
691, 0.56, 1.25, 0
692, 0.52, 1.25, 0
693, 0.48, 1.25, 0
694, 0.44, 1.25, 0
695, 0.4, 1.25, 0
696, 0.36, 1.25, 0
697, 0.32, 1.25, 0
698, 0.28, 1.25, 0
699, 0.24, 1.25, 0
700, 0.2, 1.25, 0
701, 0.16, 1.25, 0
702, 0.12, 1.25, 0
703, 0.08, 1.25, 0
704, 0.04, 1.25, 0
705, 0.98, 1.25, 0
706, 0.94, 1.25, 0
707, 0.9, 1.25, 0
708, 0.86, 1.25, 0
709, 0.82, 1.25, 0
710, 0.78, 1.25, 0
711, 0.74, 1.25, 0
712, 0.7, 1.25, 0
713, 0.66, 1.25, 0
714, 0.62, 1.25, 0
715, 0.58, 1.25, 0
716, 0.54, 1.25, 0
717, 0.5, 1.25, 0
718, 0.46, 1.25, 0
719, 0.42, 1.25, 0
720, 0.38, 1.25, 0
721, 0.34, 1.25, 0
722, 0.3, 1.25, 0
723, 0.26, 1.25, 0
724, 0.22, 1.25, 0
725, 0.18, 1.25, 0
726, 0.14, 1.25, 0
727, 0.1, 1.25, 0
728, 0.06, 1.25, 0
729, 0.02, 1.25, 0
730, 1.05, 1.25, 0
731, 1.1, 1.25, 0
732, 1.15, 1.25, 0
733, 1.025, 1.25, 0
734, 1.075, 1.25, 0
735, 1.125, 1.25, 0
736, 1.175, 1.25, 0
737, 1.2, -0.083333333333333, 0
738, 1.2, -0.11666666666667, 0
739, 1.2, -0.066666666666667, 0
740, 1.2, -0.1, 0
741, 1.2, -0.13333333333333, 0
742, 2.2, -0.083333333333333, 0
743, 2.2, -0.11666666666667, 0
744, 2.2, -0.066666666666667, 0
745, 2.2, -0.1, 0
746, 2.2, -0.13333333333333, 0
747, 1.24, -0.05, 0
748, 1.28, -0.05, 0
749, 1.32, -0.05, 0
750, 1.36, -0.05, 0
751, 1.4, -0.05, 0
752, 1.44, -0.05, 0
753, 1.48, -0.05, 0
754, 1.52, -0.05, 0
755, 1.56, -0.05, 0
756, 1.6, -0.05, 0
757, 1.64, -0.05, 0
758, 1.68, -0.05, 0
759, 1.72, -0.05, 0
760, 1.76, -0.05, 0
761, 1.8, -0.05, 0
762, 1.84, -0.05, 0
763, 1.88, -0.05, 0
764, 1.92, -0.05, 0
765, 1.96, -0.05, 0
766, 2, -0.05, 0
767, 2.04, -0.05, 0
768, 2.08, -0.05, 0
769, 2.12, -0.05, 0
770, 2.16, -0.05, 0
771, 1.22, -0.05, 0
772, 1.26, -0.05, 0
773, 1.3, -0.05, 0
774, 1.34, -0.05, 0
775, 1.38, -0.05, 0
776, 1.42, -0.05, 0
777, 1.46, -0.05, 0
778, 1.5, -0.05, 0
779, 1.54, -0.05, 0
780, 1.58, -0.05, 0
781, 1.62, -0.05, 0
782, 1.66, -0.05, 0
783, 1.7, -0.05, 0
784, 1.74, -0.05, 0
785, 1.78, -0.05, 0
786, 1.82, -0.05, 0
787, 1.86, -0.05, 0
788, 1.9, -0.05, 0
789, 1.94, -0.05, 0
790, 1.98, -0.05, 0
791, 2.02, -0.05, 0
792, 2.06, -0.05, 0
793, 2.1, -0.05, 0
794, 2.14, -0.05, 0
795, 2.18, -0.05, 0
796, 0, -0.083333333333333, 0
797, 0, -0.11666666666667, 0
798, 0, -0.066666666666667, 0
799, 0, -0.1, 0
800, 0, -0.13333333333333, 0
801, 1, -0.083333333333333, 0
802, 1, -0.11666666666667, 0
803, 1, -0.066666666666667, 0
804, 1, -0.1, 0
805, 1, -0.13333333333333, 0
806, 0.04, -0.05, 0
807, 0.08, -0.05, 0
808, 0.12, -0.05, 0
809, 0.16, -0.05, 0
810, 0.2, -0.05, 0
811, 0.24, -0.05, 0
812, 0.28, -0.05, 0
813, 0.32, -0.05, 0
814, 0.36, -0.05, 0
815, 0.4, -0.05, 0
816, 0.44, -0.05, 0
817, 0.48, -0.05, 0
818, 0.52, -0.05, 0
819, 0.56, -0.05, 0
820, 0.6, -0.05, 0
821, 0.64, -0.05, 0
822, 0.68, -0.05, 0
823, 0.72, -0.05, 0
824, 0.76, -0.05, 0
825, 0.8, -0.05, 0
826, 0.84, -0.05, 0
827, 0.88, -0.05, 0
828, 0.92, -0.05, 0
829, 0.96, -0.05, 0
830, 0.02, -0.05, 0
831, 0.06, -0.05, 0
832, 0.1, -0.05, 0
833, 0.14, -0.05, 0
834, 0.18, -0.05, 0
835, 0.22, -0.05, 0
836, 0.26, -0.05, 0
837, 0.3, -0.05, 0
838, 0.34, -0.05, 0
839, 0.38, -0.05, 0
840, 0.42, -0.05, 0
841, 0.46, -0.05, 0
842, 0.5, -0.05, 0
843, 0.54, -0.05, 0
844, 0.58, -0.05, 0
845, 0.62, -0.05, 0
846, 0.66, -0.05, 0
847, 0.7, -0.05, 0
848, 0.74, -0.05, 0
849, 0.78, -0.05, 0
850, 0.82, -0.05, 0
851, 0.86, -0.05, 0
852, 0.9, -0.05, 0
853, 0.94, -0.05, 0
854, 0.98, -0.05, 0
855, 0.04, -0.15, 0
856, 0.08, -0.15, 0
857, 0.12, -0.15, 0
858, 0.16, -0.15, 0
859, 0.2, -0.15, 0
860, 0.24, -0.15, 0
861, 0.28, -0.15, 0
862, 0.32, -0.15, 0
863, 0.36, -0.15, 0
864, 0.4, -0.15, 0
865, 0.44, -0.15, 0
866, 0.48, -0.15, 0
867, 0.52, -0.15, 0
868, 0.56, -0.15, 0
869, 0.6, -0.15, 0
870, 0.64, -0.15, 0
871, 0.68, -0.15, 0
872, 0.72, -0.15, 0
873, 0.76, -0.15, 0
874, 0.8, -0.15, 0
875, 0.84, -0.15, 0
876, 0.88, -0.15, 0
877, 0.92, -0.15, 0
878, 0.96, -0.15, 0
879, 0.02, -0.15, 0
880, 0.06, -0.15, 0
881, 0.1, -0.15, 0
882, 0.14, -0.15, 0
883, 0.18, -0.15, 0
884, 0.22, -0.15, 0
885, 0.26, -0.15, 0
886, 0.3, -0.15, 0
887, 0.34, -0.15, 0
888, 0.38, -0.15, 0
889, 0.42, -0.15, 0
890, 0.46, -0.15, 0
891, 0.5, -0.15, 0
892, 0.54, -0.15, 0
893, 0.58, -0.15, 0
894, 0.62, -0.15, 0
895, 0.66, -0.15, 0
896, 0.7, -0.15, 0
897, 0.74, -0.15, 0
898, 0.78, -0.15, 0
899, 0.82, -0.15, 0
900, 0.86, -0.15, 0
901, 0.9, -0.15, 0
902, 0.94, -0.15, 0
903, 0.98, -0.15, 0
904, -0.033333333333333, -0.05, 0
905, -0.066666666666667, -0.05, 0
906, -0.016666666666667, -0.05, 0
907, -0.05, -0.05, 0
908, -0.083333333333333, -0.05, 0
909, -0.1, -0.083333333333333, 0
910, -0.1, -0.11666666666667, 0
911, -0.1, -0.066666666666667, 0
912, -0.1, -0.1, 0
913, -0.1, -0.13333333333333, 0
914, 1, -0.2, 0
915, 1, -0.25, 0
916, 1, -0.3, 0
917, 1, -0.175, 0
918, 1, -0.225, 0
919, 1, -0.275, 0
920, 1, -0.325, 0
921, 0.04, -0.35, 0
922, 0.08, -0.35, 0
923, 0.12, -0.35, 0
924, 0.16, -0.35, 0
925, 0.2, -0.35, 0
926, 0.24, -0.35, 0
927, 0.28, -0.35, 0
928, 0.32, -0.35, 0
929, 0.36, -0.35, 0
930, 0.4, -0.35, 0
931, 0.44, -0.35, 0
932, 0.48, -0.35, 0
933, 0.52, -0.35, 0
934, 0.56, -0.35, 0
935, 0.6, -0.35, 0
936, 0.64, -0.35, 0
937, 0.68, -0.35, 0
938, 0.72, -0.35, 0
939, 0.76, -0.35, 0
940, 0.8, -0.35, 0
941, 0.84, -0.35, 0
942, 0.88, -0.35, 0
943, 0.92, -0.35, 0
944, 0.96, -0.35, 0
945, 0.02, -0.35, 0
946, 0.06, -0.35, 0
947, 0.1, -0.35, 0
948, 0.14, -0.35, 0
949, 0.18, -0.35, 0
950, 0.22, -0.35, 0
951, 0.26, -0.35, 0
952, 0.3, -0.35, 0
953, 0.34, -0.35, 0
954, 0.38, -0.35, 0
955, 0.42, -0.35, 0
956, 0.46, -0.35, 0
957, 0.5, -0.35, 0
958, 0.54, -0.35, 0
959, 0.58, -0.35, 0
960, 0.62, -0.35, 0
961, 0.66, -0.35, 0
962, 0.7, -0.35, 0
963, 0.74, -0.35, 0
964, 0.78, -0.35, 0
965, 0.82, -0.35, 0
966, 0.86, -0.35, 0
967, 0.9, -0.35, 0
968, 0.94, -0.35, 0
969, 0.98, -0.35, 0
970, 2.3, -0.083333333333333, 0
971, 2.3, -0.11666666666667, 0
972, 2.3, -0.066666666666667, 0
973, 2.3, -0.1, 0
974, 2.3, -0.13333333333333, 0
975, 2.2333333333333, -0.05, 0
976, 2.2666666666667, -0.05, 0
977, 2.2166666666667, -0.05, 0
978, 2.25, -0.05, 0
979, 2.2833333333333, -0.05, 0
980, 0, -0.025, 0
981, 0, -0.0125, 0
982, 0, -0.0375, 0
983, 1, -0.025, 0
984, 1, -0.0125, 0
985, 1, -0.0375, 0
986, 1.2, -0.025, 0
987, 1.2, -0.0125, 0
988, 1.2, -0.0375, 0
989, 2.2, -0.025, 0
990, 2.2, -0.0125, 0
991, 2.2, -0.0375, 0
992, 1, 1.225, 0
993, 1, 1.2125, 0
994, 1, 1.2375, 0
995, 0, 1.225, 0
996, 0, 1.2125, 0
997, 0, 1.2375, 0
998, 1.15, -0.15, 0
999, 1.1, -0.15, 0
1000, 1.05, -0.15, 0
1001, 1.175, -0.15, 0
1002, 1.125, -0.15, 0
1003, 1.075, -0.15, 0
1004, 1.025, -0.15, 0
1005, 1.15, -0.35, 0
1006, 1.1, -0.35, 0
1007, 1.05, -0.35, 0
1008, 1.175, -0.35, 0
1009, 1.125, -0.35, 0
1010, 1.075, -0.35, 0
1011, 1.025, -0.35, 0
1012, 0, 1.2833333333333, 0
1013, 0, 1.3166666666667, 0
1014, 0, 1.2666666666667, 0
1015, 0, 1.3, 0
1016, 0, 1.3333333333333, 0
1017, 0.96, 1.35, 0
1018, 0.92, 1.35, 0
1019, 0.88, 1.35, 0
1020, 0.84, 1.35, 0
1021, 0.8, 1.35, 0
1022, 0.76, 1.35, 0
1023, 0.72, 1.35, 0
1024, 0.68, 1.35, 0
1025, 0.64, 1.35, 0
1026, 0.6, 1.35, 0
1027, 0.56, 1.35, 0
1028, 0.52, 1.35, 0
1029, 0.48, 1.35, 0
1030, 0.44, 1.35, 0
1031, 0.4, 1.35, 0
1032, 0.36, 1.35, 0
1033, 0.32, 1.35, 0
1034, 0.28, 1.35, 0
1035, 0.24, 1.35, 0
1036, 0.2, 1.35, 0
1037, 0.16, 1.35, 0
1038, 0.12, 1.35, 0
1039, 0.08, 1.35, 0
1040, 0.04, 1.35, 0
1041, 0.98, 1.35, 0
1042, 0.94, 1.35, 0
1043, 0.9, 1.35, 0
1044, 0.86, 1.35, 0
1045, 0.82, 1.35, 0
1046, 0.78, 1.35, 0
1047, 0.74, 1.35, 0
1048, 0.7, 1.35, 0
1049, 0.66, 1.35, 0
1050, 0.62, 1.35, 0
1051, 0.58, 1.35, 0
1052, 0.54, 1.35, 0
1053, 0.5, 1.35, 0
1054, 0.46, 1.35, 0
1055, 0.42, 1.35, 0
1056, 0.38, 1.35, 0
1057, 0.34, 1.35, 0
1058, 0.3, 1.35, 0
1059, 0.26, 1.35, 0
1060, 0.22, 1.35, 0
1061, 0.18, 1.35, 0
1062, 0.14, 1.35, 0
1063, 0.1, 1.35, 0
1064, 0.06, 1.35, 0
1065, 0.02, 1.35, 0
1066, 1.24, 1.35, 0
1067, 1.28, 1.35, 0
1068, 1.32, 1.35, 0
1069, 1.36, 1.35, 0
1070, 1.4, 1.35, 0
1071, 1.44, 1.35, 0
1072, 1.48, 1.35, 0
1073, 1.52, 1.35, 0
1074, 1.56, 1.35, 0
1075, 1.6, 1.35, 0
1076, 1.64, 1.35, 0
1077, 1.68, 1.35, 0
1078, 1.72, 1.35, 0
1079, 1.76, 1.35, 0
1080, 1.8, 1.35, 0
1081, 1.84, 1.35, 0
1082, 1.88, 1.35, 0
1083, 1.92, 1.35, 0
1084, 1.96, 1.35, 0
1085, 2, 1.35, 0
1086, 2.04, 1.35, 0
1087, 2.08, 1.35, 0
1088, 2.12, 1.35, 0
1089, 2.16, 1.35, 0
1090, 1.22, 1.35, 0
1091, 1.26, 1.35, 0
1092, 1.3, 1.35, 0
1093, 1.34, 1.35, 0
1094, 1.38, 1.35, 0
1095, 1.42, 1.35, 0
1096, 1.46, 1.35, 0
1097, 1.5, 1.35, 0
1098, 1.54, 1.35, 0
1099, 1.58, 1.35, 0
1100, 1.62, 1.35, 0
1101, 1.66, 1.35, 0
1102, 1.7, 1.35, 0
1103, 1.74, 1.35, 0
1104, 1.78, 1.35, 0
1105, 1.82, 1.35, 0
1106, 1.86, 1.35, 0
1107, 1.9, 1.35, 0
1108, 1.94, 1.35, 0
1109, 1.98, 1.35, 0
1110, 2.02, 1.35, 0
1111, 2.06, 1.35, 0
1112, 2.1, 1.35, 0
1113, 2.14, 1.35, 0
1114, 2.18, 1.35, 0
1115, 2.2, 1.2833333333333, 0
1116, 2.2, 1.3166666666667, 0
1117, 2.2, 1.2666666666667, 0
1118, 2.2, 1.3, 0
1119, 2.2, 1.3333333333333, 0
1120, 0, 1.4, 0
1121, 0, 1.45, 0
1122, 0, 1.5, 0
1123, 0, 1.375, 0
1124, 0, 1.425, 0
1125, 0, 1.475, 0
1126, 0, 1.525, 0
1127, 0.96, 1.55, 0
1128, 0.92, 1.55, 0
1129, 0.88, 1.55, 0
1130, 0.84, 1.55, 0
1131, 0.8, 1.55, 0
1132, 0.76, 1.55, 0
1133, 0.72, 1.55, 0
1134, 0.68, 1.55, 0
1135, 0.64, 1.55, 0
1136, 0.6, 1.55, 0
1137, 0.56, 1.55, 0
1138, 0.52, 1.55, 0
1139, 0.48, 1.55, 0
1140, 0.44, 1.55, 0
1141, 0.4, 1.55, 0
1142, 0.36, 1.55, 0
1143, 0.32, 1.55, 0
1144, 0.28, 1.55, 0
1145, 0.24, 1.55, 0
1146, 0.2, 1.55, 0
1147, 0.16, 1.55, 0
1148, 0.12, 1.55, 0
1149, 0.08, 1.55, 0
1150, 0.04, 1.55, 0
1151, 0.98, 1.55, 0
1152, 0.94, 1.55, 0
1153, 0.9, 1.55, 0
1154, 0.86, 1.55, 0
1155, 0.82, 1.55, 0
1156, 0.78, 1.55, 0
1157, 0.74, 1.55, 0
1158, 0.7, 1.55, 0
1159, 0.66, 1.55, 0
1160, 0.62, 1.55, 0
1161, 0.58, 1.55, 0
1162, 0.54, 1.55, 0
1163, 0.5, 1.55, 0
1164, 0.46, 1.55, 0
1165, 0.42, 1.55, 0
1166, 0.38, 1.55, 0
1167, 0.34, 1.55, 0
1168, 0.3, 1.55, 0
1169, 0.26, 1.55, 0
1170, 0.22, 1.55, 0
1171, 0.18, 1.55, 0
1172, 0.14, 1.55, 0
1173, 0.1, 1.55, 0
1174, 0.06, 1.55, 0
1175, 0.02, 1.55, 0
1176, 2.2, 1.5, 0
1177, 2.2, 1.45, 0
1178, 2.2, 1.4, 0
1179, 2.2, 1.525, 0
1180, 2.2, 1.475, 0
1181, 2.2, 1.425, 0
1182, 2.2, 1.375, 0
1183, 1.24, 1.55, 0
1184, 1.28, 1.55, 0
1185, 1.32, 1.55, 0
1186, 1.36, 1.55, 0
1187, 1.4, 1.55, 0
1188, 1.44, 1.55, 0
1189, 1.48, 1.55, 0
1190, 1.52, 1.55, 0
1191, 1.56, 1.55, 0
1192, 1.6, 1.55, 0
1193, 1.64, 1.55, 0
1194, 1.68, 1.55, 0
1195, 1.72, 1.55, 0
1196, 1.76, 1.55, 0
1197, 1.8, 1.55, 0
1198, 1.84, 1.55, 0
1199, 1.88, 1.55, 0
1200, 1.92, 1.55, 0
1201, 1.96, 1.55, 0
1202, 2, 1.55, 0
1203, 2.04, 1.55, 0
1204, 2.08, 1.55, 0
1205, 2.12, 1.55, 0
1206, 2.16, 1.55, 0
1207, 1.22, 1.55, 0
1208, 1.26, 1.55, 0
1209, 1.3, 1.55, 0
1210, 1.34, 1.55, 0
1211, 1.38, 1.55, 0
1212, 1.42, 1.55, 0
1213, 1.46, 1.55, 0
1214, 1.5, 1.55, 0
1215, 1.54, 1.55, 0
1216, 1.58, 1.55, 0
1217, 1.62, 1.55, 0
1218, 1.66, 1.55, 0
1219, 1.7, 1.55, 0
1220, 1.74, 1.55, 0
1221, 1.78, 1.55, 0
1222, 1.82, 1.55, 0
1223, 1.86, 1.55, 0
1224, 1.9, 1.55, 0
1225, 1.94, 1.55, 0
1226, 1.98, 1.55, 0
1227, 2.02, 1.55, 0
1228, 2.06, 1.55, 0
1229, 2.1, 1.55, 0
1230, 2.14, 1.55, 0
1231, 2.18, 1.55, 0
1232, 2.2666666666667, 1.55, 0
1233, 2.2333333333333, 1.55, 0
1234, 2.2833333333333, 1.55, 0
1235, 2.25, 1.55, 0
1236, 2.2166666666667, 1.55, 0
1237, 2.2666666666667, 1.35, 0
1238, 2.2333333333333, 1.35, 0
1239, 2.2833333333333, 1.35, 0
1240, 2.25, 1.35, 0
1241, 2.2166666666667, 1.35, 0
1242, 2.3, 1.5, 0
1243, 2.3, 1.45, 0
1244, 2.3, 1.4, 0
1245, 2.3, 1.525, 0
1246, 2.3, 1.475, 0
1247, 2.3, 1.425, 0
1248, 2.3, 1.375, 0
1249, -0.066666666666667, 1.35, 0
1250, -0.033333333333333, 1.35, 0
1251, -0.083333333333333, 1.35, 0
1252, -0.05, 1.35, 0
1253, -0.016666666666667, 1.35, 0
1254, -0.066666666666667, 1.55, 0
1255, -0.033333333333333, 1.55, 0
1256, -0.083333333333333, 1.55, 0
1257, -0.05, 1.55, 0
1258, -0.016666666666667, 1.55, 0
1259, -0.1, 1.4, 0
1260, -0.1, 1.45, 0
1261, -0.1, 1.5, 0
1262, -0.1, 1.375, 0
1263, -0.1, 1.425, 0
1264, -0.1, 1.475, 0
1265, -0.1, 1.525, 0
1266, 0.04, 0.048, 0
1267, 0.04, 0.096, 0
1268, 0.04, 0.144, 0
1269, 0.04, 0.192, 0
1270, 0.04, 0.24, 0
1271, 0.04, 0.288, 0
1272, 0.04, 0.336, 0
1273, 0.04, 0.384, 0
1274, 0.04, 0.432, 0
1275, 0.04, 0.48, 0
1276, 0.04, 0.528, 0
1277, 0.04, 0.576, 0
1278, 0.04, 0.624, 0
1279, 0.04, 0.672, 0
1280, 0.04, 0.72, 0
1281, 0.04, 0.768, 0
1282, 0.04, 0.816, 0
1283, 0.04, 0.864, 0
1284, 0.04, 0.912, 0
1285, 0.04, 0.96, 0
1286, 0.04, 1.008, 0
1287, 0.04, 1.056, 0
1288, 0.04, 1.104, 0
1289, 0.04, 1.152, 0
1290, 0.08, 0.048, 0
1291, 0.08, 0.096, 0
1292, 0.08, 0.144, 0
1293, 0.08, 0.192, 0
1294, 0.08, 0.24, 0
1295, 0.08, 0.288, 0
1296, 0.08, 0.336, 0
1297, 0.08, 0.384, 0
1298, 0.08, 0.432, 0
1299, 0.08, 0.48, 0
1300, 0.08, 0.528, 0
1301, 0.08, 0.576, 0
1302, 0.08, 0.624, 0
1303, 0.08, 0.672, 0
1304, 0.08, 0.72, 0
1305, 0.08, 0.768, 0
1306, 0.08, 0.816, 0
1307, 0.08, 0.864, 0
1308, 0.08, 0.912, 0
1309, 0.08, 0.96, 0
1310, 0.08, 1.008, 0
1311, 0.08, 1.056, 0
1312, 0.08, 1.104, 0
1313, 0.08, 1.152, 0
1314, 0.12, 0.048, 0
1315, 0.12, 0.096, 0
1316, 0.12, 0.144, 0
1317, 0.12, 0.192, 0
1318, 0.12, 0.24, 0
1319, 0.12, 0.288, 0
1320, 0.12, 0.336, 0
1321, 0.12, 0.384, 0
1322, 0.12, 0.432, 0
1323, 0.12, 0.48, 0
1324, 0.12, 0.528, 0
1325, 0.12, 0.576, 0
1326, 0.12, 0.624, 0
1327, 0.12, 0.672, 0
1328, 0.12, 0.72, 0
1329, 0.12, 0.768, 0
1330, 0.12, 0.816, 0
1331, 0.12, 0.864, 0
1332, 0.12, 0.912, 0
1333, 0.12, 0.96, 0
1334, 0.12, 1.008, 0
1335, 0.12, 1.056, 0
1336, 0.12, 1.104, 0
1337, 0.12, 1.152, 0
1338, 0.16, 0.048, 0
1339, 0.16, 0.096, 0
1340, 0.16, 0.144, 0
1341, 0.16, 0.192, 0
1342, 0.16, 0.24, 0
1343, 0.16, 0.288, 0
1344, 0.16, 0.336, 0
1345, 0.16, 0.384, 0
1346, 0.16, 0.432, 0
1347, 0.16, 0.48, 0
1348, 0.16, 0.528, 0
1349, 0.16, 0.576, 0
1350, 0.16, 0.624, 0
1351, 0.16, 0.672, 0
1352, 0.16, 0.72, 0
1353, 0.16, 0.768, 0
1354, 0.16, 0.816, 0
1355, 0.16, 0.864, 0
1356, 0.16, 0.912, 0
1357, 0.16, 0.96, 0
1358, 0.16, 1.008, 0
1359, 0.16, 1.056, 0
1360, 0.16, 1.104, 0
1361, 0.16, 1.152, 0
1362, 0.2, 0.048, 0
1363, 0.2, 0.096, 0
1364, 0.2, 0.144, 0
1365, 0.2, 0.192, 0
1366, 0.2, 0.24, 0
1367, 0.2, 0.288, 0
1368, 0.2, 0.336, 0
1369, 0.2, 0.384, 0
1370, 0.2, 0.432, 0
1371, 0.2, 0.48, 0
1372, 0.2, 0.528, 0
1373, 0.2, 0.576, 0
1374, 0.2, 0.624, 0
1375, 0.2, 0.672, 0
1376, 0.2, 0.72, 0
1377, 0.2, 0.768, 0
1378, 0.2, 0.816, 0
1379, 0.2, 0.864, 0
1380, 0.2, 0.912, 0
1381, 0.2, 0.96, 0
1382, 0.2, 1.008, 0
1383, 0.2, 1.056, 0
1384, 0.2, 1.104, 0
1385, 0.2, 1.152, 0
1386, 0.24, 0.048, 0
1387, 0.24, 0.096, 0
1388, 0.24, 0.144, 0
1389, 0.24, 0.192, 0
1390, 0.24, 0.24, 0
1391, 0.24, 0.288, 0
1392, 0.24, 0.336, 0
1393, 0.24, 0.384, 0
1394, 0.24, 0.432, 0
1395, 0.24, 0.48, 0
1396, 0.24, 0.528, 0
1397, 0.24, 0.576, 0
1398, 0.24, 0.624, 0
1399, 0.24, 0.672, 0
1400, 0.24, 0.72, 0
1401, 0.24, 0.768, 0
1402, 0.24, 0.816, 0
1403, 0.24, 0.864, 0
1404, 0.24, 0.912, 0
1405, 0.24, 0.96, 0
1406, 0.24, 1.008, 0
1407, 0.24, 1.056, 0
1408, 0.24, 1.104, 0
1409, 0.24, 1.152, 0
1410, 0.28, 0.048, 0
1411, 0.28, 0.096, 0
1412, 0.28, 0.144, 0
1413, 0.28, 0.192, 0
1414, 0.28, 0.24, 0
1415, 0.28, 0.288, 0
1416, 0.28, 0.336, 0
1417, 0.28, 0.384, 0
1418, 0.28, 0.432, 0
1419, 0.28, 0.48, 0
1420, 0.28, 0.528, 0
1421, 0.28, 0.576, 0
1422, 0.28, 0.624, 0
1423, 0.28, 0.672, 0
1424, 0.28, 0.72, 0
1425, 0.28, 0.768, 0
1426, 0.28, 0.816, 0
1427, 0.28, 0.864, 0
1428, 0.28, 0.912, 0
1429, 0.28, 0.96, 0
1430, 0.28, 1.008, 0
1431, 0.28, 1.056, 0
1432, 0.28, 1.104, 0
1433, 0.28, 1.152, 0
1434, 0.32, 0.048, 0
1435, 0.32, 0.096, 0
1436, 0.32, 0.144, 0
1437, 0.32, 0.192, 0
1438, 0.32, 0.24, 0
1439, 0.32, 0.288, 0
1440, 0.32, 0.336, 0
1441, 0.32, 0.384, 0
1442, 0.32, 0.432, 0
1443, 0.32, 0.48, 0
1444, 0.32, 0.528, 0
1445, 0.32, 0.576, 0
1446, 0.32, 0.624, 0
1447, 0.32, 0.672, 0
1448, 0.32, 0.72, 0
1449, 0.32, 0.768, 0
1450, 0.32, 0.816, 0
1451, 0.32, 0.864, 0
1452, 0.32, 0.912, 0
1453, 0.32, 0.96, 0
1454, 0.32, 1.008, 0
1455, 0.32, 1.056, 0
1456, 0.32, 1.104, 0
1457, 0.32, 1.152, 0
1458, 0.36, 0.048, 0
1459, 0.36, 0.096, 0
1460, 0.36, 0.144, 0
1461, 0.36, 0.192, 0
1462, 0.36, 0.24, 0
1463, 0.36, 0.288, 0
1464, 0.36, 0.336, 0
1465, 0.36, 0.384, 0
1466, 0.36, 0.432, 0
1467, 0.36, 0.48, 0
1468, 0.36, 0.528, 0
1469, 0.36, 0.576, 0
1470, 0.36, 0.624, 0
1471, 0.36, 0.672, 0
1472, 0.36, 0.72, 0
1473, 0.36, 0.768, 0
1474, 0.36, 0.816, 0
1475, 0.36, 0.864, 0
1476, 0.36, 0.912, 0
1477, 0.36, 0.96, 0
1478, 0.36, 1.008, 0
1479, 0.36, 1.056, 0
1480, 0.36, 1.104, 0
1481, 0.36, 1.152, 0
1482, 0.4, 0.048, 0
1483, 0.4, 0.096, 0
1484, 0.4, 0.144, 0
1485, 0.4, 0.192, 0
1486, 0.4, 0.24, 0
1487, 0.4, 0.288, 0
1488, 0.4, 0.336, 0
1489, 0.4, 0.384, 0
1490, 0.4, 0.432, 0
1491, 0.4, 0.48, 0
1492, 0.4, 0.528, 0
1493, 0.4, 0.576, 0
1494, 0.4, 0.624, 0
1495, 0.4, 0.672, 0
1496, 0.4, 0.72, 0
1497, 0.4, 0.768, 0
1498, 0.4, 0.816, 0
1499, 0.4, 0.864, 0
1500, 0.4, 0.912, 0
1501, 0.4, 0.96, 0
1502, 0.4, 1.008, 0
1503, 0.4, 1.056, 0
1504, 0.4, 1.104, 0
1505, 0.4, 1.152, 0
1506, 0.44, 0.048, 0
1507, 0.44, 0.096, 0
1508, 0.44, 0.144, 0
1509, 0.44, 0.192, 0
1510, 0.44, 0.24, 0
1511, 0.44, 0.288, 0
1512, 0.44, 0.336, 0
1513, 0.44, 0.384, 0
1514, 0.44, 0.432, 0
1515, 0.44, 0.48, 0
1516, 0.44, 0.528, 0
1517, 0.44, 0.576, 0
1518, 0.44, 0.624, 0
1519, 0.44, 0.672, 0
1520, 0.44, 0.72, 0
1521, 0.44, 0.768, 0
1522, 0.44, 0.816, 0
1523, 0.44, 0.864, 0
1524, 0.44, 0.912, 0
1525, 0.44, 0.96, 0
1526, 0.44, 1.008, 0
1527, 0.44, 1.056, 0
1528, 0.44, 1.104, 0
1529, 0.44, 1.152, 0
1530, 0.48, 0.048, 0
1531, 0.48, 0.096, 0
1532, 0.48, 0.144, 0
1533, 0.48, 0.192, 0
1534, 0.48, 0.24, 0
1535, 0.48, 0.288, 0
1536, 0.48, 0.336, 0
1537, 0.48, 0.384, 0
1538, 0.48, 0.432, 0
1539, 0.48, 0.48, 0
1540, 0.48, 0.528, 0
1541, 0.48, 0.576, 0
1542, 0.48, 0.624, 0
1543, 0.48, 0.672, 0
1544, 0.48, 0.72, 0
1545, 0.48, 0.768, 0
1546, 0.48, 0.816, 0
1547, 0.48, 0.864, 0
1548, 0.48, 0.912, 0
1549, 0.48, 0.96, 0
1550, 0.48, 1.008, 0
1551, 0.48, 1.056, 0
1552, 0.48, 1.104, 0
1553, 0.48, 1.152, 0
1554, 0.52, 0.048, 0
1555, 0.52, 0.096, 0
1556, 0.52, 0.144, 0
1557, 0.52, 0.192, 0
1558, 0.52, 0.24, 0
1559, 0.52, 0.288, 0
1560, 0.52, 0.336, 0
1561, 0.52, 0.384, 0
1562, 0.52, 0.432, 0
1563, 0.52, 0.48, 0
1564, 0.52, 0.528, 0
1565, 0.52, 0.576, 0
1566, 0.52, 0.624, 0
1567, 0.52, 0.672, 0
1568, 0.52, 0.72, 0
1569, 0.52, 0.768, 0
1570, 0.52, 0.816, 0
1571, 0.52, 0.864, 0
1572, 0.52, 0.912, 0
1573, 0.52, 0.96, 0
1574, 0.52, 1.008, 0
1575, 0.52, 1.056, 0
1576, 0.52, 1.104, 0
1577, 0.52, 1.152, 0
1578, 0.56, 0.048, 0
1579, 0.56, 0.096, 0
1580, 0.56, 0.144, 0
1581, 0.56, 0.192, 0
1582, 0.56, 0.24, 0
1583, 0.56, 0.288, 0
1584, 0.56, 0.336, 0
1585, 0.56, 0.384, 0
1586, 0.56, 0.432, 0
1587, 0.56, 0.48, 0
1588, 0.56, 0.528, 0
1589, 0.56, 0.576, 0
1590, 0.56, 0.624, 0
1591, 0.56, 0.672, 0
1592, 0.56, 0.72, 0
1593, 0.56, 0.768, 0
1594, 0.56, 0.816, 0
1595, 0.56, 0.864, 0
1596, 0.56, 0.912, 0
1597, 0.56, 0.96, 0
1598, 0.56, 1.008, 0
1599, 0.56, 1.056, 0
1600, 0.56, 1.104, 0
1601, 0.56, 1.152, 0
1602, 0.6, 0.048, 0
1603, 0.6, 0.096, 0
1604, 0.6, 0.144, 0
1605, 0.6, 0.192, 0
1606, 0.6, 0.24, 0
1607, 0.6, 0.288, 0
1608, 0.6, 0.336, 0
1609, 0.6, 0.384, 0
1610, 0.6, 0.432, 0
1611, 0.6, 0.48, 0
1612, 0.6, 0.528, 0
1613, 0.6, 0.576, 0
1614, 0.6, 0.624, 0
1615, 0.6, 0.672, 0
1616, 0.6, 0.72, 0
1617, 0.6, 0.768, 0
1618, 0.6, 0.816, 0
1619, 0.6, 0.864, 0
1620, 0.6, 0.912, 0
1621, 0.6, 0.96, 0
1622, 0.6, 1.008, 0
1623, 0.6, 1.056, 0
1624, 0.6, 1.104, 0
1625, 0.6, 1.152, 0
1626, 0.64, 0.048, 0
1627, 0.64, 0.096, 0
1628, 0.64, 0.144, 0
1629, 0.64, 0.192, 0
1630, 0.64, 0.24, 0
1631, 0.64, 0.288, 0
1632, 0.64, 0.336, 0
1633, 0.64, 0.384, 0
1634, 0.64, 0.432, 0
1635, 0.64, 0.48, 0
1636, 0.64, 0.528, 0
1637, 0.64, 0.576, 0
1638, 0.64, 0.624, 0
1639, 0.64, 0.672, 0
1640, 0.64, 0.72, 0
1641, 0.64, 0.768, 0
1642, 0.64, 0.816, 0
1643, 0.64, 0.864, 0
1644, 0.64, 0.912, 0
1645, 0.64, 0.96, 0
1646, 0.64, 1.008, 0
1647, 0.64, 1.056, 0
1648, 0.64, 1.104, 0
1649, 0.64, 1.152, 0
1650, 0.68, 0.048, 0
1651, 0.68, 0.096, 0
1652, 0.68, 0.144, 0
1653, 0.68, 0.192, 0
1654, 0.68, 0.24, 0
1655, 0.68, 0.288, 0
1656, 0.68, 0.336, 0
1657, 0.68, 0.384, 0
1658, 0.68, 0.432, 0
1659, 0.68, 0.48, 0
1660, 0.68, 0.528, 0
1661, 0.68, 0.576, 0
1662, 0.68, 0.624, 0
1663, 0.68, 0.672, 0
1664, 0.68, 0.72, 0
1665, 0.68, 0.768, 0
1666, 0.68, 0.816, 0
1667, 0.68, 0.864, 0
1668, 0.68, 0.912, 0
1669, 0.68, 0.96, 0
1670, 0.68, 1.008, 0
1671, 0.68, 1.056, 0
1672, 0.68, 1.104, 0
1673, 0.68, 1.152, 0
1674, 0.72, 0.048, 0
1675, 0.72, 0.096, 0
1676, 0.72, 0.144, 0
1677, 0.72, 0.192, 0
1678, 0.72, 0.24, 0
1679, 0.72, 0.288, 0
1680, 0.72, 0.336, 0
1681, 0.72, 0.384, 0
1682, 0.72, 0.432, 0
1683, 0.72, 0.48, 0
1684, 0.72, 0.528, 0
1685, 0.72, 0.576, 0
1686, 0.72, 0.624, 0
1687, 0.72, 0.672, 0
1688, 0.72, 0.72, 0
1689, 0.72, 0.768, 0
1690, 0.72, 0.816, 0
1691, 0.72, 0.864, 0
1692, 0.72, 0.912, 0
1693, 0.72, 0.96, 0
1694, 0.72, 1.008, 0
1695, 0.72, 1.056, 0
1696, 0.72, 1.104, 0
1697, 0.72, 1.152, 0
1698, 0.76, 0.048, 0
1699, 0.76, 0.096, 0
1700, 0.76, 0.144, 0
1701, 0.76, 0.192, 0
1702, 0.76, 0.24, 0
1703, 0.76, 0.288, 0
1704, 0.76, 0.336, 0
1705, 0.76, 0.384, 0
1706, 0.76, 0.432, 0
1707, 0.76, 0.48, 0
1708, 0.76, 0.528, 0
1709, 0.76, 0.576, 0
1710, 0.76, 0.624, 0
1711, 0.76, 0.672, 0
1712, 0.76, 0.72, 0
1713, 0.76, 0.768, 0
1714, 0.76, 0.816, 0
1715, 0.76, 0.864, 0
1716, 0.76, 0.912, 0
1717, 0.76, 0.96, 0
1718, 0.76, 1.008, 0
1719, 0.76, 1.056, 0
1720, 0.76, 1.104, 0
1721, 0.76, 1.152, 0
1722, 0.8, 0.048, 0
1723, 0.8, 0.096, 0
1724, 0.8, 0.144, 0
1725, 0.8, 0.192, 0
1726, 0.8, 0.24, 0
1727, 0.8, 0.288, 0
1728, 0.8, 0.336, 0
1729, 0.8, 0.384, 0
1730, 0.8, 0.432, 0
1731, 0.8, 0.48, 0
1732, 0.8, 0.528, 0
1733, 0.8, 0.576, 0
1734, 0.8, 0.624, 0
1735, 0.8, 0.672, 0
1736, 0.8, 0.72, 0
1737, 0.8, 0.768, 0
1738, 0.8, 0.816, 0
1739, 0.8, 0.864, 0
1740, 0.8, 0.912, 0
1741, 0.8, 0.96, 0
1742, 0.8, 1.008, 0
1743, 0.8, 1.056, 0
1744, 0.8, 1.104, 0
1745, 0.8, 1.152, 0
1746, 0.84, 0.048, 0
1747, 0.84, 0.096, 0
1748, 0.84, 0.144, 0
1749, 0.84, 0.192, 0
1750, 0.84, 0.24, 0
1751, 0.84, 0.288, 0
1752, 0.84, 0.336, 0
1753, 0.84, 0.384, 0
1754, 0.84, 0.432, 0
1755, 0.84, 0.48, 0
1756, 0.84, 0.528, 0
1757, 0.84, 0.576, 0
1758, 0.84, 0.624, 0
1759, 0.84, 0.672, 0
1760, 0.84, 0.72, 0
1761, 0.84, 0.768, 0
1762, 0.84, 0.816, 0
1763, 0.84, 0.864, 0
1764, 0.84, 0.912, 0
1765, 0.84, 0.96, 0
1766, 0.84, 1.008, 0
1767, 0.84, 1.056, 0
1768, 0.84, 1.104, 0
1769, 0.84, 1.152, 0
1770, 0.88, 0.048, 0
1771, 0.88, 0.096, 0
1772, 0.88, 0.144, 0
1773, 0.88, 0.192, 0
1774, 0.88, 0.24, 0
1775, 0.88, 0.288, 0
1776, 0.88, 0.336, 0
1777, 0.88, 0.384, 0
1778, 0.88, 0.432, 0
1779, 0.88, 0.48, 0
1780, 0.88, 0.528, 0
1781, 0.88, 0.576, 0
1782, 0.88, 0.624, 0
1783, 0.88, 0.672, 0
1784, 0.88, 0.72, 0
1785, 0.88, 0.768, 0
1786, 0.88, 0.816, 0
1787, 0.88, 0.864, 0
1788, 0.88, 0.912, 0
1789, 0.88, 0.96, 0
1790, 0.88, 1.008, 0
1791, 0.88, 1.056, 0
1792, 0.88, 1.104, 0
1793, 0.88, 1.152, 0
1794, 0.92, 0.048, 0
1795, 0.92, 0.096, 0
1796, 0.92, 0.144, 0
1797, 0.92, 0.192, 0
1798, 0.92, 0.24, 0
1799, 0.92, 0.288, 0
1800, 0.92, 0.336, 0
1801, 0.92, 0.384, 0
1802, 0.92, 0.432, 0
1803, 0.92, 0.48, 0
1804, 0.92, 0.528, 0
1805, 0.92, 0.576, 0
1806, 0.92, 0.624, 0
1807, 0.92, 0.672, 0
1808, 0.92, 0.72, 0
1809, 0.92, 0.768, 0
1810, 0.92, 0.816, 0
1811, 0.92, 0.864, 0
1812, 0.92, 0.912, 0
1813, 0.92, 0.96, 0
1814, 0.92, 1.008, 0
1815, 0.92, 1.056, 0
1816, 0.92, 1.104, 0
1817, 0.92, 1.152, 0
1818, 0.96, 0.048, 0
1819, 0.96, 0.096, 0
1820, 0.96, 0.144, 0
1821, 0.96, 0.192, 0
1822, 0.96, 0.24, 0
1823, 0.96, 0.288, 0
1824, 0.96, 0.336, 0
1825, 0.96, 0.384, 0
1826, 0.96, 0.432, 0
1827, 0.96, 0.48, 0
1828, 0.96, 0.528, 0
1829, 0.96, 0.576, 0
1830, 0.96, 0.624, 0
1831, 0.96, 0.672, 0
1832, 0.96, 0.72, 0
1833, 0.96, 0.768, 0
1834, 0.96, 0.816, 0
1835, 0.96, 0.864, 0
1836, 0.96, 0.912, 0
1837, 0.96, 0.96, 0
1838, 0.96, 1.008, 0
1839, 0.96, 1.056, 0
1840, 0.96, 1.104, 0
1841, 0.96, 1.152, 0
1842, 0.04, 0.024, 0
1843, 0.02, 0.048, 0
1844, 0.04, 0.072, 0
1845, 0.02, 0.096, 0
1846, 0.04, 0.12, 0
1847, 0.02, 0.144, 0
1848, 0.04, 0.168, 0
1849, 0.02, 0.192, 0
1850, 0.04, 0.216, 0
1851, 0.02, 0.24, 0
1852, 0.04, 0.264, 0
1853, 0.02, 0.288, 0
1854, 0.04, 0.312, 0
1855, 0.02, 0.336, 0
1856, 0.04, 0.36, 0
1857, 0.02, 0.384, 0
1858, 0.04, 0.408, 0
1859, 0.02, 0.432, 0
1860, 0.04, 0.456, 0
1861, 0.02, 0.48, 0
1862, 0.04, 0.504, 0
1863, 0.02, 0.528, 0
1864, 0.04, 0.552, 0
1865, 0.02, 0.576, 0
1866, 0.04, 0.6, 0
1867, 0.02, 0.624, 0
1868, 0.04, 0.648, 0
1869, 0.02, 0.672, 0
1870, 0.04, 0.696, 0
1871, 0.02, 0.72, 0
1872, 0.04, 0.744, 0
1873, 0.02, 0.768, 0
1874, 0.04, 0.792, 0
1875, 0.02, 0.816, 0
1876, 0.04, 0.84, 0
1877, 0.02, 0.864, 0
1878, 0.04, 0.888, 0
1879, 0.02, 0.912, 0
1880, 0.04, 0.936, 0
1881, 0.02, 0.96, 0
1882, 0.04, 0.984, 0
1883, 0.02, 1.008, 0
1884, 0.04, 1.032, 0
1885, 0.02, 1.056, 0
1886, 0.04, 1.08, 0
1887, 0.02, 1.104, 0
1888, 0.04, 1.128, 0
1889, 0.02, 1.152, 0
1890, 0.04, 1.176, 0
1891, 0.08, 0.024, 0
1892, 0.06, 0.048, 0
1893, 0.08, 0.072, 0
1894, 0.06, 0.096, 0
1895, 0.08, 0.12, 0
1896, 0.06, 0.144, 0
1897, 0.08, 0.168, 0
1898, 0.06, 0.192, 0
1899, 0.08, 0.216, 0
1900, 0.06, 0.24, 0
1901, 0.08, 0.264, 0
1902, 0.06, 0.288, 0
1903, 0.08, 0.312, 0
1904, 0.06, 0.336, 0
1905, 0.08, 0.36, 0
1906, 0.06, 0.384, 0
1907, 0.08, 0.408, 0
1908, 0.06, 0.432, 0
1909, 0.08, 0.456, 0
1910, 0.06, 0.48, 0
1911, 0.08, 0.504, 0
1912, 0.06, 0.528, 0
1913, 0.08, 0.552, 0
1914, 0.06, 0.576, 0
1915, 0.08, 0.6, 0
1916, 0.06, 0.624, 0
1917, 0.08, 0.648, 0
1918, 0.06, 0.672, 0
1919, 0.08, 0.696, 0
1920, 0.06, 0.72, 0
1921, 0.08, 0.744, 0
1922, 0.06, 0.768, 0
1923, 0.08, 0.792, 0
1924, 0.06, 0.816, 0
1925, 0.08, 0.84, 0
1926, 0.06, 0.864, 0
1927, 0.08, 0.888, 0
1928, 0.06, 0.912, 0
1929, 0.08, 0.936, 0
1930, 0.06, 0.96, 0
1931, 0.08, 0.984, 0
1932, 0.06, 1.008, 0
1933, 0.08, 1.032, 0
1934, 0.06, 1.056, 0
1935, 0.08, 1.08, 0
1936, 0.06, 1.104, 0
1937, 0.08, 1.128, 0
1938, 0.06, 1.152, 0
1939, 0.08, 1.176, 0
1940, 0.12, 0.024, 0
1941, 0.1, 0.048, 0
1942, 0.12, 0.072, 0
1943, 0.1, 0.096, 0
1944, 0.12, 0.12, 0
1945, 0.1, 0.144, 0
1946, 0.12, 0.168, 0
1947, 0.1, 0.192, 0
1948, 0.12, 0.216, 0
1949, 0.1, 0.24, 0
1950, 0.12, 0.264, 0
1951, 0.1, 0.288, 0
1952, 0.12, 0.312, 0
1953, 0.1, 0.336, 0
1954, 0.12, 0.36, 0
1955, 0.1, 0.384, 0
1956, 0.12, 0.408, 0
1957, 0.1, 0.432, 0
1958, 0.12, 0.456, 0
1959, 0.1, 0.48, 0
1960, 0.12, 0.504, 0
1961, 0.1, 0.528, 0
1962, 0.12, 0.552, 0
1963, 0.1, 0.576, 0
1964, 0.12, 0.6, 0
1965, 0.1, 0.624, 0
1966, 0.12, 0.648, 0
1967, 0.1, 0.672, 0
1968, 0.12, 0.696, 0
1969, 0.1, 0.72, 0
1970, 0.12, 0.744, 0
1971, 0.1, 0.768, 0
1972, 0.12, 0.792, 0
1973, 0.1, 0.816, 0
1974, 0.12, 0.84, 0
1975, 0.1, 0.864, 0
1976, 0.12, 0.888, 0
1977, 0.1, 0.912, 0
1978, 0.12, 0.936, 0
1979, 0.1, 0.96, 0
1980, 0.12, 0.984, 0
1981, 0.1, 1.008, 0
1982, 0.12, 1.032, 0
1983, 0.1, 1.056, 0
1984, 0.12, 1.08, 0
1985, 0.1, 1.104, 0
1986, 0.12, 1.128, 0
1987, 0.1, 1.152, 0
1988, 0.12, 1.176, 0
1989, 0.16, 0.024, 0
1990, 0.14, 0.048, 0
1991, 0.16, 0.072, 0
1992, 0.14, 0.096, 0
1993, 0.16, 0.12, 0
1994, 0.14, 0.144, 0
1995, 0.16, 0.168, 0
1996, 0.14, 0.192, 0
1997, 0.16, 0.216, 0
1998, 0.14, 0.24, 0
1999, 0.16, 0.264, 0
2000, 0.14, 0.288, 0
2001, 0.16, 0.312, 0
2002, 0.14, 0.336, 0
2003, 0.16, 0.36, 0
2004, 0.14, 0.384, 0
2005, 0.16, 0.408, 0
2006, 0.14, 0.432, 0
2007, 0.16, 0.456, 0
2008, 0.14, 0.48, 0
2009, 0.16, 0.504, 0
2010, 0.14, 0.528, 0
2011, 0.16, 0.552, 0
2012, 0.14, 0.576, 0
2013, 0.16, 0.6, 0
2014, 0.14, 0.624, 0
2015, 0.16, 0.648, 0
2016, 0.14, 0.672, 0
2017, 0.16, 0.696, 0
2018, 0.14, 0.72, 0
2019, 0.16, 0.744, 0
2020, 0.14, 0.768, 0
2021, 0.16, 0.792, 0
2022, 0.14, 0.816, 0
2023, 0.16, 0.84, 0
2024, 0.14, 0.864, 0
2025, 0.16, 0.888, 0
2026, 0.14, 0.912, 0
2027, 0.16, 0.936, 0
2028, 0.14, 0.96, 0
2029, 0.16, 0.984, 0
2030, 0.14, 1.008, 0
2031, 0.16, 1.032, 0
2032, 0.14, 1.056, 0
2033, 0.16, 1.08, 0
2034, 0.14, 1.104, 0
2035, 0.16, 1.128, 0
2036, 0.14, 1.152, 0
2037, 0.16, 1.176, 0
2038, 0.2, 0.024, 0
2039, 0.18, 0.048, 0
2040, 0.2, 0.072, 0
2041, 0.18, 0.096, 0
2042, 0.2, 0.12, 0
2043, 0.18, 0.144, 0
2044, 0.2, 0.168, 0
2045, 0.18, 0.192, 0
2046, 0.2, 0.216, 0
2047, 0.18, 0.24, 0
2048, 0.2, 0.264, 0
2049, 0.18, 0.288, 0
2050, 0.2, 0.312, 0
2051, 0.18, 0.336, 0
2052, 0.2, 0.36, 0
2053, 0.18, 0.384, 0
2054, 0.2, 0.408, 0
2055, 0.18, 0.432, 0
2056, 0.2, 0.456, 0
2057, 0.18, 0.48, 0
2058, 0.2, 0.504, 0
2059, 0.18, 0.528, 0
2060, 0.2, 0.552, 0
2061, 0.18, 0.576, 0
2062, 0.2, 0.6, 0
2063, 0.18, 0.624, 0
2064, 0.2, 0.648, 0
2065, 0.18, 0.672, 0
2066, 0.2, 0.696, 0
2067, 0.18, 0.72, 0
2068, 0.2, 0.744, 0
2069, 0.18, 0.768, 0
2070, 0.2, 0.792, 0
2071, 0.18, 0.816, 0
2072, 0.2, 0.84, 0
2073, 0.18, 0.864, 0
2074, 0.2, 0.888, 0
2075, 0.18, 0.912, 0
2076, 0.2, 0.936, 0
2077, 0.18, 0.96, 0
2078, 0.2, 0.984, 0
2079, 0.18, 1.008, 0
2080, 0.2, 1.032, 0
2081, 0.18, 1.056, 0
2082, 0.2, 1.08, 0
2083, 0.18, 1.104, 0
2084, 0.2, 1.128, 0
2085, 0.18, 1.152, 0
2086, 0.2, 1.176, 0
2087, 0.24, 0.024, 0
2088, 0.22, 0.048, 0
2089, 0.24, 0.072, 0
2090, 0.22, 0.096, 0
2091, 0.24, 0.12, 0
2092, 0.22, 0.144, 0
2093, 0.24, 0.168, 0
2094, 0.22, 0.192, 0
2095, 0.24, 0.216, 0
2096, 0.22, 0.24, 0
2097, 0.24, 0.264, 0
2098, 0.22, 0.288, 0
2099, 0.24, 0.312, 0
2100, 0.22, 0.336, 0
2101, 0.24, 0.36, 0
2102, 0.22, 0.384, 0
2103, 0.24, 0.408, 0
2104, 0.22, 0.432, 0
2105, 0.24, 0.456, 0
2106, 0.22, 0.48, 0
2107, 0.24, 0.504, 0
2108, 0.22, 0.528, 0
2109, 0.24, 0.552, 0
2110, 0.22, 0.576, 0
2111, 0.24, 0.6, 0
2112, 0.22, 0.624, 0
2113, 0.24, 0.648, 0
2114, 0.22, 0.672, 0
2115, 0.24, 0.696, 0
2116, 0.22, 0.72, 0
2117, 0.24, 0.744, 0
2118, 0.22, 0.768, 0
2119, 0.24, 0.792, 0
2120, 0.22, 0.816, 0
2121, 0.24, 0.84, 0
2122, 0.22, 0.864, 0
2123, 0.24, 0.888, 0
2124, 0.22, 0.912, 0
2125, 0.24, 0.936, 0
2126, 0.22, 0.96, 0
2127, 0.24, 0.984, 0
2128, 0.22, 1.008, 0
2129, 0.24, 1.032, 0
2130, 0.22, 1.056, 0
2131, 0.24, 1.08, 0
2132, 0.22, 1.104, 0
2133, 0.24, 1.128, 0
2134, 0.22, 1.152, 0
2135, 0.24, 1.176, 0
2136, 0.28, 0.024, 0
2137, 0.26, 0.048, 0
2138, 0.28, 0.072, 0
2139, 0.26, 0.096, 0
2140, 0.28, 0.12, 0
2141, 0.26, 0.144, 0
2142, 0.28, 0.168, 0
2143, 0.26, 0.192, 0
2144, 0.28, 0.216, 0
2145, 0.26, 0.24, 0
2146, 0.28, 0.264, 0
2147, 0.26, 0.288, 0
2148, 0.28, 0.312, 0
2149, 0.26, 0.336, 0
2150, 0.28, 0.36, 0
2151, 0.26, 0.384, 0
2152, 0.28, 0.408, 0
2153, 0.26, 0.432, 0
2154, 0.28, 0.456, 0
2155, 0.26, 0.48, 0
2156, 0.28, 0.504, 0
2157, 0.26, 0.528, 0
2158, 0.28, 0.552, 0
2159, 0.26, 0.576, 0
2160, 0.28, 0.6, 0
2161, 0.26, 0.624, 0
2162, 0.28, 0.648, 0
2163, 0.26, 0.672, 0
2164, 0.28, 0.696, 0
2165, 0.26, 0.72, 0
2166, 0.28, 0.744, 0
2167, 0.26, 0.768, 0
2168, 0.28, 0.792, 0
2169, 0.26, 0.816, 0
2170, 0.28, 0.84, 0
2171, 0.26, 0.864, 0
2172, 0.28, 0.888, 0
2173, 0.26, 0.912, 0
2174, 0.28, 0.936, 0
2175, 0.26, 0.96, 0
2176, 0.28, 0.984, 0
2177, 0.26, 1.008, 0
2178, 0.28, 1.032, 0
2179, 0.26, 1.056, 0
2180, 0.28, 1.08, 0
2181, 0.26, 1.104, 0
2182, 0.28, 1.128, 0
2183, 0.26, 1.152, 0
2184, 0.28, 1.176, 0
2185, 0.32, 0.024, 0
2186, 0.3, 0.048, 0
2187, 0.32, 0.072, 0
2188, 0.3, 0.096, 0
2189, 0.32, 0.12, 0
2190, 0.3, 0.144, 0
2191, 0.32, 0.168, 0
2192, 0.3, 0.192, 0
2193, 0.32, 0.216, 0
2194, 0.3, 0.24, 0
2195, 0.32, 0.264, 0
2196, 0.3, 0.288, 0
2197, 0.32, 0.312, 0
2198, 0.3, 0.336, 0
2199, 0.32, 0.36, 0
2200, 0.3, 0.384, 0
2201, 0.32, 0.408, 0
2202, 0.3, 0.432, 0
2203, 0.32, 0.456, 0
2204, 0.3, 0.48, 0
2205, 0.32, 0.504, 0
2206, 0.3, 0.528, 0
2207, 0.32, 0.552, 0
2208, 0.3, 0.576, 0
2209, 0.32, 0.6, 0
2210, 0.3, 0.624, 0
2211, 0.32, 0.648, 0
2212, 0.3, 0.672, 0
2213, 0.32, 0.696, 0
2214, 0.3, 0.72, 0
2215, 0.32, 0.744, 0
2216, 0.3, 0.768, 0
2217, 0.32, 0.792, 0
2218, 0.3, 0.816, 0
2219, 0.32, 0.84, 0
2220, 0.3, 0.864, 0
2221, 0.32, 0.888, 0
2222, 0.3, 0.912, 0
2223, 0.32, 0.936, 0
2224, 0.3, 0.96, 0
2225, 0.32, 0.984, 0
2226, 0.3, 1.008, 0
2227, 0.32, 1.032, 0
2228, 0.3, 1.056, 0
2229, 0.32, 1.08, 0
2230, 0.3, 1.104, 0
2231, 0.32, 1.128, 0
2232, 0.3, 1.152, 0
2233, 0.32, 1.176, 0
2234, 0.36, 0.024, 0
2235, 0.34, 0.048, 0
2236, 0.36, 0.072, 0
2237, 0.34, 0.096, 0
2238, 0.36, 0.12, 0
2239, 0.34, 0.144, 0
2240, 0.36, 0.168, 0
2241, 0.34, 0.192, 0
2242, 0.36, 0.216, 0
2243, 0.34, 0.24, 0
2244, 0.36, 0.264, 0
2245, 0.34, 0.288, 0
2246, 0.36, 0.312, 0
2247, 0.34, 0.336, 0
2248, 0.36, 0.36, 0
2249, 0.34, 0.384, 0
2250, 0.36, 0.408, 0
2251, 0.34, 0.432, 0
2252, 0.36, 0.456, 0
2253, 0.34, 0.48, 0
2254, 0.36, 0.504, 0
2255, 0.34, 0.528, 0
2256, 0.36, 0.552, 0
2257, 0.34, 0.576, 0
2258, 0.36, 0.6, 0
2259, 0.34, 0.624, 0
2260, 0.36, 0.648, 0
2261, 0.34, 0.672, 0
2262, 0.36, 0.696, 0
2263, 0.34, 0.72, 0
2264, 0.36, 0.744, 0
2265, 0.34, 0.768, 0
2266, 0.36, 0.792, 0
2267, 0.34, 0.816, 0
2268, 0.36, 0.84, 0
2269, 0.34, 0.864, 0
2270, 0.36, 0.888, 0
2271, 0.34, 0.912, 0
2272, 0.36, 0.936, 0
2273, 0.34, 0.96, 0
2274, 0.36, 0.984, 0
2275, 0.34, 1.008, 0
2276, 0.36, 1.032, 0
2277, 0.34, 1.056, 0
2278, 0.36, 1.08, 0
2279, 0.34, 1.104, 0
2280, 0.36, 1.128, 0
2281, 0.34, 1.152, 0
2282, 0.36, 1.176, 0
2283, 0.4, 0.024, 0
2284, 0.38, 0.048, 0
2285, 0.4, 0.072, 0
2286, 0.38, 0.096, 0
2287, 0.4, 0.12, 0
2288, 0.38, 0.144, 0
2289, 0.4, 0.168, 0
2290, 0.38, 0.192, 0
2291, 0.4, 0.216, 0
2292, 0.38, 0.24, 0
2293, 0.4, 0.264, 0
2294, 0.38, 0.288, 0
2295, 0.4, 0.312, 0
2296, 0.38, 0.336, 0
2297, 0.4, 0.36, 0
2298, 0.38, 0.384, 0
2299, 0.4, 0.408, 0
2300, 0.38, 0.432, 0
2301, 0.4, 0.456, 0
2302, 0.38, 0.48, 0
2303, 0.4, 0.504, 0
2304, 0.38, 0.528, 0
2305, 0.4, 0.552, 0
2306, 0.38, 0.576, 0
2307, 0.4, 0.6, 0
2308, 0.38, 0.624, 0
2309, 0.4, 0.648, 0
2310, 0.38, 0.672, 0
2311, 0.4, 0.696, 0
2312, 0.38, 0.72, 0
2313, 0.4, 0.744, 0
2314, 0.38, 0.768, 0
2315, 0.4, 0.792, 0
2316, 0.38, 0.816, 0
2317, 0.4, 0.84, 0
2318, 0.38, 0.864, 0
2319, 0.4, 0.888, 0
2320, 0.38, 0.912, 0
2321, 0.4, 0.936, 0
2322, 0.38, 0.96, 0
2323, 0.4, 0.984, 0
2324, 0.38, 1.008, 0
2325, 0.4, 1.032, 0
2326, 0.38, 1.056, 0
2327, 0.4, 1.08, 0
2328, 0.38, 1.104, 0
2329, 0.4, 1.128, 0
2330, 0.38, 1.152, 0
2331, 0.4, 1.176, 0
2332, 0.44, 0.024, 0
2333, 0.42, 0.048, 0
2334, 0.44, 0.072, 0
2335, 0.42, 0.096, 0
2336, 0.44, 0.12, 0
2337, 0.42, 0.144, 0
2338, 0.44, 0.168, 0
2339, 0.42, 0.192, 0
2340, 0.44, 0.216, 0
2341, 0.42, 0.24, 0
2342, 0.44, 0.264, 0
2343, 0.42, 0.288, 0
2344, 0.44, 0.312, 0
2345, 0.42, 0.336, 0
2346, 0.44, 0.36, 0
2347, 0.42, 0.384, 0
2348, 0.44, 0.408, 0
2349, 0.42, 0.432, 0
2350, 0.44, 0.456, 0
2351, 0.42, 0.48, 0
2352, 0.44, 0.504, 0
2353, 0.42, 0.528, 0
2354, 0.44, 0.552, 0
2355, 0.42, 0.576, 0
2356, 0.44, 0.6, 0
2357, 0.42, 0.624, 0
2358, 0.44, 0.648, 0
2359, 0.42, 0.672, 0
2360, 0.44, 0.696, 0
2361, 0.42, 0.72, 0
2362, 0.44, 0.744, 0
2363, 0.42, 0.768, 0
2364, 0.44, 0.792, 0
2365, 0.42, 0.816, 0
2366, 0.44, 0.84, 0
2367, 0.42, 0.864, 0
2368, 0.44, 0.888, 0
2369, 0.42, 0.912, 0
2370, 0.44, 0.936, 0
2371, 0.42, 0.96, 0
2372, 0.44, 0.984, 0
2373, 0.42, 1.008, 0
2374, 0.44, 1.032, 0
2375, 0.42, 1.056, 0
2376, 0.44, 1.08, 0
2377, 0.42, 1.104, 0
2378, 0.44, 1.128, 0
2379, 0.42, 1.152, 0
2380, 0.44, 1.176, 0
2381, 0.48, 0.024, 0
2382, 0.46, 0.048, 0
2383, 0.48, 0.072, 0
2384, 0.46, 0.096, 0
2385, 0.48, 0.12, 0
2386, 0.46, 0.144, 0
2387, 0.48, 0.168, 0
2388, 0.46, 0.192, 0
2389, 0.48, 0.216, 0
2390, 0.46, 0.24, 0
2391, 0.48, 0.264, 0
2392, 0.46, 0.288, 0
2393, 0.48, 0.312, 0
2394, 0.46, 0.336, 0
2395, 0.48, 0.36, 0
2396, 0.46, 0.384, 0
2397, 0.48, 0.408, 0
2398, 0.46, 0.432, 0
2399, 0.48, 0.456, 0
2400, 0.46, 0.48, 0
2401, 0.48, 0.504, 0
2402, 0.46, 0.528, 0
2403, 0.48, 0.552, 0
2404, 0.46, 0.576, 0
2405, 0.48, 0.6, 0
2406, 0.46, 0.624, 0
2407, 0.48, 0.648, 0
2408, 0.46, 0.672, 0
2409, 0.48, 0.696, 0
2410, 0.46, 0.72, 0
2411, 0.48, 0.744, 0
2412, 0.46, 0.768, 0
2413, 0.48, 0.792, 0
2414, 0.46, 0.816, 0
2415, 0.48, 0.84, 0
2416, 0.46, 0.864, 0
2417, 0.48, 0.888, 0
2418, 0.46, 0.912, 0
2419, 0.48, 0.936, 0
2420, 0.46, 0.96, 0
2421, 0.48, 0.984, 0
2422, 0.46, 1.008, 0
2423, 0.48, 1.032, 0
2424, 0.46, 1.056, 0
2425, 0.48, 1.08, 0
2426, 0.46, 1.104, 0
2427, 0.48, 1.128, 0
2428, 0.46, 1.152, 0
2429, 0.48, 1.176, 0
2430, 0.52, 0.024, 0
2431, 0.5, 0.048, 0
2432, 0.52, 0.072, 0
2433, 0.5, 0.096, 0
2434, 0.52, 0.12, 0
2435, 0.5, 0.144, 0
2436, 0.52, 0.168, 0
2437, 0.5, 0.192, 0
2438, 0.52, 0.216, 0
2439, 0.5, 0.24, 0
2440, 0.52, 0.264, 0
2441, 0.5, 0.288, 0
2442, 0.52, 0.312, 0
2443, 0.5, 0.336, 0
2444, 0.52, 0.36, 0
2445, 0.5, 0.384, 0
2446, 0.52, 0.408, 0
2447, 0.5, 0.432, 0
2448, 0.52, 0.456, 0
2449, 0.5, 0.48, 0
2450, 0.52, 0.504, 0
2451, 0.5, 0.528, 0
2452, 0.52, 0.552, 0
2453, 0.5, 0.576, 0
2454, 0.52, 0.6, 0
2455, 0.5, 0.624, 0
2456, 0.52, 0.648, 0
2457, 0.5, 0.672, 0
2458, 0.52, 0.696, 0
2459, 0.5, 0.72, 0
2460, 0.52, 0.744, 0
2461, 0.5, 0.768, 0
2462, 0.52, 0.792, 0
2463, 0.5, 0.816, 0
2464, 0.52, 0.84, 0
2465, 0.5, 0.864, 0
2466, 0.52, 0.888, 0
2467, 0.5, 0.912, 0
2468, 0.52, 0.936, 0
2469, 0.5, 0.96, 0
2470, 0.52, 0.984, 0
2471, 0.5, 1.008, 0
2472, 0.52, 1.032, 0
2473, 0.5, 1.056, 0
2474, 0.52, 1.08, 0
2475, 0.5, 1.104, 0
2476, 0.52, 1.128, 0
2477, 0.5, 1.152, 0
2478, 0.52, 1.176, 0
2479, 0.56, 0.024, 0
2480, 0.54, 0.048, 0
2481, 0.56, 0.072, 0
2482, 0.54, 0.096, 0
2483, 0.56, 0.12, 0
2484, 0.54, 0.144, 0
2485, 0.56, 0.168, 0
2486, 0.54, 0.192, 0
2487, 0.56, 0.216, 0
2488, 0.54, 0.24, 0
2489, 0.56, 0.264, 0
2490, 0.54, 0.288, 0
2491, 0.56, 0.312, 0
2492, 0.54, 0.336, 0
2493, 0.56, 0.36, 0
2494, 0.54, 0.384, 0
2495, 0.56, 0.408, 0
2496, 0.54, 0.432, 0
2497, 0.56, 0.456, 0
2498, 0.54, 0.48, 0
2499, 0.56, 0.504, 0
2500, 0.54, 0.528, 0
2501, 0.56, 0.552, 0
2502, 0.54, 0.576, 0
2503, 0.56, 0.6, 0
2504, 0.54, 0.624, 0
2505, 0.56, 0.648, 0
2506, 0.54, 0.672, 0
2507, 0.56, 0.696, 0
2508, 0.54, 0.72, 0
2509, 0.56, 0.744, 0
2510, 0.54, 0.768, 0
2511, 0.56, 0.792, 0
2512, 0.54, 0.816, 0
2513, 0.56, 0.84, 0
2514, 0.54, 0.864, 0
2515, 0.56, 0.888, 0
2516, 0.54, 0.912, 0
2517, 0.56, 0.936, 0
2518, 0.54, 0.96, 0
2519, 0.56, 0.984, 0
2520, 0.54, 1.008, 0
2521, 0.56, 1.032, 0
2522, 0.54, 1.056, 0
2523, 0.56, 1.08, 0
2524, 0.54, 1.104, 0
2525, 0.56, 1.128, 0
2526, 0.54, 1.152, 0
2527, 0.56, 1.176, 0
2528, 0.6, 0.024, 0
2529, 0.58, 0.048, 0
2530, 0.6, 0.072, 0
2531, 0.58, 0.096, 0
2532, 0.6, 0.12, 0
2533, 0.58, 0.144, 0
2534, 0.6, 0.168, 0
2535, 0.58, 0.192, 0
2536, 0.6, 0.216, 0
2537, 0.58, 0.24, 0
2538, 0.6, 0.264, 0
2539, 0.58, 0.288, 0
2540, 0.6, 0.312, 0
2541, 0.58, 0.336, 0
2542, 0.6, 0.36, 0
2543, 0.58, 0.384, 0
2544, 0.6, 0.408, 0
2545, 0.58, 0.432, 0
2546, 0.6, 0.456, 0
2547, 0.58, 0.48, 0
2548, 0.6, 0.504, 0
2549, 0.58, 0.528, 0
2550, 0.6, 0.552, 0
2551, 0.58, 0.576, 0
2552, 0.6, 0.6, 0
2553, 0.58, 0.624, 0
2554, 0.6, 0.648, 0
2555, 0.58, 0.672, 0
2556, 0.6, 0.696, 0
2557, 0.58, 0.72, 0
2558, 0.6, 0.744, 0
2559, 0.58, 0.768, 0
2560, 0.6, 0.792, 0
2561, 0.58, 0.816, 0
2562, 0.6, 0.84, 0
2563, 0.58, 0.864, 0
2564, 0.6, 0.888, 0
2565, 0.58, 0.912, 0
2566, 0.6, 0.936, 0
2567, 0.58, 0.96, 0
2568, 0.6, 0.984, 0
2569, 0.58, 1.008, 0
2570, 0.6, 1.032, 0
2571, 0.58, 1.056, 0
2572, 0.6, 1.08, 0
2573, 0.58, 1.104, 0
2574, 0.6, 1.128, 0
2575, 0.58, 1.152, 0
2576, 0.6, 1.176, 0
2577, 0.64, 0.024, 0
2578, 0.62, 0.048, 0
2579, 0.64, 0.072, 0
2580, 0.62, 0.096, 0
2581, 0.64, 0.12, 0
2582, 0.62, 0.144, 0
2583, 0.64, 0.168, 0
2584, 0.62, 0.192, 0
2585, 0.64, 0.216, 0
2586, 0.62, 0.24, 0
2587, 0.64, 0.264, 0
2588, 0.62, 0.288, 0
2589, 0.64, 0.312, 0
2590, 0.62, 0.336, 0
2591, 0.64, 0.36, 0
2592, 0.62, 0.384, 0
2593, 0.64, 0.408, 0
2594, 0.62, 0.432, 0
2595, 0.64, 0.456, 0
2596, 0.62, 0.48, 0
2597, 0.64, 0.504, 0
2598, 0.62, 0.528, 0
2599, 0.64, 0.552, 0
2600, 0.62, 0.576, 0
2601, 0.64, 0.6, 0
2602, 0.62, 0.624, 0
2603, 0.64, 0.648, 0
2604, 0.62, 0.672, 0
2605, 0.64, 0.696, 0
2606, 0.62, 0.72, 0
2607, 0.64, 0.744, 0
2608, 0.62, 0.768, 0
2609, 0.64, 0.792, 0
2610, 0.62, 0.816, 0
2611, 0.64, 0.84, 0
2612, 0.62, 0.864, 0
2613, 0.64, 0.888, 0
2614, 0.62, 0.912, 0
2615, 0.64, 0.936, 0
2616, 0.62, 0.96, 0
2617, 0.64, 0.984, 0
2618, 0.62, 1.008, 0
2619, 0.64, 1.032, 0
2620, 0.62, 1.056, 0
2621, 0.64, 1.08, 0
2622, 0.62, 1.104, 0
2623, 0.64, 1.128, 0
2624, 0.62, 1.152, 0
2625, 0.64, 1.176, 0
2626, 0.68, 0.024, 0
2627, 0.66, 0.048, 0
2628, 0.68, 0.072, 0
2629, 0.66, 0.096, 0
2630, 0.68, 0.12, 0
2631, 0.66, 0.144, 0
2632, 0.68, 0.168, 0
2633, 0.66, 0.192, 0
2634, 0.68, 0.216, 0
2635, 0.66, 0.24, 0
2636, 0.68, 0.264, 0
2637, 0.66, 0.288, 0
2638, 0.68, 0.312, 0
2639, 0.66, 0.336, 0
2640, 0.68, 0.36, 0
2641, 0.66, 0.384, 0
2642, 0.68, 0.408, 0
2643, 0.66, 0.432, 0
2644, 0.68, 0.456, 0
2645, 0.66, 0.48, 0
2646, 0.68, 0.504, 0
2647, 0.66, 0.528, 0
2648, 0.68, 0.552, 0
2649, 0.66, 0.576, 0
2650, 0.68, 0.6, 0
2651, 0.66, 0.624, 0
2652, 0.68, 0.648, 0
2653, 0.66, 0.672, 0
2654, 0.68, 0.696, 0
2655, 0.66, 0.72, 0
2656, 0.68, 0.744, 0
2657, 0.66, 0.768, 0
2658, 0.68, 0.792, 0
2659, 0.66, 0.816, 0
2660, 0.68, 0.84, 0
2661, 0.66, 0.864, 0
2662, 0.68, 0.888, 0
2663, 0.66, 0.912, 0
2664, 0.68, 0.936, 0
2665, 0.66, 0.96, 0
2666, 0.68, 0.984, 0
2667, 0.66, 1.008, 0
2668, 0.68, 1.032, 0
2669, 0.66, 1.056, 0
2670, 0.68, 1.08, 0
2671, 0.66, 1.104, 0
2672, 0.68, 1.128, 0
2673, 0.66, 1.152, 0
2674, 0.68, 1.176, 0
2675, 0.72, 0.024, 0
2676, 0.7, 0.048, 0
2677, 0.72, 0.072, 0
2678, 0.7, 0.096, 0
2679, 0.72, 0.12, 0
2680, 0.7, 0.144, 0
2681, 0.72, 0.168, 0
2682, 0.7, 0.192, 0
2683, 0.72, 0.216, 0
2684, 0.7, 0.24, 0
2685, 0.72, 0.264, 0
2686, 0.7, 0.288, 0
2687, 0.72, 0.312, 0
2688, 0.7, 0.336, 0
2689, 0.72, 0.36, 0
2690, 0.7, 0.384, 0
2691, 0.72, 0.408, 0
2692, 0.7, 0.432, 0
2693, 0.72, 0.456, 0
2694, 0.7, 0.48, 0
2695, 0.72, 0.504, 0
2696, 0.7, 0.528, 0
2697, 0.72, 0.552, 0
2698, 0.7, 0.576, 0
2699, 0.72, 0.6, 0
2700, 0.7, 0.624, 0
2701, 0.72, 0.648, 0
2702, 0.7, 0.672, 0
2703, 0.72, 0.696, 0
2704, 0.7, 0.72, 0
2705, 0.72, 0.744, 0
2706, 0.7, 0.768, 0
2707, 0.72, 0.792, 0
2708, 0.7, 0.816, 0
2709, 0.72, 0.84, 0
2710, 0.7, 0.864, 0
2711, 0.72, 0.888, 0
2712, 0.7, 0.912, 0
2713, 0.72, 0.936, 0
2714, 0.7, 0.96, 0
2715, 0.72, 0.984, 0
2716, 0.7, 1.008, 0
2717, 0.72, 1.032, 0
2718, 0.7, 1.056, 0
2719, 0.72, 1.08, 0
2720, 0.7, 1.104, 0
2721, 0.72, 1.128, 0
2722, 0.7, 1.152, 0
2723, 0.72, 1.176, 0
2724, 0.76, 0.024, 0
2725, 0.74, 0.048, 0
2726, 0.76, 0.072, 0
2727, 0.74, 0.096, 0
2728, 0.76, 0.12, 0
2729, 0.74, 0.144, 0
2730, 0.76, 0.168, 0
2731, 0.74, 0.192, 0
2732, 0.76, 0.216, 0
2733, 0.74, 0.24, 0
2734, 0.76, 0.264, 0
2735, 0.74, 0.288, 0
2736, 0.76, 0.312, 0
2737, 0.74, 0.336, 0
2738, 0.76, 0.36, 0
2739, 0.74, 0.384, 0
2740, 0.76, 0.408, 0
2741, 0.74, 0.432, 0
2742, 0.76, 0.456, 0
2743, 0.74, 0.48, 0
2744, 0.76, 0.504, 0
2745, 0.74, 0.528, 0
2746, 0.76, 0.552, 0
2747, 0.74, 0.576, 0
2748, 0.76, 0.6, 0
2749, 0.74, 0.624, 0
2750, 0.76, 0.648, 0
2751, 0.74, 0.672, 0
2752, 0.76, 0.696, 0
2753, 0.74, 0.72, 0
2754, 0.76, 0.744, 0
2755, 0.74, 0.768, 0
2756, 0.76, 0.792, 0
2757, 0.74, 0.816, 0
2758, 0.76, 0.84, 0
2759, 0.74, 0.864, 0
2760, 0.76, 0.888, 0
2761, 0.74, 0.912, 0
2762, 0.76, 0.936, 0
2763, 0.74, 0.96, 0
2764, 0.76, 0.984, 0
2765, 0.74, 1.008, 0
2766, 0.76, 1.032, 0
2767, 0.74, 1.056, 0
2768, 0.76, 1.08, 0
2769, 0.74, 1.104, 0
2770, 0.76, 1.128, 0
2771, 0.74, 1.152, 0
2772, 0.76, 1.176, 0
2773, 0.8, 0.024, 0
2774, 0.78, 0.048, 0
2775, 0.8, 0.072, 0
2776, 0.78, 0.096, 0
2777, 0.8, 0.12, 0
2778, 0.78, 0.144, 0
2779, 0.8, 0.168, 0
2780, 0.78, 0.192, 0
2781, 0.8, 0.216, 0
2782, 0.78, 0.24, 0
2783, 0.8, 0.264, 0
2784, 0.78, 0.288, 0
2785, 0.8, 0.312, 0
2786, 0.78, 0.336, 0
2787, 0.8, 0.36, 0
2788, 0.78, 0.384, 0
2789, 0.8, 0.408, 0
2790, 0.78, 0.432, 0
2791, 0.8, 0.456, 0
2792, 0.78, 0.48, 0
2793, 0.8, 0.504, 0
2794, 0.78, 0.528, 0
2795, 0.8, 0.552, 0
2796, 0.78, 0.576, 0
2797, 0.8, 0.6, 0
2798, 0.78, 0.624, 0
2799, 0.8, 0.648, 0
2800, 0.78, 0.672, 0
2801, 0.8, 0.696, 0
2802, 0.78, 0.72, 0
2803, 0.8, 0.744, 0
2804, 0.78, 0.768, 0
2805, 0.8, 0.792, 0
2806, 0.78, 0.816, 0
2807, 0.8, 0.84, 0
2808, 0.78, 0.864, 0
2809, 0.8, 0.888, 0
2810, 0.78, 0.912, 0
2811, 0.8, 0.936, 0
2812, 0.78, 0.96, 0
2813, 0.8, 0.984, 0
2814, 0.78, 1.008, 0
2815, 0.8, 1.032, 0
2816, 0.78, 1.056, 0
2817, 0.8, 1.08, 0
2818, 0.78, 1.104, 0
2819, 0.8, 1.128, 0
2820, 0.78, 1.152, 0
2821, 0.8, 1.176, 0
2822, 0.84, 0.024, 0
2823, 0.82, 0.048, 0
2824, 0.84, 0.072, 0
2825, 0.82, 0.096, 0
2826, 0.84, 0.12, 0
2827, 0.82, 0.144, 0
2828, 0.84, 0.168, 0
2829, 0.82, 0.192, 0
2830, 0.84, 0.216, 0
2831, 0.82, 0.24, 0
2832, 0.84, 0.264, 0
2833, 0.82, 0.288, 0
2834, 0.84, 0.312, 0
2835, 0.82, 0.336, 0
2836, 0.84, 0.36, 0
2837, 0.82, 0.384, 0
2838, 0.84, 0.408, 0
2839, 0.82, 0.432, 0
2840, 0.84, 0.456, 0
2841, 0.82, 0.48, 0
2842, 0.84, 0.504, 0
2843, 0.82, 0.528, 0
2844, 0.84, 0.552, 0
2845, 0.82, 0.576, 0
2846, 0.84, 0.6, 0
2847, 0.82, 0.624, 0
2848, 0.84, 0.648, 0
2849, 0.82, 0.672, 0
2850, 0.84, 0.696, 0
2851, 0.82, 0.72, 0
2852, 0.84, 0.744, 0
2853, 0.82, 0.768, 0
2854, 0.84, 0.792, 0
2855, 0.82, 0.816, 0
2856, 0.84, 0.84, 0
2857, 0.82, 0.864, 0
2858, 0.84, 0.888, 0
2859, 0.82, 0.912, 0
2860, 0.84, 0.936, 0
2861, 0.82, 0.96, 0
2862, 0.84, 0.984, 0
2863, 0.82, 1.008, 0
2864, 0.84, 1.032, 0
2865, 0.82, 1.056, 0
2866, 0.84, 1.08, 0
2867, 0.82, 1.104, 0
2868, 0.84, 1.128, 0
2869, 0.82, 1.152, 0
2870, 0.84, 1.176, 0
2871, 0.88, 0.024, 0
2872, 0.86, 0.048, 0
2873, 0.88, 0.072, 0
2874, 0.86, 0.096, 0
2875, 0.88, 0.12, 0
2876, 0.86, 0.144, 0
2877, 0.88, 0.168, 0
2878, 0.86, 0.192, 0
2879, 0.88, 0.216, 0
2880, 0.86, 0.24, 0
2881, 0.88, 0.264, 0
2882, 0.86, 0.288, 0
2883, 0.88, 0.312, 0
2884, 0.86, 0.336, 0
2885, 0.88, 0.36, 0
2886, 0.86, 0.384, 0
2887, 0.88, 0.408, 0
2888, 0.86, 0.432, 0
2889, 0.88, 0.456, 0
2890, 0.86, 0.48, 0
2891, 0.88, 0.504, 0
2892, 0.86, 0.528, 0
2893, 0.88, 0.552, 0
2894, 0.86, 0.576, 0
2895, 0.88, 0.6, 0
2896, 0.86, 0.624, 0
2897, 0.88, 0.648, 0
2898, 0.86, 0.672, 0
2899, 0.88, 0.696, 0
2900, 0.86, 0.72, 0
2901, 0.88, 0.744, 0
2902, 0.86, 0.768, 0
2903, 0.88, 0.792, 0
2904, 0.86, 0.816, 0
2905, 0.88, 0.84, 0
2906, 0.86, 0.864, 0
2907, 0.88, 0.888, 0
2908, 0.86, 0.912, 0
2909, 0.88, 0.936, 0
2910, 0.86, 0.96, 0
2911, 0.88, 0.984, 0
2912, 0.86, 1.008, 0
2913, 0.88, 1.032, 0
2914, 0.86, 1.056, 0
2915, 0.88, 1.08, 0
2916, 0.86, 1.104, 0
2917, 0.88, 1.128, 0
2918, 0.86, 1.152, 0
2919, 0.88, 1.176, 0
2920, 0.92, 0.024, 0
2921, 0.9, 0.048, 0
2922, 0.92, 0.072, 0
2923, 0.9, 0.096, 0
2924, 0.92, 0.12, 0
2925, 0.9, 0.144, 0
2926, 0.92, 0.168, 0
2927, 0.9, 0.192, 0
2928, 0.92, 0.216, 0
2929, 0.9, 0.24, 0
2930, 0.92, 0.264, 0
2931, 0.9, 0.288, 0
2932, 0.92, 0.312, 0
2933, 0.9, 0.336, 0
2934, 0.92, 0.36, 0
2935, 0.9, 0.384, 0
2936, 0.92, 0.408, 0
2937, 0.9, 0.432, 0
2938, 0.92, 0.456, 0
2939, 0.9, 0.48, 0
2940, 0.92, 0.504, 0
2941, 0.9, 0.528, 0
2942, 0.92, 0.552, 0
2943, 0.9, 0.576, 0
2944, 0.92, 0.6, 0
2945, 0.9, 0.624, 0
2946, 0.92, 0.648, 0
2947, 0.9, 0.672, 0
2948, 0.92, 0.696, 0
2949, 0.9, 0.72, 0
2950, 0.92, 0.744, 0
2951, 0.9, 0.768, 0
2952, 0.92, 0.792, 0
2953, 0.9, 0.816, 0
2954, 0.92, 0.84, 0
2955, 0.9, 0.864, 0
2956, 0.92, 0.888, 0
2957, 0.9, 0.912, 0
2958, 0.92, 0.936, 0
2959, 0.9, 0.96, 0
2960, 0.92, 0.984, 0
2961, 0.9, 1.008, 0
2962, 0.92, 1.032, 0
2963, 0.9, 1.056, 0
2964, 0.92, 1.08, 0
2965, 0.9, 1.104, 0
2966, 0.92, 1.128, 0
2967, 0.9, 1.152, 0
2968, 0.92, 1.176, 0
2969, 0.96, 0.024, 0
2970, 0.94, 0.048, 0
2971, 0.96, 0.072, 0
2972, 0.94, 0.096, 0
2973, 0.96, 0.12, 0
2974, 0.94, 0.144, 0
2975, 0.96, 0.168, 0
2976, 0.94, 0.192, 0
2977, 0.96, 0.216, 0
2978, 0.94, 0.24, 0
2979, 0.96, 0.264, 0
2980, 0.94, 0.288, 0
2981, 0.96, 0.312, 0
2982, 0.94, 0.336, 0
2983, 0.96, 0.36, 0
2984, 0.94, 0.384, 0
2985, 0.96, 0.408, 0
2986, 0.94, 0.432, 0
2987, 0.96, 0.456, 0
2988, 0.94, 0.48, 0
2989, 0.96, 0.504, 0
2990, 0.94, 0.528, 0
2991, 0.96, 0.552, 0
2992, 0.94, 0.576, 0
2993, 0.96, 0.6, 0
2994, 0.94, 0.624, 0
2995, 0.96, 0.648, 0
2996, 0.94, 0.672, 0
2997, 0.96, 0.696, 0
2998, 0.94, 0.72, 0
2999, 0.96, 0.744, 0
3000, 0.94, 0.768, 0
3001, 0.96, 0.792, 0
3002, 0.94, 0.816, 0
3003, 0.96, 0.84, 0
3004, 0.94, 0.864, 0
3005, 0.96, 0.888, 0
3006, 0.94, 0.912, 0
3007, 0.96, 0.936, 0
3008, 0.94, 0.96, 0
3009, 0.96, 0.984, 0
3010, 0.94, 1.008, 0
3011, 0.96, 1.032, 0
3012, 0.94, 1.056, 0
3013, 0.96, 1.08, 0
3014, 0.94, 1.104, 0
3015, 0.96, 1.128, 0
3016, 0.94, 1.152, 0
3017, 0.96, 1.176, 0
3018, 0.98, 0.048, 0
3019, 0.98, 0.096, 0
3020, 0.98, 0.144, 0
3021, 0.98, 0.192, 0
3022, 0.98, 0.24, 0
3023, 0.98, 0.288, 0
3024, 0.98, 0.336, 0
3025, 0.98, 0.384, 0
3026, 0.98, 0.432, 0
3027, 0.98, 0.48, 0
3028, 0.98, 0.528, 0
3029, 0.98, 0.576, 0
3030, 0.98, 0.624, 0
3031, 0.98, 0.672, 0
3032, 0.98, 0.72, 0
3033, 0.98, 0.768, 0
3034, 0.98, 0.816, 0
3035, 0.98, 0.864, 0
3036, 0.98, 0.912, 0
3037, 0.98, 0.96, 0
3038, 0.98, 1.008, 0
3039, 0.98, 1.056, 0
3040, 0.98, 1.104, 0
3041, 0.98, 1.152, 0
3042, 0.96, 1.2833333333333, 0
3043, 0.92, 1.2833333333333, 0
3044, 0.88, 1.2833333333333, 0
3045, 0.84, 1.2833333333333, 0
3046, 0.8, 1.2833333333333, 0
3047, 0.76, 1.2833333333333, 0
3048, 0.72, 1.2833333333333, 0
3049, 0.68, 1.2833333333333, 0
3050, 0.64, 1.2833333333333, 0
3051, 0.6, 1.2833333333333, 0
3052, 0.56, 1.2833333333333, 0
3053, 0.52, 1.2833333333333, 0
3054, 0.48, 1.2833333333333, 0
3055, 0.44, 1.2833333333333, 0
3056, 0.4, 1.2833333333333, 0
3057, 0.36, 1.2833333333333, 0
3058, 0.32, 1.2833333333333, 0
3059, 0.28, 1.2833333333333, 0
3060, 0.24, 1.2833333333333, 0
3061, 0.2, 1.2833333333333, 0
3062, 0.16, 1.2833333333333, 0
3063, 0.12, 1.2833333333333, 0
3064, 0.08, 1.2833333333333, 0
3065, 0.04, 1.2833333333333, 0
3066, 0.96, 1.3166666666667, 0
3067, 0.92, 1.3166666666667, 0
3068, 0.88, 1.3166666666667, 0
3069, 0.84, 1.3166666666667, 0
3070, 0.8, 1.3166666666667, 0
3071, 0.76, 1.3166666666667, 0
3072, 0.72, 1.3166666666667, 0
3073, 0.68, 1.3166666666667, 0
3074, 0.64, 1.3166666666667, 0
3075, 0.6, 1.3166666666667, 0
3076, 0.56, 1.3166666666667, 0
3077, 0.52, 1.3166666666667, 0
3078, 0.48, 1.3166666666667, 0
3079, 0.44, 1.3166666666667, 0
3080, 0.4, 1.3166666666667, 0
3081, 0.36, 1.3166666666667, 0
3082, 0.32, 1.3166666666667, 0
3083, 0.28, 1.3166666666667, 0
3084, 0.24, 1.3166666666667, 0
3085, 0.2, 1.3166666666667, 0
3086, 0.16, 1.3166666666667, 0
3087, 0.12, 1.3166666666667, 0
3088, 0.08, 1.3166666666667, 0
3089, 0.04, 1.3166666666667, 0
3090, 0.98, 1.2833333333333, 0
3091, 0.96, 1.2666666666667, 0
3092, 0.94, 1.2833333333333, 0
3093, 0.92, 1.2666666666667, 0
3094, 0.9, 1.2833333333333, 0
3095, 0.88, 1.2666666666667, 0
3096, 0.86, 1.2833333333333, 0
3097, 0.84, 1.2666666666667, 0
3098, 0.82, 1.2833333333333, 0
3099, 0.8, 1.2666666666667, 0
3100, 0.78, 1.2833333333333, 0
3101, 0.76, 1.2666666666667, 0
3102, 0.74, 1.2833333333333, 0
3103, 0.72, 1.2666666666667, 0
3104, 0.7, 1.2833333333333, 0
3105, 0.68, 1.2666666666667, 0
3106, 0.66, 1.2833333333333, 0
3107, 0.64, 1.2666666666667, 0
3108, 0.62, 1.2833333333333, 0
3109, 0.6, 1.2666666666667, 0
3110, 0.58, 1.2833333333333, 0
3111, 0.56, 1.2666666666667, 0
3112, 0.54, 1.2833333333333, 0
3113, 0.52, 1.2666666666667, 0
3114, 0.5, 1.2833333333333, 0
3115, 0.48, 1.2666666666667, 0
3116, 0.46, 1.2833333333333, 0
3117, 0.44, 1.2666666666667, 0
3118, 0.42, 1.2833333333333, 0
3119, 0.4, 1.2666666666667, 0
3120, 0.38, 1.2833333333333, 0
3121, 0.36, 1.2666666666667, 0
3122, 0.34, 1.2833333333333, 0
3123, 0.32, 1.2666666666667, 0
3124, 0.3, 1.2833333333333, 0
3125, 0.28, 1.2666666666667, 0
3126, 0.26, 1.2833333333333, 0
3127, 0.24, 1.2666666666667, 0
3128, 0.22, 1.2833333333333, 0
3129, 0.2, 1.2666666666667, 0
3130, 0.18, 1.2833333333333, 0
3131, 0.16, 1.2666666666667, 0
3132, 0.14, 1.2833333333333, 0
3133, 0.12, 1.2666666666667, 0
3134, 0.1, 1.2833333333333, 0
3135, 0.08, 1.2666666666667, 0
3136, 0.06, 1.2833333333333, 0
3137, 0.04, 1.2666666666667, 0
3138, 0.02, 1.2833333333333, 0
3139, 0.98, 1.3166666666667, 0
3140, 0.96, 1.3, 0
3141, 0.94, 1.3166666666667, 0
3142, 0.92, 1.3, 0
3143, 0.9, 1.3166666666667, 0
3144, 0.88, 1.3, 0
3145, 0.86, 1.3166666666667, 0
3146, 0.84, 1.3, 0
3147, 0.82, 1.3166666666667, 0
3148, 0.8, 1.3, 0
3149, 0.78, 1.3166666666667, 0
3150, 0.76, 1.3, 0
3151, 0.74, 1.3166666666667, 0
3152, 0.72, 1.3, 0
3153, 0.7, 1.3166666666667, 0
3154, 0.68, 1.3, 0
3155, 0.66, 1.3166666666667, 0
3156, 0.64, 1.3, 0
3157, 0.62, 1.3166666666667, 0
3158, 0.6, 1.3, 0
3159, 0.58, 1.3166666666667, 0
3160, 0.56, 1.3, 0
3161, 0.54, 1.3166666666667, 0
3162, 0.52, 1.3, 0
3163, 0.5, 1.3166666666667, 0
3164, 0.48, 1.3, 0
3165, 0.46, 1.3166666666667, 0
3166, 0.44, 1.3, 0
3167, 0.42, 1.3166666666667, 0
3168, 0.4, 1.3, 0
3169, 0.38, 1.3166666666667, 0
3170, 0.36, 1.3, 0
3171, 0.34, 1.3166666666667, 0
3172, 0.32, 1.3, 0
3173, 0.3, 1.3166666666667, 0
3174, 0.28, 1.3, 0
3175, 0.26, 1.3166666666667, 0
3176, 0.24, 1.3, 0
3177, 0.22, 1.3166666666667, 0
3178, 0.2, 1.3, 0
3179, 0.18, 1.3166666666667, 0
3180, 0.16, 1.3, 0
3181, 0.14, 1.3166666666667, 0
3182, 0.12, 1.3, 0
3183, 0.1, 1.3166666666667, 0
3184, 0.08, 1.3, 0
3185, 0.06, 1.3166666666667, 0
3186, 0.04, 1.3, 0
3187, 0.02, 1.3166666666667, 0
3188, 0.96, 1.3333333333333, 0
3189, 0.92, 1.3333333333333, 0
3190, 0.88, 1.3333333333333, 0
3191, 0.84, 1.3333333333333, 0
3192, 0.8, 1.3333333333333, 0
3193, 0.76, 1.3333333333333, 0
3194, 0.72, 1.3333333333333, 0
3195, 0.68, 1.3333333333333, 0
3196, 0.64, 1.3333333333333, 0
3197, 0.6, 1.3333333333333, 0
3198, 0.56, 1.3333333333333, 0
3199, 0.52, 1.3333333333333, 0
3200, 0.48, 1.3333333333333, 0
3201, 0.44, 1.3333333333333, 0
3202, 0.4, 1.3333333333333, 0
3203, 0.36, 1.3333333333333, 0
3204, 0.32, 1.3333333333333, 0
3205, 0.28, 1.3333333333333, 0
3206, 0.24, 1.3333333333333, 0
3207, 0.2, 1.3333333333333, 0
3208, 0.16, 1.3333333333333, 0
3209, 0.12, 1.3333333333333, 0
3210, 0.08, 1.3333333333333, 0
3211, 0.04, 1.3333333333333, 0
3212, 1.05, 1.2833333333333, 0
3213, 1.05, 1.3166666666667, 0
3214, 1.1, 1.2833333333333, 0
3215, 1.1, 1.3166666666667, 0
3216, 1.15, 1.2833333333333, 0
3217, 1.15, 1.3166666666667, 0
3218, 1.05, 1.2666666666667, 0
3219, 1.025, 1.2833333333333, 0
3220, 1.05, 1.3, 0
3221, 1.025, 1.3166666666667, 0
3222, 1.05, 1.3333333333333, 0
3223, 1.1, 1.2666666666667, 0
3224, 1.075, 1.2833333333333, 0
3225, 1.1, 1.3, 0
3226, 1.075, 1.3166666666667, 0
3227, 1.1, 1.3333333333333, 0
3228, 1.15, 1.2666666666667, 0
3229, 1.125, 1.2833333333333, 0
3230, 1.15, 1.3, 0
3231, 1.125, 1.3166666666667, 0
3232, 1.15, 1.3333333333333, 0
3233, 1.175, 1.2833333333333, 0
3234, 1.175, 1.3166666666667, 0
3235, 1.24, 1.2833333333333, 0
3236, 1.24, 1.3166666666667, 0
3237, 1.28, 1.2833333333333, 0
3238, 1.28, 1.3166666666667, 0
3239, 1.32, 1.2833333333333, 0
3240, 1.32, 1.3166666666667, 0
3241, 1.36, 1.2833333333333, 0
3242, 1.36, 1.3166666666667, 0
3243, 1.4, 1.2833333333333, 0
3244, 1.4, 1.3166666666667, 0
3245, 1.44, 1.2833333333333, 0
3246, 1.44, 1.3166666666667, 0
3247, 1.48, 1.2833333333333, 0
3248, 1.48, 1.3166666666667, 0
3249, 1.52, 1.2833333333333, 0
3250, 1.52, 1.3166666666667, 0
3251, 1.56, 1.2833333333333, 0
3252, 1.56, 1.3166666666667, 0
3253, 1.6, 1.2833333333333, 0
3254, 1.6, 1.3166666666667, 0
3255, 1.64, 1.2833333333333, 0
3256, 1.64, 1.3166666666667, 0
3257, 1.68, 1.2833333333333, 0
3258, 1.68, 1.3166666666667, 0
3259, 1.72, 1.2833333333333, 0
3260, 1.72, 1.3166666666667, 0
3261, 1.76, 1.2833333333333, 0
3262, 1.76, 1.3166666666667, 0
3263, 1.8, 1.2833333333333, 0
3264, 1.8, 1.3166666666667, 0
3265, 1.84, 1.2833333333333, 0
3266, 1.84, 1.3166666666667, 0
3267, 1.88, 1.2833333333333, 0
3268, 1.88, 1.3166666666667, 0
3269, 1.92, 1.2833333333333, 0
3270, 1.92, 1.3166666666667, 0
3271, 1.96, 1.2833333333333, 0
3272, 1.96, 1.3166666666667, 0
3273, 2, 1.2833333333333, 0
3274, 2, 1.3166666666667, 0
3275, 2.04, 1.2833333333333, 0
3276, 2.04, 1.3166666666667, 0
3277, 2.08, 1.2833333333333, 0
3278, 2.08, 1.3166666666667, 0
3279, 2.12, 1.2833333333333, 0
3280, 2.12, 1.3166666666667, 0
3281, 2.16, 1.2833333333333, 0
3282, 2.16, 1.3166666666667, 0
3283, 1.24, 1.2666666666667, 0
3284, 1.22, 1.2833333333333, 0
3285, 1.24, 1.3, 0
3286, 1.22, 1.3166666666667, 0
3287, 1.24, 1.3333333333333, 0
3288, 1.28, 1.2666666666667, 0
3289, 1.26, 1.2833333333333, 0
3290, 1.28, 1.3, 0
3291, 1.26, 1.3166666666667, 0
3292, 1.28, 1.3333333333333, 0
3293, 1.32, 1.2666666666667, 0
3294, 1.3, 1.2833333333333, 0
3295, 1.32, 1.3, 0
3296, 1.3, 1.3166666666667, 0
3297, 1.32, 1.3333333333333, 0
3298, 1.36, 1.2666666666667, 0
3299, 1.34, 1.2833333333333, 0
3300, 1.36, 1.3, 0
3301, 1.34, 1.3166666666667, 0
3302, 1.36, 1.3333333333333, 0
3303, 1.4, 1.2666666666667, 0
3304, 1.38, 1.2833333333333, 0
3305, 1.4, 1.3, 0
3306, 1.38, 1.3166666666667, 0
3307, 1.4, 1.3333333333333, 0
3308, 1.44, 1.2666666666667, 0
3309, 1.42, 1.2833333333333, 0
3310, 1.44, 1.3, 0
3311, 1.42, 1.3166666666667, 0
3312, 1.44, 1.3333333333333, 0
3313, 1.48, 1.2666666666667, 0
3314, 1.46, 1.2833333333333, 0
3315, 1.48, 1.3, 0
3316, 1.46, 1.3166666666667, 0
3317, 1.48, 1.3333333333333, 0
3318, 1.52, 1.2666666666667, 0
3319, 1.5, 1.2833333333333, 0
3320, 1.52, 1.3, 0
3321, 1.5, 1.3166666666667, 0
3322, 1.52, 1.3333333333333, 0
3323, 1.56, 1.2666666666667, 0
3324, 1.54, 1.2833333333333, 0
3325, 1.56, 1.3, 0
3326, 1.54, 1.3166666666667, 0
3327, 1.56, 1.3333333333333, 0
3328, 1.6, 1.2666666666667, 0
3329, 1.58, 1.2833333333333, 0
3330, 1.6, 1.3, 0
3331, 1.58, 1.3166666666667, 0
3332, 1.6, 1.3333333333333, 0
3333, 1.64, 1.2666666666667, 0
3334, 1.62, 1.2833333333333, 0
3335, 1.64, 1.3, 0
3336, 1.62, 1.3166666666667, 0
3337, 1.64, 1.3333333333333, 0
3338, 1.68, 1.2666666666667, 0
3339, 1.66, 1.2833333333333, 0
3340, 1.68, 1.3, 0
3341, 1.66, 1.3166666666667, 0
3342, 1.68, 1.3333333333333, 0
3343, 1.72, 1.2666666666667, 0
3344, 1.7, 1.2833333333333, 0
3345, 1.72, 1.3, 0
3346, 1.7, 1.3166666666667, 0
3347, 1.72, 1.3333333333333, 0
3348, 1.76, 1.2666666666667, 0
3349, 1.74, 1.2833333333333, 0
3350, 1.76, 1.3, 0
3351, 1.74, 1.3166666666667, 0
3352, 1.76, 1.3333333333333, 0
3353, 1.8, 1.2666666666667, 0
3354, 1.78, 1.2833333333333, 0
3355, 1.8, 1.3, 0
3356, 1.78, 1.3166666666667, 0
3357, 1.8, 1.3333333333333, 0
3358, 1.84, 1.2666666666667, 0
3359, 1.82, 1.2833333333333, 0
3360, 1.84, 1.3, 0
3361, 1.82, 1.3166666666667, 0
3362, 1.84, 1.3333333333333, 0
3363, 1.88, 1.2666666666667, 0
3364, 1.86, 1.2833333333333, 0
3365, 1.88, 1.3, 0
3366, 1.86, 1.3166666666667, 0
3367, 1.88, 1.3333333333333, 0
3368, 1.92, 1.2666666666667, 0
3369, 1.9, 1.2833333333333, 0
3370, 1.92, 1.3, 0
3371, 1.9, 1.3166666666667, 0
3372, 1.92, 1.3333333333333, 0
3373, 1.96, 1.2666666666667, 0
3374, 1.94, 1.2833333333333, 0
3375, 1.96, 1.3, 0
3376, 1.94, 1.3166666666667, 0
3377, 1.96, 1.3333333333333, 0
3378, 2, 1.2666666666667, 0
3379, 1.98, 1.2833333333333, 0
3380, 2, 1.3, 0
3381, 1.98, 1.3166666666667, 0
3382, 2, 1.3333333333333, 0
3383, 2.04, 1.2666666666667, 0
3384, 2.02, 1.2833333333333, 0
3385, 2.04, 1.3, 0
3386, 2.02, 1.3166666666667, 0
3387, 2.04, 1.3333333333333, 0
3388, 2.08, 1.2666666666667, 0
3389, 2.06, 1.2833333333333, 0
3390, 2.08, 1.3, 0
3391, 2.06, 1.3166666666667, 0
3392, 2.08, 1.3333333333333, 0
3393, 2.12, 1.2666666666667, 0
3394, 2.1, 1.2833333333333, 0
3395, 2.12, 1.3, 0
3396, 2.1, 1.3166666666667, 0
3397, 2.12, 1.3333333333333, 0
3398, 2.16, 1.2666666666667, 0
3399, 2.14, 1.2833333333333, 0
3400, 2.16, 1.3, 0
3401, 2.14, 1.3166666666667, 0
3402, 2.16, 1.3333333333333, 0
3403, 2.18, 1.2833333333333, 0
3404, 2.18, 1.3166666666667, 0
3405, 1.24, 1.152, 0
3406, 1.28, 1.152, 0
3407, 1.32, 1.152, 0
3408, 1.36, 1.152, 0
3409, 1.4, 1.152, 0
3410, 1.44, 1.152, 0
3411, 1.48, 1.152, 0
3412, 1.52, 1.152, 0
3413, 1.56, 1.152, 0
3414, 1.6, 1.152, 0
3415, 1.64, 1.152, 0
3416, 1.68, 1.152, 0
3417, 1.72, 1.152, 0
3418, 1.76, 1.152, 0
3419, 1.8, 1.152, 0
3420, 1.84, 1.152, 0
3421, 1.88, 1.152, 0
3422, 1.92, 1.152, 0
3423, 1.96, 1.152, 0
3424, 2, 1.152, 0
3425, 2.04, 1.152, 0
3426, 2.08, 1.152, 0
3427, 2.12, 1.152, 0
3428, 2.16, 1.152, 0
3429, 1.24, 1.104, 0
3430, 1.28, 1.104, 0
3431, 1.32, 1.104, 0
3432, 1.36, 1.104, 0
3433, 1.4, 1.104, 0
3434, 1.44, 1.104, 0
3435, 1.48, 1.104, 0
3436, 1.52, 1.104, 0
3437, 1.56, 1.104, 0
3438, 1.6, 1.104, 0
3439, 1.64, 1.104, 0
3440, 1.68, 1.104, 0
3441, 1.72, 1.104, 0
3442, 1.76, 1.104, 0
3443, 1.8, 1.104, 0
3444, 1.84, 1.104, 0
3445, 1.88, 1.104, 0
3446, 1.92, 1.104, 0
3447, 1.96, 1.104, 0
3448, 2, 1.104, 0
3449, 2.04, 1.104, 0
3450, 2.08, 1.104, 0
3451, 2.12, 1.104, 0
3452, 2.16, 1.104, 0
3453, 1.24, 1.056, 0
3454, 1.28, 1.056, 0
3455, 1.32, 1.056, 0
3456, 1.36, 1.056, 0
3457, 1.4, 1.056, 0
3458, 1.44, 1.056, 0
3459, 1.48, 1.056, 0
3460, 1.52, 1.056, 0
3461, 1.56, 1.056, 0
3462, 1.6, 1.056, 0
3463, 1.64, 1.056, 0
3464, 1.68, 1.056, 0
3465, 1.72, 1.056, 0
3466, 1.76, 1.056, 0
3467, 1.8, 1.056, 0
3468, 1.84, 1.056, 0
3469, 1.88, 1.056, 0
3470, 1.92, 1.056, 0
3471, 1.96, 1.056, 0
3472, 2, 1.056, 0
3473, 2.04, 1.056, 0
3474, 2.08, 1.056, 0
3475, 2.12, 1.056, 0
3476, 2.16, 1.056, 0
3477, 1.24, 1.008, 0
3478, 1.28, 1.008, 0
3479, 1.32, 1.008, 0
3480, 1.36, 1.008, 0
3481, 1.4, 1.008, 0
3482, 1.44, 1.008, 0
3483, 1.48, 1.008, 0
3484, 1.52, 1.008, 0
3485, 1.56, 1.008, 0
3486, 1.6, 1.008, 0
3487, 1.64, 1.008, 0
3488, 1.68, 1.008, 0
3489, 1.72, 1.008, 0
3490, 1.76, 1.008, 0
3491, 1.8, 1.008, 0
3492, 1.84, 1.008, 0
3493, 1.88, 1.008, 0
3494, 1.92, 1.008, 0
3495, 1.96, 1.008, 0
3496, 2, 1.008, 0
3497, 2.04, 1.008, 0
3498, 2.08, 1.008, 0
3499, 2.12, 1.008, 0
3500, 2.16, 1.008, 0
3501, 1.24, 0.96, 0
3502, 1.28, 0.96, 0
3503, 1.32, 0.96, 0
3504, 1.36, 0.96, 0
3505, 1.4, 0.96, 0
3506, 1.44, 0.96, 0
3507, 1.48, 0.96, 0
3508, 1.52, 0.96, 0
3509, 1.56, 0.96, 0
3510, 1.6, 0.96, 0
3511, 1.64, 0.96, 0
3512, 1.68, 0.96, 0
3513, 1.72, 0.96, 0
3514, 1.76, 0.96, 0
3515, 1.8, 0.96, 0
3516, 1.84, 0.96, 0
3517, 1.88, 0.96, 0
3518, 1.92, 0.96, 0
3519, 1.96, 0.96, 0
3520, 2, 0.96, 0
3521, 2.04, 0.96, 0
3522, 2.08, 0.96, 0
3523, 2.12, 0.96, 0
3524, 2.16, 0.96, 0
3525, 1.24, 0.912, 0
3526, 1.28, 0.912, 0
3527, 1.32, 0.912, 0
3528, 1.36, 0.912, 0
3529, 1.4, 0.912, 0
3530, 1.44, 0.912, 0
3531, 1.48, 0.912, 0
3532, 1.52, 0.912, 0
3533, 1.56, 0.912, 0
3534, 1.6, 0.912, 0
3535, 1.64, 0.912, 0
3536, 1.68, 0.912, 0
3537, 1.72, 0.912, 0
3538, 1.76, 0.912, 0
3539, 1.8, 0.912, 0
3540, 1.84, 0.912, 0
3541, 1.88, 0.912, 0
3542, 1.92, 0.912, 0
3543, 1.96, 0.912, 0
3544, 2, 0.912, 0
3545, 2.04, 0.912, 0
3546, 2.08, 0.912, 0
3547, 2.12, 0.912, 0
3548, 2.16, 0.912, 0
3549, 1.24, 0.864, 0
3550, 1.28, 0.864, 0
3551, 1.32, 0.864, 0
3552, 1.36, 0.864, 0
3553, 1.4, 0.864, 0
3554, 1.44, 0.864, 0
3555, 1.48, 0.864, 0
3556, 1.52, 0.864, 0
3557, 1.56, 0.864, 0
3558, 1.6, 0.864, 0
3559, 1.64, 0.864, 0
3560, 1.68, 0.864, 0
3561, 1.72, 0.864, 0
3562, 1.76, 0.864, 0
3563, 1.8, 0.864, 0
3564, 1.84, 0.864, 0
3565, 1.88, 0.864, 0
3566, 1.92, 0.864, 0
3567, 1.96, 0.864, 0
3568, 2, 0.864, 0
3569, 2.04, 0.864, 0
3570, 2.08, 0.864, 0
3571, 2.12, 0.864, 0
3572, 2.16, 0.864, 0
3573, 1.24, 0.816, 0
3574, 1.28, 0.816, 0
3575, 1.32, 0.816, 0
3576, 1.36, 0.816, 0
3577, 1.4, 0.816, 0
3578, 1.44, 0.816, 0
3579, 1.48, 0.816, 0
3580, 1.52, 0.816, 0
3581, 1.56, 0.816, 0
3582, 1.6, 0.816, 0
3583, 1.64, 0.816, 0
3584, 1.68, 0.816, 0
3585, 1.72, 0.816, 0
3586, 1.76, 0.816, 0
3587, 1.8, 0.816, 0
3588, 1.84, 0.816, 0
3589, 1.88, 0.816, 0
3590, 1.92, 0.816, 0
3591, 1.96, 0.816, 0
3592, 2, 0.816, 0
3593, 2.04, 0.816, 0
3594, 2.08, 0.816, 0
3595, 2.12, 0.816, 0
3596, 2.16, 0.816, 0
3597, 1.24, 0.768, 0
3598, 1.28, 0.768, 0
3599, 1.32, 0.768, 0
3600, 1.36, 0.768, 0
3601, 1.4, 0.768, 0
3602, 1.44, 0.768, 0
3603, 1.48, 0.768, 0
3604, 1.52, 0.768, 0
3605, 1.56, 0.768, 0
3606, 1.6, 0.768, 0
3607, 1.64, 0.768, 0
3608, 1.68, 0.768, 0
3609, 1.72, 0.768, 0
3610, 1.76, 0.768, 0
3611, 1.8, 0.768, 0
3612, 1.84, 0.768, 0
3613, 1.88, 0.768, 0
3614, 1.92, 0.768, 0
3615, 1.96, 0.768, 0
3616, 2, 0.768, 0
3617, 2.04, 0.768, 0
3618, 2.08, 0.768, 0
3619, 2.12, 0.768, 0
3620, 2.16, 0.768, 0
3621, 1.24, 0.72, 0
3622, 1.28, 0.72, 0
3623, 1.32, 0.72, 0
3624, 1.36, 0.72, 0
3625, 1.4, 0.72, 0
3626, 1.44, 0.72, 0
3627, 1.48, 0.72, 0
3628, 1.52, 0.72, 0
3629, 1.56, 0.72, 0
3630, 1.6, 0.72, 0
3631, 1.64, 0.72, 0
3632, 1.68, 0.72, 0
3633, 1.72, 0.72, 0
3634, 1.76, 0.72, 0
3635, 1.8, 0.72, 0
3636, 1.84, 0.72, 0
3637, 1.88, 0.72, 0
3638, 1.92, 0.72, 0
3639, 1.96, 0.72, 0
3640, 2, 0.72, 0
3641, 2.04, 0.72, 0
3642, 2.08, 0.72, 0
3643, 2.12, 0.72, 0
3644, 2.16, 0.72, 0
3645, 1.24, 0.672, 0
3646, 1.28, 0.672, 0
3647, 1.32, 0.672, 0
3648, 1.36, 0.672, 0
3649, 1.4, 0.672, 0
3650, 1.44, 0.672, 0
3651, 1.48, 0.672, 0
3652, 1.52, 0.672, 0
3653, 1.56, 0.672, 0
3654, 1.6, 0.672, 0
3655, 1.64, 0.672, 0
3656, 1.68, 0.672, 0
3657, 1.72, 0.672, 0
3658, 1.76, 0.672, 0
3659, 1.8, 0.672, 0
3660, 1.84, 0.672, 0
3661, 1.88, 0.672, 0
3662, 1.92, 0.672, 0
3663, 1.96, 0.672, 0
3664, 2, 0.672, 0
3665, 2.04, 0.672, 0
3666, 2.08, 0.672, 0
3667, 2.12, 0.672, 0
3668, 2.16, 0.672, 0
3669, 1.24, 0.624, 0
3670, 1.28, 0.624, 0
3671, 1.32, 0.624, 0
3672, 1.36, 0.624, 0
3673, 1.4, 0.624, 0
3674, 1.44, 0.624, 0
3675, 1.48, 0.624, 0
3676, 1.52, 0.624, 0
3677, 1.56, 0.624, 0
3678, 1.6, 0.624, 0
3679, 1.64, 0.624, 0
3680, 1.68, 0.624, 0
3681, 1.72, 0.624, 0
3682, 1.76, 0.624, 0
3683, 1.8, 0.624, 0
3684, 1.84, 0.624, 0
3685, 1.88, 0.624, 0
3686, 1.92, 0.624, 0
3687, 1.96, 0.624, 0
3688, 2, 0.624, 0
3689, 2.04, 0.624, 0
3690, 2.08, 0.624, 0
3691, 2.12, 0.624, 0
3692, 2.16, 0.624, 0
3693, 1.24, 0.576, 0
3694, 1.28, 0.576, 0
3695, 1.32, 0.576, 0
3696, 1.36, 0.576, 0
3697, 1.4, 0.576, 0
3698, 1.44, 0.576, 0
3699, 1.48, 0.576, 0
3700, 1.52, 0.576, 0
3701, 1.56, 0.576, 0
3702, 1.6, 0.576, 0
3703, 1.64, 0.576, 0
3704, 1.68, 0.576, 0
3705, 1.72, 0.576, 0
3706, 1.76, 0.576, 0
3707, 1.8, 0.576, 0
3708, 1.84, 0.576, 0
3709, 1.88, 0.576, 0
3710, 1.92, 0.576, 0
3711, 1.96, 0.576, 0
3712, 2, 0.576, 0
3713, 2.04, 0.576, 0
3714, 2.08, 0.576, 0
3715, 2.12, 0.576, 0
3716, 2.16, 0.576, 0
3717, 1.24, 0.528, 0
3718, 1.28, 0.528, 0
3719, 1.32, 0.528, 0
3720, 1.36, 0.528, 0
3721, 1.4, 0.528, 0
3722, 1.44, 0.528, 0
3723, 1.48, 0.528, 0
3724, 1.52, 0.528, 0
3725, 1.56, 0.528, 0
3726, 1.6, 0.528, 0
3727, 1.64, 0.528, 0
3728, 1.68, 0.528, 0
3729, 1.72, 0.528, 0
3730, 1.76, 0.528, 0
3731, 1.8, 0.528, 0
3732, 1.84, 0.528, 0
3733, 1.88, 0.528, 0
3734, 1.92, 0.528, 0
3735, 1.96, 0.528, 0
3736, 2, 0.528, 0
3737, 2.04, 0.528, 0
3738, 2.08, 0.528, 0
3739, 2.12, 0.528, 0
3740, 2.16, 0.528, 0
3741, 1.24, 0.48, 0
3742, 1.28, 0.48, 0
3743, 1.32, 0.48, 0
3744, 1.36, 0.48, 0
3745, 1.4, 0.48, 0
3746, 1.44, 0.48, 0
3747, 1.48, 0.48, 0
3748, 1.52, 0.48, 0
3749, 1.56, 0.48, 0
3750, 1.6, 0.48, 0
3751, 1.64, 0.48, 0
3752, 1.68, 0.48, 0
3753, 1.72, 0.48, 0
3754, 1.76, 0.48, 0
3755, 1.8, 0.48, 0
3756, 1.84, 0.48, 0
3757, 1.88, 0.48, 0
3758, 1.92, 0.48, 0
3759, 1.96, 0.48, 0
3760, 2, 0.48, 0
3761, 2.04, 0.48, 0
3762, 2.08, 0.48, 0
3763, 2.12, 0.48, 0
3764, 2.16, 0.48, 0
3765, 1.24, 0.432, 0
3766, 1.28, 0.432, 0
3767, 1.32, 0.432, 0
3768, 1.36, 0.432, 0
3769, 1.4, 0.432, 0
3770, 1.44, 0.432, 0
3771, 1.48, 0.432, 0
3772, 1.52, 0.432, 0
3773, 1.56, 0.432, 0
3774, 1.6, 0.432, 0
3775, 1.64, 0.432, 0
3776, 1.68, 0.432, 0
3777, 1.72, 0.432, 0
3778, 1.76, 0.432, 0
3779, 1.8, 0.432, 0
3780, 1.84, 0.432, 0
3781, 1.88, 0.432, 0
3782, 1.92, 0.432, 0
3783, 1.96, 0.432, 0
3784, 2, 0.432, 0
3785, 2.04, 0.432, 0
3786, 2.08, 0.432, 0
3787, 2.12, 0.432, 0
3788, 2.16, 0.432, 0
3789, 1.24, 0.384, 0
3790, 1.28, 0.384, 0
3791, 1.32, 0.384, 0
3792, 1.36, 0.384, 0
3793, 1.4, 0.384, 0
3794, 1.44, 0.384, 0
3795, 1.48, 0.384, 0
3796, 1.52, 0.384, 0
3797, 1.56, 0.384, 0
3798, 1.6, 0.384, 0
3799, 1.64, 0.384, 0
3800, 1.68, 0.384, 0
3801, 1.72, 0.384, 0
3802, 1.76, 0.384, 0
3803, 1.8, 0.384, 0
3804, 1.84, 0.384, 0
3805, 1.88, 0.384, 0
3806, 1.92, 0.384, 0
3807, 1.96, 0.384, 0
3808, 2, 0.384, 0
3809, 2.04, 0.384, 0
3810, 2.08, 0.384, 0
3811, 2.12, 0.384, 0
3812, 2.16, 0.384, 0
3813, 1.24, 0.336, 0
3814, 1.28, 0.336, 0
3815, 1.32, 0.336, 0
3816, 1.36, 0.336, 0
3817, 1.4, 0.336, 0
3818, 1.44, 0.336, 0
3819, 1.48, 0.336, 0
3820, 1.52, 0.336, 0
3821, 1.56, 0.336, 0
3822, 1.6, 0.336, 0
3823, 1.64, 0.336, 0
3824, 1.68, 0.336, 0
3825, 1.72, 0.336, 0
3826, 1.76, 0.336, 0
3827, 1.8, 0.336, 0
3828, 1.84, 0.336, 0
3829, 1.88, 0.336, 0
3830, 1.92, 0.336, 0
3831, 1.96, 0.336, 0
3832, 2, 0.336, 0
3833, 2.04, 0.336, 0
3834, 2.08, 0.336, 0
3835, 2.12, 0.336, 0
3836, 2.16, 0.336, 0
3837, 1.24, 0.288, 0
3838, 1.28, 0.288, 0
3839, 1.32, 0.288, 0
3840, 1.36, 0.288, 0
3841, 1.4, 0.288, 0
3842, 1.44, 0.288, 0
3843, 1.48, 0.288, 0
3844, 1.52, 0.288, 0
3845, 1.56, 0.288, 0
3846, 1.6, 0.288, 0
3847, 1.64, 0.288, 0
3848, 1.68, 0.288, 0
3849, 1.72, 0.288, 0
3850, 1.76, 0.288, 0
3851, 1.8, 0.288, 0
3852, 1.84, 0.288, 0
3853, 1.88, 0.288, 0
3854, 1.92, 0.288, 0
3855, 1.96, 0.288, 0
3856, 2, 0.288, 0
3857, 2.04, 0.288, 0
3858, 2.08, 0.288, 0
3859, 2.12, 0.288, 0
3860, 2.16, 0.288, 0
3861, 1.24, 0.24, 0
3862, 1.28, 0.24, 0
3863, 1.32, 0.24, 0
3864, 1.36, 0.24, 0
3865, 1.4, 0.24, 0
3866, 1.44, 0.24, 0
3867, 1.48, 0.24, 0
3868, 1.52, 0.24, 0
3869, 1.56, 0.24, 0
3870, 1.6, 0.24, 0
3871, 1.64, 0.24, 0
3872, 1.68, 0.24, 0
3873, 1.72, 0.24, 0
3874, 1.76, 0.24, 0
3875, 1.8, 0.24, 0
3876, 1.84, 0.24, 0
3877, 1.88, 0.24, 0
3878, 1.92, 0.24, 0
3879, 1.96, 0.24, 0
3880, 2, 0.24, 0
3881, 2.04, 0.24, 0
3882, 2.08, 0.24, 0
3883, 2.12, 0.24, 0
3884, 2.16, 0.24, 0
3885, 1.24, 0.192, 0
3886, 1.28, 0.192, 0
3887, 1.32, 0.192, 0
3888, 1.36, 0.192, 0
3889, 1.4, 0.192, 0
3890, 1.44, 0.192, 0
3891, 1.48, 0.192, 0
3892, 1.52, 0.192, 0
3893, 1.56, 0.192, 0
3894, 1.6, 0.192, 0
3895, 1.64, 0.192, 0
3896, 1.68, 0.192, 0
3897, 1.72, 0.192, 0
3898, 1.76, 0.192, 0
3899, 1.8, 0.192, 0
3900, 1.84, 0.192, 0
3901, 1.88, 0.192, 0
3902, 1.92, 0.192, 0
3903, 1.96, 0.192, 0
3904, 2, 0.192, 0
3905, 2.04, 0.192, 0
3906, 2.08, 0.192, 0
3907, 2.12, 0.192, 0
3908, 2.16, 0.192, 0
3909, 1.24, 0.144, 0
3910, 1.28, 0.144, 0
3911, 1.32, 0.144, 0
3912, 1.36, 0.144, 0
3913, 1.4, 0.144, 0
3914, 1.44, 0.144, 0
3915, 1.48, 0.144, 0
3916, 1.52, 0.144, 0
3917, 1.56, 0.144, 0
3918, 1.6, 0.144, 0
3919, 1.64, 0.144, 0
3920, 1.68, 0.144, 0
3921, 1.72, 0.144, 0
3922, 1.76, 0.144, 0
3923, 1.8, 0.144, 0
3924, 1.84, 0.144, 0
3925, 1.88, 0.144, 0
3926, 1.92, 0.144, 0
3927, 1.96, 0.144, 0
3928, 2, 0.144, 0
3929, 2.04, 0.144, 0
3930, 2.08, 0.144, 0
3931, 2.12, 0.144, 0
3932, 2.16, 0.144, 0
3933, 1.24, 0.096, 0
3934, 1.28, 0.096, 0
3935, 1.32, 0.096, 0
3936, 1.36, 0.096, 0
3937, 1.4, 0.096, 0
3938, 1.44, 0.096, 0
3939, 1.48, 0.096, 0
3940, 1.52, 0.096, 0
3941, 1.56, 0.096, 0
3942, 1.6, 0.096, 0
3943, 1.64, 0.096, 0
3944, 1.68, 0.096, 0
3945, 1.72, 0.096, 0
3946, 1.76, 0.096, 0
3947, 1.8, 0.096, 0
3948, 1.84, 0.096, 0
3949, 1.88, 0.096, 0
3950, 1.92, 0.096, 0
3951, 1.96, 0.096, 0
3952, 2, 0.096, 0
3953, 2.04, 0.096, 0
3954, 2.08, 0.096, 0
3955, 2.12, 0.096, 0
3956, 2.16, 0.096, 0
3957, 1.24, 0.048, 0
3958, 1.28, 0.048, 0
3959, 1.32, 0.048, 0
3960, 1.36, 0.048, 0
3961, 1.4, 0.048, 0
3962, 1.44, 0.048, 0
3963, 1.48, 0.048, 0
3964, 1.52, 0.048, 0
3965, 1.56, 0.048, 0
3966, 1.6, 0.048, 0
3967, 1.64, 0.048, 0
3968, 1.68, 0.048, 0
3969, 1.72, 0.048, 0
3970, 1.76, 0.048, 0
3971, 1.8, 0.048, 0
3972, 1.84, 0.048, 0
3973, 1.88, 0.048, 0
3974, 1.92, 0.048, 0
3975, 1.96, 0.048, 0
3976, 2, 0.048, 0
3977, 2.04, 0.048, 0
3978, 2.08, 0.048, 0
3979, 2.12, 0.048, 0
3980, 2.16, 0.048, 0
3981, 1.22, 1.152, 0
3982, 1.24, 1.176, 0
3983, 1.26, 1.152, 0
3984, 1.28, 1.176, 0
3985, 1.3, 1.152, 0
3986, 1.32, 1.176, 0
3987, 1.34, 1.152, 0
3988, 1.36, 1.176, 0
3989, 1.38, 1.152, 0
3990, 1.4, 1.176, 0
3991, 1.42, 1.152, 0
3992, 1.44, 1.176, 0
3993, 1.46, 1.152, 0
3994, 1.48, 1.176, 0
3995, 1.5, 1.152, 0
3996, 1.52, 1.176, 0
3997, 1.54, 1.152, 0
3998, 1.56, 1.176, 0
3999, 1.58, 1.152, 0
4000, 1.6, 1.176, 0
4001, 1.62, 1.152, 0
4002, 1.64, 1.176, 0
4003, 1.66, 1.152, 0
4004, 1.68, 1.176, 0
4005, 1.7, 1.152, 0
4006, 1.72, 1.176, 0
4007, 1.74, 1.152, 0
4008, 1.76, 1.176, 0
4009, 1.78, 1.152, 0
4010, 1.8, 1.176, 0
4011, 1.82, 1.152, 0
4012, 1.84, 1.176, 0
4013, 1.86, 1.152, 0
4014, 1.88, 1.176, 0
4015, 1.9, 1.152, 0
4016, 1.92, 1.176, 0
4017, 1.94, 1.152, 0
4018, 1.96, 1.176, 0
4019, 1.98, 1.152, 0
4020, 2, 1.176, 0
4021, 2.02, 1.152, 0
4022, 2.04, 1.176, 0
4023, 2.06, 1.152, 0
4024, 2.08, 1.176, 0
4025, 2.1, 1.152, 0
4026, 2.12, 1.176, 0
4027, 2.14, 1.152, 0
4028, 2.16, 1.176, 0
4029, 2.18, 1.152, 0
4030, 1.22, 1.104, 0
4031, 1.24, 1.128, 0
4032, 1.26, 1.104, 0
4033, 1.28, 1.128, 0
4034, 1.3, 1.104, 0
4035, 1.32, 1.128, 0
4036, 1.34, 1.104, 0
4037, 1.36, 1.128, 0
4038, 1.38, 1.104, 0
4039, 1.4, 1.128, 0
4040, 1.42, 1.104, 0
4041, 1.44, 1.128, 0
4042, 1.46, 1.104, 0
4043, 1.48, 1.128, 0
4044, 1.5, 1.104, 0
4045, 1.52, 1.128, 0
4046, 1.54, 1.104, 0
4047, 1.56, 1.128, 0
4048, 1.58, 1.104, 0
4049, 1.6, 1.128, 0
4050, 1.62, 1.104, 0
4051, 1.64, 1.128, 0
4052, 1.66, 1.104, 0
4053, 1.68, 1.128, 0
4054, 1.7, 1.104, 0
4055, 1.72, 1.128, 0
4056, 1.74, 1.104, 0
4057, 1.76, 1.128, 0
4058, 1.78, 1.104, 0
4059, 1.8, 1.128, 0
4060, 1.82, 1.104, 0
4061, 1.84, 1.128, 0
4062, 1.86, 1.104, 0
4063, 1.88, 1.128, 0
4064, 1.9, 1.104, 0
4065, 1.92, 1.128, 0
4066, 1.94, 1.104, 0
4067, 1.96, 1.128, 0
4068, 1.98, 1.104, 0
4069, 2, 1.128, 0
4070, 2.02, 1.104, 0
4071, 2.04, 1.128, 0
4072, 2.06, 1.104, 0
4073, 2.08, 1.128, 0
4074, 2.1, 1.104, 0
4075, 2.12, 1.128, 0
4076, 2.14, 1.104, 0
4077, 2.16, 1.128, 0
4078, 2.18, 1.104, 0
4079, 1.22, 1.056, 0
4080, 1.24, 1.08, 0
4081, 1.26, 1.056, 0
4082, 1.28, 1.08, 0
4083, 1.3, 1.056, 0
4084, 1.32, 1.08, 0
4085, 1.34, 1.056, 0
4086, 1.36, 1.08, 0
4087, 1.38, 1.056, 0
4088, 1.4, 1.08, 0
4089, 1.42, 1.056, 0
4090, 1.44, 1.08, 0
4091, 1.46, 1.056, 0
4092, 1.48, 1.08, 0
4093, 1.5, 1.056, 0
4094, 1.52, 1.08, 0
4095, 1.54, 1.056, 0
4096, 1.56, 1.08, 0
4097, 1.58, 1.056, 0
4098, 1.6, 1.08, 0
4099, 1.62, 1.056, 0
4100, 1.64, 1.08, 0
4101, 1.66, 1.056, 0
4102, 1.68, 1.08, 0
4103, 1.7, 1.056, 0
4104, 1.72, 1.08, 0
4105, 1.74, 1.056, 0
4106, 1.76, 1.08, 0
4107, 1.78, 1.056, 0
4108, 1.8, 1.08, 0
4109, 1.82, 1.056, 0
4110, 1.84, 1.08, 0
4111, 1.86, 1.056, 0
4112, 1.88, 1.08, 0
4113, 1.9, 1.056, 0
4114, 1.92, 1.08, 0
4115, 1.94, 1.056, 0
4116, 1.96, 1.08, 0
4117, 1.98, 1.056, 0
4118, 2, 1.08, 0
4119, 2.02, 1.056, 0
4120, 2.04, 1.08, 0
4121, 2.06, 1.056, 0
4122, 2.08, 1.08, 0
4123, 2.1, 1.056, 0
4124, 2.12, 1.08, 0
4125, 2.14, 1.056, 0
4126, 2.16, 1.08, 0
4127, 2.18, 1.056, 0
4128, 1.22, 1.008, 0
4129, 1.24, 1.032, 0
4130, 1.26, 1.008, 0
4131, 1.28, 1.032, 0
4132, 1.3, 1.008, 0
4133, 1.32, 1.032, 0
4134, 1.34, 1.008, 0
4135, 1.36, 1.032, 0
4136, 1.38, 1.008, 0
4137, 1.4, 1.032, 0
4138, 1.42, 1.008, 0
4139, 1.44, 1.032, 0
4140, 1.46, 1.008, 0
4141, 1.48, 1.032, 0
4142, 1.5, 1.008, 0
4143, 1.52, 1.032, 0
4144, 1.54, 1.008, 0
4145, 1.56, 1.032, 0
4146, 1.58, 1.008, 0
4147, 1.6, 1.032, 0
4148, 1.62, 1.008, 0
4149, 1.64, 1.032, 0
4150, 1.66, 1.008, 0
4151, 1.68, 1.032, 0
4152, 1.7, 1.008, 0
4153, 1.72, 1.032, 0
4154, 1.74, 1.008, 0
4155, 1.76, 1.032, 0
4156, 1.78, 1.008, 0
4157, 1.8, 1.032, 0
4158, 1.82, 1.008, 0
4159, 1.84, 1.032, 0
4160, 1.86, 1.008, 0
4161, 1.88, 1.032, 0
4162, 1.9, 1.008, 0
4163, 1.92, 1.032, 0
4164, 1.94, 1.008, 0
4165, 1.96, 1.032, 0
4166, 1.98, 1.008, 0
4167, 2, 1.032, 0
4168, 2.02, 1.008, 0
4169, 2.04, 1.032, 0
4170, 2.06, 1.008, 0
4171, 2.08, 1.032, 0
4172, 2.1, 1.008, 0
4173, 2.12, 1.032, 0
4174, 2.14, 1.008, 0
4175, 2.16, 1.032, 0
4176, 2.18, 1.008, 0
4177, 1.22, 0.96, 0
4178, 1.24, 0.984, 0
4179, 1.26, 0.96, 0
4180, 1.28, 0.984, 0
4181, 1.3, 0.96, 0
4182, 1.32, 0.984, 0
4183, 1.34, 0.96, 0
4184, 1.36, 0.984, 0
4185, 1.38, 0.96, 0
4186, 1.4, 0.984, 0
4187, 1.42, 0.96, 0
4188, 1.44, 0.984, 0
4189, 1.46, 0.96, 0
4190, 1.48, 0.984, 0
4191, 1.5, 0.96, 0
4192, 1.52, 0.984, 0
4193, 1.54, 0.96, 0
4194, 1.56, 0.984, 0
4195, 1.58, 0.96, 0
4196, 1.6, 0.984, 0
4197, 1.62, 0.96, 0
4198, 1.64, 0.984, 0
4199, 1.66, 0.96, 0
4200, 1.68, 0.984, 0
4201, 1.7, 0.96, 0
4202, 1.72, 0.984, 0
4203, 1.74, 0.96, 0
4204, 1.76, 0.984, 0
4205, 1.78, 0.96, 0
4206, 1.8, 0.984, 0
4207, 1.82, 0.96, 0
4208, 1.84, 0.984, 0
4209, 1.86, 0.96, 0
4210, 1.88, 0.984, 0
4211, 1.9, 0.96, 0
4212, 1.92, 0.984, 0
4213, 1.94, 0.96, 0
4214, 1.96, 0.984, 0
4215, 1.98, 0.96, 0
4216, 2, 0.984, 0
4217, 2.02, 0.96, 0
4218, 2.04, 0.984, 0
4219, 2.06, 0.96, 0
4220, 2.08, 0.984, 0
4221, 2.1, 0.96, 0
4222, 2.12, 0.984, 0
4223, 2.14, 0.96, 0
4224, 2.16, 0.984, 0
4225, 2.18, 0.96, 0
4226, 1.22, 0.912, 0
4227, 1.24, 0.936, 0
4228, 1.26, 0.912, 0
4229, 1.28, 0.936, 0
4230, 1.3, 0.912, 0
4231, 1.32, 0.936, 0
4232, 1.34, 0.912, 0
4233, 1.36, 0.936, 0
4234, 1.38, 0.912, 0
4235, 1.4, 0.936, 0
4236, 1.42, 0.912, 0
4237, 1.44, 0.936, 0
4238, 1.46, 0.912, 0
4239, 1.48, 0.936, 0
4240, 1.5, 0.912, 0
4241, 1.52, 0.936, 0
4242, 1.54, 0.912, 0
4243, 1.56, 0.936, 0
4244, 1.58, 0.912, 0
4245, 1.6, 0.936, 0
4246, 1.62, 0.912, 0
4247, 1.64, 0.936, 0
4248, 1.66, 0.912, 0
4249, 1.68, 0.936, 0
4250, 1.7, 0.912, 0
4251, 1.72, 0.936, 0
4252, 1.74, 0.912, 0
4253, 1.76, 0.936, 0
4254, 1.78, 0.912, 0
4255, 1.8, 0.936, 0
4256, 1.82, 0.912, 0
4257, 1.84, 0.936, 0
4258, 1.86, 0.912, 0
4259, 1.88, 0.936, 0
4260, 1.9, 0.912, 0
4261, 1.92, 0.936, 0
4262, 1.94, 0.912, 0
4263, 1.96, 0.936, 0
4264, 1.98, 0.912, 0
4265, 2, 0.936, 0
4266, 2.02, 0.912, 0
4267, 2.04, 0.936, 0
4268, 2.06, 0.912, 0
4269, 2.08, 0.936, 0
4270, 2.1, 0.912, 0
4271, 2.12, 0.936, 0
4272, 2.14, 0.912, 0
4273, 2.16, 0.936, 0
4274, 2.18, 0.912, 0
4275, 1.22, 0.864, 0
4276, 1.24, 0.888, 0
4277, 1.26, 0.864, 0
4278, 1.28, 0.888, 0
4279, 1.3, 0.864, 0
4280, 1.32, 0.888, 0
4281, 1.34, 0.864, 0
4282, 1.36, 0.888, 0
4283, 1.38, 0.864, 0
4284, 1.4, 0.888, 0
4285, 1.42, 0.864, 0
4286, 1.44, 0.888, 0
4287, 1.46, 0.864, 0
4288, 1.48, 0.888, 0
4289, 1.5, 0.864, 0
4290, 1.52, 0.888, 0
4291, 1.54, 0.864, 0
4292, 1.56, 0.888, 0
4293, 1.58, 0.864, 0
4294, 1.6, 0.888, 0
4295, 1.62, 0.864, 0
4296, 1.64, 0.888, 0
4297, 1.66, 0.864, 0
4298, 1.68, 0.888, 0
4299, 1.7, 0.864, 0
4300, 1.72, 0.888, 0
4301, 1.74, 0.864, 0
4302, 1.76, 0.888, 0
4303, 1.78, 0.864, 0
4304, 1.8, 0.888, 0
4305, 1.82, 0.864, 0
4306, 1.84, 0.888, 0
4307, 1.86, 0.864, 0
4308, 1.88, 0.888, 0
4309, 1.9, 0.864, 0
4310, 1.92, 0.888, 0
4311, 1.94, 0.864, 0
4312, 1.96, 0.888, 0
4313, 1.98, 0.864, 0
4314, 2, 0.888, 0
4315, 2.02, 0.864, 0
4316, 2.04, 0.888, 0
4317, 2.06, 0.864, 0
4318, 2.08, 0.888, 0
4319, 2.1, 0.864, 0
4320, 2.12, 0.888, 0
4321, 2.14, 0.864, 0
4322, 2.16, 0.888, 0
4323, 2.18, 0.864, 0
4324, 1.22, 0.816, 0
4325, 1.24, 0.84, 0
4326, 1.26, 0.816, 0
4327, 1.28, 0.84, 0
4328, 1.3, 0.816, 0
4329, 1.32, 0.84, 0
4330, 1.34, 0.816, 0
4331, 1.36, 0.84, 0
4332, 1.38, 0.816, 0
4333, 1.4, 0.84, 0
4334, 1.42, 0.816, 0
4335, 1.44, 0.84, 0
4336, 1.46, 0.816, 0
4337, 1.48, 0.84, 0
4338, 1.5, 0.816, 0
4339, 1.52, 0.84, 0
4340, 1.54, 0.816, 0
4341, 1.56, 0.84, 0
4342, 1.58, 0.816, 0
4343, 1.6, 0.84, 0
4344, 1.62, 0.816, 0
4345, 1.64, 0.84, 0
4346, 1.66, 0.816, 0
4347, 1.68, 0.84, 0
4348, 1.7, 0.816, 0
4349, 1.72, 0.84, 0
4350, 1.74, 0.816, 0
4351, 1.76, 0.84, 0
4352, 1.78, 0.816, 0
4353, 1.8, 0.84, 0
4354, 1.82, 0.816, 0
4355, 1.84, 0.84, 0
4356, 1.86, 0.816, 0
4357, 1.88, 0.84, 0
4358, 1.9, 0.816, 0
4359, 1.92, 0.84, 0
4360, 1.94, 0.816, 0
4361, 1.96, 0.84, 0
4362, 1.98, 0.816, 0
4363, 2, 0.84, 0
4364, 2.02, 0.816, 0
4365, 2.04, 0.84, 0
4366, 2.06, 0.816, 0
4367, 2.08, 0.84, 0
4368, 2.1, 0.816, 0
4369, 2.12, 0.84, 0
4370, 2.14, 0.816, 0
4371, 2.16, 0.84, 0
4372, 2.18, 0.816, 0
4373, 1.22, 0.768, 0
4374, 1.24, 0.792, 0
4375, 1.26, 0.768, 0
4376, 1.28, 0.792, 0
4377, 1.3, 0.768, 0
4378, 1.32, 0.792, 0
4379, 1.34, 0.768, 0
4380, 1.36, 0.792, 0
4381, 1.38, 0.768, 0
4382, 1.4, 0.792, 0
4383, 1.42, 0.768, 0
4384, 1.44, 0.792, 0
4385, 1.46, 0.768, 0
4386, 1.48, 0.792, 0
4387, 1.5, 0.768, 0
4388, 1.52, 0.792, 0
4389, 1.54, 0.768, 0
4390, 1.56, 0.792, 0
4391, 1.58, 0.768, 0
4392, 1.6, 0.792, 0
4393, 1.62, 0.768, 0
4394, 1.64, 0.792, 0
4395, 1.66, 0.768, 0
4396, 1.68, 0.792, 0
4397, 1.7, 0.768, 0
4398, 1.72, 0.792, 0
4399, 1.74, 0.768, 0
4400, 1.76, 0.792, 0
4401, 1.78, 0.768, 0
4402, 1.8, 0.792, 0
4403, 1.82, 0.768, 0
4404, 1.84, 0.792, 0
4405, 1.86, 0.768, 0
4406, 1.88, 0.792, 0
4407, 1.9, 0.768, 0
4408, 1.92, 0.792, 0
4409, 1.94, 0.768, 0
4410, 1.96, 0.792, 0
4411, 1.98, 0.768, 0
4412, 2, 0.792, 0
4413, 2.02, 0.768, 0
4414, 2.04, 0.792, 0
4415, 2.06, 0.768, 0
4416, 2.08, 0.792, 0
4417, 2.1, 0.768, 0
4418, 2.12, 0.792, 0
4419, 2.14, 0.768, 0
4420, 2.16, 0.792, 0
4421, 2.18, 0.768, 0
4422, 1.22, 0.72, 0
4423, 1.24, 0.744, 0
4424, 1.26, 0.72, 0
4425, 1.28, 0.744, 0
4426, 1.3, 0.72, 0
4427, 1.32, 0.744, 0
4428, 1.34, 0.72, 0
4429, 1.36, 0.744, 0
4430, 1.38, 0.72, 0
4431, 1.4, 0.744, 0
4432, 1.42, 0.72, 0
4433, 1.44, 0.744, 0
4434, 1.46, 0.72, 0
4435, 1.48, 0.744, 0
4436, 1.5, 0.72, 0
4437, 1.52, 0.744, 0
4438, 1.54, 0.72, 0
4439, 1.56, 0.744, 0
4440, 1.58, 0.72, 0
4441, 1.6, 0.744, 0
4442, 1.62, 0.72, 0
4443, 1.64, 0.744, 0
4444, 1.66, 0.72, 0
4445, 1.68, 0.744, 0
4446, 1.7, 0.72, 0
4447, 1.72, 0.744, 0
4448, 1.74, 0.72, 0
4449, 1.76, 0.744, 0
4450, 1.78, 0.72, 0
4451, 1.8, 0.744, 0
4452, 1.82, 0.72, 0
4453, 1.84, 0.744, 0
4454, 1.86, 0.72, 0
4455, 1.88, 0.744, 0
4456, 1.9, 0.72, 0
4457, 1.92, 0.744, 0
4458, 1.94, 0.72, 0
4459, 1.96, 0.744, 0
4460, 1.98, 0.72, 0
4461, 2, 0.744, 0
4462, 2.02, 0.72, 0
4463, 2.04, 0.744, 0
4464, 2.06, 0.72, 0
4465, 2.08, 0.744, 0
4466, 2.1, 0.72, 0
4467, 2.12, 0.744, 0
4468, 2.14, 0.72, 0
4469, 2.16, 0.744, 0
4470, 2.18, 0.72, 0
4471, 1.22, 0.672, 0
4472, 1.24, 0.696, 0
4473, 1.26, 0.672, 0
4474, 1.28, 0.696, 0
4475, 1.3, 0.672, 0
4476, 1.32, 0.696, 0
4477, 1.34, 0.672, 0
4478, 1.36, 0.696, 0
4479, 1.38, 0.672, 0
4480, 1.4, 0.696, 0
4481, 1.42, 0.672, 0
4482, 1.44, 0.696, 0
4483, 1.46, 0.672, 0
4484, 1.48, 0.696, 0
4485, 1.5, 0.672, 0
4486, 1.52, 0.696, 0
4487, 1.54, 0.672, 0
4488, 1.56, 0.696, 0
4489, 1.58, 0.672, 0
4490, 1.6, 0.696, 0
4491, 1.62, 0.672, 0
4492, 1.64, 0.696, 0
4493, 1.66, 0.672, 0
4494, 1.68, 0.696, 0
4495, 1.7, 0.672, 0
4496, 1.72, 0.696, 0
4497, 1.74, 0.672, 0
4498, 1.76, 0.696, 0
4499, 1.78, 0.672, 0
4500, 1.8, 0.696, 0
4501, 1.82, 0.672, 0
4502, 1.84, 0.696, 0
4503, 1.86, 0.672, 0
4504, 1.88, 0.696, 0
4505, 1.9, 0.672, 0
4506, 1.92, 0.696, 0
4507, 1.94, 0.672, 0
4508, 1.96, 0.696, 0
4509, 1.98, 0.672, 0
4510, 2, 0.696, 0
4511, 2.02, 0.672, 0
4512, 2.04, 0.696, 0
4513, 2.06, 0.672, 0
4514, 2.08, 0.696, 0
4515, 2.1, 0.672, 0
4516, 2.12, 0.696, 0
4517, 2.14, 0.672, 0
4518, 2.16, 0.696, 0
4519, 2.18, 0.672, 0
4520, 1.22, 0.624, 0
4521, 1.24, 0.648, 0
4522, 1.26, 0.624, 0
4523, 1.28, 0.648, 0
4524, 1.3, 0.624, 0
4525, 1.32, 0.648, 0
4526, 1.34, 0.624, 0
4527, 1.36, 0.648, 0
4528, 1.38, 0.624, 0
4529, 1.4, 0.648, 0
4530, 1.42, 0.624, 0
4531, 1.44, 0.648, 0
4532, 1.46, 0.624, 0
4533, 1.48, 0.648, 0
4534, 1.5, 0.624, 0
4535, 1.52, 0.648, 0
4536, 1.54, 0.624, 0
4537, 1.56, 0.648, 0
4538, 1.58, 0.624, 0
4539, 1.6, 0.648, 0
4540, 1.62, 0.624, 0
4541, 1.64, 0.648, 0
4542, 1.66, 0.624, 0
4543, 1.68, 0.648, 0
4544, 1.7, 0.624, 0
4545, 1.72, 0.648, 0
4546, 1.74, 0.624, 0
4547, 1.76, 0.648, 0
4548, 1.78, 0.624, 0
4549, 1.8, 0.648, 0
4550, 1.82, 0.624, 0
4551, 1.84, 0.648, 0
4552, 1.86, 0.624, 0
4553, 1.88, 0.648, 0
4554, 1.9, 0.624, 0
4555, 1.92, 0.648, 0
4556, 1.94, 0.624, 0
4557, 1.96, 0.648, 0
4558, 1.98, 0.624, 0
4559, 2, 0.648, 0
4560, 2.02, 0.624, 0
4561, 2.04, 0.648, 0
4562, 2.06, 0.624, 0
4563, 2.08, 0.648, 0
4564, 2.1, 0.624, 0
4565, 2.12, 0.648, 0
4566, 2.14, 0.624, 0
4567, 2.16, 0.648, 0
4568, 2.18, 0.624, 0
4569, 1.22, 0.576, 0
4570, 1.24, 0.6, 0
4571, 1.26, 0.576, 0
4572, 1.28, 0.6, 0
4573, 1.3, 0.576, 0
4574, 1.32, 0.6, 0
4575, 1.34, 0.576, 0
4576, 1.36, 0.6, 0
4577, 1.38, 0.576, 0
4578, 1.4, 0.6, 0
4579, 1.42, 0.576, 0
4580, 1.44, 0.6, 0
4581, 1.46, 0.576, 0
4582, 1.48, 0.6, 0
4583, 1.5, 0.576, 0
4584, 1.52, 0.6, 0
4585, 1.54, 0.576, 0
4586, 1.56, 0.6, 0
4587, 1.58, 0.576, 0
4588, 1.6, 0.6, 0
4589, 1.62, 0.576, 0
4590, 1.64, 0.6, 0
4591, 1.66, 0.576, 0
4592, 1.68, 0.6, 0
4593, 1.7, 0.576, 0
4594, 1.72, 0.6, 0
4595, 1.74, 0.576, 0
4596, 1.76, 0.6, 0
4597, 1.78, 0.576, 0
4598, 1.8, 0.6, 0
4599, 1.82, 0.576, 0
4600, 1.84, 0.6, 0
4601, 1.86, 0.576, 0
4602, 1.88, 0.6, 0
4603, 1.9, 0.576, 0
4604, 1.92, 0.6, 0
4605, 1.94, 0.576, 0
4606, 1.96, 0.6, 0
4607, 1.98, 0.576, 0
4608, 2, 0.6, 0
4609, 2.02, 0.576, 0
4610, 2.04, 0.6, 0
4611, 2.06, 0.576, 0
4612, 2.08, 0.6, 0
4613, 2.1, 0.576, 0
4614, 2.12, 0.6, 0
4615, 2.14, 0.576, 0
4616, 2.16, 0.6, 0
4617, 2.18, 0.576, 0
4618, 1.22, 0.528, 0
4619, 1.24, 0.552, 0
4620, 1.26, 0.528, 0
4621, 1.28, 0.552, 0
4622, 1.3, 0.528, 0
4623, 1.32, 0.552, 0
4624, 1.34, 0.528, 0
4625, 1.36, 0.552, 0
4626, 1.38, 0.528, 0
4627, 1.4, 0.552, 0
4628, 1.42, 0.528, 0
4629, 1.44, 0.552, 0
4630, 1.46, 0.528, 0
4631, 1.48, 0.552, 0
4632, 1.5, 0.528, 0
4633, 1.52, 0.552, 0
4634, 1.54, 0.528, 0
4635, 1.56, 0.552, 0
4636, 1.58, 0.528, 0
4637, 1.6, 0.552, 0
4638, 1.62, 0.528, 0
4639, 1.64, 0.552, 0
4640, 1.66, 0.528, 0
4641, 1.68, 0.552, 0
4642, 1.7, 0.528, 0
4643, 1.72, 0.552, 0
4644, 1.74, 0.528, 0
4645, 1.76, 0.552, 0
4646, 1.78, 0.528, 0
4647, 1.8, 0.552, 0
4648, 1.82, 0.528, 0
4649, 1.84, 0.552, 0
4650, 1.86, 0.528, 0
4651, 1.88, 0.552, 0
4652, 1.9, 0.528, 0
4653, 1.92, 0.552, 0
4654, 1.94, 0.528, 0
4655, 1.96, 0.552, 0
4656, 1.98, 0.528, 0
4657, 2, 0.552, 0
4658, 2.02, 0.528, 0
4659, 2.04, 0.552, 0
4660, 2.06, 0.528, 0
4661, 2.08, 0.552, 0
4662, 2.1, 0.528, 0
4663, 2.12, 0.552, 0
4664, 2.14, 0.528, 0
4665, 2.16, 0.552, 0
4666, 2.18, 0.528, 0
4667, 1.22, 0.48, 0
4668, 1.24, 0.504, 0
4669, 1.26, 0.48, 0
4670, 1.28, 0.504, 0
4671, 1.3, 0.48, 0
4672, 1.32, 0.504, 0
4673, 1.34, 0.48, 0
4674, 1.36, 0.504, 0
4675, 1.38, 0.48, 0
4676, 1.4, 0.504, 0
4677, 1.42, 0.48, 0
4678, 1.44, 0.504, 0
4679, 1.46, 0.48, 0
4680, 1.48, 0.504, 0
4681, 1.5, 0.48, 0
4682, 1.52, 0.504, 0
4683, 1.54, 0.48, 0
4684, 1.56, 0.504, 0
4685, 1.58, 0.48, 0
4686, 1.6, 0.504, 0
4687, 1.62, 0.48, 0
4688, 1.64, 0.504, 0
4689, 1.66, 0.48, 0
4690, 1.68, 0.504, 0
4691, 1.7, 0.48, 0
4692, 1.72, 0.504, 0
4693, 1.74, 0.48, 0
4694, 1.76, 0.504, 0
4695, 1.78, 0.48, 0
4696, 1.8, 0.504, 0
4697, 1.82, 0.48, 0
4698, 1.84, 0.504, 0
4699, 1.86, 0.48, 0
4700, 1.88, 0.504, 0
4701, 1.9, 0.48, 0
4702, 1.92, 0.504, 0
4703, 1.94, 0.48, 0
4704, 1.96, 0.504, 0
4705, 1.98, 0.48, 0
4706, 2, 0.504, 0
4707, 2.02, 0.48, 0
4708, 2.04, 0.504, 0
4709, 2.06, 0.48, 0
4710, 2.08, 0.504, 0
4711, 2.1, 0.48, 0
4712, 2.12, 0.504, 0
4713, 2.14, 0.48, 0
4714, 2.16, 0.504, 0
4715, 2.18, 0.48, 0
4716, 1.22, 0.432, 0
4717, 1.24, 0.456, 0
4718, 1.26, 0.432, 0
4719, 1.28, 0.456, 0
4720, 1.3, 0.432, 0
4721, 1.32, 0.456, 0
4722, 1.34, 0.432, 0
4723, 1.36, 0.456, 0
4724, 1.38, 0.432, 0
4725, 1.4, 0.456, 0
4726, 1.42, 0.432, 0
4727, 1.44, 0.456, 0
4728, 1.46, 0.432, 0
4729, 1.48, 0.456, 0
4730, 1.5, 0.432, 0
4731, 1.52, 0.456, 0
4732, 1.54, 0.432, 0
4733, 1.56, 0.456, 0
4734, 1.58, 0.432, 0
4735, 1.6, 0.456, 0
4736, 1.62, 0.432, 0
4737, 1.64, 0.456, 0
4738, 1.66, 0.432, 0
4739, 1.68, 0.456, 0
4740, 1.7, 0.432, 0
4741, 1.72, 0.456, 0
4742, 1.74, 0.432, 0
4743, 1.76, 0.456, 0
4744, 1.78, 0.432, 0
4745, 1.8, 0.456, 0
4746, 1.82, 0.432, 0
4747, 1.84, 0.456, 0
4748, 1.86, 0.432, 0
4749, 1.88, 0.456, 0
4750, 1.9, 0.432, 0
4751, 1.92, 0.456, 0
4752, 1.94, 0.432, 0
4753, 1.96, 0.456, 0
4754, 1.98, 0.432, 0
4755, 2, 0.456, 0
4756, 2.02, 0.432, 0
4757, 2.04, 0.456, 0
4758, 2.06, 0.432, 0
4759, 2.08, 0.456, 0
4760, 2.1, 0.432, 0
4761, 2.12, 0.456, 0
4762, 2.14, 0.432, 0
4763, 2.16, 0.456, 0
4764, 2.18, 0.432, 0
4765, 1.22, 0.384, 0
4766, 1.24, 0.408, 0
4767, 1.26, 0.384, 0
4768, 1.28, 0.408, 0
4769, 1.3, 0.384, 0
4770, 1.32, 0.408, 0
4771, 1.34, 0.384, 0
4772, 1.36, 0.408, 0
