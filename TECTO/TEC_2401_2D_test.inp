876, 1840, 170, 171, 1841, 3040, 195, 3041, 3015
877, 1841, 171, 7, 197, 3041, 196, 221, 3017
*ELEMENT, type=CPS8, ELSET=Surface2
878, 25, 676, 3042, 681, 678, 3090, 3091, 705
879, 681, 3042, 3043, 682, 3091, 3092, 3093, 706
880, 682, 3043, 3044, 683, 3093, 3094, 3095, 707
881, 683, 3044, 3045, 684, 3095, 3096, 3097, 708
882, 684, 3045, 3046, 685, 3097, 3098, 3099, 709
883, 685, 3046, 3047, 686, 3099, 3100, 3101, 710
884, 686, 3047, 3048, 687, 3101, 3102, 3103, 711
885, 687, 3048, 3049, 688, 3103, 3104, 3105, 712
886, 688, 3049, 3050, 689, 3105, 3106, 3107, 713
887, 689, 3050, 3051, 690, 3107, 3108, 3109, 714
888, 690, 3051, 3052, 691, 3109, 3110, 3111, 715
889, 691, 3052, 3053, 692, 3111, 3112, 3113, 716
890, 692, 3053, 3054, 693, 3113, 3114, 3115, 717
891, 693, 3054, 3055, 694, 3115, 3116, 3117, 718
892, 694, 3055, 3056, 695, 3117, 3118, 3119, 719
893, 695, 3056, 3057, 696, 3119, 3120, 3121, 720
894, 696, 3057, 3058, 697, 3121, 3122, 3123, 721
895, 697, 3058, 3059, 698, 3123, 3124, 3125, 722
896, 698, 3059, 3060, 699, 3125, 3126, 3127, 723
897, 699, 3060, 3061, 700, 3127, 3128, 3129, 724
898, 700, 3061, 3062, 701, 3129, 3130, 3131, 725
899, 701, 3062, 3063, 702, 3131, 3132, 3133, 726
900, 702, 3063, 3064, 703, 3133, 3134, 3135, 727
901, 703, 3064, 3065, 704, 3135, 3136, 3137, 728
902, 704, 3065, 1012, 26, 3137, 3138, 1014, 729
903, 676, 677, 3066, 3042, 679, 3139, 3140, 3090
904, 3042, 3066, 3067, 3043, 3140, 3141, 3142, 3092
905, 3043, 3067, 3068, 3044, 3142, 3143, 3144, 3094
906, 3044, 3068, 3069, 3045, 3144, 3145, 3146, 3096
907, 3045, 3069, 3070, 3046, 3146, 3147, 3148, 3098
908, 3046, 3070, 3071, 3047, 3148, 3149, 3150, 3100
909, 3047, 3071, 3072, 3048, 3150, 3151, 3152, 3102
910, 3048, 3072, 3073, 3049, 3152, 3153, 3154, 3104
911, 3049, 3073, 3074, 3050, 3154, 3155, 3156, 3106
912, 3050, 3074, 3075, 3051, 3156, 3157, 3158, 3108
913, 3051, 3075, 3076, 3052, 3158, 3159, 3160, 3110
914, 3052, 3076, 3077, 3053, 3160, 3161, 3162, 3112
915, 3053, 3077, 3078, 3054, 3162, 3163, 3164, 3114
916, 3054, 3078, 3079, 3055, 3164, 3165, 3166, 3116
917, 3055, 3079, 3080, 3056, 3166, 3167, 3168, 3118
918, 3056, 3080, 3081, 3057, 3168, 3169, 3170, 3120
919, 3057, 3081, 3082, 3058, 3170, 3171, 3172, 3122
920, 3058, 3082, 3083, 3059, 3172, 3173, 3174, 3124
921, 3059, 3083, 3084, 3060, 3174, 3175, 3176, 3126
922, 3060, 3084, 3085, 3061, 3176, 3177, 3178, 3128
923, 3061, 3085, 3086, 3062, 3178, 3179, 3180, 3130
924, 3062, 3086, 3087, 3063, 3180, 3181, 3182, 3132
925, 3063, 3087, 3088, 3064, 3182, 3183, 3184, 3134
926, 3064, 3088, 3089, 3065, 3184, 3185, 3186, 3136
927, 3065, 3089, 1013, 1012, 3186, 3187, 1015, 3138
928, 677, 1, 1017, 3066, 680, 1041, 3188, 3139
929, 3066, 1017, 1018, 3067, 3188, 1042, 3189, 3141
930, 3067, 1018, 1019, 3068, 3189, 1043, 3190, 3143
931, 3068, 1019, 1020, 3069, 3190, 1044, 3191, 3145
932, 3069, 1020, 1021, 3070, 3191, 1045, 3192, 3147
933, 3070, 1021, 1022, 3071, 3192, 1046, 3193, 3149
934, 3071, 1022, 1023, 3072, 3193, 1047, 3194, 3151
935, 3072, 1023, 1024, 3073, 3194, 1048, 3195, 3153
936, 3073, 1024, 1025, 3074, 3195, 1049, 3196, 3155
937, 3074, 1025, 1026, 3075, 3196, 1050, 3197, 3157
938, 3075, 1026, 1027, 3076, 3197, 1051, 3198, 3159
939, 3076, 1027, 1028, 3077, 3198, 1052, 3199, 3161
940, 3077, 1028, 1029, 3078, 3199, 1053, 3200, 3163
941, 3078, 1029, 1030, 3079, 3200, 1054, 3201, 3165
942, 3079, 1030, 1031, 3080, 3201, 1055, 3202, 3167
943, 3080, 1031, 1032, 3081, 3202, 1056, 3203, 3169
944, 3081, 1032, 1033, 3082, 3203, 1057, 3204, 3171
945, 3082, 1033, 1034, 3083, 3204, 1058, 3205, 3173
946, 3083, 1034, 1035, 3084, 3205, 1059, 3206, 3175
947, 3084, 1035, 1036, 3085, 3206, 1060, 3207, 3177
948, 3085, 1036, 1037, 3086, 3207, 1061, 3208, 3179
949, 3086, 1037, 1038, 3087, 3208, 1062, 3209, 3181
950, 3087, 1038, 1039, 3088, 3209, 1063, 3210, 3183
951, 3088, 1039, 1040, 3089, 3210, 1064, 3211, 3185
952, 3089, 1040, 35, 1013, 3211, 1065, 1016, 3187
*ELEMENT, type=CPS8, ELSET=Surface3
953, 25, 730, 3212, 676, 733, 3218, 3219, 678
954, 676, 3212, 3213, 677, 3219, 3220, 3221, 679
955, 677, 3213, 295, 1, 3221, 3222, 298, 680
956, 730, 731, 3214, 3212, 734, 3223, 3224, 3218
957, 3212, 3214, 3215, 3213, 3224, 3225, 3226, 3220
958, 3213, 3215, 296, 295, 3226, 3227, 299, 3222
959, 731, 732, 3216, 3214, 735, 3228, 3229, 3223
960, 3214, 3216, 3217, 3215, 3229, 3230, 3231, 3225
961, 3215, 3217, 297, 296, 3231, 3232, 300, 3227
962, 732, 3, 302, 3216, 736, 304, 3233, 3228
963, 3216, 302, 303, 3217, 3233, 305, 3234, 3230
964, 3217, 303, 9, 297, 3234, 306, 301, 3232
*ELEMENT, type=CPS8, ELSET=Surface4
965, 3, 50, 3235, 302, 74, 3283, 3284, 304
966, 302, 3235, 3236, 303, 3284, 3285, 3286, 305
967, 303, 3236, 1066, 9, 3286, 3287, 1090, 306
968, 50, 51, 3237, 3235, 75, 3288, 3289, 3283
969, 3235, 3237, 3238, 3236, 3289, 3290, 3291, 3285
970, 3236, 3238, 1067, 1066, 3291, 3292, 1091, 3287
971, 51, 52, 3239, 3237, 76, 3293, 3294, 3288
972, 3237, 3239, 3240, 3238, 3294, 3295, 3296, 3290
973, 3238, 3240, 1068, 1067, 3296, 3297, 1092, 3292
974, 52, 53, 3241, 3239, 77, 3298, 3299, 3293
975, 3239, 3241, 3242, 3240, 3299, 3300, 3301, 3295
976, 3240, 3242, 1069, 1068, 3301, 3302, 1093, 3297
977, 53, 54, 3243, 3241, 78, 3303, 3304, 3298
978, 3241, 3243, 3244, 3242, 3304, 3305, 3306, 3300
979, 3242, 3244, 1070, 1069, 3306, 3307, 1094, 3302
980, 54, 55, 3245, 3243, 79, 3308, 3309, 3303
981, 3243, 3245, 3246, 3244, 3309, 3310, 3311, 3305
982, 3244, 3246, 1071, 1070, 3311, 3312, 1095, 3307
983, 55, 56, 3247, 3245, 80, 3313, 3314, 3308
984, 3245, 3247, 3248, 3246, 3314, 3315, 3316, 3310
985, 3246, 3248, 1072, 1071, 3316, 3317, 1096, 3312
986, 56, 57, 3249, 3247, 81, 3318, 3319, 3313
987, 3247, 3249, 3250, 3248, 3319, 3320, 3321, 3315
988, 3248, 3250, 1073, 1072, 3321, 3322, 1097, 3317
989, 57, 58, 3251, 3249, 82, 3323, 3324, 3318
990, 3249, 3251, 3252, 3250, 3324, 3325, 3326, 3320
991, 3250, 3252, 1074, 1073, 3326, 3327, 1098, 3322
992, 58, 59, 3253, 3251, 83, 3328, 3329, 3323
993, 3251, 3253, 3254, 3252, 3329, 3330, 3331, 3325
994, 3252, 3254, 1075, 1074, 3331, 3332, 1099, 3327
995, 59, 60, 3255, 3253, 84, 3333, 3334, 3328
996, 3253, 3255, 3256, 3254, 3334, 3335, 3336, 3330
997, 3254, 3256, 1076, 1075, 3336, 3337, 1100, 3332
998, 60, 61, 3257, 3255, 85, 3338, 3339, 3333
999, 3255, 3257, 3258, 3256, 3339, 3340, 3341, 3335
1000, 3256, 3258, 1077, 1076, 3341, 3342, 1101, 3337
1001, 61, 62, 3259, 3257, 86, 3343, 3344, 3338
1002, 3257, 3259, 3260, 3258, 3344, 3345, 3346, 3340
1003, 3258, 3260, 1078, 1077, 3346, 3347, 1102, 3342
1004, 62, 63, 3261, 3259, 87, 3348, 3349, 3343
1005, 3259, 3261, 3262, 3260, 3349, 3350, 3351, 3345
1006, 3260, 3262, 1079, 1078, 3351, 3352, 1103, 3347
1007, 63, 64, 3263, 3261, 88, 3353, 3354, 3348
1008, 3261, 3263, 3264, 3262, 3354, 3355, 3356, 3350
1009, 3262, 3264, 1080, 1079, 3356, 3357, 1104, 3352
1010, 64, 65, 3265, 3263, 89, 3358, 3359, 3353
1011, 3263, 3265, 3266, 3264, 3359, 3360, 3361, 3355
1012, 3264, 3266, 1081, 1080, 3361, 3362, 1105, 3357
1013, 65, 66, 3267, 3265, 90, 3363, 3364, 3358
1014, 3265, 3267, 3268, 3266, 3364, 3365, 3366, 3360
1015, 3266, 3268, 1082, 1081, 3366, 3367, 1106, 3362
1016, 66, 67, 3269, 3267, 91, 3368, 3369, 3363
1017, 3267, 3269, 3270, 3268, 3369, 3370, 3371, 3365
1018, 3268, 3270, 1083, 1082, 3371, 3372, 1107, 3367
1019, 67, 68, 3271, 3269, 92, 3373, 3374, 3368
1020, 3269, 3271, 3272, 3270, 3374, 3375, 3376, 3370
1021, 3270, 3272, 1084, 1083, 3376, 3377, 1108, 3372
1022, 68, 69, 3273, 3271, 93, 3378, 3379, 3373
1023, 3271, 3273, 3274, 3272, 3379, 3380, 3381, 3375
1024, 3272, 3274, 1085, 1084, 3381, 3382, 1109, 3377
1025, 69, 70, 3275, 3273, 94, 3383, 3384, 3378
1026, 3273, 3275, 3276, 3274, 3384, 3385, 3386, 3380
1027, 3274, 3276, 1086, 1085, 3386, 3387, 1110, 3382
1028, 70, 71, 3277, 3275, 95, 3388, 3389, 3383
1029, 3275, 3277, 3278, 3276, 3389, 3390, 3391, 3385
1030, 3276, 3278, 1087, 1086, 3391, 3392, 1111, 3387
1031, 71, 72, 3279, 3277, 96, 3393, 3394, 3388
1032, 3277, 3279, 3280, 3278, 3394, 3395, 3396, 3390
1033, 3278, 3280, 1088, 1087, 3396, 3397, 1112, 3392
1034, 72, 73, 3281, 3279, 97, 3398, 3399, 3393
1035, 3279, 3281, 3282, 3280, 3399, 3400, 3401, 3395
1036, 3280, 3282, 1089, 1088, 3401, 3402, 1113, 3397
1037, 73, 4, 1115, 3281, 98, 1117, 3403, 3398
1038, 3281, 1115, 1116, 3282, 3403, 1118, 3404, 3400
1039, 3282, 1116, 36, 1089, 3404, 1119, 1114, 3402
*ELEMENT, type=CPS8, ELSET=Surface5
1040, 10, 307, 3405, 405, 331, 3981, 3982, 429
1041, 405, 3405, 3406, 406, 3982, 3983, 3984, 430
1042, 406, 3406, 3407, 407, 3984, 3985, 3986, 431
1043, 407, 3407, 3408, 408, 3986, 3987, 3988, 432
1044, 408, 3408, 3409, 409, 3988, 3989, 3990, 433
1045, 409, 3409, 3410, 410, 3990, 3991, 3992, 434
1046, 410, 3410, 3411, 411, 3992, 3993, 3994, 435
1047, 411, 3411, 3412, 412, 3994, 3995, 3996, 436
1048, 412, 3412, 3413, 413, 3996, 3997, 3998, 437
1049, 413, 3413, 3414, 414, 3998, 3999, 4000, 438
1050, 414, 3414, 3415, 415, 4000, 4001, 4002, 439
1051, 415, 3415, 3416, 416, 4002, 4003, 4004, 440
1052, 416, 3416, 3417, 417, 4004, 4005, 4006, 441
1053, 417, 3417, 3418, 418, 4006, 4007, 4008, 442
1054, 418, 3418, 3419, 419, 4008, 4009, 4010, 443
1055, 419, 3419, 3420, 420, 4010, 4011, 4012, 444
1056, 420, 3420, 3421, 421, 4012, 4013, 4014, 445
1057, 421, 3421, 3422, 422, 4014, 4015, 4016, 446
1058, 422, 3422, 3423, 423, 4016, 4017, 4018, 447
1059, 423, 3423, 3424, 424, 4018, 4019, 4020, 448
1060, 424, 3424, 3425, 425, 4020, 4021, 4022, 449
1061, 425, 3425, 3426, 426, 4022, 4023, 4024, 450
1062, 426, 3426, 3427, 427, 4024, 4025, 4026, 451
1063, 427, 3427, 3428, 428, 4026, 4027, 4028, 452
1064, 428, 3428, 356, 12, 4028, 4029, 380, 453
1065, 307, 308, 3429, 3405, 332, 4030, 4031, 3981
1066, 3405, 3429, 3430, 3406, 4031, 4032, 4033, 3983
1067, 3406, 3430, 3431, 3407, 4033, 4034, 4035, 3985
1068, 3407, 3431, 3432, 3408, 4035, 4036, 4037, 3987
1069, 3408, 3432, 3433, 3409, 4037, 4038, 4039, 3989
1070, 3409, 3433, 3434, 3410, 4039, 4040, 4041, 3991
1071, 3410, 3434, 3435, 3411, 4041, 4042, 4043, 3993
1072, 3411, 3435, 3436, 3412, 4043, 4044, 4045, 3995
1073, 3412, 3436, 3437, 3413, 4045, 4046, 4047, 3997
1074, 3413, 3437, 3438, 3414, 4047, 4048, 4049, 3999
1075, 3414, 3438, 3439, 3415, 4049, 4050, 4051, 4001
1076, 3415, 3439, 3440, 3416, 4051, 4052, 4053, 4003
1077, 3416, 3440, 3441, 3417, 4053, 4054, 4055, 4005
1078, 3417, 3441, 3442, 3418, 4055, 4056, 4057, 4007
1079, 3418, 3442, 3443, 3419, 4057, 4058, 4059, 4009
1080, 3419, 3443, 3444, 3420, 4059, 4060, 4061, 4011
1081, 3420, 3444, 3445, 3421, 4061, 4062, 4063, 4013
1082, 3421, 3445, 3446, 3422, 4063, 4064, 4065, 4015
1083, 3422, 3446, 3447, 3423, 4065, 4066, 4067, 4017
1084, 3423, 3447, 3448, 3424, 4067, 4068, 4069, 4019
1085, 3424, 3448, 3449, 3425, 4069, 4070, 4071, 4021
1086, 3425, 3449, 3450, 3426, 4071, 4072, 4073, 4023
1087, 3426, 3450, 3451, 3427, 4073, 4074, 4075, 4025
1088, 3427, 3451, 3452, 3428, 4075, 4076, 4077, 4027
1089, 3428, 3452, 357, 356, 4077, 4078, 381, 4029
1090, 308, 309, 3453, 3429, 333, 4079, 4080, 4030
1091, 3429, 3453, 3454, 3430, 4080, 4081, 4082, 4032
1092, 3430, 3454, 3455, 3431, 4082, 4083, 4084, 4034
1093, 3431, 3455, 3456, 3432, 4084, 4085, 4086, 4036
1094, 3432, 3456, 3457, 3433, 4086, 4087, 4088, 4038
1095, 3433, 3457, 3458, 3434, 4088, 4089, 4090, 4040
1096, 3434, 3458, 3459, 3435, 4090, 4091, 4092, 4042
1097, 3435, 3459, 3460, 3436, 4092, 4093, 4094, 4044
1098, 3436, 3460, 3461, 3437, 4094, 4095, 4096, 4046
1099, 3437, 3461, 3462, 3438, 4096, 4097, 4098, 4048
1100, 3438, 3462, 3463, 3439, 4098, 4099, 4100, 4050
1101, 3439, 3463, 3464, 3440, 4100, 4101, 4102, 4052
1102, 3440, 3464, 3465, 3441, 4102, 4103, 4104, 4054
1103, 3441, 3465, 3466, 3442, 4104, 4105, 4106, 4056
1104, 3442, 3466, 3467, 3443, 4106, 4107, 4108, 4058
1105, 3443, 3467, 3468, 3444, 4108, 4109, 4110, 4060
1106, 3444, 3468, 3469, 3445, 4110, 4111, 4112, 4062
1107, 3445, 3469, 3470, 3446, 4112, 4113, 4114, 4064
1108, 3446, 3470, 3471, 3447, 4114, 4115, 4116, 4066
1109, 3447, 3471, 3472, 3448, 4116, 4117, 4118, 4068
1110, 3448, 3472, 3473, 3449, 4118, 4119, 4120, 4070
1111, 3449, 3473, 3474, 3450, 4120, 4121, 4122, 4072
1112, 3450, 3474, 3475, 3451, 4122, 4123, 4124, 4074
1113, 3451, 3475, 3476, 3452, 4124, 4125, 4126, 4076
1114, 3452, 3476, 358, 357, 4126, 4127, 382, 4078
1115, 309, 310, 3477, 3453, 334, 4128, 4129, 4079
1116, 3453, 3477, 3478, 3454, 4129, 4130, 4131, 4081
1117, 3454, 3478, 3479, 3455, 4131, 4132, 4133, 4083
1118, 3455, 3479, 3480, 3456, 4133, 4134, 4135, 4085
1119, 3456, 3480, 3481, 3457, 4135, 4136, 4137, 4087
1120, 3457, 3481, 3482, 3458, 4137, 4138, 4139, 4089
1121, 3458, 3482, 3483, 3459, 4139, 4140, 4141, 4091
1122, 3459, 3483, 3484, 3460, 4141, 4142, 4143, 4093
1123, 3460, 3484, 3485, 3461, 4143, 4144, 4145, 4095
1124, 3461, 3485, 3486, 3462, 4145, 4146, 4147, 4097
1125, 3462, 3486, 3487, 3463, 4147, 4148, 4149, 4099
1126, 3463, 3487, 3488, 3464, 4149, 4150, 4151, 4101
1127, 3464, 3488, 3489, 3465, 4151, 4152, 4153, 4103
1128, 3465, 3489, 3490, 3466, 4153, 4154, 4155, 4105
1129, 3466, 3490, 3491, 3467, 4155, 4156, 4157, 4107
1130, 3467, 3491, 3492, 3468, 4157, 4158, 4159, 4109
1131, 3468, 3492, 3493, 3469, 4159, 4160, 4161, 4111
1132, 3469, 3493, 3494, 3470, 4161, 4162, 4163, 4113
1133, 3470, 3494, 3495, 3471, 4163, 4164, 4165, 4115
1134, 3471, 3495, 3496, 3472, 4165, 4166, 4167, 4117
1135, 3472, 3496, 3497, 3473, 4167, 4168, 4169, 4119
1136, 3473, 3497, 3498, 3474, 4169, 4170, 4171, 4121
1137, 3474, 3498, 3499, 3475, 4171, 4172, 4173, 4123
1138, 3475, 3499, 3500, 3476, 4173, 4174, 4175, 4125
1139, 3476, 3500, 359, 358, 4175, 4176, 383, 4127
1140, 310, 311, 3501, 3477, 335, 4177, 4178, 4128
1141, 3477, 3501, 3502, 3478, 4178, 4179, 4180, 4130
1142, 3478, 3502, 3503, 3479, 4180, 4181, 4182, 4132
1143, 3479, 3503, 3504, 3480, 4182, 4183, 4184, 4134
1144, 3480, 3504, 3505, 3481, 4184, 4185, 4186, 4136
1145, 3481, 3505, 3506, 3482, 4186, 4187, 4188, 4138
1146, 3482, 3506, 3507, 3483, 4188, 4189, 4190, 4140
1147, 3483, 3507, 3508, 3484, 4190, 4191, 4192, 4142
1148, 3484, 3508, 3509, 3485, 4192, 4193, 4194, 4144
1149, 3485, 3509, 3510, 3486, 4194, 4195, 4196, 4146
1150, 3486, 3510, 3511, 3487, 4196, 4197, 4198, 4148
1151, 3487, 3511, 3512, 3488, 4198, 4199, 4200, 4150
1152, 3488, 3512, 3513, 3489, 4200, 4201, 4202, 4152
1153, 3489, 3513, 3514, 3490, 4202, 4203, 4204, 4154
1154, 3490, 3514, 3515, 3491, 4204, 4205, 4206, 4156
1155, 3491, 3515, 3516, 3492, 4206, 4207, 4208, 4158
1156, 3492, 3516, 3517, 3493, 4208, 4209, 4210, 4160
1157, 3493, 3517, 3518, 3494, 4210, 4211, 4212, 4162
1158, 3494, 3518, 3519, 3495, 4212, 4213, 4214, 4164
1159, 3495, 3519, 3520, 3496, 4214, 4215, 4216, 4166
1160, 3496, 3520, 3521, 3497, 4216, 4217, 4218, 4168
1161, 3497, 3521, 3522, 3498, 4218, 4219, 4220, 4170
1162, 3498, 3522, 3523, 3499, 4220, 4221, 4222, 4172
1163, 3499, 3523, 3524, 3500, 4222, 4223, 4224, 4174
1164, 3500, 3524, 360, 359, 4224, 4225, 384, 4176
1165, 311, 312, 3525, 3501, 336, 4226, 4227, 4177
1166, 3501, 3525, 3526, 3502, 4227, 4228, 4229, 4179
1167, 3502, 3526, 3527, 3503, 4229, 4230, 4231, 4181
1168, 3503, 3527, 3528, 3504, 4231, 4232, 4233, 4183
1169, 3504, 3528, 3529, 3505, 4233, 4234, 4235, 4185
1170, 3505, 3529, 3530, 3506, 4235, 4236, 4237, 4187
1171, 3506, 3530, 3531, 3507, 4237, 4238, 4239, 4189
1172, 3507, 3531, 3532, 3508, 4239, 4240, 4241, 4191
1173, 3508, 3532, 3533, 3509, 4241, 4242, 4243, 4193
1174, 3509, 3533, 3534, 3510, 4243, 4244, 4245, 4195
1175, 3510, 3534, 3535, 3511, 4245, 4246, 4247, 4197
1176, 3511, 3535, 3536, 3512, 4247, 4248, 4249, 4199
1177, 3512, 3536, 3537, 3513, 4249, 4250, 4251, 4201
1178, 3513, 3537, 3538, 3514, 4251, 4252, 4253, 4203
1179, 3514, 3538, 3539, 3515, 4253, 4254, 4255, 4205
1180, 3515, 3539, 3540, 3516, 4255, 4256, 4257, 4207
1181, 3516, 3540, 3541, 3517, 4257, 4258, 4259, 4209
1182, 3517, 3541, 3542, 3518, 4259, 4260, 4261, 4211
1183, 3518, 3542, 3543, 3519, 4261, 4262, 4263, 4213
1184, 3519, 3543, 3544, 3520, 4263, 4264, 4265, 4215
1185, 3520, 3544, 3545, 3521, 4265, 4266, 4267, 4217
1186, 3521, 3545, 3546, 3522, 4267, 4268, 4269, 4219
1187, 3522, 3546, 3547, 3523, 4269, 4270, 4271, 4221
1188, 3523, 3547, 3548, 3524, 4271, 4272, 4273, 4223
1189, 3524, 3548, 361, 360, 4273, 4274, 385, 4225
1190, 312, 313, 3549, 3525, 337, 4275, 4276, 4226
1191, 3525, 3549, 3550, 3526, 4276, 4277, 4278, 4228
1192, 3526, 3550, 3551, 3527, 4278, 4279, 4280, 4230
1193, 3527, 3551, 3552, 3528, 4280, 4281, 4282, 4232
1194, 3528, 3552, 3553, 3529, 4282, 4283, 4284, 4234
1195, 3529, 3553, 3554, 3530, 4284, 4285, 4286, 4236
1196, 3530, 3554, 3555, 3531, 4286, 4287, 4288, 4238
1197, 3531, 3555, 3556, 3532, 4288, 4289, 4290, 4240
1198, 3532, 3556, 3557, 3533, 4290, 4291, 4292, 4242
1199, 3533, 3557, 3558, 3534, 4292, 4293, 4294, 4244
1200, 3534, 3558, 3559, 3535, 4294, 4295, 4296, 4246
1201, 3535, 3559, 3560, 3536, 4296, 4297, 4298, 4248
1202, 3536, 3560, 3561, 3537, 4298, 4299, 4300, 4250
1203, 3537, 3561, 3562, 3538, 4300, 4301, 4302, 4252
1204, 3538, 3562, 3563, 3539, 4302, 4303, 4304, 4254
1205, 3539, 3563, 3564, 3540, 4304, 4305, 4306, 4256
1206, 3540, 3564, 3565, 3541, 4306, 4307, 4308, 4258
1207, 3541, 3565, 3566, 3542, 4308, 4309, 4310, 4260
1208, 3542, 3566, 3567, 3543, 4310, 4311, 4312, 4262
1209, 3543, 3567, 3568, 3544, 4312, 4313, 4314, 4264
1210, 3544, 3568, 3569, 3545, 4314, 4315, 4316, 4266
1211, 3545, 3569, 3570, 3546, 4316, 4317, 4318, 4268
1212, 3546, 3570, 3571, 3547, 4318, 4319, 4320, 4270
1213, 3547, 3571, 3572, 3548, 4320, 4321, 4322, 4272
1214, 3548, 3572, 362, 361, 4322, 4323, 386, 4274
1215, 313, 314, 3573, 3549, 338, 4324, 4325, 4275
1216, 3549, 3573, 3574, 3550, 4325, 4326, 4327, 4277
1217, 3550, 3574, 3575, 3551, 4327, 4328, 4329, 4279
1218, 3551, 3575, 3576, 3552, 4329, 4330, 4331, 4281
1219, 3552, 3576, 3577, 3553, 4331, 4332, 4333, 4283
1220, 3553, 3577, 3578, 3554, 4333, 4334, 4335, 4285
1221, 3554, 3578, 3579, 3555, 4335, 4336, 4337, 4287
1222, 3555, 3579, 3580, 3556, 4337, 4338, 4339, 4289
1223, 3556, 3580, 3581, 3557, 4339, 4340, 4341, 4291
1224, 3557, 3581, 3582, 3558, 4341, 4342, 4343, 4293
1225, 3558, 3582, 3583, 3559, 4343, 4344, 4345, 4295
1226, 3559, 3583, 3584, 3560, 4345, 4346, 4347, 4297
1227, 3560, 3584, 3585, 3561, 4347, 4348, 4349, 4299
1228, 3561, 3585, 3586, 3562, 4349, 4350, 4351, 4301
1229, 3562, 3586, 3587, 3563, 4351, 4352, 4353, 4303
1230, 3563, 3587, 3588, 3564, 4353, 4354, 4355, 4305
1231, 3564, 3588, 3589, 3565, 4355, 4356, 4357, 4307
1232, 3565, 3589, 3590, 3566, 4357, 4358, 4359, 4309
1233, 3566, 3590, 3591, 3567, 4359, 4360, 4361, 4311
1234, 3567, 3591, 3592, 3568, 4361, 4362, 4363, 4313
1235, 3568, 3592, 3593, 3569, 4363, 4364, 4365, 4315
1236, 3569, 3593, 3594, 3570, 4365, 4366, 4367, 4317
1237, 3570, 3594, 3595, 3571, 4367, 4368, 4369, 4319
1238, 3571, 3595, 3596, 3572, 4369, 4370, 4371, 4321
1239, 3572, 3596, 363, 362, 4371, 4372, 387, 4323
1240, 314, 315, 3597, 3573, 339, 4373, 4374, 4324
1241, 3573, 3597, 3598, 3574, 4374, 4375, 4376, 4326
1242, 3574, 3598, 3599, 3575, 4376, 4377, 4378, 4328
1243, 3575, 3599, 3600, 3576, 4378, 4379, 4380, 4330
1244, 3576, 3600, 3601, 3577, 4380, 4381, 4382, 4332
1245, 3577, 3601, 3602, 3578, 4382, 4383, 4384, 4334
1246, 3578, 3602, 3603, 3579, 4384, 4385, 4386, 4336
1247, 3579, 3603, 3604, 3580, 4386, 4387, 4388, 4338
1248, 3580, 3604, 3605, 3581, 4388, 4389, 4390, 4340
1249, 3581, 3605, 3606, 3582, 4390, 4391, 4392, 4342
1250, 3582, 3606, 3607, 3583, 4392, 4393, 4394, 4344
1251, 3583, 3607, 3608, 3584, 4394, 4395, 4396, 4346
1252, 3584, 3608, 3609, 3585, 4396, 4397, 4398, 4348
1253, 3585, 3609, 3610, 3586, 4398, 4399, 4400, 4350
1254, 3586, 3610, 3611, 3587, 4400, 4401, 4402, 4352
1255, 3587, 3611, 3612, 3588, 4402, 4403, 4404, 4354
1256, 3588, 3612, 3613, 3589, 4404, 4405, 4406, 4356
1257, 3589, 3613, 3614, 3590, 4406, 4407, 4408, 4358
1258, 3590, 3614, 3615, 3591, 4408, 4409, 4410, 4360
1259, 3591, 3615, 3616, 3592, 4410, 4411, 4412, 4362
1260, 3592, 3616, 3617, 3593, 4412, 4413, 4414, 4364
1261, 3593, 3617, 3618, 3594, 4414, 4415, 4416, 4366
1262, 3594, 3618, 3619, 3595, 4416, 4417, 4418, 4368
1263, 3595, 3619, 3620, 3596, 4418, 4419, 4420, 4370
1264, 3596, 3620, 364, 363, 4420, 4421, 388, 4372
1265, 315, 316, 3621, 3597, 340, 4422, 4423, 4373
1266, 3597, 3621, 3622, 3598, 4423, 4424, 4425, 4375
1267, 3598, 3622, 3623, 3599, 4425, 4426, 4427, 4377
1268, 3599, 3623, 3624, 3600, 4427, 4428, 4429, 4379
1269, 3600, 3624, 3625, 3601, 4429, 4430, 4431, 4381
1270, 3601, 3625, 3626, 3602, 4431, 4432, 4433, 4383
1271, 3602, 3626, 3627, 3603, 4433, 4434, 4435, 4385
1272, 3603, 3627, 3628, 3604, 4435, 4436, 4437, 4387
1273, 3604, 3628, 3629, 3605, 4437, 4438, 4439, 4389
1274, 3605, 3629, 3630, 3606, 4439, 4440, 4441, 4391
1275, 3606, 3630, 3631, 3607, 4441, 4442, 4443, 4393
1276, 3607, 3631, 3632, 3608, 4443, 4444, 4445, 4395
1277, 3608, 3632, 3633, 3609, 4445, 4446, 4447, 4397
1278, 3609, 3633, 3634, 3610, 4447, 4448, 4449, 4399
1279, 3610, 3634, 3635, 3611, 4449, 4450, 4451, 4401
1280, 3611, 3635, 3636, 3612, 4451, 4452, 4453, 4403
1281, 3612, 3636, 3637, 3613, 4453, 4454, 4455, 4405
1282, 3613, 3637, 3638, 3614, 4455, 4456, 4457, 4407
1283, 3614, 3638, 3639, 3615, 4457, 4458, 4459, 4409
1284, 3615, 3639, 3640, 3616, 4459, 4460, 4461, 4411
1285, 3616, 3640, 3641, 3617, 4461, 4462, 4463, 4413
1286, 3617, 3641, 3642, 3618, 4463, 4464, 4465, 4415
1287, 3618, 3642, 3643, 3619, 4465, 4466, 4467, 4417
1288, 3619, 3643, 3644, 3620, 4467, 4468, 4469, 4419
1289, 3620, 3644, 365, 364, 4469, 4470, 389, 4421
1290, 316, 317, 3645, 3621, 341, 4471, 4472, 4422
1291, 3621, 3645, 3646, 3622, 4472, 4473, 4474, 4424
1292, 3622, 3646, 3647, 3623, 4474, 4475, 4476, 4426
1293, 3623, 3647, 3648, 3624, 4476, 4477, 4478, 4428
1294, 3624, 3648, 3649, 3625, 4478, 4479, 4480, 4430
1295, 3625, 3649, 3650, 3626, 4480, 4481, 4482, 4432
1296, 3626, 3650, 3651, 3627, 4482, 4483, 4484, 4434
1297, 3627, 3651, 3652, 3628, 4484, 4485, 4486, 4436
1298, 3628, 3652, 3653, 3629, 4486, 4487, 4488, 4438
1299, 3629, 3653, 3654, 3630, 4488, 4489, 4490, 4440
1300, 3630, 3654, 3655, 3631, 4490, 4491, 4492, 4442
1301, 3631, 3655, 3656, 3632, 4492, 4493, 4494, 4444
1302, 3632, 3656, 3657, 3633, 4494, 4495, 4496, 4446
1303, 3633, 3657, 3658, 3634, 4496, 4497, 4498, 4448
1304, 3634, 3658, 3659, 3635, 4498, 4499, 4500, 4450
1305, 3635, 3659, 3660, 3636, 4500, 4501, 4502, 4452
1306, 3636, 3660, 3661, 3637, 4502, 4503, 4504, 4454
1307, 3637, 3661, 3662, 3638, 4504, 4505, 4506, 4456
1308, 3638, 3662, 3663, 3639, 4506, 4507, 4508, 4458
1309, 3639, 3663, 3664, 3640, 4508, 4509, 4510, 4460
1310, 3640, 3664, 3665, 3641, 4510, 4511, 4512, 4462
1311, 3641, 3665, 3666, 3642, 4512, 4513, 4514, 4464
1312, 3642, 3666, 3667, 3643, 4514, 4515, 4516, 4466
1313, 3643, 3667, 3668, 3644, 4516, 4517, 4518, 4468
1314, 3644, 3668, 366, 365, 4518, 4519, 390, 4470
1315, 317, 318, 3669, 3645, 342, 4520, 4521, 4471
1316, 3645, 3669, 3670, 3646, 4521, 4522, 4523, 4473
1317, 3646, 3670, 3671, 3647, 4523, 4524, 4525, 4475
1318, 3647, 3671, 3672, 3648, 4525, 4526, 4527, 4477
1319, 3648, 3672, 3673, 3649, 4527, 4528, 4529, 4479
1320, 3649, 3673, 3674, 3650, 4529, 4530, 4531, 4481
1321, 3650, 3674, 3675, 3651, 4531, 4532, 4533, 4483
1322, 3651, 3675, 3676, 3652, 4533, 4534, 4535, 4485
1323, 3652, 3676, 3677, 3653, 4535, 4536, 4537, 4487
1324, 3653, 3677, 3678, 3654, 4537, 4538, 4539, 4489
1325, 3654, 3678, 3679, 3655, 4539, 4540, 4541, 4491
1326, 3655, 3679, 3680, 3656, 4541, 4542, 4543, 4493
1327, 3656, 3680, 3681, 3657, 4543, 4544, 4545, 4495
1328, 3657, 3681, 3682, 3658, 4545, 4546, 4547, 4497
1329, 3658, 3682, 3683, 3659, 4547, 4548, 4549, 4499
1330, 3659, 3683, 3684, 3660, 4549, 4550, 4551, 4501
1331, 3660, 3684, 3685, 3661, 4551, 4552, 4553, 4503
1332, 3661, 3685, 3686, 3662, 4553, 4554, 4555, 4505
1333, 3662, 3686, 3687, 3663, 4555, 4556, 4557, 4507
1334, 3663, 3687, 3688, 3664, 4557, 4558, 4559, 4509
1335, 3664, 3688, 3689, 3665, 4559, 4560, 4561, 4511
1336, 3665, 3689, 3690, 3666, 4561, 4562, 4563, 4513
1337, 3666, 3690, 3691, 3667, 4563, 4564, 4565, 4515
1338, 3667, 3691, 3692, 3668, 4565, 4566, 4567, 4517
1339, 3668, 3692, 367, 366, 4567, 4568, 391, 4519
1340, 318, 319, 3693, 3669, 343, 4569, 4570, 4520
1341, 3669, 3693, 3694, 3670, 4570, 4571, 4572, 4522
1342, 3670, 3694, 3695, 3671, 4572, 4573, 4574, 4524
1343, 3671, 3695, 3696, 3672, 4574, 4575, 4576, 4526
1344, 3672, 3696, 3697, 3673, 4576, 4577, 4578, 4528
1345, 3673, 3697, 3698, 3674, 4578, 4579, 4580, 4530
1346, 3674, 3698, 3699, 3675, 4580, 4581, 4582, 4532
1347, 3675, 3699, 3700, 3676, 4582, 4583, 4584, 4534
1348, 3676, 3700, 3701, 3677, 4584, 4585, 4586, 4536
1349, 3677, 3701, 3702, 3678, 4586, 4587, 4588, 4538
1350, 3678, 3702, 3703, 3679, 4588, 4589, 4590, 4540
1351, 3679, 3703, 3704, 3680, 4590, 4591, 4592, 4542
1352, 3680, 3704, 3705, 3681, 4592, 4593, 4594, 4544
1353, 3681, 3705, 3706, 3682, 4594, 4595, 4596, 4546
1354, 3682, 3706, 3707, 3683, 4596, 4597, 4598, 4548
1355, 3683, 3707, 3708, 3684, 4598, 4599, 4600, 4550
1356, 3684, 3708, 3709, 3685, 4600, 4601, 4602, 4552
1357, 3685, 3709, 3710, 3686, 4602, 4603, 4604, 4554
1358, 3686, 3710, 3711, 3687, 4604, 4605, 4606, 4556
1359, 3687, 3711, 3712, 3688, 4606, 4607, 4608, 4558
1360, 3688, 3712, 3713, 3689, 4608, 4609, 4610, 4560
1361, 3689, 3713, 3714, 3690, 4610, 4611, 4612, 4562
1362, 3690, 3714, 3715, 3691, 4612, 4613, 4614, 4564
1363, 3691, 3715, 3716, 3692, 4614, 4615, 4616, 4566
1364, 3692, 3716, 368, 367, 4616, 4617, 392, 4568
1365, 319, 320, 3717, 3693, 344, 4618, 4619, 4569
1366, 3693, 3717, 3718, 3694, 4619, 4620, 4621, 4571
1367, 3694, 3718, 3719, 3695, 4621, 4622, 4623, 4573
1368, 3695, 3719, 3720, 3696, 4623, 4624, 4625, 4575
1369, 3696, 3720, 3721, 3697, 4625, 4626, 4627, 4577
1370, 3697, 3721, 3722, 3698, 4627, 4628, 4629, 4579
1371, 3698, 3722, 3723, 3699, 4629, 4630, 4631, 4581
1372, 3699, 3723, 3724, 3700, 4631, 4632, 4633, 4583
1373, 3700, 3724, 3725, 3701, 4633, 4634, 4635, 4585
1374, 3701, 3725, 3726, 3702, 4635, 4636, 4637, 4587
1375, 3702, 3726, 3727, 3703, 4637, 4638, 4639, 4589
1376, 3703, 3727, 3728, 3704, 4639, 4640, 4641, 4591
1377, 3704, 3728, 3729, 3705, 4641, 4642, 4643, 4593
1378, 3705, 3729, 3730, 3706, 4643, 4644, 4645, 4595
1379, 3706, 3730, 3731, 3707, 4645, 4646, 4647, 4597
1380, 3707, 3731, 3732, 3708, 4647, 4648, 4649, 4599
1381, 3708, 3732, 3733, 3709, 4649, 4650, 4651, 4601
1382, 3709, 3733, 3734, 3710, 4651, 4652, 4653, 4603
1383, 3710, 3734, 3735, 3711, 4653, 4654, 4655, 4605
1384, 3711, 3735, 3736, 3712, 4655, 4656, 4657, 4607
1385, 3712, 3736, 3737, 3713, 4657, 4658, 4659, 4609
1386, 3713, 3737, 3738, 3714, 4659, 4660, 4661, 4611
1387, 3714, 3738, 3739, 3715, 4661, 4662, 4663, 4613
1388, 3715, 3739, 3740, 3716, 4663, 4664, 4665, 4615
1389, 3716, 3740, 369, 368, 4665, 4666, 393, 4617
1390, 320, 321, 3741, 3717, 345, 4667, 4668, 4618
1391, 3717, 3741, 3742, 3718, 4668, 4669, 4670, 4620
1392, 3718, 3742, 3743, 3719, 4670, 4671, 4672, 4622
1393, 3719, 3743, 3744, 3720, 4672, 4673, 4674, 4624
1394, 3720, 3744, 3745, 3721, 4674, 4675, 4676, 4626
1395, 3721, 3745, 3746, 3722, 4676, 4677, 4678, 4628
1396, 3722, 3746, 3747, 3723, 4678, 4679, 4680, 4630
1397, 3723, 3747, 3748, 3724, 4680, 4681, 4682, 4632
1398, 3724, 3748, 3749, 3725, 4682, 4683, 4684, 4634
1399, 3725, 3749, 3750, 3726, 4684, 4685, 4686, 4636
1400, 3726, 3750, 3751, 3727, 4686, 4687, 4688, 4638
1401, 3727, 3751, 3752, 3728, 4688, 4689, 4690, 4640
1402, 3728, 3752, 3753, 3729, 4690, 4691, 4692, 4642
1403, 3729, 3753, 3754, 3730, 4692, 4693, 4694, 4644
1404, 3730, 3754, 3755, 3731, 4694, 4695, 4696, 4646
1405, 3731, 3755, 3756, 3732, 4696, 4697, 4698, 4648
1406, 3732, 3756, 3757, 3733, 4698, 4699, 4700, 4650
1407, 3733, 3757, 3758, 3734, 4700, 4701, 4702, 4652
1408, 3734, 3758, 3759, 3735, 4702, 4703, 4704, 4654
1409, 3735, 3759, 3760, 3736, 4704, 4705, 4706, 4656
1410, 3736, 3760, 3761, 3737, 4706, 4707, 4708, 4658
1411, 3737, 3761, 3762, 3738, 4708, 4709, 4710, 4660
1412, 3738, 3762, 3763, 3739, 4710, 4711, 4712, 4662
1413, 3739, 3763, 3764, 3740, 4712, 4713, 4714, 4664
1414, 3740, 3764, 370, 369, 4714, 4715, 394, 4666
1415, 321, 322, 3765, 3741, 346, 4716, 4717, 4667
1416, 3741, 3765, 3766, 3742, 4717, 4718, 4719, 4669
1417, 3742, 3766, 3767, 3743, 4719, 4720, 4721, 4671
1418, 3743, 3767, 3768, 3744, 4721, 4722, 4723, 4673
1419, 3744, 3768, 3769, 3745, 4723, 4724, 4725, 4675
1420, 3745, 3769, 3770, 3746, 4725, 4726, 4727, 4677
1421, 3746, 3770, 3771, 3747, 4727, 4728, 4729, 4679
1422, 3747, 3771, 3772, 3748, 4729, 4730, 4731, 4681
1423, 3748, 3772, 3773, 3749, 4731, 4732, 4733, 4683
1424, 3749, 3773, 3774, 3750, 4733, 4734, 4735, 4685
1425, 3750, 3774, 3775, 3751, 4735, 4736, 4737, 4687
1426, 3751, 3775, 3776, 3752, 4737, 4738, 4739, 4689
1427, 3752, 3776, 3777, 3753, 4739, 4740, 4741, 4691
1428, 3753, 3777, 3778, 3754, 4741, 4742, 4743, 4693
1429, 3754, 3778, 3779, 3755, 4743, 4744, 4745, 4695
1430, 3755, 3779, 3780, 3756, 4745, 4746, 4747, 4697
1431, 3756, 3780, 3781, 3757, 4747, 4748, 4749, 4699
1432, 3757, 3781, 3782, 3758, 4749, 4750, 4751, 4701
1433, 3758, 3782, 3783, 3759, 4751, 4752, 4753, 4703
1434, 3759, 3783, 3784, 3760, 4753, 4754, 4755, 4705
1435, 3760, 3784, 3785, 3761, 4755, 4756, 4757, 4707
1436, 3761, 3785, 3786, 3762, 4757, 4758, 4759, 4709
1437, 3762, 3786, 3787, 3763, 4759, 4760, 4761, 4711
1438, 3763, 3787, 3788, 3764, 4761, 4762, 4763, 4713
1439, 3764, 3788, 371, 370, 4763, 4764, 395, 4715
1440, 322, 323, 3789, 3765, 347, 4765, 4766, 4716
1441, 3765, 3789, 3790, 3766, 4766, 4767, 4768, 4718
1442, 3766, 3790, 3791, 3767, 4768, 4769, 4770, 4720
1443, 3767, 3791, 3792, 3768, 4770, 4771, 4772, 4722
1444, 3768, 3792, 3793, 3769, 4772, 4773, 4774, 4724
1445, 3769, 3793, 3794, 3770, 4774, 4775, 4776, 4726
1446, 3770, 3794, 3795, 3771, 4776, 4777, 4778, 4728
1447, 3771, 3795, 3796, 3772, 4778, 4779, 4780, 4730
1448, 3772, 3796, 3797, 3773, 4780, 4781, 4782, 4732
1449, 3773, 3797, 3798, 3774, 4782, 4783, 4784, 4734
1450, 3774, 3798, 3799, 3775, 4784, 4785, 4786, 4736
1451, 3775, 3799, 3800, 3776, 4786, 4787, 4788, 4738
1452, 3776, 3800, 3801, 3777, 4788, 4789, 4790, 4740
1453, 3777, 3801, 3802, 3778, 4790, 4791, 4792, 4742
1454, 3778, 3802, 3803, 3779, 4792, 4793, 4794, 4744
1455, 3779, 3803, 3804, 3780, 4794, 4795, 4796, 4746
1456, 3780, 3804, 3805, 3781, 4796, 4797, 4798, 4748
1457, 3781, 3805, 3806, 3782, 4798, 4799, 4800, 4750
1458, 3782, 3806, 3807, 3783, 4800, 4801, 4802, 4752
1459, 3783, 3807, 3808, 3784, 4802, 4803, 4804, 4754
1460, 3784, 3808, 3809, 3785, 4804, 4805, 4806, 4756
1461, 3785, 3809, 3810, 3786, 4806, 4807, 4808, 4758
1462, 3786, 3810, 3811, 3787, 4808, 4809, 4810, 4760
1463, 3787, 3811, 3812, 3788, 4810, 4811, 4812, 4762
1464, 3788, 3812, 372, 371, 4812, 4813, 396, 4764
1465, 323, 324, 3813, 3789, 348, 4814, 4815, 4765
1466, 3789, 3813, 3814, 3790, 4815, 4816, 4817, 4767
1467, 3790, 3814, 3815, 3791, 4817, 4818, 4819, 4769
1468, 3791, 3815, 3816, 3792, 4819, 4820, 4821, 4771
1469, 3792, 3816, 3817, 3793, 4821, 4822, 4823, 4773
1470, 3793, 3817, 3818, 3794, 4823, 4824, 4825, 4775
1471, 3794, 3818, 3819, 3795, 4825, 4826, 4827, 4777
1472, 3795, 3819, 3820, 3796, 4827, 4828, 4829, 4779
1473, 3796, 3820, 3821, 3797, 4829, 4830, 4831, 4781
1474, 3797, 3821, 3822, 3798, 4831, 4832, 4833, 4783
1475, 3798, 3822, 3823, 3799, 4833, 4834, 4835, 4785
1476, 3799, 3823, 3824, 3800, 4835, 4836, 4837, 4787
1477, 3800, 3824, 3825, 3801, 4837, 4838, 4839, 4789
1478, 3801, 3825, 3826, 3802, 4839, 4840, 4841, 4791
1479, 3802, 3826, 3827, 3803, 4841, 4842, 4843, 4793
1480, 3803, 3827, 3828, 3804, 4843, 4844, 4845, 4795
1481, 3804, 3828, 3829, 3805, 4845, 4846, 4847, 4797
1482, 3805, 3829, 3830, 3806, 4847, 4848, 4849, 4799
1483, 3806, 3830, 3831, 3807, 4849, 4850, 4851, 4801
1484, 3807, 3831, 3832, 3808, 4851, 4852, 4853, 4803
1485, 3808, 3832, 3833, 3809, 4853, 4854, 4855, 4805
1486, 3809, 3833, 3834, 3810, 4855, 4856, 4857, 4807
1487, 3810, 3834, 3835, 3811, 4857, 4858, 4859, 4809
1488, 3811, 3835, 3836, 3812, 4859, 4860, 4861, 4811
1489, 3812, 3836, 373, 372, 4861, 4862, 397, 4813
1490, 324, 325, 3837, 3813, 349, 4863, 4864, 4814
1491, 3813, 3837, 3838, 3814, 4864, 4865, 4866, 4816
1492, 3814, 3838, 3839, 3815, 4866, 4867, 4868, 4818
1493, 3815, 3839, 3840, 3816, 4868, 4869, 4870, 4820
1494, 3816, 3840, 3841, 3817, 4870, 4871, 4872, 4822
1495, 3817, 3841, 3842, 3818, 4872, 4873, 4874, 4824
1496, 3818, 3842, 3843, 3819, 4874, 4875, 4876, 4826
1497, 3819, 3843, 3844, 3820, 4876, 4877, 4878, 4828
1498, 3820, 3844, 3845, 3821, 4878, 4879, 4880, 4830
1499, 3821, 3845, 3846, 3822, 4880, 4881, 4882, 4832
1500, 3822, 3846, 3847, 3823, 4882, 4883, 4884, 4834
1501, 3823, 3847, 3848, 3824, 4884, 4885, 4886, 4836
1502, 3824, 3848, 3849, 3825, 4886, 4887, 4888, 4838
1503, 3825, 3849, 3850, 3826, 4888, 4889, 4890, 4840
1504, 3826, 3850, 3851, 3827, 4890, 4891, 4892, 4842
1505, 3827, 3851, 3852, 3828, 4892, 4893, 4894, 4844
1506, 3828, 3852, 3853, 3829, 4894, 4895, 4896, 4846
1507, 3829, 3853, 3854, 3830, 4896, 4897, 4898, 4848
1508, 3830, 3854, 3855, 3831, 4898, 4899, 4900, 4850
1509, 3831, 3855, 3856, 3832, 4900, 4901, 4902, 4852
1510, 3832, 3856, 3857, 3833, 4902, 4903, 4904, 4854
1511, 3833, 3857, 3858, 3834, 4904, 4905, 4906, 4856
1512, 3834, 3858, 3859, 3835, 4906, 4907, 4908, 4858
1513, 3835, 3859, 3860, 3836, 4908, 4909, 4910, 4860
1514, 3836, 3860, 374, 373, 4910, 4911, 398, 4862
1515, 325, 326, 3861, 3837, 350, 4912, 4913, 4863
1516, 3837, 3861, 3862, 3838, 4913, 4914, 4915, 4865
1517, 3838, 3862, 3863, 3839, 4915, 4916, 4917, 4867
1518, 3839, 3863, 3864, 3840, 4917, 4918, 4919, 4869
1519, 3840, 3864, 3865, 3841, 4919, 4920, 4921, 4871
1520, 3841, 3865, 3866, 3842, 4921, 4922, 4923, 4873
1521, 3842, 3866, 3867, 3843, 4923, 4924, 4925, 4875
1522, 3843, 3867, 3868, 3844, 4925, 4926, 4927, 4877
1523, 3844, 3868, 3869, 3845, 4927, 4928, 4929, 4879
1524, 3845, 3869, 3870, 3846, 4929, 4930, 4931, 4881
1525, 3846, 3870, 3871, 3847, 4931, 4932, 4933, 4883
1526, 3847, 3871, 3872, 3848, 4933, 4934, 4935, 4885
1527, 3848, 3872, 3873, 3849, 4935, 4936, 4937, 4887
1528, 3849, 3873, 3874, 3850, 4937, 4938, 4939, 4889
1529, 3850, 3874, 3875, 3851, 4939, 4940, 4941, 4891
1530, 3851, 3875, 3876, 3852, 4941, 4942, 4943, 4893
1531, 3852, 3876, 3877, 3853, 4943, 4944, 4945, 4895
1532, 3853, 3877, 3878, 3854, 4945, 4946, 4947, 4897
1533, 3854, 3878, 3879, 3855, 4947, 4948, 4949, 4899
1534, 3855, 3879, 3880, 3856, 4949, 4950, 4951, 4901
1535, 3856, 3880, 3881, 3857, 4951, 4952, 4953, 4903
1536, 3857, 3881, 3882, 3858, 4953, 4954, 4955, 4905
1537, 3858, 3882, 3883, 3859, 4955, 4956, 4957, 4907
1538, 3859, 3883, 3884, 3860, 4957, 4958, 4959, 4909
1539, 3860, 3884, 375, 374, 4959, 4960, 399, 4911
1540, 326, 327, 3885, 3861, 351, 4961, 4962, 4912
1541, 3861, 3885, 3886, 3862, 4962, 4963, 4964, 4914
1542, 3862, 3886, 3887, 3863, 4964, 4965, 4966, 4916
1543, 3863, 3887, 3888, 3864, 4966, 4967, 4968, 4918
1544, 3864, 3888, 3889, 3865, 4968, 4969, 4970, 4920
1545, 3865, 3889, 3890, 3866, 4970, 4971, 4972, 4922
1546, 3866, 3890, 3891, 3867, 4972, 4973, 4974, 4924
1547, 3867, 3891, 3892, 3868, 4974, 4975, 4976, 4926
1548, 3868, 3892, 3893, 3869, 4976, 4977, 4978, 4928
1549, 3869, 3893, 3894, 3870, 4978, 4979, 4980, 4930
1550, 3870, 3894, 3895, 3871, 4980, 4981, 4982, 4932
1551, 3871, 3895, 3896, 3872, 4982, 4983, 4984, 4934
1552, 3872, 3896, 3897, 3873, 4984, 4985, 4986, 4936
1553, 3873, 3897, 3898, 3874, 4986, 4987, 4988, 4938
1554, 3874, 3898, 3899, 3875, 4988, 4989, 4990, 4940
1555, 3875, 3899, 3900, 3876, 4990, 4991, 4992, 4942
1556, 3876, 3900, 3901, 3877, 4992, 4993, 4994, 4944
1557, 3877, 3901, 3902, 3878, 4994, 4995, 4996, 4946
1558, 3878, 3902, 3903, 3879, 4996, 4997, 4998, 4948
1559, 3879, 3903, 3904, 3880, 4998, 4999, 5000, 4950
1560, 3880, 3904, 3905, 3881, 5000, 5001, 5002, 4952
1561, 3881, 3905, 3906, 3882, 5002, 5003, 5004, 4954
1562, 3882, 3906, 3907, 3883, 5004, 5005, 5006, 4956
1563, 3883, 3907, 3908, 3884, 5006, 5007, 5008, 4958
1564, 3884, 3908, 376, 375, 5008, 5009, 400, 4960
1565, 327, 328, 3909, 3885, 352, 5010, 5011, 4961
1566, 3885, 3909, 3910, 3886, 5011, 5012, 5013, 4963
1567, 3886, 3910, 3911, 3887, 5013, 5014, 5015, 4965
1568, 3887, 3911, 3912, 3888, 5015, 5016, 5017, 4967
1569, 3888, 3912, 3913, 3889, 5017, 5018, 5019, 4969
1570, 3889, 3913, 3914, 3890, 5019, 5020, 5021, 4971
1571, 3890, 3914, 3915, 3891, 5021, 5022, 5023, 4973
1572, 3891, 3915, 3916, 3892, 5023, 5024, 5025, 4975
1573, 3892, 3916, 3917, 3893, 5025, 5026, 5027, 4977
1574, 3893, 3917, 3918, 3894, 5027, 5028, 5029, 4979
1575, 3894, 3918, 3919, 3895, 5029, 5030, 5031, 4981
1576, 3895, 3919, 3920, 3896, 5031, 5032, 5033, 4983
1577, 3896, 3920, 3921, 3897, 5033, 5034, 5035, 4985
1578, 3897, 3921, 3922, 3898, 5035, 5036, 5037, 4987
1579, 3898, 3922, 3923, 3899, 5037, 5038, 5039, 4989
1580, 3899, 3923, 3924, 3900, 5039, 5040, 5041, 4991
1581, 3900, 3924, 3925, 3901, 5041, 5042, 5043, 4993
1582, 3901, 3925, 3926, 3902, 5043, 5044, 5045, 4995
1583, 3902, 3926, 3927, 3903, 5045, 5046, 5047, 4997
1584, 3903, 3927, 3928, 3904, 5047, 5048, 5049, 4999
1585, 3904, 3928, 3929, 3905, 5049, 5050, 5051, 5001
1586, 3905, 3929, 3930, 3906, 5051, 5052, 5053, 5003
1587, 3906, 3930, 3931, 3907, 5053, 5054, 5055, 5005
1588, 3907, 3931, 3932, 3908, 5055, 5056, 5057, 5007
1589, 3908, 3932, 377, 376, 5057, 5058, 401, 5009
1590, 328, 329, 3933, 3909, 353, 5059, 5060, 5010
1591, 3909, 3933, 3934, 3910, 5060, 5061, 5062, 5012
1592, 3910, 3934, 3935, 3911, 5062, 5063, 5064, 5014
1593, 3911, 3935, 3936, 3912, 5064, 5065, 5066, 5016
1594, 3912, 3936, 3937, 3913, 5066, 5067, 5068, 5018
1595, 3913, 3937, 3938, 3914, 5068, 5069, 5070, 5020
1596, 3914, 3938, 3939, 3915, 5070, 5071, 5072, 5022
1597, 3915, 3939, 3940, 3916, 5072, 5073, 5074, 5024
1598, 3916, 3940, 3941, 3917, 5074, 5075, 5076, 5026
1599, 3917, 3941, 3942, 3918, 5076, 5077, 5078, 5028
1600, 3918, 3942, 3943, 3919, 5078, 5079, 5080, 5030
1601, 3919, 3943, 3944, 3920, 5080, 5081, 5082, 5032
1602, 3920, 3944, 3945, 3921, 5082, 5083, 5084, 5034
1603, 3921, 3945, 3946, 3922, 5084, 5085, 5086, 5036
1604, 3922, 3946, 3947, 3923, 5086, 5087, 5088, 5038
1605, 3923, 3947, 3948, 3924, 5088, 5089, 5090, 5040
1606, 3924, 3948, 3949, 3925, 5090, 5091, 5092, 5042
1607, 3925, 3949, 3950, 3926, 5092, 5093, 5094, 5044
1608, 3926, 3950, 3951, 3927, 5094, 5095, 5096, 5046
1609, 3927, 3951, 3952, 3928, 5096, 5097, 5098, 5048
1610, 3928, 3952, 3953, 3929, 5098, 5099, 5100, 5050
1611, 3929, 3953, 3954, 3930, 5100, 5101, 5102, 5052
1612, 3930, 3954, 3955, 3931, 5102, 5103, 5104, 5054
1613, 3931, 3955, 3956, 3932, 5104, 5105, 5106, 5056
1614, 3932, 3956, 378, 377, 5106, 5107, 402, 5058
1615, 329, 330, 3957, 3933, 354, 5108, 5109, 5059
1616, 3933, 3957, 3958, 3934, 5109, 5110, 5111, 5061
1617, 3934, 3958, 3959, 3935, 5111, 5112, 5113, 5063
1618, 3935, 3959, 3960, 3936, 5113, 5114, 5115, 5065
1619, 3936, 3960, 3961, 3937, 5115, 5116, 5117, 5067
1620, 3937, 3961, 3962, 3938, 5117, 5118, 5119, 5069
1621, 3938, 3962, 3963, 3939, 5119, 5120, 5121, 5071
1622, 3939, 3963, 3964, 3940, 5121, 5122, 5123, 5073
1623, 3940, 3964, 3965, 3941, 5123, 5124, 5125, 5075
1624, 3941, 3965, 3966, 3942, 5125, 5126, 5127, 5077
1625, 3942, 3966, 3967, 3943, 5127, 5128, 5129, 5079
1626, 3943, 3967, 3968, 3944, 5129, 5130, 5131, 5081
1627, 3944, 3968, 3969, 3945, 5131, 5132, 5133, 5083
1628, 3945, 3969, 3970, 3946, 5133, 5134, 5135, 5085
1629, 3946, 3970, 3971, 3947, 5135, 5136, 5137, 5087
1630, 3947, 3971, 3972, 3948, 5137, 5138, 5139, 5089
1631, 3948, 3972, 3973, 3949, 5139, 5140, 5141, 5091
1632, 3949, 3973, 3974, 3950, 5141, 5142, 5143, 5093
1633, 3950, 3974, 3975, 3951, 5143, 5144, 5145, 5095
1634, 3951, 3975, 3976, 3952, 5145, 5146, 5147, 5097
1635, 3952, 3976, 3977, 3953, 5147, 5148, 5149, 5099
1636, 3953, 3977, 3978, 3954, 5149, 5150, 5151, 5101
1637, 3954, 3978, 3979, 3955, 5151, 5152, 5153, 5103
1638, 3955, 3979, 3980, 3956, 5153, 5154, 5155, 5105
1639, 3956, 3980, 379, 378, 5155, 5156, 403, 5107
1640, 330, 11, 454, 3957, 355, 478, 5157, 5108
1641, 3957, 454, 455, 3958, 5157, 479, 5158, 5110
1642, 3958, 455, 456, 3959, 5158, 480, 5159, 5112
1643, 3959, 456, 457, 3960, 5159, 481, 5160, 5114
1644, 3960, 457, 458, 3961, 5160, 482, 5161, 5116
1645, 3961, 458, 459, 3962, 5161, 483, 5162, 5118
1646, 3962, 459, 460, 3963, 5162, 484, 5163, 5120
1647, 3963, 460, 461, 3964, 5163, 485, 5164, 5122
1648, 3964, 461, 462, 3965, 5164, 486, 5165, 5124
1649, 3965, 462, 463, 3966, 5165, 487, 5166, 5126
1650, 3966, 463, 464, 3967, 5166, 488, 5167, 5128
1651, 3967, 464, 465, 3968, 5167, 489, 5168, 5130
1652, 3968, 465, 466, 3969, 5168, 490, 5169, 5132
1653, 3969, 466, 467, 3970, 5169, 491, 5170, 5134
1654, 3970, 467, 468, 3971, 5170, 492, 5171, 5136
1655, 3971, 468, 469, 3972, 5171, 493, 5172, 5138
1656, 3972, 469, 470, 3973, 5172, 494, 5173, 5140
1657, 3973, 470, 471, 3974, 5173, 495, 5174, 5142
1658, 3974, 471, 472, 3975, 5174, 496, 5175, 5144
1659, 3975, 472, 473, 3976, 5175, 497, 5176, 5146
1660, 3976, 473, 474, 3977, 5176, 498, 5177, 5148
1661, 3977, 474, 475, 3978, 5177, 499, 5178, 5150
1662, 3978, 475, 476, 3979, 5178, 500, 5179, 5152
1663, 3979, 476, 477, 3980, 5179, 501, 5180, 5154
1664, 3980, 477, 13, 379, 5180, 502, 404, 5156
*ELEMENT, type=CPS8, ELSET=Surface6
1665, 27, 737, 5181, 747, 739, 5229, 5230, 771
1666, 747, 5181, 5182, 748, 5230, 5231, 5232, 772
1667, 748, 5182, 5183, 749, 5232, 5233, 5234, 773
1668, 749, 5183, 5184, 750, 5234, 5235, 5236, 774
1669, 750, 5184, 5185, 751, 5236, 5237, 5238, 775
1670, 751, 5185, 5186, 752, 5238, 5239, 5240, 776
1671, 752, 5186, 5187, 753, 5240, 5241, 5242, 777
1672, 753, 5187, 5188, 754, 5242, 5243, 5244, 778
1673, 754, 5188, 5189, 755, 5244, 5245, 5246, 779
1674, 755, 5189, 5190, 756, 5246, 5247, 5248, 780
1675, 756, 5190, 5191, 757, 5248, 5249, 5250, 781
1676, 757, 5191, 5192, 758, 5250, 5251, 5252, 782
1677, 758, 5192, 5193, 759, 5252, 5253, 5254, 783
1678, 759, 5193, 5194, 760, 5254, 5255, 5256, 784
1679, 760, 5194, 5195, 761, 5256, 5257, 5258, 785
1680, 761, 5195, 5196, 762, 5258, 5259, 5260, 786
1681, 762, 5196, 5197, 763, 5260, 5261, 5262, 787
1682, 763, 5197, 5198, 764, 5262, 5263, 5264, 788
1683, 764, 5198, 5199, 765, 5264, 5265, 5266, 789
1684, 765, 5199, 5200, 766, 5266, 5267, 5268, 790
1685, 766, 5200, 5201, 767, 5268, 5269, 5270, 791
1686, 767, 5201, 5202, 768, 5270, 5271, 5272, 792
1687, 768, 5202, 5203, 769, 5272, 5273, 5274, 793
1688, 769, 5203, 5204, 770, 5274, 5275, 5276, 794
1689, 770, 5204, 742, 28, 5276, 5277, 744, 795
1690, 737, 738, 5205, 5181, 740, 5278, 5279, 5229
1691, 5181, 5205, 5206, 5182, 5279, 5280, 5281, 5231
1692, 5182, 5206, 5207, 5183, 5281, 5282, 5283, 5233
1693, 5183, 5207, 5208, 5184, 5283, 5284, 5285, 5235
1694, 5184, 5208, 5209, 5185, 5285, 5286, 5287, 5237
1695, 5185, 5209, 5210, 5186, 5287, 5288, 5289, 5239
1696, 5186, 5210, 5211, 5187, 5289, 5290, 5291, 5241
1697, 5187, 5211, 5212, 5188, 5291, 5292, 5293, 5243
1698, 5188, 5212, 5213, 5189, 5293, 5294, 5295, 5245
1699, 5189, 5213, 5214, 5190, 5295, 5296, 5297, 5247
1700, 5190, 5214, 5215, 5191, 5297, 5298, 5299, 5249
1701, 5191, 5215, 5216, 5192, 5299, 5300, 5301, 5251
1702, 5192, 5216, 5217, 5193, 5301, 5302, 5303, 5253
1703, 5193, 5217, 5218, 5194, 5303, 5304, 5305, 5255
1704, 5194, 5218, 5219, 5195, 5305, 5306, 5307, 5257
1705, 5195, 5219, 5220, 5196, 5307, 5308, 5309, 5259
1706, 5196, 5220, 5221, 5197, 5309, 5310, 5311, 5261
1707, 5197, 5221, 5222, 5198, 5311, 5312, 5313, 5263
1708, 5198, 5222, 5223, 5199, 5313, 5314, 5315, 5265
1709, 5199, 5223, 5224, 5200, 5315, 5316, 5317, 5267
1710, 5200, 5224, 5225, 5201, 5317, 5318, 5319, 5269
1711, 5201, 5225, 5226, 5202, 5319, 5320, 5321, 5271
1712, 5202, 5226, 5227, 5203, 5321, 5322, 5323, 5273
1713, 5203, 5227, 5228, 5204, 5323, 5324, 5325, 5275
1714, 5204, 5228, 743, 742, 5325, 5326, 745, 5277
1715, 738, 14, 503, 5205, 741, 527, 5327, 5278
1716, 5205, 503, 504, 5206, 5327, 528, 5328, 5280
1717, 5206, 504, 505, 5207, 5328, 529, 5329, 5282
1718, 5207, 505, 506, 5208, 5329, 530, 5330, 5284
1719, 5208, 506, 507, 5209, 5330, 531, 5331, 5286
1720, 5209, 507, 508, 5210, 5331, 532, 5332, 5288
1721, 5210, 508, 509, 5211, 5332, 533, 5333, 5290
1722, 5211, 509, 510, 5212, 5333, 534, 5334, 5292
1723, 5212, 510, 511, 5213, 5334, 535, 5335, 5294
1724, 5213, 511, 512, 5214, 5335, 536, 5336, 5296
1725, 5214, 512, 513, 5215, 5336, 537, 5337, 5298
1726, 5215, 513, 514, 5216, 5337, 538, 5338, 5300
1727, 5216, 514, 515, 5217, 5338, 539, 5339, 5302
1728, 5217, 515, 516, 5218, 5339, 540, 5340, 5304
1729, 5218, 516, 517, 5219, 5340, 541, 5341, 5306
1730, 5219, 517, 518, 5220, 5341, 542, 5342, 5308
1731, 5220, 518, 519, 5221, 5342, 543, 5343, 5310
1732, 5221, 519, 520, 5222, 5343, 544, 5344, 5312
1733, 5222, 520, 521, 5223, 5344, 545, 5345, 5314
1734, 5223, 521, 522, 5224, 5345, 546, 5346, 5316
1735, 5224, 522, 523, 5225, 5346, 547, 5347, 5318
1736, 5225, 523, 524, 5226, 5347, 548, 5348, 5320
1737, 5226, 524, 525, 5227, 5348, 549, 5349, 5322
1738, 5227, 525, 526, 5228, 5349, 550, 5350, 5324
1739, 5228, 526, 15, 743, 5350, 551, 746, 5326
*ELEMENT, type=CPS8, ELSET=Surface7
1740, 29, 796, 5351, 806, 798, 5399, 5400, 830
1741, 806, 5351, 5352, 807, 5400, 5401, 5402, 831
1742, 807, 5352, 5353, 808, 5402, 5403, 5404, 832
1743, 808, 5353, 5354, 809, 5404, 5405, 5406, 833
1744, 809, 5354, 5355, 810, 5406, 5407, 5408, 834
1745, 810, 5355, 5356, 811, 5408, 5409, 5410, 835
1746, 811, 5356, 5357, 812, 5410, 5411, 5412, 836
1747, 812, 5357, 5358, 813, 5412, 5413, 5414, 837
1748, 813, 5358, 5359, 814, 5414, 5415, 5416, 838
1749, 814, 5359, 5360, 815, 5416, 5417, 5418, 839
1750, 815, 5360, 5361, 816, 5418, 5419, 5420, 840
1751, 816, 5361, 5362, 817, 5420, 5421, 5422, 841
1752, 817, 5362, 5363, 818, 5422, 5423, 5424, 842
1753, 818, 5363, 5364, 819, 5424, 5425, 5426, 843
1754, 819, 5364, 5365, 820, 5426, 5427, 5428, 844
1755, 820, 5365, 5366, 821, 5428, 5429, 5430, 845
1756, 821, 5366, 5367, 822, 5430, 5431, 5432, 846
1757, 822, 5367, 5368, 823, 5432, 5433, 5434, 847
1758, 823, 5368, 5369, 824, 5434, 5435, 5436, 848
1759, 824, 5369, 5370, 825, 5436, 5437, 5438, 849
1760, 825, 5370, 5371, 826, 5438, 5439, 5440, 850
1761, 826, 5371, 5372, 827, 5440, 5441, 5442, 851
1762, 827, 5372, 5373, 828, 5442, 5443, 5444, 852
1763, 828, 5373, 5374, 829, 5444, 5445, 5446, 853
1764, 829, 5374, 801, 30, 5446, 5447, 803, 854
1765, 796, 797, 5375, 5351, 799, 5448, 5449, 5399
1766, 5351, 5375, 5376, 5352, 5449, 5450, 5451, 5401
1767, 5352, 5376, 5377, 5353, 5451, 5452, 5453, 5403
1768, 5353, 5377, 5378, 5354, 5453, 5454, 5455, 5405
1769, 5354, 5378, 5379, 5355, 5455, 5456, 5457, 5407
1770, 5355, 5379, 5380, 5356, 5457, 5458, 5459, 5409
1771, 5356, 5380, 5381, 5357, 5459, 5460, 5461, 5411
1772, 5357, 5381, 5382, 5358, 5461, 5462, 5463, 5413
1773, 5358, 5382, 5383, 5359, 5463, 5464, 5465, 5415
1774, 5359, 5383, 5384, 5360, 5465, 5466, 5467, 5417
1775, 5360, 5384, 5385, 5361, 5467, 5468, 5469, 5419
1776, 5361, 5385, 5386, 5362, 5469, 5470, 5471, 5421
1777, 5362, 5386, 5387, 5363, 5471, 5472, 5473, 5423
1778, 5363, 5387, 5388, 5364, 5473, 5474, 5475, 5425
1779, 5364, 5388, 5389, 5365, 5475, 5476, 5477, 5427
1780, 5365, 5389, 5390, 5366, 5477, 5478, 5479, 5429
1781, 5366, 5390, 5391, 5367, 5479, 5480, 5481, 5431
1782, 5367, 5391, 5392, 5368, 5481, 5482, 5483, 5433
1783, 5368, 5392, 5393, 5369, 5483, 5484, 5485, 5435
1784, 5369, 5393, 5394, 5370, 5485, 5486, 5487, 5437
1785, 5370, 5394, 5395, 5371, 5487, 5488, 5489, 5439
1786, 5371, 5395, 5396, 5372, 5489, 5490, 5491, 5441
1787, 5372, 5396, 5397, 5373, 5491, 5492, 5493, 5443
1788, 5373, 5397, 5398, 5374, 5493, 5494, 5495, 5445
1789, 5374, 5398, 802, 801, 5495, 5496, 804, 5447
1790, 797, 16, 855, 5375, 800, 879, 5497, 5448
1791, 5375, 855, 856, 5376, 5497, 880, 5498, 5450
1792, 5376, 856, 857, 5377, 5498, 881, 5499, 5452
1793, 5377, 857, 858, 5378, 5499, 882, 5500, 5454
1794, 5378, 858, 859, 5379, 5500, 883, 5501, 5456
1795, 5379, 859, 860, 5380, 5501, 884, 5502, 5458
1796, 5380, 860, 861, 5381, 5502, 885, 5503, 5460
1797, 5381, 861, 862, 5382, 5503, 886, 5504, 5462
1798, 5382, 862, 863, 5383, 5504, 887, 5505, 5464
1799, 5383, 863, 864, 5384, 5505, 888, 5506, 5466
1800, 5384, 864, 865, 5385, 5506, 889, 5507, 5468
1801, 5385, 865, 866, 5386, 5507, 890, 5508, 5470
1802, 5386, 866, 867, 5387, 5508, 891, 5509, 5472
1803, 5387, 867, 868, 5388, 5509, 892, 5510, 5474
1804, 5388, 868, 869, 5389, 5510, 893, 5511, 5476
1805, 5389, 869, 870, 5390, 5511, 894, 5512, 5478
1806, 5390, 870, 871, 5391, 5512, 895, 5513, 5480
1807, 5391, 871, 872, 5392, 5513, 896, 5514, 5482
1808, 5392, 872, 873, 5393, 5514, 897, 5515, 5484
1809, 5393, 873, 874, 5394, 5515, 898, 5516, 5486
1810, 5394, 874, 875, 5395, 5516, 899, 5517, 5488
1811, 5395, 875, 876, 5396, 5517, 900, 5518, 5490
1812, 5396, 876, 877, 5397, 5518, 901, 5519, 5492
1813, 5397, 877, 878, 5398, 5519, 902, 5520, 5494
1814, 5398, 878, 31, 802, 5520, 903, 805, 5496
*ELEMENT, type=CPS8, ELSET=Surface9
1815, 29, 904, 5521, 796, 906, 5525, 5526, 798
1816, 796, 5521, 5522, 797, 5526, 5527, 5528, 799
1817, 797, 5522, 552, 16, 5528, 5529, 554, 800
1818, 904, 905, 5523, 5521, 907, 5530, 5531, 5525
1819, 5521, 5523, 5524, 5522, 5531, 5532, 5533, 5527
1820, 5522, 5524, 553, 552, 5533, 5534, 555, 5529
1821, 905, 32, 909, 5523, 908, 911, 5535, 5530
1822, 5523, 909, 910, 5524, 5535, 912, 5536, 5532
1823, 5524, 910, 17, 553, 5536, 913, 556, 5534
*ELEMENT, type=CPS8, ELSET=Surface10
1824, 16, 557, 5537, 855, 560, 5609, 5610, 879
1825, 855, 5537, 5538, 856, 5610, 5611, 5612, 880
1826, 856, 5538, 5539, 857, 5612, 5613, 5614, 881
1827, 857, 5539, 5540, 858, 5614, 5615, 5616, 882
1828, 858, 5540, 5541, 859, 5616, 5617, 5618, 883
1829, 859, 5541, 5542, 860, 5618, 5619, 5620, 884
1830, 860, 5542, 5543, 861, 5620, 5621, 5622, 885
1831, 861, 5543, 5544, 862, 5622, 5623, 5624, 886
1832, 862, 5544, 5545, 863, 5624, 5625, 5626, 887
1833, 863, 5545, 5546, 864, 5626, 5627, 5628, 888
1834, 864, 5546, 5547, 865, 5628, 5629, 5630, 889
1835, 865, 5547, 5548, 866, 5630, 5631, 5632, 890
1836, 866, 5548, 5549, 867, 5632, 5633, 5634, 891
1837, 867, 5549, 5550, 868, 5634, 5635, 5636, 892
1838, 868, 5550, 5551, 869, 5636, 5637, 5638, 893
1839, 869, 5551, 5552, 870, 5638, 5639, 5640, 894
1840, 870, 5552, 5553, 871, 5640, 5641, 5642, 895
1841, 871, 5553, 5554, 872, 5642, 5643, 5644, 896
1842, 872, 5554, 5555, 873, 5644, 5645, 5646, 897
1843, 873, 5555, 5556, 874, 5646, 5647, 5648, 898
1844, 874, 5556, 5557, 875, 5648, 5649, 5650, 899
1845, 875, 5557, 5558, 876, 5650, 5651, 5652, 900
1846, 876, 5558, 5559, 877, 5652, 5653, 5654, 901
1847, 877, 5559, 5560, 878, 5654, 5655, 5656, 902
1848, 878, 5560, 914, 31, 5656, 5657, 917, 903
1849, 557, 558, 5561, 5537, 561, 5658, 5659, 5609
1850, 5537, 5561, 5562, 5538, 5659, 5660, 5661, 5611
1851, 5538, 5562, 5563, 5539, 5661, 5662, 5663, 5613
1852, 5539, 5563, 5564, 5540, 5663, 5664, 5665, 5615
1853, 5540, 5564, 5565, 5541, 5665, 5666, 5667, 5617
1854, 5541, 5565, 5566, 5542, 5667, 5668, 5669, 5619
1855, 5542, 5566, 5567, 5543, 5669, 5670, 5671, 5621
1856, 5543, 5567, 5568, 5544, 5671, 5672, 5673, 5623
1857, 5544, 5568, 5569, 5545, 5673, 5674, 5675, 5625
1858, 5545, 5569, 5570, 5546, 5675, 5676, 5677, 5627
1859, 5546, 5570, 5571, 5547, 5677, 5678, 5679, 5629
1860, 5547, 5571, 5572, 5548, 5679, 5680, 5681, 5631
1861, 5548, 5572, 5573, 5549, 5681, 5682, 5683, 5633
1862, 5549, 5573, 5574, 5550, 5683, 5684, 5685, 5635
1863, 5550, 5574, 5575, 5551, 5685, 5686, 5687, 5637
1864, 5551, 5575, 5576, 5552, 5687, 5688, 5689, 5639
1865, 5552, 5576, 5577, 5553, 5689, 5690, 5691, 5641
1866, 5553, 5577, 5578, 5554, 5691, 5692, 5693, 5643
1867, 5554, 5578, 5579, 5555, 5693, 5694, 5695, 5645
1868, 5555, 5579, 5580, 5556, 5695, 5696, 5697, 5647
1869, 5556, 5580, 5581, 5557, 5697, 5698, 5699, 5649
1870, 5557, 5581, 5582, 5558, 5699, 5700, 5701, 5651
1871, 5558, 5582, 5583, 5559, 5701, 5702, 5703, 5653
1872, 5559, 5583, 5584, 5560, 5703, 5704, 5705, 5655
1873, 5560, 5584, 915, 914, 5705, 5706, 918, 5657
1874, 558, 559, 5585, 5561, 562, 5707, 5708, 5658
1875, 5561, 5585, 5586, 5562, 5708, 5709, 5710, 5660
1876, 5562, 5586, 5587, 5563, 5710, 5711, 5712, 5662
1877, 5563, 5587, 5588, 5564, 5712, 5713, 5714, 5664
1878, 5564, 5588, 5589, 5565, 5714, 5715, 5716, 5666
1879, 5565, 5589, 5590, 5566, 5716, 5717, 5718, 5668
1880, 5566, 5590, 5591, 5567, 5718, 5719, 5720, 5670
1881, 5567, 5591, 5592, 5568, 5720, 5721, 5722, 5672
1882, 5568, 5592, 5593, 5569, 5722, 5723, 5724, 5674
1883, 5569, 5593, 5594, 5570, 5724, 5725, 5726, 5676
1884, 5570, 5594, 5595, 5571, 5726, 5727, 5728, 5678
1885, 5571, 5595, 5596, 5572, 5728, 5729, 5730, 5680
1886, 5572, 5596, 5597, 5573, 5730, 5731, 5732, 5682
1887, 5573, 5597, 5598, 5574, 5732, 5733, 5734, 5684
1888, 5574, 5598, 5599, 5575, 5734, 5735, 5736, 5686
1889, 5575, 5599, 5600, 5576, 5736, 5737, 5738, 5688
1890, 5576, 5600, 5601, 5577, 5738, 5739, 5740, 5690
1891, 5577, 5601, 5602, 5578, 5740, 5741, 5742, 5692
1892, 5578, 5602, 5603, 5579, 5742, 5743, 5744, 5694
1893, 5579, 5603, 5604, 5580, 5744, 5745, 5746, 5696
1894, 5580, 5604, 5605, 5581, 5746, 5747, 5748, 5698
1895, 5581, 5605, 5606, 5582, 5748, 5749, 5750, 5700
1896, 5582, 5606, 5607, 5583, 5750, 5751, 5752, 5702
1897, 5583, 5607, 5608, 5584, 5752, 5753, 5754, 5704
1898, 5584, 5608, 916, 915, 5754, 5755, 919, 5706
1899, 559, 18, 921, 5585, 563, 945, 5756, 5707
1900, 5585, 921, 922, 5586, 5756, 946, 5757, 5709
1901, 5586, 922, 923, 5587, 5757, 947, 5758, 5711
1902, 5587, 923, 924, 5588, 5758, 948, 5759, 5713
1903, 5588, 924, 925, 5589, 5759, 949, 5760, 5715
1904, 5589, 925, 926, 5590, 5760, 950, 5761, 5717
1905, 5590, 926, 927, 5591, 5761, 951, 5762, 5719
1906, 5591, 927, 928, 5592, 5762, 952, 5763, 5721
1907, 5592, 928, 929, 5593, 5763, 953, 5764, 5723
1908, 5593, 929, 930, 5594, 5764, 954, 5765, 5725
1909, 5594, 930, 931, 5595, 5765, 955, 5766, 5727
1910, 5595, 931, 932, 5596, 5766, 956, 5767, 5729
1911, 5596, 932, 933, 5597, 5767, 957, 5768, 5731
1912, 5597, 933, 934, 5598, 5768, 958, 5769, 5733
1913, 5598, 934, 935, 5599, 5769, 959, 5770, 5735
1914, 5599, 935, 936, 5600, 5770, 960, 5771, 5737
1915, 5600, 936, 937, 5601, 5771, 961, 5772, 5739
1916, 5601, 937, 938, 5602, 5772, 962, 5773, 5741
1917, 5602, 938, 939, 5603, 5773, 963, 5774, 5743
1918, 5603, 939, 940, 5604, 5774, 964, 5775, 5745
1919, 5604, 940, 941, 5605, 5775, 965, 5776, 5747
1920, 5605, 941, 942, 5606, 5776, 966, 5777, 5749
1921, 5606, 942, 943, 5607, 5777, 967, 5778, 5751
1922, 5607, 943, 944, 5608, 5778, 968, 5779, 5753
1923, 5608, 944, 33, 916, 5779, 969, 920, 5755
*ELEMENT, type=CPS8, ELSET=Surface12
1924, 14, 564, 5780, 503, 567, 5852, 5853, 527
1925, 503, 5780, 5781, 504, 5853, 5854, 5855, 528
1926, 504, 5781, 5782, 505, 5855, 5856, 5857, 529
1927, 505, 5782, 5783, 506, 5857, 5858, 5859, 530
1928, 506, 5783, 5784, 507, 5859, 5860, 5861, 531
1929, 507, 5784, 5785, 508, 5861, 5862, 5863, 532
1930, 508, 5785, 5786, 509, 5863, 5864, 5865, 533
1931, 509, 5786, 5787, 510, 5865, 5866, 5867, 534
1932, 510, 5787, 5788, 511, 5867, 5868, 5869, 535
1933, 511, 5788, 5789, 512, 5869, 5870, 5871, 536
1934, 512, 5789, 5790, 513, 5871, 5872, 5873, 537
1935, 513, 5790, 5791, 514, 5873, 5874, 5875, 538
1936, 514, 5791, 5792, 515, 5875, 5876, 5877, 539
1937, 515, 5792, 5793, 516, 5877, 5878, 5879, 540
1938, 516, 5793, 5794, 517, 5879, 5880, 5881, 541
1939, 517, 5794, 5795, 518, 5881, 5882, 5883, 542
1940, 518, 5795, 5796, 519, 5883, 5884, 5885, 543
1941, 519, 5796, 5797, 520, 5885, 5886, 5887, 544
1942, 520, 5797, 5798, 521, 5887, 5888, 5889, 545
1943, 521, 5798, 5799, 522, 5889, 5890, 5891, 546
1944, 522, 5799, 5800, 523, 5891, 5892, 5893, 547
1945, 523, 5800, 5801, 524, 5893, 5894, 5895, 548
1946, 524, 5801, 5802, 525, 5895, 5896, 5897, 549
1947, 525, 5802, 5803, 526, 5897, 5898, 5899, 550
1948, 526, 5803, 571, 15, 5899, 5900, 574, 551
1949, 564, 565, 5804, 5780, 568, 5901, 5902, 5852
1950, 5780, 5804, 5805, 5781, 5902, 5903, 5904, 5854
1951, 5781, 5805, 5806, 5782, 5904, 5905, 5906, 5856
1952, 5782, 5806, 5807, 5783, 5906, 5907, 5908, 5858
1953, 5783, 5807, 5808, 5784, 5908, 5909, 5910, 5860
1954, 5784, 5808, 5809, 5785, 5910, 5911, 5912, 5862
1955, 5785, 5809, 5810, 5786, 5912, 5913, 5914, 5864
1956, 5786, 5810, 5811, 5787, 5914, 5915, 5916, 5866
1957, 5787, 5811, 5812, 5788, 5916, 5917, 5918, 5868
1958, 5788, 5812, 5813, 5789, 5918, 5919, 5920, 5870
1959, 5789, 5813, 5814, 5790, 5920, 5921, 5922, 5872
1960, 5790, 5814, 5815, 5791, 5922, 5923, 5924, 5874
1961, 5791, 5815, 5816, 5792, 5924, 5925, 5926, 5876
1962, 5792, 5816, 5817, 5793, 5926, 5927, 5928, 5878
1963, 5793, 5817, 5818, 5794, 5928, 5929, 5930, 5880
1964, 5794, 5818, 5819, 5795, 5930, 5931, 5932, 5882
1965, 5795, 5819, 5820, 5796, 5932, 5933, 5934, 5884
1966, 5796, 5820, 5821, 5797, 5934, 5935, 5936, 5886
1967, 5797, 5821, 5822, 5798, 5936, 5937, 5938, 5888
1968, 5798, 5822, 5823, 5799, 5938, 5939, 5940, 5890
1969, 5799, 5823, 5824, 5800, 5940, 5941, 5942, 5892
1970, 5800, 5824, 5825, 5801, 5942, 5943, 5944, 5894
1971, 5801, 5825, 5826, 5802, 5944, 5945, 5946, 5896
1972, 5802, 5826, 5827, 5803, 5946, 5947, 5948, 5898
1973, 5803, 5827, 572, 571, 5948, 5949, 575, 5900
1974, 565, 566, 5828, 5804, 569, 5950, 5951, 5901
1975, 5804, 5828, 5829, 5805, 5951, 5952, 5953, 5903
1976, 5805, 5829, 5830, 5806, 5953, 5954, 5955, 5905
1977, 5806, 5830, 5831, 5807, 5955, 5956, 5957, 5907
1978, 5807, 5831, 5832, 5808, 5957, 5958, 5959, 5909
1979, 5808, 5832, 5833, 5809, 5959, 5960, 5961, 5911
1980, 5809, 5833, 5834, 5810, 5961, 5962, 5963, 5913
1981, 5810, 5834, 5835, 5811, 5963, 5964, 5965, 5915
1982, 5811, 5835, 5836, 5812, 5965, 5966, 5967, 5917
1983, 5812, 5836, 5837, 5813, 5967, 5968, 5969, 5919
1984, 5813, 5837, 5838, 5814, 5969, 5970, 5971, 5921
1985, 5814, 5838, 5839, 5815, 5971, 5972, 5973, 5923
1986, 5815, 5839, 5840, 5816, 5973, 5974, 5975, 5925
1987, 5816, 5840, 5841, 5817, 5975, 5976, 5977, 5927
1988, 5817, 5841, 5842, 5818, 5977, 5978, 5979, 5929
1989, 5818, 5842, 5843, 5819, 5979, 5980, 5981, 5931
1990, 5819, 5843, 5844, 5820, 5981, 5982, 5983, 5933
1991, 5820, 5844, 5845, 5821, 5983, 5984, 5985, 5935
1992, 5821, 5845, 5846, 5822, 5985, 5986, 5987, 5937
1993, 5822, 5846, 5847, 5823, 5987, 5988, 5989, 5939
1994, 5823, 5847, 5848, 5824, 5989, 5990, 5991, 5941
1995, 5824, 5848, 5849, 5825, 5991, 5992, 5993, 5943
1996, 5825, 5849, 5850, 5826, 5993, 5994, 5995, 5945
1997, 5826, 5850, 5851, 5827, 5995, 5996, 5997, 5947
1998, 5827, 5851, 573, 572, 5997, 5998, 576, 5949
1999, 566, 19, 578, 5828, 570, 602, 5999, 5950
2000, 5828, 578, 579, 5829, 5999, 603, 6000, 5952
2001, 5829, 579, 580, 5830, 6000, 604, 6001, 5954
2002, 5830, 580, 581, 5831, 6001, 605, 6002, 5956
2003, 5831, 581, 582, 5832, 6002, 606, 6003, 5958
2004, 5832, 582, 583, 5833, 6003, 607, 6004, 5960
2005, 5833, 583, 584, 5834, 6004, 608, 6005, 5962
2006, 5834, 584, 585, 5835, 6005, 609, 6006, 5964
2007, 5835, 585, 586, 5836, 6006, 610, 6007, 5966
2008, 5836, 586, 587, 5837, 6007, 611, 6008, 5968
2009, 5837, 587, 588, 5838, 6008, 612, 6009, 5970
2010, 5838, 588, 589, 5839, 6009, 613, 6010, 5972
2011, 5839, 589, 590, 5840, 6010, 614, 6011, 5974
2012, 5840, 590, 591, 5841, 6011, 615, 6012, 5976
2013, 5841, 591, 592, 5842, 6012, 616, 6013, 5978
2014, 5842, 592, 593, 5843, 6013, 617, 6014, 5980
2015, 5843, 593, 594, 5844, 6014, 618, 6015, 5982
2016, 5844, 594, 595, 5845, 6015, 619, 6016, 5984
2017, 5845, 595, 596, 5846, 6016, 620, 6017, 5986
2018, 5846, 596, 597, 5847, 6017, 621, 6018, 5988
2019, 5847, 597, 598, 5848, 6018, 622, 6019, 5990
2020, 5848, 598, 599, 5849, 6019, 623, 6020, 5992
2021, 5849, 599, 600, 5850, 6020, 624, 6021, 5994
2022, 5850, 600, 601, 5851, 6021, 625, 6022, 5996
2023, 5851, 601, 20, 573, 6022, 626, 577, 5998
*ELEMENT, type=CPS8, ELSET=Surface13
2024, 15, 571, 6023, 634, 574, 6029, 6030, 636
2025, 634, 6023, 6024, 635, 6030, 6031, 6032, 637
2026, 635, 6024, 627, 21, 6032, 6033, 630, 638
2027, 571, 572, 6025, 6023, 575, 6034, 6035, 6029
2028, 6023, 6025, 6026, 6024, 6035, 6036, 6037, 6031
2029, 6024, 6026, 628, 627, 6037, 6038, 631, 6033
2030, 572, 573, 6027, 6025, 576, 6039, 6040, 6034
2031, 6025, 6027, 6028, 6026, 6040, 6041, 6042, 6036
2032, 6026, 6028, 629, 628, 6042, 6043, 632, 6038
2033, 573, 20, 639, 6027, 577, 641, 6044, 6039
2034, 6027, 639, 640, 6028, 6044, 642, 6045, 6041
2035, 6028, 640, 22, 629, 6045, 643, 633, 6043
*ELEMENT, type=CPS8, ELSET=Surface14
2036, 1, 43, 6046, 1017, 46, 6118, 6119, 1041
2037, 1017, 6046, 6047, 1018, 6119, 6120, 6121, 1042
2038, 1018, 6047, 6048, 1019, 6121, 6122, 6123, 1043
2039, 1019, 6048, 6049, 1020, 6123, 6124, 6125, 1044
2040, 1020, 6049, 6050, 1021, 6125, 6126, 6127, 1045
2041, 1021, 6050, 6051, 1022, 6127, 6128, 6129, 1046
2042, 1022, 6051, 6052, 1023, 6129, 6130, 6131, 1047
2043, 1023, 6052, 6053, 1024, 6131, 6132, 6133, 1048
2044, 1024, 6053, 6054, 1025, 6133, 6134, 6135, 1049
2045, 1025, 6054, 6055, 1026, 6135, 6136, 6137, 1050
2046, 1026, 6055, 6056, 1027, 6137, 6138, 6139, 1051
2047, 1027, 6056, 6057, 1028, 6139, 6140, 6141, 1052
2048, 1028, 6057, 6058, 1029, 6141, 6142, 6143, 1053
2049, 1029, 6058, 6059, 1030, 6143, 6144, 6145, 1054
2050, 1030, 6059, 6060, 1031, 6145, 6146, 6147, 1055
2051, 1031, 6060, 6061, 1032, 6147, 6148, 6149, 1056
2052, 1032, 6061, 6062, 1033, 6149, 6150, 6151, 1057
2053, 1033, 6062, 6063, 1034, 6151, 6152, 6153, 1058
2054, 1034, 6063, 6064, 1035, 6153, 6154, 6155, 1059
2055, 1035, 6064, 6065, 1036, 6155, 6156, 6157, 1060
2056, 1036, 6065, 6066, 1037, 6157, 6158, 6159, 1061
2057, 1037, 6066, 6067, 1038, 6159, 6160, 6161, 1062
2058, 1038, 6067, 6068, 1039, 6161, 6162, 6163, 1063
2059, 1039, 6068, 6069, 1040, 6163, 6164, 6165, 1064
2060, 1040, 6069, 1120, 35, 6165, 6166, 1123, 1065
2061, 43, 44, 6070, 6046, 47, 6167, 6168, 6118
2062, 6046, 6070, 6071, 6047, 6168, 6169, 6170, 6120
2063, 6047, 6071, 6072, 6048, 6170, 6171, 6172, 6122
2064, 6048, 6072, 6073, 6049, 6172, 6173, 6174, 6124
2065, 6049, 6073, 6074, 6050, 6174, 6175, 6176, 6126
2066, 6050, 6074, 6075, 6051, 6176, 6177, 6178, 6128
2067, 6051, 6075, 6076, 6052, 6178, 6179, 6180, 6130
2068, 6052, 6076, 6077, 6053, 6180, 6181, 6182, 6132
2069, 6053, 6077, 6078, 6054, 6182, 6183, 6184, 6134
2070, 6054, 6078, 6079, 6055, 6184, 6185, 6186, 6136
2071, 6055, 6079, 6080, 6056, 6186, 6187, 6188, 6138
2072, 6056, 6080, 6081, 6057, 6188, 6189, 6190, 6140
2073, 6057, 6081, 6082, 6058, 6190, 6191, 6192, 6142
2074, 6058, 6082, 6083, 6059, 6192, 6193, 6194, 6144
2075, 6059, 6083, 6084, 6060, 6194, 6195, 6196, 6146
2076, 6060, 6084, 6085, 6061, 6196, 6197, 6198, 6148
2077, 6061, 6085, 6086, 6062, 6198, 6199, 6200, 6150
2078, 6062, 6086, 6087, 6063, 6200, 6201, 6202, 6152
2079, 6063, 6087, 6088, 6064, 6202, 6203, 6204, 6154
2080, 6064, 6088, 6089, 6065, 6204, 6205, 6206, 6156
2081, 6065, 6089, 6090, 6066, 6206, 6207, 6208, 6158
2082, 6066, 6090, 6091, 6067, 6208, 6209, 6210, 6160
2083, 6067, 6091, 6092, 6068, 6210, 6211, 6212, 6162
2084, 6068, 6092, 6093, 6069, 6212, 6213, 6214, 6164
2085, 6069, 6093, 1121, 1120, 6214, 6215, 1124, 6166
2086, 44, 45, 6094, 6070, 48, 6216, 6217, 6167
2087, 6070, 6094, 6095, 6071, 6217, 6218, 6219, 6169
2088, 6071, 6095, 6096, 6072, 6219, 6220, 6221, 6171
2089, 6072, 6096, 6097, 6073, 6221, 6222, 6223, 6173
2090, 6073, 6097, 6098, 6074, 6223, 6224, 6225, 6175
2091, 6074, 6098, 6099, 6075, 6225, 6226, 6227, 6177
2092, 6075, 6099, 6100, 6076, 6227, 6228, 6229, 6179
2093, 6076, 6100, 6101, 6077, 6229, 6230, 6231, 6181
2094, 6077, 6101, 6102, 6078, 6231, 6232, 6233, 6183
2095, 6078, 6102, 6103, 6079, 6233, 6234, 6235, 6185
2096, 6079, 6103, 6104, 6080, 6235, 6236, 6237, 6187
2097, 6080, 6104, 6105, 6081, 6237, 6238, 6239, 6189
2098, 6081, 6105, 6106, 6082, 6239, 6240, 6241, 6191
2099, 6082, 6106, 6107, 6083, 6241, 6242, 6243, 6193
2100, 6083, 6107, 6108, 6084, 6243, 6244, 6245, 6195
2101, 6084, 6108, 6109, 6085, 6245, 6246, 6247, 6197
2102, 6085, 6109, 6110, 6086, 6247, 6248, 6249, 6199
2103, 6086, 6110, 6111, 6087, 6249, 6250, 6251, 6201
2104, 6087, 6111, 6112, 6088, 6251, 6252, 6253, 6203
2105, 6088, 6112, 6113, 6089, 6253, 6254, 6255, 6205
2106, 6089, 6113, 6114, 6090, 6255, 6256, 6257, 6207
2107, 6090, 6114, 6115, 6091, 6257, 6258, 6259, 6209
2108, 6091, 6115, 6116, 6092, 6259, 6260, 6261, 6211
2109, 6092, 6116, 6117, 6093, 6261, 6262, 6263, 6213
2110, 6093, 6117, 1122, 1121, 6263, 6264, 1125, 6215
2111, 45, 2, 1127, 6094, 49, 1151, 6265, 6216
2112, 6094, 1127, 1128, 6095, 6265, 1152, 6266, 6218
2113, 6095, 1128, 1129, 6096, 6266, 1153, 6267, 6220
2114, 6096, 1129, 1130, 6097, 6267, 1154, 6268, 6222
2115, 6097, 1130, 1131, 6098, 6268, 1155, 6269, 6224
2116, 6098, 1131, 1132, 6099, 6269, 1156, 6270, 6226
2117, 6099, 1132, 1133, 6100, 6270, 1157, 6271, 6228
2118, 6100, 1133, 1134, 6101, 6271, 1158, 6272, 6230
2119, 6101, 1134, 1135, 6102, 6272, 1159, 6273, 6232
2120, 6102, 1135, 1136, 6103, 6273, 1160, 6274, 6234
2121, 6103, 1136, 1137, 6104, 6274, 1161, 6275, 6236
2122, 6104, 1137, 1138, 6105, 6275, 1162, 6276, 6238
2123, 6105, 1138, 1139, 6106, 6276, 1163, 6277, 6240
2124, 6106, 1139, 1140, 6107, 6277, 1164, 6278, 6242
2125, 6107, 1140, 1141, 6108, 6278, 1165, 6279, 6244
2126, 6108, 1141, 1142, 6109, 6279, 1166, 6280, 6246
2127, 6109, 1142, 1143, 6110, 6280, 1167, 6281, 6248
2128, 6110, 1143, 1144, 6111, 6281, 1168, 6282, 6250
2129, 6111, 1144, 1145, 6112, 6282, 1169, 6283, 6252
2130, 6112, 1145, 1146, 6113, 6283, 1170, 6284, 6254
2131, 6113, 1146, 1147, 6114, 6284, 1171, 6285, 6256
2132, 6114, 1147, 1148, 6115, 6285, 1172, 6286, 6258
2133, 6115, 1148, 1149, 6116, 6286, 1173, 6287, 6260
2134, 6116, 1149, 1150, 6117, 6287, 1174, 6288, 6262
2135, 6117, 1150, 37, 1122, 6288, 1175, 1126, 6264
*ELEMENT, type=CPS8, ELSET=Surface17
2136, 1, 295, 6289, 43, 298, 6298, 6299, 46
2137, 43, 6289, 6290, 44, 6299, 6300, 6301, 47
2138, 44, 6290, 6291, 45, 6301, 6302, 6303, 48
2139, 45, 6291, 644, 2, 6303, 6304, 647, 49
2140, 295, 296, 6292, 6289, 299, 6305, 6306, 6298
2141, 6289, 6292, 6293, 6290, 6306, 6307, 6308, 6300
2142, 6290, 6293, 6294, 6291, 6308, 6309, 6310, 6302
2143, 6291, 6294, 645, 644, 6310, 6311, 648, 6304
2144, 296, 297, 6295, 6292, 300, 6312, 6313, 6305
2145, 6292, 6295, 6296, 6293, 6313, 6314, 6315, 6307
2146, 6293, 6296, 6297, 6294, 6315, 6316, 6317, 6309
2147, 6294, 6297, 646, 645, 6317, 6318, 649, 6311
2148, 297, 9, 651, 6295, 301, 654, 6319, 6312
2149, 6295, 651, 652, 6296, 6319, 655, 6320, 6314
2150, 6296, 652, 653, 6297, 6320, 656, 6321, 6316
2151, 6297, 653, 23, 646, 6321, 657, 650, 6318
*ELEMENT, type=CPS8, ELSET=Surface18
2152, 28, 742, 6322, 975, 744, 6326, 6327, 977
2153, 975, 6322, 6323, 976, 6327, 6328, 6329, 978
2154, 976, 6323, 970, 34, 6329, 6330, 972, 979
2155, 742, 743, 6324, 6322, 745, 6331, 6332, 6326
2156, 6322, 6324, 6325, 6323, 6332, 6333, 6334, 6328
2157, 6323, 6325, 971, 970, 6334, 6335, 973, 6330
2158, 743, 15, 634, 6324, 746, 636, 6336, 6331
2159, 6324, 634, 635, 6325, 6336, 637, 6337, 6333
2160, 6325, 635, 21, 971, 6337, 638, 974, 6335
*ELEMENT, type=CPS8, ELSET=Surface19
2161, 16, 552, 6338, 557, 554, 6344, 6345, 560
2162, 552, 553, 6339, 6338, 555, 6346, 6347, 6344
2163, 553, 17, 660, 6339, 556, 664, 6348, 6346
2164, 557, 6338, 6340, 558, 6345, 6349, 6350, 561
2165, 6338, 6339, 6341, 6340, 6347, 6351, 6352, 6349
2166, 6339, 660, 659, 6341, 6348, 663, 6353, 6351
2167, 558, 6340, 6342, 559, 6350, 6354, 6355, 562
2168, 6340, 6341, 6343, 6342, 6352, 6356, 6357, 6354
2169, 6341, 659, 658, 6343, 6353, 662, 6358, 6356
2170, 559, 6342, 665, 18, 6355, 6359, 667, 563
2171, 6342, 6343, 666, 665, 6357, 6360, 668, 6359
2172, 6343, 658, 24, 666, 6358, 661, 669, 6360
*ELEMENT, type=CPS8, ELSET=Surface20
2173, 9, 1066, 6361, 651, 1090, 6433, 6434, 654
2174, 1066, 1067, 6362, 6361, 1091, 6435, 6436, 6433
2175, 1067, 1068, 6363, 6362, 1092, 6437, 6438, 6435
2176, 1068, 1069, 6364, 6363, 1093, 6439, 6440, 6437
2177, 1069, 1070, 6365, 6364, 1094, 6441, 6442, 6439
2178, 1070, 1071, 6366, 6365, 1095, 6443, 6444, 6441
2179, 1071, 1072, 6367, 6366, 1096, 6445, 6446, 6443
2180, 1072, 1073, 6368, 6367, 1097, 6447, 6448, 6445
2181, 1073, 1074, 6369, 6368, 1098, 6449, 6450, 6447
2182, 1074, 1075, 6370, 6369, 1099, 6451, 6452, 6449
2183, 1075, 1076, 6371, 6370, 1100, 6453, 6454, 6451
2184, 1076, 1077, 6372, 6371, 1101, 6455, 6456, 6453
2185, 1077, 1078, 6373, 6372, 1102, 6457, 6458, 6455
2186, 1078, 1079, 6374, 6373, 1103, 6459, 6460, 6457
2187, 1079, 1080, 6375, 6374, 1104, 6461, 6462, 6459
2188, 1080, 1081, 6376, 6375, 1105, 6463, 6464, 6461
2189, 1081, 1082, 6377, 6376, 1106, 6465, 6466, 6463
2190, 1082, 1083, 6378, 6377, 1107, 6467, 6468, 6465
2191, 1083, 1084, 6379, 6378, 1108, 6469, 6470, 6467
2192, 1084, 1085, 6380, 6379, 1109, 6471, 6472, 6469
2193, 1085, 1086, 6381, 6380, 1110, 6473, 6474, 6471
2194, 1086, 1087, 6382, 6381, 1111, 6475, 6476, 6473
2195, 1087, 1088, 6383, 6382, 1112, 6477, 6478, 6475
2196, 1088, 1089, 6384, 6383, 1113, 6479, 6480, 6477
2197, 1089, 36, 1178, 6384, 1114, 1182, 6481, 6479
2198, 651, 6361, 6385, 652, 6434, 6482, 6483, 655
2199, 6361, 6362, 6386, 6385, 6436, 6484, 6485, 6482
2200, 6362, 6363, 6387, 6386, 6438, 6486, 6487, 6484
2201, 6363, 6364, 6388, 6387, 6440, 6488, 6489, 6486
2202, 6364, 6365, 6389, 6388, 6442, 6490, 6491, 6488
2203, 6365, 6366, 6390, 6389, 6444, 6492, 6493, 6490
2204, 6366, 6367, 6391, 6390, 6446, 6494, 6495, 6492
2205, 6367, 6368, 6392, 6391, 6448, 6496, 6497, 6494
2206, 6368, 6369, 6393, 6392, 6450, 6498, 6499, 6496
2207, 6369, 6370, 6394, 6393, 6452, 6500, 6501, 6498
2208, 6370, 6371, 6395, 6394, 6454, 6502, 6503, 6500
2209, 6371, 6372, 6396, 6395, 6456, 6504, 6505, 6502
2210, 6372, 6373, 6397, 6396, 6458, 6506, 6507, 6504
2211, 6373, 6374, 6398, 6397, 6460, 6508, 6509, 6506
2212, 6374, 6375, 6399, 6398, 6462, 6510, 6511, 6508
2213, 6375, 6376, 6400, 6399, 6464, 6512, 6513, 6510
2214, 6376, 6377, 6401, 6400, 6466, 6514, 6515, 6512
2215, 6377, 6378, 6402, 6401, 6468, 6516, 6517, 6514
2216, 6378, 6379, 6403, 6402, 6470, 6518, 6519, 6516
2217, 6379, 6380, 6404, 6403, 6472, 6520, 6521, 6518
2218, 6380, 6381, 6405, 6404, 6474, 6522, 6523, 6520
2219, 6381, 6382, 6406, 6405, 6476, 6524, 6525, 6522
2220, 6382, 6383, 6407, 6406, 6478, 6526, 6527, 6524
2221, 6383, 6384, 6408, 6407, 6480, 6528, 6529, 6526
2222, 6384, 1178, 1177, 6408, 6481, 1181, 6530, 6528
2223, 652, 6385, 6409, 653, 6483, 6531, 6532, 656
2224, 6385, 6386, 6410, 6409, 6485, 6533, 6534, 6531
2225, 6386, 6387, 6411, 6410, 6487, 6535, 6536, 6533
2226, 6387, 6388, 6412, 6411, 6489, 6537, 6538, 6535
2227, 6388, 6389, 6413, 6412, 6491, 6539, 6540, 6537
2228, 6389, 6390, 6414, 6413, 6493, 6541, 6542, 6539
2229, 6390, 6391, 6415, 6414, 6495, 6543, 6544, 6541
2230, 6391, 6392, 6416, 6415, 6497, 6545, 6546, 6543
2231, 6392, 6393, 6417, 6416, 6499, 6547, 6548, 6545
2232, 6393, 6394, 6418, 6417, 6501, 6549, 6550, 6547
2233, 6394, 6395, 6419, 6418, 6503, 6551, 6552, 6549
2234, 6395, 6396, 6420, 6419, 6505, 6553, 6554, 6551
2235, 6396, 6397, 6421, 6420, 6507, 6555, 6556, 6553
2236, 6397, 6398, 6422, 6421, 6509, 6557, 6558, 6555
2237, 6398, 6399, 6423, 6422, 6511, 6559, 6560, 6557
2238, 6399, 6400, 6424, 6423, 6513, 6561, 6562, 6559
2239, 6400, 6401, 6425, 6424, 6515, 6563, 6564, 6561
2240, 6401, 6402, 6426, 6425, 6517, 6565, 6566, 6563
2241, 6402, 6403, 6427, 6426, 6519, 6567, 6568, 6565
2242, 6403, 6404, 6428, 6427, 6521, 6569, 6570, 6567
2243, 6404, 6405, 6429, 6428, 6523, 6571, 6572, 6569
2244, 6405, 6406, 6430, 6429, 6525, 6573, 6574, 6571
2245, 6406, 6407, 6431, 6430, 6527, 6575, 6576, 6573
2246, 6407, 6408, 6432, 6431, 6529, 6577, 6578, 6575
2247, 6408, 1177, 1176, 6432, 6530, 1180, 6579, 6577
2248, 653, 6409, 1183, 23, 6532, 6580, 1207, 657
2249, 6409, 6410, 1184, 1183, 6534, 6581, 1208, 6580
2250, 6410, 6411, 1185, 1184, 6536, 6582, 1209, 6581
2251, 6411, 6412, 1186, 1185, 6538, 6583, 1210, 6582
2252, 6412, 6413, 1187, 1186, 6540, 6584, 1211, 6583
2253, 6413, 6414, 1188, 1187, 6542, 6585, 1212, 6584
2254, 6414, 6415, 1189, 1188, 6544, 6586, 1213, 6585
2255, 6415, 6416, 1190, 1189, 6546, 6587, 1214, 6586
2256, 6416, 6417, 1191, 1190, 6548, 6588, 1215, 6587
2257, 6417, 6418, 1192, 1191, 6550, 6589, 1216, 6588
2258, 6418, 6419, 1193, 1192, 6552, 6590, 1217, 6589
2259, 6419, 6420, 1194, 1193, 6554, 6591, 1218, 6590
2260, 6420, 6421, 1195, 1194, 6556, 6592, 1219, 6591
2261, 6421, 6422, 1196, 1195, 6558, 6593, 1220, 6592
2262, 6422, 6423, 1197, 1196, 6560, 6594, 1221, 6593
2263, 6423, 6424, 1198, 1197, 6562, 6595, 1222, 6594
2264, 6424, 6425, 1199, 1198, 6564, 6596, 1223, 6595
2265, 6425, 6426, 1200, 1199, 6566, 6597, 1224, 6596
2266, 6426, 6427, 1201, 1200, 6568, 6598, 1225, 6597
2267, 6427, 6428, 1202, 1201, 6570, 6599, 1226, 6598
2268, 6428, 6429, 1203, 1202, 6572, 6600, 1227, 6599
2269, 6429, 6430, 1204, 1203, 6574, 6601, 1228, 6600
2270, 6430, 6431, 1205, 1204, 6576, 6602, 1229, 6601
2271, 6431, 6432, 1206, 1205, 6578, 6603, 1230, 6602
2272, 6432, 1176, 38, 1206, 6579, 1179, 1231, 6603
*ELEMENT, type=CPS8, ELSET=Surface22
2273, 3, 670, 6604, 50, 671, 6628, 6629, 74
2274, 50, 6604, 6605, 51, 6629, 6630, 6631, 75
2275, 51, 6605, 6606, 52, 6631, 6632, 6633, 76
2276, 52, 6606, 6607, 53, 6633, 6634, 6635, 77
2277, 53, 6607, 6608, 54, 6635, 6636, 6637, 78
2278, 54, 6608, 6609, 55, 6637, 6638, 6639, 79
2279, 55, 6609, 6610, 56, 6639, 6640, 6641, 80
2280, 56, 6610, 6611, 57, 6641, 6642, 6643, 81
2281, 57, 6611, 6612, 58, 6643, 6644, 6645, 82
2282, 58, 6612, 6613, 59, 6645, 6646, 6647, 83
2283, 59, 6613, 6614, 60, 6647, 6648, 6649, 84
2284, 60, 6614, 6615, 61, 6649, 6650, 6651, 85
2285, 61, 6615, 6616, 62, 6651, 6652, 6653, 86
2286, 62, 6616, 6617, 63, 6653, 6654, 6655, 87
2287, 63, 6617, 6618, 64, 6655, 6656, 6657, 88
2288, 64, 6618, 6619, 65, 6657, 6658, 6659, 89
2289, 65, 6619, 6620, 66, 6659, 6660, 6661, 90
2290, 66, 6620, 6621, 67, 6661, 6662, 6663, 91
2291, 67, 6621, 6622, 68, 6663, 6664, 6665, 92
2292, 68, 6622, 6623, 69, 6665, 6666, 6667, 93
2293, 69, 6623, 6624, 70, 6667, 6668, 6669, 94
2294, 70, 6624, 6625, 71, 6669, 6670, 6671, 95
2295, 71, 6625, 6626, 72, 6671, 6672, 6673, 96
2296, 72, 6626, 6627, 73, 6673, 6674, 6675, 97
2297, 73, 6627, 673, 4, 6675, 6676, 674, 98
2298, 670, 10, 405, 6604, 672, 429, 6677, 6628
2299, 6604, 405, 406, 6605, 6677, 430, 6678, 6630
2300, 6605, 406, 407, 6606, 6678, 431, 6679, 6632
2301, 6606, 407, 408, 6607, 6679, 432, 6680, 6634
2302, 6607, 408, 409, 6608, 6680, 433, 6681, 6636
2303, 6608, 409, 410, 6609, 6681, 434, 6682, 6638
2304, 6609, 410, 411, 6610, 6682, 435, 6683, 6640
2305, 6610, 411, 412, 6611, 6683, 436, 6684, 6642
2306, 6611, 412, 413, 6612, 6684, 437, 6685, 6644
2307, 6612, 413, 414, 6613, 6685, 438, 6686, 6646
2308, 6613, 414, 415, 6614, 6686, 439, 6687, 6648
2309, 6614, 415, 416, 6615, 6687, 440, 6688, 6650
2310, 6615, 416, 417, 6616, 6688, 441, 6689, 6652
2311, 6616, 417, 418, 6617, 6689, 442, 6690, 6654
2312, 6617, 418, 419, 6618, 6690, 443, 6691, 6656
2313, 6618, 419, 420, 6619, 6691, 444, 6692, 6658
2314, 6619, 420, 421, 6620, 6692, 445, 6693, 6660
2315, 6620, 421, 422, 6621, 6693, 446, 6694, 6662
2316, 6621, 422, 423, 6622, 6694, 447, 6695, 6664
2317, 6622, 423, 424, 6623, 6695, 448, 6696, 6666
2318, 6623, 424, 425, 6624, 6696, 449, 6697, 6668
2319, 6624, 425, 426, 6625, 6697, 450, 6698, 6670
2320, 6625, 426, 427, 6626, 6698, 451, 6699, 6672
2321, 6626, 427, 428, 6627, 6699, 452, 6700, 6674
2322, 6627, 428, 12, 673, 6700, 453, 675, 6676
*ELEMENT, type=CPS8, ELSET=Surface25
2323, 5, 980, 6701, 99, 981, 6725, 6726, 123
2324, 99, 6701, 6702, 100, 6726, 6727, 6728, 124
2325, 100, 6702, 6703, 101, 6728, 6729, 6730, 125
2326, 101, 6703, 6704, 102, 6730, 6731, 6732, 126
2327, 102, 6704, 6705, 103, 6732, 6733, 6734, 127
2328, 103, 6705, 6706, 104, 6734, 6735, 6736, 128
2329, 104, 6706, 6707, 105, 6736, 6737, 6738, 129
2330, 105, 6707, 6708, 106, 6738, 6739, 6740, 130
2331, 106, 6708, 6709, 107, 6740, 6741, 6742, 131
2332, 107, 6709, 6710, 108, 6742, 6743, 6744, 132
2333, 108, 6710, 6711, 109, 6744, 6745, 6746, 133
2334, 109, 6711, 6712, 110, 6746, 6747, 6748, 134
2335, 110, 6712, 6713, 111, 6748, 6749, 6750, 135
2336, 111, 6713, 6714, 112, 6750, 6751, 6752, 136
2337, 112, 6714, 6715, 113, 6752, 6753, 6754, 137
2338, 113, 6715, 6716, 114, 6754, 6755, 6756, 138
2339, 114, 6716, 6717, 115, 6756, 6757, 6758, 139
2340, 115, 6717, 6718, 116, 6758, 6759, 6760, 140
2341, 116, 6718, 6719, 117, 6760, 6761, 6762, 141
2342, 117, 6719, 6720, 118, 6762, 6763, 6764, 142
2343, 118, 6720, 6721, 119, 6764, 6765, 6766, 143
2344, 119, 6721, 6722, 120, 6766, 6767, 6768, 144
2345, 120, 6722, 6723, 121, 6768, 6769, 6770, 145
2346, 121, 6723, 6724, 122, 6770, 6771, 6772, 146
2347, 122, 6724, 983, 6, 6772, 6773, 984, 147
2348, 980, 29, 806, 6701, 982, 830, 6774, 6725
2349, 6701, 806, 807, 6702, 6774, 831, 6775, 6727
2350, 6702, 807, 808, 6703, 6775, 832, 6776, 6729
2351, 6703, 808, 809, 6704, 6776, 833, 6777, 6731
2352, 6704, 809, 810, 6705, 6777, 834, 6778, 6733
2353, 6705, 810, 811, 6706, 6778, 835, 6779, 6735
2354, 6706, 811, 812, 6707, 6779, 836, 6780, 6737
2355, 6707, 812, 813, 6708, 6780, 837, 6781, 6739
2356, 6708, 813, 814, 6709, 6781, 838, 6782, 6741
2357, 6709, 814, 815, 6710, 6782, 839, 6783, 6743
2358, 6710, 815, 816, 6711, 6783, 840, 6784, 6745
2359, 6711, 816, 817, 6712, 6784, 841, 6785, 6747
2360, 6712, 817, 818, 6713, 6785, 842, 6786, 6749
2361, 6713, 818, 819, 6714, 6786, 843, 6787, 6751
2362, 6714, 819, 820, 6715, 6787, 844, 6788, 6753
2363, 6715, 820, 821, 6716, 6788, 845, 6789, 6755
2364, 6716, 821, 822, 6717, 6789, 846, 6790, 6757
2365, 6717, 822, 823, 6718, 6790, 847, 6791, 6759
2366, 6718, 823, 824, 6719, 6791, 848, 6792, 6761
2367, 6719, 824, 825, 6720, 6792, 849, 6793, 6763
2368, 6720, 825, 826, 6721, 6793, 850, 6794, 6765
2369, 6721, 826, 827, 6722, 6794, 851, 6795, 6767
2370, 6722, 827, 828, 6723, 6795, 852, 6796, 6769
2371, 6723, 828, 829, 6724, 6796, 853, 6797, 6771
2372, 6724, 829, 30, 983, 6797, 854, 985, 6773
*ELEMENT, type=CPS8, ELSET=Surface26
2373, 11, 986, 6798, 454, 987, 6822, 6823, 478
2374, 454, 6798, 6799, 455, 6823, 6824, 6825, 479
2375, 455, 6799, 6800, 456, 6825, 6826, 6827, 480
2376, 456, 6800, 6801, 457, 6827, 6828, 6829, 481
2377, 457, 6801, 6802, 458, 6829, 6830, 6831, 482
2378, 458, 6802, 6803, 459, 6831, 6832, 6833, 483
2379, 459, 6803, 6804, 460, 6833, 6834, 6835, 484
2380, 460, 6804, 6805, 461, 6835, 6836, 6837, 485
2381, 461, 6805, 6806, 462, 6837, 6838, 6839, 486
2382, 462, 6806, 6807, 463, 6839, 6840, 6841, 487
2383, 463, 6807, 6808, 464, 6841, 6842, 6843, 488
2384, 464, 6808, 6809, 465, 6843, 6844, 6845, 489
2385, 465, 6809, 6810, 466, 6845, 6846, 6847, 490
2386, 466, 6810, 6811, 467, 6847, 6848, 6849, 491
2387, 467, 6811, 6812, 468, 6849, 6850, 6851, 492
2388, 468, 6812, 6813, 469, 6851, 6852, 6853, 493
2389, 469, 6813, 6814, 470, 6853, 6854, 6855, 494
2390, 470, 6814, 6815, 471, 6855, 6856, 6857, 495
2391, 471, 6815, 6816, 472, 6857, 6858, 6859, 496
2392, 472, 6816, 6817, 473, 6859, 6860, 6861, 497
2393, 473, 6817, 6818, 474, 6861, 6862, 6863, 498
2394, 474, 6818, 6819, 475, 6863, 6864, 6865, 499
2395, 475, 6819, 6820, 476, 6865, 6866, 6867, 500
2396, 476, 6820, 6821, 477, 6867, 6868, 6869, 501
2397, 477, 6821, 989, 13, 6869, 6870, 990, 502
2398, 986, 27, 747, 6798, 988, 771, 6871, 6822
2399, 6798, 747, 748, 6799, 6871, 772, 6872, 6824
2400, 6799, 748, 749, 6800, 6872, 773, 6873, 6826
2401, 6800, 749, 750, 6801, 6873, 774, 6874, 6828
2402, 6801, 750, 751, 6802, 6874, 775, 6875, 6830
2403, 6802, 751, 752, 6803, 6875, 776, 6876, 6832
2404, 6803, 752, 753, 6804, 6876, 777, 6877, 6834
2405, 6804, 753, 754, 6805, 6877, 778, 6878, 6836
2406, 6805, 754, 755, 6806, 6878, 779, 6879, 6838
2407, 6806, 755, 756, 6807, 6879, 780, 6880, 6840
2408, 6807, 756, 757, 6808, 6880, 781, 6881, 6842
2409, 6808, 757, 758, 6809, 6881, 782, 6882, 6844
2410, 6809, 758, 759, 6810, 6882, 783, 6883, 6846
2411, 6810, 759, 760, 6811, 6883, 784, 6884, 6848
2412, 6811, 760, 761, 6812, 6884, 785, 6885, 6850
2413, 6812, 761, 762, 6813, 6885, 786, 6886, 6852
2414, 6813, 762, 763, 6814, 6886, 787, 6887, 6854
2415, 6814, 763, 764, 6815, 6887, 788, 6888, 6856
2416, 6815, 764, 765, 6816, 6888, 789, 6889, 6858
2417, 6816, 765, 766, 6817, 6889, 790, 6890, 6860
2418, 6817, 766, 767, 6818, 6890, 791, 6891, 6862
2419, 6818, 767, 768, 6819, 6891, 792, 6892, 6864
2420, 6819, 768, 769, 6820, 6892, 793, 6893, 6866
2421, 6820, 769, 770, 6821, 6893, 794, 6894, 6868
2422, 6821, 770, 28, 989, 6894, 795, 991, 6870
*ELEMENT, type=CPS8, ELSET=Surface27
2423, 7, 992, 6895, 197, 993, 6919, 6920, 221
2424, 197, 6895, 6896, 198, 6920, 6921, 6922, 222
2425, 198, 6896, 6897, 199, 6922, 6923, 6924, 223
2426, 199, 6897, 6898, 200, 6924, 6925, 6926, 224
2427, 200, 6898, 6899, 201, 6926, 6927, 6928, 225
2428, 201, 6899, 6900, 202, 6928, 6929, 6930, 226
2429, 202, 6900, 6901, 203, 6930, 6931, 6932, 227
2430, 203, 6901, 6902, 204, 6932, 6933, 6934, 228
2431, 204, 6902, 6903, 205, 6934, 6935, 6936, 229
2432, 205, 6903, 6904, 206, 6936, 6937, 6938, 230
2433, 206, 6904, 6905, 207, 6938, 6939, 6940, 231
2434, 207, 6905, 6906, 208, 6940, 6941, 6942, 232
2435, 208, 6906, 6907, 209, 6942, 6943, 6944, 233
2436, 209, 6907, 6908, 210, 6944, 6945, 6946, 234
2437, 210, 6908, 6909, 211, 6946, 6947, 6948, 235
2438, 211, 6909, 6910, 212, 6948, 6949, 6950, 236
2439, 212, 6910, 6911, 213, 6950, 6951, 6952, 237
2440, 213, 6911, 6912, 214, 6952, 6953, 6954, 238
2441, 214, 6912, 6913, 215, 6954, 6955, 6956, 239
2442, 215, 6913, 6914, 216, 6956, 6957, 6958, 240
2443, 216, 6914, 6915, 217, 6958, 6959, 6960, 241
2444, 217, 6915, 6916, 218, 6960, 6961, 6962, 242
2445, 218, 6916, 6917, 219, 6962, 6963, 6964, 243
2446, 219, 6917, 6918, 220, 6964, 6965, 6966, 244
2447, 220, 6918, 995, 8, 6966, 6967, 996, 245
2448, 992, 25, 681, 6895, 994, 705, 6968, 6919
2449, 6895, 681, 682, 6896, 6968, 706, 6969, 6921
2450, 6896, 682, 683, 6897, 6969, 707, 6970, 6923
2451, 6897, 683, 684, 6898, 6970, 708, 6971, 6925
2452, 6898, 684, 685, 6899, 6971, 709, 6972, 6927
2453, 6899, 685, 686, 6900, 6972, 710, 6973, 6929
2454, 6900, 686, 687, 6901, 6973, 711, 6974, 6931
2455, 6901, 687, 688, 6902, 6974, 712, 6975, 6933
2456, 6902, 688, 689, 6903, 6975, 713, 6976, 6935
2457, 6903, 689, 690, 6904, 6976, 714, 6977, 6937
2458, 6904, 690, 691, 6905, 6977, 715, 6978, 6939
2459, 6905, 691, 692, 6906, 6978, 716, 6979, 6941
2460, 6906, 692, 693, 6907, 6979, 717, 6980, 6943
2461, 6907, 693, 694, 6908, 6980, 718, 6981, 6945
2462, 6908, 694, 695, 6909, 6981, 719, 6982, 6947
2463, 6909, 695, 696, 6910, 6982, 720, 6983, 6949
2464, 6910, 696, 697, 6911, 6983, 721, 6984, 6951
2465, 6911, 697, 698, 6912, 6984, 722, 6985, 6953
2466, 6912, 698, 699, 6913, 6985, 723, 6986, 6955
2467, 6913, 699, 700, 6914, 6986, 724, 6987, 6957
2468, 6914, 700, 701, 6915, 6987, 725, 6988, 6959
2469, 6915, 701, 702, 6916, 6988, 726, 6989, 6961
2470, 6916, 702, 703, 6917, 6989, 727, 6990, 6963
2471, 6917, 703, 704, 6918, 6990, 728, 6991, 6965
2472, 6918, 704, 26, 995, 6991, 729, 997, 6967
*ELEMENT, type=CPS8, ELSET=Surface28
2473, 14, 998, 6992, 564, 1001, 7001, 7002, 567
2474, 564, 6992, 6993, 565, 7002, 7003, 7004, 568
2475, 565, 6993, 6994, 566, 7004, 7005, 7006, 569
2476, 566, 6994, 1005, 19, 7006, 7007, 1008, 570
2477, 998, 999, 6995, 6992, 1002, 7008, 7009, 7001
2478, 6992, 6995, 6996, 6993, 7009, 7010, 7011, 7003
2479, 6993, 6996, 6997, 6994, 7011, 7012, 7013, 7005
2480, 6994, 6997, 1006, 1005, 7013, 7014, 1009, 7007
2481, 999, 1000, 6998, 6995, 1003, 7015, 7016, 7008
2482, 6995, 6998, 6999, 6996, 7016, 7017, 7018, 7010
2483, 6996, 6999, 7000, 6997, 7018, 7019, 7020, 7012
2484, 6997, 7000, 1007, 1006, 7020, 7021, 1010, 7014
2485, 1000, 31, 914, 6998, 1004, 917, 7022, 7015
2486, 6998, 914, 915, 6999, 7022, 918, 7023, 7017
2487, 6999, 915, 916, 7000, 7023, 919, 7024, 7019
2488, 7000, 916, 33, 1007, 7024, 920, 1011, 7021
*ELEMENT, type=CPS8, ELSET=Surface31
2489, 39, 1232, 7025, 1242, 1234, 7031, 7032, 1245
2490, 1242, 7025, 7026, 1243, 7032, 7033, 7034, 1246
2491, 1243, 7026, 7027, 1244, 7034, 7035, 7036, 1247
2492, 1244, 7027, 1237, 40, 7036, 7037, 1239, 1248
2493, 1232, 1233, 7028, 7025, 1235, 7038, 7039, 7031
2494, 7025, 7028, 7029, 7026, 7039, 7040, 7041, 7033
2495, 7026, 7029, 7030, 7027, 7041, 7042, 7043, 7035
2496, 7027, 7030, 1238, 1237, 7043, 7044, 1240, 7037
2497, 1233, 38, 1176, 7028, 1236, 1179, 7045, 7038
2498, 7028, 1176, 1177, 7029, 7045, 1180, 7046, 7040
2499, 7029, 1177, 1178, 7030, 7046, 1181, 7047, 7042
2500, 7030, 1178, 36, 1238, 7047, 1182, 1241, 7044
*ELEMENT, type=CPS8, ELSET=Surface32
2501, 41, 1249, 7048, 1259, 1251, 7054, 7055, 1262
2502, 1259, 7048, 7049, 1260, 7055, 7056, 7057, 1263
2503, 1260, 7049, 7050, 1261, 7057, 7058, 7059, 1264
2504, 1261, 7050, 1254, 42, 7059, 7060, 1256, 1265
2505, 1249, 1250, 7051, 7048, 1252, 7061, 7062, 7054
2506, 7048, 7051, 7052, 7049, 7062, 7063, 7064, 7056
2507, 7049, 7052, 7053, 7050, 7064, 7065, 7066, 7058
2508, 7050, 7053, 1255, 1254, 7066, 7067, 1257, 7060
2509, 1250, 35, 1120, 7051, 1253, 1123, 7068, 7061
2510, 7051, 1120, 1121, 7052, 7068, 1124, 7069, 7063
2511, 7052, 1121, 1122, 7053, 7069, 1125, 7070, 7065
2512, 7053, 1122, 37, 1255, 7070, 1126, 1258, 7067
*ELSET,ELSET=Ceramic_Top
68, 69, 70, 71, 189, 190, 191, 192, 193, 194, 
195, 196, 197, 198, 199, 200, 201, 202, 203, 204, 
205, 206, 207, 208, 209, 210, 211, 212, 213, 214, 
215, 216, 217, 218, 219, 220, 221, 222, 223, 224, 
225, 226, 227, 228, 229, 230, 231, 232, 233, 234, 
235, 236, 237, 238, 239, 240, 241, 246, 247, 248, 
*ELSET,ELSET=Ceramic_Bottom
33, 34, 35, 36, 37, 38, 39, 40, 41, 42, 
43, 44, 45, 46, 47, 48, 49, 50, 51, 52, 
53, 54, 55, 56, 57, 65, 66, 67, 76, 77, 
78, 107, 108, 109, 110, 111, 112, 113, 114, 115, 
116, 117, 118, 119, 120, 121, 122, 123, 124, 125, 
126, 127, 128, 129, 130, 131, 135, 136, 137, 138, 
*ELSET,ELSET=ElectrodeMinX
104, 105, 106, 
*ELSET,ELSET=ElectrodeMaxX
132, 133, 134, 
*ELSET,ELSET=Contact_CeramicCopper
1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 
11, 12, 13, 14, 15, 16, 17, 18, 19, 20, 
21, 22, 23, 24, 25, 26, 27, 28, 29, 30, 
31, 32, 62, 63, 64, 79, 80, 81, 82, 83, 
84, 85, 86, 87, 88, 89, 90, 91, 92, 93, 
94, 95, 96, 97, 98, 99, 100, 101, 102, 103, 
139, 140, 141, 142, 143, 144, 145, 146, 147, 148, 
149, 150, 151, 152, 153, 154, 155, 156, 157, 158, 
159, 160, 161, 162, 163, 164, 165, 166, 167, 168, 
169, 170, 171, 172, 173, 174, 175, 176, 177, 178, 
179, 180, 181, 182, 183, 184, 185, 186, 187, 188, 
*ELSET,ELSET=Symm_X
58, 59, 60, 61, 72, 73, 74, 75, 104, 105, 
106, 132, 133, 134, 242, 243, 244, 245, 249, 250, 
251, 252, 
*ELSET,ELSET=Volume
253, 254, 255, 256, 257, 258, 259, 260, 261, 262, 
263, 264, 265, 266, 267, 268, 269, 270, 271, 272, 
273, 274, 275, 276, 277, 278, 279, 280, 281, 282, 
283, 284, 285, 286, 287, 288, 289, 290, 291, 292, 
293, 294, 295, 296, 297, 298, 299, 300, 301, 302, 
303, 304, 305, 306, 307, 308, 309, 310, 311, 312, 
313, 314, 315, 316, 317, 318, 319, 320, 321, 322, 
323, 324, 325, 326, 327, 328, 329, 330, 331, 332, 
333, 334, 335, 336, 337, 338, 339, 340, 341, 342, 
343, 344, 345, 346, 347, 348, 349, 350, 351, 352, 
353, 354, 355, 356, 357, 358, 359, 360, 361, 362, 
363, 364, 365, 366, 367, 368, 369, 370, 371, 372, 
373, 374, 375, 376, 377, 378, 379, 380, 381, 382, 
383, 384, 385, 386, 387, 388, 389, 390, 391, 392, 
393, 394, 395, 396, 397, 398, 399, 400, 401, 402, 
403, 404, 405, 406, 407, 408, 409, 410, 411, 412, 
413, 414, 415, 416, 417, 418, 419, 420, 421, 422, 
423, 424, 425, 426, 427, 428, 429, 430, 431, 432, 
433, 434, 435, 436, 437, 438, 439, 440, 441, 442, 
443, 444, 445, 446, 447, 448, 449, 450, 451, 452, 
453, 454, 455, 456, 457, 458, 459, 460, 461, 462, 
463, 464, 465, 466, 467, 468, 469, 470, 471, 472, 
473, 474, 475, 476, 477, 478, 479, 480, 481, 482, 
483, 484, 485, 486, 487, 488, 489, 490, 491, 492, 
493, 494, 495, 496, 497, 498, 499, 500, 501, 502, 
503, 504, 505, 506, 507, 508, 509, 510, 511, 512, 
513, 514, 515, 516, 517, 518, 519, 520, 521, 522, 
523, 524, 525, 526, 527, 528, 529, 530, 531, 532, 
533, 534, 535, 536, 537, 538, 539, 540, 541, 542, 
543, 544, 545, 546, 547, 548, 549, 550, 551, 552, 
553, 554, 555, 556, 557, 558, 559, 560, 561, 562, 
563, 564, 565, 566, 567, 568, 569, 570, 571, 572, 
573, 574, 575, 576, 577, 578, 579, 580, 581, 582, 
583, 584, 585, 586, 587, 588, 589, 590, 591, 592, 
593, 594, 595, 596, 597, 598, 599, 600, 601, 602, 
603, 604, 605, 606, 607, 608, 609, 610, 611, 612, 
613, 614, 615, 616, 617, 618, 619, 620, 621, 622, 
623, 624, 625, 626, 627, 628, 629, 630, 631, 632, 
633, 634, 635, 636, 637, 638, 639, 640, 641, 642, 
643, 644, 645, 646, 647, 648, 649, 650, 651, 652, 
653, 654, 655, 656, 657, 658, 659, 660, 661, 662, 
663, 664, 665, 666, 667, 668, 669, 670, 671, 672, 
673, 674, 675, 676, 677, 678, 679, 680, 681, 682, 
683, 684, 685, 686, 687, 688, 689, 690, 691, 692, 
693, 694, 695, 696, 697, 698, 699, 700, 701, 702, 
703, 704, 705, 706, 707, 708, 709, 710, 711, 712, 
713, 714, 715, 716, 717, 718, 719, 720, 721, 722, 
723, 724, 725, 726, 727, 728, 729, 730, 731, 732, 
733, 734, 735, 736, 737, 738, 739, 740, 741, 742, 
743, 744, 745, 746, 747, 748, 749, 750, 751, 752, 
753, 754, 755, 756, 757, 758, 759, 760, 761, 762, 
763, 764, 765, 766, 767, 768, 769, 770, 771, 772, 
773, 774, 775, 776, 777, 778, 779, 780, 781, 782, 
783, 784, 785, 786, 787, 788, 789, 790, 791, 792, 
793, 794, 795, 796, 797, 798, 799, 800, 801, 802, 
803, 804, 805, 806, 807, 808, 809, 810, 811, 812, 
813, 814, 815, 816, 817, 818, 819, 820, 821, 822, 
823, 824, 825, 826, 827, 828, 829, 830, 831, 832, 
833, 834, 835, 836, 837, 838, 839, 840, 841, 842, 
843, 844, 845, 846, 847, 848, 849, 850, 851, 852, 
853, 854, 855, 856, 857, 858, 859, 860, 861, 862, 
863, 864, 865, 866, 867, 868, 869, 870, 871, 872, 
873, 874, 875, 876, 877, 878, 879, 880, 881, 882, 
883, 884, 885, 886, 887, 888, 889, 890, 891, 892, 
893, 894, 895, 896, 897, 898, 899, 900, 901, 902, 
903, 904, 905, 906, 907, 908, 909, 910, 911, 912, 
913, 914, 915, 916, 917, 918, 919, 920, 921, 922, 
923, 924, 925, 926, 927, 928, 929, 930, 931, 932, 
933, 934, 935, 936, 937, 938, 939, 940, 941, 942, 
943, 944, 945, 946, 947, 948, 949, 950, 951, 952, 
953, 954, 955, 956, 957, 958, 959, 960, 961, 962, 
963, 964, 965, 966, 967, 968, 969, 970, 971, 972, 
973, 974, 975, 976, 977, 978, 979, 980, 981, 982, 
983, 984, 985, 986, 987, 988, 989, 990, 991, 992, 
993, 994, 995, 996, 997, 998, 999, 1000, 1001, 1002, 
1003, 1004, 1005, 1006, 1007, 1008, 1009, 1010, 1011, 1012, 
1013, 1014, 1015, 1016, 1017, 1018, 1019, 1020, 1021, 1022, 
1023, 1024, 1025, 1026, 1027, 1028, 1029, 1030, 1031, 1032, 
1033, 1034, 1035, 1036, 1037, 1038, 1039, 1040, 1041, 1042, 
1043, 1044, 1045, 1046, 1047, 1048, 1049, 1050, 1051, 1052, 
1053, 1054, 1055, 1056, 1057, 1058, 1059, 1060, 1061, 1062, 
1063, 1064, 1065, 1066, 1067, 1068, 1069, 1070, 1071, 1072, 
1073, 1074, 1075, 1076, 1077, 1078, 1079, 1080, 1081, 1082, 
1083, 1084, 1085, 1086, 1087, 1088, 1089, 1090, 1091, 1092, 
1093, 1094, 1095, 1096, 1097, 1098, 1099, 1100, 1101, 1102, 
1103, 1104, 1105, 1106, 1107, 1108, 1109, 1110, 1111, 1112, 
1113, 1114, 1115, 1116, 1117, 1118, 1119, 1120, 1121, 1122, 
1123, 1124, 1125, 1126, 1127, 1128, 1129, 1130, 1131, 1132, 
1133, 1134, 1135, 1136, 1137, 1138, 1139, 1140, 1141, 1142, 
1143, 1144, 1145, 1146, 1147, 1148, 1149, 1150, 1151, 1152, 
1153, 1154, 1155, 1156, 1157, 1158, 1159, 1160, 1161, 1162, 
1163, 1164, 1165, 1166, 1167, 1168, 1169, 1170, 1171, 1172, 
1173, 1174, 1175, 1176, 1177, 1178, 1179, 1180, 1181, 1182, 
1183, 1184, 1185, 1186, 1187, 1188, 1189, 1190, 1191, 1192, 
1193, 1194, 1195, 1196, 1197, 1198, 1199, 1200, 1201, 1202, 
1203, 1204, 1205, 1206, 1207, 1208, 1209, 1210, 1211, 1212, 
1213, 1214, 1215, 1216, 1217, 1218, 1219, 1220, 1221, 1222, 
1223, 1224, 1225, 1226, 1227, 1228, 1229, 1230, 1231, 1232, 
1233, 1234, 1235, 1236, 1237, 1238, 1239, 1240, 1241, 1242, 
1243, 1244, 1245, 1246, 1247, 1248, 1249, 1250, 1251, 1252, 
1253, 1254, 1255, 1256, 1257, 1258, 1259, 1260, 1261, 1262, 
1263, 1264, 1265, 1266, 1267, 1268, 1269, 1270, 1271, 1272, 
1273, 1274, 1275, 1276, 1277, 1278, 1279, 1280, 1281, 1282, 
1283, 1284, 1285, 1286, 1287, 1288, 1289, 1290, 1291, 1292, 
1293, 1294, 1295, 1296, 1297, 1298, 1299, 1300, 1301, 1302, 
1303, 1304, 1305, 1306, 1307, 1308, 1309, 1310, 1311, 1312, 
1313, 1314, 1315, 1316, 1317, 1318, 1319, 1320, 1321, 1322, 
1323, 1324, 1325, 1326, 1327, 1328, 1329, 1330, 1331, 1332, 
1333, 1334, 1335, 1336, 1337, 1338, 1339, 1340, 1341, 1342, 
1343, 1344, 1345, 1346, 1347, 1348, 1349, 1350, 1351, 1352, 
1353, 1354, 1355, 1356, 1357, 1358, 1359, 1360, 1361, 1362, 
1363, 1364, 1365, 1366, 1367, 1368, 1369, 1370, 1371, 1372, 
1373, 1374, 1375, 1376, 1377, 1378, 1379, 1380, 1381, 1382, 
1383, 1384, 1385, 1386, 1387, 1388, 1389, 1390, 1391, 1392, 
1393, 1394, 1395, 1396, 1397, 1398, 1399, 1400, 1401, 1402, 
1403, 1404, 1405, 1406, 1407, 1408, 1409, 1410, 1411, 1412, 
1413, 1414, 1415, 1416, 1417, 1418, 1419, 1420, 1421, 1422, 
1423, 1424, 1425, 1426, 1427, 1428, 1429, 1430, 1431, 1432, 
1433, 1434, 1435, 1436, 1437, 1438, 1439, 1440, 1441, 1442, 
1443, 1444, 1445, 1446, 1447, 1448, 1449, 1450, 1451, 1452, 
1453, 1454, 1455, 1456, 1457, 1458, 1459, 1460, 1461, 1462, 
1463, 1464, 1465, 1466, 1467, 1468, 1469, 1470, 1471, 1472, 
1473, 1474, 1475, 1476, 1477, 1478, 1479, 1480, 1481, 1482, 
1483, 1484, 1485, 1486, 1487, 1488, 1489, 1490, 1491, 1492, 
1493, 1494, 1495, 1496, 1497, 1498, 1499, 1500, 1501, 1502, 
1503, 1504, 1505, 1506, 1507, 1508, 1509, 1510, 1511, 1512, 
1513, 1514, 1515, 1516, 1517, 1518, 1519, 1520, 1521, 1522, 
1523, 1524, 1525, 1526, 1527, 1528, 1529, 1530, 1531, 1532, 
1533, 1534, 1535, 1536, 1537, 1538, 1539, 1540, 1541, 1542, 
1543, 1544, 1545, 1546, 1547, 1548, 1549, 1550, 1551, 1552, 
1553, 1554, 1555, 1556, 1557, 1558, 1559, 1560, 1561, 1562, 
1563, 1564, 1565, 1566, 1567, 1568, 1569, 1570, 1571, 1572, 
1573, 1574, 1575, 1576, 1577, 1578, 1579, 1580, 1581, 1582, 
1583, 1584, 1585, 1586, 1587, 1588, 1589, 1590, 1591, 1592, 
1593, 1594, 1595, 1596, 1597, 1598, 1599, 1600, 1601, 1602, 
1603, 1604, 1605, 1606, 1607, 1608, 1609, 1610, 1611, 1612, 
1613, 1614, 1615, 1616, 1617, 1618, 1619, 1620, 1621, 1622, 
1623, 1624, 1625, 1626, 1627, 1628, 1629, 1630, 1631, 1632, 
1633, 1634, 1635, 1636, 1637, 1638, 1639, 1640, 1641, 1642, 
1643, 1644, 1645, 1646, 1647, 1648, 1649, 1650, 1651, 1652, 
1653, 1654, 1655, 1656, 1657, 1658, 1659, 1660, 1661, 1662, 
1663, 1664, 1665, 1666, 1667, 1668, 1669, 1670, 1671, 1672, 
1673, 1674, 1675, 1676, 1677, 1678, 1679, 1680, 1681, 1682, 
1683, 1684, 1685, 1686, 1687, 1688, 1689, 1690, 1691, 1692, 
1693, 1694, 1695, 1696, 1697, 1698, 1699, 1700, 1701, 1702, 
1703, 1704, 1705, 1706, 1707, 1708, 1709, 1710, 1711, 1712, 
1713, 1714, 1715, 1716, 1717, 1718, 1719, 1720, 1721, 1722, 
1723, 1724, 1725, 1726, 1727, 1728, 1729, 1730, 1731, 1732, 
1733, 1734, 1735, 1736, 1737, 1738, 1739, 1740, 1741, 1742, 
1743, 1744, 1745, 1746, 1747, 1748, 1749, 1750, 1751, 1752, 
1753, 1754, 1755, 1756, 1757, 1758, 1759, 1760, 1761, 1762, 
1763, 1764, 1765, 1766, 1767, 1768, 1769, 1770, 1771, 1772, 
1773, 1774, 1775, 1776, 1777, 1778, 1779, 1780, 1781, 1782, 
1783, 1784, 1785, 1786, 1787, 1788, 1789, 1790, 1791, 1792, 
1793, 1794, 1795, 1796, 1797, 1798, 1799, 1800, 1801, 1802, 
1803, 1804, 1805, 1806, 1807, 1808, 1809, 1810, 1811, 1812, 
1813, 1814, 1815, 1816, 1817, 1818, 1819, 1820, 1821, 1822, 
1823, 1824, 1825, 1826, 1827, 1828, 1829, 1830, 1831, 1832, 
1833, 1834, 1835, 1836, 1837, 1838, 1839, 1840, 1841, 1842, 
1843, 1844, 1845, 1846, 1847, 1848, 1849, 1850, 1851, 1852, 
1853, 1854, 1855, 1856, 1857, 1858, 1859, 1860, 1861, 1862, 
1863, 1864, 1865, 1866, 1867, 1868, 1869, 1870, 1871, 1872, 
1873, 1874, 1875, 1876, 1877, 1878, 1879, 1880, 1881, 1882, 
1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 1891, 1892, 
1893, 1894, 1895, 1896, 1897, 1898, 1899, 1900, 1901, 1902, 
1903, 1904, 1905, 1906, 1907, 1908, 1909, 1910, 1911, 1912, 
1913, 1914, 1915, 1916, 1917, 1918, 1919, 1920, 1921, 1922, 
1923, 1924, 1925, 1926, 1927, 1928, 1929, 1930, 1931, 1932, 
1933, 1934, 1935, 1936, 1937, 1938, 1939, 1940, 1941, 1942, 
1943, 1944, 1945, 1946, 1947, 1948, 1949, 1950, 1951, 1952, 
1953, 1954, 1955, 1956, 1957, 1958, 1959, 1960, 1961, 1962, 
1963, 1964, 1965, 1966, 1967, 1968, 1969, 1970, 1971, 1972, 
1973, 1974, 1975, 1976, 1977, 1978, 1979, 1980, 1981, 1982, 
1983, 1984, 1985, 1986, 1987, 1988, 1989, 1990, 1991, 1992, 
1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 2001, 2002, 
2003, 2004, 2005, 2006, 2007, 2008, 2009, 2010, 2011, 2012, 
2013, 2014, 2015, 2016, 2017, 2018, 2019, 2020, 2021, 2022, 
2023, 2024, 2025, 2026, 2027, 2028, 2029, 2030, 2031, 2032, 
2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 2041, 2042, 
2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 2051, 2052, 
2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 2061, 2062, 
2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 2071, 2072, 
2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 2081, 2082, 
2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 2091, 2092, 
2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 2101, 2102, 
2103, 2104, 2105, 2106, 2107, 2108, 2109, 2110, 2111, 2112, 
2113, 2114, 2115, 2116, 2117, 2118, 2119, 2120, 2121, 2122, 
2123, 2124, 2125, 2126, 2127, 2128, 2129, 2130, 2131, 2132, 
2133, 2134, 2135, 2136, 2137, 2138, 2139, 2140, 2141, 2142, 
2143, 2144, 2145, 2146, 2147, 2148, 2149, 2150, 2151, 2152, 
2153, 2154, 2155, 2156, 2157, 2158, 2159, 2160, 2161, 2162, 
2163, 2164, 2165, 2166, 2167, 2168, 2169, 2170, 2171, 2172, 
2173, 2174, 2175, 2176, 2177, 2178, 2179, 2180, 2181, 2182, 
2183, 2184, 2185, 2186, 2187, 2188, 2189, 2190, 2191, 2192, 
2193, 2194, 2195, 2196, 2197, 2198, 2199, 2200, 2201, 2202, 
2203, 2204, 2205, 2206, 2207, 2208, 2209, 2210, 2211, 2212, 
2213, 2214, 2215, 2216, 2217, 2218, 2219, 2220, 2221, 2222, 
2223, 2224, 2225, 2226, 2227, 2228, 2229, 2230, 2231, 2232, 
2233, 2234, 2235, 2236, 2237, 2238, 2239, 2240, 2241, 2242, 
2243, 2244, 2245, 2246, 2247, 2248, 2249, 2250, 2251, 2252, 
2253, 2254, 2255, 2256, 2257, 2258, 2259, 2260, 2261, 2262, 
2263, 2264, 2265, 2266, 2267, 2268, 2269, 2270, 2271, 2272, 
2273, 2274, 2275, 2276, 2277, 2278, 2279, 2280, 2281, 2282, 
2283, 2284, 2285, 2286, 2287, 2288, 2289, 2290, 2291, 2292, 
2293, 2294, 2295, 2296, 2297, 2298, 2299, 2300, 2301, 2302, 
2303, 2304, 2305, 2306, 2307, 2308, 2309, 2310, 2311, 2312, 
2313, 2314, 2315, 2316, 2317, 2318, 2319, 2320, 2321, 2322, 
2323, 2324, 2325, 2326, 2327, 2328, 2329, 2330, 2331, 2332, 
2333, 2334, 2335, 2336, 2337, 2338, 2339, 2340, 2341, 2342, 
2343, 2344, 2345, 2346, 2347, 2348, 2349, 2350, 2351, 2352, 
2353, 2354, 2355, 2356, 2357, 2358, 2359, 2360, 2361, 2362, 
2363, 2364, 2365, 2366, 2367, 2368, 2369, 2370, 2371, 2372, 
2373, 2374, 2375, 2376, 2377, 2378, 2379, 2380, 2381, 2382, 
2383, 2384, 2385, 2386, 2387, 2388, 2389, 2390, 2391, 2392, 
2393, 2394, 2395, 2396, 2397, 2398, 2399, 2400, 2401, 2402, 
2403, 2404, 2405, 2406, 2407, 2408, 2409, 2410, 2411, 2412, 
2413, 2414, 2415, 2416, 2417, 2418, 2419, 2420, 2421, 2422, 
2423, 2424, 2425, 2426, 2427, 2428, 2429, 2430, 2431, 2432, 
2433, 2434, 2435, 2436, 2437, 2438, 2439, 2440, 2441, 2442, 
2443, 2444, 2445, 2446, 2447, 2448, 2449, 2450, 2451, 2452, 
2453, 2454, 2455, 2456, 2457, 2458, 2459, 2460, 2461, 2462, 
2463, 2464, 2465, 2466, 2467, 2468, 2469, 2470, 2471, 2472, 
2473, 2474, 2475, 2476, 2477, 2478, 2479, 2480, 2481, 2482, 
2483, 2484, 2485, 2486, 2487, 2488, 2489, 2490, 2491, 2492, 
2493, 2494, 2495, 2496, 2497, 2498, 2499, 2500, 2501, 2502, 
2503, 2504, 2505, 2506, 2507, 2508, 2509, 2510, 2511, 2512, 
*ELSET,ELSET=Copper
878, 879, 880, 881, 882, 883, 884, 885, 886, 887, 
888, 889, 890, 891, 892, 893, 894, 895, 896, 897, 
898, 899, 900, 901, 902, 903, 904, 905, 906, 907, 
908, 909, 910, 911, 912, 913, 914, 915, 916, 917, 
918, 919, 920, 921, 922, 923, 924, 925, 926, 927, 
928, 929, 930, 931, 932, 933, 934, 935, 936, 937, 
938, 939, 940, 941, 942, 943, 944, 945, 946, 947, 
948, 949, 950, 951, 952, 953, 954, 955, 956, 957, 
