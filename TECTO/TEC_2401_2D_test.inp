4773, 1.38, 0.384, 0
4774, 1.4, 0.408, 0
4775, 1.42, 0.384, 0
4776, 1.44, 0.408, 0
4777, 1.46, 0.384, 0
4778, 1.48, 0.408, 0
4779, 1.5, 0.384, 0
4780, 1.52, 0.408, 0
4781, 1.54, 0.384, 0
4782, 1.56, 0.408, 0
4783, 1.58, 0.384, 0
4784, 1.6, 0.408, 0
4785, 1.62, 0.384, 0
4786, 1.64, 0.408, 0
4787, 1.66, 0.384, 0
4788, 1.68, 0.408, 0
4789, 1.7, 0.384, 0
4790, 1.72, 0.408, 0
4791, 1.74, 0.384, 0
4792, 1.76, 0.408, 0
4793, 1.78, 0.384, 0
4794, 1.8, 0.408, 0
4795, 1.82, 0.384, 0
4796, 1.84, 0.408, 0
4797, 1.86, 0.384, 0
4798, 1.88, 0.408, 0
4799, 1.9, 0.384, 0
4800, 1.92, 0.408, 0
4801, 1.94, 0.384, 0
4802, 1.96, 0.408, 0
4803, 1.98, 0.384, 0
4804, 2, 0.408, 0
4805, 2.02, 0.384, 0
4806, 2.04, 0.408, 0
4807, 2.06, 0.384, 0
4808, 2.08, 0.408, 0
4809, 2.1, 0.384, 0
4810, 2.12, 0.408, 0
4811, 2.14, 0.384, 0
4812, 2.16, 0.408, 0
4813, 2.18, 0.384, 0
4814, 1.22, 0.336, 0
4815, 1.24, 0.36, 0
4816, 1.26, 0.336, 0
4817, 1.28, 0.36, 0
4818, 1.3, 0.336, 0
4819, 1.32, 0.36, 0
4820, 1.34, 0.336, 0
4821, 1.36, 0.36, 0
4822, 1.38, 0.336, 0
4823, 1.4, 0.36, 0
4824, 1.42, 0.336, 0
4825, 1.44, 0.36, 0
4826, 1.46, 0.336, 0
4827, 1.48, 0.36, 0
4828, 1.5, 0.336, 0
4829, 1.52, 0.36, 0
4830, 1.54, 0.336, 0
4831, 1.56, 0.36, 0
4832, 1.58, 0.336, 0
4833, 1.6, 0.36, 0
4834, 1.62, 0.336, 0
4835, 1.64, 0.36, 0
4836, 1.66, 0.336, 0
4837, 1.68, 0.36, 0
4838, 1.7, 0.336, 0
4839, 1.72, 0.36, 0
4840, 1.74, 0.336, 0
4841, 1.76, 0.36, 0
4842, 1.78, 0.336, 0
4843, 1.8, 0.36, 0
4844, 1.82, 0.336, 0
4845, 1.84, 0.36, 0
4846, 1.86, 0.336, 0
4847, 1.88, 0.36, 0
4848, 1.9, 0.336, 0
4849, 1.92, 0.36, 0
4850, 1.94, 0.336, 0
4851, 1.96, 0.36, 0
4852, 1.98, 0.336, 0
4853, 2, 0.36, 0
4854, 2.02, 0.336, 0
4855, 2.04, 0.36, 0
4856, 2.06, 0.336, 0
4857, 2.08, 0.36, 0
4858, 2.1, 0.336, 0
4859, 2.12, 0.36, 0
4860, 2.14, 0.336, 0
4861, 2.16, 0.36, 0
4862, 2.18, 0.336, 0
4863, 1.22, 0.288, 0
4864, 1.24, 0.312, 0
4865, 1.26, 0.288, 0
4866, 1.28, 0.312, 0
4867, 1.3, 0.288, 0
4868, 1.32, 0.312, 0
4869, 1.34, 0.288, 0
4870, 1.36, 0.312, 0
4871, 1.38, 0.288, 0
4872, 1.4, 0.312, 0
4873, 1.42, 0.288, 0
4874, 1.44, 0.312, 0
4875, 1.46, 0.288, 0
4876, 1.48, 0.312, 0
4877, 1.5, 0.288, 0
4878, 1.52, 0.312, 0
4879, 1.54, 0.288, 0
4880, 1.56, 0.312, 0
4881, 1.58, 0.288, 0
4882, 1.6, 0.312, 0
4883, 1.62, 0.288, 0
4884, 1.64, 0.312, 0
4885, 1.66, 0.288, 0
4886, 1.68, 0.312, 0
4887, 1.7, 0.288, 0
4888, 1.72, 0.312, 0
4889, 1.74, 0.288, 0
4890, 1.76, 0.312, 0
4891, 1.78, 0.288, 0
4892, 1.8, 0.312, 0
4893, 1.82, 0.288, 0
4894, 1.84, 0.312, 0
4895, 1.86, 0.288, 0
4896, 1.88, 0.312, 0
4897, 1.9, 0.288, 0
4898, 1.92, 0.312, 0
4899, 1.94, 0.288, 0
4900, 1.96, 0.312, 0
4901, 1.98, 0.288, 0
4902, 2, 0.312, 0
4903, 2.02, 0.288, 0
4904, 2.04, 0.312, 0
4905, 2.06, 0.288, 0
4906, 2.08, 0.312, 0
4907, 2.1, 0.288, 0
4908, 2.12, 0.312, 0
4909, 2.14, 0.288, 0
4910, 2.16, 0.312, 0
4911, 2.18, 0.288, 0
4912, 1.22, 0.24, 0
4913, 1.24, 0.264, 0
4914, 1.26, 0.24, 0
4915, 1.28, 0.264, 0
4916, 1.3, 0.24, 0
4917, 1.32, 0.264, 0
4918, 1.34, 0.24, 0
4919, 1.36, 0.264, 0
4920, 1.38, 0.24, 0
4921, 1.4, 0.264, 0
4922, 1.42, 0.24, 0
4923, 1.44, 0.264, 0
4924, 1.46, 0.24, 0
4925, 1.48, 0.264, 0
4926, 1.5, 0.24, 0
4927, 1.52, 0.264, 0
4928, 1.54, 0.24, 0
4929, 1.56, 0.264, 0
4930, 1.58, 0.24, 0
4931, 1.6, 0.264, 0
4932, 1.62, 0.24, 0
4933, 1.64, 0.264, 0
4934, 1.66, 0.24, 0
4935, 1.68, 0.264, 0
4936, 1.7, 0.24, 0
4937, 1.72, 0.264, 0
4938, 1.74, 0.24, 0
4939, 1.76, 0.264, 0
4940, 1.78, 0.24, 0
4941, 1.8, 0.264, 0
4942, 1.82, 0.24, 0
4943, 1.84, 0.264, 0
4944, 1.86, 0.24, 0
4945, 1.88, 0.264, 0
4946, 1.9, 0.24, 0
4947, 1.92, 0.264, 0
4948, 1.94, 0.24, 0
4949, 1.96, 0.264, 0
4950, 1.98, 0.24, 0
4951, 2, 0.264, 0
4952, 2.02, 0.24, 0
4953, 2.04, 0.264, 0
4954, 2.06, 0.24, 0
4955, 2.08, 0.264, 0
4956, 2.1, 0.24, 0
4957, 2.12, 0.264, 0
4958, 2.14, 0.24, 0
4959, 2.16, 0.264, 0
4960, 2.18, 0.24, 0
4961, 1.22, 0.192, 0
4962, 1.24, 0.216, 0
4963, 1.26, 0.192, 0
4964, 1.28, 0.216, 0
4965, 1.3, 0.192, 0
4966, 1.32, 0.216, 0
4967, 1.34, 0.192, 0
4968, 1.36, 0.216, 0
4969, 1.38, 0.192, 0
4970, 1.4, 0.216, 0
4971, 1.42, 0.192, 0
4972, 1.44, 0.216, 0
4973, 1.46, 0.192, 0
4974, 1.48, 0.216, 0
4975, 1.5, 0.192, 0
4976, 1.52, 0.216, 0
4977, 1.54, 0.192, 0
4978, 1.56, 0.216, 0
4979, 1.58, 0.192, 0
4980, 1.6, 0.216, 0
4981, 1.62, 0.192, 0
4982, 1.64, 0.216, 0
4983, 1.66, 0.192, 0
4984, 1.68, 0.216, 0
4985, 1.7, 0.192, 0
4986, 1.72, 0.216, 0
4987, 1.74, 0.192, 0
4988, 1.76, 0.216, 0
4989, 1.78, 0.192, 0
4990, 1.8, 0.216, 0
4991, 1.82, 0.192, 0
4992, 1.84, 0.216, 0
4993, 1.86, 0.192, 0
4994, 1.88, 0.216, 0
4995, 1.9, 0.192, 0
4996, 1.92, 0.216, 0
4997, 1.94, 0.192, 0
4998, 1.96, 0.216, 0
4999, 1.98, 0.192, 0
5000, 2, 0.216, 0
5001, 2.02, 0.192, 0
5002, 2.04, 0.216, 0
5003, 2.06, 0.192, 0
5004, 2.08, 0.216, 0
5005, 2.1, 0.192, 0
5006, 2.12, 0.216, 0
5007, 2.14, 0.192, 0
5008, 2.16, 0.216, 0
5009, 2.18, 0.192, 0
5010, 1.22, 0.144, 0
5011, 1.24, 0.168, 0
5012, 1.26, 0.144, 0
5013, 1.28, 0.168, 0
5014, 1.3, 0.144, 0
5015, 1.32, 0.168, 0
5016, 1.34, 0.144, 0
5017, 1.36, 0.168, 0
5018, 1.38, 0.144, 0
5019, 1.4, 0.168, 0
5020, 1.42, 0.144, 0
5021, 1.44, 0.168, 0
5022, 1.46, 0.144, 0
5023, 1.48, 0.168, 0
5024, 1.5, 0.144, 0
5025, 1.52, 0.168, 0
5026, 1.54, 0.144, 0
5027, 1.56, 0.168, 0
5028, 1.58, 0.144, 0
5029, 1.6, 0.168, 0
5030, 1.62, 0.144, 0
5031, 1.64, 0.168, 0
5032, 1.66, 0.144, 0
5033, 1.68, 0.168, 0
5034, 1.7, 0.144, 0
5035, 1.72, 0.168, 0
5036, 1.74, 0.144, 0
5037, 1.76, 0.168, 0
5038, 1.78, 0.144, 0
5039, 1.8, 0.168, 0
5040, 1.82, 0.144, 0
5041, 1.84, 0.168, 0
5042, 1.86, 0.144, 0
5043, 1.88, 0.168, 0
5044, 1.9, 0.144, 0
5045, 1.92, 0.168, 0
5046, 1.94, 0.144, 0
5047, 1.96, 0.168, 0
5048, 1.98, 0.144, 0
5049, 2, 0.168, 0
5050, 2.02, 0.144, 0
5051, 2.04, 0.168, 0
5052, 2.06, 0.144, 0
5053, 2.08, 0.168, 0
5054, 2.1, 0.144, 0
5055, 2.12, 0.168, 0
5056, 2.14, 0.144, 0
5057, 2.16, 0.168, 0
5058, 2.18, 0.144, 0
5059, 1.22, 0.096, 0
5060, 1.24, 0.12, 0
5061, 1.26, 0.096, 0
5062, 1.28, 0.12, 0
5063, 1.3, 0.096, 0
5064, 1.32, 0.12, 0
5065, 1.34, 0.096, 0
5066, 1.36, 0.12, 0
5067, 1.38, 0.096, 0
5068, 1.4, 0.12, 0
5069, 1.42, 0.096, 0
5070, 1.44, 0.12, 0
5071, 1.46, 0.096, 0
5072, 1.48, 0.12, 0
5073, 1.5, 0.096, 0
5074, 1.52, 0.12, 0
5075, 1.54, 0.096, 0
5076, 1.56, 0.12, 0
5077, 1.58, 0.096, 0
5078, 1.6, 0.12, 0
5079, 1.62, 0.096, 0
5080, 1.64, 0.12, 0
5081, 1.66, 0.096, 0
5082, 1.68, 0.12, 0
5083, 1.7, 0.096, 0
5084, 1.72, 0.12, 0
5085, 1.74, 0.096, 0
5086, 1.76, 0.12, 0
5087, 1.78, 0.096, 0
5088, 1.8, 0.12, 0
5089, 1.82, 0.096, 0
5090, 1.84, 0.12, 0
5091, 1.86, 0.096, 0
5092, 1.88, 0.12, 0
5093, 1.9, 0.096, 0
5094, 1.92, 0.12, 0
5095, 1.94, 0.096, 0
5096, 1.96, 0.12, 0
5097, 1.98, 0.096, 0
5098, 2, 0.12, 0
5099, 2.02, 0.096, 0
5100, 2.04, 0.12, 0
5101, 2.06, 0.096, 0
5102, 2.08, 0.12, 0
5103, 2.1, 0.096, 0
5104, 2.12, 0.12, 0
5105, 2.14, 0.096, 0
5106, 2.16, 0.12, 0
5107, 2.18, 0.096, 0
5108, 1.22, 0.048, 0
5109, 1.24, 0.072, 0
5110, 1.26, 0.048, 0
5111, 1.28, 0.072, 0
5112, 1.3, 0.048, 0
5113, 1.32, 0.072, 0
5114, 1.34, 0.048, 0
5115, 1.36, 0.072, 0
5116, 1.38, 0.048, 0
5117, 1.4, 0.072, 0
5118, 1.42, 0.048, 0
5119, 1.44, 0.072, 0
5120, 1.46, 0.048, 0
5121, 1.48, 0.072, 0
5122, 1.5, 0.048, 0
5123, 1.52, 0.072, 0
5124, 1.54, 0.048, 0
5125, 1.56, 0.072, 0
5126, 1.58, 0.048, 0
5127, 1.6, 0.072, 0
5128, 1.62, 0.048, 0
5129, 1.64, 0.072, 0
5130, 1.66, 0.048, 0
5131, 1.68, 0.072, 0
5132, 1.7, 0.048, 0
5133, 1.72, 0.072, 0
5134, 1.74, 0.048, 0
5135, 1.76, 0.072, 0
5136, 1.78, 0.048, 0
5137, 1.8, 0.072, 0
5138, 1.82, 0.048, 0
5139, 1.84, 0.072, 0
5140, 1.86, 0.048, 0
5141, 1.88, 0.072, 0
5142, 1.9, 0.048, 0
5143, 1.92, 0.072, 0
5144, 1.94, 0.048, 0
5145, 1.96, 0.072, 0
5146, 1.98, 0.048, 0
5147, 2, 0.072, 0
5148, 2.02, 0.048, 0
5149, 2.04, 0.072, 0
5150, 2.06, 0.048, 0
5151, 2.08, 0.072, 0
5152, 2.1, 0.048, 0
5153, 2.12, 0.072, 0
5154, 2.14, 0.048, 0
5155, 2.16, 0.072, 0
5156, 2.18, 0.048, 0
5157, 1.24, 0.024, 0
5158, 1.28, 0.024, 0
5159, 1.32, 0.024, 0
5160, 1.36, 0.024, 0
5161, 1.4, 0.024, 0
5162, 1.44, 0.024, 0
5163, 1.48, 0.024, 0
5164, 1.52, 0.024, 0
5165, 1.56, 0.024, 0
5166, 1.6, 0.024, 0
5167, 1.64, 0.024, 0
5168, 1.68, 0.024, 0
5169, 1.72, 0.024, 0
5170, 1.76, 0.024, 0
5171, 1.8, 0.024, 0
5172, 1.84, 0.024, 0
5173, 1.88, 0.024, 0
5174, 1.92, 0.024, 0
5175, 1.96, 0.024, 0
5176, 2, 0.024, 0
5177, 2.04, 0.024, 0
5178, 2.08, 0.024, 0
5179, 2.12, 0.024, 0
5180, 2.16, 0.024, 0
5181, 1.24, -0.083333333333333, 0
5182, 1.28, -0.083333333333333, 0
5183, 1.32, -0.083333333333333, 0
5184, 1.36, -0.083333333333333, 0
5185, 1.4, -0.083333333333333, 0
5186, 1.44, -0.083333333333333, 0
5187, 1.48, -0.083333333333333, 0
5188, 1.52, -0.083333333333333, 0
5189, 1.56, -0.083333333333333, 0
5190, 1.6, -0.083333333333333, 0
5191, 1.64, -0.083333333333333, 0
5192, 1.68, -0.083333333333333, 0
5193, 1.72, -0.083333333333333, 0
5194, 1.76, -0.083333333333333, 0
5195, 1.8, -0.083333333333333, 0
5196, 1.84, -0.083333333333333, 0
5197, 1.88, -0.083333333333333, 0
5198, 1.92, -0.083333333333333, 0
5199, 1.96, -0.083333333333333, 0
5200, 2, -0.083333333333333, 0
5201, 2.04, -0.083333333333333, 0
5202, 2.08, -0.083333333333333, 0
5203, 2.12, -0.083333333333333, 0
5204, 2.16, -0.083333333333333, 0
5205, 1.24, -0.11666666666667, 0
5206, 1.28, -0.11666666666667, 0
5207, 1.32, -0.11666666666667, 0
5208, 1.36, -0.11666666666667, 0
5209, 1.4, -0.11666666666667, 0
5210, 1.44, -0.11666666666667, 0
5211, 1.48, -0.11666666666667, 0
5212, 1.52, -0.11666666666667, 0
5213, 1.56, -0.11666666666667, 0
5214, 1.6, -0.11666666666667, 0
5215, 1.64, -0.11666666666667, 0
5216, 1.68, -0.11666666666667, 0
5217, 1.72, -0.11666666666667, 0
5218, 1.76, -0.11666666666667, 0
5219, 1.8, -0.11666666666667, 0
5220, 1.84, -0.11666666666667, 0
5221, 1.88, -0.11666666666667, 0
5222, 1.92, -0.11666666666667, 0
5223, 1.96, -0.11666666666667, 0
5224, 2, -0.11666666666667, 0
5225, 2.04, -0.11666666666667, 0
5226, 2.08, -0.11666666666667, 0
5227, 2.12, -0.11666666666667, 0
5228, 2.16, -0.11666666666667, 0
5229, 1.22, -0.083333333333333, 0
5230, 1.24, -0.066666666666667, 0
5231, 1.26, -0.083333333333333, 0
5232, 1.28, -0.066666666666667, 0
5233, 1.3, -0.083333333333333, 0
5234, 1.32, -0.066666666666667, 0
5235, 1.34, -0.083333333333333, 0
5236, 1.36, -0.066666666666667, 0
5237, 1.38, -0.083333333333333, 0
5238, 1.4, -0.066666666666667, 0
5239, 1.42, -0.083333333333333, 0
5240, 1.44, -0.066666666666667, 0
5241, 1.46, -0.083333333333333, 0
5242, 1.48, -0.066666666666667, 0
5243, 1.5, -0.083333333333333, 0
5244, 1.52, -0.066666666666667, 0
5245, 1.54, -0.083333333333333, 0
5246, 1.56, -0.066666666666667, 0
5247, 1.58, -0.083333333333333, 0
5248, 1.6, -0.066666666666667, 0
5249, 1.62, -0.083333333333333, 0
5250, 1.64, -0.066666666666667, 0
5251, 1.66, -0.083333333333333, 0
5252, 1.68, -0.066666666666667, 0
5253, 1.7, -0.083333333333333, 0
5254, 1.72, -0.066666666666667, 0
5255, 1.74, -0.083333333333333, 0
5256, 1.76, -0.066666666666667, 0
5257, 1.78, -0.083333333333333, 0
5258, 1.8, -0.066666666666667, 0
5259, 1.82, -0.083333333333333, 0
5260, 1.84, -0.066666666666667, 0
5261, 1.86, -0.083333333333333, 0
5262, 1.88, -0.066666666666667, 0
5263, 1.9, -0.083333333333333, 0
5264, 1.92, -0.066666666666667, 0
5265, 1.94, -0.083333333333333, 0
5266, 1.96, -0.066666666666667, 0
5267, 1.98, -0.083333333333333, 0
5268, 2, -0.066666666666667, 0
5269, 2.02, -0.083333333333333, 0
5270, 2.04, -0.066666666666667, 0
5271, 2.06, -0.083333333333333, 0
5272, 2.08, -0.066666666666667, 0
5273, 2.1, -0.083333333333333, 0
5274, 2.12, -0.066666666666667, 0
5275, 2.14, -0.083333333333333, 0
5276, 2.16, -0.066666666666667, 0
5277, 2.18, -0.083333333333333, 0
5278, 1.22, -0.11666666666667, 0
5279, 1.24, -0.1, 0
5280, 1.26, -0.11666666666667, 0
5281, 1.28, -0.1, 0
5282, 1.3, -0.11666666666667, 0
5283, 1.32, -0.1, 0
5284, 1.34, -0.11666666666667, 0
5285, 1.36, -0.1, 0
5286, 1.38, -0.11666666666667, 0
5287, 1.4, -0.1, 0
5288, 1.42, -0.11666666666667, 0
5289, 1.44, -0.1, 0
5290, 1.46, -0.11666666666667, 0
5291, 1.48, -0.1, 0
5292, 1.5, -0.11666666666667, 0
5293, 1.52, -0.1, 0
5294, 1.54, -0.11666666666667, 0
5295, 1.56, -0.1, 0
5296, 1.58, -0.11666666666667, 0
5297, 1.6, -0.1, 0
5298, 1.62, -0.11666666666667, 0
5299, 1.64, -0.1, 0
5300, 1.66, -0.11666666666667, 0
5301, 1.68, -0.1, 0
5302, 1.7, -0.11666666666667, 0
5303, 1.72, -0.1, 0
5304, 1.74, -0.11666666666667, 0
5305, 1.76, -0.1, 0
5306, 1.78, -0.11666666666667, 0
5307, 1.8, -0.1, 0
5308, 1.82, -0.11666666666667, 0
5309, 1.84, -0.1, 0
5310, 1.86, -0.11666666666667, 0
5311, 1.88, -0.1, 0
5312, 1.9, -0.11666666666667, 0
5313, 1.92, -0.1, 0
5314, 1.94, -0.11666666666667, 0
5315, 1.96, -0.1, 0
5316, 1.98, -0.11666666666667, 0
5317, 2, -0.1, 0
5318, 2.02, -0.11666666666667, 0
5319, 2.04, -0.1, 0
5320, 2.06, -0.11666666666667, 0
5321, 2.08, -0.1, 0
5322, 2.1, -0.11666666666667, 0
5323, 2.12, -0.1, 0
5324, 2.14, -0.11666666666667, 0
5325, 2.16, -0.1, 0
5326, 2.18, -0.11666666666667, 0
5327, 1.24, -0.13333333333333, 0
5328, 1.28, -0.13333333333333, 0
5329, 1.32, -0.13333333333333, 0
5330, 1.36, -0.13333333333333, 0
5331, 1.4, -0.13333333333333, 0
5332, 1.44, -0.13333333333333, 0
5333, 1.48, -0.13333333333333, 0
5334, 1.52, -0.13333333333333, 0
5335, 1.56, -0.13333333333333, 0
5336, 1.6, -0.13333333333333, 0
5337, 1.64, -0.13333333333333, 0
5338, 1.68, -0.13333333333333, 0
5339, 1.72, -0.13333333333333, 0
5340, 1.76, -0.13333333333333, 0
5341, 1.8, -0.13333333333333, 0
5342, 1.84, -0.13333333333333, 0
5343, 1.88, -0.13333333333333, 0
5344, 1.92, -0.13333333333333, 0
5345, 1.96, -0.13333333333333, 0
5346, 2, -0.13333333333333, 0
5347, 2.04, -0.13333333333333, 0
5348, 2.08, -0.13333333333333, 0
5349, 2.12, -0.13333333333333, 0
5350, 2.16, -0.13333333333333, 0
5351, 0.04, -0.083333333333333, 0
5352, 0.08, -0.083333333333333, 0
5353, 0.12, -0.083333333333333, 0
5354, 0.16, -0.083333333333333, 0
5355, 0.2, -0.083333333333333, 0
5356, 0.24, -0.083333333333333, 0
5357, 0.28, -0.083333333333333, 0
5358, 0.32, -0.083333333333333, 0
5359, 0.36, -0.083333333333333, 0
5360, 0.4, -0.083333333333333, 0
5361, 0.44, -0.083333333333333, 0
5362, 0.48, -0.083333333333333, 0
5363, 0.52, -0.083333333333333, 0
5364, 0.56, -0.083333333333333, 0
5365, 0.6, -0.083333333333333, 0
5366, 0.64, -0.083333333333333, 0
5367, 0.68, -0.083333333333333, 0
5368, 0.72, -0.083333333333333, 0
5369, 0.76, -0.083333333333333, 0
5370, 0.8, -0.083333333333333, 0
5371, 0.84, -0.083333333333333, 0
5372, 0.88, -0.083333333333333, 0
5373, 0.92, -0.083333333333333, 0
5374, 0.96, -0.083333333333333, 0
5375, 0.04, -0.11666666666667, 0
5376, 0.08, -0.11666666666667, 0
5377, 0.12, -0.11666666666667, 0
5378, 0.16, -0.11666666666667, 0
5379, 0.2, -0.11666666666667, 0
5380, 0.24, -0.11666666666667, 0
5381, 0.28, -0.11666666666667, 0
5382, 0.32, -0.11666666666667, 0
5383, 0.36, -0.11666666666667, 0
5384, 0.4, -0.11666666666667, 0
5385, 0.44, -0.11666666666667, 0
5386, 0.48, -0.11666666666667, 0
5387, 0.52, -0.11666666666667, 0
5388, 0.56, -0.11666666666667, 0
5389, 0.6, -0.11666666666667, 0
5390, 0.64, -0.11666666666667, 0
5391, 0.68, -0.11666666666667, 0
5392, 0.72, -0.11666666666667, 0
5393, 0.76, -0.11666666666667, 0
5394, 0.8, -0.11666666666667, 0
5395, 0.84, -0.11666666666667, 0
5396, 0.88, -0.11666666666667, 0
5397, 0.92, -0.11666666666667, 0
5398, 0.96, -0.11666666666667, 0
5399, 0.02, -0.083333333333333, 0
5400, 0.04, -0.066666666666667, 0
5401, 0.06, -0.083333333333333, 0
5402, 0.08, -0.066666666666667, 0
5403, 0.1, -0.083333333333333, 0
5404, 0.12, -0.066666666666667, 0
5405, 0.14, -0.083333333333333, 0
5406, 0.16, -0.066666666666667, 0
5407, 0.18, -0.083333333333333, 0
5408, 0.2, -0.066666666666667, 0
5409, 0.22, -0.083333333333333, 0
5410, 0.24, -0.066666666666667, 0
5411, 0.26, -0.083333333333333, 0
5412, 0.28, -0.066666666666667, 0
5413, 0.3, -0.083333333333333, 0
5414, 0.32, -0.066666666666667, 0
5415, 0.34, -0.083333333333333, 0
5416, 0.36, -0.066666666666667, 0
5417, 0.38, -0.083333333333333, 0
5418, 0.4, -0.066666666666667, 0
5419, 0.42, -0.083333333333333, 0
5420, 0.44, -0.066666666666667, 0
5421, 0.46, -0.083333333333333, 0
5422, 0.48, -0.066666666666667, 0
5423, 0.5, -0.083333333333333, 0
5424, 0.52, -0.066666666666667, 0
5425, 0.54, -0.083333333333333, 0
5426, 0.56, -0.066666666666667, 0
5427, 0.58, -0.083333333333333, 0
5428, 0.6, -0.066666666666667, 0
5429, 0.62, -0.083333333333333, 0
5430, 0.64, -0.066666666666667, 0
5431, 0.66, -0.083333333333333, 0
5432, 0.68, -0.066666666666667, 0
5433, 0.7, -0.083333333333333, 0
5434, 0.72, -0.066666666666667, 0
5435, 0.74, -0.083333333333333, 0
5436, 0.76, -0.066666666666667, 0
5437, 0.78, -0.083333333333333, 0
5438, 0.8, -0.066666666666667, 0
5439, 0.82, -0.083333333333333, 0
5440, 0.84, -0.066666666666667, 0
5441, 0.86, -0.083333333333333, 0
5442, 0.88, -0.066666666666667, 0
5443, 0.9, -0.083333333333333, 0
5444, 0.92, -0.066666666666667, 0
5445, 0.94, -0.083333333333333, 0
5446, 0.96, -0.066666666666667, 0
5447, 0.98, -0.083333333333333, 0
5448, 0.02, -0.11666666666667, 0
5449, 0.04, -0.1, 0
5450, 0.06, -0.11666666666667, 0
5451, 0.08, -0.1, 0
5452, 0.1, -0.11666666666667, 0
5453, 0.12, -0.1, 0
5454, 0.14, -0.11666666666667, 0
5455, 0.16, -0.1, 0
5456, 0.18, -0.11666666666667, 0
5457, 0.2, -0.1, 0
5458, 0.22, -0.11666666666667, 0
5459, 0.24, -0.1, 0
5460, 0.26, -0.11666666666667, 0
5461, 0.28, -0.1, 0
5462, 0.3, -0.11666666666667, 0
5463, 0.32, -0.1, 0
5464, 0.34, -0.11666666666667, 0
5465, 0.36, -0.1, 0
5466, 0.38, -0.11666666666667, 0
5467, 0.4, -0.1, 0
5468, 0.42, -0.11666666666667, 0
5469, 0.44, -0.1, 0
5470, 0.46, -0.11666666666667, 0
5471, 0.48, -0.1, 0
5472, 0.5, -0.11666666666667, 0
5473, 0.52, -0.1, 0
5474, 0.54, -0.11666666666667, 0
5475, 0.56, -0.1, 0
5476, 0.58, -0.11666666666667, 0
5477, 0.6, -0.1, 0
5478, 0.62, -0.11666666666667, 0
5479, 0.64, -0.1, 0
5480, 0.66, -0.11666666666667, 0
5481, 0.68, -0.1, 0
5482, 0.7, -0.11666666666667, 0
5483, 0.72, -0.1, 0
5484, 0.74, -0.11666666666667, 0
5485, 0.76, -0.1, 0
5486, 0.78, -0.11666666666667, 0
5487, 0.8, -0.1, 0
5488, 0.82, -0.11666666666667, 0
5489, 0.84, -0.1, 0
5490, 0.86, -0.11666666666667, 0
5491, 0.88, -0.1, 0
5492, 0.9, -0.11666666666667, 0
5493, 0.92, -0.1, 0
5494, 0.94, -0.11666666666667, 0
5495, 0.96, -0.1, 0
5496, 0.98, -0.11666666666667, 0
5497, 0.04, -0.13333333333333, 0
5498, 0.08, -0.13333333333333, 0
5499, 0.12, -0.13333333333333, 0
5500, 0.16, -0.13333333333333, 0
5501, 0.2, -0.13333333333333, 0
5502, 0.24, -0.13333333333333, 0
5503, 0.28, -0.13333333333333, 0
5504, 0.32, -0.13333333333333, 0
5505, 0.36, -0.13333333333333, 0
5506, 0.4, -0.13333333333333, 0
5507, 0.44, -0.13333333333333, 0
5508, 0.48, -0.13333333333333, 0
5509, 0.52, -0.13333333333333, 0
5510, 0.56, -0.13333333333333, 0
5511, 0.6, -0.13333333333333, 0
5512, 0.64, -0.13333333333333, 0
5513, 0.68, -0.13333333333333, 0
5514, 0.72, -0.13333333333333, 0
5515, 0.76, -0.13333333333333, 0
5516, 0.8, -0.13333333333333, 0
5517, 0.84, -0.13333333333333, 0
5518, 0.88, -0.13333333333333, 0
5519, 0.92, -0.13333333333333, 0
5520, 0.96, -0.13333333333333, 0
5521, -0.033333333333333, -0.083333333333333, 0
5522, -0.033333333333333, -0.11666666666667, 0
5523, -0.066666666666667, -0.083333333333333, 0
5524, -0.066666666666667, -0.11666666666667, 0
5525, -0.033333333333333, -0.066666666666667, 0
5526, -0.016666666666667, -0.083333333333333, 0
5527, -0.033333333333333, -0.1, 0
5528, -0.016666666666667, -0.11666666666667, 0
5529, -0.033333333333333, -0.13333333333333, 0
5530, -0.066666666666667, -0.066666666666667, 0
5531, -0.05, -0.083333333333333, 0
5532, -0.066666666666667, -0.1, 0
5533, -0.05, -0.11666666666667, 0
5534, -0.066666666666667, -0.13333333333333, 0
5535, -0.083333333333333, -0.083333333333333, 0
5536, -0.083333333333333, -0.11666666666667, 0
5537, 0.04, -0.2, 0
5538, 0.08, -0.2, 0
5539, 0.12, -0.2, 0
5540, 0.16, -0.2, 0
5541, 0.2, -0.2, 0
5542, 0.24, -0.2, 0
5543, 0.28, -0.2, 0
5544, 0.32, -0.2, 0
5545, 0.36, -0.2, 0
5546, 0.4, -0.2, 0
5547, 0.44, -0.2, 0
5548, 0.48, -0.2, 0
5549, 0.52, -0.2, 0
5550, 0.56, -0.2, 0
5551, 0.6, -0.2, 0
5552, 0.64, -0.2, 0
5553, 0.68, -0.2, 0
5554, 0.72, -0.2, 0
5555, 0.76, -0.2, 0
5556, 0.8, -0.2, 0
5557, 0.84, -0.2, 0
5558, 0.88, -0.2, 0
5559, 0.92, -0.2, 0
5560, 0.96, -0.2, 0
5561, 0.04, -0.25, 0
5562, 0.08, -0.25, 0
5563, 0.12, -0.25, 0
5564, 0.16, -0.25, 0
5565, 0.2, -0.25, 0
5566, 0.24, -0.25, 0
5567, 0.28, -0.25, 0
5568, 0.32, -0.25, 0
5569, 0.36, -0.25, 0
5570, 0.4, -0.25, 0
5571, 0.44, -0.25, 0
5572, 0.48, -0.25, 0
5573, 0.52, -0.25, 0
5574, 0.56, -0.25, 0
5575, 0.6, -0.25, 0
5576, 0.64, -0.25, 0
5577, 0.68, -0.25, 0
5578, 0.72, -0.25, 0
5579, 0.76, -0.25, 0
5580, 0.8, -0.25, 0
5581, 0.84, -0.25, 0
5582, 0.88, -0.25, 0
5583, 0.92, -0.25, 0
5584, 0.96, -0.25, 0
5585, 0.04, -0.3, 0
5586, 0.08, -0.3, 0
5587, 0.12, -0.3, 0
5588, 0.16, -0.3, 0
5589, 0.2, -0.3, 0
5590, 0.24, -0.3, 0
5591, 0.28, -0.3, 0
5592, 0.32, -0.3, 0
5593, 0.36, -0.3, 0
5594, 0.4, -0.3, 0
5595, 0.44, -0.3, 0
5596, 0.48, -0.3, 0
5597, 0.52, -0.3, 0
5598, 0.56, -0.3, 0
5599, 0.6, -0.3, 0
5600, 0.64, -0.3, 0
5601, 0.68, -0.3, 0
5602, 0.72, -0.3, 0
5603, 0.76, -0.3, 0
5604, 0.8, -0.3, 0
5605, 0.84, -0.3, 0
5606, 0.88, -0.3, 0
5607, 0.92, -0.3, 0
5608, 0.96, -0.3, 0
5609, 0.02, -0.2, 0
5610, 0.04, -0.175, 0
5611, 0.06, -0.2, 0
5612, 0.08, -0.175, 0
5613, 0.1, -0.2, 0
5614, 0.12, -0.175, 0
5615, 0.14, -0.2, 0
5616, 0.16, -0.175, 0
5617, 0.18, -0.2, 0
5618, 0.2, -0.175, 0
5619, 0.22, -0.2, 0
5620, 0.24, -0.175, 0
5621, 0.26, -0.2, 0
5622, 0.28, -0.175, 0
5623, 0.3, -0.2, 0
5624, 0.32, -0.175, 0
5625, 0.34, -0.2, 0
5626, 0.36, -0.175, 0
5627, 0.38, -0.2, 0
5628, 0.4, -0.175, 0
5629, 0.42, -0.2, 0
5630, 0.44, -0.175, 0
5631, 0.46, -0.2, 0
5632, 0.48, -0.175, 0
5633, 0.5, -0.2, 0
5634, 0.52, -0.175, 0
5635, 0.54, -0.2, 0
5636, 0.56, -0.175, 0
5637, 0.58, -0.2, 0
5638, 0.6, -0.175, 0
5639, 0.62, -0.2, 0
5640, 0.64, -0.175, 0
5641, 0.66, -0.2, 0
5642, 0.68, -0.175, 0
5643, 0.7, -0.2, 0
5644, 0.72, -0.175, 0
5645, 0.74, -0.2, 0
5646, 0.76, -0.175, 0
5647, 0.78, -0.2, 0
5648, 0.8, -0.175, 0
5649, 0.82, -0.2, 0
5650, 0.84, -0.175, 0
5651, 0.86, -0.2, 0
5652, 0.88, -0.175, 0
5653, 0.9, -0.2, 0
5654, 0.92, -0.175, 0
5655, 0.94, -0.2, 0
5656, 0.96, -0.175, 0
5657, 0.98, -0.2, 0
5658, 0.02, -0.25, 0
5659, 0.04, -0.225, 0
5660, 0.06, -0.25, 0
5661, 0.08, -0.225, 0
5662, 0.1, -0.25, 0
5663, 0.12, -0.225, 0
5664, 0.14, -0.25, 0
5665, 0.16, -0.225, 0
5666, 0.18, -0.25, 0
5667, 0.2, -0.225, 0
5668, 0.22, -0.25, 0
5669, 0.24, -0.225, 0
5670, 0.26, -0.25, 0
5671, 0.28, -0.225, 0
5672, 0.3, -0.25, 0
5673, 0.32, -0.225, 0
5674, 0.34, -0.25, 0
5675, 0.36, -0.225, 0
5676, 0.38, -0.25, 0
5677, 0.4, -0.225, 0
5678, 0.42, -0.25, 0
5679, 0.44, -0.225, 0
5680, 0.46, -0.25, 0
5681, 0.48, -0.225, 0
5682, 0.5, -0.25, 0
5683, 0.52, -0.225, 0
5684, 0.54, -0.25, 0
5685, 0.56, -0.225, 0
5686, 0.58, -0.25, 0
5687, 0.6, -0.225, 0
5688, 0.62, -0.25, 0
5689, 0.64, -0.225, 0
5690, 0.66, -0.25, 0
5691, 0.68, -0.225, 0
5692, 0.7, -0.25, 0
5693, 0.72, -0.225, 0
5694, 0.74, -0.25, 0
5695, 0.76, -0.225, 0
5696, 0.78, -0.25, 0
5697, 0.8, -0.225, 0
5698, 0.82, -0.25, 0
5699, 0.84, -0.225, 0
5700, 0.86, -0.25, 0
5701, 0.88, -0.225, 0
5702, 0.9, -0.25, 0
5703, 0.92, -0.225, 0
5704, 0.94, -0.25, 0
5705, 0.96, -0.225, 0
5706, 0.98, -0.25, 0
5707, 0.02, -0.3, 0
5708, 0.04, -0.275, 0
5709, 0.06, -0.3, 0
5710, 0.08, -0.275, 0
5711, 0.1, -0.3, 0
5712, 0.12, -0.275, 0
5713, 0.14, -0.3, 0
5714, 0.16, -0.275, 0
5715, 0.18, -0.3, 0
5716, 0.2, -0.275, 0
5717, 0.22, -0.3, 0
5718, 0.24, -0.275, 0
5719, 0.26, -0.3, 0
5720, 0.28, -0.275, 0
5721, 0.3, -0.3, 0
5722, 0.32, -0.275, 0
5723, 0.34, -0.3, 0
5724, 0.36, -0.275, 0
5725, 0.38, -0.3, 0
5726, 0.4, -0.275, 0
5727, 0.42, -0.3, 0
5728, 0.44, -0.275, 0
5729, 0.46, -0.3, 0
5730, 0.48, -0.275, 0
5731, 0.5, -0.3, 0
5732, 0.52, -0.275, 0
5733, 0.54, -0.3, 0
5734, 0.56, -0.275, 0
5735, 0.58, -0.3, 0
5736, 0.6, -0.275, 0
5737, 0.62, -0.3, 0
5738, 0.64, -0.275, 0
5739, 0.66, -0.3, 0
5740, 0.68, -0.275, 0
5741, 0.7, -0.3, 0
5742, 0.72, -0.275, 0
5743, 0.74, -0.3, 0
5744, 0.76, -0.275, 0
5745, 0.78, -0.3, 0
5746, 0.8, -0.275, 0
5747, 0.82, -0.3, 0
5748, 0.84, -0.275, 0
5749, 0.86, -0.3, 0
5750, 0.88, -0.275, 0
5751, 0.9, -0.3, 0
5752, 0.92, -0.275, 0
5753, 0.94, -0.3, 0
5754, 0.96, -0.275, 0
5755, 0.98, -0.3, 0
5756, 0.04, -0.325, 0
5757, 0.08, -0.325, 0
5758, 0.12, -0.325, 0
5759, 0.16, -0.325, 0
5760, 0.2, -0.325, 0
5761, 0.24, -0.325, 0
5762, 0.28, -0.325, 0
5763, 0.32, -0.325, 0
5764, 0.36, -0.325, 0
5765, 0.4, -0.325, 0
5766, 0.44, -0.325, 0
5767, 0.48, -0.325, 0
5768, 0.52, -0.325, 0
5769, 0.56, -0.325, 0
5770, 0.6, -0.325, 0
5771, 0.64, -0.325, 0
5772, 0.68, -0.325, 0
5773, 0.72, -0.325, 0
5774, 0.76, -0.325, 0
5775, 0.8, -0.325, 0
5776, 0.84, -0.325, 0
5777, 0.88, -0.325, 0
5778, 0.92, -0.325, 0
5779, 0.96, -0.325, 0
5780, 1.24, -0.2, 0
5781, 1.28, -0.2, 0
5782, 1.32, -0.2, 0
5783, 1.36, -0.2, 0
5784, 1.4, -0.2, 0
5785, 1.44, -0.2, 0
5786, 1.48, -0.2, 0
5787, 1.52, -0.2, 0
5788, 1.56, -0.2, 0
5789, 1.6, -0.2, 0
5790, 1.64, -0.2, 0
5791, 1.68, -0.2, 0
5792, 1.72, -0.2, 0
5793, 1.76, -0.2, 0
5794, 1.8, -0.2, 0
5795, 1.84, -0.2, 0
5796, 1.88, -0.2, 0
5797, 1.92, -0.2, 0
5798, 1.96, -0.2, 0
5799, 2, -0.2, 0
5800, 2.04, -0.2, 0
5801, 2.08, -0.2, 0
5802, 2.12, -0.2, 0
5803, 2.16, -0.2, 0
5804, 1.24, -0.25, 0
5805, 1.28, -0.25, 0
5806, 1.32, -0.25, 0
5807, 1.36, -0.25, 0
5808, 1.4, -0.25, 0
5809, 1.44, -0.25, 0
5810, 1.48, -0.25, 0
5811, 1.52, -0.25, 0
5812, 1.56, -0.25, 0
5813, 1.6, -0.25, 0
5814, 1.64, -0.25, 0
5815, 1.68, -0.25, 0
5816, 1.72, -0.25, 0
5817, 1.76, -0.25, 0
5818, 1.8, -0.25, 0
5819, 1.84, -0.25, 0
5820, 1.88, -0.25, 0
5821, 1.92, -0.25, 0
5822, 1.96, -0.25, 0
5823, 2, -0.25, 0
5824, 2.04, -0.25, 0
5825, 2.08, -0.25, 0
5826, 2.12, -0.25, 0
5827, 2.16, -0.25, 0
5828, 1.24, -0.3, 0
5829, 1.28, -0.3, 0
5830, 1.32, -0.3, 0
5831, 1.36, -0.3, 0
5832, 1.4, -0.3, 0
5833, 1.44, -0.3, 0
5834, 1.48, -0.3, 0
5835, 1.52, -0.3, 0
5836, 1.56, -0.3, 0
5837, 1.6, -0.3, 0
5838, 1.64, -0.3, 0
5839, 1.68, -0.3, 0
5840, 1.72, -0.3, 0
5841, 1.76, -0.3, 0
5842, 1.8, -0.3, 0
5843, 1.84, -0.3, 0
5844, 1.88, -0.3, 0
5845, 1.92, -0.3, 0
5846, 1.96, -0.3, 0
5847, 2, -0.3, 0
5848, 2.04, -0.3, 0
5849, 2.08, -0.3, 0
5850, 2.12, -0.3, 0
5851, 2.16, -0.3, 0
5852, 1.22, -0.2, 0
5853, 1.24, -0.175, 0
5854, 1.26, -0.2, 0
5855, 1.28, -0.175, 0
5856, 1.3, -0.2, 0
5857, 1.32, -0.175, 0
5858, 1.34, -0.2, 0
5859, 1.36, -0.175, 0
5860, 1.38, -0.2, 0
5861, 1.4, -0.175, 0
5862, 1.42, -0.2, 0
5863, 1.44, -0.175, 0
5864, 1.46, -0.2, 0
5865, 1.48, -0.175, 0
5866, 1.5, -0.2, 0
5867, 1.52, -0.175, 0
5868, 1.54, -0.2, 0
5869, 1.56, -0.175, 0
5870, 1.58, -0.2, 0
5871, 1.6, -0.175, 0
5872, 1.62, -0.2, 0
5873, 1.64, -0.175, 0
5874, 1.66, -0.2, 0
5875, 1.68, -0.175, 0
5876, 1.7, -0.2, 0
5877, 1.72, -0.175, 0
5878, 1.74, -0.2, 0
5879, 1.76, -0.175, 0
5880, 1.78, -0.2, 0
5881, 1.8, -0.175, 0
5882, 1.82, -0.2, 0
5883, 1.84, -0.175, 0
5884, 1.86, -0.2, 0
5885, 1.88, -0.175, 0
5886, 1.9, -0.2, 0
5887, 1.92, -0.175, 0
5888, 1.94, -0.2, 0
5889, 1.96, -0.175, 0
5890, 1.98, -0.2, 0
5891, 2, -0.175, 0
5892, 2.02, -0.2, 0
5893, 2.04, -0.175, 0
5894, 2.06, -0.2, 0
5895, 2.08, -0.175, 0
5896, 2.1, -0.2, 0
5897, 2.12, -0.175, 0
5898, 2.14, -0.2, 0
5899, 2.16, -0.175, 0
5900, 2.18, -0.2, 0
5901, 1.22, -0.25, 0
5902, 1.24, -0.225, 0
5903, 1.26, -0.25, 0
5904, 1.28, -0.225, 0
5905, 1.3, -0.25, 0
5906, 1.32, -0.225, 0
5907, 1.34, -0.25, 0
5908, 1.36, -0.225, 0
5909, 1.38, -0.25, 0
5910, 1.4, -0.225, 0
5911, 1.42, -0.25, 0
5912, 1.44, -0.225, 0
5913, 1.46, -0.25, 0
5914, 1.48, -0.225, 0
5915, 1.5, -0.25, 0
5916, 1.52, -0.225, 0
5917, 1.54, -0.25, 0
5918, 1.56, -0.225, 0
5919, 1.58, -0.25, 0
5920, 1.6, -0.225, 0
5921, 1.62, -0.25, 0
5922, 1.64, -0.225, 0
5923, 1.66, -0.25, 0
5924, 1.68, -0.225, 0
5925, 1.7, -0.25, 0
5926, 1.72, -0.225, 0
5927, 1.74, -0.25, 0
5928, 1.76, -0.225, 0
5929, 1.78, -0.25, 0
5930, 1.8, -0.225, 0
5931, 1.82, -0.25, 0
5932, 1.84, -0.225, 0
5933, 1.86, -0.25, 0
5934, 1.88, -0.225, 0
5935, 1.9, -0.25, 0
5936, 1.92, -0.225, 0
5937, 1.94, -0.25, 0
5938, 1.96, -0.225, 0
5939, 1.98, -0.25, 0
5940, 2, -0.225, 0
5941, 2.02, -0.25, 0
5942, 2.04, -0.225, 0
5943, 2.06, -0.25, 0
5944, 2.08, -0.225, 0
5945, 2.1, -0.25, 0
5946, 2.12, -0.225, 0
5947, 2.14, -0.25, 0
5948, 2.16, -0.225, 0
5949, 2.18, -0.25, 0
5950, 1.22, -0.3, 0
5951, 1.24, -0.275, 0
5952, 1.26, -0.3, 0
5953, 1.28, -0.275, 0
5954, 1.3, -0.3, 0
5955, 1.32, -0.275, 0
5956, 1.34, -0.3, 0
5957, 1.36, -0.275, 0
5958, 1.38, -0.3, 0
5959, 1.4, -0.275, 0
5960, 1.42, -0.3, 0
5961, 1.44, -0.275, 0
5962, 1.46, -0.3, 0
5963, 1.48, -0.275, 0
5964, 1.5, -0.3, 0
5965, 1.52, -0.275, 0
5966, 1.54, -0.3, 0
5967, 1.56, -0.275, 0
5968, 1.58, -0.3, 0
5969, 1.6, -0.275, 0
5970, 1.62, -0.3, 0
5971, 1.64, -0.275, 0
5972, 1.66, -0.3, 0
5973, 1.68, -0.275, 0
5974, 1.7, -0.3, 0
5975, 1.72, -0.275, 0
5976, 1.74, -0.3, 0
5977, 1.76, -0.275, 0
5978, 1.78, -0.3, 0
5979, 1.8, -0.275, 0
5980, 1.82, -0.3, 0
5981, 1.84, -0.275, 0
5982, 1.86, -0.3, 0
5983, 1.88, -0.275, 0
5984, 1.9, -0.3, 0
5985, 1.92, -0.275, 0
5986, 1.94, -0.3, 0
5987, 1.96, -0.275, 0
5988, 1.98, -0.3, 0
5989, 2, -0.275, 0
5990, 2.02, -0.3, 0
5991, 2.04, -0.275, 0
5992, 2.06, -0.3, 0
5993, 2.08, -0.275, 0
5994, 2.1, -0.3, 0
5995, 2.12, -0.275, 0
5996, 2.14, -0.3, 0
5997, 2.16, -0.275, 0
5998, 2.18, -0.3, 0
5999, 1.24, -0.325, 0
6000, 1.28, -0.325, 0
6001, 1.32, -0.325, 0
6002, 1.36, -0.325, 0
6003, 1.4, -0.325, 0
6004, 1.44, -0.325, 0
6005, 1.48, -0.325, 0
6006, 1.52, -0.325, 0
6007, 1.56, -0.325, 0
6008, 1.6, -0.325, 0
6009, 1.64, -0.325, 0
6010, 1.68, -0.325, 0
6011, 1.72, -0.325, 0
6012, 1.76, -0.325, 0
6013, 1.8, -0.325, 0
6014, 1.84, -0.325, 0
6015, 1.88, -0.325, 0
6016, 1.92, -0.325, 0
6017, 1.96, -0.325, 0
6018, 2, -0.325, 0
6019, 2.04, -0.325, 0
6020, 2.08, -0.325, 0
6021, 2.12, -0.325, 0
6022, 2.16, -0.325, 0
6023, 2.2333333333333, -0.2, 0
6024, 2.2666666666667, -0.2, 0
6025, 2.2333333333333, -0.25, 0
6026, 2.2666666666667, -0.25, 0
6027, 2.2333333333333, -0.3, 0
6028, 2.2666666666667, -0.3, 0
6029, 2.2166666666667, -0.2, 0
6030, 2.2333333333333, -0.175, 0
6031, 2.25, -0.2, 0
6032, 2.2666666666667, -0.175, 0
6033, 2.2833333333333, -0.2, 0
6034, 2.2166666666667, -0.25, 0
6035, 2.2333333333333, -0.225, 0
6036, 2.25, -0.25, 0
6037, 2.2666666666667, -0.225, 0
6038, 2.2833333333333, -0.25, 0
6039, 2.2166666666667, -0.3, 0
6040, 2.2333333333333, -0.275, 0
6041, 2.25, -0.3, 0
6042, 2.2666666666667, -0.275, 0
6043, 2.2833333333333, -0.3, 0
6044, 2.2333333333333, -0.325, 0
6045, 2.2666666666667, -0.325, 0
6046, 0.96, 1.4, 0
6047, 0.92, 1.4, 0
6048, 0.88, 1.4, 0
6049, 0.84, 1.4, 0
6050, 0.8, 1.4, 0
6051, 0.76, 1.4, 0
6052, 0.72, 1.4, 0
6053, 0.68, 1.4, 0
6054, 0.64, 1.4, 0
6055, 0.6, 1.4, 0
6056, 0.56, 1.4, 0
6057, 0.52, 1.4, 0
6058, 0.48, 1.4, 0
6059, 0.44, 1.4, 0
6060, 0.4, 1.4, 0
6061, 0.36, 1.4, 0
6062, 0.32, 1.4, 0
6063, 0.28, 1.4, 0
6064, 0.24, 1.4, 0
6065, 0.2, 1.4, 0
6066, 0.16, 1.4, 0
6067, 0.12, 1.4, 0
6068, 0.08, 1.4, 0
6069, 0.04, 1.4, 0
6070, 0.96, 1.45, 0
6071, 0.92, 1.45, 0
6072, 0.88, 1.45, 0
6073, 0.84, 1.45, 0
6074, 0.8, 1.45, 0
6075, 0.76, 1.45, 0
6076, 0.72, 1.45, 0
6077, 0.68, 1.45, 0
6078, 0.64, 1.45, 0
6079, 0.6, 1.45, 0
6080, 0.56, 1.45, 0
6081, 0.52, 1.45, 0
6082, 0.48, 1.45, 0
6083, 0.44, 1.45, 0
6084, 0.4, 1.45, 0
6085, 0.36, 1.45, 0
6086, 0.32, 1.45, 0
6087, 0.28, 1.45, 0
6088, 0.24, 1.45, 0
6089, 0.2, 1.45, 0
6090, 0.16, 1.45, 0
6091, 0.12, 1.45, 0
6092, 0.08, 1.45, 0
6093, 0.04, 1.45, 0
6094, 0.96, 1.5, 0
6095, 0.92, 1.5, 0
6096, 0.88, 1.5, 0
6097, 0.84, 1.5, 0
6098, 0.8, 1.5, 0
6099, 0.76, 1.5, 0
6100, 0.72, 1.5, 0
6101, 0.68, 1.5, 0
6102, 0.64, 1.5, 0
6103, 0.6, 1.5, 0
6104, 0.56, 1.5, 0
6105, 0.52, 1.5, 0
6106, 0.48, 1.5, 0
6107, 0.44, 1.5, 0
6108, 0.4, 1.5, 0
6109, 0.36, 1.5, 0
6110, 0.32, 1.5, 0
6111, 0.28, 1.5, 0
6112, 0.24, 1.5, 0
6113, 0.2, 1.5, 0
6114, 0.16, 1.5, 0
6115, 0.12, 1.5, 0
6116, 0.08, 1.5, 0
6117, 0.04, 1.5, 0
6118, 0.98, 1.4, 0
6119, 0.96, 1.375, 0
6120, 0.94, 1.4, 0
6121, 0.92, 1.375, 0
6122, 0.9, 1.4, 0
6123, 0.88, 1.375, 0
6124, 0.86, 1.4, 0
6125, 0.84, 1.375, 0
6126, 0.82, 1.4, 0
6127, 0.8, 1.375, 0
6128, 0.78, 1.4, 0
6129, 0.76, 1.375, 0
6130, 0.74, 1.4, 0
6131, 0.72, 1.375, 0
6132, 0.7, 1.4, 0
6133, 0.68, 1.375, 0
6134, 0.66, 1.4, 0
6135, 0.64, 1.375, 0
6136, 0.62, 1.4, 0
6137, 0.6, 1.375, 0
6138, 0.58, 1.4, 0
6139, 0.56, 1.375, 0
6140, 0.54, 1.4, 0
6141, 0.52, 1.375, 0
6142, 0.5, 1.4, 0
6143, 0.48, 1.375, 0
6144, 0.46, 1.4, 0
6145, 0.44, 1.375, 0
6146, 0.42, 1.4, 0
6147, 0.4, 1.375, 0
6148, 0.38, 1.4, 0
6149, 0.36, 1.375, 0
6150, 0.34, 1.4, 0
6151, 0.32, 1.375, 0
6152, 0.3, 1.4, 0
6153, 0.28, 1.375, 0
6154, 0.26, 1.4, 0
6155, 0.24, 1.375, 0
6156, 0.22, 1.4, 0
6157, 0.2, 1.375, 0
6158, 0.18, 1.4, 0
6159, 0.16, 1.375, 0
6160, 0.14, 1.4, 0
6161, 0.12, 1.375, 0
6162, 0.1, 1.4, 0
6163, 0.08, 1.375, 0
6164, 0.06, 1.4, 0
6165, 0.04, 1.375, 0
6166, 0.02, 1.4, 0
6167, 0.98, 1.45, 0
6168, 0.96, 1.425, 0
6169, 0.94, 1.45, 0
6170, 0.92, 1.425, 0
6171, 0.9, 1.45, 0
6172, 0.88, 1.425, 0
6173, 0.86, 1.45, 0
6174, 0.84, 1.425, 0
6175, 0.82, 1.45, 0
6176, 0.8, 1.425, 0
6177, 0.78, 1.45, 0
6178, 0.76, 1.425, 0
6179, 0.74, 1.45, 0
6180, 0.72, 1.425, 0
6181, 0.7, 1.45, 0
6182, 0.68, 1.425, 0
6183, 0.66, 1.45, 0
6184, 0.64, 1.425, 0
6185, 0.62, 1.45, 0
6186, 0.6, 1.425, 0
6187, 0.58, 1.45, 0
6188, 0.56, 1.425, 0
6189, 0.54, 1.45, 0
6190, 0.52, 1.425, 0
6191, 0.5, 1.45, 0
6192, 0.48, 1.425, 0
6193, 0.46, 1.45, 0
6194, 0.44, 1.425, 0
6195, 0.42, 1.45, 0
6196, 0.4, 1.425, 0
6197, 0.38, 1.45, 0
6198, 0.36, 1.425, 0
6199, 0.34, 1.45, 0
6200, 0.32, 1.425, 0
6201, 0.3, 1.45, 0
6202, 0.28, 1.425, 0
6203, 0.26, 1.45, 0
6204, 0.24, 1.425, 0
6205, 0.22, 1.45, 0
6206, 0.2, 1.425, 0
6207, 0.18, 1.45, 0
6208, 0.16, 1.425, 0
6209, 0.14, 1.45, 0
6210, 0.12, 1.425, 0
6211, 0.1, 1.45, 0
6212, 0.08, 1.425, 0
6213, 0.06, 1.45, 0
6214, 0.04, 1.425, 0
6215, 0.02, 1.45, 0
6216, 0.98, 1.5, 0
6217, 0.96, 1.475, 0
6218, 0.94, 1.5, 0
6219, 0.92, 1.475, 0
6220, 0.9, 1.5, 0
6221, 0.88, 1.475, 0
6222, 0.86, 1.5, 0
6223, 0.84, 1.475, 0
6224, 0.82, 1.5, 0
6225, 0.8, 1.475, 0
6226, 0.78, 1.5, 0
6227, 0.76, 1.475, 0
6228, 0.74, 1.5, 0
6229, 0.72, 1.475, 0
6230, 0.7, 1.5, 0
6231, 0.68, 1.475, 0
6232, 0.66, 1.5, 0
6233, 0.64, 1.475, 0
6234, 0.62, 1.5, 0
6235, 0.6, 1.475, 0
6236, 0.58, 1.5, 0
6237, 0.56, 1.475, 0
6238, 0.54, 1.5, 0
6239, 0.52, 1.475, 0
6240, 0.5, 1.5, 0
6241, 0.48, 1.475, 0
6242, 0.46, 1.5, 0
6243, 0.44, 1.475, 0
6244, 0.42, 1.5, 0
6245, 0.4, 1.475, 0
6246, 0.38, 1.5, 0
6247, 0.36, 1.475, 0
6248, 0.34, 1.5, 0
6249, 0.32, 1.475, 0
6250, 0.3, 1.5, 0
6251, 0.28, 1.475, 0
6252, 0.26, 1.5, 0
6253, 0.24, 1.475, 0
6254, 0.22, 1.5, 0
6255, 0.2, 1.475, 0
6256, 0.18, 1.5, 0
6257, 0.16, 1.475, 0
6258, 0.14, 1.5, 0
6259, 0.12, 1.475, 0
6260, 0.1, 1.5, 0
6261, 0.08, 1.475, 0
6262, 0.06, 1.5, 0
6263, 0.04, 1.475, 0
6264, 0.02, 1.5, 0
6265, 0.96, 1.525, 0
6266, 0.92, 1.525, 0
6267, 0.88, 1.525, 0
6268, 0.84, 1.525, 0
6269, 0.8, 1.525, 0
6270, 0.76, 1.525, 0
6271, 0.72, 1.525, 0
6272, 0.68, 1.525, 0
6273, 0.64, 1.525, 0
6274, 0.6, 1.525, 0
6275, 0.56, 1.525, 0
6276, 0.52, 1.525, 0
6277, 0.48, 1.525, 0
6278, 0.44, 1.525, 0
6279, 0.4, 1.525, 0
6280, 0.36, 1.525, 0
6281, 0.32, 1.525, 0
6282, 0.28, 1.525, 0
6283, 0.24, 1.525, 0
6284, 0.2, 1.525, 0
6285, 0.16, 1.525, 0
6286, 0.12, 1.525, 0
6287, 0.08, 1.525, 0
6288, 0.04, 1.525, 0
6289, 1.05, 1.4, 0
6290, 1.05, 1.45, 0
6291, 1.05, 1.5, 0
6292, 1.1, 1.4, 0
6293, 1.1, 1.45, 0
6294, 1.1, 1.5, 0
6295, 1.15, 1.4, 0
6296, 1.15, 1.45, 0
6297, 1.15, 1.5, 0
6298, 1.05, 1.375, 0
6299, 1.025, 1.4, 0
6300, 1.05, 1.425, 0
6301, 1.025, 1.45, 0
6302, 1.05, 1.475, 0
6303, 1.025, 1.5, 0
6304, 1.05, 1.525, 0
6305, 1.1, 1.375, 0
6306, 1.075, 1.4, 0
6307, 1.1, 1.425, 0
6308, 1.075, 1.45, 0
6309, 1.1, 1.475, 0
6310, 1.075, 1.5, 0
6311, 1.1, 1.525, 0
6312, 1.15, 1.375, 0
6313, 1.125, 1.4, 0
6314, 1.15, 1.425, 0
6315, 1.125, 1.45, 0
6316, 1.15, 1.475, 0
6317, 1.125, 1.5, 0
6318, 1.15, 1.525, 0
6319, 1.175, 1.4, 0
6320, 1.175, 1.45, 0
6321, 1.175, 1.5, 0
6322, 2.2333333333333, -0.083333333333333, 0
6323, 2.2666666666667, -0.083333333333333, 0
6324, 2.2333333333333, -0.11666666666667, 0
6325, 2.2666666666667, -0.11666666666667, 0
6326, 2.2166666666667, -0.083333333333333, 0
6327, 2.2333333333333, -0.066666666666667, 0
6328, 2.25, -0.083333333333333, 0
6329, 2.2666666666667, -0.066666666666667, 0
6330, 2.2833333333333, -0.083333333333333, 0
6331, 2.2166666666667, -0.11666666666667, 0
6332, 2.2333333333333, -0.1, 0
6333, 2.25, -0.11666666666667, 0
6334, 2.2666666666667, -0.1, 0
6335, 2.2833333333333, -0.11666666666667, 0
6336, 2.2333333333333, -0.13333333333333, 0
6337, 2.2666666666667, -0.13333333333333, 0
6338, -0.033333333333333, -0.2, 0
6339, -0.066666666666667, -0.2, 0
6340, -0.033333333333333, -0.25, 0
6341, -0.066666666666667, -0.25, 0
6342, -0.033333333333333, -0.3, 0
6343, -0.066666666666667, -0.3, 0
6344, -0.033333333333333, -0.175, 0
6345, -0.016666666666667, -0.2, 0
6346, -0.066666666666667, -0.175, 0
6347, -0.05, -0.2, 0
6348, -0.083333333333333, -0.2, 0
6349, -0.033333333333333, -0.225, 0
6350, -0.016666666666667, -0.25, 0
6351, -0.066666666666667, -0.225, 0
6352, -0.05, -0.25, 0
6353, -0.083333333333333, -0.25, 0
6354, -0.033333333333333, -0.275, 0
6355, -0.016666666666667, -0.3, 0
6356, -0.066666666666667, -0.275, 0
6357, -0.05, -0.3, 0
6358, -0.083333333333333, -0.3, 0
6359, -0.033333333333333, -0.325, 0
6360, -0.066666666666667, -0.325, 0
6361, 1.24, 1.4, 0
6362, 1.28, 1.4, 0
6363, 1.32, 1.4, 0
6364, 1.36, 1.4, 0
6365, 1.4, 1.4, 0
6366, 1.44, 1.4, 0
6367, 1.48, 1.4, 0
6368, 1.52, 1.4, 0
6369, 1.56, 1.4, 0
6370, 1.6, 1.4, 0
6371, 1.64, 1.4, 0
6372, 1.68, 1.4, 0
6373, 1.72, 1.4, 0
6374, 1.76, 1.4, 0
6375, 1.8, 1.4, 0
6376, 1.84, 1.4, 0
6377, 1.88, 1.4, 0
6378, 1.92, 1.4, 0
6379, 1.96, 1.4, 0
6380, 2, 1.4, 0
6381, 2.04, 1.4, 0
6382, 2.08, 1.4, 0
6383, 2.12, 1.4, 0
6384, 2.16, 1.4, 0
6385, 1.24, 1.45, 0
6386, 1.28, 1.45, 0
6387, 1.32, 1.45, 0
6388, 1.36, 1.45, 0
6389, 1.4, 1.45, 0
6390, 1.44, 1.45, 0
6391, 1.48, 1.45, 0
6392, 1.52, 1.45, 0
6393, 1.56, 1.45, 0
6394, 1.6, 1.45, 0
6395, 1.64, 1.45, 0
6396, 1.68, 1.45, 0
6397, 1.72, 1.45, 0
6398, 1.76, 1.45, 0
6399, 1.8, 1.45, 0
6400, 1.84, 1.45, 0
6401, 1.88, 1.45, 0
6402, 1.92, 1.45, 0
6403, 1.96, 1.45, 0
6404, 2, 1.45, 0
6405, 2.04, 1.45, 0
6406, 2.08, 1.45, 0
6407, 2.12, 1.45, 0
6408, 2.16, 1.45, 0
6409, 1.24, 1.5, 0
6410, 1.28, 1.5, 0
6411, 1.32, 1.5, 0
6412, 1.36, 1.5, 0
6413, 1.4, 1.5, 0
6414, 1.44, 1.5, 0
6415, 1.48, 1.5, 0
6416, 1.52, 1.5, 0
6417, 1.56, 1.5, 0
6418, 1.6, 1.5, 0
6419, 1.64, 1.5, 0
6420, 1.68, 1.5, 0
6421, 1.72, 1.5, 0
6422, 1.76, 1.5, 0
6423, 1.8, 1.5, 0
6424, 1.84, 1.5, 0
6425, 1.88, 1.5, 0
6426, 1.92, 1.5, 0
6427, 1.96, 1.5, 0
6428, 2, 1.5, 0
6429, 2.04, 1.5, 0
6430, 2.08, 1.5, 0
6431, 2.12, 1.5, 0
6432, 2.16, 1.5, 0
6433, 1.24, 1.375, 0
6434, 1.22, 1.4, 0
6435, 1.28, 1.375, 0
6436, 1.26, 1.4, 0
6437, 1.32, 1.375, 0
6438, 1.3, 1.4, 0
6439, 1.36, 1.375, 0
6440, 1.34, 1.4, 0
6441, 1.4, 1.375, 0
6442, 1.38, 1.4, 0
6443, 1.44, 1.375, 0
6444, 1.42, 1.4, 0
6445, 1.48, 1.375, 0
6446, 1.46, 1.4, 0
6447, 1.52, 1.375, 0
6448, 1.5, 1.4, 0
6449, 1.56, 1.375, 0
6450, 1.54, 1.4, 0
6451, 1.6, 1.375, 0
6452, 1.58, 1.4, 0
6453, 1.64, 1.375, 0
6454, 1.62, 1.4, 0
6455, 1.68, 1.375, 0
6456, 1.66, 1.4, 0
6457, 1.72, 1.375, 0
6458, 1.7, 1.4, 0
6459, 1.76, 1.375, 0
6460, 1.74, 1.4, 0
6461, 1.8, 1.375, 0
6462, 1.78, 1.4, 0
6463, 1.84, 1.375, 0
6464, 1.82, 1.4, 0
6465, 1.88, 1.375, 0
6466, 1.86, 1.4, 0
6467, 1.92, 1.375, 0
6468, 1.9, 1.4, 0
6469, 1.96, 1.375, 0
6470, 1.94, 1.4, 0
6471, 2, 1.375, 0
6472, 1.98, 1.4, 0
6473, 2.04, 1.375, 0
6474, 2.02, 1.4, 0
6475, 2.08, 1.375, 0
6476, 2.06, 1.4, 0
6477, 2.12, 1.375, 0
6478, 2.1, 1.4, 0
6479, 2.16, 1.375, 0
6480, 2.14, 1.4, 0
6481, 2.18, 1.4, 0
6482, 1.24, 1.425, 0
6483, 1.22, 1.45, 0
6484, 1.28, 1.425, 0
6485, 1.26, 1.45, 0
6486, 1.32, 1.425, 0
6487, 1.3, 1.45, 0
6488, 1.36, 1.425, 0
6489, 1.34, 1.45, 0
6490, 1.4, 1.425, 0
6491, 1.38, 1.45, 0
6492, 1.44, 1.425, 0
6493, 1.42, 1.45, 0
6494, 1.48, 1.425, 0
6495, 1.46, 1.45, 0
6496, 1.52, 1.425, 0
6497, 1.5, 1.45, 0
6498, 1.56, 1.425, 0
6499, 1.54, 1.45, 0
6500, 1.6, 1.425, 0
6501, 1.58, 1.45, 0
6502, 1.64, 1.425, 0
6503, 1.62, 1.45, 0
6504, 1.68, 1.425, 0
6505, 1.66, 1.45, 0
6506, 1.72, 1.425, 0
6507, 1.7, 1.45, 0
6508, 1.76, 1.425, 0
6509, 1.74, 1.45, 0
6510, 1.8, 1.425, 0
6511, 1.78, 1.45, 0
6512, 1.84, 1.425, 0
6513, 1.82, 1.45, 0
6514, 1.88, 1.425, 0
6515, 1.86, 1.45, 0
6516, 1.92, 1.425, 0
6517, 1.9, 1.45, 0
6518, 1.96, 1.425, 0
6519, 1.94, 1.45, 0
6520, 2, 1.425, 0
6521, 1.98, 1.45, 0
6522, 2.04, 1.425, 0
6523, 2.02, 1.45, 0
6524, 2.08, 1.425, 0
6525, 2.06, 1.45, 0
6526, 2.12, 1.425, 0
6527, 2.1, 1.45, 0
6528, 2.16, 1.425, 0
6529, 2.14, 1.45, 0
6530, 2.18, 1.45, 0
6531, 1.24, 1.475, 0
6532, 1.22, 1.5, 0
6533, 1.28, 1.475, 0
6534, 1.26, 1.5, 0
6535, 1.32, 1.475, 0
6536, 1.3, 1.5, 0
6537, 1.36, 1.475, 0
6538, 1.34, 1.5, 0
6539, 1.4, 1.475, 0
6540, 1.38, 1.5, 0
6541, 1.44, 1.475, 0
6542, 1.42, 1.5, 0
6543, 1.48, 1.475, 0
6544, 1.46, 1.5, 0
6545, 1.52, 1.475, 0
6546, 1.5, 1.5, 0
6547, 1.56, 1.475, 0
6548, 1.54, 1.5, 0
6549, 1.6, 1.475, 0
6550, 1.58, 1.5, 0
6551, 1.64, 1.475, 0
6552, 1.62, 1.5, 0
6553, 1.68, 1.475, 0
6554, 1.66, 1.5, 0
6555, 1.72, 1.475, 0
6556, 1.7, 1.5, 0
6557, 1.76, 1.475, 0
6558, 1.74, 1.5, 0
6559, 1.8, 1.475, 0
6560, 1.78, 1.5, 0
6561, 1.84, 1.475, 0
6562, 1.82, 1.5, 0
6563, 1.88, 1.475, 0
6564, 1.86, 1.5, 0
6565, 1.92, 1.475, 0
6566, 1.9, 1.5, 0
6567, 1.96, 1.475, 0
6568, 1.94, 1.5, 0
6569, 2, 1.475, 0
6570, 1.98, 1.5, 0
6571, 2.04, 1.475, 0
6572, 2.02, 1.5, 0
6573, 2.08, 1.475, 0
6574, 2.06, 1.5, 0
6575, 2.12, 1.475, 0
6576, 2.1, 1.5, 0
6577, 2.16, 1.475, 0
6578, 2.14, 1.5, 0
6579, 2.18, 1.5, 0
6580, 1.24, 1.525, 0
6581, 1.28, 1.525, 0
6582, 1.32, 1.525, 0
6583, 1.36, 1.525, 0
6584, 1.4, 1.525, 0
6585, 1.44, 1.525, 0
6586, 1.48, 1.525, 0
6587, 1.52, 1.525, 0
6588, 1.56, 1.525, 0
6589, 1.6, 1.525, 0
6590, 1.64, 1.525, 0
6591, 1.68, 1.525, 0
6592, 1.72, 1.525, 0
6593, 1.76, 1.525, 0
6594, 1.8, 1.525, 0
6595, 1.84, 1.525, 0
6596, 1.88, 1.525, 0
6597, 1.92, 1.525, 0
6598, 1.96, 1.525, 0
6599, 2, 1.525, 0
6600, 2.04, 1.525, 0
6601, 2.08, 1.525, 0
6602, 2.12, 1.525, 0
6603, 2.16, 1.525, 0
6604, 1.24, 1.225, 0
6605, 1.28, 1.225, 0
6606, 1.32, 1.225, 0
6607, 1.36, 1.225, 0
6608, 1.4, 1.225, 0
6609, 1.44, 1.225, 0
6610, 1.48, 1.225, 0
6611, 1.52, 1.225, 0
6612, 1.56, 1.225, 0
6613, 1.6, 1.225, 0
6614, 1.64, 1.225, 0
6615, 1.68, 1.225, 0
6616, 1.72, 1.225, 0
6617, 1.76, 1.225, 0
6618, 1.8, 1.225, 0
6619, 1.84, 1.225, 0
6620, 1.88, 1.225, 0
6621, 1.92, 1.225, 0
6622, 1.96, 1.225, 0
6623, 2, 1.225, 0
6624, 2.04, 1.225, 0
6625, 2.08, 1.225, 0
6626, 2.12, 1.225, 0
6627, 2.16, 1.225, 0
6628, 1.22, 1.225, 0
6629, 1.24, 1.2375, 0
6630, 1.26, 1.225, 0
6631, 1.28, 1.2375, 0
6632, 1.3, 1.225, 0
6633, 1.32, 1.2375, 0
6634, 1.34, 1.225, 0
6635, 1.36, 1.2375, 0
6636, 1.38, 1.225, 0
6637, 1.4, 1.2375, 0
6638, 1.42, 1.225, 0
6639, 1.44, 1.2375, 0
6640, 1.46, 1.225, 0
6641, 1.48, 1.2375, 0
6642, 1.5, 1.225, 0
6643, 1.52, 1.2375, 0
6644, 1.54, 1.225, 0
6645, 1.56, 1.2375, 0
6646, 1.58, 1.225, 0
6647, 1.6, 1.2375, 0
6648, 1.62, 1.225, 0
6649, 1.64, 1.2375, 0
6650, 1.66, 1.225, 0
6651, 1.68, 1.2375, 0
6652, 1.7, 1.225, 0
6653, 1.72, 1.2375, 0
6654, 1.74, 1.225, 0
6655, 1.76, 1.2375, 0
6656, 1.78, 1.225, 0
6657, 1.8, 1.2375, 0
6658, 1.82, 1.225, 0
6659, 1.84, 1.2375, 0
6660, 1.86, 1.225, 0
6661, 1.88, 1.2375, 0
6662, 1.9, 1.225, 0
6663, 1.92, 1.2375, 0
6664, 1.94, 1.225, 0
6665, 1.96, 1.2375, 0
6666, 1.98, 1.225, 0
6667, 2, 1.2375, 0
6668, 2.02, 1.225, 0
6669, 2.04, 1.2375, 0
6670, 2.06, 1.225, 0
6671, 2.08, 1.2375, 0
6672, 2.1, 1.225, 0
6673, 2.12, 1.2375, 0
6674, 2.14, 1.225, 0
6675, 2.16, 1.2375, 0
6676, 2.18, 1.225, 0
6677, 1.24, 1.2125, 0
6678, 1.28, 1.2125, 0
6679, 1.32, 1.2125, 0
6680, 1.36, 1.2125, 0
6681, 1.4, 1.2125, 0
6682, 1.44, 1.2125, 0
6683, 1.48, 1.2125, 0
6684, 1.52, 1.2125, 0
6685, 1.56, 1.2125, 0
6686, 1.6, 1.2125, 0
6687, 1.64, 1.2125, 0
6688, 1.68, 1.2125, 0
6689, 1.72, 1.2125, 0
6690, 1.76, 1.2125, 0
6691, 1.8, 1.2125, 0
6692, 1.84, 1.2125, 0
6693, 1.88, 1.2125, 0
6694, 1.92, 1.2125, 0
6695, 1.96, 1.2125, 0
6696, 2, 1.2125, 0
6697, 2.04, 1.2125, 0
6698, 2.08, 1.2125, 0
6699, 2.12, 1.2125, 0
6700, 2.16, 1.2125, 0
6701, 0.04, -0.025, 0
6702, 0.08, -0.025, 0
6703, 0.12, -0.025, 0
6704, 0.16, -0.025, 0
6705, 0.2, -0.025, 0
6706, 0.24, -0.025, 0
6707, 0.28, -0.025, 0
6708, 0.32, -0.025, 0
6709, 0.36, -0.025, 0
6710, 0.4, -0.025, 0
6711, 0.44, -0.025, 0
6712, 0.48, -0.025, 0
6713, 0.52, -0.025, 0
6714, 0.56, -0.025, 0
6715, 0.6, -0.025, 0
6716, 0.64, -0.025, 0
6717, 0.68, -0.025, 0
6718, 0.72, -0.025, 0
6719, 0.76, -0.025, 0
6720, 0.8, -0.025, 0
6721, 0.84, -0.025, 0
6722, 0.88, -0.025, 0
6723, 0.92, -0.025, 0
6724, 0.96, -0.025, 0
6725, 0.02, -0.025, 0
6726, 0.04, -0.0125, 0
6727, 0.06, -0.025, 0
6728, 0.08, -0.0125, 0
6729, 0.1, -0.025, 0
6730, 0.12, -0.0125, 0
6731, 0.14, -0.025, 0
6732, 0.16, -0.0125, 0
6733, 0.18, -0.025, 0
6734, 0.2, -0.0125, 0
6735, 0.22, -0.025, 0
6736, 0.24, -0.0125, 0
6737, 0.26, -0.025, 0
6738, 0.28, -0.0125, 0
6739, 0.3, -0.025, 0
6740, 0.32, -0.0125, 0
6741, 0.34, -0.025, 0
6742, 0.36, -0.0125, 0
6743, 0.38, -0.025, 0
6744, 0.4, -0.0125, 0
6745, 0.42, -0.025, 0
6746, 0.44, -0.0125, 0
6747, 0.46, -0.025, 0
6748, 0.48, -0.0125, 0
6749, 0.5, -0.025, 0
6750, 0.52, -0.0125, 0
6751, 0.54, -0.025, 0
6752, 0.56, -0.0125, 0
6753, 0.58, -0.025, 0
6754, 0.6, -0.0125, 0
6755, 0.62, -0.025, 0
6756, 0.64, -0.0125, 0
6757, 0.66, -0.025, 0
6758, 0.68, -0.0125, 0
6759, 0.7, -0.025, 0
6760, 0.72, -0.0125, 0
6761, 0.74, -0.025, 0
6762, 0.76, -0.0125, 0
6763, 0.78, -0.025, 0
6764, 0.8, -0.0125, 0
6765, 0.82, -0.025, 0
6766, 0.84, -0.0125, 0
6767, 0.86, -0.025, 0
6768, 0.88, -0.0125, 0
6769, 0.9, -0.025, 0
6770, 0.92, -0.0125, 0
6771, 0.94, -0.025, 0
6772, 0.96, -0.0125, 0
6773, 0.98, -0.025, 0
6774, 0.04, -0.0375, 0
6775, 0.08, -0.0375, 0
6776, 0.12, -0.0375, 0
6777, 0.16, -0.0375, 0
6778, 0.2, -0.0375, 0
6779, 0.24, -0.0375, 0
6780, 0.28, -0.0375, 0
6781, 0.32, -0.0375, 0
6782, 0.36, -0.0375, 0
6783, 0.4, -0.0375, 0
6784, 0.44, -0.0375, 0
6785, 0.48, -0.0375, 0
6786, 0.52, -0.0375, 0
6787, 0.56, -0.0375, 0
6788, 0.6, -0.0375, 0
6789, 0.64, -0.0375, 0
6790, 0.68, -0.0375, 0
6791, 0.72, -0.0375, 0
6792, 0.76, -0.0375, 0
6793, 0.8, -0.0375, 0
6794, 0.84, -0.0375, 0
6795, 0.88, -0.0375, 0
6796, 0.92, -0.0375, 0
6797, 0.96, -0.0375, 0
6798, 1.24, -0.025, 0
6799, 1.28, -0.025, 0
6800, 1.32, -0.025, 0
6801, 1.36, -0.025, 0
6802, 1.4, -0.025, 0
6803, 1.44, -0.025, 0
6804, 1.48, -0.025, 0
6805, 1.52, -0.025, 0
6806, 1.56, -0.025, 0
6807, 1.6, -0.025, 0
6808, 1.64, -0.025, 0
6809, 1.68, -0.025, 0
6810, 1.72, -0.025, 0
6811, 1.76, -0.025, 0
6812, 1.8, -0.025, 0
6813, 1.84, -0.025, 0
6814, 1.88, -0.025, 0
6815, 1.92, -0.025, 0
6816, 1.96, -0.025, 0
6817, 2, -0.025, 0
6818, 2.04, -0.025, 0
6819, 2.08, -0.025, 0
6820, 2.12, -0.025, 0
6821, 2.16, -0.025, 0
6822, 1.22, -0.025, 0
6823, 1.24, -0.0125, 0
6824, 1.26, -0.025, 0
6825, 1.28, -0.0125, 0
6826, 1.3, -0.025, 0
6827, 1.32, -0.0125, 0
6828, 1.34, -0.025, 0
6829, 1.36, -0.0125, 0
6830, 1.38, -0.025, 0
6831, 1.4, -0.0125, 0
6832, 1.42, -0.025, 0
6833, 1.44, -0.0125, 0
6834, 1.46, -0.025, 0
6835, 1.48, -0.0125, 0
6836, 1.5, -0.025, 0
6837, 1.52, -0.0125, 0
6838, 1.54, -0.025, 0
6839, 1.56, -0.0125, 0
6840, 1.58, -0.025, 0
6841, 1.6, -0.0125, 0
6842, 1.62, -0.025, 0
6843, 1.64, -0.0125, 0
6844, 1.66, -0.025, 0
6845, 1.68, -0.0125, 0
6846, 1.7, -0.025, 0
6847, 1.72, -0.0125, 0
6848, 1.74, -0.025, 0
6849, 1.76, -0.0125, 0
6850, 1.78, -0.025, 0
6851, 1.8, -0.0125, 0
6852, 1.82, -0.025, 0
6853, 1.84, -0.0125, 0
6854, 1.86, -0.025, 0
6855, 1.88, -0.0125, 0
6856, 1.9, -0.025, 0
6857, 1.92, -0.0125, 0
6858, 1.94, -0.025, 0
6859, 1.96, -0.0125, 0
6860, 1.98, -0.025, 0
6861, 2, -0.0125, 0
6862, 2.02, -0.025, 0
6863, 2.04, -0.0125, 0
6864, 2.06, -0.025, 0
6865, 2.08, -0.0125, 0
6866, 2.1, -0.025, 0
6867, 2.12, -0.0125, 0
6868, 2.14, -0.025, 0
6869, 2.16, -0.0125, 0
6870, 2.18, -0.025, 0
6871, 1.24, -0.0375, 0
6872, 1.28, -0.0375, 0
6873, 1.32, -0.0375, 0
6874, 1.36, -0.0375, 0
6875, 1.4, -0.0375, 0
6876, 1.44, -0.0375, 0
6877, 1.48, -0.0375, 0
6878, 1.52, -0.0375, 0
6879, 1.56, -0.0375, 0
6880, 1.6, -0.0375, 0
6881, 1.64, -0.0375, 0
6882, 1.68, -0.0375, 0
6883, 1.72, -0.0375, 0
6884, 1.76, -0.0375, 0
6885, 1.8, -0.0375, 0
6886, 1.84, -0.0375, 0
6887, 1.88, -0.0375, 0
6888, 1.92, -0.0375, 0
6889, 1.96, -0.0375, 0
6890, 2, -0.0375, 0
6891, 2.04, -0.0375, 0
6892, 2.08, -0.0375, 0
6893, 2.12, -0.0375, 0
6894, 2.16, -0.0375, 0
6895, 0.96, 1.225, 0
6896, 0.92, 1.225, 0
6897, 0.88, 1.225, 0
6898, 0.84, 1.225, 0
6899, 0.8, 1.225, 0
6900, 0.76, 1.225, 0
6901, 0.72, 1.225, 0
6902, 0.68, 1.225, 0
6903, 0.64, 1.225, 0
6904, 0.6, 1.225, 0
6905, 0.56, 1.225, 0
6906, 0.52, 1.225, 0
6907, 0.48, 1.225, 0
6908, 0.44, 1.225, 0
6909, 0.4, 1.225, 0
6910, 0.36, 1.225, 0
6911, 0.32, 1.225, 0
6912, 0.28, 1.225, 0
6913, 0.24, 1.225, 0
6914, 0.2, 1.225, 0
6915, 0.16, 1.225, 0
6916, 0.12, 1.225, 0
6917, 0.08, 1.225, 0
6918, 0.04, 1.225, 0
6919, 0.98, 1.225, 0
6920, 0.96, 1.2125, 0
6921, 0.94, 1.225, 0
6922, 0.92, 1.2125, 0
6923, 0.9, 1.225, 0
6924, 0.88, 1.2125, 0
6925, 0.86, 1.225, 0
6926, 0.84, 1.2125, 0
6927, 0.82, 1.225, 0
6928, 0.8, 1.2125, 0
6929, 0.78, 1.225, 0
6930, 0.76, 1.2125, 0
6931, 0.74, 1.225, 0
6932, 0.72, 1.2125, 0
6933, 0.7, 1.225, 0
6934, 0.68, 1.2125, 0
6935, 0.66, 1.225, 0
6936, 0.64, 1.2125, 0
6937, 0.62, 1.225, 0
6938, 0.6, 1.2125, 0
6939, 0.58, 1.225, 0
6940, 0.56, 1.2125, 0
6941, 0.54, 1.225, 0
6942, 0.52, 1.2125, 0
6943, 0.5, 1.225, 0
6944, 0.48, 1.2125, 0
6945, 0.46, 1.225, 0
6946, 0.44, 1.2125, 0
6947, 0.42, 1.225, 0
6948, 0.4, 1.2125, 0
6949, 0.38, 1.225, 0
6950, 0.36, 1.2125, 0
6951, 0.34, 1.225, 0
6952, 0.32, 1.2125, 0
6953, 0.3, 1.225, 0
6954, 0.28, 1.2125, 0
6955, 0.26, 1.225, 0
6956, 0.24, 1.2125, 0
6957, 0.22, 1.225, 0
6958, 0.2, 1.2125, 0
6959, 0.18, 1.225, 0
6960, 0.16, 1.2125, 0
6961, 0.14, 1.225, 0
6962, 0.12, 1.2125, 0
6963, 0.1, 1.225, 0
6964, 0.08, 1.2125, 0
6965, 0.06, 1.225, 0
6966, 0.04, 1.2125, 0
6967, 0.02, 1.225, 0
6968, 0.96, 1.2375, 0
6969, 0.92, 1.2375, 0
6970, 0.88, 1.2375, 0
6971, 0.84, 1.2375, 0
6972, 0.8, 1.2375, 0
6973, 0.76, 1.2375, 0
6974, 0.72, 1.2375, 0
6975, 0.68, 1.2375, 0
6976, 0.64, 1.2375, 0
6977, 0.6, 1.2375, 0
6978, 0.56, 1.2375, 0
6979, 0.52, 1.2375, 0
6980, 0.48, 1.2375, 0
6981, 0.44, 1.2375, 0
6982, 0.4, 1.2375, 0
6983, 0.36, 1.2375, 0
6984, 0.32, 1.2375, 0
6985, 0.28, 1.2375, 0
6986, 0.24, 1.2375, 0
6987, 0.2, 1.2375, 0
6988, 0.16, 1.2375, 0
6989, 0.12, 1.2375, 0
6990, 0.08, 1.2375, 0
6991, 0.04, 1.2375, 0
6992, 1.15, -0.2, 0
6993, 1.15, -0.25, 0
6994, 1.15, -0.3, 0
6995, 1.1, -0.2, 0
6996, 1.1, -0.25, 0
6997, 1.1, -0.3, 0
6998, 1.05, -0.2, 0
6999, 1.05, -0.25, 0
7000, 1.05, -0.3, 0
7001, 1.15, -0.175, 0
7002, 1.175, -0.2, 0
7003, 1.15, -0.225, 0
7004, 1.175, -0.25, 0
7005, 1.15, -0.275, 0
7006, 1.175, -0.3, 0
7007, 1.15, -0.325, 0
7008, 1.1, -0.175, 0
7009, 1.125, -0.2, 0
7010, 1.1, -0.225, 0
7011, 1.125, -0.25, 0
7012, 1.1, -0.275, 0
7013, 1.125, -0.3, 0
7014, 1.1, -0.325, 0
7015, 1.05, -0.175, 0
7016, 1.075, -0.2, 0
7017, 1.05, -0.225, 0
7018, 1.075, -0.25, 0
7019, 1.05, -0.275, 0
7020, 1.075, -0.3, 0
7021, 1.05, -0.325, 0
7022, 1.025, -0.2, 0
7023, 1.025, -0.25, 0
7024, 1.025, -0.3, 0
7025, 2.2666666666667, 1.5, 0
7026, 2.2666666666667, 1.45, 0
7027, 2.2666666666667, 1.4, 0
7028, 2.2333333333333, 1.5, 0
7029, 2.2333333333333, 1.45, 0
7030, 2.2333333333333, 1.4, 0
7031, 2.2666666666667, 1.525, 0
7032, 2.2833333333333, 1.5, 0
7033, 2.2666666666667, 1.475, 0
7034, 2.2833333333333, 1.45, 0
7035, 2.2666666666667, 1.425, 0
7036, 2.2833333333333, 1.4, 0
7037, 2.2666666666667, 1.375, 0
7038, 2.2333333333333, 1.525, 0
7039, 2.25, 1.5, 0
7040, 2.2333333333333, 1.475, 0
7041, 2.25, 1.45, 0
7042, 2.2333333333333, 1.425, 0
7043, 2.25, 1.4, 0
7044, 2.2333333333333, 1.375, 0
7045, 2.2166666666667, 1.5, 0
7046, 2.2166666666667, 1.45, 0
7047, 2.2166666666667, 1.4, 0
7048, -0.066666666666667, 1.4, 0
7049, -0.066666666666667, 1.45, 0
7050, -0.066666666666667, 1.5, 0
7051, -0.033333333333333, 1.4, 0
7052, -0.033333333333333, 1.45, 0
7053, -0.033333333333333, 1.5, 0
7054, -0.066666666666667, 1.375, 0
7055, -0.083333333333333, 1.4, 0
7056, -0.066666666666667, 1.425, 0
7057, -0.083333333333333, 1.45, 0
7058, -0.066666666666667, 1.475, 0
7059, -0.083333333333333, 1.5, 0
7060, -0.066666666666667, 1.525, 0
7061, -0.033333333333333, 1.375, 0
7062, -0.05, 1.4, 0
7063, -0.033333333333333, 1.425, 0
7064, -0.05, 1.45, 0
7065, -0.033333333333333, 1.475, 0
7066, -0.05, 1.5, 0
7067, -0.033333333333333, 1.525, 0
7068, -0.016666666666667, 1.4, 0
7069, -0.016666666666667, 1.45, 0
7070, -0.016666666666667, 1.5, 0
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line90
2555, 1, 46, 43
2556, 43, 47, 44
2557, 44, 48, 45
2558, 45, 49, 2
*ELEMENT, type=T3D3, ELSET=Line103
2559, 3, 74, 50
2560, 50, 75, 51
2561, 51, 76, 52
2562, 52, 77, 53
2563, 53, 78, 54
2564, 54, 79, 55
2565, 55, 80, 56
2566, 56, 81, 57
2567, 57, 82, 58
2568, 58, 83, 59
2569, 59, 84, 60
2570, 60, 85, 61
2571, 61, 86, 62
2572, 62, 87, 63
2573, 63, 88, 64
2574, 64, 89, 65
2575, 65, 90, 66
2576, 66, 91, 67
2577, 67, 92, 68
2578, 68, 93, 69
2579, 69, 94, 70
2580, 70, 95, 71
2581, 71, 96, 72
2582, 72, 97, 73
2583, 73, 98, 4
*ELEMENT, type=T3D3, ELSET=Line104
2584, 5, 123, 99
2585, 99, 124, 100
2586, 100, 125, 101
2587, 101, 126, 102
2588, 102, 127, 103
2589, 103, 128, 104
2590, 104, 129, 105
2591, 105, 130, 106
2592, 106, 131, 107
2593, 107, 132, 108
2594, 108, 133, 109
2595, 109, 134, 110
2596, 110, 135, 111
2597, 111, 136, 112
2598, 112, 137, 113
2599, 113, 138, 114
2600, 114, 139, 115
2601, 115, 140, 116
2602, 116, 141, 117
2603, 117, 142, 118
2604, 118, 143, 119
2605, 119, 144, 120
2606, 120, 145, 121
2607, 121, 146, 122
2608, 122, 147, 6
*ELEMENT, type=T3D3, ELSET=Line105
2609, 6, 172, 148
2610, 148, 173, 149
2611, 149, 174, 150
2612, 150, 175, 151
2613, 151, 176, 152
2614, 152, 177, 153
2615, 153, 178, 154
2616, 154, 179, 155
2617, 155, 180, 156
2618, 156, 181, 157
2619, 157, 182, 158
2620, 158, 183, 159
2621, 159, 184, 160
2622, 160, 185, 161
2623, 161, 186, 162
2624, 162, 187, 163
2625, 163, 188, 164
2626, 164, 189, 165
2627, 165, 190, 166
2628, 166, 191, 167
2629, 167, 192, 168
2630, 168, 193, 169
2631, 169, 194, 170
2632, 170, 195, 171
2633, 171, 196, 7
*ELEMENT, type=T3D3, ELSET=Line106
2634, 7, 221, 197
2635, 197, 222, 198
2636, 198, 223, 199
2637, 199, 224, 200
2638, 200, 225, 201
2639, 201, 226, 202
2640, 202, 227, 203
2641, 203, 228, 204
2642, 204, 229, 205
2643, 205, 230, 206
2644, 206, 231, 207
2645, 207, 232, 208
2646, 208, 233, 209
2647, 209, 234, 210
2648, 210, 235, 211
2649, 211, 236, 212
2650, 212, 237, 213
2651, 213, 238, 214
2652, 214, 239, 215
2653, 215, 240, 216
2654, 216, 241, 217
2655, 217, 242, 218
2656, 218, 243, 219
2657, 219, 244, 220
2658, 220, 245, 8
*ELEMENT, type=T3D3, ELSET=Line107
2659, 8, 270, 246
2660, 246, 271, 247
2661, 247, 272, 248
2662, 248, 273, 249
2663, 249, 274, 250
2664, 250, 275, 251
2665, 251, 276, 252
2666, 252, 277, 253
2667, 253, 278, 254
2668, 254, 279, 255
2669, 255, 280, 256
2670, 256, 281, 257
2671, 257, 282, 258
2672, 258, 283, 259
2673, 259, 284, 260
2674, 260, 285, 261
2675, 261, 286, 262
2676, 262, 287, 263
2677, 263, 288, 264
2678, 264, 289, 265
2679, 265, 290, 266
2680, 266, 291, 267
2681, 267, 292, 268
2682, 268, 293, 269
2683, 269, 294, 5
*ELEMENT, type=T3D3, ELSET=Line109
1, 1, 298, 295
2, 295, 299, 296
3, 296, 300, 297
4, 297, 301, 9
*ELEMENT, type=T3D3, ELSET=Line110
2684, 3, 304, 302
2685, 302, 305, 303
2686, 303, 306, 9
*ELEMENT, type=T3D3, ELSET=Line113
2687, 10, 331, 307
2688, 307, 332, 308
2689, 308, 333, 309
2690, 309, 334, 310
2691, 310, 335, 311
2692, 311, 336, 312
2693, 312, 337, 313
2694, 313, 338, 314
2695, 314, 339, 315
2696, 315, 340, 316
2697, 316, 341, 317
2698, 317, 342, 318
2699, 318, 343, 319
2700, 319, 344, 320
2701, 320, 345, 321
2702, 321, 346, 322
2703, 322, 347, 323
2704, 323, 348, 324
2705, 324, 349, 325
2706, 325, 350, 326
2707, 326, 351, 327
2708, 327, 352, 328
2709, 328, 353, 329
2710, 329, 354, 330
2711, 330, 355, 11
*ELEMENT, type=T3D3, ELSET=Line114
2712, 12, 380, 356
2713, 356, 381, 357
2714, 357, 382, 358
2715, 358, 383, 359
2716, 359, 384, 360
2717, 360, 385, 361
2718, 361, 386, 362
2719, 362, 387, 363
2720, 363, 388, 364
2721, 364, 389, 365
2722, 365, 390, 366
2723, 366, 391, 367
2724, 367, 392, 368
2725, 368, 393, 369
2726, 369, 394, 370
2727, 370, 395, 371
2728, 371, 396, 372
2729, 372, 397, 373
2730, 373, 398, 374
2731, 374, 399, 375
2732, 375, 400, 376
2733, 376, 401, 377
2734, 377, 402, 378
2735, 378, 403, 379
2736, 379, 404, 13
*ELEMENT, type=T3D3, ELSET=Line115
2737, 10, 429, 405
2738, 405, 430, 406
2739, 406, 431, 407
2740, 407, 432, 408
2741, 408, 433, 409
2742, 409, 434, 410
2743, 410, 435, 411
2744, 411, 436, 412
2745, 412, 437, 413
2746, 413, 438, 414
2747, 414, 439, 415
2748, 415, 440, 416
2749, 416, 441, 417
2750, 417, 442, 418
2751, 418, 443, 419
2752, 419, 444, 420
2753, 420, 445, 421
2754, 421, 446, 422
2755, 422, 447, 423
2756, 423, 448, 424
2757, 424, 449, 425
2758, 425, 450, 426
2759, 426, 451, 427
2760, 427, 452, 428
2761, 428, 453, 12
*ELEMENT, type=T3D3, ELSET=Line116
2762, 11, 478, 454
2763, 454, 479, 455
2764, 455, 480, 456
2765, 456, 481, 457
2766, 457, 482, 458
2767, 458, 483, 459
2768, 459, 484, 460
2769, 460, 485, 461
2770, 461, 486, 462
2771, 462, 487, 463
2772, 463, 488, 464
2773, 464, 489, 465
2774, 465, 490, 466
2775, 466, 491, 467
2776, 467, 492, 468
2777, 468, 493, 469
2778, 469, 494, 470
2779, 470, 495, 471
2780, 471, 496, 472
2781, 472, 497, 473
2782, 473, 498, 474
2783, 474, 499, 475
2784, 475, 500, 476
2785, 476, 501, 477
2786, 477, 502, 13
*ELEMENT, type=T3D3, ELSET=Line119
5, 14, 527, 503
6, 503, 528, 504
7, 504, 529, 505
8, 505, 530, 506
9, 506, 531, 507
10, 507, 532, 508
11, 508, 533, 509
12, 509, 534, 510
13, 510, 535, 511
14, 511, 536, 512
15, 512, 537, 513
16, 513, 538, 514
17, 514, 539, 515
18, 515, 540, 516
19, 516, 541, 517
20, 517, 542, 518
21, 518, 543, 519
22, 519, 544, 520
23, 520, 545, 521
24, 521, 546, 522
25, 522, 547, 523
26, 523, 548, 524
27, 524, 549, 525
28, 525, 550, 526
29, 526, 551, 15
*ELEMENT, type=T3D3, ELSET=Line124
30, 16, 554, 552
31, 552, 555, 553
32, 553, 556, 17
*ELEMENT, type=T3D3, ELSET=Line126
2787, 16, 560, 557
2788, 557, 561, 558
2789, 558, 562, 559
2790, 559, 563, 18
*ELEMENT, type=T3D3, ELSET=Line129
2791, 14, 567, 564
2792, 564, 568, 565
2793, 565, 569, 566
2794, 566, 570, 19
*ELEMENT, type=T3D3, ELSET=Line130
2795, 15, 574, 571
2796, 571, 575, 572
2797, 572, 576, 573
2798, 573, 577, 20
*ELEMENT, type=T3D3, ELSET=Line131
33, 19, 602, 578
34, 578, 603, 579
35, 579, 604, 580
36, 580, 605, 581
37, 581, 606, 582
38, 582, 607, 583
39, 583, 608, 584
40, 584, 609, 585
41, 585, 610, 586
42, 586, 611, 587
43, 587, 612, 588
44, 588, 613, 589
45, 589, 614, 590
46, 590, 615, 591
47, 591, 616, 592
48, 592, 617, 593
49, 593, 618, 594
50, 594, 619, 595
51, 595, 620, 596
52, 596, 621, 597
53, 597, 622, 598
54, 598, 623, 599
55, 599, 624, 600
56, 600, 625, 601
57, 601, 626, 20
*ELEMENT, type=T3D3, ELSET=Line132
58, 21, 630, 627
59, 627, 631, 628
60, 628, 632, 629
61, 629, 633, 22
*ELEMENT, type=T3D3, ELSET=Line133
62, 15, 636, 634
63, 634, 637, 635
64, 635, 638, 21
*ELEMENT, type=T3D3, ELSET=Line134
65, 20, 641, 639
66, 639, 642, 640
67, 640, 643, 22
*ELEMENT, type=T3D3, ELSET=Line135
68, 2, 647, 644
69, 644, 648, 645
70, 645, 649, 646
71, 646, 650, 23
*ELEMENT, type=T3D3, ELSET=Line136
2799, 9, 654, 651
2800, 651, 655, 652
2801, 652, 656, 653
2802, 653, 657, 23
*ELEMENT, type=T3D3, ELSET=Line139
72, 24, 661, 658
73, 658, 662, 659
74, 659, 663, 660
75, 660, 664, 17
*ELEMENT, type=T3D3, ELSET=Line140
76, 18, 667, 665
77, 665, 668, 666
78, 666, 669, 24
*ELEMENT, type=T3D3, ELSET=Line145
2803, 3, 671, 670
2804, 670, 672, 10
*ELEMENT, type=T3D3, ELSET=Line146
2805, 4, 674, 673
2806, 673, 675, 12
*ELEMENT, type=T3D3, ELSET=Line147
2807, 25, 678, 676
2808, 676, 679, 677
2809, 677, 680, 1
*ELEMENT, type=T3D3, ELSET=Line149
2810, 25, 705, 681
2811, 681, 706, 682
2812, 682, 707, 683
2813, 683, 708, 684
2814, 684, 709, 685
2815, 685, 710, 686
2816, 686, 711, 687
2817, 687, 712, 688
2818, 688, 713, 689
2819, 689, 714, 690
2820, 690, 715, 691
2821, 691, 716, 692
2822, 692, 717, 693
2823, 693, 718, 694
2824, 694, 719, 695
2825, 695, 720, 696
2826, 696, 721, 697
2827, 697, 722, 698
2828, 698, 723, 699
2829, 699, 724, 700
2830, 700, 725, 701
2831, 701, 726, 702
2832, 702, 727, 703
2833, 703, 728, 704
2834, 704, 729, 26
*ELEMENT, type=T3D3, ELSET=Line150
2835, 25, 733, 730
2836, 730, 734, 731
2837, 731, 735, 732
2838, 732, 736, 3
*ELEMENT, type=T3D3, ELSET=Line151
2839, 27, 739, 737
2840, 737, 740, 738
2841, 738, 741, 14
*ELEMENT, type=T3D3, ELSET=Line152
2842, 28, 744, 742
2843, 742, 745, 743
2844, 743, 746, 15
*ELEMENT, type=T3D3, ELSET=Line153
2845, 27, 771, 747
2846, 747, 772, 748
2847, 748, 773, 749
2848, 749, 774, 750
2849, 750, 775, 751
2850, 751, 776, 752
2851, 752, 777, 753
2852, 753, 778, 754
2853, 754, 779, 755
2854, 755, 780, 756
2855, 756, 781, 757
2856, 757, 782, 758
2857, 758, 783, 759
2858, 759, 784, 760
2859, 760, 785, 761
2860, 761, 786, 762
2861, 762, 787, 763
2862, 763, 788, 764
2863, 764, 789, 765
2864, 765, 790, 766
2865, 766, 791, 767
2866, 767, 792, 768
2867, 768, 793, 769
2868, 769, 794, 770
2869, 770, 795, 28
*ELEMENT, type=T3D3, ELSET=Line154
2870, 29, 798, 796
2871, 796, 799, 797
2872, 797, 800, 16
*ELEMENT, type=T3D3, ELSET=Line155
2873, 30, 803, 801
2874, 801, 804, 802
2875, 802, 805, 31
*ELEMENT, type=T3D3, ELSET=Line156
2876, 29, 830, 806
2877, 806, 831, 807
2878, 807, 832, 808
2879, 808, 833, 809
2880, 809, 834, 810
2881, 810, 835, 811
2882, 811, 836, 812
2883, 812, 837, 813
2884, 813, 838, 814
2885, 814, 839, 815
2886, 815, 840, 816
2887, 816, 841, 817
2888, 817, 842, 818
2889, 818, 843, 819
2890, 819, 844, 820
2891, 820, 845, 821
2892, 821, 846, 822
2893, 822, 847, 823
2894, 823, 848, 824
2895, 824, 849, 825
2896, 825, 850, 826
2897, 826, 851, 827
2898, 827, 852, 828
2899, 828, 853, 829
2900, 829, 854, 30
*ELEMENT, type=T3D3, ELSET=Line157
79, 16, 879, 855
80, 855, 880, 856
81, 856, 881, 857
82, 857, 882, 858
83, 858, 883, 859
84, 859, 884, 860
85, 860, 885, 861
86, 861, 886, 862
87, 862, 887, 863
88, 863, 888, 864
89, 864, 889, 865
90, 865, 890, 866
91, 866, 891, 867
92, 867, 892, 868
93, 868, 893, 869
94, 869, 894, 870
95, 870, 895, 871
96, 871, 896, 872
97, 872, 897, 873
98, 873, 898, 874
99, 874, 899, 875
100, 875, 900, 876
101, 876, 901, 877
102, 877, 902, 878
103, 878, 903, 31
*ELEMENT, type=T3D3, ELSET=Line158
2901, 29, 906, 904
2902, 904, 907, 905
2903, 905, 908, 32
*ELEMENT, type=T3D3, ELSET=Line159
104, 32, 911, 909
105, 909, 912, 910
106, 910, 913, 17
*ELEMENT, type=T3D3, ELSET=Line160
2904, 31, 917, 914
2905, 914, 918, 915
2906, 915, 919, 916
2907, 916, 920, 33
*ELEMENT, type=T3D3, ELSET=Line161
107, 18, 945, 921
108, 921, 946, 922
109, 922, 947, 923
110, 923, 948, 924
111, 924, 949, 925
112, 925, 950, 926
113, 926, 951, 927
114, 927, 952, 928
115, 928, 953, 929
116, 929, 954, 930
117, 930, 955, 931
118, 931, 956, 932
119, 932, 957, 933
120, 933, 958, 934
121, 934, 959, 935
122, 935, 960, 936
123, 936, 961, 937
124, 937, 962, 938
125, 938, 963, 939
126, 939, 964, 940
127, 940, 965, 941
128, 941, 966, 942
129, 942, 967, 943
130, 943, 968, 944
131, 944, 969, 33
*ELEMENT, type=T3D3, ELSET=Line162
132, 34, 972, 970
133, 970, 973, 971
134, 971, 974, 21
*ELEMENT, type=T3D3, ELSET=Line163
2908, 28, 977, 975
2909, 975, 978, 976
2910, 976, 979, 34
*ELEMENT, type=T3D3, ELSET=Line164
2911, 5, 981, 980
2912, 980, 982, 29
*ELEMENT, type=T3D3, ELSET=Line165
2913, 6, 984, 983
2914, 983, 985, 30
*ELEMENT, type=T3D3, ELSET=Line166
2915, 11, 987, 986
2916, 986, 988, 27
*ELEMENT, type=T3D3, ELSET=Line167
2917, 13, 990, 989
2918, 989, 991, 28
*ELEMENT, type=T3D3, ELSET=Line168
2919, 7, 993, 992
2920, 992, 994, 25
*ELEMENT, type=T3D3, ELSET=Line169
2921, 8, 996, 995
2922, 995, 997, 26
*ELEMENT, type=T3D3, ELSET=Line170
2923, 14, 1001, 998
2924, 998, 1002, 999
2925, 999, 1003, 1000
2926, 1000, 1004, 31
*ELEMENT, type=T3D3, ELSET=Line171
135, 19, 1008, 1005
136, 1005, 1009, 1006
137, 1006, 1010, 1007
138, 1007, 1011, 33
*ELEMENT, type=T3D3, ELSET=Line172
2927, 26, 1014, 1012
2928, 1012, 1015, 1013
2929, 1013, 1016, 35
*ELEMENT, type=T3D3, ELSET=Line173
139, 1, 1041, 1017
140, 1017, 1042, 1018
141, 1018, 1043, 1019
142, 1019, 1044, 1020
143, 1020, 1045, 1021
144, 1021, 1046, 1022
145, 1022, 1047, 1023
146, 1023, 1048, 1024
147, 1024, 1049, 1025
148, 1025, 1050, 1026
149, 1026, 1051, 1027
150, 1027, 1052, 1028
151, 1028, 1053, 1029
152, 1029, 1054, 1030
153, 1030, 1055, 1031
154, 1031, 1056, 1032
155, 1032, 1057, 1033
156, 1033, 1058, 1034
157, 1034, 1059, 1035
158, 1035, 1060, 1036
159, 1036, 1061, 1037
160, 1037, 1062, 1038
161, 1038, 1063, 1039
162, 1039, 1064, 1040
163, 1040, 1065, 35
*ELEMENT, type=T3D3, ELSET=Line174
164, 9, 1090, 1066
165, 1066, 1091, 1067
166, 1067, 1092, 1068
167, 1068, 1093, 1069
168, 1069, 1094, 1070
169, 1070, 1095, 1071
170, 1071, 1096, 1072
171, 1072, 1097, 1073
172, 1073, 1098, 1074
173, 1074, 1099, 1075
174, 1075, 1100, 1076
175, 1076, 1101, 1077
176, 1077, 1102, 1078
177, 1078, 1103, 1079
178, 1079, 1104, 1080
179, 1080, 1105, 1081
180, 1081, 1106, 1082
181, 1082, 1107, 1083
182, 1083, 1108, 1084
183, 1084, 1109, 1085
184, 1085, 1110, 1086
185, 1086, 1111, 1087
186, 1087, 1112, 1088
187, 1088, 1113, 1089
188, 1089, 1114, 36
*ELEMENT, type=T3D3, ELSET=Line175
2930, 4, 1117, 1115
2931, 1115, 1118, 1116
2932, 1116, 1119, 36
*ELEMENT, type=T3D3, ELSET=Line176
2933, 35, 1123, 1120
2934, 1120, 1124, 1121
2935, 1121, 1125, 1122
2936, 1122, 1126, 37
*ELEMENT, type=T3D3, ELSET=Line177
189, 2, 1151, 1127
190, 1127, 1152, 1128
191, 1128, 1153, 1129
192, 1129, 1154, 1130
193, 1130, 1155, 1131
194, 1131, 1156, 1132
195, 1132, 1157, 1133
196, 1133, 1158, 1134
197, 1134, 1159, 1135
198, 1135, 1160, 1136
199, 1136, 1161, 1137
200, 1137, 1162, 1138
201, 1138, 1163, 1139
202, 1139, 1164, 1140
203, 1140, 1165, 1141
204, 1141, 1166, 1142
205, 1142, 1167, 1143
206, 1143, 1168, 1144
207, 1144, 1169, 1145
208, 1145, 1170, 1146
209, 1146, 1171, 1147
210, 1147, 1172, 1148
211, 1148, 1173, 1149
212, 1149, 1174, 1150
213, 1150, 1175, 37
*ELEMENT, type=T3D3, ELSET=Line178
2937, 38, 1179, 1176
2938, 1176, 1180, 1177
2939, 1177, 1181, 1178
2940, 1178, 1182, 36
*ELEMENT, type=T3D3, ELSET=Line179
214, 23, 1207, 1183
215, 1183, 1208, 1184
216, 1184, 1209, 1185
217, 1185, 1210, 1186
218, 1186, 1211, 1187
219, 1187, 1212, 1188
220, 1188, 1213, 1189
221, 1189, 1214, 1190
222, 1190, 1215, 1191
223, 1191, 1216, 1192
224, 1192, 1217, 1193
225, 1193, 1218, 1194
226, 1194, 1219, 1195
227, 1195, 1220, 1196
228, 1196, 1221, 1197
229, 1197, 1222, 1198
230, 1198, 1223, 1199
231, 1199, 1224, 1200
232, 1200, 1225, 1201
233, 1201, 1226, 1202
234, 1202, 1227, 1203
235, 1203, 1228, 1204
236, 1204, 1229, 1205
237, 1205, 1230, 1206
238, 1206, 1231, 38
*ELEMENT, type=T3D3, ELSET=Line180
239, 39, 1234, 1232
240, 1232, 1235, 1233
241, 1233, 1236, 38
*ELEMENT, type=T3D3, ELSET=Line181
2941, 40, 1239, 1237
2942, 1237, 1240, 1238
2943, 1238, 1241, 36
*ELEMENT, type=T3D3, ELSET=Line182
242, 39, 1245, 1242
243, 1242, 1246, 1243
244, 1243, 1247, 1244
245, 1244, 1248, 40
*ELEMENT, type=T3D3, ELSET=Line183
2944, 41, 1251, 1249
2945, 1249, 1252, 1250
2946, 1250, 1253, 35
*ELEMENT, type=T3D3, ELSET=Line184
246, 42, 1256, 1254
247, 1254, 1257, 1255
248, 1255, 1258, 37
*ELEMENT, type=T3D3, ELSET=Line185
249, 41, 1262, 1259
250, 1259, 1263, 1260
251, 1260, 1264, 1261
252, 1261, 1265, 42
*ELEMENT, type=CPS8, ELSET=Surface1
253, 5, 99, 1266, 269, 123, 1842, 1843, 294
254, 269, 1266, 1267, 268, 1843, 1844, 1845, 293
255, 268, 1267, 1268, 267, 1845, 1846, 1847, 292
256, 267, 1268, 1269, 266, 1847, 1848, 1849, 291
257, 266, 1269, 1270, 265, 1849, 1850, 1851, 290
258, 265, 1270, 1271, 264, 1851, 1852, 1853, 289
259, 264, 1271, 1272, 263, 1853, 1854, 1855, 288
260, 263, 1272, 1273, 262, 1855, 1856, 1857, 287
261, 262, 1273, 1274, 261, 1857, 1858, 1859, 286
262, 261, 1274, 1275, 260, 1859, 1860, 1861, 285
263, 260, 1275, 1276, 259, 1861, 1862, 1863, 284
264, 259, 1276, 1277, 258, 1863, 1864, 1865, 283
265, 258, 1277, 1278, 257, 1865, 1866, 1867, 282
266, 257, 1278, 1279, 256, 1867, 1868, 1869, 281
267, 256, 1279, 1280, 255, 1869, 1870, 1871, 280
268, 255, 1280, 1281, 254, 1871, 1872, 1873, 279
269, 254, 1281, 1282, 253, 1873, 1874, 1875, 278
270, 253, 1282, 1283, 252, 1875, 1876, 1877, 277
271, 252, 1283, 1284, 251, 1877, 1878, 1879, 276
272, 251, 1284, 1285, 250, 1879, 1880, 1881, 275
273, 250, 1285, 1286, 249, 1881, 1882, 1883, 274
274, 249, 1286, 1287, 248, 1883, 1884, 1885, 273
275, 248, 1287, 1288, 247, 1885, 1886, 1887, 272
276, 247, 1288, 1289, 246, 1887, 1888, 1889, 271
277, 246, 1289, 220, 8, 1889, 1890, 245, 270
278, 99, 100, 1290, 1266, 124, 1891, 1892, 1842
279, 1266, 1290, 1291, 1267, 1892, 1893, 1894, 1844
280, 1267, 1291, 1292, 1268, 1894, 1895, 1896, 1846
281, 1268, 1292, 1293, 1269, 1896, 1897, 1898, 1848
282, 1269, 1293, 1294, 1270, 1898, 1899, 1900, 1850
283, 1270, 1294, 1295, 1271, 1900, 1901, 1902, 1852
284, 1271, 1295, 1296, 1272, 1902, 1903, 1904, 1854
285, 1272, 1296, 1297, 1273, 1904, 1905, 1906, 1856
286, 1273, 1297, 1298, 1274, 1906, 1907, 1908, 1858
287, 1274, 1298, 1299, 1275, 1908, 1909, 1910, 1860
288, 1275, 1299, 1300, 1276, 1910, 1911, 1912, 1862
289, 1276, 1300, 1301, 1277, 1912, 1913, 1914, 1864
290, 1277, 1301, 1302, 1278, 1914, 1915, 1916, 1866
291, 1278, 1302, 1303, 1279, 1916, 1917, 1918, 1868
292, 1279, 1303, 1304, 1280, 1918, 1919, 1920, 1870
293, 1280, 1304, 1305, 1281, 1920, 1921, 1922, 1872
294, 1281, 1305, 1306, 1282, 1922, 1923, 1924, 1874
295, 1282, 1306, 1307, 1283, 1924, 1925, 1926, 1876
296, 1283, 1307, 1308, 1284, 1926, 1927, 1928, 1878
297, 1284, 1308, 1309, 1285, 1928, 1929, 1930, 1880
298, 1285, 1309, 1310, 1286, 1930, 1931, 1932, 1882
299, 1286, 1310, 1311, 1287, 1932, 1933, 1934, 1884
300, 1287, 1311, 1312, 1288, 1934, 1935, 1936, 1886
301, 1288, 1312, 1313, 1289, 1936, 1937, 1938, 1888
302, 1289, 1313, 219, 220, 1938, 1939, 244, 1890
303, 100, 101, 1314, 1290, 125, 1940, 1941, 1891
304, 1290, 1314, 1315, 1291, 1941, 1942, 1943, 1893
305, 1291, 1315, 1316, 1292, 1943, 1944, 1945, 1895
306, 1292, 1316, 1317, 1293, 1945, 1946, 1947, 1897
307, 1293, 1317, 1318, 1294, 1947, 1948, 1949, 1899
308, 1294, 1318, 1319, 1295, 1949, 1950, 1951, 1901
309, 1295, 1319, 1320, 1296, 1951, 1952, 1953, 1903
310, 1296, 1320, 1321, 1297, 1953, 1954, 1955, 1905
311, 1297, 1321, 1322, 1298, 1955, 1956, 1957, 1907
312, 1298, 1322, 1323, 1299, 1957, 1958, 1959, 1909
313, 1299, 1323, 1324, 1300, 1959, 1960, 1961, 1911
314, 1300, 1324, 1325, 1301, 1961, 1962, 1963, 1913
315, 1301, 1325, 1326, 1302, 1963, 1964, 1965, 1915
316, 1302, 1326, 1327, 1303, 1965, 1966, 1967, 1917
317, 1303, 1327, 1328, 1304, 1967, 1968, 1969, 1919
318, 1304, 1328, 1329, 1305, 1969, 1970, 1971, 1921
319, 1305, 1329, 1330, 1306, 1971, 1972, 1973, 1923
320, 1306, 1330, 1331, 1307, 1973, 1974, 1975, 1925
321, 1307, 1331, 1332, 1308, 1975, 1976, 1977, 1927
322, 1308, 1332, 1333, 1309, 1977, 1978, 1979, 1929
323, 1309, 1333, 1334, 1310, 1979, 1980, 1981, 1931
324, 1310, 1334, 1335, 1311, 1981, 1982, 1983, 1933
325, 1311, 1335, 1336, 1312, 1983, 1984, 1985, 1935
326, 1312, 1336, 1337, 1313, 1985, 1986, 1987, 1937
327, 1313, 1337, 218, 219, 1987, 1988, 243, 1939
328, 101, 102, 1338, 1314, 126, 1989, 1990, 1940
329, 1314, 1338, 1339, 1315, 1990, 1991, 1992, 1942
330, 1315, 1339, 1340, 1316, 1992, 1993, 1994, 1944
331, 1316, 1340, 1341, 1317, 1994, 1995, 1996, 1946
332, 1317, 1341, 1342, 1318, 1996, 1997, 1998, 1948
333, 1318, 1342, 1343, 1319, 1998, 1999, 2000, 1950
334, 1319, 1343, 1344, 1320, 2000, 2001, 2002, 1952
335, 1320, 1344, 1345, 1321, 2002, 2003, 2004, 1954
336, 1321, 1345, 1346, 1322, 2004, 2005, 2006, 1956
337, 1322, 1346, 1347, 1323, 2006, 2007, 2008, 1958
338, 1323, 1347, 1348, 1324, 2008, 2009, 2010, 1960
339, 1324, 1348, 1349, 1325, 2010, 2011, 2012, 1962
340, 1325, 1349, 1350, 1326, 2012, 2013, 2014, 1964
341, 1326, 1350, 1351, 1327, 2014, 2015, 2016, 1966
342, 1327, 1351, 1352, 1328, 2016, 2017, 2018, 1968
343, 1328, 1352, 1353, 1329, 2018, 2019, 2020, 1970
344, 1329, 1353, 1354, 1330, 2020, 2021, 2022, 1972
345, 1330, 1354, 1355, 1331, 2022, 2023, 2024, 1974
346, 1331, 1355, 1356, 1332, 2024, 2025, 2026, 1976
347, 1332, 1356, 1357, 1333, 2026, 2027, 2028, 1978
348, 1333, 1357, 1358, 1334, 2028, 2029, 2030, 1980
349, 1334, 1358, 1359, 1335, 2030, 2031, 2032, 1982
350, 1335, 1359, 1360, 1336, 2032, 2033, 2034, 1984
351, 1336, 1360, 1361, 1337, 2034, 2035, 2036, 1986
352, 1337, 1361, 217, 218, 2036, 2037, 242, 1988
353, 102, 103, 1362, 1338, 127, 2038, 2039, 1989
354, 1338, 1362, 1363, 1339, 2039, 2040, 2041, 1991
355, 1339, 1363, 1364, 1340, 2041, 2042, 2043, 1993
356, 1340, 1364, 1365, 1341, 2043, 2044, 2045, 1995
357, 1341, 1365, 1366, 1342, 2045, 2046, 2047, 1997
358, 1342, 1366, 1367, 1343, 2047, 2048, 2049, 1999
359, 1343, 1367, 1368, 1344, 2049, 2050, 2051, 2001
360, 1344, 1368, 1369, 1345, 2051, 2052, 2053, 2003
361, 1345, 1369, 1370, 1346, 2053, 2054, 2055, 2005
362, 1346, 1370, 1371, 1347, 2055, 2056, 2057, 2007
363, 1347, 1371, 1372, 1348, 2057, 2058, 2059, 2009
364, 1348, 1372, 1373, 1349, 2059, 2060, 2061, 2011
365, 1349, 1373, 1374, 1350, 2061, 2062, 2063, 2013
366, 1350, 1374, 1375, 1351, 2063, 2064, 2065, 2015
367, 1351, 1375, 1376, 1352, 2065, 2066, 2067, 2017
368, 1352, 1376, 1377, 1353, 2067, 2068, 2069, 2019
369, 1353, 1377, 1378, 1354, 2069, 2070, 2071, 2021
370, 1354, 1378, 1379, 1355, 2071, 2072, 2073, 2023
371, 1355, 1379, 1380, 1356, 2073, 2074, 2075, 2025
372, 1356, 1380, 1381, 1357, 2075, 2076, 2077, 2027
373, 1357, 1381, 1382, 1358, 2077, 2078, 2079, 2029
374, 1358, 1382, 1383, 1359, 2079, 2080, 2081, 2031
375, 1359, 1383, 1384, 1360, 2081, 2082, 2083, 2033
376, 1360, 1384, 1385, 1361, 2083, 2084, 2085, 2035
377, 1361, 1385, 216, 217, 2085, 2086, 241, 2037
378, 103, 104, 1386, 1362, 128, 2087, 2088, 2038
379, 1362, 1386, 1387, 1363, 2088, 2089, 2090, 2040
380, 1363, 1387, 1388, 1364, 2090, 2091, 2092, 2042
381, 1364, 1388, 1389, 1365, 2092, 2093, 2094, 2044
382, 1365, 1389, 1390, 1366, 2094, 2095, 2096, 2046
383, 1366, 1390, 1391, 1367, 2096, 2097, 2098, 2048
384, 1367, 1391, 1392, 1368, 2098, 2099, 2100, 2050
385, 1368, 1392, 1393, 1369, 2100, 2101, 2102, 2052
386, 1369, 1393, 1394, 1370, 2102, 2103, 2104, 2054
387, 1370, 1394, 1395, 1371, 2104, 2105, 2106, 2056
388, 1371, 1395, 1396, 1372, 2106, 2107, 2108, 2058
389, 1372, 1396, 1397, 1373, 2108, 2109, 2110, 2060
390, 1373, 1397, 1398, 1374, 2110, 2111, 2112, 2062
391, 1374, 1398, 1399, 1375, 2112, 2113, 2114, 2064
392, 1375, 1399, 1400, 1376, 2114, 2115, 2116, 2066
393, 1376, 1400, 1401, 1377, 2116, 2117, 2118, 2068
394, 1377, 1401, 1402, 1378, 2118, 2119, 2120, 2070
395, 1378, 1402, 1403, 1379, 2120, 2121, 2122, 2072
396, 1379, 1403, 1404, 1380, 2122, 2123, 2124, 2074
397, 1380, 1404, 1405, 1381, 2124, 2125, 2126, 2076
398, 1381, 1405, 1406, 1382, 2126, 2127, 2128, 2078
399, 1382, 1406, 1407, 1383, 2128, 2129, 2130, 2080
400, 1383, 1407, 1408, 1384, 2130, 2131, 2132, 2082
401, 1384, 1408, 1409, 1385, 2132, 2133, 2134, 2084
402, 1385, 1409, 215, 216, 2134, 2135, 240, 2086
403, 104, 105, 1410, 1386, 129, 2136, 2137, 2087
404, 1386, 1410, 1411, 1387, 2137, 2138, 2139, 2089
405, 1387, 1411, 1412, 1388, 2139, 2140, 2141, 2091
406, 1388, 1412, 1413, 1389, 2141, 2142, 2143, 2093
407, 1389, 1413, 1414, 1390, 2143, 2144, 2145, 2095
408, 1390, 1414, 1415, 1391, 2145, 2146, 2147, 2097
409, 1391, 1415, 1416, 1392, 2147, 2148, 2149, 2099
410, 1392, 1416, 1417, 1393, 2149, 2150, 2151, 2101
411, 1393, 1417, 1418, 1394, 2151, 2152, 2153, 2103
412, 1394, 1418, 1419, 1395, 2153, 2154, 2155, 2105
413, 1395, 1419, 1420, 1396, 2155, 2156, 2157, 2107
414, 1396, 1420, 1421, 1397, 2157, 2158, 2159, 2109
415, 1397, 1421, 1422, 1398, 2159, 2160, 2161, 2111
416, 1398, 1422, 1423, 1399, 2161, 2162, 2163, 2113
417, 1399, 1423, 1424, 1400, 2163, 2164, 2165, 2115
418, 1400, 1424, 1425, 1401, 2165, 2166, 2167, 2117
419, 1401, 1425, 1426, 1402, 2167, 2168, 2169, 2119
420, 1402, 1426, 1427, 1403, 2169, 2170, 2171, 2121
421, 1403, 1427, 1428, 1404, 2171, 2172, 2173, 2123
422, 1404, 1428, 1429, 1405, 2173, 2174, 2175, 2125
423, 1405, 1429, 1430, 1406, 2175, 2176, 2177, 2127
424, 1406, 1430, 1431, 1407, 2177, 2178, 2179, 2129
425, 1407, 1431, 1432, 1408, 2179, 2180, 2181, 2131
426, 1408, 1432, 1433, 1409, 2181, 2182, 2183, 2133
427, 1409, 1433, 214, 215, 2183, 2184, 239, 2135
428, 105, 106, 1434, 1410, 130, 2185, 2186, 2136
429, 1410, 1434, 1435, 1411, 2186, 2187, 2188, 2138
430, 1411, 1435, 1436, 1412, 2188, 2189, 2190, 2140
431, 1412, 1436, 1437, 1413, 2190, 2191, 2192, 2142
432, 1413, 1437, 1438, 1414, 2192, 2193, 2194, 2144
433, 1414, 1438, 1439, 1415, 2194, 2195, 2196, 2146
434, 1415, 1439, 1440, 1416, 2196, 2197, 2198, 2148
435, 1416, 1440, 1441, 1417, 2198, 2199, 2200, 2150
436, 1417, 1441, 1442, 1418, 2200, 2201, 2202, 2152
437, 1418, 1442, 1443, 1419, 2202, 2203, 2204, 2154
438, 1419, 1443, 1444, 1420, 2204, 2205, 2206, 2156
439, 1420, 1444, 1445, 1421, 2206, 2207, 2208, 2158
440, 1421, 1445, 1446, 1422, 2208, 2209, 2210, 2160
441, 1422, 1446, 1447, 1423, 2210, 2211, 2212, 2162
442, 1423, 1447, 1448, 1424, 2212, 2213, 2214, 2164
443, 1424, 1448, 1449, 1425, 2214, 2215, 2216, 2166
444, 1425, 1449, 1450, 1426, 2216, 2217, 2218, 2168
445, 1426, 1450, 1451, 1427, 2218, 2219, 2220, 2170
446, 1427, 1451, 1452, 1428, 2220, 2221, 2222, 2172
447, 1428, 1452, 1453, 1429, 2222, 2223, 2224, 2174
448, 1429, 1453, 1454, 1430, 2224, 2225, 2226, 2176
449, 1430, 1454, 1455, 1431, 2226, 2227, 2228, 2178
450, 1431, 1455, 1456, 1432, 2228, 2229, 2230, 2180
451, 1432, 1456, 1457, 1433, 2230, 2231, 2232, 2182
452, 1433, 1457, 213, 214, 2232, 2233, 238, 2184
453, 106, 107, 1458, 1434, 131, 2234, 2235, 2185
454, 1434, 1458, 1459, 1435, 2235, 2236, 2237, 2187
455, 1435, 1459, 1460, 1436, 2237, 2238, 2239, 2189
456, 1436, 1460, 1461, 1437, 2239, 2240, 2241, 2191
457, 1437, 1461, 1462, 1438, 2241, 2242, 2243, 2193
458, 1438, 1462, 1463, 1439, 2243, 2244, 2245, 2195
459, 1439, 1463, 1464, 1440, 2245, 2246, 2247, 2197
460, 1440, 1464, 1465, 1441, 2247, 2248, 2249, 2199
461, 1441, 1465, 1466, 1442, 2249, 2250, 2251, 2201
462, 1442, 1466, 1467, 1443, 2251, 2252, 2253, 2203
463, 1443, 1467, 1468, 1444, 2253, 2254, 2255, 2205
464, 1444, 1468, 1469, 1445, 2255, 2256, 2257, 2207
465, 1445, 1469, 1470, 1446, 2257, 2258, 2259, 2209
466, 1446, 1470, 1471, 1447, 2259, 2260, 2261, 2211
467, 1447, 1471, 1472, 1448, 2261, 2262, 2263, 2213
468, 1448, 1472, 1473, 1449, 2263, 2264, 2265, 2215
469, 1449, 1473, 1474, 1450, 2265, 2266, 2267, 2217
470, 1450, 1474, 1475, 1451, 2267, 2268, 2269, 2219
471, 1451, 1475, 1476, 1452, 2269, 2270, 2271, 2221
472, 1452, 1476, 1477, 1453, 2271, 2272, 2273, 2223
473, 1453, 1477, 1478, 1454, 2273, 2274, 2275, 2225
474, 1454, 1478, 1479, 1455, 2275, 2276, 2277, 2227
475, 1455, 1479, 1480, 1456, 2277, 2278, 2279, 2229
476, 1456, 1480, 1481, 1457, 2279, 2280, 2281, 2231
477, 1457, 1481, 212, 213, 2281, 2282, 237, 2233
478, 107, 108, 1482, 1458, 132, 2283, 2284, 2234
479, 1458, 1482, 1483, 1459, 2284, 2285, 2286, 2236
480, 1459, 1483, 1484, 1460, 2286, 2287, 2288, 2238
481, 1460, 1484, 1485, 1461, 2288, 2289, 2290, 2240
482, 1461, 1485, 1486, 1462, 2290, 2291, 2292, 2242
483, 1462, 1486, 1487, 1463, 2292, 2293, 2294, 2244
484, 1463, 1487, 1488, 1464, 2294, 2295, 2296, 2246
485, 1464, 1488, 1489, 1465, 2296, 2297, 2298, 2248
486, 1465, 1489, 1490, 1466, 2298, 2299, 2300, 2250
487, 1466, 1490, 1491, 1467, 2300, 2301, 2302, 2252
488, 1467, 1491, 1492, 1468, 2302, 2303, 2304, 2254
489, 1468, 1492, 1493, 1469, 2304, 2305, 2306, 2256
490, 1469, 1493, 1494, 1470, 2306, 2307, 2308, 2258
491, 1470, 1494, 1495, 1471, 2308, 2309, 2310, 2260
492, 1471, 1495, 1496, 1472, 2310, 2311, 2312, 2262
493, 1472, 1496, 1497, 1473, 2312, 2313, 2314, 2264
494, 1473, 1497, 1498, 1474, 2314, 2315, 2316, 2266
495, 1474, 1498, 1499, 1475, 2316, 2317, 2318, 2268
496, 1475, 1499, 1500, 1476, 2318, 2319, 2320, 2270
497, 1476, 1500, 1501, 1477, 2320, 2321, 2322, 2272
498, 1477, 1501, 1502, 1478, 2322, 2323, 2324, 2274
499, 1478, 1502, 1503, 1479, 2324, 2325, 2326, 2276
500, 1479, 1503, 1504, 1480, 2326, 2327, 2328, 2278
501, 1480, 1504, 1505, 1481, 2328, 2329, 2330, 2280
502, 1481, 1505, 211, 212, 2330, 2331, 236, 2282
503, 108, 109, 1506, 1482, 133, 2332, 2333, 2283
504, 1482, 1506, 1507, 1483, 2333, 2334, 2335, 2285
505, 1483, 1507, 1508, 1484, 2335, 2336, 2337, 2287
506, 1484, 1508, 1509, 1485, 2337, 2338, 2339, 2289
507, 1485, 1509, 1510, 1486, 2339, 2340, 2341, 2291
508, 1486, 1510, 1511, 1487, 2341, 2342, 2343, 2293
509, 1487, 1511, 1512, 1488, 2343, 2344, 2345, 2295
510, 1488, 1512, 1513, 1489, 2345, 2346, 2347, 2297
511, 1489, 1513, 1514, 1490, 2347, 2348, 2349, 2299
512, 1490, 1514, 1515, 1491, 2349, 2350, 2351, 2301
513, 1491, 1515, 1516, 1492, 2351, 2352, 2353, 2303
514, 1492, 1516, 1517, 1493, 2353, 2354, 2355, 2305
515, 1493, 1517, 1518, 1494, 2355, 2356, 2357, 2307
516, 1494, 1518, 1519, 1495, 2357, 2358, 2359, 2309
517, 1495, 1519, 1520, 1496, 2359, 2360, 2361, 2311
518, 1496, 1520, 1521, 1497, 2361, 2362, 2363, 2313
519, 1497, 1521, 1522, 1498, 2363, 2364, 2365, 2315
520, 1498, 1522, 1523, 1499, 2365, 2366, 2367, 2317
521, 1499, 1523, 1524, 1500, 2367, 2368, 2369, 2319
522, 1500, 1524, 1525, 1501, 2369, 2370, 2371, 2321
523, 1501, 1525, 1526, 1502, 2371, 2372, 2373, 2323
524, 1502, 1526, 1527, 1503, 2373, 2374, 2375, 2325
525, 1503, 1527, 1528, 1504, 2375, 2376, 2377, 2327
526, 1504, 1528, 1529, 1505, 2377, 2378, 2379, 2329
527, 1505, 1529, 210, 211, 2379, 2380, 235, 2331
528, 109, 110, 1530, 1506, 134, 2381, 2382, 2332
529, 1506, 1530, 1531, 1507, 2382, 2383, 2384, 2334
530, 1507, 1531, 1532, 1508, 2384, 2385, 2386, 2336
531, 1508, 1532, 1533, 1509, 2386, 2387, 2388, 2338
532, 1509, 1533, 1534, 1510, 2388, 2389, 2390, 2340
533, 1510, 1534, 1535, 1511, 2390, 2391, 2392, 2342
534, 1511, 1535, 1536, 1512, 2392, 2393, 2394, 2344
535, 1512, 1536, 1537, 1513, 2394, 2395, 2396, 2346
536, 1513, 1537, 1538, 1514, 2396, 2397, 2398, 2348
537, 1514, 1538, 1539, 1515, 2398, 2399, 2400, 2350
538, 1515, 1539, 1540, 1516, 2400, 2401, 2402, 2352
539, 1516, 1540, 1541, 1517, 2402, 2403, 2404, 2354
540, 1517, 1541, 1542, 1518, 2404, 2405, 2406, 2356
541, 1518, 1542, 1543, 1519, 2406, 2407, 2408, 2358
542, 1519, 1543, 1544, 1520, 2408, 2409, 2410, 2360
543, 1520, 1544, 1545, 1521, 2410, 2411, 2412, 2362
544, 1521, 1545, 1546, 1522, 2412, 2413, 2414, 2364
545, 1522, 1546, 1547, 1523, 2414, 2415, 2416, 2366
546, 1523, 1547, 1548, 1524, 2416, 2417, 2418, 2368
547, 1524, 1548, 1549, 1525, 2418, 2419, 2420, 2370
548, 1525, 1549, 1550, 1526, 2420, 2421, 2422, 2372
549, 1526, 1550, 1551, 1527, 2422, 2423, 2424, 2374
550, 1527, 1551, 1552, 1528, 2424, 2425, 2426, 2376
551, 1528, 1552, 1553, 1529, 2426, 2427, 2428, 2378
552, 1529, 1553, 209, 210, 2428, 2429, 234, 2380
553, 110, 111, 1554, 1530, 135, 2430, 2431, 2381
554, 1530, 1554, 1555, 1531, 2431, 2432, 2433, 2383
555, 1531, 1555, 1556, 1532, 2433, 2434, 2435, 2385
556, 1532, 1556, 1557, 1533, 2435, 2436, 2437, 2387
557, 1533, 1557, 1558, 1534, 2437, 2438, 2439, 2389
558, 1534, 1558, 1559, 1535, 2439, 2440, 2441, 2391
559, 1535, 1559, 1560, 1536, 2441, 2442, 2443, 2393
560, 1536, 1560, 1561, 1537, 2443, 2444, 2445, 2395
561, 1537, 1561, 1562, 1538, 2445, 2446, 2447, 2397
562, 1538, 1562, 1563, 1539, 2447, 2448, 2449, 2399
563, 1539, 1563, 1564, 1540, 2449, 2450, 2451, 2401
564, 1540, 1564, 1565, 1541, 2451, 2452, 2453, 2403
565, 1541, 1565, 1566, 1542, 2453, 2454, 2455, 2405
566, 1542, 1566, 1567, 1543, 2455, 2456, 2457, 2407
567, 1543, 1567, 1568, 1544, 2457, 2458, 2459, 2409
568, 1544, 1568, 1569, 1545, 2459, 2460, 2461, 2411
569, 1545, 1569, 1570, 1546, 2461, 2462, 2463, 2413
570, 1546, 1570, 1571, 1547, 2463, 2464, 2465, 2415
571, 1547, 1571, 1572, 1548, 2465, 2466, 2467, 2417
572, 1548, 1572, 1573, 1549, 2467, 2468, 2469, 2419
573, 1549, 1573, 1574, 1550, 2469, 2470, 2471, 2421
574, 1550, 1574, 1575, 1551, 2471, 2472, 2473, 2423
575, 1551, 1575, 1576, 1552, 2473, 2474, 2475, 2425
576, 1552, 1576, 1577, 1553, 2475, 2476, 2477, 2427
577, 1553, 1577, 208, 209, 2477, 2478, 233, 2429
578, 111, 112, 1578, 1554, 136, 2479, 2480, 2430
579, 1554, 1578, 1579, 1555, 2480, 2481, 2482, 2432
580, 1555, 1579, 1580, 1556, 2482, 2483, 2484, 2434
581, 1556, 1580, 1581, 1557, 2484, 2485, 2486, 2436
582, 1557, 1581, 1582, 1558, 2486, 2487, 2488, 2438
583, 1558, 1582, 1583, 1559, 2488, 2489, 2490, 2440
584, 1559, 1583, 1584, 1560, 2490, 2491, 2492, 2442
585, 1560, 1584, 1585, 1561, 2492, 2493, 2494, 2444
586, 1561, 1585, 1586, 1562, 2494, 2495, 2496, 2446
587, 1562, 1586, 1587, 1563, 2496, 2497, 2498, 2448
588, 1563, 1587, 1588, 1564, 2498, 2499, 2500, 2450
589, 1564, 1588, 1589, 1565, 2500, 2501, 2502, 2452
590, 1565, 1589, 1590, 1566, 2502, 2503, 2504, 2454
591, 1566, 1590, 1591, 1567, 2504, 2505, 2506, 2456
592, 1567, 1591, 1592, 1568, 2506, 2507, 2508, 2458
593, 1568, 1592, 1593, 1569, 2508, 2509, 2510, 2460
594, 1569, 1593, 1594, 1570, 2510, 2511, 2512, 2462
595, 1570, 1594, 1595, 1571, 2512, 2513, 2514, 2464
596, 1571, 1595, 1596, 1572, 2514, 2515, 2516, 2466
597, 1572, 1596, 1597, 1573, 2516, 2517, 2518, 2468
598, 1573, 1597, 1598, 1574, 2518, 2519, 2520, 2470
599, 1574, 1598, 1599, 1575, 2520, 2521, 2522, 2472
600, 1575, 1599, 1600, 1576, 2522, 2523, 2524, 2474
601, 1576, 1600, 1601, 1577, 2524, 2525, 2526, 2476
602, 1577, 1601, 207, 208, 2526, 2527, 232, 2478
603, 112, 113, 1602, 1578, 137, 2528, 2529, 2479
604, 1578, 1602, 1603, 1579, 2529, 2530, 2531, 2481
605, 1579, 1603, 1604, 1580, 2531, 2532, 2533, 2483
606, 1580, 1604, 1605, 1581, 2533, 2534, 2535, 2485
607, 1581, 1605, 1606, 1582, 2535, 2536, 2537, 2487
608, 1582, 1606, 1607, 1583, 2537, 2538, 2539, 2489
609, 1583, 1607, 1608, 1584, 2539, 2540, 2541, 2491
610, 1584, 1608, 1609, 1585, 2541, 2542, 2543, 2493
611, 1585, 1609, 1610, 1586, 2543, 2544, 2545, 2495
612, 1586, 1610, 1611, 1587, 2545, 2546, 2547, 2497
613, 1587, 1611, 1612, 1588, 2547, 2548, 2549, 2499
614, 1588, 1612, 1613, 1589, 2549, 2550, 2551, 2501
615, 1589, 1613, 1614, 1590, 2551, 2552, 2553, 2503
616, 1590, 1614, 1615, 1591, 2553, 2554, 2555, 2505
617, 1591, 1615, 1616, 1592, 2555, 2556, 2557, 2507
618, 1592, 1616, 1617, 1593, 2557, 2558, 2559, 2509
619, 1593, 1617, 1618, 1594, 2559, 2560, 2561, 2511
620, 1594, 1618, 1619, 1595, 2561, 2562, 2563, 2513
621, 1595, 1619, 1620, 1596, 2563, 2564, 2565, 2515
622, 1596, 1620, 1621, 1597, 2565, 2566, 2567, 2517
623, 1597, 1621, 1622, 1598, 2567, 2568, 2569, 2519
624, 1598, 1622, 1623, 1599, 2569, 2570, 2571, 2521
625, 1599, 1623, 1624, 1600, 2571, 2572, 2573, 2523
626, 1600, 1624, 1625, 1601, 2573, 2574, 2575, 2525
627, 1601, 1625, 206, 207, 2575, 2576, 231, 2527
628, 113, 114, 1626, 1602, 138, 2577, 2578, 2528
629, 1602, 1626, 1627, 1603, 2578, 2579, 2580, 2530
630, 1603, 1627, 1628, 1604, 2580, 2581, 2582, 2532
631, 1604, 1628, 1629, 1605, 2582, 2583, 2584, 2534
632, 1605, 1629, 1630, 1606, 2584, 2585, 2586, 2536
633, 1606, 1630, 1631, 1607, 2586, 2587, 2588, 2538
634, 1607, 1631, 1632, 1608, 2588, 2589, 2590, 2540
635, 1608, 1632, 1633, 1609, 2590, 2591, 2592, 2542
636, 1609, 1633, 1634, 1610, 2592, 2593, 2594, 2544
637, 1610, 1634, 1635, 1611, 2594, 2595, 2596, 2546
638, 1611, 1635, 1636, 1612, 2596, 2597, 2598, 2548
639, 1612, 1636, 1637, 1613, 2598, 2599, 2600, 2550
640, 1613, 1637, 1638, 1614, 2600, 2601, 2602, 2552
641, 1614, 1638, 1639, 1615, 2602, 2603, 2604, 2554
642, 1615, 1639, 1640, 1616, 2604, 2605, 2606, 2556
643, 1616, 1640, 1641, 1617, 2606, 2607, 2608, 2558
644, 1617, 1641, 1642, 1618, 2608, 2609, 2610, 2560
645, 1618, 1642, 1643, 1619, 2610, 2611, 2612, 2562
646, 1619, 1643, 1644, 1620, 2612, 2613, 2614, 2564
647, 1620, 1644, 1645, 1621, 2614, 2615, 2616, 2566
648, 1621, 1645, 1646, 1622, 2616, 2617, 2618, 2568
649, 1622, 1646, 1647, 1623, 2618, 2619, 2620, 2570
650, 1623, 1647, 1648, 1624, 2620, 2621, 2622, 2572
651, 1624, 1648, 1649, 1625, 2622, 2623, 2624, 2574
652, 1625, 1649, 205, 206, 2624, 2625, 230, 2576
653, 114, 115, 1650, 1626, 139, 2626, 2627, 2577
654, 1626, 1650, 1651, 1627, 2627, 2628, 2629, 2579
655, 1627, 1651, 1652, 1628, 2629, 2630, 2631, 2581
656, 1628, 1652, 1653, 1629, 2631, 2632, 2633, 2583
657, 1629, 1653, 1654, 1630, 2633, 2634, 2635, 2585
658, 1630, 1654, 1655, 1631, 2635, 2636, 2637, 2587
659, 1631, 1655, 1656, 1632, 2637, 2638, 2639, 2589
660, 1632, 1656, 1657, 1633, 2639, 2640, 2641, 2591
661, 1633, 1657, 1658, 1634, 2641, 2642, 2643, 2593
662, 1634, 1658, 1659, 1635, 2643, 2644, 2645, 2595
663, 1635, 1659, 1660, 1636, 2645, 2646, 2647, 2597
664, 1636, 1660, 1661, 1637, 2647, 2648, 2649, 2599
665, 1637, 1661, 1662, 1638, 2649, 2650, 2651, 2601
666, 1638, 1662, 1663, 1639, 2651, 2652, 2653, 2603
667, 1639, 1663, 1664, 1640, 2653, 2654, 2655, 2605
668, 1640, 1664, 1665, 1641, 2655, 2656, 2657, 2607
669, 1641, 1665, 1666, 1642, 2657, 2658, 2659, 2609
670, 1642, 1666, 1667, 1643, 2659, 2660, 2661, 2611
671, 1643, 1667, 1668, 1644, 2661, 2662, 2663, 2613
672, 1644, 1668, 1669, 1645, 2663, 2664, 2665, 2615
673, 1645, 1669, 1670, 1646, 2665, 2666, 2667, 2617
674, 1646, 1670, 1671, 1647, 2667, 2668, 2669, 2619
675, 1647, 1671, 1672, 1648, 2669, 2670, 2671, 2621
676, 1648, 1672, 1673, 1649, 2671, 2672, 2673, 2623
677, 1649, 1673, 204, 205, 2673, 2674, 229, 2625
678, 115, 116, 1674, 1650, 140, 2675, 2676, 2626
679, 1650, 1674, 1675, 1651, 2676, 2677, 2678, 2628
680, 1651, 1675, 1676, 1652, 2678, 2679, 2680, 2630
681, 1652, 1676, 1677, 1653, 2680, 2681, 2682, 2632
682, 1653, 1677, 1678, 1654, 2682, 2683, 2684, 2634
683, 1654, 1678, 1679, 1655, 2684, 2685, 2686, 2636
684, 1655, 1679, 1680, 1656, 2686, 2687, 2688, 2638
685, 1656, 1680, 1681, 1657, 2688, 2689, 2690, 2640
686, 1657, 1681, 1682, 1658, 2690, 2691, 2692, 2642
687, 1658, 1682, 1683, 1659, 2692, 2693, 2694, 2644
688, 1659, 1683, 1684, 1660, 2694, 2695, 2696, 2646
689, 1660, 1684, 1685, 1661, 2696, 2697, 2698, 2648
690, 1661, 1685, 1686, 1662, 2698, 2699, 2700, 2650
691, 1662, 1686, 1687, 1663, 2700, 2701, 2702, 2652
692, 1663, 1687, 1688, 1664, 2702, 2703, 2704, 2654
693, 1664, 1688, 1689, 1665, 2704, 2705, 2706, 2656
694, 1665, 1689, 1690, 1666, 2706, 2707, 2708, 2658
695, 1666, 1690, 1691, 1667, 2708, 2709, 2710, 2660
696, 1667, 1691, 1692, 1668, 2710, 2711, 2712, 2662
697, 1668, 1692, 1693, 1669, 2712, 2713, 2714, 2664
698, 1669, 1693, 1694, 1670, 2714, 2715, 2716, 2666
699, 1670, 1694, 1695, 1671, 2716, 2717, 2718, 2668
700, 1671, 1695, 1696, 1672, 2718, 2719, 2720, 2670
701, 1672, 1696, 1697, 1673, 2720, 2721, 2722, 2672
702, 1673, 1697, 203, 204, 2722, 2723, 228, 2674
703, 116, 117, 1698, 1674, 141, 2724, 2725, 2675
704, 1674, 1698, 1699, 1675, 2725, 2726, 2727, 2677
705, 1675, 1699, 1700, 1676, 2727, 2728, 2729, 2679
706, 1676, 1700, 1701, 1677, 2729, 2730, 2731, 2681
707, 1677, 1701, 1702, 1678, 2731, 2732, 2733, 2683
708, 1678, 1702, 1703, 1679, 2733, 2734, 2735, 2685
709, 1679, 1703, 1704, 1680, 2735, 2736, 2737, 2687
710, 1680, 1704, 1705, 1681, 2737, 2738, 2739, 2689
711, 1681, 1705, 1706, 1682, 2739, 2740, 2741, 2691
712, 1682, 1706, 1707, 1683, 2741, 2742, 2743, 2693
713, 1683, 1707, 1708, 1684, 2743, 2744, 2745, 2695
714, 1684, 1708, 1709, 1685, 2745, 2746, 2747, 2697
715, 1685, 1709, 1710, 1686, 2747, 2748, 2749, 2699
716, 1686, 1710, 1711, 1687, 2749, 2750, 2751, 2701
717, 1687, 1711, 1712, 1688, 2751, 2752, 2753, 2703
718, 1688, 1712, 1713, 1689, 2753, 2754, 2755, 2705
719, 1689, 1713, 1714, 1690, 2755, 2756, 2757, 2707
720, 1690, 1714, 1715, 1691, 2757, 2758, 2759, 2709
721, 1691, 1715, 1716, 1692, 2759, 2760, 2761, 2711
722, 1692, 1716, 1717, 1693, 2761, 2762, 2763, 2713
723, 1693, 1717, 1718, 1694, 2763, 2764, 2765, 2715
724, 1694, 1718, 1719, 1695, 2765, 2766, 2767, 2717
725, 1695, 1719, 1720, 1696, 2767, 2768, 2769, 2719
726, 1696, 1720, 1721, 1697, 2769, 2770, 2771, 2721
727, 1697, 1721, 202, 203, 2771, 2772, 227, 2723
728, 117, 118, 1722, 1698, 142, 2773, 2774, 2724
729, 1698, 1722, 1723, 1699, 2774, 2775, 2776, 2726
730, 1699, 1723, 1724, 1700, 2776, 2777, 2778, 2728
731, 1700, 1724, 1725, 1701, 2778, 2779, 2780, 2730
732, 1701, 1725, 1726, 1702, 2780, 2781, 2782, 2732
733, 1702, 1726, 1727, 1703, 2782, 2783, 2784, 2734
734, 1703, 1727, 1728, 1704, 2784, 2785, 2786, 2736
735, 1704, 1728, 1729, 1705, 2786, 2787, 2788, 2738
736, 1705, 1729, 1730, 1706, 2788, 2789, 2790, 2740
737, 1706, 1730, 1731, 1707, 2790, 2791, 2792, 2742
738, 1707, 1731, 1732, 1708, 2792, 2793, 2794, 2744
739, 1708, 1732, 1733, 1709, 2794, 2795, 2796, 2746
740, 1709, 1733, 1734, 1710, 2796, 2797, 2798, 2748
741, 1710, 1734, 1735, 1711, 2798, 2799, 2800, 2750
742, 1711, 1735, 1736, 1712, 2800, 2801, 2802, 2752
743, 1712, 1736, 1737, 1713, 2802, 2803, 2804, 2754
744, 1713, 1737, 1738, 1714, 2804, 2805, 2806, 2756
745, 1714, 1738, 1739, 1715, 2806, 2807, 2808, 2758
746, 1715, 1739, 1740, 1716, 2808, 2809, 2810, 2760
747, 1716, 1740, 1741, 1717, 2810, 2811, 2812, 2762
748, 1717, 1741, 1742, 1718, 2812, 2813, 2814, 2764
749, 1718, 1742, 1743, 1719, 2814, 2815, 2816, 2766
750, 1719, 1743, 1744, 1720, 2816, 2817, 2818, 2768
751, 1720, 1744, 1745, 1721, 2818, 2819, 2820, 2770
752, 1721, 1745, 201, 202, 2820, 2821, 226, 2772
753, 118, 119, 1746, 1722, 143, 2822, 2823, 2773
754, 1722, 1746, 1747, 1723, 2823, 2824, 2825, 2775
755, 1723, 1747, 1748, 1724, 2825, 2826, 2827, 2777
756, 1724, 1748, 1749, 1725, 2827, 2828, 2829, 2779
757, 1725, 1749, 1750, 1726, 2829, 2830, 2831, 2781
758, 1726, 1750, 1751, 1727, 2831, 2832, 2833, 2783
759, 1727, 1751, 1752, 1728, 2833, 2834, 2835, 2785
760, 1728, 1752, 1753, 1729, 2835, 2836, 2837, 2787
761, 1729, 1753, 1754, 1730, 2837, 2838, 2839, 2789
762, 1730, 1754, 1755, 1731, 2839, 2840, 2841, 2791
763, 1731, 1755, 1756, 1732, 2841, 2842, 2843, 2793
764, 1732, 1756, 1757, 1733, 2843, 2844, 2845, 2795
765, 1733, 1757, 1758, 1734, 2845, 2846, 2847, 2797
766, 1734, 1758, 1759, 1735, 2847, 2848, 2849, 2799
767, 1735, 1759, 1760, 1736, 2849, 2850, 2851, 2801
768, 1736, 1760, 1761, 1737, 2851, 2852, 2853, 2803
769, 1737, 1761, 1762, 1738, 2853, 2854, 2855, 2805
770, 1738, 1762, 1763, 1739, 2855, 2856, 2857, 2807
771, 1739, 1763, 1764, 1740, 2857, 2858, 2859, 2809
772, 1740, 1764, 1765, 1741, 2859, 2860, 2861, 2811
773, 1741, 1765, 1766, 1742, 2861, 2862, 2863, 2813
774, 1742, 1766, 1767, 1743, 2863, 2864, 2865, 2815
775, 1743, 1767, 1768, 1744, 2865, 2866, 2867, 2817
776, 1744, 1768, 1769, 1745, 2867, 2868, 2869, 2819
777, 1745, 1769, 200, 201, 2869, 2870, 225, 2821
778, 119, 120, 1770, 1746, 144, 2871, 2872, 2822
779, 1746, 1770, 1771, 1747, 2872, 2873, 2874, 2824
780, 1747, 1771, 1772, 1748, 2874, 2875, 2876, 2826
781, 1748, 1772, 1773, 1749, 2876, 2877, 2878, 2828
782, 1749, 1773, 1774, 1750, 2878, 2879, 2880, 2830
783, 1750, 1774, 1775, 1751, 2880, 2881, 2882, 2832
784, 1751, 1775, 1776, 1752, 2882, 2883, 2884, 2834
785, 1752, 1776, 1777, 1753, 2884, 2885, 2886, 2836
786, 1753, 1777, 1778, 1754, 2886, 2887, 2888, 2838
787, 1754, 1778, 1779, 1755, 2888, 2889, 2890, 2840
788, 1755, 1779, 1780, 1756, 2890, 2891, 2892, 2842
789, 1756, 1780, 1781, 1757, 2892, 2893, 2894, 2844
790, 1757, 1781, 1782, 1758, 2894, 2895, 2896, 2846
791, 1758, 1782, 1783, 1759, 2896, 2897, 2898, 2848
792, 1759, 1783, 1784, 1760, 2898, 2899, 2900, 2850
793, 1760, 1784, 1785, 1761, 2900, 2901, 2902, 2852
794, 1761, 1785, 1786, 1762, 2902, 2903, 2904, 2854
795, 1762, 1786, 1787, 1763, 2904, 2905, 2906, 2856
796, 1763, 1787, 1788, 1764, 2906, 2907, 2908, 2858
797, 1764, 1788, 1789, 1765, 2908, 2909, 2910, 2860
798, 1765, 1789, 1790, 1766, 2910, 2911, 2912, 2862
799, 1766, 1790, 1791, 1767, 2912, 2913, 2914, 2864
800, 1767, 1791, 1792, 1768, 2914, 2915, 2916, 2866
801, 1768, 1792, 1793, 1769, 2916, 2917, 2918, 2868
802, 1769, 1793, 199, 200, 2918, 2919, 224, 2870
803, 120, 121, 1794, 1770, 145, 2920, 2921, 2871
804, 1770, 1794, 1795, 1771, 2921, 2922, 2923, 2873
805, 1771, 1795, 1796, 1772, 2923, 2924, 2925, 2875
806, 1772, 1796, 1797, 1773, 2925, 2926, 2927, 2877
807, 1773, 1797, 1798, 1774, 2927, 2928, 2929, 2879
808, 1774, 1798, 1799, 1775, 2929, 2930, 2931, 2881
809, 1775, 1799, 1800, 1776, 2931, 2932, 2933, 2883
810, 1776, 1800, 1801, 1777, 2933, 2934, 2935, 2885
811, 1777, 1801, 1802, 1778, 2935, 2936, 2937, 2887
812, 1778, 1802, 1803, 1779, 2937, 2938, 2939, 2889
813, 1779, 1803, 1804, 1780, 2939, 2940, 2941, 2891
814, 1780, 1804, 1805, 1781, 2941, 2942, 2943, 2893
815, 1781, 1805, 1806, 1782, 2943, 2944, 2945, 2895
816, 1782, 1806, 1807, 1783, 2945, 2946, 2947, 2897
817, 1783, 1807, 1808, 1784, 2947, 2948, 2949, 2899
818, 1784, 1808, 1809, 1785, 2949, 2950, 2951, 2901
819, 1785, 1809, 1810, 1786, 2951, 2952, 2953, 2903
820, 1786, 1810, 1811, 1787, 2953, 2954, 2955, 2905
821, 1787, 1811, 1812, 1788, 2955, 2956, 2957, 2907
822, 1788, 1812, 1813, 1789, 2957, 2958, 2959, 2909
823, 1789, 1813, 1814, 1790, 2959, 2960, 2961, 2911
824, 1790, 1814, 1815, 1791, 2961, 2962, 2963, 2913
825, 1791, 1815, 1816, 1792, 2963, 2964, 2965, 2915
826, 1792, 1816, 1817, 1793, 2965, 2966, 2967, 2917
827, 1793, 1817, 198, 199, 2967, 2968, 223, 2919
828, 121, 122, 1818, 1794, 146, 2969, 2970, 2920
829, 1794, 1818, 1819, 1795, 2970, 2971, 2972, 2922
830, 1795, 1819, 1820, 1796, 2972, 2973, 2974, 2924
831, 1796, 1820, 1821, 1797, 2974, 2975, 2976, 2926
832, 1797, 1821, 1822, 1798, 2976, 2977, 2978, 2928
833, 1798, 1822, 1823, 1799, 2978, 2979, 2980, 2930
834, 1799, 1823, 1824, 1800, 2980, 2981, 2982, 2932
835, 1800, 1824, 1825, 1801, 2982, 2983, 2984, 2934
836, 1801, 1825, 1826, 1802, 2984, 2985, 2986, 2936
837, 1802, 1826, 1827, 1803, 2986, 2987, 2988, 2938
838, 1803, 1827, 1828, 1804, 2988, 2989, 2990, 2940
839, 1804, 1828, 1829, 1805, 2990, 2991, 2992, 2942
840, 1805, 1829, 1830, 1806, 2992, 2993, 2994, 2944
841, 1806, 1830, 1831, 1807, 2994, 2995, 2996, 2946
842, 1807, 1831, 1832, 1808, 2996, 2997, 2998, 2948
843, 1808, 1832, 1833, 1809, 2998, 2999, 3000, 2950
844, 1809, 1833, 1834, 1810, 3000, 3001, 3002, 2952
845, 1810, 1834, 1835, 1811, 3002, 3003, 3004, 2954
846, 1811, 1835, 1836, 1812, 3004, 3005, 3006, 2956
847, 1812, 1836, 1837, 1813, 3006, 3007, 3008, 2958
848, 1813, 1837, 1838, 1814, 3008, 3009, 3010, 2960
849, 1814, 1838, 1839, 1815, 3010, 3011, 3012, 2962
850, 1815, 1839, 1840, 1816, 3012, 3013, 3014, 2964
851, 1816, 1840, 1841, 1817, 3014, 3015, 3016, 2966
852, 1817, 1841, 197, 198, 3016, 3017, 222, 2968
853, 122, 6, 148, 1818, 147, 172, 3018, 2969
854, 1818, 148, 149, 1819, 3018, 173, 3019, 2971
855, 1819, 149, 150, 1820, 3019, 174, 3020, 2973
856, 1820, 150, 151, 1821, 3020, 175, 3021, 2975
857, 1821, 151, 152, 1822, 3021, 176, 3022, 2977
858, 1822, 152, 153, 1823, 3022, 177, 3023, 2979
859, 1823, 153, 154, 1824, 3023, 178, 3024, 2981
860, 1824, 154, 155, 1825, 3024, 179, 3025, 2983
861, 1825, 155, 156, 1826, 3025, 180, 3026, 2985
862, 1826, 156, 157, 1827, 3026, 181, 3027, 2987
863, 1827, 157, 158, 1828, 3027, 182, 3028, 2989
864, 1828, 158, 159, 1829, 3028, 183, 3029, 2991
865, 1829, 159, 160, 1830, 3029, 184, 3030, 2993
866, 1830, 160, 161, 1831, 3030, 185, 3031, 2995
867, 1831, 161, 162, 1832, 3031, 186, 3032, 2997
868, 1832, 162, 163, 1833, 3032, 187, 3033, 2999
869, 1833, 163, 164, 1834, 3033, 188, 3034, 3001
870, 1834, 164, 165, 1835, 3034, 189, 3035, 3003
871, 1835, 165, 166, 1836, 3035, 190, 3036, 3005
872, 1836, 166, 167, 1837, 3036, 191, 3037, 3007
873, 1837, 167, 168, 1838, 3037, 192, 3038, 3009
874, 1838, 168, 169, 1839, 3038, 193, 3039, 3011
875, 1839, 169, 170, 1840, 3039, 194, 3040, 3013
