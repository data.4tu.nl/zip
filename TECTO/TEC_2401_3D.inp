84957, 1.5913043478261, 0.016666666666667, 0.27272727272727
84958, 1.5913043478261, 0.016666666666667, 0.22727272727273
84959, 1.5913043478261, 0.016666666666667, 0.18181818181818
84960, 1.5913043478261, 0.016666666666667, 0.13636363636364
84961, 1.5913043478261, 0.016666666666667, 0.090909090909091
84962, 1.5913043478261, 0.016666666666667, 0.045454545454545
84963, 1.6347826086957, 0.016666666666667, 0.45454545454545
84964, 1.6347826086957, 0.016666666666667, 0.40909090909091
84965, 1.6347826086957, 0.016666666666667, 0.36363636363636
84966, 1.6347826086957, 0.016666666666667, 0.31818181818182
84967, 1.6347826086957, 0.016666666666667, 0.27272727272727
84968, 1.6347826086957, 0.016666666666667, 0.22727272727273
84969, 1.6347826086957, 0.016666666666667, 0.18181818181818
84970, 1.6347826086957, 0.016666666666667, 0.13636363636364
84971, 1.6347826086957, 0.016666666666667, 0.090909090909091
84972, 1.6347826086957, 0.016666666666667, 0.045454545454545
84973, 1.6782608695652, 0.016666666666667, 0.45454545454545
84974, 1.6782608695652, 0.016666666666667, 0.40909090909091
84975, 1.6782608695652, 0.016666666666667, 0.36363636363636
84976, 1.6782608695652, 0.016666666666667, 0.31818181818182
84977, 1.6782608695652, 0.016666666666667, 0.27272727272727
84978, 1.6782608695652, 0.016666666666667, 0.22727272727273
84979, 1.6782608695652, 0.016666666666667, 0.18181818181818
84980, 1.6782608695652, 0.016666666666667, 0.13636363636364
84981, 1.6782608695652, 0.016666666666667, 0.090909090909091
84982, 1.6782608695652, 0.016666666666667, 0.045454545454545
84983, 1.7217391304348, 0.016666666666667, 0.45454545454545
84984, 1.7217391304348, 0.016666666666667, 0.40909090909091
84985, 1.7217391304348, 0.016666666666667, 0.36363636363636
84986, 1.7217391304348, 0.016666666666667, 0.31818181818182
84987, 1.7217391304348, 0.016666666666667, 0.27272727272727
84988, 1.7217391304348, 0.016666666666667, 0.22727272727273
84989, 1.7217391304348, 0.016666666666667, 0.18181818181818
84990, 1.7217391304348, 0.016666666666667, 0.13636363636364
84991, 1.7217391304348, 0.016666666666667, 0.090909090909091
84992, 1.7217391304348, 0.016666666666667, 0.045454545454545
84993, 1.7652173913043, 0.016666666666667, 0.45454545454545
84994, 1.7652173913043, 0.016666666666667, 0.40909090909091
84995, 1.7652173913043, 0.016666666666667, 0.36363636363636
84996, 1.7652173913043, 0.016666666666667, 0.31818181818182
84997, 1.7652173913043, 0.016666666666667, 0.27272727272727
84998, 1.7652173913043, 0.016666666666667, 0.22727272727273
84999, 1.7652173913043, 0.016666666666667, 0.18181818181818
85000, 1.7652173913043, 0.016666666666667, 0.13636363636364
85001, 1.7652173913043, 0.016666666666667, 0.090909090909091
85002, 1.7652173913043, 0.016666666666667, 0.045454545454545
85003, 1.8086956521739, 0.016666666666667, 0.45454545454545
85004, 1.8086956521739, 0.016666666666667, 0.40909090909091
85005, 1.8086956521739, 0.016666666666667, 0.36363636363636
85006, 1.8086956521739, 0.016666666666667, 0.31818181818182
85007, 1.8086956521739, 0.016666666666667, 0.27272727272727
85008, 1.8086956521739, 0.016666666666667, 0.22727272727273
85009, 1.8086956521739, 0.016666666666667, 0.18181818181818
85010, 1.8086956521739, 0.016666666666667, 0.13636363636364
85011, 1.8086956521739, 0.016666666666667, 0.090909090909091
85012, 1.8086956521739, 0.016666666666667, 0.045454545454545
85013, 1.8521739130435, 0.016666666666667, 0.45454545454545
85014, 1.8521739130435, 0.016666666666667, 0.40909090909091
85015, 1.8521739130435, 0.016666666666667, 0.36363636363636
85016, 1.8521739130435, 0.016666666666667, 0.31818181818182
85017, 1.8521739130435, 0.016666666666667, 0.27272727272727
85018, 1.8521739130435, 0.016666666666667, 0.22727272727273
85019, 1.8521739130435, 0.016666666666667, 0.18181818181818
85020, 1.8521739130435, 0.016666666666667, 0.13636363636364
85021, 1.8521739130435, 0.016666666666667, 0.090909090909091
85022, 1.8521739130435, 0.016666666666667, 0.045454545454545
85023, 1.895652173913, 0.016666666666667, 0.45454545454545
85024, 1.895652173913, 0.016666666666667, 0.40909090909091
85025, 1.895652173913, 0.016666666666667, 0.36363636363636
85026, 1.895652173913, 0.016666666666667, 0.31818181818182
85027, 1.895652173913, 0.016666666666667, 0.27272727272727
85028, 1.895652173913, 0.016666666666667, 0.22727272727273
85029, 1.895652173913, 0.016666666666667, 0.18181818181818
85030, 1.895652173913, 0.016666666666667, 0.13636363636364
85031, 1.895652173913, 0.016666666666667, 0.090909090909091
85032, 1.895652173913, 0.016666666666667, 0.045454545454545
85033, 1.9391304347826, 0.016666666666667, 0.45454545454545
85034, 1.9391304347826, 0.016666666666667, 0.40909090909091
85035, 1.9391304347826, 0.016666666666667, 0.36363636363636
85036, 1.9391304347826, 0.016666666666667, 0.31818181818182
85037, 1.9391304347826, 0.016666666666667, 0.27272727272727
85038, 1.9391304347826, 0.016666666666667, 0.22727272727273
85039, 1.9391304347826, 0.016666666666667, 0.18181818181818
85040, 1.9391304347826, 0.016666666666667, 0.13636363636364
85041, 1.9391304347826, 0.016666666666667, 0.090909090909091
85042, 1.9391304347826, 0.016666666666667, 0.045454545454545
85043, 1.9826086956522, 0.016666666666667, 0.45454545454545
85044, 1.9826086956522, 0.016666666666667, 0.40909090909091
85045, 1.9826086956522, 0.016666666666667, 0.36363636363636
85046, 1.9826086956522, 0.016666666666667, 0.31818181818182
85047, 1.9826086956522, 0.016666666666667, 0.27272727272727
85048, 1.9826086956522, 0.016666666666667, 0.22727272727273
85049, 1.9826086956522, 0.016666666666667, 0.18181818181818
85050, 1.9826086956522, 0.016666666666667, 0.13636363636364
85051, 1.9826086956522, 0.016666666666667, 0.090909090909091
85052, 1.9826086956522, 0.016666666666667, 0.045454545454545
85053, 2.0260869565217, 0.016666666666667, 0.45454545454545
85054, 2.0260869565217, 0.016666666666667, 0.40909090909091
85055, 2.0260869565217, 0.016666666666667, 0.36363636363636
85056, 2.0260869565217, 0.016666666666667, 0.31818181818182
85057, 2.0260869565217, 0.016666666666667, 0.27272727272727
85058, 2.0260869565217, 0.016666666666667, 0.22727272727273
85059, 2.0260869565217, 0.016666666666667, 0.18181818181818
85060, 2.0260869565217, 0.016666666666667, 0.13636363636364
85061, 2.0260869565217, 0.016666666666667, 0.090909090909091
85062, 2.0260869565217, 0.016666666666667, 0.045454545454545
85063, 2.0695652173913, 0.016666666666667, 0.45454545454545
85064, 2.0695652173913, 0.016666666666667, 0.40909090909091
85065, 2.0695652173913, 0.016666666666667, 0.36363636363636
85066, 2.0695652173913, 0.016666666666667, 0.31818181818182
85067, 2.0695652173913, 0.016666666666667, 0.27272727272727
85068, 2.0695652173913, 0.016666666666667, 0.22727272727273
85069, 2.0695652173913, 0.016666666666667, 0.18181818181818
85070, 2.0695652173913, 0.016666666666667, 0.13636363636364
85071, 2.0695652173913, 0.016666666666667, 0.090909090909091
85072, 2.0695652173913, 0.016666666666667, 0.045454545454545
85073, 2.1130434782609, 0.016666666666667, 0.45454545454545
85074, 2.1130434782609, 0.016666666666667, 0.40909090909091
85075, 2.1130434782609, 0.016666666666667, 0.36363636363636
85076, 2.1130434782609, 0.016666666666667, 0.31818181818182
85077, 2.1130434782609, 0.016666666666667, 0.27272727272727
85078, 2.1130434782609, 0.016666666666667, 0.22727272727273
85079, 2.1130434782609, 0.016666666666667, 0.18181818181818
85080, 2.1130434782609, 0.016666666666667, 0.13636363636364
85081, 2.1130434782609, 0.016666666666667, 0.090909090909091
85082, 2.1130434782609, 0.016666666666667, 0.045454545454545
85083, 2.1565217391304, 0.016666666666667, 0.45454545454545
85084, 2.1565217391304, 0.016666666666667, 0.40909090909091
85085, 2.1565217391304, 0.016666666666667, 0.36363636363636
85086, 2.1565217391304, 0.016666666666667, 0.31818181818182
85087, 2.1565217391304, 0.016666666666667, 0.27272727272727
85088, 2.1565217391304, 0.016666666666667, 0.22727272727273
85089, 2.1565217391304, 0.016666666666667, 0.18181818181818
85090, 2.1565217391304, 0.016666666666667, 0.13636363636364
85091, 2.1565217391304, 0.016666666666667, 0.090909090909091
85092, 2.1565217391304, 0.016666666666667, 0.045454545454545
85093, 2.2333333333333, 0.066666666666666, 0.45454545454545
85094, 2.2333333333333, 0.066666666666666, 0.40909090909091
85095, 2.2333333333333, 0.066666666666667, 0.36363636363636
85096, 2.2333333333333, 0.066666666666667, 0.31818181818182
85097, 2.2333333333333, 0.066666666666667, 0.27272727272727
85098, 2.2333333333333, 0.066666666666666, 0.22727272727273
85099, 2.2333333333333, 0.066666666666666, 0.18181818181818
85100, 2.2333333333333, 0.066666666666667, 0.13636363636364
85101, 2.2333333333333, 0.066666666666667, 0.090909090909091
85102, 2.2333333333333, 0.066666666666666, 0.045454545454545
85103, 2.2333333333333, 0.033333333333333, 0.45454545454545
85104, 2.2333333333333, 0.033333333333333, 0.40909090909091
85105, 2.2333333333333, 0.033333333333333, 0.36363636363636
85106, 2.2333333333333, 0.033333333333333, 0.31818181818182
85107, 2.2333333333333, 0.033333333333333, 0.27272727272727
85108, 2.2333333333333, 0.033333333333333, 0.22727272727273
85109, 2.2333333333333, 0.033333333333333, 0.18181818181818
85110, 2.2333333333333, 0.033333333333333, 0.13636363636364
85111, 2.2333333333333, 0.033333333333333, 0.090909090909091
85112, 2.2333333333333, 0.033333333333333, 0.045454545454545
85113, 2.2666666666667, 0.066666666666666, 0.45454545454545
85114, 2.2666666666667, 0.066666666666666, 0.40909090909091
85115, 2.2666666666667, 0.066666666666667, 0.36363636363636
85116, 2.2666666666667, 0.066666666666667, 0.31818181818182
85117, 2.2666666666667, 0.066666666666666, 0.27272727272727
85118, 2.2666666666667, 0.066666666666666, 0.22727272727273
85119, 2.2666666666667, 0.066666666666666, 0.18181818181818
85120, 2.2666666666667, 0.066666666666667, 0.13636363636364
85121, 2.2666666666667, 0.066666666666667, 0.090909090909091
85122, 2.2666666666667, 0.066666666666666, 0.045454545454545
85123, 2.2666666666667, 0.033333333333333, 0.45454545454545
85124, 2.2666666666667, 0.033333333333333, 0.40909090909091
85125, 2.2666666666667, 0.033333333333333, 0.36363636363636
85126, 2.2666666666667, 0.033333333333333, 0.31818181818182
85127, 2.2666666666667, 0.033333333333333, 0.27272727272727
85128, 2.2666666666667, 0.033333333333333, 0.22727272727273
85129, 2.2666666666667, 0.033333333333333, 0.18181818181818
85130, 2.2666666666667, 0.033333333333333, 0.13636363636364
85131, 2.2666666666667, 0.033333333333333, 0.090909090909091
85132, 2.2666666666667, 0.033333333333333, 0.045454545454545
85133, 2.2333333333333, 0.066666666666667, 0.47727272727273
85134, 2.2333333333333, 0.083333333333333, 0.45454545454545
85135, 2.2166666666667, 0.066666666666667, 0.45454545454545
85136, 2.2333333333333, 0.066666666666666, 0.43181818181818
85137, 2.2333333333333, 0.083333333333333, 0.40909090909091
85138, 2.2166666666667, 0.066666666666667, 0.40909090909091
85139, 2.2333333333333, 0.066666666666667, 0.38636363636364
85140, 2.2333333333333, 0.083333333333333, 0.36363636363636
85141, 2.2166666666667, 0.066666666666667, 0.36363636363636
85142, 2.2333333333333, 0.066666666666667, 0.34090909090909
85143, 2.2333333333333, 0.083333333333333, 0.31818181818182
85144, 2.2166666666667, 0.066666666666667, 0.31818181818182
85145, 2.2333333333333, 0.066666666666667, 0.29545454545455
85146, 2.2333333333333, 0.083333333333333, 0.27272727272727
85147, 2.2166666666667, 0.066666666666667, 0.27272727272727
85148, 2.2333333333333, 0.066666666666666, 0.25
85149, 2.2333333333333, 0.083333333333333, 0.22727272727273
85150, 2.2166666666667, 0.066666666666667, 0.22727272727273
85151, 2.2333333333333, 0.066666666666666, 0.20454545454545
85152, 2.2333333333333, 0.083333333333333, 0.18181818181818
85153, 2.2166666666667, 0.066666666666667, 0.18181818181818
85154, 2.2333333333333, 0.066666666666666, 0.15909090909091
85155, 2.2333333333333, 0.083333333333333, 0.13636363636364
85156, 2.2166666666667, 0.066666666666667, 0.13636363636364
85157, 2.2333333333333, 0.066666666666667, 0.11363636363636
85158, 2.2333333333333, 0.083333333333333, 0.090909090909091
85159, 2.2166666666667, 0.066666666666667, 0.090909090909091
85160, 2.2333333333333, 0.066666666666667, 0.068181818181818
85161, 2.2333333333333, 0.083333333333333, 0.045454545454545
85162, 2.2166666666667, 0.066666666666667, 0.045454545454545
85163, 2.2333333333333, 0.066666666666667, 0.022727272727273
85164, 2.2333333333333, 0.033333333333333, 0.47727272727273
85165, 2.2333333333333, 0.05, 0.45454545454545
85166, 2.2166666666667, 0.033333333333333, 0.45454545454545
85167, 2.2333333333333, 0.033333333333333, 0.43181818181818
85168, 2.2333333333333, 0.05, 0.40909090909091
85169, 2.2166666666667, 0.033333333333333, 0.40909090909091
85170, 2.2333333333333, 0.033333333333333, 0.38636363636364
85171, 2.2333333333333, 0.05, 0.36363636363636
85172, 2.2166666666667, 0.033333333333333, 0.36363636363636
85173, 2.2333333333333, 0.033333333333333, 0.34090909090909
85174, 2.2333333333333, 0.05, 0.31818181818182
85175, 2.2166666666667, 0.033333333333333, 0.31818181818182
85176, 2.2333333333333, 0.033333333333333, 0.29545454545455
85177, 2.2333333333333, 0.05, 0.27272727272727
85178, 2.2166666666667, 0.033333333333333, 0.27272727272727
85179, 2.2333333333333, 0.033333333333333, 0.25
85180, 2.2333333333333, 0.05, 0.22727272727273
85181, 2.2166666666667, 0.033333333333333, 0.22727272727273
85182, 2.2333333333333, 0.033333333333333, 0.20454545454545
85183, 2.2333333333333, 0.05, 0.18181818181818
85184, 2.2166666666667, 0.033333333333333, 0.18181818181818
85185, 2.2333333333333, 0.033333333333333, 0.15909090909091
85186, 2.2333333333333, 0.05, 0.13636363636364
85187, 2.2166666666667, 0.033333333333333, 0.13636363636364
85188, 2.2333333333333, 0.033333333333333, 0.11363636363636
85189, 2.2333333333333, 0.05, 0.090909090909091
85190, 2.2166666666667, 0.033333333333333, 0.090909090909091
85191, 2.2333333333333, 0.033333333333333, 0.068181818181818
85192, 2.2333333333333, 0.05, 0.045454545454545
85193, 2.2166666666667, 0.033333333333333, 0.045454545454545
85194, 2.2333333333333, 0.033333333333333, 0.022727272727273
85195, 2.2333333333333, 0.016666666666666, 0.45454545454545
85196, 2.2333333333333, 0.016666666666667, 0.40909090909091
85197, 2.2333333333333, 0.016666666666667, 0.36363636363636
85198, 2.2333333333333, 0.016666666666667, 0.31818181818182
85199, 2.2333333333333, 0.016666666666667, 0.27272727272727
85200, 2.2333333333333, 0.016666666666667, 0.22727272727273
85201, 2.2333333333333, 0.016666666666667, 0.18181818181818
85202, 2.2333333333333, 0.016666666666667, 0.13636363636364
85203, 2.2333333333333, 0.016666666666666, 0.090909090909091
85204, 2.2333333333333, 0.016666666666666, 0.045454545454545
85205, 2.2666666666667, 0.066666666666667, 0.47727272727273
85206, 2.2666666666667, 0.083333333333333, 0.45454545454545
85207, 2.25, 0.066666666666666, 0.45454545454545
85208, 2.2666666666667, 0.066666666666666, 0.43181818181818
85209, 2.2666666666667, 0.083333333333333, 0.40909090909091
85210, 2.25, 0.066666666666666, 0.40909090909091
85211, 2.2666666666667, 0.066666666666667, 0.38636363636364
85212, 2.2666666666667, 0.083333333333333, 0.36363636363636
85213, 2.25, 0.066666666666667, 0.36363636363636
85214, 2.2666666666667, 0.066666666666667, 0.34090909090909
85215, 2.2666666666667, 0.083333333333333, 0.31818181818182
85216, 2.25, 0.066666666666667, 0.31818181818182
85217, 2.2666666666667, 0.066666666666667, 0.29545454545455
85218, 2.2666666666667, 0.083333333333333, 0.27272727272727
85219, 2.25, 0.066666666666667, 0.27272727272727
85220, 2.2666666666667, 0.066666666666666, 0.25
85221, 2.2666666666667, 0.083333333333333, 0.22727272727273
85222, 2.25, 0.066666666666666, 0.22727272727273
85223, 2.2666666666667, 0.066666666666666, 0.20454545454545
85224, 2.2666666666667, 0.083333333333333, 0.18181818181818
85225, 2.25, 0.066666666666666, 0.18181818181818
85226, 2.2666666666667, 0.066666666666666, 0.15909090909091
85227, 2.2666666666667, 0.083333333333333, 0.13636363636364
85228, 2.25, 0.066666666666667, 0.13636363636364
85229, 2.2666666666667, 0.066666666666667, 0.11363636363636
85230, 2.2666666666667, 0.083333333333333, 0.090909090909091
85231, 2.25, 0.066666666666667, 0.090909090909091
85232, 2.2666666666667, 0.066666666666666, 0.068181818181818
85233, 2.2666666666667, 0.083333333333333, 0.045454545454545
85234, 2.25, 0.066666666666666, 0.045454545454545
85235, 2.2666666666667, 0.066666666666667, 0.022727272727273
85236, 2.2666666666667, 0.033333333333333, 0.47727272727273
85237, 2.2666666666667, 0.05, 0.45454545454545
85238, 2.25, 0.033333333333333, 0.45454545454545
85239, 2.2666666666667, 0.033333333333333, 0.43181818181818
85240, 2.2666666666667, 0.05, 0.40909090909091
85241, 2.25, 0.033333333333333, 0.40909090909091
85242, 2.2666666666667, 0.033333333333333, 0.38636363636364
85243, 2.2666666666667, 0.05, 0.36363636363636
85244, 2.25, 0.033333333333333, 0.36363636363636
85245, 2.2666666666667, 0.033333333333333, 0.34090909090909
85246, 2.2666666666667, 0.05, 0.31818181818182
85247, 2.25, 0.033333333333333, 0.31818181818182
85248, 2.2666666666667, 0.033333333333333, 0.29545454545455
85249, 2.2666666666667, 0.05, 0.27272727272727
85250, 2.25, 0.033333333333333, 0.27272727272727
85251, 2.2666666666667, 0.033333333333333, 0.25
85252, 2.2666666666667, 0.05, 0.22727272727273
85253, 2.25, 0.033333333333333, 0.22727272727273
85254, 2.2666666666667, 0.033333333333333, 0.20454545454545
85255, 2.2666666666667, 0.05, 0.18181818181818
85256, 2.25, 0.033333333333333, 0.18181818181818
85257, 2.2666666666667, 0.033333333333333, 0.15909090909091
85258, 2.2666666666667, 0.05, 0.13636363636364
85259, 2.25, 0.033333333333333, 0.13636363636364
85260, 2.2666666666667, 0.033333333333333, 0.11363636363636
85261, 2.2666666666667, 0.05, 0.090909090909091
85262, 2.25, 0.033333333333333, 0.090909090909091
85263, 2.2666666666667, 0.033333333333333, 0.068181818181818
85264, 2.2666666666667, 0.05, 0.045454545454545
85265, 2.25, 0.033333333333333, 0.045454545454545
85266, 2.2666666666667, 0.033333333333333, 0.022727272727273
85267, 2.2666666666667, 0.016666666666667, 0.45454545454545
85268, 2.2666666666667, 0.016666666666667, 0.40909090909091
85269, 2.2666666666667, 0.016666666666667, 0.36363636363636
85270, 2.2666666666667, 0.016666666666667, 0.31818181818182
85271, 2.2666666666667, 0.016666666666667, 0.27272727272727
85272, 2.2666666666667, 0.016666666666667, 0.22727272727273
85273, 2.2666666666667, 0.016666666666667, 0.18181818181818
85274, 2.2666666666667, 0.016666666666667, 0.13636363636364
85275, 2.2666666666667, 0.016666666666667, 0.090909090909091
85276, 2.2666666666667, 0.016666666666667, 0.045454545454545
85277, 2.2833333333333, 0.066666666666667, 0.45454545454545
85278, 2.2833333333333, 0.066666666666667, 0.40909090909091
85279, 2.2833333333333, 0.066666666666667, 0.36363636363636
85280, 2.2833333333333, 0.066666666666667, 0.31818181818182
85281, 2.2833333333333, 0.066666666666667, 0.27272727272727
85282, 2.2833333333333, 0.066666666666667, 0.22727272727273
85283, 2.2833333333333, 0.066666666666667, 0.18181818181818
85284, 2.2833333333333, 0.066666666666667, 0.13636363636364
85285, 2.2833333333333, 0.066666666666667, 0.090909090909091
85286, 2.2833333333333, 0.066666666666667, 0.045454545454545
85287, 2.2833333333333, 0.033333333333333, 0.45454545454545
85288, 2.2833333333333, 0.033333333333333, 0.40909090909091
85289, 2.2833333333333, 0.033333333333333, 0.36363636363636
85290, 2.2833333333333, 0.033333333333333, 0.31818181818182
85291, 2.2833333333333, 0.033333333333333, 0.27272727272727
85292, 2.2833333333333, 0.033333333333333, 0.22727272727273
85293, 2.2833333333333, 0.033333333333333, 0.18181818181818
85294, 2.2833333333333, 0.033333333333333, 0.13636363636364
85295, 2.2833333333333, 0.033333333333333, 0.090909090909091
85296, 2.2833333333333, 0.033333333333333, 0.045454545454545
85297, -0.033333333333333, 0.033333333333333, 0.45454545454545
85298, -0.033333333333333, 0.066666666666667, 0.45454545454545
85299, -0.033333333333333, 0.033333333333333, 0.40909090909091
85300, -0.033333333333333, 0.066666666666667, 0.40909090909091
85301, -0.033333333333333, 0.033333333333333, 0.36363636363636
85302, -0.033333333333333, 0.066666666666667, 0.36363636363636
85303, -0.033333333333333, 0.033333333333333, 0.31818181818182
85304, -0.033333333333333, 0.066666666666667, 0.31818181818182
85305, -0.033333333333333, 0.033333333333333, 0.27272727272727
85306, -0.033333333333333, 0.066666666666667, 0.27272727272727
85307, -0.033333333333333, 0.033333333333333, 0.22727272727273
85308, -0.033333333333333, 0.066666666666667, 0.22727272727273
85309, -0.033333333333333, 0.033333333333333, 0.18181818181818
85310, -0.033333333333333, 0.066666666666667, 0.18181818181818
85311, -0.033333333333333, 0.033333333333333, 0.13636363636364
85312, -0.033333333333333, 0.066666666666667, 0.13636363636364
85313, -0.033333333333333, 0.033333333333333, 0.090909090909091
85314, -0.033333333333333, 0.066666666666667, 0.090909090909091
85315, -0.033333333333333, 0.033333333333333, 0.045454545454545
85316, -0.033333333333333, 0.066666666666667, 0.045454545454545
85317, -0.066666666666667, 0.033333333333333, 0.45454545454545
85318, -0.066666666666667, 0.066666666666667, 0.45454545454545
85319, -0.066666666666667, 0.033333333333333, 0.40909090909091
85320, -0.066666666666667, 0.066666666666667, 0.40909090909091
85321, -0.066666666666667, 0.033333333333333, 0.36363636363636
85322, -0.066666666666667, 0.066666666666667, 0.36363636363636
85323, -0.066666666666667, 0.033333333333333, 0.31818181818182
85324, -0.066666666666667, 0.066666666666667, 0.31818181818182
85325, -0.066666666666667, 0.033333333333333, 0.27272727272727
85326, -0.066666666666667, 0.066666666666667, 0.27272727272727
85327, -0.066666666666667, 0.033333333333333, 0.22727272727273
85328, -0.066666666666667, 0.066666666666667, 0.22727272727273
85329, -0.066666666666667, 0.033333333333333, 0.18181818181818
85330, -0.066666666666667, 0.066666666666667, 0.18181818181818
85331, -0.066666666666667, 0.033333333333333, 0.13636363636364
85332, -0.066666666666667, 0.066666666666667, 0.13636363636364
85333, -0.066666666666667, 0.033333333333333, 0.090909090909091
85334, -0.066666666666667, 0.066666666666667, 0.090909090909091
85335, -0.066666666666667, 0.033333333333333, 0.045454545454545
85336, -0.066666666666667, 0.066666666666667, 0.045454545454545
85337, -0.033333333333333, 0.016666666666667, 0.45454545454545
85338, -0.033333333333333, 0.033333333333333, 0.47727272727273
85339, -0.016666666666667, 0.033333333333333, 0.45454545454545
85340, -0.033333333333333, 0.05, 0.45454545454545
85341, -0.033333333333333, 0.066666666666667, 0.47727272727273
85342, -0.016666666666667, 0.066666666666667, 0.45454545454545
85343, -0.033333333333333, 0.083333333333333, 0.45454545454545
85344, -0.033333333333333, 0.016666666666667, 0.40909090909091
85345, -0.033333333333333, 0.033333333333333, 0.43181818181818
85346, -0.016666666666667, 0.033333333333333, 0.40909090909091
85347, -0.033333333333333, 0.05, 0.40909090909091
85348, -0.033333333333333, 0.066666666666667, 0.43181818181818
85349, -0.016666666666667, 0.066666666666667, 0.40909090909091
85350, -0.033333333333333, 0.083333333333333, 0.40909090909091
85351, -0.033333333333333, 0.016666666666667, 0.36363636363636
85352, -0.033333333333333, 0.033333333333333, 0.38636363636364
85353, -0.016666666666667, 0.033333333333333, 0.36363636363636
85354, -0.033333333333333, 0.05, 0.36363636363636
85355, -0.033333333333333, 0.066666666666667, 0.38636363636364
85356, -0.016666666666667, 0.066666666666667, 0.36363636363636
85357, -0.033333333333333, 0.083333333333333, 0.36363636363636
85358, -0.033333333333333, 0.016666666666667, 0.31818181818182
85359, -0.033333333333333, 0.033333333333333, 0.34090909090909
85360, -0.016666666666667, 0.033333333333333, 0.31818181818182
85361, -0.033333333333333, 0.05, 0.31818181818182
85362, -0.033333333333333, 0.066666666666667, 0.34090909090909
85363, -0.016666666666667, 0.066666666666667, 0.31818181818182
85364, -0.033333333333333, 0.083333333333333, 0.31818181818182
85365, -0.033333333333333, 0.016666666666667, 0.27272727272727
85366, -0.033333333333333, 0.033333333333333, 0.29545454545455
85367, -0.016666666666667, 0.033333333333333, 0.27272727272727
85368, -0.033333333333333, 0.05, 0.27272727272727
85369, -0.033333333333333, 0.066666666666667, 0.29545454545455
85370, -0.016666666666667, 0.066666666666667, 0.27272727272727
85371, -0.033333333333333, 0.083333333333333, 0.27272727272727
85372, -0.033333333333333, 0.016666666666667, 0.22727272727273
85373, -0.033333333333333, 0.033333333333333, 0.25
85374, -0.016666666666667, 0.033333333333333, 0.22727272727273
85375, -0.033333333333333, 0.05, 0.22727272727273
85376, -0.033333333333333, 0.066666666666667, 0.25
85377, -0.016666666666667, 0.066666666666667, 0.22727272727273
85378, -0.033333333333333, 0.083333333333333, 0.22727272727273
85379, -0.033333333333333, 0.016666666666667, 0.18181818181818
85380, -0.033333333333333, 0.033333333333333, 0.20454545454545
85381, -0.016666666666667, 0.033333333333333, 0.18181818181818
85382, -0.033333333333333, 0.05, 0.18181818181818
85383, -0.033333333333333, 0.066666666666667, 0.20454545454545
85384, -0.016666666666667, 0.066666666666667, 0.18181818181818
85385, -0.033333333333333, 0.083333333333333, 0.18181818181818
85386, -0.033333333333333, 0.016666666666667, 0.13636363636364
85387, -0.033333333333333, 0.033333333333333, 0.15909090909091
85388, -0.016666666666667, 0.033333333333333, 0.13636363636364
85389, -0.033333333333333, 0.05, 0.13636363636364
85390, -0.033333333333333, 0.066666666666667, 0.15909090909091
85391, -0.016666666666667, 0.066666666666667, 0.13636363636364
85392, -0.033333333333333, 0.083333333333333, 0.13636363636364
85393, -0.033333333333333, 0.016666666666667, 0.090909090909091
85394, -0.033333333333333, 0.033333333333333, 0.11363636363636
85395, -0.016666666666667, 0.033333333333333, 0.090909090909091
85396, -0.033333333333333, 0.05, 0.090909090909091
85397, -0.033333333333333, 0.066666666666667, 0.11363636363636
85398, -0.016666666666667, 0.066666666666667, 0.090909090909091
85399, -0.033333333333333, 0.083333333333333, 0.090909090909091
85400, -0.033333333333333, 0.016666666666667, 0.045454545454545
85401, -0.033333333333333, 0.033333333333333, 0.068181818181818
85402, -0.016666666666667, 0.033333333333333, 0.045454545454545
85403, -0.033333333333333, 0.05, 0.045454545454545
85404, -0.033333333333333, 0.066666666666667, 0.068181818181818
85405, -0.016666666666667, 0.066666666666667, 0.045454545454545
85406, -0.033333333333333, 0.083333333333333, 0.045454545454545
85407, -0.033333333333333, 0.033333333333333, 0.022727272727273
85408, -0.033333333333333, 0.066666666666667, 0.022727272727273
85409, -0.066666666666667, 0.016666666666667, 0.45454545454545
85410, -0.066666666666667, 0.033333333333333, 0.47727272727273
85411, -0.05, 0.033333333333333, 0.45454545454545
85412, -0.066666666666667, 0.05, 0.45454545454545
85413, -0.066666666666667, 0.066666666666667, 0.47727272727273
85414, -0.05, 0.066666666666667, 0.45454545454545
85415, -0.066666666666667, 0.083333333333333, 0.45454545454545
85416, -0.066666666666667, 0.016666666666667, 0.40909090909091
85417, -0.066666666666667, 0.033333333333333, 0.43181818181818
85418, -0.05, 0.033333333333333, 0.40909090909091
85419, -0.066666666666667, 0.05, 0.40909090909091
85420, -0.066666666666667, 0.066666666666667, 0.43181818181818
85421, -0.05, 0.066666666666667, 0.40909090909091
85422, -0.066666666666667, 0.083333333333333, 0.40909090909091
85423, -0.066666666666667, 0.016666666666667, 0.36363636363636
85424, -0.066666666666667, 0.033333333333333, 0.38636363636364
85425, -0.05, 0.033333333333333, 0.36363636363636
85426, -0.066666666666667, 0.05, 0.36363636363636
85427, -0.066666666666667, 0.066666666666667, 0.38636363636364
85428, -0.05, 0.066666666666667, 0.36363636363636
85429, -0.066666666666667, 0.083333333333333, 0.36363636363636
85430, -0.066666666666667, 0.016666666666667, 0.31818181818182
85431, -0.066666666666667, 0.033333333333333, 0.34090909090909
85432, -0.05, 0.033333333333333, 0.31818181818182
85433, -0.066666666666667, 0.05, 0.31818181818182
85434, -0.066666666666667, 0.066666666666667, 0.34090909090909
85435, -0.05, 0.066666666666667, 0.31818181818182
85436, -0.066666666666667, 0.083333333333333, 0.31818181818182
85437, -0.066666666666667, 0.016666666666667, 0.27272727272727
85438, -0.066666666666667, 0.033333333333333, 0.29545454545455
85439, -0.05, 0.033333333333333, 0.27272727272727
85440, -0.066666666666667, 0.05, 0.27272727272727
85441, -0.066666666666667, 0.066666666666667, 0.29545454545455
85442, -0.05, 0.066666666666667, 0.27272727272727
85443, -0.066666666666667, 0.083333333333333, 0.27272727272727
85444, -0.066666666666667, 0.016666666666667, 0.22727272727273
85445, -0.066666666666667, 0.033333333333333, 0.25
85446, -0.05, 0.033333333333333, 0.22727272727273
85447, -0.066666666666667, 0.05, 0.22727272727273
85448, -0.066666666666667, 0.066666666666667, 0.25
85449, -0.05, 0.066666666666667, 0.22727272727273
85450, -0.066666666666667, 0.083333333333333, 0.22727272727273
85451, -0.066666666666667, 0.016666666666667, 0.18181818181818
85452, -0.066666666666667, 0.033333333333333, 0.20454545454545
85453, -0.05, 0.033333333333333, 0.18181818181818
85454, -0.066666666666667, 0.05, 0.18181818181818
85455, -0.066666666666667, 0.066666666666667, 0.20454545454545
85456, -0.05, 0.066666666666667, 0.18181818181818
85457, -0.066666666666667, 0.083333333333333, 0.18181818181818
85458, -0.066666666666667, 0.016666666666667, 0.13636363636364
85459, -0.066666666666667, 0.033333333333333, 0.15909090909091
85460, -0.05, 0.033333333333333, 0.13636363636364
85461, -0.066666666666667, 0.05, 0.13636363636364
85462, -0.066666666666667, 0.066666666666667, 0.15909090909091
85463, -0.05, 0.066666666666667, 0.13636363636364
85464, -0.066666666666667, 0.083333333333333, 0.13636363636364
85465, -0.066666666666667, 0.016666666666667, 0.090909090909091
85466, -0.066666666666667, 0.033333333333333, 0.11363636363636
85467, -0.05, 0.033333333333333, 0.090909090909091
85468, -0.066666666666667, 0.05, 0.090909090909091
85469, -0.066666666666667, 0.066666666666667, 0.11363636363636
85470, -0.05, 0.066666666666667, 0.090909090909091
85471, -0.066666666666667, 0.083333333333333, 0.090909090909091
85472, -0.066666666666667, 0.016666666666667, 0.045454545454545
85473, -0.066666666666667, 0.033333333333333, 0.068181818181818
85474, -0.05, 0.033333333333333, 0.045454545454545
85475, -0.066666666666667, 0.05, 0.045454545454545
85476, -0.066666666666667, 0.066666666666667, 0.068181818181818
85477, -0.05, 0.066666666666667, 0.045454545454545
85478, -0.066666666666667, 0.083333333333333, 0.045454545454545
85479, -0.066666666666667, 0.033333333333333, 0.022727272727273
85480, -0.066666666666667, 0.066666666666667, 0.022727272727273
85481, -0.083333333333333, 0.033333333333333, 0.45454545454545
85482, -0.083333333333333, 0.066666666666667, 0.45454545454545
85483, -0.083333333333333, 0.033333333333333, 0.40909090909091
85484, -0.083333333333333, 0.066666666666667, 0.40909090909091
85485, -0.083333333333333, 0.033333333333333, 0.36363636363636
85486, -0.083333333333333, 0.066666666666667, 0.36363636363636
85487, -0.083333333333333, 0.033333333333333, 0.31818181818182
85488, -0.083333333333333, 0.066666666666667, 0.31818181818182
85489, -0.083333333333333, 0.033333333333333, 0.27272727272727
85490, -0.083333333333333, 0.066666666666667, 0.27272727272727
85491, -0.083333333333333, 0.033333333333333, 0.22727272727273
85492, -0.083333333333333, 0.066666666666667, 0.22727272727273
85493, -0.083333333333333, 0.033333333333333, 0.18181818181818
85494, -0.083333333333333, 0.066666666666667, 0.18181818181818
85495, -0.083333333333333, 0.033333333333333, 0.13636363636364
85496, -0.083333333333333, 0.066666666666667, 0.13636363636364
85497, -0.083333333333333, 0.033333333333333, 0.090909090909091
85498, -0.083333333333333, 0.066666666666667, 0.090909090909091
85499, -0.083333333333333, 0.033333333333333, 0.045454545454545
85500, -0.083333333333333, 0.066666666666667, 0.045454545454545
85501, 0.95652173913043, 1.55, 0.045454545454545
85502, 0.95652173913043, 1.55, 0.090909090909091
85503, 0.95652173913043, 1.55, 0.13636363636364
85504, 0.95652173913043, 1.55, 0.18181818181818
85505, 0.95652173913043, 1.55, 0.22727272727273
85506, 0.95652173913043, 1.55, 0.27272727272727
85507, 0.95652173913044, 1.55, 0.31818181818182
85508, 0.95652173913043, 1.55, 0.36363636363636
85509, 0.95652173913043, 1.55, 0.40909090909091
85510, 0.95652173913043, 1.55, 0.45454545454545
85511, 0.91304347826087, 1.55, 0.045454545454545
85512, 0.91304347826087, 1.55, 0.090909090909091
85513, 0.91304347826087, 1.55, 0.13636363636364
85514, 0.91304347826087, 1.55, 0.18181818181818
85515, 0.91304347826087, 1.55, 0.22727272727273
85516, 0.91304347826087, 1.55, 0.27272727272727
85517, 0.91304347826087, 1.55, 0.31818181818182
85518, 0.91304347826087, 1.55, 0.36363636363636
85519, 0.91304347826087, 1.55, 0.40909090909091
85520, 0.91304347826087, 1.55, 0.45454545454545
85521, 0.8695652173913, 1.55, 0.045454545454545
85522, 0.8695652173913, 1.55, 0.090909090909091
85523, 0.8695652173913, 1.55, 0.13636363636364
85524, 0.8695652173913, 1.55, 0.18181818181818
85525, 0.8695652173913, 1.55, 0.22727272727273
85526, 0.8695652173913, 1.55, 0.27272727272727
85527, 0.8695652173913, 1.55, 0.31818181818182
85528, 0.8695652173913, 1.55, 0.36363636363636
85529, 0.8695652173913, 1.55, 0.40909090909091
85530, 0.8695652173913, 1.55, 0.45454545454545
85531, 0.82608695652174, 1.55, 0.045454545454545
85532, 0.82608695652174, 1.55, 0.090909090909091
85533, 0.82608695652174, 1.55, 0.13636363636364
85534, 0.82608695652174, 1.55, 0.18181818181818
85535, 0.82608695652174, 1.55, 0.22727272727273
85536, 0.82608695652174, 1.55, 0.27272727272727
85537, 0.82608695652174, 1.55, 0.31818181818182
85538, 0.82608695652174, 1.55, 0.36363636363636
85539, 0.82608695652174, 1.55, 0.40909090909091
85540, 0.82608695652174, 1.55, 0.45454545454545
85541, 0.78260869565217, 1.55, 0.045454545454545
85542, 0.78260869565217, 1.55, 0.090909090909091
85543, 0.78260869565217, 1.55, 0.13636363636364
85544, 0.78260869565217, 1.55, 0.18181818181818
85545, 0.78260869565217, 1.55, 0.22727272727273
85546, 0.78260869565217, 1.55, 0.27272727272727
85547, 0.78260869565217, 1.55, 0.31818181818182
85548, 0.78260869565217, 1.55, 0.36363636363636
85549, 0.78260869565217, 1.55, 0.40909090909091
85550, 0.78260869565217, 1.55, 0.45454545454545
85551, 0.73913043478261, 1.55, 0.045454545454545
85552, 0.73913043478261, 1.55, 0.090909090909091
85553, 0.73913043478261, 1.55, 0.13636363636364
85554, 0.73913043478261, 1.55, 0.18181818181818
85555, 0.73913043478261, 1.55, 0.22727272727273
85556, 0.73913043478261, 1.55, 0.27272727272727
85557, 0.73913043478261, 1.55, 0.31818181818182
85558, 0.73913043478261, 1.55, 0.36363636363636
85559, 0.73913043478261, 1.55, 0.40909090909091
85560, 0.73913043478261, 1.55, 0.45454545454545
85561, 0.69565217391304, 1.55, 0.045454545454545
85562, 0.69565217391304, 1.55, 0.090909090909091
85563, 0.69565217391304, 1.55, 0.13636363636364
85564, 0.69565217391304, 1.55, 0.18181818181818
85565, 0.69565217391304, 1.55, 0.22727272727273
85566, 0.69565217391304, 1.55, 0.27272727272727
85567, 0.69565217391304, 1.55, 0.31818181818182
85568, 0.69565217391304, 1.55, 0.36363636363636
85569, 0.69565217391304, 1.55, 0.40909090909091
85570, 0.69565217391304, 1.55, 0.45454545454545
85571, 0.65217391304348, 1.55, 0.045454545454545
85572, 0.65217391304348, 1.55, 0.090909090909091
85573, 0.65217391304348, 1.55, 0.13636363636364
85574, 0.65217391304348, 1.55, 0.18181818181818
85575, 0.65217391304348, 1.55, 0.22727272727273
85576, 0.65217391304348, 1.55, 0.27272727272727
85577, 0.65217391304348, 1.55, 0.31818181818182
85578, 0.65217391304348, 1.55, 0.36363636363636
85579, 0.65217391304348, 1.55, 0.40909090909091
85580, 0.65217391304348, 1.55, 0.45454545454545
85581, 0.60869565217391, 1.55, 0.045454545454545
85582, 0.60869565217391, 1.55, 0.090909090909091
85583, 0.60869565217391, 1.55, 0.13636363636364
85584, 0.60869565217391, 1.55, 0.18181818181818
85585, 0.60869565217391, 1.55, 0.22727272727273
85586, 0.60869565217391, 1.55, 0.27272727272727
85587, 0.60869565217391, 1.55, 0.31818181818182
85588, 0.60869565217391, 1.55, 0.36363636363636
85589, 0.60869565217391, 1.55, 0.40909090909091
85590, 0.60869565217391, 1.55, 0.45454545454545
85591, 0.56521739130435, 1.55, 0.045454545454545
85592, 0.56521739130435, 1.55, 0.090909090909091
85593, 0.56521739130435, 1.55, 0.13636363636364
85594, 0.56521739130435, 1.55, 0.18181818181818
85595, 0.56521739130435, 1.55, 0.22727272727273
85596, 0.56521739130435, 1.55, 0.27272727272727
85597, 0.56521739130435, 1.55, 0.31818181818182
85598, 0.56521739130435, 1.55, 0.36363636363636
85599, 0.56521739130435, 1.55, 0.40909090909091
85600, 0.56521739130435, 1.55, 0.45454545454545
85601, 0.52173913043478, 1.55, 0.045454545454545
85602, 0.52173913043478, 1.55, 0.090909090909091
85603, 0.52173913043478, 1.55, 0.13636363636364
85604, 0.52173913043478, 1.55, 0.18181818181818
85605, 0.52173913043478, 1.55, 0.22727272727273
85606, 0.52173913043478, 1.55, 0.27272727272727
85607, 0.52173913043478, 1.55, 0.31818181818182
85608, 0.52173913043478, 1.55, 0.36363636363636
85609, 0.52173913043478, 1.55, 0.40909090909091
85610, 0.52173913043478, 1.55, 0.45454545454545
85611, 0.47826086956522, 1.55, 0.045454545454545
85612, 0.47826086956522, 1.55, 0.090909090909091
85613, 0.47826086956522, 1.55, 0.13636363636364
85614, 0.47826086956522, 1.55, 0.18181818181818
85615, 0.47826086956522, 1.55, 0.22727272727273
85616, 0.47826086956522, 1.55, 0.27272727272727
85617, 0.47826086956522, 1.55, 0.31818181818182
85618, 0.47826086956522, 1.55, 0.36363636363636
85619, 0.47826086956522, 1.55, 0.40909090909091
85620, 0.47826086956522, 1.55, 0.45454545454545
85621, 0.43478260869565, 1.55, 0.045454545454545
85622, 0.43478260869565, 1.55, 0.090909090909091
85623, 0.43478260869565, 1.55, 0.13636363636364
85624, 0.43478260869565, 1.55, 0.18181818181818
85625, 0.43478260869565, 1.55, 0.22727272727273
85626, 0.43478260869565, 1.55, 0.27272727272727
85627, 0.43478260869565, 1.55, 0.31818181818182
85628, 0.43478260869565, 1.55, 0.36363636363636
85629, 0.43478260869565, 1.55, 0.40909090909091
85630, 0.43478260869565, 1.55, 0.45454545454545
85631, 0.39130434782609, 1.55, 0.045454545454545
85632, 0.39130434782609, 1.55, 0.090909090909091
85633, 0.39130434782609, 1.55, 0.13636363636364
85634, 0.39130434782609, 1.55, 0.18181818181818
85635, 0.39130434782609, 1.55, 0.22727272727273
85636, 0.39130434782609, 1.55, 0.27272727272727
85637, 0.39130434782609, 1.55, 0.31818181818182
85638, 0.39130434782609, 1.55, 0.36363636363636
85639, 0.39130434782609, 1.55, 0.40909090909091
85640, 0.39130434782609, 1.55, 0.45454545454545
85641, 0.34782608695652, 1.55, 0.045454545454545
85642, 0.34782608695652, 1.55, 0.090909090909091
85643, 0.34782608695652, 1.55, 0.13636363636364
85644, 0.34782608695652, 1.55, 0.18181818181818
85645, 0.34782608695652, 1.55, 0.22727272727273
85646, 0.34782608695652, 1.55, 0.27272727272727
85647, 0.34782608695652, 1.55, 0.31818181818182
85648, 0.34782608695652, 1.55, 0.36363636363636
85649, 0.34782608695652, 1.55, 0.40909090909091
85650, 0.34782608695652, 1.55, 0.45454545454545
85651, 0.30434782608696, 1.55, 0.045454545454545
85652, 0.30434782608696, 1.55, 0.090909090909091
85653, 0.30434782608696, 1.55, 0.13636363636364
85654, 0.30434782608696, 1.55, 0.18181818181818
85655, 0.30434782608696, 1.55, 0.22727272727273
85656, 0.30434782608696, 1.55, 0.27272727272727
85657, 0.30434782608696, 1.55, 0.31818181818182
85658, 0.30434782608696, 1.55, 0.36363636363636
85659, 0.30434782608696, 1.55, 0.40909090909091
85660, 0.30434782608696, 1.55, 0.45454545454545
85661, 0.26086956521739, 1.55, 0.045454545454545
85662, 0.26086956521739, 1.55, 0.090909090909091
85663, 0.26086956521739, 1.55, 0.13636363636364
85664, 0.26086956521739, 1.55, 0.18181818181818
85665, 0.26086956521739, 1.55, 0.22727272727273
85666, 0.26086956521739, 1.55, 0.27272727272727
85667, 0.26086956521739, 1.55, 0.31818181818182
85668, 0.26086956521739, 1.55, 0.36363636363636
85669, 0.26086956521739, 1.55, 0.40909090909091
85670, 0.26086956521739, 1.55, 0.45454545454545
85671, 0.21739130434783, 1.55, 0.045454545454545
85672, 0.21739130434783, 1.55, 0.090909090909091
85673, 0.21739130434783, 1.55, 0.13636363636364
85674, 0.21739130434783, 1.55, 0.18181818181818
85675, 0.21739130434783, 1.55, 0.22727272727273
85676, 0.21739130434783, 1.55, 0.27272727272727
85677, 0.21739130434783, 1.55, 0.31818181818182
85678, 0.21739130434783, 1.55, 0.36363636363636
85679, 0.21739130434783, 1.55, 0.40909090909091
85680, 0.21739130434783, 1.55, 0.45454545454545
85681, 0.17391304347826, 1.55, 0.045454545454545
85682, 0.17391304347826, 1.55, 0.090909090909091
85683, 0.17391304347826, 1.55, 0.13636363636364
85684, 0.17391304347826, 1.55, 0.18181818181818
85685, 0.17391304347826, 1.55, 0.22727272727273
85686, 0.17391304347826, 1.55, 0.27272727272727
85687, 0.17391304347826, 1.55, 0.31818181818182
85688, 0.17391304347826, 1.55, 0.36363636363636
85689, 0.17391304347826, 1.55, 0.40909090909091
85690, 0.17391304347826, 1.55, 0.45454545454545
85691, 0.1304347826087, 1.55, 0.045454545454545
85692, 0.1304347826087, 1.55, 0.090909090909091
85693, 0.1304347826087, 1.55, 0.13636363636364
85694, 0.1304347826087, 1.55, 0.18181818181818
85695, 0.1304347826087, 1.55, 0.22727272727273
85696, 0.1304347826087, 1.55, 0.27272727272727
85697, 0.1304347826087, 1.55, 0.31818181818182
85698, 0.1304347826087, 1.55, 0.36363636363636
85699, 0.1304347826087, 1.55, 0.40909090909091
85700, 0.1304347826087, 1.55, 0.45454545454545
85701, 0.08695652173913, 1.55, 0.045454545454545
85702, 0.08695652173913, 1.55, 0.090909090909091
85703, 0.08695652173913, 1.55, 0.13636363636364
85704, 0.08695652173913, 1.55, 0.18181818181818
85705, 0.08695652173913, 1.55, 0.22727272727273
85706, 0.08695652173913, 1.55, 0.27272727272727
85707, 0.08695652173913, 1.55, 0.31818181818182
85708, 0.08695652173913, 1.55, 0.36363636363636
85709, 0.08695652173913, 1.55, 0.40909090909091
85710, 0.08695652173913, 1.55, 0.45454545454545
85711, 0.043478260869565, 1.55, 0.045454545454545
85712, 0.043478260869565, 1.55, 0.090909090909091
85713, 0.043478260869565, 1.55, 0.13636363636364
85714, 0.043478260869565, 1.55, 0.18181818181818
85715, 0.043478260869565, 1.55, 0.22727272727273
85716, 0.043478260869565, 1.55, 0.27272727272727
85717, 0.043478260869565, 1.55, 0.31818181818182
85718, 0.043478260869565, 1.55, 0.36363636363636
85719, 0.043478260869565, 1.55, 0.40909090909091
85720, 0.043478260869565, 1.55, 0.45454545454545
85721, 0.95652173913043, 1.6, 0.045454545454545
85722, 0.95652173913043, 1.6, 0.090909090909091
85723, 0.95652173913043, 1.6, 0.13636363636364
85724, 0.95652173913043, 1.6, 0.18181818181818
85725, 0.95652173913043, 1.6, 0.22727272727273
85726, 0.95652173913044, 1.6, 0.27272727272727
85727, 0.95652173913043, 1.6, 0.31818181818182
85728, 0.95652173913043, 1.6, 0.36363636363636
85729, 0.95652173913043, 1.6, 0.40909090909091
85730, 0.95652173913044, 1.6, 0.45454545454545
85731, 0.91304347826087, 1.6, 0.045454545454545
85732, 0.91304347826087, 1.6, 0.090909090909091
85733, 0.91304347826087, 1.6, 0.13636363636364
85734, 0.91304347826087, 1.6, 0.18181818181818
85735, 0.91304347826087, 1.6, 0.22727272727273
85736, 0.91304347826087, 1.6, 0.27272727272727
85737, 0.91304347826087, 1.6, 0.31818181818182
85738, 0.91304347826087, 1.6, 0.36363636363636
85739, 0.91304347826087, 1.6, 0.40909090909091
85740, 0.91304347826087, 1.6, 0.45454545454545
85741, 0.8695652173913, 1.6, 0.045454545454545
85742, 0.8695652173913, 1.6, 0.090909090909091
85743, 0.8695652173913, 1.6, 0.13636363636364
85744, 0.8695652173913, 1.6, 0.18181818181818
85745, 0.8695652173913, 1.6, 0.22727272727273
85746, 0.8695652173913, 1.6, 0.27272727272727
85747, 0.8695652173913, 1.6, 0.31818181818182
85748, 0.8695652173913, 1.6, 0.36363636363636
85749, 0.8695652173913, 1.6, 0.40909090909091
85750, 0.8695652173913, 1.6, 0.45454545454545
85751, 0.82608695652174, 1.6, 0.045454545454545
85752, 0.82608695652174, 1.6, 0.090909090909091
85753, 0.82608695652174, 1.6, 0.13636363636364
85754, 0.82608695652174, 1.6, 0.18181818181818
85755, 0.82608695652174, 1.6, 0.22727272727273
85756, 0.82608695652174, 1.6, 0.27272727272727
85757, 0.82608695652174, 1.6, 0.31818181818182
85758, 0.82608695652174, 1.6, 0.36363636363636
85759, 0.82608695652174, 1.6, 0.40909090909091
85760, 0.82608695652174, 1.6, 0.45454545454545
85761, 0.78260869565217, 1.6, 0.045454545454545
85762, 0.78260869565217, 1.6, 0.090909090909091
85763, 0.78260869565217, 1.6, 0.13636363636364
85764, 0.78260869565217, 1.6, 0.18181818181818
85765, 0.78260869565217, 1.6, 0.22727272727273
85766, 0.78260869565217, 1.6, 0.27272727272727
85767, 0.78260869565217, 1.6, 0.31818181818182
85768, 0.78260869565217, 1.6, 0.36363636363636
85769, 0.78260869565217, 1.6, 0.40909090909091
85770, 0.78260869565217, 1.6, 0.45454545454545
85771, 0.73913043478261, 1.6, 0.045454545454545
85772, 0.73913043478261, 1.6, 0.090909090909091
85773, 0.73913043478261, 1.6, 0.13636363636364
85774, 0.73913043478261, 1.6, 0.18181818181818
85775, 0.73913043478261, 1.6, 0.22727272727273
85776, 0.73913043478261, 1.6, 0.27272727272727
85777, 0.73913043478261, 1.6, 0.31818181818182
85778, 0.73913043478261, 1.6, 0.36363636363636
85779, 0.73913043478261, 1.6, 0.40909090909091
85780, 0.73913043478261, 1.6, 0.45454545454545
85781, 0.69565217391304, 1.6, 0.045454545454545
85782, 0.69565217391304, 1.6, 0.090909090909091
85783, 0.69565217391304, 1.6, 0.13636363636364
85784, 0.69565217391304, 1.6, 0.18181818181818
85785, 0.69565217391304, 1.6, 0.22727272727273
85786, 0.69565217391304, 1.6, 0.27272727272727
85787, 0.69565217391304, 1.6, 0.31818181818182
85788, 0.69565217391304, 1.6, 0.36363636363636
85789, 0.69565217391304, 1.6, 0.40909090909091
85790, 0.69565217391304, 1.6, 0.45454545454545
85791, 0.65217391304348, 1.6, 0.045454545454545
85792, 0.65217391304348, 1.6, 0.090909090909091
85793, 0.65217391304348, 1.6, 0.13636363636364
85794, 0.65217391304348, 1.6, 0.18181818181818
85795, 0.65217391304348, 1.6, 0.22727272727273
85796, 0.65217391304348, 1.6, 0.27272727272727
85797, 0.65217391304348, 1.6, 0.31818181818182
85798, 0.65217391304348, 1.6, 0.36363636363636
85799, 0.65217391304348, 1.6, 0.40909090909091
85800, 0.65217391304348, 1.6, 0.45454545454545
85801, 0.60869565217391, 1.6, 0.045454545454545
85802, 0.60869565217391, 1.6, 0.090909090909091
85803, 0.60869565217391, 1.6, 0.13636363636364
85804, 0.60869565217391, 1.6, 0.18181818181818
85805, 0.60869565217391, 1.6, 0.22727272727273
85806, 0.60869565217391, 1.6, 0.27272727272727
85807, 0.60869565217391, 1.6, 0.31818181818182
85808, 0.60869565217391, 1.6, 0.36363636363636
85809, 0.60869565217391, 1.6, 0.40909090909091
85810, 0.60869565217391, 1.6, 0.45454545454545
85811, 0.56521739130435, 1.6, 0.045454545454545
85812, 0.56521739130435, 1.6, 0.090909090909091
85813, 0.56521739130435, 1.6, 0.13636363636364
85814, 0.56521739130435, 1.6, 0.18181818181818
85815, 0.56521739130435, 1.6, 0.22727272727273
85816, 0.56521739130435, 1.6, 0.27272727272727
85817, 0.56521739130435, 1.6, 0.31818181818182
85818, 0.56521739130435, 1.6, 0.36363636363636
85819, 0.56521739130435, 1.6, 0.40909090909091
85820, 0.56521739130435, 1.6, 0.45454545454545
85821, 0.52173913043478, 1.6, 0.045454545454545
85822, 0.52173913043478, 1.6, 0.090909090909091
85823, 0.52173913043478, 1.6, 0.13636363636364
85824, 0.52173913043478, 1.6, 0.18181818181818
85825, 0.52173913043478, 1.6, 0.22727272727273
85826, 0.52173913043478, 1.6, 0.27272727272727
85827, 0.52173913043478, 1.6, 0.31818181818182
85828, 0.52173913043478, 1.6, 0.36363636363636
85829, 0.52173913043478, 1.6, 0.40909090909091
85830, 0.52173913043478, 1.6, 0.45454545454545
85831, 0.47826086956522, 1.6, 0.045454545454545
85832, 0.47826086956522, 1.6, 0.090909090909091
85833, 0.47826086956522, 1.6, 0.13636363636364
85834, 0.47826086956522, 1.6, 0.18181818181818
85835, 0.47826086956522, 1.6, 0.22727272727273
85836, 0.47826086956522, 1.6, 0.27272727272727
85837, 0.47826086956522, 1.6, 0.31818181818182
85838, 0.47826086956522, 1.6, 0.36363636363636
85839, 0.47826086956522, 1.6, 0.40909090909091
85840, 0.47826086956522, 1.6, 0.45454545454545
85841, 0.43478260869565, 1.6, 0.045454545454545
85842, 0.43478260869565, 1.6, 0.090909090909091
85843, 0.43478260869565, 1.6, 0.13636363636364
85844, 0.43478260869565, 1.6, 0.18181818181818
85845, 0.43478260869565, 1.6, 0.22727272727273
85846, 0.43478260869565, 1.6, 0.27272727272727
85847, 0.43478260869565, 1.6, 0.31818181818182
85848, 0.43478260869565, 1.6, 0.36363636363636
85849, 0.43478260869565, 1.6, 0.40909090909091
85850, 0.43478260869565, 1.6, 0.45454545454545
85851, 0.39130434782609, 1.6, 0.045454545454545
85852, 0.39130434782609, 1.6, 0.090909090909091
85853, 0.39130434782609, 1.6, 0.13636363636364
85854, 0.39130434782609, 1.6, 0.18181818181818
85855, 0.39130434782609, 1.6, 0.22727272727273
85856, 0.39130434782609, 1.6, 0.27272727272727
85857, 0.39130434782609, 1.6, 0.31818181818182
85858, 0.39130434782609, 1.6, 0.36363636363636
85859, 0.39130434782609, 1.6, 0.40909090909091
85860, 0.39130434782609, 1.6, 0.45454545454545
85861, 0.34782608695652, 1.6, 0.045454545454545
85862, 0.34782608695652, 1.6, 0.090909090909091
85863, 0.34782608695652, 1.6, 0.13636363636364
85864, 0.34782608695652, 1.6, 0.18181818181818
85865, 0.34782608695652, 1.6, 0.22727272727273
85866, 0.34782608695652, 1.6, 0.27272727272727
85867, 0.34782608695652, 1.6, 0.31818181818182
85868, 0.34782608695652, 1.6, 0.36363636363636
85869, 0.34782608695652, 1.6, 0.40909090909091
85870, 0.34782608695652, 1.6, 0.45454545454545
85871, 0.30434782608696, 1.6, 0.045454545454545
85872, 0.30434782608696, 1.6, 0.090909090909091
85873, 0.30434782608696, 1.6, 0.13636363636364
85874, 0.30434782608696, 1.6, 0.18181818181818
85875, 0.30434782608696, 1.6, 0.22727272727273
85876, 0.30434782608696, 1.6, 0.27272727272727
85877, 0.30434782608696, 1.6, 0.31818181818182
85878, 0.30434782608696, 1.6, 0.36363636363636
85879, 0.30434782608696, 1.6, 0.40909090909091
85880, 0.30434782608696, 1.6, 0.45454545454545
85881, 0.26086956521739, 1.6, 0.045454545454545
85882, 0.26086956521739, 1.6, 0.090909090909091
85883, 0.26086956521739, 1.6, 0.13636363636364
85884, 0.26086956521739, 1.6, 0.18181818181818
85885, 0.26086956521739, 1.6, 0.22727272727273
85886, 0.26086956521739, 1.6, 0.27272727272727
85887, 0.26086956521739, 1.6, 0.31818181818182
85888, 0.26086956521739, 1.6, 0.36363636363636
85889, 0.26086956521739, 1.6, 0.40909090909091
85890, 0.26086956521739, 1.6, 0.45454545454545
85891, 0.21739130434783, 1.6, 0.045454545454545
85892, 0.21739130434783, 1.6, 0.090909090909091
85893, 0.21739130434783, 1.6, 0.13636363636364
85894, 0.21739130434783, 1.6, 0.18181818181818
85895, 0.21739130434783, 1.6, 0.22727272727273
85896, 0.21739130434783, 1.6, 0.27272727272727
85897, 0.21739130434783, 1.6, 0.31818181818182
85898, 0.21739130434783, 1.6, 0.36363636363636
85899, 0.21739130434783, 1.6, 0.40909090909091
85900, 0.21739130434783, 1.6, 0.45454545454545
85901, 0.17391304347826, 1.6, 0.045454545454545
85902, 0.17391304347826, 1.6, 0.090909090909091
85903, 0.17391304347826, 1.6, 0.13636363636364
85904, 0.17391304347826, 1.6, 0.18181818181818
85905, 0.17391304347826, 1.6, 0.22727272727273
85906, 0.17391304347826, 1.6, 0.27272727272727
85907, 0.17391304347826, 1.6, 0.31818181818182
85908, 0.17391304347826, 1.6, 0.36363636363636
85909, 0.17391304347826, 1.6, 0.40909090909091
85910, 0.17391304347826, 1.6, 0.45454545454545
85911, 0.1304347826087, 1.6, 0.045454545454545
85912, 0.1304347826087, 1.6, 0.090909090909091
85913, 0.1304347826087, 1.6, 0.13636363636364
85914, 0.1304347826087, 1.6, 0.18181818181818
85915, 0.1304347826087, 1.6, 0.22727272727273
85916, 0.1304347826087, 1.6, 0.27272727272727
85917, 0.1304347826087, 1.6, 0.31818181818182
85918, 0.1304347826087, 1.6, 0.36363636363636
85919, 0.1304347826087, 1.6, 0.40909090909091
85920, 0.1304347826087, 1.6, 0.45454545454545
85921, 0.08695652173913, 1.6, 0.045454545454545
85922, 0.08695652173913, 1.6, 0.090909090909091
85923, 0.08695652173913, 1.6, 0.13636363636364
85924, 0.08695652173913, 1.6, 0.18181818181818
85925, 0.08695652173913, 1.6, 0.22727272727273
85926, 0.08695652173913, 1.6, 0.27272727272727
85927, 0.08695652173913, 1.6, 0.31818181818182
85928, 0.08695652173913, 1.6, 0.36363636363636
85929, 0.08695652173913, 1.6, 0.40909090909091
85930, 0.08695652173913, 1.6, 0.45454545454545
85931, 0.043478260869565, 1.6, 0.045454545454545
85932, 0.043478260869565, 1.6, 0.090909090909091
85933, 0.043478260869565, 1.6, 0.13636363636364
85934, 0.043478260869565, 1.6, 0.18181818181818
85935, 0.043478260869565, 1.6, 0.22727272727273
85936, 0.043478260869565, 1.6, 0.27272727272727
85937, 0.043478260869565, 1.6, 0.31818181818182
85938, 0.043478260869565, 1.6, 0.36363636363636
85939, 0.043478260869565, 1.6, 0.40909090909091
85940, 0.043478260869565, 1.6, 0.45454545454545
85941, 0.95652173913043, 1.65, 0.045454545454545
85942, 0.95652173913043, 1.65, 0.090909090909091
85943, 0.95652173913043, 1.65, 0.13636363636364
85944, 0.95652173913044, 1.65, 0.18181818181818
85945, 0.95652173913044, 1.65, 0.22727272727273
85946, 0.95652173913044, 1.65, 0.27272727272727
85947, 0.95652173913043, 1.65, 0.31818181818182
85948, 0.95652173913043, 1.65, 0.36363636363636
85949, 0.95652173913043, 1.65, 0.40909090909091
85950, 0.95652173913044, 1.65, 0.45454545454545
85951, 0.91304347826087, 1.65, 0.045454545454545
85952, 0.91304347826087, 1.65, 0.090909090909091
85953, 0.91304347826087, 1.65, 0.13636363636364
85954, 0.91304347826087, 1.65, 0.18181818181818
85955, 0.91304347826087, 1.65, 0.22727272727273
85956, 0.91304347826087, 1.65, 0.27272727272727
85957, 0.91304347826087, 1.65, 0.31818181818182
85958, 0.91304347826087, 1.65, 0.36363636363636
85959, 0.91304347826087, 1.65, 0.40909090909091
85960, 0.91304347826087, 1.65, 0.45454545454545
85961, 0.8695652173913, 1.65, 0.045454545454545
85962, 0.8695652173913, 1.65, 0.090909090909091
85963, 0.8695652173913, 1.65, 0.13636363636364
85964, 0.8695652173913, 1.65, 0.18181818181818
85965, 0.8695652173913, 1.65, 0.22727272727273
85966, 0.8695652173913, 1.65, 0.27272727272727
85967, 0.8695652173913, 1.65, 0.31818181818182
85968, 0.8695652173913, 1.65, 0.36363636363636
85969, 0.8695652173913, 1.65, 0.40909090909091
85970, 0.8695652173913, 1.65, 0.45454545454545
85971, 0.82608695652174, 1.65, 0.045454545454545
85972, 0.82608695652174, 1.65, 0.090909090909091
85973, 0.82608695652174, 1.65, 0.13636363636364
85974, 0.82608695652174, 1.65, 0.18181818181818
85975, 0.82608695652174, 1.65, 0.22727272727273
85976, 0.82608695652174, 1.65, 0.27272727272727
85977, 0.82608695652174, 1.65, 0.31818181818182
85978, 0.82608695652174, 1.65, 0.36363636363636
85979, 0.82608695652174, 1.65, 0.40909090909091
85980, 0.82608695652174, 1.65, 0.45454545454545
85981, 0.78260869565217, 1.65, 0.045454545454545
85982, 0.78260869565217, 1.65, 0.090909090909091
85983, 0.78260869565217, 1.65, 0.13636363636364
85984, 0.78260869565217, 1.65, 0.18181818181818
85985, 0.78260869565217, 1.65, 0.22727272727273
85986, 0.78260869565217, 1.65, 0.27272727272727
85987, 0.78260869565217, 1.65, 0.31818181818182
85988, 0.78260869565217, 1.65, 0.36363636363636
85989, 0.78260869565217, 1.65, 0.40909090909091
85990, 0.78260869565217, 1.65, 0.45454545454545
85991, 0.73913043478261, 1.65, 0.045454545454545
85992, 0.73913043478261, 1.65, 0.090909090909091
85993, 0.73913043478261, 1.65, 0.13636363636364
85994, 0.73913043478261, 1.65, 0.18181818181818
85995, 0.73913043478261, 1.65, 0.22727272727273
85996, 0.73913043478261, 1.65, 0.27272727272727
85997, 0.73913043478261, 1.65, 0.31818181818182
85998, 0.73913043478261, 1.65, 0.36363636363636
85999, 0.73913043478261, 1.65, 0.40909090909091
86000, 0.73913043478261, 1.65, 0.45454545454545
86001, 0.69565217391304, 1.65, 0.045454545454545
86002, 0.69565217391304, 1.65, 0.090909090909091
86003, 0.69565217391304, 1.65, 0.13636363636364
86004, 0.69565217391304, 1.65, 0.18181818181818
86005, 0.69565217391304, 1.65, 0.22727272727273
86006, 0.69565217391304, 1.65, 0.27272727272727
86007, 0.69565217391304, 1.65, 0.31818181818182
86008, 0.69565217391304, 1.65, 0.36363636363636
86009, 0.69565217391304, 1.65, 0.40909090909091
86010, 0.69565217391304, 1.65, 0.45454545454545
86011, 0.65217391304348, 1.65, 0.045454545454545
86012, 0.65217391304348, 1.65, 0.090909090909091
86013, 0.65217391304348, 1.65, 0.13636363636364
86014, 0.65217391304348, 1.65, 0.18181818181818
86015, 0.65217391304348, 1.65, 0.22727272727273
86016, 0.65217391304348, 1.65, 0.27272727272727
86017, 0.65217391304348, 1.65, 0.31818181818182
86018, 0.65217391304348, 1.65, 0.36363636363636
86019, 0.65217391304348, 1.65, 0.40909090909091
86020, 0.65217391304348, 1.65, 0.45454545454545
86021, 0.60869565217391, 1.65, 0.045454545454545
86022, 0.60869565217391, 1.65, 0.090909090909091
86023, 0.60869565217391, 1.65, 0.13636363636364
86024, 0.60869565217391, 1.65, 0.18181818181818
86025, 0.60869565217391, 1.65, 0.22727272727273
86026, 0.60869565217391, 1.65, 0.27272727272727
86027, 0.60869565217391, 1.65, 0.31818181818182
86028, 0.60869565217391, 1.65, 0.36363636363636
86029, 0.60869565217391, 1.65, 0.40909090909091
86030, 0.60869565217391, 1.65, 0.45454545454545
86031, 0.56521739130435, 1.65, 0.045454545454545
86032, 0.56521739130435, 1.65, 0.090909090909091
86033, 0.56521739130435, 1.65, 0.13636363636364
86034, 0.56521739130435, 1.65, 0.18181818181818
86035, 0.56521739130435, 1.65, 0.22727272727273
86036, 0.56521739130435, 1.65, 0.27272727272727
86037, 0.56521739130435, 1.65, 0.31818181818182
86038, 0.56521739130435, 1.65, 0.36363636363636
86039, 0.56521739130435, 1.65, 0.40909090909091
86040, 0.56521739130435, 1.65, 0.45454545454545
86041, 0.52173913043478, 1.65, 0.045454545454545
86042, 0.52173913043478, 1.65, 0.090909090909091
86043, 0.52173913043478, 1.65, 0.13636363636364
86044, 0.52173913043478, 1.65, 0.18181818181818
86045, 0.52173913043478, 1.65, 0.22727272727273
86046, 0.52173913043478, 1.65, 0.27272727272727
86047, 0.52173913043478, 1.65, 0.31818181818182
86048, 0.52173913043478, 1.65, 0.36363636363636
86049, 0.52173913043478, 1.65, 0.40909090909091
86050, 0.52173913043478, 1.65, 0.45454545454545
86051, 0.47826086956522, 1.65, 0.045454545454545
86052, 0.47826086956522, 1.65, 0.090909090909091
86053, 0.47826086956522, 1.65, 0.13636363636364
86054, 0.47826086956522, 1.65, 0.18181818181818
86055, 0.47826086956522, 1.65, 0.22727272727273
86056, 0.47826086956522, 1.65, 0.27272727272727
86057, 0.47826086956522, 1.65, 0.31818181818182
86058, 0.47826086956522, 1.65, 0.36363636363636
86059, 0.47826086956522, 1.65, 0.40909090909091
86060, 0.47826086956522, 1.65, 0.45454545454545
86061, 0.43478260869565, 1.65, 0.045454545454545
86062, 0.43478260869565, 1.65, 0.090909090909091
86063, 0.43478260869565, 1.65, 0.13636363636364
86064, 0.43478260869565, 1.65, 0.18181818181818
86065, 0.43478260869565, 1.65, 0.22727272727273
86066, 0.43478260869565, 1.65, 0.27272727272727
86067, 0.43478260869565, 1.65, 0.31818181818182
86068, 0.43478260869565, 1.65, 0.36363636363636
86069, 0.43478260869565, 1.65, 0.40909090909091
86070, 0.43478260869565, 1.65, 0.45454545454545
86071, 0.39130434782609, 1.65, 0.045454545454545
86072, 0.39130434782609, 1.65, 0.090909090909091
86073, 0.39130434782609, 1.65, 0.13636363636364
86074, 0.39130434782609, 1.65, 0.18181818181818
86075, 0.39130434782609, 1.65, 0.22727272727273
86076, 0.39130434782609, 1.65, 0.27272727272727
86077, 0.39130434782609, 1.65, 0.31818181818182
86078, 0.39130434782609, 1.65, 0.36363636363636
86079, 0.39130434782609, 1.65, 0.40909090909091
86080, 0.39130434782609, 1.65, 0.45454545454545
86081, 0.34782608695652, 1.65, 0.045454545454545
86082, 0.34782608695652, 1.65, 0.090909090909091
86083, 0.34782608695652, 1.65, 0.13636363636364
86084, 0.34782608695652, 1.65, 0.18181818181818
86085, 0.34782608695652, 1.65, 0.22727272727273
86086, 0.34782608695652, 1.65, 0.27272727272727
86087, 0.34782608695652, 1.65, 0.31818181818182
86088, 0.34782608695652, 1.65, 0.36363636363636
86089, 0.34782608695652, 1.65, 0.40909090909091
86090, 0.34782608695652, 1.65, 0.45454545454545
86091, 0.30434782608696, 1.65, 0.045454545454545
86092, 0.30434782608696, 1.65, 0.090909090909091
86093, 0.30434782608696, 1.65, 0.13636363636364
86094, 0.30434782608696, 1.65, 0.18181818181818
86095, 0.30434782608696, 1.65, 0.22727272727273
86096, 0.30434782608696, 1.65, 0.27272727272727
86097, 0.30434782608696, 1.65, 0.31818181818182
86098, 0.30434782608696, 1.65, 0.36363636363636
86099, 0.30434782608696, 1.65, 0.40909090909091
86100, 0.30434782608696, 1.65, 0.45454545454545
86101, 0.26086956521739, 1.65, 0.045454545454545
86102, 0.26086956521739, 1.65, 0.090909090909091
86103, 0.26086956521739, 1.65, 0.13636363636364
86104, 0.26086956521739, 1.65, 0.18181818181818
86105, 0.26086956521739, 1.65, 0.22727272727273
86106, 0.26086956521739, 1.65, 0.27272727272727
86107, 0.26086956521739, 1.65, 0.31818181818182
86108, 0.26086956521739, 1.65, 0.36363636363636
86109, 0.26086956521739, 1.65, 0.40909090909091
86110, 0.26086956521739, 1.65, 0.45454545454545
86111, 0.21739130434783, 1.65, 0.045454545454545
86112, 0.21739130434783, 1.65, 0.090909090909091
86113, 0.21739130434783, 1.65, 0.13636363636364
86114, 0.21739130434783, 1.65, 0.18181818181818
86115, 0.21739130434783, 1.65, 0.22727272727273
86116, 0.21739130434783, 1.65, 0.27272727272727
86117, 0.21739130434783, 1.65, 0.31818181818182
86118, 0.21739130434783, 1.65, 0.36363636363636
86119, 0.21739130434783, 1.65, 0.40909090909091
86120, 0.21739130434783, 1.65, 0.45454545454545
86121, 0.17391304347826, 1.65, 0.045454545454545
86122, 0.17391304347826, 1.65, 0.090909090909091
86123, 0.17391304347826, 1.65, 0.13636363636364
86124, 0.17391304347826, 1.65, 0.18181818181818
86125, 0.17391304347826, 1.65, 0.22727272727273
86126, 0.17391304347826, 1.65, 0.27272727272727
86127, 0.17391304347826, 1.65, 0.31818181818182
86128, 0.17391304347826, 1.65, 0.36363636363636
86129, 0.17391304347826, 1.65, 0.40909090909091
86130, 0.17391304347826, 1.65, 0.45454545454545
86131, 0.1304347826087, 1.65, 0.045454545454545
86132, 0.1304347826087, 1.65, 0.090909090909091
86133, 0.1304347826087, 1.65, 0.13636363636364
86134, 0.1304347826087, 1.65, 0.18181818181818
86135, 0.1304347826087, 1.65, 0.22727272727273
86136, 0.1304347826087, 1.65, 0.27272727272727
86137, 0.1304347826087, 1.65, 0.31818181818182
86138, 0.1304347826087, 1.65, 0.36363636363636
86139, 0.1304347826087, 1.65, 0.40909090909091
86140, 0.1304347826087, 1.65, 0.45454545454545
86141, 0.08695652173913, 1.65, 0.045454545454545
86142, 0.08695652173913, 1.65, 0.090909090909091
86143, 0.08695652173913, 1.65, 0.13636363636364
86144, 0.08695652173913, 1.65, 0.18181818181818
86145, 0.08695652173913, 1.65, 0.22727272727273
86146, 0.08695652173913, 1.65, 0.27272727272727
86147, 0.08695652173913, 1.65, 0.31818181818182
86148, 0.08695652173913, 1.65, 0.36363636363636
86149, 0.08695652173913, 1.65, 0.40909090909091
86150, 0.08695652173913, 1.65, 0.45454545454545
86151, 0.043478260869565, 1.65, 0.045454545454545
86152, 0.043478260869565, 1.65, 0.090909090909091
86153, 0.043478260869565, 1.65, 0.13636363636364
86154, 0.043478260869565, 1.65, 0.18181818181818
86155, 0.043478260869565, 1.65, 0.22727272727273
86156, 0.043478260869565, 1.65, 0.27272727272727
86157, 0.043478260869565, 1.65, 0.31818181818182
86158, 0.043478260869565, 1.65, 0.36363636363636
86159, 0.043478260869565, 1.65, 0.40909090909091
86160, 0.043478260869565, 1.65, 0.45454545454545
86161, 0.95652173913043, 1.55, 0.022727272727273
86162, 0.97826086956522, 1.55, 0.045454545454545
86163, 0.95652173913043, 1.525, 0.045454545454545
86164, 0.95652173913043, 1.55, 0.068181818181818
86165, 0.97826086956522, 1.55, 0.090909090909091
86166, 0.95652173913043, 1.525, 0.090909090909091
86167, 0.95652173913043, 1.55, 0.11363636363636
86168, 0.97826086956522, 1.55, 0.13636363636364
86169, 0.95652173913043, 1.525, 0.13636363636364
86170, 0.95652173913043, 1.55, 0.15909090909091
86171, 0.97826086956522, 1.55, 0.18181818181818
86172, 0.95652173913043, 1.525, 0.18181818181818
86173, 0.95652173913043, 1.55, 0.20454545454545
86174, 0.97826086956522, 1.55, 0.22727272727273
86175, 0.95652173913043, 1.525, 0.22727272727273
86176, 0.95652173913043, 1.55, 0.25
86177, 0.97826086956522, 1.55, 0.27272727272727
86178, 0.95652173913043, 1.525, 0.27272727272727
86179, 0.95652173913044, 1.55, 0.29545454545455
86180, 0.97826086956522, 1.55, 0.31818181818182
86181, 0.95652173913043, 1.525, 0.31818181818182
86182, 0.95652173913043, 1.55, 0.34090909090909
86183, 0.97826086956522, 1.55, 0.36363636363636
86184, 0.95652173913043, 1.525, 0.36363636363636
86185, 0.95652173913043, 1.55, 0.38636363636364
86186, 0.97826086956522, 1.55, 0.40909090909091
86187, 0.95652173913043, 1.525, 0.40909090909091
86188, 0.95652173913043, 1.55, 0.43181818181818
86189, 0.97826086956522, 1.55, 0.45454545454545
86190, 0.95652173913043, 1.525, 0.45454545454545
86191, 0.95652173913043, 1.55, 0.47727272727273
86192, 0.91304347826087, 1.55, 0.022727272727273
86193, 0.93478260869565, 1.55, 0.045454545454545
86194, 0.91304347826087, 1.525, 0.045454545454545
86195, 0.91304347826087, 1.55, 0.068181818181818
86196, 0.93478260869565, 1.55, 0.090909090909091
86197, 0.91304347826087, 1.525, 0.090909090909091
86198, 0.91304347826087, 1.55, 0.11363636363636
86199, 0.93478260869565, 1.55, 0.13636363636364
86200, 0.91304347826087, 1.525, 0.13636363636364
86201, 0.91304347826087, 1.55, 0.15909090909091
86202, 0.93478260869565, 1.55, 0.18181818181818
86203, 0.91304347826087, 1.525, 0.18181818181818
86204, 0.91304347826087, 1.55, 0.20454545454545
86205, 0.93478260869565, 1.55, 0.22727272727273
86206, 0.91304347826087, 1.525, 0.22727272727273
86207, 0.91304347826087, 1.55, 0.25
86208, 0.93478260869565, 1.55, 0.27272727272727
86209, 0.91304347826087, 1.525, 0.27272727272727
86210, 0.91304347826087, 1.55, 0.29545454545455
86211, 0.93478260869565, 1.55, 0.31818181818182
86212, 0.91304347826087, 1.525, 0.31818181818182
86213, 0.91304347826087, 1.55, 0.34090909090909
86214, 0.93478260869565, 1.55, 0.36363636363636
86215, 0.91304347826087, 1.525, 0.36363636363636
86216, 0.91304347826087, 1.55, 0.38636363636364
86217, 0.93478260869565, 1.55, 0.40909090909091
86218, 0.91304347826087, 1.525, 0.40909090909091
86219, 0.91304347826087, 1.55, 0.43181818181818
86220, 0.93478260869565, 1.55, 0.45454545454545
86221, 0.91304347826087, 1.525, 0.45454545454545
86222, 0.91304347826087, 1.55, 0.47727272727273
86223, 0.8695652173913, 1.55, 0.022727272727273
86224, 0.89130434782609, 1.55, 0.045454545454545
86225, 0.8695652173913, 1.525, 0.045454545454545
86226, 0.8695652173913, 1.55, 0.068181818181818
86227, 0.89130434782609, 1.55, 0.090909090909091
86228, 0.8695652173913, 1.525, 0.090909090909091
86229, 0.8695652173913, 1.55, 0.11363636363636
86230, 0.89130434782609, 1.55, 0.13636363636364
86231, 0.8695652173913, 1.525, 0.13636363636364
86232, 0.8695652173913, 1.55, 0.15909090909091
86233, 0.89130434782609, 1.55, 0.18181818181818
86234, 0.8695652173913, 1.525, 0.18181818181818
86235, 0.8695652173913, 1.55, 0.20454545454545
86236, 0.89130434782609, 1.55, 0.22727272727273
86237, 0.8695652173913, 1.525, 0.22727272727273
86238, 0.8695652173913, 1.55, 0.25
86239, 0.89130434782609, 1.55, 0.27272727272727
86240, 0.8695652173913, 1.525, 0.27272727272727
86241, 0.8695652173913, 1.55, 0.29545454545455
86242, 0.89130434782609, 1.55, 0.31818181818182
86243, 0.8695652173913, 1.525, 0.31818181818182
86244, 0.8695652173913, 1.55, 0.34090909090909
86245, 0.89130434782609, 1.55, 0.36363636363636
86246, 0.8695652173913, 1.525, 0.36363636363636
86247, 0.8695652173913, 1.55, 0.38636363636364
86248, 0.89130434782609, 1.55, 0.40909090909091
86249, 0.8695652173913, 1.525, 0.40909090909091
86250, 0.8695652173913, 1.55, 0.43181818181818
86251, 0.89130434782609, 1.55, 0.45454545454545
86252, 0.8695652173913, 1.525, 0.45454545454545
86253, 0.8695652173913, 1.55, 0.47727272727273
86254, 0.82608695652174, 1.55, 0.022727272727273
86255, 0.84782608695652, 1.55, 0.045454545454545
86256, 0.82608695652174, 1.525, 0.045454545454545
86257, 0.82608695652174, 1.55, 0.068181818181818
86258, 0.84782608695652, 1.55, 0.090909090909091
86259, 0.82608695652174, 1.525, 0.090909090909091
86260, 0.82608695652174, 1.55, 0.11363636363636
86261, 0.84782608695652, 1.55, 0.13636363636364
86262, 0.82608695652174, 1.525, 0.13636363636364
86263, 0.82608695652174, 1.55, 0.15909090909091
86264, 0.84782608695652, 1.55, 0.18181818181818
86265, 0.82608695652174, 1.525, 0.18181818181818
86266, 0.82608695652174, 1.55, 0.20454545454545
86267, 0.84782608695652, 1.55, 0.22727272727273
86268, 0.82608695652174, 1.525, 0.22727272727273
86269, 0.82608695652174, 1.55, 0.25
86270, 0.84782608695652, 1.55, 0.27272727272727
86271, 0.82608695652174, 1.525, 0.27272727272727
86272, 0.82608695652174, 1.55, 0.29545454545455
86273, 0.84782608695652, 1.55, 0.31818181818182
86274, 0.82608695652174, 1.525, 0.31818181818182
86275, 0.82608695652174, 1.55, 0.34090909090909
86276, 0.84782608695652, 1.55, 0.36363636363636
86277, 0.82608695652174, 1.525, 0.36363636363636
86278, 0.82608695652174, 1.55, 0.38636363636364
86279, 0.84782608695652, 1.55, 0.40909090909091
86280, 0.82608695652174, 1.525, 0.40909090909091
86281, 0.82608695652174, 1.55, 0.43181818181818
86282, 0.84782608695652, 1.55, 0.45454545454545
86283, 0.82608695652174, 1.525, 0.45454545454545
86284, 0.82608695652174, 1.55, 0.47727272727273
86285, 0.78260869565217, 1.55, 0.022727272727273
86286, 0.80434782608696, 1.55, 0.045454545454545
86287, 0.78260869565217, 1.525, 0.045454545454545
86288, 0.78260869565217, 1.55, 0.068181818181818
86289, 0.80434782608696, 1.55, 0.090909090909091
86290, 0.78260869565217, 1.525, 0.090909090909091
86291, 0.78260869565217, 1.55, 0.11363636363636
86292, 0.80434782608696, 1.55, 0.13636363636364
86293, 0.78260869565217, 1.525, 0.13636363636364
86294, 0.78260869565217, 1.55, 0.15909090909091
86295, 0.80434782608696, 1.55, 0.18181818181818
86296, 0.78260869565217, 1.525, 0.18181818181818
86297, 0.78260869565217, 1.55, 0.20454545454545
86298, 0.80434782608696, 1.55, 0.22727272727273
86299, 0.78260869565217, 1.525, 0.22727272727273
86300, 0.78260869565217, 1.55, 0.25
86301, 0.80434782608696, 1.55, 0.27272727272727
86302, 0.78260869565217, 1.525, 0.27272727272727
86303, 0.78260869565217, 1.55, 0.29545454545455
86304, 0.80434782608696, 1.55, 0.31818181818182
86305, 0.78260869565217, 1.525, 0.31818181818182
86306, 0.78260869565217, 1.55, 0.34090909090909
86307, 0.80434782608696, 1.55, 0.36363636363636
86308, 0.78260869565217, 1.525, 0.36363636363636
86309, 0.78260869565217, 1.55, 0.38636363636364
86310, 0.80434782608696, 1.55, 0.40909090909091
86311, 0.78260869565217, 1.525, 0.40909090909091
86312, 0.78260869565217, 1.55, 0.43181818181818
86313, 0.80434782608696, 1.55, 0.45454545454545
86314, 0.78260869565217, 1.525, 0.45454545454545
86315, 0.78260869565217, 1.55, 0.47727272727273
86316, 0.73913043478261, 1.55, 0.022727272727273
86317, 0.76086956521739, 1.55, 0.045454545454545
86318, 0.73913043478261, 1.525, 0.045454545454545
86319, 0.73913043478261, 1.55, 0.068181818181818
86320, 0.76086956521739, 1.55, 0.090909090909091
86321, 0.73913043478261, 1.525, 0.090909090909091
86322, 0.73913043478261, 1.55, 0.11363636363636
86323, 0.76086956521739, 1.55, 0.13636363636364
86324, 0.73913043478261, 1.525, 0.13636363636364
86325, 0.73913043478261, 1.55, 0.15909090909091
86326, 0.76086956521739, 1.55, 0.18181818181818
86327, 0.73913043478261, 1.525, 0.18181818181818
86328, 0.73913043478261, 1.55, 0.20454545454545
86329, 0.76086956521739, 1.55, 0.22727272727273
86330, 0.73913043478261, 1.525, 0.22727272727273
86331, 0.73913043478261, 1.55, 0.25
86332, 0.76086956521739, 1.55, 0.27272727272727
86333, 0.73913043478261, 1.525, 0.27272727272727
86334, 0.73913043478261, 1.55, 0.29545454545455
86335, 0.76086956521739, 1.55, 0.31818181818182
86336, 0.73913043478261, 1.525, 0.31818181818182
86337, 0.73913043478261, 1.55, 0.34090909090909
86338, 0.76086956521739, 1.55, 0.36363636363636
86339, 0.73913043478261, 1.525, 0.36363636363636
86340, 0.73913043478261, 1.55, 0.38636363636364
86341, 0.76086956521739, 1.55, 0.40909090909091
86342, 0.73913043478261, 1.525, 0.40909090909091
86343, 0.73913043478261, 1.55, 0.43181818181818
86344, 0.76086956521739, 1.55, 0.45454545454545
86345, 0.73913043478261, 1.525, 0.45454545454545
86346, 0.73913043478261, 1.55, 0.47727272727273
86347, 0.69565217391304, 1.55, 0.022727272727273
86348, 0.71739130434783, 1.55, 0.045454545454545
86349, 0.69565217391304, 1.525, 0.045454545454545
86350, 0.69565217391304, 1.55, 0.068181818181818
86351, 0.71739130434783, 1.55, 0.090909090909091
86352, 0.69565217391304, 1.525, 0.090909090909091
86353, 0.69565217391304, 1.55, 0.11363636363636
86354, 0.71739130434783, 1.55, 0.13636363636364
86355, 0.69565217391304, 1.525, 0.13636363636364
86356, 0.69565217391304, 1.55, 0.15909090909091
86357, 0.71739130434783, 1.55, 0.18181818181818
86358, 0.69565217391304, 1.525, 0.18181818181818
86359, 0.69565217391304, 1.55, 0.20454545454545
86360, 0.71739130434783, 1.55, 0.22727272727273
86361, 0.69565217391304, 1.525, 0.22727272727273
86362, 0.69565217391304, 1.55, 0.25
86363, 0.71739130434783, 1.55, 0.27272727272727
86364, 0.69565217391304, 1.525, 0.27272727272727
86365, 0.69565217391304, 1.55, 0.29545454545455
86366, 0.71739130434783, 1.55, 0.31818181818182
86367, 0.69565217391304, 1.525, 0.31818181818182
86368, 0.69565217391304, 1.55, 0.34090909090909
86369, 0.71739130434783, 1.55, 0.36363636363636
86370, 0.69565217391304, 1.525, 0.36363636363636
86371, 0.69565217391304, 1.55, 0.38636363636364
86372, 0.71739130434783, 1.55, 0.40909090909091
86373, 0.69565217391304, 1.525, 0.40909090909091
86374, 0.69565217391304, 1.55, 0.43181818181818
86375, 0.71739130434783, 1.55, 0.45454545454545
86376, 0.69565217391304, 1.525, 0.45454545454545
86377, 0.69565217391304, 1.55, 0.47727272727273
86378, 0.65217391304348, 1.55, 0.022727272727273
86379, 0.67391304347826, 1.55, 0.045454545454545
86380, 0.65217391304348, 1.525, 0.045454545454545
86381, 0.65217391304348, 1.55, 0.068181818181818
86382, 0.67391304347826, 1.55, 0.090909090909091
86383, 0.65217391304348, 1.525, 0.090909090909091
86384, 0.65217391304348, 1.55, 0.11363636363636
86385, 0.67391304347826, 1.55, 0.13636363636364
86386, 0.65217391304348, 1.525, 0.13636363636364
86387, 0.65217391304348, 1.55, 0.15909090909091
86388, 0.67391304347826, 1.55, 0.18181818181818
86389, 0.65217391304348, 1.525, 0.18181818181818
86390, 0.65217391304348, 1.55, 0.20454545454545
86391, 0.67391304347826, 1.55, 0.22727272727273
86392, 0.65217391304348, 1.525, 0.22727272727273
86393, 0.65217391304348, 1.55, 0.25
86394, 0.67391304347826, 1.55, 0.27272727272727
86395, 0.65217391304348, 1.525, 0.27272727272727
86396, 0.65217391304348, 1.55, 0.29545454545455
86397, 0.67391304347826, 1.55, 0.31818181818182
86398, 0.65217391304348, 1.525, 0.31818181818182
86399, 0.65217391304348, 1.55, 0.34090909090909
86400, 0.67391304347826, 1.55, 0.36363636363636
86401, 0.65217391304348, 1.525, 0.36363636363636
86402, 0.65217391304348, 1.55, 0.38636363636364
86403, 0.67391304347826, 1.55, 0.40909090909091
86404, 0.65217391304348, 1.525, 0.40909090909091
86405, 0.65217391304348, 1.55, 0.43181818181818
86406, 0.67391304347826, 1.55, 0.45454545454545
86407, 0.65217391304348, 1.525, 0.45454545454545
86408, 0.65217391304348, 1.55, 0.47727272727273
86409, 0.60869565217391, 1.55, 0.022727272727273
86410, 0.6304347826087, 1.55, 0.045454545454545
86411, 0.60869565217391, 1.525, 0.045454545454545
86412, 0.60869565217391, 1.55, 0.068181818181818
86413, 0.6304347826087, 1.55, 0.090909090909091
86414, 0.60869565217391, 1.525, 0.090909090909091
86415, 0.60869565217391, 1.55, 0.11363636363636
86416, 0.6304347826087, 1.55, 0.13636363636364
86417, 0.60869565217391, 1.525, 0.13636363636364
86418, 0.60869565217391, 1.55, 0.15909090909091
86419, 0.6304347826087, 1.55, 0.18181818181818
86420, 0.60869565217391, 1.525, 0.18181818181818
86421, 0.60869565217391, 1.55, 0.20454545454545
86422, 0.6304347826087, 1.55, 0.22727272727273
86423, 0.60869565217391, 1.525, 0.22727272727273
86424, 0.60869565217391, 1.55, 0.25
86425, 0.6304347826087, 1.55, 0.27272727272727
86426, 0.60869565217391, 1.525, 0.27272727272727
86427, 0.60869565217391, 1.55, 0.29545454545455
86428, 0.6304347826087, 1.55, 0.31818181818182
86429, 0.60869565217391, 1.525, 0.31818181818182
86430, 0.60869565217391, 1.55, 0.34090909090909
86431, 0.6304347826087, 1.55, 0.36363636363636
86432, 0.60869565217391, 1.525, 0.36363636363636
86433, 0.60869565217391, 1.55, 0.38636363636364
86434, 0.6304347826087, 1.55, 0.40909090909091
86435, 0.60869565217391, 1.525, 0.40909090909091
86436, 0.60869565217391, 1.55, 0.43181818181818
86437, 0.6304347826087, 1.55, 0.45454545454545
86438, 0.60869565217391, 1.525, 0.45454545454545
86439, 0.60869565217391, 1.55, 0.47727272727273
86440, 0.56521739130435, 1.55, 0.022727272727273
86441, 0.58695652173913, 1.55, 0.045454545454545
86442, 0.56521739130435, 1.525, 0.045454545454545
86443, 0.56521739130435, 1.55, 0.068181818181818
86444, 0.58695652173913, 1.55, 0.090909090909091
86445, 0.56521739130435, 1.525, 0.090909090909091
86446, 0.56521739130435, 1.55, 0.11363636363636
86447, 0.58695652173913, 1.55, 0.13636363636364
86448, 0.56521739130435, 1.525, 0.13636363636364
86449, 0.56521739130435, 1.55, 0.15909090909091
86450, 0.58695652173913, 1.55, 0.18181818181818
86451, 0.56521739130435, 1.525, 0.18181818181818
86452, 0.56521739130435, 1.55, 0.20454545454545
86453, 0.58695652173913, 1.55, 0.22727272727273
86454, 0.56521739130435, 1.525, 0.22727272727273
86455, 0.56521739130435, 1.55, 0.25
86456, 0.58695652173913, 1.55, 0.27272727272727
86457, 0.56521739130435, 1.525, 0.27272727272727
86458, 0.56521739130435, 1.55, 0.29545454545455
86459, 0.58695652173913, 1.55, 0.31818181818182
86460, 0.56521739130435, 1.525, 0.31818181818182
86461, 0.56521739130435, 1.55, 0.34090909090909
86462, 0.58695652173913, 1.55, 0.36363636363636
86463, 0.56521739130435, 1.525, 0.36363636363636
86464, 0.56521739130435, 1.55, 0.38636363636364
86465, 0.58695652173913, 1.55, 0.40909090909091
86466, 0.56521739130435, 1.525, 0.40909090909091
86467, 0.56521739130435, 1.55, 0.43181818181818
86468, 0.58695652173913, 1.55, 0.45454545454545
86469, 0.56521739130435, 1.525, 0.45454545454545
86470, 0.56521739130435, 1.55, 0.47727272727273
86471, 0.52173913043478, 1.55, 0.022727272727273
86472, 0.54347826086956, 1.55, 0.045454545454545
86473, 0.52173913043478, 1.525, 0.045454545454545
86474, 0.52173913043478, 1.55, 0.068181818181818
86475, 0.54347826086956, 1.55, 0.090909090909091
86476, 0.52173913043478, 1.525, 0.090909090909091
86477, 0.52173913043478, 1.55, 0.11363636363636
86478, 0.54347826086957, 1.55, 0.13636363636364
86479, 0.52173913043478, 1.525, 0.13636363636364
86480, 0.52173913043478, 1.55, 0.15909090909091
86481, 0.54347826086956, 1.55, 0.18181818181818
86482, 0.52173913043478, 1.525, 0.18181818181818
86483, 0.52173913043478, 1.55, 0.20454545454545
86484, 0.54347826086956, 1.55, 0.22727272727273
86485, 0.52173913043478, 1.525, 0.22727272727273
86486, 0.52173913043478, 1.55, 0.25
86487, 0.54347826086956, 1.55, 0.27272727272727
86488, 0.52173913043478, 1.525, 0.27272727272727
86489, 0.52173913043478, 1.55, 0.29545454545455
86490, 0.54347826086956, 1.55, 0.31818181818182
86491, 0.52173913043478, 1.525, 0.31818181818182
86492, 0.52173913043478, 1.55, 0.34090909090909
86493, 0.54347826086957, 1.55, 0.36363636363636
86494, 0.52173913043478, 1.525, 0.36363636363636
86495, 0.52173913043478, 1.55, 0.38636363636364
86496, 0.54347826086956, 1.55, 0.40909090909091
86497, 0.52173913043478, 1.525, 0.40909090909091
86498, 0.52173913043478, 1.55, 0.43181818181818
86499, 0.54347826086956, 1.55, 0.45454545454545
86500, 0.52173913043478, 1.525, 0.45454545454545
86501, 0.52173913043478, 1.55, 0.47727272727273
86502, 0.47826086956522, 1.55, 0.022727272727273
86503, 0.5, 1.55, 0.045454545454545
86504, 0.47826086956522, 1.525, 0.045454545454545
86505, 0.47826086956522, 1.55, 0.068181818181818
86506, 0.5, 1.55, 0.090909090909091
86507, 0.47826086956522, 1.525, 0.090909090909091
86508, 0.47826086956522, 1.55, 0.11363636363636
86509, 0.5, 1.55, 0.13636363636364
86510, 0.47826086956522, 1.525, 0.13636363636364
86511, 0.47826086956522, 1.55, 0.15909090909091
86512, 0.5, 1.55, 0.18181818181818
86513, 0.47826086956522, 1.525, 0.18181818181818
86514, 0.47826086956522, 1.55, 0.20454545454545
86515, 0.5, 1.55, 0.22727272727273
86516, 0.47826086956522, 1.525, 0.22727272727273
86517, 0.47826086956522, 1.55, 0.25
86518, 0.5, 1.55, 0.27272727272727
86519, 0.47826086956522, 1.525, 0.27272727272727
86520, 0.47826086956522, 1.55, 0.29545454545455
86521, 0.5, 1.55, 0.31818181818182
86522, 0.47826086956522, 1.525, 0.31818181818182
86523, 0.47826086956522, 1.55, 0.34090909090909
86524, 0.5, 1.55, 0.36363636363636
86525, 0.47826086956522, 1.525, 0.36363636363636
86526, 0.47826086956522, 1.55, 0.38636363636364
86527, 0.5, 1.55, 0.40909090909091
86528, 0.47826086956522, 1.525, 0.40909090909091
86529, 0.47826086956522, 1.55, 0.43181818181818
86530, 0.5, 1.55, 0.45454545454545
86531, 0.47826086956522, 1.525, 0.45454545454545
86532, 0.47826086956522, 1.55, 0.47727272727273
86533, 0.43478260869565, 1.55, 0.022727272727273
86534, 0.45652173913043, 1.55, 0.045454545454545
86535, 0.43478260869565, 1.525, 0.045454545454545
86536, 0.43478260869565, 1.55, 0.068181818181818
86537, 0.45652173913043, 1.55, 0.090909090909091
86538, 0.43478260869565, 1.525, 0.090909090909091
86539, 0.43478260869565, 1.55, 0.11363636363636
86540, 0.45652173913043, 1.55, 0.13636363636364
86541, 0.43478260869565, 1.525, 0.13636363636364
86542, 0.43478260869565, 1.55, 0.15909090909091
86543, 0.45652173913043, 1.55, 0.18181818181818
86544, 0.43478260869565, 1.525, 0.18181818181818
86545, 0.43478260869565, 1.55, 0.20454545454545
86546, 0.45652173913043, 1.55, 0.22727272727273
86547, 0.43478260869565, 1.525, 0.22727272727273
86548, 0.43478260869565, 1.55, 0.25
86549, 0.45652173913043, 1.55, 0.27272727272727
86550, 0.43478260869565, 1.525, 0.27272727272727
86551, 0.43478260869565, 1.55, 0.29545454545455
86552, 0.45652173913043, 1.55, 0.31818181818182
86553, 0.43478260869565, 1.525, 0.31818181818182
86554, 0.43478260869565, 1.55, 0.34090909090909
86555, 0.45652173913043, 1.55, 0.36363636363636
86556, 0.43478260869565, 1.525, 0.36363636363636
86557, 0.43478260869565, 1.55, 0.38636363636364
86558, 0.45652173913043, 1.55, 0.40909090909091
86559, 0.43478260869565, 1.525, 0.40909090909091
86560, 0.43478260869565, 1.55, 0.43181818181818
86561, 0.45652173913043, 1.55, 0.45454545454545
86562, 0.43478260869565, 1.525, 0.45454545454545
86563, 0.43478260869565, 1.55, 0.47727272727273
86564, 0.39130434782609, 1.55, 0.022727272727273
86565, 0.41304347826087, 1.55, 0.045454545454545
86566, 0.39130434782609, 1.525, 0.045454545454545
86567, 0.39130434782609, 1.55, 0.068181818181818
86568, 0.41304347826087, 1.55, 0.090909090909091
86569, 0.39130434782609, 1.525, 0.090909090909091
86570, 0.39130434782609, 1.55, 0.11363636363636
86571, 0.41304347826087, 1.55, 0.13636363636364
86572, 0.39130434782609, 1.525, 0.13636363636364
86573, 0.39130434782609, 1.55, 0.15909090909091
86574, 0.41304347826087, 1.55, 0.18181818181818
86575, 0.39130434782609, 1.525, 0.18181818181818
86576, 0.39130434782609, 1.55, 0.20454545454545
86577, 0.41304347826087, 1.55, 0.22727272727273
86578, 0.39130434782609, 1.525, 0.22727272727273
86579, 0.39130434782609, 1.55, 0.25
86580, 0.41304347826087, 1.55, 0.27272727272727
86581, 0.39130434782609, 1.525, 0.27272727272727
86582, 0.39130434782609, 1.55, 0.29545454545455
86583, 0.41304347826087, 1.55, 0.31818181818182
86584, 0.39130434782609, 1.525, 0.31818181818182
86585, 0.39130434782609, 1.55, 0.34090909090909
86586, 0.41304347826087, 1.55, 0.36363636363636
86587, 0.39130434782609, 1.525, 0.36363636363636
86588, 0.39130434782609, 1.55, 0.38636363636364
86589, 0.41304347826087, 1.55, 0.40909090909091
86590, 0.39130434782609, 1.525, 0.40909090909091
86591, 0.39130434782609, 1.55, 0.43181818181818
86592, 0.41304347826087, 1.55, 0.45454545454545
86593, 0.39130434782609, 1.525, 0.45454545454545
86594, 0.39130434782609, 1.55, 0.47727272727273
86595, 0.34782608695652, 1.55, 0.022727272727273
86596, 0.3695652173913, 1.55, 0.045454545454545
86597, 0.34782608695652, 1.525, 0.045454545454545
86598, 0.34782608695652, 1.55, 0.068181818181818
86599, 0.3695652173913, 1.55, 0.090909090909091
86600, 0.34782608695652, 1.525, 0.090909090909091
86601, 0.34782608695652, 1.55, 0.11363636363636
86602, 0.3695652173913, 1.55, 0.13636363636364
86603, 0.34782608695652, 1.525, 0.13636363636364
86604, 0.34782608695652, 1.55, 0.15909090909091
86605, 0.3695652173913, 1.55, 0.18181818181818
86606, 0.34782608695652, 1.525, 0.18181818181818
86607, 0.34782608695652, 1.55, 0.20454545454545
86608, 0.3695652173913, 1.55, 0.22727272727273
86609, 0.34782608695652, 1.525, 0.22727272727273
86610, 0.34782608695652, 1.55, 0.25
86611, 0.3695652173913, 1.55, 0.27272727272727
86612, 0.34782608695652, 1.525, 0.27272727272727
86613, 0.34782608695652, 1.55, 0.29545454545455
86614, 0.3695652173913, 1.55, 0.31818181818182
86615, 0.34782608695652, 1.525, 0.31818181818182
86616, 0.34782608695652, 1.55, 0.34090909090909
86617, 0.3695652173913, 1.55, 0.36363636363636
86618, 0.34782608695652, 1.525, 0.36363636363636
86619, 0.34782608695652, 1.55, 0.38636363636364
86620, 0.3695652173913, 1.55, 0.40909090909091
86621, 0.34782608695652, 1.525, 0.40909090909091
86622, 0.34782608695652, 1.55, 0.43181818181818
86623, 0.3695652173913, 1.55, 0.45454545454545
86624, 0.34782608695652, 1.525, 0.45454545454545
86625, 0.34782608695652, 1.55, 0.47727272727273
86626, 0.30434782608696, 1.55, 0.022727272727273
86627, 0.32608695652174, 1.55, 0.045454545454545
86628, 0.30434782608696, 1.525, 0.045454545454545
86629, 0.30434782608696, 1.55, 0.068181818181818
86630, 0.32608695652174, 1.55, 0.090909090909091
86631, 0.30434782608696, 1.525, 0.090909090909091
86632, 0.30434782608696, 1.55, 0.11363636363636
86633, 0.32608695652174, 1.55, 0.13636363636364
86634, 0.30434782608696, 1.525, 0.13636363636364
86635, 0.30434782608696, 1.55, 0.15909090909091
86636, 0.32608695652174, 1.55, 0.18181818181818
86637, 0.30434782608696, 1.525, 0.18181818181818
86638, 0.30434782608696, 1.55, 0.20454545454545
86639, 0.32608695652174, 1.55, 0.22727272727273
86640, 0.30434782608696, 1.525, 0.22727272727273
86641, 0.30434782608696, 1.55, 0.25
86642, 0.32608695652174, 1.55, 0.27272727272727
86643, 0.30434782608696, 1.525, 0.27272727272727
86644, 0.30434782608696, 1.55, 0.29545454545455
86645, 0.32608695652174, 1.55, 0.31818181818182
86646, 0.30434782608696, 1.525, 0.31818181818182
86647, 0.30434782608696, 1.55, 0.34090909090909
86648, 0.32608695652174, 1.55, 0.36363636363636
86649, 0.30434782608696, 1.525, 0.36363636363636
86650, 0.30434782608696, 1.55, 0.38636363636364
86651, 0.32608695652174, 1.55, 0.40909090909091
86652, 0.30434782608696, 1.525, 0.40909090909091
86653, 0.30434782608696, 1.55, 0.43181818181818
86654, 0.32608695652174, 1.55, 0.45454545454545
86655, 0.30434782608696, 1.525, 0.45454545454545
86656, 0.30434782608696, 1.55, 0.47727272727273
86657, 0.26086956521739, 1.55, 0.022727272727273
86658, 0.28260869565217, 1.55, 0.045454545454545
86659, 0.26086956521739, 1.525, 0.045454545454545
86660, 0.26086956521739, 1.55, 0.068181818181818
86661, 0.28260869565217, 1.55, 0.090909090909091
86662, 0.26086956521739, 1.525, 0.090909090909091
86663, 0.26086956521739, 1.55, 0.11363636363636
86664, 0.28260869565217, 1.55, 0.13636363636364
86665, 0.26086956521739, 1.525, 0.13636363636364
86666, 0.26086956521739, 1.55, 0.15909090909091
86667, 0.28260869565217, 1.55, 0.18181818181818
86668, 0.26086956521739, 1.525, 0.18181818181818
86669, 0.26086956521739, 1.55, 0.20454545454545
86670, 0.28260869565217, 1.55, 0.22727272727273
86671, 0.26086956521739, 1.525, 0.22727272727273
86672, 0.26086956521739, 1.55, 0.25
86673, 0.28260869565217, 1.55, 0.27272727272727
86674, 0.26086956521739, 1.525, 0.27272727272727
86675, 0.26086956521739, 1.55, 0.29545454545455
86676, 0.28260869565217, 1.55, 0.31818181818182
86677, 0.26086956521739, 1.525, 0.31818181818182
86678, 0.26086956521739, 1.55, 0.34090909090909
86679, 0.28260869565217, 1.55, 0.36363636363636
86680, 0.26086956521739, 1.525, 0.36363636363636
86681, 0.26086956521739, 1.55, 0.38636363636364
86682, 0.28260869565217, 1.55, 0.40909090909091
86683, 0.26086956521739, 1.525, 0.40909090909091
86684, 0.26086956521739, 1.55, 0.43181818181818
86685, 0.28260869565217, 1.55, 0.45454545454545
86686, 0.26086956521739, 1.525, 0.45454545454545
86687, 0.26086956521739, 1.55, 0.47727272727273
86688, 0.21739130434783, 1.55, 0.022727272727273
86689, 0.23913043478261, 1.55, 0.045454545454545
86690, 0.21739130434783, 1.525, 0.045454545454545
86691, 0.21739130434783, 1.55, 0.068181818181818
86692, 0.23913043478261, 1.55, 0.090909090909091
86693, 0.21739130434783, 1.525, 0.090909090909091
86694, 0.21739130434783, 1.55, 0.11363636363636
86695, 0.23913043478261, 1.55, 0.13636363636364
86696, 0.21739130434783, 1.525, 0.13636363636364
86697, 0.21739130434783, 1.55, 0.15909090909091
86698, 0.23913043478261, 1.55, 0.18181818181818
86699, 0.21739130434783, 1.525, 0.18181818181818
86700, 0.21739130434783, 1.55, 0.20454545454545
86701, 0.23913043478261, 1.55, 0.22727272727273
86702, 0.21739130434783, 1.525, 0.22727272727273
86703, 0.21739130434783, 1.55, 0.25
86704, 0.23913043478261, 1.55, 0.27272727272727
86705, 0.21739130434783, 1.525, 0.27272727272727
86706, 0.21739130434783, 1.55, 0.29545454545455
86707, 0.23913043478261, 1.55, 0.31818181818182
86708, 0.21739130434783, 1.525, 0.31818181818182
86709, 0.21739130434783, 1.55, 0.34090909090909
86710, 0.23913043478261, 1.55, 0.36363636363636
86711, 0.21739130434783, 1.525, 0.36363636363636
86712, 0.21739130434783, 1.55, 0.38636363636364
86713, 0.23913043478261, 1.55, 0.40909090909091
86714, 0.21739130434783, 1.525, 0.40909090909091
86715, 0.21739130434783, 1.55, 0.43181818181818
86716, 0.23913043478261, 1.55, 0.45454545454545
86717, 0.21739130434783, 1.525, 0.45454545454545
86718, 0.21739130434783, 1.55, 0.47727272727273
86719, 0.17391304347826, 1.55, 0.022727272727273
86720, 0.19565217391304, 1.55, 0.045454545454545
86721, 0.17391304347826, 1.525, 0.045454545454545
86722, 0.17391304347826, 1.55, 0.068181818181818
86723, 0.19565217391304, 1.55, 0.090909090909091
86724, 0.17391304347826, 1.525, 0.090909090909091
86725, 0.17391304347826, 1.55, 0.11363636363636
86726, 0.19565217391304, 1.55, 0.13636363636364
86727, 0.17391304347826, 1.525, 0.13636363636364
86728, 0.17391304347826, 1.55, 0.15909090909091
86729, 0.19565217391304, 1.55, 0.18181818181818
86730, 0.17391304347826, 1.525, 0.18181818181818
86731, 0.17391304347826, 1.55, 0.20454545454545
86732, 0.19565217391304, 1.55, 0.22727272727273
86733, 0.17391304347826, 1.525, 0.22727272727273
86734, 0.17391304347826, 1.55, 0.25
86735, 0.19565217391304, 1.55, 0.27272727272727
86736, 0.17391304347826, 1.525, 0.27272727272727
86737, 0.17391304347826, 1.55, 0.29545454545455
86738, 0.19565217391304, 1.55, 0.31818181818182
86739, 0.17391304347826, 1.525, 0.31818181818182
86740, 0.17391304347826, 1.55, 0.34090909090909
86741, 0.19565217391304, 1.55, 0.36363636363636
86742, 0.17391304347826, 1.525, 0.36363636363636
86743, 0.17391304347826, 1.55, 0.38636363636364
86744, 0.19565217391304, 1.55, 0.40909090909091
86745, 0.17391304347826, 1.525, 0.40909090909091
86746, 0.17391304347826, 1.55, 0.43181818181818
86747, 0.19565217391304, 1.55, 0.45454545454545
86748, 0.17391304347826, 1.525, 0.45454545454545
86749, 0.17391304347826, 1.55, 0.47727272727273
86750, 0.1304347826087, 1.55, 0.022727272727273
86751, 0.15217391304348, 1.55, 0.045454545454545
86752, 0.1304347826087, 1.525, 0.045454545454545
86753, 0.1304347826087, 1.55, 0.068181818181818
86754, 0.15217391304348, 1.55, 0.090909090909091
86755, 0.1304347826087, 1.525, 0.090909090909091
86756, 0.1304347826087, 1.55, 0.11363636363636
86757, 0.15217391304348, 1.55, 0.13636363636364
86758, 0.1304347826087, 1.525, 0.13636363636364
86759, 0.1304347826087, 1.55, 0.15909090909091
86760, 0.15217391304348, 1.55, 0.18181818181818
86761, 0.1304347826087, 1.525, 0.18181818181818
86762, 0.1304347826087, 1.55, 0.20454545454545
86763, 0.15217391304348, 1.55, 0.22727272727273
86764, 0.1304347826087, 1.525, 0.22727272727273
86765, 0.1304347826087, 1.55, 0.25
86766, 0.15217391304348, 1.55, 0.27272727272727
86767, 0.1304347826087, 1.525, 0.27272727272727
86768, 0.1304347826087, 1.55, 0.29545454545455
86769, 0.15217391304348, 1.55, 0.31818181818182
86770, 0.1304347826087, 1.525, 0.31818181818182
86771, 0.1304347826087, 1.55, 0.34090909090909
86772, 0.15217391304348, 1.55, 0.36363636363636
86773, 0.1304347826087, 1.525, 0.36363636363636
86774, 0.1304347826087, 1.55, 0.38636363636364
86775, 0.15217391304348, 1.55, 0.40909090909091
86776, 0.1304347826087, 1.525, 0.40909090909091
86777, 0.1304347826087, 1.55, 0.43181818181818
86778, 0.15217391304348, 1.55, 0.45454545454545
86779, 0.1304347826087, 1.525, 0.45454545454545
86780, 0.1304347826087, 1.55, 0.47727272727273
86781, 0.08695652173913, 1.55, 0.022727272727273
86782, 0.10869565217391, 1.55, 0.045454545454545
86783, 0.08695652173913, 1.525, 0.045454545454545
86784, 0.08695652173913, 1.55, 0.068181818181818
86785, 0.10869565217391, 1.55, 0.090909090909091
86786, 0.08695652173913, 1.525, 0.090909090909091
86787, 0.08695652173913, 1.55, 0.11363636363636
86788, 0.10869565217391, 1.55, 0.13636363636364
86789, 0.08695652173913, 1.525, 0.13636363636364
86790, 0.08695652173913, 1.55, 0.15909090909091
86791, 0.10869565217391, 1.55, 0.18181818181818
86792, 0.08695652173913, 1.525, 0.18181818181818
86793, 0.08695652173913, 1.55, 0.20454545454545
86794, 0.10869565217391, 1.55, 0.22727272727273
86795, 0.08695652173913, 1.525, 0.22727272727273
86796, 0.08695652173913, 1.55, 0.25
86797, 0.10869565217391, 1.55, 0.27272727272727
86798, 0.08695652173913, 1.525, 0.27272727272727
86799, 0.08695652173913, 1.55, 0.29545454545455
86800, 0.10869565217391, 1.55, 0.31818181818182
86801, 0.08695652173913, 1.525, 0.31818181818182
86802, 0.08695652173913, 1.55, 0.34090909090909
86803, 0.10869565217391, 1.55, 0.36363636363636
86804, 0.08695652173913, 1.525, 0.36363636363636
86805, 0.08695652173913, 1.55, 0.38636363636364
86806, 0.10869565217391, 1.55, 0.40909090909091
86807, 0.08695652173913, 1.525, 0.40909090909091
86808, 0.08695652173913, 1.55, 0.43181818181818
86809, 0.10869565217391, 1.55, 0.45454545454545
86810, 0.08695652173913, 1.525, 0.45454545454545
86811, 0.08695652173913, 1.55, 0.47727272727273
86812, 0.043478260869565, 1.55, 0.022727272727273
86813, 0.065217391304348, 1.55, 0.045454545454545
86814, 0.043478260869565, 1.525, 0.045454545454545
86815, 0.043478260869565, 1.55, 0.068181818181818
86816, 0.065217391304348, 1.55, 0.090909090909091
86817, 0.043478260869565, 1.525, 0.090909090909091
86818, 0.043478260869565, 1.55, 0.11363636363636
86819, 0.065217391304348, 1.55, 0.13636363636364
86820, 0.043478260869565, 1.525, 0.13636363636364
86821, 0.043478260869565, 1.55, 0.15909090909091
86822, 0.065217391304348, 1.55, 0.18181818181818
86823, 0.043478260869565, 1.525, 0.18181818181818
86824, 0.043478260869565, 1.55, 0.20454545454545
86825, 0.065217391304348, 1.55, 0.22727272727273
86826, 0.043478260869565, 1.525, 0.22727272727273
86827, 0.043478260869565, 1.55, 0.25
86828, 0.065217391304348, 1.55, 0.27272727272727
86829, 0.043478260869565, 1.525, 0.27272727272727
86830, 0.043478260869565, 1.55, 0.29545454545455
86831, 0.065217391304348, 1.55, 0.31818181818182
86832, 0.043478260869565, 1.525, 0.31818181818182
86833, 0.043478260869565, 1.55, 0.34090909090909
86834, 0.065217391304348, 1.55, 0.36363636363636
86835, 0.043478260869565, 1.525, 0.36363636363636
86836, 0.043478260869565, 1.55, 0.38636363636364
86837, 0.065217391304348, 1.55, 0.40909090909091
86838, 0.043478260869565, 1.525, 0.40909090909091
86839, 0.043478260869565, 1.55, 0.43181818181818
86840, 0.065217391304348, 1.55, 0.45454545454545
86841, 0.043478260869565, 1.525, 0.45454545454545
86842, 0.043478260869565, 1.55, 0.47727272727273
86843, 0.021739130434783, 1.55, 0.045454545454545
86844, 0.021739130434783, 1.55, 0.090909090909091
86845, 0.021739130434783, 1.55, 0.13636363636364
86846, 0.021739130434783, 1.55, 0.18181818181818
86847, 0.021739130434783, 1.55, 0.22727272727273
86848, 0.021739130434783, 1.55, 0.27272727272727
86849, 0.021739130434783, 1.55, 0.31818181818182
86850, 0.021739130434783, 1.55, 0.36363636363636
86851, 0.021739130434783, 1.55, 0.40909090909091
86852, 0.021739130434783, 1.55, 0.45454545454545
86853, 0.95652173913043, 1.6, 0.022727272727273
86854, 0.97826086956522, 1.6, 0.045454545454545
86855, 0.95652173913043, 1.575, 0.045454545454545
86856, 0.95652173913043, 1.6, 0.068181818181818
86857, 0.97826086956522, 1.6, 0.090909090909091
86858, 0.95652173913043, 1.575, 0.090909090909091
86859, 0.95652173913043, 1.6, 0.11363636363636
86860, 0.97826086956522, 1.6, 0.13636363636364
86861, 0.95652173913043, 1.575, 0.13636363636364
86862, 0.95652173913043, 1.6, 0.15909090909091
86863, 0.97826086956522, 1.6, 0.18181818181818
86864, 0.95652173913043, 1.575, 0.18181818181818
86865, 0.95652173913043, 1.6, 0.20454545454545
86866, 0.97826086956522, 1.6, 0.22727272727273
86867, 0.95652173913043, 1.575, 0.22727272727273
86868, 0.95652173913044, 1.6, 0.25
86869, 0.97826086956522, 1.6, 0.27272727272727
86870, 0.95652173913044, 1.575, 0.27272727272727
86871, 0.95652173913044, 1.6, 0.29545454545455
86872, 0.97826086956522, 1.6, 0.31818181818182
86873, 0.95652173913044, 1.575, 0.31818181818182
86874, 0.95652173913043, 1.6, 0.34090909090909
86875, 0.97826086956522, 1.6, 0.36363636363636
86876, 0.95652173913043, 1.575, 0.36363636363636
86877, 0.95652173913043, 1.6, 0.38636363636364
86878, 0.97826086956522, 1.6, 0.40909090909091
86879, 0.95652173913043, 1.575, 0.40909090909091
86880, 0.95652173913043, 1.6, 0.43181818181818
86881, 0.97826086956522, 1.6, 0.45454545454545
86882, 0.95652173913043, 1.575, 0.45454545454545
86883, 0.95652173913043, 1.6, 0.47727272727273
86884, 0.91304347826087, 1.6, 0.022727272727273
86885, 0.93478260869565, 1.6, 0.045454545454545
86886, 0.91304347826087, 1.575, 0.045454545454545
86887, 0.91304347826087, 1.6, 0.068181818181818
86888, 0.93478260869565, 1.6, 0.090909090909091
86889, 0.91304347826087, 1.575, 0.090909090909091
86890, 0.91304347826087, 1.6, 0.11363636363636
86891, 0.93478260869565, 1.6, 0.13636363636364
86892, 0.91304347826087, 1.575, 0.13636363636364
86893, 0.91304347826087, 1.6, 0.15909090909091
86894, 0.93478260869565, 1.6, 0.18181818181818
86895, 0.91304347826087, 1.575, 0.18181818181818
86896, 0.91304347826087, 1.6, 0.20454545454545
86897, 0.93478260869565, 1.6, 0.22727272727273
86898, 0.91304347826087, 1.575, 0.22727272727273
86899, 0.91304347826087, 1.6, 0.25
86900, 0.93478260869565, 1.6, 0.27272727272727
86901, 0.91304347826087, 1.575, 0.27272727272727
86902, 0.91304347826087, 1.6, 0.29545454545455
86903, 0.93478260869565, 1.6, 0.31818181818182
86904, 0.91304347826087, 1.575, 0.31818181818182
86905, 0.91304347826087, 1.6, 0.34090909090909
86906, 0.93478260869565, 1.6, 0.36363636363636
86907, 0.91304347826087, 1.575, 0.36363636363636
86908, 0.91304347826087, 1.6, 0.38636363636364
86909, 0.93478260869565, 1.6, 0.40909090909091
86910, 0.91304347826087, 1.575, 0.40909090909091
86911, 0.91304347826087, 1.6, 0.43181818181818
86912, 0.93478260869565, 1.6, 0.45454545454545
86913, 0.91304347826087, 1.575, 0.45454545454545
86914, 0.91304347826087, 1.6, 0.47727272727273
86915, 0.8695652173913, 1.6, 0.022727272727273
