28664, 2.2666666666667, 1.4, 0.38636363636364
28665, 2.25, 1.4, 0.31818181818182
28666, 2.2666666666667, 1.4, 0.34090909090909
28667, 2.25, 1.4, 0.27272727272727
28668, 2.2666666666667, 1.4, 0.29545454545455
28669, 2.25, 1.4, 0.22727272727273
28670, 2.2666666666667, 1.4, 0.25
28671, 2.25, 1.4, 0.18181818181818
28672, 2.2666666666667, 1.4, 0.20454545454545
28673, 2.25, 1.4, 0.13636363636364
28674, 2.2666666666667, 1.4, 0.15909090909091
28675, 2.25, 1.4, 0.090909090909091
28676, 2.2666666666667, 1.4, 0.11363636363636
28677, 2.25, 1.4, 0.045454545454545
28678, 2.2666666666667, 1.4, 0.068181818181818
28679, 2.2666666666667, 1.4, 0.022727272727273
28680, 2.2833333333333, 1.4, 0.45454545454545
28681, 2.2833333333333, 1.4, 0.40909090909091
28682, 2.2833333333333, 1.4, 0.36363636363636
28683, 2.2833333333333, 1.4, 0.31818181818182
28684, 2.2833333333333, 1.4, 0.27272727272727
28685, 2.2833333333333, 1.4, 0.22727272727273
28686, 2.2833333333333, 1.4, 0.18181818181818
28687, 2.2833333333333, 1.4, 0.13636363636364
28688, 2.2833333333333, 1.4, 0.090909090909091
28689, 2.2833333333333, 1.4, 0.045454545454545
28690, 2.3, 1.4333333333333, 0.45454545454545
28691, 2.3, 1.4333333333333, 0.40909090909091
28692, 2.3, 1.4333333333333, 0.36363636363636
28693, 2.3, 1.4333333333333, 0.31818181818182
28694, 2.3, 1.4333333333333, 0.27272727272727
28695, 2.3, 1.4333333333333, 0.22727272727273
28696, 2.3, 1.4333333333333, 0.18181818181818
28697, 2.3, 1.4333333333333, 0.13636363636364
28698, 2.3, 1.4333333333333, 0.090909090909091
28699, 2.3, 1.4333333333333, 0.045454545454545
28700, 2.3, 1.4666666666667, 0.45454545454545
28701, 2.3, 1.4666666666667, 0.40909090909091
28702, 2.3, 1.4666666666667, 0.36363636363636
28703, 2.3, 1.4666666666667, 0.31818181818182
28704, 2.3, 1.4666666666667, 0.27272727272727
28705, 2.3, 1.4666666666667, 0.22727272727273
28706, 2.3, 1.4666666666667, 0.18181818181818
28707, 2.3, 1.4666666666667, 0.13636363636364
28708, 2.3, 1.4666666666667, 0.090909090909091
28709, 2.3, 1.4666666666667, 0.045454545454545
28710, 2.3, 1.4166666666667, 0.45454545454545
28711, 2.3, 1.4333333333333, 0.47727272727273
28712, 2.3, 1.4166666666667, 0.40909090909091
28713, 2.3, 1.4333333333333, 0.43181818181818
28714, 2.3, 1.4166666666667, 0.36363636363636
28715, 2.3, 1.4333333333333, 0.38636363636364
28716, 2.3, 1.4166666666667, 0.31818181818182
28717, 2.3, 1.4333333333333, 0.34090909090909
28718, 2.3, 1.4166666666667, 0.27272727272727
28719, 2.3, 1.4333333333333, 0.29545454545455
28720, 2.3, 1.4166666666667, 0.22727272727273
28721, 2.3, 1.4333333333333, 0.25
28722, 2.3, 1.4166666666667, 0.18181818181818
28723, 2.3, 1.4333333333333, 0.20454545454545
28724, 2.3, 1.4166666666667, 0.13636363636364
28725, 2.3, 1.4333333333333, 0.15909090909091
28726, 2.3, 1.4166666666667, 0.090909090909091
28727, 2.3, 1.4333333333333, 0.11363636363636
28728, 2.3, 1.4166666666667, 0.045454545454545
28729, 2.3, 1.4333333333333, 0.068181818181818
28730, 2.3, 1.4333333333333, 0.022727272727273
28731, 2.3, 1.45, 0.45454545454545
28732, 2.3, 1.4666666666667, 0.47727272727273
28733, 2.3, 1.45, 0.40909090909091
28734, 2.3, 1.4666666666667, 0.43181818181818
28735, 2.3, 1.45, 0.36363636363636
28736, 2.3, 1.4666666666667, 0.38636363636364
28737, 2.3, 1.45, 0.31818181818182
28738, 2.3, 1.4666666666667, 0.34090909090909
28739, 2.3, 1.45, 0.27272727272727
28740, 2.3, 1.4666666666667, 0.29545454545455
28741, 2.3, 1.45, 0.22727272727273
28742, 2.3, 1.4666666666667, 0.25
28743, 2.3, 1.45, 0.18181818181818
28744, 2.3, 1.4666666666667, 0.20454545454545
28745, 2.3, 1.45, 0.13636363636364
28746, 2.3, 1.4666666666667, 0.15909090909091
28747, 2.3, 1.45, 0.090909090909091
28748, 2.3, 1.4666666666667, 0.11363636363636
28749, 2.3, 1.45, 0.045454545454545
28750, 2.3, 1.4666666666667, 0.068181818181818
28751, 2.3, 1.4666666666667, 0.022727272727273
28752, 2.3, 1.4833333333333, 0.45454545454545
28753, 2.3, 1.4833333333333, 0.40909090909091
28754, 2.3, 1.4833333333333, 0.36363636363636
28755, 2.3, 1.4833333333333, 0.31818181818182
28756, 2.3, 1.4833333333333, 0.27272727272727
28757, 2.3, 1.4833333333333, 0.22727272727273
28758, 2.3, 1.4833333333333, 0.18181818181818
28759, 2.3, 1.4833333333333, 0.13636363636364
28760, 2.3, 1.4833333333333, 0.090909090909091
28761, 2.3, 1.4833333333333, 0.045454545454545
28762, 1.2434782608696, 0.066666666666667, 0.5
28763, 1.2869565217391, 0.066666666666667, 0.5
28764, 1.3304347826087, 0.066666666666667, 0.5
28765, 1.3739130434783, 0.066666666666667, 0.5
28766, 1.4173913043478, 0.066666666666667, 0.5
28767, 1.4608695652174, 0.066666666666667, 0.5
28768, 1.504347826087, 0.066666666666667, 0.5
28769, 1.5478260869565, 0.066666666666667, 0.5
28770, 1.5913043478261, 0.066666666666667, 0.5
28771, 1.6347826086957, 0.066666666666667, 0.5
28772, 1.6782608695652, 0.066666666666667, 0.5
28773, 1.7217391304348, 0.066666666666667, 0.5
28774, 1.7652173913043, 0.066666666666667, 0.5
28775, 1.8086956521739, 0.066666666666667, 0.5
28776, 1.8521739130435, 0.066666666666667, 0.5
28777, 1.895652173913, 0.066666666666667, 0.5
28778, 1.9391304347826, 0.066666666666667, 0.5
28779, 1.9826086956522, 0.066666666666667, 0.5
28780, 2.0260869565217, 0.066666666666667, 0.5
28781, 2.0695652173913, 0.066666666666667, 0.5
28782, 2.1130434782609, 0.066666666666667, 0.5
28783, 2.1565217391304, 0.066666666666667, 0.5
28784, 1.2434782608696, 0.033333333333333, 0.5
28785, 1.2869565217391, 0.033333333333333, 0.5
28786, 1.3304347826087, 0.033333333333333, 0.5
28787, 1.3739130434783, 0.033333333333333, 0.5
28788, 1.4173913043478, 0.033333333333333, 0.5
28789, 1.4608695652174, 0.033333333333333, 0.5
28790, 1.504347826087, 0.033333333333333, 0.5
28791, 1.5478260869565, 0.033333333333333, 0.5
28792, 1.5913043478261, 0.033333333333333, 0.5
28793, 1.6347826086957, 0.033333333333333, 0.5
28794, 1.6782608695652, 0.033333333333333, 0.5
28795, 1.7217391304348, 0.033333333333333, 0.5
28796, 1.7652173913043, 0.033333333333333, 0.5
28797, 1.8086956521739, 0.033333333333333, 0.5
28798, 1.8521739130435, 0.033333333333333, 0.5
28799, 1.895652173913, 0.033333333333333, 0.5
28800, 1.9391304347826, 0.033333333333333, 0.5
28801, 1.9826086956522, 0.033333333333333, 0.5
28802, 2.0260869565217, 0.033333333333333, 0.5
28803, 2.0695652173913, 0.033333333333333, 0.5
28804, 2.1130434782609, 0.033333333333333, 0.5
28805, 2.1565217391304, 0.033333333333333, 0.5
28806, 1.2217391304348, 0.066666666666667, 0.5
28807, 1.2434782608696, 0.083333333333333, 0.5
28808, 1.2652173913043, 0.066666666666667, 0.5
28809, 1.2869565217391, 0.083333333333333, 0.5
28810, 1.3086956521739, 0.066666666666667, 0.5
28811, 1.3304347826087, 0.083333333333333, 0.5
28812, 1.3521739130435, 0.066666666666667, 0.5
28813, 1.3739130434783, 0.083333333333333, 0.5
28814, 1.395652173913, 0.066666666666667, 0.5
28815, 1.4173913043478, 0.083333333333333, 0.5
28816, 1.4391304347826, 0.066666666666667, 0.5
28817, 1.4608695652174, 0.083333333333333, 0.5
28818, 1.4826086956522, 0.066666666666667, 0.5
28819, 1.504347826087, 0.083333333333333, 0.5
28820, 1.5260869565217, 0.066666666666667, 0.5
28821, 1.5478260869565, 0.083333333333333, 0.5
28822, 1.5695652173913, 0.066666666666667, 0.5
28823, 1.5913043478261, 0.083333333333333, 0.5
28824, 1.6130434782609, 0.066666666666667, 0.5
28825, 1.6347826086957, 0.083333333333333, 0.5
28826, 1.6565217391304, 0.066666666666667, 0.5
28827, 1.6782608695652, 0.083333333333333, 0.5
28828, 1.7, 0.066666666666667, 0.5
28829, 1.7217391304348, 0.083333333333333, 0.5
28830, 1.7434782608696, 0.066666666666667, 0.5
28831, 1.7652173913043, 0.083333333333333, 0.5
28832, 1.7869565217391, 0.066666666666667, 0.5
28833, 1.8086956521739, 0.083333333333333, 0.5
28834, 1.8304347826087, 0.066666666666667, 0.5
28835, 1.8521739130435, 0.083333333333333, 0.5
28836, 1.8739130434783, 0.066666666666667, 0.5
28837, 1.895652173913, 0.083333333333333, 0.5
28838, 1.9173913043478, 0.066666666666667, 0.5
28839, 1.9391304347826, 0.083333333333333, 0.5
28840, 1.9608695652174, 0.066666666666667, 0.5
28841, 1.9826086956522, 0.083333333333333, 0.5
28842, 2.004347826087, 0.066666666666667, 0.5
28843, 2.0260869565217, 0.083333333333333, 0.5
28844, 2.0478260869565, 0.066666666666667, 0.5
28845, 2.0695652173913, 0.083333333333333, 0.5
28846, 2.0913043478261, 0.066666666666667, 0.5
28847, 2.1130434782609, 0.083333333333333, 0.5
28848, 2.1347826086957, 0.066666666666667, 0.5
28849, 2.1565217391304, 0.083333333333333, 0.5
28850, 2.1782608695652, 0.066666666666667, 0.5
28851, 1.2217391304348, 0.033333333333333, 0.5
28852, 1.2434782608696, 0.05, 0.5
28853, 1.2652173913043, 0.033333333333333, 0.5
28854, 1.2869565217391, 0.05, 0.5
28855, 1.3086956521739, 0.033333333333333, 0.5
28856, 1.3304347826087, 0.05, 0.5
28857, 1.3521739130435, 0.033333333333333, 0.5
28858, 1.3739130434783, 0.05, 0.5
28859, 1.395652173913, 0.033333333333333, 0.5
28860, 1.4173913043478, 0.05, 0.5
28861, 1.4391304347826, 0.033333333333333, 0.5
28862, 1.4608695652174, 0.05, 0.5
28863, 1.4826086956522, 0.033333333333333, 0.5
28864, 1.504347826087, 0.05, 0.5
28865, 1.5260869565217, 0.033333333333333, 0.5
28866, 1.5478260869565, 0.05, 0.5
28867, 1.5695652173913, 0.033333333333333, 0.5
28868, 1.5913043478261, 0.05, 0.5
28869, 1.6130434782609, 0.033333333333333, 0.5
28870, 1.6347826086957, 0.05, 0.5
28871, 1.6565217391304, 0.033333333333333, 0.5
28872, 1.6782608695652, 0.05, 0.5
28873, 1.7, 0.033333333333333, 0.5
28874, 1.7217391304348, 0.05, 0.5
28875, 1.7434782608696, 0.033333333333333, 0.5
28876, 1.7652173913043, 0.05, 0.5
28877, 1.7869565217391, 0.033333333333333, 0.5
28878, 1.8086956521739, 0.05, 0.5
28879, 1.8304347826087, 0.033333333333333, 0.5
28880, 1.8521739130435, 0.05, 0.5
28881, 1.8739130434783, 0.033333333333333, 0.5
28882, 1.895652173913, 0.05, 0.5
28883, 1.9173913043478, 0.033333333333333, 0.5
28884, 1.9391304347826, 0.05, 0.5
28885, 1.9608695652174, 0.033333333333333, 0.5
28886, 1.9826086956522, 0.05, 0.5
28887, 2.004347826087, 0.033333333333333, 0.5
28888, 2.0260869565217, 0.05, 0.5
28889, 2.0478260869565, 0.033333333333333, 0.5
28890, 2.0695652173913, 0.05, 0.5
28891, 2.0913043478261, 0.033333333333333, 0.5
28892, 2.1130434782609, 0.05, 0.5
28893, 2.1347826086957, 0.033333333333333, 0.5
28894, 2.1565217391304, 0.05, 0.5
28895, 2.1782608695652, 0.033333333333333, 0.5
28896, 1.2434782608696, 0.016666666666667, 0.5
28897, 1.2869565217391, 0.016666666666667, 0.5
28898, 1.3304347826087, 0.016666666666667, 0.5
28899, 1.3739130434783, 0.016666666666667, 0.5
28900, 1.4173913043478, 0.016666666666667, 0.5
28901, 1.4608695652174, 0.016666666666667, 0.5
28902, 1.504347826087, 0.016666666666667, 0.5
28903, 1.5478260869565, 0.016666666666667, 0.5
28904, 1.5913043478261, 0.016666666666667, 0.5
28905, 1.6347826086957, 0.016666666666667, 0.5
28906, 1.6782608695652, 0.016666666666667, 0.5
28907, 1.7217391304348, 0.016666666666667, 0.5
28908, 1.7652173913043, 0.016666666666667, 0.5
28909, 1.8086956521739, 0.016666666666667, 0.5
28910, 1.8521739130435, 0.016666666666667, 0.5
28911, 1.895652173913, 0.016666666666667, 0.5
28912, 1.9391304347826, 0.016666666666667, 0.5
28913, 1.9826086956522, 0.016666666666667, 0.5
28914, 2.0260869565217, 0.016666666666667, 0.5
28915, 2.0695652173913, 0.016666666666667, 0.5
28916, 2.1130434782609, 0.016666666666667, 0.5
28917, 2.1565217391304, 0.016666666666667, 0.5
28918, 1.2434782608696, 0.066666666666667, 0
28919, 1.2869565217391, 0.066666666666667, 0
28920, 1.3304347826087, 0.066666666666667, 0
28921, 1.3739130434783, 0.066666666666667, 0
28922, 1.4173913043478, 0.066666666666667, 0
28923, 1.4608695652174, 0.066666666666667, 0
28924, 1.504347826087, 0.066666666666667, 0
28925, 1.5478260869565, 0.066666666666667, 0
28926, 1.5913043478261, 0.066666666666667, 0
28927, 1.6347826086957, 0.066666666666667, 0
28928, 1.6782608695652, 0.066666666666667, 0
28929, 1.7217391304348, 0.066666666666667, 0
28930, 1.7652173913043, 0.066666666666667, 0
28931, 1.8086956521739, 0.066666666666667, 0
28932, 1.8521739130435, 0.066666666666667, 0
28933, 1.895652173913, 0.066666666666667, 0
28934, 1.9391304347826, 0.066666666666667, 0
28935, 1.9826086956522, 0.066666666666667, 0
28936, 2.0260869565217, 0.066666666666667, 0
28937, 2.0695652173913, 0.066666666666667, 0
28938, 2.1130434782609, 0.066666666666667, 0
28939, 2.1565217391304, 0.066666666666667, 0
28940, 1.2434782608696, 0.033333333333333, 0
28941, 1.2869565217391, 0.033333333333333, 0
28942, 1.3304347826087, 0.033333333333333, 0
28943, 1.3739130434783, 0.033333333333333, 0
28944, 1.4173913043478, 0.033333333333333, 0
28945, 1.4608695652174, 0.033333333333333, 0
28946, 1.504347826087, 0.033333333333333, 0
28947, 1.5478260869565, 0.033333333333333, 0
28948, 1.5913043478261, 0.033333333333333, 0
28949, 1.6347826086957, 0.033333333333333, 0
28950, 1.6782608695652, 0.033333333333333, 0
28951, 1.7217391304348, 0.033333333333333, 0
28952, 1.7652173913043, 0.033333333333333, 0
28953, 1.8086956521739, 0.033333333333333, 0
28954, 1.8521739130435, 0.033333333333333, 0
28955, 1.895652173913, 0.033333333333333, 0
28956, 1.9391304347826, 0.033333333333333, 0
28957, 1.9826086956522, 0.033333333333333, 0
28958, 2.0260869565217, 0.033333333333333, 0
28959, 2.0695652173913, 0.033333333333333, 0
28960, 2.1130434782609, 0.033333333333333, 0
28961, 2.1565217391304, 0.033333333333333, 0
28962, 1.2434782608696, 0.083333333333333, 0
28963, 1.2217391304348, 0.066666666666667, 0
28964, 1.2869565217391, 0.083333333333333, 0
28965, 1.2652173913043, 0.066666666666667, 0
28966, 1.3304347826087, 0.083333333333333, 0
28967, 1.3086956521739, 0.066666666666667, 0
28968, 1.3739130434783, 0.083333333333333, 0
28969, 1.3521739130435, 0.066666666666667, 0
28970, 1.4173913043478, 0.083333333333333, 0
28971, 1.395652173913, 0.066666666666667, 0
28972, 1.4608695652174, 0.083333333333333, 0
28973, 1.4391304347826, 0.066666666666667, 0
28974, 1.504347826087, 0.083333333333333, 0
28975, 1.4826086956522, 0.066666666666667, 0
28976, 1.5478260869565, 0.083333333333333, 0
28977, 1.5260869565217, 0.066666666666667, 0
28978, 1.5913043478261, 0.083333333333333, 0
28979, 1.5695652173913, 0.066666666666667, 0
28980, 1.6347826086957, 0.083333333333333, 0
28981, 1.6130434782609, 0.066666666666667, 0
28982, 1.6782608695652, 0.083333333333333, 0
28983, 1.6565217391304, 0.066666666666667, 0
28984, 1.7217391304348, 0.083333333333333, 0
28985, 1.7, 0.066666666666667, 0
28986, 1.7652173913043, 0.083333333333333, 0
28987, 1.7434782608696, 0.066666666666667, 0
28988, 1.8086956521739, 0.083333333333333, 0
28989, 1.7869565217391, 0.066666666666667, 0
28990, 1.8521739130435, 0.083333333333333, 0
28991, 1.8304347826087, 0.066666666666667, 0
28992, 1.895652173913, 0.083333333333333, 0
28993, 1.8739130434783, 0.066666666666667, 0
28994, 1.9391304347826, 0.083333333333333, 0
28995, 1.9173913043478, 0.066666666666667, 0
28996, 1.9826086956522, 0.083333333333333, 0
28997, 1.9608695652174, 0.066666666666667, 0
28998, 2.0260869565217, 0.083333333333333, 0
28999, 2.004347826087, 0.066666666666667, 0
29000, 2.0695652173913, 0.083333333333333, 0
29001, 2.0478260869565, 0.066666666666667, 0
29002, 2.1130434782609, 0.083333333333333, 0
29003, 2.0913043478261, 0.066666666666667, 0
29004, 2.1565217391304, 0.083333333333333, 0
29005, 2.1347826086957, 0.066666666666667, 0
29006, 2.1782608695652, 0.066666666666667, 0
29007, 1.2434782608696, 0.05, 0
29008, 1.2217391304348, 0.033333333333333, 0
29009, 1.2869565217391, 0.05, 0
29010, 1.2652173913043, 0.033333333333333, 0
29011, 1.3304347826087, 0.05, 0
29012, 1.3086956521739, 0.033333333333333, 0
29013, 1.3739130434783, 0.05, 0
29014, 1.3521739130435, 0.033333333333333, 0
29015, 1.4173913043478, 0.05, 0
29016, 1.395652173913, 0.033333333333333, 0
29017, 1.4608695652174, 0.05, 0
29018, 1.4391304347826, 0.033333333333333, 0
29019, 1.504347826087, 0.05, 0
29020, 1.4826086956522, 0.033333333333333, 0
29021, 1.5478260869565, 0.05, 0
29022, 1.5260869565217, 0.033333333333333, 0
29023, 1.5913043478261, 0.05, 0
29024, 1.5695652173913, 0.033333333333333, 0
29025, 1.6347826086957, 0.05, 0
29026, 1.6130434782609, 0.033333333333333, 0
29027, 1.6782608695652, 0.05, 0
29028, 1.6565217391304, 0.033333333333333, 0
29029, 1.7217391304348, 0.05, 0
29030, 1.7, 0.033333333333333, 0
29031, 1.7652173913043, 0.05, 0
29032, 1.7434782608696, 0.033333333333333, 0
29033, 1.8086956521739, 0.05, 0
29034, 1.7869565217391, 0.033333333333333, 0
29035, 1.8521739130435, 0.05, 0
29036, 1.8304347826087, 0.033333333333333, 0
29037, 1.895652173913, 0.05, 0
29038, 1.8739130434783, 0.033333333333333, 0
29039, 1.9391304347826, 0.05, 0
29040, 1.9173913043478, 0.033333333333333, 0
29041, 1.9826086956522, 0.05, 0
29042, 1.9608695652174, 0.033333333333333, 0
29043, 2.0260869565217, 0.05, 0
29044, 2.004347826087, 0.033333333333333, 0
29045, 2.0695652173913, 0.05, 0
29046, 2.0478260869565, 0.033333333333333, 0
29047, 2.1130434782609, 0.05, 0
29048, 2.0913043478261, 0.033333333333333, 0
29049, 2.1565217391304, 0.05, 0
29050, 2.1347826086957, 0.033333333333333, 0
29051, 2.1782608695652, 0.033333333333333, 0
29052, 1.2434782608696, 0.016666666666667, 0
29053, 1.2869565217391, 0.016666666666667, 0
29054, 1.3304347826087, 0.016666666666667, 0
29055, 1.3739130434783, 0.016666666666667, 0
29056, 1.4173913043478, 0.016666666666667, 0
29057, 1.4608695652174, 0.016666666666667, 0
29058, 1.504347826087, 0.016666666666667, 0
29059, 1.5478260869565, 0.016666666666667, 0
29060, 1.5913043478261, 0.016666666666667, 0
29061, 1.6347826086957, 0.016666666666667, 0
29062, 1.6782608695652, 0.016666666666667, 0
29063, 1.7217391304348, 0.016666666666667, 0
29064, 1.7652173913043, 0.016666666666667, 0
29065, 1.8086956521739, 0.016666666666667, 0
29066, 1.8521739130435, 0.016666666666667, 0
29067, 1.895652173913, 0.016666666666667, 0
29068, 1.9391304347826, 0.016666666666667, 0
29069, 1.9826086956522, 0.016666666666667, 0
29070, 2.0260869565217, 0.016666666666667, 0
29071, 2.0695652173913, 0.016666666666667, 0
29072, 2.1130434782609, 0.016666666666667, 0
29073, 2.1565217391304, 0.016666666666667, 0
29074, 1.2, 0.066666666666667, 0.45454545454545
29075, 1.2, 0.066666666666667, 0.40909090909091
29076, 1.2, 0.066666666666667, 0.36363636363636
29077, 1.2, 0.066666666666667, 0.31818181818182
29078, 1.2, 0.066666666666667, 0.27272727272727
29079, 1.2, 0.066666666666667, 0.22727272727273
29080, 1.2, 0.066666666666667, 0.18181818181818
29081, 1.2, 0.066666666666667, 0.13636363636364
29082, 1.2, 0.066666666666667, 0.090909090909091
29083, 1.2, 0.066666666666667, 0.045454545454545
29084, 1.2, 0.033333333333333, 0.45454545454545
29085, 1.2, 0.033333333333333, 0.40909090909091
29086, 1.2, 0.033333333333333, 0.36363636363636
29087, 1.2, 0.033333333333333, 0.31818181818182
29088, 1.2, 0.033333333333333, 0.27272727272727
29089, 1.2, 0.033333333333333, 0.22727272727273
29090, 1.2, 0.033333333333333, 0.18181818181818
29091, 1.2, 0.033333333333333, 0.13636363636364
29092, 1.2, 0.033333333333333, 0.090909090909091
29093, 1.2, 0.033333333333333, 0.045454545454545
29094, 1.2, 0.083333333333333, 0.45454545454545
29095, 1.2, 0.066666666666667, 0.47727272727273
29096, 1.2, 0.083333333333333, 0.40909090909091
29097, 1.2, 0.066666666666667, 0.43181818181818
29098, 1.2, 0.083333333333333, 0.36363636363636
29099, 1.2, 0.066666666666667, 0.38636363636364
29100, 1.2, 0.083333333333333, 0.31818181818182
29101, 1.2, 0.066666666666667, 0.34090909090909
29102, 1.2, 0.083333333333333, 0.27272727272727
29103, 1.2, 0.066666666666667, 0.29545454545455
29104, 1.2, 0.083333333333333, 0.22727272727273
29105, 1.2, 0.066666666666667, 0.25
29106, 1.2, 0.083333333333333, 0.18181818181818
29107, 1.2, 0.066666666666667, 0.20454545454545
29108, 1.2, 0.083333333333333, 0.13636363636364
29109, 1.2, 0.066666666666667, 0.15909090909091
29110, 1.2, 0.083333333333333, 0.090909090909091
29111, 1.2, 0.066666666666667, 0.11363636363636
29112, 1.2, 0.083333333333333, 0.045454545454545
29113, 1.2, 0.066666666666667, 0.068181818181818
29114, 1.2, 0.066666666666667, 0.022727272727273
29115, 1.2, 0.05, 0.45454545454545
29116, 1.2, 0.033333333333333, 0.47727272727273
29117, 1.2, 0.05, 0.40909090909091
29118, 1.2, 0.033333333333333, 0.43181818181818
29119, 1.2, 0.05, 0.36363636363636
29120, 1.2, 0.033333333333333, 0.38636363636364
29121, 1.2, 0.05, 0.31818181818182
29122, 1.2, 0.033333333333333, 0.34090909090909
29123, 1.2, 0.05, 0.27272727272727
29124, 1.2, 0.033333333333333, 0.29545454545455
29125, 1.2, 0.05, 0.22727272727273
29126, 1.2, 0.033333333333333, 0.25
29127, 1.2, 0.05, 0.18181818181818
29128, 1.2, 0.033333333333333, 0.20454545454545
29129, 1.2, 0.05, 0.13636363636364
29130, 1.2, 0.033333333333333, 0.15909090909091
29131, 1.2, 0.05, 0.090909090909091
29132, 1.2, 0.033333333333333, 0.11363636363636
29133, 1.2, 0.05, 0.045454545454545
29134, 1.2, 0.033333333333333, 0.068181818181818
29135, 1.2, 0.033333333333333, 0.022727272727273
29136, 1.2, 0.016666666666667, 0.45454545454545
29137, 1.2, 0.016666666666667, 0.40909090909091
29138, 1.2, 0.016666666666667, 0.36363636363636
29139, 1.2, 0.016666666666667, 0.31818181818182
29140, 1.2, 0.016666666666667, 0.27272727272727
29141, 1.2, 0.016666666666667, 0.22727272727273
29142, 1.2, 0.016666666666667, 0.18181818181818
29143, 1.2, 0.016666666666667, 0.13636363636364
29144, 1.2, 0.016666666666667, 0.090909090909091
29145, 1.2, 0.016666666666667, 0.045454545454545
29146, 1.2434782608696, 0, 0.45454545454545
29147, 1.2434782608696, 0, 0.40909090909091
29148, 1.2434782608696, 0, 0.36363636363636
29149, 1.2434782608696, 0, 0.31818181818182
29150, 1.2434782608696, 0, 0.27272727272727
29151, 1.2434782608696, 0, 0.22727272727273
29152, 1.2434782608696, 0, 0.18181818181818
29153, 1.2434782608696, 0, 0.13636363636364
29154, 1.2434782608696, 0, 0.090909090909091
29155, 1.2434782608696, 0, 0.045454545454545
29156, 1.2869565217391, 0, 0.45454545454545
29157, 1.2869565217391, 0, 0.40909090909091
29158, 1.2869565217391, 0, 0.36363636363636
29159, 1.2869565217391, 0, 0.31818181818182
29160, 1.2869565217391, 0, 0.27272727272727
29161, 1.2869565217391, 0, 0.22727272727273
29162, 1.2869565217391, 0, 0.18181818181818
29163, 1.2869565217391, 0, 0.13636363636364
29164, 1.2869565217391, 0, 0.090909090909091
29165, 1.2869565217391, 0, 0.045454545454545
29166, 1.3304347826087, 0, 0.45454545454545
29167, 1.3304347826087, 0, 0.40909090909091
29168, 1.3304347826087, 0, 0.36363636363636
29169, 1.3304347826087, 0, 0.31818181818182
29170, 1.3304347826087, 0, 0.27272727272727
29171, 1.3304347826087, 0, 0.22727272727273
29172, 1.3304347826087, 0, 0.18181818181818
29173, 1.3304347826087, 0, 0.13636363636364
29174, 1.3304347826087, 0, 0.090909090909091
29175, 1.3304347826087, 0, 0.045454545454545
29176, 1.3739130434783, 0, 0.45454545454545
29177, 1.3739130434783, 0, 0.40909090909091
29178, 1.3739130434783, 0, 0.36363636363636
29179, 1.3739130434783, 0, 0.31818181818182
29180, 1.3739130434783, 0, 0.27272727272727
29181, 1.3739130434783, 0, 0.22727272727273
29182, 1.3739130434783, 0, 0.18181818181818
29183, 1.3739130434783, 0, 0.13636363636364
29184, 1.3739130434783, 0, 0.090909090909091
29185, 1.3739130434783, 0, 0.045454545454545
29186, 1.4173913043478, 0, 0.45454545454545
29187, 1.4173913043478, 0, 0.40909090909091
29188, 1.4173913043478, 0, 0.36363636363636
29189, 1.4173913043478, 0, 0.31818181818182
29190, 1.4173913043478, 0, 0.27272727272727
29191, 1.4173913043478, 0, 0.22727272727273
29192, 1.4173913043478, 0, 0.18181818181818
29193, 1.4173913043478, 0, 0.13636363636364
29194, 1.4173913043478, 0, 0.090909090909091
29195, 1.4173913043478, 0, 0.045454545454545
29196, 1.4608695652174, 0, 0.45454545454545
29197, 1.4608695652174, 0, 0.40909090909091
29198, 1.4608695652174, 0, 0.36363636363636
29199, 1.4608695652174, 0, 0.31818181818182
29200, 1.4608695652174, 0, 0.27272727272727
29201, 1.4608695652174, 0, 0.22727272727273
29202, 1.4608695652174, 0, 0.18181818181818
29203, 1.4608695652174, 0, 0.13636363636364
29204, 1.4608695652174, 0, 0.090909090909091
29205, 1.4608695652174, 0, 0.045454545454545
29206, 1.504347826087, 0, 0.45454545454545
29207, 1.504347826087, 0, 0.40909090909091
29208, 1.504347826087, 0, 0.36363636363636
29209, 1.504347826087, 0, 0.31818181818182
29210, 1.504347826087, 0, 0.27272727272727
29211, 1.504347826087, 0, 0.22727272727273
29212, 1.504347826087, 0, 0.18181818181818
29213, 1.504347826087, 0, 0.13636363636364
29214, 1.504347826087, 0, 0.090909090909091
29215, 1.504347826087, 0, 0.045454545454545
29216, 1.5478260869565, 0, 0.45454545454545
29217, 1.5478260869565, 0, 0.40909090909091
29218, 1.5478260869565, 0, 0.36363636363636
29219, 1.5478260869565, 0, 0.31818181818182
29220, 1.5478260869565, 0, 0.27272727272727
29221, 1.5478260869565, 0, 0.22727272727273
29222, 1.5478260869565, 0, 0.18181818181818
29223, 1.5478260869565, 0, 0.13636363636364
29224, 1.5478260869565, 0, 0.090909090909091
29225, 1.5478260869565, 0, 0.045454545454545
29226, 1.5913043478261, 0, 0.45454545454545
29227, 1.5913043478261, 0, 0.40909090909091
29228, 1.5913043478261, 0, 0.36363636363636
29229, 1.5913043478261, 0, 0.31818181818182
29230, 1.5913043478261, 0, 0.27272727272727
29231, 1.5913043478261, 0, 0.22727272727273
29232, 1.5913043478261, 0, 0.18181818181818
29233, 1.5913043478261, 0, 0.13636363636364
29234, 1.5913043478261, 0, 0.090909090909091
29235, 1.5913043478261, 0, 0.045454545454545
29236, 1.6347826086957, 0, 0.45454545454545
29237, 1.6347826086957, 0, 0.40909090909091
29238, 1.6347826086957, 0, 0.36363636363636
29239, 1.6347826086957, 0, 0.31818181818182
29240, 1.6347826086957, 0, 0.27272727272727
29241, 1.6347826086957, 0, 0.22727272727273
29242, 1.6347826086957, 0, 0.18181818181818
29243, 1.6347826086957, 0, 0.13636363636364
29244, 1.6347826086957, 0, 0.090909090909091
29245, 1.6347826086957, 0, 0.045454545454545
29246, 1.6782608695652, 0, 0.45454545454545
29247, 1.6782608695652, 0, 0.40909090909091
29248, 1.6782608695652, 0, 0.36363636363636
29249, 1.6782608695652, 0, 0.31818181818182
29250, 1.6782608695652, 0, 0.27272727272727
29251, 1.6782608695652, 0, 0.22727272727273
29252, 1.6782608695652, 0, 0.18181818181818
29253, 1.6782608695652, 0, 0.13636363636364
29254, 1.6782608695652, 0, 0.090909090909091
29255, 1.6782608695652, 0, 0.045454545454545
29256, 1.7217391304348, 0, 0.45454545454545
29257, 1.7217391304348, 0, 0.40909090909091
29258, 1.7217391304348, 0, 0.36363636363636
29259, 1.7217391304348, 0, 0.31818181818182
29260, 1.7217391304348, 0, 0.27272727272727
29261, 1.7217391304348, 0, 0.22727272727273
29262, 1.7217391304348, 0, 0.18181818181818
29263, 1.7217391304348, 0, 0.13636363636364
29264, 1.7217391304348, 0, 0.090909090909091
29265, 1.7217391304348, 0, 0.045454545454545
29266, 1.7652173913043, 0, 0.45454545454545
29267, 1.7652173913043, 0, 0.40909090909091
29268, 1.7652173913043, 0, 0.36363636363636
29269, 1.7652173913043, 0, 0.31818181818182
29270, 1.7652173913043, 0, 0.27272727272727
29271, 1.7652173913043, 0, 0.22727272727273
29272, 1.7652173913043, 0, 0.18181818181818
29273, 1.7652173913043, 0, 0.13636363636364
29274, 1.7652173913043, 0, 0.090909090909091
29275, 1.7652173913043, 0, 0.045454545454545
29276, 1.8086956521739, 0, 0.45454545454545
29277, 1.8086956521739, 0, 0.40909090909091
29278, 1.8086956521739, 0, 0.36363636363636
29279, 1.8086956521739, 0, 0.31818181818182
29280, 1.8086956521739, 0, 0.27272727272727
29281, 1.8086956521739, 0, 0.22727272727273
29282, 1.8086956521739, 0, 0.18181818181818
29283, 1.8086956521739, 0, 0.13636363636364
29284, 1.8086956521739, 0, 0.090909090909091
29285, 1.8086956521739, 0, 0.045454545454545
29286, 1.8521739130435, 0, 0.45454545454545
29287, 1.8521739130435, 0, 0.40909090909091
29288, 1.8521739130435, 0, 0.36363636363636
29289, 1.8521739130435, 0, 0.31818181818182
29290, 1.8521739130435, 0, 0.27272727272727
29291, 1.8521739130435, 0, 0.22727272727273
29292, 1.8521739130435, 0, 0.18181818181818
29293, 1.8521739130435, 0, 0.13636363636364
29294, 1.8521739130435, 0, 0.090909090909091
29295, 1.8521739130435, 0, 0.045454545454545
29296, 1.895652173913, 0, 0.45454545454545
29297, 1.895652173913, 0, 0.40909090909091
29298, 1.895652173913, 0, 0.36363636363636
29299, 1.895652173913, 0, 0.31818181818182
29300, 1.895652173913, 0, 0.27272727272727
29301, 1.895652173913, 0, 0.22727272727273
29302, 1.895652173913, 0, 0.18181818181818
29303, 1.895652173913, 0, 0.13636363636364
29304, 1.895652173913, 0, 0.090909090909091
29305, 1.895652173913, 0, 0.045454545454545
29306, 1.9391304347826, 0, 0.45454545454545
29307, 1.9391304347826, 0, 0.40909090909091
29308, 1.9391304347826, 0, 0.36363636363636
29309, 1.9391304347826, 0, 0.31818181818182
29310, 1.9391304347826, 0, 0.27272727272727
29311, 1.9391304347826, 0, 0.22727272727273
29312, 1.9391304347826, 0, 0.18181818181818
29313, 1.9391304347826, 0, 0.13636363636364
29314, 1.9391304347826, 0, 0.090909090909091
29315, 1.9391304347826, 0, 0.045454545454545
29316, 1.9826086956522, 0, 0.45454545454545
29317, 1.9826086956522, 0, 0.40909090909091
29318, 1.9826086956522, 0, 0.36363636363636
29319, 1.9826086956522, 0, 0.31818181818182
29320, 1.9826086956522, 0, 0.27272727272727
29321, 1.9826086956522, 0, 0.22727272727273
29322, 1.9826086956522, 0, 0.18181818181818
29323, 1.9826086956522, 0, 0.13636363636364
29324, 1.9826086956522, 0, 0.090909090909091
29325, 1.9826086956522, 0, 0.045454545454545
29326, 2.0260869565217, 0, 0.45454545454545
29327, 2.0260869565217, 0, 0.40909090909091
29328, 2.0260869565217, 0, 0.36363636363636
29329, 2.0260869565217, 0, 0.31818181818182
29330, 2.0260869565217, 0, 0.27272727272727
29331, 2.0260869565217, 0, 0.22727272727273
29332, 2.0260869565217, 0, 0.18181818181818
29333, 2.0260869565217, 0, 0.13636363636364
29334, 2.0260869565217, 0, 0.090909090909091
29335, 2.0260869565217, 0, 0.045454545454545
29336, 2.0695652173913, 0, 0.45454545454545
29337, 2.0695652173913, 0, 0.40909090909091
29338, 2.0695652173913, 0, 0.36363636363636
29339, 2.0695652173913, 0, 0.31818181818182
29340, 2.0695652173913, 0, 0.27272727272727
29341, 2.0695652173913, 0, 0.22727272727273
29342, 2.0695652173913, 0, 0.18181818181818
29343, 2.0695652173913, 0, 0.13636363636364
29344, 2.0695652173913, 0, 0.090909090909091
29345, 2.0695652173913, 0, 0.045454545454545
29346, 2.1130434782609, 0, 0.45454545454545
29347, 2.1130434782609, 0, 0.40909090909091
29348, 2.1130434782609, 0, 0.36363636363636
29349, 2.1130434782609, 0, 0.31818181818182
29350, 2.1130434782609, 0, 0.27272727272727
29351, 2.1130434782609, 0, 0.22727272727273
29352, 2.1130434782609, 0, 0.18181818181818
29353, 2.1130434782609, 0, 0.13636363636364
29354, 2.1130434782609, 0, 0.090909090909091
29355, 2.1130434782609, 0, 0.045454545454545
29356, 2.1565217391304, 0, 0.45454545454545
29357, 2.1565217391304, 0, 0.40909090909091
29358, 2.1565217391304, 0, 0.36363636363636
29359, 2.1565217391304, 0, 0.31818181818182
29360, 2.1565217391304, 0, 0.27272727272727
29361, 2.1565217391304, 0, 0.22727272727273
29362, 2.1565217391304, 0, 0.18181818181818
29363, 2.1565217391304, 0, 0.13636363636364
29364, 2.1565217391304, 0, 0.090909090909091
29365, 2.1565217391304, 0, 0.045454545454545
29366, 1.2217391304348, 0, 0.45454545454545
29367, 1.2434782608696, 0, 0.47727272727273
29368, 1.2217391304348, 0, 0.40909090909091
29369, 1.2434782608696, 0, 0.43181818181818
29370, 1.2217391304348, 0, 0.36363636363636
29371, 1.2434782608696, 0, 0.38636363636364
29372, 1.2217391304348, 0, 0.31818181818182
29373, 1.2434782608696, 0, 0.34090909090909
29374, 1.2217391304348, 0, 0.27272727272727
29375, 1.2434782608696, 0, 0.29545454545455
29376, 1.2217391304348, 0, 0.22727272727273
29377, 1.2434782608696, 0, 0.25
29378, 1.2217391304348, 0, 0.18181818181818
29379, 1.2434782608696, 0, 0.20454545454545
29380, 1.2217391304348, 0, 0.13636363636364
29381, 1.2434782608696, 0, 0.15909090909091
29382, 1.2217391304348, 0, 0.090909090909091
29383, 1.2434782608696, 0, 0.11363636363636
29384, 1.2217391304348, 0, 0.045454545454545
29385, 1.2434782608696, 0, 0.068181818181818
29386, 1.2434782608696, 0, 0.022727272727273
29387, 1.2652173913043, 0, 0.45454545454545
29388, 1.2869565217391, 0, 0.47727272727273
29389, 1.2652173913043, 0, 0.40909090909091
29390, 1.2869565217391, 0, 0.43181818181818
29391, 1.2652173913043, 0, 0.36363636363636
29392, 1.2869565217391, 0, 0.38636363636364
29393, 1.2652173913043, 0, 0.31818181818182
29394, 1.2869565217391, 0, 0.34090909090909
29395, 1.2652173913043, 0, 0.27272727272727
29396, 1.2869565217391, 0, 0.29545454545455
29397, 1.2652173913043, 0, 0.22727272727273
29398, 1.2869565217391, 0, 0.25
29399, 1.2652173913043, 0, 0.18181818181818
29400, 1.2869565217391, 0, 0.20454545454545
29401, 1.2652173913043, 0, 0.13636363636364
29402, 1.2869565217391, 0, 0.15909090909091
29403, 1.2652173913043, 0, 0.090909090909091
29404, 1.2869565217391, 0, 0.11363636363636
29405, 1.2652173913043, 0, 0.045454545454545
29406, 1.2869565217391, 0, 0.068181818181818
29407, 1.2869565217391, 0, 0.022727272727273
29408, 1.3086956521739, 0, 0.45454545454545
29409, 1.3304347826087, 0, 0.47727272727273
29410, 1.3086956521739, 0, 0.40909090909091
29411, 1.3304347826087, 0, 0.43181818181818
29412, 1.3086956521739, 0, 0.36363636363636
29413, 1.3304347826087, 0, 0.38636363636364
29414, 1.3086956521739, 0, 0.31818181818182
29415, 1.3304347826087, 0, 0.34090909090909
29416, 1.3086956521739, 0, 0.27272727272727
29417, 1.3304347826087, 0, 0.29545454545455
29418, 1.3086956521739, 0, 0.22727272727273
29419, 1.3304347826087, 0, 0.25
29420, 1.3086956521739, 0, 0.18181818181818
29421, 1.3304347826087, 0, 0.20454545454545
29422, 1.3086956521739, 0, 0.13636363636364
29423, 1.3304347826087, 0, 0.15909090909091
29424, 1.3086956521739, 0, 0.090909090909091
29425, 1.3304347826087, 0, 0.11363636363636
29426, 1.3086956521739, 0, 0.045454545454545
29427, 1.3304347826087, 0, 0.068181818181818
29428, 1.3304347826087, 0, 0.022727272727273
29429, 1.3521739130435, 0, 0.45454545454545
29430, 1.3739130434783, 0, 0.47727272727273
29431, 1.3521739130435, 0, 0.40909090909091
29432, 1.3739130434783, 0, 0.43181818181818
29433, 1.3521739130435, 0, 0.36363636363636
29434, 1.3739130434783, 0, 0.38636363636364
29435, 1.3521739130435, 0, 0.31818181818182
29436, 1.3739130434783, 0, 0.34090909090909
29437, 1.3521739130435, 0, 0.27272727272727
29438, 1.3739130434783, 0, 0.29545454545455
29439, 1.3521739130435, 0, 0.22727272727273
29440, 1.3739130434783, 0, 0.25
29441, 1.3521739130435, 0, 0.18181818181818
29442, 1.3739130434783, 0, 0.20454545454545
29443, 1.3521739130435, 0, 0.13636363636364
29444, 1.3739130434783, 0, 0.15909090909091
29445, 1.3521739130435, 0, 0.090909090909091
29446, 1.3739130434783, 0, 0.11363636363636
29447, 1.3521739130435, 0, 0.045454545454545
29448, 1.3739130434783, 0, 0.068181818181818
29449, 1.3739130434783, 0, 0.022727272727273
29450, 1.395652173913, 0, 0.45454545454545
29451, 1.4173913043478, 0, 0.47727272727273
29452, 1.395652173913, 0, 0.40909090909091
29453, 1.4173913043478, 0, 0.43181818181818
29454, 1.395652173913, 0, 0.36363636363636
29455, 1.4173913043478, 0, 0.38636363636364
29456, 1.395652173913, 0, 0.31818181818182
29457, 1.4173913043478, 0, 0.34090909090909
29458, 1.395652173913, 0, 0.27272727272727
29459, 1.4173913043478, 0, 0.29545454545455
29460, 1.395652173913, 0, 0.22727272727273
29461, 1.4173913043478, 0, 0.25
29462, 1.395652173913, 0, 0.18181818181818
29463, 1.4173913043478, 0, 0.20454545454545
29464, 1.395652173913, 0, 0.13636363636364
29465, 1.4173913043478, 0, 0.15909090909091
29466, 1.395652173913, 0, 0.090909090909091
29467, 1.4173913043478, 0, 0.11363636363636
29468, 1.395652173913, 0, 0.045454545454545
29469, 1.4173913043478, 0, 0.068181818181818
29470, 1.4173913043478, 0, 0.022727272727273
29471, 1.4391304347826, 0, 0.45454545454545
29472, 1.4608695652174, 0, 0.47727272727273
29473, 1.4391304347826, 0, 0.40909090909091
29474, 1.4608695652174, 0, 0.43181818181818
29475, 1.4391304347826, 0, 0.36363636363636
29476, 1.4608695652174, 0, 0.38636363636364
29477, 1.4391304347826, 0, 0.31818181818182
29478, 1.4608695652174, 0, 0.34090909090909
29479, 1.4391304347826, 0, 0.27272727272727
29480, 1.4608695652174, 0, 0.29545454545455
29481, 1.4391304347826, 0, 0.22727272727273
29482, 1.4608695652174, 0, 0.25
29483, 1.4391304347826, 0, 0.18181818181818
29484, 1.4608695652174, 0, 0.20454545454545
29485, 1.4391304347826, 0, 0.13636363636364
29486, 1.4608695652174, 0, 0.15909090909091
29487, 1.4391304347826, 0, 0.090909090909091
29488, 1.4608695652174, 0, 0.11363636363636
29489, 1.4391304347826, 0, 0.045454545454545
29490, 1.4608695652174, 0, 0.068181818181818
29491, 1.4608695652174, 0, 0.022727272727273
29492, 1.4826086956522, 0, 0.45454545454545
29493, 1.504347826087, 0, 0.47727272727273
29494, 1.4826086956522, 0, 0.40909090909091
29495, 1.504347826087, 0, 0.43181818181818
29496, 1.4826086956522, 0, 0.36363636363636
29497, 1.504347826087, 0, 0.38636363636364
29498, 1.4826086956522, 0, 0.31818181818182
29499, 1.504347826087, 0, 0.34090909090909
29500, 1.4826086956522, 0, 0.27272727272727
29501, 1.504347826087, 0, 0.29545454545455
29502, 1.4826086956522, 0, 0.22727272727273
29503, 1.504347826087, 0, 0.25
29504, 1.4826086956522, 0, 0.18181818181818
29505, 1.504347826087, 0, 0.20454545454545
29506, 1.4826086956522, 0, 0.13636363636364
29507, 1.504347826087, 0, 0.15909090909091
29508, 1.4826086956522, 0, 0.090909090909091
29509, 1.504347826087, 0, 0.11363636363636
29510, 1.4826086956522, 0, 0.045454545454545
29511, 1.504347826087, 0, 0.068181818181818
29512, 1.504347826087, 0, 0.022727272727273
29513, 1.5260869565217, 0, 0.45454545454545
29514, 1.5478260869565, 0, 0.47727272727273
29515, 1.5260869565217, 0, 0.40909090909091
29516, 1.5478260869565, 0, 0.43181818181818
29517, 1.5260869565217, 0, 0.36363636363636
29518, 1.5478260869565, 0, 0.38636363636364
29519, 1.5260869565217, 0, 0.31818181818182
29520, 1.5478260869565, 0, 0.34090909090909
29521, 1.5260869565217, 0, 0.27272727272727
29522, 1.5478260869565, 0, 0.29545454545455
29523, 1.5260869565217, 0, 0.22727272727273
29524, 1.5478260869565, 0, 0.25
29525, 1.5260869565217, 0, 0.18181818181818
29526, 1.5478260869565, 0, 0.20454545454545
29527, 1.5260869565217, 0, 0.13636363636364
29528, 1.5478260869565, 0, 0.15909090909091
29529, 1.5260869565217, 0, 0.090909090909091
29530, 1.5478260869565, 0, 0.11363636363636
29531, 1.5260869565217, 0, 0.045454545454545
29532, 1.5478260869565, 0, 0.068181818181818
29533, 1.5478260869565, 0, 0.022727272727273
29534, 1.5695652173913, 0, 0.45454545454545
29535, 1.5913043478261, 0, 0.47727272727273
29536, 1.5695652173913, 0, 0.40909090909091
29537, 1.5913043478261, 0, 0.43181818181818
29538, 1.5695652173913, 0, 0.36363636363636
29539, 1.5913043478261, 0, 0.38636363636364
29540, 1.5695652173913, 0, 0.31818181818182
29541, 1.5913043478261, 0, 0.34090909090909
29542, 1.5695652173913, 0, 0.27272727272727
29543, 1.5913043478261, 0, 0.29545454545455
29544, 1.5695652173913, 0, 0.22727272727273
29545, 1.5913043478261, 0, 0.25
29546, 1.5695652173913, 0, 0.18181818181818
29547, 1.5913043478261, 0, 0.20454545454545
29548, 1.5695652173913, 0, 0.13636363636364
29549, 1.5913043478261, 0, 0.15909090909091
29550, 1.5695652173913, 0, 0.090909090909091
29551, 1.5913043478261, 0, 0.11363636363636
29552, 1.5695652173913, 0, 0.045454545454545
29553, 1.5913043478261, 0, 0.068181818181818
29554, 1.5913043478261, 0, 0.022727272727273
29555, 1.6130434782609, 0, 0.45454545454545
29556, 1.6347826086957, 0, 0.47727272727273
29557, 1.6130434782609, 0, 0.40909090909091
29558, 1.6347826086957, 0, 0.43181818181818
29559, 1.6130434782609, 0, 0.36363636363636
29560, 1.6347826086957, 0, 0.38636363636364
29561, 1.6130434782609, 0, 0.31818181818182
29562, 1.6347826086957, 0, 0.34090909090909
29563, 1.6130434782609, 0, 0.27272727272727
29564, 1.6347826086957, 0, 0.29545454545455
29565, 1.6130434782609, 0, 0.22727272727273
29566, 1.6347826086957, 0, 0.25
29567, 1.6130434782609, 0, 0.18181818181818
29568, 1.6347826086957, 0, 0.20454545454545
29569, 1.6130434782609, 0, 0.13636363636364
29570, 1.6347826086957, 0, 0.15909090909091
29571, 1.6130434782609, 0, 0.090909090909091
29572, 1.6347826086957, 0, 0.11363636363636
29573, 1.6130434782609, 0, 0.045454545454545
29574, 1.6347826086957, 0, 0.068181818181818
29575, 1.6347826086957, 0, 0.022727272727273
29576, 1.6565217391304, 0, 0.45454545454545
29577, 1.6782608695652, 0, 0.47727272727273
29578, 1.6565217391304, 0, 0.40909090909091
29579, 1.6782608695652, 0, 0.43181818181818
29580, 1.6565217391304, 0, 0.36363636363636
29581, 1.6782608695652, 0, 0.38636363636364
29582, 1.6565217391304, 0, 0.31818181818182
29583, 1.6782608695652, 0, 0.34090909090909
29584, 1.6565217391304, 0, 0.27272727272727
29585, 1.6782608695652, 0, 0.29545454545455
29586, 1.6565217391304, 0, 0.22727272727273
29587, 1.6782608695652, 0, 0.25
29588, 1.6565217391304, 0, 0.18181818181818
29589, 1.6782608695652, 0, 0.20454545454545
29590, 1.6565217391304, 0, 0.13636363636364
29591, 1.6782608695652, 0, 0.15909090909091
29592, 1.6565217391304, 0, 0.090909090909091
29593, 1.6782608695652, 0, 0.11363636363636
29594, 1.6565217391304, 0, 0.045454545454545
29595, 1.6782608695652, 0, 0.068181818181818
29596, 1.6782608695652, 0, 0.022727272727273
29597, 1.7, 0, 0.45454545454545
29598, 1.7217391304348, 0, 0.47727272727273
29599, 1.7, 0, 0.40909090909091
29600, 1.7217391304348, 0, 0.43181818181818
29601, 1.7, 0, 0.36363636363636
29602, 1.7217391304348, 0, 0.38636363636364
29603, 1.7, 0, 0.31818181818182
29604, 1.7217391304348, 0, 0.34090909090909
29605, 1.7, 0, 0.27272727272727
29606, 1.7217391304348, 0, 0.29545454545455
29607, 1.7, 0, 0.22727272727273
29608, 1.7217391304348, 0, 0.25
29609, 1.7, 0, 0.18181818181818
29610, 1.7217391304348, 0, 0.20454545454545
29611, 1.7, 0, 0.13636363636364
29612, 1.7217391304348, 0, 0.15909090909091
29613, 1.7, 0, 0.090909090909091
29614, 1.7217391304348, 0, 0.11363636363636
29615, 1.7, 0, 0.045454545454545
29616, 1.7217391304348, 0, 0.068181818181818
29617, 1.7217391304348, 0, 0.022727272727273
29618, 1.7434782608696, 0, 0.45454545454545
29619, 1.7652173913043, 0, 0.47727272727273
29620, 1.7434782608696, 0, 0.40909090909091
29621, 1.7652173913043, 0, 0.43181818181818
29622, 1.7434782608696, 0, 0.36363636363636
29623, 1.7652173913043, 0, 0.38636363636364
29624, 1.7434782608696, 0, 0.31818181818182
29625, 1.7652173913043, 0, 0.34090909090909
29626, 1.7434782608696, 0, 0.27272727272727
29627, 1.7652173913043, 0, 0.29545454545455
29628, 1.7434782608696, 0, 0.22727272727273
29629, 1.7652173913043, 0, 0.25
29630, 1.7434782608696, 0, 0.18181818181818
29631, 1.7652173913043, 0, 0.20454545454545
29632, 1.7434782608696, 0, 0.13636363636364
29633, 1.7652173913043, 0, 0.15909090909091
29634, 1.7434782608696, 0, 0.090909090909091
29635, 1.7652173913043, 0, 0.11363636363636
29636, 1.7434782608696, 0, 0.045454545454545
29637, 1.7652173913043, 0, 0.068181818181818
29638, 1.7652173913043, 0, 0.022727272727273
29639, 1.7869565217391, 0, 0.45454545454545
29640, 1.8086956521739, 0, 0.47727272727273
29641, 1.7869565217391, 0, 0.40909090909091
29642, 1.8086956521739, 0, 0.43181818181818
29643, 1.7869565217391, 0, 0.36363636363636
29644, 1.8086956521739, 0, 0.38636363636364
29645, 1.7869565217391, 0, 0.31818181818182
29646, 1.8086956521739, 0, 0.34090909090909
29647, 1.7869565217391, 0, 0.27272727272727
29648, 1.8086956521739, 0, 0.29545454545455
29649, 1.7869565217391, 0, 0.22727272727273
29650, 1.8086956521739, 0, 0.25
29651, 1.7869565217391, 0, 0.18181818181818
29652, 1.8086956521739, 0, 0.20454545454545
29653, 1.7869565217391, 0, 0.13636363636364
29654, 1.8086956521739, 0, 0.15909090909091
29655, 1.7869565217391, 0, 0.090909090909091
29656, 1.8086956521739, 0, 0.11363636363636
29657, 1.7869565217391, 0, 0.045454545454545
29658, 1.8086956521739, 0, 0.068181818181818
29659, 1.8086956521739, 0, 0.022727272727273
29660, 1.8304347826087, 0, 0.45454545454545
29661, 1.8521739130435, 0, 0.47727272727273
29662, 1.8304347826087, 0, 0.40909090909091
29663, 1.8521739130435, 0, 0.43181818181818
29664, 1.8304347826087, 0, 0.36363636363636
29665, 1.8521739130435, 0, 0.38636363636364
29666, 1.8304347826087, 0, 0.31818181818182
29667, 1.8521739130435, 0, 0.34090909090909
29668, 1.8304347826087, 0, 0.27272727272727
29669, 1.8521739130435, 0, 0.29545454545455
29670, 1.8304347826087, 0, 0.22727272727273
29671, 1.8521739130435, 0, 0.25
29672, 1.8304347826087, 0, 0.18181818181818
29673, 1.8521739130435, 0, 0.20454545454545
29674, 1.8304347826087, 0, 0.13636363636364
29675, 1.8521739130435, 0, 0.15909090909091
29676, 1.8304347826087, 0, 0.090909090909091
29677, 1.8521739130435, 0, 0.11363636363636
29678, 1.8304347826087, 0, 0.045454545454545
29679, 1.8521739130435, 0, 0.068181818181818
29680, 1.8521739130435, 0, 0.022727272727273
29681, 1.8739130434783, 0, 0.45454545454545
29682, 1.895652173913, 0, 0.47727272727273
29683, 1.8739130434783, 0, 0.40909090909091
29684, 1.895652173913, 0, 0.43181818181818
29685, 1.8739130434783, 0, 0.36363636363636
29686, 1.895652173913, 0, 0.38636363636364
29687, 1.8739130434783, 0, 0.31818181818182
29688, 1.895652173913, 0, 0.34090909090909
29689, 1.8739130434783, 0, 0.27272727272727
29690, 1.895652173913, 0, 0.29545454545455
29691, 1.8739130434783, 0, 0.22727272727273
29692, 1.895652173913, 0, 0.25
29693, 1.8739130434783, 0, 0.18181818181818
29694, 1.895652173913, 0, 0.20454545454545
29695, 1.8739130434783, 0, 0.13636363636364
29696, 1.895652173913, 0, 0.15909090909091
29697, 1.8739130434783, 0, 0.090909090909091
29698, 1.895652173913, 0, 0.11363636363636
29699, 1.8739130434783, 0, 0.045454545454545
29700, 1.895652173913, 0, 0.068181818181818
29701, 1.895652173913, 0, 0.022727272727273
29702, 1.9173913043478, 0, 0.45454545454545
29703, 1.9391304347826, 0, 0.47727272727273
29704, 1.9173913043478, 0, 0.40909090909091
29705, 1.9391304347826, 0, 0.43181818181818
29706, 1.9173913043478, 0, 0.36363636363636
29707, 1.9391304347826, 0, 0.38636363636364
29708, 1.9173913043478, 0, 0.31818181818182
29709, 1.9391304347826, 0, 0.34090909090909
29710, 1.9173913043478, 0, 0.27272727272727
29711, 1.9391304347826, 0, 0.29545454545455
29712, 1.9173913043478, 0, 0.22727272727273
29713, 1.9391304347826, 0, 0.25
29714, 1.9173913043478, 0, 0.18181818181818
29715, 1.9391304347826, 0, 0.20454545454545
29716, 1.9173913043478, 0, 0.13636363636364
29717, 1.9391304347826, 0, 0.15909090909091
29718, 1.9173913043478, 0, 0.090909090909091
29719, 1.9391304347826, 0, 0.11363636363636
29720, 1.9173913043478, 0, 0.045454545454545
29721, 1.9391304347826, 0, 0.068181818181818
29722, 1.9391304347826, 0, 0.022727272727273
29723, 1.9608695652174, 0, 0.45454545454545
29724, 1.9826086956522, 0, 0.47727272727273
29725, 1.9608695652174, 0, 0.40909090909091
29726, 1.9826086956522, 0, 0.43181818181818
29727, 1.9608695652174, 0, 0.36363636363636
29728, 1.9826086956522, 0, 0.38636363636364
29729, 1.9608695652174, 0, 0.31818181818182
29730, 1.9826086956522, 0, 0.34090909090909
29731, 1.9608695652174, 0, 0.27272727272727
29732, 1.9826086956522, 0, 0.29545454545455
29733, 1.9608695652174, 0, 0.22727272727273
29734, 1.9826086956522, 0, 0.25
29735, 1.9608695652174, 0, 0.18181818181818
29736, 1.9826086956522, 0, 0.20454545454545
29737, 1.9608695652174, 0, 0.13636363636364
29738, 1.9826086956522, 0, 0.15909090909091
29739, 1.9608695652174, 0, 0.090909090909091
29740, 1.9826086956522, 0, 0.11363636363636
29741, 1.9608695652174, 0, 0.045454545454545
29742, 1.9826086956522, 0, 0.068181818181818
29743, 1.9826086956522, 0, 0.022727272727273
29744, 2.004347826087, 0, 0.45454545454545
29745, 2.0260869565217, 0, 0.47727272727273
29746, 2.004347826087, 0, 0.40909090909091
29747, 2.0260869565217, 0, 0.43181818181818
29748, 2.004347826087, 0, 0.36363636363636
29749, 2.0260869565217, 0, 0.38636363636364
29750, 2.004347826087, 0, 0.31818181818182
29751, 2.0260869565217, 0, 0.34090909090909
29752, 2.004347826087, 0, 0.27272727272727
29753, 2.0260869565217, 0, 0.29545454545455
29754, 2.004347826087, 0, 0.22727272727273
29755, 2.0260869565217, 0, 0.25
29756, 2.004347826087, 0, 0.18181818181818
29757, 2.0260869565217, 0, 0.20454545454545
29758, 2.004347826087, 0, 0.13636363636364
29759, 2.0260869565217, 0, 0.15909090909091
29760, 2.004347826087, 0, 0.090909090909091
29761, 2.0260869565217, 0, 0.11363636363636
29762, 2.004347826087, 0, 0.045454545454545
29763, 2.0260869565217, 0, 0.068181818181818
29764, 2.0260869565217, 0, 0.022727272727273
29765, 2.0478260869565, 0, 0.45454545454545
29766, 2.0695652173913, 0, 0.47727272727273
29767, 2.0478260869565, 0, 0.40909090909091
29768, 2.0695652173913, 0, 0.43181818181818
29769, 2.0478260869565, 0, 0.36363636363636
29770, 2.0695652173913, 0, 0.38636363636364
29771, 2.0478260869565, 0, 0.31818181818182
29772, 2.0695652173913, 0, 0.34090909090909
29773, 2.0478260869565, 0, 0.27272727272727
29774, 2.0695652173913, 0, 0.29545454545455
29775, 2.0478260869565, 0, 0.22727272727273
29776, 2.0695652173913, 0, 0.25
29777, 2.0478260869565, 0, 0.18181818181818
29778, 2.0695652173913, 0, 0.20454545454545
29779, 2.0478260869565, 0, 0.13636363636364
29780, 2.0695652173913, 0, 0.15909090909091
29781, 2.0478260869565, 0, 0.090909090909091
29782, 2.0695652173913, 0, 0.11363636363636
29783, 2.0478260869565, 0, 0.045454545454545
29784, 2.0695652173913, 0, 0.068181818181818
29785, 2.0695652173913, 0, 0.022727272727273
29786, 2.0913043478261, 0, 0.45454545454545
29787, 2.1130434782609, 0, 0.47727272727273
29788, 2.0913043478261, 0, 0.40909090909091
29789, 2.1130434782609, 0, 0.43181818181818
29790, 2.0913043478261, 0, 0.36363636363636
29791, 2.1130434782609, 0, 0.38636363636364
29792, 2.0913043478261, 0, 0.31818181818182
29793, 2.1130434782609, 0, 0.34090909090909
29794, 2.0913043478261, 0, 0.27272727272727
29795, 2.1130434782609, 0, 0.29545454545455
29796, 2.0913043478261, 0, 0.22727272727273
29797, 2.1130434782609, 0, 0.25
29798, 2.0913043478261, 0, 0.18181818181818
29799, 2.1130434782609, 0, 0.20454545454545
29800, 2.0913043478261, 0, 0.13636363636364
29801, 2.1130434782609, 0, 0.15909090909091
29802, 2.0913043478261, 0, 0.090909090909091
29803, 2.1130434782609, 0, 0.11363636363636
29804, 2.0913043478261, 0, 0.045454545454545
29805, 2.1130434782609, 0, 0.068181818181818
29806, 2.1130434782609, 0, 0.022727272727273
29807, 2.1347826086957, 0, 0.45454545454545
29808, 2.1565217391304, 0, 0.47727272727273
29809, 2.1347826086957, 0, 0.40909090909091
29810, 2.1565217391304, 0, 0.43181818181818
29811, 2.1347826086957, 0, 0.36363636363636
29812, 2.1565217391304, 0, 0.38636363636364
29813, 2.1347826086957, 0, 0.31818181818182
29814, 2.1565217391304, 0, 0.34090909090909
29815, 2.1347826086957, 0, 0.27272727272727
29816, 2.1565217391304, 0, 0.29545454545455
29817, 2.1347826086957, 0, 0.22727272727273
29818, 2.1565217391304, 0, 0.25
29819, 2.1347826086957, 0, 0.18181818181818
29820, 2.1565217391304, 0, 0.20454545454545
29821, 2.1347826086957, 0, 0.13636363636364
29822, 2.1565217391304, 0, 0.15909090909091
29823, 2.1347826086957, 0, 0.090909090909091
29824, 2.1565217391304, 0, 0.11363636363636
29825, 2.1347826086957, 0, 0.045454545454545
29826, 2.1565217391304, 0, 0.068181818181818
29827, 2.1565217391304, 0, 0.022727272727273
29828, 2.1782608695652, 0, 0.45454545454545
29829, 2.1782608695652, 0, 0.40909090909091
29830, 2.1782608695652, 0, 0.36363636363636
29831, 2.1782608695652, 0, 0.31818181818182
29832, 2.1782608695652, 0, 0.27272727272727
29833, 2.1782608695652, 0, 0.22727272727273
29834, 2.1782608695652, 0, 0.18181818181818
29835, 2.1782608695652, 0, 0.13636363636364
29836, 2.1782608695652, 0, 0.090909090909091
29837, 2.1782608695652, 0, 0.045454545454545
29838, 1.2434782608696, -0.05, 0.5
29839, 1.2869565217391, -0.05, 0.5
29840, 1.3304347826087, -0.05, 0.5
29841, 1.3739130434783, -0.05, 0.5
29842, 1.4173913043478, -0.05, 0.5
29843, 1.4608695652174, -0.05, 0.5
29844, 1.504347826087, -0.05, 0.5
29845, 1.5478260869565, -0.05, 0.5
29846, 1.5913043478261, -0.05, 0.5
29847, 1.6347826086957, -0.05, 0.5
29848, 1.6782608695652, -0.05, 0.5
29849, 1.7217391304348, -0.05, 0.5
29850, 1.7652173913043, -0.05, 0.5
29851, 1.8086956521739, -0.05, 0.5
29852, 1.8521739130435, -0.05, 0.5
29853, 1.895652173913, -0.05, 0.5
29854, 1.9391304347826, -0.05, 0.5
29855, 1.9826086956522, -0.05, 0.5
29856, 2.0260869565217, -0.05, 0.5
29857, 2.0695652173913, -0.05, 0.5
29858, 2.1130434782609, -0.05, 0.5
29859, 2.1565217391304, -0.05, 0.5
29860, 1.2434782608696, -0.1, 0.5
29861, 1.2869565217391, -0.1, 0.5
29862, 1.3304347826087, -0.1, 0.5
29863, 1.3739130434783, -0.1, 0.5
29864, 1.4173913043478, -0.1, 0.5
29865, 1.4608695652174, -0.1, 0.5
29866, 1.504347826087, -0.1, 0.5
29867, 1.5478260869565, -0.1, 0.5
29868, 1.5913043478261, -0.1, 0.5
29869, 1.6347826086957, -0.1, 0.5
29870, 1.6782608695652, -0.1, 0.5
29871, 1.7217391304348, -0.1, 0.5
29872, 1.7652173913043, -0.1, 0.5
29873, 1.8086956521739, -0.1, 0.5
29874, 1.8521739130435, -0.1, 0.5
29875, 1.895652173913, -0.1, 0.5
29876, 1.9391304347826, -0.1, 0.5
29877, 1.9826086956522, -0.1, 0.5
29878, 2.0260869565217, -0.1, 0.5
29879, 2.0695652173913, -0.1, 0.5
29880, 2.1130434782609, -0.1, 0.5
29881, 2.1565217391304, -0.1, 0.5
29882, 1.2434782608696, -0.15, 0.5
29883, 1.2869565217391, -0.15, 0.5
29884, 1.3304347826087, -0.15, 0.5
29885, 1.3739130434783, -0.15, 0.5
29886, 1.4173913043478, -0.15, 0.5
29887, 1.4608695652174, -0.15, 0.5
29888, 1.504347826087, -0.15, 0.5
29889, 1.5478260869565, -0.15, 0.5
29890, 1.5913043478261, -0.15, 0.5
29891, 1.6347826086957, -0.15, 0.5
29892, 1.6782608695652, -0.15, 0.5
29893, 1.7217391304348, -0.15, 0.5
29894, 1.7652173913043, -0.15, 0.5
29895, 1.8086956521739, -0.15, 0.5
29896, 1.8521739130435, -0.15, 0.5
29897, 1.895652173913, -0.15, 0.5
29898, 1.9391304347826, -0.15, 0.5
29899, 1.9826086956522, -0.15, 0.5
29900, 2.0260869565217, -0.15, 0.5
29901, 2.0695652173913, -0.15, 0.5
29902, 2.1130434782609, -0.15, 0.5
29903, 2.1565217391304, -0.15, 0.5
29904, 1.2217391304348, -0.05, 0.5
29905, 1.2434782608696, -0.025, 0.5
29906, 1.2652173913043, -0.05, 0.5
29907, 1.2869565217391, -0.025, 0.5
29908, 1.3086956521739, -0.05, 0.5
29909, 1.3304347826087, -0.025, 0.5
29910, 1.3521739130435, -0.05, 0.5
29911, 1.3739130434783, -0.025, 0.5
29912, 1.395652173913, -0.05, 0.5
29913, 1.4173913043478, -0.025, 0.5
29914, 1.4391304347826, -0.05, 0.5
29915, 1.4608695652174, -0.025, 0.5
29916, 1.4826086956522, -0.05, 0.5
29917, 1.504347826087, -0.025, 0.5
29918, 1.5260869565217, -0.05, 0.5
29919, 1.5478260869565, -0.025, 0.5
29920, 1.5695652173913, -0.05, 0.5
29921, 1.5913043478261, -0.025, 0.5
29922, 1.6130434782609, -0.05, 0.5
29923, 1.6347826086957, -0.025, 0.5
29924, 1.6565217391304, -0.05, 0.5
29925, 1.6782608695652, -0.025, 0.5
29926, 1.7, -0.05, 0.5
29927, 1.7217391304348, -0.025, 0.5
29928, 1.7434782608696, -0.05, 0.5
29929, 1.7652173913043, -0.025, 0.5
29930, 1.7869565217391, -0.05, 0.5
29931, 1.8086956521739, -0.025, 0.5
29932, 1.8304347826087, -0.05, 0.5
29933, 1.8521739130435, -0.025, 0.5
29934, 1.8739130434783, -0.05, 0.5
29935, 1.895652173913, -0.025, 0.5
29936, 1.9173913043478, -0.05, 0.5
29937, 1.9391304347826, -0.025, 0.5
29938, 1.9608695652174, -0.05, 0.5
29939, 1.9826086956522, -0.025, 0.5
29940, 2.004347826087, -0.05, 0.5
29941, 2.0260869565217, -0.025, 0.5
29942, 2.0478260869565, -0.05, 0.5
29943, 2.0695652173913, -0.025, 0.5
29944, 2.0913043478261, -0.05, 0.5
29945, 2.1130434782609, -0.025, 0.5
29946, 2.1347826086957, -0.05, 0.5
29947, 2.1565217391304, -0.025, 0.5
29948, 2.1782608695652, -0.05, 0.5
29949, 1.2217391304348, -0.1, 0.5
29950, 1.2434782608696, -0.075, 0.5
29951, 1.2652173913043, -0.1, 0.5
29952, 1.2869565217391, -0.075, 0.5
29953, 1.3086956521739, -0.1, 0.5
29954, 1.3304347826087, -0.075, 0.5
29955, 1.3521739130435, -0.1, 0.5
29956, 1.3739130434783, -0.075, 0.5
29957, 1.395652173913, -0.1, 0.5
29958, 1.4173913043478, -0.075, 0.5
29959, 1.4391304347826, -0.1, 0.5
29960, 1.4608695652174, -0.075, 0.5
29961, 1.4826086956522, -0.1, 0.5
29962, 1.504347826087, -0.075, 0.5
29963, 1.5260869565217, -0.1, 0.5
29964, 1.5478260869565, -0.075, 0.5
29965, 1.5695652173913, -0.1, 0.5
29966, 1.5913043478261, -0.075, 0.5
29967, 1.6130434782609, -0.1, 0.5
29968, 1.6347826086957, -0.075, 0.5
29969, 1.6565217391304, -0.1, 0.5
29970, 1.6782608695652, -0.075, 0.5
29971, 1.7, -0.1, 0.5
29972, 1.7217391304348, -0.075, 0.5
29973, 1.7434782608696, -0.1, 0.5
29974, 1.7652173913043, -0.075, 0.5
29975, 1.7869565217391, -0.1, 0.5
29976, 1.8086956521739, -0.075, 0.5
29977, 1.8304347826087, -0.1, 0.5
29978, 1.8521739130435, -0.075, 0.5
29979, 1.8739130434783, -0.1, 0.5
29980, 1.895652173913, -0.075, 0.5
29981, 1.9173913043478, -0.1, 0.5
29982, 1.9391304347826, -0.075, 0.5
29983, 1.9608695652174, -0.1, 0.5
29984, 1.9826086956522, -0.075, 0.5
29985, 2.004347826087, -0.1, 0.5
29986, 2.0260869565217, -0.075, 0.5
29987, 2.0478260869565, -0.1, 0.5
29988, 2.0695652173913, -0.075, 0.5
29989, 2.0913043478261, -0.1, 0.5
29990, 2.1130434782609, -0.075, 0.5
29991, 2.1347826086957, -0.1, 0.5
29992, 2.1565217391304, -0.075, 0.5
29993, 2.1782608695652, -0.1, 0.5
29994, 1.2217391304348, -0.15, 0.5
29995, 1.2434782608696, -0.125, 0.5
29996, 1.2652173913043, -0.15, 0.5
29997, 1.2869565217391, -0.125, 0.5
29998, 1.3086956521739, -0.15, 0.5
29999, 1.3304347826087, -0.125, 0.5
30000, 1.3521739130435, -0.15, 0.5
30001, 1.3739130434783, -0.125, 0.5
30002, 1.395652173913, -0.15, 0.5
30003, 1.4173913043478, -0.125, 0.5
30004, 1.4391304347826, -0.15, 0.5
30005, 1.4608695652174, -0.125, 0.5
30006, 1.4826086956522, -0.15, 0.5
30007, 1.504347826087, -0.125, 0.5
30008, 1.5260869565217, -0.15, 0.5
30009, 1.5478260869565, -0.125, 0.5
30010, 1.5695652173913, -0.15, 0.5
30011, 1.5913043478261, -0.125, 0.5
30012, 1.6130434782609, -0.15, 0.5
30013, 1.6347826086957, -0.125, 0.5
30014, 1.6565217391304, -0.15, 0.5
30015, 1.6782608695652, -0.125, 0.5
30016, 1.7, -0.15, 0.5
30017, 1.7217391304348, -0.125, 0.5
30018, 1.7434782608696, -0.15, 0.5
30019, 1.7652173913043, -0.125, 0.5
30020, 1.7869565217391, -0.15, 0.5
30021, 1.8086956521739, -0.125, 0.5
30022, 1.8304347826087, -0.15, 0.5
30023, 1.8521739130435, -0.125, 0.5
30024, 1.8739130434783, -0.15, 0.5
30025, 1.895652173913, -0.125, 0.5
30026, 1.9173913043478, -0.15, 0.5
30027, 1.9391304347826, -0.125, 0.5
30028, 1.9608695652174, -0.15, 0.5
30029, 1.9826086956522, -0.125, 0.5
30030, 2.004347826087, -0.15, 0.5
30031, 2.0260869565217, -0.125, 0.5
30032, 2.0478260869565, -0.15, 0.5
30033, 2.0695652173913, -0.125, 0.5
30034, 2.0913043478261, -0.15, 0.5
30035, 2.1130434782609, -0.125, 0.5
30036, 2.1347826086957, -0.15, 0.5
30037, 2.1565217391304, -0.125, 0.5
30038, 2.1782608695652, -0.15, 0.5
30039, 1.2434782608696, -0.175, 0.5
30040, 1.2869565217391, -0.175, 0.5
30041, 1.3304347826087, -0.175, 0.5
30042, 1.3739130434783, -0.175, 0.5
30043, 1.4173913043478, -0.175, 0.5
30044, 1.4608695652174, -0.175, 0.5
30045, 1.504347826087, -0.175, 0.5
30046, 1.5478260869565, -0.175, 0.5
30047, 1.5913043478261, -0.175, 0.5
30048, 1.6347826086957, -0.175, 0.5
30049, 1.6782608695652, -0.175, 0.5
30050, 1.7217391304348, -0.175, 0.5
30051, 1.7652173913043, -0.175, 0.5
30052, 1.8086956521739, -0.175, 0.5
30053, 1.8521739130435, -0.175, 0.5
30054, 1.895652173913, -0.175, 0.5
30055, 1.9391304347826, -0.175, 0.5
30056, 1.9826086956522, -0.175, 0.5
30057, 2.0260869565217, -0.175, 0.5
30058, 2.0695652173913, -0.175, 0.5
30059, 2.1130434782609, -0.175, 0.5
30060, 2.1565217391304, -0.175, 0.5
30061, 1.2434782608696, -0.05, 0
30062, 1.2869565217391, -0.05, 0
30063, 1.3304347826087, -0.05, 0
30064, 1.3739130434783, -0.05, 0
30065, 1.4173913043478, -0.05, 0
30066, 1.4608695652174, -0.05, 0
30067, 1.504347826087, -0.05, 0
30068, 1.5478260869565, -0.05, 0
30069, 1.5913043478261, -0.05, 0
30070, 1.6347826086957, -0.05, 0
30071, 1.6782608695652, -0.05, 0
30072, 1.7217391304348, -0.05, 0
30073, 1.7652173913043, -0.05, 0
30074, 1.8086956521739, -0.05, 0
30075, 1.8521739130435, -0.05, 0
30076, 1.895652173913, -0.05, 0
30077, 1.9391304347826, -0.05, 0
30078, 1.9826086956522, -0.05, 0
30079, 2.0260869565217, -0.05, 0
30080, 2.0695652173913, -0.05, 0
30081, 2.1130434782609, -0.05, 0
30082, 2.1565217391304, -0.05, 0
30083, 1.2434782608696, -0.1, 0
30084, 1.2869565217391, -0.1, 0
30085, 1.3304347826087, -0.1, 0
30086, 1.3739130434783, -0.1, 0
30087, 1.4173913043478, -0.1, 0
30088, 1.4608695652174, -0.1, 0
30089, 1.504347826087, -0.1, 0
30090, 1.5478260869565, -0.1, 0
30091, 1.5913043478261, -0.1, 0
30092, 1.6347826086957, -0.1, 0
30093, 1.6782608695652, -0.1, 0
30094, 1.7217391304348, -0.1, 0
30095, 1.7652173913043, -0.1, 0
30096, 1.8086956521739, -0.1, 0
30097, 1.8521739130435, -0.1, 0
30098, 1.895652173913, -0.1, 0
30099, 1.9391304347826, -0.1, 0
30100, 1.9826086956522, -0.1, 0
30101, 2.0260869565217, -0.1, 0
30102, 2.0695652173913, -0.1, 0
30103, 2.1130434782609, -0.1, 0
30104, 2.1565217391304, -0.1, 0
30105, 1.2434782608696, -0.15, 0
30106, 1.2869565217391, -0.15, 0
30107, 1.3304347826087, -0.15, 0
30108, 1.3739130434783, -0.15, 0
30109, 1.4173913043478, -0.15, 0
30110, 1.4608695652174, -0.15, 0
30111, 1.504347826087, -0.15, 0
30112, 1.5478260869565, -0.15, 0
30113, 1.5913043478261, -0.15, 0
30114, 1.6347826086957, -0.15, 0
30115, 1.6782608695652, -0.15, 0
30116, 1.7217391304348, -0.15, 0
30117, 1.7652173913043, -0.15, 0
30118, 1.8086956521739, -0.15, 0
30119, 1.8521739130435, -0.15, 0
30120, 1.895652173913, -0.15, 0
30121, 1.9391304347826, -0.15, 0
30122, 1.9826086956522, -0.15, 0
30123, 2.0260869565217, -0.15, 0
30124, 2.0695652173913, -0.15, 0
30125, 2.1130434782609, -0.15, 0
30126, 2.1565217391304, -0.15, 0
30127, 1.2434782608696, -0.025, 0
30128, 1.2217391304348, -0.05, 0
30129, 1.2869565217391, -0.025, 0
30130, 1.2652173913043, -0.05, 0
30131, 1.3304347826087, -0.025, 0
30132, 1.3086956521739, -0.05, 0
30133, 1.3739130434783, -0.025, 0
30134, 1.3521739130435, -0.05, 0
30135, 1.4173913043478, -0.025, 0
30136, 1.395652173913, -0.05, 0
30137, 1.4608695652174, -0.025, 0
30138, 1.4391304347826, -0.05, 0
30139, 1.504347826087, -0.025, 0
30140, 1.4826086956522, -0.05, 0
30141, 1.5478260869565, -0.025, 0
30142, 1.5260869565217, -0.05, 0
30143, 1.5913043478261, -0.025, 0
30144, 1.5695652173913, -0.05, 0
30145, 1.6347826086957, -0.025, 0
30146, 1.6130434782609, -0.05, 0
30147, 1.6782608695652, -0.025, 0
30148, 1.6565217391304, -0.05, 0
30149, 1.7217391304348, -0.025, 0
30150, 1.7, -0.05, 0
30151, 1.7652173913043, -0.025, 0
30152, 1.7434782608696, -0.05, 0
30153, 1.8086956521739, -0.025, 0
30154, 1.7869565217391, -0.05, 0
30155, 1.8521739130435, -0.025, 0
30156, 1.8304347826087, -0.05, 0
30157, 1.895652173913, -0.025, 0
30158, 1.8739130434783, -0.05, 0
30159, 1.9391304347826, -0.025, 0
30160, 1.9173913043478, -0.05, 0
30161, 1.9826086956522, -0.025, 0
30162, 1.9608695652174, -0.05, 0
30163, 2.0260869565217, -0.025, 0
30164, 2.004347826087, -0.05, 0
30165, 2.0695652173913, -0.025, 0
30166, 2.0478260869565, -0.05, 0
30167, 2.1130434782609, -0.025, 0
30168, 2.0913043478261, -0.05, 0
30169, 2.1565217391304, -0.025, 0
30170, 2.1347826086957, -0.05, 0
30171, 2.1782608695652, -0.05, 0
30172, 1.2434782608696, -0.075, 0
30173, 1.2217391304348, -0.1, 0
30174, 1.2869565217391, -0.075, 0
30175, 1.2652173913043, -0.1, 0
30176, 1.3304347826087, -0.075, 0
30177, 1.3086956521739, -0.1, 0
30178, 1.3739130434783, -0.075, 0
30179, 1.3521739130435, -0.1, 0
30180, 1.4173913043478, -0.075, 0
30181, 1.395652173913, -0.1, 0
30182, 1.4608695652174, -0.075, 0
30183, 1.4391304347826, -0.1, 0
30184, 1.504347826087, -0.075, 0
30185, 1.4826086956522, -0.1, 0
30186, 1.5478260869565, -0.075, 0
30187, 1.5260869565217, -0.1, 0
30188, 1.5913043478261, -0.075, 0
30189, 1.5695652173913, -0.1, 0
30190, 1.6347826086957, -0.075, 0
30191, 1.6130434782609, -0.1, 0
30192, 1.6782608695652, -0.075, 0
30193, 1.6565217391304, -0.1, 0
30194, 1.7217391304348, -0.075, 0
30195, 1.7, -0.1, 0
30196, 1.7652173913043, -0.075, 0
30197, 1.7434782608696, -0.1, 0
30198, 1.8086956521739, -0.075, 0
30199, 1.7869565217391, -0.1, 0
30200, 1.8521739130435, -0.075, 0
30201, 1.8304347826087, -0.1, 0
30202, 1.895652173913, -0.075, 0
30203, 1.8739130434783, -0.1, 0
30204, 1.9391304347826, -0.075, 0
30205, 1.9173913043478, -0.1, 0
30206, 1.9826086956522, -0.075, 0
30207, 1.9608695652174, -0.1, 0
30208, 2.0260869565217, -0.075, 0
30209, 2.004347826087, -0.1, 0
30210, 2.0695652173913, -0.075, 0
30211, 2.0478260869565, -0.1, 0
30212, 2.1130434782609, -0.075, 0
30213, 2.0913043478261, -0.1, 0
30214, 2.1565217391304, -0.075, 0
30215, 2.1347826086957, -0.1, 0
30216, 2.1782608695652, -0.1, 0
30217, 1.2434782608696, -0.125, 0
30218, 1.2217391304348, -0.15, 0
30219, 1.2869565217391, -0.125, 0
30220, 1.2652173913043, -0.15, 0
30221, 1.3304347826087, -0.125, 0
30222, 1.3086956521739, -0.15, 0
30223, 1.3739130434783, -0.125, 0
30224, 1.3521739130435, -0.15, 0
30225, 1.4173913043478, -0.125, 0
30226, 1.395652173913, -0.15, 0
30227, 1.4608695652174, -0.125, 0
30228, 1.4391304347826, -0.15, 0
30229, 1.504347826087, -0.125, 0
30230, 1.4826086956522, -0.15, 0
30231, 1.5478260869565, -0.125, 0
30232, 1.5260869565217, -0.15, 0
30233, 1.5913043478261, -0.125, 0
30234, 1.5695652173913, -0.15, 0
30235, 1.6347826086957, -0.125, 0
30236, 1.6130434782609, -0.15, 0
30237, 1.6782608695652, -0.125, 0
30238, 1.6565217391304, -0.15, 0
30239, 1.7217391304348, -0.125, 0
30240, 1.7, -0.15, 0
30241, 1.7652173913043, -0.125, 0
30242, 1.7434782608696, -0.15, 0
30243, 1.8086956521739, -0.125, 0
30244, 1.7869565217391, -0.15, 0
30245, 1.8521739130435, -0.125, 0
30246, 1.8304347826087, -0.15, 0
30247, 1.895652173913, -0.125, 0
30248, 1.8739130434783, -0.15, 0
30249, 1.9391304347826, -0.125, 0
30250, 1.9173913043478, -0.15, 0
30251, 1.9826086956522, -0.125, 0
30252, 1.9608695652174, -0.15, 0
30253, 2.0260869565217, -0.125, 0
30254, 2.004347826087, -0.15, 0
30255, 2.0695652173913, -0.125, 0
30256, 2.0478260869565, -0.15, 0
30257, 2.1130434782609, -0.125, 0
30258, 2.0913043478261, -0.15, 0
30259, 2.1565217391304, -0.125, 0
30260, 2.1347826086957, -0.15, 0
30261, 2.1782608695652, -0.15, 0
30262, 1.2434782608696, -0.175, 0
30263, 1.2869565217391, -0.175, 0
30264, 1.3304347826087, -0.175, 0
30265, 1.3739130434783, -0.175, 0
30266, 1.4173913043478, -0.175, 0
30267, 1.4608695652174, -0.175, 0
30268, 1.504347826087, -0.175, 0
30269, 1.5478260869565, -0.175, 0
30270, 1.5913043478261, -0.175, 0
30271, 1.6347826086957, -0.175, 0
30272, 1.6782608695652, -0.175, 0
30273, 1.7217391304348, -0.175, 0
30274, 1.7652173913043, -0.175, 0
30275, 1.8086956521739, -0.175, 0
30276, 1.8521739130435, -0.175, 0
30277, 1.895652173913, -0.175, 0
30278, 1.9391304347826, -0.175, 0
30279, 1.9826086956522, -0.175, 0
30280, 2.0260869565217, -0.175, 0
30281, 2.0695652173913, -0.175, 0
30282, 2.1130434782609, -0.175, 0
30283, 2.1565217391304, -0.175, 0
30284, 1.2, -0.05, 0.45454545454545
30285, 1.2, -0.05, 0.40909090909091
30286, 1.2, -0.05, 0.36363636363636
30287, 1.2, -0.05, 0.31818181818182
30288, 1.2, -0.05, 0.27272727272727
30289, 1.2, -0.05, 0.22727272727273
30290, 1.2, -0.05, 0.18181818181818
30291, 1.2, -0.05, 0.13636363636364
30292, 1.2, -0.05, 0.090909090909091
30293, 1.2, -0.05, 0.045454545454545
30294, 1.2, -0.1, 0.45454545454545
30295, 1.2, -0.1, 0.40909090909091
30296, 1.2, -0.1, 0.36363636363636
30297, 1.2, -0.1, 0.31818181818182
30298, 1.2, -0.1, 0.27272727272727
30299, 1.2, -0.1, 0.22727272727273
30300, 1.2, -0.1, 0.18181818181818
30301, 1.2, -0.1, 0.13636363636364
30302, 1.2, -0.1, 0.090909090909091
30303, 1.2, -0.1, 0.045454545454545
30304, 1.2, -0.15, 0.45454545454545
30305, 1.2, -0.15, 0.40909090909091
30306, 1.2, -0.15, 0.36363636363636
30307, 1.2, -0.15, 0.31818181818182
30308, 1.2, -0.15, 0.27272727272727
30309, 1.2, -0.15, 0.22727272727273
30310, 1.2, -0.15, 0.18181818181818
30311, 1.2, -0.15, 0.13636363636364
30312, 1.2, -0.15, 0.090909090909091
30313, 1.2, -0.15, 0.045454545454545
30314, 1.2, -0.025, 0.45454545454545
30315, 1.2, -0.05, 0.47727272727273
30316, 1.2, -0.025, 0.40909090909091
30317, 1.2, -0.05, 0.43181818181818
30318, 1.2, -0.025, 0.36363636363636
30319, 1.2, -0.05, 0.38636363636364
30320, 1.2, -0.025, 0.31818181818182
30321, 1.2, -0.05, 0.34090909090909
30322, 1.2, -0.025, 0.27272727272727
30323, 1.2, -0.05, 0.29545454545455
30324, 1.2, -0.025, 0.22727272727273
30325, 1.2, -0.05, 0.25
30326, 1.2, -0.025, 0.18181818181818
30327, 1.2, -0.05, 0.20454545454545
30328, 1.2, -0.025, 0.13636363636364
30329, 1.2, -0.05, 0.15909090909091
30330, 1.2, -0.025, 0.090909090909091
30331, 1.2, -0.05, 0.11363636363636
30332, 1.2, -0.025, 0.045454545454545
30333, 1.2, -0.05, 0.068181818181818
30334, 1.2, -0.05, 0.022727272727273
30335, 1.2, -0.075, 0.45454545454545
30336, 1.2, -0.1, 0.47727272727273
30337, 1.2, -0.075, 0.40909090909091
30338, 1.2, -0.1, 0.43181818181818
30339, 1.2, -0.075, 0.36363636363636
30340, 1.2, -0.1, 0.38636363636364
30341, 1.2, -0.075, 0.31818181818182
30342, 1.2, -0.1, 0.34090909090909
30343, 1.2, -0.075, 0.27272727272727
30344, 1.2, -0.1, 0.29545454545455
30345, 1.2, -0.075, 0.22727272727273
30346, 1.2, -0.1, 0.25
30347, 1.2, -0.075, 0.18181818181818
30348, 1.2, -0.1, 0.20454545454545
30349, 1.2, -0.075, 0.13636363636364
30350, 1.2, -0.1, 0.15909090909091
30351, 1.2, -0.075, 0.090909090909091
30352, 1.2, -0.1, 0.11363636363636
30353, 1.2, -0.075, 0.045454545454545
30354, 1.2, -0.1, 0.068181818181818
30355, 1.2, -0.1, 0.022727272727273
30356, 1.2, -0.125, 0.45454545454545
30357, 1.2, -0.15, 0.47727272727273
30358, 1.2, -0.125, 0.40909090909091
30359, 1.2, -0.15, 0.43181818181818
30360, 1.2, -0.125, 0.36363636363636
30361, 1.2, -0.15, 0.38636363636364
30362, 1.2, -0.125, 0.31818181818182
30363, 1.2, -0.15, 0.34090909090909
30364, 1.2, -0.125, 0.27272727272727
30365, 1.2, -0.15, 0.29545454545455
30366, 1.2, -0.125, 0.22727272727273
30367, 1.2, -0.15, 0.25
30368, 1.2, -0.125, 0.18181818181818
30369, 1.2, -0.15, 0.20454545454545
30370, 1.2, -0.125, 0.13636363636364
30371, 1.2, -0.15, 0.15909090909091
30372, 1.2, -0.125, 0.090909090909091
30373, 1.2, -0.15, 0.11363636363636
30374, 1.2, -0.125, 0.045454545454545
30375, 1.2, -0.15, 0.068181818181818
30376, 1.2, -0.15, 0.022727272727273
30377, 1.2, -0.175, 0.45454545454545
30378, 1.2, -0.175, 0.40909090909091
30379, 1.2, -0.175, 0.36363636363636
30380, 1.2, -0.175, 0.31818181818182
30381, 1.2, -0.175, 0.27272727272727
30382, 1.2, -0.175, 0.22727272727273
30383, 1.2, -0.175, 0.18181818181818
30384, 1.2, -0.175, 0.13636363636364
30385, 1.2, -0.175, 0.090909090909091
30386, 1.2, -0.175, 0.045454545454545
30387, 1.2434782608696, -0.2, 0.45454545454545
30388, 1.2434782608696, -0.2, 0.40909090909091
30389, 1.2434782608696, -0.2, 0.36363636363636
30390, 1.2434782608696, -0.2, 0.31818181818182
30391, 1.2434782608696, -0.2, 0.27272727272727
30392, 1.2434782608696, -0.2, 0.22727272727273
30393, 1.2434782608696, -0.2, 0.18181818181818
30394, 1.2434782608696, -0.2, 0.13636363636364
30395, 1.2434782608696, -0.2, 0.090909090909091
30396, 1.2434782608696, -0.2, 0.045454545454545
30397, 1.2869565217391, -0.2, 0.45454545454545
30398, 1.2869565217391, -0.2, 0.40909090909091
30399, 1.2869565217391, -0.2, 0.36363636363636
30400, 1.2869565217391, -0.2, 0.31818181818182
30401, 1.2869565217391, -0.2, 0.27272727272727
30402, 1.2869565217391, -0.2, 0.22727272727273
30403, 1.2869565217391, -0.2, 0.18181818181818
30404, 1.2869565217391, -0.2, 0.13636363636364
30405, 1.2869565217391, -0.2, 0.090909090909091
30406, 1.2869565217391, -0.2, 0.045454545454545
30407, 1.3304347826087, -0.2, 0.45454545454545
30408, 1.3304347826087, -0.2, 0.40909090909091
30409, 1.3304347826087, -0.2, 0.36363636363636
30410, 1.3304347826087, -0.2, 0.31818181818182
30411, 1.3304347826087, -0.2, 0.27272727272727
30412, 1.3304347826087, -0.2, 0.22727272727273
30413, 1.3304347826087, -0.2, 0.18181818181818
30414, 1.3304347826087, -0.2, 0.13636363636364
30415, 1.3304347826087, -0.2, 0.090909090909091
30416, 1.3304347826087, -0.2, 0.045454545454545
30417, 1.3739130434783, -0.2, 0.45454545454545
30418, 1.3739130434783, -0.2, 0.40909090909091
30419, 1.3739130434783, -0.2, 0.36363636363636
30420, 1.3739130434783, -0.2, 0.31818181818182
30421, 1.3739130434783, -0.2, 0.27272727272727
30422, 1.3739130434783, -0.2, 0.22727272727273
30423, 1.3739130434783, -0.2, 0.18181818181818
30424, 1.3739130434783, -0.2, 0.13636363636364
30425, 1.3739130434783, -0.2, 0.090909090909091
30426, 1.3739130434783, -0.2, 0.045454545454545
30427, 1.4173913043478, -0.2, 0.45454545454545
30428, 1.4173913043478, -0.2, 0.40909090909091
30429, 1.4173913043478, -0.2, 0.36363636363636
30430, 1.4173913043478, -0.2, 0.31818181818182
30431, 1.4173913043478, -0.2, 0.27272727272727
30432, 1.4173913043478, -0.2, 0.22727272727273
30433, 1.4173913043478, -0.2, 0.18181818181818
30434, 1.4173913043478, -0.2, 0.13636363636364
30435, 1.4173913043478, -0.2, 0.090909090909091
30436, 1.4173913043478, -0.2, 0.045454545454545
30437, 1.4608695652174, -0.2, 0.45454545454545
30438, 1.4608695652174, -0.2, 0.40909090909091
30439, 1.4608695652174, -0.2, 0.36363636363636
30440, 1.4608695652174, -0.2, 0.31818181818182
30441, 1.4608695652174, -0.2, 0.27272727272727
30442, 1.4608695652174, -0.2, 0.22727272727273
30443, 1.4608695652174, -0.2, 0.18181818181818
30444, 1.4608695652174, -0.2, 0.13636363636364
30445, 1.4608695652174, -0.2, 0.090909090909091
30446, 1.4608695652174, -0.2, 0.045454545454545
30447, 1.504347826087, -0.2, 0.45454545454545
30448, 1.504347826087, -0.2, 0.40909090909091
30449, 1.504347826087, -0.2, 0.36363636363636
30450, 1.504347826087, -0.2, 0.31818181818182
30451, 1.504347826087, -0.2, 0.27272727272727
30452, 1.504347826087, -0.2, 0.22727272727273
30453, 1.504347826087, -0.2, 0.18181818181818
30454, 1.504347826087, -0.2, 0.13636363636364
30455, 1.504347826087, -0.2, 0.090909090909091
30456, 1.504347826087, -0.2, 0.045454545454545
30457, 1.5478260869565, -0.2, 0.45454545454545
30458, 1.5478260869565, -0.2, 0.40909090909091
30459, 1.5478260869565, -0.2, 0.36363636363636
30460, 1.5478260869565, -0.2, 0.31818181818182
30461, 1.5478260869565, -0.2, 0.27272727272727
30462, 1.5478260869565, -0.2, 0.22727272727273
30463, 1.5478260869565, -0.2, 0.18181818181818
30464, 1.5478260869565, -0.2, 0.13636363636364
30465, 1.5478260869565, -0.2, 0.090909090909091
30466, 1.5478260869565, -0.2, 0.045454545454545
30467, 1.5913043478261, -0.2, 0.45454545454545
30468, 1.5913043478261, -0.2, 0.40909090909091
30469, 1.5913043478261, -0.2, 0.36363636363636
30470, 1.5913043478261, -0.2, 0.31818181818182
30471, 1.5913043478261, -0.2, 0.27272727272727
30472, 1.5913043478261, -0.2, 0.22727272727273
30473, 1.5913043478261, -0.2, 0.18181818181818
30474, 1.5913043478261, -0.2, 0.13636363636364
30475, 1.5913043478261, -0.2, 0.090909090909091
30476, 1.5913043478261, -0.2, 0.045454545454545
30477, 1.6347826086957, -0.2, 0.45454545454545
30478, 1.6347826086957, -0.2, 0.40909090909091
30479, 1.6347826086957, -0.2, 0.36363636363636
30480, 1.6347826086957, -0.2, 0.31818181818182
30481, 1.6347826086957, -0.2, 0.27272727272727
30482, 1.6347826086957, -0.2, 0.22727272727273
30483, 1.6347826086957, -0.2, 0.18181818181818
30484, 1.6347826086957, -0.2, 0.13636363636364
30485, 1.6347826086957, -0.2, 0.090909090909091
30486, 1.6347826086957, -0.2, 0.045454545454545
30487, 1.6782608695652, -0.2, 0.45454545454545
30488, 1.6782608695652, -0.2, 0.40909090909091
30489, 1.6782608695652, -0.2, 0.36363636363636
30490, 1.6782608695652, -0.2, 0.31818181818182
30491, 1.6782608695652, -0.2, 0.27272727272727
30492, 1.6782608695652, -0.2, 0.22727272727273
30493, 1.6782608695652, -0.2, 0.18181818181818
30494, 1.6782608695652, -0.2, 0.13636363636364
30495, 1.6782608695652, -0.2, 0.090909090909091
30496, 1.6782608695652, -0.2, 0.045454545454545
30497, 1.7217391304348, -0.2, 0.45454545454545
30498, 1.7217391304348, -0.2, 0.40909090909091
30499, 1.7217391304348, -0.2, 0.36363636363636
30500, 1.7217391304348, -0.2, 0.31818181818182
30501, 1.7217391304348, -0.2, 0.27272727272727
30502, 1.7217391304348, -0.2, 0.22727272727273
30503, 1.7217391304348, -0.2, 0.18181818181818
30504, 1.7217391304348, -0.2, 0.13636363636364
30505, 1.7217391304348, -0.2, 0.090909090909091
30506, 1.7217391304348, -0.2, 0.045454545454545
30507, 1.7652173913043, -0.2, 0.45454545454545
30508, 1.7652173913043, -0.2, 0.40909090909091
30509, 1.7652173913043, -0.2, 0.36363636363636
30510, 1.7652173913043, -0.2, 0.31818181818182
30511, 1.7652173913043, -0.2, 0.27272727272727
30512, 1.7652173913043, -0.2, 0.22727272727273
30513, 1.7652173913043, -0.2, 0.18181818181818
30514, 1.7652173913043, -0.2, 0.13636363636364
30515, 1.7652173913043, -0.2, 0.090909090909091
30516, 1.7652173913043, -0.2, 0.045454545454545
30517, 1.8086956521739, -0.2, 0.45454545454545
30518, 1.8086956521739, -0.2, 0.40909090909091
30519, 1.8086956521739, -0.2, 0.36363636363636
30520, 1.8086956521739, -0.2, 0.31818181818182
30521, 1.8086956521739, -0.2, 0.27272727272727
30522, 1.8086956521739, -0.2, 0.22727272727273
30523, 1.8086956521739, -0.2, 0.18181818181818
30524, 1.8086956521739, -0.2, 0.13636363636364
30525, 1.8086956521739, -0.2, 0.090909090909091
30526, 1.8086956521739, -0.2, 0.045454545454545
30527, 1.8521739130435, -0.2, 0.45454545454545
30528, 1.8521739130435, -0.2, 0.40909090909091
30529, 1.8521739130435, -0.2, 0.36363636363636
30530, 1.8521739130435, -0.2, 0.31818181818182
30531, 1.8521739130435, -0.2, 0.27272727272727
30532, 1.8521739130435, -0.2, 0.22727272727273
30533, 1.8521739130435, -0.2, 0.18181818181818
30534, 1.8521739130435, -0.2, 0.13636363636364
30535, 1.8521739130435, -0.2, 0.090909090909091
30536, 1.8521739130435, -0.2, 0.045454545454545
30537, 1.895652173913, -0.2, 0.45454545454545
30538, 1.895652173913, -0.2, 0.40909090909091
30539, 1.895652173913, -0.2, 0.36363636363636
30540, 1.895652173913, -0.2, 0.31818181818182
30541, 1.895652173913, -0.2, 0.27272727272727
30542, 1.895652173913, -0.2, 0.22727272727273
30543, 1.895652173913, -0.2, 0.18181818181818
30544, 1.895652173913, -0.2, 0.13636363636364
30545, 1.895652173913, -0.2, 0.090909090909091
30546, 1.895652173913, -0.2, 0.045454545454545
30547, 1.9391304347826, -0.2, 0.45454545454545
30548, 1.9391304347826, -0.2, 0.40909090909091
30549, 1.9391304347826, -0.2, 0.36363636363636
30550, 1.9391304347826, -0.2, 0.31818181818182
30551, 1.9391304347826, -0.2, 0.27272727272727
30552, 1.9391304347826, -0.2, 0.22727272727273
30553, 1.9391304347826, -0.2, 0.18181818181818
30554, 1.9391304347826, -0.2, 0.13636363636364
30555, 1.9391304347826, -0.2, 0.090909090909091
30556, 1.9391304347826, -0.2, 0.045454545454545
30557, 1.9826086956522, -0.2, 0.45454545454545
30558, 1.9826086956522, -0.2, 0.40909090909091
30559, 1.9826086956522, -0.2, 0.36363636363636
30560, 1.9826086956522, -0.2, 0.31818181818182
30561, 1.9826086956522, -0.2, 0.27272727272727
30562, 1.9826086956522, -0.2, 0.22727272727273
30563, 1.9826086956522, -0.2, 0.18181818181818
30564, 1.9826086956522, -0.2, 0.13636363636364
30565, 1.9826086956522, -0.2, 0.090909090909091
30566, 1.9826086956522, -0.2, 0.045454545454545
30567, 2.0260869565217, -0.2, 0.45454545454545
30568, 2.0260869565217, -0.2, 0.40909090909091
30569, 2.0260869565217, -0.2, 0.36363636363636
30570, 2.0260869565217, -0.2, 0.31818181818182
30571, 2.0260869565217, -0.2, 0.27272727272727
30572, 2.0260869565217, -0.2, 0.22727272727273
30573, 2.0260869565217, -0.2, 0.18181818181818
30574, 2.0260869565217, -0.2, 0.13636363636364
30575, 2.0260869565217, -0.2, 0.090909090909091
30576, 2.0260869565217, -0.2, 0.045454545454545
30577, 2.0695652173913, -0.2, 0.45454545454545
30578, 2.0695652173913, -0.2, 0.40909090909091
30579, 2.0695652173913, -0.2, 0.36363636363636
30580, 2.0695652173913, -0.2, 0.31818181818182
30581, 2.0695652173913, -0.2, 0.27272727272727
30582, 2.0695652173913, -0.2, 0.22727272727273
30583, 2.0695652173913, -0.2, 0.18181818181818
30584, 2.0695652173913, -0.2, 0.13636363636364
30585, 2.0695652173913, -0.2, 0.090909090909091
30586, 2.0695652173913, -0.2, 0.045454545454545
30587, 2.1130434782609, -0.2, 0.45454545454545
30588, 2.1130434782609, -0.2, 0.40909090909091
30589, 2.1130434782609, -0.2, 0.36363636363636
30590, 2.1130434782609, -0.2, 0.31818181818182
30591, 2.1130434782609, -0.2, 0.27272727272727
30592, 2.1130434782609, -0.2, 0.22727272727273
30593, 2.1130434782609, -0.2, 0.18181818181818
30594, 2.1130434782609, -0.2, 0.13636363636364
30595, 2.1130434782609, -0.2, 0.090909090909091
30596, 2.1130434782609, -0.2, 0.045454545454545
30597, 2.1565217391304, -0.2, 0.45454545454545
30598, 2.1565217391304, -0.2, 0.40909090909091
30599, 2.1565217391304, -0.2, 0.36363636363636
30600, 2.1565217391304, -0.2, 0.31818181818182
30601, 2.1565217391304, -0.2, 0.27272727272727
30602, 2.1565217391304, -0.2, 0.22727272727273
30603, 2.1565217391304, -0.2, 0.18181818181818
30604, 2.1565217391304, -0.2, 0.13636363636364
30605, 2.1565217391304, -0.2, 0.090909090909091
30606, 2.1565217391304, -0.2, 0.045454545454545
30607, 1.2217391304348, -0.2, 0.45454545454545
30608, 1.2434782608696, -0.2, 0.47727272727273
30609, 1.2217391304348, -0.2, 0.40909090909091
30610, 1.2434782608696, -0.2, 0.43181818181818
30611, 1.2217391304348, -0.2, 0.36363636363636
30612, 1.2434782608696, -0.2, 0.38636363636364
30613, 1.2217391304348, -0.2, 0.31818181818182
30614, 1.2434782608696, -0.2, 0.34090909090909
30615, 1.2217391304348, -0.2, 0.27272727272727
30616, 1.2434782608696, -0.2, 0.29545454545455
30617, 1.2217391304348, -0.2, 0.22727272727273
30618, 1.2434782608696, -0.2, 0.25
30619, 1.2217391304348, -0.2, 0.18181818181818
30620, 1.2434782608696, -0.2, 0.20454545454545
30621, 1.2217391304348, -0.2, 0.13636363636364
30622, 1.2434782608696, -0.2, 0.15909090909091
30623, 1.2217391304348, -0.2, 0.090909090909091
30624, 1.2434782608696, -0.2, 0.11363636363636
30625, 1.2217391304348, -0.2, 0.045454545454545
30626, 1.2434782608696, -0.2, 0.068181818181818
30627, 1.2434782608696, -0.2, 0.022727272727273
30628, 1.2652173913043, -0.2, 0.45454545454545
30629, 1.2869565217391, -0.2, 0.47727272727273
30630, 1.2652173913043, -0.2, 0.40909090909091
30631, 1.2869565217391, -0.2, 0.43181818181818
30632, 1.2652173913043, -0.2, 0.36363636363636
30633, 1.2869565217391, -0.2, 0.38636363636364
30634, 1.2652173913043, -0.2, 0.31818181818182
30635, 1.2869565217391, -0.2, 0.34090909090909
30636, 1.2652173913043, -0.2, 0.27272727272727
30637, 1.2869565217391, -0.2, 0.29545454545455
30638, 1.2652173913043, -0.2, 0.22727272727273
30639, 1.2869565217391, -0.2, 0.25
30640, 1.2652173913043, -0.2, 0.18181818181818
30641, 1.2869565217391, -0.2, 0.20454545454545
30642, 1.2652173913043, -0.2, 0.13636363636364
30643, 1.2869565217391, -0.2, 0.15909090909091
30644, 1.2652173913043, -0.2, 0.090909090909091
30645, 1.2869565217391, -0.2, 0.11363636363636
30646, 1.2652173913043, -0.2, 0.045454545454545
30647, 1.2869565217391, -0.2, 0.068181818181818
30648, 1.2869565217391, -0.2, 0.022727272727273
30649, 1.3086956521739, -0.2, 0.45454545454545
30650, 1.3304347826087, -0.2, 0.47727272727273
30651, 1.3086956521739, -0.2, 0.40909090909091
30652, 1.3304347826087, -0.2, 0.43181818181818
30653, 1.3086956521739, -0.2, 0.36363636363636
30654, 1.3304347826087, -0.2, 0.38636363636364
30655, 1.3086956521739, -0.2, 0.31818181818182
30656, 1.3304347826087, -0.2, 0.34090909090909
30657, 1.3086956521739, -0.2, 0.27272727272727
30658, 1.3304347826087, -0.2, 0.29545454545455
30659, 1.3086956521739, -0.2, 0.22727272727273
30660, 1.3304347826087, -0.2, 0.25
30661, 1.3086956521739, -0.2, 0.18181818181818
30662, 1.3304347826087, -0.2, 0.20454545454545
30663, 1.3086956521739, -0.2, 0.13636363636364
30664, 1.3304347826087, -0.2, 0.15909090909091
30665, 1.3086956521739, -0.2, 0.090909090909091
30666, 1.3304347826087, -0.2, 0.11363636363636
30667, 1.3086956521739, -0.2, 0.045454545454545
30668, 1.3304347826087, -0.2, 0.068181818181818
30669, 1.3304347826087, -0.2, 0.022727272727273
30670, 1.3521739130435, -0.2, 0.45454545454545
30671, 1.3739130434783, -0.2, 0.47727272727273
30672, 1.3521739130435, -0.2, 0.40909090909091
30673, 1.3739130434783, -0.2, 0.43181818181818
30674, 1.3521739130435, -0.2, 0.36363636363636
30675, 1.3739130434783, -0.2, 0.38636363636364
30676, 1.3521739130435, -0.2, 0.31818181818182
30677, 1.3739130434783, -0.2, 0.34090909090909
30678, 1.3521739130435, -0.2, 0.27272727272727
30679, 1.3739130434783, -0.2, 0.29545454545455
30680, 1.3521739130435, -0.2, 0.22727272727273
30681, 1.3739130434783, -0.2, 0.25
30682, 1.3521739130435, -0.2, 0.18181818181818
30683, 1.3739130434783, -0.2, 0.20454545454545
30684, 1.3521739130435, -0.2, 0.13636363636364
30685, 1.3739130434783, -0.2, 0.15909090909091
30686, 1.3521739130435, -0.2, 0.090909090909091
30687, 1.3739130434783, -0.2, 0.11363636363636
30688, 1.3521739130435, -0.2, 0.045454545454545
30689, 1.3739130434783, -0.2, 0.068181818181818
30690, 1.3739130434783, -0.2, 0.022727272727273
30691, 1.395652173913, -0.2, 0.45454545454545
30692, 1.4173913043478, -0.2, 0.47727272727273
30693, 1.395652173913, -0.2, 0.40909090909091
30694, 1.4173913043478, -0.2, 0.43181818181818
30695, 1.395652173913, -0.2, 0.36363636363636
30696, 1.4173913043478, -0.2, 0.38636363636364
30697, 1.395652173913, -0.2, 0.31818181818182
30698, 1.4173913043478, -0.2, 0.34090909090909
30699, 1.395652173913, -0.2, 0.27272727272727
30700, 1.4173913043478, -0.2, 0.29545454545455
30701, 1.395652173913, -0.2, 0.22727272727273
30702, 1.4173913043478, -0.2, 0.25
30703, 1.395652173913, -0.2, 0.18181818181818
30704, 1.4173913043478, -0.2, 0.20454545454545
30705, 1.395652173913, -0.2, 0.13636363636364
30706, 1.4173913043478, -0.2, 0.15909090909091
30707, 1.395652173913, -0.2, 0.090909090909091
30708, 1.4173913043478, -0.2, 0.11363636363636
30709, 1.395652173913, -0.2, 0.045454545454545
30710, 1.4173913043478, -0.2, 0.068181818181818
30711, 1.4173913043478, -0.2, 0.022727272727273
30712, 1.4391304347826, -0.2, 0.45454545454545
30713, 1.4608695652174, -0.2, 0.47727272727273
30714, 1.4391304347826, -0.2, 0.40909090909091
30715, 1.4608695652174, -0.2, 0.43181818181818
30716, 1.4391304347826, -0.2, 0.36363636363636
30717, 1.4608695652174, -0.2, 0.38636363636364
30718, 1.4391304347826, -0.2, 0.31818181818182
30719, 1.4608695652174, -0.2, 0.34090909090909
30720, 1.4391304347826, -0.2, 0.27272727272727
30721, 1.4608695652174, -0.2, 0.29545454545455
30722, 1.4391304347826, -0.2, 0.22727272727273
30723, 1.4608695652174, -0.2, 0.25
30724, 1.4391304347826, -0.2, 0.18181818181818
30725, 1.4608695652174, -0.2, 0.20454545454545
30726, 1.4391304347826, -0.2, 0.13636363636364
30727, 1.4608695652174, -0.2, 0.15909090909091
30728, 1.4391304347826, -0.2, 0.090909090909091
30729, 1.4608695652174, -0.2, 0.11363636363636
30730, 1.4391304347826, -0.2, 0.045454545454545
30731, 1.4608695652174, -0.2, 0.068181818181818
30732, 1.4608695652174, -0.2, 0.022727272727273
30733, 1.4826086956522, -0.2, 0.45454545454545
30734, 1.504347826087, -0.2, 0.47727272727273
30735, 1.4826086956522, -0.2, 0.40909090909091
30736, 1.504347826087, -0.2, 0.43181818181818
30737, 1.4826086956522, -0.2, 0.36363636363636
30738, 1.504347826087, -0.2, 0.38636363636364
30739, 1.4826086956522, -0.2, 0.31818181818182
30740, 1.504347826087, -0.2, 0.34090909090909
30741, 1.4826086956522, -0.2, 0.27272727272727
30742, 1.504347826087, -0.2, 0.29545454545455
30743, 1.4826086956522, -0.2, 0.22727272727273
30744, 1.504347826087, -0.2, 0.25
30745, 1.4826086956522, -0.2, 0.18181818181818
30746, 1.504347826087, -0.2, 0.20454545454545
30747, 1.4826086956522, -0.2, 0.13636363636364
30748, 1.504347826087, -0.2, 0.15909090909091
30749, 1.4826086956522, -0.2, 0.090909090909091
30750, 1.504347826087, -0.2, 0.11363636363636
30751, 1.4826086956522, -0.2, 0.045454545454545
30752, 1.504347826087, -0.2, 0.068181818181818
30753, 1.504347826087, -0.2, 0.022727272727273
30754, 1.5260869565217, -0.2, 0.45454545454545
30755, 1.5478260869565, -0.2, 0.47727272727273
30756, 1.5260869565217, -0.2, 0.40909090909091
30757, 1.5478260869565, -0.2, 0.43181818181818
30758, 1.5260869565217, -0.2, 0.36363636363636
30759, 1.5478260869565, -0.2, 0.38636363636364
30760, 1.5260869565217, -0.2, 0.31818181818182
30761, 1.5478260869565, -0.2, 0.34090909090909
30762, 1.5260869565217, -0.2, 0.27272727272727
30763, 1.5478260869565, -0.2, 0.29545454545455
30764, 1.5260869565217, -0.2, 0.22727272727273
30765, 1.5478260869565, -0.2, 0.25
30766, 1.5260869565217, -0.2, 0.18181818181818
30767, 1.5478260869565, -0.2, 0.20454545454545
30768, 1.5260869565217, -0.2, 0.13636363636364
30769, 1.5478260869565, -0.2, 0.15909090909091
30770, 1.5260869565217, -0.2, 0.090909090909091
30771, 1.5478260869565, -0.2, 0.11363636363636
30772, 1.5260869565217, -0.2, 0.045454545454545
30773, 1.5478260869565, -0.2, 0.068181818181818
30774, 1.5478260869565, -0.2, 0.022727272727273
30775, 1.5695652173913, -0.2, 0.45454545454545
30776, 1.5913043478261, -0.2, 0.47727272727273
30777, 1.5695652173913, -0.2, 0.40909090909091
30778, 1.5913043478261, -0.2, 0.43181818181818
30779, 1.5695652173913, -0.2, 0.36363636363636
30780, 1.5913043478261, -0.2, 0.38636363636364
30781, 1.5695652173913, -0.2, 0.31818181818182
30782, 1.5913043478261, -0.2, 0.34090909090909
30783, 1.5695652173913, -0.2, 0.27272727272727
30784, 1.5913043478261, -0.2, 0.29545454545455
30785, 1.5695652173913, -0.2, 0.22727272727273
30786, 1.5913043478261, -0.2, 0.25
30787, 1.5695652173913, -0.2, 0.18181818181818
30788, 1.5913043478261, -0.2, 0.20454545454545
30789, 1.5695652173913, -0.2, 0.13636363636364
30790, 1.5913043478261, -0.2, 0.15909090909091
30791, 1.5695652173913, -0.2, 0.090909090909091
30792, 1.5913043478261, -0.2, 0.11363636363636
30793, 1.5695652173913, -0.2, 0.045454545454545
30794, 1.5913043478261, -0.2, 0.068181818181818
30795, 1.5913043478261, -0.2, 0.022727272727273
30796, 1.6130434782609, -0.2, 0.45454545454545
30797, 1.6347826086957, -0.2, 0.47727272727273
30798, 1.6130434782609, -0.2, 0.40909090909091
30799, 1.6347826086957, -0.2, 0.43181818181818
30800, 1.6130434782609, -0.2, 0.36363636363636
30801, 1.6347826086957, -0.2, 0.38636363636364
30802, 1.6130434782609, -0.2, 0.31818181818182
30803, 1.6347826086957, -0.2, 0.34090909090909
30804, 1.6130434782609, -0.2, 0.27272727272727
30805, 1.6347826086957, -0.2, 0.29545454545455
30806, 1.6130434782609, -0.2, 0.22727272727273
30807, 1.6347826086957, -0.2, 0.25
30808, 1.6130434782609, -0.2, 0.18181818181818
30809, 1.6347826086957, -0.2, 0.20454545454545
30810, 1.6130434782609, -0.2, 0.13636363636364
30811, 1.6347826086957, -0.2, 0.15909090909091
30812, 1.6130434782609, -0.2, 0.090909090909091
30813, 1.6347826086957, -0.2, 0.11363636363636
30814, 1.6130434782609, -0.2, 0.045454545454545
30815, 1.6347826086957, -0.2, 0.068181818181818
30816, 1.6347826086957, -0.2, 0.022727272727273
30817, 1.6565217391304, -0.2, 0.45454545454545
30818, 1.6782608695652, -0.2, 0.47727272727273
30819, 1.6565217391304, -0.2, 0.40909090909091
30820, 1.6782608695652, -0.2, 0.43181818181818
30821, 1.6565217391304, -0.2, 0.36363636363636
30822, 1.6782608695652, -0.2, 0.38636363636364
30823, 1.6565217391304, -0.2, 0.31818181818182
30824, 1.6782608695652, -0.2, 0.34090909090909
30825, 1.6565217391304, -0.2, 0.27272727272727
30826, 1.6782608695652, -0.2, 0.29545454545455
30827, 1.6565217391304, -0.2, 0.22727272727273
30828, 1.6782608695652, -0.2, 0.25
30829, 1.6565217391304, -0.2, 0.18181818181818
30830, 1.6782608695652, -0.2, 0.20454545454545
30831, 1.6565217391304, -0.2, 0.13636363636364
30832, 1.6782608695652, -0.2, 0.15909090909091
30833, 1.6565217391304, -0.2, 0.090909090909091
30834, 1.6782608695652, -0.2, 0.11363636363636
30835, 1.6565217391304, -0.2, 0.045454545454545
30836, 1.6782608695652, -0.2, 0.068181818181818
30837, 1.6782608695652, -0.2, 0.022727272727273
30838, 1.7, -0.2, 0.45454545454545
30839, 1.7217391304348, -0.2, 0.47727272727273
30840, 1.7, -0.2, 0.40909090909091
30841, 1.7217391304348, -0.2, 0.43181818181818
30842, 1.7, -0.2, 0.36363636363636
30843, 1.7217391304348, -0.2, 0.38636363636364
30844, 1.7, -0.2, 0.31818181818182
30845, 1.7217391304348, -0.2, 0.34090909090909
30846, 1.7, -0.2, 0.27272727272727
30847, 1.7217391304348, -0.2, 0.29545454545455
30848, 1.7, -0.2, 0.22727272727273
30849, 1.7217391304348, -0.2, 0.25
30850, 1.7, -0.2, 0.18181818181818
30851, 1.7217391304348, -0.2, 0.20454545454545
30852, 1.7, -0.2, 0.13636363636364
30853, 1.7217391304348, -0.2, 0.15909090909091
30854, 1.7, -0.2, 0.090909090909091
30855, 1.7217391304348, -0.2, 0.11363636363636
30856, 1.7, -0.2, 0.045454545454545
30857, 1.7217391304348, -0.2, 0.068181818181818
30858, 1.7217391304348, -0.2, 0.022727272727273
30859, 1.7434782608696, -0.2, 0.45454545454545
30860, 1.7652173913043, -0.2, 0.47727272727273
30861, 1.7434782608696, -0.2, 0.40909090909091
30862, 1.7652173913043, -0.2, 0.43181818181818
30863, 1.7434782608696, -0.2, 0.36363636363636
30864, 1.7652173913043, -0.2, 0.38636363636364
30865, 1.7434782608696, -0.2, 0.31818181818182
30866, 1.7652173913043, -0.2, 0.34090909090909
30867, 1.7434782608696, -0.2, 0.27272727272727
30868, 1.7652173913043, -0.2, 0.29545454545455
30869, 1.7434782608696, -0.2, 0.22727272727273
30870, 1.7652173913043, -0.2, 0.25
30871, 1.7434782608696, -0.2, 0.18181818181818
30872, 1.7652173913043, -0.2, 0.20454545454545
30873, 1.7434782608696, -0.2, 0.13636363636364
30874, 1.7652173913043, -0.2, 0.15909090909091
30875, 1.7434782608696, -0.2, 0.090909090909091
30876, 1.7652173913043, -0.2, 0.11363636363636
30877, 1.7434782608696, -0.2, 0.045454545454545
30878, 1.7652173913043, -0.2, 0.068181818181818
30879, 1.7652173913043, -0.2, 0.022727272727273
30880, 1.7869565217391, -0.2, 0.45454545454545
30881, 1.8086956521739, -0.2, 0.47727272727273
30882, 1.7869565217391, -0.2, 0.40909090909091
30883, 1.8086956521739, -0.2, 0.43181818181818
30884, 1.7869565217391, -0.2, 0.36363636363636
30885, 1.8086956521739, -0.2, 0.38636363636364
30886, 1.7869565217391, -0.2, 0.31818181818182
30887, 1.8086956521739, -0.2, 0.34090909090909
30888, 1.7869565217391, -0.2, 0.27272727272727
30889, 1.8086956521739, -0.2, 0.29545454545455
30890, 1.7869565217391, -0.2, 0.22727272727273
30891, 1.8086956521739, -0.2, 0.25
30892, 1.7869565217391, -0.2, 0.18181818181818
30893, 1.8086956521739, -0.2, 0.20454545454545
30894, 1.7869565217391, -0.2, 0.13636363636364
30895, 1.8086956521739, -0.2, 0.15909090909091
30896, 1.7869565217391, -0.2, 0.090909090909091
30897, 1.8086956521739, -0.2, 0.11363636363636
30898, 1.7869565217391, -0.2, 0.045454545454545
30899, 1.8086956521739, -0.2, 0.068181818181818
30900, 1.8086956521739, -0.2, 0.022727272727273
30901, 1.8304347826087, -0.2, 0.45454545454545
30902, 1.8521739130435, -0.2, 0.47727272727273
30903, 1.8304347826087, -0.2, 0.40909090909091
30904, 1.8521739130435, -0.2, 0.43181818181818
30905, 1.8304347826087, -0.2, 0.36363636363636
30906, 1.8521739130435, -0.2, 0.38636363636364
30907, 1.8304347826087, -0.2, 0.31818181818182
30908, 1.8521739130435, -0.2, 0.34090909090909
30909, 1.8304347826087, -0.2, 0.27272727272727
30910, 1.8521739130435, -0.2, 0.29545454545455
30911, 1.8304347826087, -0.2, 0.22727272727273
30912, 1.8521739130435, -0.2, 0.25
30913, 1.8304347826087, -0.2, 0.18181818181818
30914, 1.8521739130435, -0.2, 0.20454545454545
30915, 1.8304347826087, -0.2, 0.13636363636364
30916, 1.8521739130435, -0.2, 0.15909090909091
30917, 1.8304347826087, -0.2, 0.090909090909091
30918, 1.8521739130435, -0.2, 0.11363636363636
30919, 1.8304347826087, -0.2, 0.045454545454545
30920, 1.8521739130435, -0.2, 0.068181818181818
30921, 1.8521739130435, -0.2, 0.022727272727273
30922, 1.8739130434783, -0.2, 0.45454545454545
30923, 1.895652173913, -0.2, 0.47727272727273
30924, 1.8739130434783, -0.2, 0.40909090909091
30925, 1.895652173913, -0.2, 0.43181818181818
30926, 1.8739130434783, -0.2, 0.36363636363636
30927, 1.895652173913, -0.2, 0.38636363636364
30928, 1.8739130434783, -0.2, 0.31818181818182
30929, 1.895652173913, -0.2, 0.34090909090909
30930, 1.8739130434783, -0.2, 0.27272727272727
30931, 1.895652173913, -0.2, 0.29545454545455
30932, 1.8739130434783, -0.2, 0.22727272727273
30933, 1.895652173913, -0.2, 0.25
30934, 1.8739130434783, -0.2, 0.18181818181818
30935, 1.895652173913, -0.2, 0.20454545454545
30936, 1.8739130434783, -0.2, 0.13636363636364
30937, 1.895652173913, -0.2, 0.15909090909091
30938, 1.8739130434783, -0.2, 0.090909090909091
30939, 1.895652173913, -0.2, 0.11363636363636
30940, 1.8739130434783, -0.2, 0.045454545454545
30941, 1.895652173913, -0.2, 0.068181818181818
30942, 1.895652173913, -0.2, 0.022727272727273
30943, 1.9173913043478, -0.2, 0.45454545454545
30944, 1.9391304347826, -0.2, 0.47727272727273
30945, 1.9173913043478, -0.2, 0.40909090909091
30946, 1.9391304347826, -0.2, 0.43181818181818
30947, 1.9173913043478, -0.2, 0.36363636363636
30948, 1.9391304347826, -0.2, 0.38636363636364
30949, 1.9173913043478, -0.2, 0.31818181818182
30950, 1.9391304347826, -0.2, 0.34090909090909
30951, 1.9173913043478, -0.2, 0.27272727272727
30952, 1.9391304347826, -0.2, 0.29545454545455
30953, 1.9173913043478, -0.2, 0.22727272727273
30954, 1.9391304347826, -0.2, 0.25
30955, 1.9173913043478, -0.2, 0.18181818181818
30956, 1.9391304347826, -0.2, 0.20454545454545
30957, 1.9173913043478, -0.2, 0.13636363636364
30958, 1.9391304347826, -0.2, 0.15909090909091
30959, 1.9173913043478, -0.2, 0.090909090909091
30960, 1.9391304347826, -0.2, 0.11363636363636
30961, 1.9173913043478, -0.2, 0.045454545454545
30962, 1.9391304347826, -0.2, 0.068181818181818
30963, 1.9391304347826, -0.2, 0.022727272727273
30964, 1.9608695652174, -0.2, 0.45454545454545
30965, 1.9826086956522, -0.2, 0.47727272727273
30966, 1.9608695652174, -0.2, 0.40909090909091
30967, 1.9826086956522, -0.2, 0.43181818181818
30968, 1.9608695652174, -0.2, 0.36363636363636
30969, 1.9826086956522, -0.2, 0.38636363636364
30970, 1.9608695652174, -0.2, 0.31818181818182
30971, 1.9826086956522, -0.2, 0.34090909090909
30972, 1.9608695652174, -0.2, 0.27272727272727
30973, 1.9826086956522, -0.2, 0.29545454545455
30974, 1.9608695652174, -0.2, 0.22727272727273
30975, 1.9826086956522, -0.2, 0.25
30976, 1.9608695652174, -0.2, 0.18181818181818
30977, 1.9826086956522, -0.2, 0.20454545454545
30978, 1.9608695652174, -0.2, 0.13636363636364
30979, 1.9826086956522, -0.2, 0.15909090909091
30980, 1.9608695652174, -0.2, 0.090909090909091
30981, 1.9826086956522, -0.2, 0.11363636363636
30982, 1.9608695652174, -0.2, 0.045454545454545
30983, 1.9826086956522, -0.2, 0.068181818181818
30984, 1.9826086956522, -0.2, 0.022727272727273
30985, 2.004347826087, -0.2, 0.45454545454545
30986, 2.0260869565217, -0.2, 0.47727272727273
30987, 2.004347826087, -0.2, 0.40909090909091
30988, 2.0260869565217, -0.2, 0.43181818181818
30989, 2.004347826087, -0.2, 0.36363636363636
30990, 2.0260869565217, -0.2, 0.38636363636364
30991, 2.004347826087, -0.2, 0.31818181818182
30992, 2.0260869565217, -0.2, 0.34090909090909
30993, 2.004347826087, -0.2, 0.27272727272727
30994, 2.0260869565217, -0.2, 0.29545454545455
30995, 2.004347826087, -0.2, 0.22727272727273
30996, 2.0260869565217, -0.2, 0.25
30997, 2.004347826087, -0.2, 0.18181818181818
30998, 2.0260869565217, -0.2, 0.20454545454545
30999, 2.004347826087, -0.2, 0.13636363636364
31000, 2.0260869565217, -0.2, 0.15909090909091
31001, 2.004347826087, -0.2, 0.090909090909091
31002, 2.0260869565217, -0.2, 0.11363636363636
31003, 2.004347826087, -0.2, 0.045454545454545
31004, 2.0260869565217, -0.2, 0.068181818181818
31005, 2.0260869565217, -0.2, 0.022727272727273
31006, 2.0478260869565, -0.2, 0.45454545454545
31007, 2.0695652173913, -0.2, 0.47727272727273
31008, 2.0478260869565, -0.2, 0.40909090909091
31009, 2.0695652173913, -0.2, 0.43181818181818
31010, 2.0478260869565, -0.2, 0.36363636363636
31011, 2.0695652173913, -0.2, 0.38636363636364
31012, 2.0478260869565, -0.2, 0.31818181818182
31013, 2.0695652173913, -0.2, 0.34090909090909
31014, 2.0478260869565, -0.2, 0.27272727272727
31015, 2.0695652173913, -0.2, 0.29545454545455
31016, 2.0478260869565, -0.2, 0.22727272727273
31017, 2.0695652173913, -0.2, 0.25
31018, 2.0478260869565, -0.2, 0.18181818181818
31019, 2.0695652173913, -0.2, 0.20454545454545
31020, 2.0478260869565, -0.2, 0.13636363636364
31021, 2.0695652173913, -0.2, 0.15909090909091
31022, 2.0478260869565, -0.2, 0.090909090909091
31023, 2.0695652173913, -0.2, 0.11363636363636
31024, 2.0478260869565, -0.2, 0.045454545454545
