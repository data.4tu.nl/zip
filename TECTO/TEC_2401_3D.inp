39782, 0.52173913043478, 0.17608695652174, 0.36363636363636
39783, 0.52173913043478, 0.20217391304348, 0.38636363636364
39784, 0.54347826086956, 0.20217391304348, 0.40909090909091
39785, 0.52173913043478, 0.17608695652174, 0.40909090909091
39786, 0.52173913043478, 0.20217391304348, 0.43181818181818
39787, 0.54347826086956, 0.20217391304348, 0.45454545454545
39788, 0.52173913043478, 0.17608695652174, 0.45454545454545
39789, 0.52173913043478, 0.20217391304348, 0.47727272727273
39790, 0.47826086956522, 0.20217391304348, 0.022727272727273
39791, 0.5, 0.20217391304348, 0.045454545454545
39792, 0.47826086956522, 0.17608695652174, 0.045454545454545
39793, 0.47826086956522, 0.20217391304348, 0.068181818181818
39794, 0.5, 0.20217391304348, 0.090909090909091
39795, 0.47826086956522, 0.17608695652174, 0.090909090909091
39796, 0.47826086956522, 0.20217391304348, 0.11363636363636
39797, 0.5, 0.20217391304348, 0.13636363636364
39798, 0.47826086956522, 0.17608695652174, 0.13636363636364
39799, 0.47826086956522, 0.20217391304348, 0.15909090909091
39800, 0.5, 0.20217391304348, 0.18181818181818
39801, 0.47826086956522, 0.17608695652174, 0.18181818181818
39802, 0.47826086956522, 0.20217391304348, 0.20454545454545
39803, 0.5, 0.20217391304348, 0.22727272727273
39804, 0.47826086956522, 0.17608695652174, 0.22727272727273
39805, 0.47826086956522, 0.20217391304348, 0.25
39806, 0.5, 0.20217391304348, 0.27272727272727
39807, 0.47826086956522, 0.17608695652174, 0.27272727272727
39808, 0.47826086956522, 0.20217391304348, 0.29545454545455
39809, 0.5, 0.20217391304348, 0.31818181818182
39810, 0.47826086956522, 0.17608695652174, 0.31818181818182
39811, 0.47826086956522, 0.20217391304348, 0.34090909090909
39812, 0.5, 0.20217391304348, 0.36363636363636
39813, 0.47826086956522, 0.17608695652174, 0.36363636363636
39814, 0.47826086956522, 0.20217391304348, 0.38636363636364
39815, 0.5, 0.20217391304348, 0.40909090909091
39816, 0.47826086956522, 0.17608695652174, 0.40909090909091
39817, 0.47826086956522, 0.20217391304348, 0.43181818181818
39818, 0.5, 0.20217391304348, 0.45454545454545
39819, 0.47826086956522, 0.17608695652174, 0.45454545454545
39820, 0.47826086956522, 0.20217391304348, 0.47727272727273
39821, 0.43478260869565, 0.20217391304348, 0.022727272727273
39822, 0.45652173913043, 0.20217391304348, 0.045454545454545
39823, 0.43478260869565, 0.17608695652174, 0.045454545454545
39824, 0.43478260869565, 0.20217391304348, 0.068181818181818
39825, 0.45652173913043, 0.20217391304348, 0.090909090909091
39826, 0.43478260869565, 0.17608695652174, 0.090909090909091
39827, 0.43478260869565, 0.20217391304348, 0.11363636363636
39828, 0.45652173913043, 0.20217391304348, 0.13636363636364
39829, 0.43478260869565, 0.17608695652174, 0.13636363636364
39830, 0.43478260869565, 0.20217391304348, 0.15909090909091
39831, 0.45652173913043, 0.20217391304348, 0.18181818181818
39832, 0.43478260869565, 0.17608695652174, 0.18181818181818
39833, 0.43478260869565, 0.20217391304348, 0.20454545454545
39834, 0.45652173913043, 0.20217391304348, 0.22727272727273
39835, 0.43478260869565, 0.17608695652174, 0.22727272727273
39836, 0.43478260869565, 0.20217391304348, 0.25
39837, 0.45652173913043, 0.20217391304348, 0.27272727272727
39838, 0.43478260869565, 0.17608695652174, 0.27272727272727
39839, 0.43478260869565, 0.20217391304348, 0.29545454545455
39840, 0.45652173913043, 0.20217391304348, 0.31818181818182
39841, 0.43478260869565, 0.17608695652174, 0.31818181818182
39842, 0.43478260869565, 0.20217391304348, 0.34090909090909
39843, 0.45652173913043, 0.20217391304348, 0.36363636363636
39844, 0.43478260869565, 0.17608695652174, 0.36363636363636
39845, 0.43478260869565, 0.20217391304348, 0.38636363636364
39846, 0.45652173913043, 0.20217391304348, 0.40909090909091
39847, 0.43478260869565, 0.17608695652174, 0.40909090909091
39848, 0.43478260869565, 0.20217391304348, 0.43181818181818
39849, 0.45652173913043, 0.20217391304348, 0.45454545454545
39850, 0.43478260869565, 0.17608695652174, 0.45454545454545
39851, 0.43478260869565, 0.20217391304348, 0.47727272727273
39852, 0.39130434782609, 0.20217391304348, 0.022727272727273
39853, 0.41304347826087, 0.20217391304348, 0.045454545454545
39854, 0.39130434782609, 0.17608695652174, 0.045454545454545
39855, 0.39130434782609, 0.20217391304348, 0.068181818181818
39856, 0.41304347826087, 0.20217391304348, 0.090909090909091
39857, 0.39130434782609, 0.17608695652174, 0.090909090909091
39858, 0.39130434782609, 0.20217391304348, 0.11363636363636
39859, 0.41304347826087, 0.20217391304348, 0.13636363636364
39860, 0.39130434782609, 0.17608695652174, 0.13636363636364
39861, 0.39130434782609, 0.20217391304348, 0.15909090909091
39862, 0.41304347826087, 0.20217391304348, 0.18181818181818
39863, 0.39130434782609, 0.17608695652174, 0.18181818181818
39864, 0.39130434782609, 0.20217391304348, 0.20454545454545
39865, 0.41304347826087, 0.20217391304348, 0.22727272727273
39866, 0.39130434782609, 0.17608695652174, 0.22727272727273
39867, 0.39130434782609, 0.20217391304348, 0.25
39868, 0.41304347826087, 0.20217391304348, 0.27272727272727
39869, 0.39130434782609, 0.17608695652174, 0.27272727272727
39870, 0.39130434782609, 0.20217391304348, 0.29545454545455
39871, 0.41304347826087, 0.20217391304348, 0.31818181818182
39872, 0.39130434782609, 0.17608695652174, 0.31818181818182
39873, 0.39130434782609, 0.20217391304348, 0.34090909090909
39874, 0.41304347826087, 0.20217391304348, 0.36363636363636
39875, 0.39130434782609, 0.17608695652174, 0.36363636363636
39876, 0.39130434782609, 0.20217391304348, 0.38636363636364
39877, 0.41304347826087, 0.20217391304348, 0.40909090909091
39878, 0.39130434782609, 0.17608695652174, 0.40909090909091
39879, 0.39130434782609, 0.20217391304348, 0.43181818181818
39880, 0.41304347826087, 0.20217391304348, 0.45454545454545
39881, 0.39130434782609, 0.17608695652174, 0.45454545454545
39882, 0.39130434782609, 0.20217391304348, 0.47727272727273
39883, 0.34782608695652, 0.20217391304348, 0.022727272727273
39884, 0.3695652173913, 0.20217391304348, 0.045454545454545
39885, 0.34782608695652, 0.17608695652174, 0.045454545454545
39886, 0.34782608695652, 0.20217391304348, 0.068181818181818
39887, 0.3695652173913, 0.20217391304348, 0.090909090909091
39888, 0.34782608695652, 0.17608695652174, 0.090909090909091
39889, 0.34782608695652, 0.20217391304348, 0.11363636363636
39890, 0.3695652173913, 0.20217391304348, 0.13636363636364
39891, 0.34782608695652, 0.17608695652174, 0.13636363636364
39892, 0.34782608695652, 0.20217391304348, 0.15909090909091
39893, 0.3695652173913, 0.20217391304348, 0.18181818181818
39894, 0.34782608695652, 0.17608695652174, 0.18181818181818
39895, 0.34782608695652, 0.20217391304348, 0.20454545454545
39896, 0.3695652173913, 0.20217391304348, 0.22727272727273
39897, 0.34782608695652, 0.17608695652174, 0.22727272727273
39898, 0.34782608695652, 0.20217391304348, 0.25
39899, 0.3695652173913, 0.20217391304348, 0.27272727272727
39900, 0.34782608695652, 0.17608695652174, 0.27272727272727
39901, 0.34782608695652, 0.20217391304348, 0.29545454545455
39902, 0.3695652173913, 0.20217391304348, 0.31818181818182
39903, 0.34782608695652, 0.17608695652174, 0.31818181818182
39904, 0.34782608695652, 0.20217391304348, 0.34090909090909
39905, 0.3695652173913, 0.20217391304348, 0.36363636363636
39906, 0.34782608695652, 0.17608695652174, 0.36363636363636
39907, 0.34782608695652, 0.20217391304348, 0.38636363636364
39908, 0.3695652173913, 0.20217391304348, 0.40909090909091
39909, 0.34782608695652, 0.17608695652174, 0.40909090909091
39910, 0.34782608695652, 0.20217391304348, 0.43181818181818
39911, 0.3695652173913, 0.20217391304348, 0.45454545454545
39912, 0.34782608695652, 0.17608695652174, 0.45454545454545
39913, 0.34782608695652, 0.20217391304348, 0.47727272727273
39914, 0.30434782608696, 0.20217391304348, 0.022727272727273
39915, 0.32608695652174, 0.20217391304348, 0.045454545454545
39916, 0.30434782608696, 0.17608695652174, 0.045454545454545
39917, 0.30434782608696, 0.20217391304348, 0.068181818181818
39918, 0.32608695652174, 0.20217391304348, 0.090909090909091
39919, 0.30434782608696, 0.17608695652174, 0.090909090909091
39920, 0.30434782608696, 0.20217391304348, 0.11363636363636
39921, 0.32608695652174, 0.20217391304348, 0.13636363636364
39922, 0.30434782608696, 0.17608695652174, 0.13636363636364
39923, 0.30434782608696, 0.20217391304348, 0.15909090909091
39924, 0.32608695652174, 0.20217391304348, 0.18181818181818
39925, 0.30434782608696, 0.17608695652174, 0.18181818181818
39926, 0.30434782608696, 0.20217391304348, 0.20454545454545
39927, 0.32608695652174, 0.20217391304348, 0.22727272727273
39928, 0.30434782608696, 0.17608695652174, 0.22727272727273
39929, 0.30434782608696, 0.20217391304348, 0.25
39930, 0.32608695652174, 0.20217391304348, 0.27272727272727
39931, 0.30434782608696, 0.17608695652174, 0.27272727272727
39932, 0.30434782608696, 0.20217391304348, 0.29545454545455
39933, 0.32608695652174, 0.20217391304348, 0.31818181818182
39934, 0.30434782608696, 0.17608695652174, 0.31818181818182
39935, 0.30434782608696, 0.20217391304348, 0.34090909090909
39936, 0.32608695652174, 0.20217391304348, 0.36363636363636
39937, 0.30434782608696, 0.17608695652174, 0.36363636363636
39938, 0.30434782608696, 0.20217391304348, 0.38636363636364
39939, 0.32608695652174, 0.20217391304348, 0.40909090909091
39940, 0.30434782608696, 0.17608695652174, 0.40909090909091
39941, 0.30434782608696, 0.20217391304348, 0.43181818181818
39942, 0.32608695652174, 0.20217391304348, 0.45454545454545
39943, 0.30434782608696, 0.17608695652174, 0.45454545454545
39944, 0.30434782608696, 0.20217391304348, 0.47727272727273
39945, 0.26086956521739, 0.20217391304348, 0.022727272727273
39946, 0.28260869565217, 0.20217391304348, 0.045454545454545
39947, 0.26086956521739, 0.17608695652174, 0.045454545454545
39948, 0.26086956521739, 0.20217391304348, 0.068181818181818
39949, 0.28260869565217, 0.20217391304348, 0.090909090909091
39950, 0.26086956521739, 0.17608695652174, 0.090909090909091
39951, 0.26086956521739, 0.20217391304348, 0.11363636363636
39952, 0.28260869565217, 0.20217391304348, 0.13636363636364
39953, 0.26086956521739, 0.17608695652174, 0.13636363636364
39954, 0.26086956521739, 0.20217391304348, 0.15909090909091
39955, 0.28260869565217, 0.20217391304348, 0.18181818181818
39956, 0.26086956521739, 0.17608695652174, 0.18181818181818
39957, 0.26086956521739, 0.20217391304348, 0.20454545454545
39958, 0.28260869565217, 0.20217391304348, 0.22727272727273
39959, 0.26086956521739, 0.17608695652174, 0.22727272727273
39960, 0.26086956521739, 0.20217391304348, 0.25
39961, 0.28260869565217, 0.20217391304348, 0.27272727272727
39962, 0.26086956521739, 0.17608695652174, 0.27272727272727
39963, 0.26086956521739, 0.20217391304348, 0.29545454545455
39964, 0.28260869565217, 0.20217391304348, 0.31818181818182
39965, 0.26086956521739, 0.17608695652174, 0.31818181818182
39966, 0.26086956521739, 0.20217391304348, 0.34090909090909
39967, 0.28260869565217, 0.20217391304348, 0.36363636363636
39968, 0.26086956521739, 0.17608695652174, 0.36363636363636
39969, 0.26086956521739, 0.20217391304348, 0.38636363636364
39970, 0.28260869565217, 0.20217391304348, 0.40909090909091
39971, 0.26086956521739, 0.17608695652174, 0.40909090909091
39972, 0.26086956521739, 0.20217391304348, 0.43181818181818
39973, 0.28260869565217, 0.20217391304348, 0.45454545454545
39974, 0.26086956521739, 0.17608695652174, 0.45454545454545
39975, 0.26086956521739, 0.20217391304348, 0.47727272727273
39976, 0.21739130434783, 0.20217391304348, 0.022727272727273
39977, 0.23913043478261, 0.20217391304348, 0.045454545454545
39978, 0.21739130434783, 0.17608695652174, 0.045454545454545
39979, 0.21739130434783, 0.20217391304348, 0.068181818181818
39980, 0.23913043478261, 0.20217391304348, 0.090909090909091
39981, 0.21739130434783, 0.17608695652174, 0.090909090909091
39982, 0.21739130434783, 0.20217391304348, 0.11363636363636
39983, 0.23913043478261, 0.20217391304348, 0.13636363636364
39984, 0.21739130434783, 0.17608695652174, 0.13636363636364
39985, 0.21739130434783, 0.20217391304348, 0.15909090909091
39986, 0.23913043478261, 0.20217391304348, 0.18181818181818
39987, 0.21739130434783, 0.17608695652174, 0.18181818181818
39988, 0.21739130434783, 0.20217391304348, 0.20454545454545
39989, 0.23913043478261, 0.20217391304348, 0.22727272727273
39990, 0.21739130434783, 0.17608695652174, 0.22727272727273
39991, 0.21739130434783, 0.20217391304348, 0.25
39992, 0.23913043478261, 0.20217391304348, 0.27272727272727
39993, 0.21739130434783, 0.17608695652174, 0.27272727272727
39994, 0.21739130434783, 0.20217391304348, 0.29545454545455
39995, 0.23913043478261, 0.20217391304348, 0.31818181818182
39996, 0.21739130434783, 0.17608695652174, 0.31818181818182
39997, 0.21739130434783, 0.20217391304348, 0.34090909090909
39998, 0.23913043478261, 0.20217391304348, 0.36363636363636
39999, 0.21739130434783, 0.17608695652174, 0.36363636363636
40000, 0.21739130434783, 0.20217391304348, 0.38636363636364
40001, 0.23913043478261, 0.20217391304348, 0.40909090909091
40002, 0.21739130434783, 0.17608695652174, 0.40909090909091
40003, 0.21739130434783, 0.20217391304348, 0.43181818181818
40004, 0.23913043478261, 0.20217391304348, 0.45454545454545
40005, 0.21739130434783, 0.17608695652174, 0.45454545454545
40006, 0.21739130434783, 0.20217391304348, 0.47727272727273
40007, 0.17391304347826, 0.20217391304348, 0.022727272727273
40008, 0.19565217391304, 0.20217391304348, 0.045454545454545
40009, 0.17391304347826, 0.17608695652174, 0.045454545454545
40010, 0.17391304347826, 0.20217391304348, 0.068181818181818
40011, 0.19565217391304, 0.20217391304348, 0.090909090909091
40012, 0.17391304347826, 0.17608695652174, 0.090909090909091
40013, 0.17391304347826, 0.20217391304348, 0.11363636363636
40014, 0.19565217391304, 0.20217391304348, 0.13636363636364
40015, 0.17391304347826, 0.17608695652174, 0.13636363636364
40016, 0.17391304347826, 0.20217391304348, 0.15909090909091
40017, 0.19565217391304, 0.20217391304348, 0.18181818181818
40018, 0.17391304347826, 0.17608695652174, 0.18181818181818
40019, 0.17391304347826, 0.20217391304348, 0.20454545454545
40020, 0.19565217391304, 0.20217391304348, 0.22727272727273
40021, 0.17391304347826, 0.17608695652174, 0.22727272727273
40022, 0.17391304347826, 0.20217391304348, 0.25
40023, 0.19565217391304, 0.20217391304348, 0.27272727272727
40024, 0.17391304347826, 0.17608695652174, 0.27272727272727
40025, 0.17391304347826, 0.20217391304348, 0.29545454545455
40026, 0.19565217391304, 0.20217391304348, 0.31818181818182
40027, 0.17391304347826, 0.17608695652174, 0.31818181818182
40028, 0.17391304347826, 0.20217391304348, 0.34090909090909
40029, 0.19565217391304, 0.20217391304348, 0.36363636363636
40030, 0.17391304347826, 0.17608695652174, 0.36363636363636
40031, 0.17391304347826, 0.20217391304348, 0.38636363636364
40032, 0.19565217391304, 0.20217391304348, 0.40909090909091
40033, 0.17391304347826, 0.17608695652174, 0.40909090909091
40034, 0.17391304347826, 0.20217391304348, 0.43181818181818
40035, 0.19565217391304, 0.20217391304348, 0.45454545454545
40036, 0.17391304347826, 0.17608695652174, 0.45454545454545
40037, 0.17391304347826, 0.20217391304348, 0.47727272727273
40038, 0.1304347826087, 0.20217391304348, 0.022727272727273
40039, 0.15217391304348, 0.20217391304348, 0.045454545454545
40040, 0.1304347826087, 0.17608695652174, 0.045454545454545
40041, 0.1304347826087, 0.20217391304348, 0.068181818181818
40042, 0.15217391304348, 0.20217391304348, 0.090909090909091
40043, 0.1304347826087, 0.17608695652174, 0.090909090909091
40044, 0.1304347826087, 0.20217391304348, 0.11363636363636
40045, 0.15217391304348, 0.20217391304348, 0.13636363636364
40046, 0.1304347826087, 0.17608695652174, 0.13636363636364
40047, 0.1304347826087, 0.20217391304348, 0.15909090909091
40048, 0.15217391304348, 0.20217391304348, 0.18181818181818
40049, 0.1304347826087, 0.17608695652174, 0.18181818181818
40050, 0.1304347826087, 0.20217391304348, 0.20454545454545
40051, 0.15217391304348, 0.20217391304348, 0.22727272727273
40052, 0.1304347826087, 0.17608695652174, 0.22727272727273
40053, 0.1304347826087, 0.20217391304348, 0.25
40054, 0.15217391304348, 0.20217391304348, 0.27272727272727
40055, 0.1304347826087, 0.17608695652174, 0.27272727272727
40056, 0.1304347826087, 0.20217391304348, 0.29545454545455
40057, 0.15217391304348, 0.20217391304348, 0.31818181818182
40058, 0.1304347826087, 0.17608695652174, 0.31818181818182
40059, 0.1304347826087, 0.20217391304348, 0.34090909090909
40060, 0.15217391304348, 0.20217391304348, 0.36363636363636
40061, 0.1304347826087, 0.17608695652174, 0.36363636363636
40062, 0.1304347826087, 0.20217391304348, 0.38636363636364
40063, 0.15217391304348, 0.20217391304348, 0.40909090909091
40064, 0.1304347826087, 0.17608695652174, 0.40909090909091
40065, 0.1304347826087, 0.20217391304348, 0.43181818181818
40066, 0.15217391304348, 0.20217391304348, 0.45454545454545
40067, 0.1304347826087, 0.17608695652174, 0.45454545454545
40068, 0.1304347826087, 0.20217391304348, 0.47727272727273
40069, 0.08695652173913, 0.20217391304348, 0.022727272727273
40070, 0.10869565217391, 0.20217391304348, 0.045454545454545
40071, 0.08695652173913, 0.17608695652174, 0.045454545454545
40072, 0.08695652173913, 0.20217391304348, 0.068181818181818
40073, 0.10869565217391, 0.20217391304348, 0.090909090909091
40074, 0.08695652173913, 0.17608695652174, 0.090909090909091
40075, 0.08695652173913, 0.20217391304348, 0.11363636363636
40076, 0.10869565217391, 0.20217391304348, 0.13636363636364
40077, 0.08695652173913, 0.17608695652174, 0.13636363636364
40078, 0.08695652173913, 0.20217391304348, 0.15909090909091
40079, 0.10869565217391, 0.20217391304348, 0.18181818181818
40080, 0.08695652173913, 0.17608695652174, 0.18181818181818
40081, 0.08695652173913, 0.20217391304348, 0.20454545454545
40082, 0.10869565217391, 0.20217391304348, 0.22727272727273
40083, 0.08695652173913, 0.17608695652174, 0.22727272727273
40084, 0.08695652173913, 0.20217391304348, 0.25
40085, 0.10869565217391, 0.20217391304348, 0.27272727272727
40086, 0.08695652173913, 0.17608695652174, 0.27272727272727
40087, 0.08695652173913, 0.20217391304348, 0.29545454545455
40088, 0.10869565217391, 0.20217391304348, 0.31818181818182
40089, 0.08695652173913, 0.17608695652174, 0.31818181818182
40090, 0.08695652173913, 0.20217391304348, 0.34090909090909
40091, 0.10869565217391, 0.20217391304348, 0.36363636363636
40092, 0.08695652173913, 0.17608695652174, 0.36363636363636
40093, 0.08695652173913, 0.20217391304348, 0.38636363636364
40094, 0.10869565217391, 0.20217391304348, 0.40909090909091
40095, 0.08695652173913, 0.17608695652174, 0.40909090909091
40096, 0.08695652173913, 0.20217391304348, 0.43181818181818
40097, 0.10869565217391, 0.20217391304348, 0.45454545454545
40098, 0.08695652173913, 0.17608695652174, 0.45454545454545
40099, 0.08695652173913, 0.20217391304348, 0.47727272727273
40100, 0.043478260869565, 0.20217391304348, 0.022727272727273
40101, 0.065217391304348, 0.20217391304348, 0.045454545454545
40102, 0.043478260869565, 0.17608695652174, 0.045454545454545
40103, 0.043478260869565, 0.20217391304348, 0.068181818181818
40104, 0.065217391304348, 0.20217391304348, 0.090909090909091
40105, 0.043478260869565, 0.17608695652174, 0.090909090909091
40106, 0.043478260869565, 0.20217391304348, 0.11363636363636
40107, 0.065217391304348, 0.20217391304348, 0.13636363636364
40108, 0.043478260869565, 0.17608695652174, 0.13636363636364
40109, 0.043478260869565, 0.20217391304348, 0.15909090909091
40110, 0.065217391304348, 0.20217391304348, 0.18181818181818
40111, 0.043478260869565, 0.17608695652174, 0.18181818181818
40112, 0.043478260869565, 0.20217391304348, 0.20454545454545
40113, 0.065217391304348, 0.20217391304348, 0.22727272727273
40114, 0.043478260869565, 0.17608695652174, 0.22727272727273
40115, 0.043478260869565, 0.20217391304348, 0.25
40116, 0.065217391304348, 0.20217391304348, 0.27272727272727
40117, 0.043478260869565, 0.17608695652174, 0.27272727272727
40118, 0.043478260869565, 0.20217391304348, 0.29545454545455
40119, 0.065217391304348, 0.20217391304348, 0.31818181818182
40120, 0.043478260869565, 0.17608695652174, 0.31818181818182
40121, 0.043478260869565, 0.20217391304348, 0.34090909090909
40122, 0.065217391304348, 0.20217391304348, 0.36363636363636
40123, 0.043478260869565, 0.17608695652174, 0.36363636363636
40124, 0.043478260869565, 0.20217391304348, 0.38636363636364
40125, 0.065217391304348, 0.20217391304348, 0.40909090909091
40126, 0.043478260869565, 0.17608695652174, 0.40909090909091
40127, 0.043478260869565, 0.20217391304348, 0.43181818181818
40128, 0.065217391304348, 0.20217391304348, 0.45454545454545
40129, 0.043478260869565, 0.17608695652174, 0.45454545454545
40130, 0.043478260869565, 0.20217391304348, 0.47727272727273
40131, 0.021739130434783, 0.20217391304348, 0.045454545454545
40132, 0.021739130434783, 0.20217391304348, 0.090909090909091
40133, 0.021739130434783, 0.20217391304348, 0.13636363636364
40134, 0.021739130434783, 0.20217391304348, 0.18181818181818
40135, 0.021739130434783, 0.20217391304348, 0.22727272727273
40136, 0.021739130434783, 0.20217391304348, 0.27272727272727
40137, 0.021739130434783, 0.20217391304348, 0.31818181818182
40138, 0.021739130434783, 0.20217391304348, 0.36363636363636
40139, 0.021739130434783, 0.20217391304348, 0.40909090909091
40140, 0.021739130434783, 0.20217391304348, 0.45454545454545
40141, 0.95652173913043, 0.25434782608696, 0.022727272727273
40142, 0.97826086956522, 0.25434782608696, 0.045454545454545
40143, 0.95652173913043, 0.22826086956522, 0.045454545454545
40144, 0.95652173913043, 0.25434782608696, 0.068181818181818
40145, 0.97826086956522, 0.25434782608696, 0.090909090909091
40146, 0.95652173913043, 0.22826086956522, 0.090909090909091
40147, 0.95652173913043, 0.25434782608696, 0.11363636363636
40148, 0.97826086956522, 0.25434782608696, 0.13636363636364
40149, 0.95652173913043, 0.22826086956522, 0.13636363636364
40150, 0.95652173913043, 0.25434782608696, 0.15909090909091
40151, 0.97826086956522, 0.25434782608696, 0.18181818181818
40152, 0.95652173913043, 0.22826086956522, 0.18181818181818
40153, 0.95652173913043, 0.25434782608696, 0.20454545454545
40154, 0.97826086956522, 0.25434782608696, 0.22727272727273
40155, 0.95652173913043, 0.22826086956522, 0.22727272727273
40156, 0.95652173913043, 0.25434782608696, 0.25
40157, 0.97826086956522, 0.25434782608696, 0.27272727272727
40158, 0.95652173913044, 0.22826086956522, 0.27272727272727
40159, 0.95652173913043, 0.25434782608696, 0.29545454545455
40160, 0.97826086956522, 0.25434782608696, 0.31818181818182
40161, 0.95652173913043, 0.22826086956522, 0.31818181818182
40162, 0.95652173913043, 0.25434782608696, 0.34090909090909
40163, 0.97826086956522, 0.25434782608696, 0.36363636363636
40164, 0.95652173913043, 0.22826086956522, 0.36363636363636
40165, 0.95652173913043, 0.25434782608696, 0.38636363636364
40166, 0.97826086956522, 0.25434782608696, 0.40909090909091
40167, 0.95652173913043, 0.22826086956522, 0.40909090909091
40168, 0.95652173913043, 0.25434782608696, 0.43181818181818
40169, 0.97826086956522, 0.25434782608696, 0.45454545454545
40170, 0.95652173913043, 0.22826086956522, 0.45454545454545
40171, 0.95652173913043, 0.25434782608696, 0.47727272727273
40172, 0.91304347826087, 0.25434782608696, 0.022727272727273
40173, 0.93478260869565, 0.25434782608696, 0.045454545454545
40174, 0.91304347826087, 0.22826086956522, 0.045454545454545
40175, 0.91304347826087, 0.25434782608696, 0.068181818181818
40176, 0.93478260869565, 0.25434782608696, 0.090909090909091
40177, 0.91304347826087, 0.22826086956522, 0.090909090909091
40178, 0.91304347826087, 0.25434782608696, 0.11363636363636
40179, 0.93478260869565, 0.25434782608696, 0.13636363636364
40180, 0.91304347826087, 0.22826086956522, 0.13636363636364
40181, 0.91304347826087, 0.25434782608696, 0.15909090909091
40182, 0.93478260869565, 0.25434782608696, 0.18181818181818
40183, 0.91304347826087, 0.22826086956522, 0.18181818181818
40184, 0.91304347826087, 0.25434782608696, 0.20454545454545
40185, 0.93478260869565, 0.25434782608696, 0.22727272727273
40186, 0.91304347826087, 0.22826086956522, 0.22727272727273
40187, 0.91304347826087, 0.25434782608696, 0.25
40188, 0.93478260869565, 0.25434782608696, 0.27272727272727
40189, 0.91304347826087, 0.22826086956522, 0.27272727272727
40190, 0.91304347826087, 0.25434782608696, 0.29545454545455
40191, 0.93478260869565, 0.25434782608696, 0.31818181818182
40192, 0.91304347826087, 0.22826086956522, 0.31818181818182
40193, 0.91304347826087, 0.25434782608696, 0.34090909090909
40194, 0.93478260869565, 0.25434782608696, 0.36363636363636
40195, 0.91304347826087, 0.22826086956522, 0.36363636363636
40196, 0.91304347826087, 0.25434782608696, 0.38636363636364
40197, 0.93478260869565, 0.25434782608696, 0.40909090909091
40198, 0.91304347826087, 0.22826086956522, 0.40909090909091
40199, 0.91304347826087, 0.25434782608696, 0.43181818181818
40200, 0.93478260869565, 0.25434782608696, 0.45454545454545
40201, 0.91304347826087, 0.22826086956522, 0.45454545454545
40202, 0.91304347826087, 0.25434782608696, 0.47727272727273
40203, 0.8695652173913, 0.25434782608696, 0.022727272727273
40204, 0.89130434782609, 0.25434782608696, 0.045454545454545
40205, 0.8695652173913, 0.22826086956522, 0.045454545454545
40206, 0.8695652173913, 0.25434782608696, 0.068181818181818
40207, 0.89130434782609, 0.25434782608696, 0.090909090909091
40208, 0.8695652173913, 0.22826086956522, 0.090909090909091
40209, 0.8695652173913, 0.25434782608696, 0.11363636363636
40210, 0.89130434782609, 0.25434782608696, 0.13636363636364
40211, 0.8695652173913, 0.22826086956522, 0.13636363636364
40212, 0.8695652173913, 0.25434782608696, 0.15909090909091
40213, 0.89130434782609, 0.25434782608696, 0.18181818181818
40214, 0.8695652173913, 0.22826086956522, 0.18181818181818
40215, 0.8695652173913, 0.25434782608696, 0.20454545454545
40216, 0.89130434782609, 0.25434782608696, 0.22727272727273
40217, 0.8695652173913, 0.22826086956522, 0.22727272727273
40218, 0.8695652173913, 0.25434782608696, 0.25
40219, 0.89130434782609, 0.25434782608696, 0.27272727272727
40220, 0.8695652173913, 0.22826086956522, 0.27272727272727
40221, 0.8695652173913, 0.25434782608696, 0.29545454545455
40222, 0.89130434782609, 0.25434782608696, 0.31818181818182
40223, 0.8695652173913, 0.22826086956522, 0.31818181818182
40224, 0.8695652173913, 0.25434782608696, 0.34090909090909
40225, 0.89130434782609, 0.25434782608696, 0.36363636363636
40226, 0.8695652173913, 0.22826086956522, 0.36363636363636
40227, 0.8695652173913, 0.25434782608696, 0.38636363636364
40228, 0.89130434782609, 0.25434782608696, 0.40909090909091
40229, 0.8695652173913, 0.22826086956522, 0.40909090909091
40230, 0.8695652173913, 0.25434782608696, 0.43181818181818
40231, 0.89130434782609, 0.25434782608696, 0.45454545454545
40232, 0.8695652173913, 0.22826086956522, 0.45454545454545
40233, 0.8695652173913, 0.25434782608696, 0.47727272727273
40234, 0.82608695652174, 0.25434782608696, 0.022727272727273
40235, 0.84782608695652, 0.25434782608696, 0.045454545454545
40236, 0.82608695652174, 0.22826086956522, 0.045454545454545
40237, 0.82608695652174, 0.25434782608696, 0.068181818181818
40238, 0.84782608695652, 0.25434782608696, 0.090909090909091
40239, 0.82608695652174, 0.22826086956522, 0.090909090909091
40240, 0.82608695652174, 0.25434782608696, 0.11363636363636
40241, 0.84782608695652, 0.25434782608696, 0.13636363636364
40242, 0.82608695652174, 0.22826086956522, 0.13636363636364
40243, 0.82608695652174, 0.25434782608696, 0.15909090909091
40244, 0.84782608695652, 0.25434782608696, 0.18181818181818
40245, 0.82608695652174, 0.22826086956522, 0.18181818181818
40246, 0.82608695652174, 0.25434782608696, 0.20454545454545
40247, 0.84782608695652, 0.25434782608696, 0.22727272727273
40248, 0.82608695652174, 0.22826086956522, 0.22727272727273
40249, 0.82608695652174, 0.25434782608696, 0.25
40250, 0.84782608695652, 0.25434782608696, 0.27272727272727
40251, 0.82608695652174, 0.22826086956522, 0.27272727272727
40252, 0.82608695652174, 0.25434782608696, 0.29545454545455
40253, 0.84782608695652, 0.25434782608696, 0.31818181818182
40254, 0.82608695652174, 0.22826086956522, 0.31818181818182
40255, 0.82608695652174, 0.25434782608696, 0.34090909090909
40256, 0.84782608695652, 0.25434782608696, 0.36363636363636
40257, 0.82608695652174, 0.22826086956522, 0.36363636363636
40258, 0.82608695652174, 0.25434782608696, 0.38636363636364
40259, 0.84782608695652, 0.25434782608696, 0.40909090909091
40260, 0.82608695652174, 0.22826086956522, 0.40909090909091
40261, 0.82608695652174, 0.25434782608696, 0.43181818181818
40262, 0.84782608695652, 0.25434782608696, 0.45454545454545
40263, 0.82608695652174, 0.22826086956522, 0.45454545454545
40264, 0.82608695652174, 0.25434782608696, 0.47727272727273
40265, 0.78260869565217, 0.25434782608696, 0.022727272727273
40266, 0.80434782608696, 0.25434782608696, 0.045454545454545
40267, 0.78260869565217, 0.22826086956522, 0.045454545454545
40268, 0.78260869565217, 0.25434782608696, 0.068181818181818
40269, 0.80434782608696, 0.25434782608696, 0.090909090909091
40270, 0.78260869565217, 0.22826086956522, 0.090909090909091
40271, 0.78260869565217, 0.25434782608696, 0.11363636363636
40272, 0.80434782608696, 0.25434782608696, 0.13636363636364
40273, 0.78260869565217, 0.22826086956522, 0.13636363636364
40274, 0.78260869565217, 0.25434782608696, 0.15909090909091
40275, 0.80434782608696, 0.25434782608696, 0.18181818181818
40276, 0.78260869565217, 0.22826086956522, 0.18181818181818
40277, 0.78260869565217, 0.25434782608696, 0.20454545454545
40278, 0.80434782608696, 0.25434782608696, 0.22727272727273
40279, 0.78260869565217, 0.22826086956522, 0.22727272727273
40280, 0.78260869565217, 0.25434782608696, 0.25
40281, 0.80434782608696, 0.25434782608696, 0.27272727272727
40282, 0.78260869565217, 0.22826086956522, 0.27272727272727
40283, 0.78260869565217, 0.25434782608696, 0.29545454545455
40284, 0.80434782608696, 0.25434782608696, 0.31818181818182
40285, 0.78260869565217, 0.22826086956522, 0.31818181818182
40286, 0.78260869565217, 0.25434782608696, 0.34090909090909
40287, 0.80434782608696, 0.25434782608696, 0.36363636363636
40288, 0.78260869565217, 0.22826086956522, 0.36363636363636
40289, 0.78260869565217, 0.25434782608696, 0.38636363636364
40290, 0.80434782608696, 0.25434782608696, 0.40909090909091
40291, 0.78260869565217, 0.22826086956522, 0.40909090909091
40292, 0.78260869565217, 0.25434782608696, 0.43181818181818
40293, 0.80434782608696, 0.25434782608696, 0.45454545454545
40294, 0.78260869565217, 0.22826086956522, 0.45454545454545
40295, 0.78260869565217, 0.25434782608696, 0.47727272727273
40296, 0.73913043478261, 0.25434782608696, 0.022727272727273
40297, 0.76086956521739, 0.25434782608696, 0.045454545454545
40298, 0.73913043478261, 0.22826086956522, 0.045454545454545
40299, 0.73913043478261, 0.25434782608696, 0.068181818181818
40300, 0.76086956521739, 0.25434782608696, 0.090909090909091
40301, 0.73913043478261, 0.22826086956522, 0.090909090909091
40302, 0.73913043478261, 0.25434782608696, 0.11363636363636
40303, 0.76086956521739, 0.25434782608696, 0.13636363636364
40304, 0.73913043478261, 0.22826086956522, 0.13636363636364
40305, 0.73913043478261, 0.25434782608696, 0.15909090909091
40306, 0.76086956521739, 0.25434782608696, 0.18181818181818
40307, 0.73913043478261, 0.22826086956522, 0.18181818181818
40308, 0.73913043478261, 0.25434782608696, 0.20454545454545
40309, 0.76086956521739, 0.25434782608696, 0.22727272727273
40310, 0.73913043478261, 0.22826086956522, 0.22727272727273
40311, 0.73913043478261, 0.25434782608696, 0.25
40312, 0.76086956521739, 0.25434782608696, 0.27272727272727
40313, 0.73913043478261, 0.22826086956522, 0.27272727272727
40314, 0.73913043478261, 0.25434782608696, 0.29545454545455
40315, 0.76086956521739, 0.25434782608696, 0.31818181818182
40316, 0.73913043478261, 0.22826086956522, 0.31818181818182
40317, 0.73913043478261, 0.25434782608696, 0.34090909090909
40318, 0.76086956521739, 0.25434782608696, 0.36363636363636
40319, 0.73913043478261, 0.22826086956522, 0.36363636363636
40320, 0.73913043478261, 0.25434782608696, 0.38636363636364
40321, 0.76086956521739, 0.25434782608696, 0.40909090909091
40322, 0.73913043478261, 0.22826086956522, 0.40909090909091
40323, 0.73913043478261, 0.25434782608696, 0.43181818181818
40324, 0.76086956521739, 0.25434782608696, 0.45454545454545
40325, 0.73913043478261, 0.22826086956522, 0.45454545454545
40326, 0.73913043478261, 0.25434782608696, 0.47727272727273
40327, 0.69565217391304, 0.25434782608696, 0.022727272727273
40328, 0.71739130434783, 0.25434782608696, 0.045454545454545
40329, 0.69565217391304, 0.22826086956522, 0.045454545454545
40330, 0.69565217391304, 0.25434782608696, 0.068181818181818
40331, 0.71739130434783, 0.25434782608696, 0.090909090909091
40332, 0.69565217391304, 0.22826086956522, 0.090909090909091
40333, 0.69565217391304, 0.25434782608696, 0.11363636363636
40334, 0.71739130434783, 0.25434782608696, 0.13636363636364
40335, 0.69565217391304, 0.22826086956522, 0.13636363636364
40336, 0.69565217391304, 0.25434782608696, 0.15909090909091
40337, 0.71739130434783, 0.25434782608696, 0.18181818181818
40338, 0.69565217391304, 0.22826086956522, 0.18181818181818
40339, 0.69565217391304, 0.25434782608696, 0.20454545454545
40340, 0.71739130434783, 0.25434782608696, 0.22727272727273
40341, 0.69565217391304, 0.22826086956522, 0.22727272727273
40342, 0.69565217391304, 0.25434782608696, 0.25
40343, 0.71739130434783, 0.25434782608696, 0.27272727272727
40344, 0.69565217391304, 0.22826086956522, 0.27272727272727
40345, 0.69565217391304, 0.25434782608696, 0.29545454545455
40346, 0.71739130434783, 0.25434782608696, 0.31818181818182
40347, 0.69565217391304, 0.22826086956522, 0.31818181818182
40348, 0.69565217391304, 0.25434782608696, 0.34090909090909
40349, 0.71739130434783, 0.25434782608696, 0.36363636363636
40350, 0.69565217391304, 0.22826086956522, 0.36363636363636
40351, 0.69565217391304, 0.25434782608696, 0.38636363636364
40352, 0.71739130434783, 0.25434782608696, 0.40909090909091
40353, 0.69565217391304, 0.22826086956522, 0.40909090909091
40354, 0.69565217391304, 0.25434782608696, 0.43181818181818
40355, 0.71739130434783, 0.25434782608696, 0.45454545454545
40356, 0.69565217391304, 0.22826086956522, 0.45454545454545
40357, 0.69565217391304, 0.25434782608696, 0.47727272727273
40358, 0.65217391304348, 0.25434782608696, 0.022727272727273
40359, 0.67391304347826, 0.25434782608696, 0.045454545454545
40360, 0.65217391304348, 0.22826086956522, 0.045454545454545
40361, 0.65217391304348, 0.25434782608696, 0.068181818181818
40362, 0.67391304347826, 0.25434782608696, 0.090909090909091
40363, 0.65217391304348, 0.22826086956522, 0.090909090909091
40364, 0.65217391304348, 0.25434782608696, 0.11363636363636
40365, 0.67391304347826, 0.25434782608696, 0.13636363636364
40366, 0.65217391304348, 0.22826086956522, 0.13636363636364
40367, 0.65217391304348, 0.25434782608696, 0.15909090909091
40368, 0.67391304347826, 0.25434782608696, 0.18181818181818
40369, 0.65217391304348, 0.22826086956522, 0.18181818181818
40370, 0.65217391304348, 0.25434782608696, 0.20454545454545
40371, 0.67391304347826, 0.25434782608696, 0.22727272727273
40372, 0.65217391304348, 0.22826086956522, 0.22727272727273
40373, 0.65217391304348, 0.25434782608696, 0.25
40374, 0.67391304347826, 0.25434782608696, 0.27272727272727
40375, 0.65217391304348, 0.22826086956522, 0.27272727272727
40376, 0.65217391304348, 0.25434782608696, 0.29545454545455
40377, 0.67391304347826, 0.25434782608696, 0.31818181818182
40378, 0.65217391304348, 0.22826086956522, 0.31818181818182
40379, 0.65217391304348, 0.25434782608696, 0.34090909090909
40380, 0.67391304347826, 0.25434782608696, 0.36363636363636
40381, 0.65217391304348, 0.22826086956522, 0.36363636363636
40382, 0.65217391304348, 0.25434782608696, 0.38636363636364
40383, 0.67391304347826, 0.25434782608696, 0.40909090909091
40384, 0.65217391304348, 0.22826086956522, 0.40909090909091
40385, 0.65217391304348, 0.25434782608696, 0.43181818181818
40386, 0.67391304347826, 0.25434782608696, 0.45454545454545
40387, 0.65217391304348, 0.22826086956522, 0.45454545454545
40388, 0.65217391304348, 0.25434782608696, 0.47727272727273
40389, 0.60869565217391, 0.25434782608696, 0.022727272727273
40390, 0.6304347826087, 0.25434782608696, 0.045454545454545
40391, 0.60869565217391, 0.22826086956522, 0.045454545454545
40392, 0.60869565217391, 0.25434782608696, 0.068181818181818
40393, 0.6304347826087, 0.25434782608696, 0.090909090909091
40394, 0.60869565217391, 0.22826086956522, 0.090909090909091
40395, 0.60869565217391, 0.25434782608696, 0.11363636363636
40396, 0.6304347826087, 0.25434782608696, 0.13636363636364
40397, 0.60869565217391, 0.22826086956522, 0.13636363636364
40398, 0.60869565217391, 0.25434782608696, 0.15909090909091
40399, 0.6304347826087, 0.25434782608696, 0.18181818181818
40400, 0.60869565217391, 0.22826086956522, 0.18181818181818
40401, 0.60869565217391, 0.25434782608696, 0.20454545454545
40402, 0.6304347826087, 0.25434782608696, 0.22727272727273
40403, 0.60869565217391, 0.22826086956522, 0.22727272727273
40404, 0.60869565217391, 0.25434782608696, 0.25
40405, 0.6304347826087, 0.25434782608696, 0.27272727272727
40406, 0.60869565217391, 0.22826086956522, 0.27272727272727
40407, 0.60869565217391, 0.25434782608696, 0.29545454545455
40408, 0.6304347826087, 0.25434782608696, 0.31818181818182
40409, 0.60869565217391, 0.22826086956522, 0.31818181818182
40410, 0.60869565217391, 0.25434782608696, 0.34090909090909
40411, 0.6304347826087, 0.25434782608696, 0.36363636363636
40412, 0.60869565217391, 0.22826086956522, 0.36363636363636
40413, 0.60869565217391, 0.25434782608696, 0.38636363636364
40414, 0.6304347826087, 0.25434782608696, 0.40909090909091
40415, 0.60869565217391, 0.22826086956522, 0.40909090909091
40416, 0.60869565217391, 0.25434782608696, 0.43181818181818
40417, 0.6304347826087, 0.25434782608696, 0.45454545454545
40418, 0.60869565217391, 0.22826086956522, 0.45454545454545
40419, 0.60869565217391, 0.25434782608696, 0.47727272727273
40420, 0.56521739130435, 0.25434782608696, 0.022727272727273
40421, 0.58695652173913, 0.25434782608696, 0.045454545454545
40422, 0.56521739130435, 0.22826086956522, 0.045454545454545
40423, 0.56521739130435, 0.25434782608696, 0.068181818181818
40424, 0.58695652173913, 0.25434782608696, 0.090909090909091
40425, 0.56521739130435, 0.22826086956522, 0.090909090909091
40426, 0.56521739130435, 0.25434782608696, 0.11363636363636
40427, 0.58695652173913, 0.25434782608696, 0.13636363636364
40428, 0.56521739130435, 0.22826086956522, 0.13636363636364
40429, 0.56521739130435, 0.25434782608696, 0.15909090909091
40430, 0.58695652173913, 0.25434782608696, 0.18181818181818
40431, 0.56521739130435, 0.22826086956522, 0.18181818181818
40432, 0.56521739130435, 0.25434782608696, 0.20454545454545
40433, 0.58695652173913, 0.25434782608696, 0.22727272727273
40434, 0.56521739130435, 0.22826086956522, 0.22727272727273
40435, 0.56521739130435, 0.25434782608696, 0.25
40436, 0.58695652173913, 0.25434782608696, 0.27272727272727
40437, 0.56521739130435, 0.22826086956522, 0.27272727272727
40438, 0.56521739130435, 0.25434782608696, 0.29545454545455
40439, 0.58695652173913, 0.25434782608696, 0.31818181818182
40440, 0.56521739130435, 0.22826086956522, 0.31818181818182
40441, 0.56521739130435, 0.25434782608696, 0.34090909090909
40442, 0.58695652173913, 0.25434782608696, 0.36363636363636
40443, 0.56521739130435, 0.22826086956522, 0.36363636363636
40444, 0.56521739130435, 0.25434782608696, 0.38636363636364
40445, 0.58695652173913, 0.25434782608696, 0.40909090909091
40446, 0.56521739130435, 0.22826086956522, 0.40909090909091
40447, 0.56521739130435, 0.25434782608696, 0.43181818181818
40448, 0.58695652173913, 0.25434782608696, 0.45454545454545
40449, 0.56521739130435, 0.22826086956522, 0.45454545454545
40450, 0.56521739130435, 0.25434782608696, 0.47727272727273
40451, 0.52173913043478, 0.25434782608696, 0.022727272727273
40452, 0.54347826086956, 0.25434782608696, 0.045454545454545
40453, 0.52173913043478, 0.22826086956522, 0.045454545454545
40454, 0.52173913043478, 0.25434782608696, 0.068181818181818
40455, 0.54347826086956, 0.25434782608696, 0.090909090909091
40456, 0.52173913043478, 0.22826086956522, 0.090909090909091
40457, 0.52173913043478, 0.25434782608696, 0.11363636363636
40458, 0.54347826086957, 0.25434782608696, 0.13636363636364
40459, 0.52173913043478, 0.22826086956522, 0.13636363636364
40460, 0.52173913043478, 0.25434782608696, 0.15909090909091
40461, 0.54347826086956, 0.25434782608696, 0.18181818181818
40462, 0.52173913043478, 0.22826086956522, 0.18181818181818
40463, 0.52173913043478, 0.25434782608696, 0.20454545454545
40464, 0.54347826086956, 0.25434782608696, 0.22727272727273
40465, 0.52173913043478, 0.22826086956522, 0.22727272727273
40466, 0.52173913043478, 0.25434782608696, 0.25
40467, 0.54347826086956, 0.25434782608696, 0.27272727272727
40468, 0.52173913043478, 0.22826086956522, 0.27272727272727
40469, 0.52173913043478, 0.25434782608696, 0.29545454545455
40470, 0.54347826086956, 0.25434782608696, 0.31818181818182
40471, 0.52173913043478, 0.22826086956522, 0.31818181818182
40472, 0.52173913043478, 0.25434782608696, 0.34090909090909
40473, 0.54347826086956, 0.25434782608696, 0.36363636363636
40474, 0.52173913043478, 0.22826086956522, 0.36363636363636
40475, 0.52173913043478, 0.25434782608696, 0.38636363636364
40476, 0.54347826086956, 0.25434782608696, 0.40909090909091
40477, 0.52173913043478, 0.22826086956522, 0.40909090909091
40478, 0.52173913043478, 0.25434782608696, 0.43181818181818
40479, 0.54347826086956, 0.25434782608696, 0.45454545454545
40480, 0.52173913043478, 0.22826086956522, 0.45454545454545
40481, 0.52173913043478, 0.25434782608696, 0.47727272727273
40482, 0.47826086956522, 0.25434782608696, 0.022727272727273
40483, 0.5, 0.25434782608696, 0.045454545454545
40484, 0.47826086956522, 0.22826086956522, 0.045454545454545
40485, 0.47826086956522, 0.25434782608696, 0.068181818181818
40486, 0.5, 0.25434782608696, 0.090909090909091
40487, 0.47826086956522, 0.22826086956522, 0.090909090909091
40488, 0.47826086956522, 0.25434782608696, 0.11363636363636
40489, 0.5, 0.25434782608696, 0.13636363636364
40490, 0.47826086956522, 0.22826086956522, 0.13636363636364
40491, 0.47826086956522, 0.25434782608696, 0.15909090909091
40492, 0.5, 0.25434782608696, 0.18181818181818
40493, 0.47826086956522, 0.22826086956522, 0.18181818181818
40494, 0.47826086956522, 0.25434782608696, 0.20454545454545
40495, 0.5, 0.25434782608696, 0.22727272727273
40496, 0.47826086956522, 0.22826086956522, 0.22727272727273
40497, 0.47826086956522, 0.25434782608696, 0.25
40498, 0.5, 0.25434782608696, 0.27272727272727
40499, 0.47826086956522, 0.22826086956522, 0.27272727272727
40500, 0.47826086956522, 0.25434782608696, 0.29545454545455
40501, 0.5, 0.25434782608696, 0.31818181818182
40502, 0.47826086956522, 0.22826086956522, 0.31818181818182
40503, 0.47826086956522, 0.25434782608696, 0.34090909090909
40504, 0.5, 0.25434782608696, 0.36363636363636
40505, 0.47826086956522, 0.22826086956522, 0.36363636363636
40506, 0.47826086956522, 0.25434782608696, 0.38636363636364
40507, 0.5, 0.25434782608696, 0.40909090909091
40508, 0.47826086956522, 0.22826086956522, 0.40909090909091
40509, 0.47826086956522, 0.25434782608696, 0.43181818181818
40510, 0.5, 0.25434782608696, 0.45454545454545
40511, 0.47826086956522, 0.22826086956522, 0.45454545454545
40512, 0.47826086956522, 0.25434782608696, 0.47727272727273
40513, 0.43478260869565, 0.25434782608696, 0.022727272727273
40514, 0.45652173913043, 0.25434782608696, 0.045454545454545
40515, 0.43478260869565, 0.22826086956522, 0.045454545454545
40516, 0.43478260869565, 0.25434782608696, 0.068181818181818
40517, 0.45652173913043, 0.25434782608696, 0.090909090909091
40518, 0.43478260869565, 0.22826086956522, 0.090909090909091
40519, 0.43478260869565, 0.25434782608696, 0.11363636363636
40520, 0.45652173913043, 0.25434782608696, 0.13636363636364
40521, 0.43478260869565, 0.22826086956522, 0.13636363636364
40522, 0.43478260869565, 0.25434782608696, 0.15909090909091
40523, 0.45652173913043, 0.25434782608696, 0.18181818181818
40524, 0.43478260869565, 0.22826086956522, 0.18181818181818
40525, 0.43478260869565, 0.25434782608696, 0.20454545454545
40526, 0.45652173913043, 0.25434782608696, 0.22727272727273
40527, 0.43478260869565, 0.22826086956522, 0.22727272727273
40528, 0.43478260869565, 0.25434782608696, 0.25
40529, 0.45652173913043, 0.25434782608696, 0.27272727272727
40530, 0.43478260869565, 0.22826086956522, 0.27272727272727
40531, 0.43478260869565, 0.25434782608696, 0.29545454545455
40532, 0.45652173913043, 0.25434782608696, 0.31818181818182
40533, 0.43478260869565, 0.22826086956522, 0.31818181818182
40534, 0.43478260869565, 0.25434782608696, 0.34090909090909
40535, 0.45652173913043, 0.25434782608696, 0.36363636363636
40536, 0.43478260869565, 0.22826086956522, 0.36363636363636
40537, 0.43478260869565, 0.25434782608696, 0.38636363636364
40538, 0.45652173913043, 0.25434782608696, 0.40909090909091
40539, 0.43478260869565, 0.22826086956522, 0.40909090909091
40540, 0.43478260869565, 0.25434782608696, 0.43181818181818
40541, 0.45652173913043, 0.25434782608696, 0.45454545454545
40542, 0.43478260869565, 0.22826086956522, 0.45454545454545
40543, 0.43478260869565, 0.25434782608696, 0.47727272727273
40544, 0.39130434782609, 0.25434782608696, 0.022727272727273
40545, 0.41304347826087, 0.25434782608696, 0.045454545454545
40546, 0.39130434782609, 0.22826086956522, 0.045454545454545
40547, 0.39130434782609, 0.25434782608696, 0.068181818181818
40548, 0.41304347826087, 0.25434782608696, 0.090909090909091
40549, 0.39130434782609, 0.22826086956522, 0.090909090909091
40550, 0.39130434782609, 0.25434782608696, 0.11363636363636
40551, 0.41304347826087, 0.25434782608696, 0.13636363636364
40552, 0.39130434782609, 0.22826086956522, 0.13636363636364
40553, 0.39130434782609, 0.25434782608696, 0.15909090909091
40554, 0.41304347826087, 0.25434782608696, 0.18181818181818
40555, 0.39130434782609, 0.22826086956522, 0.18181818181818
40556, 0.39130434782609, 0.25434782608696, 0.20454545454545
40557, 0.41304347826087, 0.25434782608696, 0.22727272727273
40558, 0.39130434782609, 0.22826086956522, 0.22727272727273
40559, 0.39130434782609, 0.25434782608696, 0.25
40560, 0.41304347826087, 0.25434782608696, 0.27272727272727
40561, 0.39130434782609, 0.22826086956522, 0.27272727272727
40562, 0.39130434782609, 0.25434782608696, 0.29545454545455
40563, 0.41304347826087, 0.25434782608696, 0.31818181818182
40564, 0.39130434782609, 0.22826086956522, 0.31818181818182
40565, 0.39130434782609, 0.25434782608696, 0.34090909090909
40566, 0.41304347826087, 0.25434782608696, 0.36363636363636
40567, 0.39130434782609, 0.22826086956522, 0.36363636363636
40568, 0.39130434782609, 0.25434782608696, 0.38636363636364
40569, 0.41304347826087, 0.25434782608696, 0.40909090909091
40570, 0.39130434782609, 0.22826086956522, 0.40909090909091
40571, 0.39130434782609, 0.25434782608696, 0.43181818181818
40572, 0.41304347826087, 0.25434782608696, 0.45454545454545
40573, 0.39130434782609, 0.22826086956522, 0.45454545454545
40574, 0.39130434782609, 0.25434782608696, 0.47727272727273
40575, 0.34782608695652, 0.25434782608696, 0.022727272727273
40576, 0.3695652173913, 0.25434782608696, 0.045454545454545
40577, 0.34782608695652, 0.22826086956522, 0.045454545454545
40578, 0.34782608695652, 0.25434782608696, 0.068181818181818
40579, 0.3695652173913, 0.25434782608696, 0.090909090909091
40580, 0.34782608695652, 0.22826086956522, 0.090909090909091
40581, 0.34782608695652, 0.25434782608696, 0.11363636363636
40582, 0.3695652173913, 0.25434782608696, 0.13636363636364
40583, 0.34782608695652, 0.22826086956522, 0.13636363636364
40584, 0.34782608695652, 0.25434782608696, 0.15909090909091
40585, 0.3695652173913, 0.25434782608696, 0.18181818181818
40586, 0.34782608695652, 0.22826086956522, 0.18181818181818
40587, 0.34782608695652, 0.25434782608696, 0.20454545454545
40588, 0.3695652173913, 0.25434782608696, 0.22727272727273
40589, 0.34782608695652, 0.22826086956522, 0.22727272727273
40590, 0.34782608695652, 0.25434782608696, 0.25
40591, 0.3695652173913, 0.25434782608696, 0.27272727272727
40592, 0.34782608695652, 0.22826086956522, 0.27272727272727
40593, 0.34782608695652, 0.25434782608696, 0.29545454545455
40594, 0.3695652173913, 0.25434782608696, 0.31818181818182
40595, 0.34782608695652, 0.22826086956522, 0.31818181818182
40596, 0.34782608695652, 0.25434782608696, 0.34090909090909
40597, 0.3695652173913, 0.25434782608696, 0.36363636363636
40598, 0.34782608695652, 0.22826086956522, 0.36363636363636
40599, 0.34782608695652, 0.25434782608696, 0.38636363636364
40600, 0.3695652173913, 0.25434782608696, 0.40909090909091
40601, 0.34782608695652, 0.22826086956522, 0.40909090909091
40602, 0.34782608695652, 0.25434782608696, 0.43181818181818
40603, 0.3695652173913, 0.25434782608696, 0.45454545454545
40604, 0.34782608695652, 0.22826086956522, 0.45454545454545
40605, 0.34782608695652, 0.25434782608696, 0.47727272727273
40606, 0.30434782608696, 0.25434782608696, 0.022727272727273
40607, 0.32608695652174, 0.25434782608696, 0.045454545454545
40608, 0.30434782608696, 0.22826086956522, 0.045454545454545
40609, 0.30434782608696, 0.25434782608696, 0.068181818181818
40610, 0.32608695652174, 0.25434782608696, 0.090909090909091
40611, 0.30434782608696, 0.22826086956522, 0.090909090909091
40612, 0.30434782608696, 0.25434782608696, 0.11363636363636
40613, 0.32608695652174, 0.25434782608696, 0.13636363636364
40614, 0.30434782608696, 0.22826086956522, 0.13636363636364
40615, 0.30434782608696, 0.25434782608696, 0.15909090909091
40616, 0.32608695652174, 0.25434782608696, 0.18181818181818
40617, 0.30434782608696, 0.22826086956522, 0.18181818181818
40618, 0.30434782608696, 0.25434782608696, 0.20454545454545
40619, 0.32608695652174, 0.25434782608696, 0.22727272727273
40620, 0.30434782608696, 0.22826086956522, 0.22727272727273
40621, 0.30434782608696, 0.25434782608696, 0.25
40622, 0.32608695652174, 0.25434782608696, 0.27272727272727
40623, 0.30434782608696, 0.22826086956522, 0.27272727272727
40624, 0.30434782608696, 0.25434782608696, 0.29545454545455
40625, 0.32608695652174, 0.25434782608696, 0.31818181818182
40626, 0.30434782608696, 0.22826086956522, 0.31818181818182
40627, 0.30434782608696, 0.25434782608696, 0.34090909090909
40628, 0.32608695652174, 0.25434782608696, 0.36363636363636
40629, 0.30434782608696, 0.22826086956522, 0.36363636363636
40630, 0.30434782608696, 0.25434782608696, 0.38636363636364
40631, 0.32608695652174, 0.25434782608696, 0.40909090909091
40632, 0.30434782608696, 0.22826086956522, 0.40909090909091
40633, 0.30434782608696, 0.25434782608696, 0.43181818181818
40634, 0.32608695652174, 0.25434782608696, 0.45454545454545
40635, 0.30434782608696, 0.22826086956522, 0.45454545454545
40636, 0.30434782608696, 0.25434782608696, 0.47727272727273
40637, 0.26086956521739, 0.25434782608696, 0.022727272727273
40638, 0.28260869565217, 0.25434782608696, 0.045454545454545
40639, 0.26086956521739, 0.22826086956522, 0.045454545454545
40640, 0.26086956521739, 0.25434782608696, 0.068181818181818
40641, 0.28260869565217, 0.25434782608696, 0.090909090909091
40642, 0.26086956521739, 0.22826086956522, 0.090909090909091
40643, 0.26086956521739, 0.25434782608696, 0.11363636363636
40644, 0.28260869565217, 0.25434782608696, 0.13636363636364
40645, 0.26086956521739, 0.22826086956522, 0.13636363636364
40646, 0.26086956521739, 0.25434782608696, 0.15909090909091
40647, 0.28260869565217, 0.25434782608696, 0.18181818181818
40648, 0.26086956521739, 0.22826086956522, 0.18181818181818
40649, 0.26086956521739, 0.25434782608696, 0.20454545454545
40650, 0.28260869565217, 0.25434782608696, 0.22727272727273
40651, 0.26086956521739, 0.22826086956522, 0.22727272727273
40652, 0.26086956521739, 0.25434782608696, 0.25
40653, 0.28260869565217, 0.25434782608696, 0.27272727272727
40654, 0.26086956521739, 0.22826086956522, 0.27272727272727
40655, 0.26086956521739, 0.25434782608696, 0.29545454545455
40656, 0.28260869565217, 0.25434782608696, 0.31818181818182
40657, 0.26086956521739, 0.22826086956522, 0.31818181818182
40658, 0.26086956521739, 0.25434782608696, 0.34090909090909
40659, 0.28260869565217, 0.25434782608696, 0.36363636363636
40660, 0.26086956521739, 0.22826086956522, 0.36363636363636
40661, 0.26086956521739, 0.25434782608696, 0.38636363636364
40662, 0.28260869565217, 0.25434782608696, 0.40909090909091
40663, 0.26086956521739, 0.22826086956522, 0.40909090909091
40664, 0.26086956521739, 0.25434782608696, 0.43181818181818
40665, 0.28260869565217, 0.25434782608696, 0.45454545454545
40666, 0.26086956521739, 0.22826086956522, 0.45454545454545
40667, 0.26086956521739, 0.25434782608696, 0.47727272727273
40668, 0.21739130434783, 0.25434782608696, 0.022727272727273
40669, 0.23913043478261, 0.25434782608696, 0.045454545454545
40670, 0.21739130434783, 0.22826086956522, 0.045454545454545
40671, 0.21739130434783, 0.25434782608696, 0.068181818181818
40672, 0.23913043478261, 0.25434782608696, 0.090909090909091
40673, 0.21739130434783, 0.22826086956522, 0.090909090909091
40674, 0.21739130434783, 0.25434782608696, 0.11363636363636
40675, 0.23913043478261, 0.25434782608696, 0.13636363636364
40676, 0.21739130434783, 0.22826086956522, 0.13636363636364
40677, 0.21739130434783, 0.25434782608696, 0.15909090909091
40678, 0.23913043478261, 0.25434782608696, 0.18181818181818
40679, 0.21739130434783, 0.22826086956522, 0.18181818181818
40680, 0.21739130434783, 0.25434782608696, 0.20454545454545
40681, 0.23913043478261, 0.25434782608696, 0.22727272727273
40682, 0.21739130434783, 0.22826086956522, 0.22727272727273
40683, 0.21739130434783, 0.25434782608696, 0.25
40684, 0.23913043478261, 0.25434782608696, 0.27272727272727
40685, 0.21739130434783, 0.22826086956522, 0.27272727272727
40686, 0.21739130434783, 0.25434782608696, 0.29545454545455
40687, 0.23913043478261, 0.25434782608696, 0.31818181818182
40688, 0.21739130434783, 0.22826086956522, 0.31818181818182
40689, 0.21739130434783, 0.25434782608696, 0.34090909090909
40690, 0.23913043478261, 0.25434782608696, 0.36363636363636
40691, 0.21739130434783, 0.22826086956522, 0.36363636363636
40692, 0.21739130434783, 0.25434782608696, 0.38636363636364
40693, 0.23913043478261, 0.25434782608696, 0.40909090909091
40694, 0.21739130434783, 0.22826086956522, 0.40909090909091
40695, 0.21739130434783, 0.25434782608696, 0.43181818181818
40696, 0.23913043478261, 0.25434782608696, 0.45454545454545
40697, 0.21739130434783, 0.22826086956522, 0.45454545454545
40698, 0.21739130434783, 0.25434782608696, 0.47727272727273
40699, 0.17391304347826, 0.25434782608696, 0.022727272727273
40700, 0.19565217391304, 0.25434782608696, 0.045454545454545
40701, 0.17391304347826, 0.22826086956522, 0.045454545454545
40702, 0.17391304347826, 0.25434782608696, 0.068181818181818
40703, 0.19565217391304, 0.25434782608696, 0.090909090909091
40704, 0.17391304347826, 0.22826086956522, 0.090909090909091
40705, 0.17391304347826, 0.25434782608696, 0.11363636363636
40706, 0.19565217391304, 0.25434782608696, 0.13636363636364
40707, 0.17391304347826, 0.22826086956522, 0.13636363636364
40708, 0.17391304347826, 0.25434782608696, 0.15909090909091
40709, 0.19565217391304, 0.25434782608696, 0.18181818181818
40710, 0.17391304347826, 0.22826086956522, 0.18181818181818
40711, 0.17391304347826, 0.25434782608696, 0.20454545454545
40712, 0.19565217391304, 0.25434782608696, 0.22727272727273
40713, 0.17391304347826, 0.22826086956522, 0.22727272727273
40714, 0.17391304347826, 0.25434782608696, 0.25
40715, 0.19565217391304, 0.25434782608696, 0.27272727272727
40716, 0.17391304347826, 0.22826086956522, 0.27272727272727
40717, 0.17391304347826, 0.25434782608696, 0.29545454545455
40718, 0.19565217391304, 0.25434782608696, 0.31818181818182
40719, 0.17391304347826, 0.22826086956522, 0.31818181818182
40720, 0.17391304347826, 0.25434782608696, 0.34090909090909
40721, 0.19565217391304, 0.25434782608696, 0.36363636363636
40722, 0.17391304347826, 0.22826086956522, 0.36363636363636
40723, 0.17391304347826, 0.25434782608696, 0.38636363636364
40724, 0.19565217391304, 0.25434782608696, 0.40909090909091
40725, 0.17391304347826, 0.22826086956522, 0.40909090909091
40726, 0.17391304347826, 0.25434782608696, 0.43181818181818
40727, 0.19565217391304, 0.25434782608696, 0.45454545454545
40728, 0.17391304347826, 0.22826086956522, 0.45454545454545
40729, 0.17391304347826, 0.25434782608696, 0.47727272727273
40730, 0.1304347826087, 0.25434782608696, 0.022727272727273
40731, 0.15217391304348, 0.25434782608696, 0.045454545454545
40732, 0.1304347826087, 0.22826086956522, 0.045454545454545
40733, 0.1304347826087, 0.25434782608696, 0.068181818181818
40734, 0.15217391304348, 0.25434782608696, 0.090909090909091
40735, 0.1304347826087, 0.22826086956522, 0.090909090909091
40736, 0.1304347826087, 0.25434782608696, 0.11363636363636
40737, 0.15217391304348, 0.25434782608696, 0.13636363636364
40738, 0.1304347826087, 0.22826086956522, 0.13636363636364
40739, 0.1304347826087, 0.25434782608696, 0.15909090909091
40740, 0.15217391304348, 0.25434782608696, 0.18181818181818
40741, 0.1304347826087, 0.22826086956522, 0.18181818181818
40742, 0.1304347826087, 0.25434782608696, 0.20454545454545
40743, 0.15217391304348, 0.25434782608696, 0.22727272727273
40744, 0.1304347826087, 0.22826086956522, 0.22727272727273
40745, 0.1304347826087, 0.25434782608696, 0.25
40746, 0.15217391304348, 0.25434782608696, 0.27272727272727
40747, 0.1304347826087, 0.22826086956522, 0.27272727272727
40748, 0.1304347826087, 0.25434782608696, 0.29545454545455
40749, 0.15217391304348, 0.25434782608696, 0.31818181818182
40750, 0.1304347826087, 0.22826086956522, 0.31818181818182
40751, 0.1304347826087, 0.25434782608696, 0.34090909090909
40752, 0.15217391304348, 0.25434782608696, 0.36363636363636
40753, 0.1304347826087, 0.22826086956522, 0.36363636363636
40754, 0.1304347826087, 0.25434782608696, 0.38636363636364
40755, 0.15217391304348, 0.25434782608696, 0.40909090909091
40756, 0.1304347826087, 0.22826086956522, 0.40909090909091
40757, 0.1304347826087, 0.25434782608696, 0.43181818181818
40758, 0.15217391304348, 0.25434782608696, 0.45454545454545
40759, 0.1304347826087, 0.22826086956522, 0.45454545454545
40760, 0.1304347826087, 0.25434782608696, 0.47727272727273
40761, 0.08695652173913, 0.25434782608696, 0.022727272727273
40762, 0.10869565217391, 0.25434782608696, 0.045454545454545
40763, 0.08695652173913, 0.22826086956522, 0.045454545454545
40764, 0.08695652173913, 0.25434782608696, 0.068181818181818
40765, 0.10869565217391, 0.25434782608696, 0.090909090909091
40766, 0.08695652173913, 0.22826086956522, 0.090909090909091
40767, 0.08695652173913, 0.25434782608696, 0.11363636363636
40768, 0.10869565217391, 0.25434782608696, 0.13636363636364
40769, 0.08695652173913, 0.22826086956522, 0.13636363636364
40770, 0.08695652173913, 0.25434782608696, 0.15909090909091
40771, 0.10869565217391, 0.25434782608696, 0.18181818181818
40772, 0.08695652173913, 0.22826086956522, 0.18181818181818
40773, 0.08695652173913, 0.25434782608696, 0.20454545454545
40774, 0.10869565217391, 0.25434782608696, 0.22727272727273
40775, 0.08695652173913, 0.22826086956522, 0.22727272727273
40776, 0.08695652173913, 0.25434782608696, 0.25
40777, 0.10869565217391, 0.25434782608696, 0.27272727272727
40778, 0.08695652173913, 0.22826086956522, 0.27272727272727
40779, 0.08695652173913, 0.25434782608696, 0.29545454545455
40780, 0.10869565217391, 0.25434782608696, 0.31818181818182
40781, 0.08695652173913, 0.22826086956522, 0.31818181818182
40782, 0.08695652173913, 0.25434782608696, 0.34090909090909
40783, 0.10869565217391, 0.25434782608696, 0.36363636363636
40784, 0.08695652173913, 0.22826086956522, 0.36363636363636
40785, 0.08695652173913, 0.25434782608696, 0.38636363636364
40786, 0.10869565217391, 0.25434782608696, 0.40909090909091
40787, 0.08695652173913, 0.22826086956522, 0.40909090909091
40788, 0.08695652173913, 0.25434782608696, 0.43181818181818
40789, 0.10869565217391, 0.25434782608696, 0.45454545454545
40790, 0.08695652173913, 0.22826086956522, 0.45454545454545
40791, 0.08695652173913, 0.25434782608696, 0.47727272727273
40792, 0.043478260869565, 0.25434782608696, 0.022727272727273
40793, 0.065217391304348, 0.25434782608696, 0.045454545454545
40794, 0.043478260869565, 0.22826086956522, 0.045454545454545
40795, 0.043478260869565, 0.25434782608696, 0.068181818181818
40796, 0.065217391304348, 0.25434782608696, 0.090909090909091
40797, 0.043478260869565, 0.22826086956522, 0.090909090909091
40798, 0.043478260869565, 0.25434782608696, 0.11363636363636
40799, 0.065217391304348, 0.25434782608696, 0.13636363636364
40800, 0.043478260869565, 0.22826086956522, 0.13636363636364
40801, 0.043478260869565, 0.25434782608696, 0.15909090909091
40802, 0.065217391304348, 0.25434782608696, 0.18181818181818
40803, 0.043478260869565, 0.22826086956522, 0.18181818181818
40804, 0.043478260869565, 0.25434782608696, 0.20454545454545
40805, 0.065217391304348, 0.25434782608696, 0.22727272727273
40806, 0.043478260869565, 0.22826086956522, 0.22727272727273
40807, 0.043478260869565, 0.25434782608696, 0.25
40808, 0.065217391304348, 0.25434782608696, 0.27272727272727
40809, 0.043478260869565, 0.22826086956522, 0.27272727272727
40810, 0.043478260869565, 0.25434782608696, 0.29545454545455
40811, 0.065217391304348, 0.25434782608696, 0.31818181818182
40812, 0.043478260869565, 0.22826086956522, 0.31818181818182
40813, 0.043478260869565, 0.25434782608696, 0.34090909090909
40814, 0.065217391304348, 0.25434782608696, 0.36363636363636
40815, 0.043478260869565, 0.22826086956522, 0.36363636363636
40816, 0.043478260869565, 0.25434782608696, 0.38636363636364
40817, 0.065217391304348, 0.25434782608696, 0.40909090909091
40818, 0.043478260869565, 0.22826086956522, 0.40909090909091
40819, 0.043478260869565, 0.25434782608696, 0.43181818181818
40820, 0.065217391304348, 0.25434782608696, 0.45454545454545
40821, 0.043478260869565, 0.22826086956522, 0.45454545454545
40822, 0.043478260869565, 0.25434782608696, 0.47727272727273
40823, 0.021739130434783, 0.25434782608696, 0.045454545454545
40824, 0.021739130434783, 0.25434782608696, 0.090909090909091
40825, 0.021739130434783, 0.25434782608696, 0.13636363636364
40826, 0.021739130434783, 0.25434782608696, 0.18181818181818
40827, 0.021739130434783, 0.25434782608696, 0.22727272727273
40828, 0.021739130434783, 0.25434782608696, 0.27272727272727
40829, 0.021739130434783, 0.25434782608696, 0.31818181818182
40830, 0.021739130434783, 0.25434782608696, 0.36363636363636
40831, 0.021739130434783, 0.25434782608696, 0.40909090909091
40832, 0.021739130434783, 0.25434782608696, 0.45454545454545
40833, 0.95652173913043, 0.30652173913043, 0.022727272727273
40834, 0.97826086956522, 0.30652173913043, 0.045454545454545
40835, 0.95652173913043, 0.2804347826087, 0.045454545454545
40836, 0.95652173913043, 0.30652173913043, 0.068181818181818
40837, 0.97826086956522, 0.30652173913043, 0.090909090909091
40838, 0.95652173913043, 0.2804347826087, 0.090909090909091
40839, 0.95652173913044, 0.30652173913043, 0.11363636363636
40840, 0.97826086956522, 0.30652173913043, 0.13636363636364
40841, 0.95652173913043, 0.2804347826087, 0.13636363636364
40842, 0.95652173913044, 0.30652173913043, 0.15909090909091
40843, 0.97826086956522, 0.30652173913043, 0.18181818181818
40844, 0.95652173913043, 0.2804347826087, 0.18181818181818
40845, 0.95652173913044, 0.30652173913043, 0.20454545454545
40846, 0.97826086956522, 0.30652173913043, 0.22727272727273
40847, 0.95652173913044, 0.2804347826087, 0.22727272727273
40848, 0.95652173913044, 0.30652173913043, 0.25
40849, 0.97826086956522, 0.30652173913043, 0.27272727272727
40850, 0.95652173913044, 0.2804347826087, 0.27272727272727
40851, 0.95652173913044, 0.30652173913043, 0.29545454545455
40852, 0.97826086956522, 0.30652173913043, 0.31818181818182
40853, 0.95652173913043, 0.2804347826087, 0.31818181818182
40854, 0.95652173913044, 0.30652173913043, 0.34090909090909
40855, 0.97826086956522, 0.30652173913043, 0.36363636363636
40856, 0.95652173913043, 0.2804347826087, 0.36363636363636
40857, 0.95652173913044, 0.30652173913043, 0.38636363636364
40858, 0.97826086956522, 0.30652173913043, 0.40909090909091
40859, 0.95652173913043, 0.2804347826087, 0.40909090909091
40860, 0.95652173913044, 0.30652173913043, 0.43181818181818
40861, 0.97826086956522, 0.30652173913043, 0.45454545454545
40862, 0.95652173913043, 0.2804347826087, 0.45454545454545
40863, 0.95652173913044, 0.30652173913043, 0.47727272727273
40864, 0.91304347826087, 0.30652173913043, 0.022727272727273
40865, 0.93478260869565, 0.30652173913043, 0.045454545454545
40866, 0.91304347826087, 0.2804347826087, 0.045454545454545
40867, 0.91304347826087, 0.30652173913043, 0.068181818181818
40868, 0.93478260869565, 0.30652173913043, 0.090909090909091
40869, 0.91304347826087, 0.2804347826087, 0.090909090909091
40870, 0.91304347826087, 0.30652173913043, 0.11363636363636
40871, 0.93478260869565, 0.30652173913043, 0.13636363636364
40872, 0.91304347826087, 0.2804347826087, 0.13636363636364
40873, 0.91304347826087, 0.30652173913043, 0.15909090909091
40874, 0.93478260869565, 0.30652173913043, 0.18181818181818
40875, 0.91304347826087, 0.2804347826087, 0.18181818181818
40876, 0.91304347826087, 0.30652173913043, 0.20454545454545
40877, 0.93478260869565, 0.30652173913043, 0.22727272727273
40878, 0.91304347826087, 0.2804347826087, 0.22727272727273
40879, 0.91304347826087, 0.30652173913043, 0.25
40880, 0.93478260869565, 0.30652173913043, 0.27272727272727
40881, 0.91304347826087, 0.2804347826087, 0.27272727272727
40882, 0.91304347826087, 0.30652173913043, 0.29545454545455
40883, 0.93478260869565, 0.30652173913043, 0.31818181818182
40884, 0.91304347826087, 0.2804347826087, 0.31818181818182
40885, 0.91304347826087, 0.30652173913043, 0.34090909090909
40886, 0.93478260869565, 0.30652173913043, 0.36363636363636
40887, 0.91304347826087, 0.2804347826087, 0.36363636363636
40888, 0.91304347826087, 0.30652173913043, 0.38636363636364
40889, 0.93478260869565, 0.30652173913043, 0.40909090909091
40890, 0.91304347826087, 0.2804347826087, 0.40909090909091
40891, 0.91304347826087, 0.30652173913043, 0.43181818181818
40892, 0.93478260869565, 0.30652173913043, 0.45454545454545
40893, 0.91304347826087, 0.2804347826087, 0.45454545454545
40894, 0.91304347826087, 0.30652173913043, 0.47727272727273
40895, 0.8695652173913, 0.30652173913043, 0.022727272727273
40896, 0.89130434782609, 0.30652173913043, 0.045454545454545
40897, 0.8695652173913, 0.2804347826087, 0.045454545454545
40898, 0.8695652173913, 0.30652173913043, 0.068181818181818
40899, 0.89130434782609, 0.30652173913043, 0.090909090909091
40900, 0.8695652173913, 0.2804347826087, 0.090909090909091
40901, 0.8695652173913, 0.30652173913043, 0.11363636363636
40902, 0.89130434782609, 0.30652173913043, 0.13636363636364
40903, 0.8695652173913, 0.2804347826087, 0.13636363636364
40904, 0.8695652173913, 0.30652173913043, 0.15909090909091
40905, 0.89130434782609, 0.30652173913043, 0.18181818181818
40906, 0.8695652173913, 0.2804347826087, 0.18181818181818
40907, 0.8695652173913, 0.30652173913043, 0.20454545454545
40908, 0.89130434782609, 0.30652173913043, 0.22727272727273
40909, 0.8695652173913, 0.2804347826087, 0.22727272727273
40910, 0.8695652173913, 0.30652173913043, 0.25
40911, 0.89130434782609, 0.30652173913043, 0.27272727272727
40912, 0.8695652173913, 0.2804347826087, 0.27272727272727
40913, 0.8695652173913, 0.30652173913043, 0.29545454545455
40914, 0.89130434782609, 0.30652173913043, 0.31818181818182
40915, 0.8695652173913, 0.2804347826087, 0.31818181818182
40916, 0.8695652173913, 0.30652173913043, 0.34090909090909
40917, 0.89130434782609, 0.30652173913043, 0.36363636363636
40918, 0.8695652173913, 0.2804347826087, 0.36363636363636
40919, 0.8695652173913, 0.30652173913043, 0.38636363636364
40920, 0.89130434782609, 0.30652173913043, 0.40909090909091
40921, 0.8695652173913, 0.2804347826087, 0.40909090909091
40922, 0.8695652173913, 0.30652173913043, 0.43181818181818
40923, 0.89130434782609, 0.30652173913043, 0.45454545454545
40924, 0.8695652173913, 0.2804347826087, 0.45454545454545
40925, 0.8695652173913, 0.30652173913043, 0.47727272727273
40926, 0.82608695652174, 0.30652173913043, 0.022727272727273
40927, 0.84782608695652, 0.30652173913043, 0.045454545454545
40928, 0.82608695652174, 0.2804347826087, 0.045454545454545
40929, 0.82608695652174, 0.30652173913043, 0.068181818181818
40930, 0.84782608695652, 0.30652173913043, 0.090909090909091
40931, 0.82608695652174, 0.2804347826087, 0.090909090909091
40932, 0.82608695652174, 0.30652173913043, 0.11363636363636
40933, 0.84782608695652, 0.30652173913043, 0.13636363636364
40934, 0.82608695652174, 0.2804347826087, 0.13636363636364
40935, 0.82608695652174, 0.30652173913043, 0.15909090909091
40936, 0.84782608695652, 0.30652173913043, 0.18181818181818
40937, 0.82608695652174, 0.2804347826087, 0.18181818181818
40938, 0.82608695652174, 0.30652173913043, 0.20454545454545
40939, 0.84782608695652, 0.30652173913043, 0.22727272727273
40940, 0.82608695652174, 0.2804347826087, 0.22727272727273
40941, 0.82608695652174, 0.30652173913043, 0.25
40942, 0.84782608695652, 0.30652173913043, 0.27272727272727
40943, 0.82608695652174, 0.2804347826087, 0.27272727272727
40944, 0.82608695652174, 0.30652173913043, 0.29545454545455
40945, 0.84782608695652, 0.30652173913043, 0.31818181818182
40946, 0.82608695652174, 0.2804347826087, 0.31818181818182
40947, 0.82608695652174, 0.30652173913043, 0.34090909090909
40948, 0.84782608695652, 0.30652173913043, 0.36363636363636
40949, 0.82608695652174, 0.2804347826087, 0.36363636363636
40950, 0.82608695652174, 0.30652173913043, 0.38636363636364
40951, 0.84782608695652, 0.30652173913043, 0.40909090909091
40952, 0.82608695652174, 0.2804347826087, 0.40909090909091
40953, 0.82608695652174, 0.30652173913043, 0.43181818181818
40954, 0.84782608695652, 0.30652173913043, 0.45454545454545
40955, 0.82608695652174, 0.2804347826087, 0.45454545454545
40956, 0.82608695652174, 0.30652173913043, 0.47727272727273
40957, 0.78260869565217, 0.30652173913043, 0.022727272727273
40958, 0.80434782608696, 0.30652173913043, 0.045454545454545
40959, 0.78260869565217, 0.2804347826087, 0.045454545454545
40960, 0.78260869565217, 0.30652173913043, 0.068181818181818
40961, 0.80434782608696, 0.30652173913043, 0.090909090909091
40962, 0.78260869565217, 0.2804347826087, 0.090909090909091
40963, 0.78260869565217, 0.30652173913043, 0.11363636363636
40964, 0.80434782608696, 0.30652173913043, 0.13636363636364
40965, 0.78260869565217, 0.2804347826087, 0.13636363636364
40966, 0.78260869565217, 0.30652173913043, 0.15909090909091
40967, 0.80434782608696, 0.30652173913043, 0.18181818181818
40968, 0.78260869565217, 0.2804347826087, 0.18181818181818
40969, 0.78260869565217, 0.30652173913043, 0.20454545454545
40970, 0.80434782608696, 0.30652173913043, 0.22727272727273
40971, 0.78260869565217, 0.2804347826087, 0.22727272727273
40972, 0.78260869565217, 0.30652173913043, 0.25
40973, 0.80434782608696, 0.30652173913043, 0.27272727272727
40974, 0.78260869565217, 0.2804347826087, 0.27272727272727
40975, 0.78260869565217, 0.30652173913043, 0.29545454545455
40976, 0.80434782608696, 0.30652173913043, 0.31818181818182
40977, 0.78260869565217, 0.2804347826087, 0.31818181818182
40978, 0.78260869565217, 0.30652173913043, 0.34090909090909
40979, 0.80434782608696, 0.30652173913043, 0.36363636363636
40980, 0.78260869565217, 0.2804347826087, 0.36363636363636
40981, 0.78260869565217, 0.30652173913043, 0.38636363636364
40982, 0.80434782608696, 0.30652173913043, 0.40909090909091
40983, 0.78260869565217, 0.2804347826087, 0.40909090909091
40984, 0.78260869565217, 0.30652173913043, 0.43181818181818
40985, 0.80434782608696, 0.30652173913043, 0.45454545454545
40986, 0.78260869565217, 0.2804347826087, 0.45454545454545
40987, 0.78260869565217, 0.30652173913043, 0.47727272727273
40988, 0.73913043478261, 0.30652173913043, 0.022727272727273
40989, 0.76086956521739, 0.30652173913043, 0.045454545454545
40990, 0.73913043478261, 0.2804347826087, 0.045454545454545
40991, 0.73913043478261, 0.30652173913043, 0.068181818181818
40992, 0.76086956521739, 0.30652173913043, 0.090909090909091
40993, 0.73913043478261, 0.2804347826087, 0.090909090909091
40994, 0.73913043478261, 0.30652173913043, 0.11363636363636
40995, 0.76086956521739, 0.30652173913043, 0.13636363636364
40996, 0.73913043478261, 0.2804347826087, 0.13636363636364
40997, 0.73913043478261, 0.30652173913043, 0.15909090909091
40998, 0.76086956521739, 0.30652173913043, 0.18181818181818
40999, 0.73913043478261, 0.2804347826087, 0.18181818181818
41000, 0.73913043478261, 0.30652173913043, 0.20454545454545
41001, 0.76086956521739, 0.30652173913043, 0.22727272727273
41002, 0.73913043478261, 0.2804347826087, 0.22727272727273
41003, 0.73913043478261, 0.30652173913043, 0.25
41004, 0.76086956521739, 0.30652173913043, 0.27272727272727
41005, 0.73913043478261, 0.2804347826087, 0.27272727272727
41006, 0.73913043478261, 0.30652173913043, 0.29545454545455
41007, 0.76086956521739, 0.30652173913043, 0.31818181818182
41008, 0.73913043478261, 0.2804347826087, 0.31818181818182
41009, 0.73913043478261, 0.30652173913043, 0.34090909090909
41010, 0.76086956521739, 0.30652173913043, 0.36363636363636
41011, 0.73913043478261, 0.2804347826087, 0.36363636363636
41012, 0.73913043478261, 0.30652173913043, 0.38636363636364
41013, 0.76086956521739, 0.30652173913043, 0.40909090909091
41014, 0.73913043478261, 0.2804347826087, 0.40909090909091
41015, 0.73913043478261, 0.30652173913043, 0.43181818181818
41016, 0.76086956521739, 0.30652173913043, 0.45454545454545
41017, 0.73913043478261, 0.2804347826087, 0.45454545454545
41018, 0.73913043478261, 0.30652173913043, 0.47727272727273
41019, 0.69565217391304, 0.30652173913043, 0.022727272727273
41020, 0.71739130434783, 0.30652173913043, 0.045454545454545
41021, 0.69565217391304, 0.2804347826087, 0.045454545454545
41022, 0.69565217391304, 0.30652173913043, 0.068181818181818
41023, 0.71739130434783, 0.30652173913043, 0.090909090909091
41024, 0.69565217391304, 0.2804347826087, 0.090909090909091
41025, 0.69565217391304, 0.30652173913043, 0.11363636363636
41026, 0.71739130434783, 0.30652173913043, 0.13636363636364
41027, 0.69565217391304, 0.2804347826087, 0.13636363636364
41028, 0.69565217391304, 0.30652173913043, 0.15909090909091
41029, 0.71739130434783, 0.30652173913043, 0.18181818181818
41030, 0.69565217391304, 0.2804347826087, 0.18181818181818
41031, 0.69565217391304, 0.30652173913043, 0.20454545454545
41032, 0.71739130434783, 0.30652173913043, 0.22727272727273
41033, 0.69565217391304, 0.2804347826087, 0.22727272727273
41034, 0.69565217391304, 0.30652173913043, 0.25
41035, 0.71739130434783, 0.30652173913043, 0.27272727272727
41036, 0.69565217391304, 0.2804347826087, 0.27272727272727
41037, 0.69565217391304, 0.30652173913043, 0.29545454545455
41038, 0.71739130434783, 0.30652173913043, 0.31818181818182
41039, 0.69565217391304, 0.2804347826087, 0.31818181818182
41040, 0.69565217391304, 0.30652173913043, 0.34090909090909
41041, 0.71739130434783, 0.30652173913043, 0.36363636363636
41042, 0.69565217391304, 0.2804347826087, 0.36363636363636
41043, 0.69565217391304, 0.30652173913043, 0.38636363636364
41044, 0.71739130434783, 0.30652173913043, 0.40909090909091
41045, 0.69565217391304, 0.2804347826087, 0.40909090909091
41046, 0.69565217391304, 0.30652173913043, 0.43181818181818
41047, 0.71739130434783, 0.30652173913043, 0.45454545454545
41048, 0.69565217391304, 0.2804347826087, 0.45454545454545
41049, 0.69565217391304, 0.30652173913043, 0.47727272727273
41050, 0.65217391304348, 0.30652173913043, 0.022727272727273
41051, 0.67391304347826, 0.30652173913043, 0.045454545454545
41052, 0.65217391304348, 0.2804347826087, 0.045454545454545
41053, 0.65217391304348, 0.30652173913043, 0.068181818181818
41054, 0.67391304347826, 0.30652173913043, 0.090909090909091
41055, 0.65217391304348, 0.2804347826087, 0.090909090909091
41056, 0.65217391304348, 0.30652173913043, 0.11363636363636
41057, 0.67391304347826, 0.30652173913043, 0.13636363636364
41058, 0.65217391304348, 0.2804347826087, 0.13636363636364
41059, 0.65217391304348, 0.30652173913043, 0.15909090909091
41060, 0.67391304347826, 0.30652173913043, 0.18181818181818
41061, 0.65217391304348, 0.2804347826087, 0.18181818181818
41062, 0.65217391304348, 0.30652173913043, 0.20454545454545
41063, 0.67391304347826, 0.30652173913043, 0.22727272727273
41064, 0.65217391304348, 0.2804347826087, 0.22727272727273
41065, 0.65217391304348, 0.30652173913043, 0.25
41066, 0.67391304347826, 0.30652173913043, 0.27272727272727
41067, 0.65217391304348, 0.2804347826087, 0.27272727272727
41068, 0.65217391304348, 0.30652173913043, 0.29545454545455
41069, 0.67391304347826, 0.30652173913043, 0.31818181818182
41070, 0.65217391304348, 0.2804347826087, 0.31818181818182
41071, 0.65217391304348, 0.30652173913043, 0.34090909090909
41072, 0.67391304347826, 0.30652173913043, 0.36363636363636
41073, 0.65217391304348, 0.2804347826087, 0.36363636363636
41074, 0.65217391304348, 0.30652173913043, 0.38636363636364
41075, 0.67391304347826, 0.30652173913043, 0.40909090909091
41076, 0.65217391304348, 0.2804347826087, 0.40909090909091
41077, 0.65217391304348, 0.30652173913043, 0.43181818181818
41078, 0.67391304347826, 0.30652173913043, 0.45454545454545
41079, 0.65217391304348, 0.2804347826087, 0.45454545454545
41080, 0.65217391304348, 0.30652173913043, 0.47727272727273
41081, 0.60869565217391, 0.30652173913043, 0.022727272727273
41082, 0.6304347826087, 0.30652173913043, 0.045454545454545
41083, 0.60869565217391, 0.2804347826087, 0.045454545454545
41084, 0.60869565217391, 0.30652173913043, 0.068181818181818
41085, 0.6304347826087, 0.30652173913043, 0.090909090909091
41086, 0.60869565217391, 0.2804347826087, 0.090909090909091
41087, 0.60869565217391, 0.30652173913043, 0.11363636363636
41088, 0.6304347826087, 0.30652173913043, 0.13636363636364
41089, 0.60869565217391, 0.2804347826087, 0.13636363636364
41090, 0.60869565217391, 0.30652173913043, 0.15909090909091
41091, 0.6304347826087, 0.30652173913043, 0.18181818181818
41092, 0.60869565217391, 0.2804347826087, 0.18181818181818
41093, 0.60869565217391, 0.30652173913043, 0.20454545454545
41094, 0.6304347826087, 0.30652173913043, 0.22727272727273
41095, 0.60869565217391, 0.2804347826087, 0.22727272727273
41096, 0.60869565217391, 0.30652173913043, 0.25
41097, 0.6304347826087, 0.30652173913043, 0.27272727272727
41098, 0.60869565217391, 0.2804347826087, 0.27272727272727
41099, 0.60869565217391, 0.30652173913043, 0.29545454545455
41100, 0.6304347826087, 0.30652173913043, 0.31818181818182
41101, 0.60869565217391, 0.2804347826087, 0.31818181818182
41102, 0.60869565217391, 0.30652173913043, 0.34090909090909
41103, 0.6304347826087, 0.30652173913043, 0.36363636363636
41104, 0.60869565217391, 0.2804347826087, 0.36363636363636
41105, 0.60869565217391, 0.30652173913043, 0.38636363636364
41106, 0.6304347826087, 0.30652173913043, 0.40909090909091
41107, 0.60869565217391, 0.2804347826087, 0.40909090909091
41108, 0.60869565217391, 0.30652173913043, 0.43181818181818
41109, 0.6304347826087, 0.30652173913043, 0.45454545454545
41110, 0.60869565217391, 0.2804347826087, 0.45454545454545
41111, 0.60869565217391, 0.30652173913043, 0.47727272727273
41112, 0.56521739130435, 0.30652173913043, 0.022727272727273
41113, 0.58695652173913, 0.30652173913043, 0.045454545454545
41114, 0.56521739130435, 0.2804347826087, 0.045454545454545
41115, 0.56521739130435, 0.30652173913043, 0.068181818181818
41116, 0.58695652173913, 0.30652173913043, 0.090909090909091
41117, 0.56521739130435, 0.2804347826087, 0.090909090909091
41118, 0.56521739130435, 0.30652173913043, 0.11363636363636
41119, 0.58695652173913, 0.30652173913043, 0.13636363636364
41120, 0.56521739130435, 0.2804347826087, 0.13636363636364
41121, 0.56521739130435, 0.30652173913043, 0.15909090909091
41122, 0.58695652173913, 0.30652173913043, 0.18181818181818
41123, 0.56521739130435, 0.2804347826087, 0.18181818181818
41124, 0.56521739130435, 0.30652173913043, 0.20454545454545
41125, 0.58695652173913, 0.30652173913043, 0.22727272727273
41126, 0.56521739130435, 0.2804347826087, 0.22727272727273
41127, 0.56521739130435, 0.30652173913043, 0.25
41128, 0.58695652173913, 0.30652173913043, 0.27272727272727
41129, 0.56521739130435, 0.2804347826087, 0.27272727272727
41130, 0.56521739130435, 0.30652173913043, 0.29545454545455
41131, 0.58695652173913, 0.30652173913043, 0.31818181818182
41132, 0.56521739130435, 0.2804347826087, 0.31818181818182
41133, 0.56521739130435, 0.30652173913043, 0.34090909090909
41134, 0.58695652173913, 0.30652173913043, 0.36363636363636
41135, 0.56521739130435, 0.2804347826087, 0.36363636363636
41136, 0.56521739130435, 0.30652173913043, 0.38636363636364
41137, 0.58695652173913, 0.30652173913043, 0.40909090909091
41138, 0.56521739130435, 0.2804347826087, 0.40909090909091
41139, 0.56521739130435, 0.30652173913043, 0.43181818181818
41140, 0.58695652173913, 0.30652173913043, 0.45454545454545
41141, 0.56521739130435, 0.2804347826087, 0.45454545454545
41142, 0.56521739130435, 0.30652173913043, 0.47727272727273
41143, 0.52173913043478, 0.30652173913043, 0.022727272727273
41144, 0.54347826086956, 0.30652173913043, 0.045454545454545
41145, 0.52173913043478, 0.2804347826087, 0.045454545454545
41146, 0.52173913043478, 0.30652173913043, 0.068181818181818
41147, 0.54347826086956, 0.30652173913043, 0.090909090909091
41148, 0.52173913043478, 0.2804347826087, 0.090909090909091
41149, 0.52173913043478, 0.30652173913043, 0.11363636363636
41150, 0.54347826086957, 0.30652173913043, 0.13636363636364
41151, 0.52173913043478, 0.2804347826087, 0.13636363636364
41152, 0.52173913043478, 0.30652173913043, 0.15909090909091
41153, 0.54347826086956, 0.30652173913043, 0.18181818181818
41154, 0.52173913043478, 0.2804347826087, 0.18181818181818
41155, 0.52173913043478, 0.30652173913043, 0.20454545454545
41156, 0.54347826086956, 0.30652173913043, 0.22727272727273
41157, 0.52173913043478, 0.2804347826087, 0.22727272727273
41158, 0.52173913043478, 0.30652173913043, 0.25
41159, 0.54347826086956, 0.30652173913043, 0.27272727272727
41160, 0.52173913043478, 0.2804347826087, 0.27272727272727
41161, 0.52173913043478, 0.30652173913043, 0.29545454545455
41162, 0.54347826086956, 0.30652173913043, 0.31818181818182
41163, 0.52173913043478, 0.2804347826087, 0.31818181818182
41164, 0.52173913043478, 0.30652173913043, 0.34090909090909
41165, 0.54347826086957, 0.30652173913043, 0.36363636363636
41166, 0.52173913043478, 0.2804347826087, 0.36363636363636
41167, 0.52173913043478, 0.30652173913043, 0.38636363636364
41168, 0.54347826086956, 0.30652173913043, 0.40909090909091
41169, 0.52173913043478, 0.2804347826087, 0.40909090909091
41170, 0.52173913043478, 0.30652173913043, 0.43181818181818
41171, 0.54347826086956, 0.30652173913043, 0.45454545454545
41172, 0.52173913043478, 0.2804347826087, 0.45454545454545
41173, 0.52173913043478, 0.30652173913043, 0.47727272727273
41174, 0.47826086956522, 0.30652173913043, 0.022727272727273
41175, 0.5, 0.30652173913043, 0.045454545454545
41176, 0.47826086956522, 0.2804347826087, 0.045454545454545
41177, 0.47826086956522, 0.30652173913043, 0.068181818181818
41178, 0.5, 0.30652173913043, 0.090909090909091
41179, 0.47826086956522, 0.2804347826087, 0.090909090909091
41180, 0.47826086956522, 0.30652173913043, 0.11363636363636
41181, 0.5, 0.30652173913043, 0.13636363636364
41182, 0.47826086956522, 0.2804347826087, 0.13636363636364
41183, 0.47826086956522, 0.30652173913043, 0.15909090909091
41184, 0.5, 0.30652173913043, 0.18181818181818
41185, 0.47826086956522, 0.2804347826087, 0.18181818181818
41186, 0.47826086956522, 0.30652173913043, 0.20454545454545
41187, 0.5, 0.30652173913043, 0.22727272727273
41188, 0.47826086956522, 0.2804347826087, 0.22727272727273
41189, 0.47826086956522, 0.30652173913043, 0.25
41190, 0.5, 0.30652173913043, 0.27272727272727
41191, 0.47826086956522, 0.2804347826087, 0.27272727272727
41192, 0.47826086956522, 0.30652173913043, 0.29545454545455
41193, 0.5, 0.30652173913043, 0.31818181818182
41194, 0.47826086956522, 0.2804347826087, 0.31818181818182
41195, 0.47826086956522, 0.30652173913043, 0.34090909090909
41196, 0.5, 0.30652173913043, 0.36363636363636
41197, 0.47826086956522, 0.2804347826087, 0.36363636363636
41198, 0.47826086956522, 0.30652173913043, 0.38636363636364
41199, 0.5, 0.30652173913043, 0.40909090909091
41200, 0.47826086956522, 0.2804347826087, 0.40909090909091
41201, 0.47826086956522, 0.30652173913043, 0.43181818181818
41202, 0.5, 0.30652173913043, 0.45454545454545
41203, 0.47826086956522, 0.2804347826087, 0.45454545454545
41204, 0.47826086956522, 0.30652173913043, 0.47727272727273
41205, 0.43478260869565, 0.30652173913043, 0.022727272727273
41206, 0.45652173913043, 0.30652173913043, 0.045454545454545
41207, 0.43478260869565, 0.2804347826087, 0.045454545454545
41208, 0.43478260869565, 0.30652173913043, 0.068181818181818
41209, 0.45652173913043, 0.30652173913043, 0.090909090909091
41210, 0.43478260869565, 0.2804347826087, 0.090909090909091
41211, 0.43478260869565, 0.30652173913043, 0.11363636363636
41212, 0.45652173913043, 0.30652173913043, 0.13636363636364
41213, 0.43478260869565, 0.2804347826087, 0.13636363636364
41214, 0.43478260869565, 0.30652173913043, 0.15909090909091
41215, 0.45652173913043, 0.30652173913043, 0.18181818181818
41216, 0.43478260869565, 0.2804347826087, 0.18181818181818
41217, 0.43478260869565, 0.30652173913043, 0.20454545454545
41218, 0.45652173913043, 0.30652173913043, 0.22727272727273
41219, 0.43478260869565, 0.2804347826087, 0.22727272727273
41220, 0.43478260869565, 0.30652173913043, 0.25
41221, 0.45652173913043, 0.30652173913043, 0.27272727272727
41222, 0.43478260869565, 0.2804347826087, 0.27272727272727
41223, 0.43478260869565, 0.30652173913043, 0.29545454545455
41224, 0.45652173913043, 0.30652173913043, 0.31818181818182
41225, 0.43478260869565, 0.2804347826087, 0.31818181818182
41226, 0.43478260869565, 0.30652173913043, 0.34090909090909
41227, 0.45652173913043, 0.30652173913043, 0.36363636363636
41228, 0.43478260869565, 0.2804347826087, 0.36363636363636
41229, 0.43478260869565, 0.30652173913043, 0.38636363636364
41230, 0.45652173913043, 0.30652173913043, 0.40909090909091
41231, 0.43478260869565, 0.2804347826087, 0.40909090909091
41232, 0.43478260869565, 0.30652173913043, 0.43181818181818
41233, 0.45652173913043, 0.30652173913043, 0.45454545454545
41234, 0.43478260869565, 0.2804347826087, 0.45454545454545
41235, 0.43478260869565, 0.30652173913043, 0.47727272727273
41236, 0.39130434782609, 0.30652173913043, 0.022727272727273
41237, 0.41304347826087, 0.30652173913043, 0.045454545454545
41238, 0.39130434782609, 0.2804347826087, 0.045454545454545
41239, 0.39130434782609, 0.30652173913043, 0.068181818181818
41240, 0.41304347826087, 0.30652173913043, 0.090909090909091
41241, 0.39130434782609, 0.2804347826087, 0.090909090909091
41242, 0.39130434782609, 0.30652173913043, 0.11363636363636
41243, 0.41304347826087, 0.30652173913043, 0.13636363636364
41244, 0.39130434782609, 0.2804347826087, 0.13636363636364
41245, 0.39130434782609, 0.30652173913043, 0.15909090909091
41246, 0.41304347826087, 0.30652173913043, 0.18181818181818
41247, 0.39130434782609, 0.2804347826087, 0.18181818181818
41248, 0.39130434782609, 0.30652173913043, 0.20454545454545
41249, 0.41304347826087, 0.30652173913043, 0.22727272727273
41250, 0.39130434782609, 0.2804347826087, 0.22727272727273
41251, 0.39130434782609, 0.30652173913043, 0.25
41252, 0.41304347826087, 0.30652173913043, 0.27272727272727
41253, 0.39130434782609, 0.2804347826087, 0.27272727272727
41254, 0.39130434782609, 0.30652173913043, 0.29545454545455
41255, 0.41304347826087, 0.30652173913043, 0.31818181818182
41256, 0.39130434782609, 0.2804347826087, 0.31818181818182
41257, 0.39130434782609, 0.30652173913043, 0.34090909090909
41258, 0.41304347826087, 0.30652173913043, 0.36363636363636
41259, 0.39130434782609, 0.2804347826087, 0.36363636363636
41260, 0.39130434782609, 0.30652173913043, 0.38636363636364
41261, 0.41304347826087, 0.30652173913043, 0.40909090909091
41262, 0.39130434782609, 0.2804347826087, 0.40909090909091
41263, 0.39130434782609, 0.30652173913043, 0.43181818181818
41264, 0.41304347826087, 0.30652173913043, 0.45454545454545
41265, 0.39130434782609, 0.2804347826087, 0.45454545454545
41266, 0.39130434782609, 0.30652173913043, 0.47727272727273
41267, 0.34782608695652, 0.30652173913043, 0.022727272727273
41268, 0.3695652173913, 0.30652173913043, 0.045454545454545
41269, 0.34782608695652, 0.2804347826087, 0.045454545454545
41270, 0.34782608695652, 0.30652173913043, 0.068181818181818
41271, 0.3695652173913, 0.30652173913043, 0.090909090909091
41272, 0.34782608695652, 0.2804347826087, 0.090909090909091
41273, 0.34782608695652, 0.30652173913043, 0.11363636363636
41274, 0.3695652173913, 0.30652173913043, 0.13636363636364
41275, 0.34782608695652, 0.2804347826087, 0.13636363636364
41276, 0.34782608695652, 0.30652173913043, 0.15909090909091
41277, 0.3695652173913, 0.30652173913043, 0.18181818181818
41278, 0.34782608695652, 0.2804347826087, 0.18181818181818
41279, 0.34782608695652, 0.30652173913043, 0.20454545454545
41280, 0.3695652173913, 0.30652173913043, 0.22727272727273
41281, 0.34782608695652, 0.2804347826087, 0.22727272727273
41282, 0.34782608695652, 0.30652173913043, 0.25
41283, 0.3695652173913, 0.30652173913043, 0.27272727272727
41284, 0.34782608695652, 0.2804347826087, 0.27272727272727
41285, 0.34782608695652, 0.30652173913043, 0.29545454545455
41286, 0.3695652173913, 0.30652173913043, 0.31818181818182
41287, 0.34782608695652, 0.2804347826087, 0.31818181818182
41288, 0.34782608695652, 0.30652173913043, 0.34090909090909
41289, 0.3695652173913, 0.30652173913043, 0.36363636363636
41290, 0.34782608695652, 0.2804347826087, 0.36363636363636
41291, 0.34782608695652, 0.30652173913043, 0.38636363636364
41292, 0.3695652173913, 0.30652173913043, 0.40909090909091
41293, 0.34782608695652, 0.2804347826087, 0.40909090909091
41294, 0.34782608695652, 0.30652173913043, 0.43181818181818
41295, 0.3695652173913, 0.30652173913043, 0.45454545454545
41296, 0.34782608695652, 0.2804347826087, 0.45454545454545
41297, 0.34782608695652, 0.30652173913043, 0.47727272727273
41298, 0.30434782608696, 0.30652173913043, 0.022727272727273
41299, 0.32608695652174, 0.30652173913043, 0.045454545454545
41300, 0.30434782608696, 0.2804347826087, 0.045454545454545
41301, 0.30434782608696, 0.30652173913043, 0.068181818181818
41302, 0.32608695652174, 0.30652173913043, 0.090909090909091
41303, 0.30434782608696, 0.2804347826087, 0.090909090909091
41304, 0.30434782608696, 0.30652173913043, 0.11363636363636
41305, 0.32608695652174, 0.30652173913043, 0.13636363636364
41306, 0.30434782608696, 0.2804347826087, 0.13636363636364
41307, 0.30434782608696, 0.30652173913043, 0.15909090909091
41308, 0.32608695652174, 0.30652173913043, 0.18181818181818
41309, 0.30434782608696, 0.2804347826087, 0.18181818181818
41310, 0.30434782608696, 0.30652173913043, 0.20454545454545
41311, 0.32608695652174, 0.30652173913043, 0.22727272727273
41312, 0.30434782608696, 0.2804347826087, 0.22727272727273
41313, 0.30434782608696, 0.30652173913043, 0.25
41314, 0.32608695652174, 0.30652173913043, 0.27272727272727
41315, 0.30434782608696, 0.2804347826087, 0.27272727272727
41316, 0.30434782608696, 0.30652173913043, 0.29545454545455
41317, 0.32608695652174, 0.30652173913043, 0.31818181818182
41318, 0.30434782608696, 0.2804347826087, 0.31818181818182
41319, 0.30434782608696, 0.30652173913043, 0.34090909090909
41320, 0.32608695652174, 0.30652173913043, 0.36363636363636
41321, 0.30434782608696, 0.2804347826087, 0.36363636363636
41322, 0.30434782608696, 0.30652173913043, 0.38636363636364
41323, 0.32608695652174, 0.30652173913043, 0.40909090909091
41324, 0.30434782608696, 0.2804347826087, 0.40909090909091
41325, 0.30434782608696, 0.30652173913043, 0.43181818181818
41326, 0.32608695652174, 0.30652173913043, 0.45454545454545
41327, 0.30434782608696, 0.2804347826087, 0.45454545454545
41328, 0.30434782608696, 0.30652173913043, 0.47727272727273
41329, 0.26086956521739, 0.30652173913043, 0.022727272727273
41330, 0.28260869565217, 0.30652173913043, 0.045454545454545
41331, 0.26086956521739, 0.2804347826087, 0.045454545454545
41332, 0.26086956521739, 0.30652173913043, 0.068181818181818
41333, 0.28260869565217, 0.30652173913043, 0.090909090909091
41334, 0.26086956521739, 0.2804347826087, 0.090909090909091
41335, 0.26086956521739, 0.30652173913043, 0.11363636363636
41336, 0.28260869565217, 0.30652173913043, 0.13636363636364
41337, 0.26086956521739, 0.2804347826087, 0.13636363636364
41338, 0.26086956521739, 0.30652173913043, 0.15909090909091
41339, 0.28260869565217, 0.30652173913043, 0.18181818181818
41340, 0.26086956521739, 0.2804347826087, 0.18181818181818
41341, 0.26086956521739, 0.30652173913043, 0.20454545454545
41342, 0.28260869565217, 0.30652173913043, 0.22727272727273
41343, 0.26086956521739, 0.2804347826087, 0.22727272727273
41344, 0.26086956521739, 0.30652173913043, 0.25
41345, 0.28260869565217, 0.30652173913043, 0.27272727272727
41346, 0.26086956521739, 0.2804347826087, 0.27272727272727
41347, 0.26086956521739, 0.30652173913043, 0.29545454545455
41348, 0.28260869565217, 0.30652173913043, 0.31818181818182
41349, 0.26086956521739, 0.2804347826087, 0.31818181818182
41350, 0.26086956521739, 0.30652173913043, 0.34090909090909
41351, 0.28260869565217, 0.30652173913043, 0.36363636363636
41352, 0.26086956521739, 0.2804347826087, 0.36363636363636
41353, 0.26086956521739, 0.30652173913043, 0.38636363636364
41354, 0.28260869565217, 0.30652173913043, 0.40909090909091
41355, 0.26086956521739, 0.2804347826087, 0.40909090909091
41356, 0.26086956521739, 0.30652173913043, 0.43181818181818
41357, 0.28260869565217, 0.30652173913043, 0.45454545454545
41358, 0.26086956521739, 0.2804347826087, 0.45454545454545
41359, 0.26086956521739, 0.30652173913043, 0.47727272727273
41360, 0.21739130434783, 0.30652173913043, 0.022727272727273
41361, 0.23913043478261, 0.30652173913043, 0.045454545454545
41362, 0.21739130434783, 0.2804347826087, 0.045454545454545
41363, 0.21739130434783, 0.30652173913043, 0.068181818181818
41364, 0.23913043478261, 0.30652173913043, 0.090909090909091
41365, 0.21739130434783, 0.2804347826087, 0.090909090909091
41366, 0.21739130434783, 0.30652173913043, 0.11363636363636
41367, 0.23913043478261, 0.30652173913043, 0.13636363636364
41368, 0.21739130434783, 0.2804347826087, 0.13636363636364
41369, 0.21739130434783, 0.30652173913043, 0.15909090909091
41370, 0.23913043478261, 0.30652173913043, 0.18181818181818
41371, 0.21739130434783, 0.2804347826087, 0.18181818181818
41372, 0.21739130434783, 0.30652173913043, 0.20454545454545
41373, 0.23913043478261, 0.30652173913043, 0.22727272727273
41374, 0.21739130434783, 0.2804347826087, 0.22727272727273
41375, 0.21739130434783, 0.30652173913043, 0.25
41376, 0.23913043478261, 0.30652173913043, 0.27272727272727
41377, 0.21739130434783, 0.2804347826087, 0.27272727272727
41378, 0.21739130434783, 0.30652173913043, 0.29545454545455
41379, 0.23913043478261, 0.30652173913043, 0.31818181818182
41380, 0.21739130434783, 0.2804347826087, 0.31818181818182
41381, 0.21739130434783, 0.30652173913043, 0.34090909090909
41382, 0.23913043478261, 0.30652173913043, 0.36363636363636
41383, 0.21739130434783, 0.2804347826087, 0.36363636363636
41384, 0.21739130434783, 0.30652173913043, 0.38636363636364
41385, 0.23913043478261, 0.30652173913043, 0.40909090909091
41386, 0.21739130434783, 0.2804347826087, 0.40909090909091
41387, 0.21739130434783, 0.30652173913043, 0.43181818181818
41388, 0.23913043478261, 0.30652173913043, 0.45454545454545
41389, 0.21739130434783, 0.2804347826087, 0.45454545454545
41390, 0.21739130434783, 0.30652173913043, 0.47727272727273
41391, 0.17391304347826, 0.30652173913043, 0.022727272727273
41392, 0.19565217391304, 0.30652173913043, 0.045454545454545
41393, 0.17391304347826, 0.2804347826087, 0.045454545454545
41394, 0.17391304347826, 0.30652173913043, 0.068181818181818
41395, 0.19565217391304, 0.30652173913043, 0.090909090909091
41396, 0.17391304347826, 0.2804347826087, 0.090909090909091
41397, 0.17391304347826, 0.30652173913043, 0.11363636363636
41398, 0.19565217391304, 0.30652173913043, 0.13636363636364
41399, 0.17391304347826, 0.2804347826087, 0.13636363636364
41400, 0.17391304347826, 0.30652173913043, 0.15909090909091
41401, 0.19565217391304, 0.30652173913043, 0.18181818181818
41402, 0.17391304347826, 0.2804347826087, 0.18181818181818
41403, 0.17391304347826, 0.30652173913043, 0.20454545454545
41404, 0.19565217391304, 0.30652173913043, 0.22727272727273
41405, 0.17391304347826, 0.2804347826087, 0.22727272727273
41406, 0.17391304347826, 0.30652173913043, 0.25
41407, 0.19565217391304, 0.30652173913043, 0.27272727272727
41408, 0.17391304347826, 0.2804347826087, 0.27272727272727
41409, 0.17391304347826, 0.30652173913043, 0.29545454545455
41410, 0.19565217391304, 0.30652173913043, 0.31818181818182
41411, 0.17391304347826, 0.2804347826087, 0.31818181818182
41412, 0.17391304347826, 0.30652173913043, 0.34090909090909
41413, 0.19565217391304, 0.30652173913043, 0.36363636363636
41414, 0.17391304347826, 0.2804347826087, 0.36363636363636
41415, 0.17391304347826, 0.30652173913043, 0.38636363636364
41416, 0.19565217391304, 0.30652173913043, 0.40909090909091
41417, 0.17391304347826, 0.2804347826087, 0.40909090909091
41418, 0.17391304347826, 0.30652173913043, 0.43181818181818
41419, 0.19565217391304, 0.30652173913043, 0.45454545454545
41420, 0.17391304347826, 0.2804347826087, 0.45454545454545
41421, 0.17391304347826, 0.30652173913043, 0.47727272727273
41422, 0.1304347826087, 0.30652173913043, 0.022727272727273
41423, 0.15217391304348, 0.30652173913043, 0.045454545454545
41424, 0.1304347826087, 0.2804347826087, 0.045454545454545
41425, 0.1304347826087, 0.30652173913043, 0.068181818181818
41426, 0.15217391304348, 0.30652173913043, 0.090909090909091
41427, 0.1304347826087, 0.2804347826087, 0.090909090909091
41428, 0.1304347826087, 0.30652173913043, 0.11363636363636
41429, 0.15217391304348, 0.30652173913043, 0.13636363636364
41430, 0.1304347826087, 0.2804347826087, 0.13636363636364
41431, 0.1304347826087, 0.30652173913043, 0.15909090909091
41432, 0.15217391304348, 0.30652173913043, 0.18181818181818
41433, 0.1304347826087, 0.2804347826087, 0.18181818181818
41434, 0.1304347826087, 0.30652173913043, 0.20454545454545
41435, 0.15217391304348, 0.30652173913043, 0.22727272727273
41436, 0.1304347826087, 0.2804347826087, 0.22727272727273
41437, 0.1304347826087, 0.30652173913043, 0.25
41438, 0.15217391304348, 0.30652173913043, 0.27272727272727
41439, 0.1304347826087, 0.2804347826087, 0.27272727272727
41440, 0.1304347826087, 0.30652173913043, 0.29545454545455
41441, 0.15217391304348, 0.30652173913043, 0.31818181818182
41442, 0.1304347826087, 0.2804347826087, 0.31818181818182
41443, 0.1304347826087, 0.30652173913043, 0.34090909090909
41444, 0.15217391304348, 0.30652173913043, 0.36363636363636
41445, 0.1304347826087, 0.2804347826087, 0.36363636363636
41446, 0.1304347826087, 0.30652173913043, 0.38636363636364
41447, 0.15217391304348, 0.30652173913043, 0.40909090909091
41448, 0.1304347826087, 0.2804347826087, 0.40909090909091
41449, 0.1304347826087, 0.30652173913043, 0.43181818181818
41450, 0.15217391304348, 0.30652173913043, 0.45454545454545
41451, 0.1304347826087, 0.2804347826087, 0.45454545454545
41452, 0.1304347826087, 0.30652173913043, 0.47727272727273
41453, 0.08695652173913, 0.30652173913043, 0.022727272727273
41454, 0.10869565217391, 0.30652173913043, 0.045454545454545
41455, 0.08695652173913, 0.2804347826087, 0.045454545454545
41456, 0.08695652173913, 0.30652173913043, 0.068181818181818
41457, 0.10869565217391, 0.30652173913043, 0.090909090909091
41458, 0.08695652173913, 0.2804347826087, 0.090909090909091
41459, 0.08695652173913, 0.30652173913043, 0.11363636363636
41460, 0.10869565217391, 0.30652173913043, 0.13636363636364
41461, 0.08695652173913, 0.2804347826087, 0.13636363636364
41462, 0.08695652173913, 0.30652173913043, 0.15909090909091
41463, 0.10869565217391, 0.30652173913043, 0.18181818181818
