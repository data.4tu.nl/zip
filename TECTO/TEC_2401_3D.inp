41464, 0.08695652173913, 0.2804347826087, 0.18181818181818
41465, 0.08695652173913, 0.30652173913043, 0.20454545454545
41466, 0.10869565217391, 0.30652173913043, 0.22727272727273
41467, 0.08695652173913, 0.2804347826087, 0.22727272727273
41468, 0.08695652173913, 0.30652173913043, 0.25
41469, 0.10869565217391, 0.30652173913043, 0.27272727272727
41470, 0.08695652173913, 0.2804347826087, 0.27272727272727
41471, 0.08695652173913, 0.30652173913043, 0.29545454545455
41472, 0.10869565217391, 0.30652173913043, 0.31818181818182
41473, 0.08695652173913, 0.2804347826087, 0.31818181818182
41474, 0.08695652173913, 0.30652173913043, 0.34090909090909
41475, 0.10869565217391, 0.30652173913043, 0.36363636363636
41476, 0.08695652173913, 0.2804347826087, 0.36363636363636
41477, 0.08695652173913, 0.30652173913043, 0.38636363636364
41478, 0.10869565217391, 0.30652173913043, 0.40909090909091
41479, 0.08695652173913, 0.2804347826087, 0.40909090909091
41480, 0.08695652173913, 0.30652173913043, 0.43181818181818
41481, 0.10869565217391, 0.30652173913043, 0.45454545454545
41482, 0.08695652173913, 0.2804347826087, 0.45454545454545
41483, 0.08695652173913, 0.30652173913043, 0.47727272727273
41484, 0.043478260869565, 0.30652173913043, 0.022727272727273
41485, 0.065217391304348, 0.30652173913043, 0.045454545454545
41486, 0.043478260869565, 0.2804347826087, 0.045454545454545
41487, 0.043478260869565, 0.30652173913043, 0.068181818181818
41488, 0.065217391304348, 0.30652173913043, 0.090909090909091
41489, 0.043478260869565, 0.2804347826087, 0.090909090909091
41490, 0.043478260869565, 0.30652173913043, 0.11363636363636
41491, 0.065217391304348, 0.30652173913043, 0.13636363636364
41492, 0.043478260869565, 0.2804347826087, 0.13636363636364
41493, 0.043478260869565, 0.30652173913043, 0.15909090909091
41494, 0.065217391304348, 0.30652173913043, 0.18181818181818
41495, 0.043478260869565, 0.2804347826087, 0.18181818181818
41496, 0.043478260869565, 0.30652173913043, 0.20454545454545
41497, 0.065217391304348, 0.30652173913043, 0.22727272727273
41498, 0.043478260869565, 0.2804347826087, 0.22727272727273
41499, 0.043478260869565, 0.30652173913043, 0.25
41500, 0.065217391304348, 0.30652173913043, 0.27272727272727
41501, 0.043478260869565, 0.2804347826087, 0.27272727272727
41502, 0.043478260869565, 0.30652173913043, 0.29545454545455
41503, 0.065217391304348, 0.30652173913043, 0.31818181818182
41504, 0.043478260869565, 0.2804347826087, 0.31818181818182
41505, 0.043478260869565, 0.30652173913043, 0.34090909090909
41506, 0.065217391304348, 0.30652173913043, 0.36363636363636
41507, 0.043478260869565, 0.2804347826087, 0.36363636363636
41508, 0.043478260869565, 0.30652173913043, 0.38636363636364
41509, 0.065217391304348, 0.30652173913043, 0.40909090909091
41510, 0.043478260869565, 0.2804347826087, 0.40909090909091
41511, 0.043478260869565, 0.30652173913043, 0.43181818181818
41512, 0.065217391304348, 0.30652173913043, 0.45454545454545
41513, 0.043478260869565, 0.2804347826087, 0.45454545454545
41514, 0.043478260869565, 0.30652173913043, 0.47727272727273
41515, 0.021739130434783, 0.30652173913043, 0.045454545454545
41516, 0.021739130434783, 0.30652173913043, 0.090909090909091
41517, 0.021739130434783, 0.30652173913043, 0.13636363636364
41518, 0.021739130434783, 0.30652173913043, 0.18181818181818
41519, 0.021739130434783, 0.30652173913043, 0.22727272727273
41520, 0.021739130434783, 0.30652173913043, 0.27272727272727
41521, 0.021739130434783, 0.30652173913043, 0.31818181818182
41522, 0.021739130434783, 0.30652173913043, 0.36363636363636
41523, 0.021739130434783, 0.30652173913043, 0.40909090909091
41524, 0.021739130434783, 0.30652173913043, 0.45454545454545
41525, 0.95652173913043, 0.35869565217391, 0.022727272727273
41526, 0.97826086956522, 0.35869565217391, 0.045454545454545
41527, 0.95652173913043, 0.33260869565217, 0.045454545454545
41528, 0.95652173913043, 0.35869565217391, 0.068181818181818
41529, 0.97826086956522, 0.35869565217391, 0.090909090909091
41530, 0.95652173913044, 0.33260869565217, 0.090909090909091
41531, 0.95652173913044, 0.35869565217391, 0.11363636363636
41532, 0.97826086956522, 0.35869565217391, 0.13636363636364
41533, 0.95652173913044, 0.33260869565217, 0.13636363636364
41534, 0.95652173913044, 0.35869565217391, 0.15909090909091
41535, 0.97826086956522, 0.35869565217391, 0.18181818181818
41536, 0.95652173913044, 0.33260869565217, 0.18181818181818
41537, 0.95652173913044, 0.35869565217391, 0.20454545454545
41538, 0.97826086956522, 0.35869565217391, 0.22727272727273
41539, 0.95652173913044, 0.33260869565217, 0.22727272727273
41540, 0.95652173913044, 0.35869565217391, 0.25
41541, 0.97826086956522, 0.35869565217391, 0.27272727272727
41542, 0.95652173913044, 0.33260869565217, 0.27272727272727
41543, 0.95652173913044, 0.35869565217391, 0.29545454545455
41544, 0.97826086956522, 0.35869565217391, 0.31818181818182
41545, 0.95652173913044, 0.33260869565217, 0.31818181818182
41546, 0.95652173913043, 0.35869565217391, 0.34090909090909
41547, 0.97826086956522, 0.35869565217391, 0.36363636363636
41548, 0.95652173913043, 0.33260869565217, 0.36363636363636
41549, 0.95652173913043, 0.35869565217391, 0.38636363636364
41550, 0.97826086956522, 0.35869565217391, 0.40909090909091
41551, 0.95652173913043, 0.33260869565217, 0.40909090909091
41552, 0.95652173913043, 0.35869565217391, 0.43181818181818
41553, 0.97826086956522, 0.35869565217391, 0.45454545454545
41554, 0.95652173913044, 0.33260869565217, 0.45454545454545
41555, 0.95652173913043, 0.35869565217391, 0.47727272727273
41556, 0.91304347826087, 0.35869565217391, 0.022727272727273
41557, 0.93478260869565, 0.35869565217391, 0.045454545454545
41558, 0.91304347826087, 0.33260869565217, 0.045454545454545
41559, 0.91304347826087, 0.35869565217391, 0.068181818181818
41560, 0.93478260869565, 0.35869565217391, 0.090909090909091
41561, 0.91304347826087, 0.33260869565217, 0.090909090909091
41562, 0.91304347826087, 0.35869565217391, 0.11363636363636
41563, 0.93478260869565, 0.35869565217391, 0.13636363636364
41564, 0.91304347826087, 0.33260869565217, 0.13636363636364
41565, 0.91304347826087, 0.35869565217391, 0.15909090909091
41566, 0.93478260869565, 0.35869565217391, 0.18181818181818
41567, 0.91304347826087, 0.33260869565217, 0.18181818181818
41568, 0.91304347826087, 0.35869565217391, 0.20454545454545
41569, 0.93478260869565, 0.35869565217391, 0.22727272727273
41570, 0.91304347826087, 0.33260869565217, 0.22727272727273
41571, 0.91304347826087, 0.35869565217391, 0.25
41572, 0.93478260869565, 0.35869565217391, 0.27272727272727
41573, 0.91304347826087, 0.33260869565217, 0.27272727272727
41574, 0.91304347826087, 0.35869565217391, 0.29545454545455
41575, 0.93478260869565, 0.35869565217391, 0.31818181818182
41576, 0.91304347826087, 0.33260869565217, 0.31818181818182
41577, 0.91304347826087, 0.35869565217391, 0.34090909090909
41578, 0.93478260869565, 0.35869565217391, 0.36363636363636
41579, 0.91304347826087, 0.33260869565217, 0.36363636363636
41580, 0.91304347826087, 0.35869565217391, 0.38636363636364
41581, 0.93478260869565, 0.35869565217391, 0.40909090909091
41582, 0.91304347826087, 0.33260869565217, 0.40909090909091
41583, 0.91304347826087, 0.35869565217391, 0.43181818181818
41584, 0.93478260869565, 0.35869565217391, 0.45454545454545
41585, 0.91304347826087, 0.33260869565217, 0.45454545454545
41586, 0.91304347826087, 0.35869565217391, 0.47727272727273
41587, 0.8695652173913, 0.35869565217391, 0.022727272727273
41588, 0.89130434782609, 0.35869565217391, 0.045454545454545
41589, 0.8695652173913, 0.33260869565217, 0.045454545454545
41590, 0.8695652173913, 0.35869565217391, 0.068181818181818
41591, 0.89130434782609, 0.35869565217391, 0.090909090909091
41592, 0.8695652173913, 0.33260869565217, 0.090909090909091
41593, 0.8695652173913, 0.35869565217391, 0.11363636363636
41594, 0.89130434782609, 0.35869565217391, 0.13636363636364
41595, 0.8695652173913, 0.33260869565217, 0.13636363636364
41596, 0.8695652173913, 0.35869565217391, 0.15909090909091
41597, 0.89130434782609, 0.35869565217391, 0.18181818181818
41598, 0.8695652173913, 0.33260869565217, 0.18181818181818
41599, 0.8695652173913, 0.35869565217391, 0.20454545454545
41600, 0.89130434782609, 0.35869565217391, 0.22727272727273
41601, 0.8695652173913, 0.33260869565217, 0.22727272727273
41602, 0.8695652173913, 0.35869565217391, 0.25
41603, 0.89130434782609, 0.35869565217391, 0.27272727272727
41604, 0.8695652173913, 0.33260869565217, 0.27272727272727
41605, 0.8695652173913, 0.35869565217391, 0.29545454545455
41606, 0.89130434782609, 0.35869565217391, 0.31818181818182
41607, 0.8695652173913, 0.33260869565217, 0.31818181818182
41608, 0.8695652173913, 0.35869565217391, 0.34090909090909
41609, 0.89130434782609, 0.35869565217391, 0.36363636363636
41610, 0.8695652173913, 0.33260869565217, 0.36363636363636
41611, 0.8695652173913, 0.35869565217391, 0.38636363636364
41612, 0.89130434782609, 0.35869565217391, 0.40909090909091
41613, 0.8695652173913, 0.33260869565217, 0.40909090909091
41614, 0.8695652173913, 0.35869565217391, 0.43181818181818
41615, 0.89130434782609, 0.35869565217391, 0.45454545454545
41616, 0.8695652173913, 0.33260869565217, 0.45454545454545
41617, 0.8695652173913, 0.35869565217391, 0.47727272727273
41618, 0.82608695652174, 0.35869565217391, 0.022727272727273
41619, 0.84782608695652, 0.35869565217391, 0.045454545454545
41620, 0.82608695652174, 0.33260869565217, 0.045454545454545
41621, 0.82608695652174, 0.35869565217391, 0.068181818181818
41622, 0.84782608695652, 0.35869565217391, 0.090909090909091
41623, 0.82608695652174, 0.33260869565217, 0.090909090909091
41624, 0.82608695652174, 0.35869565217391, 0.11363636363636
41625, 0.84782608695652, 0.35869565217391, 0.13636363636364
41626, 0.82608695652174, 0.33260869565217, 0.13636363636364
41627, 0.82608695652174, 0.35869565217391, 0.15909090909091
41628, 0.84782608695652, 0.35869565217391, 0.18181818181818
41629, 0.82608695652174, 0.33260869565217, 0.18181818181818
41630, 0.82608695652174, 0.35869565217391, 0.20454545454545
41631, 0.84782608695652, 0.35869565217391, 0.22727272727273
41632, 0.82608695652174, 0.33260869565217, 0.22727272727273
41633, 0.82608695652174, 0.35869565217391, 0.25
41634, 0.84782608695652, 0.35869565217391, 0.27272727272727
41635, 0.82608695652174, 0.33260869565217, 0.27272727272727
41636, 0.82608695652174, 0.35869565217391, 0.29545454545455
41637, 0.84782608695652, 0.35869565217391, 0.31818181818182
41638, 0.82608695652174, 0.33260869565217, 0.31818181818182
41639, 0.82608695652174, 0.35869565217391, 0.34090909090909
41640, 0.84782608695652, 0.35869565217391, 0.36363636363636
41641, 0.82608695652174, 0.33260869565217, 0.36363636363636
41642, 0.82608695652174, 0.35869565217391, 0.38636363636364
41643, 0.84782608695652, 0.35869565217391, 0.40909090909091
41644, 0.82608695652174, 0.33260869565217, 0.40909090909091
41645, 0.82608695652174, 0.35869565217391, 0.43181818181818
41646, 0.84782608695652, 0.35869565217391, 0.45454545454545
41647, 0.82608695652174, 0.33260869565217, 0.45454545454545
41648, 0.82608695652174, 0.35869565217391, 0.47727272727273
41649, 0.78260869565217, 0.35869565217391, 0.022727272727273
41650, 0.80434782608696, 0.35869565217391, 0.045454545454545
41651, 0.78260869565217, 0.33260869565217, 0.045454545454545
41652, 0.78260869565217, 0.35869565217391, 0.068181818181818
41653, 0.80434782608696, 0.35869565217391, 0.090909090909091
41654, 0.78260869565217, 0.33260869565217, 0.090909090909091
41655, 0.78260869565217, 0.35869565217391, 0.11363636363636
41656, 0.80434782608696, 0.35869565217391, 0.13636363636364
41657, 0.78260869565217, 0.33260869565217, 0.13636363636364
41658, 0.78260869565217, 0.35869565217391, 0.15909090909091
41659, 0.80434782608696, 0.35869565217391, 0.18181818181818
41660, 0.78260869565217, 0.33260869565217, 0.18181818181818
41661, 0.78260869565217, 0.35869565217391, 0.20454545454545
41662, 0.80434782608696, 0.35869565217391, 0.22727272727273
41663, 0.78260869565217, 0.33260869565217, 0.22727272727273
41664, 0.78260869565217, 0.35869565217391, 0.25
41665, 0.80434782608696, 0.35869565217391, 0.27272727272727
41666, 0.78260869565217, 0.33260869565217, 0.27272727272727
41667, 0.78260869565217, 0.35869565217391, 0.29545454545455
41668, 0.80434782608696, 0.35869565217391, 0.31818181818182
41669, 0.78260869565217, 0.33260869565217, 0.31818181818182
41670, 0.78260869565217, 0.35869565217391, 0.34090909090909
41671, 0.80434782608696, 0.35869565217391, 0.36363636363636
41672, 0.78260869565217, 0.33260869565217, 0.36363636363636
41673, 0.78260869565217, 0.35869565217391, 0.38636363636364
41674, 0.80434782608696, 0.35869565217391, 0.40909090909091
41675, 0.78260869565217, 0.33260869565217, 0.40909090909091
41676, 0.78260869565217, 0.35869565217391, 0.43181818181818
41677, 0.80434782608696, 0.35869565217391, 0.45454545454545
41678, 0.78260869565217, 0.33260869565217, 0.45454545454545
41679, 0.78260869565217, 0.35869565217391, 0.47727272727273
41680, 0.73913043478261, 0.35869565217391, 0.022727272727273
41681, 0.76086956521739, 0.35869565217391, 0.045454545454545
41682, 0.73913043478261, 0.33260869565217, 0.045454545454545
41683, 0.73913043478261, 0.35869565217391, 0.068181818181818
41684, 0.76086956521739, 0.35869565217391, 0.090909090909091
41685, 0.73913043478261, 0.33260869565217, 0.090909090909091
41686, 0.73913043478261, 0.35869565217391, 0.11363636363636
41687, 0.76086956521739, 0.35869565217391, 0.13636363636364
41688, 0.73913043478261, 0.33260869565217, 0.13636363636364
41689, 0.73913043478261, 0.35869565217391, 0.15909090909091
41690, 0.76086956521739, 0.35869565217391, 0.18181818181818
41691, 0.73913043478261, 0.33260869565217, 0.18181818181818
41692, 0.73913043478261, 0.35869565217391, 0.20454545454545
41693, 0.76086956521739, 0.35869565217391, 0.22727272727273
41694, 0.73913043478261, 0.33260869565217, 0.22727272727273
41695, 0.73913043478261, 0.35869565217391, 0.25
41696, 0.76086956521739, 0.35869565217391, 0.27272727272727
41697, 0.73913043478261, 0.33260869565217, 0.27272727272727
41698, 0.73913043478261, 0.35869565217391, 0.29545454545455
41699, 0.76086956521739, 0.35869565217391, 0.31818181818182
41700, 0.73913043478261, 0.33260869565217, 0.31818181818182
41701, 0.73913043478261, 0.35869565217391, 0.34090909090909
41702, 0.76086956521739, 0.35869565217391, 0.36363636363636
41703, 0.73913043478261, 0.33260869565217, 0.36363636363636
41704, 0.73913043478261, 0.35869565217391, 0.38636363636364
41705, 0.76086956521739, 0.35869565217391, 0.40909090909091
41706, 0.73913043478261, 0.33260869565217, 0.40909090909091
41707, 0.73913043478261, 0.35869565217391, 0.43181818181818
41708, 0.76086956521739, 0.35869565217391, 0.45454545454545
41709, 0.73913043478261, 0.33260869565217, 0.45454545454545
41710, 0.73913043478261, 0.35869565217391, 0.47727272727273
41711, 0.69565217391304, 0.35869565217391, 0.022727272727273
41712, 0.71739130434783, 0.35869565217391, 0.045454545454545
41713, 0.69565217391304, 0.33260869565217, 0.045454545454545
41714, 0.69565217391304, 0.35869565217391, 0.068181818181818
41715, 0.71739130434783, 0.35869565217391, 0.090909090909091
41716, 0.69565217391304, 0.33260869565217, 0.090909090909091
41717, 0.69565217391304, 0.35869565217391, 0.11363636363636
41718, 0.71739130434783, 0.35869565217391, 0.13636363636364
41719, 0.69565217391304, 0.33260869565217, 0.13636363636364
41720, 0.69565217391304, 0.35869565217391, 0.15909090909091
41721, 0.71739130434783, 0.35869565217391, 0.18181818181818
41722, 0.69565217391304, 0.33260869565217, 0.18181818181818
41723, 0.69565217391304, 0.35869565217391, 0.20454545454545
41724, 0.71739130434783, 0.35869565217391, 0.22727272727273
41725, 0.69565217391304, 0.33260869565217, 0.22727272727273
41726, 0.69565217391304, 0.35869565217391, 0.25
41727, 0.71739130434783, 0.35869565217391, 0.27272727272727
41728, 0.69565217391304, 0.33260869565217, 0.27272727272727
41729, 0.69565217391304, 0.35869565217391, 0.29545454545455
41730, 0.71739130434783, 0.35869565217391, 0.31818181818182
41731, 0.69565217391304, 0.33260869565217, 0.31818181818182
41732, 0.69565217391304, 0.35869565217391, 0.34090909090909
41733, 0.71739130434783, 0.35869565217391, 0.36363636363636
41734, 0.69565217391304, 0.33260869565217, 0.36363636363636
41735, 0.69565217391304, 0.35869565217391, 0.38636363636364
41736, 0.71739130434783, 0.35869565217391, 0.40909090909091
41737, 0.69565217391304, 0.33260869565217, 0.40909090909091
41738, 0.69565217391304, 0.35869565217391, 0.43181818181818
41739, 0.71739130434783, 0.35869565217391, 0.45454545454545
41740, 0.69565217391304, 0.33260869565217, 0.45454545454545
41741, 0.69565217391304, 0.35869565217391, 0.47727272727273
41742, 0.65217391304348, 0.35869565217391, 0.022727272727273
41743, 0.67391304347826, 0.35869565217391, 0.045454545454545
41744, 0.65217391304348, 0.33260869565217, 0.045454545454545
41745, 0.65217391304348, 0.35869565217391, 0.068181818181818
41746, 0.67391304347826, 0.35869565217391, 0.090909090909091
41747, 0.65217391304348, 0.33260869565217, 0.090909090909091
41748, 0.65217391304348, 0.35869565217391, 0.11363636363636
41749, 0.67391304347826, 0.35869565217391, 0.13636363636364
41750, 0.65217391304348, 0.33260869565217, 0.13636363636364
41751, 0.65217391304348, 0.35869565217391, 0.15909090909091
41752, 0.67391304347826, 0.35869565217391, 0.18181818181818
41753, 0.65217391304348, 0.33260869565217, 0.18181818181818
41754, 0.65217391304348, 0.35869565217391, 0.20454545454545
41755, 0.67391304347826, 0.35869565217391, 0.22727272727273
41756, 0.65217391304348, 0.33260869565217, 0.22727272727273
41757, 0.65217391304348, 0.35869565217391, 0.25
41758, 0.67391304347826, 0.35869565217391, 0.27272727272727
41759, 0.65217391304348, 0.33260869565217, 0.27272727272727
41760, 0.65217391304348, 0.35869565217391, 0.29545454545455
41761, 0.67391304347826, 0.35869565217391, 0.31818181818182
41762, 0.65217391304348, 0.33260869565217, 0.31818181818182
41763, 0.65217391304348, 0.35869565217391, 0.34090909090909
41764, 0.67391304347826, 0.35869565217391, 0.36363636363636
41765, 0.65217391304348, 0.33260869565217, 0.36363636363636
41766, 0.65217391304348, 0.35869565217391, 0.38636363636364
41767, 0.67391304347826, 0.35869565217391, 0.40909090909091
41768, 0.65217391304348, 0.33260869565217, 0.40909090909091
41769, 0.65217391304348, 0.35869565217391, 0.43181818181818
41770, 0.67391304347826, 0.35869565217391, 0.45454545454545
41771, 0.65217391304348, 0.33260869565217, 0.45454545454545
41772, 0.65217391304348, 0.35869565217391, 0.47727272727273
41773, 0.60869565217391, 0.35869565217391, 0.022727272727273
41774, 0.6304347826087, 0.35869565217391, 0.045454545454545
41775, 0.60869565217391, 0.33260869565217, 0.045454545454545
41776, 0.60869565217391, 0.35869565217391, 0.068181818181818
41777, 0.6304347826087, 0.35869565217391, 0.090909090909091
41778, 0.60869565217391, 0.33260869565217, 0.090909090909091
41779, 0.60869565217391, 0.35869565217391, 0.11363636363636
41780, 0.6304347826087, 0.35869565217391, 0.13636363636364
41781, 0.60869565217391, 0.33260869565217, 0.13636363636364
41782, 0.60869565217391, 0.35869565217391, 0.15909090909091
41783, 0.6304347826087, 0.35869565217391, 0.18181818181818
41784, 0.60869565217391, 0.33260869565217, 0.18181818181818
41785, 0.60869565217391, 0.35869565217391, 0.20454545454545
41786, 0.6304347826087, 0.35869565217391, 0.22727272727273
41787, 0.60869565217391, 0.33260869565217, 0.22727272727273
41788, 0.60869565217391, 0.35869565217391, 0.25
41789, 0.6304347826087, 0.35869565217391, 0.27272727272727
41790, 0.60869565217391, 0.33260869565217, 0.27272727272727
41791, 0.60869565217391, 0.35869565217391, 0.29545454545455
41792, 0.6304347826087, 0.35869565217391, 0.31818181818182
41793, 0.60869565217391, 0.33260869565217, 0.31818181818182
41794, 0.60869565217391, 0.35869565217391, 0.34090909090909
41795, 0.6304347826087, 0.35869565217391, 0.36363636363636
41796, 0.60869565217391, 0.33260869565217, 0.36363636363636
41797, 0.60869565217391, 0.35869565217391, 0.38636363636364
41798, 0.6304347826087, 0.35869565217391, 0.40909090909091
41799, 0.60869565217391, 0.33260869565217, 0.40909090909091
41800, 0.60869565217391, 0.35869565217391, 0.43181818181818
41801, 0.6304347826087, 0.35869565217391, 0.45454545454545
41802, 0.60869565217391, 0.33260869565217, 0.45454545454545
41803, 0.60869565217391, 0.35869565217391, 0.47727272727273
41804, 0.56521739130435, 0.35869565217391, 0.022727272727273
41805, 0.58695652173913, 0.35869565217391, 0.045454545454545
41806, 0.56521739130435, 0.33260869565217, 0.045454545454545
41807, 0.56521739130435, 0.35869565217391, 0.068181818181818
41808, 0.58695652173913, 0.35869565217391, 0.090909090909091
41809, 0.56521739130435, 0.33260869565217, 0.090909090909091
41810, 0.56521739130435, 0.35869565217391, 0.11363636363636
41811, 0.58695652173913, 0.35869565217391, 0.13636363636364
41812, 0.56521739130435, 0.33260869565217, 0.13636363636364
41813, 0.56521739130435, 0.35869565217391, 0.15909090909091
41814, 0.58695652173913, 0.35869565217391, 0.18181818181818
41815, 0.56521739130435, 0.33260869565217, 0.18181818181818
41816, 0.56521739130435, 0.35869565217391, 0.20454545454545
41817, 0.58695652173913, 0.35869565217391, 0.22727272727273
41818, 0.56521739130435, 0.33260869565217, 0.22727272727273
41819, 0.56521739130435, 0.35869565217391, 0.25
41820, 0.58695652173913, 0.35869565217391, 0.27272727272727
41821, 0.56521739130435, 0.33260869565217, 0.27272727272727
41822, 0.56521739130435, 0.35869565217391, 0.29545454545455
41823, 0.58695652173913, 0.35869565217391, 0.31818181818182
41824, 0.56521739130435, 0.33260869565217, 0.31818181818182
41825, 0.56521739130435, 0.35869565217391, 0.34090909090909
41826, 0.58695652173913, 0.35869565217391, 0.36363636363636
41827, 0.56521739130435, 0.33260869565217, 0.36363636363636
41828, 0.56521739130435, 0.35869565217391, 0.38636363636364
41829, 0.58695652173913, 0.35869565217391, 0.40909090909091
41830, 0.56521739130435, 0.33260869565217, 0.40909090909091
41831, 0.56521739130435, 0.35869565217391, 0.43181818181818
41832, 0.58695652173913, 0.35869565217391, 0.45454545454545
41833, 0.56521739130435, 0.33260869565217, 0.45454545454545
41834, 0.56521739130435, 0.35869565217391, 0.47727272727273
41835, 0.52173913043478, 0.35869565217391, 0.022727272727273
41836, 0.54347826086956, 0.35869565217391, 0.045454545454545
41837, 0.52173913043478, 0.33260869565217, 0.045454545454545
41838, 0.52173913043478, 0.35869565217391, 0.068181818181818
41839, 0.54347826086956, 0.35869565217391, 0.090909090909091
41840, 0.52173913043478, 0.33260869565217, 0.090909090909091
41841, 0.52173913043478, 0.35869565217391, 0.11363636363636
41842, 0.54347826086956, 0.35869565217391, 0.13636363636364
41843, 0.52173913043478, 0.33260869565217, 0.13636363636364
41844, 0.52173913043478, 0.35869565217391, 0.15909090909091
41845, 0.54347826086956, 0.35869565217391, 0.18181818181818
41846, 0.52173913043478, 0.33260869565217, 0.18181818181818
41847, 0.52173913043478, 0.35869565217391, 0.20454545454545
41848, 0.54347826086956, 0.35869565217391, 0.22727272727273
41849, 0.52173913043478, 0.33260869565217, 0.22727272727273
41850, 0.52173913043478, 0.35869565217391, 0.25
41851, 0.54347826086956, 0.35869565217391, 0.27272727272727
41852, 0.52173913043478, 0.33260869565217, 0.27272727272727
41853, 0.52173913043478, 0.35869565217391, 0.29545454545455
41854, 0.54347826086956, 0.35869565217391, 0.31818181818182
41855, 0.52173913043478, 0.33260869565217, 0.31818181818182
41856, 0.52173913043478, 0.35869565217391, 0.34090909090909
41857, 0.54347826086956, 0.35869565217391, 0.36363636363636
41858, 0.52173913043478, 0.33260869565217, 0.36363636363636
41859, 0.52173913043478, 0.35869565217391, 0.38636363636364
41860, 0.54347826086956, 0.35869565217391, 0.40909090909091
41861, 0.52173913043478, 0.33260869565217, 0.40909090909091
41862, 0.52173913043478, 0.35869565217391, 0.43181818181818
41863, 0.54347826086956, 0.35869565217391, 0.45454545454545
41864, 0.52173913043478, 0.33260869565217, 0.45454545454545
41865, 0.52173913043478, 0.35869565217391, 0.47727272727273
41866, 0.47826086956522, 0.35869565217391, 0.022727272727273
41867, 0.5, 0.35869565217391, 0.045454545454545
41868, 0.47826086956522, 0.33260869565217, 0.045454545454545
41869, 0.47826086956522, 0.35869565217391, 0.068181818181818
41870, 0.5, 0.35869565217391, 0.090909090909091
41871, 0.47826086956522, 0.33260869565217, 0.090909090909091
41872, 0.47826086956522, 0.35869565217391, 0.11363636363636
41873, 0.5, 0.35869565217391, 0.13636363636364
41874, 0.47826086956522, 0.33260869565217, 0.13636363636364
41875, 0.47826086956522, 0.35869565217391, 0.15909090909091
41876, 0.5, 0.35869565217391, 0.18181818181818
41877, 0.47826086956522, 0.33260869565217, 0.18181818181818
41878, 0.47826086956522, 0.35869565217391, 0.20454545454545
41879, 0.5, 0.35869565217391, 0.22727272727273
41880, 0.47826086956522, 0.33260869565217, 0.22727272727273
41881, 0.47826086956522, 0.35869565217391, 0.25
41882, 0.5, 0.35869565217391, 0.27272727272727
41883, 0.47826086956522, 0.33260869565217, 0.27272727272727
41884, 0.47826086956522, 0.35869565217391, 0.29545454545455
41885, 0.5, 0.35869565217391, 0.31818181818182
41886, 0.47826086956522, 0.33260869565217, 0.31818181818182
41887, 0.47826086956522, 0.35869565217391, 0.34090909090909
41888, 0.5, 0.35869565217391, 0.36363636363636
41889, 0.47826086956522, 0.33260869565217, 0.36363636363636
41890, 0.47826086956522, 0.35869565217391, 0.38636363636364
41891, 0.5, 0.35869565217391, 0.40909090909091
41892, 0.47826086956522, 0.33260869565217, 0.40909090909091
41893, 0.47826086956522, 0.35869565217391, 0.43181818181818
41894, 0.5, 0.35869565217391, 0.45454545454545
41895, 0.47826086956522, 0.33260869565217, 0.45454545454545
41896, 0.47826086956522, 0.35869565217391, 0.47727272727273
41897, 0.43478260869565, 0.35869565217391, 0.022727272727273
41898, 0.45652173913043, 0.35869565217391, 0.045454545454545
41899, 0.43478260869565, 0.33260869565217, 0.045454545454545
41900, 0.43478260869565, 0.35869565217391, 0.068181818181818
41901, 0.45652173913043, 0.35869565217391, 0.090909090909091
41902, 0.43478260869565, 0.33260869565217, 0.090909090909091
41903, 0.43478260869565, 0.35869565217391, 0.11363636363636
41904, 0.45652173913043, 0.35869565217391, 0.13636363636364
41905, 0.43478260869565, 0.33260869565217, 0.13636363636364
41906, 0.43478260869565, 0.35869565217391, 0.15909090909091
41907, 0.45652173913043, 0.35869565217391, 0.18181818181818
41908, 0.43478260869565, 0.33260869565217, 0.18181818181818
41909, 0.43478260869565, 0.35869565217391, 0.20454545454545
41910, 0.45652173913043, 0.35869565217391, 0.22727272727273
41911, 0.43478260869565, 0.33260869565217, 0.22727272727273
41912, 0.43478260869565, 0.35869565217391, 0.25
41913, 0.45652173913043, 0.35869565217391, 0.27272727272727
41914, 0.43478260869565, 0.33260869565217, 0.27272727272727
41915, 0.43478260869565, 0.35869565217391, 0.29545454545455
41916, 0.45652173913043, 0.35869565217391, 0.31818181818182
41917, 0.43478260869565, 0.33260869565217, 0.31818181818182
41918, 0.43478260869565, 0.35869565217391, 0.34090909090909
41919, 0.45652173913043, 0.35869565217391, 0.36363636363636
41920, 0.43478260869565, 0.33260869565217, 0.36363636363636
41921, 0.43478260869565, 0.35869565217391, 0.38636363636364
41922, 0.45652173913043, 0.35869565217391, 0.40909090909091
41923, 0.43478260869565, 0.33260869565217, 0.40909090909091
41924, 0.43478260869565, 0.35869565217391, 0.43181818181818
41925, 0.45652173913043, 0.35869565217391, 0.45454545454545
41926, 0.43478260869565, 0.33260869565217, 0.45454545454545
41927, 0.43478260869565, 0.35869565217391, 0.47727272727273
41928, 0.39130434782609, 0.35869565217391, 0.022727272727273
41929, 0.41304347826087, 0.35869565217391, 0.045454545454545
41930, 0.39130434782609, 0.33260869565217, 0.045454545454545
41931, 0.39130434782609, 0.35869565217391, 0.068181818181818
41932, 0.41304347826087, 0.35869565217391, 0.090909090909091
41933, 0.39130434782609, 0.33260869565217, 0.090909090909091
41934, 0.39130434782609, 0.35869565217391, 0.11363636363636
41935, 0.41304347826087, 0.35869565217391, 0.13636363636364
41936, 0.39130434782609, 0.33260869565217, 0.13636363636364
41937, 0.39130434782609, 0.35869565217391, 0.15909090909091
41938, 0.41304347826087, 0.35869565217391, 0.18181818181818
41939, 0.39130434782609, 0.33260869565217, 0.18181818181818
41940, 0.39130434782609, 0.35869565217391, 0.20454545454545
41941, 0.41304347826087, 0.35869565217391, 0.22727272727273
41942, 0.39130434782609, 0.33260869565217, 0.22727272727273
41943, 0.39130434782609, 0.35869565217391, 0.25
41944, 0.41304347826087, 0.35869565217391, 0.27272727272727
41945, 0.39130434782609, 0.33260869565217, 0.27272727272727
41946, 0.39130434782609, 0.35869565217391, 0.29545454545455
41947, 0.41304347826087, 0.35869565217391, 0.31818181818182
41948, 0.39130434782609, 0.33260869565217, 0.31818181818182
41949, 0.39130434782609, 0.35869565217391, 0.34090909090909
41950, 0.41304347826087, 0.35869565217391, 0.36363636363636
41951, 0.39130434782609, 0.33260869565217, 0.36363636363636
41952, 0.39130434782609, 0.35869565217391, 0.38636363636364
41953, 0.41304347826087, 0.35869565217391, 0.40909090909091
41954, 0.39130434782609, 0.33260869565217, 0.40909090909091
41955, 0.39130434782609, 0.35869565217391, 0.43181818181818
41956, 0.41304347826087, 0.35869565217391, 0.45454545454545
41957, 0.39130434782609, 0.33260869565217, 0.45454545454545
41958, 0.39130434782609, 0.35869565217391, 0.47727272727273
41959, 0.34782608695652, 0.35869565217391, 0.022727272727273
41960, 0.3695652173913, 0.35869565217391, 0.045454545454545
41961, 0.34782608695652, 0.33260869565217, 0.045454545454545
41962, 0.34782608695652, 0.35869565217391, 0.068181818181818
41963, 0.3695652173913, 0.35869565217391, 0.090909090909091
41964, 0.34782608695652, 0.33260869565217, 0.090909090909091
41965, 0.34782608695652, 0.35869565217391, 0.11363636363636
41966, 0.3695652173913, 0.35869565217391, 0.13636363636364
41967, 0.34782608695652, 0.33260869565217, 0.13636363636364
41968, 0.34782608695652, 0.35869565217391, 0.15909090909091
41969, 0.3695652173913, 0.35869565217391, 0.18181818181818
41970, 0.34782608695652, 0.33260869565217, 0.18181818181818
41971, 0.34782608695652, 0.35869565217391, 0.20454545454545
41972, 0.3695652173913, 0.35869565217391, 0.22727272727273
41973, 0.34782608695652, 0.33260869565217, 0.22727272727273
41974, 0.34782608695652, 0.35869565217391, 0.25
41975, 0.3695652173913, 0.35869565217391, 0.27272727272727
41976, 0.34782608695652, 0.33260869565217, 0.27272727272727
41977, 0.34782608695652, 0.35869565217391, 0.29545454545455
41978, 0.3695652173913, 0.35869565217391, 0.31818181818182
41979, 0.34782608695652, 0.33260869565217, 0.31818181818182
41980, 0.34782608695652, 0.35869565217391, 0.34090909090909
41981, 0.3695652173913, 0.35869565217391, 0.36363636363636
41982, 0.34782608695652, 0.33260869565217, 0.36363636363636
41983, 0.34782608695652, 0.35869565217391, 0.38636363636364
41984, 0.3695652173913, 0.35869565217391, 0.40909090909091
41985, 0.34782608695652, 0.33260869565217, 0.40909090909091
41986, 0.34782608695652, 0.35869565217391, 0.43181818181818
41987, 0.3695652173913, 0.35869565217391, 0.45454545454545
41988, 0.34782608695652, 0.33260869565217, 0.45454545454545
41989, 0.34782608695652, 0.35869565217391, 0.47727272727273
41990, 0.30434782608696, 0.35869565217391, 0.022727272727273
41991, 0.32608695652174, 0.35869565217391, 0.045454545454545
41992, 0.30434782608696, 0.33260869565217, 0.045454545454545
41993, 0.30434782608696, 0.35869565217391, 0.068181818181818
41994, 0.32608695652174, 0.35869565217391, 0.090909090909091
41995, 0.30434782608696, 0.33260869565217, 0.090909090909091
41996, 0.30434782608696, 0.35869565217391, 0.11363636363636
41997, 0.32608695652174, 0.35869565217391, 0.13636363636364
41998, 0.30434782608696, 0.33260869565217, 0.13636363636364
41999, 0.30434782608696, 0.35869565217391, 0.15909090909091
42000, 0.32608695652174, 0.35869565217391, 0.18181818181818
42001, 0.30434782608696, 0.33260869565217, 0.18181818181818
42002, 0.30434782608696, 0.35869565217391, 0.20454545454545
42003, 0.32608695652174, 0.35869565217391, 0.22727272727273
42004, 0.30434782608696, 0.33260869565217, 0.22727272727273
42005, 0.30434782608696, 0.35869565217391, 0.25
42006, 0.32608695652174, 0.35869565217391, 0.27272727272727
42007, 0.30434782608696, 0.33260869565217, 0.27272727272727
42008, 0.30434782608696, 0.35869565217391, 0.29545454545455
42009, 0.32608695652174, 0.35869565217391, 0.31818181818182
42010, 0.30434782608696, 0.33260869565217, 0.31818181818182
42011, 0.30434782608696, 0.35869565217391, 0.34090909090909
42012, 0.32608695652174, 0.35869565217391, 0.36363636363636
42013, 0.30434782608696, 0.33260869565217, 0.36363636363636
42014, 0.30434782608696, 0.35869565217391, 0.38636363636364
42015, 0.32608695652174, 0.35869565217391, 0.40909090909091
42016, 0.30434782608696, 0.33260869565217, 0.40909090909091
42017, 0.30434782608696, 0.35869565217391, 0.43181818181818
42018, 0.32608695652174, 0.35869565217391, 0.45454545454545
42019, 0.30434782608696, 0.33260869565217, 0.45454545454545
42020, 0.30434782608696, 0.35869565217391, 0.47727272727273
42021, 0.26086956521739, 0.35869565217391, 0.022727272727273
42022, 0.28260869565217, 0.35869565217391, 0.045454545454545
42023, 0.26086956521739, 0.33260869565217, 0.045454545454545
42024, 0.26086956521739, 0.35869565217391, 0.068181818181818
42025, 0.28260869565217, 0.35869565217391, 0.090909090909091
42026, 0.26086956521739, 0.33260869565217, 0.090909090909091
42027, 0.26086956521739, 0.35869565217391, 0.11363636363636
42028, 0.28260869565217, 0.35869565217391, 0.13636363636364
42029, 0.26086956521739, 0.33260869565217, 0.13636363636364
42030, 0.26086956521739, 0.35869565217391, 0.15909090909091
42031, 0.28260869565217, 0.35869565217391, 0.18181818181818
42032, 0.26086956521739, 0.33260869565217, 0.18181818181818
42033, 0.26086956521739, 0.35869565217391, 0.20454545454545
42034, 0.28260869565217, 0.35869565217391, 0.22727272727273
42035, 0.26086956521739, 0.33260869565217, 0.22727272727273
42036, 0.26086956521739, 0.35869565217391, 0.25
42037, 0.28260869565217, 0.35869565217391, 0.27272727272727
42038, 0.26086956521739, 0.33260869565217, 0.27272727272727
42039, 0.26086956521739, 0.35869565217391, 0.29545454545455
42040, 0.28260869565217, 0.35869565217391, 0.31818181818182
42041, 0.26086956521739, 0.33260869565217, 0.31818181818182
42042, 0.26086956521739, 0.35869565217391, 0.34090909090909
42043, 0.28260869565217, 0.35869565217391, 0.36363636363636
42044, 0.26086956521739, 0.33260869565217, 0.36363636363636
42045, 0.26086956521739, 0.35869565217391, 0.38636363636364
42046, 0.28260869565217, 0.35869565217391, 0.40909090909091
42047, 0.26086956521739, 0.33260869565217, 0.40909090909091
42048, 0.26086956521739, 0.35869565217391, 0.43181818181818
42049, 0.28260869565217, 0.35869565217391, 0.45454545454545
42050, 0.26086956521739, 0.33260869565217, 0.45454545454545
42051, 0.26086956521739, 0.35869565217391, 0.47727272727273
42052, 0.21739130434783, 0.35869565217391, 0.022727272727273
42053, 0.23913043478261, 0.35869565217391, 0.045454545454545
42054, 0.21739130434783, 0.33260869565217, 0.045454545454545
42055, 0.21739130434783, 0.35869565217391, 0.068181818181818
42056, 0.23913043478261, 0.35869565217391, 0.090909090909091
42057, 0.21739130434783, 0.33260869565217, 0.090909090909091
42058, 0.21739130434783, 0.35869565217391, 0.11363636363636
42059, 0.23913043478261, 0.35869565217391, 0.13636363636364
42060, 0.21739130434783, 0.33260869565217, 0.13636363636364
42061, 0.21739130434783, 0.35869565217391, 0.15909090909091
42062, 0.23913043478261, 0.35869565217391, 0.18181818181818
42063, 0.21739130434783, 0.33260869565217, 0.18181818181818
42064, 0.21739130434783, 0.35869565217391, 0.20454545454545
42065, 0.23913043478261, 0.35869565217391, 0.22727272727273
42066, 0.21739130434783, 0.33260869565217, 0.22727272727273
42067, 0.21739130434783, 0.35869565217391, 0.25
42068, 0.23913043478261, 0.35869565217391, 0.27272727272727
42069, 0.21739130434783, 0.33260869565217, 0.27272727272727
42070, 0.21739130434783, 0.35869565217391, 0.29545454545455
42071, 0.23913043478261, 0.35869565217391, 0.31818181818182
42072, 0.21739130434783, 0.33260869565217, 0.31818181818182
42073, 0.21739130434783, 0.35869565217391, 0.34090909090909
42074, 0.23913043478261, 0.35869565217391, 0.36363636363636
42075, 0.21739130434783, 0.33260869565217, 0.36363636363636
42076, 0.21739130434783, 0.35869565217391, 0.38636363636364
42077, 0.23913043478261, 0.35869565217391, 0.40909090909091
42078, 0.21739130434783, 0.33260869565217, 0.40909090909091
42079, 0.21739130434783, 0.35869565217391, 0.43181818181818
42080, 0.23913043478261, 0.35869565217391, 0.45454545454545
42081, 0.21739130434783, 0.33260869565217, 0.45454545454545
42082, 0.21739130434783, 0.35869565217391, 0.47727272727273
42083, 0.17391304347826, 0.35869565217391, 0.022727272727273
42084, 0.19565217391304, 0.35869565217391, 0.045454545454545
42085, 0.17391304347826, 0.33260869565217, 0.045454545454545
42086, 0.17391304347826, 0.35869565217391, 0.068181818181818
42087, 0.19565217391304, 0.35869565217391, 0.090909090909091
42088, 0.17391304347826, 0.33260869565217, 0.090909090909091
42089, 0.17391304347826, 0.35869565217391, 0.11363636363636
42090, 0.19565217391304, 0.35869565217391, 0.13636363636364
42091, 0.17391304347826, 0.33260869565217, 0.13636363636364
42092, 0.17391304347826, 0.35869565217391, 0.15909090909091
42093, 0.19565217391304, 0.35869565217391, 0.18181818181818
42094, 0.17391304347826, 0.33260869565217, 0.18181818181818
42095, 0.17391304347826, 0.35869565217391, 0.20454545454545
42096, 0.19565217391304, 0.35869565217391, 0.22727272727273
42097, 0.17391304347826, 0.33260869565217, 0.22727272727273
42098, 0.17391304347826, 0.35869565217391, 0.25
42099, 0.19565217391304, 0.35869565217391, 0.27272727272727
42100, 0.17391304347826, 0.33260869565217, 0.27272727272727
42101, 0.17391304347826, 0.35869565217391, 0.29545454545455
42102, 0.19565217391304, 0.35869565217391, 0.31818181818182
42103, 0.17391304347826, 0.33260869565217, 0.31818181818182
42104, 0.17391304347826, 0.35869565217391, 0.34090909090909
42105, 0.19565217391304, 0.35869565217391, 0.36363636363636
42106, 0.17391304347826, 0.33260869565217, 0.36363636363636
42107, 0.17391304347826, 0.35869565217391, 0.38636363636364
42108, 0.19565217391304, 0.35869565217391, 0.40909090909091
42109, 0.17391304347826, 0.33260869565217, 0.40909090909091
42110, 0.17391304347826, 0.35869565217391, 0.43181818181818
42111, 0.19565217391304, 0.35869565217391, 0.45454545454545
42112, 0.17391304347826, 0.33260869565217, 0.45454545454545
42113, 0.17391304347826, 0.35869565217391, 0.47727272727273
42114, 0.1304347826087, 0.35869565217391, 0.022727272727273
42115, 0.15217391304348, 0.35869565217391, 0.045454545454545
42116, 0.1304347826087, 0.33260869565217, 0.045454545454545
42117, 0.1304347826087, 0.35869565217391, 0.068181818181818
42118, 0.15217391304348, 0.35869565217391, 0.090909090909091
42119, 0.1304347826087, 0.33260869565217, 0.090909090909091
42120, 0.1304347826087, 0.35869565217391, 0.11363636363636
42121, 0.15217391304348, 0.35869565217391, 0.13636363636364
42122, 0.1304347826087, 0.33260869565217, 0.13636363636364
42123, 0.1304347826087, 0.35869565217391, 0.15909090909091
42124, 0.15217391304348, 0.35869565217391, 0.18181818181818
42125, 0.1304347826087, 0.33260869565217, 0.18181818181818
42126, 0.1304347826087, 0.35869565217391, 0.20454545454545
42127, 0.15217391304348, 0.35869565217391, 0.22727272727273
42128, 0.1304347826087, 0.33260869565217, 0.22727272727273
42129, 0.1304347826087, 0.35869565217391, 0.25
42130, 0.15217391304348, 0.35869565217391, 0.27272727272727
42131, 0.1304347826087, 0.33260869565217, 0.27272727272727
42132, 0.1304347826087, 0.35869565217391, 0.29545454545455
42133, 0.15217391304348, 0.35869565217391, 0.31818181818182
42134, 0.1304347826087, 0.33260869565217, 0.31818181818182
42135, 0.1304347826087, 0.35869565217391, 0.34090909090909
42136, 0.15217391304348, 0.35869565217391, 0.36363636363636
42137, 0.1304347826087, 0.33260869565217, 0.36363636363636
42138, 0.1304347826087, 0.35869565217391, 0.38636363636364
42139, 0.15217391304348, 0.35869565217391, 0.40909090909091
42140, 0.1304347826087, 0.33260869565217, 0.40909090909091
42141, 0.1304347826087, 0.35869565217391, 0.43181818181818
42142, 0.15217391304348, 0.35869565217391, 0.45454545454545
42143, 0.1304347826087, 0.33260869565217, 0.45454545454545
42144, 0.1304347826087, 0.35869565217391, 0.47727272727273
42145, 0.08695652173913, 0.35869565217391, 0.022727272727273
42146, 0.10869565217391, 0.35869565217391, 0.045454545454545
42147, 0.08695652173913, 0.33260869565217, 0.045454545454545
42148, 0.08695652173913, 0.35869565217391, 0.068181818181818
42149, 0.10869565217391, 0.35869565217391, 0.090909090909091
42150, 0.08695652173913, 0.33260869565217, 0.090909090909091
42151, 0.08695652173913, 0.35869565217391, 0.11363636363636
42152, 0.10869565217391, 0.35869565217391, 0.13636363636364
42153, 0.08695652173913, 0.33260869565217, 0.13636363636364
42154, 0.08695652173913, 0.35869565217391, 0.15909090909091
42155, 0.10869565217391, 0.35869565217391, 0.18181818181818
42156, 0.08695652173913, 0.33260869565217, 0.18181818181818
42157, 0.08695652173913, 0.35869565217391, 0.20454545454545
42158, 0.10869565217391, 0.35869565217391, 0.22727272727273
42159, 0.08695652173913, 0.33260869565217, 0.22727272727273
42160, 0.08695652173913, 0.35869565217391, 0.25
42161, 0.10869565217391, 0.35869565217391, 0.27272727272727
42162, 0.08695652173913, 0.33260869565217, 0.27272727272727
42163, 0.08695652173913, 0.35869565217391, 0.29545454545455
42164, 0.10869565217391, 0.35869565217391, 0.31818181818182
42165, 0.08695652173913, 0.33260869565217, 0.31818181818182
42166, 0.08695652173913, 0.35869565217391, 0.34090909090909
42167, 0.10869565217391, 0.35869565217391, 0.36363636363636
42168, 0.08695652173913, 0.33260869565217, 0.36363636363636
42169, 0.08695652173913, 0.35869565217391, 0.38636363636364
42170, 0.10869565217391, 0.35869565217391, 0.40909090909091
42171, 0.08695652173913, 0.33260869565217, 0.40909090909091
42172, 0.08695652173913, 0.35869565217391, 0.43181818181818
42173, 0.10869565217391, 0.35869565217391, 0.45454545454545
42174, 0.08695652173913, 0.33260869565217, 0.45454545454545
42175, 0.08695652173913, 0.35869565217391, 0.47727272727273
42176, 0.043478260869565, 0.35869565217391, 0.022727272727273
42177, 0.065217391304348, 0.35869565217391, 0.045454545454545
42178, 0.043478260869565, 0.33260869565217, 0.045454545454545
42179, 0.043478260869565, 0.35869565217391, 0.068181818181818
42180, 0.065217391304348, 0.35869565217391, 0.090909090909091
42181, 0.043478260869565, 0.33260869565217, 0.090909090909091
42182, 0.043478260869565, 0.35869565217391, 0.11363636363636
42183, 0.065217391304348, 0.35869565217391, 0.13636363636364
42184, 0.043478260869565, 0.33260869565217, 0.13636363636364
42185, 0.043478260869565, 0.35869565217391, 0.15909090909091
42186, 0.065217391304348, 0.35869565217391, 0.18181818181818
42187, 0.043478260869565, 0.33260869565217, 0.18181818181818
42188, 0.043478260869565, 0.35869565217391, 0.20454545454545
42189, 0.065217391304348, 0.35869565217391, 0.22727272727273
42190, 0.043478260869565, 0.33260869565217, 0.22727272727273
42191, 0.043478260869565, 0.35869565217391, 0.25
42192, 0.065217391304348, 0.35869565217391, 0.27272727272727
42193, 0.043478260869565, 0.33260869565217, 0.27272727272727
42194, 0.043478260869565, 0.35869565217391, 0.29545454545455
42195, 0.065217391304348, 0.35869565217391, 0.31818181818182
42196, 0.043478260869565, 0.33260869565217, 0.31818181818182
42197, 0.043478260869565, 0.35869565217391, 0.34090909090909
42198, 0.065217391304348, 0.35869565217391, 0.36363636363636
42199, 0.043478260869565, 0.33260869565217, 0.36363636363636
42200, 0.043478260869565, 0.35869565217391, 0.38636363636364
42201, 0.065217391304348, 0.35869565217391, 0.40909090909091
42202, 0.043478260869565, 0.33260869565217, 0.40909090909091
42203, 0.043478260869565, 0.35869565217391, 0.43181818181818
42204, 0.065217391304348, 0.35869565217391, 0.45454545454545
42205, 0.043478260869565, 0.33260869565217, 0.45454545454545
42206, 0.043478260869565, 0.35869565217391, 0.47727272727273
42207, 0.021739130434783, 0.35869565217391, 0.045454545454545
42208, 0.021739130434783, 0.35869565217391, 0.090909090909091
42209, 0.021739130434783, 0.35869565217391, 0.13636363636364
42210, 0.021739130434783, 0.35869565217391, 0.18181818181818
42211, 0.021739130434783, 0.35869565217391, 0.22727272727273
42212, 0.021739130434783, 0.35869565217391, 0.27272727272727
42213, 0.021739130434783, 0.35869565217391, 0.31818181818182
42214, 0.021739130434783, 0.35869565217391, 0.36363636363636
42215, 0.021739130434783, 0.35869565217391, 0.40909090909091
42216, 0.021739130434783, 0.35869565217391, 0.45454545454545
42217, 0.95652173913043, 0.41086956521739, 0.022727272727273
42218, 0.97826086956522, 0.41086956521739, 0.045454545454545
42219, 0.95652173913043, 0.38478260869565, 0.045454545454545
42220, 0.95652173913043, 0.41086956521739, 0.068181818181818
42221, 0.97826086956522, 0.41086956521739, 0.090909090909091
42222, 0.95652173913043, 0.38478260869565, 0.090909090909091
42223, 0.95652173913043, 0.41086956521739, 0.11363636363636
42224, 0.97826086956522, 0.41086956521739, 0.13636363636364
42225, 0.95652173913044, 0.38478260869565, 0.13636363636364
42226, 0.95652173913044, 0.41086956521739, 0.15909090909091
42227, 0.97826086956522, 0.41086956521739, 0.18181818181818
42228, 0.95652173913044, 0.38478260869565, 0.18181818181818
42229, 0.95652173913044, 0.41086956521739, 0.20454545454545
42230, 0.97826086956522, 0.41086956521739, 0.22727272727273
42231, 0.95652173913044, 0.38478260869565, 0.22727272727273
42232, 0.95652173913044, 0.41086956521739, 0.25
42233, 0.97826086956522, 0.41086956521739, 0.27272727272727
42234, 0.95652173913044, 0.38478260869565, 0.27272727272727
42235, 0.95652173913044, 0.41086956521739, 0.29545454545455
42236, 0.97826086956522, 0.41086956521739, 0.31818181818182
42237, 0.95652173913044, 0.38478260869565, 0.31818181818182
42238, 0.95652173913043, 0.41086956521739, 0.34090909090909
42239, 0.97826086956522, 0.41086956521739, 0.36363636363636
42240, 0.95652173913043, 0.38478260869565, 0.36363636363636
42241, 0.95652173913043, 0.41086956521739, 0.38636363636364
42242, 0.97826086956522, 0.41086956521739, 0.40909090909091
42243, 0.95652173913043, 0.38478260869565, 0.40909090909091
42244, 0.95652173913043, 0.41086956521739, 0.43181818181818
42245, 0.97826086956522, 0.41086956521739, 0.45454545454545
42246, 0.95652173913044, 0.38478260869565, 0.45454545454545
42247, 0.95652173913043, 0.41086956521739, 0.47727272727273
42248, 0.91304347826087, 0.41086956521739, 0.022727272727273
42249, 0.93478260869565, 0.41086956521739, 0.045454545454545
42250, 0.91304347826087, 0.38478260869565, 0.045454545454545
42251, 0.91304347826087, 0.41086956521739, 0.068181818181818
42252, 0.93478260869565, 0.41086956521739, 0.090909090909091
42253, 0.91304347826087, 0.38478260869565, 0.090909090909091
42254, 0.91304347826087, 0.41086956521739, 0.11363636363636
42255, 0.93478260869565, 0.41086956521739, 0.13636363636364
42256, 0.91304347826087, 0.38478260869565, 0.13636363636364
42257, 0.91304347826087, 0.41086956521739, 0.15909090909091
42258, 0.93478260869565, 0.41086956521739, 0.18181818181818
42259, 0.91304347826087, 0.38478260869565, 0.18181818181818
42260, 0.91304347826087, 0.41086956521739, 0.20454545454545
42261, 0.93478260869565, 0.41086956521739, 0.22727272727273
42262, 0.91304347826087, 0.38478260869565, 0.22727272727273
42263, 0.91304347826087, 0.41086956521739, 0.25
42264, 0.93478260869565, 0.41086956521739, 0.27272727272727
42265, 0.91304347826087, 0.38478260869565, 0.27272727272727
42266, 0.91304347826087, 0.41086956521739, 0.29545454545455
42267, 0.93478260869565, 0.41086956521739, 0.31818181818182
42268, 0.91304347826087, 0.38478260869565, 0.31818181818182
42269, 0.91304347826087, 0.41086956521739, 0.34090909090909
42270, 0.93478260869565, 0.41086956521739, 0.36363636363636
42271, 0.91304347826087, 0.38478260869565, 0.36363636363636
42272, 0.91304347826087, 0.41086956521739, 0.38636363636364
42273, 0.93478260869565, 0.41086956521739, 0.40909090909091
42274, 0.91304347826087, 0.38478260869565, 0.40909090909091
42275, 0.91304347826087, 0.41086956521739, 0.43181818181818
42276, 0.93478260869565, 0.41086956521739, 0.45454545454545
42277, 0.91304347826087, 0.38478260869565, 0.45454545454545
42278, 0.91304347826087, 0.41086956521739, 0.47727272727273
42279, 0.8695652173913, 0.41086956521739, 0.022727272727273
42280, 0.89130434782609, 0.41086956521739, 0.045454545454545
42281, 0.8695652173913, 0.38478260869565, 0.045454545454545
42282, 0.8695652173913, 0.41086956521739, 0.068181818181818
42283, 0.89130434782609, 0.41086956521739, 0.090909090909091
42284, 0.8695652173913, 0.38478260869565, 0.090909090909091
42285, 0.8695652173913, 0.41086956521739, 0.11363636363636
42286, 0.89130434782609, 0.41086956521739, 0.13636363636364
42287, 0.8695652173913, 0.38478260869565, 0.13636363636364
42288, 0.8695652173913, 0.41086956521739, 0.15909090909091
42289, 0.89130434782609, 0.41086956521739, 0.18181818181818
42290, 0.8695652173913, 0.38478260869565, 0.18181818181818
42291, 0.8695652173913, 0.41086956521739, 0.20454545454545
42292, 0.89130434782609, 0.41086956521739, 0.22727272727273
42293, 0.8695652173913, 0.38478260869565, 0.22727272727273
42294, 0.8695652173913, 0.41086956521739, 0.25
42295, 0.89130434782609, 0.41086956521739, 0.27272727272727
42296, 0.8695652173913, 0.38478260869565, 0.27272727272727
42297, 0.8695652173913, 0.41086956521739, 0.29545454545455
42298, 0.89130434782609, 0.41086956521739, 0.31818181818182
42299, 0.8695652173913, 0.38478260869565, 0.31818181818182
42300, 0.8695652173913, 0.41086956521739, 0.34090909090909
42301, 0.89130434782609, 0.41086956521739, 0.36363636363636
42302, 0.8695652173913, 0.38478260869565, 0.36363636363636
42303, 0.8695652173913, 0.41086956521739, 0.38636363636364
42304, 0.89130434782609, 0.41086956521739, 0.40909090909091
42305, 0.8695652173913, 0.38478260869565, 0.40909090909091
42306, 0.8695652173913, 0.41086956521739, 0.43181818181818
42307, 0.89130434782609, 0.41086956521739, 0.45454545454545
42308, 0.8695652173913, 0.38478260869565, 0.45454545454545
42309, 0.8695652173913, 0.41086956521739, 0.47727272727273
42310, 0.82608695652174, 0.41086956521739, 0.022727272727273
42311, 0.84782608695652, 0.41086956521739, 0.045454545454545
42312, 0.82608695652174, 0.38478260869565, 0.045454545454545
42313, 0.82608695652174, 0.41086956521739, 0.068181818181818
42314, 0.84782608695652, 0.41086956521739, 0.090909090909091
42315, 0.82608695652174, 0.38478260869565, 0.090909090909091
42316, 0.82608695652174, 0.41086956521739, 0.11363636363636
42317, 0.84782608695652, 0.41086956521739, 0.13636363636364
42318, 0.82608695652174, 0.38478260869565, 0.13636363636364
42319, 0.82608695652174, 0.41086956521739, 0.15909090909091
42320, 0.84782608695652, 0.41086956521739, 0.18181818181818
42321, 0.82608695652174, 0.38478260869565, 0.18181818181818
42322, 0.82608695652174, 0.41086956521739, 0.20454545454545
42323, 0.84782608695652, 0.41086956521739, 0.22727272727273
42324, 0.82608695652174, 0.38478260869565, 0.22727272727273
42325, 0.82608695652174, 0.41086956521739, 0.25
42326, 0.84782608695652, 0.41086956521739, 0.27272727272727
42327, 0.82608695652174, 0.38478260869565, 0.27272727272727
42328, 0.82608695652174, 0.41086956521739, 0.29545454545455
42329, 0.84782608695652, 0.41086956521739, 0.31818181818182
42330, 0.82608695652174, 0.38478260869565, 0.31818181818182
42331, 0.82608695652174, 0.41086956521739, 0.34090909090909
42332, 0.84782608695652, 0.41086956521739, 0.36363636363636
42333, 0.82608695652174, 0.38478260869565, 0.36363636363636
42334, 0.82608695652174, 0.41086956521739, 0.38636363636364
42335, 0.84782608695652, 0.41086956521739, 0.40909090909091
42336, 0.82608695652174, 0.38478260869565, 0.40909090909091
42337, 0.82608695652174, 0.41086956521739, 0.43181818181818
42338, 0.84782608695652, 0.41086956521739, 0.45454545454545
42339, 0.82608695652174, 0.38478260869565, 0.45454545454545
42340, 0.82608695652174, 0.41086956521739, 0.47727272727273
42341, 0.78260869565217, 0.41086956521739, 0.022727272727273
42342, 0.80434782608696, 0.41086956521739, 0.045454545454545
42343, 0.78260869565217, 0.38478260869565, 0.045454545454545
42344, 0.78260869565217, 0.41086956521739, 0.068181818181818
42345, 0.80434782608696, 0.41086956521739, 0.090909090909091
42346, 0.78260869565217, 0.38478260869565, 0.090909090909091
42347, 0.78260869565217, 0.41086956521739, 0.11363636363636
42348, 0.80434782608696, 0.41086956521739, 0.13636363636364
42349, 0.78260869565217, 0.38478260869565, 0.13636363636364
42350, 0.78260869565217, 0.41086956521739, 0.15909090909091
42351, 0.80434782608696, 0.41086956521739, 0.18181818181818
42352, 0.78260869565217, 0.38478260869565, 0.18181818181818
42353, 0.78260869565217, 0.41086956521739, 0.20454545454545
42354, 0.80434782608696, 0.41086956521739, 0.22727272727273
42355, 0.78260869565217, 0.38478260869565, 0.22727272727273
42356, 0.78260869565217, 0.41086956521739, 0.25
42357, 0.80434782608696, 0.41086956521739, 0.27272727272727
42358, 0.78260869565217, 0.38478260869565, 0.27272727272727
42359, 0.78260869565217, 0.41086956521739, 0.29545454545455
42360, 0.80434782608696, 0.41086956521739, 0.31818181818182
42361, 0.78260869565217, 0.38478260869565, 0.31818181818182
42362, 0.78260869565217, 0.41086956521739, 0.34090909090909
42363, 0.80434782608696, 0.41086956521739, 0.36363636363636
42364, 0.78260869565217, 0.38478260869565, 0.36363636363636
42365, 0.78260869565217, 0.41086956521739, 0.38636363636364
42366, 0.80434782608696, 0.41086956521739, 0.40909090909091
42367, 0.78260869565217, 0.38478260869565, 0.40909090909091
42368, 0.78260869565217, 0.41086956521739, 0.43181818181818
42369, 0.80434782608696, 0.41086956521739, 0.45454545454545
42370, 0.78260869565217, 0.38478260869565, 0.45454545454545
42371, 0.78260869565217, 0.41086956521739, 0.47727272727273
42372, 0.73913043478261, 0.41086956521739, 0.022727272727273
42373, 0.76086956521739, 0.41086956521739, 0.045454545454545
42374, 0.73913043478261, 0.38478260869565, 0.045454545454545
42375, 0.73913043478261, 0.41086956521739, 0.068181818181818
42376, 0.76086956521739, 0.41086956521739, 0.090909090909091
42377, 0.73913043478261, 0.38478260869565, 0.090909090909091
42378, 0.73913043478261, 0.41086956521739, 0.11363636363636
42379, 0.76086956521739, 0.41086956521739, 0.13636363636364
42380, 0.73913043478261, 0.38478260869565, 0.13636363636364
42381, 0.73913043478261, 0.41086956521739, 0.15909090909091
42382, 0.76086956521739, 0.41086956521739, 0.18181818181818
42383, 0.73913043478261, 0.38478260869565, 0.18181818181818
42384, 0.73913043478261, 0.41086956521739, 0.20454545454545
42385, 0.76086956521739, 0.41086956521739, 0.22727272727273
42386, 0.73913043478261, 0.38478260869565, 0.22727272727273
42387, 0.73913043478261, 0.41086956521739, 0.25
42388, 0.76086956521739, 0.41086956521739, 0.27272727272727
42389, 0.73913043478261, 0.38478260869565, 0.27272727272727
42390, 0.73913043478261, 0.41086956521739, 0.29545454545455
42391, 0.76086956521739, 0.41086956521739, 0.31818181818182
42392, 0.73913043478261, 0.38478260869565, 0.31818181818182
42393, 0.73913043478261, 0.41086956521739, 0.34090909090909
42394, 0.76086956521739, 0.41086956521739, 0.36363636363636
42395, 0.73913043478261, 0.38478260869565, 0.36363636363636
42396, 0.73913043478261, 0.41086956521739, 0.38636363636364
42397, 0.76086956521739, 0.41086956521739, 0.40909090909091
42398, 0.73913043478261, 0.38478260869565, 0.40909090909091
42399, 0.73913043478261, 0.41086956521739, 0.43181818181818
42400, 0.76086956521739, 0.41086956521739, 0.45454545454545
42401, 0.73913043478261, 0.38478260869565, 0.45454545454545
42402, 0.73913043478261, 0.41086956521739, 0.47727272727273
42403, 0.69565217391304, 0.41086956521739, 0.022727272727273
42404, 0.71739130434783, 0.41086956521739, 0.045454545454545
42405, 0.69565217391304, 0.38478260869565, 0.045454545454545
42406, 0.69565217391304, 0.41086956521739, 0.068181818181818
42407, 0.71739130434783, 0.41086956521739, 0.090909090909091
42408, 0.69565217391304, 0.38478260869565, 0.090909090909091
42409, 0.69565217391304, 0.41086956521739, 0.11363636363636
42410, 0.71739130434783, 0.41086956521739, 0.13636363636364
42411, 0.69565217391304, 0.38478260869565, 0.13636363636364
42412, 0.69565217391304, 0.41086956521739, 0.15909090909091
42413, 0.71739130434783, 0.41086956521739, 0.18181818181818
42414, 0.69565217391304, 0.38478260869565, 0.18181818181818
42415, 0.69565217391304, 0.41086956521739, 0.20454545454545
42416, 0.71739130434783, 0.41086956521739, 0.22727272727273
42417, 0.69565217391304, 0.38478260869565, 0.22727272727273
42418, 0.69565217391304, 0.41086956521739, 0.25
42419, 0.71739130434783, 0.41086956521739, 0.27272727272727
42420, 0.69565217391304, 0.38478260869565, 0.27272727272727
42421, 0.69565217391304, 0.41086956521739, 0.29545454545455
42422, 0.71739130434783, 0.41086956521739, 0.31818181818182
42423, 0.69565217391304, 0.38478260869565, 0.31818181818182
42424, 0.69565217391304, 0.41086956521739, 0.34090909090909
42425, 0.71739130434783, 0.41086956521739, 0.36363636363636
42426, 0.69565217391304, 0.38478260869565, 0.36363636363636
42427, 0.69565217391304, 0.41086956521739, 0.38636363636364
42428, 0.71739130434783, 0.41086956521739, 0.40909090909091
42429, 0.69565217391304, 0.38478260869565, 0.40909090909091
42430, 0.69565217391304, 0.41086956521739, 0.43181818181818
42431, 0.71739130434783, 0.41086956521739, 0.45454545454545
42432, 0.69565217391304, 0.38478260869565, 0.45454545454545
42433, 0.69565217391304, 0.41086956521739, 0.47727272727273
42434, 0.65217391304348, 0.41086956521739, 0.022727272727273
42435, 0.67391304347826, 0.41086956521739, 0.045454545454545
42436, 0.65217391304348, 0.38478260869565, 0.045454545454545
42437, 0.65217391304348, 0.41086956521739, 0.068181818181818
42438, 0.67391304347826, 0.41086956521739, 0.090909090909091
42439, 0.65217391304348, 0.38478260869565, 0.090909090909091
42440, 0.65217391304348, 0.41086956521739, 0.11363636363636
42441, 0.67391304347826, 0.41086956521739, 0.13636363636364
42442, 0.65217391304348, 0.38478260869565, 0.13636363636364
42443, 0.65217391304348, 0.41086956521739, 0.15909090909091
42444, 0.67391304347826, 0.41086956521739, 0.18181818181818
42445, 0.65217391304348, 0.38478260869565, 0.18181818181818
42446, 0.65217391304348, 0.41086956521739, 0.20454545454545
42447, 0.67391304347826, 0.41086956521739, 0.22727272727273
42448, 0.65217391304348, 0.38478260869565, 0.22727272727273
42449, 0.65217391304348, 0.41086956521739, 0.25
42450, 0.67391304347826, 0.41086956521739, 0.27272727272727
42451, 0.65217391304348, 0.38478260869565, 0.27272727272727
42452, 0.65217391304348, 0.41086956521739, 0.29545454545455
42453, 0.67391304347826, 0.41086956521739, 0.31818181818182
42454, 0.65217391304348, 0.38478260869565, 0.31818181818182
42455, 0.65217391304348, 0.41086956521739, 0.34090909090909
42456, 0.67391304347826, 0.41086956521739, 0.36363636363636
42457, 0.65217391304348, 0.38478260869565, 0.36363636363636
42458, 0.65217391304348, 0.41086956521739, 0.38636363636364
42459, 0.67391304347826, 0.41086956521739, 0.40909090909091
42460, 0.65217391304348, 0.38478260869565, 0.40909090909091
42461, 0.65217391304348, 0.41086956521739, 0.43181818181818
42462, 0.67391304347826, 0.41086956521739, 0.45454545454545
42463, 0.65217391304348, 0.38478260869565, 0.45454545454545
42464, 0.65217391304348, 0.41086956521739, 0.47727272727273
42465, 0.60869565217391, 0.41086956521739, 0.022727272727273
42466, 0.6304347826087, 0.41086956521739, 0.045454545454545
42467, 0.60869565217391, 0.38478260869565, 0.045454545454545
42468, 0.60869565217391, 0.41086956521739, 0.068181818181818
42469, 0.6304347826087, 0.41086956521739, 0.090909090909091
42470, 0.60869565217391, 0.38478260869565, 0.090909090909091
42471, 0.60869565217391, 0.41086956521739, 0.11363636363636
42472, 0.6304347826087, 0.41086956521739, 0.13636363636364
42473, 0.60869565217391, 0.38478260869565, 0.13636363636364
42474, 0.60869565217391, 0.41086956521739, 0.15909090909091
42475, 0.6304347826087, 0.41086956521739, 0.18181818181818
42476, 0.60869565217391, 0.38478260869565, 0.18181818181818
42477, 0.60869565217391, 0.41086956521739, 0.20454545454545
42478, 0.6304347826087, 0.41086956521739, 0.22727272727273
42479, 0.60869565217391, 0.38478260869565, 0.22727272727273
42480, 0.60869565217391, 0.41086956521739, 0.25
42481, 0.6304347826087, 0.41086956521739, 0.27272727272727
42482, 0.60869565217391, 0.38478260869565, 0.27272727272727
42483, 0.60869565217391, 0.41086956521739, 0.29545454545455
42484, 0.6304347826087, 0.41086956521739, 0.31818181818182
42485, 0.60869565217391, 0.38478260869565, 0.31818181818182
42486, 0.60869565217391, 0.41086956521739, 0.34090909090909
42487, 0.6304347826087, 0.41086956521739, 0.36363636363636
42488, 0.60869565217391, 0.38478260869565, 0.36363636363636
42489, 0.60869565217391, 0.41086956521739, 0.38636363636364
42490, 0.6304347826087, 0.41086956521739, 0.40909090909091
42491, 0.60869565217391, 0.38478260869565, 0.40909090909091
42492, 0.60869565217391, 0.41086956521739, 0.43181818181818
42493, 0.6304347826087, 0.41086956521739, 0.45454545454545
42494, 0.60869565217391, 0.38478260869565, 0.45454545454545
42495, 0.60869565217391, 0.41086956521739, 0.47727272727273
42496, 0.56521739130435, 0.41086956521739, 0.022727272727273
42497, 0.58695652173913, 0.41086956521739, 0.045454545454545
42498, 0.56521739130435, 0.38478260869565, 0.045454545454545
42499, 0.56521739130435, 0.41086956521739, 0.068181818181818
42500, 0.58695652173913, 0.41086956521739, 0.090909090909091
42501, 0.56521739130435, 0.38478260869565, 0.090909090909091
42502, 0.56521739130435, 0.41086956521739, 0.11363636363636
42503, 0.58695652173913, 0.41086956521739, 0.13636363636364
42504, 0.56521739130435, 0.38478260869565, 0.13636363636364
42505, 0.56521739130435, 0.41086956521739, 0.15909090909091
42506, 0.58695652173913, 0.41086956521739, 0.18181818181818
42507, 0.56521739130435, 0.38478260869565, 0.18181818181818
42508, 0.56521739130435, 0.41086956521739, 0.20454545454545
42509, 0.58695652173913, 0.41086956521739, 0.22727272727273
42510, 0.56521739130435, 0.38478260869565, 0.22727272727273
42511, 0.56521739130435, 0.41086956521739, 0.25
42512, 0.58695652173913, 0.41086956521739, 0.27272727272727
42513, 0.56521739130435, 0.38478260869565, 0.27272727272727
42514, 0.56521739130435, 0.41086956521739, 0.29545454545455
42515, 0.58695652173913, 0.41086956521739, 0.31818181818182
42516, 0.56521739130435, 0.38478260869565, 0.31818181818182
42517, 0.56521739130435, 0.41086956521739, 0.34090909090909
42518, 0.58695652173913, 0.41086956521739, 0.36363636363636
42519, 0.56521739130435, 0.38478260869565, 0.36363636363636
42520, 0.56521739130435, 0.41086956521739, 0.38636363636364
42521, 0.58695652173913, 0.41086956521739, 0.40909090909091
42522, 0.56521739130435, 0.38478260869565, 0.40909090909091
42523, 0.56521739130435, 0.41086956521739, 0.43181818181818
42524, 0.58695652173913, 0.41086956521739, 0.45454545454545
42525, 0.56521739130435, 0.38478260869565, 0.45454545454545
42526, 0.56521739130435, 0.41086956521739, 0.47727272727273
42527, 0.52173913043478, 0.41086956521739, 0.022727272727273
42528, 0.54347826086956, 0.41086956521739, 0.045454545454545
42529, 0.52173913043478, 0.38478260869565, 0.045454545454545
42530, 0.52173913043478, 0.41086956521739, 0.068181818181818
42531, 0.54347826086956, 0.41086956521739, 0.090909090909091
42532, 0.52173913043478, 0.38478260869565, 0.090909090909091
42533, 0.52173913043478, 0.41086956521739, 0.11363636363636
42534, 0.54347826086957, 0.41086956521739, 0.13636363636364
42535, 0.52173913043478, 0.38478260869565, 0.13636363636364
42536, 0.52173913043478, 0.41086956521739, 0.15909090909091
42537, 0.54347826086956, 0.41086956521739, 0.18181818181818
42538, 0.52173913043478, 0.38478260869565, 0.18181818181818
42539, 0.52173913043478, 0.41086956521739, 0.20454545454545
42540, 0.54347826086956, 0.41086956521739, 0.22727272727273
42541, 0.52173913043478, 0.38478260869565, 0.22727272727273
42542, 0.52173913043478, 0.41086956521739, 0.25
42543, 0.54347826086956, 0.41086956521739, 0.27272727272727
42544, 0.52173913043478, 0.38478260869565, 0.27272727272727
42545, 0.52173913043478, 0.41086956521739, 0.29545454545455
42546, 0.54347826086956, 0.41086956521739, 0.31818181818182
42547, 0.52173913043478, 0.38478260869565, 0.31818181818182
42548, 0.52173913043478, 0.41086956521739, 0.34090909090909
42549, 0.54347826086957, 0.41086956521739, 0.36363636363636
42550, 0.52173913043478, 0.38478260869565, 0.36363636363636
42551, 0.52173913043478, 0.41086956521739, 0.38636363636364
42552, 0.54347826086956, 0.41086956521739, 0.40909090909091
42553, 0.52173913043478, 0.38478260869565, 0.40909090909091
42554, 0.52173913043478, 0.41086956521739, 0.43181818181818
42555, 0.54347826086956, 0.41086956521739, 0.45454545454545
42556, 0.52173913043478, 0.38478260869565, 0.45454545454545
42557, 0.52173913043478, 0.41086956521739, 0.47727272727273
42558, 0.47826086956522, 0.41086956521739, 0.022727272727273
42559, 0.5, 0.41086956521739, 0.045454545454545
42560, 0.47826086956522, 0.38478260869565, 0.045454545454545
42561, 0.47826086956522, 0.41086956521739, 0.068181818181818
42562, 0.5, 0.41086956521739, 0.090909090909091
42563, 0.47826086956522, 0.38478260869565, 0.090909090909091
42564, 0.47826086956522, 0.41086956521739, 0.11363636363636
42565, 0.5, 0.41086956521739, 0.13636363636364
42566, 0.47826086956522, 0.38478260869565, 0.13636363636364
42567, 0.47826086956522, 0.41086956521739, 0.15909090909091
42568, 0.5, 0.41086956521739, 0.18181818181818
42569, 0.47826086956522, 0.38478260869565, 0.18181818181818
42570, 0.47826086956522, 0.41086956521739, 0.20454545454545
42571, 0.5, 0.41086956521739, 0.22727272727273
42572, 0.47826086956522, 0.38478260869565, 0.22727272727273
42573, 0.47826086956522, 0.41086956521739, 0.25
42574, 0.5, 0.41086956521739, 0.27272727272727
42575, 0.47826086956522, 0.38478260869565, 0.27272727272727
42576, 0.47826086956522, 0.41086956521739, 0.29545454545455
42577, 0.5, 0.41086956521739, 0.31818181818182
42578, 0.47826086956522, 0.38478260869565, 0.31818181818182
42579, 0.47826086956522, 0.41086956521739, 0.34090909090909
42580, 0.5, 0.41086956521739, 0.36363636363636
42581, 0.47826086956522, 0.38478260869565, 0.36363636363636
42582, 0.47826086956522, 0.41086956521739, 0.38636363636364
42583, 0.5, 0.41086956521739, 0.40909090909091
42584, 0.47826086956522, 0.38478260869565, 0.40909090909091
42585, 0.47826086956522, 0.41086956521739, 0.43181818181818
42586, 0.5, 0.41086956521739, 0.45454545454545
42587, 0.47826086956522, 0.38478260869565, 0.45454545454545
42588, 0.47826086956522, 0.41086956521739, 0.47727272727273
42589, 0.43478260869565, 0.41086956521739, 0.022727272727273
42590, 0.45652173913043, 0.41086956521739, 0.045454545454545
42591, 0.43478260869565, 0.38478260869565, 0.045454545454545
42592, 0.43478260869565, 0.41086956521739, 0.068181818181818
42593, 0.45652173913043, 0.41086956521739, 0.090909090909091
42594, 0.43478260869565, 0.38478260869565, 0.090909090909091
42595, 0.43478260869565, 0.41086956521739, 0.11363636363636
42596, 0.45652173913043, 0.41086956521739, 0.13636363636364
42597, 0.43478260869565, 0.38478260869565, 0.13636363636364
42598, 0.43478260869565, 0.41086956521739, 0.15909090909091
42599, 0.45652173913043, 0.41086956521739, 0.18181818181818
42600, 0.43478260869565, 0.38478260869565, 0.18181818181818
42601, 0.43478260869565, 0.41086956521739, 0.20454545454545
42602, 0.45652173913043, 0.41086956521739, 0.22727272727273
42603, 0.43478260869565, 0.38478260869565, 0.22727272727273
42604, 0.43478260869565, 0.41086956521739, 0.25
42605, 0.45652173913043, 0.41086956521739, 0.27272727272727
42606, 0.43478260869565, 0.38478260869565, 0.27272727272727
42607, 0.43478260869565, 0.41086956521739, 0.29545454545455
42608, 0.45652173913043, 0.41086956521739, 0.31818181818182
42609, 0.43478260869565, 0.38478260869565, 0.31818181818182
42610, 0.43478260869565, 0.41086956521739, 0.34090909090909
42611, 0.45652173913043, 0.41086956521739, 0.36363636363636
42612, 0.43478260869565, 0.38478260869565, 0.36363636363636
42613, 0.43478260869565, 0.41086956521739, 0.38636363636364
42614, 0.45652173913043, 0.41086956521739, 0.40909090909091
42615, 0.43478260869565, 0.38478260869565, 0.40909090909091
42616, 0.43478260869565, 0.41086956521739, 0.43181818181818
42617, 0.45652173913043, 0.41086956521739, 0.45454545454545
42618, 0.43478260869565, 0.38478260869565, 0.45454545454545
42619, 0.43478260869565, 0.41086956521739, 0.47727272727273
42620, 0.39130434782609, 0.41086956521739, 0.022727272727273
42621, 0.41304347826087, 0.41086956521739, 0.045454545454545
42622, 0.39130434782609, 0.38478260869565, 0.045454545454545
42623, 0.39130434782609, 0.41086956521739, 0.068181818181818
42624, 0.41304347826087, 0.41086956521739, 0.090909090909091
42625, 0.39130434782609, 0.38478260869565, 0.090909090909091
42626, 0.39130434782609, 0.41086956521739, 0.11363636363636
42627, 0.41304347826087, 0.41086956521739, 0.13636363636364
42628, 0.39130434782609, 0.38478260869565, 0.13636363636364
42629, 0.39130434782609, 0.41086956521739, 0.15909090909091
42630, 0.41304347826087, 0.41086956521739, 0.18181818181818
42631, 0.39130434782609, 0.38478260869565, 0.18181818181818
42632, 0.39130434782609, 0.41086956521739, 0.20454545454545
42633, 0.41304347826087, 0.41086956521739, 0.22727272727273
42634, 0.39130434782609, 0.38478260869565, 0.22727272727273
42635, 0.39130434782609, 0.41086956521739, 0.25
42636, 0.41304347826087, 0.41086956521739, 0.27272727272727
42637, 0.39130434782609, 0.38478260869565, 0.27272727272727
42638, 0.39130434782609, 0.41086956521739, 0.29545454545455
42639, 0.41304347826087, 0.41086956521739, 0.31818181818182
42640, 0.39130434782609, 0.38478260869565, 0.31818181818182
42641, 0.39130434782609, 0.41086956521739, 0.34090909090909
42642, 0.41304347826087, 0.41086956521739, 0.36363636363636
42643, 0.39130434782609, 0.38478260869565, 0.36363636363636
42644, 0.39130434782609, 0.41086956521739, 0.38636363636364
42645, 0.41304347826087, 0.41086956521739, 0.40909090909091
42646, 0.39130434782609, 0.38478260869565, 0.40909090909091
42647, 0.39130434782609, 0.41086956521739, 0.43181818181818
42648, 0.41304347826087, 0.41086956521739, 0.45454545454545
42649, 0.39130434782609, 0.38478260869565, 0.45454545454545
42650, 0.39130434782609, 0.41086956521739, 0.47727272727273
42651, 0.34782608695652, 0.41086956521739, 0.022727272727273
42652, 0.3695652173913, 0.41086956521739, 0.045454545454545
42653, 0.34782608695652, 0.38478260869565, 0.045454545454545
42654, 0.34782608695652, 0.41086956521739, 0.068181818181818
42655, 0.3695652173913, 0.41086956521739, 0.090909090909091
42656, 0.34782608695652, 0.38478260869565, 0.090909090909091
42657, 0.34782608695652, 0.41086956521739, 0.11363636363636
42658, 0.3695652173913, 0.41086956521739, 0.13636363636364
42659, 0.34782608695652, 0.38478260869565, 0.13636363636364
42660, 0.34782608695652, 0.41086956521739, 0.15909090909091
42661, 0.3695652173913, 0.41086956521739, 0.18181818181818
42662, 0.34782608695652, 0.38478260869565, 0.18181818181818
42663, 0.34782608695652, 0.41086956521739, 0.20454545454545
42664, 0.3695652173913, 0.41086956521739, 0.22727272727273
42665, 0.34782608695652, 0.38478260869565, 0.22727272727273
42666, 0.34782608695652, 0.41086956521739, 0.25
42667, 0.3695652173913, 0.41086956521739, 0.27272727272727
42668, 0.34782608695652, 0.38478260869565, 0.27272727272727
42669, 0.34782608695652, 0.41086956521739, 0.29545454545455
42670, 0.3695652173913, 0.41086956521739, 0.31818181818182
42671, 0.34782608695652, 0.38478260869565, 0.31818181818182
42672, 0.34782608695652, 0.41086956521739, 0.34090909090909
42673, 0.3695652173913, 0.41086956521739, 0.36363636363636
42674, 0.34782608695652, 0.38478260869565, 0.36363636363636
42675, 0.34782608695652, 0.41086956521739, 0.38636363636364
42676, 0.3695652173913, 0.41086956521739, 0.40909090909091
42677, 0.34782608695652, 0.38478260869565, 0.40909090909091
42678, 0.34782608695652, 0.41086956521739, 0.43181818181818
42679, 0.3695652173913, 0.41086956521739, 0.45454545454545
42680, 0.34782608695652, 0.38478260869565, 0.45454545454545
42681, 0.34782608695652, 0.41086956521739, 0.47727272727273
42682, 0.30434782608696, 0.41086956521739, 0.022727272727273
42683, 0.32608695652174, 0.41086956521739, 0.045454545454545
42684, 0.30434782608696, 0.38478260869565, 0.045454545454545
42685, 0.30434782608696, 0.41086956521739, 0.068181818181818
42686, 0.32608695652174, 0.41086956521739, 0.090909090909091
42687, 0.30434782608696, 0.38478260869565, 0.090909090909091
42688, 0.30434782608696, 0.41086956521739, 0.11363636363636
42689, 0.32608695652174, 0.41086956521739, 0.13636363636364
42690, 0.30434782608696, 0.38478260869565, 0.13636363636364
42691, 0.30434782608696, 0.41086956521739, 0.15909090909091
42692, 0.32608695652174, 0.41086956521739, 0.18181818181818
42693, 0.30434782608696, 0.38478260869565, 0.18181818181818
42694, 0.30434782608696, 0.41086956521739, 0.20454545454545
42695, 0.32608695652174, 0.41086956521739, 0.22727272727273
42696, 0.30434782608696, 0.38478260869565, 0.22727272727273
42697, 0.30434782608696, 0.41086956521739, 0.25
42698, 0.32608695652174, 0.41086956521739, 0.27272727272727
42699, 0.30434782608696, 0.38478260869565, 0.27272727272727
42700, 0.30434782608696, 0.41086956521739, 0.29545454545455
42701, 0.32608695652174, 0.41086956521739, 0.31818181818182
42702, 0.30434782608696, 0.38478260869565, 0.31818181818182
42703, 0.30434782608696, 0.41086956521739, 0.34090909090909
42704, 0.32608695652174, 0.41086956521739, 0.36363636363636
42705, 0.30434782608696, 0.38478260869565, 0.36363636363636
42706, 0.30434782608696, 0.41086956521739, 0.38636363636364
42707, 0.32608695652174, 0.41086956521739, 0.40909090909091
42708, 0.30434782608696, 0.38478260869565, 0.40909090909091
42709, 0.30434782608696, 0.41086956521739, 0.43181818181818
42710, 0.32608695652174, 0.41086956521739, 0.45454545454545
42711, 0.30434782608696, 0.38478260869565, 0.45454545454545
42712, 0.30434782608696, 0.41086956521739, 0.47727272727273
42713, 0.26086956521739, 0.41086956521739, 0.022727272727273
42714, 0.28260869565217, 0.41086956521739, 0.045454545454545
42715, 0.26086956521739, 0.38478260869565, 0.045454545454545
42716, 0.26086956521739, 0.41086956521739, 0.068181818181818
42717, 0.28260869565217, 0.41086956521739, 0.090909090909091
42718, 0.26086956521739, 0.38478260869565, 0.090909090909091
42719, 0.26086956521739, 0.41086956521739, 0.11363636363636
42720, 0.28260869565217, 0.41086956521739, 0.13636363636364
42721, 0.26086956521739, 0.38478260869565, 0.13636363636364
42722, 0.26086956521739, 0.41086956521739, 0.15909090909091
42723, 0.28260869565217, 0.41086956521739, 0.18181818181818
42724, 0.26086956521739, 0.38478260869565, 0.18181818181818
42725, 0.26086956521739, 0.41086956521739, 0.20454545454545
42726, 0.28260869565217, 0.41086956521739, 0.22727272727273
42727, 0.26086956521739, 0.38478260869565, 0.22727272727273
42728, 0.26086956521739, 0.41086956521739, 0.25
42729, 0.28260869565217, 0.41086956521739, 0.27272727272727
42730, 0.26086956521739, 0.38478260869565, 0.27272727272727
42731, 0.26086956521739, 0.41086956521739, 0.29545454545455
42732, 0.28260869565217, 0.41086956521739, 0.31818181818182
42733, 0.26086956521739, 0.38478260869565, 0.31818181818182
42734, 0.26086956521739, 0.41086956521739, 0.34090909090909
42735, 0.28260869565217, 0.41086956521739, 0.36363636363636
42736, 0.26086956521739, 0.38478260869565, 0.36363636363636
42737, 0.26086956521739, 0.41086956521739, 0.38636363636364
42738, 0.28260869565217, 0.41086956521739, 0.40909090909091
42739, 0.26086956521739, 0.38478260869565, 0.40909090909091
42740, 0.26086956521739, 0.41086956521739, 0.43181818181818
42741, 0.28260869565217, 0.41086956521739, 0.45454545454545
42742, 0.26086956521739, 0.38478260869565, 0.45454545454545
42743, 0.26086956521739, 0.41086956521739, 0.47727272727273
42744, 0.21739130434783, 0.41086956521739, 0.022727272727273
42745, 0.23913043478261, 0.41086956521739, 0.045454545454545
42746, 0.21739130434783, 0.38478260869565, 0.045454545454545
42747, 0.21739130434783, 0.41086956521739, 0.068181818181818
42748, 0.23913043478261, 0.41086956521739, 0.090909090909091
42749, 0.21739130434783, 0.38478260869565, 0.090909090909091
42750, 0.21739130434783, 0.41086956521739, 0.11363636363636
42751, 0.23913043478261, 0.41086956521739, 0.13636363636364
42752, 0.21739130434783, 0.38478260869565, 0.13636363636364
42753, 0.21739130434783, 0.41086956521739, 0.15909090909091
42754, 0.23913043478261, 0.41086956521739, 0.18181818181818
42755, 0.21739130434783, 0.38478260869565, 0.18181818181818
42756, 0.21739130434783, 0.41086956521739, 0.20454545454545
42757, 0.23913043478261, 0.41086956521739, 0.22727272727273
42758, 0.21739130434783, 0.38478260869565, 0.22727272727273
42759, 0.21739130434783, 0.41086956521739, 0.25
42760, 0.23913043478261, 0.41086956521739, 0.27272727272727
42761, 0.21739130434783, 0.38478260869565, 0.27272727272727
42762, 0.21739130434783, 0.41086956521739, 0.29545454545455
42763, 0.23913043478261, 0.41086956521739, 0.31818181818182
42764, 0.21739130434783, 0.38478260869565, 0.31818181818182
42765, 0.21739130434783, 0.41086956521739, 0.34090909090909
42766, 0.23913043478261, 0.41086956521739, 0.36363636363636
42767, 0.21739130434783, 0.38478260869565, 0.36363636363636
42768, 0.21739130434783, 0.41086956521739, 0.38636363636364
42769, 0.23913043478261, 0.41086956521739, 0.40909090909091
42770, 0.21739130434783, 0.38478260869565, 0.40909090909091
42771, 0.21739130434783, 0.41086956521739, 0.43181818181818
42772, 0.23913043478261, 0.41086956521739, 0.45454545454545
42773, 0.21739130434783, 0.38478260869565, 0.45454545454545
42774, 0.21739130434783, 0.41086956521739, 0.47727272727273
42775, 0.17391304347826, 0.41086956521739, 0.022727272727273
42776, 0.19565217391304, 0.41086956521739, 0.045454545454545
42777, 0.17391304347826, 0.38478260869565, 0.045454545454545
42778, 0.17391304347826, 0.41086956521739, 0.068181818181818
42779, 0.19565217391304, 0.41086956521739, 0.090909090909091
42780, 0.17391304347826, 0.38478260869565, 0.090909090909091
42781, 0.17391304347826, 0.41086956521739, 0.11363636363636
42782, 0.19565217391304, 0.41086956521739, 0.13636363636364
42783, 0.17391304347826, 0.38478260869565, 0.13636363636364
42784, 0.17391304347826, 0.41086956521739, 0.15909090909091
42785, 0.19565217391304, 0.41086956521739, 0.18181818181818
42786, 0.17391304347826, 0.38478260869565, 0.18181818181818
42787, 0.17391304347826, 0.41086956521739, 0.20454545454545
42788, 0.19565217391304, 0.41086956521739, 0.22727272727273
42789, 0.17391304347826, 0.38478260869565, 0.22727272727273
42790, 0.17391304347826, 0.41086956521739, 0.25
42791, 0.19565217391304, 0.41086956521739, 0.27272727272727
42792, 0.17391304347826, 0.38478260869565, 0.27272727272727
42793, 0.17391304347826, 0.41086956521739, 0.29545454545455
42794, 0.19565217391304, 0.41086956521739, 0.31818181818182
42795, 0.17391304347826, 0.38478260869565, 0.31818181818182
42796, 0.17391304347826, 0.41086956521739, 0.34090909090909
42797, 0.19565217391304, 0.41086956521739, 0.36363636363636
42798, 0.17391304347826, 0.38478260869565, 0.36363636363636
42799, 0.17391304347826, 0.41086956521739, 0.38636363636364
42800, 0.19565217391304, 0.41086956521739, 0.40909090909091
42801, 0.17391304347826, 0.38478260869565, 0.40909090909091
42802, 0.17391304347826, 0.41086956521739, 0.43181818181818
42803, 0.19565217391304, 0.41086956521739, 0.45454545454545
42804, 0.17391304347826, 0.38478260869565, 0.45454545454545
42805, 0.17391304347826, 0.41086956521739, 0.47727272727273
42806, 0.1304347826087, 0.41086956521739, 0.022727272727273
42807, 0.15217391304348, 0.41086956521739, 0.045454545454545
42808, 0.1304347826087, 0.38478260869565, 0.045454545454545
42809, 0.1304347826087, 0.41086956521739, 0.068181818181818
42810, 0.15217391304348, 0.41086956521739, 0.090909090909091
42811, 0.1304347826087, 0.38478260869565, 0.090909090909091
42812, 0.1304347826087, 0.41086956521739, 0.11363636363636
42813, 0.15217391304348, 0.41086956521739, 0.13636363636364
42814, 0.1304347826087, 0.38478260869565, 0.13636363636364
42815, 0.1304347826087, 0.41086956521739, 0.15909090909091
42816, 0.15217391304348, 0.41086956521739, 0.18181818181818
42817, 0.1304347826087, 0.38478260869565, 0.18181818181818
42818, 0.1304347826087, 0.41086956521739, 0.20454545454545
42819, 0.15217391304348, 0.41086956521739, 0.22727272727273
42820, 0.1304347826087, 0.38478260869565, 0.22727272727273
42821, 0.1304347826087, 0.41086956521739, 0.25
42822, 0.15217391304348, 0.41086956521739, 0.27272727272727
42823, 0.1304347826087, 0.38478260869565, 0.27272727272727
42824, 0.1304347826087, 0.41086956521739, 0.29545454545455
42825, 0.15217391304348, 0.41086956521739, 0.31818181818182
42826, 0.1304347826087, 0.38478260869565, 0.31818181818182
42827, 0.1304347826087, 0.41086956521739, 0.34090909090909
42828, 0.15217391304348, 0.41086956521739, 0.36363636363636
42829, 0.1304347826087, 0.38478260869565, 0.36363636363636
42830, 0.1304347826087, 0.41086956521739, 0.38636363636364
42831, 0.15217391304348, 0.41086956521739, 0.40909090909091
42832, 0.1304347826087, 0.38478260869565, 0.40909090909091
42833, 0.1304347826087, 0.41086956521739, 0.43181818181818
42834, 0.15217391304348, 0.41086956521739, 0.45454545454545
42835, 0.1304347826087, 0.38478260869565, 0.45454545454545
42836, 0.1304347826087, 0.41086956521739, 0.47727272727273
42837, 0.08695652173913, 0.41086956521739, 0.022727272727273
42838, 0.10869565217391, 0.41086956521739, 0.045454545454545
42839, 0.08695652173913, 0.38478260869565, 0.045454545454545
42840, 0.08695652173913, 0.41086956521739, 0.068181818181818
42841, 0.10869565217391, 0.41086956521739, 0.090909090909091
42842, 0.08695652173913, 0.38478260869565, 0.090909090909091
42843, 0.08695652173913, 0.41086956521739, 0.11363636363636
42844, 0.10869565217391, 0.41086956521739, 0.13636363636364
42845, 0.08695652173913, 0.38478260869565, 0.13636363636364
42846, 0.08695652173913, 0.41086956521739, 0.15909090909091
42847, 0.10869565217391, 0.41086956521739, 0.18181818181818
42848, 0.08695652173913, 0.38478260869565, 0.18181818181818
42849, 0.08695652173913, 0.41086956521739, 0.20454545454545
42850, 0.10869565217391, 0.41086956521739, 0.22727272727273
42851, 0.08695652173913, 0.38478260869565, 0.22727272727273
42852, 0.08695652173913, 0.41086956521739, 0.25
42853, 0.10869565217391, 0.41086956521739, 0.27272727272727
42854, 0.08695652173913, 0.38478260869565, 0.27272727272727
42855, 0.08695652173913, 0.41086956521739, 0.29545454545455
42856, 0.10869565217391, 0.41086956521739, 0.31818181818182
42857, 0.08695652173913, 0.38478260869565, 0.31818181818182
42858, 0.08695652173913, 0.41086956521739, 0.34090909090909
42859, 0.10869565217391, 0.41086956521739, 0.36363636363636
42860, 0.08695652173913, 0.38478260869565, 0.36363636363636
42861, 0.08695652173913, 0.41086956521739, 0.38636363636364
42862, 0.10869565217391, 0.41086956521739, 0.40909090909091
42863, 0.08695652173913, 0.38478260869565, 0.40909090909091
42864, 0.08695652173913, 0.41086956521739, 0.43181818181818
42865, 0.10869565217391, 0.41086956521739, 0.45454545454545
42866, 0.08695652173913, 0.38478260869565, 0.45454545454545
42867, 0.08695652173913, 0.41086956521739, 0.47727272727273
42868, 0.043478260869565, 0.41086956521739, 0.022727272727273
42869, 0.065217391304348, 0.41086956521739, 0.045454545454545
42870, 0.043478260869565, 0.38478260869565, 0.045454545454545
42871, 0.043478260869565, 0.41086956521739, 0.068181818181818
42872, 0.065217391304348, 0.41086956521739, 0.090909090909091
42873, 0.043478260869565, 0.38478260869565, 0.090909090909091
42874, 0.043478260869565, 0.41086956521739, 0.11363636363636
42875, 0.065217391304348, 0.41086956521739, 0.13636363636364
42876, 0.043478260869565, 0.38478260869565, 0.13636363636364
42877, 0.043478260869565, 0.41086956521739, 0.15909090909091
42878, 0.065217391304348, 0.41086956521739, 0.18181818181818
42879, 0.043478260869565, 0.38478260869565, 0.18181818181818
42880, 0.043478260869565, 0.41086956521739, 0.20454545454545
42881, 0.065217391304348, 0.41086956521739, 0.22727272727273
42882, 0.043478260869565, 0.38478260869565, 0.22727272727273
42883, 0.043478260869565, 0.41086956521739, 0.25
42884, 0.065217391304348, 0.41086956521739, 0.27272727272727
42885, 0.043478260869565, 0.38478260869565, 0.27272727272727
42886, 0.043478260869565, 0.41086956521739, 0.29545454545455
42887, 0.065217391304348, 0.41086956521739, 0.31818181818182
42888, 0.043478260869565, 0.38478260869565, 0.31818181818182
42889, 0.043478260869565, 0.41086956521739, 0.34090909090909
42890, 0.065217391304348, 0.41086956521739, 0.36363636363636
42891, 0.043478260869565, 0.38478260869565, 0.36363636363636
42892, 0.043478260869565, 0.41086956521739, 0.38636363636364
42893, 0.065217391304348, 0.41086956521739, 0.40909090909091
42894, 0.043478260869565, 0.38478260869565, 0.40909090909091
42895, 0.043478260869565, 0.41086956521739, 0.43181818181818
42896, 0.065217391304348, 0.41086956521739, 0.45454545454545
42897, 0.043478260869565, 0.38478260869565, 0.45454545454545
42898, 0.043478260869565, 0.41086956521739, 0.47727272727273
42899, 0.021739130434783, 0.41086956521739, 0.045454545454545
42900, 0.021739130434783, 0.41086956521739, 0.090909090909091
42901, 0.021739130434783, 0.41086956521739, 0.13636363636364
42902, 0.021739130434783, 0.41086956521739, 0.18181818181818
42903, 0.021739130434783, 0.41086956521739, 0.22727272727273
42904, 0.021739130434783, 0.41086956521739, 0.27272727272727
42905, 0.021739130434783, 0.41086956521739, 0.31818181818182
42906, 0.021739130434783, 0.41086956521739, 0.36363636363636
42907, 0.021739130434783, 0.41086956521739, 0.40909090909091
42908, 0.021739130434783, 0.41086956521739, 0.45454545454545
42909, 0.95652173913043, 0.46304347826087, 0.022727272727273
42910, 0.97826086956522, 0.46304347826087, 0.045454545454545
42911, 0.95652173913043, 0.43695652173913, 0.045454545454545
42912, 0.95652173913043, 0.46304347826087, 0.068181818181818
42913, 0.97826086956522, 0.46304347826087, 0.090909090909091
42914, 0.95652173913043, 0.43695652173913, 0.090909090909091
42915, 0.95652173913043, 0.46304347826087, 0.11363636363636
42916, 0.97826086956522, 0.46304347826087, 0.13636363636364
42917, 0.95652173913044, 0.43695652173913, 0.13636363636364
42918, 0.95652173913044, 0.46304347826087, 0.15909090909091
42919, 0.97826086956522, 0.46304347826087, 0.18181818181818
42920, 0.95652173913044, 0.43695652173913, 0.18181818181818
42921, 0.95652173913044, 0.46304347826087, 0.20454545454545
42922, 0.97826086956522, 0.46304347826087, 0.22727272727273
42923, 0.95652173913044, 0.43695652173913, 0.22727272727273
42924, 0.95652173913044, 0.46304347826087, 0.25
42925, 0.97826086956522, 0.46304347826087, 0.27272727272727
42926, 0.95652173913044, 0.43695652173913, 0.27272727272727
42927, 0.95652173913044, 0.46304347826087, 0.29545454545455
42928, 0.97826086956522, 0.46304347826087, 0.31818181818182
42929, 0.95652173913044, 0.43695652173913, 0.31818181818182
42930, 0.95652173913043, 0.46304347826087, 0.34090909090909
42931, 0.97826086956522, 0.46304347826087, 0.36363636363636
42932, 0.95652173913043, 0.43695652173913, 0.36363636363636
42933, 0.95652173913043, 0.46304347826087, 0.38636363636364
42934, 0.97826086956522, 0.46304347826087, 0.40909090909091
42935, 0.95652173913043, 0.43695652173913, 0.40909090909091
42936, 0.95652173913043, 0.46304347826087, 0.43181818181818
42937, 0.97826086956522, 0.46304347826087, 0.45454545454545
42938, 0.95652173913044, 0.43695652173913, 0.45454545454545
42939, 0.95652173913043, 0.46304347826087, 0.47727272727273
42940, 0.91304347826087, 0.46304347826087, 0.022727272727273
42941, 0.93478260869565, 0.46304347826087, 0.045454545454545
42942, 0.91304347826087, 0.43695652173913, 0.045454545454545
42943, 0.91304347826087, 0.46304347826087, 0.068181818181818
42944, 0.93478260869565, 0.46304347826087, 0.090909090909091
42945, 0.91304347826087, 0.43695652173913, 0.090909090909091
42946, 0.91304347826087, 0.46304347826087, 0.11363636363636
42947, 0.93478260869565, 0.46304347826087, 0.13636363636364
42948, 0.91304347826087, 0.43695652173913, 0.13636363636364
42949, 0.91304347826087, 0.46304347826087, 0.15909090909091
42950, 0.93478260869565, 0.46304347826087, 0.18181818181818
42951, 0.91304347826087, 0.43695652173913, 0.18181818181818
42952, 0.91304347826087, 0.46304347826087, 0.20454545454545
42953, 0.93478260869565, 0.46304347826087, 0.22727272727273
42954, 0.91304347826087, 0.43695652173913, 0.22727272727273
42955, 0.91304347826087, 0.46304347826087, 0.25
42956, 0.93478260869565, 0.46304347826087, 0.27272727272727
42957, 0.91304347826087, 0.43695652173913, 0.27272727272727
42958, 0.91304347826087, 0.46304347826087, 0.29545454545455
42959, 0.93478260869565, 0.46304347826087, 0.31818181818182
42960, 0.91304347826087, 0.43695652173913, 0.31818181818182
42961, 0.91304347826087, 0.46304347826087, 0.34090909090909
42962, 0.93478260869565, 0.46304347826087, 0.36363636363636
42963, 0.91304347826087, 0.43695652173913, 0.36363636363636
42964, 0.91304347826087, 0.46304347826087, 0.38636363636364
42965, 0.93478260869565, 0.46304347826087, 0.40909090909091
42966, 0.91304347826087, 0.43695652173913, 0.40909090909091
42967, 0.91304347826087, 0.46304347826087, 0.43181818181818
42968, 0.93478260869565, 0.46304347826087, 0.45454545454545
42969, 0.91304347826087, 0.43695652173913, 0.45454545454545
42970, 0.91304347826087, 0.46304347826087, 0.47727272727273
42971, 0.8695652173913, 0.46304347826087, 0.022727272727273
42972, 0.89130434782609, 0.46304347826087, 0.045454545454545
42973, 0.8695652173913, 0.43695652173913, 0.045454545454545
42974, 0.8695652173913, 0.46304347826087, 0.068181818181818
42975, 0.89130434782609, 0.46304347826087, 0.090909090909091
42976, 0.8695652173913, 0.43695652173913, 0.090909090909091
42977, 0.8695652173913, 0.46304347826087, 0.11363636363636
42978, 0.89130434782609, 0.46304347826087, 0.13636363636364
42979, 0.8695652173913, 0.43695652173913, 0.13636363636364
42980, 0.8695652173913, 0.46304347826087, 0.15909090909091
42981, 0.89130434782609, 0.46304347826087, 0.18181818181818
42982, 0.8695652173913, 0.43695652173913, 0.18181818181818
42983, 0.8695652173913, 0.46304347826087, 0.20454545454545
42984, 0.89130434782609, 0.46304347826087, 0.22727272727273
42985, 0.8695652173913, 0.43695652173913, 0.22727272727273
42986, 0.8695652173913, 0.46304347826087, 0.25
42987, 0.89130434782609, 0.46304347826087, 0.27272727272727
42988, 0.8695652173913, 0.43695652173913, 0.27272727272727
42989, 0.8695652173913, 0.46304347826087, 0.29545454545455
42990, 0.89130434782609, 0.46304347826087, 0.31818181818182
42991, 0.8695652173913, 0.43695652173913, 0.31818181818182
42992, 0.8695652173913, 0.46304347826087, 0.34090909090909
42993, 0.89130434782609, 0.46304347826087, 0.36363636363636
42994, 0.8695652173913, 0.43695652173913, 0.36363636363636
42995, 0.8695652173913, 0.46304347826087, 0.38636363636364
42996, 0.89130434782609, 0.46304347826087, 0.40909090909091
42997, 0.8695652173913, 0.43695652173913, 0.40909090909091
42998, 0.8695652173913, 0.46304347826087, 0.43181818181818
42999, 0.89130434782609, 0.46304347826087, 0.45454545454545
43000, 0.8695652173913, 0.43695652173913, 0.45454545454545
43001, 0.8695652173913, 0.46304347826087, 0.47727272727273
43002, 0.82608695652174, 0.46304347826087, 0.022727272727273
43003, 0.84782608695652, 0.46304347826087, 0.045454545454545
43004, 0.82608695652174, 0.43695652173913, 0.045454545454545
43005, 0.82608695652174, 0.46304347826087, 0.068181818181818
43006, 0.84782608695652, 0.46304347826087, 0.090909090909091
43007, 0.82608695652174, 0.43695652173913, 0.090909090909091
43008, 0.82608695652174, 0.46304347826087, 0.11363636363636
43009, 0.84782608695652, 0.46304347826087, 0.13636363636364
43010, 0.82608695652174, 0.43695652173913, 0.13636363636364
43011, 0.82608695652174, 0.46304347826087, 0.15909090909091
43012, 0.84782608695652, 0.46304347826087, 0.18181818181818
43013, 0.82608695652174, 0.43695652173913, 0.18181818181818
43014, 0.82608695652174, 0.46304347826087, 0.20454545454545
43015, 0.84782608695652, 0.46304347826087, 0.22727272727273
43016, 0.82608695652174, 0.43695652173913, 0.22727272727273
43017, 0.82608695652174, 0.46304347826087, 0.25
43018, 0.84782608695652, 0.46304347826087, 0.27272727272727
43019, 0.82608695652174, 0.43695652173913, 0.27272727272727
43020, 0.82608695652174, 0.46304347826087, 0.29545454545455
43021, 0.84782608695652, 0.46304347826087, 0.31818181818182
43022, 0.82608695652174, 0.43695652173913, 0.31818181818182
43023, 0.82608695652174, 0.46304347826087, 0.34090909090909
43024, 0.84782608695652, 0.46304347826087, 0.36363636363636
43025, 0.82608695652174, 0.43695652173913, 0.36363636363636
43026, 0.82608695652174, 0.46304347826087, 0.38636363636364
43027, 0.84782608695652, 0.46304347826087, 0.40909090909091
43028, 0.82608695652174, 0.43695652173913, 0.40909090909091
43029, 0.82608695652174, 0.46304347826087, 0.43181818181818
43030, 0.84782608695652, 0.46304347826087, 0.45454545454545
43031, 0.82608695652174, 0.43695652173913, 0.45454545454545
43032, 0.82608695652174, 0.46304347826087, 0.47727272727273
43033, 0.78260869565217, 0.46304347826087, 0.022727272727273
43034, 0.80434782608696, 0.46304347826087, 0.045454545454545
43035, 0.78260869565217, 0.43695652173913, 0.045454545454545
43036, 0.78260869565217, 0.46304347826087, 0.068181818181818
43037, 0.80434782608696, 0.46304347826087, 0.090909090909091
43038, 0.78260869565217, 0.43695652173913, 0.090909090909091
43039, 0.78260869565217, 0.46304347826087, 0.11363636363636
43040, 0.80434782608696, 0.46304347826087, 0.13636363636364
43041, 0.78260869565217, 0.43695652173913, 0.13636363636364
43042, 0.78260869565217, 0.46304347826087, 0.15909090909091
43043, 0.80434782608696, 0.46304347826087, 0.18181818181818
43044, 0.78260869565217, 0.43695652173913, 0.18181818181818
43045, 0.78260869565217, 0.46304347826087, 0.20454545454545
43046, 0.80434782608696, 0.46304347826087, 0.22727272727273
43047, 0.78260869565217, 0.43695652173913, 0.22727272727273
43048, 0.78260869565217, 0.46304347826087, 0.25
43049, 0.80434782608696, 0.46304347826087, 0.27272727272727
43050, 0.78260869565217, 0.43695652173913, 0.27272727272727
43051, 0.78260869565217, 0.46304347826087, 0.29545454545455
43052, 0.80434782608696, 0.46304347826087, 0.31818181818182
43053, 0.78260869565217, 0.43695652173913, 0.31818181818182
43054, 0.78260869565217, 0.46304347826087, 0.34090909090909
43055, 0.80434782608696, 0.46304347826087, 0.36363636363636
43056, 0.78260869565217, 0.43695652173913, 0.36363636363636
43057, 0.78260869565217, 0.46304347826087, 0.38636363636364
43058, 0.80434782608696, 0.46304347826087, 0.40909090909091
43059, 0.78260869565217, 0.43695652173913, 0.40909090909091
43060, 0.78260869565217, 0.46304347826087, 0.43181818181818
43061, 0.80434782608696, 0.46304347826087, 0.45454545454545
43062, 0.78260869565217, 0.43695652173913, 0.45454545454545
43063, 0.78260869565217, 0.46304347826087, 0.47727272727273
43064, 0.73913043478261, 0.46304347826087, 0.022727272727273
43065, 0.76086956521739, 0.46304347826087, 0.045454545454545
43066, 0.73913043478261, 0.43695652173913, 0.045454545454545
43067, 0.73913043478261, 0.46304347826087, 0.068181818181818
43068, 0.76086956521739, 0.46304347826087, 0.090909090909091
43069, 0.73913043478261, 0.43695652173913, 0.090909090909091
43070, 0.73913043478261, 0.46304347826087, 0.11363636363636
43071, 0.76086956521739, 0.46304347826087, 0.13636363636364
43072, 0.73913043478261, 0.43695652173913, 0.13636363636364
43073, 0.73913043478261, 0.46304347826087, 0.15909090909091
43074, 0.76086956521739, 0.46304347826087, 0.18181818181818
43075, 0.73913043478261, 0.43695652173913, 0.18181818181818
43076, 0.73913043478261, 0.46304347826087, 0.20454545454545
43077, 0.76086956521739, 0.46304347826087, 0.22727272727273
43078, 0.73913043478261, 0.43695652173913, 0.22727272727273
43079, 0.73913043478261, 0.46304347826087, 0.25
43080, 0.76086956521739, 0.46304347826087, 0.27272727272727
43081, 0.73913043478261, 0.43695652173913, 0.27272727272727
43082, 0.73913043478261, 0.46304347826087, 0.29545454545455
43083, 0.76086956521739, 0.46304347826087, 0.31818181818182
43084, 0.73913043478261, 0.43695652173913, 0.31818181818182
43085, 0.73913043478261, 0.46304347826087, 0.34090909090909
43086, 0.76086956521739, 0.46304347826087, 0.36363636363636
43087, 0.73913043478261, 0.43695652173913, 0.36363636363636
43088, 0.73913043478261, 0.46304347826087, 0.38636363636364
43089, 0.76086956521739, 0.46304347826087, 0.40909090909091
43090, 0.73913043478261, 0.43695652173913, 0.40909090909091
43091, 0.73913043478261, 0.46304347826087, 0.43181818181818
43092, 0.76086956521739, 0.46304347826087, 0.45454545454545
43093, 0.73913043478261, 0.43695652173913, 0.45454545454545
43094, 0.73913043478261, 0.46304347826087, 0.47727272727273
43095, 0.69565217391304, 0.46304347826087, 0.022727272727273
43096, 0.71739130434783, 0.46304347826087, 0.045454545454545
43097, 0.69565217391304, 0.43695652173913, 0.045454545454545
43098, 0.69565217391304, 0.46304347826087, 0.068181818181818
43099, 0.71739130434783, 0.46304347826087, 0.090909090909091
43100, 0.69565217391304, 0.43695652173913, 0.090909090909091
43101, 0.69565217391304, 0.46304347826087, 0.11363636363636
43102, 0.71739130434783, 0.46304347826087, 0.13636363636364
43103, 0.69565217391304, 0.43695652173913, 0.13636363636364
43104, 0.69565217391304, 0.46304347826087, 0.15909090909091
43105, 0.71739130434783, 0.46304347826087, 0.18181818181818
43106, 0.69565217391304, 0.43695652173913, 0.18181818181818
43107, 0.69565217391304, 0.46304347826087, 0.20454545454545
43108, 0.71739130434783, 0.46304347826087, 0.22727272727273
43109, 0.69565217391304, 0.43695652173913, 0.22727272727273
43110, 0.69565217391304, 0.46304347826087, 0.25
43111, 0.71739130434783, 0.46304347826087, 0.27272727272727
43112, 0.69565217391304, 0.43695652173913, 0.27272727272727
43113, 0.69565217391304, 0.46304347826087, 0.29545454545455
43114, 0.71739130434783, 0.46304347826087, 0.31818181818182
43115, 0.69565217391304, 0.43695652173913, 0.31818181818182
43116, 0.69565217391304, 0.46304347826087, 0.34090909090909
43117, 0.71739130434783, 0.46304347826087, 0.36363636363636
43118, 0.69565217391304, 0.43695652173913, 0.36363636363636
43119, 0.69565217391304, 0.46304347826087, 0.38636363636364
43120, 0.71739130434783, 0.46304347826087, 0.40909090909091
43121, 0.69565217391304, 0.43695652173913, 0.40909090909091
43122, 0.69565217391304, 0.46304347826087, 0.43181818181818
43123, 0.71739130434783, 0.46304347826087, 0.45454545454545
43124, 0.69565217391304, 0.43695652173913, 0.45454545454545
43125, 0.69565217391304, 0.46304347826087, 0.47727272727273
43126, 0.65217391304348, 0.46304347826087, 0.022727272727273
43127, 0.67391304347826, 0.46304347826087, 0.045454545454545
43128, 0.65217391304348, 0.43695652173913, 0.045454545454545
43129, 0.65217391304348, 0.46304347826087, 0.068181818181818
43130, 0.67391304347826, 0.46304347826087, 0.090909090909091
43131, 0.65217391304348, 0.43695652173913, 0.090909090909091
43132, 0.65217391304348, 0.46304347826087, 0.11363636363636
43133, 0.67391304347826, 0.46304347826087, 0.13636363636364
43134, 0.65217391304348, 0.43695652173913, 0.13636363636364
43135, 0.65217391304348, 0.46304347826087, 0.15909090909091
43136, 0.67391304347826, 0.46304347826087, 0.18181818181818
43137, 0.65217391304348, 0.43695652173913, 0.18181818181818
43138, 0.65217391304348, 0.46304347826087, 0.20454545454545
43139, 0.67391304347826, 0.46304347826087, 0.22727272727273
