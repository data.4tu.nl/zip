89149, 1.8086956521739, 1.55, 0.45454545454545
89150, 1.8086956521739, 1.55, 0.40909090909091
89151, 1.8086956521739, 1.55, 0.36363636363636
89152, 1.8086956521739, 1.55, 0.31818181818182
89153, 1.8086956521739, 1.55, 0.27272727272727
89154, 1.8086956521739, 1.55, 0.22727272727273
89155, 1.8086956521739, 1.55, 0.18181818181818
89156, 1.8086956521739, 1.55, 0.13636363636364
89157, 1.8086956521739, 1.55, 0.090909090909091
89158, 1.8086956521739, 1.55, 0.045454545454545
89159, 1.8521739130435, 1.55, 0.45454545454545
89160, 1.8521739130435, 1.55, 0.40909090909091
89161, 1.8521739130435, 1.55, 0.36363636363636
89162, 1.8521739130435, 1.55, 0.31818181818182
89163, 1.8521739130435, 1.55, 0.27272727272727
89164, 1.8521739130435, 1.55, 0.22727272727273
89165, 1.8521739130435, 1.55, 0.18181818181818
89166, 1.8521739130435, 1.55, 0.13636363636364
89167, 1.8521739130435, 1.55, 0.090909090909091
89168, 1.8521739130435, 1.55, 0.045454545454545
89169, 1.895652173913, 1.55, 0.45454545454545
89170, 1.895652173913, 1.55, 0.40909090909091
89171, 1.895652173913, 1.55, 0.36363636363636
89172, 1.895652173913, 1.55, 0.31818181818182
89173, 1.895652173913, 1.55, 0.27272727272727
89174, 1.895652173913, 1.55, 0.22727272727273
89175, 1.895652173913, 1.55, 0.18181818181818
89176, 1.895652173913, 1.55, 0.13636363636364
89177, 1.895652173913, 1.55, 0.090909090909091
89178, 1.895652173913, 1.55, 0.045454545454545
89179, 1.9391304347826, 1.55, 0.45454545454545
89180, 1.9391304347826, 1.55, 0.40909090909091
89181, 1.9391304347826, 1.55, 0.36363636363636
89182, 1.9391304347826, 1.55, 0.31818181818182
89183, 1.9391304347826, 1.55, 0.27272727272727
89184, 1.9391304347826, 1.55, 0.22727272727273
89185, 1.9391304347826, 1.55, 0.18181818181818
89186, 1.9391304347826, 1.55, 0.13636363636364
89187, 1.9391304347826, 1.55, 0.090909090909091
89188, 1.9391304347826, 1.55, 0.045454545454545
89189, 1.9826086956522, 1.55, 0.45454545454545
89190, 1.9826086956522, 1.55, 0.40909090909091
89191, 1.9826086956522, 1.55, 0.36363636363636
89192, 1.9826086956522, 1.55, 0.31818181818182
89193, 1.9826086956522, 1.55, 0.27272727272727
89194, 1.9826086956522, 1.55, 0.22727272727273
89195, 1.9826086956522, 1.55, 0.18181818181818
89196, 1.9826086956522, 1.55, 0.13636363636364
89197, 1.9826086956522, 1.55, 0.090909090909091
89198, 1.9826086956522, 1.55, 0.045454545454545
89199, 2.0260869565217, 1.55, 0.45454545454545
89200, 2.0260869565217, 1.55, 0.40909090909091
89201, 2.0260869565217, 1.55, 0.36363636363636
89202, 2.0260869565217, 1.55, 0.31818181818182
89203, 2.0260869565217, 1.55, 0.27272727272727
89204, 2.0260869565217, 1.55, 0.22727272727273
89205, 2.0260869565217, 1.55, 0.18181818181818
89206, 2.0260869565217, 1.55, 0.13636363636364
89207, 2.0260869565217, 1.55, 0.090909090909091
89208, 2.0260869565217, 1.55, 0.045454545454545
89209, 2.0695652173913, 1.55, 0.45454545454545
89210, 2.0695652173913, 1.55, 0.40909090909091
89211, 2.0695652173913, 1.55, 0.36363636363636
89212, 2.0695652173913, 1.55, 0.31818181818182
89213, 2.0695652173913, 1.55, 0.27272727272727
89214, 2.0695652173913, 1.55, 0.22727272727273
89215, 2.0695652173913, 1.55, 0.18181818181818
89216, 2.0695652173913, 1.55, 0.13636363636364
89217, 2.0695652173913, 1.55, 0.090909090909091
89218, 2.0695652173913, 1.55, 0.045454545454545
89219, 2.1130434782609, 1.55, 0.45454545454545
89220, 2.1130434782609, 1.55, 0.40909090909091
89221, 2.1130434782609, 1.55, 0.36363636363636
89222, 2.1130434782609, 1.55, 0.31818181818182
89223, 2.1130434782609, 1.55, 0.27272727272727
89224, 2.1130434782609, 1.55, 0.22727272727273
89225, 2.1130434782609, 1.55, 0.18181818181818
89226, 2.1130434782609, 1.55, 0.13636363636364
89227, 2.1130434782609, 1.55, 0.090909090909091
89228, 2.1130434782609, 1.55, 0.045454545454545
89229, 2.1565217391304, 1.55, 0.45454545454545
89230, 2.1565217391304, 1.55, 0.40909090909091
89231, 2.1565217391304, 1.55, 0.36363636363636
89232, 2.1565217391304, 1.55, 0.31818181818182
89233, 2.1565217391304, 1.55, 0.27272727272727
89234, 2.1565217391304, 1.55, 0.22727272727273
89235, 2.1565217391304, 1.55, 0.18181818181818
89236, 2.1565217391304, 1.55, 0.13636363636364
89237, 2.1565217391304, 1.55, 0.090909090909091
89238, 2.1565217391304, 1.55, 0.045454545454545
89239, 1.2434782608696, 1.6, 0.45454545454545
89240, 1.2434782608696, 1.6, 0.40909090909091
89241, 1.2434782608696, 1.6, 0.36363636363636
89242, 1.2434782608696, 1.6, 0.31818181818182
89243, 1.2434782608696, 1.6, 0.27272727272727
89244, 1.2434782608696, 1.6, 0.22727272727273
89245, 1.2434782608696, 1.6, 0.18181818181818
89246, 1.2434782608696, 1.6, 0.13636363636364
89247, 1.2434782608696, 1.6, 0.090909090909091
89248, 1.2434782608696, 1.6, 0.045454545454545
89249, 1.2869565217391, 1.6, 0.45454545454545
89250, 1.2869565217391, 1.6, 0.40909090909091
89251, 1.2869565217391, 1.6, 0.36363636363636
89252, 1.2869565217391, 1.6, 0.31818181818182
89253, 1.2869565217391, 1.6, 0.27272727272727
89254, 1.2869565217391, 1.6, 0.22727272727273
89255, 1.2869565217391, 1.6, 0.18181818181818
89256, 1.2869565217391, 1.6, 0.13636363636364
89257, 1.2869565217391, 1.6, 0.090909090909091
89258, 1.2869565217391, 1.6, 0.045454545454545
89259, 1.3304347826087, 1.6, 0.45454545454545
89260, 1.3304347826087, 1.6, 0.40909090909091
89261, 1.3304347826087, 1.6, 0.36363636363636
89262, 1.3304347826087, 1.6, 0.31818181818182
89263, 1.3304347826087, 1.6, 0.27272727272727
89264, 1.3304347826087, 1.6, 0.22727272727273
89265, 1.3304347826087, 1.6, 0.18181818181818
89266, 1.3304347826087, 1.6, 0.13636363636364
89267, 1.3304347826087, 1.6, 0.090909090909091
89268, 1.3304347826087, 1.6, 0.045454545454545
89269, 1.3739130434783, 1.6, 0.45454545454545
89270, 1.3739130434783, 1.6, 0.40909090909091
89271, 1.3739130434783, 1.6, 0.36363636363636
89272, 1.3739130434783, 1.6, 0.31818181818182
89273, 1.3739130434783, 1.6, 0.27272727272727
89274, 1.3739130434783, 1.6, 0.22727272727273
89275, 1.3739130434783, 1.6, 0.18181818181818
89276, 1.3739130434783, 1.6, 0.13636363636364
89277, 1.3739130434783, 1.6, 0.090909090909091
89278, 1.3739130434783, 1.6, 0.045454545454545
89279, 1.4173913043478, 1.6, 0.45454545454545
89280, 1.4173913043478, 1.6, 0.40909090909091
89281, 1.4173913043478, 1.6, 0.36363636363636
89282, 1.4173913043478, 1.6, 0.31818181818182
89283, 1.4173913043478, 1.6, 0.27272727272727
89284, 1.4173913043478, 1.6, 0.22727272727273
89285, 1.4173913043478, 1.6, 0.18181818181818
89286, 1.4173913043478, 1.6, 0.13636363636364
89287, 1.4173913043478, 1.6, 0.090909090909091
89288, 1.4173913043478, 1.6, 0.045454545454545
89289, 1.4608695652174, 1.6, 0.45454545454545
89290, 1.4608695652174, 1.6, 0.40909090909091
89291, 1.4608695652174, 1.6, 0.36363636363636
89292, 1.4608695652174, 1.6, 0.31818181818182
89293, 1.4608695652174, 1.6, 0.27272727272727
89294, 1.4608695652174, 1.6, 0.22727272727273
89295, 1.4608695652174, 1.6, 0.18181818181818
89296, 1.4608695652174, 1.6, 0.13636363636364
89297, 1.4608695652174, 1.6, 0.090909090909091
89298, 1.4608695652174, 1.6, 0.045454545454545
89299, 1.504347826087, 1.6, 0.45454545454545
89300, 1.504347826087, 1.6, 0.40909090909091
89301, 1.504347826087, 1.6, 0.36363636363636
89302, 1.504347826087, 1.6, 0.31818181818182
89303, 1.504347826087, 1.6, 0.27272727272727
89304, 1.504347826087, 1.6, 0.22727272727273
89305, 1.504347826087, 1.6, 0.18181818181818
89306, 1.504347826087, 1.6, 0.13636363636364
89307, 1.504347826087, 1.6, 0.090909090909091
89308, 1.504347826087, 1.6, 0.045454545454545
89309, 1.5478260869565, 1.6, 0.45454545454545
89310, 1.5478260869565, 1.6, 0.40909090909091
89311, 1.5478260869565, 1.6, 0.36363636363636
89312, 1.5478260869565, 1.6, 0.31818181818182
89313, 1.5478260869565, 1.6, 0.27272727272727
89314, 1.5478260869565, 1.6, 0.22727272727273
89315, 1.5478260869565, 1.6, 0.18181818181818
89316, 1.5478260869565, 1.6, 0.13636363636364
89317, 1.5478260869565, 1.6, 0.090909090909091
89318, 1.5478260869565, 1.6, 0.045454545454545
89319, 1.5913043478261, 1.6, 0.45454545454545
89320, 1.5913043478261, 1.6, 0.40909090909091
89321, 1.5913043478261, 1.6, 0.36363636363636
89322, 1.5913043478261, 1.6, 0.31818181818182
89323, 1.5913043478261, 1.6, 0.27272727272727
89324, 1.5913043478261, 1.6, 0.22727272727273
89325, 1.5913043478261, 1.6, 0.18181818181818
89326, 1.5913043478261, 1.6, 0.13636363636364
89327, 1.5913043478261, 1.6, 0.090909090909091
89328, 1.5913043478261, 1.6, 0.045454545454545
89329, 1.6347826086957, 1.6, 0.45454545454545
89330, 1.6347826086957, 1.6, 0.40909090909091
89331, 1.6347826086957, 1.6, 0.36363636363636
89332, 1.6347826086957, 1.6, 0.31818181818182
89333, 1.6347826086957, 1.6, 0.27272727272727
89334, 1.6347826086957, 1.6, 0.22727272727273
89335, 1.6347826086957, 1.6, 0.18181818181818
89336, 1.6347826086957, 1.6, 0.13636363636364
89337, 1.6347826086957, 1.6, 0.090909090909091
89338, 1.6347826086957, 1.6, 0.045454545454545
89339, 1.6782608695652, 1.6, 0.45454545454545
89340, 1.6782608695652, 1.6, 0.40909090909091
89341, 1.6782608695652, 1.6, 0.36363636363636
89342, 1.6782608695652, 1.6, 0.31818181818182
89343, 1.6782608695652, 1.6, 0.27272727272727
89344, 1.6782608695652, 1.6, 0.22727272727273
89345, 1.6782608695652, 1.6, 0.18181818181818
89346, 1.6782608695652, 1.6, 0.13636363636364
89347, 1.6782608695652, 1.6, 0.090909090909091
89348, 1.6782608695652, 1.6, 0.045454545454545
89349, 1.7217391304348, 1.6, 0.45454545454545
89350, 1.7217391304348, 1.6, 0.40909090909091
89351, 1.7217391304348, 1.6, 0.36363636363636
89352, 1.7217391304348, 1.6, 0.31818181818182
89353, 1.7217391304348, 1.6, 0.27272727272727
89354, 1.7217391304348, 1.6, 0.22727272727273
89355, 1.7217391304348, 1.6, 0.18181818181818
89356, 1.7217391304348, 1.6, 0.13636363636364
89357, 1.7217391304348, 1.6, 0.090909090909091
89358, 1.7217391304348, 1.6, 0.045454545454545
89359, 1.7652173913043, 1.6, 0.45454545454545
89360, 1.7652173913043, 1.6, 0.40909090909091
89361, 1.7652173913043, 1.6, 0.36363636363636
89362, 1.7652173913043, 1.6, 0.31818181818182
89363, 1.7652173913043, 1.6, 0.27272727272727
89364, 1.7652173913043, 1.6, 0.22727272727273
89365, 1.7652173913043, 1.6, 0.18181818181818
89366, 1.7652173913043, 1.6, 0.13636363636364
89367, 1.7652173913043, 1.6, 0.090909090909091
89368, 1.7652173913043, 1.6, 0.045454545454545
89369, 1.8086956521739, 1.6, 0.45454545454545
89370, 1.8086956521739, 1.6, 0.40909090909091
89371, 1.8086956521739, 1.6, 0.36363636363636
89372, 1.8086956521739, 1.6, 0.31818181818182
89373, 1.8086956521739, 1.6, 0.27272727272727
89374, 1.8086956521739, 1.6, 0.22727272727273
89375, 1.8086956521739, 1.6, 0.18181818181818
89376, 1.8086956521739, 1.6, 0.13636363636364
89377, 1.8086956521739, 1.6, 0.090909090909091
89378, 1.8086956521739, 1.6, 0.045454545454545
89379, 1.8521739130435, 1.6, 0.45454545454545
89380, 1.8521739130435, 1.6, 0.40909090909091
89381, 1.8521739130435, 1.6, 0.36363636363636
89382, 1.8521739130435, 1.6, 0.31818181818182
89383, 1.8521739130435, 1.6, 0.27272727272727
89384, 1.8521739130435, 1.6, 0.22727272727273
89385, 1.8521739130435, 1.6, 0.18181818181818
89386, 1.8521739130435, 1.6, 0.13636363636364
89387, 1.8521739130435, 1.6, 0.090909090909091
89388, 1.8521739130435, 1.6, 0.045454545454545
89389, 1.895652173913, 1.6, 0.45454545454545
89390, 1.895652173913, 1.6, 0.40909090909091
89391, 1.895652173913, 1.6, 0.36363636363636
89392, 1.895652173913, 1.6, 0.31818181818182
89393, 1.895652173913, 1.6, 0.27272727272727
89394, 1.895652173913, 1.6, 0.22727272727273
89395, 1.895652173913, 1.6, 0.18181818181818
89396, 1.895652173913, 1.6, 0.13636363636364
89397, 1.895652173913, 1.6, 0.090909090909091
89398, 1.895652173913, 1.6, 0.045454545454545
89399, 1.9391304347826, 1.6, 0.45454545454545
89400, 1.9391304347826, 1.6, 0.40909090909091
89401, 1.9391304347826, 1.6, 0.36363636363636
89402, 1.9391304347826, 1.6, 0.31818181818182
89403, 1.9391304347826, 1.6, 0.27272727272727
89404, 1.9391304347826, 1.6, 0.22727272727273
89405, 1.9391304347826, 1.6, 0.18181818181818
89406, 1.9391304347826, 1.6, 0.13636363636364
89407, 1.9391304347826, 1.6, 0.090909090909091
89408, 1.9391304347826, 1.6, 0.045454545454545
89409, 1.9826086956522, 1.6, 0.45454545454545
89410, 1.9826086956522, 1.6, 0.40909090909091
89411, 1.9826086956522, 1.6, 0.36363636363636
89412, 1.9826086956522, 1.6, 0.31818181818182
89413, 1.9826086956522, 1.6, 0.27272727272727
89414, 1.9826086956522, 1.6, 0.22727272727273
89415, 1.9826086956522, 1.6, 0.18181818181818
89416, 1.9826086956522, 1.6, 0.13636363636364
89417, 1.9826086956522, 1.6, 0.090909090909091
89418, 1.9826086956522, 1.6, 0.045454545454545
89419, 2.0260869565217, 1.6, 0.45454545454545
89420, 2.0260869565217, 1.6, 0.40909090909091
89421, 2.0260869565217, 1.6, 0.36363636363636
89422, 2.0260869565217, 1.6, 0.31818181818182
89423, 2.0260869565217, 1.6, 0.27272727272727
89424, 2.0260869565217, 1.6, 0.22727272727273
89425, 2.0260869565217, 1.6, 0.18181818181818
89426, 2.0260869565217, 1.6, 0.13636363636364
89427, 2.0260869565217, 1.6, 0.090909090909091
89428, 2.0260869565217, 1.6, 0.045454545454545
89429, 2.0695652173913, 1.6, 0.45454545454545
89430, 2.0695652173913, 1.6, 0.40909090909091
89431, 2.0695652173913, 1.6, 0.36363636363636
89432, 2.0695652173913, 1.6, 0.31818181818182
89433, 2.0695652173913, 1.6, 0.27272727272727
89434, 2.0695652173913, 1.6, 0.22727272727273
89435, 2.0695652173913, 1.6, 0.18181818181818
89436, 2.0695652173913, 1.6, 0.13636363636364
89437, 2.0695652173913, 1.6, 0.090909090909091
89438, 2.0695652173913, 1.6, 0.045454545454545
89439, 2.1130434782609, 1.6, 0.45454545454545
89440, 2.1130434782609, 1.6, 0.40909090909091
89441, 2.1130434782609, 1.6, 0.36363636363636
89442, 2.1130434782609, 1.6, 0.31818181818182
89443, 2.1130434782609, 1.6, 0.27272727272727
89444, 2.1130434782609, 1.6, 0.22727272727273
89445, 2.1130434782609, 1.6, 0.18181818181818
89446, 2.1130434782609, 1.6, 0.13636363636364
89447, 2.1130434782609, 1.6, 0.090909090909091
89448, 2.1130434782609, 1.6, 0.045454545454545
89449, 2.1565217391304, 1.6, 0.45454545454545
89450, 2.1565217391304, 1.6, 0.40909090909091
89451, 2.1565217391304, 1.6, 0.36363636363636
89452, 2.1565217391304, 1.6, 0.31818181818182
89453, 2.1565217391304, 1.6, 0.27272727272727
89454, 2.1565217391304, 1.6, 0.22727272727273
89455, 2.1565217391304, 1.6, 0.18181818181818
89456, 2.1565217391304, 1.6, 0.13636363636364
89457, 2.1565217391304, 1.6, 0.090909090909091
89458, 2.1565217391304, 1.6, 0.045454545454545
89459, 1.2434782608696, 1.65, 0.45454545454545
89460, 1.2434782608696, 1.65, 0.40909090909091
89461, 1.2434782608696, 1.65, 0.36363636363636
89462, 1.2434782608696, 1.65, 0.31818181818182
89463, 1.2434782608696, 1.65, 0.27272727272727
89464, 1.2434782608696, 1.65, 0.22727272727273
89465, 1.2434782608696, 1.65, 0.18181818181818
89466, 1.2434782608696, 1.65, 0.13636363636364
89467, 1.2434782608696, 1.65, 0.090909090909091
89468, 1.2434782608696, 1.65, 0.045454545454545
89469, 1.2869565217391, 1.65, 0.45454545454545
89470, 1.2869565217391, 1.65, 0.40909090909091
89471, 1.2869565217391, 1.65, 0.36363636363636
89472, 1.2869565217391, 1.65, 0.31818181818182
89473, 1.2869565217391, 1.65, 0.27272727272727
89474, 1.2869565217391, 1.65, 0.22727272727273
89475, 1.2869565217391, 1.65, 0.18181818181818
89476, 1.2869565217391, 1.65, 0.13636363636364
89477, 1.2869565217391, 1.65, 0.090909090909091
89478, 1.2869565217391, 1.65, 0.045454545454545
89479, 1.3304347826087, 1.65, 0.45454545454545
89480, 1.3304347826087, 1.65, 0.40909090909091
89481, 1.3304347826087, 1.65, 0.36363636363636
89482, 1.3304347826087, 1.65, 0.31818181818182
89483, 1.3304347826087, 1.65, 0.27272727272727
89484, 1.3304347826087, 1.65, 0.22727272727273
89485, 1.3304347826087, 1.65, 0.18181818181818
89486, 1.3304347826087, 1.65, 0.13636363636364
89487, 1.3304347826087, 1.65, 0.090909090909091
89488, 1.3304347826087, 1.65, 0.045454545454545
89489, 1.3739130434783, 1.65, 0.45454545454545
89490, 1.3739130434783, 1.65, 0.40909090909091
89491, 1.3739130434783, 1.65, 0.36363636363636
89492, 1.3739130434783, 1.65, 0.31818181818182
89493, 1.3739130434783, 1.65, 0.27272727272727
89494, 1.3739130434783, 1.65, 0.22727272727273
89495, 1.3739130434783, 1.65, 0.18181818181818
89496, 1.3739130434783, 1.65, 0.13636363636364
89497, 1.3739130434783, 1.65, 0.090909090909091
89498, 1.3739130434783, 1.65, 0.045454545454545
89499, 1.4173913043478, 1.65, 0.45454545454545
89500, 1.4173913043478, 1.65, 0.40909090909091
89501, 1.4173913043478, 1.65, 0.36363636363636
89502, 1.4173913043478, 1.65, 0.31818181818182
89503, 1.4173913043478, 1.65, 0.27272727272727
89504, 1.4173913043478, 1.65, 0.22727272727273
89505, 1.4173913043478, 1.65, 0.18181818181818
89506, 1.4173913043478, 1.65, 0.13636363636364
89507, 1.4173913043478, 1.65, 0.090909090909091
89508, 1.4173913043478, 1.65, 0.045454545454545
89509, 1.4608695652174, 1.65, 0.45454545454545
89510, 1.4608695652174, 1.65, 0.40909090909091
89511, 1.4608695652174, 1.65, 0.36363636363636
89512, 1.4608695652174, 1.65, 0.31818181818182
89513, 1.4608695652174, 1.65, 0.27272727272727
89514, 1.4608695652174, 1.65, 0.22727272727273
89515, 1.4608695652174, 1.65, 0.18181818181818
89516, 1.4608695652174, 1.65, 0.13636363636364
89517, 1.4608695652174, 1.65, 0.090909090909091
89518, 1.4608695652174, 1.65, 0.045454545454545
89519, 1.504347826087, 1.65, 0.45454545454545
89520, 1.504347826087, 1.65, 0.40909090909091
89521, 1.504347826087, 1.65, 0.36363636363636
89522, 1.504347826087, 1.65, 0.31818181818182
89523, 1.504347826087, 1.65, 0.27272727272727
89524, 1.504347826087, 1.65, 0.22727272727273
89525, 1.504347826087, 1.65, 0.18181818181818
89526, 1.504347826087, 1.65, 0.13636363636364
89527, 1.504347826087, 1.65, 0.090909090909091
89528, 1.504347826087, 1.65, 0.045454545454545
89529, 1.5478260869565, 1.65, 0.45454545454545
89530, 1.5478260869565, 1.65, 0.40909090909091
89531, 1.5478260869565, 1.65, 0.36363636363636
89532, 1.5478260869565, 1.65, 0.31818181818182
89533, 1.5478260869565, 1.65, 0.27272727272727
89534, 1.5478260869565, 1.65, 0.22727272727273
89535, 1.5478260869565, 1.65, 0.18181818181818
89536, 1.5478260869565, 1.65, 0.13636363636364
89537, 1.5478260869565, 1.65, 0.090909090909091
89538, 1.5478260869565, 1.65, 0.045454545454545
89539, 1.5913043478261, 1.65, 0.45454545454545
89540, 1.5913043478261, 1.65, 0.40909090909091
89541, 1.5913043478261, 1.65, 0.36363636363636
89542, 1.5913043478261, 1.65, 0.31818181818182
89543, 1.5913043478261, 1.65, 0.27272727272727
89544, 1.5913043478261, 1.65, 0.22727272727273
89545, 1.5913043478261, 1.65, 0.18181818181818
89546, 1.5913043478261, 1.65, 0.13636363636364
89547, 1.5913043478261, 1.65, 0.090909090909091
89548, 1.5913043478261, 1.65, 0.045454545454545
89549, 1.6347826086957, 1.65, 0.45454545454545
89550, 1.6347826086957, 1.65, 0.40909090909091
89551, 1.6347826086957, 1.65, 0.36363636363636
89552, 1.6347826086957, 1.65, 0.31818181818182
89553, 1.6347826086957, 1.65, 0.27272727272727
89554, 1.6347826086957, 1.65, 0.22727272727273
89555, 1.6347826086957, 1.65, 0.18181818181818
89556, 1.6347826086957, 1.65, 0.13636363636364
89557, 1.6347826086957, 1.65, 0.090909090909091
89558, 1.6347826086957, 1.65, 0.045454545454545
89559, 1.6782608695652, 1.65, 0.45454545454545
89560, 1.6782608695652, 1.65, 0.40909090909091
89561, 1.6782608695652, 1.65, 0.36363636363636
89562, 1.6782608695652, 1.65, 0.31818181818182
89563, 1.6782608695652, 1.65, 0.27272727272727
89564, 1.6782608695652, 1.65, 0.22727272727273
89565, 1.6782608695652, 1.65, 0.18181818181818
89566, 1.6782608695652, 1.65, 0.13636363636364
89567, 1.6782608695652, 1.65, 0.090909090909091
89568, 1.6782608695652, 1.65, 0.045454545454545
89569, 1.7217391304348, 1.65, 0.45454545454545
89570, 1.7217391304348, 1.65, 0.40909090909091
89571, 1.7217391304348, 1.65, 0.36363636363636
89572, 1.7217391304348, 1.65, 0.31818181818182
89573, 1.7217391304348, 1.65, 0.27272727272727
89574, 1.7217391304348, 1.65, 0.22727272727273
89575, 1.7217391304348, 1.65, 0.18181818181818
89576, 1.7217391304348, 1.65, 0.13636363636364
89577, 1.7217391304348, 1.65, 0.090909090909091
89578, 1.7217391304348, 1.65, 0.045454545454545
89579, 1.7652173913043, 1.65, 0.45454545454545
89580, 1.7652173913043, 1.65, 0.40909090909091
89581, 1.7652173913043, 1.65, 0.36363636363636
89582, 1.7652173913043, 1.65, 0.31818181818182
89583, 1.7652173913043, 1.65, 0.27272727272727
89584, 1.7652173913043, 1.65, 0.22727272727273
89585, 1.7652173913043, 1.65, 0.18181818181818
89586, 1.7652173913043, 1.65, 0.13636363636364
89587, 1.7652173913043, 1.65, 0.090909090909091
89588, 1.7652173913043, 1.65, 0.045454545454545
89589, 1.8086956521739, 1.65, 0.45454545454545
89590, 1.8086956521739, 1.65, 0.40909090909091
89591, 1.8086956521739, 1.65, 0.36363636363636
89592, 1.8086956521739, 1.65, 0.31818181818182
89593, 1.8086956521739, 1.65, 0.27272727272727
89594, 1.8086956521739, 1.65, 0.22727272727273
89595, 1.8086956521739, 1.65, 0.18181818181818
89596, 1.8086956521739, 1.65, 0.13636363636364
89597, 1.8086956521739, 1.65, 0.090909090909091
89598, 1.8086956521739, 1.65, 0.045454545454545
89599, 1.8521739130435, 1.65, 0.45454545454545
89600, 1.8521739130435, 1.65, 0.40909090909091
89601, 1.8521739130435, 1.65, 0.36363636363636
89602, 1.8521739130435, 1.65, 0.31818181818182
89603, 1.8521739130435, 1.65, 0.27272727272727
89604, 1.8521739130435, 1.65, 0.22727272727273
89605, 1.8521739130435, 1.65, 0.18181818181818
89606, 1.8521739130435, 1.65, 0.13636363636364
89607, 1.8521739130435, 1.65, 0.090909090909091
89608, 1.8521739130435, 1.65, 0.045454545454545
89609, 1.895652173913, 1.65, 0.45454545454545
89610, 1.895652173913, 1.65, 0.40909090909091
89611, 1.895652173913, 1.65, 0.36363636363636
89612, 1.895652173913, 1.65, 0.31818181818182
89613, 1.895652173913, 1.65, 0.27272727272727
89614, 1.895652173913, 1.65, 0.22727272727273
89615, 1.895652173913, 1.65, 0.18181818181818
89616, 1.895652173913, 1.65, 0.13636363636364
89617, 1.895652173913, 1.65, 0.090909090909091
89618, 1.895652173913, 1.65, 0.045454545454545
89619, 1.9391304347826, 1.65, 0.45454545454545
89620, 1.9391304347826, 1.65, 0.40909090909091
89621, 1.9391304347826, 1.65, 0.36363636363636
89622, 1.9391304347826, 1.65, 0.31818181818182
89623, 1.9391304347826, 1.65, 0.27272727272727
89624, 1.9391304347826, 1.65, 0.22727272727273
89625, 1.9391304347826, 1.65, 0.18181818181818
89626, 1.9391304347826, 1.65, 0.13636363636364
89627, 1.9391304347826, 1.65, 0.090909090909091
89628, 1.9391304347826, 1.65, 0.045454545454545
89629, 1.9826086956522, 1.65, 0.45454545454545
89630, 1.9826086956522, 1.65, 0.40909090909091
89631, 1.9826086956522, 1.65, 0.36363636363636
89632, 1.9826086956522, 1.65, 0.31818181818182
89633, 1.9826086956522, 1.65, 0.27272727272727
89634, 1.9826086956522, 1.65, 0.22727272727273
89635, 1.9826086956522, 1.65, 0.18181818181818
89636, 1.9826086956522, 1.65, 0.13636363636364
89637, 1.9826086956522, 1.65, 0.090909090909091
89638, 1.9826086956522, 1.65, 0.045454545454545
89639, 2.0260869565217, 1.65, 0.45454545454545
89640, 2.0260869565217, 1.65, 0.40909090909091
89641, 2.0260869565217, 1.65, 0.36363636363636
89642, 2.0260869565217, 1.65, 0.31818181818182
89643, 2.0260869565217, 1.65, 0.27272727272727
89644, 2.0260869565217, 1.65, 0.22727272727273
89645, 2.0260869565217, 1.65, 0.18181818181818
89646, 2.0260869565217, 1.65, 0.13636363636364
89647, 2.0260869565217, 1.65, 0.090909090909091
89648, 2.0260869565217, 1.65, 0.045454545454545
89649, 2.0695652173913, 1.65, 0.45454545454545
89650, 2.0695652173913, 1.65, 0.40909090909091
89651, 2.0695652173913, 1.65, 0.36363636363636
89652, 2.0695652173913, 1.65, 0.31818181818182
89653, 2.0695652173913, 1.65, 0.27272727272727
89654, 2.0695652173913, 1.65, 0.22727272727273
89655, 2.0695652173913, 1.65, 0.18181818181818
89656, 2.0695652173913, 1.65, 0.13636363636364
89657, 2.0695652173913, 1.65, 0.090909090909091
89658, 2.0695652173913, 1.65, 0.045454545454545
89659, 2.1130434782609, 1.65, 0.45454545454545
89660, 2.1130434782609, 1.65, 0.40909090909091
89661, 2.1130434782609, 1.65, 0.36363636363636
89662, 2.1130434782609, 1.65, 0.31818181818182
89663, 2.1130434782609, 1.65, 0.27272727272727
89664, 2.1130434782609, 1.65, 0.22727272727273
89665, 2.1130434782609, 1.65, 0.18181818181818
89666, 2.1130434782609, 1.65, 0.13636363636364
89667, 2.1130434782609, 1.65, 0.090909090909091
89668, 2.1130434782609, 1.65, 0.045454545454545
89669, 2.1565217391304, 1.65, 0.45454545454545
89670, 2.1565217391304, 1.65, 0.40909090909091
89671, 2.1565217391304, 1.65, 0.36363636363636
89672, 2.1565217391304, 1.65, 0.31818181818182
89673, 2.1565217391304, 1.65, 0.27272727272727
89674, 2.1565217391304, 1.65, 0.22727272727273
89675, 2.1565217391304, 1.65, 0.18181818181818
89676, 2.1565217391304, 1.65, 0.13636363636364
89677, 2.1565217391304, 1.65, 0.090909090909091
89678, 2.1565217391304, 1.65, 0.045454545454545
89679, 1.2434782608696, 1.55, 0.47727272727273
89680, 1.2217391304348, 1.55, 0.45454545454545
89681, 1.2434782608696, 1.525, 0.45454545454545
89682, 1.2434782608696, 1.55, 0.43181818181818
89683, 1.2217391304348, 1.55, 0.40909090909091
89684, 1.2434782608696, 1.525, 0.40909090909091
89685, 1.2434782608696, 1.55, 0.38636363636364
89686, 1.2217391304348, 1.55, 0.36363636363636
89687, 1.2434782608696, 1.525, 0.36363636363636
89688, 1.2434782608696, 1.55, 0.34090909090909
89689, 1.2217391304348, 1.55, 0.31818181818182
89690, 1.2434782608696, 1.525, 0.31818181818182
89691, 1.2434782608696, 1.55, 0.29545454545455
89692, 1.2217391304348, 1.55, 0.27272727272727
89693, 1.2434782608696, 1.525, 0.27272727272727
89694, 1.2434782608696, 1.55, 0.25
89695, 1.2217391304348, 1.55, 0.22727272727273
89696, 1.2434782608696, 1.525, 0.22727272727273
89697, 1.2434782608696, 1.55, 0.20454545454545
89698, 1.2217391304348, 1.55, 0.18181818181818
89699, 1.2434782608696, 1.525, 0.18181818181818
89700, 1.2434782608696, 1.55, 0.15909090909091
89701, 1.2217391304348, 1.55, 0.13636363636364
89702, 1.2434782608696, 1.525, 0.13636363636364
89703, 1.2434782608696, 1.55, 0.11363636363636
89704, 1.2217391304348, 1.55, 0.090909090909091
89705, 1.2434782608696, 1.525, 0.090909090909091
89706, 1.2434782608696, 1.55, 0.068181818181818
89707, 1.2217391304348, 1.55, 0.045454545454545
89708, 1.2434782608696, 1.525, 0.045454545454545
89709, 1.2434782608696, 1.55, 0.022727272727273
89710, 1.2869565217391, 1.55, 0.47727272727273
89711, 1.2652173913043, 1.55, 0.45454545454545
89712, 1.2869565217391, 1.525, 0.45454545454545
89713, 1.2869565217391, 1.55, 0.43181818181818
89714, 1.2652173913043, 1.55, 0.40909090909091
89715, 1.2869565217391, 1.525, 0.40909090909091
89716, 1.2869565217391, 1.55, 0.38636363636364
89717, 1.2652173913043, 1.55, 0.36363636363636
89718, 1.2869565217391, 1.525, 0.36363636363636
89719, 1.2869565217391, 1.55, 0.34090909090909
89720, 1.2652173913043, 1.55, 0.31818181818182
89721, 1.2869565217391, 1.525, 0.31818181818182
89722, 1.2869565217391, 1.55, 0.29545454545455
89723, 1.2652173913043, 1.55, 0.27272727272727
89724, 1.2869565217391, 1.525, 0.27272727272727
89725, 1.2869565217391, 1.55, 0.25
89726, 1.2652173913043, 1.55, 0.22727272727273
89727, 1.2869565217391, 1.525, 0.22727272727273
89728, 1.2869565217391, 1.55, 0.20454545454545
89729, 1.2652173913043, 1.55, 0.18181818181818
89730, 1.2869565217391, 1.525, 0.18181818181818
89731, 1.2869565217391, 1.55, 0.15909090909091
89732, 1.2652173913043, 1.55, 0.13636363636364
89733, 1.2869565217391, 1.525, 0.13636363636364
89734, 1.2869565217391, 1.55, 0.11363636363636
89735, 1.2652173913043, 1.55, 0.090909090909091
89736, 1.2869565217391, 1.525, 0.090909090909091
89737, 1.2869565217391, 1.55, 0.068181818181818
89738, 1.2652173913043, 1.55, 0.045454545454545
89739, 1.2869565217391, 1.525, 0.045454545454545
89740, 1.2869565217391, 1.55, 0.022727272727273
89741, 1.3304347826087, 1.55, 0.47727272727273
89742, 1.3086956521739, 1.55, 0.45454545454545
89743, 1.3304347826087, 1.525, 0.45454545454545
89744, 1.3304347826087, 1.55, 0.43181818181818
89745, 1.3086956521739, 1.55, 0.40909090909091
89746, 1.3304347826087, 1.525, 0.40909090909091
89747, 1.3304347826087, 1.55, 0.38636363636364
89748, 1.3086956521739, 1.55, 0.36363636363636
89749, 1.3304347826087, 1.525, 0.36363636363636
89750, 1.3304347826087, 1.55, 0.34090909090909
89751, 1.3086956521739, 1.55, 0.31818181818182
89752, 1.3304347826087, 1.525, 0.31818181818182
89753, 1.3304347826087, 1.55, 0.29545454545455
89754, 1.3086956521739, 1.55, 0.27272727272727
89755, 1.3304347826087, 1.525, 0.27272727272727
89756, 1.3304347826087, 1.55, 0.25
89757, 1.3086956521739, 1.55, 0.22727272727273
89758, 1.3304347826087, 1.525, 0.22727272727273
89759, 1.3304347826087, 1.55, 0.20454545454545
89760, 1.3086956521739, 1.55, 0.18181818181818
89761, 1.3304347826087, 1.525, 0.18181818181818
89762, 1.3304347826087, 1.55, 0.15909090909091
89763, 1.3086956521739, 1.55, 0.13636363636364
89764, 1.3304347826087, 1.525, 0.13636363636364
89765, 1.3304347826087, 1.55, 0.11363636363636
89766, 1.3086956521739, 1.55, 0.090909090909091
89767, 1.3304347826087, 1.525, 0.090909090909091
89768, 1.3304347826087, 1.55, 0.068181818181818
89769, 1.3086956521739, 1.55, 0.045454545454545
89770, 1.3304347826087, 1.525, 0.045454545454545
89771, 1.3304347826087, 1.55, 0.022727272727273
89772, 1.3739130434783, 1.55, 0.47727272727273
89773, 1.3521739130435, 1.55, 0.45454545454545
89774, 1.3739130434783, 1.525, 0.45454545454545
89775, 1.3739130434783, 1.55, 0.43181818181818
89776, 1.3521739130435, 1.55, 0.40909090909091
89777, 1.3739130434783, 1.525, 0.40909090909091
89778, 1.3739130434783, 1.55, 0.38636363636364
89779, 1.3521739130435, 1.55, 0.36363636363636
89780, 1.3739130434783, 1.525, 0.36363636363636
89781, 1.3739130434783, 1.55, 0.34090909090909
89782, 1.3521739130435, 1.55, 0.31818181818182
89783, 1.3739130434783, 1.525, 0.31818181818182
89784, 1.3739130434783, 1.55, 0.29545454545455
89785, 1.3521739130435, 1.55, 0.27272727272727
89786, 1.3739130434783, 1.525, 0.27272727272727
89787, 1.3739130434783, 1.55, 0.25
89788, 1.3521739130435, 1.55, 0.22727272727273
89789, 1.3739130434783, 1.525, 0.22727272727273
89790, 1.3739130434783, 1.55, 0.20454545454545
89791, 1.3521739130435, 1.55, 0.18181818181818
89792, 1.3739130434783, 1.525, 0.18181818181818
89793, 1.3739130434783, 1.55, 0.15909090909091
89794, 1.3521739130435, 1.55, 0.13636363636364
89795, 1.3739130434783, 1.525, 0.13636363636364
89796, 1.3739130434783, 1.55, 0.11363636363636
89797, 1.3521739130435, 1.55, 0.090909090909091
89798, 1.3739130434783, 1.525, 0.090909090909091
89799, 1.3739130434783, 1.55, 0.068181818181818
89800, 1.3521739130435, 1.55, 0.045454545454545
89801, 1.3739130434783, 1.525, 0.045454545454545
89802, 1.3739130434783, 1.55, 0.022727272727273
89803, 1.4173913043478, 1.55, 0.47727272727273
89804, 1.395652173913, 1.55, 0.45454545454545
89805, 1.4173913043478, 1.525, 0.45454545454545
89806, 1.4173913043478, 1.55, 0.43181818181818
89807, 1.395652173913, 1.55, 0.40909090909091
89808, 1.4173913043478, 1.525, 0.40909090909091
89809, 1.4173913043478, 1.55, 0.38636363636364
89810, 1.395652173913, 1.55, 0.36363636363636
89811, 1.4173913043478, 1.525, 0.36363636363636
89812, 1.4173913043478, 1.55, 0.34090909090909
89813, 1.395652173913, 1.55, 0.31818181818182
89814, 1.4173913043478, 1.525, 0.31818181818182
89815, 1.4173913043478, 1.55, 0.29545454545455
89816, 1.395652173913, 1.55, 0.27272727272727
89817, 1.4173913043478, 1.525, 0.27272727272727
89818, 1.4173913043478, 1.55, 0.25
89819, 1.395652173913, 1.55, 0.22727272727273
89820, 1.4173913043478, 1.525, 0.22727272727273
89821, 1.4173913043478, 1.55, 0.20454545454545
89822, 1.395652173913, 1.55, 0.18181818181818
89823, 1.4173913043478, 1.525, 0.18181818181818
89824, 1.4173913043478, 1.55, 0.15909090909091
89825, 1.395652173913, 1.55, 0.13636363636364
89826, 1.4173913043478, 1.525, 0.13636363636364
89827, 1.4173913043478, 1.55, 0.11363636363636
89828, 1.395652173913, 1.55, 0.090909090909091
89829, 1.4173913043478, 1.525, 0.090909090909091
89830, 1.4173913043478, 1.55, 0.068181818181818
89831, 1.395652173913, 1.55, 0.045454545454545
89832, 1.4173913043478, 1.525, 0.045454545454545
89833, 1.4173913043478, 1.55, 0.022727272727273
89834, 1.4608695652174, 1.55, 0.47727272727273
89835, 1.4391304347826, 1.55, 0.45454545454545
89836, 1.4608695652174, 1.525, 0.45454545454545
89837, 1.4608695652174, 1.55, 0.43181818181818
89838, 1.4391304347826, 1.55, 0.40909090909091
89839, 1.4608695652174, 1.525, 0.40909090909091
89840, 1.4608695652174, 1.55, 0.38636363636364
89841, 1.4391304347826, 1.55, 0.36363636363636
89842, 1.4608695652174, 1.525, 0.36363636363636
89843, 1.4608695652174, 1.55, 0.34090909090909
89844, 1.4391304347826, 1.55, 0.31818181818182
89845, 1.4608695652174, 1.525, 0.31818181818182
89846, 1.4608695652174, 1.55, 0.29545454545455
89847, 1.4391304347826, 1.55, 0.27272727272727
89848, 1.4608695652174, 1.525, 0.27272727272727
89849, 1.4608695652174, 1.55, 0.25
89850, 1.4391304347826, 1.55, 0.22727272727273
89851, 1.4608695652174, 1.525, 0.22727272727273
89852, 1.4608695652174, 1.55, 0.20454545454545
89853, 1.4391304347826, 1.55, 0.18181818181818
89854, 1.4608695652174, 1.525, 0.18181818181818
89855, 1.4608695652174, 1.55, 0.15909090909091
89856, 1.4391304347826, 1.55, 0.13636363636364
89857, 1.4608695652174, 1.525, 0.13636363636364
89858, 1.4608695652174, 1.55, 0.11363636363636
89859, 1.4391304347826, 1.55, 0.090909090909091
89860, 1.4608695652174, 1.525, 0.090909090909091
89861, 1.4608695652174, 1.55, 0.068181818181818
89862, 1.4391304347826, 1.55, 0.045454545454545
89863, 1.4608695652174, 1.525, 0.045454545454545
89864, 1.4608695652174, 1.55, 0.022727272727273
89865, 1.504347826087, 1.55, 0.47727272727273
89866, 1.4826086956522, 1.55, 0.45454545454545
89867, 1.504347826087, 1.525, 0.45454545454545
89868, 1.504347826087, 1.55, 0.43181818181818
89869, 1.4826086956522, 1.55, 0.40909090909091
89870, 1.504347826087, 1.525, 0.40909090909091
89871, 1.504347826087, 1.55, 0.38636363636364
89872, 1.4826086956522, 1.55, 0.36363636363636
89873, 1.504347826087, 1.525, 0.36363636363636
89874, 1.504347826087, 1.55, 0.34090909090909
89875, 1.4826086956522, 1.55, 0.31818181818182
89876, 1.504347826087, 1.525, 0.31818181818182
89877, 1.504347826087, 1.55, 0.29545454545455
89878, 1.4826086956522, 1.55, 0.27272727272727
89879, 1.504347826087, 1.525, 0.27272727272727
89880, 1.504347826087, 1.55, 0.25
89881, 1.4826086956522, 1.55, 0.22727272727273
89882, 1.504347826087, 1.525, 0.22727272727273
89883, 1.504347826087, 1.55, 0.20454545454545
89884, 1.4826086956522, 1.55, 0.18181818181818
89885, 1.504347826087, 1.525, 0.18181818181818
89886, 1.504347826087, 1.55, 0.15909090909091
89887, 1.4826086956522, 1.55, 0.13636363636364
89888, 1.504347826087, 1.525, 0.13636363636364
89889, 1.504347826087, 1.55, 0.11363636363636
89890, 1.4826086956522, 1.55, 0.090909090909091
89891, 1.504347826087, 1.525, 0.090909090909091
89892, 1.504347826087, 1.55, 0.068181818181818
89893, 1.4826086956522, 1.55, 0.045454545454545
89894, 1.504347826087, 1.525, 0.045454545454545
89895, 1.504347826087, 1.55, 0.022727272727273
89896, 1.5478260869565, 1.55, 0.47727272727273
89897, 1.5260869565217, 1.55, 0.45454545454545
89898, 1.5478260869565, 1.525, 0.45454545454545
89899, 1.5478260869565, 1.55, 0.43181818181818
89900, 1.5260869565217, 1.55, 0.40909090909091
89901, 1.5478260869565, 1.525, 0.40909090909091
89902, 1.5478260869565, 1.55, 0.38636363636364
89903, 1.5260869565217, 1.55, 0.36363636363636
89904, 1.5478260869565, 1.525, 0.36363636363636
89905, 1.5478260869565, 1.55, 0.34090909090909
89906, 1.5260869565217, 1.55, 0.31818181818182
89907, 1.5478260869565, 1.525, 0.31818181818182
89908, 1.5478260869565, 1.55, 0.29545454545455
89909, 1.5260869565217, 1.55, 0.27272727272727
89910, 1.5478260869565, 1.525, 0.27272727272727
89911, 1.5478260869565, 1.55, 0.25
89912, 1.5260869565217, 1.55, 0.22727272727273
89913, 1.5478260869565, 1.525, 0.22727272727273
89914, 1.5478260869565, 1.55, 0.20454545454545
89915, 1.5260869565217, 1.55, 0.18181818181818
89916, 1.5478260869565, 1.525, 0.18181818181818
89917, 1.5478260869565, 1.55, 0.15909090909091
89918, 1.5260869565217, 1.55, 0.13636363636364
89919, 1.5478260869565, 1.525, 0.13636363636364
89920, 1.5478260869565, 1.55, 0.11363636363636
89921, 1.5260869565217, 1.55, 0.090909090909091
89922, 1.5478260869565, 1.525, 0.090909090909091
89923, 1.5478260869565, 1.55, 0.068181818181818
89924, 1.5260869565217, 1.55, 0.045454545454545
89925, 1.5478260869565, 1.525, 0.045454545454545
89926, 1.5478260869565, 1.55, 0.022727272727273
89927, 1.5913043478261, 1.55, 0.47727272727273
89928, 1.5695652173913, 1.55, 0.45454545454545
89929, 1.5913043478261, 1.525, 0.45454545454545
89930, 1.5913043478261, 1.55, 0.43181818181818
89931, 1.5695652173913, 1.55, 0.40909090909091
89932, 1.5913043478261, 1.525, 0.40909090909091
89933, 1.5913043478261, 1.55, 0.38636363636364
89934, 1.5695652173913, 1.55, 0.36363636363636
89935, 1.5913043478261, 1.525, 0.36363636363636
89936, 1.5913043478261, 1.55, 0.34090909090909
89937, 1.5695652173913, 1.55, 0.31818181818182
89938, 1.5913043478261, 1.525, 0.31818181818182
89939, 1.5913043478261, 1.55, 0.29545454545455
89940, 1.5695652173913, 1.55, 0.27272727272727
89941, 1.5913043478261, 1.525, 0.27272727272727
89942, 1.5913043478261, 1.55, 0.25
89943, 1.5695652173913, 1.55, 0.22727272727273
89944, 1.5913043478261, 1.525, 0.22727272727273
89945, 1.5913043478261, 1.55, 0.20454545454545
89946, 1.5695652173913, 1.55, 0.18181818181818
89947, 1.5913043478261, 1.525, 0.18181818181818
89948, 1.5913043478261, 1.55, 0.15909090909091
89949, 1.5695652173913, 1.55, 0.13636363636364
89950, 1.5913043478261, 1.525, 0.13636363636364
89951, 1.5913043478261, 1.55, 0.11363636363636
89952, 1.5695652173913, 1.55, 0.090909090909091
89953, 1.5913043478261, 1.525, 0.090909090909091
89954, 1.5913043478261, 1.55, 0.068181818181818
89955, 1.5695652173913, 1.55, 0.045454545454545
89956, 1.5913043478261, 1.525, 0.045454545454545
89957, 1.5913043478261, 1.55, 0.022727272727273
89958, 1.6347826086957, 1.55, 0.47727272727273
89959, 1.6130434782609, 1.55, 0.45454545454545
89960, 1.6347826086957, 1.525, 0.45454545454545
89961, 1.6347826086957, 1.55, 0.43181818181818
89962, 1.6130434782609, 1.55, 0.40909090909091
89963, 1.6347826086957, 1.525, 0.40909090909091
89964, 1.6347826086957, 1.55, 0.38636363636364
89965, 1.6130434782609, 1.55, 0.36363636363636
89966, 1.6347826086957, 1.525, 0.36363636363636
89967, 1.6347826086957, 1.55, 0.34090909090909
89968, 1.6130434782609, 1.55, 0.31818181818182
89969, 1.6347826086957, 1.525, 0.31818181818182
89970, 1.6347826086957, 1.55, 0.29545454545455
89971, 1.6130434782609, 1.55, 0.27272727272727
89972, 1.6347826086957, 1.525, 0.27272727272727
89973, 1.6347826086957, 1.55, 0.25
89974, 1.6130434782609, 1.55, 0.22727272727273
89975, 1.6347826086957, 1.525, 0.22727272727273
89976, 1.6347826086957, 1.55, 0.20454545454545
89977, 1.6130434782609, 1.55, 0.18181818181818
89978, 1.6347826086957, 1.525, 0.18181818181818
89979, 1.6347826086957, 1.55, 0.15909090909091
89980, 1.6130434782609, 1.55, 0.13636363636364
89981, 1.6347826086957, 1.525, 0.13636363636364
89982, 1.6347826086957, 1.55, 0.11363636363636
89983, 1.6130434782609, 1.55, 0.090909090909091
89984, 1.6347826086957, 1.525, 0.090909090909091
89985, 1.6347826086957, 1.55, 0.068181818181818
89986, 1.6130434782609, 1.55, 0.045454545454545
89987, 1.6347826086957, 1.525, 0.045454545454545
89988, 1.6347826086957, 1.55, 0.022727272727273
89989, 1.6782608695652, 1.55, 0.47727272727273
89990, 1.6565217391304, 1.55, 0.45454545454545
89991, 1.6782608695652, 1.525, 0.45454545454545
89992, 1.6782608695652, 1.55, 0.43181818181818
89993, 1.6565217391304, 1.55, 0.40909090909091
89994, 1.6782608695652, 1.525, 0.40909090909091
89995, 1.6782608695652, 1.55, 0.38636363636364
89996, 1.6565217391304, 1.55, 0.36363636363636
89997, 1.6782608695652, 1.525, 0.36363636363636
89998, 1.6782608695652, 1.55, 0.34090909090909
89999, 1.6565217391304, 1.55, 0.31818181818182
90000, 1.6782608695652, 1.525, 0.31818181818182
90001, 1.6782608695652, 1.55, 0.29545454545455
90002, 1.6565217391304, 1.55, 0.27272727272727
90003, 1.6782608695652, 1.525, 0.27272727272727
90004, 1.6782608695652, 1.55, 0.25
90005, 1.6565217391304, 1.55, 0.22727272727273
90006, 1.6782608695652, 1.525, 0.22727272727273
90007, 1.6782608695652, 1.55, 0.20454545454545
90008, 1.6565217391304, 1.55, 0.18181818181818
90009, 1.6782608695652, 1.525, 0.18181818181818
90010, 1.6782608695652, 1.55, 0.15909090909091
90011, 1.6565217391304, 1.55, 0.13636363636364
90012, 1.6782608695652, 1.525, 0.13636363636364
90013, 1.6782608695652, 1.55, 0.11363636363636
90014, 1.6565217391304, 1.55, 0.090909090909091
90015, 1.6782608695652, 1.525, 0.090909090909091
90016, 1.6782608695652, 1.55, 0.068181818181818
90017, 1.6565217391304, 1.55, 0.045454545454545
90018, 1.6782608695652, 1.525, 0.045454545454545
90019, 1.6782608695652, 1.55, 0.022727272727273
90020, 1.7217391304348, 1.55, 0.47727272727273
90021, 1.7, 1.55, 0.45454545454545
90022, 1.7217391304348, 1.525, 0.45454545454545
90023, 1.7217391304348, 1.55, 0.43181818181818
90024, 1.7, 1.55, 0.40909090909091
90025, 1.7217391304348, 1.525, 0.40909090909091
90026, 1.7217391304348, 1.55, 0.38636363636364
90027, 1.7, 1.55, 0.36363636363636
90028, 1.7217391304348, 1.525, 0.36363636363636
90029, 1.7217391304348, 1.55, 0.34090909090909
90030, 1.7, 1.55, 0.31818181818182
90031, 1.7217391304348, 1.525, 0.31818181818182
90032, 1.7217391304348, 1.55, 0.29545454545455
90033, 1.7, 1.55, 0.27272727272727
90034, 1.7217391304348, 1.525, 0.27272727272727
90035, 1.7217391304348, 1.55, 0.25
90036, 1.7, 1.55, 0.22727272727273
90037, 1.7217391304348, 1.525, 0.22727272727273
90038, 1.7217391304348, 1.55, 0.20454545454545
90039, 1.7, 1.55, 0.18181818181818
90040, 1.7217391304348, 1.525, 0.18181818181818
90041, 1.7217391304348, 1.55, 0.15909090909091
90042, 1.7, 1.55, 0.13636363636364
90043, 1.7217391304348, 1.525, 0.13636363636364
90044, 1.7217391304348, 1.55, 0.11363636363636
90045, 1.7, 1.55, 0.090909090909091
90046, 1.7217391304348, 1.525, 0.090909090909091
90047, 1.7217391304348, 1.55, 0.068181818181818
90048, 1.7, 1.55, 0.045454545454545
90049, 1.7217391304348, 1.525, 0.045454545454545
90050, 1.7217391304348, 1.55, 0.022727272727273
90051, 1.7652173913043, 1.55, 0.47727272727273
90052, 1.7434782608696, 1.55, 0.45454545454545
90053, 1.7652173913043, 1.525, 0.45454545454545
90054, 1.7652173913043, 1.55, 0.43181818181818
90055, 1.7434782608696, 1.55, 0.40909090909091
90056, 1.7652173913043, 1.525, 0.40909090909091
90057, 1.7652173913043, 1.55, 0.38636363636364
90058, 1.7434782608696, 1.55, 0.36363636363636
90059, 1.7652173913043, 1.525, 0.36363636363636
90060, 1.7652173913043, 1.55, 0.34090909090909
90061, 1.7434782608696, 1.55, 0.31818181818182
90062, 1.7652173913043, 1.525, 0.31818181818182
90063, 1.7652173913043, 1.55, 0.29545454545455
90064, 1.7434782608696, 1.55, 0.27272727272727
90065, 1.7652173913043, 1.525, 0.27272727272727
90066, 1.7652173913043, 1.55, 0.25
90067, 1.7434782608696, 1.55, 0.22727272727273
90068, 1.7652173913043, 1.525, 0.22727272727273
90069, 1.7652173913043, 1.55, 0.20454545454545
90070, 1.7434782608696, 1.55, 0.18181818181818
90071, 1.7652173913043, 1.525, 0.18181818181818
90072, 1.7652173913043, 1.55, 0.15909090909091
90073, 1.7434782608696, 1.55, 0.13636363636364
90074, 1.7652173913043, 1.525, 0.13636363636364
90075, 1.7652173913043, 1.55, 0.11363636363636
90076, 1.7434782608696, 1.55, 0.090909090909091
90077, 1.7652173913043, 1.525, 0.090909090909091
90078, 1.7652173913043, 1.55, 0.068181818181818
90079, 1.7434782608696, 1.55, 0.045454545454545
90080, 1.7652173913043, 1.525, 0.045454545454545
90081, 1.7652173913043, 1.55, 0.022727272727273
90082, 1.8086956521739, 1.55, 0.47727272727273
90083, 1.7869565217391, 1.55, 0.45454545454545
90084, 1.8086956521739, 1.525, 0.45454545454545
90085, 1.8086956521739, 1.55, 0.43181818181818
90086, 1.7869565217391, 1.55, 0.40909090909091
90087, 1.8086956521739, 1.525, 0.40909090909091
90088, 1.8086956521739, 1.55, 0.38636363636364
90089, 1.7869565217391, 1.55, 0.36363636363636
90090, 1.8086956521739, 1.525, 0.36363636363636
90091, 1.8086956521739, 1.55, 0.34090909090909
90092, 1.7869565217391, 1.55, 0.31818181818182
90093, 1.8086956521739, 1.525, 0.31818181818182
90094, 1.8086956521739, 1.55, 0.29545454545455
90095, 1.7869565217391, 1.55, 0.27272727272727
90096, 1.8086956521739, 1.525, 0.27272727272727
90097, 1.8086956521739, 1.55, 0.25
90098, 1.7869565217391, 1.55, 0.22727272727273
90099, 1.8086956521739, 1.525, 0.22727272727273
90100, 1.8086956521739, 1.55, 0.20454545454545
90101, 1.7869565217391, 1.55, 0.18181818181818
90102, 1.8086956521739, 1.525, 0.18181818181818
90103, 1.8086956521739, 1.55, 0.15909090909091
90104, 1.7869565217391, 1.55, 0.13636363636364
90105, 1.8086956521739, 1.525, 0.13636363636364
90106, 1.8086956521739, 1.55, 0.11363636363636
90107, 1.7869565217391, 1.55, 0.090909090909091
90108, 1.8086956521739, 1.525, 0.090909090909091
90109, 1.8086956521739, 1.55, 0.068181818181818
90110, 1.7869565217391, 1.55, 0.045454545454545
90111, 1.8086956521739, 1.525, 0.045454545454545
90112, 1.8086956521739, 1.55, 0.022727272727273
90113, 1.8521739130435, 1.55, 0.47727272727273
90114, 1.8304347826087, 1.55, 0.45454545454545
90115, 1.8521739130435, 1.525, 0.45454545454545
90116, 1.8521739130435, 1.55, 0.43181818181818
90117, 1.8304347826087, 1.55, 0.40909090909091
90118, 1.8521739130435, 1.525, 0.40909090909091
90119, 1.8521739130435, 1.55, 0.38636363636364
90120, 1.8304347826087, 1.55, 0.36363636363636
90121, 1.8521739130435, 1.525, 0.36363636363636
90122, 1.8521739130435, 1.55, 0.34090909090909
90123, 1.8304347826087, 1.55, 0.31818181818182
90124, 1.8521739130435, 1.525, 0.31818181818182
90125, 1.8521739130435, 1.55, 0.29545454545455
90126, 1.8304347826087, 1.55, 0.27272727272727
90127, 1.8521739130435, 1.525, 0.27272727272727
90128, 1.8521739130435, 1.55, 0.25
90129, 1.8304347826087, 1.55, 0.22727272727273
90130, 1.8521739130435, 1.525, 0.22727272727273
90131, 1.8521739130435, 1.55, 0.20454545454545
90132, 1.8304347826087, 1.55, 0.18181818181818
90133, 1.8521739130435, 1.525, 0.18181818181818
90134, 1.8521739130435, 1.55, 0.15909090909091
90135, 1.8304347826087, 1.55, 0.13636363636364
90136, 1.8521739130435, 1.525, 0.13636363636364
90137, 1.8521739130435, 1.55, 0.11363636363636
90138, 1.8304347826087, 1.55, 0.090909090909091
90139, 1.8521739130435, 1.525, 0.090909090909091
90140, 1.8521739130435, 1.55, 0.068181818181818
90141, 1.8304347826087, 1.55, 0.045454545454545
90142, 1.8521739130435, 1.525, 0.045454545454545
90143, 1.8521739130435, 1.55, 0.022727272727273
90144, 1.895652173913, 1.55, 0.47727272727273
90145, 1.8739130434783, 1.55, 0.45454545454545
90146, 1.895652173913, 1.525, 0.45454545454545
90147, 1.895652173913, 1.55, 0.43181818181818
90148, 1.8739130434783, 1.55, 0.40909090909091
90149, 1.895652173913, 1.525, 0.40909090909091
90150, 1.895652173913, 1.55, 0.38636363636364
90151, 1.8739130434783, 1.55, 0.36363636363636
90152, 1.895652173913, 1.525, 0.36363636363636
90153, 1.895652173913, 1.55, 0.34090909090909
90154, 1.8739130434783, 1.55, 0.31818181818182
90155, 1.895652173913, 1.525, 0.31818181818182
90156, 1.895652173913, 1.55, 0.29545454545455
90157, 1.8739130434783, 1.55, 0.27272727272727
90158, 1.895652173913, 1.525, 0.27272727272727
90159, 1.895652173913, 1.55, 0.25
90160, 1.8739130434783, 1.55, 0.22727272727273
90161, 1.895652173913, 1.525, 0.22727272727273
90162, 1.895652173913, 1.55, 0.20454545454545
90163, 1.8739130434783, 1.55, 0.18181818181818
90164, 1.895652173913, 1.525, 0.18181818181818
90165, 1.895652173913, 1.55, 0.15909090909091
90166, 1.8739130434783, 1.55, 0.13636363636364
90167, 1.895652173913, 1.525, 0.13636363636364
90168, 1.895652173913, 1.55, 0.11363636363636
90169, 1.8739130434783, 1.55, 0.090909090909091
90170, 1.895652173913, 1.525, 0.090909090909091
90171, 1.895652173913, 1.55, 0.068181818181818
90172, 1.8739130434783, 1.55, 0.045454545454545
90173, 1.895652173913, 1.525, 0.045454545454545
90174, 1.895652173913, 1.55, 0.022727272727273
90175, 1.9391304347826, 1.55, 0.47727272727273
90176, 1.9173913043478, 1.55, 0.45454545454545
90177, 1.9391304347826, 1.525, 0.45454545454545
90178, 1.9391304347826, 1.55, 0.43181818181818
90179, 1.9173913043478, 1.55, 0.40909090909091
90180, 1.9391304347826, 1.525, 0.40909090909091
90181, 1.9391304347826, 1.55, 0.38636363636364
90182, 1.9173913043478, 1.55, 0.36363636363636
90183, 1.9391304347826, 1.525, 0.36363636363636
90184, 1.9391304347826, 1.55, 0.34090909090909
90185, 1.9173913043478, 1.55, 0.31818181818182
90186, 1.9391304347826, 1.525, 0.31818181818182
90187, 1.9391304347826, 1.55, 0.29545454545455
90188, 1.9173913043478, 1.55, 0.27272727272727
90189, 1.9391304347826, 1.525, 0.27272727272727
90190, 1.9391304347826, 1.55, 0.25
90191, 1.9173913043478, 1.55, 0.22727272727273
90192, 1.9391304347826, 1.525, 0.22727272727273
90193, 1.9391304347826, 1.55, 0.20454545454545
90194, 1.9173913043478, 1.55, 0.18181818181818
90195, 1.9391304347826, 1.525, 0.18181818181818
90196, 1.9391304347826, 1.55, 0.15909090909091
90197, 1.9173913043478, 1.55, 0.13636363636364
90198, 1.9391304347826, 1.525, 0.13636363636364
90199, 1.9391304347826, 1.55, 0.11363636363636
90200, 1.9173913043478, 1.55, 0.090909090909091
90201, 1.9391304347826, 1.525, 0.090909090909091
90202, 1.9391304347826, 1.55, 0.068181818181818
90203, 1.9173913043478, 1.55, 0.045454545454545
90204, 1.9391304347826, 1.525, 0.045454545454545
90205, 1.9391304347826, 1.55, 0.022727272727273
90206, 1.9826086956522, 1.55, 0.47727272727273
90207, 1.9608695652174, 1.55, 0.45454545454545
90208, 1.9826086956522, 1.525, 0.45454545454545
90209, 1.9826086956522, 1.55, 0.43181818181818
90210, 1.9608695652174, 1.55, 0.40909090909091
90211, 1.9826086956522, 1.525, 0.40909090909091
90212, 1.9826086956522, 1.55, 0.38636363636364
90213, 1.9608695652174, 1.55, 0.36363636363636
90214, 1.9826086956522, 1.525, 0.36363636363636
90215, 1.9826086956522, 1.55, 0.34090909090909
90216, 1.9608695652174, 1.55, 0.31818181818182
90217, 1.9826086956522, 1.525, 0.31818181818182
90218, 1.9826086956522, 1.55, 0.29545454545455
90219, 1.9608695652174, 1.55, 0.27272727272727
90220, 1.9826086956522, 1.525, 0.27272727272727
90221, 1.9826086956522, 1.55, 0.25
90222, 1.9608695652174, 1.55, 0.22727272727273
90223, 1.9826086956522, 1.525, 0.22727272727273
90224, 1.9826086956522, 1.55, 0.20454545454545
90225, 1.9608695652174, 1.55, 0.18181818181818
90226, 1.9826086956522, 1.525, 0.18181818181818
90227, 1.9826086956522, 1.55, 0.15909090909091
90228, 1.9608695652174, 1.55, 0.13636363636364
90229, 1.9826086956522, 1.525, 0.13636363636364
90230, 1.9826086956522, 1.55, 0.11363636363636
90231, 1.9608695652174, 1.55, 0.090909090909091
90232, 1.9826086956522, 1.525, 0.090909090909091
90233, 1.9826086956522, 1.55, 0.068181818181818
90234, 1.9608695652174, 1.55, 0.045454545454545
90235, 1.9826086956522, 1.525, 0.045454545454545
90236, 1.9826086956522, 1.55, 0.022727272727273
90237, 2.0260869565217, 1.55, 0.47727272727273
90238, 2.004347826087, 1.55, 0.45454545454545
90239, 2.0260869565217, 1.525, 0.45454545454545
90240, 2.0260869565217, 1.55, 0.43181818181818
90241, 2.004347826087, 1.55, 0.40909090909091
90242, 2.0260869565217, 1.525, 0.40909090909091
90243, 2.0260869565217, 1.55, 0.38636363636364
90244, 2.004347826087, 1.55, 0.36363636363636
90245, 2.0260869565217, 1.525, 0.36363636363636
90246, 2.0260869565217, 1.55, 0.34090909090909
90247, 2.004347826087, 1.55, 0.31818181818182
90248, 2.0260869565217, 1.525, 0.31818181818182
90249, 2.0260869565217, 1.55, 0.29545454545455
90250, 2.004347826087, 1.55, 0.27272727272727
90251, 2.0260869565217, 1.525, 0.27272727272727
90252, 2.0260869565217, 1.55, 0.25
90253, 2.004347826087, 1.55, 0.22727272727273
90254, 2.0260869565217, 1.525, 0.22727272727273
90255, 2.0260869565217, 1.55, 0.20454545454545
90256, 2.004347826087, 1.55, 0.18181818181818
90257, 2.0260869565217, 1.525, 0.18181818181818
90258, 2.0260869565217, 1.55, 0.15909090909091
90259, 2.004347826087, 1.55, 0.13636363636364
90260, 2.0260869565217, 1.525, 0.13636363636364
90261, 2.0260869565217, 1.55, 0.11363636363636
90262, 2.004347826087, 1.55, 0.090909090909091
90263, 2.0260869565217, 1.525, 0.090909090909091
90264, 2.0260869565217, 1.55, 0.068181818181818
90265, 2.004347826087, 1.55, 0.045454545454545
90266, 2.0260869565217, 1.525, 0.045454545454545
90267, 2.0260869565217, 1.55, 0.022727272727273
90268, 2.0695652173913, 1.55, 0.47727272727273
90269, 2.0478260869565, 1.55, 0.45454545454545
90270, 2.0695652173913, 1.525, 0.45454545454545
90271, 2.0695652173913, 1.55, 0.43181818181818
90272, 2.0478260869565, 1.55, 0.40909090909091
90273, 2.0695652173913, 1.525, 0.40909090909091
90274, 2.0695652173913, 1.55, 0.38636363636364
90275, 2.0478260869565, 1.55, 0.36363636363636
90276, 2.0695652173913, 1.525, 0.36363636363636
90277, 2.0695652173913, 1.55, 0.34090909090909
90278, 2.0478260869565, 1.55, 0.31818181818182
90279, 2.0695652173913, 1.525, 0.31818181818182
90280, 2.0695652173913, 1.55, 0.29545454545455
90281, 2.0478260869565, 1.55, 0.27272727272727
90282, 2.0695652173913, 1.525, 0.27272727272727
90283, 2.0695652173913, 1.55, 0.25
90284, 2.0478260869565, 1.55, 0.22727272727273
90285, 2.0695652173913, 1.525, 0.22727272727273
90286, 2.0695652173913, 1.55, 0.20454545454545
90287, 2.0478260869565, 1.55, 0.18181818181818
90288, 2.0695652173913, 1.525, 0.18181818181818
90289, 2.0695652173913, 1.55, 0.15909090909091
90290, 2.0478260869565, 1.55, 0.13636363636364
90291, 2.0695652173913, 1.525, 0.13636363636364
90292, 2.0695652173913, 1.55, 0.11363636363636
90293, 2.0478260869565, 1.55, 0.090909090909091
90294, 2.0695652173913, 1.525, 0.090909090909091
90295, 2.0695652173913, 1.55, 0.068181818181818
90296, 2.0478260869565, 1.55, 0.045454545454545
90297, 2.0695652173913, 1.525, 0.045454545454545
90298, 2.0695652173913, 1.55, 0.022727272727273
90299, 2.1130434782609, 1.55, 0.47727272727273
90300, 2.0913043478261, 1.55, 0.45454545454545
90301, 2.1130434782609, 1.525, 0.45454545454545
90302, 2.1130434782609, 1.55, 0.43181818181818
90303, 2.0913043478261, 1.55, 0.40909090909091
90304, 2.1130434782609, 1.525, 0.40909090909091
90305, 2.1130434782609, 1.55, 0.38636363636364
90306, 2.0913043478261, 1.55, 0.36363636363636
90307, 2.1130434782609, 1.525, 0.36363636363636
90308, 2.1130434782609, 1.55, 0.34090909090909
90309, 2.0913043478261, 1.55, 0.31818181818182
90310, 2.1130434782609, 1.525, 0.31818181818182
90311, 2.1130434782609, 1.55, 0.29545454545455
90312, 2.0913043478261, 1.55, 0.27272727272727
90313, 2.1130434782609, 1.525, 0.27272727272727
90314, 2.1130434782609, 1.55, 0.25
90315, 2.0913043478261, 1.55, 0.22727272727273
90316, 2.1130434782609, 1.525, 0.22727272727273
90317, 2.1130434782609, 1.55, 0.20454545454545
90318, 2.0913043478261, 1.55, 0.18181818181818
90319, 2.1130434782609, 1.525, 0.18181818181818
90320, 2.1130434782609, 1.55, 0.15909090909091
90321, 2.0913043478261, 1.55, 0.13636363636364
90322, 2.1130434782609, 1.525, 0.13636363636364
90323, 2.1130434782609, 1.55, 0.11363636363636
90324, 2.0913043478261, 1.55, 0.090909090909091
90325, 2.1130434782609, 1.525, 0.090909090909091
90326, 2.1130434782609, 1.55, 0.068181818181818
90327, 2.0913043478261, 1.55, 0.045454545454545
90328, 2.1130434782609, 1.525, 0.045454545454545
90329, 2.1130434782609, 1.55, 0.022727272727273
90330, 2.1565217391304, 1.55, 0.47727272727273
90331, 2.1347826086957, 1.55, 0.45454545454545
90332, 2.1565217391304, 1.525, 0.45454545454545
90333, 2.1565217391304, 1.55, 0.43181818181818
90334, 2.1347826086957, 1.55, 0.40909090909091
90335, 2.1565217391304, 1.525, 0.40909090909091
90336, 2.1565217391304, 1.55, 0.38636363636364
90337, 2.1347826086957, 1.55, 0.36363636363636
90338, 2.1565217391304, 1.525, 0.36363636363636
90339, 2.1565217391304, 1.55, 0.34090909090909
90340, 2.1347826086957, 1.55, 0.31818181818182
90341, 2.1565217391304, 1.525, 0.31818181818182
90342, 2.1565217391304, 1.55, 0.29545454545455
90343, 2.1347826086957, 1.55, 0.27272727272727
90344, 2.1565217391304, 1.525, 0.27272727272727
90345, 2.1565217391304, 1.55, 0.25
90346, 2.1347826086957, 1.55, 0.22727272727273
90347, 2.1565217391304, 1.525, 0.22727272727273
90348, 2.1565217391304, 1.55, 0.20454545454545
90349, 2.1347826086957, 1.55, 0.18181818181818
90350, 2.1565217391304, 1.525, 0.18181818181818
90351, 2.1565217391304, 1.55, 0.15909090909091
90352, 2.1347826086957, 1.55, 0.13636363636364
90353, 2.1565217391304, 1.525, 0.13636363636364
90354, 2.1565217391304, 1.55, 0.11363636363636
90355, 2.1347826086957, 1.55, 0.090909090909091
90356, 2.1565217391304, 1.525, 0.090909090909091
90357, 2.1565217391304, 1.55, 0.068181818181818
90358, 2.1347826086957, 1.55, 0.045454545454545
90359, 2.1565217391304, 1.525, 0.045454545454545
90360, 2.1565217391304, 1.55, 0.022727272727273
90361, 2.1782608695652, 1.55, 0.45454545454545
90362, 2.1782608695652, 1.55, 0.40909090909091
90363, 2.1782608695652, 1.55, 0.36363636363636
90364, 2.1782608695652, 1.55, 0.31818181818182
90365, 2.1782608695652, 1.55, 0.27272727272727
90366, 2.1782608695652, 1.55, 0.22727272727273
90367, 2.1782608695652, 1.55, 0.18181818181818
90368, 2.1782608695652, 1.55, 0.13636363636364
90369, 2.1782608695652, 1.55, 0.090909090909091
90370, 2.1782608695652, 1.55, 0.045454545454545
90371, 1.2434782608696, 1.6, 0.47727272727273
90372, 1.2217391304348, 1.6, 0.45454545454545
90373, 1.2434782608696, 1.575, 0.45454545454545
90374, 1.2434782608696, 1.6, 0.43181818181818
90375, 1.2217391304348, 1.6, 0.40909090909091
90376, 1.2434782608696, 1.575, 0.40909090909091
90377, 1.2434782608696, 1.6, 0.38636363636364
90378, 1.2217391304348, 1.6, 0.36363636363636
90379, 1.2434782608696, 1.575, 0.36363636363636
90380, 1.2434782608696, 1.6, 0.34090909090909
90381, 1.2217391304348, 1.6, 0.31818181818182
90382, 1.2434782608696, 1.575, 0.31818181818182
90383, 1.2434782608696, 1.6, 0.29545454545455
90384, 1.2217391304348, 1.6, 0.27272727272727
90385, 1.2434782608696, 1.575, 0.27272727272727
90386, 1.2434782608696, 1.6, 0.25
90387, 1.2217391304348, 1.6, 0.22727272727273
90388, 1.2434782608696, 1.575, 0.22727272727273
90389, 1.2434782608696, 1.6, 0.20454545454545
90390, 1.2217391304348, 1.6, 0.18181818181818
90391, 1.2434782608696, 1.575, 0.18181818181818
90392, 1.2434782608696, 1.6, 0.15909090909091
90393, 1.2217391304348, 1.6, 0.13636363636364
90394, 1.2434782608696, 1.575, 0.13636363636364
90395, 1.2434782608696, 1.6, 0.11363636363636
90396, 1.2217391304348, 1.6, 0.090909090909091
90397, 1.2434782608696, 1.575, 0.090909090909091
90398, 1.2434782608696, 1.6, 0.068181818181818
90399, 1.2217391304348, 1.6, 0.045454545454545
90400, 1.2434782608696, 1.575, 0.045454545454545
90401, 1.2434782608696, 1.6, 0.022727272727273
90402, 1.2869565217391, 1.6, 0.47727272727273
90403, 1.2652173913043, 1.6, 0.45454545454545
90404, 1.2869565217391, 1.575, 0.45454545454545
90405, 1.2869565217391, 1.6, 0.43181818181818
90406, 1.2652173913043, 1.6, 0.40909090909091
90407, 1.2869565217391, 1.575, 0.40909090909091
90408, 1.2869565217391, 1.6, 0.38636363636364
90409, 1.2652173913043, 1.6, 0.36363636363636
90410, 1.2869565217391, 1.575, 0.36363636363636
90411, 1.2869565217391, 1.6, 0.34090909090909
90412, 1.2652173913043, 1.6, 0.31818181818182
90413, 1.2869565217391, 1.575, 0.31818181818182
90414, 1.2869565217391, 1.6, 0.29545454545455
90415, 1.2652173913043, 1.6, 0.27272727272727
90416, 1.2869565217391, 1.575, 0.27272727272727
90417, 1.2869565217391, 1.6, 0.25
90418, 1.2652173913043, 1.6, 0.22727272727273
90419, 1.2869565217391, 1.575, 0.22727272727273
90420, 1.2869565217391, 1.6, 0.20454545454545
90421, 1.2652173913043, 1.6, 0.18181818181818
90422, 1.2869565217391, 1.575, 0.18181818181818
90423, 1.2869565217391, 1.6, 0.15909090909091
90424, 1.2652173913043, 1.6, 0.13636363636364
90425, 1.2869565217391, 1.575, 0.13636363636364
90426, 1.2869565217391, 1.6, 0.11363636363636
90427, 1.2652173913043, 1.6, 0.090909090909091
90428, 1.2869565217391, 1.575, 0.090909090909091
90429, 1.2869565217391, 1.6, 0.068181818181818
90430, 1.2652173913043, 1.6, 0.045454545454545
90431, 1.2869565217391, 1.575, 0.045454545454545
90432, 1.2869565217391, 1.6, 0.022727272727273
90433, 1.3304347826087, 1.6, 0.47727272727273
90434, 1.3086956521739, 1.6, 0.45454545454545
90435, 1.3304347826087, 1.575, 0.45454545454545
90436, 1.3304347826087, 1.6, 0.43181818181818
90437, 1.3086956521739, 1.6, 0.40909090909091
90438, 1.3304347826087, 1.575, 0.40909090909091
90439, 1.3304347826087, 1.6, 0.38636363636364
90440, 1.3086956521739, 1.6, 0.36363636363636
90441, 1.3304347826087, 1.575, 0.36363636363636
90442, 1.3304347826087, 1.6, 0.34090909090909
90443, 1.3086956521739, 1.6, 0.31818181818182
90444, 1.3304347826087, 1.575, 0.31818181818182
90445, 1.3304347826087, 1.6, 0.29545454545455
90446, 1.3086956521739, 1.6, 0.27272727272727
90447, 1.3304347826087, 1.575, 0.27272727272727
90448, 1.3304347826087, 1.6, 0.25
90449, 1.3086956521739, 1.6, 0.22727272727273
90450, 1.3304347826087, 1.575, 0.22727272727273
90451, 1.3304347826087, 1.6, 0.20454545454545
90452, 1.3086956521739, 1.6, 0.18181818181818
90453, 1.3304347826087, 1.575, 0.18181818181818
90454, 1.3304347826087, 1.6, 0.15909090909091
90455, 1.3086956521739, 1.6, 0.13636363636364
90456, 1.3304347826087, 1.575, 0.13636363636364
90457, 1.3304347826087, 1.6, 0.11363636363636
90458, 1.3086956521739, 1.6, 0.090909090909091
90459, 1.3304347826087, 1.575, 0.090909090909091
90460, 1.3304347826087, 1.6, 0.068181818181818
90461, 1.3086956521739, 1.6, 0.045454545454545
90462, 1.3304347826087, 1.575, 0.045454545454545
90463, 1.3304347826087, 1.6, 0.022727272727273
90464, 1.3739130434783, 1.6, 0.47727272727273
90465, 1.3521739130435, 1.6, 0.45454545454545
90466, 1.3739130434783, 1.575, 0.45454545454545
90467, 1.3739130434783, 1.6, 0.43181818181818
90468, 1.3521739130435, 1.6, 0.40909090909091
90469, 1.3739130434783, 1.575, 0.40909090909091
90470, 1.3739130434783, 1.6, 0.38636363636364
90471, 1.3521739130435, 1.6, 0.36363636363636
90472, 1.3739130434783, 1.575, 0.36363636363636
90473, 1.3739130434783, 1.6, 0.34090909090909
90474, 1.3521739130435, 1.6, 0.31818181818182
90475, 1.3739130434783, 1.575, 0.31818181818182
90476, 1.3739130434783, 1.6, 0.29545454545455
90477, 1.3521739130435, 1.6, 0.27272727272727
90478, 1.3739130434783, 1.575, 0.27272727272727
90479, 1.3739130434783, 1.6, 0.25
90480, 1.3521739130435, 1.6, 0.22727272727273
90481, 1.3739130434783, 1.575, 0.22727272727273
90482, 1.3739130434783, 1.6, 0.20454545454545
90483, 1.3521739130435, 1.6, 0.18181818181818
90484, 1.3739130434783, 1.575, 0.18181818181818
90485, 1.3739130434783, 1.6, 0.15909090909091
90486, 1.3521739130435, 1.6, 0.13636363636364
90487, 1.3739130434783, 1.575, 0.13636363636364
90488, 1.3739130434783, 1.6, 0.11363636363636
90489, 1.3521739130435, 1.6, 0.090909090909091
90490, 1.3739130434783, 1.575, 0.090909090909091
90491, 1.3739130434783, 1.6, 0.068181818181818
90492, 1.3521739130435, 1.6, 0.045454545454545
90493, 1.3739130434783, 1.575, 0.045454545454545
90494, 1.3739130434783, 1.6, 0.022727272727273
90495, 1.4173913043478, 1.6, 0.47727272727273
90496, 1.395652173913, 1.6, 0.45454545454545
90497, 1.4173913043478, 1.575, 0.45454545454545
90498, 1.4173913043478, 1.6, 0.43181818181818
90499, 1.395652173913, 1.6, 0.40909090909091
90500, 1.4173913043478, 1.575, 0.40909090909091
90501, 1.4173913043478, 1.6, 0.38636363636364
90502, 1.395652173913, 1.6, 0.36363636363636
90503, 1.4173913043478, 1.575, 0.36363636363636
90504, 1.4173913043478, 1.6, 0.34090909090909
90505, 1.395652173913, 1.6, 0.31818181818182
90506, 1.4173913043478, 1.575, 0.31818181818182
90507, 1.4173913043478, 1.6, 0.29545454545455
90508, 1.395652173913, 1.6, 0.27272727272727
90509, 1.4173913043478, 1.575, 0.27272727272727
90510, 1.4173913043478, 1.6, 0.25
90511, 1.395652173913, 1.6, 0.22727272727273
90512, 1.4173913043478, 1.575, 0.22727272727273
90513, 1.4173913043478, 1.6, 0.20454545454545
90514, 1.395652173913, 1.6, 0.18181818181818
90515, 1.4173913043478, 1.575, 0.18181818181818
90516, 1.4173913043478, 1.6, 0.15909090909091
90517, 1.395652173913, 1.6, 0.13636363636364
90518, 1.4173913043478, 1.575, 0.13636363636364
90519, 1.4173913043478, 1.6, 0.11363636363636
90520, 1.395652173913, 1.6, 0.090909090909091
90521, 1.4173913043478, 1.575, 0.090909090909091
90522, 1.4173913043478, 1.6, 0.068181818181818
90523, 1.395652173913, 1.6, 0.045454545454545
90524, 1.4173913043478, 1.575, 0.045454545454545
90525, 1.4173913043478, 1.6, 0.022727272727273
90526, 1.4608695652174, 1.6, 0.47727272727273
90527, 1.4391304347826, 1.6, 0.45454545454545
90528, 1.4608695652174, 1.575, 0.45454545454545
90529, 1.4608695652174, 1.6, 0.43181818181818
90530, 1.4391304347826, 1.6, 0.40909090909091
90531, 1.4608695652174, 1.575, 0.40909090909091
90532, 1.4608695652174, 1.6, 0.38636363636364
90533, 1.4391304347826, 1.6, 0.36363636363636
90534, 1.4608695652174, 1.575, 0.36363636363636
90535, 1.4608695652174, 1.6, 0.34090909090909
90536, 1.4391304347826, 1.6, 0.31818181818182
90537, 1.4608695652174, 1.575, 0.31818181818182
90538, 1.4608695652174, 1.6, 0.29545454545455
90539, 1.4391304347826, 1.6, 0.27272727272727
90540, 1.4608695652174, 1.575, 0.27272727272727
90541, 1.4608695652174, 1.6, 0.25
90542, 1.4391304347826, 1.6, 0.22727272727273
90543, 1.4608695652174, 1.575, 0.22727272727273
90544, 1.4608695652174, 1.6, 0.20454545454545
90545, 1.4391304347826, 1.6, 0.18181818181818
90546, 1.4608695652174, 1.575, 0.18181818181818
90547, 1.4608695652174, 1.6, 0.15909090909091
90548, 1.4391304347826, 1.6, 0.13636363636364
90549, 1.4608695652174, 1.575, 0.13636363636364
90550, 1.4608695652174, 1.6, 0.11363636363636
90551, 1.4391304347826, 1.6, 0.090909090909091
90552, 1.4608695652174, 1.575, 0.090909090909091
90553, 1.4608695652174, 1.6, 0.068181818181818
90554, 1.4391304347826, 1.6, 0.045454545454545
90555, 1.4608695652174, 1.575, 0.045454545454545
90556, 1.4608695652174, 1.6, 0.022727272727273
90557, 1.504347826087, 1.6, 0.47727272727273
90558, 1.4826086956522, 1.6, 0.45454545454545
90559, 1.504347826087, 1.575, 0.45454545454545
90560, 1.504347826087, 1.6, 0.43181818181818
90561, 1.4826086956522, 1.6, 0.40909090909091
90562, 1.504347826087, 1.575, 0.40909090909091
90563, 1.504347826087, 1.6, 0.38636363636364
90564, 1.4826086956522, 1.6, 0.36363636363636
90565, 1.504347826087, 1.575, 0.36363636363636
90566, 1.504347826087, 1.6, 0.34090909090909
90567, 1.4826086956522, 1.6, 0.31818181818182
90568, 1.504347826087, 1.575, 0.31818181818182
90569, 1.504347826087, 1.6, 0.29545454545455
90570, 1.4826086956522, 1.6, 0.27272727272727
90571, 1.504347826087, 1.575, 0.27272727272727
90572, 1.504347826087, 1.6, 0.25
90573, 1.4826086956522, 1.6, 0.22727272727273
90574, 1.504347826087, 1.575, 0.22727272727273
90575, 1.504347826087, 1.6, 0.20454545454545
90576, 1.4826086956522, 1.6, 0.18181818181818
90577, 1.504347826087, 1.575, 0.18181818181818
90578, 1.504347826087, 1.6, 0.15909090909091
90579, 1.4826086956522, 1.6, 0.13636363636364
90580, 1.504347826087, 1.575, 0.13636363636364
90581, 1.504347826087, 1.6, 0.11363636363636
90582, 1.4826086956522, 1.6, 0.090909090909091
90583, 1.504347826087, 1.575, 0.090909090909091
90584, 1.504347826087, 1.6, 0.068181818181818
90585, 1.4826086956522, 1.6, 0.045454545454545
90586, 1.504347826087, 1.575, 0.045454545454545
90587, 1.504347826087, 1.6, 0.022727272727273
90588, 1.5478260869565, 1.6, 0.47727272727273
90589, 1.5260869565217, 1.6, 0.45454545454545
90590, 1.5478260869565, 1.575, 0.45454545454545
90591, 1.5478260869565, 1.6, 0.43181818181818
90592, 1.5260869565217, 1.6, 0.40909090909091
90593, 1.5478260869565, 1.575, 0.40909090909091
90594, 1.5478260869565, 1.6, 0.38636363636364
90595, 1.5260869565217, 1.6, 0.36363636363636
90596, 1.5478260869565, 1.575, 0.36363636363636
90597, 1.5478260869565, 1.6, 0.34090909090909
90598, 1.5260869565217, 1.6, 0.31818181818182
90599, 1.5478260869565, 1.575, 0.31818181818182
90600, 1.5478260869565, 1.6, 0.29545454545455
90601, 1.5260869565217, 1.6, 0.27272727272727
90602, 1.5478260869565, 1.575, 0.27272727272727
90603, 1.5478260869565, 1.6, 0.25
90604, 1.5260869565217, 1.6, 0.22727272727273
90605, 1.5478260869565, 1.575, 0.22727272727273
90606, 1.5478260869565, 1.6, 0.20454545454545
90607, 1.5260869565217, 1.6, 0.18181818181818
90608, 1.5478260869565, 1.575, 0.18181818181818
90609, 1.5478260869565, 1.6, 0.15909090909091
90610, 1.5260869565217, 1.6, 0.13636363636364
90611, 1.5478260869565, 1.575, 0.13636363636364
90612, 1.5478260869565, 1.6, 0.11363636363636
90613, 1.5260869565217, 1.6, 0.090909090909091
90614, 1.5478260869565, 1.575, 0.090909090909091
90615, 1.5478260869565, 1.6, 0.068181818181818
90616, 1.5260869565217, 1.6, 0.045454545454545
90617, 1.5478260869565, 1.575, 0.045454545454545
90618, 1.5478260869565, 1.6, 0.022727272727273
90619, 1.5913043478261, 1.6, 0.47727272727273
90620, 1.5695652173913, 1.6, 0.45454545454545
90621, 1.5913043478261, 1.575, 0.45454545454545
90622, 1.5913043478261, 1.6, 0.43181818181818
90623, 1.5695652173913, 1.6, 0.40909090909091
90624, 1.5913043478261, 1.575, 0.40909090909091
90625, 1.5913043478261, 1.6, 0.38636363636364
90626, 1.5695652173913, 1.6, 0.36363636363636
90627, 1.5913043478261, 1.575, 0.36363636363636
90628, 1.5913043478261, 1.6, 0.34090909090909
90629, 1.5695652173913, 1.6, 0.31818181818182
90630, 1.5913043478261, 1.575, 0.31818181818182
90631, 1.5913043478261, 1.6, 0.29545454545455
90632, 1.5695652173913, 1.6, 0.27272727272727
90633, 1.5913043478261, 1.575, 0.27272727272727
90634, 1.5913043478261, 1.6, 0.25
90635, 1.5695652173913, 1.6, 0.22727272727273
90636, 1.5913043478261, 1.575, 0.22727272727273
90637, 1.5913043478261, 1.6, 0.20454545454545
90638, 1.5695652173913, 1.6, 0.18181818181818
90639, 1.5913043478261, 1.575, 0.18181818181818
90640, 1.5913043478261, 1.6, 0.15909090909091
90641, 1.5695652173913, 1.6, 0.13636363636364
90642, 1.5913043478261, 1.575, 0.13636363636364
90643, 1.5913043478261, 1.6, 0.11363636363636
90644, 1.5695652173913, 1.6, 0.090909090909091
90645, 1.5913043478261, 1.575, 0.090909090909091
90646, 1.5913043478261, 1.6, 0.068181818181818
90647, 1.5695652173913, 1.6, 0.045454545454545
90648, 1.5913043478261, 1.575, 0.045454545454545
90649, 1.5913043478261, 1.6, 0.022727272727273
90650, 1.6347826086957, 1.6, 0.47727272727273
90651, 1.6130434782609, 1.6, 0.45454545454545
90652, 1.6347826086957, 1.575, 0.45454545454545
90653, 1.6347826086957, 1.6, 0.43181818181818
90654, 1.6130434782609, 1.6, 0.40909090909091
90655, 1.6347826086957, 1.575, 0.40909090909091
90656, 1.6347826086957, 1.6, 0.38636363636364
90657, 1.6130434782609, 1.6, 0.36363636363636
90658, 1.6347826086957, 1.575, 0.36363636363636
90659, 1.6347826086957, 1.6, 0.34090909090909
90660, 1.6130434782609, 1.6, 0.31818181818182
90661, 1.6347826086957, 1.575, 0.31818181818182
90662, 1.6347826086957, 1.6, 0.29545454545455
90663, 1.6130434782609, 1.6, 0.27272727272727
90664, 1.6347826086957, 1.575, 0.27272727272727
90665, 1.6347826086957, 1.6, 0.25
90666, 1.6130434782609, 1.6, 0.22727272727273
90667, 1.6347826086957, 1.575, 0.22727272727273
90668, 1.6347826086957, 1.6, 0.20454545454545
90669, 1.6130434782609, 1.6, 0.18181818181818
90670, 1.6347826086957, 1.575, 0.18181818181818
90671, 1.6347826086957, 1.6, 0.15909090909091
90672, 1.6130434782609, 1.6, 0.13636363636364
90673, 1.6347826086957, 1.575, 0.13636363636364
90674, 1.6347826086957, 1.6, 0.11363636363636
90675, 1.6130434782609, 1.6, 0.090909090909091
90676, 1.6347826086957, 1.575, 0.090909090909091
90677, 1.6347826086957, 1.6, 0.068181818181818
90678, 1.6130434782609, 1.6, 0.045454545454545
90679, 1.6347826086957, 1.575, 0.045454545454545
90680, 1.6347826086957, 1.6, 0.022727272727273
90681, 1.6782608695652, 1.6, 0.47727272727273
90682, 1.6565217391304, 1.6, 0.45454545454545
90683, 1.6782608695652, 1.575, 0.45454545454545
90684, 1.6782608695652, 1.6, 0.43181818181818
90685, 1.6565217391304, 1.6, 0.40909090909091
90686, 1.6782608695652, 1.575, 0.40909090909091
90687, 1.6782608695652, 1.6, 0.38636363636364
90688, 1.6565217391304, 1.6, 0.36363636363636
90689, 1.6782608695652, 1.575, 0.36363636363636
90690, 1.6782608695652, 1.6, 0.34090909090909
90691, 1.6565217391304, 1.6, 0.31818181818182
90692, 1.6782608695652, 1.575, 0.31818181818182
90693, 1.6782608695652, 1.6, 0.29545454545455
90694, 1.6565217391304, 1.6, 0.27272727272727
90695, 1.6782608695652, 1.575, 0.27272727272727
90696, 1.6782608695652, 1.6, 0.25
90697, 1.6565217391304, 1.6, 0.22727272727273
90698, 1.6782608695652, 1.575, 0.22727272727273
90699, 1.6782608695652, 1.6, 0.20454545454545
90700, 1.6565217391304, 1.6, 0.18181818181818
90701, 1.6782608695652, 1.575, 0.18181818181818
90702, 1.6782608695652, 1.6, 0.15909090909091
90703, 1.6565217391304, 1.6, 0.13636363636364
90704, 1.6782608695652, 1.575, 0.13636363636364
90705, 1.6782608695652, 1.6, 0.11363636363636
90706, 1.6565217391304, 1.6, 0.090909090909091
90707, 1.6782608695652, 1.575, 0.090909090909091
90708, 1.6782608695652, 1.6, 0.068181818181818
90709, 1.6565217391304, 1.6, 0.045454545454545
90710, 1.6782608695652, 1.575, 0.045454545454545
90711, 1.6782608695652, 1.6, 0.022727272727273
90712, 1.7217391304348, 1.6, 0.47727272727273
90713, 1.7, 1.6, 0.45454545454545
90714, 1.7217391304348, 1.575, 0.45454545454545
90715, 1.7217391304348, 1.6, 0.43181818181818
90716, 1.7, 1.6, 0.40909090909091
90717, 1.7217391304348, 1.575, 0.40909090909091
90718, 1.7217391304348, 1.6, 0.38636363636364
90719, 1.7, 1.6, 0.36363636363636
90720, 1.7217391304348, 1.575, 0.36363636363636
90721, 1.7217391304348, 1.6, 0.34090909090909
90722, 1.7, 1.6, 0.31818181818182
90723, 1.7217391304348, 1.575, 0.31818181818182
90724, 1.7217391304348, 1.6, 0.29545454545455
90725, 1.7, 1.6, 0.27272727272727
90726, 1.7217391304348, 1.575, 0.27272727272727
90727, 1.7217391304348, 1.6, 0.25
90728, 1.7, 1.6, 0.22727272727273
90729, 1.7217391304348, 1.575, 0.22727272727273
90730, 1.7217391304348, 1.6, 0.20454545454545
90731, 1.7, 1.6, 0.18181818181818
90732, 1.7217391304348, 1.575, 0.18181818181818
90733, 1.7217391304348, 1.6, 0.15909090909091
90734, 1.7, 1.6, 0.13636363636364
90735, 1.7217391304348, 1.575, 0.13636363636364
90736, 1.7217391304348, 1.6, 0.11363636363636
90737, 1.7, 1.6, 0.090909090909091
90738, 1.7217391304348, 1.575, 0.090909090909091
90739, 1.7217391304348, 1.6, 0.068181818181818
90740, 1.7, 1.6, 0.045454545454545
90741, 1.7217391304348, 1.575, 0.045454545454545
90742, 1.7217391304348, 1.6, 0.022727272727273
90743, 1.7652173913043, 1.6, 0.47727272727273
90744, 1.7434782608696, 1.6, 0.45454545454545
90745, 1.7652173913043, 1.575, 0.45454545454545
90746, 1.7652173913043, 1.6, 0.43181818181818
90747, 1.7434782608696, 1.6, 0.40909090909091
90748, 1.7652173913043, 1.575, 0.40909090909091
90749, 1.7652173913043, 1.6, 0.38636363636364
90750, 1.7434782608696, 1.6, 0.36363636363636
90751, 1.7652173913043, 1.575, 0.36363636363636
90752, 1.7652173913043, 1.6, 0.34090909090909
90753, 1.7434782608696, 1.6, 0.31818181818182
90754, 1.7652173913043, 1.575, 0.31818181818182
90755, 1.7652173913043, 1.6, 0.29545454545455
90756, 1.7434782608696, 1.6, 0.27272727272727
90757, 1.7652173913043, 1.575, 0.27272727272727
90758, 1.7652173913043, 1.6, 0.25
90759, 1.7434782608696, 1.6, 0.22727272727273
90760, 1.7652173913043, 1.575, 0.22727272727273
90761, 1.7652173913043, 1.6, 0.20454545454545
90762, 1.7434782608696, 1.6, 0.18181818181818
90763, 1.7652173913043, 1.575, 0.18181818181818
90764, 1.7652173913043, 1.6, 0.15909090909091
90765, 1.7434782608696, 1.6, 0.13636363636364
90766, 1.7652173913043, 1.575, 0.13636363636364
90767, 1.7652173913043, 1.6, 0.11363636363636
90768, 1.7434782608696, 1.6, 0.090909090909091
90769, 1.7652173913043, 1.575, 0.090909090909091
90770, 1.7652173913043, 1.6, 0.068181818181818
90771, 1.7434782608696, 1.6, 0.045454545454545
90772, 1.7652173913043, 1.575, 0.045454545454545
90773, 1.7652173913043, 1.6, 0.022727272727273
90774, 1.8086956521739, 1.6, 0.47727272727273
90775, 1.7869565217391, 1.6, 0.45454545454545
90776, 1.8086956521739, 1.575, 0.45454545454545
90777, 1.8086956521739, 1.6, 0.43181818181818
90778, 1.7869565217391, 1.6, 0.40909090909091
90779, 1.8086956521739, 1.575, 0.40909090909091
90780, 1.8086956521739, 1.6, 0.38636363636364
90781, 1.7869565217391, 1.6, 0.36363636363636
90782, 1.8086956521739, 1.575, 0.36363636363636
90783, 1.8086956521739, 1.6, 0.34090909090909
90784, 1.7869565217391, 1.6, 0.31818181818182
90785, 1.8086956521739, 1.575, 0.31818181818182
90786, 1.8086956521739, 1.6, 0.29545454545455
90787, 1.7869565217391, 1.6, 0.27272727272727
90788, 1.8086956521739, 1.575, 0.27272727272727
90789, 1.8086956521739, 1.6, 0.25
90790, 1.7869565217391, 1.6, 0.22727272727273
90791, 1.8086956521739, 1.575, 0.22727272727273
90792, 1.8086956521739, 1.6, 0.20454545454545
90793, 1.7869565217391, 1.6, 0.18181818181818
90794, 1.8086956521739, 1.575, 0.18181818181818
90795, 1.8086956521739, 1.6, 0.15909090909091
90796, 1.7869565217391, 1.6, 0.13636363636364
90797, 1.8086956521739, 1.575, 0.13636363636364
90798, 1.8086956521739, 1.6, 0.11363636363636
90799, 1.7869565217391, 1.6, 0.090909090909091
90800, 1.8086956521739, 1.575, 0.090909090909091
90801, 1.8086956521739, 1.6, 0.068181818181818
90802, 1.7869565217391, 1.6, 0.045454545454545
90803, 1.8086956521739, 1.575, 0.045454545454545
90804, 1.8086956521739, 1.6, 0.022727272727273
90805, 1.8521739130435, 1.6, 0.47727272727273
90806, 1.8304347826087, 1.6, 0.45454545454545
90807, 1.8521739130435, 1.575, 0.45454545454545
90808, 1.8521739130435, 1.6, 0.43181818181818
90809, 1.8304347826087, 1.6, 0.40909090909091
90810, 1.8521739130435, 1.575, 0.40909090909091
90811, 1.8521739130435, 1.6, 0.38636363636364
90812, 1.8304347826087, 1.6, 0.36363636363636
90813, 1.8521739130435, 1.575, 0.36363636363636
90814, 1.8521739130435, 1.6, 0.34090909090909
90815, 1.8304347826087, 1.6, 0.31818181818182
90816, 1.8521739130435, 1.575, 0.31818181818182
90817, 1.8521739130435, 1.6, 0.29545454545455
90818, 1.8304347826087, 1.6, 0.27272727272727
90819, 1.8521739130435, 1.575, 0.27272727272727
90820, 1.8521739130435, 1.6, 0.25
90821, 1.8304347826087, 1.6, 0.22727272727273
90822, 1.8521739130435, 1.575, 0.22727272727273
90823, 1.8521739130435, 1.6, 0.20454545454545
90824, 1.8304347826087, 1.6, 0.18181818181818
90825, 1.8521739130435, 1.575, 0.18181818181818
90826, 1.8521739130435, 1.6, 0.15909090909091
90827, 1.8304347826087, 1.6, 0.13636363636364
90828, 1.8521739130435, 1.575, 0.13636363636364
90829, 1.8521739130435, 1.6, 0.11363636363636
90830, 1.8304347826087, 1.6, 0.090909090909091
90831, 1.8521739130435, 1.575, 0.090909090909091
90832, 1.8521739130435, 1.6, 0.068181818181818
90833, 1.8304347826087, 1.6, 0.045454545454545
90834, 1.8521739130435, 1.575, 0.045454545454545
90835, 1.8521739130435, 1.6, 0.022727272727273
90836, 1.895652173913, 1.6, 0.47727272727273
90837, 1.8739130434783, 1.6, 0.45454545454545
90838, 1.895652173913, 1.575, 0.45454545454545
90839, 1.895652173913, 1.6, 0.43181818181818
90840, 1.8739130434783, 1.6, 0.40909090909091
90841, 1.895652173913, 1.575, 0.40909090909091
90842, 1.895652173913, 1.6, 0.38636363636364
90843, 1.8739130434783, 1.6, 0.36363636363636
90844, 1.895652173913, 1.575, 0.36363636363636
90845, 1.895652173913, 1.6, 0.34090909090909
90846, 1.8739130434783, 1.6, 0.31818181818182
90847, 1.895652173913, 1.575, 0.31818181818182
90848, 1.895652173913, 1.6, 0.29545454545455
90849, 1.8739130434783, 1.6, 0.27272727272727
90850, 1.895652173913, 1.575, 0.27272727272727
90851, 1.895652173913, 1.6, 0.25
90852, 1.8739130434783, 1.6, 0.22727272727273
90853, 1.895652173913, 1.575, 0.22727272727273
90854, 1.895652173913, 1.6, 0.20454545454545
90855, 1.8739130434783, 1.6, 0.18181818181818
90856, 1.895652173913, 1.575, 0.18181818181818
90857, 1.895652173913, 1.6, 0.15909090909091
90858, 1.8739130434783, 1.6, 0.13636363636364
90859, 1.895652173913, 1.575, 0.13636363636364
90860, 1.895652173913, 1.6, 0.11363636363636
90861, 1.8739130434783, 1.6, 0.090909090909091
90862, 1.895652173913, 1.575, 0.090909090909091
90863, 1.895652173913, 1.6, 0.068181818181818
90864, 1.8739130434783, 1.6, 0.045454545454545
90865, 1.895652173913, 1.575, 0.045454545454545
90866, 1.895652173913, 1.6, 0.022727272727273
90867, 1.9391304347826, 1.6, 0.47727272727273
90868, 1.9173913043478, 1.6, 0.45454545454545
90869, 1.9391304347826, 1.575, 0.45454545454545
90870, 1.9391304347826, 1.6, 0.43181818181818
90871, 1.9173913043478, 1.6, 0.40909090909091
90872, 1.9391304347826, 1.575, 0.40909090909091
90873, 1.9391304347826, 1.6, 0.38636363636364
90874, 1.9173913043478, 1.6, 0.36363636363636
90875, 1.9391304347826, 1.575, 0.36363636363636
90876, 1.9391304347826, 1.6, 0.34090909090909
90877, 1.9173913043478, 1.6, 0.31818181818182
90878, 1.9391304347826, 1.575, 0.31818181818182
90879, 1.9391304347826, 1.6, 0.29545454545455
90880, 1.9173913043478, 1.6, 0.27272727272727
90881, 1.9391304347826, 1.575, 0.27272727272727
90882, 1.9391304347826, 1.6, 0.25
90883, 1.9173913043478, 1.6, 0.22727272727273
90884, 1.9391304347826, 1.575, 0.22727272727273
90885, 1.9391304347826, 1.6, 0.20454545454545
90886, 1.9173913043478, 1.6, 0.18181818181818
90887, 1.9391304347826, 1.575, 0.18181818181818
90888, 1.9391304347826, 1.6, 0.15909090909091
90889, 1.9173913043478, 1.6, 0.13636363636364
90890, 1.9391304347826, 1.575, 0.13636363636364
90891, 1.9391304347826, 1.6, 0.11363636363636
90892, 1.9173913043478, 1.6, 0.090909090909091
90893, 1.9391304347826, 1.575, 0.090909090909091
90894, 1.9391304347826, 1.6, 0.068181818181818
90895, 1.9173913043478, 1.6, 0.045454545454545
90896, 1.9391304347826, 1.575, 0.045454545454545
90897, 1.9391304347826, 1.6, 0.022727272727273
90898, 1.9826086956522, 1.6, 0.47727272727273
90899, 1.9608695652174, 1.6, 0.45454545454545
90900, 1.9826086956522, 1.575, 0.45454545454545
90901, 1.9826086956522, 1.6, 0.43181818181818
90902, 1.9608695652174, 1.6, 0.40909090909091
90903, 1.9826086956522, 1.575, 0.40909090909091
90904, 1.9826086956522, 1.6, 0.38636363636364
90905, 1.9608695652174, 1.6, 0.36363636363636
90906, 1.9826086956522, 1.575, 0.36363636363636
90907, 1.9826086956522, 1.6, 0.34090909090909
90908, 1.9608695652174, 1.6, 0.31818181818182
90909, 1.9826086956522, 1.575, 0.31818181818182
90910, 1.9826086956522, 1.6, 0.29545454545455
90911, 1.9608695652174, 1.6, 0.27272727272727
90912, 1.9826086956522, 1.575, 0.27272727272727
90913, 1.9826086956522, 1.6, 0.25
90914, 1.9608695652174, 1.6, 0.22727272727273
90915, 1.9826086956522, 1.575, 0.22727272727273
90916, 1.9826086956522, 1.6, 0.20454545454545
90917, 1.9608695652174, 1.6, 0.18181818181818
90918, 1.9826086956522, 1.575, 0.18181818181818
90919, 1.9826086956522, 1.6, 0.15909090909091
90920, 1.9608695652174, 1.6, 0.13636363636364
90921, 1.9826086956522, 1.575, 0.13636363636364
90922, 1.9826086956522, 1.6, 0.11363636363636
90923, 1.9608695652174, 1.6, 0.090909090909091
90924, 1.9826086956522, 1.575, 0.090909090909091
90925, 1.9826086956522, 1.6, 0.068181818181818
90926, 1.9608695652174, 1.6, 0.045454545454545
90927, 1.9826086956522, 1.575, 0.045454545454545
90928, 1.9826086956522, 1.6, 0.022727272727273
90929, 2.0260869565217, 1.6, 0.47727272727273
90930, 2.004347826087, 1.6, 0.45454545454545
90931, 2.0260869565217, 1.575, 0.45454545454545
90932, 2.0260869565217, 1.6, 0.43181818181818
90933, 2.004347826087, 1.6, 0.40909090909091
90934, 2.0260869565217, 1.575, 0.40909090909091
90935, 2.0260869565217, 1.6, 0.38636363636364
90936, 2.004347826087, 1.6, 0.36363636363636
90937, 2.0260869565217, 1.575, 0.36363636363636
90938, 2.0260869565217, 1.6, 0.34090909090909
90939, 2.004347826087, 1.6, 0.31818181818182
90940, 2.0260869565217, 1.575, 0.31818181818182
90941, 2.0260869565217, 1.6, 0.29545454545455
90942, 2.004347826087, 1.6, 0.27272727272727
90943, 2.0260869565217, 1.575, 0.27272727272727
90944, 2.0260869565217, 1.6, 0.25
90945, 2.004347826087, 1.6, 0.22727272727273
90946, 2.0260869565217, 1.575, 0.22727272727273
90947, 2.0260869565217, 1.6, 0.20454545454545
90948, 2.004347826087, 1.6, 0.18181818181818
90949, 2.0260869565217, 1.575, 0.18181818181818
90950, 2.0260869565217, 1.6, 0.15909090909091
90951, 2.004347826087, 1.6, 0.13636363636364
90952, 2.0260869565217, 1.575, 0.13636363636364
90953, 2.0260869565217, 1.6, 0.11363636363636
90954, 2.004347826087, 1.6, 0.090909090909091
90955, 2.0260869565217, 1.575, 0.090909090909091
90956, 2.0260869565217, 1.6, 0.068181818181818
90957, 2.004347826087, 1.6, 0.045454545454545
90958, 2.0260869565217, 1.575, 0.045454545454545
90959, 2.0260869565217, 1.6, 0.022727272727273
90960, 2.0695652173913, 1.6, 0.47727272727273
90961, 2.0478260869565, 1.6, 0.45454545454545
90962, 2.0695652173913, 1.575, 0.45454545454545
90963, 2.0695652173913, 1.6, 0.43181818181818
90964, 2.0478260869565, 1.6, 0.40909090909091
90965, 2.0695652173913, 1.575, 0.40909090909091
90966, 2.0695652173913, 1.6, 0.38636363636364
90967, 2.0478260869565, 1.6, 0.36363636363636
90968, 2.0695652173913, 1.575, 0.36363636363636
90969, 2.0695652173913, 1.6, 0.34090909090909
90970, 2.0478260869565, 1.6, 0.31818181818182
90971, 2.0695652173913, 1.575, 0.31818181818182
90972, 2.0695652173913, 1.6, 0.29545454545455
90973, 2.0478260869565, 1.6, 0.27272727272727
90974, 2.0695652173913, 1.575, 0.27272727272727
90975, 2.0695652173913, 1.6, 0.25
90976, 2.0478260869565, 1.6, 0.22727272727273
90977, 2.0695652173913, 1.575, 0.22727272727273
90978, 2.0695652173913, 1.6, 0.20454545454545
90979, 2.0478260869565, 1.6, 0.18181818181818
90980, 2.0695652173913, 1.575, 0.18181818181818
90981, 2.0695652173913, 1.6, 0.15909090909091
90982, 2.0478260869565, 1.6, 0.13636363636364
90983, 2.0695652173913, 1.575, 0.13636363636364
90984, 2.0695652173913, 1.6, 0.11363636363636
90985, 2.0478260869565, 1.6, 0.090909090909091
90986, 2.0695652173913, 1.575, 0.090909090909091
90987, 2.0695652173913, 1.6, 0.068181818181818
90988, 2.0478260869565, 1.6, 0.045454545454545
90989, 2.0695652173913, 1.575, 0.045454545454545
90990, 2.0695652173913, 1.6, 0.022727272727273
90991, 2.1130434782609, 1.6, 0.47727272727273
90992, 2.0913043478261, 1.6, 0.45454545454545
90993, 2.1130434782609, 1.575, 0.45454545454545
90994, 2.1130434782609, 1.6, 0.43181818181818
90995, 2.0913043478261, 1.6, 0.40909090909091
90996, 2.1130434782609, 1.575, 0.40909090909091
90997, 2.1130434782609, 1.6, 0.38636363636364
90998, 2.0913043478261, 1.6, 0.36363636363636
90999, 2.1130434782609, 1.575, 0.36363636363636
91000, 2.1130434782609, 1.6, 0.34090909090909
91001, 2.0913043478261, 1.6, 0.31818181818182
91002, 2.1130434782609, 1.575, 0.31818181818182
91003, 2.1130434782609, 1.6, 0.29545454545455
91004, 2.0913043478261, 1.6, 0.27272727272727
91005, 2.1130434782609, 1.575, 0.27272727272727
91006, 2.1130434782609, 1.6, 0.25
91007, 2.0913043478261, 1.6, 0.22727272727273
91008, 2.1130434782609, 1.575, 0.22727272727273
91009, 2.1130434782609, 1.6, 0.20454545454545
91010, 2.0913043478261, 1.6, 0.18181818181818
91011, 2.1130434782609, 1.575, 0.18181818181818
91012, 2.1130434782609, 1.6, 0.15909090909091
91013, 2.0913043478261, 1.6, 0.13636363636364
91014, 2.1130434782609, 1.575, 0.13636363636364
91015, 2.1130434782609, 1.6, 0.11363636363636
91016, 2.0913043478261, 1.6, 0.090909090909091
91017, 2.1130434782609, 1.575, 0.090909090909091
91018, 2.1130434782609, 1.6, 0.068181818181818
91019, 2.0913043478261, 1.6, 0.045454545454545
91020, 2.1130434782609, 1.575, 0.045454545454545
91021, 2.1130434782609, 1.6, 0.022727272727273
91022, 2.1565217391304, 1.6, 0.47727272727273
91023, 2.1347826086957, 1.6, 0.45454545454545
91024, 2.1565217391304, 1.575, 0.45454545454545
91025, 2.1565217391304, 1.6, 0.43181818181818
91026, 2.1347826086957, 1.6, 0.40909090909091
91027, 2.1565217391304, 1.575, 0.40909090909091
91028, 2.1565217391304, 1.6, 0.38636363636364
91029, 2.1347826086957, 1.6, 0.36363636363636
91030, 2.1565217391304, 1.575, 0.36363636363636
91031, 2.1565217391304, 1.6, 0.34090909090909
91032, 2.1347826086957, 1.6, 0.31818181818182
91033, 2.1565217391304, 1.575, 0.31818181818182
91034, 2.1565217391304, 1.6, 0.29545454545455
91035, 2.1347826086957, 1.6, 0.27272727272727
91036, 2.1565217391304, 1.575, 0.27272727272727
91037, 2.1565217391304, 1.6, 0.25
91038, 2.1347826086957, 1.6, 0.22727272727273
91039, 2.1565217391304, 1.575, 0.22727272727273
91040, 2.1565217391304, 1.6, 0.20454545454545
91041, 2.1347826086957, 1.6, 0.18181818181818
91042, 2.1565217391304, 1.575, 0.18181818181818
91043, 2.1565217391304, 1.6, 0.15909090909091
91044, 2.1347826086957, 1.6, 0.13636363636364
91045, 2.1565217391304, 1.575, 0.13636363636364
91046, 2.1565217391304, 1.6, 0.11363636363636
91047, 2.1347826086957, 1.6, 0.090909090909091
91048, 2.1565217391304, 1.575, 0.090909090909091
91049, 2.1565217391304, 1.6, 0.068181818181818
91050, 2.1347826086957, 1.6, 0.045454545454545
91051, 2.1565217391304, 1.575, 0.045454545454545
91052, 2.1565217391304, 1.6, 0.022727272727273
91053, 2.1782608695652, 1.6, 0.45454545454545
91054, 2.1782608695652, 1.6, 0.40909090909091
91055, 2.1782608695652, 1.6, 0.36363636363636
91056, 2.1782608695652, 1.6, 0.31818181818182
91057, 2.1782608695652, 1.6, 0.27272727272727
91058, 2.1782608695652, 1.6, 0.22727272727273
91059, 2.1782608695652, 1.6, 0.18181818181818
91060, 2.1782608695652, 1.6, 0.13636363636364
91061, 2.1782608695652, 1.6, 0.090909090909091
91062, 2.1782608695652, 1.6, 0.045454545454545
91063, 1.2434782608696, 1.65, 0.47727272727273
91064, 1.2217391304348, 1.65, 0.45454545454545
91065, 1.2434782608696, 1.625, 0.45454545454545
91066, 1.2434782608696, 1.65, 0.43181818181818
91067, 1.2217391304348, 1.65, 0.40909090909091
91068, 1.2434782608696, 1.625, 0.40909090909091
91069, 1.2434782608696, 1.65, 0.38636363636364
91070, 1.2217391304348, 1.65, 0.36363636363636
91071, 1.2434782608696, 1.625, 0.36363636363636
91072, 1.2434782608696, 1.65, 0.34090909090909
91073, 1.2217391304348, 1.65, 0.31818181818182
91074, 1.2434782608696, 1.625, 0.31818181818182
91075, 1.2434782608696, 1.65, 0.29545454545455
91076, 1.2217391304348, 1.65, 0.27272727272727
91077, 1.2434782608696, 1.625, 0.27272727272727
91078, 1.2434782608696, 1.65, 0.25
91079, 1.2217391304348, 1.65, 0.22727272727273
91080, 1.2434782608696, 1.625, 0.22727272727273
91081, 1.2434782608696, 1.65, 0.20454545454545
91082, 1.2217391304348, 1.65, 0.18181818181818
91083, 1.2434782608696, 1.625, 0.18181818181818
91084, 1.2434782608696, 1.65, 0.15909090909091
91085, 1.2217391304348, 1.65, 0.13636363636364
91086, 1.2434782608696, 1.625, 0.13636363636364
91087, 1.2434782608696, 1.65, 0.11363636363636
91088, 1.2217391304348, 1.65, 0.090909090909091
91089, 1.2434782608696, 1.625, 0.090909090909091
91090, 1.2434782608696, 1.65, 0.068181818181818
91091, 1.2217391304348, 1.65, 0.045454545454545
91092, 1.2434782608696, 1.625, 0.045454545454545
91093, 1.2434782608696, 1.65, 0.022727272727273
91094, 1.2869565217391, 1.65, 0.47727272727273
91095, 1.2652173913043, 1.65, 0.45454545454545
91096, 1.2869565217391, 1.625, 0.45454545454545
91097, 1.2869565217391, 1.65, 0.43181818181818
91098, 1.2652173913043, 1.65, 0.40909090909091
91099, 1.2869565217391, 1.625, 0.40909090909091
91100, 1.2869565217391, 1.65, 0.38636363636364
91101, 1.2652173913043, 1.65, 0.36363636363636
91102, 1.2869565217391, 1.625, 0.36363636363636
91103, 1.2869565217391, 1.65, 0.34090909090909
91104, 1.2652173913043, 1.65, 0.31818181818182
91105, 1.2869565217391, 1.625, 0.31818181818182
91106, 1.2869565217391, 1.65, 0.29545454545455
91107, 1.2652173913043, 1.65, 0.27272727272727
91108, 1.2869565217391, 1.625, 0.27272727272727
91109, 1.2869565217391, 1.65, 0.25
91110, 1.2652173913043, 1.65, 0.22727272727273
91111, 1.2869565217391, 1.625, 0.22727272727273
91112, 1.2869565217391, 1.65, 0.20454545454545
91113, 1.2652173913043, 1.65, 0.18181818181818
91114, 1.2869565217391, 1.625, 0.18181818181818
91115, 1.2869565217391, 1.65, 0.15909090909091
91116, 1.2652173913043, 1.65, 0.13636363636364
91117, 1.2869565217391, 1.625, 0.13636363636364
91118, 1.2869565217391, 1.65, 0.11363636363636
91119, 1.2652173913043, 1.65, 0.090909090909091
91120, 1.2869565217391, 1.625, 0.090909090909091
91121, 1.2869565217391, 1.65, 0.068181818181818
91122, 1.2652173913043, 1.65, 0.045454545454545
91123, 1.2869565217391, 1.625, 0.045454545454545
91124, 1.2869565217391, 1.65, 0.022727272727273
91125, 1.3304347826087, 1.65, 0.47727272727273
91126, 1.3086956521739, 1.65, 0.45454545454545
91127, 1.3304347826087, 1.625, 0.45454545454545
91128, 1.3304347826087, 1.65, 0.43181818181818
91129, 1.3086956521739, 1.65, 0.40909090909091
91130, 1.3304347826087, 1.625, 0.40909090909091
91131, 1.3304347826087, 1.65, 0.38636363636364
91132, 1.3086956521739, 1.65, 0.36363636363636
91133, 1.3304347826087, 1.625, 0.36363636363636
91134, 1.3304347826087, 1.65, 0.34090909090909
91135, 1.3086956521739, 1.65, 0.31818181818182
91136, 1.3304347826087, 1.625, 0.31818181818182
91137, 1.3304347826087, 1.65, 0.29545454545455
91138, 1.3086956521739, 1.65, 0.27272727272727
91139, 1.3304347826087, 1.625, 0.27272727272727
91140, 1.3304347826087, 1.65, 0.25
91141, 1.3086956521739, 1.65, 0.22727272727273
91142, 1.3304347826087, 1.625, 0.22727272727273
91143, 1.3304347826087, 1.65, 0.20454545454545
91144, 1.3086956521739, 1.65, 0.18181818181818
91145, 1.3304347826087, 1.625, 0.18181818181818
91146, 1.3304347826087, 1.65, 0.15909090909091
91147, 1.3086956521739, 1.65, 0.13636363636364
91148, 1.3304347826087, 1.625, 0.13636363636364
91149, 1.3304347826087, 1.65, 0.11363636363636
91150, 1.3086956521739, 1.65, 0.090909090909091
91151, 1.3304347826087, 1.625, 0.090909090909091
91152, 1.3304347826087, 1.65, 0.068181818181818
91153, 1.3086956521739, 1.65, 0.045454545454545
91154, 1.3304347826087, 1.625, 0.045454545454545
91155, 1.3304347826087, 1.65, 0.022727272727273
91156, 1.3739130434783, 1.65, 0.47727272727273
91157, 1.3521739130435, 1.65, 0.45454545454545
91158, 1.3739130434783, 1.625, 0.45454545454545
91159, 1.3739130434783, 1.65, 0.43181818181818
91160, 1.3521739130435, 1.65, 0.40909090909091
91161, 1.3739130434783, 1.625, 0.40909090909091
91162, 1.3739130434783, 1.65, 0.38636363636364
91163, 1.3521739130435, 1.65, 0.36363636363636
91164, 1.3739130434783, 1.625, 0.36363636363636
91165, 1.3739130434783, 1.65, 0.34090909090909
91166, 1.3521739130435, 1.65, 0.31818181818182
91167, 1.3739130434783, 1.625, 0.31818181818182
91168, 1.3739130434783, 1.65, 0.29545454545455
91169, 1.3521739130435, 1.65, 0.27272727272727
91170, 1.3739130434783, 1.625, 0.27272727272727
91171, 1.3739130434783, 1.65, 0.25
91172, 1.3521739130435, 1.65, 0.22727272727273
91173, 1.3739130434783, 1.625, 0.22727272727273
91174, 1.3739130434783, 1.65, 0.20454545454545
91175, 1.3521739130435, 1.65, 0.18181818181818
91176, 1.3739130434783, 1.625, 0.18181818181818
91177, 1.3739130434783, 1.65, 0.15909090909091
91178, 1.3521739130435, 1.65, 0.13636363636364
91179, 1.3739130434783, 1.625, 0.13636363636364
91180, 1.3739130434783, 1.65, 0.11363636363636
91181, 1.3521739130435, 1.65, 0.090909090909091
91182, 1.3739130434783, 1.625, 0.090909090909091
91183, 1.3739130434783, 1.65, 0.068181818181818
91184, 1.3521739130435, 1.65, 0.045454545454545
91185, 1.3739130434783, 1.625, 0.045454545454545
91186, 1.3739130434783, 1.65, 0.022727272727273
91187, 1.4173913043478, 1.65, 0.47727272727273
91188, 1.395652173913, 1.65, 0.45454545454545
91189, 1.4173913043478, 1.625, 0.45454545454545
91190, 1.4173913043478, 1.65, 0.43181818181818
91191, 1.395652173913, 1.65, 0.40909090909091
91192, 1.4173913043478, 1.625, 0.40909090909091
91193, 1.4173913043478, 1.65, 0.38636363636364
91194, 1.395652173913, 1.65, 0.36363636363636
91195, 1.4173913043478, 1.625, 0.36363636363636
91196, 1.4173913043478, 1.65, 0.34090909090909
91197, 1.395652173913, 1.65, 0.31818181818182
91198, 1.4173913043478, 1.625, 0.31818181818182
91199, 1.4173913043478, 1.65, 0.29545454545455
91200, 1.395652173913, 1.65, 0.27272727272727
91201, 1.4173913043478, 1.625, 0.27272727272727
91202, 1.4173913043478, 1.65, 0.25
91203, 1.395652173913, 1.65, 0.22727272727273
91204, 1.4173913043478, 1.625, 0.22727272727273
91205, 1.4173913043478, 1.65, 0.20454545454545
91206, 1.395652173913, 1.65, 0.18181818181818
91207, 1.4173913043478, 1.625, 0.18181818181818
91208, 1.4173913043478, 1.65, 0.15909090909091
91209, 1.395652173913, 1.65, 0.13636363636364
91210, 1.4173913043478, 1.625, 0.13636363636364
91211, 1.4173913043478, 1.65, 0.11363636363636
91212, 1.395652173913, 1.65, 0.090909090909091
91213, 1.4173913043478, 1.625, 0.090909090909091
91214, 1.4173913043478, 1.65, 0.068181818181818
91215, 1.395652173913, 1.65, 0.045454545454545
91216, 1.4173913043478, 1.625, 0.045454545454545
91217, 1.4173913043478, 1.65, 0.022727272727273
91218, 1.4608695652174, 1.65, 0.47727272727273
91219, 1.4391304347826, 1.65, 0.45454545454545
91220, 1.4608695652174, 1.625, 0.45454545454545
91221, 1.4608695652174, 1.65, 0.43181818181818
91222, 1.4391304347826, 1.65, 0.40909090909091
91223, 1.4608695652174, 1.625, 0.40909090909091
91224, 1.4608695652174, 1.65, 0.38636363636364
91225, 1.4391304347826, 1.65, 0.36363636363636
91226, 1.4608695652174, 1.625, 0.36363636363636
91227, 1.4608695652174, 1.65, 0.34090909090909
91228, 1.4391304347826, 1.65, 0.31818181818182
91229, 1.4608695652174, 1.625, 0.31818181818182
91230, 1.4608695652174, 1.65, 0.29545454545455
91231, 1.4391304347826, 1.65, 0.27272727272727
91232, 1.4608695652174, 1.625, 0.27272727272727
91233, 1.4608695652174, 1.65, 0.25
91234, 1.4391304347826, 1.65, 0.22727272727273
91235, 1.4608695652174, 1.625, 0.22727272727273
91236, 1.4608695652174, 1.65, 0.20454545454545
91237, 1.4391304347826, 1.65, 0.18181818181818
91238, 1.4608695652174, 1.625, 0.18181818181818
91239, 1.4608695652174, 1.65, 0.15909090909091
91240, 1.4391304347826, 1.65, 0.13636363636364
91241, 1.4608695652174, 1.625, 0.13636363636364
91242, 1.4608695652174, 1.65, 0.11363636363636
91243, 1.4391304347826, 1.65, 0.090909090909091
91244, 1.4608695652174, 1.625, 0.090909090909091
91245, 1.4608695652174, 1.65, 0.068181818181818
91246, 1.4391304347826, 1.65, 0.045454545454545
91247, 1.4608695652174, 1.625, 0.045454545454545
91248, 1.4608695652174, 1.65, 0.022727272727273
91249, 1.504347826087, 1.65, 0.47727272727273
91250, 1.4826086956522, 1.65, 0.45454545454545
91251, 1.504347826087, 1.625, 0.45454545454545
91252, 1.504347826087, 1.65, 0.43181818181818
91253, 1.4826086956522, 1.65, 0.40909090909091
91254, 1.504347826087, 1.625, 0.40909090909091
91255, 1.504347826087, 1.65, 0.38636363636364
91256, 1.4826086956522, 1.65, 0.36363636363636
91257, 1.504347826087, 1.625, 0.36363636363636
91258, 1.504347826087, 1.65, 0.34090909090909
91259, 1.4826086956522, 1.65, 0.31818181818182
91260, 1.504347826087, 1.625, 0.31818181818182
91261, 1.504347826087, 1.65, 0.29545454545455
91262, 1.4826086956522, 1.65, 0.27272727272727
91263, 1.504347826087, 1.625, 0.27272727272727
91264, 1.504347826087, 1.65, 0.25
91265, 1.4826086956522, 1.65, 0.22727272727273
91266, 1.504347826087, 1.625, 0.22727272727273
91267, 1.504347826087, 1.65, 0.20454545454545
91268, 1.4826086956522, 1.65, 0.18181818181818
91269, 1.504347826087, 1.625, 0.18181818181818
91270, 1.504347826087, 1.65, 0.15909090909091
91271, 1.4826086956522, 1.65, 0.13636363636364
91272, 1.504347826087, 1.625, 0.13636363636364
91273, 1.504347826087, 1.65, 0.11363636363636
91274, 1.4826086956522, 1.65, 0.090909090909091
91275, 1.504347826087, 1.625, 0.090909090909091
91276, 1.504347826087, 1.65, 0.068181818181818
91277, 1.4826086956522, 1.65, 0.045454545454545
91278, 1.504347826087, 1.625, 0.045454545454545
91279, 1.504347826087, 1.65, 0.022727272727273
91280, 1.5478260869565, 1.65, 0.47727272727273
91281, 1.5260869565217, 1.65, 0.45454545454545
91282, 1.5478260869565, 1.625, 0.45454545454545
91283, 1.5478260869565, 1.65, 0.43181818181818
91284, 1.5260869565217, 1.65, 0.40909090909091
91285, 1.5478260869565, 1.625, 0.40909090909091
91286, 1.5478260869565, 1.65, 0.38636363636364
91287, 1.5260869565217, 1.65, 0.36363636363636
91288, 1.5478260869565, 1.625, 0.36363636363636
91289, 1.5478260869565, 1.65, 0.34090909090909
91290, 1.5260869565217, 1.65, 0.31818181818182
91291, 1.5478260869565, 1.625, 0.31818181818182
91292, 1.5478260869565, 1.65, 0.29545454545455
91293, 1.5260869565217, 1.65, 0.27272727272727
