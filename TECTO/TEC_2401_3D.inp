86916, 0.89130434782609, 1.6, 0.045454545454545
86917, 0.8695652173913, 1.575, 0.045454545454545
86918, 0.8695652173913, 1.6, 0.068181818181818
86919, 0.89130434782609, 1.6, 0.090909090909091
86920, 0.8695652173913, 1.575, 0.090909090909091
86921, 0.8695652173913, 1.6, 0.11363636363636
86922, 0.89130434782609, 1.6, 0.13636363636364
86923, 0.8695652173913, 1.575, 0.13636363636364
86924, 0.8695652173913, 1.6, 0.15909090909091
86925, 0.89130434782609, 1.6, 0.18181818181818
86926, 0.8695652173913, 1.575, 0.18181818181818
86927, 0.8695652173913, 1.6, 0.20454545454545
86928, 0.89130434782609, 1.6, 0.22727272727273
86929, 0.8695652173913, 1.575, 0.22727272727273
86930, 0.8695652173913, 1.6, 0.25
86931, 0.89130434782609, 1.6, 0.27272727272727
86932, 0.8695652173913, 1.575, 0.27272727272727
86933, 0.8695652173913, 1.6, 0.29545454545455
86934, 0.89130434782609, 1.6, 0.31818181818182
86935, 0.8695652173913, 1.575, 0.31818181818182
86936, 0.8695652173913, 1.6, 0.34090909090909
86937, 0.89130434782609, 1.6, 0.36363636363636
86938, 0.8695652173913, 1.575, 0.36363636363636
86939, 0.8695652173913, 1.6, 0.38636363636364
86940, 0.89130434782609, 1.6, 0.40909090909091
86941, 0.8695652173913, 1.575, 0.40909090909091
86942, 0.8695652173913, 1.6, 0.43181818181818
86943, 0.89130434782609, 1.6, 0.45454545454545
86944, 0.8695652173913, 1.575, 0.45454545454545
86945, 0.8695652173913, 1.6, 0.47727272727273
86946, 0.82608695652174, 1.6, 0.022727272727273
86947, 0.84782608695652, 1.6, 0.045454545454545
86948, 0.82608695652174, 1.575, 0.045454545454545
86949, 0.82608695652174, 1.6, 0.068181818181818
86950, 0.84782608695652, 1.6, 0.090909090909091
86951, 0.82608695652174, 1.575, 0.090909090909091
86952, 0.82608695652174, 1.6, 0.11363636363636
86953, 0.84782608695652, 1.6, 0.13636363636364
86954, 0.82608695652174, 1.575, 0.13636363636364
86955, 0.82608695652174, 1.6, 0.15909090909091
86956, 0.84782608695652, 1.6, 0.18181818181818
86957, 0.82608695652174, 1.575, 0.18181818181818
86958, 0.82608695652174, 1.6, 0.20454545454545
86959, 0.84782608695652, 1.6, 0.22727272727273
86960, 0.82608695652174, 1.575, 0.22727272727273
86961, 0.82608695652174, 1.6, 0.25
86962, 0.84782608695652, 1.6, 0.27272727272727
86963, 0.82608695652174, 1.575, 0.27272727272727
86964, 0.82608695652174, 1.6, 0.29545454545455
86965, 0.84782608695652, 1.6, 0.31818181818182
86966, 0.82608695652174, 1.575, 0.31818181818182
86967, 0.82608695652174, 1.6, 0.34090909090909
86968, 0.84782608695652, 1.6, 0.36363636363636
86969, 0.82608695652174, 1.575, 0.36363636363636
86970, 0.82608695652174, 1.6, 0.38636363636364
86971, 0.84782608695652, 1.6, 0.40909090909091
86972, 0.82608695652174, 1.575, 0.40909090909091
86973, 0.82608695652174, 1.6, 0.43181818181818
86974, 0.84782608695652, 1.6, 0.45454545454545
86975, 0.82608695652174, 1.575, 0.45454545454545
86976, 0.82608695652174, 1.6, 0.47727272727273
86977, 0.78260869565217, 1.6, 0.022727272727273
86978, 0.80434782608696, 1.6, 0.045454545454545
86979, 0.78260869565217, 1.575, 0.045454545454545
86980, 0.78260869565217, 1.6, 0.068181818181818
86981, 0.80434782608696, 1.6, 0.090909090909091
86982, 0.78260869565217, 1.575, 0.090909090909091
86983, 0.78260869565217, 1.6, 0.11363636363636
86984, 0.80434782608696, 1.6, 0.13636363636364
86985, 0.78260869565217, 1.575, 0.13636363636364
86986, 0.78260869565217, 1.6, 0.15909090909091
86987, 0.80434782608696, 1.6, 0.18181818181818
86988, 0.78260869565217, 1.575, 0.18181818181818
86989, 0.78260869565217, 1.6, 0.20454545454545
86990, 0.80434782608696, 1.6, 0.22727272727273
86991, 0.78260869565217, 1.575, 0.22727272727273
86992, 0.78260869565217, 1.6, 0.25
86993, 0.80434782608696, 1.6, 0.27272727272727
86994, 0.78260869565217, 1.575, 0.27272727272727
86995, 0.78260869565217, 1.6, 0.29545454545455
86996, 0.80434782608696, 1.6, 0.31818181818182
86997, 0.78260869565217, 1.575, 0.31818181818182
86998, 0.78260869565217, 1.6, 0.34090909090909
86999, 0.80434782608696, 1.6, 0.36363636363636
87000, 0.78260869565217, 1.575, 0.36363636363636
87001, 0.78260869565217, 1.6, 0.38636363636364
87002, 0.80434782608696, 1.6, 0.40909090909091
87003, 0.78260869565217, 1.575, 0.40909090909091
87004, 0.78260869565217, 1.6, 0.43181818181818
87005, 0.80434782608696, 1.6, 0.45454545454545
87006, 0.78260869565217, 1.575, 0.45454545454545
87007, 0.78260869565217, 1.6, 0.47727272727273
87008, 0.73913043478261, 1.6, 0.022727272727273
87009, 0.76086956521739, 1.6, 0.045454545454545
87010, 0.73913043478261, 1.575, 0.045454545454545
87011, 0.73913043478261, 1.6, 0.068181818181818
87012, 0.76086956521739, 1.6, 0.090909090909091
87013, 0.73913043478261, 1.575, 0.090909090909091
87014, 0.73913043478261, 1.6, 0.11363636363636
87015, 0.76086956521739, 1.6, 0.13636363636364
87016, 0.73913043478261, 1.575, 0.13636363636364
87017, 0.73913043478261, 1.6, 0.15909090909091
87018, 0.76086956521739, 1.6, 0.18181818181818
87019, 0.73913043478261, 1.575, 0.18181818181818
87020, 0.73913043478261, 1.6, 0.20454545454545
87021, 0.76086956521739, 1.6, 0.22727272727273
87022, 0.73913043478261, 1.575, 0.22727272727273
87023, 0.73913043478261, 1.6, 0.25
87024, 0.76086956521739, 1.6, 0.27272727272727
87025, 0.73913043478261, 1.575, 0.27272727272727
87026, 0.73913043478261, 1.6, 0.29545454545455
87027, 0.76086956521739, 1.6, 0.31818181818182
87028, 0.73913043478261, 1.575, 0.31818181818182
87029, 0.73913043478261, 1.6, 0.34090909090909
87030, 0.76086956521739, 1.6, 0.36363636363636
87031, 0.73913043478261, 1.575, 0.36363636363636
87032, 0.73913043478261, 1.6, 0.38636363636364
87033, 0.76086956521739, 1.6, 0.40909090909091
87034, 0.73913043478261, 1.575, 0.40909090909091
87035, 0.73913043478261, 1.6, 0.43181818181818
87036, 0.76086956521739, 1.6, 0.45454545454545
87037, 0.73913043478261, 1.575, 0.45454545454545
87038, 0.73913043478261, 1.6, 0.47727272727273
87039, 0.69565217391304, 1.6, 0.022727272727273
87040, 0.71739130434783, 1.6, 0.045454545454545
87041, 0.69565217391304, 1.575, 0.045454545454545
87042, 0.69565217391304, 1.6, 0.068181818181818
87043, 0.71739130434783, 1.6, 0.090909090909091
87044, 0.69565217391304, 1.575, 0.090909090909091
87045, 0.69565217391304, 1.6, 0.11363636363636
87046, 0.71739130434783, 1.6, 0.13636363636364
87047, 0.69565217391304, 1.575, 0.13636363636364
87048, 0.69565217391304, 1.6, 0.15909090909091
87049, 0.71739130434783, 1.6, 0.18181818181818
87050, 0.69565217391304, 1.575, 0.18181818181818
87051, 0.69565217391304, 1.6, 0.20454545454545
87052, 0.71739130434783, 1.6, 0.22727272727273
87053, 0.69565217391304, 1.575, 0.22727272727273
87054, 0.69565217391304, 1.6, 0.25
87055, 0.71739130434783, 1.6, 0.27272727272727
87056, 0.69565217391304, 1.575, 0.27272727272727
87057, 0.69565217391304, 1.6, 0.29545454545455
87058, 0.71739130434783, 1.6, 0.31818181818182
87059, 0.69565217391304, 1.575, 0.31818181818182
87060, 0.69565217391304, 1.6, 0.34090909090909
87061, 0.71739130434783, 1.6, 0.36363636363636
87062, 0.69565217391304, 1.575, 0.36363636363636
87063, 0.69565217391304, 1.6, 0.38636363636364
87064, 0.71739130434783, 1.6, 0.40909090909091
87065, 0.69565217391304, 1.575, 0.40909090909091
87066, 0.69565217391304, 1.6, 0.43181818181818
87067, 0.71739130434783, 1.6, 0.45454545454545
87068, 0.69565217391304, 1.575, 0.45454545454545
87069, 0.69565217391304, 1.6, 0.47727272727273
87070, 0.65217391304348, 1.6, 0.022727272727273
87071, 0.67391304347826, 1.6, 0.045454545454545
87072, 0.65217391304348, 1.575, 0.045454545454545
87073, 0.65217391304348, 1.6, 0.068181818181818
87074, 0.67391304347826, 1.6, 0.090909090909091
87075, 0.65217391304348, 1.575, 0.090909090909091
87076, 0.65217391304348, 1.6, 0.11363636363636
87077, 0.67391304347826, 1.6, 0.13636363636364
87078, 0.65217391304348, 1.575, 0.13636363636364
87079, 0.65217391304348, 1.6, 0.15909090909091
87080, 0.67391304347826, 1.6, 0.18181818181818
87081, 0.65217391304348, 1.575, 0.18181818181818
87082, 0.65217391304348, 1.6, 0.20454545454545
87083, 0.67391304347826, 1.6, 0.22727272727273
87084, 0.65217391304348, 1.575, 0.22727272727273
87085, 0.65217391304348, 1.6, 0.25
87086, 0.67391304347826, 1.6, 0.27272727272727
87087, 0.65217391304348, 1.575, 0.27272727272727
87088, 0.65217391304348, 1.6, 0.29545454545455
87089, 0.67391304347826, 1.6, 0.31818181818182
87090, 0.65217391304348, 1.575, 0.31818181818182
87091, 0.65217391304348, 1.6, 0.34090909090909
87092, 0.67391304347826, 1.6, 0.36363636363636
87093, 0.65217391304348, 1.575, 0.36363636363636
87094, 0.65217391304348, 1.6, 0.38636363636364
87095, 0.67391304347826, 1.6, 0.40909090909091
87096, 0.65217391304348, 1.575, 0.40909090909091
87097, 0.65217391304348, 1.6, 0.43181818181818
87098, 0.67391304347826, 1.6, 0.45454545454545
87099, 0.65217391304348, 1.575, 0.45454545454545
87100, 0.65217391304348, 1.6, 0.47727272727273
87101, 0.60869565217391, 1.6, 0.022727272727273
87102, 0.6304347826087, 1.6, 0.045454545454545
87103, 0.60869565217391, 1.575, 0.045454545454545
87104, 0.60869565217391, 1.6, 0.068181818181818
87105, 0.6304347826087, 1.6, 0.090909090909091
87106, 0.60869565217391, 1.575, 0.090909090909091
87107, 0.60869565217391, 1.6, 0.11363636363636
87108, 0.6304347826087, 1.6, 0.13636363636364
87109, 0.60869565217391, 1.575, 0.13636363636364
87110, 0.60869565217391, 1.6, 0.15909090909091
87111, 0.6304347826087, 1.6, 0.18181818181818
87112, 0.60869565217391, 1.575, 0.18181818181818
87113, 0.60869565217391, 1.6, 0.20454545454545
87114, 0.6304347826087, 1.6, 0.22727272727273
87115, 0.60869565217391, 1.575, 0.22727272727273
87116, 0.60869565217391, 1.6, 0.25
87117, 0.6304347826087, 1.6, 0.27272727272727
87118, 0.60869565217391, 1.575, 0.27272727272727
87119, 0.60869565217391, 1.6, 0.29545454545455
87120, 0.6304347826087, 1.6, 0.31818181818182
87121, 0.60869565217391, 1.575, 0.31818181818182
87122, 0.60869565217391, 1.6, 0.34090909090909
87123, 0.6304347826087, 1.6, 0.36363636363636
87124, 0.60869565217391, 1.575, 0.36363636363636
87125, 0.60869565217391, 1.6, 0.38636363636364
87126, 0.6304347826087, 1.6, 0.40909090909091
87127, 0.60869565217391, 1.575, 0.40909090909091
87128, 0.60869565217391, 1.6, 0.43181818181818
87129, 0.6304347826087, 1.6, 0.45454545454545
87130, 0.60869565217391, 1.575, 0.45454545454545
87131, 0.60869565217391, 1.6, 0.47727272727273
87132, 0.56521739130435, 1.6, 0.022727272727273
87133, 0.58695652173913, 1.6, 0.045454545454545
87134, 0.56521739130435, 1.575, 0.045454545454545
87135, 0.56521739130435, 1.6, 0.068181818181818
87136, 0.58695652173913, 1.6, 0.090909090909091
87137, 0.56521739130435, 1.575, 0.090909090909091
87138, 0.56521739130435, 1.6, 0.11363636363636
87139, 0.58695652173913, 1.6, 0.13636363636364
87140, 0.56521739130435, 1.575, 0.13636363636364
87141, 0.56521739130435, 1.6, 0.15909090909091
87142, 0.58695652173913, 1.6, 0.18181818181818
87143, 0.56521739130435, 1.575, 0.18181818181818
87144, 0.56521739130435, 1.6, 0.20454545454545
87145, 0.58695652173913, 1.6, 0.22727272727273
87146, 0.56521739130435, 1.575, 0.22727272727273
87147, 0.56521739130435, 1.6, 0.25
87148, 0.58695652173913, 1.6, 0.27272727272727
87149, 0.56521739130435, 1.575, 0.27272727272727
87150, 0.56521739130435, 1.6, 0.29545454545455
87151, 0.58695652173913, 1.6, 0.31818181818182
87152, 0.56521739130435, 1.575, 0.31818181818182
87153, 0.56521739130435, 1.6, 0.34090909090909
87154, 0.58695652173913, 1.6, 0.36363636363636
87155, 0.56521739130435, 1.575, 0.36363636363636
87156, 0.56521739130435, 1.6, 0.38636363636364
87157, 0.58695652173913, 1.6, 0.40909090909091
87158, 0.56521739130435, 1.575, 0.40909090909091
87159, 0.56521739130435, 1.6, 0.43181818181818
87160, 0.58695652173913, 1.6, 0.45454545454545
87161, 0.56521739130435, 1.575, 0.45454545454545
87162, 0.56521739130435, 1.6, 0.47727272727273
87163, 0.52173913043478, 1.6, 0.022727272727273
87164, 0.54347826086956, 1.6, 0.045454545454545
87165, 0.52173913043478, 1.575, 0.045454545454545
87166, 0.52173913043478, 1.6, 0.068181818181818
87167, 0.54347826086956, 1.6, 0.090909090909091
87168, 0.52173913043478, 1.575, 0.090909090909091
87169, 0.52173913043478, 1.6, 0.11363636363636
87170, 0.54347826086957, 1.6, 0.13636363636364
87171, 0.52173913043478, 1.575, 0.13636363636364
87172, 0.52173913043478, 1.6, 0.15909090909091
87173, 0.54347826086956, 1.6, 0.18181818181818
87174, 0.52173913043478, 1.575, 0.18181818181818
87175, 0.52173913043478, 1.6, 0.20454545454545
87176, 0.54347826086956, 1.6, 0.22727272727273
87177, 0.52173913043478, 1.575, 0.22727272727273
87178, 0.52173913043478, 1.6, 0.25
87179, 0.54347826086956, 1.6, 0.27272727272727
87180, 0.52173913043478, 1.575, 0.27272727272727
87181, 0.52173913043478, 1.6, 0.29545454545455
87182, 0.54347826086956, 1.6, 0.31818181818182
87183, 0.52173913043478, 1.575, 0.31818181818182
87184, 0.52173913043478, 1.6, 0.34090909090909
87185, 0.54347826086957, 1.6, 0.36363636363636
87186, 0.52173913043478, 1.575, 0.36363636363636
87187, 0.52173913043478, 1.6, 0.38636363636364
87188, 0.54347826086956, 1.6, 0.40909090909091
87189, 0.52173913043478, 1.575, 0.40909090909091
87190, 0.52173913043478, 1.6, 0.43181818181818
87191, 0.54347826086956, 1.6, 0.45454545454545
87192, 0.52173913043478, 1.575, 0.45454545454545
87193, 0.52173913043478, 1.6, 0.47727272727273
87194, 0.47826086956522, 1.6, 0.022727272727273
87195, 0.5, 1.6, 0.045454545454545
87196, 0.47826086956522, 1.575, 0.045454545454545
87197, 0.47826086956522, 1.6, 0.068181818181818
87198, 0.5, 1.6, 0.090909090909091
87199, 0.47826086956522, 1.575, 0.090909090909091
87200, 0.47826086956522, 1.6, 0.11363636363636
87201, 0.5, 1.6, 0.13636363636364
87202, 0.47826086956522, 1.575, 0.13636363636364
87203, 0.47826086956522, 1.6, 0.15909090909091
87204, 0.5, 1.6, 0.18181818181818
87205, 0.47826086956522, 1.575, 0.18181818181818
87206, 0.47826086956522, 1.6, 0.20454545454545
87207, 0.5, 1.6, 0.22727272727273
87208, 0.47826086956522, 1.575, 0.22727272727273
87209, 0.47826086956522, 1.6, 0.25
87210, 0.5, 1.6, 0.27272727272727
87211, 0.47826086956522, 1.575, 0.27272727272727
87212, 0.47826086956522, 1.6, 0.29545454545455
87213, 0.5, 1.6, 0.31818181818182
87214, 0.47826086956522, 1.575, 0.31818181818182
87215, 0.47826086956522, 1.6, 0.34090909090909
87216, 0.5, 1.6, 0.36363636363636
87217, 0.47826086956522, 1.575, 0.36363636363636
87218, 0.47826086956522, 1.6, 0.38636363636364
87219, 0.5, 1.6, 0.40909090909091
87220, 0.47826086956522, 1.575, 0.40909090909091
87221, 0.47826086956522, 1.6, 0.43181818181818
87222, 0.5, 1.6, 0.45454545454545
87223, 0.47826086956522, 1.575, 0.45454545454545
87224, 0.47826086956522, 1.6, 0.47727272727273
87225, 0.43478260869565, 1.6, 0.022727272727273
87226, 0.45652173913043, 1.6, 0.045454545454545
87227, 0.43478260869565, 1.575, 0.045454545454545
87228, 0.43478260869565, 1.6, 0.068181818181818
87229, 0.45652173913043, 1.6, 0.090909090909091
87230, 0.43478260869565, 1.575, 0.090909090909091
87231, 0.43478260869565, 1.6, 0.11363636363636
87232, 0.45652173913043, 1.6, 0.13636363636364
87233, 0.43478260869565, 1.575, 0.13636363636364
87234, 0.43478260869565, 1.6, 0.15909090909091
87235, 0.45652173913043, 1.6, 0.18181818181818
87236, 0.43478260869565, 1.575, 0.18181818181818
87237, 0.43478260869565, 1.6, 0.20454545454545
87238, 0.45652173913043, 1.6, 0.22727272727273
87239, 0.43478260869565, 1.575, 0.22727272727273
87240, 0.43478260869565, 1.6, 0.25
87241, 0.45652173913043, 1.6, 0.27272727272727
87242, 0.43478260869565, 1.575, 0.27272727272727
87243, 0.43478260869565, 1.6, 0.29545454545455
87244, 0.45652173913043, 1.6, 0.31818181818182
87245, 0.43478260869565, 1.575, 0.31818181818182
87246, 0.43478260869565, 1.6, 0.34090909090909
87247, 0.45652173913043, 1.6, 0.36363636363636
87248, 0.43478260869565, 1.575, 0.36363636363636
87249, 0.43478260869565, 1.6, 0.38636363636364
87250, 0.45652173913043, 1.6, 0.40909090909091
87251, 0.43478260869565, 1.575, 0.40909090909091
87252, 0.43478260869565, 1.6, 0.43181818181818
87253, 0.45652173913043, 1.6, 0.45454545454545
87254, 0.43478260869565, 1.575, 0.45454545454545
87255, 0.43478260869565, 1.6, 0.47727272727273
87256, 0.39130434782609, 1.6, 0.022727272727273
87257, 0.41304347826087, 1.6, 0.045454545454545
87258, 0.39130434782609, 1.575, 0.045454545454545
87259, 0.39130434782609, 1.6, 0.068181818181818
87260, 0.41304347826087, 1.6, 0.090909090909091
87261, 0.39130434782609, 1.575, 0.090909090909091
87262, 0.39130434782609, 1.6, 0.11363636363636
87263, 0.41304347826087, 1.6, 0.13636363636364
87264, 0.39130434782609, 1.575, 0.13636363636364
87265, 0.39130434782609, 1.6, 0.15909090909091
87266, 0.41304347826087, 1.6, 0.18181818181818
87267, 0.39130434782609, 1.575, 0.18181818181818
87268, 0.39130434782609, 1.6, 0.20454545454545
87269, 0.41304347826087, 1.6, 0.22727272727273
87270, 0.39130434782609, 1.575, 0.22727272727273
87271, 0.39130434782609, 1.6, 0.25
87272, 0.41304347826087, 1.6, 0.27272727272727
87273, 0.39130434782609, 1.575, 0.27272727272727
87274, 0.39130434782609, 1.6, 0.29545454545455
87275, 0.41304347826087, 1.6, 0.31818181818182
87276, 0.39130434782609, 1.575, 0.31818181818182
87277, 0.39130434782609, 1.6, 0.34090909090909
87278, 0.41304347826087, 1.6, 0.36363636363636
87279, 0.39130434782609, 1.575, 0.36363636363636
87280, 0.39130434782609, 1.6, 0.38636363636364
87281, 0.41304347826087, 1.6, 0.40909090909091
87282, 0.39130434782609, 1.575, 0.40909090909091
87283, 0.39130434782609, 1.6, 0.43181818181818
87284, 0.41304347826087, 1.6, 0.45454545454545
87285, 0.39130434782609, 1.575, 0.45454545454545
87286, 0.39130434782609, 1.6, 0.47727272727273
87287, 0.34782608695652, 1.6, 0.022727272727273
87288, 0.3695652173913, 1.6, 0.045454545454545
87289, 0.34782608695652, 1.575, 0.045454545454545
87290, 0.34782608695652, 1.6, 0.068181818181818
87291, 0.3695652173913, 1.6, 0.090909090909091
87292, 0.34782608695652, 1.575, 0.090909090909091
87293, 0.34782608695652, 1.6, 0.11363636363636
87294, 0.3695652173913, 1.6, 0.13636363636364
87295, 0.34782608695652, 1.575, 0.13636363636364
87296, 0.34782608695652, 1.6, 0.15909090909091
87297, 0.3695652173913, 1.6, 0.18181818181818
87298, 0.34782608695652, 1.575, 0.18181818181818
87299, 0.34782608695652, 1.6, 0.20454545454545
87300, 0.3695652173913, 1.6, 0.22727272727273
87301, 0.34782608695652, 1.575, 0.22727272727273
87302, 0.34782608695652, 1.6, 0.25
87303, 0.3695652173913, 1.6, 0.27272727272727
87304, 0.34782608695652, 1.575, 0.27272727272727
87305, 0.34782608695652, 1.6, 0.29545454545455
87306, 0.3695652173913, 1.6, 0.31818181818182
87307, 0.34782608695652, 1.575, 0.31818181818182
87308, 0.34782608695652, 1.6, 0.34090909090909
87309, 0.3695652173913, 1.6, 0.36363636363636
87310, 0.34782608695652, 1.575, 0.36363636363636
87311, 0.34782608695652, 1.6, 0.38636363636364
87312, 0.3695652173913, 1.6, 0.40909090909091
87313, 0.34782608695652, 1.575, 0.40909090909091
87314, 0.34782608695652, 1.6, 0.43181818181818
87315, 0.3695652173913, 1.6, 0.45454545454545
87316, 0.34782608695652, 1.575, 0.45454545454545
87317, 0.34782608695652, 1.6, 0.47727272727273
87318, 0.30434782608696, 1.6, 0.022727272727273
87319, 0.32608695652174, 1.6, 0.045454545454545
87320, 0.30434782608696, 1.575, 0.045454545454545
87321, 0.30434782608696, 1.6, 0.068181818181818
87322, 0.32608695652174, 1.6, 0.090909090909091
87323, 0.30434782608696, 1.575, 0.090909090909091
87324, 0.30434782608696, 1.6, 0.11363636363636
87325, 0.32608695652174, 1.6, 0.13636363636364
87326, 0.30434782608696, 1.575, 0.13636363636364
87327, 0.30434782608696, 1.6, 0.15909090909091
87328, 0.32608695652174, 1.6, 0.18181818181818
87329, 0.30434782608696, 1.575, 0.18181818181818
87330, 0.30434782608696, 1.6, 0.20454545454545
87331, 0.32608695652174, 1.6, 0.22727272727273
87332, 0.30434782608696, 1.575, 0.22727272727273
87333, 0.30434782608696, 1.6, 0.25
87334, 0.32608695652174, 1.6, 0.27272727272727
87335, 0.30434782608696, 1.575, 0.27272727272727
87336, 0.30434782608696, 1.6, 0.29545454545455
87337, 0.32608695652174, 1.6, 0.31818181818182
87338, 0.30434782608696, 1.575, 0.31818181818182
87339, 0.30434782608696, 1.6, 0.34090909090909
87340, 0.32608695652174, 1.6, 0.36363636363636
87341, 0.30434782608696, 1.575, 0.36363636363636
87342, 0.30434782608696, 1.6, 0.38636363636364
87343, 0.32608695652174, 1.6, 0.40909090909091
87344, 0.30434782608696, 1.575, 0.40909090909091
87345, 0.30434782608696, 1.6, 0.43181818181818
87346, 0.32608695652174, 1.6, 0.45454545454545
87347, 0.30434782608696, 1.575, 0.45454545454545
87348, 0.30434782608696, 1.6, 0.47727272727273
87349, 0.26086956521739, 1.6, 0.022727272727273
87350, 0.28260869565217, 1.6, 0.045454545454545
87351, 0.26086956521739, 1.575, 0.045454545454545
87352, 0.26086956521739, 1.6, 0.068181818181818
87353, 0.28260869565217, 1.6, 0.090909090909091
87354, 0.26086956521739, 1.575, 0.090909090909091
87355, 0.26086956521739, 1.6, 0.11363636363636
87356, 0.28260869565217, 1.6, 0.13636363636364
87357, 0.26086956521739, 1.575, 0.13636363636364
87358, 0.26086956521739, 1.6, 0.15909090909091
87359, 0.28260869565217, 1.6, 0.18181818181818
87360, 0.26086956521739, 1.575, 0.18181818181818
87361, 0.26086956521739, 1.6, 0.20454545454545
87362, 0.28260869565217, 1.6, 0.22727272727273
87363, 0.26086956521739, 1.575, 0.22727272727273
87364, 0.26086956521739, 1.6, 0.25
87365, 0.28260869565217, 1.6, 0.27272727272727
87366, 0.26086956521739, 1.575, 0.27272727272727
87367, 0.26086956521739, 1.6, 0.29545454545455
87368, 0.28260869565217, 1.6, 0.31818181818182
87369, 0.26086956521739, 1.575, 0.31818181818182
87370, 0.26086956521739, 1.6, 0.34090909090909
87371, 0.28260869565217, 1.6, 0.36363636363636
87372, 0.26086956521739, 1.575, 0.36363636363636
87373, 0.26086956521739, 1.6, 0.38636363636364
87374, 0.28260869565217, 1.6, 0.40909090909091
87375, 0.26086956521739, 1.575, 0.40909090909091
87376, 0.26086956521739, 1.6, 0.43181818181818
87377, 0.28260869565217, 1.6, 0.45454545454545
87378, 0.26086956521739, 1.575, 0.45454545454545
87379, 0.26086956521739, 1.6, 0.47727272727273
87380, 0.21739130434783, 1.6, 0.022727272727273
87381, 0.23913043478261, 1.6, 0.045454545454545
87382, 0.21739130434783, 1.575, 0.045454545454545
87383, 0.21739130434783, 1.6, 0.068181818181818
87384, 0.23913043478261, 1.6, 0.090909090909091
87385, 0.21739130434783, 1.575, 0.090909090909091
87386, 0.21739130434783, 1.6, 0.11363636363636
87387, 0.23913043478261, 1.6, 0.13636363636364
87388, 0.21739130434783, 1.575, 0.13636363636364
87389, 0.21739130434783, 1.6, 0.15909090909091
87390, 0.23913043478261, 1.6, 0.18181818181818
87391, 0.21739130434783, 1.575, 0.18181818181818
87392, 0.21739130434783, 1.6, 0.20454545454545
87393, 0.23913043478261, 1.6, 0.22727272727273
87394, 0.21739130434783, 1.575, 0.22727272727273
87395, 0.21739130434783, 1.6, 0.25
87396, 0.23913043478261, 1.6, 0.27272727272727
87397, 0.21739130434783, 1.575, 0.27272727272727
87398, 0.21739130434783, 1.6, 0.29545454545455
87399, 0.23913043478261, 1.6, 0.31818181818182
87400, 0.21739130434783, 1.575, 0.31818181818182
87401, 0.21739130434783, 1.6, 0.34090909090909
87402, 0.23913043478261, 1.6, 0.36363636363636
87403, 0.21739130434783, 1.575, 0.36363636363636
87404, 0.21739130434783, 1.6, 0.38636363636364
87405, 0.23913043478261, 1.6, 0.40909090909091
87406, 0.21739130434783, 1.575, 0.40909090909091
87407, 0.21739130434783, 1.6, 0.43181818181818
87408, 0.23913043478261, 1.6, 0.45454545454545
87409, 0.21739130434783, 1.575, 0.45454545454545
87410, 0.21739130434783, 1.6, 0.47727272727273
87411, 0.17391304347826, 1.6, 0.022727272727273
87412, 0.19565217391304, 1.6, 0.045454545454545
87413, 0.17391304347826, 1.575, 0.045454545454545
87414, 0.17391304347826, 1.6, 0.068181818181818
87415, 0.19565217391304, 1.6, 0.090909090909091
87416, 0.17391304347826, 1.575, 0.090909090909091
87417, 0.17391304347826, 1.6, 0.11363636363636
87418, 0.19565217391304, 1.6, 0.13636363636364
87419, 0.17391304347826, 1.575, 0.13636363636364
87420, 0.17391304347826, 1.6, 0.15909090909091
87421, 0.19565217391304, 1.6, 0.18181818181818
87422, 0.17391304347826, 1.575, 0.18181818181818
87423, 0.17391304347826, 1.6, 0.20454545454545
87424, 0.19565217391304, 1.6, 0.22727272727273
87425, 0.17391304347826, 1.575, 0.22727272727273
87426, 0.17391304347826, 1.6, 0.25
87427, 0.19565217391304, 1.6, 0.27272727272727
87428, 0.17391304347826, 1.575, 0.27272727272727
87429, 0.17391304347826, 1.6, 0.29545454545455
87430, 0.19565217391304, 1.6, 0.31818181818182
87431, 0.17391304347826, 1.575, 0.31818181818182
87432, 0.17391304347826, 1.6, 0.34090909090909
87433, 0.19565217391304, 1.6, 0.36363636363636
87434, 0.17391304347826, 1.575, 0.36363636363636
87435, 0.17391304347826, 1.6, 0.38636363636364
87436, 0.19565217391304, 1.6, 0.40909090909091
87437, 0.17391304347826, 1.575, 0.40909090909091
87438, 0.17391304347826, 1.6, 0.43181818181818
87439, 0.19565217391304, 1.6, 0.45454545454545
87440, 0.17391304347826, 1.575, 0.45454545454545
87441, 0.17391304347826, 1.6, 0.47727272727273
87442, 0.1304347826087, 1.6, 0.022727272727273
87443, 0.15217391304348, 1.6, 0.045454545454545
87444, 0.1304347826087, 1.575, 0.045454545454545
87445, 0.1304347826087, 1.6, 0.068181818181818
87446, 0.15217391304348, 1.6, 0.090909090909091
87447, 0.1304347826087, 1.575, 0.090909090909091
87448, 0.1304347826087, 1.6, 0.11363636363636
87449, 0.15217391304348, 1.6, 0.13636363636364
87450, 0.1304347826087, 1.575, 0.13636363636364
87451, 0.1304347826087, 1.6, 0.15909090909091
87452, 0.15217391304348, 1.6, 0.18181818181818
87453, 0.1304347826087, 1.575, 0.18181818181818
87454, 0.1304347826087, 1.6, 0.20454545454545
87455, 0.15217391304348, 1.6, 0.22727272727273
87456, 0.1304347826087, 1.575, 0.22727272727273
87457, 0.1304347826087, 1.6, 0.25
87458, 0.15217391304348, 1.6, 0.27272727272727
87459, 0.1304347826087, 1.575, 0.27272727272727
87460, 0.1304347826087, 1.6, 0.29545454545455
87461, 0.15217391304348, 1.6, 0.31818181818182
87462, 0.1304347826087, 1.575, 0.31818181818182
87463, 0.1304347826087, 1.6, 0.34090909090909
87464, 0.15217391304348, 1.6, 0.36363636363636
87465, 0.1304347826087, 1.575, 0.36363636363636
87466, 0.1304347826087, 1.6, 0.38636363636364
87467, 0.15217391304348, 1.6, 0.40909090909091
87468, 0.1304347826087, 1.575, 0.40909090909091
87469, 0.1304347826087, 1.6, 0.43181818181818
87470, 0.15217391304348, 1.6, 0.45454545454545
87471, 0.1304347826087, 1.575, 0.45454545454545
87472, 0.1304347826087, 1.6, 0.47727272727273
87473, 0.08695652173913, 1.6, 0.022727272727273
87474, 0.10869565217391, 1.6, 0.045454545454545
87475, 0.08695652173913, 1.575, 0.045454545454545
87476, 0.08695652173913, 1.6, 0.068181818181818
87477, 0.10869565217391, 1.6, 0.090909090909091
87478, 0.08695652173913, 1.575, 0.090909090909091
87479, 0.08695652173913, 1.6, 0.11363636363636
87480, 0.10869565217391, 1.6, 0.13636363636364
87481, 0.08695652173913, 1.575, 0.13636363636364
87482, 0.08695652173913, 1.6, 0.15909090909091
87483, 0.10869565217391, 1.6, 0.18181818181818
87484, 0.08695652173913, 1.575, 0.18181818181818
87485, 0.08695652173913, 1.6, 0.20454545454545
87486, 0.10869565217391, 1.6, 0.22727272727273
87487, 0.08695652173913, 1.575, 0.22727272727273
87488, 0.08695652173913, 1.6, 0.25
87489, 0.10869565217391, 1.6, 0.27272727272727
87490, 0.08695652173913, 1.575, 0.27272727272727
87491, 0.08695652173913, 1.6, 0.29545454545455
87492, 0.10869565217391, 1.6, 0.31818181818182
87493, 0.08695652173913, 1.575, 0.31818181818182
87494, 0.08695652173913, 1.6, 0.34090909090909
87495, 0.10869565217391, 1.6, 0.36363636363636
87496, 0.08695652173913, 1.575, 0.36363636363636
87497, 0.08695652173913, 1.6, 0.38636363636364
87498, 0.10869565217391, 1.6, 0.40909090909091
87499, 0.08695652173913, 1.575, 0.40909090909091
87500, 0.08695652173913, 1.6, 0.43181818181818
87501, 0.10869565217391, 1.6, 0.45454545454545
87502, 0.08695652173913, 1.575, 0.45454545454545
87503, 0.08695652173913, 1.6, 0.47727272727273
87504, 0.043478260869565, 1.6, 0.022727272727273
87505, 0.065217391304348, 1.6, 0.045454545454545
87506, 0.043478260869565, 1.575, 0.045454545454545
87507, 0.043478260869565, 1.6, 0.068181818181818
87508, 0.065217391304348, 1.6, 0.090909090909091
87509, 0.043478260869565, 1.575, 0.090909090909091
87510, 0.043478260869565, 1.6, 0.11363636363636
87511, 0.065217391304348, 1.6, 0.13636363636364
87512, 0.043478260869565, 1.575, 0.13636363636364
87513, 0.043478260869565, 1.6, 0.15909090909091
87514, 0.065217391304348, 1.6, 0.18181818181818
87515, 0.043478260869565, 1.575, 0.18181818181818
87516, 0.043478260869565, 1.6, 0.20454545454545
87517, 0.065217391304348, 1.6, 0.22727272727273
87518, 0.043478260869565, 1.575, 0.22727272727273
87519, 0.043478260869565, 1.6, 0.25
87520, 0.065217391304348, 1.6, 0.27272727272727
87521, 0.043478260869565, 1.575, 0.27272727272727
87522, 0.043478260869565, 1.6, 0.29545454545455
87523, 0.065217391304348, 1.6, 0.31818181818182
87524, 0.043478260869565, 1.575, 0.31818181818182
87525, 0.043478260869565, 1.6, 0.34090909090909
87526, 0.065217391304348, 1.6, 0.36363636363636
87527, 0.043478260869565, 1.575, 0.36363636363636
87528, 0.043478260869565, 1.6, 0.38636363636364
87529, 0.065217391304348, 1.6, 0.40909090909091
87530, 0.043478260869565, 1.575, 0.40909090909091
87531, 0.043478260869565, 1.6, 0.43181818181818
87532, 0.065217391304348, 1.6, 0.45454545454545
87533, 0.043478260869565, 1.575, 0.45454545454545
87534, 0.043478260869565, 1.6, 0.47727272727273
87535, 0.021739130434783, 1.6, 0.045454545454545
87536, 0.021739130434783, 1.6, 0.090909090909091
87537, 0.021739130434783, 1.6, 0.13636363636364
87538, 0.021739130434783, 1.6, 0.18181818181818
87539, 0.021739130434783, 1.6, 0.22727272727273
87540, 0.021739130434783, 1.6, 0.27272727272727
87541, 0.021739130434783, 1.6, 0.31818181818182
87542, 0.021739130434783, 1.6, 0.36363636363636
87543, 0.021739130434783, 1.6, 0.40909090909091
87544, 0.021739130434783, 1.6, 0.45454545454545
87545, 0.95652173913043, 1.65, 0.022727272727273
87546, 0.97826086956522, 1.65, 0.045454545454545
87547, 0.95652173913043, 1.625, 0.045454545454545
87548, 0.95652173913043, 1.65, 0.068181818181818
87549, 0.97826086956522, 1.65, 0.090909090909091
87550, 0.95652173913043, 1.625, 0.090909090909091
87551, 0.95652173913043, 1.65, 0.11363636363636
87552, 0.97826086956522, 1.65, 0.13636363636364
87553, 0.95652173913043, 1.625, 0.13636363636364
87554, 0.95652173913044, 1.65, 0.15909090909091
87555, 0.97826086956522, 1.65, 0.18181818181818
87556, 0.95652173913043, 1.625, 0.18181818181818
87557, 0.95652173913044, 1.65, 0.20454545454545
87558, 0.97826086956522, 1.65, 0.22727272727273
87559, 0.95652173913044, 1.625, 0.22727272727273
87560, 0.95652173913044, 1.65, 0.25
87561, 0.97826086956522, 1.65, 0.27272727272727
87562, 0.95652173913044, 1.625, 0.27272727272727
87563, 0.95652173913043, 1.65, 0.29545454545455
87564, 0.97826086956522, 1.65, 0.31818181818182
87565, 0.95652173913043, 1.625, 0.31818181818182
87566, 0.95652173913043, 1.65, 0.34090909090909
87567, 0.97826086956522, 1.65, 0.36363636363636
87568, 0.95652173913043, 1.625, 0.36363636363636
87569, 0.95652173913043, 1.65, 0.38636363636364
87570, 0.97826086956522, 1.65, 0.40909090909091
87571, 0.95652173913043, 1.625, 0.40909090909091
87572, 0.95652173913043, 1.65, 0.43181818181818
87573, 0.97826086956522, 1.65, 0.45454545454545
87574, 0.95652173913044, 1.625, 0.45454545454545
87575, 0.95652173913043, 1.65, 0.47727272727273
87576, 0.91304347826087, 1.65, 0.022727272727273
87577, 0.93478260869565, 1.65, 0.045454545454545
87578, 0.91304347826087, 1.625, 0.045454545454545
87579, 0.91304347826087, 1.65, 0.068181818181818
87580, 0.93478260869565, 1.65, 0.090909090909091
87581, 0.91304347826087, 1.625, 0.090909090909091
87582, 0.91304347826087, 1.65, 0.11363636363636
87583, 0.93478260869565, 1.65, 0.13636363636364
87584, 0.91304347826087, 1.625, 0.13636363636364
87585, 0.91304347826087, 1.65, 0.15909090909091
87586, 0.93478260869565, 1.65, 0.18181818181818
87587, 0.91304347826087, 1.625, 0.18181818181818
87588, 0.91304347826087, 1.65, 0.20454545454545
87589, 0.93478260869565, 1.65, 0.22727272727273
87590, 0.91304347826087, 1.625, 0.22727272727273
87591, 0.91304347826087, 1.65, 0.25
87592, 0.93478260869565, 1.65, 0.27272727272727
87593, 0.91304347826087, 1.625, 0.27272727272727
87594, 0.91304347826087, 1.65, 0.29545454545455
87595, 0.93478260869565, 1.65, 0.31818181818182
87596, 0.91304347826087, 1.625, 0.31818181818182
87597, 0.91304347826087, 1.65, 0.34090909090909
87598, 0.93478260869565, 1.65, 0.36363636363636
87599, 0.91304347826087, 1.625, 0.36363636363636
87600, 0.91304347826087, 1.65, 0.38636363636364
87601, 0.93478260869565, 1.65, 0.40909090909091
87602, 0.91304347826087, 1.625, 0.40909090909091
87603, 0.91304347826087, 1.65, 0.43181818181818
87604, 0.93478260869565, 1.65, 0.45454545454545
87605, 0.91304347826087, 1.625, 0.45454545454545
87606, 0.91304347826087, 1.65, 0.47727272727273
87607, 0.8695652173913, 1.65, 0.022727272727273
87608, 0.89130434782609, 1.65, 0.045454545454545
87609, 0.8695652173913, 1.625, 0.045454545454545
87610, 0.8695652173913, 1.65, 0.068181818181818
87611, 0.89130434782609, 1.65, 0.090909090909091
87612, 0.8695652173913, 1.625, 0.090909090909091
87613, 0.8695652173913, 1.65, 0.11363636363636
87614, 0.89130434782609, 1.65, 0.13636363636364
87615, 0.8695652173913, 1.625, 0.13636363636364
87616, 0.8695652173913, 1.65, 0.15909090909091
87617, 0.89130434782609, 1.65, 0.18181818181818
87618, 0.8695652173913, 1.625, 0.18181818181818
87619, 0.8695652173913, 1.65, 0.20454545454545
87620, 0.89130434782609, 1.65, 0.22727272727273
87621, 0.8695652173913, 1.625, 0.22727272727273
87622, 0.8695652173913, 1.65, 0.25
87623, 0.89130434782609, 1.65, 0.27272727272727
87624, 0.8695652173913, 1.625, 0.27272727272727
87625, 0.8695652173913, 1.65, 0.29545454545455
87626, 0.89130434782609, 1.65, 0.31818181818182
87627, 0.8695652173913, 1.625, 0.31818181818182
87628, 0.8695652173913, 1.65, 0.34090909090909
87629, 0.89130434782609, 1.65, 0.36363636363636
87630, 0.8695652173913, 1.625, 0.36363636363636
87631, 0.8695652173913, 1.65, 0.38636363636364
87632, 0.89130434782609, 1.65, 0.40909090909091
87633, 0.8695652173913, 1.625, 0.40909090909091
87634, 0.8695652173913, 1.65, 0.43181818181818
87635, 0.89130434782609, 1.65, 0.45454545454545
87636, 0.8695652173913, 1.625, 0.45454545454545
87637, 0.8695652173913, 1.65, 0.47727272727273
87638, 0.82608695652174, 1.65, 0.022727272727273
87639, 0.84782608695652, 1.65, 0.045454545454545
87640, 0.82608695652174, 1.625, 0.045454545454545
87641, 0.82608695652174, 1.65, 0.068181818181818
87642, 0.84782608695652, 1.65, 0.090909090909091
87643, 0.82608695652174, 1.625, 0.090909090909091
87644, 0.82608695652174, 1.65, 0.11363636363636
87645, 0.84782608695652, 1.65, 0.13636363636364
87646, 0.82608695652174, 1.625, 0.13636363636364
87647, 0.82608695652174, 1.65, 0.15909090909091
87648, 0.84782608695652, 1.65, 0.18181818181818
87649, 0.82608695652174, 1.625, 0.18181818181818
87650, 0.82608695652174, 1.65, 0.20454545454545
87651, 0.84782608695652, 1.65, 0.22727272727273
87652, 0.82608695652174, 1.625, 0.22727272727273
87653, 0.82608695652174, 1.65, 0.25
87654, 0.84782608695652, 1.65, 0.27272727272727
87655, 0.82608695652174, 1.625, 0.27272727272727
87656, 0.82608695652174, 1.65, 0.29545454545455
87657, 0.84782608695652, 1.65, 0.31818181818182
87658, 0.82608695652174, 1.625, 0.31818181818182
87659, 0.82608695652174, 1.65, 0.34090909090909
87660, 0.84782608695652, 1.65, 0.36363636363636
87661, 0.82608695652174, 1.625, 0.36363636363636
87662, 0.82608695652174, 1.65, 0.38636363636364
87663, 0.84782608695652, 1.65, 0.40909090909091
87664, 0.82608695652174, 1.625, 0.40909090909091
87665, 0.82608695652174, 1.65, 0.43181818181818
87666, 0.84782608695652, 1.65, 0.45454545454545
87667, 0.82608695652174, 1.625, 0.45454545454545
87668, 0.82608695652174, 1.65, 0.47727272727273
87669, 0.78260869565217, 1.65, 0.022727272727273
87670, 0.80434782608696, 1.65, 0.045454545454545
87671, 0.78260869565217, 1.625, 0.045454545454545
87672, 0.78260869565217, 1.65, 0.068181818181818
87673, 0.80434782608696, 1.65, 0.090909090909091
87674, 0.78260869565217, 1.625, 0.090909090909091
87675, 0.78260869565217, 1.65, 0.11363636363636
87676, 0.80434782608696, 1.65, 0.13636363636364
87677, 0.78260869565217, 1.625, 0.13636363636364
87678, 0.78260869565217, 1.65, 0.15909090909091
87679, 0.80434782608696, 1.65, 0.18181818181818
87680, 0.78260869565217, 1.625, 0.18181818181818
87681, 0.78260869565217, 1.65, 0.20454545454545
87682, 0.80434782608696, 1.65, 0.22727272727273
87683, 0.78260869565217, 1.625, 0.22727272727273
87684, 0.78260869565217, 1.65, 0.25
87685, 0.80434782608696, 1.65, 0.27272727272727
87686, 0.78260869565217, 1.625, 0.27272727272727
87687, 0.78260869565217, 1.65, 0.29545454545455
87688, 0.80434782608696, 1.65, 0.31818181818182
87689, 0.78260869565217, 1.625, 0.31818181818182
87690, 0.78260869565217, 1.65, 0.34090909090909
87691, 0.80434782608696, 1.65, 0.36363636363636
87692, 0.78260869565217, 1.625, 0.36363636363636
87693, 0.78260869565217, 1.65, 0.38636363636364
87694, 0.80434782608696, 1.65, 0.40909090909091
87695, 0.78260869565217, 1.625, 0.40909090909091
87696, 0.78260869565217, 1.65, 0.43181818181818
87697, 0.80434782608696, 1.65, 0.45454545454545
87698, 0.78260869565217, 1.625, 0.45454545454545
87699, 0.78260869565217, 1.65, 0.47727272727273
87700, 0.73913043478261, 1.65, 0.022727272727273
87701, 0.76086956521739, 1.65, 0.045454545454545
87702, 0.73913043478261, 1.625, 0.045454545454545
87703, 0.73913043478261, 1.65, 0.068181818181818
87704, 0.76086956521739, 1.65, 0.090909090909091
87705, 0.73913043478261, 1.625, 0.090909090909091
87706, 0.73913043478261, 1.65, 0.11363636363636
87707, 0.76086956521739, 1.65, 0.13636363636364
87708, 0.73913043478261, 1.625, 0.13636363636364
87709, 0.73913043478261, 1.65, 0.15909090909091
87710, 0.76086956521739, 1.65, 0.18181818181818
87711, 0.73913043478261, 1.625, 0.18181818181818
87712, 0.73913043478261, 1.65, 0.20454545454545
87713, 0.76086956521739, 1.65, 0.22727272727273
87714, 0.73913043478261, 1.625, 0.22727272727273
87715, 0.73913043478261, 1.65, 0.25
87716, 0.76086956521739, 1.65, 0.27272727272727
87717, 0.73913043478261, 1.625, 0.27272727272727
87718, 0.73913043478261, 1.65, 0.29545454545455
87719, 0.76086956521739, 1.65, 0.31818181818182
87720, 0.73913043478261, 1.625, 0.31818181818182
87721, 0.73913043478261, 1.65, 0.34090909090909
87722, 0.76086956521739, 1.65, 0.36363636363636
87723, 0.73913043478261, 1.625, 0.36363636363636
87724, 0.73913043478261, 1.65, 0.38636363636364
87725, 0.76086956521739, 1.65, 0.40909090909091
87726, 0.73913043478261, 1.625, 0.40909090909091
87727, 0.73913043478261, 1.65, 0.43181818181818
87728, 0.76086956521739, 1.65, 0.45454545454545
87729, 0.73913043478261, 1.625, 0.45454545454545
87730, 0.73913043478261, 1.65, 0.47727272727273
87731, 0.69565217391304, 1.65, 0.022727272727273
87732, 0.71739130434783, 1.65, 0.045454545454545
87733, 0.69565217391304, 1.625, 0.045454545454545
87734, 0.69565217391304, 1.65, 0.068181818181818
87735, 0.71739130434783, 1.65, 0.090909090909091
87736, 0.69565217391304, 1.625, 0.090909090909091
87737, 0.69565217391304, 1.65, 0.11363636363636
87738, 0.71739130434783, 1.65, 0.13636363636364
87739, 0.69565217391304, 1.625, 0.13636363636364
87740, 0.69565217391304, 1.65, 0.15909090909091
87741, 0.71739130434783, 1.65, 0.18181818181818
87742, 0.69565217391304, 1.625, 0.18181818181818
87743, 0.69565217391304, 1.65, 0.20454545454545
87744, 0.71739130434783, 1.65, 0.22727272727273
87745, 0.69565217391304, 1.625, 0.22727272727273
87746, 0.69565217391304, 1.65, 0.25
87747, 0.71739130434783, 1.65, 0.27272727272727
87748, 0.69565217391304, 1.625, 0.27272727272727
87749, 0.69565217391304, 1.65, 0.29545454545455
87750, 0.71739130434783, 1.65, 0.31818181818182
87751, 0.69565217391304, 1.625, 0.31818181818182
87752, 0.69565217391304, 1.65, 0.34090909090909
87753, 0.71739130434783, 1.65, 0.36363636363636
87754, 0.69565217391304, 1.625, 0.36363636363636
87755, 0.69565217391304, 1.65, 0.38636363636364
87756, 0.71739130434783, 1.65, 0.40909090909091
87757, 0.69565217391304, 1.625, 0.40909090909091
87758, 0.69565217391304, 1.65, 0.43181818181818
87759, 0.71739130434783, 1.65, 0.45454545454545
87760, 0.69565217391304, 1.625, 0.45454545454545
87761, 0.69565217391304, 1.65, 0.47727272727273
87762, 0.65217391304348, 1.65, 0.022727272727273
87763, 0.67391304347826, 1.65, 0.045454545454545
87764, 0.65217391304348, 1.625, 0.045454545454545
87765, 0.65217391304348, 1.65, 0.068181818181818
87766, 0.67391304347826, 1.65, 0.090909090909091
87767, 0.65217391304348, 1.625, 0.090909090909091
87768, 0.65217391304348, 1.65, 0.11363636363636
87769, 0.67391304347826, 1.65, 0.13636363636364
87770, 0.65217391304348, 1.625, 0.13636363636364
87771, 0.65217391304348, 1.65, 0.15909090909091
87772, 0.67391304347826, 1.65, 0.18181818181818
87773, 0.65217391304348, 1.625, 0.18181818181818
87774, 0.65217391304348, 1.65, 0.20454545454545
87775, 0.67391304347826, 1.65, 0.22727272727273
87776, 0.65217391304348, 1.625, 0.22727272727273
87777, 0.65217391304348, 1.65, 0.25
87778, 0.67391304347826, 1.65, 0.27272727272727
87779, 0.65217391304348, 1.625, 0.27272727272727
87780, 0.65217391304348, 1.65, 0.29545454545455
87781, 0.67391304347826, 1.65, 0.31818181818182
87782, 0.65217391304348, 1.625, 0.31818181818182
87783, 0.65217391304348, 1.65, 0.34090909090909
87784, 0.67391304347826, 1.65, 0.36363636363636
87785, 0.65217391304348, 1.625, 0.36363636363636
87786, 0.65217391304348, 1.65, 0.38636363636364
87787, 0.67391304347826, 1.65, 0.40909090909091
87788, 0.65217391304348, 1.625, 0.40909090909091
87789, 0.65217391304348, 1.65, 0.43181818181818
87790, 0.67391304347826, 1.65, 0.45454545454545
87791, 0.65217391304348, 1.625, 0.45454545454545
87792, 0.65217391304348, 1.65, 0.47727272727273
87793, 0.60869565217391, 1.65, 0.022727272727273
87794, 0.6304347826087, 1.65, 0.045454545454545
87795, 0.60869565217391, 1.625, 0.045454545454545
87796, 0.60869565217391, 1.65, 0.068181818181818
87797, 0.6304347826087, 1.65, 0.090909090909091
87798, 0.60869565217391, 1.625, 0.090909090909091
87799, 0.60869565217391, 1.65, 0.11363636363636
87800, 0.6304347826087, 1.65, 0.13636363636364
87801, 0.60869565217391, 1.625, 0.13636363636364
87802, 0.60869565217391, 1.65, 0.15909090909091
87803, 0.6304347826087, 1.65, 0.18181818181818
87804, 0.60869565217391, 1.625, 0.18181818181818
87805, 0.60869565217391, 1.65, 0.20454545454545
87806, 0.6304347826087, 1.65, 0.22727272727273
87807, 0.60869565217391, 1.625, 0.22727272727273
87808, 0.60869565217391, 1.65, 0.25
87809, 0.6304347826087, 1.65, 0.27272727272727
87810, 0.60869565217391, 1.625, 0.27272727272727
87811, 0.60869565217391, 1.65, 0.29545454545455
87812, 0.6304347826087, 1.65, 0.31818181818182
87813, 0.60869565217391, 1.625, 0.31818181818182
87814, 0.60869565217391, 1.65, 0.34090909090909
87815, 0.6304347826087, 1.65, 0.36363636363636
87816, 0.60869565217391, 1.625, 0.36363636363636
87817, 0.60869565217391, 1.65, 0.38636363636364
87818, 0.6304347826087, 1.65, 0.40909090909091
87819, 0.60869565217391, 1.625, 0.40909090909091
87820, 0.60869565217391, 1.65, 0.43181818181818
87821, 0.6304347826087, 1.65, 0.45454545454545
87822, 0.60869565217391, 1.625, 0.45454545454545
87823, 0.60869565217391, 1.65, 0.47727272727273
87824, 0.56521739130435, 1.65, 0.022727272727273
87825, 0.58695652173913, 1.65, 0.045454545454545
87826, 0.56521739130435, 1.625, 0.045454545454545
87827, 0.56521739130435, 1.65, 0.068181818181818
87828, 0.58695652173913, 1.65, 0.090909090909091
87829, 0.56521739130435, 1.625, 0.090909090909091
87830, 0.56521739130435, 1.65, 0.11363636363636
87831, 0.58695652173913, 1.65, 0.13636363636364
87832, 0.56521739130435, 1.625, 0.13636363636364
87833, 0.56521739130435, 1.65, 0.15909090909091
87834, 0.58695652173913, 1.65, 0.18181818181818
87835, 0.56521739130435, 1.625, 0.18181818181818
87836, 0.56521739130435, 1.65, 0.20454545454545
87837, 0.58695652173913, 1.65, 0.22727272727273
87838, 0.56521739130435, 1.625, 0.22727272727273
87839, 0.56521739130435, 1.65, 0.25
87840, 0.58695652173913, 1.65, 0.27272727272727
87841, 0.56521739130435, 1.625, 0.27272727272727
87842, 0.56521739130435, 1.65, 0.29545454545455
87843, 0.58695652173913, 1.65, 0.31818181818182
87844, 0.56521739130435, 1.625, 0.31818181818182
87845, 0.56521739130435, 1.65, 0.34090909090909
87846, 0.58695652173913, 1.65, 0.36363636363636
87847, 0.56521739130435, 1.625, 0.36363636363636
87848, 0.56521739130435, 1.65, 0.38636363636364
87849, 0.58695652173913, 1.65, 0.40909090909091
87850, 0.56521739130435, 1.625, 0.40909090909091
87851, 0.56521739130435, 1.65, 0.43181818181818
87852, 0.58695652173913, 1.65, 0.45454545454545
87853, 0.56521739130435, 1.625, 0.45454545454545
87854, 0.56521739130435, 1.65, 0.47727272727273
87855, 0.52173913043478, 1.65, 0.022727272727273
87856, 0.54347826086956, 1.65, 0.045454545454545
87857, 0.52173913043478, 1.625, 0.045454545454545
87858, 0.52173913043478, 1.65, 0.068181818181818
87859, 0.54347826086956, 1.65, 0.090909090909091
87860, 0.52173913043478, 1.625, 0.090909090909091
87861, 0.52173913043478, 1.65, 0.11363636363636
87862, 0.54347826086956, 1.65, 0.13636363636364
87863, 0.52173913043478, 1.625, 0.13636363636364
87864, 0.52173913043478, 1.65, 0.15909090909091
87865, 0.54347826086956, 1.65, 0.18181818181818
87866, 0.52173913043478, 1.625, 0.18181818181818
87867, 0.52173913043478, 1.65, 0.20454545454545
87868, 0.54347826086956, 1.65, 0.22727272727273
87869, 0.52173913043478, 1.625, 0.22727272727273
87870, 0.52173913043478, 1.65, 0.25
87871, 0.54347826086956, 1.65, 0.27272727272727
87872, 0.52173913043478, 1.625, 0.27272727272727
87873, 0.52173913043478, 1.65, 0.29545454545455
87874, 0.54347826086956, 1.65, 0.31818181818182
87875, 0.52173913043478, 1.625, 0.31818181818182
87876, 0.52173913043478, 1.65, 0.34090909090909
87877, 0.54347826086957, 1.65, 0.36363636363636
87878, 0.52173913043478, 1.625, 0.36363636363636
87879, 0.52173913043478, 1.65, 0.38636363636364
87880, 0.54347826086956, 1.65, 0.40909090909091
87881, 0.52173913043478, 1.625, 0.40909090909091
87882, 0.52173913043478, 1.65, 0.43181818181818
87883, 0.54347826086956, 1.65, 0.45454545454545
87884, 0.52173913043478, 1.625, 0.45454545454545
87885, 0.52173913043478, 1.65, 0.47727272727273
87886, 0.47826086956522, 1.65, 0.022727272727273
87887, 0.5, 1.65, 0.045454545454545
87888, 0.47826086956522, 1.625, 0.045454545454545
87889, 0.47826086956522, 1.65, 0.068181818181818
87890, 0.5, 1.65, 0.090909090909091
87891, 0.47826086956522, 1.625, 0.090909090909091
87892, 0.47826086956522, 1.65, 0.11363636363636
87893, 0.5, 1.65, 0.13636363636364
87894, 0.47826086956522, 1.625, 0.13636363636364
87895, 0.47826086956522, 1.65, 0.15909090909091
87896, 0.5, 1.65, 0.18181818181818
87897, 0.47826086956522, 1.625, 0.18181818181818
87898, 0.47826086956522, 1.65, 0.20454545454545
87899, 0.5, 1.65, 0.22727272727273
87900, 0.47826086956522, 1.625, 0.22727272727273
87901, 0.47826086956522, 1.65, 0.25
87902, 0.5, 1.65, 0.27272727272727
87903, 0.47826086956522, 1.625, 0.27272727272727
87904, 0.47826086956522, 1.65, 0.29545454545455
87905, 0.5, 1.65, 0.31818181818182
87906, 0.47826086956522, 1.625, 0.31818181818182
87907, 0.47826086956522, 1.65, 0.34090909090909
87908, 0.5, 1.65, 0.36363636363636
87909, 0.47826086956522, 1.625, 0.36363636363636
87910, 0.47826086956522, 1.65, 0.38636363636364
87911, 0.5, 1.65, 0.40909090909091
87912, 0.47826086956522, 1.625, 0.40909090909091
87913, 0.47826086956522, 1.65, 0.43181818181818
87914, 0.5, 1.65, 0.45454545454545
87915, 0.47826086956522, 1.625, 0.45454545454545
87916, 0.47826086956522, 1.65, 0.47727272727273
87917, 0.43478260869565, 1.65, 0.022727272727273
87918, 0.45652173913043, 1.65, 0.045454545454545
87919, 0.43478260869565, 1.625, 0.045454545454545
87920, 0.43478260869565, 1.65, 0.068181818181818
87921, 0.45652173913043, 1.65, 0.090909090909091
87922, 0.43478260869565, 1.625, 0.090909090909091
87923, 0.43478260869565, 1.65, 0.11363636363636
87924, 0.45652173913043, 1.65, 0.13636363636364
87925, 0.43478260869565, 1.625, 0.13636363636364
87926, 0.43478260869565, 1.65, 0.15909090909091
87927, 0.45652173913043, 1.65, 0.18181818181818
87928, 0.43478260869565, 1.625, 0.18181818181818
87929, 0.43478260869565, 1.65, 0.20454545454545
87930, 0.45652173913043, 1.65, 0.22727272727273
87931, 0.43478260869565, 1.625, 0.22727272727273
87932, 0.43478260869565, 1.65, 0.25
87933, 0.45652173913043, 1.65, 0.27272727272727
87934, 0.43478260869565, 1.625, 0.27272727272727
87935, 0.43478260869565, 1.65, 0.29545454545455
87936, 0.45652173913043, 1.65, 0.31818181818182
87937, 0.43478260869565, 1.625, 0.31818181818182
87938, 0.43478260869565, 1.65, 0.34090909090909
87939, 0.45652173913043, 1.65, 0.36363636363636
87940, 0.43478260869565, 1.625, 0.36363636363636
87941, 0.43478260869565, 1.65, 0.38636363636364
87942, 0.45652173913043, 1.65, 0.40909090909091
87943, 0.43478260869565, 1.625, 0.40909090909091
87944, 0.43478260869565, 1.65, 0.43181818181818
87945, 0.45652173913043, 1.65, 0.45454545454545
87946, 0.43478260869565, 1.625, 0.45454545454545
87947, 0.43478260869565, 1.65, 0.47727272727273
87948, 0.39130434782609, 1.65, 0.022727272727273
87949, 0.41304347826087, 1.65, 0.045454545454545
87950, 0.39130434782609, 1.625, 0.045454545454545
87951, 0.39130434782609, 1.65, 0.068181818181818
87952, 0.41304347826087, 1.65, 0.090909090909091
87953, 0.39130434782609, 1.625, 0.090909090909091
87954, 0.39130434782609, 1.65, 0.11363636363636
87955, 0.41304347826087, 1.65, 0.13636363636364
87956, 0.39130434782609, 1.625, 0.13636363636364
87957, 0.39130434782609, 1.65, 0.15909090909091
87958, 0.41304347826087, 1.65, 0.18181818181818
87959, 0.39130434782609, 1.625, 0.18181818181818
87960, 0.39130434782609, 1.65, 0.20454545454545
87961, 0.41304347826087, 1.65, 0.22727272727273
87962, 0.39130434782609, 1.625, 0.22727272727273
87963, 0.39130434782609, 1.65, 0.25
87964, 0.41304347826087, 1.65, 0.27272727272727
87965, 0.39130434782609, 1.625, 0.27272727272727
87966, 0.39130434782609, 1.65, 0.29545454545455
87967, 0.41304347826087, 1.65, 0.31818181818182
87968, 0.39130434782609, 1.625, 0.31818181818182
87969, 0.39130434782609, 1.65, 0.34090909090909
87970, 0.41304347826087, 1.65, 0.36363636363636
87971, 0.39130434782609, 1.625, 0.36363636363636
87972, 0.39130434782609, 1.65, 0.38636363636364
87973, 0.41304347826087, 1.65, 0.40909090909091
87974, 0.39130434782609, 1.625, 0.40909090909091
87975, 0.39130434782609, 1.65, 0.43181818181818
87976, 0.41304347826087, 1.65, 0.45454545454545
87977, 0.39130434782609, 1.625, 0.45454545454545
87978, 0.39130434782609, 1.65, 0.47727272727273
87979, 0.34782608695652, 1.65, 0.022727272727273
87980, 0.3695652173913, 1.65, 0.045454545454545
87981, 0.34782608695652, 1.625, 0.045454545454545
87982, 0.34782608695652, 1.65, 0.068181818181818
87983, 0.3695652173913, 1.65, 0.090909090909091
87984, 0.34782608695652, 1.625, 0.090909090909091
87985, 0.34782608695652, 1.65, 0.11363636363636
87986, 0.3695652173913, 1.65, 0.13636363636364
87987, 0.34782608695652, 1.625, 0.13636363636364
87988, 0.34782608695652, 1.65, 0.15909090909091
87989, 0.3695652173913, 1.65, 0.18181818181818
87990, 0.34782608695652, 1.625, 0.18181818181818
87991, 0.34782608695652, 1.65, 0.20454545454545
87992, 0.3695652173913, 1.65, 0.22727272727273
87993, 0.34782608695652, 1.625, 0.22727272727273
87994, 0.34782608695652, 1.65, 0.25
87995, 0.3695652173913, 1.65, 0.27272727272727
87996, 0.34782608695652, 1.625, 0.27272727272727
87997, 0.34782608695652, 1.65, 0.29545454545455
87998, 0.3695652173913, 1.65, 0.31818181818182
87999, 0.34782608695652, 1.625, 0.31818181818182
88000, 0.34782608695652, 1.65, 0.34090909090909
88001, 0.3695652173913, 1.65, 0.36363636363636
88002, 0.34782608695652, 1.625, 0.36363636363636
88003, 0.34782608695652, 1.65, 0.38636363636364
88004, 0.3695652173913, 1.65, 0.40909090909091
88005, 0.34782608695652, 1.625, 0.40909090909091
88006, 0.34782608695652, 1.65, 0.43181818181818
88007, 0.3695652173913, 1.65, 0.45454545454545
88008, 0.34782608695652, 1.625, 0.45454545454545
88009, 0.34782608695652, 1.65, 0.47727272727273
88010, 0.30434782608696, 1.65, 0.022727272727273
88011, 0.32608695652174, 1.65, 0.045454545454545
88012, 0.30434782608696, 1.625, 0.045454545454545
88013, 0.30434782608696, 1.65, 0.068181818181818
88014, 0.32608695652174, 1.65, 0.090909090909091
88015, 0.30434782608696, 1.625, 0.090909090909091
88016, 0.30434782608696, 1.65, 0.11363636363636
88017, 0.32608695652174, 1.65, 0.13636363636364
88018, 0.30434782608696, 1.625, 0.13636363636364
88019, 0.30434782608696, 1.65, 0.15909090909091
88020, 0.32608695652174, 1.65, 0.18181818181818
88021, 0.30434782608696, 1.625, 0.18181818181818
88022, 0.30434782608696, 1.65, 0.20454545454545
88023, 0.32608695652174, 1.65, 0.22727272727273
88024, 0.30434782608696, 1.625, 0.22727272727273
88025, 0.30434782608696, 1.65, 0.25
88026, 0.32608695652174, 1.65, 0.27272727272727
88027, 0.30434782608696, 1.625, 0.27272727272727
88028, 0.30434782608696, 1.65, 0.29545454545455
88029, 0.32608695652174, 1.65, 0.31818181818182
88030, 0.30434782608696, 1.625, 0.31818181818182
88031, 0.30434782608696, 1.65, 0.34090909090909
88032, 0.32608695652174, 1.65, 0.36363636363636
88033, 0.30434782608696, 1.625, 0.36363636363636
88034, 0.30434782608696, 1.65, 0.38636363636364
88035, 0.32608695652174, 1.65, 0.40909090909091
88036, 0.30434782608696, 1.625, 0.40909090909091
88037, 0.30434782608696, 1.65, 0.43181818181818
88038, 0.32608695652174, 1.65, 0.45454545454545
88039, 0.30434782608696, 1.625, 0.45454545454545
88040, 0.30434782608696, 1.65, 0.47727272727273
88041, 0.26086956521739, 1.65, 0.022727272727273
88042, 0.28260869565217, 1.65, 0.045454545454545
88043, 0.26086956521739, 1.625, 0.045454545454545
88044, 0.26086956521739, 1.65, 0.068181818181818
88045, 0.28260869565217, 1.65, 0.090909090909091
88046, 0.26086956521739, 1.625, 0.090909090909091
88047, 0.26086956521739, 1.65, 0.11363636363636
88048, 0.28260869565217, 1.65, 0.13636363636364
88049, 0.26086956521739, 1.625, 0.13636363636364
88050, 0.26086956521739, 1.65, 0.15909090909091
88051, 0.28260869565217, 1.65, 0.18181818181818
88052, 0.26086956521739, 1.625, 0.18181818181818
88053, 0.26086956521739, 1.65, 0.20454545454545
88054, 0.28260869565217, 1.65, 0.22727272727273
88055, 0.26086956521739, 1.625, 0.22727272727273
88056, 0.26086956521739, 1.65, 0.25
88057, 0.28260869565217, 1.65, 0.27272727272727
88058, 0.26086956521739, 1.625, 0.27272727272727
88059, 0.26086956521739, 1.65, 0.29545454545455
88060, 0.28260869565217, 1.65, 0.31818181818182
88061, 0.26086956521739, 1.625, 0.31818181818182
88062, 0.26086956521739, 1.65, 0.34090909090909
88063, 0.28260869565217, 1.65, 0.36363636363636
88064, 0.26086956521739, 1.625, 0.36363636363636
88065, 0.26086956521739, 1.65, 0.38636363636364
88066, 0.28260869565217, 1.65, 0.40909090909091
88067, 0.26086956521739, 1.625, 0.40909090909091
88068, 0.26086956521739, 1.65, 0.43181818181818
88069, 0.28260869565217, 1.65, 0.45454545454545
88070, 0.26086956521739, 1.625, 0.45454545454545
88071, 0.26086956521739, 1.65, 0.47727272727273
88072, 0.21739130434783, 1.65, 0.022727272727273
88073, 0.23913043478261, 1.65, 0.045454545454545
88074, 0.21739130434783, 1.625, 0.045454545454545
88075, 0.21739130434783, 1.65, 0.068181818181818
88076, 0.23913043478261, 1.65, 0.090909090909091
88077, 0.21739130434783, 1.625, 0.090909090909091
88078, 0.21739130434783, 1.65, 0.11363636363636
88079, 0.23913043478261, 1.65, 0.13636363636364
88080, 0.21739130434783, 1.625, 0.13636363636364
88081, 0.21739130434783, 1.65, 0.15909090909091
88082, 0.23913043478261, 1.65, 0.18181818181818
88083, 0.21739130434783, 1.625, 0.18181818181818
88084, 0.21739130434783, 1.65, 0.20454545454545
88085, 0.23913043478261, 1.65, 0.22727272727273
88086, 0.21739130434783, 1.625, 0.22727272727273
88087, 0.21739130434783, 1.65, 0.25
88088, 0.23913043478261, 1.65, 0.27272727272727
88089, 0.21739130434783, 1.625, 0.27272727272727
88090, 0.21739130434783, 1.65, 0.29545454545455
88091, 0.23913043478261, 1.65, 0.31818181818182
88092, 0.21739130434783, 1.625, 0.31818181818182
88093, 0.21739130434783, 1.65, 0.34090909090909
88094, 0.23913043478261, 1.65, 0.36363636363636
88095, 0.21739130434783, 1.625, 0.36363636363636
88096, 0.21739130434783, 1.65, 0.38636363636364
88097, 0.23913043478261, 1.65, 0.40909090909091
88098, 0.21739130434783, 1.625, 0.40909090909091
88099, 0.21739130434783, 1.65, 0.43181818181818
88100, 0.23913043478261, 1.65, 0.45454545454545
88101, 0.21739130434783, 1.625, 0.45454545454545
88102, 0.21739130434783, 1.65, 0.47727272727273
88103, 0.17391304347826, 1.65, 0.022727272727273
88104, 0.19565217391304, 1.65, 0.045454545454545
88105, 0.17391304347826, 1.625, 0.045454545454545
88106, 0.17391304347826, 1.65, 0.068181818181818
88107, 0.19565217391304, 1.65, 0.090909090909091
88108, 0.17391304347826, 1.625, 0.090909090909091
88109, 0.17391304347826, 1.65, 0.11363636363636
88110, 0.19565217391304, 1.65, 0.13636363636364
88111, 0.17391304347826, 1.625, 0.13636363636364
88112, 0.17391304347826, 1.65, 0.15909090909091
88113, 0.19565217391304, 1.65, 0.18181818181818
88114, 0.17391304347826, 1.625, 0.18181818181818
88115, 0.17391304347826, 1.65, 0.20454545454545
88116, 0.19565217391304, 1.65, 0.22727272727273
88117, 0.17391304347826, 1.625, 0.22727272727273
88118, 0.17391304347826, 1.65, 0.25
88119, 0.19565217391304, 1.65, 0.27272727272727
88120, 0.17391304347826, 1.625, 0.27272727272727
88121, 0.17391304347826, 1.65, 0.29545454545455
88122, 0.19565217391304, 1.65, 0.31818181818182
88123, 0.17391304347826, 1.625, 0.31818181818182
88124, 0.17391304347826, 1.65, 0.34090909090909
88125, 0.19565217391304, 1.65, 0.36363636363636
88126, 0.17391304347826, 1.625, 0.36363636363636
88127, 0.17391304347826, 1.65, 0.38636363636364
88128, 0.19565217391304, 1.65, 0.40909090909091
88129, 0.17391304347826, 1.625, 0.40909090909091
88130, 0.17391304347826, 1.65, 0.43181818181818
88131, 0.19565217391304, 1.65, 0.45454545454545
88132, 0.17391304347826, 1.625, 0.45454545454545
88133, 0.17391304347826, 1.65, 0.47727272727273
88134, 0.1304347826087, 1.65, 0.022727272727273
88135, 0.15217391304348, 1.65, 0.045454545454545
88136, 0.1304347826087, 1.625, 0.045454545454545
88137, 0.1304347826087, 1.65, 0.068181818181818
88138, 0.15217391304348, 1.65, 0.090909090909091
88139, 0.1304347826087, 1.625, 0.090909090909091
88140, 0.1304347826087, 1.65, 0.11363636363636
88141, 0.15217391304348, 1.65, 0.13636363636364
88142, 0.1304347826087, 1.625, 0.13636363636364
88143, 0.1304347826087, 1.65, 0.15909090909091
88144, 0.15217391304348, 1.65, 0.18181818181818
88145, 0.1304347826087, 1.625, 0.18181818181818
88146, 0.1304347826087, 1.65, 0.20454545454545
88147, 0.15217391304348, 1.65, 0.22727272727273
88148, 0.1304347826087, 1.625, 0.22727272727273
88149, 0.1304347826087, 1.65, 0.25
88150, 0.15217391304348, 1.65, 0.27272727272727
88151, 0.1304347826087, 1.625, 0.27272727272727
88152, 0.1304347826087, 1.65, 0.29545454545455
88153, 0.15217391304348, 1.65, 0.31818181818182
88154, 0.1304347826087, 1.625, 0.31818181818182
88155, 0.1304347826087, 1.65, 0.34090909090909
88156, 0.15217391304348, 1.65, 0.36363636363636
88157, 0.1304347826087, 1.625, 0.36363636363636
88158, 0.1304347826087, 1.65, 0.38636363636364
88159, 0.15217391304348, 1.65, 0.40909090909091
88160, 0.1304347826087, 1.625, 0.40909090909091
88161, 0.1304347826087, 1.65, 0.43181818181818
88162, 0.15217391304348, 1.65, 0.45454545454545
88163, 0.1304347826087, 1.625, 0.45454545454545
88164, 0.1304347826087, 1.65, 0.47727272727273
88165, 0.08695652173913, 1.65, 0.022727272727273
88166, 0.10869565217391, 1.65, 0.045454545454545
88167, 0.08695652173913, 1.625, 0.045454545454545
88168, 0.08695652173913, 1.65, 0.068181818181818
88169, 0.10869565217391, 1.65, 0.090909090909091
88170, 0.08695652173913, 1.625, 0.090909090909091
88171, 0.08695652173913, 1.65, 0.11363636363636
88172, 0.10869565217391, 1.65, 0.13636363636364
88173, 0.08695652173913, 1.625, 0.13636363636364
88174, 0.08695652173913, 1.65, 0.15909090909091
88175, 0.10869565217391, 1.65, 0.18181818181818
88176, 0.08695652173913, 1.625, 0.18181818181818
88177, 0.08695652173913, 1.65, 0.20454545454545
88178, 0.10869565217391, 1.65, 0.22727272727273
88179, 0.08695652173913, 1.625, 0.22727272727273
88180, 0.08695652173913, 1.65, 0.25
88181, 0.10869565217391, 1.65, 0.27272727272727
88182, 0.08695652173913, 1.625, 0.27272727272727
88183, 0.08695652173913, 1.65, 0.29545454545455
88184, 0.10869565217391, 1.65, 0.31818181818182
88185, 0.08695652173913, 1.625, 0.31818181818182
88186, 0.08695652173913, 1.65, 0.34090909090909
88187, 0.10869565217391, 1.65, 0.36363636363636
88188, 0.08695652173913, 1.625, 0.36363636363636
88189, 0.08695652173913, 1.65, 0.38636363636364
88190, 0.10869565217391, 1.65, 0.40909090909091
88191, 0.08695652173913, 1.625, 0.40909090909091
88192, 0.08695652173913, 1.65, 0.43181818181818
88193, 0.10869565217391, 1.65, 0.45454545454545
88194, 0.08695652173913, 1.625, 0.45454545454545
88195, 0.08695652173913, 1.65, 0.47727272727273
88196, 0.043478260869565, 1.65, 0.022727272727273
88197, 0.065217391304348, 1.65, 0.045454545454545
88198, 0.043478260869565, 1.625, 0.045454545454545
88199, 0.043478260869565, 1.65, 0.068181818181818
88200, 0.065217391304348, 1.65, 0.090909090909091
88201, 0.043478260869565, 1.625, 0.090909090909091
88202, 0.043478260869565, 1.65, 0.11363636363636
88203, 0.065217391304348, 1.65, 0.13636363636364
88204, 0.043478260869565, 1.625, 0.13636363636364
88205, 0.043478260869565, 1.65, 0.15909090909091
88206, 0.065217391304348, 1.65, 0.18181818181818
88207, 0.043478260869565, 1.625, 0.18181818181818
88208, 0.043478260869565, 1.65, 0.20454545454545
88209, 0.065217391304348, 1.65, 0.22727272727273
88210, 0.043478260869565, 1.625, 0.22727272727273
88211, 0.043478260869565, 1.65, 0.25
88212, 0.065217391304348, 1.65, 0.27272727272727
88213, 0.043478260869565, 1.625, 0.27272727272727
88214, 0.043478260869565, 1.65, 0.29545454545455
88215, 0.065217391304348, 1.65, 0.31818181818182
88216, 0.043478260869565, 1.625, 0.31818181818182
88217, 0.043478260869565, 1.65, 0.34090909090909
88218, 0.065217391304348, 1.65, 0.36363636363636
88219, 0.043478260869565, 1.625, 0.36363636363636
88220, 0.043478260869565, 1.65, 0.38636363636364
88221, 0.065217391304348, 1.65, 0.40909090909091
88222, 0.043478260869565, 1.625, 0.40909090909091
88223, 0.043478260869565, 1.65, 0.43181818181818
88224, 0.065217391304348, 1.65, 0.45454545454545
88225, 0.043478260869565, 1.625, 0.45454545454545
88226, 0.043478260869565, 1.65, 0.47727272727273
88227, 0.021739130434783, 1.65, 0.045454545454545
88228, 0.021739130434783, 1.65, 0.090909090909091
88229, 0.021739130434783, 1.65, 0.13636363636364
88230, 0.021739130434783, 1.65, 0.18181818181818
88231, 0.021739130434783, 1.65, 0.22727272727273
88232, 0.021739130434783, 1.65, 0.27272727272727
88233, 0.021739130434783, 1.65, 0.31818181818182
88234, 0.021739130434783, 1.65, 0.36363636363636
88235, 0.021739130434783, 1.65, 0.40909090909091
88236, 0.021739130434783, 1.65, 0.45454545454545
88237, 0.95652173913043, 1.675, 0.045454545454545
88238, 0.95652173913043, 1.675, 0.090909090909091
88239, 0.95652173913044, 1.675, 0.13636363636364
88240, 0.95652173913043, 1.675, 0.18181818181818
88241, 0.95652173913043, 1.675, 0.22727272727273
88242, 0.95652173913043, 1.675, 0.27272727272727
88243, 0.95652173913043, 1.675, 0.31818181818182
88244, 0.95652173913043, 1.675, 0.36363636363636
88245, 0.95652173913043, 1.675, 0.40909090909091
88246, 0.95652173913043, 1.675, 0.45454545454545
88247, 0.91304347826087, 1.675, 0.045454545454545
88248, 0.91304347826087, 1.675, 0.090909090909091
88249, 0.91304347826087, 1.675, 0.13636363636364
88250, 0.91304347826087, 1.675, 0.18181818181818
88251, 0.91304347826087, 1.675, 0.22727272727273
88252, 0.91304347826087, 1.675, 0.27272727272727
88253, 0.91304347826087, 1.675, 0.31818181818182
88254, 0.91304347826087, 1.675, 0.36363636363636
88255, 0.91304347826087, 1.675, 0.40909090909091
88256, 0.91304347826087, 1.675, 0.45454545454545
88257, 0.8695652173913, 1.675, 0.045454545454545
88258, 0.8695652173913, 1.675, 0.090909090909091
88259, 0.8695652173913, 1.675, 0.13636363636364
88260, 0.8695652173913, 1.675, 0.18181818181818
88261, 0.8695652173913, 1.675, 0.22727272727273
88262, 0.8695652173913, 1.675, 0.27272727272727
88263, 0.8695652173913, 1.675, 0.31818181818182
88264, 0.8695652173913, 1.675, 0.36363636363636
88265, 0.8695652173913, 1.675, 0.40909090909091
88266, 0.8695652173913, 1.675, 0.45454545454545
88267, 0.82608695652174, 1.675, 0.045454545454545
88268, 0.82608695652174, 1.675, 0.090909090909091
88269, 0.82608695652174, 1.675, 0.13636363636364
88270, 0.82608695652174, 1.675, 0.18181818181818
88271, 0.82608695652174, 1.675, 0.22727272727273
88272, 0.82608695652174, 1.675, 0.27272727272727
88273, 0.82608695652174, 1.675, 0.31818181818182
88274, 0.82608695652174, 1.675, 0.36363636363636
88275, 0.82608695652174, 1.675, 0.40909090909091
88276, 0.82608695652174, 1.675, 0.45454545454545
88277, 0.78260869565217, 1.675, 0.045454545454545
88278, 0.78260869565217, 1.675, 0.090909090909091
88279, 0.78260869565217, 1.675, 0.13636363636364
88280, 0.78260869565217, 1.675, 0.18181818181818
88281, 0.78260869565217, 1.675, 0.22727272727273
88282, 0.78260869565217, 1.675, 0.27272727272727
88283, 0.78260869565217, 1.675, 0.31818181818182
88284, 0.78260869565217, 1.675, 0.36363636363636
88285, 0.78260869565217, 1.675, 0.40909090909091
88286, 0.78260869565217, 1.675, 0.45454545454545
88287, 0.73913043478261, 1.675, 0.045454545454545
88288, 0.73913043478261, 1.675, 0.090909090909091
88289, 0.73913043478261, 1.675, 0.13636363636364
88290, 0.73913043478261, 1.675, 0.18181818181818
88291, 0.73913043478261, 1.675, 0.22727272727273
88292, 0.73913043478261, 1.675, 0.27272727272727
88293, 0.73913043478261, 1.675, 0.31818181818182
88294, 0.73913043478261, 1.675, 0.36363636363636
88295, 0.73913043478261, 1.675, 0.40909090909091
88296, 0.73913043478261, 1.675, 0.45454545454545
88297, 0.69565217391304, 1.675, 0.045454545454545
88298, 0.69565217391304, 1.675, 0.090909090909091
88299, 0.69565217391304, 1.675, 0.13636363636364
88300, 0.69565217391304, 1.675, 0.18181818181818
88301, 0.69565217391304, 1.675, 0.22727272727273
88302, 0.69565217391304, 1.675, 0.27272727272727
88303, 0.69565217391304, 1.675, 0.31818181818182
88304, 0.69565217391304, 1.675, 0.36363636363636
88305, 0.69565217391304, 1.675, 0.40909090909091
88306, 0.69565217391304, 1.675, 0.45454545454545
88307, 0.65217391304348, 1.675, 0.045454545454545
88308, 0.65217391304348, 1.675, 0.090909090909091
88309, 0.65217391304348, 1.675, 0.13636363636364
88310, 0.65217391304348, 1.675, 0.18181818181818
88311, 0.65217391304348, 1.675, 0.22727272727273
88312, 0.65217391304348, 1.675, 0.27272727272727
88313, 0.65217391304348, 1.675, 0.31818181818182
88314, 0.65217391304348, 1.675, 0.36363636363636
88315, 0.65217391304348, 1.675, 0.40909090909091
88316, 0.65217391304348, 1.675, 0.45454545454545
88317, 0.60869565217391, 1.675, 0.045454545454545
88318, 0.60869565217391, 1.675, 0.090909090909091
88319, 0.60869565217391, 1.675, 0.13636363636364
88320, 0.60869565217391, 1.675, 0.18181818181818
88321, 0.60869565217391, 1.675, 0.22727272727273
88322, 0.60869565217391, 1.675, 0.27272727272727
88323, 0.60869565217391, 1.675, 0.31818181818182
88324, 0.60869565217391, 1.675, 0.36363636363636
88325, 0.60869565217391, 1.675, 0.40909090909091
88326, 0.60869565217391, 1.675, 0.45454545454545
88327, 0.56521739130435, 1.675, 0.045454545454545
88328, 0.56521739130435, 1.675, 0.090909090909091
88329, 0.56521739130435, 1.675, 0.13636363636364
88330, 0.56521739130435, 1.675, 0.18181818181818
88331, 0.56521739130435, 1.675, 0.22727272727273
88332, 0.56521739130435, 1.675, 0.27272727272727
88333, 0.56521739130435, 1.675, 0.31818181818182
88334, 0.56521739130435, 1.675, 0.36363636363636
88335, 0.56521739130435, 1.675, 0.40909090909091
88336, 0.56521739130435, 1.675, 0.45454545454545
88337, 0.52173913043478, 1.675, 0.045454545454545
88338, 0.52173913043478, 1.675, 0.090909090909091
88339, 0.52173913043478, 1.675, 0.13636363636364
88340, 0.52173913043478, 1.675, 0.18181818181818
88341, 0.52173913043478, 1.675, 0.22727272727273
88342, 0.52173913043478, 1.675, 0.27272727272727
88343, 0.52173913043478, 1.675, 0.31818181818182
88344, 0.52173913043478, 1.675, 0.36363636363636
88345, 0.52173913043478, 1.675, 0.40909090909091
88346, 0.52173913043478, 1.675, 0.45454545454545
88347, 0.47826086956522, 1.675, 0.045454545454545
88348, 0.47826086956522, 1.675, 0.090909090909091
88349, 0.47826086956522, 1.675, 0.13636363636364
88350, 0.47826086956522, 1.675, 0.18181818181818
88351, 0.47826086956522, 1.675, 0.22727272727273
88352, 0.47826086956522, 1.675, 0.27272727272727
88353, 0.47826086956522, 1.675, 0.31818181818182
88354, 0.47826086956522, 1.675, 0.36363636363636
88355, 0.47826086956522, 1.675, 0.40909090909091
88356, 0.47826086956522, 1.675, 0.45454545454545
88357, 0.43478260869565, 1.675, 0.045454545454545
88358, 0.43478260869565, 1.675, 0.090909090909091
88359, 0.43478260869565, 1.675, 0.13636363636364
88360, 0.43478260869565, 1.675, 0.18181818181818
88361, 0.43478260869565, 1.675, 0.22727272727273
88362, 0.43478260869565, 1.675, 0.27272727272727
88363, 0.43478260869565, 1.675, 0.31818181818182
88364, 0.43478260869565, 1.675, 0.36363636363636
88365, 0.43478260869565, 1.675, 0.40909090909091
88366, 0.43478260869565, 1.675, 0.45454545454545
88367, 0.39130434782609, 1.675, 0.045454545454545
88368, 0.39130434782609, 1.675, 0.090909090909091
88369, 0.39130434782609, 1.675, 0.13636363636364
88370, 0.39130434782609, 1.675, 0.18181818181818
88371, 0.39130434782609, 1.675, 0.22727272727273
88372, 0.39130434782609, 1.675, 0.27272727272727
88373, 0.39130434782609, 1.675, 0.31818181818182
88374, 0.39130434782609, 1.675, 0.36363636363636
88375, 0.39130434782609, 1.675, 0.40909090909091
88376, 0.39130434782609, 1.675, 0.45454545454545
88377, 0.34782608695652, 1.675, 0.045454545454545
88378, 0.34782608695652, 1.675, 0.090909090909091
88379, 0.34782608695652, 1.675, 0.13636363636364
88380, 0.34782608695652, 1.675, 0.18181818181818
88381, 0.34782608695652, 1.675, 0.22727272727273
88382, 0.34782608695652, 1.675, 0.27272727272727
88383, 0.34782608695652, 1.675, 0.31818181818182
88384, 0.34782608695652, 1.675, 0.36363636363636
88385, 0.34782608695652, 1.675, 0.40909090909091
88386, 0.34782608695652, 1.675, 0.45454545454545
88387, 0.30434782608696, 1.675, 0.045454545454545
88388, 0.30434782608696, 1.675, 0.090909090909091
88389, 0.30434782608696, 1.675, 0.13636363636364
88390, 0.30434782608696, 1.675, 0.18181818181818
88391, 0.30434782608696, 1.675, 0.22727272727273
88392, 0.30434782608696, 1.675, 0.27272727272727
88393, 0.30434782608696, 1.675, 0.31818181818182
88394, 0.30434782608696, 1.675, 0.36363636363636
88395, 0.30434782608696, 1.675, 0.40909090909091
88396, 0.30434782608696, 1.675, 0.45454545454545
88397, 0.26086956521739, 1.675, 0.045454545454545
88398, 0.26086956521739, 1.675, 0.090909090909091
88399, 0.26086956521739, 1.675, 0.13636363636364
88400, 0.26086956521739, 1.675, 0.18181818181818
88401, 0.26086956521739, 1.675, 0.22727272727273
88402, 0.26086956521739, 1.675, 0.27272727272727
88403, 0.26086956521739, 1.675, 0.31818181818182
88404, 0.26086956521739, 1.675, 0.36363636363636
88405, 0.26086956521739, 1.675, 0.40909090909091
88406, 0.26086956521739, 1.675, 0.45454545454545
88407, 0.21739130434783, 1.675, 0.045454545454545
88408, 0.21739130434783, 1.675, 0.090909090909091
88409, 0.21739130434783, 1.675, 0.13636363636364
88410, 0.21739130434783, 1.675, 0.18181818181818
88411, 0.21739130434783, 1.675, 0.22727272727273
88412, 0.21739130434783, 1.675, 0.27272727272727
88413, 0.21739130434783, 1.675, 0.31818181818182
88414, 0.21739130434783, 1.675, 0.36363636363636
88415, 0.21739130434783, 1.675, 0.40909090909091
88416, 0.21739130434783, 1.675, 0.45454545454545
88417, 0.17391304347826, 1.675, 0.045454545454545
88418, 0.17391304347826, 1.675, 0.090909090909091
88419, 0.17391304347826, 1.675, 0.13636363636364
88420, 0.17391304347826, 1.675, 0.18181818181818
88421, 0.17391304347826, 1.675, 0.22727272727273
88422, 0.17391304347826, 1.675, 0.27272727272727
88423, 0.17391304347826, 1.675, 0.31818181818182
88424, 0.17391304347826, 1.675, 0.36363636363636
88425, 0.17391304347826, 1.675, 0.40909090909091
88426, 0.17391304347826, 1.675, 0.45454545454545
88427, 0.1304347826087, 1.675, 0.045454545454545
88428, 0.1304347826087, 1.675, 0.090909090909091
88429, 0.1304347826087, 1.675, 0.13636363636364
88430, 0.1304347826087, 1.675, 0.18181818181818
88431, 0.1304347826087, 1.675, 0.22727272727273
88432, 0.1304347826087, 1.675, 0.27272727272727
88433, 0.1304347826087, 1.675, 0.31818181818182
88434, 0.1304347826087, 1.675, 0.36363636363636
88435, 0.1304347826087, 1.675, 0.40909090909091
88436, 0.1304347826087, 1.675, 0.45454545454545
88437, 0.08695652173913, 1.675, 0.045454545454545
88438, 0.08695652173913, 1.675, 0.090909090909091
88439, 0.08695652173913, 1.675, 0.13636363636364
88440, 0.08695652173913, 1.675, 0.18181818181818
88441, 0.08695652173913, 1.675, 0.22727272727273
88442, 0.08695652173913, 1.675, 0.27272727272727
88443, 0.08695652173913, 1.675, 0.31818181818182
88444, 0.08695652173913, 1.675, 0.36363636363636
88445, 0.08695652173913, 1.675, 0.40909090909091
88446, 0.08695652173913, 1.675, 0.45454545454545
88447, 0.043478260869565, 1.675, 0.045454545454545
88448, 0.043478260869565, 1.675, 0.090909090909091
88449, 0.043478260869565, 1.675, 0.13636363636364
88450, 0.043478260869565, 1.675, 0.18181818181818
88451, 0.043478260869565, 1.675, 0.22727272727273
88452, 0.043478260869565, 1.675, 0.27272727272727
88453, 0.043478260869565, 1.675, 0.31818181818182
88454, 0.043478260869565, 1.675, 0.36363636363636
88455, 0.043478260869565, 1.675, 0.40909090909091
88456, 0.043478260869565, 1.675, 0.45454545454545
88457, 1.04, 1.55, 0.45454545454545
88458, 1.04, 1.55, 0.40909090909091
88459, 1.04, 1.55, 0.36363636363636
88460, 1.04, 1.55, 0.31818181818182
88461, 1.04, 1.55, 0.27272727272727
88462, 1.04, 1.55, 0.22727272727273
88463, 1.04, 1.55, 0.18181818181818
88464, 1.04, 1.55, 0.13636363636364
88465, 1.04, 1.55, 0.090909090909091
88466, 1.04, 1.55, 0.045454545454545
88467, 1.08, 1.55, 0.45454545454545
88468, 1.08, 1.55, 0.40909090909091
88469, 1.08, 1.55, 0.36363636363636
88470, 1.08, 1.55, 0.31818181818182
88471, 1.08, 1.55, 0.27272727272727
88472, 1.08, 1.55, 0.22727272727273
88473, 1.08, 1.55, 0.18181818181818
88474, 1.08, 1.55, 0.13636363636364
88475, 1.08, 1.55, 0.090909090909091
88476, 1.08, 1.55, 0.045454545454545
88477, 1.12, 1.55, 0.45454545454545
88478, 1.12, 1.55, 0.40909090909091
88479, 1.12, 1.55, 0.36363636363636
88480, 1.12, 1.55, 0.31818181818182
88481, 1.12, 1.55, 0.27272727272727
88482, 1.12, 1.55, 0.22727272727273
88483, 1.12, 1.55, 0.18181818181818
88484, 1.12, 1.55, 0.13636363636364
88485, 1.12, 1.55, 0.090909090909091
88486, 1.12, 1.55, 0.045454545454545
88487, 1.16, 1.55, 0.45454545454545
88488, 1.16, 1.55, 0.40909090909091
88489, 1.16, 1.55, 0.36363636363636
88490, 1.16, 1.55, 0.31818181818182
88491, 1.16, 1.55, 0.27272727272727
88492, 1.16, 1.55, 0.22727272727273
88493, 1.16, 1.55, 0.18181818181818
88494, 1.16, 1.55, 0.13636363636364
88495, 1.16, 1.55, 0.090909090909091
88496, 1.16, 1.55, 0.045454545454545
88497, 1.04, 1.6, 0.45454545454545
88498, 1.04, 1.6, 0.40909090909091
88499, 1.04, 1.6, 0.36363636363636
88500, 1.04, 1.6, 0.31818181818182
88501, 1.04, 1.6, 0.27272727272727
88502, 1.04, 1.6, 0.22727272727273
88503, 1.04, 1.6, 0.18181818181818
88504, 1.04, 1.6, 0.13636363636364
88505, 1.04, 1.6, 0.090909090909091
88506, 1.04, 1.6, 0.045454545454545
88507, 1.08, 1.6, 0.45454545454545
88508, 1.08, 1.6, 0.40909090909091
88509, 1.08, 1.6, 0.36363636363636
88510, 1.08, 1.6, 0.31818181818182
88511, 1.08, 1.6, 0.27272727272727
88512, 1.08, 1.6, 0.22727272727273
88513, 1.08, 1.6, 0.18181818181818
88514, 1.08, 1.6, 0.13636363636364
88515, 1.08, 1.6, 0.090909090909091
88516, 1.08, 1.6, 0.045454545454545
88517, 1.12, 1.6, 0.45454545454545
88518, 1.12, 1.6, 0.40909090909091
88519, 1.12, 1.6, 0.36363636363636
88520, 1.12, 1.6, 0.31818181818182
88521, 1.12, 1.6, 0.27272727272727
88522, 1.12, 1.6, 0.22727272727273
88523, 1.12, 1.6, 0.18181818181818
88524, 1.12, 1.6, 0.13636363636364
88525, 1.12, 1.6, 0.090909090909091
88526, 1.12, 1.6, 0.045454545454545
88527, 1.16, 1.6, 0.45454545454545
88528, 1.16, 1.6, 0.40909090909091
88529, 1.16, 1.6, 0.36363636363636
88530, 1.16, 1.6, 0.31818181818182
88531, 1.16, 1.6, 0.27272727272727
88532, 1.16, 1.6, 0.22727272727273
88533, 1.16, 1.6, 0.18181818181818
88534, 1.16, 1.6, 0.13636363636364
88535, 1.16, 1.6, 0.090909090909091
88536, 1.16, 1.6, 0.045454545454545
88537, 1.04, 1.65, 0.45454545454545
88538, 1.04, 1.65, 0.40909090909091
88539, 1.04, 1.65, 0.36363636363636
88540, 1.04, 1.65, 0.31818181818182
88541, 1.04, 1.65, 0.27272727272727
88542, 1.04, 1.65, 0.22727272727273
88543, 1.04, 1.65, 0.18181818181818
88544, 1.04, 1.65, 0.13636363636364
88545, 1.04, 1.65, 0.090909090909091
88546, 1.04, 1.65, 0.045454545454545
88547, 1.08, 1.65, 0.45454545454545
88548, 1.08, 1.65, 0.40909090909091
88549, 1.08, 1.65, 0.36363636363636
88550, 1.08, 1.65, 0.31818181818182
88551, 1.08, 1.65, 0.27272727272727
88552, 1.08, 1.65, 0.22727272727273
88553, 1.08, 1.65, 0.18181818181818
88554, 1.08, 1.65, 0.13636363636364
88555, 1.08, 1.65, 0.090909090909091
88556, 1.08, 1.65, 0.045454545454545
88557, 1.12, 1.65, 0.45454545454545
88558, 1.12, 1.65, 0.40909090909091
88559, 1.12, 1.65, 0.36363636363636
88560, 1.12, 1.65, 0.31818181818182
88561, 1.12, 1.65, 0.27272727272727
88562, 1.12, 1.65, 0.22727272727273
88563, 1.12, 1.65, 0.18181818181818
88564, 1.12, 1.65, 0.13636363636364
88565, 1.12, 1.65, 0.090909090909091
88566, 1.12, 1.65, 0.045454545454545
88567, 1.16, 1.65, 0.45454545454545
88568, 1.16, 1.65, 0.40909090909091
88569, 1.16, 1.65, 0.36363636363636
88570, 1.16, 1.65, 0.31818181818182
88571, 1.16, 1.65, 0.27272727272727
88572, 1.16, 1.65, 0.22727272727273
88573, 1.16, 1.65, 0.18181818181818
88574, 1.16, 1.65, 0.13636363636364
88575, 1.16, 1.65, 0.090909090909091
88576, 1.16, 1.65, 0.045454545454545
88577, 1.04, 1.55, 0.47727272727273
88578, 1.02, 1.55, 0.45454545454545
88579, 1.04, 1.525, 0.45454545454545
88580, 1.04, 1.55, 0.43181818181818
88581, 1.02, 1.55, 0.40909090909091
88582, 1.04, 1.525, 0.40909090909091
88583, 1.04, 1.55, 0.38636363636364
88584, 1.02, 1.55, 0.36363636363636
88585, 1.04, 1.525, 0.36363636363636
88586, 1.04, 1.55, 0.34090909090909
88587, 1.02, 1.55, 0.31818181818182
88588, 1.04, 1.525, 0.31818181818182
88589, 1.04, 1.55, 0.29545454545455
88590, 1.02, 1.55, 0.27272727272727
88591, 1.04, 1.525, 0.27272727272727
88592, 1.04, 1.55, 0.25
88593, 1.02, 1.55, 0.22727272727273
88594, 1.04, 1.525, 0.22727272727273
88595, 1.04, 1.55, 0.20454545454545
88596, 1.02, 1.55, 0.18181818181818
88597, 1.04, 1.525, 0.18181818181818
88598, 1.04, 1.55, 0.15909090909091
88599, 1.02, 1.55, 0.13636363636364
88600, 1.04, 1.525, 0.13636363636364
88601, 1.04, 1.55, 0.11363636363636
88602, 1.02, 1.55, 0.090909090909091
88603, 1.04, 1.525, 0.090909090909091
88604, 1.04, 1.55, 0.068181818181818
88605, 1.02, 1.55, 0.045454545454545
88606, 1.04, 1.525, 0.045454545454545
88607, 1.04, 1.55, 0.022727272727273
88608, 1.08, 1.55, 0.47727272727273
88609, 1.06, 1.55, 0.45454545454545
88610, 1.08, 1.525, 0.45454545454545
88611, 1.08, 1.55, 0.43181818181818
88612, 1.06, 1.55, 0.40909090909091
88613, 1.08, 1.525, 0.40909090909091
88614, 1.08, 1.55, 0.38636363636364
88615, 1.06, 1.55, 0.36363636363636
88616, 1.08, 1.525, 0.36363636363636
88617, 1.08, 1.55, 0.34090909090909
88618, 1.06, 1.55, 0.31818181818182
88619, 1.08, 1.525, 0.31818181818182
88620, 1.08, 1.55, 0.29545454545455
88621, 1.06, 1.55, 0.27272727272727
88622, 1.08, 1.525, 0.27272727272727
88623, 1.08, 1.55, 0.25
88624, 1.06, 1.55, 0.22727272727273
88625, 1.08, 1.525, 0.22727272727273
88626, 1.08, 1.55, 0.20454545454545
88627, 1.06, 1.55, 0.18181818181818
88628, 1.08, 1.525, 0.18181818181818
88629, 1.08, 1.55, 0.15909090909091
88630, 1.06, 1.55, 0.13636363636364
88631, 1.08, 1.525, 0.13636363636364
88632, 1.08, 1.55, 0.11363636363636
88633, 1.06, 1.55, 0.090909090909091
88634, 1.08, 1.525, 0.090909090909091
88635, 1.08, 1.55, 0.068181818181818
88636, 1.06, 1.55, 0.045454545454545
88637, 1.08, 1.525, 0.045454545454545
88638, 1.08, 1.55, 0.022727272727273
88639, 1.12, 1.55, 0.47727272727273
88640, 1.1, 1.55, 0.45454545454545
88641, 1.12, 1.525, 0.45454545454545
88642, 1.12, 1.55, 0.43181818181818
88643, 1.1, 1.55, 0.40909090909091
88644, 1.12, 1.525, 0.40909090909091
88645, 1.12, 1.55, 0.38636363636364
88646, 1.1, 1.55, 0.36363636363636
88647, 1.12, 1.525, 0.36363636363636
88648, 1.12, 1.55, 0.34090909090909
88649, 1.1, 1.55, 0.31818181818182
88650, 1.12, 1.525, 0.31818181818182
88651, 1.12, 1.55, 0.29545454545455
88652, 1.1, 1.55, 0.27272727272727
88653, 1.12, 1.525, 0.27272727272727
88654, 1.12, 1.55, 0.25
88655, 1.1, 1.55, 0.22727272727273
88656, 1.12, 1.525, 0.22727272727273
88657, 1.12, 1.55, 0.20454545454545
88658, 1.1, 1.55, 0.18181818181818
88659, 1.12, 1.525, 0.18181818181818
88660, 1.12, 1.55, 0.15909090909091
88661, 1.1, 1.55, 0.13636363636364
88662, 1.12, 1.525, 0.13636363636364
88663, 1.12, 1.55, 0.11363636363636
88664, 1.1, 1.55, 0.090909090909091
88665, 1.12, 1.525, 0.090909090909091
88666, 1.12, 1.55, 0.068181818181818
88667, 1.1, 1.55, 0.045454545454545
88668, 1.12, 1.525, 0.045454545454545
88669, 1.12, 1.55, 0.022727272727273
88670, 1.16, 1.55, 0.47727272727273
88671, 1.14, 1.55, 0.45454545454545
88672, 1.16, 1.525, 0.45454545454545
88673, 1.16, 1.55, 0.43181818181818
88674, 1.14, 1.55, 0.40909090909091
88675, 1.16, 1.525, 0.40909090909091
88676, 1.16, 1.55, 0.38636363636364
88677, 1.14, 1.55, 0.36363636363636
88678, 1.16, 1.525, 0.36363636363636
88679, 1.16, 1.55, 0.34090909090909
88680, 1.14, 1.55, 0.31818181818182
88681, 1.16, 1.525, 0.31818181818182
88682, 1.16, 1.55, 0.29545454545455
88683, 1.14, 1.55, 0.27272727272727
88684, 1.16, 1.525, 0.27272727272727
88685, 1.16, 1.55, 0.25
88686, 1.14, 1.55, 0.22727272727273
88687, 1.16, 1.525, 0.22727272727273
88688, 1.16, 1.55, 0.20454545454545
88689, 1.14, 1.55, 0.18181818181818
88690, 1.16, 1.525, 0.18181818181818
88691, 1.16, 1.55, 0.15909090909091
88692, 1.14, 1.55, 0.13636363636364
88693, 1.16, 1.525, 0.13636363636364
88694, 1.16, 1.55, 0.11363636363636
88695, 1.14, 1.55, 0.090909090909091
88696, 1.16, 1.525, 0.090909090909091
88697, 1.16, 1.55, 0.068181818181818
88698, 1.14, 1.55, 0.045454545454545
88699, 1.16, 1.525, 0.045454545454545
88700, 1.16, 1.55, 0.022727272727273
88701, 1.18, 1.55, 0.45454545454545
88702, 1.18, 1.55, 0.40909090909091
88703, 1.18, 1.55, 0.36363636363636
88704, 1.18, 1.55, 0.31818181818182
88705, 1.18, 1.55, 0.27272727272727
88706, 1.18, 1.55, 0.22727272727273
88707, 1.18, 1.55, 0.18181818181818
88708, 1.18, 1.55, 0.13636363636364
88709, 1.18, 1.55, 0.090909090909091
88710, 1.18, 1.55, 0.045454545454545
88711, 1.04, 1.6, 0.47727272727273
88712, 1.02, 1.6, 0.45454545454545
88713, 1.04, 1.575, 0.45454545454545
88714, 1.04, 1.6, 0.43181818181818
88715, 1.02, 1.6, 0.40909090909091
88716, 1.04, 1.575, 0.40909090909091
88717, 1.04, 1.6, 0.38636363636364
88718, 1.02, 1.6, 0.36363636363636
88719, 1.04, 1.575, 0.36363636363636
88720, 1.04, 1.6, 0.34090909090909
88721, 1.02, 1.6, 0.31818181818182
88722, 1.04, 1.575, 0.31818181818182
88723, 1.04, 1.6, 0.29545454545455
88724, 1.02, 1.6, 0.27272727272727
88725, 1.04, 1.575, 0.27272727272727
88726, 1.04, 1.6, 0.25
88727, 1.02, 1.6, 0.22727272727273
88728, 1.04, 1.575, 0.22727272727273
88729, 1.04, 1.6, 0.20454545454545
88730, 1.02, 1.6, 0.18181818181818
88731, 1.04, 1.575, 0.18181818181818
88732, 1.04, 1.6, 0.15909090909091
88733, 1.02, 1.6, 0.13636363636364
88734, 1.04, 1.575, 0.13636363636364
88735, 1.04, 1.6, 0.11363636363636
88736, 1.02, 1.6, 0.090909090909091
88737, 1.04, 1.575, 0.090909090909091
88738, 1.04, 1.6, 0.068181818181818
88739, 1.02, 1.6, 0.045454545454545
88740, 1.04, 1.575, 0.045454545454545
88741, 1.04, 1.6, 0.022727272727273
88742, 1.08, 1.6, 0.47727272727273
88743, 1.06, 1.6, 0.45454545454545
88744, 1.08, 1.575, 0.45454545454545
88745, 1.08, 1.6, 0.43181818181818
88746, 1.06, 1.6, 0.40909090909091
88747, 1.08, 1.575, 0.40909090909091
88748, 1.08, 1.6, 0.38636363636364
88749, 1.06, 1.6, 0.36363636363636
88750, 1.08, 1.575, 0.36363636363636
88751, 1.08, 1.6, 0.34090909090909
88752, 1.06, 1.6, 0.31818181818182
88753, 1.08, 1.575, 0.31818181818182
88754, 1.08, 1.6, 0.29545454545455
88755, 1.06, 1.6, 0.27272727272727
88756, 1.08, 1.575, 0.27272727272727
88757, 1.08, 1.6, 0.25
88758, 1.06, 1.6, 0.22727272727273
88759, 1.08, 1.575, 0.22727272727273
88760, 1.08, 1.6, 0.20454545454545
88761, 1.06, 1.6, 0.18181818181818
88762, 1.08, 1.575, 0.18181818181818
88763, 1.08, 1.6, 0.15909090909091
88764, 1.06, 1.6, 0.13636363636364
88765, 1.08, 1.575, 0.13636363636364
88766, 1.08, 1.6, 0.11363636363636
88767, 1.06, 1.6, 0.090909090909091
88768, 1.08, 1.575, 0.090909090909091
88769, 1.08, 1.6, 0.068181818181818
88770, 1.06, 1.6, 0.045454545454545
88771, 1.08, 1.575, 0.045454545454545
88772, 1.08, 1.6, 0.022727272727273
88773, 1.12, 1.6, 0.47727272727273
88774, 1.1, 1.6, 0.45454545454545
88775, 1.12, 1.575, 0.45454545454545
88776, 1.12, 1.6, 0.43181818181818
88777, 1.1, 1.6, 0.40909090909091
88778, 1.12, 1.575, 0.40909090909091
88779, 1.12, 1.6, 0.38636363636364
88780, 1.1, 1.6, 0.36363636363636
88781, 1.12, 1.575, 0.36363636363636
88782, 1.12, 1.6, 0.34090909090909
88783, 1.1, 1.6, 0.31818181818182
88784, 1.12, 1.575, 0.31818181818182
88785, 1.12, 1.6, 0.29545454545455
88786, 1.1, 1.6, 0.27272727272727
88787, 1.12, 1.575, 0.27272727272727
88788, 1.12, 1.6, 0.25
88789, 1.1, 1.6, 0.22727272727273
88790, 1.12, 1.575, 0.22727272727273
88791, 1.12, 1.6, 0.20454545454545
88792, 1.1, 1.6, 0.18181818181818
88793, 1.12, 1.575, 0.18181818181818
88794, 1.12, 1.6, 0.15909090909091
88795, 1.1, 1.6, 0.13636363636364
88796, 1.12, 1.575, 0.13636363636364
88797, 1.12, 1.6, 0.11363636363636
88798, 1.1, 1.6, 0.090909090909091
88799, 1.12, 1.575, 0.090909090909091
88800, 1.12, 1.6, 0.068181818181818
88801, 1.1, 1.6, 0.045454545454545
88802, 1.12, 1.575, 0.045454545454545
88803, 1.12, 1.6, 0.022727272727273
88804, 1.16, 1.6, 0.47727272727273
88805, 1.14, 1.6, 0.45454545454545
88806, 1.16, 1.575, 0.45454545454545
88807, 1.16, 1.6, 0.43181818181818
88808, 1.14, 1.6, 0.40909090909091
88809, 1.16, 1.575, 0.40909090909091
88810, 1.16, 1.6, 0.38636363636364
88811, 1.14, 1.6, 0.36363636363636
88812, 1.16, 1.575, 0.36363636363636
88813, 1.16, 1.6, 0.34090909090909
88814, 1.14, 1.6, 0.31818181818182
88815, 1.16, 1.575, 0.31818181818182
88816, 1.16, 1.6, 0.29545454545455
88817, 1.14, 1.6, 0.27272727272727
88818, 1.16, 1.575, 0.27272727272727
88819, 1.16, 1.6, 0.25
88820, 1.14, 1.6, 0.22727272727273
88821, 1.16, 1.575, 0.22727272727273
88822, 1.16, 1.6, 0.20454545454545
88823, 1.14, 1.6, 0.18181818181818
88824, 1.16, 1.575, 0.18181818181818
88825, 1.16, 1.6, 0.15909090909091
88826, 1.14, 1.6, 0.13636363636364
88827, 1.16, 1.575, 0.13636363636364
88828, 1.16, 1.6, 0.11363636363636
88829, 1.14, 1.6, 0.090909090909091
88830, 1.16, 1.575, 0.090909090909091
88831, 1.16, 1.6, 0.068181818181818
88832, 1.14, 1.6, 0.045454545454545
88833, 1.16, 1.575, 0.045454545454545
88834, 1.16, 1.6, 0.022727272727273
88835, 1.18, 1.6, 0.45454545454545
88836, 1.18, 1.6, 0.40909090909091
88837, 1.18, 1.6, 0.36363636363636
88838, 1.18, 1.6, 0.31818181818182
88839, 1.18, 1.6, 0.27272727272727
88840, 1.18, 1.6, 0.22727272727273
88841, 1.18, 1.6, 0.18181818181818
88842, 1.18, 1.6, 0.13636363636364
88843, 1.18, 1.6, 0.090909090909091
88844, 1.18, 1.6, 0.045454545454545
88845, 1.04, 1.65, 0.47727272727273
88846, 1.02, 1.65, 0.45454545454545
88847, 1.04, 1.625, 0.45454545454545
88848, 1.04, 1.65, 0.43181818181818
88849, 1.02, 1.65, 0.40909090909091
88850, 1.04, 1.625, 0.40909090909091
88851, 1.04, 1.65, 0.38636363636364
88852, 1.02, 1.65, 0.36363636363636
88853, 1.04, 1.625, 0.36363636363636
88854, 1.04, 1.65, 0.34090909090909
88855, 1.02, 1.65, 0.31818181818182
88856, 1.04, 1.625, 0.31818181818182
88857, 1.04, 1.65, 0.29545454545455
88858, 1.02, 1.65, 0.27272727272727
88859, 1.04, 1.625, 0.27272727272727
88860, 1.04, 1.65, 0.25
88861, 1.02, 1.65, 0.22727272727273
88862, 1.04, 1.625, 0.22727272727273
88863, 1.04, 1.65, 0.20454545454545
88864, 1.02, 1.65, 0.18181818181818
88865, 1.04, 1.625, 0.18181818181818
88866, 1.04, 1.65, 0.15909090909091
88867, 1.02, 1.65, 0.13636363636364
88868, 1.04, 1.625, 0.13636363636364
88869, 1.04, 1.65, 0.11363636363636
88870, 1.02, 1.65, 0.090909090909091
88871, 1.04, 1.625, 0.090909090909091
88872, 1.04, 1.65, 0.068181818181818
88873, 1.02, 1.65, 0.045454545454545
88874, 1.04, 1.625, 0.045454545454545
88875, 1.04, 1.65, 0.022727272727273
88876, 1.08, 1.65, 0.47727272727273
88877, 1.06, 1.65, 0.45454545454545
88878, 1.08, 1.625, 0.45454545454545
88879, 1.08, 1.65, 0.43181818181818
88880, 1.06, 1.65, 0.40909090909091
88881, 1.08, 1.625, 0.40909090909091
88882, 1.08, 1.65, 0.38636363636364
88883, 1.06, 1.65, 0.36363636363636
88884, 1.08, 1.625, 0.36363636363636
88885, 1.08, 1.65, 0.34090909090909
88886, 1.06, 1.65, 0.31818181818182
88887, 1.08, 1.625, 0.31818181818182
88888, 1.08, 1.65, 0.29545454545455
88889, 1.06, 1.65, 0.27272727272727
88890, 1.08, 1.625, 0.27272727272727
88891, 1.08, 1.65, 0.25
88892, 1.06, 1.65, 0.22727272727273
88893, 1.08, 1.625, 0.22727272727273
88894, 1.08, 1.65, 0.20454545454545
88895, 1.06, 1.65, 0.18181818181818
88896, 1.08, 1.625, 0.18181818181818
88897, 1.08, 1.65, 0.15909090909091
88898, 1.06, 1.65, 0.13636363636364
88899, 1.08, 1.625, 0.13636363636364
88900, 1.08, 1.65, 0.11363636363636
88901, 1.06, 1.65, 0.090909090909091
88902, 1.08, 1.625, 0.090909090909091
88903, 1.08, 1.65, 0.068181818181818
88904, 1.06, 1.65, 0.045454545454545
88905, 1.08, 1.625, 0.045454545454545
88906, 1.08, 1.65, 0.022727272727273
88907, 1.12, 1.65, 0.47727272727273
88908, 1.1, 1.65, 0.45454545454545
88909, 1.12, 1.625, 0.45454545454545
88910, 1.12, 1.65, 0.43181818181818
88911, 1.1, 1.65, 0.40909090909091
88912, 1.12, 1.625, 0.40909090909091
88913, 1.12, 1.65, 0.38636363636364
88914, 1.1, 1.65, 0.36363636363636
88915, 1.12, 1.625, 0.36363636363636
88916, 1.12, 1.65, 0.34090909090909
88917, 1.1, 1.65, 0.31818181818182
88918, 1.12, 1.625, 0.31818181818182
88919, 1.12, 1.65, 0.29545454545455
88920, 1.1, 1.65, 0.27272727272727
88921, 1.12, 1.625, 0.27272727272727
88922, 1.12, 1.65, 0.25
88923, 1.1, 1.65, 0.22727272727273
88924, 1.12, 1.625, 0.22727272727273
88925, 1.12, 1.65, 0.20454545454545
88926, 1.1, 1.65, 0.18181818181818
88927, 1.12, 1.625, 0.18181818181818
88928, 1.12, 1.65, 0.15909090909091
88929, 1.1, 1.65, 0.13636363636364
88930, 1.12, 1.625, 0.13636363636364
88931, 1.12, 1.65, 0.11363636363636
88932, 1.1, 1.65, 0.090909090909091
88933, 1.12, 1.625, 0.090909090909091
88934, 1.12, 1.65, 0.068181818181818
88935, 1.1, 1.65, 0.045454545454545
88936, 1.12, 1.625, 0.045454545454545
88937, 1.12, 1.65, 0.022727272727273
88938, 1.16, 1.65, 0.47727272727273
88939, 1.14, 1.65, 0.45454545454545
88940, 1.16, 1.625, 0.45454545454545
88941, 1.16, 1.65, 0.43181818181818
88942, 1.14, 1.65, 0.40909090909091
88943, 1.16, 1.625, 0.40909090909091
88944, 1.16, 1.65, 0.38636363636364
88945, 1.14, 1.65, 0.36363636363636
88946, 1.16, 1.625, 0.36363636363636
88947, 1.16, 1.65, 0.34090909090909
88948, 1.14, 1.65, 0.31818181818182
88949, 1.16, 1.625, 0.31818181818182
88950, 1.16, 1.65, 0.29545454545455
88951, 1.14, 1.65, 0.27272727272727
88952, 1.16, 1.625, 0.27272727272727
88953, 1.16, 1.65, 0.25
88954, 1.14, 1.65, 0.22727272727273
88955, 1.16, 1.625, 0.22727272727273
88956, 1.16, 1.65, 0.20454545454545
88957, 1.14, 1.65, 0.18181818181818
88958, 1.16, 1.625, 0.18181818181818
88959, 1.16, 1.65, 0.15909090909091
88960, 1.14, 1.65, 0.13636363636364
88961, 1.16, 1.625, 0.13636363636364
88962, 1.16, 1.65, 0.11363636363636
88963, 1.14, 1.65, 0.090909090909091
88964, 1.16, 1.625, 0.090909090909091
88965, 1.16, 1.65, 0.068181818181818
88966, 1.14, 1.65, 0.045454545454545
88967, 1.16, 1.625, 0.045454545454545
88968, 1.16, 1.65, 0.022727272727273
88969, 1.18, 1.65, 0.45454545454545
88970, 1.18, 1.65, 0.40909090909091
88971, 1.18, 1.65, 0.36363636363636
88972, 1.18, 1.65, 0.31818181818182
88973, 1.18, 1.65, 0.27272727272727
88974, 1.18, 1.65, 0.22727272727273
88975, 1.18, 1.65, 0.18181818181818
88976, 1.18, 1.65, 0.13636363636364
88977, 1.18, 1.65, 0.090909090909091
88978, 1.18, 1.65, 0.045454545454545
88979, 1.04, 1.675, 0.45454545454545
88980, 1.04, 1.675, 0.40909090909091
88981, 1.04, 1.675, 0.36363636363636
88982, 1.04, 1.675, 0.31818181818182
88983, 1.04, 1.675, 0.27272727272727
88984, 1.04, 1.675, 0.22727272727273
88985, 1.04, 1.675, 0.18181818181818
88986, 1.04, 1.675, 0.13636363636364
88987, 1.04, 1.675, 0.090909090909091
88988, 1.04, 1.675, 0.045454545454545
88989, 1.08, 1.675, 0.45454545454545
88990, 1.08, 1.675, 0.40909090909091
88991, 1.08, 1.675, 0.36363636363636
88992, 1.08, 1.675, 0.31818181818182
88993, 1.08, 1.675, 0.27272727272727
88994, 1.08, 1.675, 0.22727272727273
88995, 1.08, 1.675, 0.18181818181818
88996, 1.08, 1.675, 0.13636363636364
88997, 1.08, 1.675, 0.090909090909091
88998, 1.08, 1.675, 0.045454545454545
88999, 1.12, 1.675, 0.45454545454545
89000, 1.12, 1.675, 0.40909090909091
89001, 1.12, 1.675, 0.36363636363636
89002, 1.12, 1.675, 0.31818181818182
89003, 1.12, 1.675, 0.27272727272727
89004, 1.12, 1.675, 0.22727272727273
89005, 1.12, 1.675, 0.18181818181818
89006, 1.12, 1.675, 0.13636363636364
89007, 1.12, 1.675, 0.090909090909091
89008, 1.12, 1.675, 0.045454545454545
89009, 1.16, 1.675, 0.45454545454545
89010, 1.16, 1.675, 0.40909090909091
89011, 1.16, 1.675, 0.36363636363636
89012, 1.16, 1.675, 0.31818181818182
89013, 1.16, 1.675, 0.27272727272727
89014, 1.16, 1.675, 0.22727272727273
89015, 1.16, 1.675, 0.18181818181818
89016, 1.16, 1.675, 0.13636363636364
89017, 1.16, 1.675, 0.090909090909091
89018, 1.16, 1.675, 0.045454545454545
89019, 1.2434782608696, 1.55, 0.45454545454545
89020, 1.2434782608696, 1.55, 0.40909090909091
89021, 1.2434782608696, 1.55, 0.36363636363636
89022, 1.2434782608696, 1.55, 0.31818181818182
89023, 1.2434782608696, 1.55, 0.27272727272727
89024, 1.2434782608696, 1.55, 0.22727272727273
89025, 1.2434782608696, 1.55, 0.18181818181818
89026, 1.2434782608696, 1.55, 0.13636363636364
89027, 1.2434782608696, 1.55, 0.090909090909091
89028, 1.2434782608696, 1.55, 0.045454545454545
89029, 1.2869565217391, 1.55, 0.45454545454545
89030, 1.2869565217391, 1.55, 0.40909090909091
89031, 1.2869565217391, 1.55, 0.36363636363636
89032, 1.2869565217391, 1.55, 0.31818181818182
89033, 1.2869565217391, 1.55, 0.27272727272727
89034, 1.2869565217391, 1.55, 0.22727272727273
89035, 1.2869565217391, 1.55, 0.18181818181818
89036, 1.2869565217391, 1.55, 0.13636363636364
89037, 1.2869565217391, 1.55, 0.090909090909091
89038, 1.2869565217391, 1.55, 0.045454545454545
89039, 1.3304347826087, 1.55, 0.45454545454545
89040, 1.3304347826087, 1.55, 0.40909090909091
89041, 1.3304347826087, 1.55, 0.36363636363636
89042, 1.3304347826087, 1.55, 0.31818181818182
89043, 1.3304347826087, 1.55, 0.27272727272727
89044, 1.3304347826087, 1.55, 0.22727272727273
89045, 1.3304347826087, 1.55, 0.18181818181818
89046, 1.3304347826087, 1.55, 0.13636363636364
89047, 1.3304347826087, 1.55, 0.090909090909091
89048, 1.3304347826087, 1.55, 0.045454545454545
89049, 1.3739130434783, 1.55, 0.45454545454545
89050, 1.3739130434783, 1.55, 0.40909090909091
89051, 1.3739130434783, 1.55, 0.36363636363636
89052, 1.3739130434783, 1.55, 0.31818181818182
89053, 1.3739130434783, 1.55, 0.27272727272727
89054, 1.3739130434783, 1.55, 0.22727272727273
89055, 1.3739130434783, 1.55, 0.18181818181818
89056, 1.3739130434783, 1.55, 0.13636363636364
89057, 1.3739130434783, 1.55, 0.090909090909091
89058, 1.3739130434783, 1.55, 0.045454545454545
89059, 1.4173913043478, 1.55, 0.45454545454545
89060, 1.4173913043478, 1.55, 0.40909090909091
89061, 1.4173913043478, 1.55, 0.36363636363636
89062, 1.4173913043478, 1.55, 0.31818181818182
89063, 1.4173913043478, 1.55, 0.27272727272727
89064, 1.4173913043478, 1.55, 0.22727272727273
89065, 1.4173913043478, 1.55, 0.18181818181818
89066, 1.4173913043478, 1.55, 0.13636363636364
89067, 1.4173913043478, 1.55, 0.090909090909091
89068, 1.4173913043478, 1.55, 0.045454545454545
89069, 1.4608695652174, 1.55, 0.45454545454545
89070, 1.4608695652174, 1.55, 0.40909090909091
89071, 1.4608695652174, 1.55, 0.36363636363636
89072, 1.4608695652174, 1.55, 0.31818181818182
89073, 1.4608695652174, 1.55, 0.27272727272727
89074, 1.4608695652174, 1.55, 0.22727272727273
89075, 1.4608695652174, 1.55, 0.18181818181818
89076, 1.4608695652174, 1.55, 0.13636363636364
89077, 1.4608695652174, 1.55, 0.090909090909091
89078, 1.4608695652174, 1.55, 0.045454545454545
89079, 1.504347826087, 1.55, 0.45454545454545
89080, 1.504347826087, 1.55, 0.40909090909091
89081, 1.504347826087, 1.55, 0.36363636363636
89082, 1.504347826087, 1.55, 0.31818181818182
89083, 1.504347826087, 1.55, 0.27272727272727
89084, 1.504347826087, 1.55, 0.22727272727273
89085, 1.504347826087, 1.55, 0.18181818181818
89086, 1.504347826087, 1.55, 0.13636363636364
89087, 1.504347826087, 1.55, 0.090909090909091
89088, 1.504347826087, 1.55, 0.045454545454545
89089, 1.5478260869565, 1.55, 0.45454545454545
89090, 1.5478260869565, 1.55, 0.40909090909091
89091, 1.5478260869565, 1.55, 0.36363636363636
89092, 1.5478260869565, 1.55, 0.31818181818182
89093, 1.5478260869565, 1.55, 0.27272727272727
89094, 1.5478260869565, 1.55, 0.22727272727273
89095, 1.5478260869565, 1.55, 0.18181818181818
89096, 1.5478260869565, 1.55, 0.13636363636364
89097, 1.5478260869565, 1.55, 0.090909090909091
89098, 1.5478260869565, 1.55, 0.045454545454545
89099, 1.5913043478261, 1.55, 0.45454545454545
89100, 1.5913043478261, 1.55, 0.40909090909091
89101, 1.5913043478261, 1.55, 0.36363636363636
89102, 1.5913043478261, 1.55, 0.31818181818182
89103, 1.5913043478261, 1.55, 0.27272727272727
89104, 1.5913043478261, 1.55, 0.22727272727273
89105, 1.5913043478261, 1.55, 0.18181818181818
89106, 1.5913043478261, 1.55, 0.13636363636364
89107, 1.5913043478261, 1.55, 0.090909090909091
89108, 1.5913043478261, 1.55, 0.045454545454545
89109, 1.6347826086957, 1.55, 0.45454545454545
89110, 1.6347826086957, 1.55, 0.40909090909091
89111, 1.6347826086957, 1.55, 0.36363636363636
89112, 1.6347826086957, 1.55, 0.31818181818182
89113, 1.6347826086957, 1.55, 0.27272727272727
89114, 1.6347826086957, 1.55, 0.22727272727273
89115, 1.6347826086957, 1.55, 0.18181818181818
89116, 1.6347826086957, 1.55, 0.13636363636364
89117, 1.6347826086957, 1.55, 0.090909090909091
89118, 1.6347826086957, 1.55, 0.045454545454545
89119, 1.6782608695652, 1.55, 0.45454545454545
89120, 1.6782608695652, 1.55, 0.40909090909091
89121, 1.6782608695652, 1.55, 0.36363636363636
89122, 1.6782608695652, 1.55, 0.31818181818182
89123, 1.6782608695652, 1.55, 0.27272727272727
89124, 1.6782608695652, 1.55, 0.22727272727273
89125, 1.6782608695652, 1.55, 0.18181818181818
89126, 1.6782608695652, 1.55, 0.13636363636364
89127, 1.6782608695652, 1.55, 0.090909090909091
89128, 1.6782608695652, 1.55, 0.045454545454545
89129, 1.7217391304348, 1.55, 0.45454545454545
89130, 1.7217391304348, 1.55, 0.40909090909091
89131, 1.7217391304348, 1.55, 0.36363636363636
89132, 1.7217391304348, 1.55, 0.31818181818182
89133, 1.7217391304348, 1.55, 0.27272727272727
89134, 1.7217391304348, 1.55, 0.22727272727273
89135, 1.7217391304348, 1.55, 0.18181818181818
89136, 1.7217391304348, 1.55, 0.13636363636364
89137, 1.7217391304348, 1.55, 0.090909090909091
89138, 1.7217391304348, 1.55, 0.045454545454545
89139, 1.7652173913043, 1.55, 0.45454545454545
89140, 1.7652173913043, 1.55, 0.40909090909091
89141, 1.7652173913043, 1.55, 0.36363636363636
89142, 1.7652173913043, 1.55, 0.31818181818182
89143, 1.7652173913043, 1.55, 0.27272727272727
89144, 1.7652173913043, 1.55, 0.22727272727273
89145, 1.7652173913043, 1.55, 0.18181818181818
89146, 1.7652173913043, 1.55, 0.13636363636364
89147, 1.7652173913043, 1.55, 0.090909090909091
89148, 1.7652173913043, 1.55, 0.045454545454545
