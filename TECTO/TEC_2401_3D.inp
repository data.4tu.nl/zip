53310, 0.95652173913043, 1.245652173913, 0.34090909090909
53311, 0.97826086956522, 1.245652173913, 0.36363636363636
53312, 0.95652173913043, 1.2195652173913, 0.36363636363636
53313, 0.95652173913043, 1.245652173913, 0.38636363636364
53314, 0.97826086956522, 1.245652173913, 0.40909090909091
53315, 0.95652173913043, 1.2195652173913, 0.40909090909091
53316, 0.95652173913043, 1.245652173913, 0.43181818181818
53317, 0.97826086956522, 1.245652173913, 0.45454545454545
53318, 0.95652173913044, 1.2195652173913, 0.45454545454545
53319, 0.95652173913043, 1.245652173913, 0.47727272727273
53320, 0.91304347826087, 1.245652173913, 0.022727272727273
53321, 0.93478260869565, 1.245652173913, 0.045454545454545
53322, 0.91304347826087, 1.2195652173913, 0.045454545454545
53323, 0.91304347826087, 1.245652173913, 0.068181818181818
53324, 0.93478260869565, 1.245652173913, 0.090909090909091
53325, 0.91304347826087, 1.2195652173913, 0.090909090909091
53326, 0.91304347826087, 1.245652173913, 0.11363636363636
53327, 0.93478260869565, 1.245652173913, 0.13636363636364
53328, 0.91304347826087, 1.2195652173913, 0.13636363636364
53329, 0.91304347826087, 1.245652173913, 0.15909090909091
53330, 0.93478260869565, 1.245652173913, 0.18181818181818
53331, 0.91304347826087, 1.2195652173913, 0.18181818181818
53332, 0.91304347826087, 1.245652173913, 0.20454545454545
53333, 0.93478260869565, 1.245652173913, 0.22727272727273
53334, 0.91304347826087, 1.2195652173913, 0.22727272727273
53335, 0.91304347826087, 1.245652173913, 0.25
53336, 0.93478260869565, 1.245652173913, 0.27272727272727
53337, 0.91304347826087, 1.2195652173913, 0.27272727272727
53338, 0.91304347826087, 1.245652173913, 0.29545454545455
53339, 0.93478260869565, 1.245652173913, 0.31818181818182
53340, 0.91304347826087, 1.2195652173913, 0.31818181818182
53341, 0.91304347826087, 1.245652173913, 0.34090909090909
53342, 0.93478260869565, 1.245652173913, 0.36363636363636
53343, 0.91304347826087, 1.2195652173913, 0.36363636363636
53344, 0.91304347826087, 1.245652173913, 0.38636363636364
53345, 0.93478260869565, 1.245652173913, 0.40909090909091
53346, 0.91304347826087, 1.2195652173913, 0.40909090909091
53347, 0.91304347826087, 1.245652173913, 0.43181818181818
53348, 0.93478260869565, 1.245652173913, 0.45454545454545
53349, 0.91304347826087, 1.2195652173913, 0.45454545454545
53350, 0.91304347826087, 1.245652173913, 0.47727272727273
53351, 0.8695652173913, 1.245652173913, 0.022727272727273
53352, 0.89130434782609, 1.245652173913, 0.045454545454545
53353, 0.8695652173913, 1.2195652173913, 0.045454545454545
53354, 0.8695652173913, 1.245652173913, 0.068181818181818
53355, 0.89130434782609, 1.245652173913, 0.090909090909091
53356, 0.8695652173913, 1.2195652173913, 0.090909090909091
53357, 0.8695652173913, 1.245652173913, 0.11363636363636
53358, 0.89130434782609, 1.245652173913, 0.13636363636364
53359, 0.8695652173913, 1.2195652173913, 0.13636363636364
53360, 0.8695652173913, 1.245652173913, 0.15909090909091
53361, 0.89130434782609, 1.245652173913, 0.18181818181818
53362, 0.8695652173913, 1.2195652173913, 0.18181818181818
53363, 0.8695652173913, 1.245652173913, 0.20454545454545
53364, 0.89130434782609, 1.245652173913, 0.22727272727273
53365, 0.8695652173913, 1.2195652173913, 0.22727272727273
53366, 0.8695652173913, 1.245652173913, 0.25
53367, 0.89130434782609, 1.245652173913, 0.27272727272727
53368, 0.8695652173913, 1.2195652173913, 0.27272727272727
53369, 0.8695652173913, 1.245652173913, 0.29545454545455
53370, 0.89130434782609, 1.245652173913, 0.31818181818182
53371, 0.8695652173913, 1.2195652173913, 0.31818181818182
53372, 0.8695652173913, 1.245652173913, 0.34090909090909
53373, 0.89130434782609, 1.245652173913, 0.36363636363636
53374, 0.8695652173913, 1.2195652173913, 0.36363636363636
53375, 0.8695652173913, 1.245652173913, 0.38636363636364
53376, 0.89130434782609, 1.245652173913, 0.40909090909091
53377, 0.8695652173913, 1.2195652173913, 0.40909090909091
53378, 0.8695652173913, 1.245652173913, 0.43181818181818
53379, 0.89130434782609, 1.245652173913, 0.45454545454545
53380, 0.8695652173913, 1.2195652173913, 0.45454545454545
53381, 0.8695652173913, 1.245652173913, 0.47727272727273
53382, 0.82608695652174, 1.245652173913, 0.022727272727273
53383, 0.84782608695652, 1.245652173913, 0.045454545454545
53384, 0.82608695652174, 1.2195652173913, 0.045454545454545
53385, 0.82608695652174, 1.245652173913, 0.068181818181818
53386, 0.84782608695652, 1.245652173913, 0.090909090909091
53387, 0.82608695652174, 1.2195652173913, 0.090909090909091
53388, 0.82608695652174, 1.245652173913, 0.11363636363636
53389, 0.84782608695652, 1.245652173913, 0.13636363636364
53390, 0.82608695652174, 1.2195652173913, 0.13636363636364
53391, 0.82608695652174, 1.245652173913, 0.15909090909091
53392, 0.84782608695652, 1.245652173913, 0.18181818181818
53393, 0.82608695652174, 1.2195652173913, 0.18181818181818
53394, 0.82608695652174, 1.245652173913, 0.20454545454545
53395, 0.84782608695652, 1.245652173913, 0.22727272727273
53396, 0.82608695652174, 1.2195652173913, 0.22727272727273
53397, 0.82608695652174, 1.245652173913, 0.25
53398, 0.84782608695652, 1.245652173913, 0.27272727272727
53399, 0.82608695652174, 1.2195652173913, 0.27272727272727
53400, 0.82608695652174, 1.245652173913, 0.29545454545455
53401, 0.84782608695652, 1.245652173913, 0.31818181818182
53402, 0.82608695652174, 1.2195652173913, 0.31818181818182
53403, 0.82608695652174, 1.245652173913, 0.34090909090909
53404, 0.84782608695652, 1.245652173913, 0.36363636363636
53405, 0.82608695652174, 1.2195652173913, 0.36363636363636
53406, 0.82608695652174, 1.245652173913, 0.38636363636364
53407, 0.84782608695652, 1.245652173913, 0.40909090909091
53408, 0.82608695652174, 1.2195652173913, 0.40909090909091
53409, 0.82608695652174, 1.245652173913, 0.43181818181818
53410, 0.84782608695652, 1.245652173913, 0.45454545454545
53411, 0.82608695652174, 1.2195652173913, 0.45454545454545
53412, 0.82608695652174, 1.245652173913, 0.47727272727273
53413, 0.78260869565217, 1.245652173913, 0.022727272727273
53414, 0.80434782608696, 1.245652173913, 0.045454545454545
53415, 0.78260869565217, 1.2195652173913, 0.045454545454545
53416, 0.78260869565217, 1.245652173913, 0.068181818181818
53417, 0.80434782608696, 1.245652173913, 0.090909090909091
53418, 0.78260869565217, 1.2195652173913, 0.090909090909091
53419, 0.78260869565217, 1.245652173913, 0.11363636363636
53420, 0.80434782608696, 1.245652173913, 0.13636363636364
53421, 0.78260869565217, 1.2195652173913, 0.13636363636364
53422, 0.78260869565217, 1.245652173913, 0.15909090909091
53423, 0.80434782608696, 1.245652173913, 0.18181818181818
53424, 0.78260869565217, 1.2195652173913, 0.18181818181818
53425, 0.78260869565217, 1.245652173913, 0.20454545454545
53426, 0.80434782608696, 1.245652173913, 0.22727272727273
53427, 0.78260869565217, 1.2195652173913, 0.22727272727273
53428, 0.78260869565217, 1.245652173913, 0.25
53429, 0.80434782608696, 1.245652173913, 0.27272727272727
53430, 0.78260869565217, 1.2195652173913, 0.27272727272727
53431, 0.78260869565217, 1.245652173913, 0.29545454545455
53432, 0.80434782608696, 1.245652173913, 0.31818181818182
53433, 0.78260869565217, 1.2195652173913, 0.31818181818182
53434, 0.78260869565217, 1.245652173913, 0.34090909090909
53435, 0.80434782608696, 1.245652173913, 0.36363636363636
53436, 0.78260869565217, 1.2195652173913, 0.36363636363636
53437, 0.78260869565217, 1.245652173913, 0.38636363636364
53438, 0.80434782608696, 1.245652173913, 0.40909090909091
53439, 0.78260869565217, 1.2195652173913, 0.40909090909091
53440, 0.78260869565217, 1.245652173913, 0.43181818181818
53441, 0.80434782608696, 1.245652173913, 0.45454545454545
53442, 0.78260869565217, 1.2195652173913, 0.45454545454545
53443, 0.78260869565217, 1.245652173913, 0.47727272727273
53444, 0.73913043478261, 1.245652173913, 0.022727272727273
53445, 0.76086956521739, 1.245652173913, 0.045454545454545
53446, 0.73913043478261, 1.2195652173913, 0.045454545454545
53447, 0.73913043478261, 1.245652173913, 0.068181818181818
53448, 0.76086956521739, 1.245652173913, 0.090909090909091
53449, 0.73913043478261, 1.2195652173913, 0.090909090909091
53450, 0.73913043478261, 1.245652173913, 0.11363636363636
53451, 0.76086956521739, 1.245652173913, 0.13636363636364
53452, 0.73913043478261, 1.2195652173913, 0.13636363636364
53453, 0.73913043478261, 1.245652173913, 0.15909090909091
53454, 0.76086956521739, 1.245652173913, 0.18181818181818
53455, 0.73913043478261, 1.2195652173913, 0.18181818181818
53456, 0.73913043478261, 1.245652173913, 0.20454545454545
53457, 0.76086956521739, 1.245652173913, 0.22727272727273
53458, 0.73913043478261, 1.2195652173913, 0.22727272727273
53459, 0.73913043478261, 1.245652173913, 0.25
53460, 0.76086956521739, 1.245652173913, 0.27272727272727
53461, 0.73913043478261, 1.2195652173913, 0.27272727272727
53462, 0.73913043478261, 1.245652173913, 0.29545454545455
53463, 0.76086956521739, 1.245652173913, 0.31818181818182
53464, 0.73913043478261, 1.2195652173913, 0.31818181818182
53465, 0.73913043478261, 1.245652173913, 0.34090909090909
53466, 0.76086956521739, 1.245652173913, 0.36363636363636
53467, 0.73913043478261, 1.2195652173913, 0.36363636363636
53468, 0.73913043478261, 1.245652173913, 0.38636363636364
53469, 0.76086956521739, 1.245652173913, 0.40909090909091
53470, 0.73913043478261, 1.2195652173913, 0.40909090909091
53471, 0.73913043478261, 1.245652173913, 0.43181818181818
53472, 0.76086956521739, 1.245652173913, 0.45454545454545
53473, 0.73913043478261, 1.2195652173913, 0.45454545454545
53474, 0.73913043478261, 1.245652173913, 0.47727272727273
53475, 0.69565217391304, 1.245652173913, 0.022727272727273
53476, 0.71739130434783, 1.245652173913, 0.045454545454545
53477, 0.69565217391304, 1.2195652173913, 0.045454545454545
53478, 0.69565217391304, 1.245652173913, 0.068181818181818
53479, 0.71739130434783, 1.245652173913, 0.090909090909091
53480, 0.69565217391304, 1.2195652173913, 0.090909090909091
53481, 0.69565217391304, 1.245652173913, 0.11363636363636
53482, 0.71739130434783, 1.245652173913, 0.13636363636364
53483, 0.69565217391304, 1.2195652173913, 0.13636363636364
53484, 0.69565217391304, 1.245652173913, 0.15909090909091
53485, 0.71739130434783, 1.245652173913, 0.18181818181818
53486, 0.69565217391304, 1.2195652173913, 0.18181818181818
53487, 0.69565217391304, 1.245652173913, 0.20454545454545
53488, 0.71739130434783, 1.245652173913, 0.22727272727273
53489, 0.69565217391304, 1.2195652173913, 0.22727272727273
53490, 0.69565217391304, 1.245652173913, 0.25
53491, 0.71739130434783, 1.245652173913, 0.27272727272727
53492, 0.69565217391304, 1.2195652173913, 0.27272727272727
53493, 0.69565217391304, 1.245652173913, 0.29545454545455
53494, 0.71739130434783, 1.245652173913, 0.31818181818182
53495, 0.69565217391304, 1.2195652173913, 0.31818181818182
53496, 0.69565217391304, 1.245652173913, 0.34090909090909
53497, 0.71739130434783, 1.245652173913, 0.36363636363636
53498, 0.69565217391304, 1.2195652173913, 0.36363636363636
53499, 0.69565217391304, 1.245652173913, 0.38636363636364
53500, 0.71739130434783, 1.245652173913, 0.40909090909091
53501, 0.69565217391304, 1.2195652173913, 0.40909090909091
53502, 0.69565217391304, 1.245652173913, 0.43181818181818
53503, 0.71739130434783, 1.245652173913, 0.45454545454545
53504, 0.69565217391304, 1.2195652173913, 0.45454545454545
53505, 0.69565217391304, 1.245652173913, 0.47727272727273
53506, 0.65217391304348, 1.245652173913, 0.022727272727273
53507, 0.67391304347826, 1.245652173913, 0.045454545454545
53508, 0.65217391304348, 1.2195652173913, 0.045454545454545
53509, 0.65217391304348, 1.245652173913, 0.068181818181818
53510, 0.67391304347826, 1.245652173913, 0.090909090909091
53511, 0.65217391304348, 1.2195652173913, 0.090909090909091
53512, 0.65217391304348, 1.245652173913, 0.11363636363636
53513, 0.67391304347826, 1.245652173913, 0.13636363636364
53514, 0.65217391304348, 1.2195652173913, 0.13636363636364
53515, 0.65217391304348, 1.245652173913, 0.15909090909091
53516, 0.67391304347826, 1.245652173913, 0.18181818181818
53517, 0.65217391304348, 1.2195652173913, 0.18181818181818
53518, 0.65217391304348, 1.245652173913, 0.20454545454545
53519, 0.67391304347826, 1.245652173913, 0.22727272727273
53520, 0.65217391304348, 1.2195652173913, 0.22727272727273
53521, 0.65217391304348, 1.245652173913, 0.25
53522, 0.67391304347826, 1.245652173913, 0.27272727272727
53523, 0.65217391304348, 1.2195652173913, 0.27272727272727
53524, 0.65217391304348, 1.245652173913, 0.29545454545455
53525, 0.67391304347826, 1.245652173913, 0.31818181818182
53526, 0.65217391304348, 1.2195652173913, 0.31818181818182
53527, 0.65217391304348, 1.245652173913, 0.34090909090909
53528, 0.67391304347826, 1.245652173913, 0.36363636363636
53529, 0.65217391304348, 1.2195652173913, 0.36363636363636
53530, 0.65217391304348, 1.245652173913, 0.38636363636364
53531, 0.67391304347826, 1.245652173913, 0.40909090909091
53532, 0.65217391304348, 1.2195652173913, 0.40909090909091
53533, 0.65217391304348, 1.245652173913, 0.43181818181818
53534, 0.67391304347826, 1.245652173913, 0.45454545454545
53535, 0.65217391304348, 1.2195652173913, 0.45454545454545
53536, 0.65217391304348, 1.245652173913, 0.47727272727273
53537, 0.60869565217391, 1.245652173913, 0.022727272727273
53538, 0.6304347826087, 1.245652173913, 0.045454545454545
53539, 0.60869565217391, 1.2195652173913, 0.045454545454545
53540, 0.60869565217391, 1.245652173913, 0.068181818181818
53541, 0.6304347826087, 1.245652173913, 0.090909090909091
53542, 0.60869565217391, 1.2195652173913, 0.090909090909091
53543, 0.60869565217391, 1.245652173913, 0.11363636363636
53544, 0.6304347826087, 1.245652173913, 0.13636363636364
53545, 0.60869565217391, 1.2195652173913, 0.13636363636364
53546, 0.60869565217391, 1.245652173913, 0.15909090909091
53547, 0.6304347826087, 1.245652173913, 0.18181818181818
53548, 0.60869565217391, 1.2195652173913, 0.18181818181818
53549, 0.60869565217391, 1.245652173913, 0.20454545454545
53550, 0.6304347826087, 1.245652173913, 0.22727272727273
53551, 0.60869565217391, 1.2195652173913, 0.22727272727273
53552, 0.60869565217391, 1.245652173913, 0.25
53553, 0.6304347826087, 1.245652173913, 0.27272727272727
53554, 0.60869565217391, 1.2195652173913, 0.27272727272727
53555, 0.60869565217391, 1.245652173913, 0.29545454545455
53556, 0.6304347826087, 1.245652173913, 0.31818181818182
53557, 0.60869565217391, 1.2195652173913, 0.31818181818182
53558, 0.60869565217391, 1.245652173913, 0.34090909090909
53559, 0.6304347826087, 1.245652173913, 0.36363636363636
53560, 0.60869565217391, 1.2195652173913, 0.36363636363636
53561, 0.60869565217391, 1.245652173913, 0.38636363636364
53562, 0.6304347826087, 1.245652173913, 0.40909090909091
53563, 0.60869565217391, 1.2195652173913, 0.40909090909091
53564, 0.60869565217391, 1.245652173913, 0.43181818181818
53565, 0.6304347826087, 1.245652173913, 0.45454545454545
53566, 0.60869565217391, 1.2195652173913, 0.45454545454545
53567, 0.60869565217391, 1.245652173913, 0.47727272727273
53568, 0.56521739130435, 1.245652173913, 0.022727272727273
53569, 0.58695652173913, 1.245652173913, 0.045454545454545
53570, 0.56521739130435, 1.2195652173913, 0.045454545454545
53571, 0.56521739130435, 1.245652173913, 0.068181818181818
53572, 0.58695652173913, 1.245652173913, 0.090909090909091
53573, 0.56521739130435, 1.2195652173913, 0.090909090909091
53574, 0.56521739130435, 1.245652173913, 0.11363636363636
53575, 0.58695652173913, 1.245652173913, 0.13636363636364
53576, 0.56521739130435, 1.2195652173913, 0.13636363636364
53577, 0.56521739130435, 1.245652173913, 0.15909090909091
53578, 0.58695652173913, 1.245652173913, 0.18181818181818
53579, 0.56521739130435, 1.2195652173913, 0.18181818181818
53580, 0.56521739130435, 1.245652173913, 0.20454545454545
53581, 0.58695652173913, 1.245652173913, 0.22727272727273
53582, 0.56521739130435, 1.2195652173913, 0.22727272727273
53583, 0.56521739130435, 1.245652173913, 0.25
53584, 0.58695652173913, 1.245652173913, 0.27272727272727
53585, 0.56521739130435, 1.2195652173913, 0.27272727272727
53586, 0.56521739130435, 1.245652173913, 0.29545454545455
53587, 0.58695652173913, 1.245652173913, 0.31818181818182
53588, 0.56521739130435, 1.2195652173913, 0.31818181818182
53589, 0.56521739130435, 1.245652173913, 0.34090909090909
53590, 0.58695652173913, 1.245652173913, 0.36363636363636
53591, 0.56521739130435, 1.2195652173913, 0.36363636363636
53592, 0.56521739130435, 1.245652173913, 0.38636363636364
53593, 0.58695652173913, 1.245652173913, 0.40909090909091
53594, 0.56521739130435, 1.2195652173913, 0.40909090909091
53595, 0.56521739130435, 1.245652173913, 0.43181818181818
53596, 0.58695652173913, 1.245652173913, 0.45454545454545
53597, 0.56521739130435, 1.2195652173913, 0.45454545454545
53598, 0.56521739130435, 1.245652173913, 0.47727272727273
53599, 0.52173913043478, 1.245652173913, 0.022727272727273
53600, 0.54347826086956, 1.245652173913, 0.045454545454545
53601, 0.52173913043478, 1.2195652173913, 0.045454545454545
53602, 0.52173913043478, 1.245652173913, 0.068181818181818
53603, 0.54347826086956, 1.245652173913, 0.090909090909091
53604, 0.52173913043478, 1.2195652173913, 0.090909090909091
53605, 0.52173913043478, 1.245652173913, 0.11363636363636
53606, 0.54347826086956, 1.245652173913, 0.13636363636364
53607, 0.52173913043478, 1.2195652173913, 0.13636363636364
53608, 0.52173913043478, 1.245652173913, 0.15909090909091
53609, 0.54347826086956, 1.245652173913, 0.18181818181818
53610, 0.52173913043478, 1.2195652173913, 0.18181818181818
53611, 0.52173913043478, 1.245652173913, 0.20454545454545
53612, 0.54347826086956, 1.245652173913, 0.22727272727273
53613, 0.52173913043478, 1.2195652173913, 0.22727272727273
53614, 0.52173913043478, 1.245652173913, 0.25
53615, 0.54347826086956, 1.245652173913, 0.27272727272727
53616, 0.52173913043478, 1.2195652173913, 0.27272727272727
53617, 0.52173913043478, 1.245652173913, 0.29545454545455
53618, 0.54347826086956, 1.245652173913, 0.31818181818182
53619, 0.52173913043478, 1.2195652173913, 0.31818181818182
53620, 0.52173913043478, 1.245652173913, 0.34090909090909
53621, 0.54347826086957, 1.245652173913, 0.36363636363636
53622, 0.52173913043478, 1.2195652173913, 0.36363636363636
53623, 0.52173913043478, 1.245652173913, 0.38636363636364
53624, 0.54347826086956, 1.245652173913, 0.40909090909091
53625, 0.52173913043478, 1.2195652173913, 0.40909090909091
53626, 0.52173913043478, 1.245652173913, 0.43181818181818
53627, 0.54347826086956, 1.245652173913, 0.45454545454545
53628, 0.52173913043478, 1.2195652173913, 0.45454545454545
53629, 0.52173913043478, 1.245652173913, 0.47727272727273
53630, 0.47826086956522, 1.245652173913, 0.022727272727273
53631, 0.5, 1.245652173913, 0.045454545454545
53632, 0.47826086956522, 1.2195652173913, 0.045454545454545
53633, 0.47826086956522, 1.245652173913, 0.068181818181818
53634, 0.5, 1.245652173913, 0.090909090909091
53635, 0.47826086956522, 1.2195652173913, 0.090909090909091
53636, 0.47826086956522, 1.245652173913, 0.11363636363636
53637, 0.5, 1.245652173913, 0.13636363636364
53638, 0.47826086956522, 1.2195652173913, 0.13636363636364
53639, 0.47826086956522, 1.245652173913, 0.15909090909091
53640, 0.5, 1.245652173913, 0.18181818181818
53641, 0.47826086956522, 1.2195652173913, 0.18181818181818
53642, 0.47826086956522, 1.245652173913, 0.20454545454545
53643, 0.5, 1.245652173913, 0.22727272727273
53644, 0.47826086956522, 1.2195652173913, 0.22727272727273
53645, 0.47826086956522, 1.245652173913, 0.25
53646, 0.5, 1.245652173913, 0.27272727272727
53647, 0.47826086956522, 1.2195652173913, 0.27272727272727
53648, 0.47826086956522, 1.245652173913, 0.29545454545455
53649, 0.5, 1.245652173913, 0.31818181818182
53650, 0.47826086956522, 1.2195652173913, 0.31818181818182
53651, 0.47826086956522, 1.245652173913, 0.34090909090909
53652, 0.5, 1.245652173913, 0.36363636363636
53653, 0.47826086956522, 1.2195652173913, 0.36363636363636
53654, 0.47826086956522, 1.245652173913, 0.38636363636364
53655, 0.5, 1.245652173913, 0.40909090909091
53656, 0.47826086956522, 1.2195652173913, 0.40909090909091
53657, 0.47826086956522, 1.245652173913, 0.43181818181818
53658, 0.5, 1.245652173913, 0.45454545454545
53659, 0.47826086956522, 1.2195652173913, 0.45454545454545
53660, 0.47826086956522, 1.245652173913, 0.47727272727273
53661, 0.43478260869565, 1.245652173913, 0.022727272727273
53662, 0.45652173913043, 1.245652173913, 0.045454545454545
53663, 0.43478260869565, 1.2195652173913, 0.045454545454545
53664, 0.43478260869565, 1.245652173913, 0.068181818181818
53665, 0.45652173913043, 1.245652173913, 0.090909090909091
53666, 0.43478260869565, 1.2195652173913, 0.090909090909091
53667, 0.43478260869565, 1.245652173913, 0.11363636363636
53668, 0.45652173913043, 1.245652173913, 0.13636363636364
53669, 0.43478260869565, 1.2195652173913, 0.13636363636364
53670, 0.43478260869565, 1.245652173913, 0.15909090909091
53671, 0.45652173913043, 1.245652173913, 0.18181818181818
53672, 0.43478260869565, 1.2195652173913, 0.18181818181818
53673, 0.43478260869565, 1.245652173913, 0.20454545454545
53674, 0.45652173913043, 1.245652173913, 0.22727272727273
53675, 0.43478260869565, 1.2195652173913, 0.22727272727273
53676, 0.43478260869565, 1.245652173913, 0.25
53677, 0.45652173913043, 1.245652173913, 0.27272727272727
53678, 0.43478260869565, 1.2195652173913, 0.27272727272727
53679, 0.43478260869565, 1.245652173913, 0.29545454545455
53680, 0.45652173913043, 1.245652173913, 0.31818181818182
53681, 0.43478260869565, 1.2195652173913, 0.31818181818182
53682, 0.43478260869565, 1.245652173913, 0.34090909090909
53683, 0.45652173913043, 1.245652173913, 0.36363636363636
53684, 0.43478260869565, 1.2195652173913, 0.36363636363636
53685, 0.43478260869565, 1.245652173913, 0.38636363636364
53686, 0.45652173913043, 1.245652173913, 0.40909090909091
53687, 0.43478260869565, 1.2195652173913, 0.40909090909091
53688, 0.43478260869565, 1.245652173913, 0.43181818181818
53689, 0.45652173913043, 1.245652173913, 0.45454545454545
53690, 0.43478260869565, 1.2195652173913, 0.45454545454545
53691, 0.43478260869565, 1.245652173913, 0.47727272727273
53692, 0.39130434782609, 1.245652173913, 0.022727272727273
53693, 0.41304347826087, 1.245652173913, 0.045454545454545
53694, 0.39130434782609, 1.2195652173913, 0.045454545454545
53695, 0.39130434782609, 1.245652173913, 0.068181818181818
53696, 0.41304347826087, 1.245652173913, 0.090909090909091
53697, 0.39130434782609, 1.2195652173913, 0.090909090909091
53698, 0.39130434782609, 1.245652173913, 0.11363636363636
53699, 0.41304347826087, 1.245652173913, 0.13636363636364
53700, 0.39130434782609, 1.2195652173913, 0.13636363636364
53701, 0.39130434782609, 1.245652173913, 0.15909090909091
53702, 0.41304347826087, 1.245652173913, 0.18181818181818
53703, 0.39130434782609, 1.2195652173913, 0.18181818181818
53704, 0.39130434782609, 1.245652173913, 0.20454545454545
53705, 0.41304347826087, 1.245652173913, 0.22727272727273
53706, 0.39130434782609, 1.2195652173913, 0.22727272727273
53707, 0.39130434782609, 1.245652173913, 0.25
53708, 0.41304347826087, 1.245652173913, 0.27272727272727
53709, 0.39130434782609, 1.2195652173913, 0.27272727272727
53710, 0.39130434782609, 1.245652173913, 0.29545454545455
53711, 0.41304347826087, 1.245652173913, 0.31818181818182
53712, 0.39130434782609, 1.2195652173913, 0.31818181818182
53713, 0.39130434782609, 1.245652173913, 0.34090909090909
53714, 0.41304347826087, 1.245652173913, 0.36363636363636
53715, 0.39130434782609, 1.2195652173913, 0.36363636363636
53716, 0.39130434782609, 1.245652173913, 0.38636363636364
53717, 0.41304347826087, 1.245652173913, 0.40909090909091
53718, 0.39130434782609, 1.2195652173913, 0.40909090909091
53719, 0.39130434782609, 1.245652173913, 0.43181818181818
53720, 0.41304347826087, 1.245652173913, 0.45454545454545
53721, 0.39130434782609, 1.2195652173913, 0.45454545454545
53722, 0.39130434782609, 1.245652173913, 0.47727272727273
53723, 0.34782608695652, 1.245652173913, 0.022727272727273
53724, 0.3695652173913, 1.245652173913, 0.045454545454545
53725, 0.34782608695652, 1.2195652173913, 0.045454545454545
53726, 0.34782608695652, 1.245652173913, 0.068181818181818
53727, 0.3695652173913, 1.245652173913, 0.090909090909091
53728, 0.34782608695652, 1.2195652173913, 0.090909090909091
53729, 0.34782608695652, 1.245652173913, 0.11363636363636
53730, 0.3695652173913, 1.245652173913, 0.13636363636364
53731, 0.34782608695652, 1.2195652173913, 0.13636363636364
53732, 0.34782608695652, 1.245652173913, 0.15909090909091
53733, 0.3695652173913, 1.245652173913, 0.18181818181818
53734, 0.34782608695652, 1.2195652173913, 0.18181818181818
53735, 0.34782608695652, 1.245652173913, 0.20454545454545
53736, 0.3695652173913, 1.245652173913, 0.22727272727273
53737, 0.34782608695652, 1.2195652173913, 0.22727272727273
53738, 0.34782608695652, 1.245652173913, 0.25
53739, 0.3695652173913, 1.245652173913, 0.27272727272727
53740, 0.34782608695652, 1.2195652173913, 0.27272727272727
53741, 0.34782608695652, 1.245652173913, 0.29545454545455
53742, 0.3695652173913, 1.245652173913, 0.31818181818182
53743, 0.34782608695652, 1.2195652173913, 0.31818181818182
53744, 0.34782608695652, 1.245652173913, 0.34090909090909
53745, 0.3695652173913, 1.245652173913, 0.36363636363636
53746, 0.34782608695652, 1.2195652173913, 0.36363636363636
53747, 0.34782608695652, 1.245652173913, 0.38636363636364
53748, 0.3695652173913, 1.245652173913, 0.40909090909091
53749, 0.34782608695652, 1.2195652173913, 0.40909090909091
53750, 0.34782608695652, 1.245652173913, 0.43181818181818
53751, 0.3695652173913, 1.245652173913, 0.45454545454545
53752, 0.34782608695652, 1.2195652173913, 0.45454545454545
53753, 0.34782608695652, 1.245652173913, 0.47727272727273
53754, 0.30434782608696, 1.245652173913, 0.022727272727273
53755, 0.32608695652174, 1.245652173913, 0.045454545454545
53756, 0.30434782608696, 1.2195652173913, 0.045454545454545
53757, 0.30434782608696, 1.245652173913, 0.068181818181818
53758, 0.32608695652174, 1.245652173913, 0.090909090909091
53759, 0.30434782608696, 1.2195652173913, 0.090909090909091
53760, 0.30434782608696, 1.245652173913, 0.11363636363636
53761, 0.32608695652174, 1.245652173913, 0.13636363636364
53762, 0.30434782608696, 1.2195652173913, 0.13636363636364
53763, 0.30434782608696, 1.245652173913, 0.15909090909091
53764, 0.32608695652174, 1.245652173913, 0.18181818181818
53765, 0.30434782608696, 1.2195652173913, 0.18181818181818
53766, 0.30434782608696, 1.245652173913, 0.20454545454545
53767, 0.32608695652174, 1.245652173913, 0.22727272727273
53768, 0.30434782608696, 1.2195652173913, 0.22727272727273
53769, 0.30434782608696, 1.245652173913, 0.25
53770, 0.32608695652174, 1.245652173913, 0.27272727272727
53771, 0.30434782608696, 1.2195652173913, 0.27272727272727
53772, 0.30434782608696, 1.245652173913, 0.29545454545455
53773, 0.32608695652174, 1.245652173913, 0.31818181818182
53774, 0.30434782608696, 1.2195652173913, 0.31818181818182
53775, 0.30434782608696, 1.245652173913, 0.34090909090909
53776, 0.32608695652174, 1.245652173913, 0.36363636363636
53777, 0.30434782608696, 1.2195652173913, 0.36363636363636
53778, 0.30434782608696, 1.245652173913, 0.38636363636364
53779, 0.32608695652174, 1.245652173913, 0.40909090909091
53780, 0.30434782608696, 1.2195652173913, 0.40909090909091
53781, 0.30434782608696, 1.245652173913, 0.43181818181818
53782, 0.32608695652174, 1.245652173913, 0.45454545454545
53783, 0.30434782608696, 1.2195652173913, 0.45454545454545
53784, 0.30434782608696, 1.245652173913, 0.47727272727273
53785, 0.26086956521739, 1.245652173913, 0.022727272727273
53786, 0.28260869565217, 1.245652173913, 0.045454545454545
53787, 0.26086956521739, 1.2195652173913, 0.045454545454545
53788, 0.26086956521739, 1.245652173913, 0.068181818181818
53789, 0.28260869565217, 1.245652173913, 0.090909090909091
53790, 0.26086956521739, 1.2195652173913, 0.090909090909091
53791, 0.26086956521739, 1.245652173913, 0.11363636363636
53792, 0.28260869565217, 1.245652173913, 0.13636363636364
53793, 0.26086956521739, 1.2195652173913, 0.13636363636364
53794, 0.26086956521739, 1.245652173913, 0.15909090909091
53795, 0.28260869565217, 1.245652173913, 0.18181818181818
53796, 0.26086956521739, 1.2195652173913, 0.18181818181818
53797, 0.26086956521739, 1.245652173913, 0.20454545454545
53798, 0.28260869565217, 1.245652173913, 0.22727272727273
53799, 0.26086956521739, 1.2195652173913, 0.22727272727273
53800, 0.26086956521739, 1.245652173913, 0.25
53801, 0.28260869565217, 1.245652173913, 0.27272727272727
53802, 0.26086956521739, 1.2195652173913, 0.27272727272727
53803, 0.26086956521739, 1.245652173913, 0.29545454545455
53804, 0.28260869565217, 1.245652173913, 0.31818181818182
53805, 0.26086956521739, 1.2195652173913, 0.31818181818182
53806, 0.26086956521739, 1.245652173913, 0.34090909090909
53807, 0.28260869565217, 1.245652173913, 0.36363636363636
53808, 0.26086956521739, 1.2195652173913, 0.36363636363636
53809, 0.26086956521739, 1.245652173913, 0.38636363636364
53810, 0.28260869565217, 1.245652173913, 0.40909090909091
53811, 0.26086956521739, 1.2195652173913, 0.40909090909091
53812, 0.26086956521739, 1.245652173913, 0.43181818181818
53813, 0.28260869565217, 1.245652173913, 0.45454545454545
53814, 0.26086956521739, 1.2195652173913, 0.45454545454545
53815, 0.26086956521739, 1.245652173913, 0.47727272727273
53816, 0.21739130434783, 1.245652173913, 0.022727272727273
53817, 0.23913043478261, 1.245652173913, 0.045454545454545
53818, 0.21739130434783, 1.2195652173913, 0.045454545454545
53819, 0.21739130434783, 1.245652173913, 0.068181818181818
53820, 0.23913043478261, 1.245652173913, 0.090909090909091
53821, 0.21739130434783, 1.2195652173913, 0.090909090909091
53822, 0.21739130434783, 1.245652173913, 0.11363636363636
53823, 0.23913043478261, 1.245652173913, 0.13636363636364
53824, 0.21739130434783, 1.2195652173913, 0.13636363636364
53825, 0.21739130434783, 1.245652173913, 0.15909090909091
53826, 0.23913043478261, 1.245652173913, 0.18181818181818
53827, 0.21739130434783, 1.2195652173913, 0.18181818181818
53828, 0.21739130434783, 1.245652173913, 0.20454545454545
53829, 0.23913043478261, 1.245652173913, 0.22727272727273
53830, 0.21739130434783, 1.2195652173913, 0.22727272727273
53831, 0.21739130434783, 1.245652173913, 0.25
53832, 0.23913043478261, 1.245652173913, 0.27272727272727
53833, 0.21739130434783, 1.2195652173913, 0.27272727272727
53834, 0.21739130434783, 1.245652173913, 0.29545454545455
53835, 0.23913043478261, 1.245652173913, 0.31818181818182
53836, 0.21739130434783, 1.2195652173913, 0.31818181818182
53837, 0.21739130434783, 1.245652173913, 0.34090909090909
53838, 0.23913043478261, 1.245652173913, 0.36363636363636
53839, 0.21739130434783, 1.2195652173913, 0.36363636363636
53840, 0.21739130434783, 1.245652173913, 0.38636363636364
53841, 0.23913043478261, 1.245652173913, 0.40909090909091
53842, 0.21739130434783, 1.2195652173913, 0.40909090909091
53843, 0.21739130434783, 1.245652173913, 0.43181818181818
53844, 0.23913043478261, 1.245652173913, 0.45454545454545
53845, 0.21739130434783, 1.2195652173913, 0.45454545454545
53846, 0.21739130434783, 1.245652173913, 0.47727272727273
53847, 0.17391304347826, 1.245652173913, 0.022727272727273
53848, 0.19565217391304, 1.245652173913, 0.045454545454545
53849, 0.17391304347826, 1.2195652173913, 0.045454545454545
53850, 0.17391304347826, 1.245652173913, 0.068181818181818
53851, 0.19565217391304, 1.245652173913, 0.090909090909091
53852, 0.17391304347826, 1.2195652173913, 0.090909090909091
53853, 0.17391304347826, 1.245652173913, 0.11363636363636
53854, 0.19565217391304, 1.245652173913, 0.13636363636364
53855, 0.17391304347826, 1.2195652173913, 0.13636363636364
53856, 0.17391304347826, 1.245652173913, 0.15909090909091
53857, 0.19565217391304, 1.245652173913, 0.18181818181818
53858, 0.17391304347826, 1.2195652173913, 0.18181818181818
53859, 0.17391304347826, 1.245652173913, 0.20454545454545
53860, 0.19565217391304, 1.245652173913, 0.22727272727273
53861, 0.17391304347826, 1.2195652173913, 0.22727272727273
53862, 0.17391304347826, 1.245652173913, 0.25
53863, 0.19565217391304, 1.245652173913, 0.27272727272727
53864, 0.17391304347826, 1.2195652173913, 0.27272727272727
53865, 0.17391304347826, 1.245652173913, 0.29545454545455
53866, 0.19565217391304, 1.245652173913, 0.31818181818182
53867, 0.17391304347826, 1.2195652173913, 0.31818181818182
53868, 0.17391304347826, 1.245652173913, 0.34090909090909
53869, 0.19565217391304, 1.245652173913, 0.36363636363636
53870, 0.17391304347826, 1.2195652173913, 0.36363636363636
53871, 0.17391304347826, 1.245652173913, 0.38636363636364
53872, 0.19565217391304, 1.245652173913, 0.40909090909091
53873, 0.17391304347826, 1.2195652173913, 0.40909090909091
53874, 0.17391304347826, 1.245652173913, 0.43181818181818
53875, 0.19565217391304, 1.245652173913, 0.45454545454545
53876, 0.17391304347826, 1.2195652173913, 0.45454545454545
53877, 0.17391304347826, 1.245652173913, 0.47727272727273
53878, 0.1304347826087, 1.245652173913, 0.022727272727273
53879, 0.15217391304348, 1.245652173913, 0.045454545454545
53880, 0.1304347826087, 1.2195652173913, 0.045454545454545
53881, 0.1304347826087, 1.245652173913, 0.068181818181818
53882, 0.15217391304348, 1.245652173913, 0.090909090909091
53883, 0.1304347826087, 1.2195652173913, 0.090909090909091
53884, 0.1304347826087, 1.245652173913, 0.11363636363636
53885, 0.15217391304348, 1.245652173913, 0.13636363636364
53886, 0.1304347826087, 1.2195652173913, 0.13636363636364
53887, 0.1304347826087, 1.245652173913, 0.15909090909091
53888, 0.15217391304348, 1.245652173913, 0.18181818181818
53889, 0.1304347826087, 1.2195652173913, 0.18181818181818
53890, 0.1304347826087, 1.245652173913, 0.20454545454545
53891, 0.15217391304348, 1.245652173913, 0.22727272727273
53892, 0.1304347826087, 1.2195652173913, 0.22727272727273
53893, 0.1304347826087, 1.245652173913, 0.25
53894, 0.15217391304348, 1.245652173913, 0.27272727272727
53895, 0.1304347826087, 1.2195652173913, 0.27272727272727
53896, 0.1304347826087, 1.245652173913, 0.29545454545455
53897, 0.15217391304348, 1.245652173913, 0.31818181818182
53898, 0.1304347826087, 1.2195652173913, 0.31818181818182
53899, 0.1304347826087, 1.245652173913, 0.34090909090909
53900, 0.15217391304348, 1.245652173913, 0.36363636363636
53901, 0.1304347826087, 1.2195652173913, 0.36363636363636
53902, 0.1304347826087, 1.245652173913, 0.38636363636364
53903, 0.15217391304348, 1.245652173913, 0.40909090909091
53904, 0.1304347826087, 1.2195652173913, 0.40909090909091
53905, 0.1304347826087, 1.245652173913, 0.43181818181818
53906, 0.15217391304348, 1.245652173913, 0.45454545454545
53907, 0.1304347826087, 1.2195652173913, 0.45454545454545
53908, 0.1304347826087, 1.245652173913, 0.47727272727273
53909, 0.08695652173913, 1.245652173913, 0.022727272727273
53910, 0.10869565217391, 1.245652173913, 0.045454545454545
53911, 0.08695652173913, 1.2195652173913, 0.045454545454545
53912, 0.08695652173913, 1.245652173913, 0.068181818181818
53913, 0.10869565217391, 1.245652173913, 0.090909090909091
53914, 0.08695652173913, 1.2195652173913, 0.090909090909091
53915, 0.08695652173913, 1.245652173913, 0.11363636363636
53916, 0.10869565217391, 1.245652173913, 0.13636363636364
53917, 0.08695652173913, 1.2195652173913, 0.13636363636364
53918, 0.08695652173913, 1.245652173913, 0.15909090909091
53919, 0.10869565217391, 1.245652173913, 0.18181818181818
53920, 0.08695652173913, 1.2195652173913, 0.18181818181818
53921, 0.08695652173913, 1.245652173913, 0.20454545454545
53922, 0.10869565217391, 1.245652173913, 0.22727272727273
53923, 0.08695652173913, 1.2195652173913, 0.22727272727273
53924, 0.08695652173913, 1.245652173913, 0.25
53925, 0.10869565217391, 1.245652173913, 0.27272727272727
53926, 0.08695652173913, 1.2195652173913, 0.27272727272727
53927, 0.08695652173913, 1.245652173913, 0.29545454545455
53928, 0.10869565217391, 1.245652173913, 0.31818181818182
53929, 0.08695652173913, 1.2195652173913, 0.31818181818182
53930, 0.08695652173913, 1.245652173913, 0.34090909090909
53931, 0.10869565217391, 1.245652173913, 0.36363636363636
53932, 0.08695652173913, 1.2195652173913, 0.36363636363636
53933, 0.08695652173913, 1.245652173913, 0.38636363636364
53934, 0.10869565217391, 1.245652173913, 0.40909090909091
53935, 0.08695652173913, 1.2195652173913, 0.40909090909091
53936, 0.08695652173913, 1.245652173913, 0.43181818181818
53937, 0.10869565217391, 1.245652173913, 0.45454545454545
53938, 0.08695652173913, 1.2195652173913, 0.45454545454545
53939, 0.08695652173913, 1.245652173913, 0.47727272727273
53940, 0.043478260869565, 1.245652173913, 0.022727272727273
53941, 0.065217391304348, 1.245652173913, 0.045454545454545
53942, 0.043478260869565, 1.2195652173913, 0.045454545454545
53943, 0.043478260869565, 1.245652173913, 0.068181818181818
53944, 0.065217391304348, 1.245652173913, 0.090909090909091
53945, 0.043478260869565, 1.2195652173913, 0.090909090909091
53946, 0.043478260869565, 1.245652173913, 0.11363636363636
53947, 0.065217391304348, 1.245652173913, 0.13636363636364
53948, 0.043478260869565, 1.2195652173913, 0.13636363636364
53949, 0.043478260869565, 1.245652173913, 0.15909090909091
53950, 0.065217391304348, 1.245652173913, 0.18181818181818
53951, 0.043478260869565, 1.2195652173913, 0.18181818181818
53952, 0.043478260869565, 1.245652173913, 0.20454545454545
53953, 0.065217391304348, 1.245652173913, 0.22727272727273
53954, 0.043478260869565, 1.2195652173913, 0.22727272727273
53955, 0.043478260869565, 1.245652173913, 0.25
53956, 0.065217391304348, 1.245652173913, 0.27272727272727
53957, 0.043478260869565, 1.2195652173913, 0.27272727272727
53958, 0.043478260869565, 1.245652173913, 0.29545454545455
53959, 0.065217391304348, 1.245652173913, 0.31818181818182
53960, 0.043478260869565, 1.2195652173913, 0.31818181818182
53961, 0.043478260869565, 1.245652173913, 0.34090909090909
53962, 0.065217391304348, 1.245652173913, 0.36363636363636
53963, 0.043478260869565, 1.2195652173913, 0.36363636363636
53964, 0.043478260869565, 1.245652173913, 0.38636363636364
53965, 0.065217391304348, 1.245652173913, 0.40909090909091
53966, 0.043478260869565, 1.2195652173913, 0.40909090909091
53967, 0.043478260869565, 1.245652173913, 0.43181818181818
53968, 0.065217391304348, 1.245652173913, 0.45454545454545
53969, 0.043478260869565, 1.2195652173913, 0.45454545454545
53970, 0.043478260869565, 1.245652173913, 0.47727272727273
53971, 0.021739130434783, 1.245652173913, 0.045454545454545
53972, 0.021739130434783, 1.245652173913, 0.090909090909091
53973, 0.021739130434783, 1.245652173913, 0.13636363636364
53974, 0.021739130434783, 1.245652173913, 0.18181818181818
53975, 0.021739130434783, 1.245652173913, 0.22727272727273
53976, 0.021739130434783, 1.245652173913, 0.27272727272727
53977, 0.021739130434783, 1.245652173913, 0.31818181818182
53978, 0.021739130434783, 1.245652173913, 0.36363636363636
53979, 0.021739130434783, 1.245652173913, 0.40909090909091
53980, 0.021739130434783, 1.245652173913, 0.45454545454545
53981, 0.95652173913043, 1.2978260869565, 0.022727272727273
53982, 0.97826086956522, 1.2978260869565, 0.045454545454545
53983, 0.95652173913043, 1.2717391304348, 0.045454545454545
53984, 0.95652173913043, 1.2978260869565, 0.068181818181818
53985, 0.97826086956522, 1.2978260869565, 0.090909090909091
53986, 0.95652173913043, 1.2717391304348, 0.090909090909091
53987, 0.95652173913043, 1.2978260869565, 0.11363636363636
53988, 0.97826086956522, 1.2978260869565, 0.13636363636364
53989, 0.95652173913044, 1.2717391304348, 0.13636363636364
53990, 0.95652173913044, 1.2978260869565, 0.15909090909091
53991, 0.97826086956522, 1.2978260869565, 0.18181818181818
53992, 0.95652173913044, 1.2717391304348, 0.18181818181818
53993, 0.95652173913044, 1.2978260869565, 0.20454545454545
53994, 0.97826086956522, 1.2978260869565, 0.22727272727273
53995, 0.95652173913044, 1.2717391304348, 0.22727272727273
53996, 0.95652173913044, 1.2978260869565, 0.25
53997, 0.97826086956522, 1.2978260869565, 0.27272727272727
53998, 0.95652173913044, 1.2717391304348, 0.27272727272727
53999, 0.95652173913044, 1.2978260869565, 0.29545454545455
54000, 0.97826086956522, 1.2978260869565, 0.31818181818182
54001, 0.95652173913044, 1.2717391304348, 0.31818181818182
54002, 0.95652173913043, 1.2978260869565, 0.34090909090909
54003, 0.97826086956522, 1.2978260869565, 0.36363636363636
54004, 0.95652173913043, 1.2717391304348, 0.36363636363636
54005, 0.95652173913043, 1.2978260869565, 0.38636363636364
54006, 0.97826086956522, 1.2978260869565, 0.40909090909091
54007, 0.95652173913043, 1.2717391304348, 0.40909090909091
54008, 0.95652173913043, 1.2978260869565, 0.43181818181818
54009, 0.97826086956522, 1.2978260869565, 0.45454545454545
54010, 0.95652173913044, 1.2717391304348, 0.45454545454545
54011, 0.95652173913044, 1.2978260869565, 0.47727272727273
54012, 0.91304347826087, 1.2978260869565, 0.022727272727273
54013, 0.93478260869565, 1.2978260869565, 0.045454545454545
54014, 0.91304347826087, 1.2717391304348, 0.045454545454545
54015, 0.91304347826087, 1.2978260869565, 0.068181818181818
54016, 0.93478260869565, 1.2978260869565, 0.090909090909091
54017, 0.91304347826087, 1.2717391304348, 0.090909090909091
54018, 0.91304347826087, 1.2978260869565, 0.11363636363636
54019, 0.93478260869565, 1.2978260869565, 0.13636363636364
54020, 0.91304347826087, 1.2717391304348, 0.13636363636364
54021, 0.91304347826087, 1.2978260869565, 0.15909090909091
54022, 0.93478260869565, 1.2978260869565, 0.18181818181818
54023, 0.91304347826087, 1.2717391304348, 0.18181818181818
54024, 0.91304347826087, 1.2978260869565, 0.20454545454545
54025, 0.93478260869565, 1.2978260869565, 0.22727272727273
54026, 0.91304347826087, 1.2717391304348, 0.22727272727273
54027, 0.91304347826087, 1.2978260869565, 0.25
54028, 0.93478260869565, 1.2978260869565, 0.27272727272727
54029, 0.91304347826087, 1.2717391304348, 0.27272727272727
54030, 0.91304347826087, 1.2978260869565, 0.29545454545455
54031, 0.93478260869565, 1.2978260869565, 0.31818181818182
54032, 0.91304347826087, 1.2717391304348, 0.31818181818182
54033, 0.91304347826087, 1.2978260869565, 0.34090909090909
54034, 0.93478260869565, 1.2978260869565, 0.36363636363636
54035, 0.91304347826087, 1.2717391304348, 0.36363636363636
54036, 0.91304347826087, 1.2978260869565, 0.38636363636364
54037, 0.93478260869565, 1.2978260869565, 0.40909090909091
54038, 0.91304347826087, 1.2717391304348, 0.40909090909091
54039, 0.91304347826087, 1.2978260869565, 0.43181818181818
54040, 0.93478260869565, 1.2978260869565, 0.45454545454545
54041, 0.91304347826087, 1.2717391304348, 0.45454545454545
54042, 0.91304347826087, 1.2978260869565, 0.47727272727273
54043, 0.8695652173913, 1.2978260869565, 0.022727272727273
54044, 0.89130434782609, 1.2978260869565, 0.045454545454545
54045, 0.8695652173913, 1.2717391304348, 0.045454545454545
54046, 0.8695652173913, 1.2978260869565, 0.068181818181818
54047, 0.89130434782609, 1.2978260869565, 0.090909090909091
54048, 0.8695652173913, 1.2717391304348, 0.090909090909091
54049, 0.8695652173913, 1.2978260869565, 0.11363636363636
54050, 0.89130434782609, 1.2978260869565, 0.13636363636364
54051, 0.8695652173913, 1.2717391304348, 0.13636363636364
54052, 0.8695652173913, 1.2978260869565, 0.15909090909091
54053, 0.89130434782609, 1.2978260869565, 0.18181818181818
54054, 0.8695652173913, 1.2717391304348, 0.18181818181818
54055, 0.8695652173913, 1.2978260869565, 0.20454545454545
54056, 0.89130434782609, 1.2978260869565, 0.22727272727273
54057, 0.8695652173913, 1.2717391304348, 0.22727272727273
54058, 0.8695652173913, 1.2978260869565, 0.25
54059, 0.89130434782609, 1.2978260869565, 0.27272727272727
54060, 0.8695652173913, 1.2717391304348, 0.27272727272727
54061, 0.8695652173913, 1.2978260869565, 0.29545454545455
54062, 0.89130434782609, 1.2978260869565, 0.31818181818182
54063, 0.8695652173913, 1.2717391304348, 0.31818181818182
54064, 0.8695652173913, 1.2978260869565, 0.34090909090909
54065, 0.89130434782609, 1.2978260869565, 0.36363636363636
54066, 0.8695652173913, 1.2717391304348, 0.36363636363636
54067, 0.8695652173913, 1.2978260869565, 0.38636363636364
54068, 0.89130434782609, 1.2978260869565, 0.40909090909091
54069, 0.8695652173913, 1.2717391304348, 0.40909090909091
54070, 0.8695652173913, 1.2978260869565, 0.43181818181818
54071, 0.89130434782609, 1.2978260869565, 0.45454545454545
54072, 0.8695652173913, 1.2717391304348, 0.45454545454545
54073, 0.8695652173913, 1.2978260869565, 0.47727272727273
54074, 0.82608695652174, 1.2978260869565, 0.022727272727273
54075, 0.84782608695652, 1.2978260869565, 0.045454545454545
54076, 0.82608695652174, 1.2717391304348, 0.045454545454545
54077, 0.82608695652174, 1.2978260869565, 0.068181818181818
54078, 0.84782608695652, 1.2978260869565, 0.090909090909091
54079, 0.82608695652174, 1.2717391304348, 0.090909090909091
54080, 0.82608695652174, 1.2978260869565, 0.11363636363636
54081, 0.84782608695652, 1.2978260869565, 0.13636363636364
54082, 0.82608695652174, 1.2717391304348, 0.13636363636364
54083, 0.82608695652174, 1.2978260869565, 0.15909090909091
54084, 0.84782608695652, 1.2978260869565, 0.18181818181818
54085, 0.82608695652174, 1.2717391304348, 0.18181818181818
54086, 0.82608695652174, 1.2978260869565, 0.20454545454545
54087, 0.84782608695652, 1.2978260869565, 0.22727272727273
54088, 0.82608695652174, 1.2717391304348, 0.22727272727273
54089, 0.82608695652174, 1.2978260869565, 0.25
54090, 0.84782608695652, 1.2978260869565, 0.27272727272727
54091, 0.82608695652174, 1.2717391304348, 0.27272727272727
54092, 0.82608695652174, 1.2978260869565, 0.29545454545455
54093, 0.84782608695652, 1.2978260869565, 0.31818181818182
54094, 0.82608695652174, 1.2717391304348, 0.31818181818182
54095, 0.82608695652174, 1.2978260869565, 0.34090909090909
54096, 0.84782608695652, 1.2978260869565, 0.36363636363636
54097, 0.82608695652174, 1.2717391304348, 0.36363636363636
54098, 0.82608695652174, 1.2978260869565, 0.38636363636364
54099, 0.84782608695652, 1.2978260869565, 0.40909090909091
54100, 0.82608695652174, 1.2717391304348, 0.40909090909091
54101, 0.82608695652174, 1.2978260869565, 0.43181818181818
54102, 0.84782608695652, 1.2978260869565, 0.45454545454545
54103, 0.82608695652174, 1.2717391304348, 0.45454545454545
54104, 0.82608695652174, 1.2978260869565, 0.47727272727273
54105, 0.78260869565217, 1.2978260869565, 0.022727272727273
54106, 0.80434782608696, 1.2978260869565, 0.045454545454545
54107, 0.78260869565217, 1.2717391304348, 0.045454545454545
54108, 0.78260869565217, 1.2978260869565, 0.068181818181818
54109, 0.80434782608696, 1.2978260869565, 0.090909090909091
54110, 0.78260869565217, 1.2717391304348, 0.090909090909091
54111, 0.78260869565217, 1.2978260869565, 0.11363636363636
54112, 0.80434782608696, 1.2978260869565, 0.13636363636364
54113, 0.78260869565217, 1.2717391304348, 0.13636363636364
54114, 0.78260869565217, 1.2978260869565, 0.15909090909091
54115, 0.80434782608696, 1.2978260869565, 0.18181818181818
54116, 0.78260869565217, 1.2717391304348, 0.18181818181818
54117, 0.78260869565217, 1.2978260869565, 0.20454545454545
54118, 0.80434782608696, 1.2978260869565, 0.22727272727273
54119, 0.78260869565217, 1.2717391304348, 0.22727272727273
54120, 0.78260869565217, 1.2978260869565, 0.25
54121, 0.80434782608696, 1.2978260869565, 0.27272727272727
54122, 0.78260869565217, 1.2717391304348, 0.27272727272727
54123, 0.78260869565217, 1.2978260869565, 0.29545454545455
54124, 0.80434782608696, 1.2978260869565, 0.31818181818182
54125, 0.78260869565217, 1.2717391304348, 0.31818181818182
54126, 0.78260869565217, 1.2978260869565, 0.34090909090909
54127, 0.80434782608696, 1.2978260869565, 0.36363636363636
54128, 0.78260869565217, 1.2717391304348, 0.36363636363636
54129, 0.78260869565217, 1.2978260869565, 0.38636363636364
54130, 0.80434782608696, 1.2978260869565, 0.40909090909091
54131, 0.78260869565217, 1.2717391304348, 0.40909090909091
54132, 0.78260869565217, 1.2978260869565, 0.43181818181818
54133, 0.80434782608696, 1.2978260869565, 0.45454545454545
54134, 0.78260869565217, 1.2717391304348, 0.45454545454545
54135, 0.78260869565217, 1.2978260869565, 0.47727272727273
54136, 0.73913043478261, 1.2978260869565, 0.022727272727273
54137, 0.76086956521739, 1.2978260869565, 0.045454545454545
54138, 0.73913043478261, 1.2717391304348, 0.045454545454545
54139, 0.73913043478261, 1.2978260869565, 0.068181818181818
54140, 0.76086956521739, 1.2978260869565, 0.090909090909091
54141, 0.73913043478261, 1.2717391304348, 0.090909090909091
54142, 0.73913043478261, 1.2978260869565, 0.11363636363636
54143, 0.76086956521739, 1.2978260869565, 0.13636363636364
54144, 0.73913043478261, 1.2717391304348, 0.13636363636364
54145, 0.73913043478261, 1.2978260869565, 0.15909090909091
54146, 0.76086956521739, 1.2978260869565, 0.18181818181818
54147, 0.73913043478261, 1.2717391304348, 0.18181818181818
54148, 0.73913043478261, 1.2978260869565, 0.20454545454545
54149, 0.76086956521739, 1.2978260869565, 0.22727272727273
54150, 0.73913043478261, 1.2717391304348, 0.22727272727273
54151, 0.73913043478261, 1.2978260869565, 0.25
54152, 0.76086956521739, 1.2978260869565, 0.27272727272727
54153, 0.73913043478261, 1.2717391304348, 0.27272727272727
54154, 0.73913043478261, 1.2978260869565, 0.29545454545455
54155, 0.76086956521739, 1.2978260869565, 0.31818181818182
54156, 0.73913043478261, 1.2717391304348, 0.31818181818182
54157, 0.73913043478261, 1.2978260869565, 0.34090909090909
54158, 0.76086956521739, 1.2978260869565, 0.36363636363636
54159, 0.73913043478261, 1.2717391304348, 0.36363636363636
54160, 0.73913043478261, 1.2978260869565, 0.38636363636364
54161, 0.76086956521739, 1.2978260869565, 0.40909090909091
54162, 0.73913043478261, 1.2717391304348, 0.40909090909091
54163, 0.73913043478261, 1.2978260869565, 0.43181818181818
54164, 0.76086956521739, 1.2978260869565, 0.45454545454545
54165, 0.73913043478261, 1.2717391304348, 0.45454545454545
54166, 0.73913043478261, 1.2978260869565, 0.47727272727273
54167, 0.69565217391304, 1.2978260869565, 0.022727272727273
54168, 0.71739130434783, 1.2978260869565, 0.045454545454545
54169, 0.69565217391304, 1.2717391304348, 0.045454545454545
54170, 0.69565217391304, 1.2978260869565, 0.068181818181818
54171, 0.71739130434783, 1.2978260869565, 0.090909090909091
54172, 0.69565217391304, 1.2717391304348, 0.090909090909091
54173, 0.69565217391304, 1.2978260869565, 0.11363636363636
54174, 0.71739130434783, 1.2978260869565, 0.13636363636364
54175, 0.69565217391304, 1.2717391304348, 0.13636363636364
54176, 0.69565217391304, 1.2978260869565, 0.15909090909091
54177, 0.71739130434783, 1.2978260869565, 0.18181818181818
54178, 0.69565217391304, 1.2717391304348, 0.18181818181818
54179, 0.69565217391304, 1.2978260869565, 0.20454545454545
54180, 0.71739130434783, 1.2978260869565, 0.22727272727273
54181, 0.69565217391304, 1.2717391304348, 0.22727272727273
54182, 0.69565217391304, 1.2978260869565, 0.25
54183, 0.71739130434783, 1.2978260869565, 0.27272727272727
54184, 0.69565217391304, 1.2717391304348, 0.27272727272727
54185, 0.69565217391304, 1.2978260869565, 0.29545454545455
54186, 0.71739130434783, 1.2978260869565, 0.31818181818182
54187, 0.69565217391304, 1.2717391304348, 0.31818181818182
54188, 0.69565217391304, 1.2978260869565, 0.34090909090909
54189, 0.71739130434783, 1.2978260869565, 0.36363636363636
54190, 0.69565217391304, 1.2717391304348, 0.36363636363636
54191, 0.69565217391304, 1.2978260869565, 0.38636363636364
54192, 0.71739130434783, 1.2978260869565, 0.40909090909091
54193, 0.69565217391304, 1.2717391304348, 0.40909090909091
54194, 0.69565217391304, 1.2978260869565, 0.43181818181818
54195, 0.71739130434783, 1.2978260869565, 0.45454545454545
54196, 0.69565217391304, 1.2717391304348, 0.45454545454545
54197, 0.69565217391304, 1.2978260869565, 0.47727272727273
54198, 0.65217391304348, 1.2978260869565, 0.022727272727273
54199, 0.67391304347826, 1.2978260869565, 0.045454545454545
54200, 0.65217391304348, 1.2717391304348, 0.045454545454545
54201, 0.65217391304348, 1.2978260869565, 0.068181818181818
54202, 0.67391304347826, 1.2978260869565, 0.090909090909091
54203, 0.65217391304348, 1.2717391304348, 0.090909090909091
54204, 0.65217391304348, 1.2978260869565, 0.11363636363636
54205, 0.67391304347826, 1.2978260869565, 0.13636363636364
54206, 0.65217391304348, 1.2717391304348, 0.13636363636364
54207, 0.65217391304348, 1.2978260869565, 0.15909090909091
54208, 0.67391304347826, 1.2978260869565, 0.18181818181818
54209, 0.65217391304348, 1.2717391304348, 0.18181818181818
54210, 0.65217391304348, 1.2978260869565, 0.20454545454545
54211, 0.67391304347826, 1.2978260869565, 0.22727272727273
54212, 0.65217391304348, 1.2717391304348, 0.22727272727273
54213, 0.65217391304348, 1.2978260869565, 0.25
54214, 0.67391304347826, 1.2978260869565, 0.27272727272727
54215, 0.65217391304348, 1.2717391304348, 0.27272727272727
54216, 0.65217391304348, 1.2978260869565, 0.29545454545455
54217, 0.67391304347826, 1.2978260869565, 0.31818181818182
54218, 0.65217391304348, 1.2717391304348, 0.31818181818182
54219, 0.65217391304348, 1.2978260869565, 0.34090909090909
54220, 0.67391304347826, 1.2978260869565, 0.36363636363636
54221, 0.65217391304348, 1.2717391304348, 0.36363636363636
54222, 0.65217391304348, 1.2978260869565, 0.38636363636364
54223, 0.67391304347826, 1.2978260869565, 0.40909090909091
54224, 0.65217391304348, 1.2717391304348, 0.40909090909091
54225, 0.65217391304348, 1.2978260869565, 0.43181818181818
54226, 0.67391304347826, 1.2978260869565, 0.45454545454545
54227, 0.65217391304348, 1.2717391304348, 0.45454545454545
54228, 0.65217391304348, 1.2978260869565, 0.47727272727273
54229, 0.60869565217391, 1.2978260869565, 0.022727272727273
54230, 0.6304347826087, 1.2978260869565, 0.045454545454545
54231, 0.60869565217391, 1.2717391304348, 0.045454545454545
54232, 0.60869565217391, 1.2978260869565, 0.068181818181818
54233, 0.6304347826087, 1.2978260869565, 0.090909090909091
54234, 0.60869565217391, 1.2717391304348, 0.090909090909091
54235, 0.60869565217391, 1.2978260869565, 0.11363636363636
54236, 0.6304347826087, 1.2978260869565, 0.13636363636364
54237, 0.60869565217391, 1.2717391304348, 0.13636363636364
54238, 0.60869565217391, 1.2978260869565, 0.15909090909091
54239, 0.6304347826087, 1.2978260869565, 0.18181818181818
54240, 0.60869565217391, 1.2717391304348, 0.18181818181818
54241, 0.60869565217391, 1.2978260869565, 0.20454545454545
54242, 0.6304347826087, 1.2978260869565, 0.22727272727273
54243, 0.60869565217391, 1.2717391304348, 0.22727272727273
54244, 0.60869565217391, 1.2978260869565, 0.25
54245, 0.6304347826087, 1.2978260869565, 0.27272727272727
54246, 0.60869565217391, 1.2717391304348, 0.27272727272727
54247, 0.60869565217391, 1.2978260869565, 0.29545454545455
54248, 0.6304347826087, 1.2978260869565, 0.31818181818182
54249, 0.60869565217391, 1.2717391304348, 0.31818181818182
54250, 0.60869565217391, 1.2978260869565, 0.34090909090909
54251, 0.6304347826087, 1.2978260869565, 0.36363636363636
54252, 0.60869565217391, 1.2717391304348, 0.36363636363636
54253, 0.60869565217391, 1.2978260869565, 0.38636363636364
54254, 0.6304347826087, 1.2978260869565, 0.40909090909091
54255, 0.60869565217391, 1.2717391304348, 0.40909090909091
54256, 0.60869565217391, 1.2978260869565, 0.43181818181818
54257, 0.6304347826087, 1.2978260869565, 0.45454545454545
54258, 0.60869565217391, 1.2717391304348, 0.45454545454545
54259, 0.60869565217391, 1.2978260869565, 0.47727272727273
54260, 0.56521739130435, 1.2978260869565, 0.022727272727273
54261, 0.58695652173913, 1.2978260869565, 0.045454545454545
54262, 0.56521739130435, 1.2717391304348, 0.045454545454545
54263, 0.56521739130435, 1.2978260869565, 0.068181818181818
54264, 0.58695652173913, 1.2978260869565, 0.090909090909091
54265, 0.56521739130435, 1.2717391304348, 0.090909090909091
54266, 0.56521739130435, 1.2978260869565, 0.11363636363636
54267, 0.58695652173913, 1.2978260869565, 0.13636363636364
54268, 0.56521739130435, 1.2717391304348, 0.13636363636364
54269, 0.56521739130435, 1.2978260869565, 0.15909090909091
54270, 0.58695652173913, 1.2978260869565, 0.18181818181818
54271, 0.56521739130435, 1.2717391304348, 0.18181818181818
54272, 0.56521739130435, 1.2978260869565, 0.20454545454545
54273, 0.58695652173913, 1.2978260869565, 0.22727272727273
54274, 0.56521739130435, 1.2717391304348, 0.22727272727273
54275, 0.56521739130435, 1.2978260869565, 0.25
54276, 0.58695652173913, 1.2978260869565, 0.27272727272727
54277, 0.56521739130435, 1.2717391304348, 0.27272727272727
54278, 0.56521739130435, 1.2978260869565, 0.29545454545455
54279, 0.58695652173913, 1.2978260869565, 0.31818181818182
54280, 0.56521739130435, 1.2717391304348, 0.31818181818182
54281, 0.56521739130435, 1.2978260869565, 0.34090909090909
54282, 0.58695652173913, 1.2978260869565, 0.36363636363636
54283, 0.56521739130435, 1.2717391304348, 0.36363636363636
54284, 0.56521739130435, 1.2978260869565, 0.38636363636364
54285, 0.58695652173913, 1.2978260869565, 0.40909090909091
54286, 0.56521739130435, 1.2717391304348, 0.40909090909091
54287, 0.56521739130435, 1.2978260869565, 0.43181818181818
54288, 0.58695652173913, 1.2978260869565, 0.45454545454545
54289, 0.56521739130435, 1.2717391304348, 0.45454545454545
54290, 0.56521739130435, 1.2978260869565, 0.47727272727273
54291, 0.52173913043478, 1.2978260869565, 0.022727272727273
54292, 0.54347826086956, 1.2978260869565, 0.045454545454545
54293, 0.52173913043478, 1.2717391304348, 0.045454545454545
54294, 0.52173913043478, 1.2978260869565, 0.068181818181818
54295, 0.54347826086956, 1.2978260869565, 0.090909090909091
54296, 0.52173913043478, 1.2717391304348, 0.090909090909091
54297, 0.52173913043478, 1.2978260869565, 0.11363636363636
54298, 0.54347826086956, 1.2978260869565, 0.13636363636364
54299, 0.52173913043478, 1.2717391304348, 0.13636363636364
54300, 0.52173913043478, 1.2978260869565, 0.15909090909091
54301, 0.54347826086956, 1.2978260869565, 0.18181818181818
54302, 0.52173913043478, 1.2717391304348, 0.18181818181818
54303, 0.52173913043478, 1.2978260869565, 0.20454545454545
54304, 0.54347826086956, 1.2978260869565, 0.22727272727273
54305, 0.52173913043478, 1.2717391304348, 0.22727272727273
54306, 0.52173913043478, 1.2978260869565, 0.25
54307, 0.54347826086956, 1.2978260869565, 0.27272727272727
54308, 0.52173913043478, 1.2717391304348, 0.27272727272727
54309, 0.52173913043478, 1.2978260869565, 0.29545454545455
54310, 0.54347826086956, 1.2978260869565, 0.31818181818182
54311, 0.52173913043478, 1.2717391304348, 0.31818181818182
54312, 0.52173913043478, 1.2978260869565, 0.34090909090909
54313, 0.54347826086957, 1.2978260869565, 0.36363636363636
54314, 0.52173913043478, 1.2717391304348, 0.36363636363636
54315, 0.52173913043478, 1.2978260869565, 0.38636363636364
54316, 0.54347826086956, 1.2978260869565, 0.40909090909091
54317, 0.52173913043478, 1.2717391304348, 0.40909090909091
54318, 0.52173913043478, 1.2978260869565, 0.43181818181818
54319, 0.54347826086956, 1.2978260869565, 0.45454545454545
54320, 0.52173913043478, 1.2717391304348, 0.45454545454545
54321, 0.52173913043478, 1.2978260869565, 0.47727272727273
54322, 0.47826086956522, 1.2978260869565, 0.022727272727273
54323, 0.5, 1.2978260869565, 0.045454545454545
54324, 0.47826086956522, 1.2717391304348, 0.045454545454545
54325, 0.47826086956522, 1.2978260869565, 0.068181818181818
54326, 0.5, 1.2978260869565, 0.090909090909091
54327, 0.47826086956522, 1.2717391304348, 0.090909090909091
54328, 0.47826086956522, 1.2978260869565, 0.11363636363636
54329, 0.5, 1.2978260869565, 0.13636363636364
54330, 0.47826086956522, 1.2717391304348, 0.13636363636364
54331, 0.47826086956522, 1.2978260869565, 0.15909090909091
54332, 0.5, 1.2978260869565, 0.18181818181818
54333, 0.47826086956522, 1.2717391304348, 0.18181818181818
54334, 0.47826086956522, 1.2978260869565, 0.20454545454545
54335, 0.5, 1.2978260869565, 0.22727272727273
54336, 0.47826086956522, 1.2717391304348, 0.22727272727273
54337, 0.47826086956522, 1.2978260869565, 0.25
54338, 0.5, 1.2978260869565, 0.27272727272727
54339, 0.47826086956522, 1.2717391304348, 0.27272727272727
54340, 0.47826086956522, 1.2978260869565, 0.29545454545455
54341, 0.5, 1.2978260869565, 0.31818181818182
54342, 0.47826086956522, 1.2717391304348, 0.31818181818182
54343, 0.47826086956522, 1.2978260869565, 0.34090909090909
54344, 0.5, 1.2978260869565, 0.36363636363636
54345, 0.47826086956522, 1.2717391304348, 0.36363636363636
54346, 0.47826086956522, 1.2978260869565, 0.38636363636364
54347, 0.5, 1.2978260869565, 0.40909090909091
54348, 0.47826086956522, 1.2717391304348, 0.40909090909091
54349, 0.47826086956522, 1.2978260869565, 0.43181818181818
54350, 0.5, 1.2978260869565, 0.45454545454545
54351, 0.47826086956522, 1.2717391304348, 0.45454545454545
54352, 0.47826086956522, 1.2978260869565, 0.47727272727273
54353, 0.43478260869565, 1.2978260869565, 0.022727272727273
54354, 0.45652173913043, 1.2978260869565, 0.045454545454545
54355, 0.43478260869565, 1.2717391304348, 0.045454545454545
54356, 0.43478260869565, 1.2978260869565, 0.068181818181818
54357, 0.45652173913043, 1.2978260869565, 0.090909090909091
54358, 0.43478260869565, 1.2717391304348, 0.090909090909091
54359, 0.43478260869565, 1.2978260869565, 0.11363636363636
54360, 0.45652173913043, 1.2978260869565, 0.13636363636364
54361, 0.43478260869565, 1.2717391304348, 0.13636363636364
54362, 0.43478260869565, 1.2978260869565, 0.15909090909091
54363, 0.45652173913043, 1.2978260869565, 0.18181818181818
54364, 0.43478260869565, 1.2717391304348, 0.18181818181818
54365, 0.43478260869565, 1.2978260869565, 0.20454545454545
54366, 0.45652173913043, 1.2978260869565, 0.22727272727273
54367, 0.43478260869565, 1.2717391304348, 0.22727272727273
54368, 0.43478260869565, 1.2978260869565, 0.25
54369, 0.45652173913043, 1.2978260869565, 0.27272727272727
54370, 0.43478260869565, 1.2717391304348, 0.27272727272727
54371, 0.43478260869565, 1.2978260869565, 0.29545454545455
54372, 0.45652173913043, 1.2978260869565, 0.31818181818182
54373, 0.43478260869565, 1.2717391304348, 0.31818181818182
54374, 0.43478260869565, 1.2978260869565, 0.34090909090909
54375, 0.45652173913043, 1.2978260869565, 0.36363636363636
54376, 0.43478260869565, 1.2717391304348, 0.36363636363636
54377, 0.43478260869565, 1.2978260869565, 0.38636363636364
54378, 0.45652173913043, 1.2978260869565, 0.40909090909091
54379, 0.43478260869565, 1.2717391304348, 0.40909090909091
54380, 0.43478260869565, 1.2978260869565, 0.43181818181818
54381, 0.45652173913043, 1.2978260869565, 0.45454545454545
54382, 0.43478260869565, 1.2717391304348, 0.45454545454545
54383, 0.43478260869565, 1.2978260869565, 0.47727272727273
54384, 0.39130434782609, 1.2978260869565, 0.022727272727273
54385, 0.41304347826087, 1.2978260869565, 0.045454545454545
54386, 0.39130434782609, 1.2717391304348, 0.045454545454545
54387, 0.39130434782609, 1.2978260869565, 0.068181818181818
54388, 0.41304347826087, 1.2978260869565, 0.090909090909091
54389, 0.39130434782609, 1.2717391304348, 0.090909090909091
54390, 0.39130434782609, 1.2978260869565, 0.11363636363636
54391, 0.41304347826087, 1.2978260869565, 0.13636363636364
54392, 0.39130434782609, 1.2717391304348, 0.13636363636364
54393, 0.39130434782609, 1.2978260869565, 0.15909090909091
54394, 0.41304347826087, 1.2978260869565, 0.18181818181818
54395, 0.39130434782609, 1.2717391304348, 0.18181818181818
54396, 0.39130434782609, 1.2978260869565, 0.20454545454545
54397, 0.41304347826087, 1.2978260869565, 0.22727272727273
54398, 0.39130434782609, 1.2717391304348, 0.22727272727273
54399, 0.39130434782609, 1.2978260869565, 0.25
54400, 0.41304347826087, 1.2978260869565, 0.27272727272727
54401, 0.39130434782609, 1.2717391304348, 0.27272727272727
54402, 0.39130434782609, 1.2978260869565, 0.29545454545455
54403, 0.41304347826087, 1.2978260869565, 0.31818181818182
54404, 0.39130434782609, 1.2717391304348, 0.31818181818182
54405, 0.39130434782609, 1.2978260869565, 0.34090909090909
54406, 0.41304347826087, 1.2978260869565, 0.36363636363636
54407, 0.39130434782609, 1.2717391304348, 0.36363636363636
54408, 0.39130434782609, 1.2978260869565, 0.38636363636364
54409, 0.41304347826087, 1.2978260869565, 0.40909090909091
54410, 0.39130434782609, 1.2717391304348, 0.40909090909091
54411, 0.39130434782609, 1.2978260869565, 0.43181818181818
54412, 0.41304347826087, 1.2978260869565, 0.45454545454545
54413, 0.39130434782609, 1.2717391304348, 0.45454545454545
54414, 0.39130434782609, 1.2978260869565, 0.47727272727273
54415, 0.34782608695652, 1.2978260869565, 0.022727272727273
54416, 0.3695652173913, 1.2978260869565, 0.045454545454545
54417, 0.34782608695652, 1.2717391304348, 0.045454545454545
54418, 0.34782608695652, 1.2978260869565, 0.068181818181818
54419, 0.3695652173913, 1.2978260869565, 0.090909090909091
54420, 0.34782608695652, 1.2717391304348, 0.090909090909091
54421, 0.34782608695652, 1.2978260869565, 0.11363636363636
54422, 0.3695652173913, 1.2978260869565, 0.13636363636364
54423, 0.34782608695652, 1.2717391304348, 0.13636363636364
54424, 0.34782608695652, 1.2978260869565, 0.15909090909091
54425, 0.3695652173913, 1.2978260869565, 0.18181818181818
54426, 0.34782608695652, 1.2717391304348, 0.18181818181818
54427, 0.34782608695652, 1.2978260869565, 0.20454545454545
54428, 0.3695652173913, 1.2978260869565, 0.22727272727273
54429, 0.34782608695652, 1.2717391304348, 0.22727272727273
54430, 0.34782608695652, 1.2978260869565, 0.25
54431, 0.3695652173913, 1.2978260869565, 0.27272727272727
54432, 0.34782608695652, 1.2717391304348, 0.27272727272727
54433, 0.34782608695652, 1.2978260869565, 0.29545454545455
54434, 0.3695652173913, 1.2978260869565, 0.31818181818182
54435, 0.34782608695652, 1.2717391304348, 0.31818181818182
54436, 0.34782608695652, 1.2978260869565, 0.34090909090909
54437, 0.3695652173913, 1.2978260869565, 0.36363636363636
54438, 0.34782608695652, 1.2717391304348, 0.36363636363636
54439, 0.34782608695652, 1.2978260869565, 0.38636363636364
54440, 0.3695652173913, 1.2978260869565, 0.40909090909091
54441, 0.34782608695652, 1.2717391304348, 0.40909090909091
54442, 0.34782608695652, 1.2978260869565, 0.43181818181818
54443, 0.3695652173913, 1.2978260869565, 0.45454545454545
54444, 0.34782608695652, 1.2717391304348, 0.45454545454545
54445, 0.34782608695652, 1.2978260869565, 0.47727272727273
54446, 0.30434782608696, 1.2978260869565, 0.022727272727273
54447, 0.32608695652174, 1.2978260869565, 0.045454545454545
54448, 0.30434782608696, 1.2717391304348, 0.045454545454545
54449, 0.30434782608696, 1.2978260869565, 0.068181818181818
54450, 0.32608695652174, 1.2978260869565, 0.090909090909091
54451, 0.30434782608696, 1.2717391304348, 0.090909090909091
54452, 0.30434782608696, 1.2978260869565, 0.11363636363636
54453, 0.32608695652174, 1.2978260869565, 0.13636363636364
54454, 0.30434782608696, 1.2717391304348, 0.13636363636364
54455, 0.30434782608696, 1.2978260869565, 0.15909090909091
54456, 0.32608695652174, 1.2978260869565, 0.18181818181818
54457, 0.30434782608696, 1.2717391304348, 0.18181818181818
54458, 0.30434782608696, 1.2978260869565, 0.20454545454545
54459, 0.32608695652174, 1.2978260869565, 0.22727272727273
54460, 0.30434782608696, 1.2717391304348, 0.22727272727273
54461, 0.30434782608696, 1.2978260869565, 0.25
54462, 0.32608695652174, 1.2978260869565, 0.27272727272727
54463, 0.30434782608696, 1.2717391304348, 0.27272727272727
54464, 0.30434782608696, 1.2978260869565, 0.29545454545455
54465, 0.32608695652174, 1.2978260869565, 0.31818181818182
54466, 0.30434782608696, 1.2717391304348, 0.31818181818182
54467, 0.30434782608696, 1.2978260869565, 0.34090909090909
54468, 0.32608695652174, 1.2978260869565, 0.36363636363636
54469, 0.30434782608696, 1.2717391304348, 0.36363636363636
54470, 0.30434782608696, 1.2978260869565, 0.38636363636364
54471, 0.32608695652174, 1.2978260869565, 0.40909090909091
54472, 0.30434782608696, 1.2717391304348, 0.40909090909091
54473, 0.30434782608696, 1.2978260869565, 0.43181818181818
54474, 0.32608695652174, 1.2978260869565, 0.45454545454545
54475, 0.30434782608696, 1.2717391304348, 0.45454545454545
54476, 0.30434782608696, 1.2978260869565, 0.47727272727273
54477, 0.26086956521739, 1.2978260869565, 0.022727272727273
54478, 0.28260869565217, 1.2978260869565, 0.045454545454545
54479, 0.26086956521739, 1.2717391304348, 0.045454545454545
54480, 0.26086956521739, 1.2978260869565, 0.068181818181818
54481, 0.28260869565217, 1.2978260869565, 0.090909090909091
54482, 0.26086956521739, 1.2717391304348, 0.090909090909091
54483, 0.26086956521739, 1.2978260869565, 0.11363636363636
54484, 0.28260869565217, 1.2978260869565, 0.13636363636364
54485, 0.26086956521739, 1.2717391304348, 0.13636363636364
54486, 0.26086956521739, 1.2978260869565, 0.15909090909091
54487, 0.28260869565217, 1.2978260869565, 0.18181818181818
54488, 0.26086956521739, 1.2717391304348, 0.18181818181818
54489, 0.26086956521739, 1.2978260869565, 0.20454545454545
54490, 0.28260869565217, 1.2978260869565, 0.22727272727273
54491, 0.26086956521739, 1.2717391304348, 0.22727272727273
54492, 0.26086956521739, 1.2978260869565, 0.25
54493, 0.28260869565217, 1.2978260869565, 0.27272727272727
54494, 0.26086956521739, 1.2717391304348, 0.27272727272727
54495, 0.26086956521739, 1.2978260869565, 0.29545454545455
54496, 0.28260869565217, 1.2978260869565, 0.31818181818182
54497, 0.26086956521739, 1.2717391304348, 0.31818181818182
54498, 0.26086956521739, 1.2978260869565, 0.34090909090909
54499, 0.28260869565217, 1.2978260869565, 0.36363636363636
54500, 0.26086956521739, 1.2717391304348, 0.36363636363636
54501, 0.26086956521739, 1.2978260869565, 0.38636363636364
54502, 0.28260869565217, 1.2978260869565, 0.40909090909091
54503, 0.26086956521739, 1.2717391304348, 0.40909090909091
54504, 0.26086956521739, 1.2978260869565, 0.43181818181818
54505, 0.28260869565217, 1.2978260869565, 0.45454545454545
54506, 0.26086956521739, 1.2717391304348, 0.45454545454545
54507, 0.26086956521739, 1.2978260869565, 0.47727272727273
54508, 0.21739130434783, 1.2978260869565, 0.022727272727273
54509, 0.23913043478261, 1.2978260869565, 0.045454545454545
54510, 0.21739130434783, 1.2717391304348, 0.045454545454545
54511, 0.21739130434783, 1.2978260869565, 0.068181818181818
54512, 0.23913043478261, 1.2978260869565, 0.090909090909091
54513, 0.21739130434783, 1.2717391304348, 0.090909090909091
54514, 0.21739130434783, 1.2978260869565, 0.11363636363636
54515, 0.23913043478261, 1.2978260869565, 0.13636363636364
54516, 0.21739130434783, 1.2717391304348, 0.13636363636364
54517, 0.21739130434783, 1.2978260869565, 0.15909090909091
54518, 0.23913043478261, 1.2978260869565, 0.18181818181818
54519, 0.21739130434783, 1.2717391304348, 0.18181818181818
54520, 0.21739130434783, 1.2978260869565, 0.20454545454545
54521, 0.23913043478261, 1.2978260869565, 0.22727272727273
54522, 0.21739130434783, 1.2717391304348, 0.22727272727273
54523, 0.21739130434783, 1.2978260869565, 0.25
54524, 0.23913043478261, 1.2978260869565, 0.27272727272727
54525, 0.21739130434783, 1.2717391304348, 0.27272727272727
54526, 0.21739130434783, 1.2978260869565, 0.29545454545455
54527, 0.23913043478261, 1.2978260869565, 0.31818181818182
54528, 0.21739130434783, 1.2717391304348, 0.31818181818182
54529, 0.21739130434783, 1.2978260869565, 0.34090909090909
54530, 0.23913043478261, 1.2978260869565, 0.36363636363636
54531, 0.21739130434783, 1.2717391304348, 0.36363636363636
54532, 0.21739130434783, 1.2978260869565, 0.38636363636364
54533, 0.23913043478261, 1.2978260869565, 0.40909090909091
54534, 0.21739130434783, 1.2717391304348, 0.40909090909091
54535, 0.21739130434783, 1.2978260869565, 0.43181818181818
54536, 0.23913043478261, 1.2978260869565, 0.45454545454545
54537, 0.21739130434783, 1.2717391304348, 0.45454545454545
54538, 0.21739130434783, 1.2978260869565, 0.47727272727273
54539, 0.17391304347826, 1.2978260869565, 0.022727272727273
54540, 0.19565217391304, 1.2978260869565, 0.045454545454545
54541, 0.17391304347826, 1.2717391304348, 0.045454545454545
54542, 0.17391304347826, 1.2978260869565, 0.068181818181818
54543, 0.19565217391304, 1.2978260869565, 0.090909090909091
54544, 0.17391304347826, 1.2717391304348, 0.090909090909091
54545, 0.17391304347826, 1.2978260869565, 0.11363636363636
54546, 0.19565217391304, 1.2978260869565, 0.13636363636364
54547, 0.17391304347826, 1.2717391304348, 0.13636363636364
54548, 0.17391304347826, 1.2978260869565, 0.15909090909091
54549, 0.19565217391304, 1.2978260869565, 0.18181818181818
54550, 0.17391304347826, 1.2717391304348, 0.18181818181818
54551, 0.17391304347826, 1.2978260869565, 0.20454545454545
54552, 0.19565217391304, 1.2978260869565, 0.22727272727273
54553, 0.17391304347826, 1.2717391304348, 0.22727272727273
54554, 0.17391304347826, 1.2978260869565, 0.25
54555, 0.19565217391304, 1.2978260869565, 0.27272727272727
54556, 0.17391304347826, 1.2717391304348, 0.27272727272727
54557, 0.17391304347826, 1.2978260869565, 0.29545454545455
54558, 0.19565217391304, 1.2978260869565, 0.31818181818182
54559, 0.17391304347826, 1.2717391304348, 0.31818181818182
54560, 0.17391304347826, 1.2978260869565, 0.34090909090909
54561, 0.19565217391304, 1.2978260869565, 0.36363636363636
54562, 0.17391304347826, 1.2717391304348, 0.36363636363636
54563, 0.17391304347826, 1.2978260869565, 0.38636363636364
54564, 0.19565217391304, 1.2978260869565, 0.40909090909091
54565, 0.17391304347826, 1.2717391304348, 0.40909090909091
54566, 0.17391304347826, 1.2978260869565, 0.43181818181818
54567, 0.19565217391304, 1.2978260869565, 0.45454545454545
54568, 0.17391304347826, 1.2717391304348, 0.45454545454545
54569, 0.17391304347826, 1.2978260869565, 0.47727272727273
54570, 0.1304347826087, 1.2978260869565, 0.022727272727273
54571, 0.15217391304348, 1.2978260869565, 0.045454545454545
54572, 0.1304347826087, 1.2717391304348, 0.045454545454545
54573, 0.1304347826087, 1.2978260869565, 0.068181818181818
54574, 0.15217391304348, 1.2978260869565, 0.090909090909091
54575, 0.1304347826087, 1.2717391304348, 0.090909090909091
54576, 0.1304347826087, 1.2978260869565, 0.11363636363636
54577, 0.15217391304348, 1.2978260869565, 0.13636363636364
54578, 0.1304347826087, 1.2717391304348, 0.13636363636364
54579, 0.1304347826087, 1.2978260869565, 0.15909090909091
54580, 0.15217391304348, 1.2978260869565, 0.18181818181818
54581, 0.1304347826087, 1.2717391304348, 0.18181818181818
54582, 0.1304347826087, 1.2978260869565, 0.20454545454545
54583, 0.15217391304348, 1.2978260869565, 0.22727272727273
54584, 0.1304347826087, 1.2717391304348, 0.22727272727273
54585, 0.1304347826087, 1.2978260869565, 0.25
54586, 0.15217391304348, 1.2978260869565, 0.27272727272727
54587, 0.1304347826087, 1.2717391304348, 0.27272727272727
54588, 0.1304347826087, 1.2978260869565, 0.29545454545455
54589, 0.15217391304348, 1.2978260869565, 0.31818181818182
54590, 0.1304347826087, 1.2717391304348, 0.31818181818182
54591, 0.1304347826087, 1.2978260869565, 0.34090909090909
54592, 0.15217391304348, 1.2978260869565, 0.36363636363636
54593, 0.1304347826087, 1.2717391304348, 0.36363636363636
54594, 0.1304347826087, 1.2978260869565, 0.38636363636364
54595, 0.15217391304348, 1.2978260869565, 0.40909090909091
54596, 0.1304347826087, 1.2717391304348, 0.40909090909091
54597, 0.1304347826087, 1.2978260869565, 0.43181818181818
54598, 0.15217391304348, 1.2978260869565, 0.45454545454545
54599, 0.1304347826087, 1.2717391304348, 0.45454545454545
54600, 0.1304347826087, 1.2978260869565, 0.47727272727273
54601, 0.08695652173913, 1.2978260869565, 0.022727272727273
54602, 0.10869565217391, 1.2978260869565, 0.045454545454545
54603, 0.08695652173913, 1.2717391304348, 0.045454545454545
54604, 0.08695652173913, 1.2978260869565, 0.068181818181818
54605, 0.10869565217391, 1.2978260869565, 0.090909090909091
54606, 0.08695652173913, 1.2717391304348, 0.090909090909091
54607, 0.08695652173913, 1.2978260869565, 0.11363636363636
54608, 0.10869565217391, 1.2978260869565, 0.13636363636364
54609, 0.08695652173913, 1.2717391304348, 0.13636363636364
54610, 0.08695652173913, 1.2978260869565, 0.15909090909091
54611, 0.10869565217391, 1.2978260869565, 0.18181818181818
54612, 0.08695652173913, 1.2717391304348, 0.18181818181818
54613, 0.08695652173913, 1.2978260869565, 0.20454545454545
54614, 0.10869565217391, 1.2978260869565, 0.22727272727273
54615, 0.08695652173913, 1.2717391304348, 0.22727272727273
54616, 0.08695652173913, 1.2978260869565, 0.25
54617, 0.10869565217391, 1.2978260869565, 0.27272727272727
54618, 0.08695652173913, 1.2717391304348, 0.27272727272727
54619, 0.08695652173913, 1.2978260869565, 0.29545454545455
54620, 0.10869565217391, 1.2978260869565, 0.31818181818182
54621, 0.08695652173913, 1.2717391304348, 0.31818181818182
54622, 0.08695652173913, 1.2978260869565, 0.34090909090909
54623, 0.10869565217391, 1.2978260869565, 0.36363636363636
54624, 0.08695652173913, 1.2717391304348, 0.36363636363636
54625, 0.08695652173913, 1.2978260869565, 0.38636363636364
54626, 0.10869565217391, 1.2978260869565, 0.40909090909091
54627, 0.08695652173913, 1.2717391304348, 0.40909090909091
54628, 0.08695652173913, 1.2978260869565, 0.43181818181818
54629, 0.10869565217391, 1.2978260869565, 0.45454545454545
54630, 0.08695652173913, 1.2717391304348, 0.45454545454545
54631, 0.08695652173913, 1.2978260869565, 0.47727272727273
54632, 0.043478260869565, 1.2978260869565, 0.022727272727273
54633, 0.065217391304348, 1.2978260869565, 0.045454545454545
54634, 0.043478260869565, 1.2717391304348, 0.045454545454545
54635, 0.043478260869565, 1.2978260869565, 0.068181818181818
54636, 0.065217391304348, 1.2978260869565, 0.090909090909091
54637, 0.043478260869565, 1.2717391304348, 0.090909090909091
54638, 0.043478260869565, 1.2978260869565, 0.11363636363636
54639, 0.065217391304348, 1.2978260869565, 0.13636363636364
54640, 0.043478260869565, 1.2717391304348, 0.13636363636364
54641, 0.043478260869565, 1.2978260869565, 0.15909090909091
54642, 0.065217391304348, 1.2978260869565, 0.18181818181818
54643, 0.043478260869565, 1.2717391304348, 0.18181818181818
54644, 0.043478260869565, 1.2978260869565, 0.20454545454545
54645, 0.065217391304348, 1.2978260869565, 0.22727272727273
54646, 0.043478260869565, 1.2717391304348, 0.22727272727273
54647, 0.043478260869565, 1.2978260869565, 0.25
54648, 0.065217391304348, 1.2978260869565, 0.27272727272727
54649, 0.043478260869565, 1.2717391304348, 0.27272727272727
54650, 0.043478260869565, 1.2978260869565, 0.29545454545455
54651, 0.065217391304348, 1.2978260869565, 0.31818181818182
54652, 0.043478260869565, 1.2717391304348, 0.31818181818182
54653, 0.043478260869565, 1.2978260869565, 0.34090909090909
54654, 0.065217391304348, 1.2978260869565, 0.36363636363636
54655, 0.043478260869565, 1.2717391304348, 0.36363636363636
54656, 0.043478260869565, 1.2978260869565, 0.38636363636364
54657, 0.065217391304348, 1.2978260869565, 0.40909090909091
54658, 0.043478260869565, 1.2717391304348, 0.40909090909091
54659, 0.043478260869565, 1.2978260869565, 0.43181818181818
54660, 0.065217391304348, 1.2978260869565, 0.45454545454545
54661, 0.043478260869565, 1.2717391304348, 0.45454545454545
54662, 0.043478260869565, 1.2978260869565, 0.47727272727273
54663, 0.021739130434783, 1.2978260869565, 0.045454545454545
54664, 0.021739130434783, 1.2978260869565, 0.090909090909091
54665, 0.021739130434783, 1.2978260869565, 0.13636363636364
54666, 0.021739130434783, 1.2978260869565, 0.18181818181818
54667, 0.021739130434783, 1.2978260869565, 0.22727272727273
54668, 0.021739130434783, 1.2978260869565, 0.27272727272727
54669, 0.021739130434783, 1.2978260869565, 0.31818181818182
54670, 0.021739130434783, 1.2978260869565, 0.36363636363636
54671, 0.021739130434783, 1.2978260869565, 0.40909090909091
54672, 0.021739130434783, 1.2978260869565, 0.45454545454545
54673, 0.95652173913043, 1.3239130434783, 0.045454545454545
54674, 0.95652173913043, 1.3239130434783, 0.090909090909091
54675, 0.95652173913044, 1.3239130434783, 0.13636363636364
54676, 0.95652173913043, 1.3239130434783, 0.18181818181818
54677, 0.95652173913044, 1.3239130434783, 0.22727272727273
54678, 0.95652173913044, 1.3239130434783, 0.27272727272727
54679, 0.95652173913043, 1.3239130434783, 0.31818181818182
54680, 0.95652173913043, 1.3239130434783, 0.36363636363636
54681, 0.95652173913043, 1.3239130434783, 0.40909090909091
54682, 0.95652173913044, 1.3239130434783, 0.45454545454545
54683, 0.91304347826087, 1.3239130434783, 0.045454545454545
54684, 0.91304347826087, 1.3239130434783, 0.090909090909091
54685, 0.91304347826087, 1.3239130434783, 0.13636363636364
54686, 0.91304347826087, 1.3239130434783, 0.18181818181818
54687, 0.91304347826087, 1.3239130434783, 0.22727272727273
54688, 0.91304347826087, 1.3239130434783, 0.27272727272727
54689, 0.91304347826087, 1.3239130434783, 0.31818181818182
54690, 0.91304347826087, 1.3239130434783, 0.36363636363636
54691, 0.91304347826087, 1.3239130434783, 0.40909090909091
54692, 0.91304347826087, 1.3239130434783, 0.45454545454545
54693, 0.8695652173913, 1.3239130434783, 0.045454545454545
54694, 0.8695652173913, 1.3239130434783, 0.090909090909091
54695, 0.8695652173913, 1.3239130434783, 0.13636363636364
54696, 0.8695652173913, 1.3239130434783, 0.18181818181818
54697, 0.8695652173913, 1.3239130434783, 0.22727272727273
54698, 0.8695652173913, 1.3239130434783, 0.27272727272727
54699, 0.8695652173913, 1.3239130434783, 0.31818181818182
54700, 0.8695652173913, 1.3239130434783, 0.36363636363636
54701, 0.8695652173913, 1.3239130434783, 0.40909090909091
54702, 0.8695652173913, 1.3239130434783, 0.45454545454545
54703, 0.82608695652174, 1.3239130434783, 0.045454545454545
54704, 0.82608695652174, 1.3239130434783, 0.090909090909091
54705, 0.82608695652174, 1.3239130434783, 0.13636363636364
54706, 0.82608695652174, 1.3239130434783, 0.18181818181818
54707, 0.82608695652174, 1.3239130434783, 0.22727272727273
54708, 0.82608695652174, 1.3239130434783, 0.27272727272727
54709, 0.82608695652174, 1.3239130434783, 0.31818181818182
54710, 0.82608695652174, 1.3239130434783, 0.36363636363636
54711, 0.82608695652174, 1.3239130434783, 0.40909090909091
54712, 0.82608695652174, 1.3239130434783, 0.45454545454545
54713, 0.78260869565217, 1.3239130434783, 0.045454545454545
54714, 0.78260869565217, 1.3239130434783, 0.090909090909091
54715, 0.78260869565217, 1.3239130434783, 0.13636363636364
54716, 0.78260869565217, 1.3239130434783, 0.18181818181818
54717, 0.78260869565217, 1.3239130434783, 0.22727272727273
54718, 0.78260869565217, 1.3239130434783, 0.27272727272727
54719, 0.78260869565217, 1.3239130434783, 0.31818181818182
54720, 0.78260869565217, 1.3239130434783, 0.36363636363636
54721, 0.78260869565217, 1.3239130434783, 0.40909090909091
54722, 0.78260869565217, 1.3239130434783, 0.45454545454545
54723, 0.73913043478261, 1.3239130434783, 0.045454545454545
54724, 0.73913043478261, 1.3239130434783, 0.090909090909091
54725, 0.73913043478261, 1.3239130434783, 0.13636363636364
54726, 0.73913043478261, 1.3239130434783, 0.18181818181818
54727, 0.73913043478261, 1.3239130434783, 0.22727272727273
54728, 0.73913043478261, 1.3239130434783, 0.27272727272727
54729, 0.73913043478261, 1.3239130434783, 0.31818181818182
54730, 0.73913043478261, 1.3239130434783, 0.36363636363636
54731, 0.73913043478261, 1.3239130434783, 0.40909090909091
54732, 0.73913043478261, 1.3239130434783, 0.45454545454545
54733, 0.69565217391304, 1.3239130434783, 0.045454545454545
54734, 0.69565217391304, 1.3239130434783, 0.090909090909091
54735, 0.69565217391304, 1.3239130434783, 0.13636363636364
54736, 0.69565217391304, 1.3239130434783, 0.18181818181818
54737, 0.69565217391304, 1.3239130434783, 0.22727272727273
54738, 0.69565217391304, 1.3239130434783, 0.27272727272727
54739, 0.69565217391304, 1.3239130434783, 0.31818181818182
54740, 0.69565217391304, 1.3239130434783, 0.36363636363636
54741, 0.69565217391304, 1.3239130434783, 0.40909090909091
54742, 0.69565217391304, 1.3239130434783, 0.45454545454545
54743, 0.65217391304348, 1.3239130434783, 0.045454545454545
54744, 0.65217391304348, 1.3239130434783, 0.090909090909091
54745, 0.65217391304348, 1.3239130434783, 0.13636363636364
54746, 0.65217391304348, 1.3239130434783, 0.18181818181818
54747, 0.65217391304348, 1.3239130434783, 0.22727272727273
54748, 0.65217391304348, 1.3239130434783, 0.27272727272727
54749, 0.65217391304348, 1.3239130434783, 0.31818181818182
54750, 0.65217391304348, 1.3239130434783, 0.36363636363636
54751, 0.65217391304348, 1.3239130434783, 0.40909090909091
54752, 0.65217391304348, 1.3239130434783, 0.45454545454545
54753, 0.60869565217391, 1.3239130434783, 0.045454545454545
54754, 0.60869565217391, 1.3239130434783, 0.090909090909091
54755, 0.60869565217391, 1.3239130434783, 0.13636363636364
54756, 0.60869565217391, 1.3239130434783, 0.18181818181818
54757, 0.60869565217391, 1.3239130434783, 0.22727272727273
54758, 0.60869565217391, 1.3239130434783, 0.27272727272727
54759, 0.60869565217391, 1.3239130434783, 0.31818181818182
54760, 0.60869565217391, 1.3239130434783, 0.36363636363636
54761, 0.60869565217391, 1.3239130434783, 0.40909090909091
54762, 0.60869565217391, 1.3239130434783, 0.45454545454545
54763, 0.56521739130435, 1.3239130434783, 0.045454545454545
54764, 0.56521739130435, 1.3239130434783, 0.090909090909091
54765, 0.56521739130435, 1.3239130434783, 0.13636363636364
54766, 0.56521739130435, 1.3239130434783, 0.18181818181818
54767, 0.56521739130435, 1.3239130434783, 0.22727272727273
54768, 0.56521739130435, 1.3239130434783, 0.27272727272727
54769, 0.56521739130435, 1.3239130434783, 0.31818181818182
54770, 0.56521739130435, 1.3239130434783, 0.36363636363636
54771, 0.56521739130435, 1.3239130434783, 0.40909090909091
54772, 0.56521739130435, 1.3239130434783, 0.45454545454545
54773, 0.52173913043478, 1.3239130434783, 0.045454545454545
54774, 0.52173913043478, 1.3239130434783, 0.090909090909091
54775, 0.52173913043478, 1.3239130434783, 0.13636363636364
54776, 0.52173913043478, 1.3239130434783, 0.18181818181818
54777, 0.52173913043478, 1.3239130434783, 0.22727272727273
54778, 0.52173913043478, 1.3239130434783, 0.27272727272727
54779, 0.52173913043478, 1.3239130434783, 0.31818181818182
54780, 0.52173913043478, 1.3239130434783, 0.36363636363636
54781, 0.52173913043478, 1.3239130434783, 0.40909090909091
54782, 0.52173913043478, 1.3239130434783, 0.45454545454545
54783, 0.47826086956522, 1.3239130434783, 0.045454545454545
54784, 0.47826086956522, 1.3239130434783, 0.090909090909091
54785, 0.47826086956522, 1.3239130434783, 0.13636363636364
54786, 0.47826086956522, 1.3239130434783, 0.18181818181818
54787, 0.47826086956522, 1.3239130434783, 0.22727272727273
54788, 0.47826086956522, 1.3239130434783, 0.27272727272727
54789, 0.47826086956522, 1.3239130434783, 0.31818181818182
54790, 0.47826086956522, 1.3239130434783, 0.36363636363636
54791, 0.47826086956522, 1.3239130434783, 0.40909090909091
54792, 0.47826086956522, 1.3239130434783, 0.45454545454545
54793, 0.43478260869565, 1.3239130434783, 0.045454545454545
54794, 0.43478260869565, 1.3239130434783, 0.090909090909091
54795, 0.43478260869565, 1.3239130434783, 0.13636363636364
54796, 0.43478260869565, 1.3239130434783, 0.18181818181818
54797, 0.43478260869565, 1.3239130434783, 0.22727272727273
54798, 0.43478260869565, 1.3239130434783, 0.27272727272727
54799, 0.43478260869565, 1.3239130434783, 0.31818181818182
54800, 0.43478260869565, 1.3239130434783, 0.36363636363636
54801, 0.43478260869565, 1.3239130434783, 0.40909090909091
54802, 0.43478260869565, 1.3239130434783, 0.45454545454545
54803, 0.39130434782609, 1.3239130434783, 0.045454545454545
54804, 0.39130434782609, 1.3239130434783, 0.090909090909091
54805, 0.39130434782609, 1.3239130434783, 0.13636363636364
54806, 0.39130434782609, 1.3239130434783, 0.18181818181818
54807, 0.39130434782609, 1.3239130434783, 0.22727272727273
54808, 0.39130434782609, 1.3239130434783, 0.27272727272727
54809, 0.39130434782609, 1.3239130434783, 0.31818181818182
54810, 0.39130434782609, 1.3239130434783, 0.36363636363636
54811, 0.39130434782609, 1.3239130434783, 0.40909090909091
54812, 0.39130434782609, 1.3239130434783, 0.45454545454545
54813, 0.34782608695652, 1.3239130434783, 0.045454545454545
54814, 0.34782608695652, 1.3239130434783, 0.090909090909091
54815, 0.34782608695652, 1.3239130434783, 0.13636363636364
54816, 0.34782608695652, 1.3239130434783, 0.18181818181818
54817, 0.34782608695652, 1.3239130434783, 0.22727272727273
54818, 0.34782608695652, 1.3239130434783, 0.27272727272727
54819, 0.34782608695652, 1.3239130434783, 0.31818181818182
54820, 0.34782608695652, 1.3239130434783, 0.36363636363636
54821, 0.34782608695652, 1.3239130434783, 0.40909090909091
54822, 0.34782608695652, 1.3239130434783, 0.45454545454545
54823, 0.30434782608696, 1.3239130434783, 0.045454545454545
54824, 0.30434782608696, 1.3239130434783, 0.090909090909091
54825, 0.30434782608696, 1.3239130434783, 0.13636363636364
54826, 0.30434782608696, 1.3239130434783, 0.18181818181818
54827, 0.30434782608696, 1.3239130434783, 0.22727272727273
54828, 0.30434782608696, 1.3239130434783, 0.27272727272727
54829, 0.30434782608696, 1.3239130434783, 0.31818181818182
54830, 0.30434782608696, 1.3239130434783, 0.36363636363636
54831, 0.30434782608696, 1.3239130434783, 0.40909090909091
54832, 0.30434782608696, 1.3239130434783, 0.45454545454545
54833, 0.26086956521739, 1.3239130434783, 0.045454545454545
54834, 0.26086956521739, 1.3239130434783, 0.090909090909091
54835, 0.26086956521739, 1.3239130434783, 0.13636363636364
54836, 0.26086956521739, 1.3239130434783, 0.18181818181818
54837, 0.26086956521739, 1.3239130434783, 0.22727272727273
54838, 0.26086956521739, 1.3239130434783, 0.27272727272727
54839, 0.26086956521739, 1.3239130434783, 0.31818181818182
54840, 0.26086956521739, 1.3239130434783, 0.36363636363636
54841, 0.26086956521739, 1.3239130434783, 0.40909090909091
54842, 0.26086956521739, 1.3239130434783, 0.45454545454545
54843, 0.21739130434783, 1.3239130434783, 0.045454545454545
54844, 0.21739130434783, 1.3239130434783, 0.090909090909091
54845, 0.21739130434783, 1.3239130434783, 0.13636363636364
54846, 0.21739130434783, 1.3239130434783, 0.18181818181818
54847, 0.21739130434783, 1.3239130434783, 0.22727272727273
54848, 0.21739130434783, 1.3239130434783, 0.27272727272727
54849, 0.21739130434783, 1.3239130434783, 0.31818181818182
54850, 0.21739130434783, 1.3239130434783, 0.36363636363636
54851, 0.21739130434783, 1.3239130434783, 0.40909090909091
54852, 0.21739130434783, 1.3239130434783, 0.45454545454545
54853, 0.17391304347826, 1.3239130434783, 0.045454545454545
54854, 0.17391304347826, 1.3239130434783, 0.090909090909091
54855, 0.17391304347826, 1.3239130434783, 0.13636363636364
54856, 0.17391304347826, 1.3239130434783, 0.18181818181818
54857, 0.17391304347826, 1.3239130434783, 0.22727272727273
54858, 0.17391304347826, 1.3239130434783, 0.27272727272727
54859, 0.17391304347826, 1.3239130434783, 0.31818181818182
54860, 0.17391304347826, 1.3239130434783, 0.36363636363636
54861, 0.17391304347826, 1.3239130434783, 0.40909090909091
54862, 0.17391304347826, 1.3239130434783, 0.45454545454545
54863, 0.1304347826087, 1.3239130434783, 0.045454545454545
54864, 0.1304347826087, 1.3239130434783, 0.090909090909091
54865, 0.1304347826087, 1.3239130434783, 0.13636363636364
54866, 0.1304347826087, 1.3239130434783, 0.18181818181818
54867, 0.1304347826087, 1.3239130434783, 0.22727272727273
54868, 0.1304347826087, 1.3239130434783, 0.27272727272727
54869, 0.1304347826087, 1.3239130434783, 0.31818181818182
54870, 0.1304347826087, 1.3239130434783, 0.36363636363636
54871, 0.1304347826087, 1.3239130434783, 0.40909090909091
54872, 0.1304347826087, 1.3239130434783, 0.45454545454545
54873, 0.08695652173913, 1.3239130434783, 0.045454545454545
54874, 0.08695652173913, 1.3239130434783, 0.090909090909091
54875, 0.08695652173913, 1.3239130434783, 0.13636363636364
54876, 0.08695652173913, 1.3239130434783, 0.18181818181818
54877, 0.08695652173913, 1.3239130434783, 0.22727272727273
54878, 0.08695652173913, 1.3239130434783, 0.27272727272727
54879, 0.08695652173913, 1.3239130434783, 0.31818181818182
54880, 0.08695652173913, 1.3239130434783, 0.36363636363636
54881, 0.08695652173913, 1.3239130434783, 0.40909090909091
54882, 0.08695652173913, 1.3239130434783, 0.45454545454545
54883, 0.043478260869565, 1.3239130434783, 0.045454545454545
54884, 0.043478260869565, 1.3239130434783, 0.090909090909091
54885, 0.043478260869565, 1.3239130434783, 0.13636363636364
54886, 0.043478260869565, 1.3239130434783, 0.18181818181818
54887, 0.043478260869565, 1.3239130434783, 0.22727272727273
54888, 0.043478260869565, 1.3239130434783, 0.27272727272727
54889, 0.043478260869565, 1.3239130434783, 0.31818181818182
54890, 0.043478260869565, 1.3239130434783, 0.36363636363636
54891, 0.043478260869565, 1.3239130434783, 0.40909090909091
54892, 0.043478260869565, 1.3239130434783, 0.45454545454545
54893, 0.95652173913043, 1.375, 0.045454545454545
54894, 0.95652173913043, 1.375, 0.090909090909091
54895, 0.95652173913044, 1.375, 0.13636363636364
54896, 0.95652173913044, 1.375, 0.18181818181818
54897, 0.95652173913044, 1.375, 0.22727272727273
54898, 0.95652173913044, 1.375, 0.27272727272727
54899, 0.95652173913044, 1.375, 0.31818181818182
54900, 0.95652173913043, 1.375, 0.36363636363636
54901, 0.95652173913043, 1.375, 0.40909090909091
54902, 0.95652173913044, 1.375, 0.45454545454545
54903, 0.91304347826087, 1.375, 0.045454545454545
54904, 0.91304347826087, 1.375, 0.090909090909091
54905, 0.91304347826087, 1.375, 0.13636363636364
54906, 0.91304347826087, 1.375, 0.18181818181818
54907, 0.91304347826087, 1.375, 0.22727272727273
54908, 0.91304347826087, 1.375, 0.27272727272727
54909, 0.91304347826087, 1.375, 0.31818181818182
54910, 0.91304347826087, 1.375, 0.36363636363636
54911, 0.91304347826087, 1.375, 0.40909090909091
54912, 0.91304347826087, 1.375, 0.45454545454545
54913, 0.8695652173913, 1.375, 0.045454545454545
54914, 0.8695652173913, 1.375, 0.090909090909091
54915, 0.8695652173913, 1.375, 0.13636363636364
54916, 0.8695652173913, 1.375, 0.18181818181818
54917, 0.8695652173913, 1.375, 0.22727272727273
54918, 0.8695652173913, 1.375, 0.27272727272727
54919, 0.8695652173913, 1.375, 0.31818181818182
54920, 0.8695652173913, 1.375, 0.36363636363636
54921, 0.8695652173913, 1.375, 0.40909090909091
54922, 0.8695652173913, 1.375, 0.45454545454545
54923, 0.82608695652174, 1.375, 0.045454545454545
54924, 0.82608695652174, 1.375, 0.090909090909091
54925, 0.82608695652174, 1.375, 0.13636363636364
54926, 0.82608695652174, 1.375, 0.18181818181818
54927, 0.82608695652174, 1.375, 0.22727272727273
54928, 0.82608695652174, 1.375, 0.27272727272727
54929, 0.82608695652174, 1.375, 0.31818181818182
54930, 0.82608695652174, 1.375, 0.36363636363636
54931, 0.82608695652174, 1.375, 0.40909090909091
54932, 0.82608695652174, 1.375, 0.45454545454545
54933, 0.78260869565217, 1.375, 0.045454545454545
54934, 0.78260869565217, 1.375, 0.090909090909091
54935, 0.78260869565217, 1.375, 0.13636363636364
54936, 0.78260869565217, 1.375, 0.18181818181818
54937, 0.78260869565217, 1.375, 0.22727272727273
54938, 0.78260869565217, 1.375, 0.27272727272727
54939, 0.78260869565217, 1.375, 0.31818181818182
54940, 0.78260869565217, 1.375, 0.36363636363636
54941, 0.78260869565217, 1.375, 0.40909090909091
54942, 0.78260869565217, 1.375, 0.45454545454545
54943, 0.73913043478261, 1.375, 0.045454545454545
54944, 0.73913043478261, 1.375, 0.090909090909091
54945, 0.73913043478261, 1.375, 0.13636363636364
54946, 0.73913043478261, 1.375, 0.18181818181818
54947, 0.73913043478261, 1.375, 0.22727272727273
54948, 0.73913043478261, 1.375, 0.27272727272727
54949, 0.73913043478261, 1.375, 0.31818181818182
54950, 0.73913043478261, 1.375, 0.36363636363636
54951, 0.73913043478261, 1.375, 0.40909090909091
54952, 0.73913043478261, 1.375, 0.45454545454545
54953, 0.69565217391304, 1.375, 0.045454545454545
54954, 0.69565217391304, 1.375, 0.090909090909091
54955, 0.69565217391304, 1.375, 0.13636363636364
54956, 0.69565217391304, 1.375, 0.18181818181818
54957, 0.69565217391304, 1.375, 0.22727272727273
54958, 0.69565217391304, 1.375, 0.27272727272727
54959, 0.69565217391304, 1.375, 0.31818181818182
54960, 0.69565217391304, 1.375, 0.36363636363636
54961, 0.69565217391304, 1.375, 0.40909090909091
54962, 0.69565217391304, 1.375, 0.45454545454545
54963, 0.65217391304348, 1.375, 0.045454545454545
54964, 0.65217391304348, 1.375, 0.090909090909091
54965, 0.65217391304348, 1.375, 0.13636363636364
54966, 0.65217391304348, 1.375, 0.18181818181818
54967, 0.65217391304348, 1.375, 0.22727272727273
54968, 0.65217391304348, 1.375, 0.27272727272727
54969, 0.65217391304348, 1.375, 0.31818181818182
54970, 0.65217391304348, 1.375, 0.36363636363636
54971, 0.65217391304348, 1.375, 0.40909090909091
54972, 0.65217391304348, 1.375, 0.45454545454545
54973, 0.60869565217391, 1.375, 0.045454545454545
54974, 0.60869565217391, 1.375, 0.090909090909091
54975, 0.60869565217391, 1.375, 0.13636363636364
54976, 0.60869565217391, 1.375, 0.18181818181818
54977, 0.60869565217391, 1.375, 0.22727272727273
54978, 0.60869565217391, 1.375, 0.27272727272727
54979, 0.60869565217391, 1.375, 0.31818181818182
54980, 0.60869565217391, 1.375, 0.36363636363636
54981, 0.60869565217391, 1.375, 0.40909090909091
54982, 0.60869565217391, 1.375, 0.45454545454545
54983, 0.56521739130435, 1.375, 0.045454545454545
54984, 0.56521739130435, 1.375, 0.090909090909091
54985, 0.56521739130435, 1.375, 0.13636363636364
54986, 0.56521739130435, 1.375, 0.18181818181818
54987, 0.56521739130435, 1.375, 0.22727272727273
54988, 0.56521739130435, 1.375, 0.27272727272727
54989, 0.56521739130435, 1.375, 0.31818181818182
54990, 0.56521739130435, 1.375, 0.36363636363636
54991, 0.56521739130435, 1.375, 0.40909090909091
54992, 0.56521739130435, 1.375, 0.45454545454545
54993, 0.52173913043478, 1.375, 0.045454545454545
54994, 0.52173913043478, 1.375, 0.090909090909091
54995, 0.52173913043478, 1.375, 0.13636363636364
54996, 0.52173913043478, 1.375, 0.18181818181818
54997, 0.52173913043478, 1.375, 0.22727272727273
54998, 0.52173913043478, 1.375, 0.27272727272727
54999, 0.52173913043478, 1.375, 0.31818181818182
55000, 0.52173913043478, 1.375, 0.36363636363636
55001, 0.52173913043478, 1.375, 0.40909090909091
55002, 0.52173913043478, 1.375, 0.45454545454545
55003, 0.47826086956522, 1.375, 0.045454545454545
55004, 0.47826086956522, 1.375, 0.090909090909091
55005, 0.47826086956522, 1.375, 0.13636363636364
55006, 0.47826086956522, 1.375, 0.18181818181818
55007, 0.47826086956522, 1.375, 0.22727272727273
55008, 0.47826086956522, 1.375, 0.27272727272727
55009, 0.47826086956522, 1.375, 0.31818181818182
55010, 0.47826086956522, 1.375, 0.36363636363636
55011, 0.47826086956522, 1.375, 0.40909090909091
55012, 0.47826086956522, 1.375, 0.45454545454545
55013, 0.43478260869565, 1.375, 0.045454545454545
55014, 0.43478260869565, 1.375, 0.090909090909091
55015, 0.43478260869565, 1.375, 0.13636363636364
55016, 0.43478260869565, 1.375, 0.18181818181818
55017, 0.43478260869565, 1.375, 0.22727272727273
55018, 0.43478260869565, 1.375, 0.27272727272727
55019, 0.43478260869565, 1.375, 0.31818181818182
55020, 0.43478260869565, 1.375, 0.36363636363636
55021, 0.43478260869565, 1.375, 0.40909090909091
55022, 0.43478260869565, 1.375, 0.45454545454545
55023, 0.39130434782609, 1.375, 0.045454545454545
55024, 0.39130434782609, 1.375, 0.090909090909091
55025, 0.39130434782609, 1.375, 0.13636363636364
55026, 0.39130434782609, 1.375, 0.18181818181818
55027, 0.39130434782609, 1.375, 0.22727272727273
55028, 0.39130434782609, 1.375, 0.27272727272727
55029, 0.39130434782609, 1.375, 0.31818181818182
55030, 0.39130434782609, 1.375, 0.36363636363636
55031, 0.39130434782609, 1.375, 0.40909090909091
55032, 0.39130434782609, 1.375, 0.45454545454545
55033, 0.34782608695652, 1.375, 0.045454545454545
55034, 0.34782608695652, 1.375, 0.090909090909091
55035, 0.34782608695652, 1.375, 0.13636363636364
55036, 0.34782608695652, 1.375, 0.18181818181818
55037, 0.34782608695652, 1.375, 0.22727272727273
55038, 0.34782608695652, 1.375, 0.27272727272727
55039, 0.34782608695652, 1.375, 0.31818181818182
55040, 0.34782608695652, 1.375, 0.36363636363636
55041, 0.34782608695652, 1.375, 0.40909090909091
55042, 0.34782608695652, 1.375, 0.45454545454545
55043, 0.30434782608696, 1.375, 0.045454545454545
55044, 0.30434782608696, 1.375, 0.090909090909091
55045, 0.30434782608696, 1.375, 0.13636363636364
55046, 0.30434782608696, 1.375, 0.18181818181818
