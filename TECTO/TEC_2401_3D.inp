36425, 0.73913043478261, 0.6195652173913, 0.31818181818182
36426, 0.73913043478261, 0.6195652173913, 0.36363636363636
36427, 0.73913043478261, 0.6195652173913, 0.40909090909091
36428, 0.73913043478261, 0.6195652173913, 0.45454545454545
36429, 0.69565217391304, 0.6195652173913, 0.045454545454545
36430, 0.69565217391304, 0.6195652173913, 0.090909090909091
36431, 0.69565217391304, 0.6195652173913, 0.13636363636364
36432, 0.69565217391304, 0.6195652173913, 0.18181818181818
36433, 0.69565217391304, 0.6195652173913, 0.22727272727273
36434, 0.69565217391304, 0.6195652173913, 0.27272727272727
36435, 0.69565217391304, 0.6195652173913, 0.31818181818182
36436, 0.69565217391304, 0.6195652173913, 0.36363636363636
36437, 0.69565217391304, 0.6195652173913, 0.40909090909091
36438, 0.69565217391304, 0.6195652173913, 0.45454545454545
36439, 0.65217391304348, 0.6195652173913, 0.045454545454545
36440, 0.65217391304348, 0.6195652173913, 0.090909090909091
36441, 0.65217391304348, 0.6195652173913, 0.13636363636364
36442, 0.65217391304348, 0.6195652173913, 0.18181818181818
36443, 0.65217391304348, 0.6195652173913, 0.22727272727273
36444, 0.65217391304348, 0.6195652173913, 0.27272727272727
36445, 0.65217391304348, 0.6195652173913, 0.31818181818182
36446, 0.65217391304348, 0.6195652173913, 0.36363636363636
36447, 0.65217391304348, 0.6195652173913, 0.40909090909091
36448, 0.65217391304348, 0.6195652173913, 0.45454545454545
36449, 0.60869565217391, 0.6195652173913, 0.045454545454545
36450, 0.60869565217391, 0.6195652173913, 0.090909090909091
36451, 0.60869565217391, 0.6195652173913, 0.13636363636364
36452, 0.60869565217391, 0.6195652173913, 0.18181818181818
36453, 0.60869565217391, 0.6195652173913, 0.22727272727273
36454, 0.60869565217391, 0.6195652173913, 0.27272727272727
36455, 0.60869565217391, 0.6195652173913, 0.31818181818182
36456, 0.60869565217391, 0.6195652173913, 0.36363636363636
36457, 0.60869565217391, 0.6195652173913, 0.40909090909091
36458, 0.60869565217391, 0.6195652173913, 0.45454545454545
36459, 0.56521739130435, 0.6195652173913, 0.045454545454545
36460, 0.56521739130435, 0.6195652173913, 0.090909090909091
36461, 0.56521739130435, 0.6195652173913, 0.13636363636364
36462, 0.56521739130435, 0.6195652173913, 0.18181818181818
36463, 0.56521739130435, 0.6195652173913, 0.22727272727273
36464, 0.56521739130435, 0.6195652173913, 0.27272727272727
36465, 0.56521739130435, 0.6195652173913, 0.31818181818182
36466, 0.56521739130435, 0.6195652173913, 0.36363636363636
36467, 0.56521739130435, 0.6195652173913, 0.40909090909091
36468, 0.56521739130435, 0.6195652173913, 0.45454545454545
36469, 0.52173913043478, 0.6195652173913, 0.045454545454545
36470, 0.52173913043478, 0.6195652173913, 0.090909090909091
36471, 0.52173913043478, 0.6195652173913, 0.13636363636364
36472, 0.52173913043478, 0.6195652173913, 0.18181818181818
36473, 0.52173913043478, 0.6195652173913, 0.22727272727273
36474, 0.52173913043478, 0.6195652173913, 0.27272727272727
36475, 0.52173913043478, 0.6195652173913, 0.31818181818182
36476, 0.52173913043478, 0.6195652173913, 0.36363636363636
36477, 0.52173913043478, 0.6195652173913, 0.40909090909091
36478, 0.52173913043478, 0.6195652173913, 0.45454545454545
36479, 0.47826086956522, 0.6195652173913, 0.045454545454545
36480, 0.47826086956522, 0.6195652173913, 0.090909090909091
36481, 0.47826086956522, 0.6195652173913, 0.13636363636364
36482, 0.47826086956522, 0.6195652173913, 0.18181818181818
36483, 0.47826086956522, 0.6195652173913, 0.22727272727273
36484, 0.47826086956522, 0.6195652173913, 0.27272727272727
36485, 0.47826086956522, 0.6195652173913, 0.31818181818182
36486, 0.47826086956522, 0.6195652173913, 0.36363636363636
36487, 0.47826086956522, 0.6195652173913, 0.40909090909091
36488, 0.47826086956522, 0.6195652173913, 0.45454545454545
36489, 0.43478260869565, 0.6195652173913, 0.045454545454545
36490, 0.43478260869565, 0.6195652173913, 0.090909090909091
36491, 0.43478260869565, 0.6195652173913, 0.13636363636364
36492, 0.43478260869565, 0.6195652173913, 0.18181818181818
36493, 0.43478260869565, 0.6195652173913, 0.22727272727273
36494, 0.43478260869565, 0.6195652173913, 0.27272727272727
36495, 0.43478260869565, 0.6195652173913, 0.31818181818182
36496, 0.43478260869565, 0.6195652173913, 0.36363636363636
36497, 0.43478260869565, 0.6195652173913, 0.40909090909091
36498, 0.43478260869565, 0.6195652173913, 0.45454545454545
36499, 0.39130434782609, 0.6195652173913, 0.045454545454545
36500, 0.39130434782609, 0.6195652173913, 0.090909090909091
36501, 0.39130434782609, 0.6195652173913, 0.13636363636364
36502, 0.39130434782609, 0.6195652173913, 0.18181818181818
36503, 0.39130434782609, 0.6195652173913, 0.22727272727273
36504, 0.39130434782609, 0.6195652173913, 0.27272727272727
36505, 0.39130434782609, 0.6195652173913, 0.31818181818182
36506, 0.39130434782609, 0.6195652173913, 0.36363636363636
36507, 0.39130434782609, 0.6195652173913, 0.40909090909091
36508, 0.39130434782609, 0.6195652173913, 0.45454545454545
36509, 0.34782608695652, 0.6195652173913, 0.045454545454545
36510, 0.34782608695652, 0.6195652173913, 0.090909090909091
36511, 0.34782608695652, 0.6195652173913, 0.13636363636364
36512, 0.34782608695652, 0.6195652173913, 0.18181818181818
36513, 0.34782608695652, 0.6195652173913, 0.22727272727273
36514, 0.34782608695652, 0.6195652173913, 0.27272727272727
36515, 0.34782608695652, 0.6195652173913, 0.31818181818182
36516, 0.34782608695652, 0.6195652173913, 0.36363636363636
36517, 0.34782608695652, 0.6195652173913, 0.40909090909091
36518, 0.34782608695652, 0.6195652173913, 0.45454545454545
36519, 0.30434782608696, 0.6195652173913, 0.045454545454545
36520, 0.30434782608696, 0.6195652173913, 0.090909090909091
36521, 0.30434782608696, 0.6195652173913, 0.13636363636364
36522, 0.30434782608696, 0.6195652173913, 0.18181818181818
36523, 0.30434782608696, 0.6195652173913, 0.22727272727273
36524, 0.30434782608696, 0.6195652173913, 0.27272727272727
36525, 0.30434782608696, 0.6195652173913, 0.31818181818182
36526, 0.30434782608696, 0.6195652173913, 0.36363636363636
36527, 0.30434782608696, 0.6195652173913, 0.40909090909091
36528, 0.30434782608696, 0.6195652173913, 0.45454545454545
36529, 0.26086956521739, 0.6195652173913, 0.045454545454545
36530, 0.26086956521739, 0.6195652173913, 0.090909090909091
36531, 0.26086956521739, 0.6195652173913, 0.13636363636364
36532, 0.26086956521739, 0.6195652173913, 0.18181818181818
36533, 0.26086956521739, 0.6195652173913, 0.22727272727273
36534, 0.26086956521739, 0.6195652173913, 0.27272727272727
36535, 0.26086956521739, 0.6195652173913, 0.31818181818182
36536, 0.26086956521739, 0.6195652173913, 0.36363636363636
36537, 0.26086956521739, 0.6195652173913, 0.40909090909091
36538, 0.26086956521739, 0.6195652173913, 0.45454545454545
36539, 0.21739130434783, 0.6195652173913, 0.045454545454545
36540, 0.21739130434783, 0.6195652173913, 0.090909090909091
36541, 0.21739130434783, 0.6195652173913, 0.13636363636364
36542, 0.21739130434783, 0.6195652173913, 0.18181818181818
36543, 0.21739130434783, 0.6195652173913, 0.22727272727273
36544, 0.21739130434783, 0.6195652173913, 0.27272727272727
36545, 0.21739130434783, 0.6195652173913, 0.31818181818182
36546, 0.21739130434783, 0.6195652173913, 0.36363636363636
36547, 0.21739130434783, 0.6195652173913, 0.40909090909091
36548, 0.21739130434783, 0.6195652173913, 0.45454545454545
36549, 0.17391304347826, 0.6195652173913, 0.045454545454545
36550, 0.17391304347826, 0.6195652173913, 0.090909090909091
36551, 0.17391304347826, 0.6195652173913, 0.13636363636364
36552, 0.17391304347826, 0.6195652173913, 0.18181818181818
36553, 0.17391304347826, 0.6195652173913, 0.22727272727273
36554, 0.17391304347826, 0.6195652173913, 0.27272727272727
36555, 0.17391304347826, 0.6195652173913, 0.31818181818182
36556, 0.17391304347826, 0.6195652173913, 0.36363636363636
36557, 0.17391304347826, 0.6195652173913, 0.40909090909091
36558, 0.17391304347826, 0.6195652173913, 0.45454545454545
36559, 0.1304347826087, 0.6195652173913, 0.045454545454545
36560, 0.1304347826087, 0.6195652173913, 0.090909090909091
36561, 0.1304347826087, 0.6195652173913, 0.13636363636364
36562, 0.1304347826087, 0.6195652173913, 0.18181818181818
36563, 0.1304347826087, 0.6195652173913, 0.22727272727273
36564, 0.1304347826087, 0.6195652173913, 0.27272727272727
36565, 0.1304347826087, 0.6195652173913, 0.31818181818182
36566, 0.1304347826087, 0.6195652173913, 0.36363636363636
36567, 0.1304347826087, 0.6195652173913, 0.40909090909091
36568, 0.1304347826087, 0.6195652173913, 0.45454545454545
36569, 0.08695652173913, 0.6195652173913, 0.045454545454545
36570, 0.08695652173913, 0.6195652173913, 0.090909090909091
36571, 0.08695652173913, 0.6195652173913, 0.13636363636364
36572, 0.08695652173913, 0.6195652173913, 0.18181818181818
36573, 0.08695652173913, 0.6195652173913, 0.22727272727273
36574, 0.08695652173913, 0.6195652173913, 0.27272727272727
36575, 0.08695652173913, 0.6195652173913, 0.31818181818182
36576, 0.08695652173913, 0.6195652173913, 0.36363636363636
36577, 0.08695652173913, 0.6195652173913, 0.40909090909091
36578, 0.08695652173913, 0.6195652173913, 0.45454545454545
36579, 0.043478260869565, 0.6195652173913, 0.045454545454545
36580, 0.043478260869565, 0.6195652173913, 0.090909090909091
36581, 0.043478260869565, 0.6195652173913, 0.13636363636364
36582, 0.043478260869565, 0.6195652173913, 0.18181818181818
36583, 0.043478260869565, 0.6195652173913, 0.22727272727273
36584, 0.043478260869565, 0.6195652173913, 0.27272727272727
36585, 0.043478260869565, 0.6195652173913, 0.31818181818182
36586, 0.043478260869565, 0.6195652173913, 0.36363636363636
36587, 0.043478260869565, 0.6195652173913, 0.40909090909091
36588, 0.043478260869565, 0.6195652173913, 0.45454545454545
36589, 0.95652173913043, 0.67173913043478, 0.045454545454545
36590, 0.95652173913043, 0.67173913043478, 0.090909090909091
36591, 0.95652173913044, 0.67173913043478, 0.13636363636364
36592, 0.95652173913043, 0.67173913043478, 0.18181818181818
36593, 0.95652173913044, 0.67173913043478, 0.22727272727273
36594, 0.95652173913044, 0.67173913043478, 0.27272727272727
36595, 0.95652173913044, 0.67173913043478, 0.31818181818182
36596, 0.95652173913043, 0.67173913043478, 0.36363636363636
36597, 0.95652173913043, 0.67173913043478, 0.40909090909091
36598, 0.95652173913044, 0.67173913043478, 0.45454545454545
36599, 0.91304347826087, 0.67173913043478, 0.045454545454545
36600, 0.91304347826087, 0.67173913043478, 0.090909090909091
36601, 0.91304347826087, 0.67173913043478, 0.13636363636364
36602, 0.91304347826087, 0.67173913043478, 0.18181818181818
36603, 0.91304347826087, 0.67173913043478, 0.22727272727273
36604, 0.91304347826087, 0.67173913043478, 0.27272727272727
36605, 0.91304347826087, 0.67173913043478, 0.31818181818182
36606, 0.91304347826087, 0.67173913043478, 0.36363636363636
36607, 0.91304347826087, 0.67173913043478, 0.40909090909091
36608, 0.91304347826087, 0.67173913043478, 0.45454545454545
36609, 0.8695652173913, 0.67173913043478, 0.045454545454545
36610, 0.8695652173913, 0.67173913043478, 0.090909090909091
36611, 0.8695652173913, 0.67173913043478, 0.13636363636364
36612, 0.8695652173913, 0.67173913043478, 0.18181818181818
36613, 0.8695652173913, 0.67173913043478, 0.22727272727273
36614, 0.8695652173913, 0.67173913043478, 0.27272727272727
36615, 0.8695652173913, 0.67173913043478, 0.31818181818182
36616, 0.8695652173913, 0.67173913043478, 0.36363636363636
36617, 0.8695652173913, 0.67173913043478, 0.40909090909091
36618, 0.8695652173913, 0.67173913043478, 0.45454545454545
36619, 0.82608695652174, 0.67173913043478, 0.045454545454545
36620, 0.82608695652174, 0.67173913043478, 0.090909090909091
36621, 0.82608695652174, 0.67173913043478, 0.13636363636364
36622, 0.82608695652174, 0.67173913043478, 0.18181818181818
36623, 0.82608695652174, 0.67173913043478, 0.22727272727273
36624, 0.82608695652174, 0.67173913043478, 0.27272727272727
36625, 0.82608695652174, 0.67173913043478, 0.31818181818182
36626, 0.82608695652174, 0.67173913043478, 0.36363636363636
36627, 0.82608695652174, 0.67173913043478, 0.40909090909091
36628, 0.82608695652174, 0.67173913043478, 0.45454545454545
36629, 0.78260869565217, 0.67173913043478, 0.045454545454545
36630, 0.78260869565217, 0.67173913043478, 0.090909090909091
36631, 0.78260869565217, 0.67173913043478, 0.13636363636364
36632, 0.78260869565217, 0.67173913043478, 0.18181818181818
36633, 0.78260869565217, 0.67173913043478, 0.22727272727273
36634, 0.78260869565217, 0.67173913043478, 0.27272727272727
36635, 0.78260869565217, 0.67173913043478, 0.31818181818182
36636, 0.78260869565217, 0.67173913043478, 0.36363636363636
36637, 0.78260869565217, 0.67173913043478, 0.40909090909091
36638, 0.78260869565217, 0.67173913043478, 0.45454545454545
36639, 0.73913043478261, 0.67173913043478, 0.045454545454545
36640, 0.73913043478261, 0.67173913043478, 0.090909090909091
36641, 0.73913043478261, 0.67173913043478, 0.13636363636364
36642, 0.73913043478261, 0.67173913043478, 0.18181818181818
36643, 0.73913043478261, 0.67173913043478, 0.22727272727273
36644, 0.73913043478261, 0.67173913043478, 0.27272727272727
36645, 0.73913043478261, 0.67173913043478, 0.31818181818182
36646, 0.73913043478261, 0.67173913043478, 0.36363636363636
36647, 0.73913043478261, 0.67173913043478, 0.40909090909091
36648, 0.73913043478261, 0.67173913043478, 0.45454545454545
36649, 0.69565217391304, 0.67173913043478, 0.045454545454545
36650, 0.69565217391304, 0.67173913043478, 0.090909090909091
36651, 0.69565217391304, 0.67173913043478, 0.13636363636364
36652, 0.69565217391304, 0.67173913043478, 0.18181818181818
36653, 0.69565217391304, 0.67173913043478, 0.22727272727273
36654, 0.69565217391304, 0.67173913043478, 0.27272727272727
36655, 0.69565217391304, 0.67173913043478, 0.31818181818182
36656, 0.69565217391304, 0.67173913043478, 0.36363636363636
36657, 0.69565217391304, 0.67173913043478, 0.40909090909091
36658, 0.69565217391304, 0.67173913043478, 0.45454545454545
36659, 0.65217391304348, 0.67173913043478, 0.045454545454545
36660, 0.65217391304348, 0.67173913043478, 0.090909090909091
36661, 0.65217391304348, 0.67173913043478, 0.13636363636364
36662, 0.65217391304348, 0.67173913043478, 0.18181818181818
36663, 0.65217391304348, 0.67173913043478, 0.22727272727273
36664, 0.65217391304348, 0.67173913043478, 0.27272727272727
36665, 0.65217391304348, 0.67173913043478, 0.31818181818182
36666, 0.65217391304348, 0.67173913043478, 0.36363636363636
36667, 0.65217391304348, 0.67173913043478, 0.40909090909091
36668, 0.65217391304348, 0.67173913043478, 0.45454545454545
36669, 0.60869565217391, 0.67173913043478, 0.045454545454545
36670, 0.60869565217391, 0.67173913043478, 0.090909090909091
36671, 0.60869565217391, 0.67173913043478, 0.13636363636364
36672, 0.60869565217391, 0.67173913043478, 0.18181818181818
36673, 0.60869565217391, 0.67173913043478, 0.22727272727273
36674, 0.60869565217391, 0.67173913043478, 0.27272727272727
36675, 0.60869565217391, 0.67173913043478, 0.31818181818182
36676, 0.60869565217391, 0.67173913043478, 0.36363636363636
36677, 0.60869565217391, 0.67173913043478, 0.40909090909091
36678, 0.60869565217391, 0.67173913043478, 0.45454545454545
36679, 0.56521739130435, 0.67173913043478, 0.045454545454545
36680, 0.56521739130435, 0.67173913043478, 0.090909090909091
36681, 0.56521739130435, 0.67173913043478, 0.13636363636364
36682, 0.56521739130435, 0.67173913043478, 0.18181818181818
36683, 0.56521739130435, 0.67173913043478, 0.22727272727273
36684, 0.56521739130435, 0.67173913043478, 0.27272727272727
36685, 0.56521739130435, 0.67173913043478, 0.31818181818182
36686, 0.56521739130435, 0.67173913043478, 0.36363636363636
36687, 0.56521739130435, 0.67173913043478, 0.40909090909091
36688, 0.56521739130435, 0.67173913043478, 0.45454545454545
36689, 0.52173913043478, 0.67173913043478, 0.045454545454545
36690, 0.52173913043478, 0.67173913043478, 0.090909090909091
36691, 0.52173913043478, 0.67173913043478, 0.13636363636364
36692, 0.52173913043478, 0.67173913043478, 0.18181818181818
36693, 0.52173913043478, 0.67173913043478, 0.22727272727273
36694, 0.52173913043478, 0.67173913043478, 0.27272727272727
36695, 0.52173913043478, 0.67173913043478, 0.31818181818182
36696, 0.52173913043478, 0.67173913043478, 0.36363636363636
36697, 0.52173913043478, 0.67173913043478, 0.40909090909091
36698, 0.52173913043478, 0.67173913043478, 0.45454545454545
36699, 0.47826086956522, 0.67173913043478, 0.045454545454545
36700, 0.47826086956522, 0.67173913043478, 0.090909090909091
36701, 0.47826086956522, 0.67173913043478, 0.13636363636364
36702, 0.47826086956522, 0.67173913043478, 0.18181818181818
36703, 0.47826086956522, 0.67173913043478, 0.22727272727273
36704, 0.47826086956522, 0.67173913043478, 0.27272727272727
36705, 0.47826086956522, 0.67173913043478, 0.31818181818182
36706, 0.47826086956522, 0.67173913043478, 0.36363636363636
36707, 0.47826086956522, 0.67173913043478, 0.40909090909091
36708, 0.47826086956522, 0.67173913043478, 0.45454545454545
36709, 0.43478260869565, 0.67173913043478, 0.045454545454545
36710, 0.43478260869565, 0.67173913043478, 0.090909090909091
36711, 0.43478260869565, 0.67173913043478, 0.13636363636364
36712, 0.43478260869565, 0.67173913043478, 0.18181818181818
36713, 0.43478260869565, 0.67173913043478, 0.22727272727273
36714, 0.43478260869565, 0.67173913043478, 0.27272727272727
36715, 0.43478260869565, 0.67173913043478, 0.31818181818182
36716, 0.43478260869565, 0.67173913043478, 0.36363636363636
36717, 0.43478260869565, 0.67173913043478, 0.40909090909091
36718, 0.43478260869565, 0.67173913043478, 0.45454545454545
36719, 0.39130434782609, 0.67173913043478, 0.045454545454545
36720, 0.39130434782609, 0.67173913043478, 0.090909090909091
36721, 0.39130434782609, 0.67173913043478, 0.13636363636364
36722, 0.39130434782609, 0.67173913043478, 0.18181818181818
36723, 0.39130434782609, 0.67173913043478, 0.22727272727273
36724, 0.39130434782609, 0.67173913043478, 0.27272727272727
36725, 0.39130434782609, 0.67173913043478, 0.31818181818182
36726, 0.39130434782609, 0.67173913043478, 0.36363636363636
36727, 0.39130434782609, 0.67173913043478, 0.40909090909091
36728, 0.39130434782609, 0.67173913043478, 0.45454545454545
36729, 0.34782608695652, 0.67173913043478, 0.045454545454545
36730, 0.34782608695652, 0.67173913043478, 0.090909090909091
36731, 0.34782608695652, 0.67173913043478, 0.13636363636364
36732, 0.34782608695652, 0.67173913043478, 0.18181818181818
36733, 0.34782608695652, 0.67173913043478, 0.22727272727273
36734, 0.34782608695652, 0.67173913043478, 0.27272727272727
36735, 0.34782608695652, 0.67173913043478, 0.31818181818182
36736, 0.34782608695652, 0.67173913043478, 0.36363636363636
36737, 0.34782608695652, 0.67173913043478, 0.40909090909091
36738, 0.34782608695652, 0.67173913043478, 0.45454545454545
36739, 0.30434782608696, 0.67173913043478, 0.045454545454545
36740, 0.30434782608696, 0.67173913043478, 0.090909090909091
36741, 0.30434782608696, 0.67173913043478, 0.13636363636364
36742, 0.30434782608696, 0.67173913043478, 0.18181818181818
36743, 0.30434782608696, 0.67173913043478, 0.22727272727273
36744, 0.30434782608696, 0.67173913043478, 0.27272727272727
36745, 0.30434782608696, 0.67173913043478, 0.31818181818182
36746, 0.30434782608696, 0.67173913043478, 0.36363636363636
36747, 0.30434782608696, 0.67173913043478, 0.40909090909091
36748, 0.30434782608696, 0.67173913043478, 0.45454545454545
36749, 0.26086956521739, 0.67173913043478, 0.045454545454545
36750, 0.26086956521739, 0.67173913043478, 0.090909090909091
36751, 0.26086956521739, 0.67173913043478, 0.13636363636364
36752, 0.26086956521739, 0.67173913043478, 0.18181818181818
36753, 0.26086956521739, 0.67173913043478, 0.22727272727273
36754, 0.26086956521739, 0.67173913043478, 0.27272727272727
36755, 0.26086956521739, 0.67173913043478, 0.31818181818182
36756, 0.26086956521739, 0.67173913043478, 0.36363636363636
36757, 0.26086956521739, 0.67173913043478, 0.40909090909091
36758, 0.26086956521739, 0.67173913043478, 0.45454545454545
36759, 0.21739130434783, 0.67173913043478, 0.045454545454545
36760, 0.21739130434783, 0.67173913043478, 0.090909090909091
36761, 0.21739130434783, 0.67173913043478, 0.13636363636364
36762, 0.21739130434783, 0.67173913043478, 0.18181818181818
36763, 0.21739130434783, 0.67173913043478, 0.22727272727273
36764, 0.21739130434783, 0.67173913043478, 0.27272727272727
36765, 0.21739130434783, 0.67173913043478, 0.31818181818182
36766, 0.21739130434783, 0.67173913043478, 0.36363636363636
36767, 0.21739130434783, 0.67173913043478, 0.40909090909091
36768, 0.21739130434783, 0.67173913043478, 0.45454545454545
36769, 0.17391304347826, 0.67173913043478, 0.045454545454545
36770, 0.17391304347826, 0.67173913043478, 0.090909090909091
36771, 0.17391304347826, 0.67173913043478, 0.13636363636364
36772, 0.17391304347826, 0.67173913043478, 0.18181818181818
36773, 0.17391304347826, 0.67173913043478, 0.22727272727273
36774, 0.17391304347826, 0.67173913043478, 0.27272727272727
36775, 0.17391304347826, 0.67173913043478, 0.31818181818182
36776, 0.17391304347826, 0.67173913043478, 0.36363636363636
36777, 0.17391304347826, 0.67173913043478, 0.40909090909091
36778, 0.17391304347826, 0.67173913043478, 0.45454545454545
36779, 0.1304347826087, 0.67173913043478, 0.045454545454545
36780, 0.1304347826087, 0.67173913043478, 0.090909090909091
36781, 0.1304347826087, 0.67173913043478, 0.13636363636364
36782, 0.1304347826087, 0.67173913043478, 0.18181818181818
36783, 0.1304347826087, 0.67173913043478, 0.22727272727273
36784, 0.1304347826087, 0.67173913043478, 0.27272727272727
36785, 0.1304347826087, 0.67173913043478, 0.31818181818182
36786, 0.1304347826087, 0.67173913043478, 0.36363636363636
36787, 0.1304347826087, 0.67173913043478, 0.40909090909091
36788, 0.1304347826087, 0.67173913043478, 0.45454545454545
36789, 0.08695652173913, 0.67173913043478, 0.045454545454545
36790, 0.08695652173913, 0.67173913043478, 0.090909090909091
36791, 0.08695652173913, 0.67173913043478, 0.13636363636364
36792, 0.08695652173913, 0.67173913043478, 0.18181818181818
36793, 0.08695652173913, 0.67173913043478, 0.22727272727273
36794, 0.08695652173913, 0.67173913043478, 0.27272727272727
36795, 0.08695652173913, 0.67173913043478, 0.31818181818182
36796, 0.08695652173913, 0.67173913043478, 0.36363636363636
36797, 0.08695652173913, 0.67173913043478, 0.40909090909091
36798, 0.08695652173913, 0.67173913043478, 0.45454545454545
36799, 0.043478260869565, 0.67173913043478, 0.045454545454545
36800, 0.043478260869565, 0.67173913043478, 0.090909090909091
36801, 0.043478260869565, 0.67173913043478, 0.13636363636364
36802, 0.043478260869565, 0.67173913043478, 0.18181818181818
36803, 0.043478260869565, 0.67173913043478, 0.22727272727273
36804, 0.043478260869565, 0.67173913043478, 0.27272727272727
36805, 0.043478260869565, 0.67173913043478, 0.31818181818182
36806, 0.043478260869565, 0.67173913043478, 0.36363636363636
36807, 0.043478260869565, 0.67173913043478, 0.40909090909091
36808, 0.043478260869565, 0.67173913043478, 0.45454545454545
36809, 0.95652173913043, 0.72391304347826, 0.045454545454545
36810, 0.95652173913043, 0.72391304347826, 0.090909090909091
36811, 0.95652173913044, 0.72391304347826, 0.13636363636364
36812, 0.95652173913044, 0.72391304347826, 0.18181818181818
36813, 0.95652173913043, 0.72391304347826, 0.22727272727273
36814, 0.95652173913044, 0.72391304347826, 0.27272727272727
36815, 0.95652173913044, 0.72391304347826, 0.31818181818182
36816, 0.95652173913043, 0.72391304347826, 0.36363636363636
36817, 0.95652173913043, 0.72391304347826, 0.40909090909091
36818, 0.95652173913043, 0.72391304347826, 0.45454545454545
36819, 0.91304347826087, 0.72391304347826, 0.045454545454545
36820, 0.91304347826087, 0.72391304347826, 0.090909090909091
36821, 0.91304347826087, 0.72391304347826, 0.13636363636364
36822, 0.91304347826087, 0.72391304347826, 0.18181818181818
36823, 0.91304347826087, 0.72391304347826, 0.22727272727273
36824, 0.91304347826087, 0.72391304347826, 0.27272727272727
36825, 0.91304347826087, 0.72391304347826, 0.31818181818182
36826, 0.91304347826087, 0.72391304347826, 0.36363636363636
36827, 0.91304347826087, 0.72391304347826, 0.40909090909091
36828, 0.91304347826087, 0.72391304347826, 0.45454545454545
36829, 0.8695652173913, 0.72391304347826, 0.045454545454545
36830, 0.8695652173913, 0.72391304347826, 0.090909090909091
36831, 0.8695652173913, 0.72391304347826, 0.13636363636364
36832, 0.8695652173913, 0.72391304347826, 0.18181818181818
36833, 0.8695652173913, 0.72391304347826, 0.22727272727273
36834, 0.8695652173913, 0.72391304347826, 0.27272727272727
36835, 0.8695652173913, 0.72391304347826, 0.31818181818182
36836, 0.8695652173913, 0.72391304347826, 0.36363636363636
36837, 0.8695652173913, 0.72391304347826, 0.40909090909091
36838, 0.8695652173913, 0.72391304347826, 0.45454545454545
36839, 0.82608695652174, 0.72391304347826, 0.045454545454545
36840, 0.82608695652174, 0.72391304347826, 0.090909090909091
36841, 0.82608695652174, 0.72391304347826, 0.13636363636364
36842, 0.82608695652174, 0.72391304347826, 0.18181818181818
36843, 0.82608695652174, 0.72391304347826, 0.22727272727273
36844, 0.82608695652174, 0.72391304347826, 0.27272727272727
36845, 0.82608695652174, 0.72391304347826, 0.31818181818182
36846, 0.82608695652174, 0.72391304347826, 0.36363636363636
36847, 0.82608695652174, 0.72391304347826, 0.40909090909091
36848, 0.82608695652174, 0.72391304347826, 0.45454545454545
36849, 0.78260869565217, 0.72391304347826, 0.045454545454545
36850, 0.78260869565217, 0.72391304347826, 0.090909090909091
36851, 0.78260869565217, 0.72391304347826, 0.13636363636364
36852, 0.78260869565217, 0.72391304347826, 0.18181818181818
36853, 0.78260869565217, 0.72391304347826, 0.22727272727273
36854, 0.78260869565217, 0.72391304347826, 0.27272727272727
36855, 0.78260869565217, 0.72391304347826, 0.31818181818182
36856, 0.78260869565217, 0.72391304347826, 0.36363636363636
36857, 0.78260869565217, 0.72391304347826, 0.40909090909091
36858, 0.78260869565217, 0.72391304347826, 0.45454545454545
36859, 0.73913043478261, 0.72391304347826, 0.045454545454545
36860, 0.73913043478261, 0.72391304347826, 0.090909090909091
36861, 0.73913043478261, 0.72391304347826, 0.13636363636364
36862, 0.73913043478261, 0.72391304347826, 0.18181818181818
36863, 0.73913043478261, 0.72391304347826, 0.22727272727273
36864, 0.73913043478261, 0.72391304347826, 0.27272727272727
36865, 0.73913043478261, 0.72391304347826, 0.31818181818182
36866, 0.73913043478261, 0.72391304347826, 0.36363636363636
36867, 0.73913043478261, 0.72391304347826, 0.40909090909091
36868, 0.73913043478261, 0.72391304347826, 0.45454545454545
36869, 0.69565217391304, 0.72391304347826, 0.045454545454545
36870, 0.69565217391304, 0.72391304347826, 0.090909090909091
36871, 0.69565217391304, 0.72391304347826, 0.13636363636364
36872, 0.69565217391304, 0.72391304347826, 0.18181818181818
36873, 0.69565217391304, 0.72391304347826, 0.22727272727273
36874, 0.69565217391304, 0.72391304347826, 0.27272727272727
36875, 0.69565217391304, 0.72391304347826, 0.31818181818182
36876, 0.69565217391304, 0.72391304347826, 0.36363636363636
36877, 0.69565217391304, 0.72391304347826, 0.40909090909091
36878, 0.69565217391304, 0.72391304347826, 0.45454545454545
36879, 0.65217391304348, 0.72391304347826, 0.045454545454545
36880, 0.65217391304348, 0.72391304347826, 0.090909090909091
36881, 0.65217391304348, 0.72391304347826, 0.13636363636364
36882, 0.65217391304348, 0.72391304347826, 0.18181818181818
36883, 0.65217391304348, 0.72391304347826, 0.22727272727273
36884, 0.65217391304348, 0.72391304347826, 0.27272727272727
36885, 0.65217391304348, 0.72391304347826, 0.31818181818182
36886, 0.65217391304348, 0.72391304347826, 0.36363636363636
36887, 0.65217391304348, 0.72391304347826, 0.40909090909091
36888, 0.65217391304348, 0.72391304347826, 0.45454545454545
36889, 0.60869565217391, 0.72391304347826, 0.045454545454545
36890, 0.60869565217391, 0.72391304347826, 0.090909090909091
36891, 0.60869565217391, 0.72391304347826, 0.13636363636364
36892, 0.60869565217391, 0.72391304347826, 0.18181818181818
36893, 0.60869565217391, 0.72391304347826, 0.22727272727273
36894, 0.60869565217391, 0.72391304347826, 0.27272727272727
36895, 0.60869565217391, 0.72391304347826, 0.31818181818182
36896, 0.60869565217391, 0.72391304347826, 0.36363636363636
36897, 0.60869565217391, 0.72391304347826, 0.40909090909091
36898, 0.60869565217391, 0.72391304347826, 0.45454545454545
36899, 0.56521739130435, 0.72391304347826, 0.045454545454545
36900, 0.56521739130435, 0.72391304347826, 0.090909090909091
36901, 0.56521739130435, 0.72391304347826, 0.13636363636364
36902, 0.56521739130435, 0.72391304347826, 0.18181818181818
36903, 0.56521739130435, 0.72391304347826, 0.22727272727273
36904, 0.56521739130435, 0.72391304347826, 0.27272727272727
36905, 0.56521739130435, 0.72391304347826, 0.31818181818182
36906, 0.56521739130435, 0.72391304347826, 0.36363636363636
36907, 0.56521739130435, 0.72391304347826, 0.40909090909091
36908, 0.56521739130435, 0.72391304347826, 0.45454545454545
36909, 0.52173913043478, 0.72391304347826, 0.045454545454545
36910, 0.52173913043478, 0.72391304347826, 0.090909090909091
36911, 0.52173913043478, 0.72391304347826, 0.13636363636364
36912, 0.52173913043478, 0.72391304347826, 0.18181818181818
36913, 0.52173913043478, 0.72391304347826, 0.22727272727273
36914, 0.52173913043478, 0.72391304347826, 0.27272727272727
36915, 0.52173913043478, 0.72391304347826, 0.31818181818182
36916, 0.52173913043478, 0.72391304347826, 0.36363636363636
36917, 0.52173913043478, 0.72391304347826, 0.40909090909091
36918, 0.52173913043478, 0.72391304347826, 0.45454545454545
36919, 0.47826086956522, 0.72391304347826, 0.045454545454545
36920, 0.47826086956522, 0.72391304347826, 0.090909090909091
36921, 0.47826086956522, 0.72391304347826, 0.13636363636364
36922, 0.47826086956522, 0.72391304347826, 0.18181818181818
36923, 0.47826086956522, 0.72391304347826, 0.22727272727273
36924, 0.47826086956522, 0.72391304347826, 0.27272727272727
36925, 0.47826086956522, 0.72391304347826, 0.31818181818182
36926, 0.47826086956522, 0.72391304347826, 0.36363636363636
36927, 0.47826086956522, 0.72391304347826, 0.40909090909091
36928, 0.47826086956522, 0.72391304347826, 0.45454545454545
36929, 0.43478260869565, 0.72391304347826, 0.045454545454545
36930, 0.43478260869565, 0.72391304347826, 0.090909090909091
36931, 0.43478260869565, 0.72391304347826, 0.13636363636364
36932, 0.43478260869565, 0.72391304347826, 0.18181818181818
36933, 0.43478260869565, 0.72391304347826, 0.22727272727273
36934, 0.43478260869565, 0.72391304347826, 0.27272727272727
36935, 0.43478260869565, 0.72391304347826, 0.31818181818182
36936, 0.43478260869565, 0.72391304347826, 0.36363636363636
36937, 0.43478260869565, 0.72391304347826, 0.40909090909091
36938, 0.43478260869565, 0.72391304347826, 0.45454545454545
36939, 0.39130434782609, 0.72391304347826, 0.045454545454545
36940, 0.39130434782609, 0.72391304347826, 0.090909090909091
36941, 0.39130434782609, 0.72391304347826, 0.13636363636364
36942, 0.39130434782609, 0.72391304347826, 0.18181818181818
36943, 0.39130434782609, 0.72391304347826, 0.22727272727273
36944, 0.39130434782609, 0.72391304347826, 0.27272727272727
36945, 0.39130434782609, 0.72391304347826, 0.31818181818182
36946, 0.39130434782609, 0.72391304347826, 0.36363636363636
36947, 0.39130434782609, 0.72391304347826, 0.40909090909091
36948, 0.39130434782609, 0.72391304347826, 0.45454545454545
36949, 0.34782608695652, 0.72391304347826, 0.045454545454545
36950, 0.34782608695652, 0.72391304347826, 0.090909090909091
36951, 0.34782608695652, 0.72391304347826, 0.13636363636364
36952, 0.34782608695652, 0.72391304347826, 0.18181818181818
36953, 0.34782608695652, 0.72391304347826, 0.22727272727273
36954, 0.34782608695652, 0.72391304347826, 0.27272727272727
36955, 0.34782608695652, 0.72391304347826, 0.31818181818182
36956, 0.34782608695652, 0.72391304347826, 0.36363636363636
36957, 0.34782608695652, 0.72391304347826, 0.40909090909091
36958, 0.34782608695652, 0.72391304347826, 0.45454545454545
36959, 0.30434782608696, 0.72391304347826, 0.045454545454545
36960, 0.30434782608696, 0.72391304347826, 0.090909090909091
36961, 0.30434782608696, 0.72391304347826, 0.13636363636364
36962, 0.30434782608696, 0.72391304347826, 0.18181818181818
36963, 0.30434782608696, 0.72391304347826, 0.22727272727273
36964, 0.30434782608696, 0.72391304347826, 0.27272727272727
36965, 0.30434782608696, 0.72391304347826, 0.31818181818182
36966, 0.30434782608696, 0.72391304347826, 0.36363636363636
36967, 0.30434782608696, 0.72391304347826, 0.40909090909091
36968, 0.30434782608696, 0.72391304347826, 0.45454545454545
36969, 0.26086956521739, 0.72391304347826, 0.045454545454545
36970, 0.26086956521739, 0.72391304347826, 0.090909090909091
36971, 0.26086956521739, 0.72391304347826, 0.13636363636364
36972, 0.26086956521739, 0.72391304347826, 0.18181818181818
36973, 0.26086956521739, 0.72391304347826, 0.22727272727273
36974, 0.26086956521739, 0.72391304347826, 0.27272727272727
36975, 0.26086956521739, 0.72391304347826, 0.31818181818182
36976, 0.26086956521739, 0.72391304347826, 0.36363636363636
36977, 0.26086956521739, 0.72391304347826, 0.40909090909091
36978, 0.26086956521739, 0.72391304347826, 0.45454545454545
36979, 0.21739130434783, 0.72391304347826, 0.045454545454545
36980, 0.21739130434783, 0.72391304347826, 0.090909090909091
36981, 0.21739130434783, 0.72391304347826, 0.13636363636364
36982, 0.21739130434783, 0.72391304347826, 0.18181818181818
36983, 0.21739130434783, 0.72391304347826, 0.22727272727273
36984, 0.21739130434783, 0.72391304347826, 0.27272727272727
36985, 0.21739130434783, 0.72391304347826, 0.31818181818182
36986, 0.21739130434783, 0.72391304347826, 0.36363636363636
36987, 0.21739130434783, 0.72391304347826, 0.40909090909091
36988, 0.21739130434783, 0.72391304347826, 0.45454545454545
36989, 0.17391304347826, 0.72391304347826, 0.045454545454545
36990, 0.17391304347826, 0.72391304347826, 0.090909090909091
36991, 0.17391304347826, 0.72391304347826, 0.13636363636364
36992, 0.17391304347826, 0.72391304347826, 0.18181818181818
36993, 0.17391304347826, 0.72391304347826, 0.22727272727273
36994, 0.17391304347826, 0.72391304347826, 0.27272727272727
36995, 0.17391304347826, 0.72391304347826, 0.31818181818182
36996, 0.17391304347826, 0.72391304347826, 0.36363636363636
36997, 0.17391304347826, 0.72391304347826, 0.40909090909091
36998, 0.17391304347826, 0.72391304347826, 0.45454545454545
36999, 0.1304347826087, 0.72391304347826, 0.045454545454545
37000, 0.1304347826087, 0.72391304347826, 0.090909090909091
37001, 0.1304347826087, 0.72391304347826, 0.13636363636364
37002, 0.1304347826087, 0.72391304347826, 0.18181818181818
37003, 0.1304347826087, 0.72391304347826, 0.22727272727273
37004, 0.1304347826087, 0.72391304347826, 0.27272727272727
37005, 0.1304347826087, 0.72391304347826, 0.31818181818182
37006, 0.1304347826087, 0.72391304347826, 0.36363636363636
37007, 0.1304347826087, 0.72391304347826, 0.40909090909091
37008, 0.1304347826087, 0.72391304347826, 0.45454545454545
37009, 0.08695652173913, 0.72391304347826, 0.045454545454545
37010, 0.08695652173913, 0.72391304347826, 0.090909090909091
37011, 0.08695652173913, 0.72391304347826, 0.13636363636364
37012, 0.08695652173913, 0.72391304347826, 0.18181818181818
37013, 0.08695652173913, 0.72391304347826, 0.22727272727273
37014, 0.08695652173913, 0.72391304347826, 0.27272727272727
37015, 0.08695652173913, 0.72391304347826, 0.31818181818182
37016, 0.08695652173913, 0.72391304347826, 0.36363636363636
37017, 0.08695652173913, 0.72391304347826, 0.40909090909091
37018, 0.08695652173913, 0.72391304347826, 0.45454545454545
37019, 0.043478260869565, 0.72391304347826, 0.045454545454545
37020, 0.043478260869565, 0.72391304347826, 0.090909090909091
37021, 0.043478260869565, 0.72391304347826, 0.13636363636364
37022, 0.043478260869565, 0.72391304347826, 0.18181818181818
37023, 0.043478260869565, 0.72391304347826, 0.22727272727273
37024, 0.043478260869565, 0.72391304347826, 0.27272727272727
37025, 0.043478260869565, 0.72391304347826, 0.31818181818182
37026, 0.043478260869565, 0.72391304347826, 0.36363636363636
37027, 0.043478260869565, 0.72391304347826, 0.40909090909091
37028, 0.043478260869565, 0.72391304347826, 0.45454545454545
37029, 0.95652173913043, 0.77608695652174, 0.045454545454545
37030, 0.95652173913043, 0.77608695652174, 0.090909090909091
37031, 0.95652173913044, 0.77608695652174, 0.13636363636364
37032, 0.95652173913044, 0.77608695652174, 0.18181818181818
37033, 0.95652173913044, 0.77608695652174, 0.22727272727273
37034, 0.95652173913044, 0.77608695652174, 0.27272727272727
37035, 0.95652173913044, 0.77608695652174, 0.31818181818182
37036, 0.95652173913043, 0.77608695652174, 0.36363636363636
37037, 0.95652173913043, 0.77608695652174, 0.40909090909091
37038, 0.95652173913044, 0.77608695652174, 0.45454545454545
37039, 0.91304347826087, 0.77608695652174, 0.045454545454545
37040, 0.91304347826087, 0.77608695652174, 0.090909090909091
37041, 0.91304347826087, 0.77608695652174, 0.13636363636364
37042, 0.91304347826087, 0.77608695652174, 0.18181818181818
37043, 0.91304347826087, 0.77608695652174, 0.22727272727273
37044, 0.91304347826087, 0.77608695652174, 0.27272727272727
37045, 0.91304347826087, 0.77608695652174, 0.31818181818182
37046, 0.91304347826087, 0.77608695652174, 0.36363636363636
37047, 0.91304347826087, 0.77608695652174, 0.40909090909091
37048, 0.91304347826087, 0.77608695652174, 0.45454545454545
37049, 0.8695652173913, 0.77608695652174, 0.045454545454545
37050, 0.8695652173913, 0.77608695652174, 0.090909090909091
37051, 0.8695652173913, 0.77608695652174, 0.13636363636364
37052, 0.8695652173913, 0.77608695652174, 0.18181818181818
37053, 0.8695652173913, 0.77608695652174, 0.22727272727273
37054, 0.8695652173913, 0.77608695652174, 0.27272727272727
37055, 0.8695652173913, 0.77608695652174, 0.31818181818182
37056, 0.8695652173913, 0.77608695652174, 0.36363636363636
37057, 0.8695652173913, 0.77608695652174, 0.40909090909091
37058, 0.8695652173913, 0.77608695652174, 0.45454545454545
37059, 0.82608695652174, 0.77608695652174, 0.045454545454545
37060, 0.82608695652174, 0.77608695652174, 0.090909090909091
37061, 0.82608695652174, 0.77608695652174, 0.13636363636364
37062, 0.82608695652174, 0.77608695652174, 0.18181818181818
37063, 0.82608695652174, 0.77608695652174, 0.22727272727273
37064, 0.82608695652174, 0.77608695652174, 0.27272727272727
37065, 0.82608695652174, 0.77608695652174, 0.31818181818182
37066, 0.82608695652174, 0.77608695652174, 0.36363636363636
37067, 0.82608695652174, 0.77608695652174, 0.40909090909091
37068, 0.82608695652174, 0.77608695652174, 0.45454545454545
37069, 0.78260869565217, 0.77608695652174, 0.045454545454545
37070, 0.78260869565217, 0.77608695652174, 0.090909090909091
37071, 0.78260869565217, 0.77608695652174, 0.13636363636364
37072, 0.78260869565217, 0.77608695652174, 0.18181818181818
37073, 0.78260869565217, 0.77608695652174, 0.22727272727273
37074, 0.78260869565217, 0.77608695652174, 0.27272727272727
37075, 0.78260869565217, 0.77608695652174, 0.31818181818182
37076, 0.78260869565217, 0.77608695652174, 0.36363636363636
37077, 0.78260869565217, 0.77608695652174, 0.40909090909091
37078, 0.78260869565217, 0.77608695652174, 0.45454545454545
37079, 0.73913043478261, 0.77608695652174, 0.045454545454545
37080, 0.73913043478261, 0.77608695652174, 0.090909090909091
37081, 0.73913043478261, 0.77608695652174, 0.13636363636364
37082, 0.73913043478261, 0.77608695652174, 0.18181818181818
37083, 0.73913043478261, 0.77608695652174, 0.22727272727273
37084, 0.73913043478261, 0.77608695652174, 0.27272727272727
37085, 0.73913043478261, 0.77608695652174, 0.31818181818182
37086, 0.73913043478261, 0.77608695652174, 0.36363636363636
37087, 0.73913043478261, 0.77608695652174, 0.40909090909091
37088, 0.73913043478261, 0.77608695652174, 0.45454545454545
37089, 0.69565217391304, 0.77608695652174, 0.045454545454545
37090, 0.69565217391304, 0.77608695652174, 0.090909090909091
37091, 0.69565217391304, 0.77608695652174, 0.13636363636364
37092, 0.69565217391304, 0.77608695652174, 0.18181818181818
37093, 0.69565217391304, 0.77608695652174, 0.22727272727273
37094, 0.69565217391304, 0.77608695652174, 0.27272727272727
37095, 0.69565217391304, 0.77608695652174, 0.31818181818182
37096, 0.69565217391304, 0.77608695652174, 0.36363636363636
37097, 0.69565217391304, 0.77608695652174, 0.40909090909091
37098, 0.69565217391304, 0.77608695652174, 0.45454545454545
37099, 0.65217391304348, 0.77608695652174, 0.045454545454545
37100, 0.65217391304348, 0.77608695652174, 0.090909090909091
37101, 0.65217391304348, 0.77608695652174, 0.13636363636364
37102, 0.65217391304348, 0.77608695652174, 0.18181818181818
37103, 0.65217391304348, 0.77608695652174, 0.22727272727273
37104, 0.65217391304348, 0.77608695652174, 0.27272727272727
37105, 0.65217391304348, 0.77608695652174, 0.31818181818182
37106, 0.65217391304348, 0.77608695652174, 0.36363636363636
37107, 0.65217391304348, 0.77608695652174, 0.40909090909091
37108, 0.65217391304348, 0.77608695652174, 0.45454545454545
37109, 0.60869565217391, 0.77608695652174, 0.045454545454545
37110, 0.60869565217391, 0.77608695652174, 0.090909090909091
37111, 0.60869565217391, 0.77608695652174, 0.13636363636364
37112, 0.60869565217391, 0.77608695652174, 0.18181818181818
37113, 0.60869565217391, 0.77608695652174, 0.22727272727273
37114, 0.60869565217391, 0.77608695652174, 0.27272727272727
37115, 0.60869565217391, 0.77608695652174, 0.31818181818182
37116, 0.60869565217391, 0.77608695652174, 0.36363636363636
37117, 0.60869565217391, 0.77608695652174, 0.40909090909091
37118, 0.60869565217391, 0.77608695652174, 0.45454545454545
37119, 0.56521739130435, 0.77608695652174, 0.045454545454545
37120, 0.56521739130435, 0.77608695652174, 0.090909090909091
37121, 0.56521739130435, 0.77608695652174, 0.13636363636364
37122, 0.56521739130435, 0.77608695652174, 0.18181818181818
37123, 0.56521739130435, 0.77608695652174, 0.22727272727273
37124, 0.56521739130435, 0.77608695652174, 0.27272727272727
37125, 0.56521739130435, 0.77608695652174, 0.31818181818182
37126, 0.56521739130435, 0.77608695652174, 0.36363636363636
37127, 0.56521739130435, 0.77608695652174, 0.40909090909091
37128, 0.56521739130435, 0.77608695652174, 0.45454545454545
37129, 0.52173913043478, 0.77608695652174, 0.045454545454545
37130, 0.52173913043478, 0.77608695652174, 0.090909090909091
37131, 0.52173913043478, 0.77608695652174, 0.13636363636364
37132, 0.52173913043478, 0.77608695652174, 0.18181818181818
37133, 0.52173913043478, 0.77608695652174, 0.22727272727273
37134, 0.52173913043478, 0.77608695652174, 0.27272727272727
37135, 0.52173913043478, 0.77608695652174, 0.31818181818182
37136, 0.52173913043478, 0.77608695652174, 0.36363636363636
37137, 0.52173913043478, 0.77608695652174, 0.40909090909091
37138, 0.52173913043478, 0.77608695652174, 0.45454545454545
37139, 0.47826086956522, 0.77608695652174, 0.045454545454545
37140, 0.47826086956522, 0.77608695652174, 0.090909090909091
37141, 0.47826086956522, 0.77608695652174, 0.13636363636364
37142, 0.47826086956522, 0.77608695652174, 0.18181818181818
37143, 0.47826086956522, 0.77608695652174, 0.22727272727273
37144, 0.47826086956522, 0.77608695652174, 0.27272727272727
37145, 0.47826086956522, 0.77608695652174, 0.31818181818182
37146, 0.47826086956522, 0.77608695652174, 0.36363636363636
37147, 0.47826086956522, 0.77608695652174, 0.40909090909091
37148, 0.47826086956522, 0.77608695652174, 0.45454545454545
37149, 0.43478260869565, 0.77608695652174, 0.045454545454545
37150, 0.43478260869565, 0.77608695652174, 0.090909090909091
37151, 0.43478260869565, 0.77608695652174, 0.13636363636364
37152, 0.43478260869565, 0.77608695652174, 0.18181818181818
37153, 0.43478260869565, 0.77608695652174, 0.22727272727273
37154, 0.43478260869565, 0.77608695652174, 0.27272727272727
37155, 0.43478260869565, 0.77608695652174, 0.31818181818182
37156, 0.43478260869565, 0.77608695652174, 0.36363636363636
37157, 0.43478260869565, 0.77608695652174, 0.40909090909091
37158, 0.43478260869565, 0.77608695652174, 0.45454545454545
37159, 0.39130434782609, 0.77608695652174, 0.045454545454545
37160, 0.39130434782609, 0.77608695652174, 0.090909090909091
37161, 0.39130434782609, 0.77608695652174, 0.13636363636364
37162, 0.39130434782609, 0.77608695652174, 0.18181818181818
37163, 0.39130434782609, 0.77608695652174, 0.22727272727273
37164, 0.39130434782609, 0.77608695652174, 0.27272727272727
37165, 0.39130434782609, 0.77608695652174, 0.31818181818182
37166, 0.39130434782609, 0.77608695652174, 0.36363636363636
37167, 0.39130434782609, 0.77608695652174, 0.40909090909091
37168, 0.39130434782609, 0.77608695652174, 0.45454545454545
37169, 0.34782608695652, 0.77608695652174, 0.045454545454545
37170, 0.34782608695652, 0.77608695652174, 0.090909090909091
37171, 0.34782608695652, 0.77608695652174, 0.13636363636364
37172, 0.34782608695652, 0.77608695652174, 0.18181818181818
37173, 0.34782608695652, 0.77608695652174, 0.22727272727273
37174, 0.34782608695652, 0.77608695652174, 0.27272727272727
37175, 0.34782608695652, 0.77608695652174, 0.31818181818182
37176, 0.34782608695652, 0.77608695652174, 0.36363636363636
37177, 0.34782608695652, 0.77608695652174, 0.40909090909091
37178, 0.34782608695652, 0.77608695652174, 0.45454545454545
37179, 0.30434782608696, 0.77608695652174, 0.045454545454545
37180, 0.30434782608696, 0.77608695652174, 0.090909090909091
37181, 0.30434782608696, 0.77608695652174, 0.13636363636364
37182, 0.30434782608696, 0.77608695652174, 0.18181818181818
37183, 0.30434782608696, 0.77608695652174, 0.22727272727273
37184, 0.30434782608696, 0.77608695652174, 0.27272727272727
37185, 0.30434782608696, 0.77608695652174, 0.31818181818182
37186, 0.30434782608696, 0.77608695652174, 0.36363636363636
37187, 0.30434782608696, 0.77608695652174, 0.40909090909091
37188, 0.30434782608696, 0.77608695652174, 0.45454545454545
37189, 0.26086956521739, 0.77608695652174, 0.045454545454545
37190, 0.26086956521739, 0.77608695652174, 0.090909090909091
37191, 0.26086956521739, 0.77608695652174, 0.13636363636364
37192, 0.26086956521739, 0.77608695652174, 0.18181818181818
37193, 0.26086956521739, 0.77608695652174, 0.22727272727273
37194, 0.26086956521739, 0.77608695652174, 0.27272727272727
37195, 0.26086956521739, 0.77608695652174, 0.31818181818182
37196, 0.26086956521739, 0.77608695652174, 0.36363636363636
37197, 0.26086956521739, 0.77608695652174, 0.40909090909091
37198, 0.26086956521739, 0.77608695652174, 0.45454545454545
37199, 0.21739130434783, 0.77608695652174, 0.045454545454545
37200, 0.21739130434783, 0.77608695652174, 0.090909090909091
37201, 0.21739130434783, 0.77608695652174, 0.13636363636364
37202, 0.21739130434783, 0.77608695652174, 0.18181818181818
37203, 0.21739130434783, 0.77608695652174, 0.22727272727273
37204, 0.21739130434783, 0.77608695652174, 0.27272727272727
37205, 0.21739130434783, 0.77608695652174, 0.31818181818182
37206, 0.21739130434783, 0.77608695652174, 0.36363636363636
37207, 0.21739130434783, 0.77608695652174, 0.40909090909091
37208, 0.21739130434783, 0.77608695652174, 0.45454545454545
37209, 0.17391304347826, 0.77608695652174, 0.045454545454545
37210, 0.17391304347826, 0.77608695652174, 0.090909090909091
37211, 0.17391304347826, 0.77608695652174, 0.13636363636364
37212, 0.17391304347826, 0.77608695652174, 0.18181818181818
37213, 0.17391304347826, 0.77608695652174, 0.22727272727273
37214, 0.17391304347826, 0.77608695652174, 0.27272727272727
37215, 0.17391304347826, 0.77608695652174, 0.31818181818182
37216, 0.17391304347826, 0.77608695652174, 0.36363636363636
37217, 0.17391304347826, 0.77608695652174, 0.40909090909091
37218, 0.17391304347826, 0.77608695652174, 0.45454545454545
37219, 0.1304347826087, 0.77608695652174, 0.045454545454545
37220, 0.1304347826087, 0.77608695652174, 0.090909090909091
37221, 0.1304347826087, 0.77608695652174, 0.13636363636364
37222, 0.1304347826087, 0.77608695652174, 0.18181818181818
37223, 0.1304347826087, 0.77608695652174, 0.22727272727273
37224, 0.1304347826087, 0.77608695652174, 0.27272727272727
37225, 0.1304347826087, 0.77608695652174, 0.31818181818182
37226, 0.1304347826087, 0.77608695652174, 0.36363636363636
37227, 0.1304347826087, 0.77608695652174, 0.40909090909091
37228, 0.1304347826087, 0.77608695652174, 0.45454545454545
37229, 0.08695652173913, 0.77608695652174, 0.045454545454545
37230, 0.08695652173913, 0.77608695652174, 0.090909090909091
37231, 0.08695652173913, 0.77608695652174, 0.13636363636364
37232, 0.08695652173913, 0.77608695652174, 0.18181818181818
37233, 0.08695652173913, 0.77608695652174, 0.22727272727273
37234, 0.08695652173913, 0.77608695652174, 0.27272727272727
37235, 0.08695652173913, 0.77608695652174, 0.31818181818182
37236, 0.08695652173913, 0.77608695652174, 0.36363636363636
37237, 0.08695652173913, 0.77608695652174, 0.40909090909091
37238, 0.08695652173913, 0.77608695652174, 0.45454545454545
37239, 0.043478260869565, 0.77608695652174, 0.045454545454545
37240, 0.043478260869565, 0.77608695652174, 0.090909090909091
37241, 0.043478260869565, 0.77608695652174, 0.13636363636364
37242, 0.043478260869565, 0.77608695652174, 0.18181818181818
37243, 0.043478260869565, 0.77608695652174, 0.22727272727273
37244, 0.043478260869565, 0.77608695652174, 0.27272727272727
37245, 0.043478260869565, 0.77608695652174, 0.31818181818182
37246, 0.043478260869565, 0.77608695652174, 0.36363636363636
37247, 0.043478260869565, 0.77608695652174, 0.40909090909091
37248, 0.043478260869565, 0.77608695652174, 0.45454545454545
37249, 0.95652173913043, 0.82826086956522, 0.045454545454545
37250, 0.95652173913043, 0.82826086956522, 0.090909090909091
37251, 0.95652173913044, 0.82826086956522, 0.13636363636364
37252, 0.95652173913044, 0.82826086956522, 0.18181818181818
37253, 0.95652173913044, 0.82826086956522, 0.22727272727273
37254, 0.95652173913044, 0.82826086956522, 0.27272727272727
37255, 0.95652173913044, 0.82826086956522, 0.31818181818182
37256, 0.95652173913043, 0.82826086956522, 0.36363636363636
37257, 0.95652173913043, 0.82826086956522, 0.40909090909091
37258, 0.95652173913044, 0.82826086956522, 0.45454545454545
37259, 0.91304347826087, 0.82826086956522, 0.045454545454545
37260, 0.91304347826087, 0.82826086956522, 0.090909090909091
37261, 0.91304347826087, 0.82826086956522, 0.13636363636364
37262, 0.91304347826087, 0.82826086956522, 0.18181818181818
37263, 0.91304347826087, 0.82826086956522, 0.22727272727273
37264, 0.91304347826087, 0.82826086956522, 0.27272727272727
37265, 0.91304347826087, 0.82826086956522, 0.31818181818182
37266, 0.91304347826087, 0.82826086956522, 0.36363636363636
37267, 0.91304347826087, 0.82826086956522, 0.40909090909091
37268, 0.91304347826087, 0.82826086956522, 0.45454545454545
37269, 0.8695652173913, 0.82826086956522, 0.045454545454545
37270, 0.8695652173913, 0.82826086956522, 0.090909090909091
37271, 0.8695652173913, 0.82826086956522, 0.13636363636364
37272, 0.8695652173913, 0.82826086956522, 0.18181818181818
37273, 0.8695652173913, 0.82826086956522, 0.22727272727273
37274, 0.8695652173913, 0.82826086956522, 0.27272727272727
37275, 0.8695652173913, 0.82826086956522, 0.31818181818182
37276, 0.8695652173913, 0.82826086956522, 0.36363636363636
37277, 0.8695652173913, 0.82826086956522, 0.40909090909091
37278, 0.8695652173913, 0.82826086956522, 0.45454545454545
37279, 0.82608695652174, 0.82826086956522, 0.045454545454545
37280, 0.82608695652174, 0.82826086956522, 0.090909090909091
37281, 0.82608695652174, 0.82826086956522, 0.13636363636364
37282, 0.82608695652174, 0.82826086956522, 0.18181818181818
37283, 0.82608695652174, 0.82826086956522, 0.22727272727273
37284, 0.82608695652174, 0.82826086956522, 0.27272727272727
37285, 0.82608695652174, 0.82826086956522, 0.31818181818182
37286, 0.82608695652174, 0.82826086956522, 0.36363636363636
37287, 0.82608695652174, 0.82826086956522, 0.40909090909091
37288, 0.82608695652174, 0.82826086956522, 0.45454545454545
37289, 0.78260869565217, 0.82826086956522, 0.045454545454545
37290, 0.78260869565217, 0.82826086956522, 0.090909090909091
37291, 0.78260869565217, 0.82826086956522, 0.13636363636364
37292, 0.78260869565217, 0.82826086956522, 0.18181818181818
37293, 0.78260869565217, 0.82826086956522, 0.22727272727273
37294, 0.78260869565217, 0.82826086956522, 0.27272727272727
37295, 0.78260869565217, 0.82826086956522, 0.31818181818182
37296, 0.78260869565217, 0.82826086956522, 0.36363636363636
37297, 0.78260869565217, 0.82826086956522, 0.40909090909091
37298, 0.78260869565217, 0.82826086956522, 0.45454545454545
37299, 0.73913043478261, 0.82826086956522, 0.045454545454545
37300, 0.73913043478261, 0.82826086956522, 0.090909090909091
37301, 0.73913043478261, 0.82826086956522, 0.13636363636364
37302, 0.73913043478261, 0.82826086956522, 0.18181818181818
37303, 0.73913043478261, 0.82826086956522, 0.22727272727273
37304, 0.73913043478261, 0.82826086956522, 0.27272727272727
37305, 0.73913043478261, 0.82826086956522, 0.31818181818182
37306, 0.73913043478261, 0.82826086956522, 0.36363636363636
37307, 0.73913043478261, 0.82826086956522, 0.40909090909091
37308, 0.73913043478261, 0.82826086956522, 0.45454545454545
37309, 0.69565217391304, 0.82826086956522, 0.045454545454545
37310, 0.69565217391304, 0.82826086956522, 0.090909090909091
37311, 0.69565217391304, 0.82826086956522, 0.13636363636364
37312, 0.69565217391304, 0.82826086956522, 0.18181818181818
37313, 0.69565217391304, 0.82826086956522, 0.22727272727273
37314, 0.69565217391304, 0.82826086956522, 0.27272727272727
37315, 0.69565217391304, 0.82826086956522, 0.31818181818182
37316, 0.69565217391304, 0.82826086956522, 0.36363636363636
37317, 0.69565217391304, 0.82826086956522, 0.40909090909091
37318, 0.69565217391304, 0.82826086956522, 0.45454545454545
37319, 0.65217391304348, 0.82826086956522, 0.045454545454545
37320, 0.65217391304348, 0.82826086956522, 0.090909090909091
37321, 0.65217391304348, 0.82826086956522, 0.13636363636364
37322, 0.65217391304348, 0.82826086956522, 0.18181818181818
37323, 0.65217391304348, 0.82826086956522, 0.22727272727273
37324, 0.65217391304348, 0.82826086956522, 0.27272727272727
37325, 0.65217391304348, 0.82826086956522, 0.31818181818182
37326, 0.65217391304348, 0.82826086956522, 0.36363636363636
37327, 0.65217391304348, 0.82826086956522, 0.40909090909091
37328, 0.65217391304348, 0.82826086956522, 0.45454545454545
37329, 0.60869565217391, 0.82826086956522, 0.045454545454545
37330, 0.60869565217391, 0.82826086956522, 0.090909090909091
37331, 0.60869565217391, 0.82826086956522, 0.13636363636364
37332, 0.60869565217391, 0.82826086956522, 0.18181818181818
37333, 0.60869565217391, 0.82826086956522, 0.22727272727273
37334, 0.60869565217391, 0.82826086956522, 0.27272727272727
37335, 0.60869565217391, 0.82826086956522, 0.31818181818182
37336, 0.60869565217391, 0.82826086956522, 0.36363636363636
37337, 0.60869565217391, 0.82826086956522, 0.40909090909091
37338, 0.60869565217391, 0.82826086956522, 0.45454545454545
37339, 0.56521739130435, 0.82826086956522, 0.045454545454545
37340, 0.56521739130435, 0.82826086956522, 0.090909090909091
37341, 0.56521739130435, 0.82826086956522, 0.13636363636364
37342, 0.56521739130435, 0.82826086956522, 0.18181818181818
37343, 0.56521739130435, 0.82826086956522, 0.22727272727273
37344, 0.56521739130435, 0.82826086956522, 0.27272727272727
37345, 0.56521739130435, 0.82826086956522, 0.31818181818182
37346, 0.56521739130435, 0.82826086956522, 0.36363636363636
37347, 0.56521739130435, 0.82826086956522, 0.40909090909091
37348, 0.56521739130435, 0.82826086956522, 0.45454545454545
37349, 0.52173913043478, 0.82826086956522, 0.045454545454545
37350, 0.52173913043478, 0.82826086956522, 0.090909090909091
37351, 0.52173913043478, 0.82826086956522, 0.13636363636364
37352, 0.52173913043478, 0.82826086956522, 0.18181818181818
37353, 0.52173913043478, 0.82826086956522, 0.22727272727273
37354, 0.52173913043478, 0.82826086956522, 0.27272727272727
37355, 0.52173913043478, 0.82826086956522, 0.31818181818182
37356, 0.52173913043478, 0.82826086956522, 0.36363636363636
37357, 0.52173913043478, 0.82826086956522, 0.40909090909091
37358, 0.52173913043478, 0.82826086956522, 0.45454545454545
37359, 0.47826086956522, 0.82826086956522, 0.045454545454545
37360, 0.47826086956522, 0.82826086956522, 0.090909090909091
37361, 0.47826086956522, 0.82826086956522, 0.13636363636364
37362, 0.47826086956522, 0.82826086956522, 0.18181818181818
37363, 0.47826086956522, 0.82826086956522, 0.22727272727273
37364, 0.47826086956522, 0.82826086956522, 0.27272727272727
37365, 0.47826086956522, 0.82826086956522, 0.31818181818182
37366, 0.47826086956522, 0.82826086956522, 0.36363636363636
37367, 0.47826086956522, 0.82826086956522, 0.40909090909091
37368, 0.47826086956522, 0.82826086956522, 0.45454545454545
37369, 0.43478260869565, 0.82826086956522, 0.045454545454545
37370, 0.43478260869565, 0.82826086956522, 0.090909090909091
37371, 0.43478260869565, 0.82826086956522, 0.13636363636364
37372, 0.43478260869565, 0.82826086956522, 0.18181818181818
37373, 0.43478260869565, 0.82826086956522, 0.22727272727273
37374, 0.43478260869565, 0.82826086956522, 0.27272727272727
37375, 0.43478260869565, 0.82826086956522, 0.31818181818182
37376, 0.43478260869565, 0.82826086956522, 0.36363636363636
37377, 0.43478260869565, 0.82826086956522, 0.40909090909091
37378, 0.43478260869565, 0.82826086956522, 0.45454545454545
37379, 0.39130434782609, 0.82826086956522, 0.045454545454545
37380, 0.39130434782609, 0.82826086956522, 0.090909090909091
37381, 0.39130434782609, 0.82826086956522, 0.13636363636364
37382, 0.39130434782609, 0.82826086956522, 0.18181818181818
37383, 0.39130434782609, 0.82826086956522, 0.22727272727273
37384, 0.39130434782609, 0.82826086956522, 0.27272727272727
37385, 0.39130434782609, 0.82826086956522, 0.31818181818182
37386, 0.39130434782609, 0.82826086956522, 0.36363636363636
37387, 0.39130434782609, 0.82826086956522, 0.40909090909091
37388, 0.39130434782609, 0.82826086956522, 0.45454545454545
37389, 0.34782608695652, 0.82826086956522, 0.045454545454545
37390, 0.34782608695652, 0.82826086956522, 0.090909090909091
37391, 0.34782608695652, 0.82826086956522, 0.13636363636364
37392, 0.34782608695652, 0.82826086956522, 0.18181818181818
37393, 0.34782608695652, 0.82826086956522, 0.22727272727273
37394, 0.34782608695652, 0.82826086956522, 0.27272727272727
37395, 0.34782608695652, 0.82826086956522, 0.31818181818182
37396, 0.34782608695652, 0.82826086956522, 0.36363636363636
37397, 0.34782608695652, 0.82826086956522, 0.40909090909091
37398, 0.34782608695652, 0.82826086956522, 0.45454545454545
37399, 0.30434782608696, 0.82826086956522, 0.045454545454545
37400, 0.30434782608696, 0.82826086956522, 0.090909090909091
37401, 0.30434782608696, 0.82826086956522, 0.13636363636364
37402, 0.30434782608696, 0.82826086956522, 0.18181818181818
37403, 0.30434782608696, 0.82826086956522, 0.22727272727273
37404, 0.30434782608696, 0.82826086956522, 0.27272727272727
37405, 0.30434782608696, 0.82826086956522, 0.31818181818182
37406, 0.30434782608696, 0.82826086956522, 0.36363636363636
37407, 0.30434782608696, 0.82826086956522, 0.40909090909091
37408, 0.30434782608696, 0.82826086956522, 0.45454545454545
37409, 0.26086956521739, 0.82826086956522, 0.045454545454545
37410, 0.26086956521739, 0.82826086956522, 0.090909090909091
37411, 0.26086956521739, 0.82826086956522, 0.13636363636364
37412, 0.26086956521739, 0.82826086956522, 0.18181818181818
37413, 0.26086956521739, 0.82826086956522, 0.22727272727273
37414, 0.26086956521739, 0.82826086956522, 0.27272727272727
37415, 0.26086956521739, 0.82826086956522, 0.31818181818182
37416, 0.26086956521739, 0.82826086956522, 0.36363636363636
37417, 0.26086956521739, 0.82826086956522, 0.40909090909091
37418, 0.26086956521739, 0.82826086956522, 0.45454545454545
37419, 0.21739130434783, 0.82826086956522, 0.045454545454545
37420, 0.21739130434783, 0.82826086956522, 0.090909090909091
37421, 0.21739130434783, 0.82826086956522, 0.13636363636364
37422, 0.21739130434783, 0.82826086956522, 0.18181818181818
37423, 0.21739130434783, 0.82826086956522, 0.22727272727273
37424, 0.21739130434783, 0.82826086956522, 0.27272727272727
37425, 0.21739130434783, 0.82826086956522, 0.31818181818182
37426, 0.21739130434783, 0.82826086956522, 0.36363636363636
37427, 0.21739130434783, 0.82826086956522, 0.40909090909091
37428, 0.21739130434783, 0.82826086956522, 0.45454545454545
37429, 0.17391304347826, 0.82826086956522, 0.045454545454545
37430, 0.17391304347826, 0.82826086956522, 0.090909090909091
37431, 0.17391304347826, 0.82826086956522, 0.13636363636364
37432, 0.17391304347826, 0.82826086956522, 0.18181818181818
37433, 0.17391304347826, 0.82826086956522, 0.22727272727273
37434, 0.17391304347826, 0.82826086956522, 0.27272727272727
37435, 0.17391304347826, 0.82826086956522, 0.31818181818182
37436, 0.17391304347826, 0.82826086956522, 0.36363636363636
37437, 0.17391304347826, 0.82826086956522, 0.40909090909091
37438, 0.17391304347826, 0.82826086956522, 0.45454545454545
37439, 0.1304347826087, 0.82826086956522, 0.045454545454545
37440, 0.1304347826087, 0.82826086956522, 0.090909090909091
37441, 0.1304347826087, 0.82826086956522, 0.13636363636364
37442, 0.1304347826087, 0.82826086956522, 0.18181818181818
37443, 0.1304347826087, 0.82826086956522, 0.22727272727273
37444, 0.1304347826087, 0.82826086956522, 0.27272727272727
37445, 0.1304347826087, 0.82826086956522, 0.31818181818182
37446, 0.1304347826087, 0.82826086956522, 0.36363636363636
37447, 0.1304347826087, 0.82826086956522, 0.40909090909091
37448, 0.1304347826087, 0.82826086956522, 0.45454545454545
37449, 0.08695652173913, 0.82826086956522, 0.045454545454545
37450, 0.08695652173913, 0.82826086956522, 0.090909090909091
37451, 0.08695652173913, 0.82826086956522, 0.13636363636364
37452, 0.08695652173913, 0.82826086956522, 0.18181818181818
37453, 0.08695652173913, 0.82826086956522, 0.22727272727273
37454, 0.08695652173913, 0.82826086956522, 0.27272727272727
37455, 0.08695652173913, 0.82826086956522, 0.31818181818182
37456, 0.08695652173913, 0.82826086956522, 0.36363636363636
37457, 0.08695652173913, 0.82826086956522, 0.40909090909091
37458, 0.08695652173913, 0.82826086956522, 0.45454545454545
37459, 0.043478260869565, 0.82826086956522, 0.045454545454545
37460, 0.043478260869565, 0.82826086956522, 0.090909090909091
37461, 0.043478260869565, 0.82826086956522, 0.13636363636364
37462, 0.043478260869565, 0.82826086956522, 0.18181818181818
37463, 0.043478260869565, 0.82826086956522, 0.22727272727273
37464, 0.043478260869565, 0.82826086956522, 0.27272727272727
37465, 0.043478260869565, 0.82826086956522, 0.31818181818182
37466, 0.043478260869565, 0.82826086956522, 0.36363636363636
37467, 0.043478260869565, 0.82826086956522, 0.40909090909091
37468, 0.043478260869565, 0.82826086956522, 0.45454545454545
37469, 0.95652173913043, 0.8804347826087, 0.045454545454545
37470, 0.95652173913043, 0.8804347826087, 0.090909090909091
37471, 0.95652173913044, 0.8804347826087, 0.13636363636364
37472, 0.95652173913044, 0.88043478260869, 0.18181818181818
37473, 0.95652173913044, 0.8804347826087, 0.22727272727273
37474, 0.95652173913044, 0.8804347826087, 0.27272727272727
37475, 0.95652173913044, 0.8804347826087, 0.31818181818182
37476, 0.95652173913043, 0.8804347826087, 0.36363636363636
37477, 0.95652173913043, 0.8804347826087, 0.40909090909091
37478, 0.95652173913044, 0.8804347826087, 0.45454545454545
37479, 0.91304347826087, 0.88043478260869, 0.045454545454545
37480, 0.91304347826087, 0.8804347826087, 0.090909090909091
37481, 0.91304347826087, 0.8804347826087, 0.13636363636364
37482, 0.91304347826087, 0.88043478260869, 0.18181818181818
37483, 0.91304347826087, 0.8804347826087, 0.22727272727273
37484, 0.91304347826087, 0.88043478260869, 0.27272727272727
37485, 0.91304347826087, 0.8804347826087, 0.31818181818182
37486, 0.91304347826087, 0.8804347826087, 0.36363636363636
37487, 0.91304347826087, 0.8804347826087, 0.40909090909091
37488, 0.91304347826087, 0.88043478260869, 0.45454545454545
37489, 0.8695652173913, 0.8804347826087, 0.045454545454545
37490, 0.8695652173913, 0.8804347826087, 0.090909090909091
37491, 0.8695652173913, 0.8804347826087, 0.13636363636364
37492, 0.8695652173913, 0.8804347826087, 0.18181818181818
37493, 0.8695652173913, 0.8804347826087, 0.22727272727273
37494, 0.8695652173913, 0.8804347826087, 0.27272727272727
37495, 0.8695652173913, 0.8804347826087, 0.31818181818182
37496, 0.8695652173913, 0.8804347826087, 0.36363636363636
37497, 0.8695652173913, 0.8804347826087, 0.40909090909091
37498, 0.8695652173913, 0.8804347826087, 0.45454545454545
37499, 0.82608695652174, 0.8804347826087, 0.045454545454545
37500, 0.82608695652174, 0.8804347826087, 0.090909090909091
37501, 0.82608695652174, 0.8804347826087, 0.13636363636364
37502, 0.82608695652174, 0.8804347826087, 0.18181818181818
37503, 0.82608695652174, 0.8804347826087, 0.22727272727273
37504, 0.82608695652174, 0.8804347826087, 0.27272727272727
37505, 0.82608695652174, 0.8804347826087, 0.31818181818182
37506, 0.82608695652174, 0.8804347826087, 0.36363636363636
37507, 0.82608695652174, 0.8804347826087, 0.40909090909091
37508, 0.82608695652174, 0.8804347826087, 0.45454545454545
37509, 0.78260869565217, 0.8804347826087, 0.045454545454545
37510, 0.78260869565217, 0.8804347826087, 0.090909090909091
37511, 0.78260869565217, 0.88043478260869, 0.13636363636364
37512, 0.78260869565217, 0.88043478260869, 0.18181818181818
37513, 0.78260869565217, 0.88043478260869, 0.22727272727273
37514, 0.78260869565217, 0.88043478260869, 0.27272727272727
37515, 0.78260869565217, 0.8804347826087, 0.31818181818182
37516, 0.78260869565217, 0.88043478260869, 0.36363636363636
37517, 0.78260869565217, 0.8804347826087, 0.40909090909091
37518, 0.78260869565217, 0.88043478260869, 0.45454545454545
37519, 0.73913043478261, 0.8804347826087, 0.045454545454545
37520, 0.73913043478261, 0.88043478260869, 0.090909090909091
37521, 0.73913043478261, 0.88043478260869, 0.13636363636364
37522, 0.73913043478261, 0.8804347826087, 0.18181818181818
37523, 0.73913043478261, 0.8804347826087, 0.22727272727273
37524, 0.73913043478261, 0.8804347826087, 0.27272727272727
37525, 0.73913043478261, 0.8804347826087, 0.31818181818182
37526, 0.73913043478261, 0.8804347826087, 0.36363636363636
37527, 0.73913043478261, 0.88043478260869, 0.40909090909091
37528, 0.73913043478261, 0.88043478260869, 0.45454545454545
37529, 0.69565217391304, 0.88043478260869, 0.045454545454545
37530, 0.69565217391304, 0.8804347826087, 0.090909090909091
37531, 0.69565217391304, 0.8804347826087, 0.13636363636364
37532, 0.69565217391304, 0.88043478260869, 0.18181818181818
37533, 0.69565217391304, 0.8804347826087, 0.22727272727273
37534, 0.69565217391304, 0.8804347826087, 0.27272727272727
37535, 0.69565217391304, 0.8804347826087, 0.31818181818182
37536, 0.69565217391304, 0.8804347826087, 0.36363636363636
37537, 0.69565217391304, 0.8804347826087, 0.40909090909091
37538, 0.69565217391304, 0.8804347826087, 0.45454545454545
37539, 0.65217391304348, 0.8804347826087, 0.045454545454545
37540, 0.65217391304348, 0.8804347826087, 0.090909090909091
37541, 0.65217391304348, 0.8804347826087, 0.13636363636364
37542, 0.65217391304348, 0.8804347826087, 0.18181818181818
37543, 0.65217391304348, 0.8804347826087, 0.22727272727273
37544, 0.65217391304348, 0.8804347826087, 0.27272727272727
37545, 0.65217391304348, 0.8804347826087, 0.31818181818182
37546, 0.65217391304348, 0.8804347826087, 0.36363636363636
37547, 0.65217391304348, 0.8804347826087, 0.40909090909091
37548, 0.65217391304348, 0.8804347826087, 0.45454545454545
37549, 0.60869565217391, 0.8804347826087, 0.045454545454545
37550, 0.60869565217391, 0.8804347826087, 0.090909090909091
37551, 0.60869565217391, 0.8804347826087, 0.13636363636364
37552, 0.60869565217391, 0.88043478260869, 0.18181818181818
37553, 0.60869565217391, 0.8804347826087, 0.22727272727273
37554, 0.60869565217391, 0.8804347826087, 0.27272727272727
37555, 0.60869565217391, 0.8804347826087, 0.31818181818182
37556, 0.60869565217391, 0.8804347826087, 0.36363636363636
37557, 0.60869565217391, 0.8804347826087, 0.40909090909091
37558, 0.60869565217391, 0.8804347826087, 0.45454545454545
37559, 0.56521739130435, 0.88043478260869, 0.045454545454545
37560, 0.56521739130435, 0.8804347826087, 0.090909090909091
37561, 0.56521739130435, 0.8804347826087, 0.13636363636364
37562, 0.56521739130435, 0.88043478260869, 0.18181818181818
37563, 0.56521739130435, 0.8804347826087, 0.22727272727273
37564, 0.56521739130435, 0.88043478260869, 0.27272727272727
37565, 0.56521739130435, 0.8804347826087, 0.31818181818182
37566, 0.56521739130435, 0.88043478260869, 0.36363636363636
37567, 0.56521739130435, 0.8804347826087, 0.40909090909091
37568, 0.56521739130435, 0.88043478260869, 0.45454545454545
37569, 0.52173913043478, 0.88043478260869, 0.045454545454545
37570, 0.52173913043478, 0.8804347826087, 0.090909090909091
37571, 0.52173913043478, 0.88043478260869, 0.13636363636364
37572, 0.52173913043478, 0.88043478260869, 0.18181818181818
37573, 0.52173913043478, 0.8804347826087, 0.22727272727273
37574, 0.52173913043478, 0.88043478260869, 0.27272727272727
37575, 0.52173913043478, 0.88043478260869, 0.31818181818182
37576, 0.52173913043478, 0.88043478260869, 0.36363636363636
37577, 0.52173913043478, 0.88043478260869, 0.40909090909091
37578, 0.52173913043478, 0.88043478260869, 0.45454545454545
37579, 0.47826086956522, 0.88043478260869, 0.045454545454545
37580, 0.47826086956522, 0.8804347826087, 0.090909090909091
37581, 0.47826086956522, 0.8804347826087, 0.13636363636364
37582, 0.47826086956522, 0.88043478260869, 0.18181818181818
37583, 0.47826086956522, 0.8804347826087, 0.22727272727273
37584, 0.47826086956522, 0.8804347826087, 0.27272727272727
37585, 0.47826086956522, 0.8804347826087, 0.31818181818182
37586, 0.47826086956522, 0.8804347826087, 0.36363636363636
37587, 0.47826086956522, 0.8804347826087, 0.40909090909091
37588, 0.47826086956522, 0.8804347826087, 0.45454545454545
37589, 0.43478260869565, 0.88043478260869, 0.045454545454545
37590, 0.43478260869565, 0.8804347826087, 0.090909090909091
37591, 0.43478260869565, 0.8804347826087, 0.13636363636364
37592, 0.43478260869565, 0.88043478260869, 0.18181818181818
37593, 0.43478260869565, 0.8804347826087, 0.22727272727273
37594, 0.43478260869565, 0.8804347826087, 0.27272727272727
37595, 0.43478260869565, 0.8804347826087, 0.31818181818182
37596, 0.43478260869565, 0.88043478260869, 0.36363636363636
37597, 0.43478260869565, 0.8804347826087, 0.40909090909091
37598, 0.43478260869565, 0.8804347826087, 0.45454545454545
37599, 0.39130434782609, 0.88043478260869, 0.045454545454545
37600, 0.39130434782609, 0.8804347826087, 0.090909090909091
37601, 0.39130434782609, 0.8804347826087, 0.13636363636364
37602, 0.39130434782609, 0.88043478260869, 0.18181818181818
37603, 0.39130434782609, 0.8804347826087, 0.22727272727273
37604, 0.39130434782609, 0.8804347826087, 0.27272727272727
37605, 0.39130434782609, 0.88043478260869, 0.31818181818182
37606, 0.39130434782609, 0.88043478260869, 0.36363636363636
37607, 0.39130434782609, 0.88043478260869, 0.40909090909091
37608, 0.39130434782609, 0.8804347826087, 0.45454545454545
37609, 0.34782608695652, 0.8804347826087, 0.045454545454545
37610, 0.34782608695652, 0.88043478260869, 0.090909090909091
37611, 0.34782608695652, 0.8804347826087, 0.13636363636364
37612, 0.34782608695652, 0.8804347826087, 0.18181818181818
37613, 0.34782608695652, 0.8804347826087, 0.22727272727273
37614, 0.34782608695652, 0.8804347826087, 0.27272727272727
37615, 0.34782608695652, 0.8804347826087, 0.31818181818182
37616, 0.34782608695652, 0.8804347826087, 0.36363636363636
37617, 0.34782608695652, 0.88043478260869, 0.40909090909091
37618, 0.34782608695652, 0.8804347826087, 0.45454545454545
37619, 0.30434782608696, 0.88043478260869, 0.045454545454545
37620, 0.30434782608696, 0.8804347826087, 0.090909090909091
37621, 0.30434782608696, 0.88043478260869, 0.13636363636364
37622, 0.30434782608696, 0.8804347826087, 0.18181818181818
37623, 0.30434782608696, 0.8804347826087, 0.22727272727273
37624, 0.30434782608696, 0.88043478260869, 0.27272727272727
37625, 0.30434782608696, 0.8804347826087, 0.31818181818182
37626, 0.30434782608696, 0.88043478260869, 0.36363636363636
37627, 0.30434782608696, 0.88043478260869, 0.40909090909091
37628, 0.30434782608696, 0.88043478260869, 0.45454545454545
37629, 0.26086956521739, 0.88043478260869, 0.045454545454545
37630, 0.26086956521739, 0.8804347826087, 0.090909090909091
37631, 0.26086956521739, 0.88043478260869, 0.13636363636364
37632, 0.26086956521739, 0.88043478260869, 0.18181818181818
37633, 0.26086956521739, 0.88043478260869, 0.22727272727273
37634, 0.26086956521739, 0.88043478260869, 0.27272727272727
37635, 0.26086956521739, 0.8804347826087, 0.31818181818182
37636, 0.26086956521739, 0.88043478260869, 0.36363636363636
37637, 0.26086956521739, 0.88043478260869, 0.40909090909091
37638, 0.26086956521739, 0.8804347826087, 0.45454545454545
37639, 0.21739130434783, 0.8804347826087, 0.045454545454545
37640, 0.21739130434783, 0.8804347826087, 0.090909090909091
37641, 0.21739130434783, 0.88043478260869, 0.13636363636364
37642, 0.21739130434783, 0.88043478260869, 0.18181818181818
37643, 0.21739130434783, 0.8804347826087, 0.22727272727273
37644, 0.21739130434783, 0.8804347826087, 0.27272727272727
37645, 0.21739130434783, 0.8804347826087, 0.31818181818182
37646, 0.21739130434783, 0.88043478260869, 0.36363636363636
37647, 0.21739130434783, 0.88043478260869, 0.40909090909091
37648, 0.21739130434783, 0.8804347826087, 0.45454545454545
37649, 0.17391304347826, 0.88043478260869, 0.045454545454545
37650, 0.17391304347826, 0.8804347826087, 0.090909090909091
37651, 0.17391304347826, 0.88043478260869, 0.13636363636364
37652, 0.17391304347826, 0.88043478260869, 0.18181818181818
37653, 0.17391304347826, 0.88043478260869, 0.22727272727273
37654, 0.17391304347826, 0.88043478260869, 0.27272727272727
37655, 0.17391304347826, 0.8804347826087, 0.31818181818182
37656, 0.17391304347826, 0.8804347826087, 0.36363636363636
37657, 0.17391304347826, 0.8804347826087, 0.40909090909091
37658, 0.17391304347826, 0.88043478260869, 0.45454545454545
37659, 0.1304347826087, 0.88043478260869, 0.045454545454545
37660, 0.1304347826087, 0.8804347826087, 0.090909090909091
37661, 0.1304347826087, 0.88043478260869, 0.13636363636364
37662, 0.1304347826087, 0.88043478260869, 0.18181818181818
37663, 0.1304347826087, 0.8804347826087, 0.22727272727273
37664, 0.1304347826087, 0.88043478260869, 0.27272727272727
37665, 0.1304347826087, 0.8804347826087, 0.31818181818182
37666, 0.1304347826087, 0.88043478260869, 0.36363636363636
37667, 0.1304347826087, 0.8804347826087, 0.40909090909091
37668, 0.1304347826087, 0.88043478260869, 0.45454545454545
37669, 0.08695652173913, 0.8804347826087, 0.045454545454545
37670, 0.08695652173913, 0.8804347826087, 0.090909090909091
37671, 0.08695652173913, 0.8804347826087, 0.13636363636364
37672, 0.08695652173913, 0.8804347826087, 0.18181818181818
37673, 0.08695652173913, 0.8804347826087, 0.22727272727273
37674, 0.08695652173913, 0.8804347826087, 0.27272727272727
37675, 0.08695652173913, 0.8804347826087, 0.31818181818182
37676, 0.08695652173913, 0.8804347826087, 0.36363636363636
37677, 0.08695652173913, 0.8804347826087, 0.40909090909091
37678, 0.08695652173913, 0.8804347826087, 0.45454545454545
37679, 0.043478260869565, 0.8804347826087, 0.045454545454545
37680, 0.043478260869565, 0.8804347826087, 0.090909090909091
37681, 0.043478260869565, 0.8804347826087, 0.13636363636364
37682, 0.043478260869565, 0.88043478260869, 0.18181818181818
37683, 0.043478260869565, 0.8804347826087, 0.22727272727273
37684, 0.043478260869565, 0.8804347826087, 0.27272727272727
37685, 0.043478260869565, 0.8804347826087, 0.31818181818182
37686, 0.043478260869565, 0.88043478260869, 0.36363636363636
37687, 0.043478260869565, 0.8804347826087, 0.40909090909091
37688, 0.043478260869565, 0.8804347826087, 0.45454545454545
37689, 0.95652173913043, 0.93260869565217, 0.045454545454545
37690, 0.95652173913044, 0.93260869565217, 0.090909090909091
37691, 0.95652173913044, 0.93260869565217, 0.13636363636364
37692, 0.95652173913044, 0.93260869565217, 0.18181818181818
37693, 0.95652173913044, 0.93260869565217, 0.22727272727273
37694, 0.95652173913044, 0.93260869565217, 0.27272727272727
37695, 0.95652173913044, 0.93260869565217, 0.31818181818182
37696, 0.95652173913043, 0.93260869565217, 0.36363636363636
37697, 0.95652173913043, 0.93260869565217, 0.40909090909091
37698, 0.95652173913044, 0.93260869565217, 0.45454545454545
37699, 0.91304347826087, 0.93260869565217, 0.045454545454545
37700, 0.91304347826087, 0.93260869565217, 0.090909090909091
37701, 0.91304347826087, 0.93260869565217, 0.13636363636364
37702, 0.91304347826087, 0.93260869565217, 0.18181818181818
37703, 0.91304347826087, 0.93260869565217, 0.22727272727273
37704, 0.91304347826087, 0.93260869565217, 0.27272727272727
37705, 0.91304347826087, 0.93260869565217, 0.31818181818182
37706, 0.91304347826087, 0.93260869565217, 0.36363636363636
37707, 0.91304347826087, 0.93260869565217, 0.40909090909091
37708, 0.91304347826087, 0.93260869565217, 0.45454545454545
37709, 0.8695652173913, 0.93260869565217, 0.045454545454545
37710, 0.8695652173913, 0.93260869565217, 0.090909090909091
37711, 0.8695652173913, 0.93260869565217, 0.13636363636364
37712, 0.8695652173913, 0.93260869565217, 0.18181818181818
37713, 0.8695652173913, 0.93260869565217, 0.22727272727273
37714, 0.8695652173913, 0.93260869565217, 0.27272727272727
37715, 0.8695652173913, 0.93260869565217, 0.31818181818182
37716, 0.8695652173913, 0.93260869565217, 0.36363636363636
37717, 0.8695652173913, 0.93260869565217, 0.40909090909091
37718, 0.8695652173913, 0.93260869565217, 0.45454545454545
37719, 0.82608695652174, 0.93260869565217, 0.045454545454545
37720, 0.82608695652174, 0.93260869565217, 0.090909090909091
37721, 0.82608695652174, 0.93260869565217, 0.13636363636364
37722, 0.82608695652174, 0.93260869565217, 0.18181818181818
37723, 0.82608695652174, 0.93260869565217, 0.22727272727273
37724, 0.82608695652174, 0.93260869565217, 0.27272727272727
37725, 0.82608695652174, 0.93260869565217, 0.31818181818182
37726, 0.82608695652174, 0.93260869565217, 0.36363636363636
37727, 0.82608695652174, 0.93260869565217, 0.40909090909091
37728, 0.82608695652174, 0.93260869565217, 0.45454545454545
37729, 0.78260869565217, 0.93260869565217, 0.045454545454545
37730, 0.78260869565217, 0.93260869565217, 0.090909090909091
37731, 0.78260869565217, 0.93260869565217, 0.13636363636364
37732, 0.78260869565217, 0.93260869565217, 0.18181818181818
37733, 0.78260869565217, 0.93260869565217, 0.22727272727273
37734, 0.78260869565217, 0.93260869565217, 0.27272727272727
37735, 0.78260869565217, 0.93260869565217, 0.31818181818182
37736, 0.78260869565217, 0.93260869565217, 0.36363636363636
37737, 0.78260869565217, 0.93260869565217, 0.40909090909091
37738, 0.78260869565217, 0.93260869565217, 0.45454545454545
37739, 0.73913043478261, 0.93260869565217, 0.045454545454545
37740, 0.73913043478261, 0.93260869565217, 0.090909090909091
37741, 0.73913043478261, 0.93260869565217, 0.13636363636364
37742, 0.73913043478261, 0.93260869565217, 0.18181818181818
37743, 0.73913043478261, 0.93260869565217, 0.22727272727273
37744, 0.73913043478261, 0.93260869565217, 0.27272727272727
37745, 0.73913043478261, 0.93260869565217, 0.31818181818182
37746, 0.73913043478261, 0.93260869565217, 0.36363636363636
37747, 0.73913043478261, 0.93260869565217, 0.40909090909091
37748, 0.73913043478261, 0.93260869565217, 0.45454545454545
37749, 0.69565217391304, 0.93260869565217, 0.045454545454545
37750, 0.69565217391304, 0.93260869565217, 0.090909090909091
37751, 0.69565217391304, 0.93260869565217, 0.13636363636364
37752, 0.69565217391304, 0.93260869565217, 0.18181818181818
37753, 0.69565217391304, 0.93260869565217, 0.22727272727273
37754, 0.69565217391304, 0.93260869565217, 0.27272727272727
37755, 0.69565217391304, 0.93260869565217, 0.31818181818182
37756, 0.69565217391304, 0.93260869565217, 0.36363636363636
37757, 0.69565217391304, 0.93260869565217, 0.40909090909091
37758, 0.69565217391304, 0.93260869565217, 0.45454545454545
37759, 0.65217391304348, 0.93260869565217, 0.045454545454545
37760, 0.65217391304348, 0.93260869565217, 0.090909090909091
37761, 0.65217391304348, 0.93260869565217, 0.13636363636364
37762, 0.65217391304348, 0.93260869565217, 0.18181818181818
37763, 0.65217391304348, 0.93260869565217, 0.22727272727273
37764, 0.65217391304348, 0.93260869565217, 0.27272727272727
37765, 0.65217391304348, 0.93260869565217, 0.31818181818182
37766, 0.65217391304348, 0.93260869565217, 0.36363636363636
37767, 0.65217391304348, 0.93260869565217, 0.40909090909091
37768, 0.65217391304348, 0.93260869565217, 0.45454545454545
37769, 0.60869565217391, 0.93260869565217, 0.045454545454545
37770, 0.60869565217391, 0.93260869565217, 0.090909090909091
37771, 0.60869565217391, 0.93260869565217, 0.13636363636364
37772, 0.60869565217391, 0.93260869565217, 0.18181818181818
37773, 0.60869565217391, 0.93260869565217, 0.22727272727273
37774, 0.60869565217391, 0.93260869565217, 0.27272727272727
37775, 0.60869565217391, 0.93260869565217, 0.31818181818182
37776, 0.60869565217391, 0.93260869565217, 0.36363636363636
37777, 0.60869565217391, 0.93260869565217, 0.40909090909091
37778, 0.60869565217391, 0.93260869565217, 0.45454545454545
37779, 0.56521739130435, 0.93260869565217, 0.045454545454545
37780, 0.56521739130435, 0.93260869565217, 0.090909090909091
37781, 0.56521739130435, 0.93260869565217, 0.13636363636364
37782, 0.56521739130435, 0.93260869565217, 0.18181818181818
37783, 0.56521739130435, 0.93260869565217, 0.22727272727273
37784, 0.56521739130435, 0.93260869565217, 0.27272727272727
37785, 0.56521739130435, 0.93260869565217, 0.31818181818182
37786, 0.56521739130435, 0.93260869565217, 0.36363636363636
37787, 0.56521739130435, 0.93260869565217, 0.40909090909091
37788, 0.56521739130435, 0.93260869565217, 0.45454545454545
37789, 0.52173913043478, 0.93260869565217, 0.045454545454545
37790, 0.52173913043478, 0.93260869565217, 0.090909090909091
37791, 0.52173913043478, 0.93260869565217, 0.13636363636364
37792, 0.52173913043478, 0.93260869565217, 0.18181818181818
37793, 0.52173913043478, 0.93260869565217, 0.22727272727273
37794, 0.52173913043478, 0.93260869565217, 0.27272727272727
37795, 0.52173913043478, 0.93260869565217, 0.31818181818182
37796, 0.52173913043478, 0.93260869565217, 0.36363636363636
37797, 0.52173913043478, 0.93260869565217, 0.40909090909091
37798, 0.52173913043478, 0.93260869565217, 0.45454545454545
37799, 0.47826086956522, 0.93260869565217, 0.045454545454545
37800, 0.47826086956522, 0.93260869565217, 0.090909090909091
37801, 0.47826086956522, 0.93260869565217, 0.13636363636364
37802, 0.47826086956522, 0.93260869565217, 0.18181818181818
37803, 0.47826086956522, 0.93260869565217, 0.22727272727273
37804, 0.47826086956522, 0.93260869565217, 0.27272727272727
37805, 0.47826086956522, 0.93260869565217, 0.31818181818182
37806, 0.47826086956522, 0.93260869565217, 0.36363636363636
37807, 0.47826086956522, 0.93260869565217, 0.40909090909091
37808, 0.47826086956522, 0.93260869565217, 0.45454545454545
37809, 0.43478260869565, 0.93260869565217, 0.045454545454545
37810, 0.43478260869565, 0.93260869565217, 0.090909090909091
37811, 0.43478260869565, 0.93260869565217, 0.13636363636364
37812, 0.43478260869565, 0.93260869565217, 0.18181818181818
37813, 0.43478260869565, 0.93260869565217, 0.22727272727273
37814, 0.43478260869565, 0.93260869565217, 0.27272727272727
37815, 0.43478260869565, 0.93260869565217, 0.31818181818182
37816, 0.43478260869565, 0.93260869565217, 0.36363636363636
37817, 0.43478260869565, 0.93260869565217, 0.40909090909091
37818, 0.43478260869565, 0.93260869565217, 0.45454545454545
37819, 0.39130434782609, 0.93260869565217, 0.045454545454545
37820, 0.39130434782609, 0.93260869565217, 0.090909090909091
37821, 0.39130434782609, 0.93260869565217, 0.13636363636364
37822, 0.39130434782609, 0.93260869565217, 0.18181818181818
37823, 0.39130434782609, 0.93260869565217, 0.22727272727273
37824, 0.39130434782609, 0.93260869565217, 0.27272727272727
37825, 0.39130434782609, 0.93260869565217, 0.31818181818182
37826, 0.39130434782609, 0.93260869565217, 0.36363636363636
37827, 0.39130434782609, 0.93260869565217, 0.40909090909091
37828, 0.39130434782609, 0.93260869565217, 0.45454545454545
37829, 0.34782608695652, 0.93260869565217, 0.045454545454545
37830, 0.34782608695652, 0.93260869565217, 0.090909090909091
37831, 0.34782608695652, 0.93260869565217, 0.13636363636364
37832, 0.34782608695652, 0.93260869565217, 0.18181818181818
37833, 0.34782608695652, 0.93260869565217, 0.22727272727273
37834, 0.34782608695652, 0.93260869565217, 0.27272727272727
37835, 0.34782608695652, 0.93260869565217, 0.31818181818182
37836, 0.34782608695652, 0.93260869565217, 0.36363636363636
37837, 0.34782608695652, 0.93260869565217, 0.40909090909091
37838, 0.34782608695652, 0.93260869565217, 0.45454545454545
37839, 0.30434782608696, 0.93260869565217, 0.045454545454545
37840, 0.30434782608696, 0.93260869565217, 0.090909090909091
37841, 0.30434782608696, 0.93260869565217, 0.13636363636364
37842, 0.30434782608696, 0.93260869565217, 0.18181818181818
37843, 0.30434782608696, 0.93260869565217, 0.22727272727273
37844, 0.30434782608696, 0.93260869565217, 0.27272727272727
37845, 0.30434782608696, 0.93260869565217, 0.31818181818182
37846, 0.30434782608696, 0.93260869565217, 0.36363636363636
37847, 0.30434782608696, 0.93260869565217, 0.40909090909091
37848, 0.30434782608696, 0.93260869565217, 0.45454545454545
37849, 0.26086956521739, 0.93260869565217, 0.045454545454545
37850, 0.26086956521739, 0.93260869565217, 0.090909090909091
37851, 0.26086956521739, 0.93260869565217, 0.13636363636364
37852, 0.26086956521739, 0.93260869565217, 0.18181818181818
37853, 0.26086956521739, 0.93260869565217, 0.22727272727273
37854, 0.26086956521739, 0.93260869565217, 0.27272727272727
37855, 0.26086956521739, 0.93260869565217, 0.31818181818182
37856, 0.26086956521739, 0.93260869565217, 0.36363636363636
37857, 0.26086956521739, 0.93260869565217, 0.40909090909091
37858, 0.26086956521739, 0.93260869565217, 0.45454545454545
37859, 0.21739130434783, 0.93260869565217, 0.045454545454545
37860, 0.21739130434783, 0.93260869565217, 0.090909090909091
37861, 0.21739130434783, 0.93260869565217, 0.13636363636364
37862, 0.21739130434783, 0.93260869565217, 0.18181818181818
37863, 0.21739130434783, 0.93260869565217, 0.22727272727273
37864, 0.21739130434783, 0.93260869565217, 0.27272727272727
37865, 0.21739130434783, 0.93260869565217, 0.31818181818182
37866, 0.21739130434783, 0.93260869565217, 0.36363636363636
37867, 0.21739130434783, 0.93260869565217, 0.40909090909091
37868, 0.21739130434783, 0.93260869565217, 0.45454545454545
37869, 0.17391304347826, 0.93260869565217, 0.045454545454545
37870, 0.17391304347826, 0.93260869565217, 0.090909090909091
37871, 0.17391304347826, 0.93260869565217, 0.13636363636364
37872, 0.17391304347826, 0.93260869565217, 0.18181818181818
37873, 0.17391304347826, 0.93260869565217, 0.22727272727273
37874, 0.17391304347826, 0.93260869565217, 0.27272727272727
37875, 0.17391304347826, 0.93260869565217, 0.31818181818182
37876, 0.17391304347826, 0.93260869565217, 0.36363636363636
37877, 0.17391304347826, 0.93260869565217, 0.40909090909091
37878, 0.17391304347826, 0.93260869565217, 0.45454545454545
37879, 0.1304347826087, 0.93260869565217, 0.045454545454545
37880, 0.1304347826087, 0.93260869565217, 0.090909090909091
37881, 0.1304347826087, 0.93260869565217, 0.13636363636364
37882, 0.1304347826087, 0.93260869565217, 0.18181818181818
37883, 0.1304347826087, 0.93260869565217, 0.22727272727273
37884, 0.1304347826087, 0.93260869565217, 0.27272727272727
37885, 0.1304347826087, 0.93260869565217, 0.31818181818182
37886, 0.1304347826087, 0.93260869565217, 0.36363636363636
37887, 0.1304347826087, 0.93260869565217, 0.40909090909091
37888, 0.1304347826087, 0.93260869565217, 0.45454545454545
37889, 0.08695652173913, 0.93260869565217, 0.045454545454545
37890, 0.08695652173913, 0.93260869565217, 0.090909090909091
37891, 0.08695652173913, 0.93260869565217, 0.13636363636364
37892, 0.08695652173913, 0.93260869565217, 0.18181818181818
37893, 0.08695652173913, 0.93260869565217, 0.22727272727273
37894, 0.08695652173913, 0.93260869565217, 0.27272727272727
37895, 0.08695652173913, 0.93260869565217, 0.31818181818182
37896, 0.08695652173913, 0.93260869565217, 0.36363636363636
37897, 0.08695652173913, 0.93260869565217, 0.40909090909091
37898, 0.08695652173913, 0.93260869565217, 0.45454545454545
37899, 0.043478260869565, 0.93260869565217, 0.045454545454545
37900, 0.043478260869565, 0.93260869565217, 0.090909090909091
37901, 0.043478260869565, 0.93260869565217, 0.13636363636364
37902, 0.043478260869565, 0.93260869565217, 0.18181818181818
37903, 0.043478260869565, 0.93260869565217, 0.22727272727273
37904, 0.043478260869565, 0.93260869565217, 0.27272727272727
37905, 0.043478260869565, 0.93260869565217, 0.31818181818182
37906, 0.043478260869565, 0.93260869565217, 0.36363636363636
37907, 0.043478260869565, 0.93260869565217, 0.40909090909091
37908, 0.043478260869565, 0.93260869565217, 0.45454545454545
37909, 0.95652173913043, 0.98478260869565, 0.045454545454545
37910, 0.95652173913044, 0.98478260869565, 0.090909090909091
37911, 0.95652173913043, 0.98478260869565, 0.13636363636364
37912, 0.95652173913044, 0.98478260869565, 0.18181818181818
37913, 0.95652173913044, 0.98478260869565, 0.22727272727273
37914, 0.95652173913044, 0.98478260869565, 0.27272727272727
37915, 0.95652173913044, 0.98478260869565, 0.31818181818182
37916, 0.95652173913043, 0.98478260869565, 0.36363636363636
37917, 0.95652173913043, 0.98478260869565, 0.40909090909091
37918, 0.95652173913044, 0.98478260869565, 0.45454545454545
37919, 0.91304347826087, 0.98478260869565, 0.045454545454545
37920, 0.91304347826087, 0.98478260869565, 0.090909090909091
37921, 0.91304347826087, 0.98478260869565, 0.13636363636364
37922, 0.91304347826087, 0.98478260869565, 0.18181818181818
37923, 0.91304347826087, 0.98478260869565, 0.22727272727273
37924, 0.91304347826087, 0.98478260869565, 0.27272727272727
37925, 0.91304347826087, 0.98478260869565, 0.31818181818182
37926, 0.91304347826087, 0.98478260869565, 0.36363636363636
37927, 0.91304347826087, 0.98478260869565, 0.40909090909091
37928, 0.91304347826087, 0.98478260869565, 0.45454545454545
37929, 0.8695652173913, 0.98478260869565, 0.045454545454545
37930, 0.8695652173913, 0.98478260869565, 0.090909090909091
37931, 0.8695652173913, 0.98478260869565, 0.13636363636364
37932, 0.8695652173913, 0.98478260869565, 0.18181818181818
37933, 0.8695652173913, 0.98478260869565, 0.22727272727273
37934, 0.8695652173913, 0.98478260869565, 0.27272727272727
37935, 0.8695652173913, 0.98478260869565, 0.31818181818182
37936, 0.8695652173913, 0.98478260869565, 0.36363636363636
37937, 0.8695652173913, 0.98478260869565, 0.40909090909091
37938, 0.8695652173913, 0.98478260869565, 0.45454545454545
37939, 0.82608695652174, 0.98478260869565, 0.045454545454545
37940, 0.82608695652174, 0.98478260869565, 0.090909090909091
37941, 0.82608695652174, 0.98478260869565, 0.13636363636364
37942, 0.82608695652174, 0.98478260869565, 0.18181818181818
37943, 0.82608695652174, 0.98478260869565, 0.22727272727273
37944, 0.82608695652174, 0.98478260869565, 0.27272727272727
37945, 0.82608695652174, 0.98478260869565, 0.31818181818182
37946, 0.82608695652174, 0.98478260869565, 0.36363636363636
37947, 0.82608695652174, 0.98478260869565, 0.40909090909091
37948, 0.82608695652174, 0.98478260869565, 0.45454545454545
37949, 0.78260869565217, 0.98478260869565, 0.045454545454545
37950, 0.78260869565217, 0.98478260869565, 0.090909090909091
37951, 0.78260869565217, 0.98478260869565, 0.13636363636364
37952, 0.78260869565217, 0.98478260869565, 0.18181818181818
37953, 0.78260869565217, 0.98478260869565, 0.22727272727273
37954, 0.78260869565217, 0.98478260869565, 0.27272727272727
37955, 0.78260869565217, 0.98478260869565, 0.31818181818182
37956, 0.78260869565217, 0.98478260869565, 0.36363636363636
37957, 0.78260869565217, 0.98478260869565, 0.40909090909091
37958, 0.78260869565217, 0.98478260869565, 0.45454545454545
37959, 0.73913043478261, 0.98478260869565, 0.045454545454545
37960, 0.73913043478261, 0.98478260869565, 0.090909090909091
37961, 0.73913043478261, 0.98478260869565, 0.13636363636364
37962, 0.73913043478261, 0.98478260869565, 0.18181818181818
37963, 0.73913043478261, 0.98478260869565, 0.22727272727273
37964, 0.73913043478261, 0.98478260869565, 0.27272727272727
37965, 0.73913043478261, 0.98478260869565, 0.31818181818182
37966, 0.73913043478261, 0.98478260869565, 0.36363636363636
37967, 0.73913043478261, 0.98478260869565, 0.40909090909091
37968, 0.73913043478261, 0.98478260869565, 0.45454545454545
37969, 0.69565217391304, 0.98478260869565, 0.045454545454545
37970, 0.69565217391304, 0.98478260869565, 0.090909090909091
37971, 0.69565217391304, 0.98478260869565, 0.13636363636364
37972, 0.69565217391304, 0.98478260869565, 0.18181818181818
37973, 0.69565217391304, 0.98478260869565, 0.22727272727273
37974, 0.69565217391304, 0.98478260869565, 0.27272727272727
37975, 0.69565217391304, 0.98478260869565, 0.31818181818182
37976, 0.69565217391304, 0.98478260869565, 0.36363636363636
37977, 0.69565217391304, 0.98478260869565, 0.40909090909091
37978, 0.69565217391304, 0.98478260869565, 0.45454545454545
37979, 0.65217391304348, 0.98478260869565, 0.045454545454545
37980, 0.65217391304348, 0.98478260869565, 0.090909090909091
37981, 0.65217391304348, 0.98478260869565, 0.13636363636364
37982, 0.65217391304348, 0.98478260869565, 0.18181818181818
37983, 0.65217391304348, 0.98478260869565, 0.22727272727273
37984, 0.65217391304348, 0.98478260869565, 0.27272727272727
37985, 0.65217391304348, 0.98478260869565, 0.31818181818182
37986, 0.65217391304348, 0.98478260869565, 0.36363636363636
37987, 0.65217391304348, 0.98478260869565, 0.40909090909091
37988, 0.65217391304348, 0.98478260869565, 0.45454545454545
37989, 0.60869565217391, 0.98478260869565, 0.045454545454545
37990, 0.60869565217391, 0.98478260869565, 0.090909090909091
37991, 0.60869565217391, 0.98478260869565, 0.13636363636364
37992, 0.60869565217391, 0.98478260869565, 0.18181818181818
37993, 0.60869565217391, 0.98478260869565, 0.22727272727273
37994, 0.60869565217391, 0.98478260869565, 0.27272727272727
37995, 0.60869565217391, 0.98478260869565, 0.31818181818182
37996, 0.60869565217391, 0.98478260869565, 0.36363636363636
37997, 0.60869565217391, 0.98478260869565, 0.40909090909091
37998, 0.60869565217391, 0.98478260869565, 0.45454545454545
37999, 0.56521739130435, 0.98478260869565, 0.045454545454545
38000, 0.56521739130435, 0.98478260869565, 0.090909090909091
38001, 0.56521739130435, 0.98478260869565, 0.13636363636364
38002, 0.56521739130435, 0.98478260869565, 0.18181818181818
38003, 0.56521739130435, 0.98478260869565, 0.22727272727273
38004, 0.56521739130435, 0.98478260869565, 0.27272727272727
38005, 0.56521739130435, 0.98478260869565, 0.31818181818182
38006, 0.56521739130435, 0.98478260869565, 0.36363636363636
38007, 0.56521739130435, 0.98478260869565, 0.40909090909091
38008, 0.56521739130435, 0.98478260869565, 0.45454545454545
38009, 0.52173913043478, 0.98478260869565, 0.045454545454545
38010, 0.52173913043478, 0.98478260869565, 0.090909090909091
38011, 0.52173913043478, 0.98478260869565, 0.13636363636364
38012, 0.52173913043478, 0.98478260869565, 0.18181818181818
38013, 0.52173913043478, 0.98478260869565, 0.22727272727273
38014, 0.52173913043478, 0.98478260869565, 0.27272727272727
38015, 0.52173913043478, 0.98478260869565, 0.31818181818182
38016, 0.52173913043478, 0.98478260869565, 0.36363636363636
38017, 0.52173913043478, 0.98478260869565, 0.40909090909091
38018, 0.52173913043478, 0.98478260869565, 0.45454545454545
38019, 0.47826086956522, 0.98478260869565, 0.045454545454545
38020, 0.47826086956522, 0.98478260869565, 0.090909090909091
38021, 0.47826086956522, 0.98478260869565, 0.13636363636364
38022, 0.47826086956522, 0.98478260869565, 0.18181818181818
38023, 0.47826086956522, 0.98478260869565, 0.22727272727273
38024, 0.47826086956522, 0.98478260869565, 0.27272727272727
38025, 0.47826086956522, 0.98478260869565, 0.31818181818182
38026, 0.47826086956522, 0.98478260869565, 0.36363636363636
38027, 0.47826086956522, 0.98478260869565, 0.40909090909091
38028, 0.47826086956522, 0.98478260869565, 0.45454545454545
38029, 0.43478260869565, 0.98478260869565, 0.045454545454545
38030, 0.43478260869565, 0.98478260869565, 0.090909090909091
38031, 0.43478260869565, 0.98478260869565, 0.13636363636364
38032, 0.43478260869565, 0.98478260869565, 0.18181818181818
38033, 0.43478260869565, 0.98478260869565, 0.22727272727273
38034, 0.43478260869565, 0.98478260869565, 0.27272727272727
38035, 0.43478260869565, 0.98478260869565, 0.31818181818182
38036, 0.43478260869565, 0.98478260869565, 0.36363636363636
38037, 0.43478260869565, 0.98478260869565, 0.40909090909091
38038, 0.43478260869565, 0.98478260869565, 0.45454545454545
38039, 0.39130434782609, 0.98478260869565, 0.045454545454545
38040, 0.39130434782609, 0.98478260869565, 0.090909090909091
38041, 0.39130434782609, 0.98478260869565, 0.13636363636364
38042, 0.39130434782609, 0.98478260869565, 0.18181818181818
38043, 0.39130434782609, 0.98478260869565, 0.22727272727273
38044, 0.39130434782609, 0.98478260869565, 0.27272727272727
38045, 0.39130434782609, 0.98478260869565, 0.31818181818182
38046, 0.39130434782609, 0.98478260869565, 0.36363636363636
38047, 0.39130434782609, 0.98478260869565, 0.40909090909091
38048, 0.39130434782609, 0.98478260869565, 0.45454545454545
38049, 0.34782608695652, 0.98478260869565, 0.045454545454545
38050, 0.34782608695652, 0.98478260869565, 0.090909090909091
38051, 0.34782608695652, 0.98478260869565, 0.13636363636364
38052, 0.34782608695652, 0.98478260869565, 0.18181818181818
38053, 0.34782608695652, 0.98478260869565, 0.22727272727273
38054, 0.34782608695652, 0.98478260869565, 0.27272727272727
38055, 0.34782608695652, 0.98478260869565, 0.31818181818182
38056, 0.34782608695652, 0.98478260869565, 0.36363636363636
38057, 0.34782608695652, 0.98478260869565, 0.40909090909091
38058, 0.34782608695652, 0.98478260869565, 0.45454545454545
38059, 0.30434782608696, 0.98478260869565, 0.045454545454545
38060, 0.30434782608696, 0.98478260869565, 0.090909090909091
38061, 0.30434782608696, 0.98478260869565, 0.13636363636364
38062, 0.30434782608696, 0.98478260869565, 0.18181818181818
38063, 0.30434782608696, 0.98478260869565, 0.22727272727273
38064, 0.30434782608696, 0.98478260869565, 0.27272727272727
38065, 0.30434782608696, 0.98478260869565, 0.31818181818182
38066, 0.30434782608696, 0.98478260869565, 0.36363636363636
38067, 0.30434782608696, 0.98478260869565, 0.40909090909091
38068, 0.30434782608696, 0.98478260869565, 0.45454545454545
38069, 0.26086956521739, 0.98478260869565, 0.045454545454545
38070, 0.26086956521739, 0.98478260869565, 0.090909090909091
38071, 0.26086956521739, 0.98478260869565, 0.13636363636364
38072, 0.26086956521739, 0.98478260869565, 0.18181818181818
38073, 0.26086956521739, 0.98478260869565, 0.22727272727273
38074, 0.26086956521739, 0.98478260869565, 0.27272727272727
38075, 0.26086956521739, 0.98478260869565, 0.31818181818182
38076, 0.26086956521739, 0.98478260869565, 0.36363636363636
38077, 0.26086956521739, 0.98478260869565, 0.40909090909091
38078, 0.26086956521739, 0.98478260869565, 0.45454545454545
38079, 0.21739130434783, 0.98478260869565, 0.045454545454545
38080, 0.21739130434783, 0.98478260869565, 0.090909090909091
38081, 0.21739130434783, 0.98478260869565, 0.13636363636364
38082, 0.21739130434783, 0.98478260869565, 0.18181818181818
38083, 0.21739130434783, 0.98478260869565, 0.22727272727273
38084, 0.21739130434783, 0.98478260869565, 0.27272727272727
38085, 0.21739130434783, 0.98478260869565, 0.31818181818182
38086, 0.21739130434783, 0.98478260869565, 0.36363636363636
38087, 0.21739130434783, 0.98478260869565, 0.40909090909091
38088, 0.21739130434783, 0.98478260869565, 0.45454545454545
38089, 0.17391304347826, 0.98478260869565, 0.045454545454545
38090, 0.17391304347826, 0.98478260869565, 0.090909090909091
38091, 0.17391304347826, 0.98478260869565, 0.13636363636364
