60517, 1.2869565217391, 1.375, 0.18181818181818
60518, 1.2869565217391, 1.375, 0.13636363636364
60519, 1.2869565217391, 1.375, 0.090909090909091
60520, 1.2869565217391, 1.375, 0.045454545454545
60521, 1.3304347826087, 1.375, 0.45454545454545
60522, 1.3304347826087, 1.375, 0.40909090909091
60523, 1.3304347826087, 1.375, 0.36363636363636
60524, 1.3304347826087, 1.375, 0.31818181818182
60525, 1.3304347826087, 1.375, 0.27272727272727
60526, 1.3304347826087, 1.375, 0.22727272727273
60527, 1.3304347826087, 1.375, 0.18181818181818
60528, 1.3304347826087, 1.375, 0.13636363636364
60529, 1.3304347826087, 1.375, 0.090909090909091
60530, 1.3304347826087, 1.375, 0.045454545454545
60531, 1.3739130434783, 1.375, 0.45454545454545
60532, 1.3739130434783, 1.375, 0.40909090909091
60533, 1.3739130434783, 1.375, 0.36363636363636
60534, 1.3739130434783, 1.375, 0.31818181818182
60535, 1.3739130434783, 1.375, 0.27272727272727
60536, 1.3739130434783, 1.375, 0.22727272727273
60537, 1.3739130434783, 1.375, 0.18181818181818
60538, 1.3739130434783, 1.375, 0.13636363636364
60539, 1.3739130434783, 1.375, 0.090909090909091
60540, 1.3739130434783, 1.375, 0.045454545454545
60541, 1.4173913043478, 1.375, 0.45454545454545
60542, 1.4173913043478, 1.375, 0.40909090909091
60543, 1.4173913043478, 1.375, 0.36363636363636
60544, 1.4173913043478, 1.375, 0.31818181818182
60545, 1.4173913043478, 1.375, 0.27272727272727
60546, 1.4173913043478, 1.375, 0.22727272727273
60547, 1.4173913043478, 1.375, 0.18181818181818
60548, 1.4173913043478, 1.375, 0.13636363636364
60549, 1.4173913043478, 1.375, 0.090909090909091
60550, 1.4173913043478, 1.375, 0.045454545454545
60551, 1.4608695652174, 1.375, 0.45454545454545
60552, 1.4608695652174, 1.375, 0.40909090909091
60553, 1.4608695652174, 1.375, 0.36363636363636
60554, 1.4608695652174, 1.375, 0.31818181818182
60555, 1.4608695652174, 1.375, 0.27272727272727
60556, 1.4608695652174, 1.375, 0.22727272727273
60557, 1.4608695652174, 1.375, 0.18181818181818
60558, 1.4608695652174, 1.375, 0.13636363636364
60559, 1.4608695652174, 1.375, 0.090909090909091
60560, 1.4608695652174, 1.375, 0.045454545454545
60561, 1.504347826087, 1.375, 0.45454545454545
60562, 1.504347826087, 1.375, 0.40909090909091
60563, 1.504347826087, 1.375, 0.36363636363636
60564, 1.504347826087, 1.375, 0.31818181818182
60565, 1.504347826087, 1.375, 0.27272727272727
60566, 1.504347826087, 1.375, 0.22727272727273
60567, 1.504347826087, 1.375, 0.18181818181818
60568, 1.504347826087, 1.375, 0.13636363636364
60569, 1.504347826087, 1.375, 0.090909090909091
60570, 1.504347826087, 1.375, 0.045454545454545
60571, 1.5478260869565, 1.375, 0.45454545454545
60572, 1.5478260869565, 1.375, 0.40909090909091
60573, 1.5478260869565, 1.375, 0.36363636363636
60574, 1.5478260869565, 1.375, 0.31818181818182
60575, 1.5478260869565, 1.375, 0.27272727272727
60576, 1.5478260869565, 1.375, 0.22727272727273
60577, 1.5478260869565, 1.375, 0.18181818181818
60578, 1.5478260869565, 1.375, 0.13636363636364
60579, 1.5478260869565, 1.375, 0.090909090909091
60580, 1.5478260869565, 1.375, 0.045454545454545
60581, 1.5913043478261, 1.375, 0.45454545454545
60582, 1.5913043478261, 1.375, 0.40909090909091
60583, 1.5913043478261, 1.375, 0.36363636363636
60584, 1.5913043478261, 1.375, 0.31818181818182
60585, 1.5913043478261, 1.375, 0.27272727272727
60586, 1.5913043478261, 1.375, 0.22727272727273
60587, 1.5913043478261, 1.375, 0.18181818181818
60588, 1.5913043478261, 1.375, 0.13636363636364
60589, 1.5913043478261, 1.375, 0.090909090909091
60590, 1.5913043478261, 1.375, 0.045454545454545
60591, 1.6347826086957, 1.375, 0.45454545454545
60592, 1.6347826086957, 1.375, 0.40909090909091
60593, 1.6347826086957, 1.375, 0.36363636363636
60594, 1.6347826086957, 1.375, 0.31818181818182
60595, 1.6347826086957, 1.375, 0.27272727272727
60596, 1.6347826086957, 1.375, 0.22727272727273
60597, 1.6347826086957, 1.375, 0.18181818181818
60598, 1.6347826086957, 1.375, 0.13636363636364
60599, 1.6347826086957, 1.375, 0.090909090909091
60600, 1.6347826086957, 1.375, 0.045454545454545
60601, 1.6782608695652, 1.375, 0.45454545454545
60602, 1.6782608695652, 1.375, 0.40909090909091
60603, 1.6782608695652, 1.375, 0.36363636363636
60604, 1.6782608695652, 1.375, 0.31818181818182
60605, 1.6782608695652, 1.375, 0.27272727272727
60606, 1.6782608695652, 1.375, 0.22727272727273
60607, 1.6782608695652, 1.375, 0.18181818181818
60608, 1.6782608695652, 1.375, 0.13636363636364
60609, 1.6782608695652, 1.375, 0.090909090909091
60610, 1.6782608695652, 1.375, 0.045454545454545
60611, 1.7217391304348, 1.375, 0.45454545454545
60612, 1.7217391304348, 1.375, 0.40909090909091
60613, 1.7217391304348, 1.375, 0.36363636363636
60614, 1.7217391304348, 1.375, 0.31818181818182
60615, 1.7217391304348, 1.375, 0.27272727272727
60616, 1.7217391304348, 1.375, 0.22727272727273
60617, 1.7217391304348, 1.375, 0.18181818181818
60618, 1.7217391304348, 1.375, 0.13636363636364
60619, 1.7217391304348, 1.375, 0.090909090909091
60620, 1.7217391304348, 1.375, 0.045454545454545
60621, 1.7652173913043, 1.375, 0.45454545454545
60622, 1.7652173913043, 1.375, 0.40909090909091
60623, 1.7652173913043, 1.375, 0.36363636363636
60624, 1.7652173913043, 1.375, 0.31818181818182
60625, 1.7652173913043, 1.375, 0.27272727272727
60626, 1.7652173913043, 1.375, 0.22727272727273
60627, 1.7652173913043, 1.375, 0.18181818181818
60628, 1.7652173913043, 1.375, 0.13636363636364
60629, 1.7652173913043, 1.375, 0.090909090909091
60630, 1.7652173913043, 1.375, 0.045454545454545
60631, 1.8086956521739, 1.375, 0.45454545454545
60632, 1.8086956521739, 1.375, 0.40909090909091
60633, 1.8086956521739, 1.375, 0.36363636363636
60634, 1.8086956521739, 1.375, 0.31818181818182
60635, 1.8086956521739, 1.375, 0.27272727272727
60636, 1.8086956521739, 1.375, 0.22727272727273
60637, 1.8086956521739, 1.375, 0.18181818181818
60638, 1.8086956521739, 1.375, 0.13636363636364
60639, 1.8086956521739, 1.375, 0.090909090909091
60640, 1.8086956521739, 1.375, 0.045454545454545
60641, 1.8521739130435, 1.375, 0.45454545454545
60642, 1.8521739130435, 1.375, 0.40909090909091
60643, 1.8521739130435, 1.375, 0.36363636363636
60644, 1.8521739130435, 1.375, 0.31818181818182
60645, 1.8521739130435, 1.375, 0.27272727272727
60646, 1.8521739130435, 1.375, 0.22727272727273
60647, 1.8521739130435, 1.375, 0.18181818181818
60648, 1.8521739130435, 1.375, 0.13636363636364
60649, 1.8521739130435, 1.375, 0.090909090909091
60650, 1.8521739130435, 1.375, 0.045454545454545
60651, 1.895652173913, 1.375, 0.45454545454545
60652, 1.895652173913, 1.375, 0.40909090909091
60653, 1.895652173913, 1.375, 0.36363636363636
60654, 1.895652173913, 1.375, 0.31818181818182
60655, 1.895652173913, 1.375, 0.27272727272727
60656, 1.895652173913, 1.375, 0.22727272727273
60657, 1.895652173913, 1.375, 0.18181818181818
60658, 1.895652173913, 1.375, 0.13636363636364
60659, 1.895652173913, 1.375, 0.090909090909091
60660, 1.895652173913, 1.375, 0.045454545454545
60661, 1.9391304347826, 1.375, 0.45454545454545
60662, 1.9391304347826, 1.375, 0.40909090909091
60663, 1.9391304347826, 1.375, 0.36363636363636
60664, 1.9391304347826, 1.375, 0.31818181818182
60665, 1.9391304347826, 1.375, 0.27272727272727
60666, 1.9391304347826, 1.375, 0.22727272727273
60667, 1.9391304347826, 1.375, 0.18181818181818
60668, 1.9391304347826, 1.375, 0.13636363636364
60669, 1.9391304347826, 1.375, 0.090909090909091
60670, 1.9391304347826, 1.375, 0.045454545454545
60671, 1.9826086956522, 1.375, 0.45454545454545
60672, 1.9826086956522, 1.375, 0.40909090909091
60673, 1.9826086956522, 1.375, 0.36363636363636
60674, 1.9826086956522, 1.375, 0.31818181818182
60675, 1.9826086956522, 1.375, 0.27272727272727
60676, 1.9826086956522, 1.375, 0.22727272727273
60677, 1.9826086956522, 1.375, 0.18181818181818
60678, 1.9826086956522, 1.375, 0.13636363636364
60679, 1.9826086956522, 1.375, 0.090909090909091
60680, 1.9826086956522, 1.375, 0.045454545454545
60681, 2.0260869565217, 1.375, 0.45454545454545
60682, 2.0260869565217, 1.375, 0.40909090909091
60683, 2.0260869565217, 1.375, 0.36363636363636
60684, 2.0260869565217, 1.375, 0.31818181818182
60685, 2.0260869565217, 1.375, 0.27272727272727
60686, 2.0260869565217, 1.375, 0.22727272727273
60687, 2.0260869565217, 1.375, 0.18181818181818
60688, 2.0260869565217, 1.375, 0.13636363636364
60689, 2.0260869565217, 1.375, 0.090909090909091
60690, 2.0260869565217, 1.375, 0.045454545454545
60691, 2.0695652173913, 1.375, 0.45454545454545
60692, 2.0695652173913, 1.375, 0.40909090909091
60693, 2.0695652173913, 1.375, 0.36363636363636
60694, 2.0695652173913, 1.375, 0.31818181818182
60695, 2.0695652173913, 1.375, 0.27272727272727
60696, 2.0695652173913, 1.375, 0.22727272727273
60697, 2.0695652173913, 1.375, 0.18181818181818
60698, 2.0695652173913, 1.375, 0.13636363636364
60699, 2.0695652173913, 1.375, 0.090909090909091
60700, 2.0695652173913, 1.375, 0.045454545454545
60701, 2.1130434782609, 1.375, 0.45454545454545
60702, 2.1130434782609, 1.375, 0.40909090909091
60703, 2.1130434782609, 1.375, 0.36363636363636
60704, 2.1130434782609, 1.375, 0.31818181818182
60705, 2.1130434782609, 1.375, 0.27272727272727
60706, 2.1130434782609, 1.375, 0.22727272727273
60707, 2.1130434782609, 1.375, 0.18181818181818
60708, 2.1130434782609, 1.375, 0.13636363636364
60709, 2.1130434782609, 1.375, 0.090909090909091
60710, 2.1130434782609, 1.375, 0.045454545454545
60711, 2.1565217391304, 1.375, 0.45454545454545
60712, 2.1565217391304, 1.375, 0.40909090909091
60713, 2.1565217391304, 1.375, 0.36363636363636
60714, 2.1565217391304, 1.375, 0.31818181818182
60715, 2.1565217391304, 1.375, 0.27272727272727
60716, 2.1565217391304, 1.375, 0.22727272727273
60717, 2.1565217391304, 1.375, 0.18181818181818
60718, 2.1565217391304, 1.375, 0.13636363636364
60719, 2.1565217391304, 1.375, 0.090909090909091
60720, 2.1565217391304, 1.375, 0.045454545454545
60721, 1.2434782608696, 1.375, 0.47727272727273
60722, 1.2217391304348, 1.375, 0.45454545454545
60723, 1.2434782608696, 1.3875, 0.45454545454545
60724, 1.2434782608696, 1.375, 0.43181818181818
60725, 1.2217391304348, 1.375, 0.40909090909091
60726, 1.2434782608696, 1.3875, 0.40909090909091
60727, 1.2434782608696, 1.375, 0.38636363636364
60728, 1.2217391304348, 1.375, 0.36363636363636
60729, 1.2434782608696, 1.3875, 0.36363636363636
60730, 1.2434782608696, 1.375, 0.34090909090909
60731, 1.2217391304348, 1.375, 0.31818181818182
60732, 1.2434782608696, 1.3875, 0.31818181818182
60733, 1.2434782608696, 1.375, 0.29545454545455
60734, 1.2217391304348, 1.375, 0.27272727272727
60735, 1.2434782608696, 1.3875, 0.27272727272727
60736, 1.2434782608696, 1.375, 0.25
60737, 1.2217391304348, 1.375, 0.22727272727273
60738, 1.2434782608696, 1.3875, 0.22727272727273
60739, 1.2434782608696, 1.375, 0.20454545454545
60740, 1.2217391304348, 1.375, 0.18181818181818
60741, 1.2434782608696, 1.3875, 0.18181818181818
60742, 1.2434782608696, 1.375, 0.15909090909091
60743, 1.2217391304348, 1.375, 0.13636363636364
60744, 1.2434782608696, 1.3875, 0.13636363636364
60745, 1.2434782608696, 1.375, 0.11363636363636
60746, 1.2217391304348, 1.375, 0.090909090909091
60747, 1.2434782608696, 1.3875, 0.090909090909091
60748, 1.2434782608696, 1.375, 0.068181818181818
60749, 1.2217391304348, 1.375, 0.045454545454545
60750, 1.2434782608696, 1.3875, 0.045454545454545
60751, 1.2434782608696, 1.375, 0.022727272727273
60752, 1.2869565217391, 1.375, 0.47727272727273
60753, 1.2652173913043, 1.375, 0.45454545454545
60754, 1.2869565217391, 1.3875, 0.45454545454545
60755, 1.2869565217391, 1.375, 0.43181818181818
60756, 1.2652173913043, 1.375, 0.40909090909091
60757, 1.2869565217391, 1.3875, 0.40909090909091
60758, 1.2869565217391, 1.375, 0.38636363636364
60759, 1.2652173913043, 1.375, 0.36363636363636
60760, 1.2869565217391, 1.3875, 0.36363636363636
60761, 1.2869565217391, 1.375, 0.34090909090909
60762, 1.2652173913043, 1.375, 0.31818181818182
60763, 1.2869565217391, 1.3875, 0.31818181818182
60764, 1.2869565217391, 1.375, 0.29545454545455
60765, 1.2652173913043, 1.375, 0.27272727272727
60766, 1.2869565217391, 1.3875, 0.27272727272727
60767, 1.2869565217391, 1.375, 0.25
60768, 1.2652173913043, 1.375, 0.22727272727273
60769, 1.2869565217391, 1.3875, 0.22727272727273
60770, 1.2869565217391, 1.375, 0.20454545454545
60771, 1.2652173913043, 1.375, 0.18181818181818
60772, 1.2869565217391, 1.3875, 0.18181818181818
60773, 1.2869565217391, 1.375, 0.15909090909091
60774, 1.2652173913043, 1.375, 0.13636363636364
60775, 1.2869565217391, 1.3875, 0.13636363636364
60776, 1.2869565217391, 1.375, 0.11363636363636
60777, 1.2652173913043, 1.375, 0.090909090909091
60778, 1.2869565217391, 1.3875, 0.090909090909091
60779, 1.2869565217391, 1.375, 0.068181818181818
60780, 1.2652173913043, 1.375, 0.045454545454545
60781, 1.2869565217391, 1.3875, 0.045454545454545
60782, 1.2869565217391, 1.375, 0.022727272727273
60783, 1.3304347826087, 1.375, 0.47727272727273
60784, 1.3086956521739, 1.375, 0.45454545454545
60785, 1.3304347826087, 1.3875, 0.45454545454545
60786, 1.3304347826087, 1.375, 0.43181818181818
60787, 1.3086956521739, 1.375, 0.40909090909091
60788, 1.3304347826087, 1.3875, 0.40909090909091
60789, 1.3304347826087, 1.375, 0.38636363636364
60790, 1.3086956521739, 1.375, 0.36363636363636
60791, 1.3304347826087, 1.3875, 0.36363636363636
60792, 1.3304347826087, 1.375, 0.34090909090909
60793, 1.3086956521739, 1.375, 0.31818181818182
60794, 1.3304347826087, 1.3875, 0.31818181818182
60795, 1.3304347826087, 1.375, 0.29545454545455
60796, 1.3086956521739, 1.375, 0.27272727272727
60797, 1.3304347826087, 1.3875, 0.27272727272727
60798, 1.3304347826087, 1.375, 0.25
60799, 1.3086956521739, 1.375, 0.22727272727273
60800, 1.3304347826087, 1.3875, 0.22727272727273
60801, 1.3304347826087, 1.375, 0.20454545454545
60802, 1.3086956521739, 1.375, 0.18181818181818
60803, 1.3304347826087, 1.3875, 0.18181818181818
60804, 1.3304347826087, 1.375, 0.15909090909091
60805, 1.3086956521739, 1.375, 0.13636363636364
60806, 1.3304347826087, 1.3875, 0.13636363636364
60807, 1.3304347826087, 1.375, 0.11363636363636
60808, 1.3086956521739, 1.375, 0.090909090909091
60809, 1.3304347826087, 1.3875, 0.090909090909091
60810, 1.3304347826087, 1.375, 0.068181818181818
60811, 1.3086956521739, 1.375, 0.045454545454545
60812, 1.3304347826087, 1.3875, 0.045454545454545
60813, 1.3304347826087, 1.375, 0.022727272727273
60814, 1.3739130434783, 1.375, 0.47727272727273
60815, 1.3521739130435, 1.375, 0.45454545454545
60816, 1.3739130434783, 1.3875, 0.45454545454545
60817, 1.3739130434783, 1.375, 0.43181818181818
60818, 1.3521739130435, 1.375, 0.40909090909091
60819, 1.3739130434783, 1.3875, 0.40909090909091
60820, 1.3739130434783, 1.375, 0.38636363636364
60821, 1.3521739130435, 1.375, 0.36363636363636
60822, 1.3739130434783, 1.3875, 0.36363636363636
60823, 1.3739130434783, 1.375, 0.34090909090909
60824, 1.3521739130435, 1.375, 0.31818181818182
60825, 1.3739130434783, 1.3875, 0.31818181818182
60826, 1.3739130434783, 1.375, 0.29545454545455
60827, 1.3521739130435, 1.375, 0.27272727272727
60828, 1.3739130434783, 1.3875, 0.27272727272727
60829, 1.3739130434783, 1.375, 0.25
60830, 1.3521739130435, 1.375, 0.22727272727273
60831, 1.3739130434783, 1.3875, 0.22727272727273
60832, 1.3739130434783, 1.375, 0.20454545454545
60833, 1.3521739130435, 1.375, 0.18181818181818
60834, 1.3739130434783, 1.3875, 0.18181818181818
60835, 1.3739130434783, 1.375, 0.15909090909091
60836, 1.3521739130435, 1.375, 0.13636363636364
60837, 1.3739130434783, 1.3875, 0.13636363636364
60838, 1.3739130434783, 1.375, 0.11363636363636
60839, 1.3521739130435, 1.375, 0.090909090909091
60840, 1.3739130434783, 1.3875, 0.090909090909091
60841, 1.3739130434783, 1.375, 0.068181818181818
60842, 1.3521739130435, 1.375, 0.045454545454545
60843, 1.3739130434783, 1.3875, 0.045454545454545
60844, 1.3739130434783, 1.375, 0.022727272727273
60845, 1.4173913043478, 1.375, 0.47727272727273
60846, 1.395652173913, 1.375, 0.45454545454545
60847, 1.4173913043478, 1.3875, 0.45454545454545
60848, 1.4173913043478, 1.375, 0.43181818181818
60849, 1.395652173913, 1.375, 0.40909090909091
60850, 1.4173913043478, 1.3875, 0.40909090909091
60851, 1.4173913043478, 1.375, 0.38636363636364
60852, 1.395652173913, 1.375, 0.36363636363636
60853, 1.4173913043478, 1.3875, 0.36363636363636
60854, 1.4173913043478, 1.375, 0.34090909090909
60855, 1.395652173913, 1.375, 0.31818181818182
60856, 1.4173913043478, 1.3875, 0.31818181818182
60857, 1.4173913043478, 1.375, 0.29545454545455
60858, 1.395652173913, 1.375, 0.27272727272727
60859, 1.4173913043478, 1.3875, 0.27272727272727
60860, 1.4173913043478, 1.375, 0.25
60861, 1.395652173913, 1.375, 0.22727272727273
60862, 1.4173913043478, 1.3875, 0.22727272727273
60863, 1.4173913043478, 1.375, 0.20454545454545
60864, 1.395652173913, 1.375, 0.18181818181818
60865, 1.4173913043478, 1.3875, 0.18181818181818
60866, 1.4173913043478, 1.375, 0.15909090909091
60867, 1.395652173913, 1.375, 0.13636363636364
60868, 1.4173913043478, 1.3875, 0.13636363636364
60869, 1.4173913043478, 1.375, 0.11363636363636
60870, 1.395652173913, 1.375, 0.090909090909091
60871, 1.4173913043478, 1.3875, 0.090909090909091
60872, 1.4173913043478, 1.375, 0.068181818181818
60873, 1.395652173913, 1.375, 0.045454545454545
60874, 1.4173913043478, 1.3875, 0.045454545454545
60875, 1.4173913043478, 1.375, 0.022727272727273
60876, 1.4608695652174, 1.375, 0.47727272727273
60877, 1.4391304347826, 1.375, 0.45454545454545
60878, 1.4608695652174, 1.3875, 0.45454545454545
60879, 1.4608695652174, 1.375, 0.43181818181818
60880, 1.4391304347826, 1.375, 0.40909090909091
60881, 1.4608695652174, 1.3875, 0.40909090909091
60882, 1.4608695652174, 1.375, 0.38636363636364
60883, 1.4391304347826, 1.375, 0.36363636363636
60884, 1.4608695652174, 1.3875, 0.36363636363636
60885, 1.4608695652174, 1.375, 0.34090909090909
60886, 1.4391304347826, 1.375, 0.31818181818182
60887, 1.4608695652174, 1.3875, 0.31818181818182
60888, 1.4608695652174, 1.375, 0.29545454545455
60889, 1.4391304347826, 1.375, 0.27272727272727
60890, 1.4608695652174, 1.3875, 0.27272727272727
60891, 1.4608695652174, 1.375, 0.25
60892, 1.4391304347826, 1.375, 0.22727272727273
60893, 1.4608695652174, 1.3875, 0.22727272727273
60894, 1.4608695652174, 1.375, 0.20454545454545
60895, 1.4391304347826, 1.375, 0.18181818181818
60896, 1.4608695652174, 1.3875, 0.18181818181818
60897, 1.4608695652174, 1.375, 0.15909090909091
60898, 1.4391304347826, 1.375, 0.13636363636364
60899, 1.4608695652174, 1.3875, 0.13636363636364
60900, 1.4608695652174, 1.375, 0.11363636363636
60901, 1.4391304347826, 1.375, 0.090909090909091
60902, 1.4608695652174, 1.3875, 0.090909090909091
60903, 1.4608695652174, 1.375, 0.068181818181818
60904, 1.4391304347826, 1.375, 0.045454545454545
60905, 1.4608695652174, 1.3875, 0.045454545454545
60906, 1.4608695652174, 1.375, 0.022727272727273
60907, 1.504347826087, 1.375, 0.47727272727273
60908, 1.4826086956522, 1.375, 0.45454545454545
60909, 1.504347826087, 1.3875, 0.45454545454545
60910, 1.504347826087, 1.375, 0.43181818181818
60911, 1.4826086956522, 1.375, 0.40909090909091
60912, 1.504347826087, 1.3875, 0.40909090909091
60913, 1.504347826087, 1.375, 0.38636363636364
60914, 1.4826086956522, 1.375, 0.36363636363636
60915, 1.504347826087, 1.3875, 0.36363636363636
60916, 1.504347826087, 1.375, 0.34090909090909
60917, 1.4826086956522, 1.375, 0.31818181818182
60918, 1.504347826087, 1.3875, 0.31818181818182
60919, 1.504347826087, 1.375, 0.29545454545455
60920, 1.4826086956522, 1.375, 0.27272727272727
60921, 1.504347826087, 1.3875, 0.27272727272727
60922, 1.504347826087, 1.375, 0.25
60923, 1.4826086956522, 1.375, 0.22727272727273
60924, 1.504347826087, 1.3875, 0.22727272727273
60925, 1.504347826087, 1.375, 0.20454545454545
60926, 1.4826086956522, 1.375, 0.18181818181818
60927, 1.504347826087, 1.3875, 0.18181818181818
60928, 1.504347826087, 1.375, 0.15909090909091
60929, 1.4826086956522, 1.375, 0.13636363636364
60930, 1.504347826087, 1.3875, 0.13636363636364
60931, 1.504347826087, 1.375, 0.11363636363636
60932, 1.4826086956522, 1.375, 0.090909090909091
60933, 1.504347826087, 1.3875, 0.090909090909091
60934, 1.504347826087, 1.375, 0.068181818181818
60935, 1.4826086956522, 1.375, 0.045454545454545
60936, 1.504347826087, 1.3875, 0.045454545454545
60937, 1.504347826087, 1.375, 0.022727272727273
60938, 1.5478260869565, 1.375, 0.47727272727273
60939, 1.5260869565217, 1.375, 0.45454545454545
60940, 1.5478260869565, 1.3875, 0.45454545454545
60941, 1.5478260869565, 1.375, 0.43181818181818
60942, 1.5260869565217, 1.375, 0.40909090909091
60943, 1.5478260869565, 1.3875, 0.40909090909091
60944, 1.5478260869565, 1.375, 0.38636363636364
60945, 1.5260869565217, 1.375, 0.36363636363636
60946, 1.5478260869565, 1.3875, 0.36363636363636
60947, 1.5478260869565, 1.375, 0.34090909090909
60948, 1.5260869565217, 1.375, 0.31818181818182
60949, 1.5478260869565, 1.3875, 0.31818181818182
60950, 1.5478260869565, 1.375, 0.29545454545455
60951, 1.5260869565217, 1.375, 0.27272727272727
60952, 1.5478260869565, 1.3875, 0.27272727272727
60953, 1.5478260869565, 1.375, 0.25
60954, 1.5260869565217, 1.375, 0.22727272727273
60955, 1.5478260869565, 1.3875, 0.22727272727273
60956, 1.5478260869565, 1.375, 0.20454545454545
60957, 1.5260869565217, 1.375, 0.18181818181818
60958, 1.5478260869565, 1.3875, 0.18181818181818
60959, 1.5478260869565, 1.375, 0.15909090909091
60960, 1.5260869565217, 1.375, 0.13636363636364
60961, 1.5478260869565, 1.3875, 0.13636363636364
60962, 1.5478260869565, 1.375, 0.11363636363636
60963, 1.5260869565217, 1.375, 0.090909090909091
60964, 1.5478260869565, 1.3875, 0.090909090909091
60965, 1.5478260869565, 1.375, 0.068181818181818
60966, 1.5260869565217, 1.375, 0.045454545454545
60967, 1.5478260869565, 1.3875, 0.045454545454545
60968, 1.5478260869565, 1.375, 0.022727272727273
60969, 1.5913043478261, 1.375, 0.47727272727273
60970, 1.5695652173913, 1.375, 0.45454545454545
60971, 1.5913043478261, 1.3875, 0.45454545454545
60972, 1.5913043478261, 1.375, 0.43181818181818
60973, 1.5695652173913, 1.375, 0.40909090909091
60974, 1.5913043478261, 1.3875, 0.40909090909091
60975, 1.5913043478261, 1.375, 0.38636363636364
60976, 1.5695652173913, 1.375, 0.36363636363636
60977, 1.5913043478261, 1.3875, 0.36363636363636
60978, 1.5913043478261, 1.375, 0.34090909090909
60979, 1.5695652173913, 1.375, 0.31818181818182
60980, 1.5913043478261, 1.3875, 0.31818181818182
60981, 1.5913043478261, 1.375, 0.29545454545455
60982, 1.5695652173913, 1.375, 0.27272727272727
60983, 1.5913043478261, 1.3875, 0.27272727272727
60984, 1.5913043478261, 1.375, 0.25
60985, 1.5695652173913, 1.375, 0.22727272727273
60986, 1.5913043478261, 1.3875, 0.22727272727273
60987, 1.5913043478261, 1.375, 0.20454545454545
60988, 1.5695652173913, 1.375, 0.18181818181818
60989, 1.5913043478261, 1.3875, 0.18181818181818
60990, 1.5913043478261, 1.375, 0.15909090909091
60991, 1.5695652173913, 1.375, 0.13636363636364
60992, 1.5913043478261, 1.3875, 0.13636363636364
60993, 1.5913043478261, 1.375, 0.11363636363636
60994, 1.5695652173913, 1.375, 0.090909090909091
60995, 1.5913043478261, 1.3875, 0.090909090909091
60996, 1.5913043478261, 1.375, 0.068181818181818
60997, 1.5695652173913, 1.375, 0.045454545454545
60998, 1.5913043478261, 1.3875, 0.045454545454545
60999, 1.5913043478261, 1.375, 0.022727272727273
61000, 1.6347826086957, 1.375, 0.47727272727273
61001, 1.6130434782609, 1.375, 0.45454545454545
61002, 1.6347826086957, 1.3875, 0.45454545454545
61003, 1.6347826086957, 1.375, 0.43181818181818
61004, 1.6130434782609, 1.375, 0.40909090909091
61005, 1.6347826086957, 1.3875, 0.40909090909091
61006, 1.6347826086957, 1.375, 0.38636363636364
61007, 1.6130434782609, 1.375, 0.36363636363636
61008, 1.6347826086957, 1.3875, 0.36363636363636
61009, 1.6347826086957, 1.375, 0.34090909090909
61010, 1.6130434782609, 1.375, 0.31818181818182
61011, 1.6347826086957, 1.3875, 0.31818181818182
61012, 1.6347826086957, 1.375, 0.29545454545455
61013, 1.6130434782609, 1.375, 0.27272727272727
61014, 1.6347826086957, 1.3875, 0.27272727272727
61015, 1.6347826086957, 1.375, 0.25
61016, 1.6130434782609, 1.375, 0.22727272727273
61017, 1.6347826086957, 1.3875, 0.22727272727273
61018, 1.6347826086957, 1.375, 0.20454545454545
61019, 1.6130434782609, 1.375, 0.18181818181818
61020, 1.6347826086957, 1.3875, 0.18181818181818
61021, 1.6347826086957, 1.375, 0.15909090909091
61022, 1.6130434782609, 1.375, 0.13636363636364
61023, 1.6347826086957, 1.3875, 0.13636363636364
61024, 1.6347826086957, 1.375, 0.11363636363636
61025, 1.6130434782609, 1.375, 0.090909090909091
61026, 1.6347826086957, 1.3875, 0.090909090909091
61027, 1.6347826086957, 1.375, 0.068181818181818
61028, 1.6130434782609, 1.375, 0.045454545454545
61029, 1.6347826086957, 1.3875, 0.045454545454545
61030, 1.6347826086957, 1.375, 0.022727272727273
61031, 1.6782608695652, 1.375, 0.47727272727273
61032, 1.6565217391304, 1.375, 0.45454545454545
61033, 1.6782608695652, 1.3875, 0.45454545454545
61034, 1.6782608695652, 1.375, 0.43181818181818
61035, 1.6565217391304, 1.375, 0.40909090909091
61036, 1.6782608695652, 1.3875, 0.40909090909091
61037, 1.6782608695652, 1.375, 0.38636363636364
61038, 1.6565217391304, 1.375, 0.36363636363636
61039, 1.6782608695652, 1.3875, 0.36363636363636
61040, 1.6782608695652, 1.375, 0.34090909090909
61041, 1.6565217391304, 1.375, 0.31818181818182
61042, 1.6782608695652, 1.3875, 0.31818181818182
61043, 1.6782608695652, 1.375, 0.29545454545455
61044, 1.6565217391304, 1.375, 0.27272727272727
61045, 1.6782608695652, 1.3875, 0.27272727272727
61046, 1.6782608695652, 1.375, 0.25
61047, 1.6565217391304, 1.375, 0.22727272727273
61048, 1.6782608695652, 1.3875, 0.22727272727273
61049, 1.6782608695652, 1.375, 0.20454545454545
61050, 1.6565217391304, 1.375, 0.18181818181818
61051, 1.6782608695652, 1.3875, 0.18181818181818
61052, 1.6782608695652, 1.375, 0.15909090909091
61053, 1.6565217391304, 1.375, 0.13636363636364
61054, 1.6782608695652, 1.3875, 0.13636363636364
61055, 1.6782608695652, 1.375, 0.11363636363636
61056, 1.6565217391304, 1.375, 0.090909090909091
61057, 1.6782608695652, 1.3875, 0.090909090909091
61058, 1.6782608695652, 1.375, 0.068181818181818
61059, 1.6565217391304, 1.375, 0.045454545454545
61060, 1.6782608695652, 1.3875, 0.045454545454545
61061, 1.6782608695652, 1.375, 0.022727272727273
61062, 1.7217391304348, 1.375, 0.47727272727273
61063, 1.7, 1.375, 0.45454545454545
61064, 1.7217391304348, 1.3875, 0.45454545454545
61065, 1.7217391304348, 1.375, 0.43181818181818
61066, 1.7, 1.375, 0.40909090909091
61067, 1.7217391304348, 1.3875, 0.40909090909091
61068, 1.7217391304348, 1.375, 0.38636363636364
61069, 1.7, 1.375, 0.36363636363636
61070, 1.7217391304348, 1.3875, 0.36363636363636
61071, 1.7217391304348, 1.375, 0.34090909090909
61072, 1.7, 1.375, 0.31818181818182
61073, 1.7217391304348, 1.3875, 0.31818181818182
61074, 1.7217391304348, 1.375, 0.29545454545455
61075, 1.7, 1.375, 0.27272727272727
61076, 1.7217391304348, 1.3875, 0.27272727272727
61077, 1.7217391304348, 1.375, 0.25
61078, 1.7, 1.375, 0.22727272727273
61079, 1.7217391304348, 1.3875, 0.22727272727273
61080, 1.7217391304348, 1.375, 0.20454545454545
61081, 1.7, 1.375, 0.18181818181818
61082, 1.7217391304348, 1.3875, 0.18181818181818
61083, 1.7217391304348, 1.375, 0.15909090909091
61084, 1.7, 1.375, 0.13636363636364
61085, 1.7217391304348, 1.3875, 0.13636363636364
61086, 1.7217391304348, 1.375, 0.11363636363636
61087, 1.7, 1.375, 0.090909090909091
61088, 1.7217391304348, 1.3875, 0.090909090909091
61089, 1.7217391304348, 1.375, 0.068181818181818
61090, 1.7, 1.375, 0.045454545454545
61091, 1.7217391304348, 1.3875, 0.045454545454545
61092, 1.7217391304348, 1.375, 0.022727272727273
61093, 1.7652173913043, 1.375, 0.47727272727273
61094, 1.7434782608696, 1.375, 0.45454545454545
61095, 1.7652173913043, 1.3875, 0.45454545454545
61096, 1.7652173913043, 1.375, 0.43181818181818
61097, 1.7434782608696, 1.375, 0.40909090909091
61098, 1.7652173913043, 1.3875, 0.40909090909091
61099, 1.7652173913043, 1.375, 0.38636363636364
61100, 1.7434782608696, 1.375, 0.36363636363636
61101, 1.7652173913043, 1.3875, 0.36363636363636
61102, 1.7652173913043, 1.375, 0.34090909090909
61103, 1.7434782608696, 1.375, 0.31818181818182
61104, 1.7652173913043, 1.3875, 0.31818181818182
61105, 1.7652173913043, 1.375, 0.29545454545455
61106, 1.7434782608696, 1.375, 0.27272727272727
61107, 1.7652173913043, 1.3875, 0.27272727272727
61108, 1.7652173913043, 1.375, 0.25
61109, 1.7434782608696, 1.375, 0.22727272727273
61110, 1.7652173913043, 1.3875, 0.22727272727273
61111, 1.7652173913043, 1.375, 0.20454545454545
61112, 1.7434782608696, 1.375, 0.18181818181818
61113, 1.7652173913043, 1.3875, 0.18181818181818
61114, 1.7652173913043, 1.375, 0.15909090909091
61115, 1.7434782608696, 1.375, 0.13636363636364
61116, 1.7652173913043, 1.3875, 0.13636363636364
61117, 1.7652173913043, 1.375, 0.11363636363636
61118, 1.7434782608696, 1.375, 0.090909090909091
61119, 1.7652173913043, 1.3875, 0.090909090909091
61120, 1.7652173913043, 1.375, 0.068181818181818
61121, 1.7434782608696, 1.375, 0.045454545454545
61122, 1.7652173913043, 1.3875, 0.045454545454545
61123, 1.7652173913043, 1.375, 0.022727272727273
61124, 1.8086956521739, 1.375, 0.47727272727273
61125, 1.7869565217391, 1.375, 0.45454545454545
61126, 1.8086956521739, 1.3875, 0.45454545454545
61127, 1.8086956521739, 1.375, 0.43181818181818
61128, 1.7869565217391, 1.375, 0.40909090909091
61129, 1.8086956521739, 1.3875, 0.40909090909091
61130, 1.8086956521739, 1.375, 0.38636363636364
61131, 1.7869565217391, 1.375, 0.36363636363636
61132, 1.8086956521739, 1.3875, 0.36363636363636
61133, 1.8086956521739, 1.375, 0.34090909090909
61134, 1.7869565217391, 1.375, 0.31818181818182
61135, 1.8086956521739, 1.3875, 0.31818181818182
61136, 1.8086956521739, 1.375, 0.29545454545455
61137, 1.7869565217391, 1.375, 0.27272727272727
61138, 1.8086956521739, 1.3875, 0.27272727272727
61139, 1.8086956521739, 1.375, 0.25
61140, 1.7869565217391, 1.375, 0.22727272727273
61141, 1.8086956521739, 1.3875, 0.22727272727273
61142, 1.8086956521739, 1.375, 0.20454545454545
61143, 1.7869565217391, 1.375, 0.18181818181818
61144, 1.8086956521739, 1.3875, 0.18181818181818
61145, 1.8086956521739, 1.375, 0.15909090909091
61146, 1.7869565217391, 1.375, 0.13636363636364
61147, 1.8086956521739, 1.3875, 0.13636363636364
61148, 1.8086956521739, 1.375, 0.11363636363636
61149, 1.7869565217391, 1.375, 0.090909090909091
61150, 1.8086956521739, 1.3875, 0.090909090909091
61151, 1.8086956521739, 1.375, 0.068181818181818
61152, 1.7869565217391, 1.375, 0.045454545454545
61153, 1.8086956521739, 1.3875, 0.045454545454545
61154, 1.8086956521739, 1.375, 0.022727272727273
61155, 1.8521739130435, 1.375, 0.47727272727273
61156, 1.8304347826087, 1.375, 0.45454545454545
61157, 1.8521739130435, 1.3875, 0.45454545454545
61158, 1.8521739130435, 1.375, 0.43181818181818
61159, 1.8304347826087, 1.375, 0.40909090909091
61160, 1.8521739130435, 1.3875, 0.40909090909091
61161, 1.8521739130435, 1.375, 0.38636363636364
61162, 1.8304347826087, 1.375, 0.36363636363636
61163, 1.8521739130435, 1.3875, 0.36363636363636
61164, 1.8521739130435, 1.375, 0.34090909090909
61165, 1.8304347826087, 1.375, 0.31818181818182
61166, 1.8521739130435, 1.3875, 0.31818181818182
61167, 1.8521739130435, 1.375, 0.29545454545455
61168, 1.8304347826087, 1.375, 0.27272727272727
61169, 1.8521739130435, 1.3875, 0.27272727272727
61170, 1.8521739130435, 1.375, 0.25
61171, 1.8304347826087, 1.375, 0.22727272727273
61172, 1.8521739130435, 1.3875, 0.22727272727273
61173, 1.8521739130435, 1.375, 0.20454545454545
61174, 1.8304347826087, 1.375, 0.18181818181818
61175, 1.8521739130435, 1.3875, 0.18181818181818
61176, 1.8521739130435, 1.375, 0.15909090909091
61177, 1.8304347826087, 1.375, 0.13636363636364
61178, 1.8521739130435, 1.3875, 0.13636363636364
61179, 1.8521739130435, 1.375, 0.11363636363636
61180, 1.8304347826087, 1.375, 0.090909090909091
61181, 1.8521739130435, 1.3875, 0.090909090909091
61182, 1.8521739130435, 1.375, 0.068181818181818
61183, 1.8304347826087, 1.375, 0.045454545454545
61184, 1.8521739130435, 1.3875, 0.045454545454545
61185, 1.8521739130435, 1.375, 0.022727272727273
61186, 1.895652173913, 1.375, 0.47727272727273
61187, 1.8739130434783, 1.375, 0.45454545454545
61188, 1.895652173913, 1.3875, 0.45454545454545
61189, 1.895652173913, 1.375, 0.43181818181818
61190, 1.8739130434783, 1.375, 0.40909090909091
61191, 1.895652173913, 1.3875, 0.40909090909091
61192, 1.895652173913, 1.375, 0.38636363636364
61193, 1.8739130434783, 1.375, 0.36363636363636
61194, 1.895652173913, 1.3875, 0.36363636363636
61195, 1.895652173913, 1.375, 0.34090909090909
61196, 1.8739130434783, 1.375, 0.31818181818182
61197, 1.895652173913, 1.3875, 0.31818181818182
61198, 1.895652173913, 1.375, 0.29545454545455
61199, 1.8739130434783, 1.375, 0.27272727272727
61200, 1.895652173913, 1.3875, 0.27272727272727
61201, 1.895652173913, 1.375, 0.25
61202, 1.8739130434783, 1.375, 0.22727272727273
61203, 1.895652173913, 1.3875, 0.22727272727273
61204, 1.895652173913, 1.375, 0.20454545454545
61205, 1.8739130434783, 1.375, 0.18181818181818
61206, 1.895652173913, 1.3875, 0.18181818181818
61207, 1.895652173913, 1.375, 0.15909090909091
61208, 1.8739130434783, 1.375, 0.13636363636364
61209, 1.895652173913, 1.3875, 0.13636363636364
61210, 1.895652173913, 1.375, 0.11363636363636
61211, 1.8739130434783, 1.375, 0.090909090909091
61212, 1.895652173913, 1.3875, 0.090909090909091
61213, 1.895652173913, 1.375, 0.068181818181818
61214, 1.8739130434783, 1.375, 0.045454545454545
61215, 1.895652173913, 1.3875, 0.045454545454545
61216, 1.895652173913, 1.375, 0.022727272727273
61217, 1.9391304347826, 1.375, 0.47727272727273
61218, 1.9173913043478, 1.375, 0.45454545454545
61219, 1.9391304347826, 1.3875, 0.45454545454545
61220, 1.9391304347826, 1.375, 0.43181818181818
61221, 1.9173913043478, 1.375, 0.40909090909091
61222, 1.9391304347826, 1.3875, 0.40909090909091
61223, 1.9391304347826, 1.375, 0.38636363636364
61224, 1.9173913043478, 1.375, 0.36363636363636
61225, 1.9391304347826, 1.3875, 0.36363636363636
61226, 1.9391304347826, 1.375, 0.34090909090909
61227, 1.9173913043478, 1.375, 0.31818181818182
61228, 1.9391304347826, 1.3875, 0.31818181818182
61229, 1.9391304347826, 1.375, 0.29545454545455
61230, 1.9173913043478, 1.375, 0.27272727272727
61231, 1.9391304347826, 1.3875, 0.27272727272727
61232, 1.9391304347826, 1.375, 0.25
61233, 1.9173913043478, 1.375, 0.22727272727273
61234, 1.9391304347826, 1.3875, 0.22727272727273
61235, 1.9391304347826, 1.375, 0.20454545454545
61236, 1.9173913043478, 1.375, 0.18181818181818
61237, 1.9391304347826, 1.3875, 0.18181818181818
61238, 1.9391304347826, 1.375, 0.15909090909091
61239, 1.9173913043478, 1.375, 0.13636363636364
61240, 1.9391304347826, 1.3875, 0.13636363636364
61241, 1.9391304347826, 1.375, 0.11363636363636
61242, 1.9173913043478, 1.375, 0.090909090909091
61243, 1.9391304347826, 1.3875, 0.090909090909091
61244, 1.9391304347826, 1.375, 0.068181818181818
61245, 1.9173913043478, 1.375, 0.045454545454545
61246, 1.9391304347826, 1.3875, 0.045454545454545
61247, 1.9391304347826, 1.375, 0.022727272727273
61248, 1.9826086956522, 1.375, 0.47727272727273
61249, 1.9608695652174, 1.375, 0.45454545454545
61250, 1.9826086956522, 1.3875, 0.45454545454545
61251, 1.9826086956522, 1.375, 0.43181818181818
61252, 1.9608695652174, 1.375, 0.40909090909091
61253, 1.9826086956522, 1.3875, 0.40909090909091
61254, 1.9826086956522, 1.375, 0.38636363636364
61255, 1.9608695652174, 1.375, 0.36363636363636
61256, 1.9826086956522, 1.3875, 0.36363636363636
61257, 1.9826086956522, 1.375, 0.34090909090909
61258, 1.9608695652174, 1.375, 0.31818181818182
61259, 1.9826086956522, 1.3875, 0.31818181818182
61260, 1.9826086956522, 1.375, 0.29545454545455
61261, 1.9608695652174, 1.375, 0.27272727272727
61262, 1.9826086956522, 1.3875, 0.27272727272727
61263, 1.9826086956522, 1.375, 0.25
61264, 1.9608695652174, 1.375, 0.22727272727273
61265, 1.9826086956522, 1.3875, 0.22727272727273
61266, 1.9826086956522, 1.375, 0.20454545454545
61267, 1.9608695652174, 1.375, 0.18181818181818
61268, 1.9826086956522, 1.3875, 0.18181818181818
61269, 1.9826086956522, 1.375, 0.15909090909091
61270, 1.9608695652174, 1.375, 0.13636363636364
61271, 1.9826086956522, 1.3875, 0.13636363636364
61272, 1.9826086956522, 1.375, 0.11363636363636
61273, 1.9608695652174, 1.375, 0.090909090909091
61274, 1.9826086956522, 1.3875, 0.090909090909091
61275, 1.9826086956522, 1.375, 0.068181818181818
61276, 1.9608695652174, 1.375, 0.045454545454545
61277, 1.9826086956522, 1.3875, 0.045454545454545
61278, 1.9826086956522, 1.375, 0.022727272727273
61279, 2.0260869565217, 1.375, 0.47727272727273
61280, 2.004347826087, 1.375, 0.45454545454545
61281, 2.0260869565217, 1.3875, 0.45454545454545
61282, 2.0260869565217, 1.375, 0.43181818181818
61283, 2.004347826087, 1.375, 0.40909090909091
61284, 2.0260869565217, 1.3875, 0.40909090909091
61285, 2.0260869565217, 1.375, 0.38636363636364
61286, 2.004347826087, 1.375, 0.36363636363636
61287, 2.0260869565217, 1.3875, 0.36363636363636
61288, 2.0260869565217, 1.375, 0.34090909090909
61289, 2.004347826087, 1.375, 0.31818181818182
61290, 2.0260869565217, 1.3875, 0.31818181818182
61291, 2.0260869565217, 1.375, 0.29545454545455
61292, 2.004347826087, 1.375, 0.27272727272727
61293, 2.0260869565217, 1.3875, 0.27272727272727
61294, 2.0260869565217, 1.375, 0.25
61295, 2.004347826087, 1.375, 0.22727272727273
61296, 2.0260869565217, 1.3875, 0.22727272727273
61297, 2.0260869565217, 1.375, 0.20454545454545
61298, 2.004347826087, 1.375, 0.18181818181818
61299, 2.0260869565217, 1.3875, 0.18181818181818
61300, 2.0260869565217, 1.375, 0.15909090909091
61301, 2.004347826087, 1.375, 0.13636363636364
61302, 2.0260869565217, 1.3875, 0.13636363636364
61303, 2.0260869565217, 1.375, 0.11363636363636
61304, 2.004347826087, 1.375, 0.090909090909091
61305, 2.0260869565217, 1.3875, 0.090909090909091
61306, 2.0260869565217, 1.375, 0.068181818181818
61307, 2.004347826087, 1.375, 0.045454545454545
61308, 2.0260869565217, 1.3875, 0.045454545454545
61309, 2.0260869565217, 1.375, 0.022727272727273
61310, 2.0695652173913, 1.375, 0.47727272727273
61311, 2.0478260869565, 1.375, 0.45454545454545
61312, 2.0695652173913, 1.3875, 0.45454545454545
61313, 2.0695652173913, 1.375, 0.43181818181818
61314, 2.0478260869565, 1.375, 0.40909090909091
61315, 2.0695652173913, 1.3875, 0.40909090909091
61316, 2.0695652173913, 1.375, 0.38636363636364
61317, 2.0478260869565, 1.375, 0.36363636363636
61318, 2.0695652173913, 1.3875, 0.36363636363636
61319, 2.0695652173913, 1.375, 0.34090909090909
61320, 2.0478260869565, 1.375, 0.31818181818182
61321, 2.0695652173913, 1.3875, 0.31818181818182
61322, 2.0695652173913, 1.375, 0.29545454545455
61323, 2.0478260869565, 1.375, 0.27272727272727
61324, 2.0695652173913, 1.3875, 0.27272727272727
61325, 2.0695652173913, 1.375, 0.25
61326, 2.0478260869565, 1.375, 0.22727272727273
61327, 2.0695652173913, 1.3875, 0.22727272727273
61328, 2.0695652173913, 1.375, 0.20454545454545
61329, 2.0478260869565, 1.375, 0.18181818181818
61330, 2.0695652173913, 1.3875, 0.18181818181818
61331, 2.0695652173913, 1.375, 0.15909090909091
61332, 2.0478260869565, 1.375, 0.13636363636364
61333, 2.0695652173913, 1.3875, 0.13636363636364
61334, 2.0695652173913, 1.375, 0.11363636363636
61335, 2.0478260869565, 1.375, 0.090909090909091
61336, 2.0695652173913, 1.3875, 0.090909090909091
61337, 2.0695652173913, 1.375, 0.068181818181818
61338, 2.0478260869565, 1.375, 0.045454545454545
61339, 2.0695652173913, 1.3875, 0.045454545454545
61340, 2.0695652173913, 1.375, 0.022727272727273
61341, 2.1130434782609, 1.375, 0.47727272727273
61342, 2.0913043478261, 1.375, 0.45454545454545
61343, 2.1130434782609, 1.3875, 0.45454545454545
61344, 2.1130434782609, 1.375, 0.43181818181818
61345, 2.0913043478261, 1.375, 0.40909090909091
61346, 2.1130434782609, 1.3875, 0.40909090909091
61347, 2.1130434782609, 1.375, 0.38636363636364
61348, 2.0913043478261, 1.375, 0.36363636363636
61349, 2.1130434782609, 1.3875, 0.36363636363636
61350, 2.1130434782609, 1.375, 0.34090909090909
61351, 2.0913043478261, 1.375, 0.31818181818182
61352, 2.1130434782609, 1.3875, 0.31818181818182
61353, 2.1130434782609, 1.375, 0.29545454545455
61354, 2.0913043478261, 1.375, 0.27272727272727
61355, 2.1130434782609, 1.3875, 0.27272727272727
61356, 2.1130434782609, 1.375, 0.25
61357, 2.0913043478261, 1.375, 0.22727272727273
61358, 2.1130434782609, 1.3875, 0.22727272727273
61359, 2.1130434782609, 1.375, 0.20454545454545
61360, 2.0913043478261, 1.375, 0.18181818181818
61361, 2.1130434782609, 1.3875, 0.18181818181818
61362, 2.1130434782609, 1.375, 0.15909090909091
61363, 2.0913043478261, 1.375, 0.13636363636364
61364, 2.1130434782609, 1.3875, 0.13636363636364
61365, 2.1130434782609, 1.375, 0.11363636363636
61366, 2.0913043478261, 1.375, 0.090909090909091
61367, 2.1130434782609, 1.3875, 0.090909090909091
61368, 2.1130434782609, 1.375, 0.068181818181818
61369, 2.0913043478261, 1.375, 0.045454545454545
61370, 2.1130434782609, 1.3875, 0.045454545454545
61371, 2.1130434782609, 1.375, 0.022727272727273
61372, 2.1565217391304, 1.375, 0.47727272727273
61373, 2.1347826086957, 1.375, 0.45454545454545
61374, 2.1565217391304, 1.3875, 0.45454545454545
61375, 2.1565217391304, 1.375, 0.43181818181818
61376, 2.1347826086957, 1.375, 0.40909090909091
61377, 2.1565217391304, 1.3875, 0.40909090909091
61378, 2.1565217391304, 1.375, 0.38636363636364
61379, 2.1347826086957, 1.375, 0.36363636363636
61380, 2.1565217391304, 1.3875, 0.36363636363636
61381, 2.1565217391304, 1.375, 0.34090909090909
61382, 2.1347826086957, 1.375, 0.31818181818182
61383, 2.1565217391304, 1.3875, 0.31818181818182
61384, 2.1565217391304, 1.375, 0.29545454545455
61385, 2.1347826086957, 1.375, 0.27272727272727
61386, 2.1565217391304, 1.3875, 0.27272727272727
61387, 2.1565217391304, 1.375, 0.25
61388, 2.1347826086957, 1.375, 0.22727272727273
61389, 2.1565217391304, 1.3875, 0.22727272727273
61390, 2.1565217391304, 1.375, 0.20454545454545
61391, 2.1347826086957, 1.375, 0.18181818181818
61392, 2.1565217391304, 1.3875, 0.18181818181818
61393, 2.1565217391304, 1.375, 0.15909090909091
61394, 2.1347826086957, 1.375, 0.13636363636364
61395, 2.1565217391304, 1.3875, 0.13636363636364
61396, 2.1565217391304, 1.375, 0.11363636363636
61397, 2.1347826086957, 1.375, 0.090909090909091
61398, 2.1565217391304, 1.3875, 0.090909090909091
61399, 2.1565217391304, 1.375, 0.068181818181818
61400, 2.1347826086957, 1.375, 0.045454545454545
61401, 2.1565217391304, 1.3875, 0.045454545454545
61402, 2.1565217391304, 1.375, 0.022727272727273
61403, 2.1782608695652, 1.375, 0.45454545454545
61404, 2.1782608695652, 1.375, 0.40909090909091
61405, 2.1782608695652, 1.375, 0.36363636363636
61406, 2.1782608695652, 1.375, 0.31818181818182
61407, 2.1782608695652, 1.375, 0.27272727272727
61408, 2.1782608695652, 1.375, 0.22727272727273
61409, 2.1782608695652, 1.375, 0.18181818181818
61410, 2.1782608695652, 1.375, 0.13636363636364
61411, 2.1782608695652, 1.375, 0.090909090909091
61412, 2.1782608695652, 1.375, 0.045454545454545
61413, 1.2434782608696, 1.3625, 0.45454545454545
61414, 1.2434782608696, 1.3625, 0.40909090909091
61415, 1.2434782608696, 1.3625, 0.36363636363636
61416, 1.2434782608696, 1.3625, 0.31818181818182
61417, 1.2434782608696, 1.3625, 0.27272727272727
61418, 1.2434782608696, 1.3625, 0.22727272727273
61419, 1.2434782608696, 1.3625, 0.18181818181818
61420, 1.2434782608696, 1.3625, 0.13636363636364
61421, 1.2434782608696, 1.3625, 0.090909090909091
61422, 1.2434782608696, 1.3625, 0.045454545454545
61423, 1.2869565217391, 1.3625, 0.45454545454545
61424, 1.2869565217391, 1.3625, 0.40909090909091
61425, 1.2869565217391, 1.3625, 0.36363636363636
61426, 1.2869565217391, 1.3625, 0.31818181818182
61427, 1.2869565217391, 1.3625, 0.27272727272727
61428, 1.2869565217391, 1.3625, 0.22727272727273
61429, 1.2869565217391, 1.3625, 0.18181818181818
61430, 1.2869565217391, 1.3625, 0.13636363636364
61431, 1.2869565217391, 1.3625, 0.090909090909091
61432, 1.2869565217391, 1.3625, 0.045454545454545
61433, 1.3304347826087, 1.3625, 0.45454545454545
61434, 1.3304347826087, 1.3625, 0.40909090909091
61435, 1.3304347826087, 1.3625, 0.36363636363636
61436, 1.3304347826087, 1.3625, 0.31818181818182
61437, 1.3304347826087, 1.3625, 0.27272727272727
61438, 1.3304347826087, 1.3625, 0.22727272727273
61439, 1.3304347826087, 1.3625, 0.18181818181818
61440, 1.3304347826087, 1.3625, 0.13636363636364
61441, 1.3304347826087, 1.3625, 0.090909090909091
61442, 1.3304347826087, 1.3625, 0.045454545454545
61443, 1.3739130434783, 1.3625, 0.45454545454545
61444, 1.3739130434783, 1.3625, 0.40909090909091
61445, 1.3739130434783, 1.3625, 0.36363636363636
61446, 1.3739130434783, 1.3625, 0.31818181818182
61447, 1.3739130434783, 1.3625, 0.27272727272727
61448, 1.3739130434783, 1.3625, 0.22727272727273
61449, 1.3739130434783, 1.3625, 0.18181818181818
61450, 1.3739130434783, 1.3625, 0.13636363636364
61451, 1.3739130434783, 1.3625, 0.090909090909091
61452, 1.3739130434783, 1.3625, 0.045454545454545
61453, 1.4173913043478, 1.3625, 0.45454545454545
61454, 1.4173913043478, 1.3625, 0.40909090909091
61455, 1.4173913043478, 1.3625, 0.36363636363636
61456, 1.4173913043478, 1.3625, 0.31818181818182
61457, 1.4173913043478, 1.3625, 0.27272727272727
61458, 1.4173913043478, 1.3625, 0.22727272727273
61459, 1.4173913043478, 1.3625, 0.18181818181818
61460, 1.4173913043478, 1.3625, 0.13636363636364
61461, 1.4173913043478, 1.3625, 0.090909090909091
61462, 1.4173913043478, 1.3625, 0.045454545454545
61463, 1.4608695652174, 1.3625, 0.45454545454545
61464, 1.4608695652174, 1.3625, 0.40909090909091
61465, 1.4608695652174, 1.3625, 0.36363636363636
61466, 1.4608695652174, 1.3625, 0.31818181818182
61467, 1.4608695652174, 1.3625, 0.27272727272727
61468, 1.4608695652174, 1.3625, 0.22727272727273
61469, 1.4608695652174, 1.3625, 0.18181818181818
61470, 1.4608695652174, 1.3625, 0.13636363636364
61471, 1.4608695652174, 1.3625, 0.090909090909091
61472, 1.4608695652174, 1.3625, 0.045454545454545
61473, 1.504347826087, 1.3625, 0.45454545454545
61474, 1.504347826087, 1.3625, 0.40909090909091
61475, 1.504347826087, 1.3625, 0.36363636363636
61476, 1.504347826087, 1.3625, 0.31818181818182
61477, 1.504347826087, 1.3625, 0.27272727272727
61478, 1.504347826087, 1.3625, 0.22727272727273
61479, 1.504347826087, 1.3625, 0.18181818181818
61480, 1.504347826087, 1.3625, 0.13636363636364
61481, 1.504347826087, 1.3625, 0.090909090909091
61482, 1.504347826087, 1.3625, 0.045454545454545
61483, 1.5478260869565, 1.3625, 0.45454545454545
61484, 1.5478260869565, 1.3625, 0.40909090909091
61485, 1.5478260869565, 1.3625, 0.36363636363636
61486, 1.5478260869565, 1.3625, 0.31818181818182
61487, 1.5478260869565, 1.3625, 0.27272727272727
61488, 1.5478260869565, 1.3625, 0.22727272727273
61489, 1.5478260869565, 1.3625, 0.18181818181818
61490, 1.5478260869565, 1.3625, 0.13636363636364
61491, 1.5478260869565, 1.3625, 0.090909090909091
61492, 1.5478260869565, 1.3625, 0.045454545454545
61493, 1.5913043478261, 1.3625, 0.45454545454545
61494, 1.5913043478261, 1.3625, 0.40909090909091
61495, 1.5913043478261, 1.3625, 0.36363636363636
61496, 1.5913043478261, 1.3625, 0.31818181818182
61497, 1.5913043478261, 1.3625, 0.27272727272727
61498, 1.5913043478261, 1.3625, 0.22727272727273
61499, 1.5913043478261, 1.3625, 0.18181818181818
61500, 1.5913043478261, 1.3625, 0.13636363636364
61501, 1.5913043478261, 1.3625, 0.090909090909091
61502, 1.5913043478261, 1.3625, 0.045454545454545
61503, 1.6347826086957, 1.3625, 0.45454545454545
61504, 1.6347826086957, 1.3625, 0.40909090909091
61505, 1.6347826086957, 1.3625, 0.36363636363636
61506, 1.6347826086957, 1.3625, 0.31818181818182
61507, 1.6347826086957, 1.3625, 0.27272727272727
61508, 1.6347826086957, 1.3625, 0.22727272727273
61509, 1.6347826086957, 1.3625, 0.18181818181818
61510, 1.6347826086957, 1.3625, 0.13636363636364
61511, 1.6347826086957, 1.3625, 0.090909090909091
61512, 1.6347826086957, 1.3625, 0.045454545454545
61513, 1.6782608695652, 1.3625, 0.45454545454545
61514, 1.6782608695652, 1.3625, 0.40909090909091
61515, 1.6782608695652, 1.3625, 0.36363636363636
61516, 1.6782608695652, 1.3625, 0.31818181818182
61517, 1.6782608695652, 1.3625, 0.27272727272727
61518, 1.6782608695652, 1.3625, 0.22727272727273
61519, 1.6782608695652, 1.3625, 0.18181818181818
61520, 1.6782608695652, 1.3625, 0.13636363636364
61521, 1.6782608695652, 1.3625, 0.090909090909091
61522, 1.6782608695652, 1.3625, 0.045454545454545
61523, 1.7217391304348, 1.3625, 0.45454545454545
61524, 1.7217391304348, 1.3625, 0.40909090909091
61525, 1.7217391304348, 1.3625, 0.36363636363636
61526, 1.7217391304348, 1.3625, 0.31818181818182
61527, 1.7217391304348, 1.3625, 0.27272727272727
61528, 1.7217391304348, 1.3625, 0.22727272727273
61529, 1.7217391304348, 1.3625, 0.18181818181818
61530, 1.7217391304348, 1.3625, 0.13636363636364
61531, 1.7217391304348, 1.3625, 0.090909090909091
61532, 1.7217391304348, 1.3625, 0.045454545454545
61533, 1.7652173913043, 1.3625, 0.45454545454545
61534, 1.7652173913043, 1.3625, 0.40909090909091
61535, 1.7652173913043, 1.3625, 0.36363636363636
61536, 1.7652173913043, 1.3625, 0.31818181818182
61537, 1.7652173913043, 1.3625, 0.27272727272727
61538, 1.7652173913043, 1.3625, 0.22727272727273
61539, 1.7652173913043, 1.3625, 0.18181818181818
61540, 1.7652173913043, 1.3625, 0.13636363636364
61541, 1.7652173913043, 1.3625, 0.090909090909091
61542, 1.7652173913043, 1.3625, 0.045454545454545
61543, 1.8086956521739, 1.3625, 0.45454545454545
61544, 1.8086956521739, 1.3625, 0.40909090909091
61545, 1.8086956521739, 1.3625, 0.36363636363636
61546, 1.8086956521739, 1.3625, 0.31818181818182
61547, 1.8086956521739, 1.3625, 0.27272727272727
61548, 1.8086956521739, 1.3625, 0.22727272727273
61549, 1.8086956521739, 1.3625, 0.18181818181818
61550, 1.8086956521739, 1.3625, 0.13636363636364
61551, 1.8086956521739, 1.3625, 0.090909090909091
61552, 1.8086956521739, 1.3625, 0.045454545454545
61553, 1.8521739130435, 1.3625, 0.45454545454545
61554, 1.8521739130435, 1.3625, 0.40909090909091
61555, 1.8521739130435, 1.3625, 0.36363636363636
61556, 1.8521739130435, 1.3625, 0.31818181818182
61557, 1.8521739130435, 1.3625, 0.27272727272727
61558, 1.8521739130435, 1.3625, 0.22727272727273
61559, 1.8521739130435, 1.3625, 0.18181818181818
61560, 1.8521739130435, 1.3625, 0.13636363636364
61561, 1.8521739130435, 1.3625, 0.090909090909091
61562, 1.8521739130435, 1.3625, 0.045454545454545
61563, 1.895652173913, 1.3625, 0.45454545454545
61564, 1.895652173913, 1.3625, 0.40909090909091
61565, 1.895652173913, 1.3625, 0.36363636363636
61566, 1.895652173913, 1.3625, 0.31818181818182
61567, 1.895652173913, 1.3625, 0.27272727272727
61568, 1.895652173913, 1.3625, 0.22727272727273
61569, 1.895652173913, 1.3625, 0.18181818181818
61570, 1.895652173913, 1.3625, 0.13636363636364
61571, 1.895652173913, 1.3625, 0.090909090909091
61572, 1.895652173913, 1.3625, 0.045454545454545
61573, 1.9391304347826, 1.3625, 0.45454545454545
61574, 1.9391304347826, 1.3625, 0.40909090909091
61575, 1.9391304347826, 1.3625, 0.36363636363636
61576, 1.9391304347826, 1.3625, 0.31818181818182
61577, 1.9391304347826, 1.3625, 0.27272727272727
61578, 1.9391304347826, 1.3625, 0.22727272727273
61579, 1.9391304347826, 1.3625, 0.18181818181818
61580, 1.9391304347826, 1.3625, 0.13636363636364
61581, 1.9391304347826, 1.3625, 0.090909090909091
61582, 1.9391304347826, 1.3625, 0.045454545454545
61583, 1.9826086956522, 1.3625, 0.45454545454545
61584, 1.9826086956522, 1.3625, 0.40909090909091
61585, 1.9826086956522, 1.3625, 0.36363636363636
61586, 1.9826086956522, 1.3625, 0.31818181818182
61587, 1.9826086956522, 1.3625, 0.27272727272727
61588, 1.9826086956522, 1.3625, 0.22727272727273
61589, 1.9826086956522, 1.3625, 0.18181818181818
61590, 1.9826086956522, 1.3625, 0.13636363636364
61591, 1.9826086956522, 1.3625, 0.090909090909091
61592, 1.9826086956522, 1.3625, 0.045454545454545
61593, 2.0260869565217, 1.3625, 0.45454545454545
61594, 2.0260869565217, 1.3625, 0.40909090909091
61595, 2.0260869565217, 1.3625, 0.36363636363636
61596, 2.0260869565217, 1.3625, 0.31818181818182
61597, 2.0260869565217, 1.3625, 0.27272727272727
61598, 2.0260869565217, 1.3625, 0.22727272727273
61599, 2.0260869565217, 1.3625, 0.18181818181818
61600, 2.0260869565217, 1.3625, 0.13636363636364
61601, 2.0260869565217, 1.3625, 0.090909090909091
61602, 2.0260869565217, 1.3625, 0.045454545454545
61603, 2.0695652173913, 1.3625, 0.45454545454545
61604, 2.0695652173913, 1.3625, 0.40909090909091
61605, 2.0695652173913, 1.3625, 0.36363636363636
61606, 2.0695652173913, 1.3625, 0.31818181818182
61607, 2.0695652173913, 1.3625, 0.27272727272727
61608, 2.0695652173913, 1.3625, 0.22727272727273
61609, 2.0695652173913, 1.3625, 0.18181818181818
61610, 2.0695652173913, 1.3625, 0.13636363636364
61611, 2.0695652173913, 1.3625, 0.090909090909091
61612, 2.0695652173913, 1.3625, 0.045454545454545
61613, 2.1130434782609, 1.3625, 0.45454545454545
61614, 2.1130434782609, 1.3625, 0.40909090909091
61615, 2.1130434782609, 1.3625, 0.36363636363636
61616, 2.1130434782609, 1.3625, 0.31818181818182
61617, 2.1130434782609, 1.3625, 0.27272727272727
61618, 2.1130434782609, 1.3625, 0.22727272727273
61619, 2.1130434782609, 1.3625, 0.18181818181818
61620, 2.1130434782609, 1.3625, 0.13636363636364
61621, 2.1130434782609, 1.3625, 0.090909090909091
61622, 2.1130434782609, 1.3625, 0.045454545454545
61623, 2.1565217391304, 1.3625, 0.45454545454545
61624, 2.1565217391304, 1.3625, 0.40909090909091
61625, 2.1565217391304, 1.3625, 0.36363636363636
61626, 2.1565217391304, 1.3625, 0.31818181818182
61627, 2.1565217391304, 1.3625, 0.27272727272727
61628, 2.1565217391304, 1.3625, 0.22727272727273
61629, 2.1565217391304, 1.3625, 0.18181818181818
61630, 2.1565217391304, 1.3625, 0.13636363636364
61631, 2.1565217391304, 1.3625, 0.090909090909091
61632, 2.1565217391304, 1.3625, 0.045454545454545
61633, 1.2434782608696, 1.2978260869565, 0.45454545454545
61634, 1.2434782608696, 1.2978260869565, 0.40909090909091
61635, 1.2434782608696, 1.2978260869565, 0.36363636363636
61636, 1.2434782608696, 1.2978260869565, 0.31818181818182
61637, 1.2434782608696, 1.2978260869565, 0.27272727272727
61638, 1.2434782608696, 1.2978260869565, 0.22727272727273
61639, 1.2434782608696, 1.2978260869565, 0.18181818181818
61640, 1.2434782608696, 1.2978260869565, 0.13636363636364
61641, 1.2434782608696, 1.2978260869565, 0.090909090909091
61642, 1.2434782608696, 1.2978260869565, 0.045454545454545
61643, 1.2869565217391, 1.2978260869565, 0.45454545454545
61644, 1.2869565217391, 1.2978260869565, 0.40909090909091
61645, 1.2869565217391, 1.2978260869565, 0.36363636363636
61646, 1.2869565217391, 1.2978260869565, 0.31818181818182
61647, 1.2869565217391, 1.2978260869565, 0.27272727272727
61648, 1.2869565217391, 1.2978260869565, 0.22727272727273
61649, 1.2869565217391, 1.2978260869565, 0.18181818181818
61650, 1.2869565217391, 1.2978260869565, 0.13636363636364
61651, 1.2869565217391, 1.2978260869565, 0.090909090909091
61652, 1.2869565217391, 1.2978260869565, 0.045454545454545
61653, 1.3304347826087, 1.2978260869565, 0.45454545454545
61654, 1.3304347826087, 1.2978260869565, 0.40909090909091
61655, 1.3304347826087, 1.2978260869565, 0.36363636363636
61656, 1.3304347826087, 1.2978260869565, 0.31818181818182
61657, 1.3304347826087, 1.2978260869565, 0.27272727272727
61658, 1.3304347826087, 1.2978260869565, 0.22727272727273
61659, 1.3304347826087, 1.2978260869565, 0.18181818181818
61660, 1.3304347826087, 1.2978260869565, 0.13636363636364
61661, 1.3304347826087, 1.2978260869565, 0.090909090909091
61662, 1.3304347826087, 1.2978260869565, 0.045454545454545
61663, 1.3739130434783, 1.2978260869565, 0.45454545454545
61664, 1.3739130434783, 1.2978260869565, 0.40909090909091
61665, 1.3739130434783, 1.2978260869565, 0.36363636363636
61666, 1.3739130434783, 1.2978260869565, 0.31818181818182
61667, 1.3739130434783, 1.2978260869565, 0.27272727272727
61668, 1.3739130434783, 1.2978260869565, 0.22727272727273
61669, 1.3739130434783, 1.2978260869565, 0.18181818181818
61670, 1.3739130434783, 1.2978260869565, 0.13636363636364
61671, 1.3739130434783, 1.2978260869565, 0.090909090909091
61672, 1.3739130434783, 1.2978260869565, 0.045454545454545
61673, 1.4173913043478, 1.2978260869565, 0.45454545454545
61674, 1.4173913043478, 1.2978260869565, 0.40909090909091
61675, 1.4173913043478, 1.2978260869565, 0.36363636363636
61676, 1.4173913043478, 1.2978260869565, 0.31818181818182
61677, 1.4173913043478, 1.2978260869565, 0.27272727272727
61678, 1.4173913043478, 1.2978260869565, 0.22727272727273
61679, 1.4173913043478, 1.2978260869565, 0.18181818181818
61680, 1.4173913043478, 1.2978260869565, 0.13636363636364
61681, 1.4173913043478, 1.2978260869565, 0.090909090909091
61682, 1.4173913043478, 1.2978260869565, 0.045454545454545
61683, 1.4608695652174, 1.2978260869565, 0.45454545454545
61684, 1.4608695652174, 1.2978260869565, 0.40909090909091
61685, 1.4608695652174, 1.2978260869565, 0.36363636363636
61686, 1.4608695652174, 1.2978260869565, 0.31818181818182
61687, 1.4608695652174, 1.2978260869565, 0.27272727272727
61688, 1.4608695652174, 1.2978260869565, 0.22727272727273
61689, 1.4608695652174, 1.2978260869565, 0.18181818181818
61690, 1.4608695652174, 1.2978260869565, 0.13636363636364
61691, 1.4608695652174, 1.2978260869565, 0.090909090909091
61692, 1.4608695652174, 1.2978260869565, 0.045454545454545
61693, 1.504347826087, 1.2978260869565, 0.45454545454545
61694, 1.504347826087, 1.2978260869565, 0.40909090909091
61695, 1.504347826087, 1.2978260869565, 0.36363636363636
61696, 1.504347826087, 1.2978260869565, 0.31818181818182
61697, 1.504347826087, 1.2978260869565, 0.27272727272727
61698, 1.504347826087, 1.2978260869565, 0.22727272727273
61699, 1.504347826087, 1.2978260869565, 0.18181818181818
61700, 1.504347826087, 1.2978260869565, 0.13636363636364
61701, 1.504347826087, 1.2978260869565, 0.090909090909091
61702, 1.504347826087, 1.2978260869565, 0.045454545454545
61703, 1.5478260869565, 1.2978260869565, 0.45454545454545
61704, 1.5478260869565, 1.2978260869565, 0.40909090909091
61705, 1.5478260869565, 1.2978260869565, 0.36363636363636
61706, 1.5478260869565, 1.2978260869565, 0.31818181818182
61707, 1.5478260869565, 1.2978260869565, 0.27272727272727
61708, 1.5478260869565, 1.2978260869565, 0.22727272727273
61709, 1.5478260869565, 1.2978260869565, 0.18181818181818
61710, 1.5478260869565, 1.2978260869565, 0.13636363636364
61711, 1.5478260869565, 1.2978260869565, 0.090909090909091
61712, 1.5478260869565, 1.2978260869565, 0.045454545454545
61713, 1.5913043478261, 1.2978260869565, 0.45454545454545
61714, 1.5913043478261, 1.2978260869565, 0.40909090909091
61715, 1.5913043478261, 1.2978260869565, 0.36363636363636
61716, 1.5913043478261, 1.2978260869565, 0.31818181818182
61717, 1.5913043478261, 1.2978260869565, 0.27272727272727
61718, 1.5913043478261, 1.2978260869565, 0.22727272727273
61719, 1.5913043478261, 1.2978260869565, 0.18181818181818
61720, 1.5913043478261, 1.2978260869565, 0.13636363636364
61721, 1.5913043478261, 1.2978260869565, 0.090909090909091
61722, 1.5913043478261, 1.2978260869565, 0.045454545454545
61723, 1.6347826086957, 1.2978260869565, 0.45454545454545
61724, 1.6347826086957, 1.2978260869565, 0.40909090909091
61725, 1.6347826086957, 1.2978260869565, 0.36363636363636
61726, 1.6347826086957, 1.2978260869565, 0.31818181818182
61727, 1.6347826086957, 1.2978260869565, 0.27272727272727
61728, 1.6347826086957, 1.2978260869565, 0.22727272727273
61729, 1.6347826086957, 1.2978260869565, 0.18181818181818
61730, 1.6347826086957, 1.2978260869565, 0.13636363636364
61731, 1.6347826086957, 1.2978260869565, 0.090909090909091
61732, 1.6347826086957, 1.2978260869565, 0.045454545454545
61733, 1.6782608695652, 1.2978260869565, 0.45454545454545
61734, 1.6782608695652, 1.2978260869565, 0.40909090909091
61735, 1.6782608695652, 1.2978260869565, 0.36363636363636
61736, 1.6782608695652, 1.2978260869565, 0.31818181818182
61737, 1.6782608695652, 1.2978260869565, 0.27272727272727
61738, 1.6782608695652, 1.2978260869565, 0.22727272727273
61739, 1.6782608695652, 1.2978260869565, 0.18181818181818
61740, 1.6782608695652, 1.2978260869565, 0.13636363636364
61741, 1.6782608695652, 1.2978260869565, 0.090909090909091
61742, 1.6782608695652, 1.2978260869565, 0.045454545454545
61743, 1.7217391304348, 1.2978260869565, 0.45454545454545
61744, 1.7217391304348, 1.2978260869565, 0.40909090909091
61745, 1.7217391304348, 1.2978260869565, 0.36363636363636
61746, 1.7217391304348, 1.2978260869565, 0.31818181818182
61747, 1.7217391304348, 1.2978260869565, 0.27272727272727
61748, 1.7217391304348, 1.2978260869565, 0.22727272727273
61749, 1.7217391304348, 1.2978260869565, 0.18181818181818
61750, 1.7217391304348, 1.2978260869565, 0.13636363636364
61751, 1.7217391304348, 1.2978260869565, 0.090909090909091
61752, 1.7217391304348, 1.2978260869565, 0.045454545454545
61753, 1.7652173913043, 1.2978260869565, 0.45454545454545
61754, 1.7652173913043, 1.2978260869565, 0.40909090909091
61755, 1.7652173913043, 1.2978260869565, 0.36363636363636
61756, 1.7652173913043, 1.2978260869565, 0.31818181818182
61757, 1.7652173913043, 1.2978260869565, 0.27272727272727
61758, 1.7652173913043, 1.2978260869565, 0.22727272727273
61759, 1.7652173913043, 1.2978260869565, 0.18181818181818
61760, 1.7652173913043, 1.2978260869565, 0.13636363636364
61761, 1.7652173913043, 1.2978260869565, 0.090909090909091
61762, 1.7652173913043, 1.2978260869565, 0.045454545454545
61763, 1.8086956521739, 1.2978260869565, 0.45454545454545
61764, 1.8086956521739, 1.2978260869565, 0.40909090909091
61765, 1.8086956521739, 1.2978260869565, 0.36363636363636
61766, 1.8086956521739, 1.2978260869565, 0.31818181818182
61767, 1.8086956521739, 1.2978260869565, 0.27272727272727
61768, 1.8086956521739, 1.2978260869565, 0.22727272727273
61769, 1.8086956521739, 1.2978260869565, 0.18181818181818
61770, 1.8086956521739, 1.2978260869565, 0.13636363636364
61771, 1.8086956521739, 1.2978260869565, 0.090909090909091
61772, 1.8086956521739, 1.2978260869565, 0.045454545454545
61773, 1.8521739130435, 1.2978260869565, 0.45454545454545
61774, 1.8521739130435, 1.2978260869565, 0.40909090909091
61775, 1.8521739130435, 1.2978260869565, 0.36363636363636
61776, 1.8521739130435, 1.2978260869565, 0.31818181818182
61777, 1.8521739130435, 1.2978260869565, 0.27272727272727
61778, 1.8521739130435, 1.2978260869565, 0.22727272727273
61779, 1.8521739130435, 1.2978260869565, 0.18181818181818
61780, 1.8521739130435, 1.2978260869565, 0.13636363636364
61781, 1.8521739130435, 1.2978260869565, 0.090909090909091
61782, 1.8521739130435, 1.2978260869565, 0.045454545454545
61783, 1.895652173913, 1.2978260869565, 0.45454545454545
61784, 1.895652173913, 1.2978260869565, 0.40909090909091
61785, 1.895652173913, 1.2978260869565, 0.36363636363636
61786, 1.895652173913, 1.2978260869565, 0.31818181818182
61787, 1.895652173913, 1.2978260869565, 0.27272727272727
61788, 1.895652173913, 1.2978260869565, 0.22727272727273
61789, 1.895652173913, 1.2978260869565, 0.18181818181818
61790, 1.895652173913, 1.2978260869565, 0.13636363636364
61791, 1.895652173913, 1.2978260869565, 0.090909090909091
61792, 1.895652173913, 1.2978260869565, 0.045454545454545
61793, 1.9391304347826, 1.2978260869565, 0.45454545454545
61794, 1.9391304347826, 1.2978260869565, 0.40909090909091
61795, 1.9391304347826, 1.2978260869565, 0.36363636363636
61796, 1.9391304347826, 1.2978260869565, 0.31818181818182
61797, 1.9391304347826, 1.2978260869565, 0.27272727272727
61798, 1.9391304347826, 1.2978260869565, 0.22727272727273
61799, 1.9391304347826, 1.2978260869565, 0.18181818181818
61800, 1.9391304347826, 1.2978260869565, 0.13636363636364
61801, 1.9391304347826, 1.2978260869565, 0.090909090909091
61802, 1.9391304347826, 1.2978260869565, 0.045454545454545
61803, 1.9826086956522, 1.2978260869565, 0.45454545454545
61804, 1.9826086956522, 1.2978260869565, 0.40909090909091
61805, 1.9826086956522, 1.2978260869565, 0.36363636363636
61806, 1.9826086956522, 1.2978260869565, 0.31818181818182
61807, 1.9826086956522, 1.2978260869565, 0.27272727272727
61808, 1.9826086956522, 1.2978260869565, 0.22727272727273
61809, 1.9826086956522, 1.2978260869565, 0.18181818181818
61810, 1.9826086956522, 1.2978260869565, 0.13636363636364
61811, 1.9826086956522, 1.2978260869565, 0.090909090909091
61812, 1.9826086956522, 1.2978260869565, 0.045454545454545
61813, 2.0260869565217, 1.2978260869565, 0.45454545454545
61814, 2.0260869565217, 1.2978260869565, 0.40909090909091
61815, 2.0260869565217, 1.2978260869565, 0.36363636363636
61816, 2.0260869565217, 1.2978260869565, 0.31818181818182
61817, 2.0260869565217, 1.2978260869565, 0.27272727272727
61818, 2.0260869565217, 1.2978260869565, 0.22727272727273
61819, 2.0260869565217, 1.2978260869565, 0.18181818181818
61820, 2.0260869565217, 1.2978260869565, 0.13636363636364
61821, 2.0260869565217, 1.2978260869565, 0.090909090909091
61822, 2.0260869565217, 1.2978260869565, 0.045454545454545
61823, 2.0695652173913, 1.2978260869565, 0.45454545454545
61824, 2.0695652173913, 1.2978260869565, 0.40909090909091
61825, 2.0695652173913, 1.2978260869565, 0.36363636363636
61826, 2.0695652173913, 1.2978260869565, 0.31818181818182
61827, 2.0695652173913, 1.2978260869565, 0.27272727272727
61828, 2.0695652173913, 1.2978260869565, 0.22727272727273
61829, 2.0695652173913, 1.2978260869565, 0.18181818181818
61830, 2.0695652173913, 1.2978260869565, 0.13636363636364
61831, 2.0695652173913, 1.2978260869565, 0.090909090909091
61832, 2.0695652173913, 1.2978260869565, 0.045454545454545
61833, 2.1130434782609, 1.2978260869565, 0.45454545454545
61834, 2.1130434782609, 1.2978260869565, 0.40909090909091
61835, 2.1130434782609, 1.2978260869565, 0.36363636363636
61836, 2.1130434782609, 1.2978260869565, 0.31818181818182
61837, 2.1130434782609, 1.2978260869565, 0.27272727272727
61838, 2.1130434782609, 1.2978260869565, 0.22727272727273
61839, 2.1130434782609, 1.2978260869565, 0.18181818181818
61840, 2.1130434782609, 1.2978260869565, 0.13636363636364
61841, 2.1130434782609, 1.2978260869565, 0.090909090909091
61842, 2.1130434782609, 1.2978260869565, 0.045454545454545
61843, 2.1565217391304, 1.2978260869565, 0.45454545454545
61844, 2.1565217391304, 1.2978260869565, 0.40909090909091
61845, 2.1565217391304, 1.2978260869565, 0.36363636363636
61846, 2.1565217391304, 1.2978260869565, 0.31818181818182
61847, 2.1565217391304, 1.2978260869565, 0.27272727272727
61848, 2.1565217391304, 1.2978260869565, 0.22727272727273
61849, 2.1565217391304, 1.2978260869565, 0.18181818181818
61850, 2.1565217391304, 1.2978260869565, 0.13636363636364
61851, 2.1565217391304, 1.2978260869565, 0.090909090909091
61852, 2.1565217391304, 1.2978260869565, 0.045454545454545
61853, 1.2434782608696, 1.245652173913, 0.45454545454545
61854, 1.2434782608696, 1.245652173913, 0.40909090909091
61855, 1.2434782608696, 1.245652173913, 0.36363636363636
61856, 1.2434782608696, 1.245652173913, 0.31818181818182
61857, 1.2434782608696, 1.245652173913, 0.27272727272727
61858, 1.2434782608696, 1.245652173913, 0.22727272727273
61859, 1.2434782608696, 1.245652173913, 0.18181818181818
61860, 1.2434782608696, 1.245652173913, 0.13636363636364
61861, 1.2434782608696, 1.245652173913, 0.090909090909091
61862, 1.2434782608696, 1.245652173913, 0.045454545454545
61863, 1.2869565217391, 1.245652173913, 0.45454545454545
61864, 1.2869565217391, 1.245652173913, 0.40909090909091
61865, 1.2869565217391, 1.245652173913, 0.36363636363636
61866, 1.2869565217391, 1.245652173913, 0.31818181818182
61867, 1.2869565217391, 1.245652173913, 0.27272727272727
61868, 1.2869565217391, 1.245652173913, 0.22727272727273
61869, 1.2869565217391, 1.245652173913, 0.18181818181818
61870, 1.2869565217391, 1.245652173913, 0.13636363636364
61871, 1.2869565217391, 1.245652173913, 0.090909090909091
61872, 1.2869565217391, 1.245652173913, 0.045454545454545
61873, 1.3304347826087, 1.245652173913, 0.45454545454545
61874, 1.3304347826087, 1.245652173913, 0.40909090909091
61875, 1.3304347826087, 1.245652173913, 0.36363636363636
61876, 1.3304347826087, 1.245652173913, 0.31818181818182
61877, 1.3304347826087, 1.245652173913, 0.27272727272727
61878, 1.3304347826087, 1.245652173913, 0.22727272727273
61879, 1.3304347826087, 1.245652173913, 0.18181818181818
61880, 1.3304347826087, 1.245652173913, 0.13636363636364
61881, 1.3304347826087, 1.245652173913, 0.090909090909091
61882, 1.3304347826087, 1.245652173913, 0.045454545454545
61883, 1.3739130434783, 1.245652173913, 0.45454545454545
61884, 1.3739130434783, 1.245652173913, 0.40909090909091
61885, 1.3739130434783, 1.245652173913, 0.36363636363636
61886, 1.3739130434783, 1.245652173913, 0.31818181818182
61887, 1.3739130434783, 1.245652173913, 0.27272727272727
61888, 1.3739130434783, 1.245652173913, 0.22727272727273
61889, 1.3739130434783, 1.245652173913, 0.18181818181818
61890, 1.3739130434783, 1.245652173913, 0.13636363636364
61891, 1.3739130434783, 1.245652173913, 0.090909090909091
61892, 1.3739130434783, 1.245652173913, 0.045454545454545
61893, 1.4173913043478, 1.245652173913, 0.45454545454545
61894, 1.4173913043478, 1.245652173913, 0.40909090909091
61895, 1.4173913043478, 1.245652173913, 0.36363636363636
61896, 1.4173913043478, 1.245652173913, 0.31818181818182
61897, 1.4173913043478, 1.245652173913, 0.27272727272727
61898, 1.4173913043478, 1.245652173913, 0.22727272727273
61899, 1.4173913043478, 1.245652173913, 0.18181818181818
61900, 1.4173913043478, 1.245652173913, 0.13636363636364
61901, 1.4173913043478, 1.245652173913, 0.090909090909091
61902, 1.4173913043478, 1.245652173913, 0.045454545454545
61903, 1.4608695652174, 1.245652173913, 0.45454545454545
61904, 1.4608695652174, 1.245652173913, 0.40909090909091
61905, 1.4608695652174, 1.245652173913, 0.36363636363636
61906, 1.4608695652174, 1.245652173913, 0.31818181818182
61907, 1.4608695652174, 1.245652173913, 0.27272727272727
61908, 1.4608695652174, 1.245652173913, 0.22727272727273
61909, 1.4608695652174, 1.245652173913, 0.18181818181818
61910, 1.4608695652174, 1.245652173913, 0.13636363636364
61911, 1.4608695652174, 1.245652173913, 0.090909090909091
61912, 1.4608695652174, 1.245652173913, 0.045454545454545
61913, 1.504347826087, 1.245652173913, 0.45454545454545
61914, 1.504347826087, 1.245652173913, 0.40909090909091
61915, 1.504347826087, 1.245652173913, 0.36363636363636
61916, 1.504347826087, 1.245652173913, 0.31818181818182
61917, 1.504347826087, 1.245652173913, 0.27272727272727
61918, 1.504347826087, 1.245652173913, 0.22727272727273
61919, 1.504347826087, 1.245652173913, 0.18181818181818
61920, 1.504347826087, 1.245652173913, 0.13636363636364
61921, 1.504347826087, 1.245652173913, 0.090909090909091
61922, 1.504347826087, 1.245652173913, 0.045454545454545
61923, 1.5478260869565, 1.245652173913, 0.45454545454545
61924, 1.5478260869565, 1.245652173913, 0.40909090909091
61925, 1.5478260869565, 1.245652173913, 0.36363636363636
61926, 1.5478260869565, 1.245652173913, 0.31818181818182
61927, 1.5478260869565, 1.245652173913, 0.27272727272727
61928, 1.5478260869565, 1.245652173913, 0.22727272727273
61929, 1.5478260869565, 1.245652173913, 0.18181818181818
61930, 1.5478260869565, 1.245652173913, 0.13636363636364
61931, 1.5478260869565, 1.245652173913, 0.090909090909091
61932, 1.5478260869565, 1.245652173913, 0.045454545454545
61933, 1.5913043478261, 1.245652173913, 0.45454545454545
61934, 1.5913043478261, 1.245652173913, 0.40909090909091
61935, 1.5913043478261, 1.245652173913, 0.36363636363636
61936, 1.5913043478261, 1.245652173913, 0.31818181818182
61937, 1.5913043478261, 1.245652173913, 0.27272727272727
61938, 1.5913043478261, 1.245652173913, 0.22727272727273
61939, 1.5913043478261, 1.245652173913, 0.18181818181818
61940, 1.5913043478261, 1.245652173913, 0.13636363636364
61941, 1.5913043478261, 1.245652173913, 0.090909090909091
61942, 1.5913043478261, 1.245652173913, 0.045454545454545
61943, 1.6347826086957, 1.245652173913, 0.45454545454545
61944, 1.6347826086957, 1.245652173913, 0.40909090909091
61945, 1.6347826086957, 1.245652173913, 0.36363636363636
61946, 1.6347826086957, 1.245652173913, 0.31818181818182
61947, 1.6347826086957, 1.245652173913, 0.27272727272727
61948, 1.6347826086957, 1.245652173913, 0.22727272727273
61949, 1.6347826086957, 1.245652173913, 0.18181818181818
61950, 1.6347826086957, 1.245652173913, 0.13636363636364
61951, 1.6347826086957, 1.245652173913, 0.090909090909091
61952, 1.6347826086957, 1.245652173913, 0.045454545454545
61953, 1.6782608695652, 1.245652173913, 0.45454545454545
61954, 1.6782608695652, 1.245652173913, 0.40909090909091
61955, 1.6782608695652, 1.245652173913, 0.36363636363636
61956, 1.6782608695652, 1.245652173913, 0.31818181818182
61957, 1.6782608695652, 1.245652173913, 0.27272727272727
61958, 1.6782608695652, 1.245652173913, 0.22727272727273
61959, 1.6782608695652, 1.245652173913, 0.18181818181818
61960, 1.6782608695652, 1.245652173913, 0.13636363636364
61961, 1.6782608695652, 1.245652173913, 0.090909090909091
61962, 1.6782608695652, 1.245652173913, 0.045454545454545
61963, 1.7217391304348, 1.245652173913, 0.45454545454545
61964, 1.7217391304348, 1.245652173913, 0.40909090909091
61965, 1.7217391304348, 1.245652173913, 0.36363636363636
61966, 1.7217391304348, 1.245652173913, 0.31818181818182
61967, 1.7217391304348, 1.245652173913, 0.27272727272727
61968, 1.7217391304348, 1.245652173913, 0.22727272727273
61969, 1.7217391304348, 1.245652173913, 0.18181818181818
61970, 1.7217391304348, 1.245652173913, 0.13636363636364
61971, 1.7217391304348, 1.245652173913, 0.090909090909091
61972, 1.7217391304348, 1.245652173913, 0.045454545454545
61973, 1.7652173913043, 1.245652173913, 0.45454545454545
61974, 1.7652173913043, 1.245652173913, 0.40909090909091
61975, 1.7652173913043, 1.245652173913, 0.36363636363636
61976, 1.7652173913043, 1.245652173913, 0.31818181818182
61977, 1.7652173913043, 1.245652173913, 0.27272727272727
61978, 1.7652173913043, 1.245652173913, 0.22727272727273
61979, 1.7652173913043, 1.245652173913, 0.18181818181818
61980, 1.7652173913043, 1.245652173913, 0.13636363636364
61981, 1.7652173913043, 1.245652173913, 0.090909090909091
61982, 1.7652173913043, 1.245652173913, 0.045454545454545
61983, 1.8086956521739, 1.245652173913, 0.45454545454545
61984, 1.8086956521739, 1.245652173913, 0.40909090909091
61985, 1.8086956521739, 1.245652173913, 0.36363636363636
61986, 1.8086956521739, 1.245652173913, 0.31818181818182
61987, 1.8086956521739, 1.245652173913, 0.27272727272727
61988, 1.8086956521739, 1.245652173913, 0.22727272727273
61989, 1.8086956521739, 1.245652173913, 0.18181818181818
61990, 1.8086956521739, 1.245652173913, 0.13636363636364
61991, 1.8086956521739, 1.245652173913, 0.090909090909091
61992, 1.8086956521739, 1.245652173913, 0.045454545454545
61993, 1.8521739130435, 1.245652173913, 0.45454545454545
61994, 1.8521739130435, 1.245652173913, 0.40909090909091
61995, 1.8521739130435, 1.245652173913, 0.36363636363636
61996, 1.8521739130435, 1.245652173913, 0.31818181818182
61997, 1.8521739130435, 1.245652173913, 0.27272727272727
61998, 1.8521739130435, 1.245652173913, 0.22727272727273
61999, 1.8521739130435, 1.245652173913, 0.18181818181818
62000, 1.8521739130435, 1.245652173913, 0.13636363636364
62001, 1.8521739130435, 1.245652173913, 0.090909090909091
62002, 1.8521739130435, 1.245652173913, 0.045454545454545
62003, 1.895652173913, 1.245652173913, 0.45454545454545
62004, 1.895652173913, 1.245652173913, 0.40909090909091
62005, 1.895652173913, 1.245652173913, 0.36363636363636
62006, 1.895652173913, 1.245652173913, 0.31818181818182
62007, 1.895652173913, 1.245652173913, 0.27272727272727
62008, 1.895652173913, 1.245652173913, 0.22727272727273
62009, 1.895652173913, 1.245652173913, 0.18181818181818
62010, 1.895652173913, 1.245652173913, 0.13636363636364
62011, 1.895652173913, 1.245652173913, 0.090909090909091
62012, 1.895652173913, 1.245652173913, 0.045454545454545
62013, 1.9391304347826, 1.245652173913, 0.45454545454545
62014, 1.9391304347826, 1.245652173913, 0.40909090909091
62015, 1.9391304347826, 1.245652173913, 0.36363636363636
62016, 1.9391304347826, 1.245652173913, 0.31818181818182
62017, 1.9391304347826, 1.245652173913, 0.27272727272727
62018, 1.9391304347826, 1.245652173913, 0.22727272727273
62019, 1.9391304347826, 1.245652173913, 0.18181818181818
62020, 1.9391304347826, 1.245652173913, 0.13636363636364
62021, 1.9391304347826, 1.245652173913, 0.090909090909091
62022, 1.9391304347826, 1.245652173913, 0.045454545454545
62023, 1.9826086956522, 1.245652173913, 0.45454545454545
62024, 1.9826086956522, 1.245652173913, 0.40909090909091
62025, 1.9826086956522, 1.245652173913, 0.36363636363636
62026, 1.9826086956522, 1.245652173913, 0.31818181818182
62027, 1.9826086956522, 1.245652173913, 0.27272727272727
62028, 1.9826086956522, 1.245652173913, 0.22727272727273
62029, 1.9826086956522, 1.245652173913, 0.18181818181818
62030, 1.9826086956522, 1.245652173913, 0.13636363636364
62031, 1.9826086956522, 1.245652173913, 0.090909090909091
62032, 1.9826086956522, 1.245652173913, 0.045454545454545
62033, 2.0260869565217, 1.245652173913, 0.45454545454545
62034, 2.0260869565217, 1.245652173913, 0.40909090909091
62035, 2.0260869565217, 1.245652173913, 0.36363636363636
62036, 2.0260869565217, 1.245652173913, 0.31818181818182
62037, 2.0260869565217, 1.245652173913, 0.27272727272727
62038, 2.0260869565217, 1.245652173913, 0.22727272727273
62039, 2.0260869565217, 1.245652173913, 0.18181818181818
62040, 2.0260869565217, 1.245652173913, 0.13636363636364
62041, 2.0260869565217, 1.245652173913, 0.090909090909091
62042, 2.0260869565217, 1.245652173913, 0.045454545454545
62043, 2.0695652173913, 1.245652173913, 0.45454545454545
62044, 2.0695652173913, 1.245652173913, 0.40909090909091
62045, 2.0695652173913, 1.245652173913, 0.36363636363636
62046, 2.0695652173913, 1.245652173913, 0.31818181818182
62047, 2.0695652173913, 1.245652173913, 0.27272727272727
62048, 2.0695652173913, 1.245652173913, 0.22727272727273
62049, 2.0695652173913, 1.245652173913, 0.18181818181818
62050, 2.0695652173913, 1.245652173913, 0.13636363636364
62051, 2.0695652173913, 1.245652173913, 0.090909090909091
62052, 2.0695652173913, 1.245652173913, 0.045454545454545
62053, 2.1130434782609, 1.245652173913, 0.45454545454545
62054, 2.1130434782609, 1.245652173913, 0.40909090909091
62055, 2.1130434782609, 1.245652173913, 0.36363636363636
62056, 2.1130434782609, 1.245652173913, 0.31818181818182
62057, 2.1130434782609, 1.245652173913, 0.27272727272727
62058, 2.1130434782609, 1.245652173913, 0.22727272727273
62059, 2.1130434782609, 1.245652173913, 0.18181818181818
62060, 2.1130434782609, 1.245652173913, 0.13636363636364
62061, 2.1130434782609, 1.245652173913, 0.090909090909091
62062, 2.1130434782609, 1.245652173913, 0.045454545454545
62063, 2.1565217391304, 1.245652173913, 0.45454545454545
62064, 2.1565217391304, 1.245652173913, 0.40909090909091
62065, 2.1565217391304, 1.245652173913, 0.36363636363636
62066, 2.1565217391304, 1.245652173913, 0.31818181818182
62067, 2.1565217391304, 1.245652173913, 0.27272727272727
62068, 2.1565217391304, 1.245652173913, 0.22727272727273
62069, 2.1565217391304, 1.245652173913, 0.18181818181818
62070, 2.1565217391304, 1.245652173913, 0.13636363636364
62071, 2.1565217391304, 1.245652173913, 0.090909090909091
62072, 2.1565217391304, 1.245652173913, 0.045454545454545
62073, 1.2434782608696, 1.1934782608696, 0.45454545454545
62074, 1.2434782608696, 1.1934782608696, 0.40909090909091
62075, 1.2434782608696, 1.1934782608696, 0.36363636363636
62076, 1.2434782608696, 1.1934782608696, 0.31818181818182
62077, 1.2434782608696, 1.1934782608696, 0.27272727272727
62078, 1.2434782608696, 1.1934782608696, 0.22727272727273
62079, 1.2434782608696, 1.1934782608696, 0.18181818181818
62080, 1.2434782608696, 1.1934782608696, 0.13636363636364
62081, 1.2434782608696, 1.1934782608696, 0.090909090909091
62082, 1.2434782608696, 1.1934782608696, 0.045454545454545
62083, 1.2869565217391, 1.1934782608696, 0.45454545454545
62084, 1.2869565217391, 1.1934782608696, 0.40909090909091
62085, 1.2869565217391, 1.1934782608696, 0.36363636363636
62086, 1.2869565217391, 1.1934782608696, 0.31818181818182
62087, 1.2869565217391, 1.1934782608696, 0.27272727272727
62088, 1.2869565217391, 1.1934782608696, 0.22727272727273
62089, 1.2869565217391, 1.1934782608696, 0.18181818181818
62090, 1.2869565217391, 1.1934782608696, 0.13636363636364
62091, 1.2869565217391, 1.1934782608696, 0.090909090909091
62092, 1.2869565217391, 1.1934782608696, 0.045454545454545
62093, 1.3304347826087, 1.1934782608696, 0.45454545454545
62094, 1.3304347826087, 1.1934782608696, 0.40909090909091
62095, 1.3304347826087, 1.1934782608696, 0.36363636363636
62096, 1.3304347826087, 1.1934782608696, 0.31818181818182
62097, 1.3304347826087, 1.1934782608696, 0.27272727272727
62098, 1.3304347826087, 1.1934782608696, 0.22727272727273
62099, 1.3304347826087, 1.1934782608696, 0.18181818181818
62100, 1.3304347826087, 1.1934782608696, 0.13636363636364
62101, 1.3304347826087, 1.1934782608696, 0.090909090909091
62102, 1.3304347826087, 1.1934782608696, 0.045454545454545
62103, 1.3739130434783, 1.1934782608696, 0.45454545454545
62104, 1.3739130434783, 1.1934782608696, 0.40909090909091
62105, 1.3739130434783, 1.1934782608696, 0.36363636363636
62106, 1.3739130434783, 1.1934782608696, 0.31818181818182
62107, 1.3739130434783, 1.1934782608696, 0.27272727272727
62108, 1.3739130434783, 1.1934782608696, 0.22727272727273
62109, 1.3739130434783, 1.1934782608696, 0.18181818181818
62110, 1.3739130434783, 1.1934782608696, 0.13636363636364
62111, 1.3739130434783, 1.1934782608696, 0.090909090909091
62112, 1.3739130434783, 1.1934782608696, 0.045454545454545
62113, 1.4173913043478, 1.1934782608696, 0.45454545454545
62114, 1.4173913043478, 1.1934782608696, 0.40909090909091
62115, 1.4173913043478, 1.1934782608696, 0.36363636363636
62116, 1.4173913043478, 1.1934782608696, 0.31818181818182
62117, 1.4173913043478, 1.1934782608696, 0.27272727272727
62118, 1.4173913043478, 1.1934782608696, 0.22727272727273
62119, 1.4173913043478, 1.1934782608696, 0.18181818181818
62120, 1.4173913043478, 1.1934782608696, 0.13636363636364
62121, 1.4173913043478, 1.1934782608696, 0.090909090909091
62122, 1.4173913043478, 1.1934782608696, 0.045454545454545
62123, 1.4608695652174, 1.1934782608696, 0.45454545454545
62124, 1.4608695652174, 1.1934782608696, 0.40909090909091
62125, 1.4608695652174, 1.1934782608696, 0.36363636363636
62126, 1.4608695652174, 1.1934782608696, 0.31818181818182
62127, 1.4608695652174, 1.1934782608696, 0.27272727272727
62128, 1.4608695652174, 1.1934782608696, 0.22727272727273
62129, 1.4608695652174, 1.1934782608696, 0.18181818181818
62130, 1.4608695652174, 1.1934782608696, 0.13636363636364
62131, 1.4608695652174, 1.1934782608696, 0.090909090909091
62132, 1.4608695652174, 1.1934782608696, 0.045454545454545
62133, 1.504347826087, 1.1934782608696, 0.45454545454545
62134, 1.504347826087, 1.1934782608696, 0.40909090909091
62135, 1.504347826087, 1.1934782608696, 0.36363636363636
62136, 1.504347826087, 1.1934782608696, 0.31818181818182
62137, 1.504347826087, 1.1934782608696, 0.27272727272727
62138, 1.504347826087, 1.1934782608696, 0.22727272727273
62139, 1.504347826087, 1.1934782608696, 0.18181818181818
62140, 1.504347826087, 1.1934782608696, 0.13636363636364
62141, 1.504347826087, 1.1934782608696, 0.090909090909091
62142, 1.504347826087, 1.1934782608696, 0.045454545454545
62143, 1.5478260869565, 1.1934782608696, 0.45454545454545
62144, 1.5478260869565, 1.1934782608696, 0.40909090909091
62145, 1.5478260869565, 1.1934782608696, 0.36363636363636
62146, 1.5478260869565, 1.1934782608696, 0.31818181818182
62147, 1.5478260869565, 1.1934782608696, 0.27272727272727
62148, 1.5478260869565, 1.1934782608696, 0.22727272727273
62149, 1.5478260869565, 1.1934782608696, 0.18181818181818
62150, 1.5478260869565, 1.1934782608696, 0.13636363636364
62151, 1.5478260869565, 1.1934782608696, 0.090909090909091
62152, 1.5478260869565, 1.1934782608696, 0.045454545454545
62153, 1.5913043478261, 1.1934782608696, 0.45454545454545
62154, 1.5913043478261, 1.1934782608696, 0.40909090909091
62155, 1.5913043478261, 1.1934782608696, 0.36363636363636
62156, 1.5913043478261, 1.1934782608696, 0.31818181818182
62157, 1.5913043478261, 1.1934782608696, 0.27272727272727
62158, 1.5913043478261, 1.1934782608696, 0.22727272727273
62159, 1.5913043478261, 1.1934782608696, 0.18181818181818
62160, 1.5913043478261, 1.1934782608696, 0.13636363636364
62161, 1.5913043478261, 1.1934782608696, 0.090909090909091
62162, 1.5913043478261, 1.1934782608696, 0.045454545454545
62163, 1.6347826086957, 1.1934782608696, 0.45454545454545
62164, 1.6347826086957, 1.1934782608696, 0.40909090909091
62165, 1.6347826086957, 1.1934782608696, 0.36363636363636
62166, 1.6347826086957, 1.1934782608696, 0.31818181818182
62167, 1.6347826086957, 1.1934782608696, 0.27272727272727
62168, 1.6347826086957, 1.1934782608696, 0.22727272727273
62169, 1.6347826086957, 1.1934782608696, 0.18181818181818
62170, 1.6347826086957, 1.1934782608696, 0.13636363636364
62171, 1.6347826086957, 1.1934782608696, 0.090909090909091
62172, 1.6347826086957, 1.1934782608696, 0.045454545454545
62173, 1.6782608695652, 1.1934782608696, 0.45454545454545
62174, 1.6782608695652, 1.1934782608696, 0.40909090909091
62175, 1.6782608695652, 1.1934782608696, 0.36363636363636
62176, 1.6782608695652, 1.1934782608696, 0.31818181818182
62177, 1.6782608695652, 1.1934782608696, 0.27272727272727
62178, 1.6782608695652, 1.1934782608696, 0.22727272727273
62179, 1.6782608695652, 1.1934782608696, 0.18181818181818
62180, 1.6782608695652, 1.1934782608696, 0.13636363636364
62181, 1.6782608695652, 1.1934782608696, 0.090909090909091
62182, 1.6782608695652, 1.1934782608696, 0.045454545454545
62183, 1.7217391304348, 1.1934782608696, 0.45454545454545
62184, 1.7217391304348, 1.1934782608696, 0.40909090909091
62185, 1.7217391304348, 1.1934782608696, 0.36363636363636
62186, 1.7217391304348, 1.1934782608696, 0.31818181818182
62187, 1.7217391304348, 1.1934782608696, 0.27272727272727
62188, 1.7217391304348, 1.1934782608696, 0.22727272727273
62189, 1.7217391304348, 1.1934782608696, 0.18181818181818
62190, 1.7217391304348, 1.1934782608696, 0.13636363636364
62191, 1.7217391304348, 1.1934782608696, 0.090909090909091
62192, 1.7217391304348, 1.1934782608696, 0.045454545454545
62193, 1.7652173913043, 1.1934782608696, 0.45454545454545
62194, 1.7652173913043, 1.1934782608696, 0.40909090909091
62195, 1.7652173913043, 1.1934782608696, 0.36363636363636
62196, 1.7652173913043, 1.1934782608696, 0.31818181818182
62197, 1.7652173913043, 1.1934782608696, 0.27272727272727
62198, 1.7652173913043, 1.1934782608696, 0.22727272727273
62199, 1.7652173913043, 1.1934782608696, 0.18181818181818
62200, 1.7652173913043, 1.1934782608696, 0.13636363636364
62201, 1.7652173913043, 1.1934782608696, 0.090909090909091
62202, 1.7652173913043, 1.1934782608696, 0.045454545454545
62203, 1.8086956521739, 1.1934782608696, 0.45454545454545
62204, 1.8086956521739, 1.1934782608696, 0.40909090909091
62205, 1.8086956521739, 1.1934782608696, 0.36363636363636
62206, 1.8086956521739, 1.1934782608696, 0.31818181818182
62207, 1.8086956521739, 1.1934782608696, 0.27272727272727
62208, 1.8086956521739, 1.1934782608696, 0.22727272727273
62209, 1.8086956521739, 1.1934782608696, 0.18181818181818
62210, 1.8086956521739, 1.1934782608696, 0.13636363636364
62211, 1.8086956521739, 1.1934782608696, 0.090909090909091
62212, 1.8086956521739, 1.1934782608696, 0.045454545454545
62213, 1.8521739130435, 1.1934782608696, 0.45454545454545
62214, 1.8521739130435, 1.1934782608696, 0.40909090909091
62215, 1.8521739130435, 1.1934782608696, 0.36363636363636
62216, 1.8521739130435, 1.1934782608696, 0.31818181818182
62217, 1.8521739130435, 1.1934782608696, 0.27272727272727
62218, 1.8521739130435, 1.1934782608696, 0.22727272727273
62219, 1.8521739130435, 1.1934782608696, 0.18181818181818
62220, 1.8521739130435, 1.1934782608696, 0.13636363636364
62221, 1.8521739130435, 1.1934782608696, 0.090909090909091
62222, 1.8521739130435, 1.1934782608696, 0.045454545454545
62223, 1.895652173913, 1.1934782608696, 0.45454545454545
62224, 1.895652173913, 1.1934782608696, 0.40909090909091
62225, 1.895652173913, 1.1934782608696, 0.36363636363636
62226, 1.895652173913, 1.1934782608696, 0.31818181818182
62227, 1.895652173913, 1.1934782608696, 0.27272727272727
62228, 1.895652173913, 1.1934782608696, 0.22727272727273
62229, 1.895652173913, 1.1934782608696, 0.18181818181818
62230, 1.895652173913, 1.1934782608696, 0.13636363636364
62231, 1.895652173913, 1.1934782608696, 0.090909090909091
62232, 1.895652173913, 1.1934782608696, 0.045454545454545
62233, 1.9391304347826, 1.1934782608696, 0.45454545454545
62234, 1.9391304347826, 1.1934782608696, 0.40909090909091
62235, 1.9391304347826, 1.1934782608696, 0.36363636363636
62236, 1.9391304347826, 1.1934782608696, 0.31818181818182
62237, 1.9391304347826, 1.1934782608696, 0.27272727272727
62238, 1.9391304347826, 1.1934782608696, 0.22727272727273
62239, 1.9391304347826, 1.1934782608696, 0.18181818181818
62240, 1.9391304347826, 1.1934782608696, 0.13636363636364
62241, 1.9391304347826, 1.1934782608696, 0.090909090909091
62242, 1.9391304347826, 1.1934782608696, 0.045454545454545
62243, 1.9826086956522, 1.1934782608696, 0.45454545454545
62244, 1.9826086956522, 1.1934782608696, 0.40909090909091
62245, 1.9826086956522, 1.1934782608696, 0.36363636363636
62246, 1.9826086956522, 1.1934782608696, 0.31818181818182
62247, 1.9826086956522, 1.1934782608696, 0.27272727272727
62248, 1.9826086956522, 1.1934782608696, 0.22727272727273
62249, 1.9826086956522, 1.1934782608696, 0.18181818181818
62250, 1.9826086956522, 1.1934782608696, 0.13636363636364
62251, 1.9826086956522, 1.1934782608696, 0.090909090909091
62252, 1.9826086956522, 1.1934782608696, 0.045454545454545
62253, 2.0260869565217, 1.1934782608696, 0.45454545454545
62254, 2.0260869565217, 1.1934782608696, 0.40909090909091
62255, 2.0260869565217, 1.1934782608696, 0.36363636363636
62256, 2.0260869565217, 1.1934782608696, 0.31818181818182
62257, 2.0260869565217, 1.1934782608696, 0.27272727272727
62258, 2.0260869565217, 1.1934782608696, 0.22727272727273
62259, 2.0260869565217, 1.1934782608696, 0.18181818181818
62260, 2.0260869565217, 1.1934782608696, 0.13636363636364
62261, 2.0260869565217, 1.1934782608696, 0.090909090909091
62262, 2.0260869565217, 1.1934782608696, 0.045454545454545
62263, 2.0695652173913, 1.1934782608696, 0.45454545454545
62264, 2.0695652173913, 1.1934782608696, 0.40909090909091
62265, 2.0695652173913, 1.1934782608696, 0.36363636363636
62266, 2.0695652173913, 1.1934782608696, 0.31818181818182
62267, 2.0695652173913, 1.1934782608696, 0.27272727272727
62268, 2.0695652173913, 1.1934782608696, 0.22727272727273
62269, 2.0695652173913, 1.1934782608696, 0.18181818181818
62270, 2.0695652173913, 1.1934782608696, 0.13636363636364
62271, 2.0695652173913, 1.1934782608696, 0.090909090909091
62272, 2.0695652173913, 1.1934782608696, 0.045454545454545
62273, 2.1130434782609, 1.1934782608696, 0.45454545454545
62274, 2.1130434782609, 1.1934782608696, 0.40909090909091
62275, 2.1130434782609, 1.1934782608696, 0.36363636363636
62276, 2.1130434782609, 1.1934782608696, 0.31818181818182
62277, 2.1130434782609, 1.1934782608696, 0.27272727272727
62278, 2.1130434782609, 1.1934782608696, 0.22727272727273
62279, 2.1130434782609, 1.1934782608696, 0.18181818181818
62280, 2.1130434782609, 1.1934782608696, 0.13636363636364
62281, 2.1130434782609, 1.1934782608696, 0.090909090909091
62282, 2.1130434782609, 1.1934782608696, 0.045454545454545
62283, 2.1565217391304, 1.1934782608696, 0.45454545454545
62284, 2.1565217391304, 1.1934782608696, 0.40909090909091
62285, 2.1565217391304, 1.1934782608696, 0.36363636363636
62286, 2.1565217391304, 1.1934782608696, 0.31818181818182
62287, 2.1565217391304, 1.1934782608696, 0.27272727272727
62288, 2.1565217391304, 1.1934782608696, 0.22727272727273
62289, 2.1565217391304, 1.1934782608696, 0.18181818181818
62290, 2.1565217391304, 1.1934782608696, 0.13636363636364
62291, 2.1565217391304, 1.1934782608696, 0.090909090909091
62292, 2.1565217391304, 1.1934782608696, 0.045454545454545
62293, 1.2434782608696, 1.1413043478261, 0.45454545454545
62294, 1.2434782608696, 1.1413043478261, 0.40909090909091
62295, 1.2434782608696, 1.1413043478261, 0.36363636363636
62296, 1.2434782608696, 1.1413043478261, 0.31818181818182
62297, 1.2434782608696, 1.1413043478261, 0.27272727272727
62298, 1.2434782608696, 1.1413043478261, 0.22727272727273
62299, 1.2434782608696, 1.1413043478261, 0.18181818181818
62300, 1.2434782608696, 1.1413043478261, 0.13636363636364
62301, 1.2434782608696, 1.1413043478261, 0.090909090909091
62302, 1.2434782608696, 1.1413043478261, 0.045454545454545
62303, 1.2869565217391, 1.1413043478261, 0.45454545454545
62304, 1.2869565217391, 1.1413043478261, 0.40909090909091
62305, 1.2869565217391, 1.1413043478261, 0.36363636363636
62306, 1.2869565217391, 1.1413043478261, 0.31818181818182
62307, 1.2869565217391, 1.1413043478261, 0.27272727272727
62308, 1.2869565217391, 1.1413043478261, 0.22727272727273
62309, 1.2869565217391, 1.1413043478261, 0.18181818181818
62310, 1.2869565217391, 1.1413043478261, 0.13636363636364
62311, 1.2869565217391, 1.1413043478261, 0.090909090909091
62312, 1.2869565217391, 1.1413043478261, 0.045454545454545
62313, 1.3304347826087, 1.1413043478261, 0.45454545454545
62314, 1.3304347826087, 1.1413043478261, 0.40909090909091
62315, 1.3304347826087, 1.1413043478261, 0.36363636363636
62316, 1.3304347826087, 1.1413043478261, 0.31818181818182
62317, 1.3304347826087, 1.1413043478261, 0.27272727272727
62318, 1.3304347826087, 1.1413043478261, 0.22727272727273
62319, 1.3304347826087, 1.1413043478261, 0.18181818181818
62320, 1.3304347826087, 1.1413043478261, 0.13636363636364
62321, 1.3304347826087, 1.1413043478261, 0.090909090909091
62322, 1.3304347826087, 1.1413043478261, 0.045454545454545
62323, 1.3739130434783, 1.1413043478261, 0.45454545454545
62324, 1.3739130434783, 1.1413043478261, 0.40909090909091
62325, 1.3739130434783, 1.1413043478261, 0.36363636363636
62326, 1.3739130434783, 1.1413043478261, 0.31818181818182
62327, 1.3739130434783, 1.1413043478261, 0.27272727272727
62328, 1.3739130434783, 1.1413043478261, 0.22727272727273
62329, 1.3739130434783, 1.1413043478261, 0.18181818181818
62330, 1.3739130434783, 1.1413043478261, 0.13636363636364
62331, 1.3739130434783, 1.1413043478261, 0.090909090909091
62332, 1.3739130434783, 1.1413043478261, 0.045454545454545
62333, 1.4173913043478, 1.1413043478261, 0.45454545454545
62334, 1.4173913043478, 1.1413043478261, 0.40909090909091
62335, 1.4173913043478, 1.1413043478261, 0.36363636363636
62336, 1.4173913043478, 1.1413043478261, 0.31818181818182
62337, 1.4173913043478, 1.1413043478261, 0.27272727272727
62338, 1.4173913043478, 1.1413043478261, 0.22727272727273
62339, 1.4173913043478, 1.1413043478261, 0.18181818181818
62340, 1.4173913043478, 1.1413043478261, 0.13636363636364
62341, 1.4173913043478, 1.1413043478261, 0.090909090909091
62342, 1.4173913043478, 1.1413043478261, 0.045454545454545
62343, 1.4608695652174, 1.1413043478261, 0.45454545454545
62344, 1.4608695652174, 1.1413043478261, 0.40909090909091
62345, 1.4608695652174, 1.1413043478261, 0.36363636363636
62346, 1.4608695652174, 1.1413043478261, 0.31818181818182
62347, 1.4608695652174, 1.1413043478261, 0.27272727272727
62348, 1.4608695652174, 1.1413043478261, 0.22727272727273
62349, 1.4608695652174, 1.1413043478261, 0.18181818181818
62350, 1.4608695652174, 1.1413043478261, 0.13636363636364
62351, 1.4608695652174, 1.1413043478261, 0.090909090909091
62352, 1.4608695652174, 1.1413043478261, 0.045454545454545
62353, 1.504347826087, 1.1413043478261, 0.45454545454545
62354, 1.504347826087, 1.1413043478261, 0.40909090909091
62355, 1.504347826087, 1.1413043478261, 0.36363636363636
62356, 1.504347826087, 1.1413043478261, 0.31818181818182
62357, 1.504347826087, 1.1413043478261, 0.27272727272727
62358, 1.504347826087, 1.1413043478261, 0.22727272727273
62359, 1.504347826087, 1.1413043478261, 0.18181818181818
62360, 1.504347826087, 1.1413043478261, 0.13636363636364
62361, 1.504347826087, 1.1413043478261, 0.090909090909091
62362, 1.504347826087, 1.1413043478261, 0.045454545454545
62363, 1.5478260869565, 1.1413043478261, 0.45454545454545
62364, 1.5478260869565, 1.1413043478261, 0.40909090909091
62365, 1.5478260869565, 1.1413043478261, 0.36363636363636
62366, 1.5478260869565, 1.1413043478261, 0.31818181818182
62367, 1.5478260869565, 1.1413043478261, 0.27272727272727
62368, 1.5478260869565, 1.1413043478261, 0.22727272727273
62369, 1.5478260869565, 1.1413043478261, 0.18181818181818
62370, 1.5478260869565, 1.1413043478261, 0.13636363636364
62371, 1.5478260869565, 1.1413043478261, 0.090909090909091
62372, 1.5478260869565, 1.1413043478261, 0.045454545454545
62373, 1.5913043478261, 1.1413043478261, 0.45454545454545
62374, 1.5913043478261, 1.1413043478261, 0.40909090909091
62375, 1.5913043478261, 1.1413043478261, 0.36363636363636
62376, 1.5913043478261, 1.1413043478261, 0.31818181818182
62377, 1.5913043478261, 1.1413043478261, 0.27272727272727
62378, 1.5913043478261, 1.1413043478261, 0.22727272727273
62379, 1.5913043478261, 1.1413043478261, 0.18181818181818
62380, 1.5913043478261, 1.1413043478261, 0.13636363636364
62381, 1.5913043478261, 1.1413043478261, 0.090909090909091
62382, 1.5913043478261, 1.1413043478261, 0.045454545454545
62383, 1.6347826086957, 1.1413043478261, 0.45454545454545
62384, 1.6347826086957, 1.1413043478261, 0.40909090909091
62385, 1.6347826086957, 1.1413043478261, 0.36363636363636
62386, 1.6347826086957, 1.1413043478261, 0.31818181818182
62387, 1.6347826086957, 1.1413043478261, 0.27272727272727
62388, 1.6347826086957, 1.1413043478261, 0.22727272727273
62389, 1.6347826086957, 1.1413043478261, 0.18181818181818
62390, 1.6347826086957, 1.1413043478261, 0.13636363636364
62391, 1.6347826086957, 1.1413043478261, 0.090909090909091
62392, 1.6347826086957, 1.1413043478261, 0.045454545454545
62393, 1.6782608695652, 1.1413043478261, 0.45454545454545
62394, 1.6782608695652, 1.1413043478261, 0.40909090909091
62395, 1.6782608695652, 1.1413043478261, 0.36363636363636
62396, 1.6782608695652, 1.1413043478261, 0.31818181818182
62397, 1.6782608695652, 1.1413043478261, 0.27272727272727
62398, 1.6782608695652, 1.1413043478261, 0.22727272727273
62399, 1.6782608695652, 1.1413043478261, 0.18181818181818
62400, 1.6782608695652, 1.1413043478261, 0.13636363636364
62401, 1.6782608695652, 1.1413043478261, 0.090909090909091
62402, 1.6782608695652, 1.1413043478261, 0.045454545454545
62403, 1.7217391304348, 1.1413043478261, 0.45454545454545
62404, 1.7217391304348, 1.1413043478261, 0.40909090909091
62405, 1.7217391304348, 1.1413043478261, 0.36363636363636
62406, 1.7217391304348, 1.1413043478261, 0.31818181818182
62407, 1.7217391304348, 1.1413043478261, 0.27272727272727
62408, 1.7217391304348, 1.1413043478261, 0.22727272727273
62409, 1.7217391304348, 1.1413043478261, 0.18181818181818
62410, 1.7217391304348, 1.1413043478261, 0.13636363636364
62411, 1.7217391304348, 1.1413043478261, 0.090909090909091
62412, 1.7217391304348, 1.1413043478261, 0.045454545454545
62413, 1.7652173913043, 1.1413043478261, 0.45454545454545
62414, 1.7652173913043, 1.1413043478261, 0.40909090909091
62415, 1.7652173913043, 1.1413043478261, 0.36363636363636
62416, 1.7652173913043, 1.1413043478261, 0.31818181818182
62417, 1.7652173913043, 1.1413043478261, 0.27272727272727
62418, 1.7652173913043, 1.1413043478261, 0.22727272727273
62419, 1.7652173913043, 1.1413043478261, 0.18181818181818
62420, 1.7652173913043, 1.1413043478261, 0.13636363636364
62421, 1.7652173913043, 1.1413043478261, 0.090909090909091
62422, 1.7652173913043, 1.1413043478261, 0.045454545454545
62423, 1.8086956521739, 1.1413043478261, 0.45454545454545
62424, 1.8086956521739, 1.1413043478261, 0.40909090909091
62425, 1.8086956521739, 1.1413043478261, 0.36363636363636
62426, 1.8086956521739, 1.1413043478261, 0.31818181818182
62427, 1.8086956521739, 1.1413043478261, 0.27272727272727
62428, 1.8086956521739, 1.1413043478261, 0.22727272727273
62429, 1.8086956521739, 1.1413043478261, 0.18181818181818
62430, 1.8086956521739, 1.1413043478261, 0.13636363636364
62431, 1.8086956521739, 1.1413043478261, 0.090909090909091
