4447, 10026, 10036, 10037, 10027, 10478, 10479, 10480, 10458
4448, 10027, 10037, 10038, 10028, 10480, 10481, 10482, 10460
4449, 10028, 10038, 10039, 10029, 10482, 10483, 10484, 10462
4450, 10029, 10039, 10040, 10030, 10484, 10485, 10486, 10464
4451, 10030, 10040, 10041, 10031, 10486, 10487, 10488, 10466
4452, 10031, 10041, 10042, 10032, 10488, 10489, 10490, 10468
4453, 10032, 10042, 10043, 10033, 10490, 10491, 10492, 10470
4454, 10033, 10043, 10044, 10034, 10492, 10493, 10494, 10472
4455, 10034, 10044, 582, 581, 10494, 10495, 604, 10474
4456, 738, 739, 10045, 10035, 761, 10496, 10497, 10475
4457, 10035, 10045, 10046, 10036, 10497, 10498, 10499, 10477
4458, 10036, 10046, 10047, 10037, 10499, 10500, 10501, 10479
4459, 10037, 10047, 10048, 10038, 10501, 10502, 10503, 10481
4460, 10038, 10048, 10049, 10039, 10503, 10504, 10505, 10483
4461, 10039, 10049, 10050, 10040, 10505, 10506, 10507, 10485
4462, 10040, 10050, 10051, 10041, 10507, 10508, 10509, 10487
4463, 10041, 10051, 10052, 10042, 10509, 10510, 10511, 10489
4464, 10042, 10052, 10053, 10043, 10511, 10512, 10513, 10491
4465, 10043, 10053, 10054, 10044, 10513, 10514, 10515, 10493
4466, 10044, 10054, 583, 582, 10515, 10516, 605, 10495
4467, 739, 16, 817, 10045, 762, 828, 10517, 10496
4468, 10045, 817, 816, 10046, 10517, 827, 10518, 10498
4469, 10046, 816, 815, 10047, 10518, 826, 10519, 10500
4470, 10047, 815, 814, 10048, 10519, 825, 10520, 10502
4471, 10048, 814, 813, 10049, 10520, 824, 10521, 10504
4472, 10049, 813, 812, 10050, 10521, 823, 10522, 10506
4473, 10050, 812, 811, 10051, 10522, 822, 10523, 10508
4474, 10051, 811, 810, 10052, 10523, 821, 10524, 10510
4475, 10052, 810, 809, 10053, 10524, 820, 10525, 10512
4476, 10053, 809, 808, 10054, 10525, 819, 10526, 10514
4477, 10054, 808, 14, 583, 10526, 818, 606, 10516
*ELEMENT, type=CPS8, ELSET=Surface16
4478, 14, 808, 10527, 607, 818, 10747, 10748, 629
4479, 808, 809, 10528, 10527, 819, 10749, 10750, 10747
4480, 809, 810, 10529, 10528, 820, 10751, 10752, 10749
4481, 810, 811, 10530, 10529, 821, 10753, 10754, 10751
4482, 811, 812, 10531, 10530, 822, 10755, 10756, 10753
4483, 812, 813, 10532, 10531, 823, 10757, 10758, 10755
4484, 813, 814, 10533, 10532, 824, 10759, 10760, 10757
4485, 814, 815, 10534, 10533, 825, 10761, 10762, 10759
4486, 815, 816, 10535, 10534, 826, 10763, 10764, 10761
4487, 816, 817, 10536, 10535, 827, 10765, 10766, 10763
4488, 817, 16, 763, 10536, 828, 785, 10767, 10765
4489, 607, 10527, 10537, 608, 10748, 10768, 10769, 630
4490, 10527, 10528, 10538, 10537, 10750, 10770, 10771, 10768
4491, 10528, 10529, 10539, 10538, 10752, 10772, 10773, 10770
4492, 10529, 10530, 10540, 10539, 10754, 10774, 10775, 10772
4493, 10530, 10531, 10541, 10540, 10756, 10776, 10777, 10774
4494, 10531, 10532, 10542, 10541, 10758, 10778, 10779, 10776
4495, 10532, 10533, 10543, 10542, 10760, 10780, 10781, 10778
4496, 10533, 10534, 10544, 10543, 10762, 10782, 10783, 10780
4497, 10534, 10535, 10545, 10544, 10764, 10784, 10785, 10782
4498, 10535, 10536, 10546, 10545, 10766, 10786, 10787, 10784
4499, 10536, 763, 764, 10546, 10767, 786, 10788, 10786
4500, 608, 10537, 10547, 609, 10769, 10789, 10790, 631
4501, 10537, 10538, 10548, 10547, 10771, 10791, 10792, 10789
4502, 10538, 10539, 10549, 10548, 10773, 10793, 10794, 10791
4503, 10539, 10540, 10550, 10549, 10775, 10795, 10796, 10793
4504, 10540, 10541, 10551, 10550, 10777, 10797, 10798, 10795
4505, 10541, 10542, 10552, 10551, 10779, 10799, 10800, 10797
4506, 10542, 10543, 10553, 10552, 10781, 10801, 10802, 10799
4507, 10543, 10544, 10554, 10553, 10783, 10803, 10804, 10801
4508, 10544, 10545, 10555, 10554, 10785, 10805, 10806, 10803
4509, 10545, 10546, 10556, 10555, 10787, 10807, 10808, 10805
4510, 10546, 764, 765, 10556, 10788, 787, 10809, 10807
4511, 609, 10547, 10557, 610, 10790, 10810, 10811, 632
4512, 10547, 10548, 10558, 10557, 10792, 10812, 10813, 10810
4513, 10548, 10549, 10559, 10558, 10794, 10814, 10815, 10812
4514, 10549, 10550, 10560, 10559, 10796, 10816, 10817, 10814
4515, 10550, 10551, 10561, 10560, 10798, 10818, 10819, 10816
4516, 10551, 10552, 10562, 10561, 10800, 10820, 10821, 10818
4517, 10552, 10553, 10563, 10562, 10802, 10822, 10823, 10820
4518, 10553, 10554, 10564, 10563, 10804, 10824, 10825, 10822
4519, 10554, 10555, 10565, 10564, 10806, 10826, 10827, 10824
4520, 10555, 10556, 10566, 10565, 10808, 10828, 10829, 10826
4521, 10556, 765, 766, 10566, 10809, 788, 10830, 10828
4522, 610, 10557, 10567, 611, 10811, 10831, 10832, 633
4523, 10557, 10558, 10568, 10567, 10813, 10833, 10834, 10831
4524, 10558, 10559, 10569, 10568, 10815, 10835, 10836, 10833
4525, 10559, 10560, 10570, 10569, 10817, 10837, 10838, 10835
4526, 10560, 10561, 10571, 10570, 10819, 10839, 10840, 10837
4527, 10561, 10562, 10572, 10571, 10821, 10841, 10842, 10839
4528, 10562, 10563, 10573, 10572, 10823, 10843, 10844, 10841
4529, 10563, 10564, 10574, 10573, 10825, 10845, 10846, 10843
4530, 10564, 10565, 10575, 10574, 10827, 10847, 10848, 10845
4531, 10565, 10566, 10576, 10575, 10829, 10849, 10850, 10847
4532, 10566, 766, 767, 10576, 10830, 789, 10851, 10849
4533, 611, 10567, 10577, 612, 10832, 10852, 10853, 634
4534, 10567, 10568, 10578, 10577, 10834, 10854, 10855, 10852
4535, 10568, 10569, 10579, 10578, 10836, 10856, 10857, 10854
4536, 10569, 10570, 10580, 10579, 10838, 10858, 10859, 10856
4537, 10570, 10571, 10581, 10580, 10840, 10860, 10861, 10858
4538, 10571, 10572, 10582, 10581, 10842, 10862, 10863, 10860
4539, 10572, 10573, 10583, 10582, 10844, 10864, 10865, 10862
4540, 10573, 10574, 10584, 10583, 10846, 10866, 10867, 10864
4541, 10574, 10575, 10585, 10584, 10848, 10868, 10869, 10866
4542, 10575, 10576, 10586, 10585, 10850, 10870, 10871, 10868
4543, 10576, 767, 768, 10586, 10851, 790, 10872, 10870
4544, 612, 10577, 10587, 613, 10853, 10873, 10874, 635
4545, 10577, 10578, 10588, 10587, 10855, 10875, 10876, 10873
4546, 10578, 10579, 10589, 10588, 10857, 10877, 10878, 10875
4547, 10579, 10580, 10590, 10589, 10859, 10879, 10880, 10877
4548, 10580, 10581, 10591, 10590, 10861, 10881, 10882, 10879
4549, 10581, 10582, 10592, 10591, 10863, 10883, 10884, 10881
4550, 10582, 10583, 10593, 10592, 10865, 10885, 10886, 10883
4551, 10583, 10584, 10594, 10593, 10867, 10887, 10888, 10885
4552, 10584, 10585, 10595, 10594, 10869, 10889, 10890, 10887
4553, 10585, 10586, 10596, 10595, 10871, 10891, 10892, 10889
4554, 10586, 768, 769, 10596, 10872, 791, 10893, 10891
4555, 613, 10587, 10597, 614, 10874, 10894, 10895, 636
4556, 10587, 10588, 10598, 10597, 10876, 10896, 10897, 10894
4557, 10588, 10589, 10599, 10598, 10878, 10898, 10899, 10896
4558, 10589, 10590, 10600, 10599, 10880, 10900, 10901, 10898
4559, 10590, 10591, 10601, 10600, 10882, 10902, 10903, 10900
4560, 10591, 10592, 10602, 10601, 10884, 10904, 10905, 10902
4561, 10592, 10593, 10603, 10602, 10886, 10906, 10907, 10904
4562, 10593, 10594, 10604, 10603, 10888, 10908, 10909, 10906
4563, 10594, 10595, 10605, 10604, 10890, 10910, 10911, 10908
4564, 10595, 10596, 10606, 10605, 10892, 10912, 10913, 10910
4565, 10596, 769, 770, 10606, 10893, 792, 10914, 10912
4566, 614, 10597, 10607, 615, 10895, 10915, 10916, 637
4567, 10597, 10598, 10608, 10607, 10897, 10917, 10918, 10915
4568, 10598, 10599, 10609, 10608, 10899, 10919, 10920, 10917
4569, 10599, 10600, 10610, 10609, 10901, 10921, 10922, 10919
4570, 10600, 10601, 10611, 10610, 10903, 10923, 10924, 10921
4571, 10601, 10602, 10612, 10611, 10905, 10925, 10926, 10923
4572, 10602, 10603, 10613, 10612, 10907, 10927, 10928, 10925
4573, 10603, 10604, 10614, 10613, 10909, 10929, 10930, 10927
4574, 10604, 10605, 10615, 10614, 10911, 10931, 10932, 10929
4575, 10605, 10606, 10616, 10615, 10913, 10933, 10934, 10931
4576, 10606, 770, 771, 10616, 10914, 793, 10935, 10933
4577, 615, 10607, 10617, 616, 10916, 10936, 10937, 638
4578, 10607, 10608, 10618, 10617, 10918, 10938, 10939, 10936
4579, 10608, 10609, 10619, 10618, 10920, 10940, 10941, 10938
4580, 10609, 10610, 10620, 10619, 10922, 10942, 10943, 10940
4581, 10610, 10611, 10621, 10620, 10924, 10944, 10945, 10942
4582, 10611, 10612, 10622, 10621, 10926, 10946, 10947, 10944
4583, 10612, 10613, 10623, 10622, 10928, 10948, 10949, 10946
4584, 10613, 10614, 10624, 10623, 10930, 10950, 10951, 10948
4585, 10614, 10615, 10625, 10624, 10932, 10952, 10953, 10950
4586, 10615, 10616, 10626, 10625, 10934, 10954, 10955, 10952
4587, 10616, 771, 772, 10626, 10935, 794, 10956, 10954
4588, 616, 10617, 10627, 617, 10937, 10957, 10958, 639
4589, 10617, 10618, 10628, 10627, 10939, 10959, 10960, 10957
4590, 10618, 10619, 10629, 10628, 10941, 10961, 10962, 10959
4591, 10619, 10620, 10630, 10629, 10943, 10963, 10964, 10961
4592, 10620, 10621, 10631, 10630, 10945, 10965, 10966, 10963
4593, 10621, 10622, 10632, 10631, 10947, 10967, 10968, 10965
4594, 10622, 10623, 10633, 10632, 10949, 10969, 10970, 10967
4595, 10623, 10624, 10634, 10633, 10951, 10971, 10972, 10969
4596, 10624, 10625, 10635, 10634, 10953, 10973, 10974, 10971
4597, 10625, 10626, 10636, 10635, 10955, 10975, 10976, 10973
4598, 10626, 772, 773, 10636, 10956, 795, 10977, 10975
4599, 617, 10627, 10637, 618, 10958, 10978, 10979, 640
4600, 10627, 10628, 10638, 10637, 10960, 10980, 10981, 10978
4601, 10628, 10629, 10639, 10638, 10962, 10982, 10983, 10980
4602, 10629, 10630, 10640, 10639, 10964, 10984, 10985, 10982
4603, 10630, 10631, 10641, 10640, 10966, 10986, 10987, 10984
4604, 10631, 10632, 10642, 10641, 10968, 10988, 10989, 10986
4605, 10632, 10633, 10643, 10642, 10970, 10990, 10991, 10988
4606, 10633, 10634, 10644, 10643, 10972, 10992, 10993, 10990
4607, 10634, 10635, 10645, 10644, 10974, 10994, 10995, 10992
4608, 10635, 10636, 10646, 10645, 10976, 10996, 10997, 10994
4609, 10636, 773, 774, 10646, 10977, 796, 10998, 10996
4610, 618, 10637, 10647, 619, 10979, 10999, 11000, 641
4611, 10637, 10638, 10648, 10647, 10981, 11001, 11002, 10999
4612, 10638, 10639, 10649, 10648, 10983, 11003, 11004, 11001
4613, 10639, 10640, 10650, 10649, 10985, 11005, 11006, 11003
4614, 10640, 10641, 10651, 10650, 10987, 11007, 11008, 11005
4615, 10641, 10642, 10652, 10651, 10989, 11009, 11010, 11007
4616, 10642, 10643, 10653, 10652, 10991, 11011, 11012, 11009
4617, 10643, 10644, 10654, 10653, 10993, 11013, 11014, 11011
4618, 10644, 10645, 10655, 10654, 10995, 11015, 11016, 11013
4619, 10645, 10646, 10656, 10655, 10997, 11017, 11018, 11015
4620, 10646, 774, 775, 10656, 10998, 797, 11019, 11017
4621, 619, 10647, 10657, 620, 11000, 11020, 11021, 642
4622, 10647, 10648, 10658, 10657, 11002, 11022, 11023, 11020
4623, 10648, 10649, 10659, 10658, 11004, 11024, 11025, 11022
4624, 10649, 10650, 10660, 10659, 11006, 11026, 11027, 11024
4625, 10650, 10651, 10661, 10660, 11008, 11028, 11029, 11026
4626, 10651, 10652, 10662, 10661, 11010, 11030, 11031, 11028
4627, 10652, 10653, 10663, 10662, 11012, 11032, 11033, 11030
4628, 10653, 10654, 10664, 10663, 11014, 11034, 11035, 11032
4629, 10654, 10655, 10665, 10664, 11016, 11036, 11037, 11034
4630, 10655, 10656, 10666, 10665, 11018, 11038, 11039, 11036
4631, 10656, 775, 776, 10666, 11019, 798, 11040, 11038
4632, 620, 10657, 10667, 621, 11021, 11041, 11042, 643
4633, 10657, 10658, 10668, 10667, 11023, 11043, 11044, 11041
4634, 10658, 10659, 10669, 10668, 11025, 11045, 11046, 11043
4635, 10659, 10660, 10670, 10669, 11027, 11047, 11048, 11045
4636, 10660, 10661, 10671, 10670, 11029, 11049, 11050, 11047
4637, 10661, 10662, 10672, 10671, 11031, 11051, 11052, 11049
4638, 10662, 10663, 10673, 10672, 11033, 11053, 11054, 11051
4639, 10663, 10664, 10674, 10673, 11035, 11055, 11056, 11053
4640, 10664, 10665, 10675, 10674, 11037, 11057, 11058, 11055
4641, 10665, 10666, 10676, 10675, 11039, 11059, 11060, 11057
4642, 10666, 776, 777, 10676, 11040, 799, 11061, 11059
4643, 621, 10667, 10677, 622, 11042, 11062, 11063, 644
4644, 10667, 10668, 10678, 10677, 11044, 11064, 11065, 11062
4645, 10668, 10669, 10679, 10678, 11046, 11066, 11067, 11064
4646, 10669, 10670, 10680, 10679, 11048, 11068, 11069, 11066
4647, 10670, 10671, 10681, 10680, 11050, 11070, 11071, 11068
4648, 10671, 10672, 10682, 10681, 11052, 11072, 11073, 11070
4649, 10672, 10673, 10683, 10682, 11054, 11074, 11075, 11072
4650, 10673, 10674, 10684, 10683, 11056, 11076, 11077, 11074
4651, 10674, 10675, 10685, 10684, 11058, 11078, 11079, 11076
4652, 10675, 10676, 10686, 10685, 11060, 11080, 11081, 11078
4653, 10676, 777, 778, 10686, 11061, 800, 11082, 11080
4654, 622, 10677, 10687, 623, 11063, 11083, 11084, 645
4655, 10677, 10678, 10688, 10687, 11065, 11085, 11086, 11083
4656, 10678, 10679, 10689, 10688, 11067, 11087, 11088, 11085
4657, 10679, 10680, 10690, 10689, 11069, 11089, 11090, 11087
4658, 10680, 10681, 10691, 10690, 11071, 11091, 11092, 11089
4659, 10681, 10682, 10692, 10691, 11073, 11093, 11094, 11091
4660, 10682, 10683, 10693, 10692, 11075, 11095, 11096, 11093
4661, 10683, 10684, 10694, 10693, 11077, 11097, 11098, 11095
4662, 10684, 10685, 10695, 10694, 11079, 11099, 11100, 11097
4663, 10685, 10686, 10696, 10695, 11081, 11101, 11102, 11099
4664, 10686, 778, 779, 10696, 11082, 801, 11103, 11101
4665, 623, 10687, 10697, 624, 11084, 11104, 11105, 646
4666, 10687, 10688, 10698, 10697, 11086, 11106, 11107, 11104
4667, 10688, 10689, 10699, 10698, 11088, 11108, 11109, 11106
4668, 10689, 10690, 10700, 10699, 11090, 11110, 11111, 11108
4669, 10690, 10691, 10701, 10700, 11092, 11112, 11113, 11110
4670, 10691, 10692, 10702, 10701, 11094, 11114, 11115, 11112
4671, 10692, 10693, 10703, 10702, 11096, 11116, 11117, 11114
4672, 10693, 10694, 10704, 10703, 11098, 11118, 11119, 11116
4673, 10694, 10695, 10705, 10704, 11100, 11120, 11121, 11118
4674, 10695, 10696, 10706, 10705, 11102, 11122, 11123, 11120
4675, 10696, 779, 780, 10706, 11103, 802, 11124, 11122
4676, 624, 10697, 10707, 625, 11105, 11125, 11126, 647
4677, 10697, 10698, 10708, 10707, 11107, 11127, 11128, 11125
4678, 10698, 10699, 10709, 10708, 11109, 11129, 11130, 11127
4679, 10699, 10700, 10710, 10709, 11111, 11131, 11132, 11129
4680, 10700, 10701, 10711, 10710, 11113, 11133, 11134, 11131
4681, 10701, 10702, 10712, 10711, 11115, 11135, 11136, 11133
4682, 10702, 10703, 10713, 10712, 11117, 11137, 11138, 11135
4683, 10703, 10704, 10714, 10713, 11119, 11139, 11140, 11137
4684, 10704, 10705, 10715, 10714, 11121, 11141, 11142, 11139
4685, 10705, 10706, 10716, 10715, 11123, 11143, 11144, 11141
4686, 10706, 780, 781, 10716, 11124, 803, 11145, 11143
4687, 625, 10707, 10717, 626, 11126, 11146, 11147, 648
4688, 10707, 10708, 10718, 10717, 11128, 11148, 11149, 11146
4689, 10708, 10709, 10719, 10718, 11130, 11150, 11151, 11148
4690, 10709, 10710, 10720, 10719, 11132, 11152, 11153, 11150
4691, 10710, 10711, 10721, 10720, 11134, 11154, 11155, 11152
4692, 10711, 10712, 10722, 10721, 11136, 11156, 11157, 11154
4693, 10712, 10713, 10723, 10722, 11138, 11158, 11159, 11156
4694, 10713, 10714, 10724, 10723, 11140, 11160, 11161, 11158
4695, 10714, 10715, 10725, 10724, 11142, 11162, 11163, 11160
4696, 10715, 10716, 10726, 10725, 11144, 11164, 11165, 11162
4697, 10716, 781, 782, 10726, 11145, 804, 11166, 11164
4698, 626, 10717, 10727, 627, 11147, 11167, 11168, 649
4699, 10717, 10718, 10728, 10727, 11149, 11169, 11170, 11167
4700, 10718, 10719, 10729, 10728, 11151, 11171, 11172, 11169
4701, 10719, 10720, 10730, 10729, 11153, 11173, 11174, 11171
4702, 10720, 10721, 10731, 10730, 11155, 11175, 11176, 11173
4703, 10721, 10722, 10732, 10731, 11157, 11177, 11178, 11175
4704, 10722, 10723, 10733, 10732, 11159, 11179, 11180, 11177
4705, 10723, 10724, 10734, 10733, 11161, 11181, 11182, 11179
4706, 10724, 10725, 10735, 10734, 11163, 11183, 11184, 11181
4707, 10725, 10726, 10736, 10735, 11165, 11185, 11186, 11183
4708, 10726, 782, 783, 10736, 11166, 805, 11187, 11185
4709, 627, 10727, 10737, 628, 11168, 11188, 11189, 650
4710, 10727, 10728, 10738, 10737, 11170, 11190, 11191, 11188
4711, 10728, 10729, 10739, 10738, 11172, 11192, 11193, 11190
4712, 10729, 10730, 10740, 10739, 11174, 11194, 11195, 11192
4713, 10730, 10731, 10741, 10740, 11176, 11196, 11197, 11194
4714, 10731, 10732, 10742, 10741, 11178, 11198, 11199, 11196
4715, 10732, 10733, 10743, 10742, 11180, 11200, 11201, 11198
4716, 10733, 10734, 10744, 10743, 11182, 11202, 11203, 11200
4717, 10734, 10735, 10745, 10744, 11184, 11204, 11205, 11202
4718, 10735, 10736, 10746, 10745, 11186, 11206, 11207, 11204
4719, 10736, 783, 784, 10746, 11187, 806, 11208, 11206
4720, 628, 10737, 697, 13, 11189, 11209, 707, 651
4721, 10737, 10738, 698, 697, 11191, 11210, 708, 11209
4722, 10738, 10739, 699, 698, 11193, 11211, 709, 11210
4723, 10739, 10740, 700, 699, 11195, 11212, 710, 11211
4724, 10740, 10741, 701, 700, 11197, 11213, 711, 11212
4725, 10741, 10742, 702, 701, 11199, 11214, 712, 11213
4726, 10742, 10743, 703, 702, 11201, 11215, 713, 11214
4727, 10743, 10744, 704, 703, 11203, 11216, 714, 11215
4728, 10744, 10745, 705, 704, 11205, 11217, 715, 11216
4729, 10745, 10746, 706, 705, 11207, 11218, 716, 11217
4730, 10746, 784, 15, 706, 11208, 807, 717, 11218
*ELEMENT, type=CPS8, ELSET=Surface17
4731, 13, 628, 11219, 829, 651, 11241, 11242, 830
4732, 628, 627, 11220, 11219, 650, 11243, 11244, 11241
4733, 627, 626, 11221, 11220, 649, 11245, 11246, 11243
4734, 626, 625, 11222, 11221, 648, 11247, 11248, 11245
4735, 625, 624, 11223, 11222, 647, 11249, 11250, 11247
4736, 624, 623, 11224, 11223, 646, 11251, 11252, 11249
4737, 623, 622, 11225, 11224, 645, 11253, 11254, 11251
4738, 622, 621, 11226, 11225, 644, 11255, 11256, 11253
4739, 621, 620, 11227, 11226, 643, 11257, 11258, 11255
4740, 620, 619, 11228, 11227, 642, 11259, 11260, 11257
4741, 619, 618, 11229, 11228, 641, 11261, 11262, 11259
4742, 618, 617, 11230, 11229, 640, 11263, 11264, 11261
4743, 617, 616, 11231, 11230, 639, 11265, 11266, 11263
4744, 616, 615, 11232, 11231, 638, 11267, 11268, 11265
4745, 615, 614, 11233, 11232, 637, 11269, 11270, 11267
4746, 614, 613, 11234, 11233, 636, 11271, 11272, 11269
4747, 613, 612, 11235, 11234, 635, 11273, 11274, 11271
4748, 612, 611, 11236, 11235, 634, 11275, 11276, 11273
4749, 611, 610, 11237, 11236, 633, 11277, 11278, 11275
4750, 610, 609, 11238, 11237, 632, 11279, 11280, 11277
4751, 609, 608, 11239, 11238, 631, 11281, 11282, 11279
4752, 608, 607, 11240, 11239, 630, 11283, 11284, 11281
4753, 607, 14, 832, 11240, 629, 833, 11285, 11283
4754, 829, 11219, 856, 17, 11242, 11286, 879, 831
4755, 11219, 11220, 855, 856, 11244, 11287, 878, 11286
4756, 11220, 11221, 854, 855, 11246, 11288, 877, 11287
4757, 11221, 11222, 853, 854, 11248, 11289, 876, 11288
4758, 11222, 11223, 852, 853, 11250, 11290, 875, 11289
4759, 11223, 11224, 851, 852, 11252, 11291, 874, 11290
4760, 11224, 11225, 850, 851, 11254, 11292, 873, 11291
4761, 11225, 11226, 849, 850, 11256, 11293, 872, 11292
4762, 11226, 11227, 848, 849, 11258, 11294, 871, 11293
4763, 11227, 11228, 847, 848, 11260, 11295, 870, 11294
4764, 11228, 11229, 846, 847, 11262, 11296, 869, 11295
4765, 11229, 11230, 845, 846, 11264, 11297, 868, 11296
4766, 11230, 11231, 844, 845, 11266, 11298, 867, 11297
4767, 11231, 11232, 843, 844, 11268, 11299, 866, 11298
4768, 11232, 11233, 842, 843, 11270, 11300, 865, 11299
4769, 11233, 11234, 841, 842, 11272, 11301, 864, 11300
4770, 11234, 11235, 840, 841, 11274, 11302, 863, 11301
4771, 11235, 11236, 839, 840, 11276, 11303, 862, 11302
4772, 11236, 11237, 838, 839, 11278, 11304, 861, 11303
4773, 11237, 11238, 837, 838, 11280, 11305, 860, 11304
4774, 11238, 11239, 836, 837, 11282, 11306, 859, 11305
4775, 11239, 11240, 835, 836, 11284, 11307, 858, 11306
4776, 11240, 832, 18, 835, 11285, 834, 857, 11307
*ELEMENT, type=CPS8, ELSET=Surface18
4777, 15, 706, 11308, 880, 717, 11318, 11319, 881
4778, 706, 705, 11309, 11308, 716, 11320, 11321, 11318
4779, 705, 704, 11310, 11309, 715, 11322, 11323, 11320
4780, 704, 703, 11311, 11310, 714, 11324, 11325, 11322
4781, 703, 702, 11312, 11311, 713, 11326, 11327, 11324
4782, 702, 701, 11313, 11312, 712, 11328, 11329, 11326
4783, 701, 700, 11314, 11313, 711, 11330, 11331, 11328
4784, 700, 699, 11315, 11314, 710, 11332, 11333, 11330
4785, 699, 698, 11316, 11315, 709, 11334, 11335, 11332
4786, 698, 697, 11317, 11316, 708, 11336, 11337, 11334
4787, 697, 13, 829, 11317, 707, 830, 11338, 11336
4788, 880, 11308, 892, 19, 11319, 11339, 903, 882
4789, 11308, 11309, 891, 892, 11321, 11340, 902, 11339
4790, 11309, 11310, 890, 891, 11323, 11341, 901, 11340
4791, 11310, 11311, 889, 890, 11325, 11342, 900, 11341
4792, 11311, 11312, 888, 889, 11327, 11343, 899, 11342
4793, 11312, 11313, 887, 888, 11329, 11344, 898, 11343
4794, 11313, 11314, 886, 887, 11331, 11345, 897, 11344
4795, 11314, 11315, 885, 886, 11333, 11346, 896, 11345
4796, 11315, 11316, 884, 885, 11335, 11347, 895, 11346
4797, 11316, 11317, 883, 884, 11337, 11348, 894, 11347
4798, 11317, 829, 17, 883, 11338, 831, 893, 11348
*ELEMENT, type=CPS8, ELSET=Surface19
4799, 15, 880, 11349, 784, 881, 11371, 11372, 807
4800, 784, 11349, 11350, 783, 11372, 11373, 11374, 806
4801, 783, 11350, 11351, 782, 11374, 11375, 11376, 805
4802, 782, 11351, 11352, 781, 11376, 11377, 11378, 804
4803, 781, 11352, 11353, 780, 11378, 11379, 11380, 803
4804, 780, 11353, 11354, 779, 11380, 11381, 11382, 802
4805, 779, 11354, 11355, 778, 11382, 11383, 11384, 801
4806, 778, 11355, 11356, 777, 11384, 11385, 11386, 800
4807, 777, 11356, 11357, 776, 11386, 11387, 11388, 799
4808, 776, 11357, 11358, 775, 11388, 11389, 11390, 798
4809, 775, 11358, 11359, 774, 11390, 11391, 11392, 797
4810, 774, 11359, 11360, 773, 11392, 11393, 11394, 796
4811, 773, 11360, 11361, 772, 11394, 11395, 11396, 795
4812, 772, 11361, 11362, 771, 11396, 11397, 11398, 794
4813, 771, 11362, 11363, 770, 11398, 11399, 11400, 793
4814, 770, 11363, 11364, 769, 11400, 11401, 11402, 792
4815, 769, 11364, 11365, 768, 11402, 11403, 11404, 791
4816, 768, 11365, 11366, 767, 11404, 11405, 11406, 790
4817, 767, 11366, 11367, 766, 11406, 11407, 11408, 789
4818, 766, 11367, 11368, 765, 11408, 11409, 11410, 788
4819, 765, 11368, 11369, 764, 11410, 11411, 11412, 787
4820, 764, 11369, 11370, 763, 11412, 11413, 11414, 786
4821, 763, 11370, 904, 16, 11414, 11415, 905, 785
4822, 880, 19, 928, 11349, 882, 951, 11416, 11371
4823, 11349, 928, 927, 11350, 11416, 950, 11417, 11373
4824, 11350, 927, 926, 11351, 11417, 949, 11418, 11375
4825, 11351, 926, 925, 11352, 11418, 948, 11419, 11377
4826, 11352, 925, 924, 11353, 11419, 947, 11420, 11379
4827, 11353, 924, 923, 11354, 11420, 946, 11421, 11381
4828, 11354, 923, 922, 11355, 11421, 945, 11422, 11383
4829, 11355, 922, 921, 11356, 11422, 944, 11423, 11385
4830, 11356, 921, 920, 11357, 11423, 943, 11424, 11387
4831, 11357, 920, 919, 11358, 11424, 942, 11425, 11389
4832, 11358, 919, 918, 11359, 11425, 941, 11426, 11391
4833, 11359, 918, 917, 11360, 11426, 940, 11427, 11393
4834, 11360, 917, 916, 11361, 11427, 939, 11428, 11395
4835, 11361, 916, 915, 11362, 11428, 938, 11429, 11397
4836, 11362, 915, 914, 11363, 11429, 937, 11430, 11399
4837, 11363, 914, 913, 11364, 11430, 936, 11431, 11401
4838, 11364, 913, 912, 11365, 11431, 935, 11432, 11403
4839, 11365, 912, 911, 11366, 11432, 934, 11433, 11405
4840, 11366, 911, 910, 11367, 11433, 933, 11434, 11407
4841, 11367, 910, 909, 11368, 11434, 932, 11435, 11409
4842, 11368, 909, 908, 11369, 11435, 931, 11436, 11411
4843, 11369, 908, 907, 11370, 11436, 930, 11437, 11413
4844, 11370, 907, 20, 904, 11437, 929, 906, 11415
*ELEMENT, type=CPS8, ELSET=Surface20
4845, 16, 904, 11438, 817, 905, 11448, 11449, 828
4846, 817, 11438, 11439, 816, 11449, 11450, 11451, 827
4847, 816, 11439, 11440, 815, 11451, 11452, 11453, 826
4848, 815, 11440, 11441, 814, 11453, 11454, 11455, 825
4849, 814, 11441, 11442, 813, 11455, 11456, 11457, 824
4850, 813, 11442, 11443, 812, 11457, 11458, 11459, 823
4851, 812, 11443, 11444, 811, 11459, 11460, 11461, 822
4852, 811, 11444, 11445, 810, 11461, 11462, 11463, 821
4853, 810, 11445, 11446, 809, 11463, 11464, 11465, 820
4854, 809, 11446, 11447, 808, 11465, 11466, 11467, 819
4855, 808, 11447, 832, 14, 11467, 11468, 833, 818
4856, 904, 20, 961, 11438, 906, 972, 11469, 11448
4857, 11438, 961, 960, 11439, 11469, 971, 11470, 11450
4858, 11439, 960, 959, 11440, 11470, 970, 11471, 11452
4859, 11440, 959, 958, 11441, 11471, 969, 11472, 11454
4860, 11441, 958, 957, 11442, 11472, 968, 11473, 11456
4861, 11442, 957, 956, 11443, 11473, 967, 11474, 11458
4862, 11443, 956, 955, 11444, 11474, 966, 11475, 11460
4863, 11444, 955, 954, 11445, 11475, 965, 11476, 11462
4864, 11445, 954, 953, 11446, 11476, 964, 11477, 11464
4865, 11446, 953, 952, 11447, 11477, 963, 11478, 11466
4866, 11447, 952, 18, 832, 11478, 962, 834, 11468
*ELEMENT, type=CPS8, ELSET=Surface21
4867, 18, 952, 11479, 835, 962, 11699, 11700, 857
4868, 952, 953, 11480, 11479, 963, 11701, 11702, 11699
4869, 953, 954, 11481, 11480, 964, 11703, 11704, 11701
4870, 954, 955, 11482, 11481, 965, 11705, 11706, 11703
4871, 955, 956, 11483, 11482, 966, 11707, 11708, 11705
4872, 956, 957, 11484, 11483, 967, 11709, 11710, 11707
4873, 957, 958, 11485, 11484, 968, 11711, 11712, 11709
4874, 958, 959, 11486, 11485, 969, 11713, 11714, 11711
4875, 959, 960, 11487, 11486, 970, 11715, 11716, 11713
4876, 960, 961, 11488, 11487, 971, 11717, 11718, 11715
4877, 961, 20, 907, 11488, 972, 929, 11719, 11717
4878, 835, 11479, 11489, 836, 11700, 11720, 11721, 858
4879, 11479, 11480, 11490, 11489, 11702, 11722, 11723, 11720
4880, 11480, 11481, 11491, 11490, 11704, 11724, 11725, 11722
4881, 11481, 11482, 11492, 11491, 11706, 11726, 11727, 11724
4882, 11482, 11483, 11493, 11492, 11708, 11728, 11729, 11726
4883, 11483, 11484, 11494, 11493, 11710, 11730, 11731, 11728
4884, 11484, 11485, 11495, 11494, 11712, 11732, 11733, 11730
4885, 11485, 11486, 11496, 11495, 11714, 11734, 11735, 11732
4886, 11486, 11487, 11497, 11496, 11716, 11736, 11737, 11734
4887, 11487, 11488, 11498, 11497, 11718, 11738, 11739, 11736
4888, 11488, 907, 908, 11498, 11719, 930, 11740, 11738
4889, 836, 11489, 11499, 837, 11721, 11741, 11742, 859
4890, 11489, 11490, 11500, 11499, 11723, 11743, 11744, 11741
4891, 11490, 11491, 11501, 11500, 11725, 11745, 11746, 11743
4892, 11491, 11492, 11502, 11501, 11727, 11747, 11748, 11745
4893, 11492, 11493, 11503, 11502, 11729, 11749, 11750, 11747
4894, 11493, 11494, 11504, 11503, 11731, 11751, 11752, 11749
4895, 11494, 11495, 11505, 11504, 11733, 11753, 11754, 11751
4896, 11495, 11496, 11506, 11505, 11735, 11755, 11756, 11753
4897, 11496, 11497, 11507, 11506, 11737, 11757, 11758, 11755
4898, 11497, 11498, 11508, 11507, 11739, 11759, 11760, 11757
4899, 11498, 908, 909, 11508, 11740, 931, 11761, 11759
4900, 837, 11499, 11509, 838, 11742, 11762, 11763, 860
4901, 11499, 11500, 11510, 11509, 11744, 11764, 11765, 11762
4902, 11500, 11501, 11511, 11510, 11746, 11766, 11767, 11764
4903, 11501, 11502, 11512, 11511, 11748, 11768, 11769, 11766
4904, 11502, 11503, 11513, 11512, 11750, 11770, 11771, 11768
4905, 11503, 11504, 11514, 11513, 11752, 11772, 11773, 11770
4906, 11504, 11505, 11515, 11514, 11754, 11774, 11775, 11772
4907, 11505, 11506, 11516, 11515, 11756, 11776, 11777, 11774
4908, 11506, 11507, 11517, 11516, 11758, 11778, 11779, 11776
4909, 11507, 11508, 11518, 11517, 11760, 11780, 11781, 11778
4910, 11508, 909, 910, 11518, 11761, 932, 11782, 11780
4911, 838, 11509, 11519, 839, 11763, 11783, 11784, 861
4912, 11509, 11510, 11520, 11519, 11765, 11785, 11786, 11783
4913, 11510, 11511, 11521, 11520, 11767, 11787, 11788, 11785
4914, 11511, 11512, 11522, 11521, 11769, 11789, 11790, 11787
4915, 11512, 11513, 11523, 11522, 11771, 11791, 11792, 11789
4916, 11513, 11514, 11524, 11523, 11773, 11793, 11794, 11791
4917, 11514, 11515, 11525, 11524, 11775, 11795, 11796, 11793
4918, 11515, 11516, 11526, 11525, 11777, 11797, 11798, 11795
4919, 11516, 11517, 11527, 11526, 11779, 11799, 11800, 11797
4920, 11517, 11518, 11528, 11527, 11781, 11801, 11802, 11799
4921, 11518, 910, 911, 11528, 11782, 933, 11803, 11801
4922, 839, 11519, 11529, 840, 11784, 11804, 11805, 862
4923, 11519, 11520, 11530, 11529, 11786, 11806, 11807, 11804
4924, 11520, 11521, 11531, 11530, 11788, 11808, 11809, 11806
4925, 11521, 11522, 11532, 11531, 11790, 11810, 11811, 11808
4926, 11522, 11523, 11533, 11532, 11792, 11812, 11813, 11810
4927, 11523, 11524, 11534, 11533, 11794, 11814, 11815, 11812
4928, 11524, 11525, 11535, 11534, 11796, 11816, 11817, 11814
4929, 11525, 11526, 11536, 11535, 11798, 11818, 11819, 11816
4930, 11526, 11527, 11537, 11536, 11800, 11820, 11821, 11818
4931, 11527, 11528, 11538, 11537, 11802, 11822, 11823, 11820
4932, 11528, 911, 912, 11538, 11803, 934, 11824, 11822
4933, 840, 11529, 11539, 841, 11805, 11825, 11826, 863
4934, 11529, 11530, 11540, 11539, 11807, 11827, 11828, 11825
4935, 11530, 11531, 11541, 11540, 11809, 11829, 11830, 11827
4936, 11531, 11532, 11542, 11541, 11811, 11831, 11832, 11829
4937, 11532, 11533, 11543, 11542, 11813, 11833, 11834, 11831
4938, 11533, 11534, 11544, 11543, 11815, 11835, 11836, 11833
4939, 11534, 11535, 11545, 11544, 11817, 11837, 11838, 11835
4940, 11535, 11536, 11546, 11545, 11819, 11839, 11840, 11837
4941, 11536, 11537, 11547, 11546, 11821, 11841, 11842, 11839
4942, 11537, 11538, 11548, 11547, 11823, 11843, 11844, 11841
4943, 11538, 912, 913, 11548, 11824, 935, 11845, 11843
4944, 841, 11539, 11549, 842, 11826, 11846, 11847, 864
4945, 11539, 11540, 11550, 11549, 11828, 11848, 11849, 11846
4946, 11540, 11541, 11551, 11550, 11830, 11850, 11851, 11848
4947, 11541, 11542, 11552, 11551, 11832, 11852, 11853, 11850
4948, 11542, 11543, 11553, 11552, 11834, 11854, 11855, 11852
4949, 11543, 11544, 11554, 11553, 11836, 11856, 11857, 11854
4950, 11544, 11545, 11555, 11554, 11838, 11858, 11859, 11856
4951, 11545, 11546, 11556, 11555, 11840, 11860, 11861, 11858
4952, 11546, 11547, 11557, 11556, 11842, 11862, 11863, 11860
4953, 11547, 11548, 11558, 11557, 11844, 11864, 11865, 11862
4954, 11548, 913, 914, 11558, 11845, 936, 11866, 11864
4955, 842, 11549, 11559, 843, 11847, 11867, 11868, 865
4956, 11549, 11550, 11560, 11559, 11849, 11869, 11870, 11867
4957, 11550, 11551, 11561, 11560, 11851, 11871, 11872, 11869
4958, 11551, 11552, 11562, 11561, 11853, 11873, 11874, 11871
4959, 11552, 11553, 11563, 11562, 11855, 11875, 11876, 11873
4960, 11553, 11554, 11564, 11563, 11857, 11877, 11878, 11875
4961, 11554, 11555, 11565, 11564, 11859, 11879, 11880, 11877
4962, 11555, 11556, 11566, 11565, 11861, 11881, 11882, 11879
4963, 11556, 11557, 11567, 11566, 11863, 11883, 11884, 11881
4964, 11557, 11558, 11568, 11567, 11865, 11885, 11886, 11883
4965, 11558, 914, 915, 11568, 11866, 937, 11887, 11885
4966, 843, 11559, 11569, 844, 11868, 11888, 11889, 866
4967, 11559, 11560, 11570, 11569, 11870, 11890, 11891, 11888
4968, 11560, 11561, 11571, 11570, 11872, 11892, 11893, 11890
4969, 11561, 11562, 11572, 11571, 11874, 11894, 11895, 11892
4970, 11562, 11563, 11573, 11572, 11876, 11896, 11897, 11894
4971, 11563, 11564, 11574, 11573, 11878, 11898, 11899, 11896
4972, 11564, 11565, 11575, 11574, 11880, 11900, 11901, 11898
4973, 11565, 11566, 11576, 11575, 11882, 11902, 11903, 11900
4974, 11566, 11567, 11577, 11576, 11884, 11904, 11905, 11902
4975, 11567, 11568, 11578, 11577, 11886, 11906, 11907, 11904
4976, 11568, 915, 916, 11578, 11887, 938, 11908, 11906
4977, 844, 11569, 11579, 845, 11889, 11909, 11910, 867
4978, 11569, 11570, 11580, 11579, 11891, 11911, 11912, 11909
4979, 11570, 11571, 11581, 11580, 11893, 11913, 11914, 11911
4980, 11571, 11572, 11582, 11581, 11895, 11915, 11916, 11913
4981, 11572, 11573, 11583, 11582, 11897, 11917, 11918, 11915
4982, 11573, 11574, 11584, 11583, 11899, 11919, 11920, 11917
4983, 11574, 11575, 11585, 11584, 11901, 11921, 11922, 11919
4984, 11575, 11576, 11586, 11585, 11903, 11923, 11924, 11921
4985, 11576, 11577, 11587, 11586, 11905, 11925, 11926, 11923
4986, 11577, 11578, 11588, 11587, 11907, 11927, 11928, 11925
4987, 11578, 916, 917, 11588, 11908, 939, 11929, 11927
4988, 845, 11579, 11589, 846, 11910, 11930, 11931, 868
4989, 11579, 11580, 11590, 11589, 11912, 11932, 11933, 11930
4990, 11580, 11581, 11591, 11590, 11914, 11934, 11935, 11932
4991, 11581, 11582, 11592, 11591, 11916, 11936, 11937, 11934
4992, 11582, 11583, 11593, 11592, 11918, 11938, 11939, 11936
4993, 11583, 11584, 11594, 11593, 11920, 11940, 11941, 11938
4994, 11584, 11585, 11595, 11594, 11922, 11942, 11943, 11940
4995, 11585, 11586, 11596, 11595, 11924, 11944, 11945, 11942
4996, 11586, 11587, 11597, 11596, 11926, 11946, 11947, 11944
4997, 11587, 11588, 11598, 11597, 11928, 11948, 11949, 11946
4998, 11588, 917, 918, 11598, 11929, 940, 11950, 11948
4999, 846, 11589, 11599, 847, 11931, 11951, 11952, 869
5000, 11589, 11590, 11600, 11599, 11933, 11953, 11954, 11951
5001, 11590, 11591, 11601, 11600, 11935, 11955, 11956, 11953
5002, 11591, 11592, 11602, 11601, 11937, 11957, 11958, 11955
5003, 11592, 11593, 11603, 11602, 11939, 11959, 11960, 11957
5004, 11593, 11594, 11604, 11603, 11941, 11961, 11962, 11959
5005, 11594, 11595, 11605, 11604, 11943, 11963, 11964, 11961
5006, 11595, 11596, 11606, 11605, 11945, 11965, 11966, 11963
5007, 11596, 11597, 11607, 11606, 11947, 11967, 11968, 11965
5008, 11597, 11598, 11608, 11607, 11949, 11969, 11970, 11967
5009, 11598, 918, 919, 11608, 11950, 941, 11971, 11969
5010, 847, 11599, 11609, 848, 11952, 11972, 11973, 870
5011, 11599, 11600, 11610, 11609, 11954, 11974, 11975, 11972
5012, 11600, 11601, 11611, 11610, 11956, 11976, 11977, 11974
5013, 11601, 11602, 11612, 11611, 11958, 11978, 11979, 11976
5014, 11602, 11603, 11613, 11612, 11960, 11980, 11981, 11978
5015, 11603, 11604, 11614, 11613, 11962, 11982, 11983, 11980
5016, 11604, 11605, 11615, 11614, 11964, 11984, 11985, 11982
5017, 11605, 11606, 11616, 11615, 11966, 11986, 11987, 11984
5018, 11606, 11607, 11617, 11616, 11968, 11988, 11989, 11986
5019, 11607, 11608, 11618, 11617, 11970, 11990, 11991, 11988
5020, 11608, 919, 920, 11618, 11971, 942, 11992, 11990
5021, 848, 11609, 11619, 849, 11973, 11993, 11994, 871
5022, 11609, 11610, 11620, 11619, 11975, 11995, 11996, 11993
5023, 11610, 11611, 11621, 11620, 11977, 11997, 11998, 11995
5024, 11611, 11612, 11622, 11621, 11979, 11999, 12000, 11997
5025, 11612, 11613, 11623, 11622, 11981, 12001, 12002, 11999
5026, 11613, 11614, 11624, 11623, 11983, 12003, 12004, 12001
5027, 11614, 11615, 11625, 11624, 11985, 12005, 12006, 12003
5028, 11615, 11616, 11626, 11625, 11987, 12007, 12008, 12005
5029, 11616, 11617, 11627, 11626, 11989, 12009, 12010, 12007
5030, 11617, 11618, 11628, 11627, 11991, 12011, 12012, 12009
5031, 11618, 920, 921, 11628, 11992, 943, 12013, 12011
5032, 849, 11619, 11629, 850, 11994, 12014, 12015, 872
5033, 11619, 11620, 11630, 11629, 11996, 12016, 12017, 12014
5034, 11620, 11621, 11631, 11630, 11998, 12018, 12019, 12016
5035, 11621, 11622, 11632, 11631, 12000, 12020, 12021, 12018
5036, 11622, 11623, 11633, 11632, 12002, 12022, 12023, 12020
5037, 11623, 11624, 11634, 11633, 12004, 12024, 12025, 12022
5038, 11624, 11625, 11635, 11634, 12006, 12026, 12027, 12024
5039, 11625, 11626, 11636, 11635, 12008, 12028, 12029, 12026
5040, 11626, 11627, 11637, 11636, 12010, 12030, 12031, 12028
5041, 11627, 11628, 11638, 11637, 12012, 12032, 12033, 12030
5042, 11628, 921, 922, 11638, 12013, 944, 12034, 12032
5043, 850, 11629, 11639, 851, 12015, 12035, 12036, 873
5044, 11629, 11630, 11640, 11639, 12017, 12037, 12038, 12035
5045, 11630, 11631, 11641, 11640, 12019, 12039, 12040, 12037
5046, 11631, 11632, 11642, 11641, 12021, 12041, 12042, 12039
5047, 11632, 11633, 11643, 11642, 12023, 12043, 12044, 12041
5048, 11633, 11634, 11644, 11643, 12025, 12045, 12046, 12043
5049, 11634, 11635, 11645, 11644, 12027, 12047, 12048, 12045
5050, 11635, 11636, 11646, 11645, 12029, 12049, 12050, 12047
5051, 11636, 11637, 11647, 11646, 12031, 12051, 12052, 12049
5052, 11637, 11638, 11648, 11647, 12033, 12053, 12054, 12051
5053, 11638, 922, 923, 11648, 12034, 945, 12055, 12053
5054, 851, 11639, 11649, 852, 12036, 12056, 12057, 874
5055, 11639, 11640, 11650, 11649, 12038, 12058, 12059, 12056
5056, 11640, 11641, 11651, 11650, 12040, 12060, 12061, 12058
5057, 11641, 11642, 11652, 11651, 12042, 12062, 12063, 12060
5058, 11642, 11643, 11653, 11652, 12044, 12064, 12065, 12062
5059, 11643, 11644, 11654, 11653, 12046, 12066, 12067, 12064
5060, 11644, 11645, 11655, 11654, 12048, 12068, 12069, 12066
5061, 11645, 11646, 11656, 11655, 12050, 12070, 12071, 12068
5062, 11646, 11647, 11657, 11656, 12052, 12072, 12073, 12070
5063, 11647, 11648, 11658, 11657, 12054, 12074, 12075, 12072
5064, 11648, 923, 924, 11658, 12055, 946, 12076, 12074
5065, 852, 11649, 11659, 853, 12057, 12077, 12078, 875
5066, 11649, 11650, 11660, 11659, 12059, 12079, 12080, 12077
5067, 11650, 11651, 11661, 11660, 12061, 12081, 12082, 12079
5068, 11651, 11652, 11662, 11661, 12063, 12083, 12084, 12081
5069, 11652, 11653, 11663, 11662, 12065, 12085, 12086, 12083
5070, 11653, 11654, 11664, 11663, 12067, 12087, 12088, 12085
5071, 11654, 11655, 11665, 11664, 12069, 12089, 12090, 12087
5072, 11655, 11656, 11666, 11665, 12071, 12091, 12092, 12089
5073, 11656, 11657, 11667, 11666, 12073, 12093, 12094, 12091
5074, 11657, 11658, 11668, 11667, 12075, 12095, 12096, 12093
5075, 11658, 924, 925, 11668, 12076, 947, 12097, 12095
5076, 853, 11659, 11669, 854, 12078, 12098, 12099, 876
5077, 11659, 11660, 11670, 11669, 12080, 12100, 12101, 12098
5078, 11660, 11661, 11671, 11670, 12082, 12102, 12103, 12100
5079, 11661, 11662, 11672, 11671, 12084, 12104, 12105, 12102
5080, 11662, 11663, 11673, 11672, 12086, 12106, 12107, 12104
5081, 11663, 11664, 11674, 11673, 12088, 12108, 12109, 12106
5082, 11664, 11665, 11675, 11674, 12090, 12110, 12111, 12108
5083, 11665, 11666, 11676, 11675, 12092, 12112, 12113, 12110
5084, 11666, 11667, 11677, 11676, 12094, 12114, 12115, 12112
5085, 11667, 11668, 11678, 11677, 12096, 12116, 12117, 12114
5086, 11668, 925, 926, 11678, 12097, 948, 12118, 12116
5087, 854, 11669, 11679, 855, 12099, 12119, 12120, 877
5088, 11669, 11670, 11680, 11679, 12101, 12121, 12122, 12119
5089, 11670, 11671, 11681, 11680, 12103, 12123, 12124, 12121
5090, 11671, 11672, 11682, 11681, 12105, 12125, 12126, 12123
5091, 11672, 11673, 11683, 11682, 12107, 12127, 12128, 12125
5092, 11673, 11674, 11684, 11683, 12109, 12129, 12130, 12127
5093, 11674, 11675, 11685, 11684, 12111, 12131, 12132, 12129
5094, 11675, 11676, 11686, 11685, 12113, 12133, 12134, 12131
5095, 11676, 11677, 11687, 11686, 12115, 12135, 12136, 12133
5096, 11677, 11678, 11688, 11687, 12117, 12137, 12138, 12135
5097, 11678, 926, 927, 11688, 12118, 949, 12139, 12137
5098, 855, 11679, 11689, 856, 12120, 12140, 12141, 878
5099, 11679, 11680, 11690, 11689, 12122, 12142, 12143, 12140
5100, 11680, 11681, 11691, 11690, 12124, 12144, 12145, 12142
5101, 11681, 11682, 11692, 11691, 12126, 12146, 12147, 12144
5102, 11682, 11683, 11693, 11692, 12128, 12148, 12149, 12146
5103, 11683, 11684, 11694, 11693, 12130, 12150, 12151, 12148
5104, 11684, 11685, 11695, 11694, 12132, 12152, 12153, 12150
5105, 11685, 11686, 11696, 11695, 12134, 12154, 12155, 12152
5106, 11686, 11687, 11697, 11696, 12136, 12156, 12157, 12154
5107, 11687, 11688, 11698, 11697, 12138, 12158, 12159, 12156
5108, 11688, 927, 928, 11698, 12139, 950, 12160, 12158
5109, 856, 11689, 883, 17, 12141, 12161, 893, 879
5110, 11689, 11690, 884, 883, 12143, 12162, 894, 12161
5111, 11690, 11691, 885, 884, 12145, 12163, 895, 12162
5112, 11691, 11692, 886, 885, 12147, 12164, 896, 12163
5113, 11692, 11693, 887, 886, 12149, 12165, 897, 12164
5114, 11693, 11694, 888, 887, 12151, 12166, 898, 12165
5115, 11694, 11695, 889, 888, 12153, 12167, 899, 12166
5116, 11695, 11696, 890, 889, 12155, 12168, 900, 12167
5117, 11696, 11697, 891, 890, 12157, 12169, 901, 12168
5118, 11697, 11698, 892, 891, 12159, 12170, 902, 12169
5119, 11698, 928, 19, 892, 12160, 951, 903, 12170
*ELEMENT, type=CPS8, ELSET=Surface22
5120, 17, 856, 12171, 973, 879, 12215, 12216, 975
5121, 856, 855, 12172, 12171, 878, 12217, 12218, 12215
5122, 855, 854, 12173, 12172, 877, 12219, 12220, 12217
5123, 854, 853, 12174, 12173, 876, 12221, 12222, 12219
5124, 853, 852, 12175, 12174, 875, 12223, 12224, 12221
5125, 852, 851, 12176, 12175, 874, 12225, 12226, 12223
5126, 851, 850, 12177, 12176, 873, 12227, 12228, 12225
5127, 850, 849, 12178, 12177, 872, 12229, 12230, 12227
5128, 849, 848, 12179, 12178, 871, 12231, 12232, 12229
5129, 848, 847, 12180, 12179, 870, 12233, 12234, 12231
5130, 847, 846, 12181, 12180, 869, 12235, 12236, 12233
5131, 846, 845, 12182, 12181, 868, 12237, 12238, 12235
5132, 845, 844, 12183, 12182, 867, 12239, 12240, 12237
5133, 844, 843, 12184, 12183, 866, 12241, 12242, 12239
5134, 843, 842, 12185, 12184, 865, 12243, 12244, 12241
5135, 842, 841, 12186, 12185, 864, 12245, 12246, 12243
5136, 841, 840, 12187, 12186, 863, 12247, 12248, 12245
5137, 840, 839, 12188, 12187, 862, 12249, 12250, 12247
5138, 839, 838, 12189, 12188, 861, 12251, 12252, 12249
5139, 838, 837, 12190, 12189, 860, 12253, 12254, 12251
5140, 837, 836, 12191, 12190, 859, 12255, 12256, 12253
5141, 836, 835, 12192, 12191, 858, 12257, 12258, 12255
5142, 835, 18, 978, 12192, 857, 980, 12259, 12257
5143, 973, 12171, 12193, 974, 12216, 12260, 12261, 976
5144, 12171, 12172, 12194, 12193, 12218, 12262, 12263, 12260
5145, 12172, 12173, 12195, 12194, 12220, 12264, 12265, 12262
5146, 12173, 12174, 12196, 12195, 12222, 12266, 12267, 12264
5147, 12174, 12175, 12197, 12196, 12224, 12268, 12269, 12266
5148, 12175, 12176, 12198, 12197, 12226, 12270, 12271, 12268
5149, 12176, 12177, 12199, 12198, 12228, 12272, 12273, 12270
5150, 12177, 12178, 12200, 12199, 12230, 12274, 12275, 12272
5151, 12178, 12179, 12201, 12200, 12232, 12276, 12277, 12274
5152, 12179, 12180, 12202, 12201, 12234, 12278, 12279, 12276
5153, 12180, 12181, 12203, 12202, 12236, 12280, 12281, 12278
5154, 12181, 12182, 12204, 12203, 12238, 12282, 12283, 12280
5155, 12182, 12183, 12205, 12204, 12240, 12284, 12285, 12282
5156, 12183, 12184, 12206, 12205, 12242, 12286, 12287, 12284
5157, 12184, 12185, 12207, 12206, 12244, 12288, 12289, 12286
5158, 12185, 12186, 12208, 12207, 12246, 12290, 12291, 12288
5159, 12186, 12187, 12209, 12208, 12248, 12292, 12293, 12290
5160, 12187, 12188, 12210, 12209, 12250, 12294, 12295, 12292
5161, 12188, 12189, 12211, 12210, 12252, 12296, 12297, 12294
5162, 12189, 12190, 12212, 12211, 12254, 12298, 12299, 12296
5163, 12190, 12191, 12213, 12212, 12256, 12300, 12301, 12298
5164, 12191, 12192, 12214, 12213, 12258, 12302, 12303, 12300
5165, 12192, 978, 979, 12214, 12259, 981, 12304, 12302
5166, 974, 12193, 1004, 21, 12261, 12305, 1027, 977
5167, 12193, 12194, 1003, 1004, 12263, 12306, 1026, 12305
5168, 12194, 12195, 1002, 1003, 12265, 12307, 1025, 12306
5169, 12195, 12196, 1001, 1002, 12267, 12308, 1024, 12307
5170, 12196, 12197, 1000, 1001, 12269, 12309, 1023, 12308
5171, 12197, 12198, 999, 1000, 12271, 12310, 1022, 12309
5172, 12198, 12199, 998, 999, 12273, 12311, 1021, 12310
5173, 12199, 12200, 997, 998, 12275, 12312, 1020, 12311
5174, 12200, 12201, 996, 997, 12277, 12313, 1019, 12312
5175, 12201, 12202, 995, 996, 12279, 12314, 1018, 12313
5176, 12202, 12203, 994, 995, 12281, 12315, 1017, 12314
5177, 12203, 12204, 993, 994, 12283, 12316, 1016, 12315
5178, 12204, 12205, 992, 993, 12285, 12317, 1015, 12316
5179, 12205, 12206, 991, 992, 12287, 12318, 1014, 12317
5180, 12206, 12207, 990, 991, 12289, 12319, 1013, 12318
5181, 12207, 12208, 989, 990, 12291, 12320, 1012, 12319
5182, 12208, 12209, 988, 989, 12293, 12321, 1011, 12320
5183, 12209, 12210, 987, 988, 12295, 12322, 1010, 12321
5184, 12210, 12211, 986, 987, 12297, 12323, 1009, 12322
5185, 12211, 12212, 985, 986, 12299, 12324, 1008, 12323
5186, 12212, 12213, 984, 985, 12301, 12325, 1007, 12324
5187, 12213, 12214, 983, 984, 12303, 12326, 1006, 12325
5188, 12214, 979, 22, 983, 12304, 982, 1005, 12326
*ELEMENT, type=CPS8, ELSET=Surface23
5189, 19, 892, 12327, 1028, 903, 12347, 12348, 1030
5190, 892, 891, 12328, 12327, 902, 12349, 12350, 12347
5191, 891, 890, 12329, 12328, 901, 12351, 12352, 12349
5192, 890, 889, 12330, 12329, 900, 12353, 12354, 12351
5193, 889, 888, 12331, 12330, 899, 12355, 12356, 12353
5194, 888, 887, 12332, 12331, 898, 12357, 12358, 12355
5195, 887, 886, 12333, 12332, 897, 12359, 12360, 12357
5196, 886, 885, 12334, 12333, 896, 12361, 12362, 12359
5197, 885, 884, 12335, 12334, 895, 12363, 12364, 12361
5198, 884, 883, 12336, 12335, 894, 12365, 12366, 12363
5199, 883, 17, 973, 12336, 893, 975, 12367, 12365
5200, 1028, 12327, 12337, 1029, 12348, 12368, 12369, 1031
5201, 12327, 12328, 12338, 12337, 12350, 12370, 12371, 12368
5202, 12328, 12329, 12339, 12338, 12352, 12372, 12373, 12370
5203, 12329, 12330, 12340, 12339, 12354, 12374, 12375, 12372
5204, 12330, 12331, 12341, 12340, 12356, 12376, 12377, 12374
5205, 12331, 12332, 12342, 12341, 12358, 12378, 12379, 12376
5206, 12332, 12333, 12343, 12342, 12360, 12380, 12381, 12378
5207, 12333, 12334, 12344, 12343, 12362, 12382, 12383, 12380
5208, 12334, 12335, 12345, 12344, 12364, 12384, 12385, 12382
5209, 12335, 12336, 12346, 12345, 12366, 12386, 12387, 12384
5210, 12336, 973, 974, 12346, 12367, 976, 12388, 12386
5211, 1029, 12337, 1042, 23, 12369, 12389, 1053, 1032
5212, 12337, 12338, 1041, 1042, 12371, 12390, 1052, 12389
5213, 12338, 12339, 1040, 1041, 12373, 12391, 1051, 12390
5214, 12339, 12340, 1039, 1040, 12375, 12392, 1050, 12391
5215, 12340, 12341, 1038, 1039, 12377, 12393, 1049, 12392
5216, 12341, 12342, 1037, 1038, 12379, 12394, 1048, 12393
5217, 12342, 12343, 1036, 1037, 12381, 12395, 1047, 12394
5218, 12343, 12344, 1035, 1036, 12383, 12396, 1046, 12395
5219, 12344, 12345, 1034, 1035, 12385, 12397, 1045, 12396
5220, 12345, 12346, 1033, 1034, 12387, 12398, 1044, 12397
5221, 12346, 974, 21, 1033, 12388, 977, 1043, 12398
*ELEMENT, type=CPS8, ELSET=Surface24
5222, 19, 1028, 12399, 928, 1030, 12443, 12444, 951
5223, 928, 12399, 12400, 927, 12444, 12445, 12446, 950
5224, 927, 12400, 12401, 926, 12446, 12447, 12448, 949
5225, 926, 12401, 12402, 925, 12448, 12449, 12450, 948
5226, 925, 12402, 12403, 924, 12450, 12451, 12452, 947
5227, 924, 12403, 12404, 923, 12452, 12453, 12454, 946
5228, 923, 12404, 12405, 922, 12454, 12455, 12456, 945
5229, 922, 12405, 12406, 921, 12456, 12457, 12458, 944
5230, 921, 12406, 12407, 920, 12458, 12459, 12460, 943
5231, 920, 12407, 12408, 919, 12460, 12461, 12462, 942
5232, 919, 12408, 12409, 918, 12462, 12463, 12464, 941
5233, 918, 12409, 12410, 917, 12464, 12465, 12466, 940
5234, 917, 12410, 12411, 916, 12466, 12467, 12468, 939
5235, 916, 12411, 12412, 915, 12468, 12469, 12470, 938
5236, 915, 12412, 12413, 914, 12470, 12471, 12472, 937
5237, 914, 12413, 12414, 913, 12472, 12473, 12474, 936
5238, 913, 12414, 12415, 912, 12474, 12475, 12476, 935
5239, 912, 12415, 12416, 911, 12476, 12477, 12478, 934
5240, 911, 12416, 12417, 910, 12478, 12479, 12480, 933
5241, 910, 12417, 12418, 909, 12480, 12481, 12482, 932
5242, 909, 12418, 12419, 908, 12482, 12483, 12484, 931
5243, 908, 12419, 12420, 907, 12484, 12485, 12486, 930
5244, 907, 12420, 1054, 20, 12486, 12487, 1056, 929
5245, 1028, 1029, 12421, 12399, 1031, 12488, 12489, 12443
5246, 12399, 12421, 12422, 12400, 12489, 12490, 12491, 12445
5247, 12400, 12422, 12423, 12401, 12491, 12492, 12493, 12447
5248, 12401, 12423, 12424, 12402, 12493, 12494, 12495, 12449
5249, 12402, 12424, 12425, 12403, 12495, 12496, 12497, 12451
5250, 12403, 12425, 12426, 12404, 12497, 12498, 12499, 12453
5251, 12404, 12426, 12427, 12405, 12499, 12500, 12501, 12455
5252, 12405, 12427, 12428, 12406, 12501, 12502, 12503, 12457
5253, 12406, 12428, 12429, 12407, 12503, 12504, 12505, 12459
5254, 12407, 12429, 12430, 12408, 12505, 12506, 12507, 12461
5255, 12408, 12430, 12431, 12409, 12507, 12508, 12509, 12463
5256, 12409, 12431, 12432, 12410, 12509, 12510, 12511, 12465
5257, 12410, 12432, 12433, 12411, 12511, 12512, 12513, 12467
5258, 12411, 12433, 12434, 12412, 12513, 12514, 12515, 12469
5259, 12412, 12434, 12435, 12413, 12515, 12516, 12517, 12471
5260, 12413, 12435, 12436, 12414, 12517, 12518, 12519, 12473
5261, 12414, 12436, 12437, 12415, 12519, 12520, 12521, 12475
5262, 12415, 12437, 12438, 12416, 12521, 12522, 12523, 12477
5263, 12416, 12438, 12439, 12417, 12523, 12524, 12525, 12479
5264, 12417, 12439, 12440, 12418, 12525, 12526, 12527, 12481
5265, 12418, 12440, 12441, 12419, 12527, 12528, 12529, 12483
5266, 12419, 12441, 12442, 12420, 12529, 12530, 12531, 12485
5267, 12420, 12442, 1055, 1054, 12531, 12532, 1057, 12487
5268, 1029, 23, 1080, 12421, 1032, 1103, 12533, 12488
5269, 12421, 1080, 1079, 12422, 12533, 1102, 12534, 12490
5270, 12422, 1079, 1078, 12423, 12534, 1101, 12535, 12492
5271, 12423, 1078, 1077, 12424, 12535, 1100, 12536, 12494
5272, 12424, 1077, 1076, 12425, 12536, 1099, 12537, 12496
5273, 12425, 1076, 1075, 12426, 12537, 1098, 12538, 12498
5274, 12426, 1075, 1074, 12427, 12538, 1097, 12539, 12500
5275, 12427, 1074, 1073, 12428, 12539, 1096, 12540, 12502
5276, 12428, 1073, 1072, 12429, 12540, 1095, 12541, 12504
5277, 12429, 1072, 1071, 12430, 12541, 1094, 12542, 12506
5278, 12430, 1071, 1070, 12431, 12542, 1093, 12543, 12508
5279, 12431, 1070, 1069, 12432, 12543, 1092, 12544, 12510
5280, 12432, 1069, 1068, 12433, 12544, 1091, 12545, 12512
5281, 12433, 1068, 1067, 12434, 12545, 1090, 12546, 12514
5282, 12434, 1067, 1066, 12435, 12546, 1089, 12547, 12516
5283, 12435, 1066, 1065, 12436, 12547, 1088, 12548, 12518
5284, 12436, 1065, 1064, 12437, 12548, 1087, 12549, 12520
5285, 12437, 1064, 1063, 12438, 12549, 1086, 12550, 12522
5286, 12438, 1063, 1062, 12439, 12550, 1085, 12551, 12524
5287, 12439, 1062, 1061, 12440, 12551, 1084, 12552, 12526
5288, 12440, 1061, 1060, 12441, 12552, 1083, 12553, 12528
5289, 12441, 1060, 1059, 12442, 12553, 1082, 12554, 12530
5290, 12442, 1059, 24, 1055, 12554, 1081, 1058, 12532
*ELEMENT, type=CPS8, ELSET=Surface25
5291, 20, 1054, 12555, 961, 1056, 12575, 12576, 972
5292, 961, 12555, 12556, 960, 12576, 12577, 12578, 971
5293, 960, 12556, 12557, 959, 12578, 12579, 12580, 970
5294, 959, 12557, 12558, 958, 12580, 12581, 12582, 969
5295, 958, 12558, 12559, 957, 12582, 12583, 12584, 968
5296, 957, 12559, 12560, 956, 12584, 12585, 12586, 967
5297, 956, 12560, 12561, 955, 12586, 12587, 12588, 966
5298, 955, 12561, 12562, 954, 12588, 12589, 12590, 965
5299, 954, 12562, 12563, 953, 12590, 12591, 12592, 964
5300, 953, 12563, 12564, 952, 12592, 12593, 12594, 963
5301, 952, 12564, 978, 18, 12594, 12595, 980, 962
5302, 1054, 1055, 12565, 12555, 1057, 12596, 12597, 12575
5303, 12555, 12565, 12566, 12556, 12597, 12598, 12599, 12577
5304, 12556, 12566, 12567, 12557, 12599, 12600, 12601, 12579
5305, 12557, 12567, 12568, 12558, 12601, 12602, 12603, 12581
5306, 12558, 12568, 12569, 12559, 12603, 12604, 12605, 12583
5307, 12559, 12569, 12570, 12560, 12605, 12606, 12607, 12585
5308, 12560, 12570, 12571, 12561, 12607, 12608, 12609, 12587
5309, 12561, 12571, 12572, 12562, 12609, 12610, 12611, 12589
5310, 12562, 12572, 12573, 12563, 12611, 12612, 12613, 12591
5311, 12563, 12573, 12574, 12564, 12613, 12614, 12615, 12593
5312, 12564, 12574, 979, 978, 12615, 12616, 981, 12595
5313, 1055, 24, 1113, 12565, 1058, 1124, 12617, 12596
5314, 12565, 1113, 1112, 12566, 12617, 1123, 12618, 12598
5315, 12566, 1112, 1111, 12567, 12618, 1122, 12619, 12600
5316, 12567, 1111, 1110, 12568, 12619, 1121, 12620, 12602
5317, 12568, 1110, 1109, 12569, 12620, 1120, 12621, 12604
5318, 12569, 1109, 1108, 12570, 12621, 1119, 12622, 12606
5319, 12570, 1108, 1107, 12571, 12622, 1118, 12623, 12608
5320, 12571, 1107, 1106, 12572, 12623, 1117, 12624, 12610
5321, 12572, 1106, 1105, 12573, 12624, 1116, 12625, 12612
5322, 12573, 1105, 1104, 12574, 12625, 1115, 12626, 12614
5323, 12574, 1104, 22, 979, 12626, 1114, 982, 12616
*ELEMENT, type=CPS8, ELSET=Surface26
5324, 22, 1104, 12627, 983, 1114, 12847, 12848, 1005
5325, 1104, 1105, 12628, 12627, 1115, 12849, 12850, 12847
5326, 1105, 1106, 12629, 12628, 1116, 12851, 12852, 12849
5327, 1106, 1107, 12630, 12629, 1117, 12853, 12854, 12851
5328, 1107, 1108, 12631, 12630, 1118, 12855, 12856, 12853
5329, 1108, 1109, 12632, 12631, 1119, 12857, 12858, 12855
5330, 1109, 1110, 12633, 12632, 1120, 12859, 12860, 12857
5331, 1110, 1111, 12634, 12633, 1121, 12861, 12862, 12859
5332, 1111, 1112, 12635, 12634, 1122, 12863, 12864, 12861
5333, 1112, 1113, 12636, 12635, 1123, 12865, 12866, 12863
5334, 1113, 24, 1059, 12636, 1124, 1081, 12867, 12865
5335, 983, 12627, 12637, 984, 12848, 12868, 12869, 1006
5336, 12627, 12628, 12638, 12637, 12850, 12870, 12871, 12868
5337, 12628, 12629, 12639, 12638, 12852, 12872, 12873, 12870
5338, 12629, 12630, 12640, 12639, 12854, 12874, 12875, 12872
5339, 12630, 12631, 12641, 12640, 12856, 12876, 12877, 12874
5340, 12631, 12632, 12642, 12641, 12858, 12878, 12879, 12876
5341, 12632, 12633, 12643, 12642, 12860, 12880, 12881, 12878
5342, 12633, 12634, 12644, 12643, 12862, 12882, 12883, 12880
5343, 12634, 12635, 12645, 12644, 12864, 12884, 12885, 12882
5344, 12635, 12636, 12646, 12645, 12866, 12886, 12887, 12884
5345, 12636, 1059, 1060, 12646, 12867, 1082, 12888, 12886
5346, 984, 12637, 12647, 985, 12869, 12889, 12890, 1007
5347, 12637, 12638, 12648, 12647, 12871, 12891, 12892, 12889
5348, 12638, 12639, 12649, 12648, 12873, 12893, 12894, 12891
5349, 12639, 12640, 12650, 12649, 12875, 12895, 12896, 12893
5350, 12640, 12641, 12651, 12650, 12877, 12897, 12898, 12895
5351, 12641, 12642, 12652, 12651, 12879, 12899, 12900, 12897
5352, 12642, 12643, 12653, 12652, 12881, 12901, 12902, 12899
5353, 12643, 12644, 12654, 12653, 12883, 12903, 12904, 12901
5354, 12644, 12645, 12655, 12654, 12885, 12905, 12906, 12903
5355, 12645, 12646, 12656, 12655, 12887, 12907, 12908, 12905
5356, 12646, 1060, 1061, 12656, 12888, 1083, 12909, 12907
5357, 985, 12647, 12657, 986, 12890, 12910, 12911, 1008
5358, 12647, 12648, 12658, 12657, 12892, 12912, 12913, 12910
5359, 12648, 12649, 12659, 12658, 12894, 12914, 12915, 12912
5360, 12649, 12650, 12660, 12659, 12896, 12916, 12917, 12914
5361, 12650, 12651, 12661, 12660, 12898, 12918, 12919, 12916
5362, 12651, 12652, 12662, 12661, 12900, 12920, 12921, 12918
5363, 12652, 12653, 12663, 12662, 12902, 12922, 12923, 12920
5364, 12653, 12654, 12664, 12663, 12904, 12924, 12925, 12922
5365, 12654, 12655, 12665, 12664, 12906, 12926, 12927, 12924
5366, 12655, 12656, 12666, 12665, 12908, 12928, 12929, 12926
5367, 12656, 1061, 1062, 12666, 12909, 1084, 12930, 12928
5368, 986, 12657, 12667, 987, 12911, 12931, 12932, 1009
5369, 12657, 12658, 12668, 12667, 12913, 12933, 12934, 12931
5370, 12658, 12659, 12669, 12668, 12915, 12935, 12936, 12933
5371, 12659, 12660, 12670, 12669, 12917, 12937, 12938, 12935
5372, 12660, 12661, 12671, 12670, 12919, 12939, 12940, 12937
5373, 12661, 12662, 12672, 12671, 12921, 12941, 12942, 12939
5374, 12662, 12663, 12673, 12672, 12923, 12943, 12944, 12941
5375, 12663, 12664, 12674, 12673, 12925, 12945, 12946, 12943
5376, 12664, 12665, 12675, 12674, 12927, 12947, 12948, 12945
5377, 12665, 12666, 12676, 12675, 12929, 12949, 12950, 12947
5378, 12666, 1062, 1063, 12676, 12930, 1085, 12951, 12949
5379, 987, 12667, 12677, 988, 12932, 12952, 12953, 1010
5380, 12667, 12668, 12678, 12677, 12934, 12954, 12955, 12952
5381, 12668, 12669, 12679, 12678, 12936, 12956, 12957, 12954
5382, 12669, 12670, 12680, 12679, 12938, 12958, 12959, 12956
5383, 12670, 12671, 12681, 12680, 12940, 12960, 12961, 12958
5384, 12671, 12672, 12682, 12681, 12942, 12962, 12963, 12960
5385, 12672, 12673, 12683, 12682, 12944, 12964, 12965, 12962
5386, 12673, 12674, 12684, 12683, 12946, 12966, 12967, 12964
5387, 12674, 12675, 12685, 12684, 12948, 12968, 12969, 12966
5388, 12675, 12676, 12686, 12685, 12950, 12970, 12971, 12968
5389, 12676, 1063, 1064, 12686, 12951, 1086, 12972, 12970
5390, 988, 12677, 12687, 989, 12953, 12973, 12974, 1011
5391, 12677, 12678, 12688, 12687, 12955, 12975, 12976, 12973
5392, 12678, 12679, 12689, 12688, 12957, 12977, 12978, 12975
5393, 12679, 12680, 12690, 12689, 12959, 12979, 12980, 12977
5394, 12680, 12681, 12691, 12690, 12961, 12981, 12982, 12979
5395, 12681, 12682, 12692, 12691, 12963, 12983, 12984, 12981
5396, 12682, 12683, 12693, 12692, 12965, 12985, 12986, 12983
5397, 12683, 12684, 12694, 12693, 12967, 12987, 12988, 12985
5398, 12684, 12685, 12695, 12694, 12969, 12989, 12990, 12987
5399, 12685, 12686, 12696, 12695, 12971, 12991, 12992, 12989
5400, 12686, 1064, 1065, 12696, 12972, 1087, 12993, 12991
5401, 989, 12687, 12697, 990, 12974, 12994, 12995, 1012
5402, 12687, 12688, 12698, 12697, 12976, 12996, 12997, 12994
5403, 12688, 12689, 12699, 12698, 12978, 12998, 12999, 12996
5404, 12689, 12690, 12700, 12699, 12980, 13000, 13001, 12998
5405, 12690, 12691, 12701, 12700, 12982, 13002, 13003, 13000
5406, 12691, 12692, 12702, 12701, 12984, 13004, 13005, 13002
5407, 12692, 12693, 12703, 12702, 12986, 13006, 13007, 13004
5408, 12693, 12694, 12704, 12703, 12988, 13008, 13009, 13006
5409, 12694, 12695, 12705, 12704, 12990, 13010, 13011, 13008
5410, 12695, 12696, 12706, 12705, 12992, 13012, 13013, 13010
5411, 12696, 1065, 1066, 12706, 12993, 1088, 13014, 13012
5412, 990, 12697, 12707, 991, 12995, 13015, 13016, 1013
5413, 12697, 12698, 12708, 12707, 12997, 13017, 13018, 13015
5414, 12698, 12699, 12709, 12708, 12999, 13019, 13020, 13017
5415, 12699, 12700, 12710, 12709, 13001, 13021, 13022, 13019
5416, 12700, 12701, 12711, 12710, 13003, 13023, 13024, 13021
5417, 12701, 12702, 12712, 12711, 13005, 13025, 13026, 13023
5418, 12702, 12703, 12713, 12712, 13007, 13027, 13028, 13025
5419, 12703, 12704, 12714, 12713, 13009, 13029, 13030, 13027
5420, 12704, 12705, 12715, 12714, 13011, 13031, 13032, 13029
5421, 12705, 12706, 12716, 12715, 13013, 13033, 13034, 13031
5422, 12706, 1066, 1067, 12716, 13014, 1089, 13035, 13033
5423, 991, 12707, 12717, 992, 13016, 13036, 13037, 1014
5424, 12707, 12708, 12718, 12717, 13018, 13038, 13039, 13036
5425, 12708, 12709, 12719, 12718, 13020, 13040, 13041, 13038
5426, 12709, 12710, 12720, 12719, 13022, 13042, 13043, 13040
5427, 12710, 12711, 12721, 12720, 13024, 13044, 13045, 13042
5428, 12711, 12712, 12722, 12721, 13026, 13046, 13047, 13044
5429, 12712, 12713, 12723, 12722, 13028, 13048, 13049, 13046
5430, 12713, 12714, 12724, 12723, 13030, 13050, 13051, 13048
5431, 12714, 12715, 12725, 12724, 13032, 13052, 13053, 13050
5432, 12715, 12716, 12726, 12725, 13034, 13054, 13055, 13052
5433, 12716, 1067, 1068, 12726, 13035, 1090, 13056, 13054
5434, 992, 12717, 12727, 993, 13037, 13057, 13058, 1015
5435, 12717, 12718, 12728, 12727, 13039, 13059, 13060, 13057
5436, 12718, 12719, 12729, 12728, 13041, 13061, 13062, 13059
5437, 12719, 12720, 12730, 12729, 13043, 13063, 13064, 13061
5438, 12720, 12721, 12731, 12730, 13045, 13065, 13066, 13063
5439, 12721, 12722, 12732, 12731, 13047, 13067, 13068, 13065
5440, 12722, 12723, 12733, 12732, 13049, 13069, 13070, 13067
5441, 12723, 12724, 12734, 12733, 13051, 13071, 13072, 13069
5442, 12724, 12725, 12735, 12734, 13053, 13073, 13074, 13071
5443, 12725, 12726, 12736, 12735, 13055, 13075, 13076, 13073
5444, 12726, 1068, 1069, 12736, 13056, 1091, 13077, 13075
5445, 993, 12727, 12737, 994, 13058, 13078, 13079, 1016
5446, 12727, 12728, 12738, 12737, 13060, 13080, 13081, 13078
5447, 12728, 12729, 12739, 12738, 13062, 13082, 13083, 13080
5448, 12729, 12730, 12740, 12739, 13064, 13084, 13085, 13082
5449, 12730, 12731, 12741, 12740, 13066, 13086, 13087, 13084
5450, 12731, 12732, 12742, 12741, 13068, 13088, 13089, 13086
5451, 12732, 12733, 12743, 12742, 13070, 13090, 13091, 13088
5452, 12733, 12734, 12744, 12743, 13072, 13092, 13093, 13090
5453, 12734, 12735, 12745, 12744, 13074, 13094, 13095, 13092
5454, 12735, 12736, 12746, 12745, 13076, 13096, 13097, 13094
5455, 12736, 1069, 1070, 12746, 13077, 1092, 13098, 13096
5456, 994, 12737, 12747, 995, 13079, 13099, 13100, 1017
5457, 12737, 12738, 12748, 12747, 13081, 13101, 13102, 13099
5458, 12738, 12739, 12749, 12748, 13083, 13103, 13104, 13101
5459, 12739, 12740, 12750, 12749, 13085, 13105, 13106, 13103
5460, 12740, 12741, 12751, 12750, 13087, 13107, 13108, 13105
5461, 12741, 12742, 12752, 12751, 13089, 13109, 13110, 13107
5462, 12742, 12743, 12753, 12752, 13091, 13111, 13112, 13109
5463, 12743, 12744, 12754, 12753, 13093, 13113, 13114, 13111
5464, 12744, 12745, 12755, 12754, 13095, 13115, 13116, 13113
5465, 12745, 12746, 12756, 12755, 13097, 13117, 13118, 13115
5466, 12746, 1070, 1071, 12756, 13098, 1093, 13119, 13117
5467, 995, 12747, 12757, 996, 13100, 13120, 13121, 1018
5468, 12747, 12748, 12758, 12757, 13102, 13122, 13123, 13120
5469, 12748, 12749, 12759, 12758, 13104, 13124, 13125, 13122
5470, 12749, 12750, 12760, 12759, 13106, 13126, 13127, 13124
5471, 12750, 12751, 12761, 12760, 13108, 13128, 13129, 13126
5472, 12751, 12752, 12762, 12761, 13110, 13130, 13131, 13128
5473, 12752, 12753, 12763, 12762, 13112, 13132, 13133, 13130
5474, 12753, 12754, 12764, 12763, 13114, 13134, 13135, 13132
5475, 12754, 12755, 12765, 12764, 13116, 13136, 13137, 13134
5476, 12755, 12756, 12766, 12765, 13118, 13138, 13139, 13136
5477, 12756, 1071, 1072, 12766, 13119, 1094, 13140, 13138
5478, 996, 12757, 12767, 997, 13121, 13141, 13142, 1019
5479, 12757, 12758, 12768, 12767, 13123, 13143, 13144, 13141
5480, 12758, 12759, 12769, 12768, 13125, 13145, 13146, 13143
5481, 12759, 12760, 12770, 12769, 13127, 13147, 13148, 13145
5482, 12760, 12761, 12771, 12770, 13129, 13149, 13150, 13147
5483, 12761, 12762, 12772, 12771, 13131, 13151, 13152, 13149
5484, 12762, 12763, 12773, 12772, 13133, 13153, 13154, 13151
5485, 12763, 12764, 12774, 12773, 13135, 13155, 13156, 13153
5486, 12764, 12765, 12775, 12774, 13137, 13157, 13158, 13155
5487, 12765, 12766, 12776, 12775, 13139, 13159, 13160, 13157
5488, 12766, 1072, 1073, 12776, 13140, 1095, 13161, 13159
5489, 997, 12767, 12777, 998, 13142, 13162, 13163, 1020
5490, 12767, 12768, 12778, 12777, 13144, 13164, 13165, 13162
5491, 12768, 12769, 12779, 12778, 13146, 13166, 13167, 13164
5492, 12769, 12770, 12780, 12779, 13148, 13168, 13169, 13166
5493, 12770, 12771, 12781, 12780, 13150, 13170, 13171, 13168
5494, 12771, 12772, 12782, 12781, 13152, 13172, 13173, 13170
5495, 12772, 12773, 12783, 12782, 13154, 13174, 13175, 13172
5496, 12773, 12774, 12784, 12783, 13156, 13176, 13177, 13174
5497, 12774, 12775, 12785, 12784, 13158, 13178, 13179, 13176
5498, 12775, 12776, 12786, 12785, 13160, 13180, 13181, 13178
5499, 12776, 1073, 1074, 12786, 13161, 1096, 13182, 13180
5500, 998, 12777, 12787, 999, 13163, 13183, 13184, 1021
5501, 12777, 12778, 12788, 12787, 13165, 13185, 13186, 13183
5502, 12778, 12779, 12789, 12788, 13167, 13187, 13188, 13185
5503, 12779, 12780, 12790, 12789, 13169, 13189, 13190, 13187
5504, 12780, 12781, 12791, 12790, 13171, 13191, 13192, 13189
5505, 12781, 12782, 12792, 12791, 13173, 13193, 13194, 13191
5506, 12782, 12783, 12793, 12792, 13175, 13195, 13196, 13193
5507, 12783, 12784, 12794, 12793, 13177, 13197, 13198, 13195
5508, 12784, 12785, 12795, 12794, 13179, 13199, 13200, 13197
5509, 12785, 12786, 12796, 12795, 13181, 13201, 13202, 13199
5510, 12786, 1074, 1075, 12796, 13182, 1097, 13203, 13201
5511, 999, 12787, 12797, 1000, 13184, 13204, 13205, 1022
5512, 12787, 12788, 12798, 12797, 13186, 13206, 13207, 13204
5513, 12788, 12789, 12799, 12798, 13188, 13208, 13209, 13206
5514, 12789, 12790, 12800, 12799, 13190, 13210, 13211, 13208
5515, 12790, 12791, 12801, 12800, 13192, 13212, 13213, 13210
5516, 12791, 12792, 12802, 12801, 13194, 13214, 13215, 13212
5517, 12792, 12793, 12803, 12802, 13196, 13216, 13217, 13214
5518, 12793, 12794, 12804, 12803, 13198, 13218, 13219, 13216
5519, 12794, 12795, 12805, 12804, 13200, 13220, 13221, 13218
5520, 12795, 12796, 12806, 12805, 13202, 13222, 13223, 13220
5521, 12796, 1075, 1076, 12806, 13203, 1098, 13224, 13222
5522, 1000, 12797, 12807, 1001, 13205, 13225, 13226, 1023
5523, 12797, 12798, 12808, 12807, 13207, 13227, 13228, 13225
5524, 12798, 12799, 12809, 12808, 13209, 13229, 13230, 13227
5525, 12799, 12800, 12810, 12809, 13211, 13231, 13232, 13229
5526, 12800, 12801, 12811, 12810, 13213, 13233, 13234, 13231
5527, 12801, 12802, 12812, 12811, 13215, 13235, 13236, 13233
5528, 12802, 12803, 12813, 12812, 13217, 13237, 13238, 13235
5529, 12803, 12804, 12814, 12813, 13219, 13239, 13240, 13237
5530, 12804, 12805, 12815, 12814, 13221, 13241, 13242, 13239
5531, 12805, 12806, 12816, 12815, 13223, 13243, 13244, 13241
5532, 12806, 1076, 1077, 12816, 13224, 1099, 13245, 13243
5533, 1001, 12807, 12817, 1002, 13226, 13246, 13247, 1024
5534, 12807, 12808, 12818, 12817, 13228, 13248, 13249, 13246
5535, 12808, 12809, 12819, 12818, 13230, 13250, 13251, 13248
5536, 12809, 12810, 12820, 12819, 13232, 13252, 13253, 13250
5537, 12810, 12811, 12821, 12820, 13234, 13254, 13255, 13252
5538, 12811, 12812, 12822, 12821, 13236, 13256, 13257, 13254
5539, 12812, 12813, 12823, 12822, 13238, 13258, 13259, 13256
5540, 12813, 12814, 12824, 12823, 13240, 13260, 13261, 13258
5541, 12814, 12815, 12825, 12824, 13242, 13262, 13263, 13260
5542, 12815, 12816, 12826, 12825, 13244, 13264, 13265, 13262
5543, 12816, 1077, 1078, 12826, 13245, 1100, 13266, 13264
5544, 1002, 12817, 12827, 1003, 13247, 13267, 13268, 1025
5545, 12817, 12818, 12828, 12827, 13249, 13269, 13270, 13267
5546, 12818, 12819, 12829, 12828, 13251, 13271, 13272, 13269
5547, 12819, 12820, 12830, 12829, 13253, 13273, 13274, 13271
5548, 12820, 12821, 12831, 12830, 13255, 13275, 13276, 13273
5549, 12821, 12822, 12832, 12831, 13257, 13277, 13278, 13275
5550, 12822, 12823, 12833, 12832, 13259, 13279, 13280, 13277
5551, 12823, 12824, 12834, 12833, 13261, 13281, 13282, 13279
5552, 12824, 12825, 12835, 12834, 13263, 13283, 13284, 13281
5553, 12825, 12826, 12836, 12835, 13265, 13285, 13286, 13283
5554, 12826, 1078, 1079, 12836, 13266, 1101, 13287, 13285
5555, 1003, 12827, 12837, 1004, 13268, 13288, 13289, 1026
5556, 12827, 12828, 12838, 12837, 13270, 13290, 13291, 13288
5557, 12828, 12829, 12839, 12838, 13272, 13292, 13293, 13290
5558, 12829, 12830, 12840, 12839, 13274, 13294, 13295, 13292
5559, 12830, 12831, 12841, 12840, 13276, 13296, 13297, 13294
5560, 12831, 12832, 12842, 12841, 13278, 13298, 13299, 13296
5561, 12832, 12833, 12843, 12842, 13280, 13300, 13301, 13298
5562, 12833, 12834, 12844, 12843, 13282, 13302, 13303, 13300
5563, 12834, 12835, 12845, 12844, 13284, 13304, 13305, 13302
5564, 12835, 12836, 12846, 12845, 13286, 13306, 13307, 13304
5565, 12836, 1079, 1080, 12846, 13287, 1102, 13308, 13306
5566, 1004, 12837, 1033, 21, 13289, 13309, 1043, 1027
5567, 12837, 12838, 1034, 1033, 13291, 13310, 1044, 13309
5568, 12838, 12839, 1035, 1034, 13293, 13311, 1045, 13310
5569, 12839, 12840, 1036, 1035, 13295, 13312, 1046, 13311
5570, 12840, 12841, 1037, 1036, 13297, 13313, 1047, 13312
5571, 12841, 12842, 1038, 1037, 13299, 13314, 1048, 13313
5572, 12842, 12843, 1039, 1038, 13301, 13315, 1049, 13314
5573, 12843, 12844, 1040, 1039, 13303, 13316, 1050, 13315
5574, 12844, 12845, 1041, 1040, 13305, 13317, 1051, 13316
5575, 12845, 12846, 1042, 1041, 13307, 13318, 1052, 13317
5576, 12846, 1080, 23, 1042, 13308, 1103, 1053, 13318
*ELEMENT, type=CPS8, ELSET=Surface27
5577, 19, 1125, 13319, 1028, 1129, 13327, 13328, 1030
5578, 1028, 13319, 13320, 1029, 13328, 13329, 13330, 1031
5579, 1029, 13320, 1134, 23, 13330, 13331, 1138, 1032
5580, 1125, 1126, 13321, 13319, 1130, 13332, 13333, 13327
5581, 13319, 13321, 13322, 13320, 13333, 13334, 13335, 13329
5582, 13320, 13322, 1135, 1134, 13335, 13336, 1139, 13331
5583, 1126, 1127, 13323, 13321, 1131, 13337, 13338, 13332
5584, 13321, 13323, 13324, 13322, 13338, 13339, 13340, 13334
5585, 13322, 13324, 1136, 1135, 13340, 13341, 1140, 13336
5586, 1127, 1128, 13325, 13323, 1132, 13342, 13343, 13337
5587, 13323, 13325, 13326, 13324, 13343, 13344, 13345, 13339
5588, 13324, 13326, 1137, 1136, 13345, 13346, 1141, 13341
5589, 1128, 25, 1143, 13325, 1133, 1145, 13347, 13342
5590, 13325, 1143, 1144, 13326, 13347, 1146, 13348, 13344
5591, 13326, 1144, 26, 1137, 13348, 1147, 1142, 13346
*ELEMENT, type=CPS8, ELSET=Surface28
5592, 17, 973, 13349, 1148, 975, 13357, 13358, 1152
5593, 973, 974, 13350, 13349, 976, 13359, 13360, 13357
5594, 974, 21, 1157, 13350, 977, 1161, 13361, 13359
5595, 1148, 13349, 13351, 1149, 13358, 13362, 13363, 1153
5596, 13349, 13350, 13352, 13351, 13360, 13364, 13365, 13362
5597, 13350, 1157, 1158, 13352, 13361, 1162, 13366, 13364
5598, 1149, 13351, 13353, 1150, 13363, 13367, 13368, 1154
5599, 13351, 13352, 13354, 13353, 13365, 13369, 13370, 13367
5600, 13352, 1158, 1159, 13354, 13366, 1163, 13371, 13369
5601, 1150, 13353, 13355, 1151, 13368, 13372, 13373, 1155
5602, 13353, 13354, 13356, 13355, 13370, 13374, 13375, 13372
5603, 13354, 1159, 1160, 13356, 13371, 1164, 13376, 13374
5604, 1151, 13355, 1166, 27, 13373, 13377, 1168, 1156
5605, 13355, 13356, 1167, 1166, 13375, 13378, 1169, 13377
5606, 13356, 1160, 28, 1167, 13376, 1165, 1170, 13378
*ELEMENT, type=CPS8, ELSET=Surface29
5607, 19, 892, 13379, 1125, 903, 13419, 13420, 1129
5608, 892, 891, 13380, 13379, 902, 13421, 13422, 13419
5609, 891, 890, 13381, 13380, 901, 13423, 13424, 13421
5610, 890, 889, 13382, 13381, 900, 13425, 13426, 13423
5611, 889, 888, 13383, 13382, 899, 13427, 13428, 13425
5612, 888, 887, 13384, 13383, 898, 13429, 13430, 13427
5613, 887, 886, 13385, 13384, 897, 13431, 13432, 13429
5614, 886, 885, 13386, 13385, 896, 13433, 13434, 13431
5615, 885, 884, 13387, 13386, 895, 13435, 13436, 13433
5616, 884, 883, 13388, 13387, 894, 13437, 13438, 13435
5617, 883, 17, 1148, 13388, 893, 1152, 13439, 13437
5618, 1125, 13379, 13389, 1126, 13420, 13440, 13441, 1130
5619, 13379, 13380, 13390, 13389, 13422, 13442, 13443, 13440
5620, 13380, 13381, 13391, 13390, 13424, 13444, 13445, 13442
5621, 13381, 13382, 13392, 13391, 13426, 13446, 13447, 13444
5622, 13382, 13383, 13393, 13392, 13428, 13448, 13449, 13446
5623, 13383, 13384, 13394, 13393, 13430, 13450, 13451, 13448
5624, 13384, 13385, 13395, 13394, 13432, 13452, 13453, 13450
5625, 13385, 13386, 13396, 13395, 13434, 13454, 13455, 13452
5626, 13386, 13387, 13397, 13396, 13436, 13456, 13457, 13454
5627, 13387, 13388, 13398, 13397, 13438, 13458, 13459, 13456
5628, 13388, 1148, 1149, 13398, 13439, 1153, 13460, 13458
5629, 1126, 13389, 13399, 1127, 13441, 13461, 13462, 1131
5630, 13389, 13390, 13400, 13399, 13443, 13463, 13464, 13461
5631, 13390, 13391, 13401, 13400, 13445, 13465, 13466, 13463
5632, 13391, 13392, 13402, 13401, 13447, 13467, 13468, 13465
5633, 13392, 13393, 13403, 13402, 13449, 13469, 13470, 13467
5634, 13393, 13394, 13404, 13403, 13451, 13471, 13472, 13469
5635, 13394, 13395, 13405, 13404, 13453, 13473, 13474, 13471
5636, 13395, 13396, 13406, 13405, 13455, 13475, 13476, 13473
5637, 13396, 13397, 13407, 13406, 13457, 13477, 13478, 13475
5638, 13397, 13398, 13408, 13407, 13459, 13479, 13480, 13477
5639, 13398, 1149, 1150, 13408, 13460, 1154, 13481, 13479
5640, 1127, 13399, 13409, 1128, 13462, 13482, 13483, 1132
5641, 13399, 13400, 13410, 13409, 13464, 13484, 13485, 13482
5642, 13400, 13401, 13411, 13410, 13466, 13486, 13487, 13484
5643, 13401, 13402, 13412, 13411, 13468, 13488, 13489, 13486
5644, 13402, 13403, 13413, 13412, 13470, 13490, 13491, 13488
5645, 13403, 13404, 13414, 13413, 13472, 13492, 13493, 13490
5646, 13404, 13405, 13415, 13414, 13474, 13494, 13495, 13492
5647, 13405, 13406, 13416, 13415, 13476, 13496, 13497, 13494
5648, 13406, 13407, 13417, 13416, 13478, 13498, 13499, 13496
5649, 13407, 13408, 13418, 13417, 13480, 13500, 13501, 13498
5650, 13408, 1150, 1151, 13418, 13481, 1155, 13502, 13500
5651, 1128, 13409, 1180, 25, 13483, 13503, 1191, 1133
5652, 13409, 13410, 1179, 1180, 13485, 13504, 1190, 13503
5653, 13410, 13411, 1178, 1179, 13487, 13505, 1189, 13504
5654, 13411, 13412, 1177, 1178, 13489, 13506, 1188, 13505
5655, 13412, 13413, 1176, 1177, 13491, 13507, 1187, 13506
5656, 13413, 13414, 1175, 1176, 13493, 13508, 1186, 13507
5657, 13414, 13415, 1174, 1175, 13495, 13509, 1185, 13508
5658, 13415, 13416, 1173, 1174, 13497, 13510, 1184, 13509
5659, 13416, 13417, 1172, 1173, 13499, 13511, 1183, 13510
5660, 13417, 13418, 1171, 1172, 13501, 13512, 1182, 13511
5661, 13418, 1151, 27, 1171, 13502, 1156, 1181, 13512
*ELEMENT, type=CPS8, ELSET=Surface30
5662, 23, 1134, 13513, 1042, 1138, 13553, 13554, 1053
5663, 1042, 13513, 13514, 1041, 13554, 13555, 13556, 1052
5664, 1041, 13514, 13515, 1040, 13556, 13557, 13558, 1051
5665, 1040, 13515, 13516, 1039, 13558, 13559, 13560, 1050
5666, 1039, 13516, 13517, 1038, 13560, 13561, 13562, 1049
5667, 1038, 13517, 13518, 1037, 13562, 13563, 13564, 1048
5668, 1037, 13518, 13519, 1036, 13564, 13565, 13566, 1047
5669, 1036, 13519, 13520, 1035, 13566, 13567, 13568, 1046
5670, 1035, 13520, 13521, 1034, 13568, 13569, 13570, 1045
5671, 1034, 13521, 13522, 1033, 13570, 13571, 13572, 1044
5672, 1033, 13522, 1157, 21, 13572, 13573, 1161, 1043
5673, 1134, 1135, 13523, 13513, 1139, 13574, 13575, 13553
5674, 13513, 13523, 13524, 13514, 13575, 13576, 13577, 13555
5675, 13514, 13524, 13525, 13515, 13577, 13578, 13579, 13557
5676, 13515, 13525, 13526, 13516, 13579, 13580, 13581, 13559
5677, 13516, 13526, 13527, 13517, 13581, 13582, 13583, 13561
5678, 13517, 13527, 13528, 13518, 13583, 13584, 13585, 13563
5679, 13518, 13528, 13529, 13519, 13585, 13586, 13587, 13565
5680, 13519, 13529, 13530, 13520, 13587, 13588, 13589, 13567
5681, 13520, 13530, 13531, 13521, 13589, 13590, 13591, 13569
5682, 13521, 13531, 13532, 13522, 13591, 13592, 13593, 13571
5683, 13522, 13532, 1158, 1157, 13593, 13594, 1162, 13573
5684, 1135, 1136, 13533, 13523, 1140, 13595, 13596, 13574
5685, 13523, 13533, 13534, 13524, 13596, 13597, 13598, 13576
5686, 13524, 13534, 13535, 13525, 13598, 13599, 13600, 13578
5687, 13525, 13535, 13536, 13526, 13600, 13601, 13602, 13580
5688, 13526, 13536, 13537, 13527, 13602, 13603, 13604, 13582
5689, 13527, 13537, 13538, 13528, 13604, 13605, 13606, 13584
5690, 13528, 13538, 13539, 13529, 13606, 13607, 13608, 13586
5691, 13529, 13539, 13540, 13530, 13608, 13609, 13610, 13588
5692, 13530, 13540, 13541, 13531, 13610, 13611, 13612, 13590
5693, 13531, 13541, 13542, 13532, 13612, 13613, 13614, 13592
5694, 13532, 13542, 1159, 1158, 13614, 13615, 1163, 13594
5695, 1136, 1137, 13543, 13533, 1141, 13616, 13617, 13595
5696, 13533, 13543, 13544, 13534, 13617, 13618, 13619, 13597
5697, 13534, 13544, 13545, 13535, 13619, 13620, 13621, 13599
5698, 13535, 13545, 13546, 13536, 13621, 13622, 13623, 13601
5699, 13536, 13546, 13547, 13537, 13623, 13624, 13625, 13603
5700, 13537, 13547, 13548, 13538, 13625, 13626, 13627, 13605
5701, 13538, 13548, 13549, 13539, 13627, 13628, 13629, 13607
5702, 13539, 13549, 13550, 13540, 13629, 13630, 13631, 13609
5703, 13540, 13550, 13551, 13541, 13631, 13632, 13633, 13611
5704, 13541, 13551, 13552, 13542, 13633, 13634, 13635, 13613
5705, 13542, 13552, 1160, 1159, 13635, 13636, 1164, 13615
5706, 1137, 26, 1201, 13543, 1142, 1212, 13637, 13616
5707, 13543, 1201, 1200, 13544, 13637, 1211, 13638, 13618
5708, 13544, 1200, 1199, 13545, 13638, 1210, 13639, 13620
5709, 13545, 1199, 1198, 13546, 13639, 1209, 13640, 13622
5710, 13546, 1198, 1197, 13547, 13640, 1208, 13641, 13624
5711, 13547, 1197, 1196, 13548, 13641, 1207, 13642, 13626
5712, 13548, 1196, 1195, 13549, 13642, 1206, 13643, 13628
5713, 13549, 1195, 1194, 13550, 13643, 1205, 13644, 13630
5714, 13550, 1194, 1193, 13551, 13644, 1204, 13645, 13632
5715, 13551, 1193, 1192, 13552, 13645, 1203, 13646, 13634
5716, 13552, 1192, 28, 1160, 13646, 1202, 1165, 13636
*ELEMENT, type=CPS8, ELSET=Surface31
5717, 25, 1180, 13647, 1143, 1191, 13667, 13668, 1145
5718, 1180, 1179, 13648, 13647, 1190, 13669, 13670, 13667
5719, 1179, 1178, 13649, 13648, 1189, 13671, 13672, 13669
5720, 1178, 1177, 13650, 13649, 1188, 13673, 13674, 13671
5721, 1177, 1176, 13651, 13650, 1187, 13675, 13676, 13673
5722, 1176, 1175, 13652, 13651, 1186, 13677, 13678, 13675
5723, 1175, 1174, 13653, 13652, 1185, 13679, 13680, 13677
5724, 1174, 1173, 13654, 13653, 1184, 13681, 13682, 13679
5725, 1173, 1172, 13655, 13654, 1183, 13683, 13684, 13681
5726, 1172, 1171, 13656, 13655, 1182, 13685, 13686, 13683
5727, 1171, 27, 1166, 13656, 1181, 1168, 13687, 13685
5728, 1143, 13647, 13657, 1144, 13668, 13688, 13689, 1146
5729, 13647, 13648, 13658, 13657, 13670, 13690, 13691, 13688
5730, 13648, 13649, 13659, 13658, 13672, 13692, 13693, 13690
5731, 13649, 13650, 13660, 13659, 13674, 13694, 13695, 13692
5732, 13650, 13651, 13661, 13660, 13676, 13696, 13697, 13694
5733, 13651, 13652, 13662, 13661, 13678, 13698, 13699, 13696
5734, 13652, 13653, 13663, 13662, 13680, 13700, 13701, 13698
5735, 13653, 13654, 13664, 13663, 13682, 13702, 13703, 13700
5736, 13654, 13655, 13665, 13664, 13684, 13704, 13705, 13702
5737, 13655, 13656, 13666, 13665, 13686, 13706, 13707, 13704
5738, 13656, 1166, 1167, 13666, 13687, 1169, 13708, 13706
5739, 1144, 13657, 1201, 26, 13689, 13709, 1212, 1147
5740, 13657, 13658, 1200, 1201, 13691, 13710, 1211, 13709
5741, 13658, 13659, 1199, 1200, 13693, 13711, 1210, 13710
5742, 13659, 13660, 1198, 1199, 13695, 13712, 1209, 13711
5743, 13660, 13661, 1197, 1198, 13697, 13713, 1208, 13712
5744, 13661, 13662, 1196, 1197, 13699, 13714, 1207, 13713
5745, 13662, 13663, 1195, 1196, 13701, 13715, 1206, 13714
5746, 13663, 13664, 1194, 1195, 13703, 13716, 1205, 13715
5747, 13664, 13665, 1193, 1194, 13705, 13717, 1204, 13716
5748, 13665, 13666, 1192, 1193, 13707, 13718, 1203, 13717
5749, 13666, 1167, 28, 1192, 13708, 1170, 1202, 13718
*ELEMENT, type=CPS8, ELSET=Surface32
5750, 25, 1213, 13719, 1143, 1235, 13763, 13764, 1145
5751, 1143, 13719, 13720, 1144, 13764, 13765, 13766, 1146
5752, 1144, 13720, 1258, 26, 13766, 13767, 1280, 1147
5753, 1213, 1214, 13721, 13719, 1236, 13768, 13769, 13763
5754, 13719, 13721, 13722, 13720, 13769, 13770, 13771, 13765
5755, 13720, 13722, 1259, 1258, 13771, 13772, 1281, 13767
5756, 1214, 1215, 13723, 13721, 1237, 13773, 13774, 13768
5757, 13721, 13723, 13724, 13722, 13774, 13775, 13776, 13770
5758, 13722, 13724, 1260, 1259, 13776, 13777, 1282, 13772
5759, 1215, 1216, 13725, 13723, 1238, 13778, 13779, 13773
5760, 13723, 13725, 13726, 13724, 13779, 13780, 13781, 13775
5761, 13724, 13726, 1261, 1260, 13781, 13782, 1283, 13777
5762, 1216, 1217, 13727, 13725, 1239, 13783, 13784, 13778
5763, 13725, 13727, 13728, 13726, 13784, 13785, 13786, 13780
5764, 13726, 13728, 1262, 1261, 13786, 13787, 1284, 13782
5765, 1217, 1218, 13729, 13727, 1240, 13788, 13789, 13783
5766, 13727, 13729, 13730, 13728, 13789, 13790, 13791, 13785
5767, 13728, 13730, 1263, 1262, 13791, 13792, 1285, 13787
5768, 1218, 1219, 13731, 13729, 1241, 13793, 13794, 13788
5769, 13729, 13731, 13732, 13730, 13794, 13795, 13796, 13790
5770, 13730, 13732, 1264, 1263, 13796, 13797, 1286, 13792
5771, 1219, 1220, 13733, 13731, 1242, 13798, 13799, 13793
5772, 13731, 13733, 13734, 13732, 13799, 13800, 13801, 13795
5773, 13732, 13734, 1265, 1264, 13801, 13802, 1287, 13797
5774, 1220, 1221, 13735, 13733, 1243, 13803, 13804, 13798
5775, 13733, 13735, 13736, 13734, 13804, 13805, 13806, 13800
5776, 13734, 13736, 1266, 1265, 13806, 13807, 1288, 13802
5777, 1221, 1222, 13737, 13735, 1244, 13808, 13809, 13803
5778, 13735, 13737, 13738, 13736, 13809, 13810, 13811, 13805
5779, 13736, 13738, 1267, 1266, 13811, 13812, 1289, 13807
5780, 1222, 1223, 13739, 13737, 1245, 13813, 13814, 13808
5781, 13737, 13739, 13740, 13738, 13814, 13815, 13816, 13810
5782, 13738, 13740, 1268, 1267, 13816, 13817, 1290, 13812
5783, 1223, 1224, 13741, 13739, 1246, 13818, 13819, 13813
5784, 13739, 13741, 13742, 13740, 13819, 13820, 13821, 13815
5785, 13740, 13742, 1269, 1268, 13821, 13822, 1291, 13817
5786, 1224, 1225, 13743, 13741, 1247, 13823, 13824, 13818
5787, 13741, 13743, 13744, 13742, 13824, 13825, 13826, 13820
5788, 13742, 13744, 1270, 1269, 13826, 13827, 1292, 13822
5789, 1225, 1226, 13745, 13743, 1248, 13828, 13829, 13823
5790, 13743, 13745, 13746, 13744, 13829, 13830, 13831, 13825
5791, 13744, 13746, 1271, 1270, 13831, 13832, 1293, 13827
5792, 1226, 1227, 13747, 13745, 1249, 13833, 13834, 13828
5793, 13745, 13747, 13748, 13746, 13834, 13835, 13836, 13830
5794, 13746, 13748, 1272, 1271, 13836, 13837, 1294, 13832
5795, 1227, 1228, 13749, 13747, 1250, 13838, 13839, 13833
5796, 13747, 13749, 13750, 13748, 13839, 13840, 13841, 13835
5797, 13748, 13750, 1273, 1272, 13841, 13842, 1295, 13837
5798, 1228, 1229, 13751, 13749, 1251, 13843, 13844, 13838
5799, 13749, 13751, 13752, 13750, 13844, 13845, 13846, 13840
5800, 13750, 13752, 1274, 1273, 13846, 13847, 1296, 13842
5801, 1229, 1230, 13753, 13751, 1252, 13848, 13849, 13843
5802, 13751, 13753, 13754, 13752, 13849, 13850, 13851, 13845
5803, 13752, 13754, 1275, 1274, 13851, 13852, 1297, 13847
5804, 1230, 1231, 13755, 13753, 1253, 13853, 13854, 13848
5805, 13753, 13755, 13756, 13754, 13854, 13855, 13856, 13850
5806, 13754, 13756, 1276, 1275, 13856, 13857, 1298, 13852
5807, 1231, 1232, 13757, 13755, 1254, 13858, 13859, 13853
5808, 13755, 13757, 13758, 13756, 13859, 13860, 13861, 13855
5809, 13756, 13758, 1277, 1276, 13861, 13862, 1299, 13857
5810, 1232, 1233, 13759, 13757, 1255, 13863, 13864, 13858
5811, 13757, 13759, 13760, 13758, 13864, 13865, 13866, 13860
5812, 13758, 13760, 1278, 1277, 13866, 13867, 1300, 13862
5813, 1233, 1234, 13761, 13759, 1256, 13868, 13869, 13863
5814, 13759, 13761, 13762, 13760, 13869, 13870, 13871, 13865
5815, 13760, 13762, 1279, 1278, 13871, 13872, 1301, 13867
5816, 1234, 29, 1303, 13761, 1257, 1305, 13873, 13868
5817, 13761, 1303, 1304, 13762, 13873, 1306, 13874, 13870
5818, 13762, 1304, 30, 1279, 13874, 1307, 1302, 13872
*ELEMENT, type=CPS8, ELSET=Surface33
5819, 27, 1166, 13875, 1308, 1168, 13919, 13920, 1330
5820, 1166, 1167, 13876, 13875, 1169, 13921, 13922, 13919
5821, 1167, 28, 1353, 13876, 1170, 1375, 13923, 13921
5822, 1308, 13875, 13877, 1309, 13920, 13924, 13925, 1331
5823, 13875, 13876, 13878, 13877, 13922, 13926, 13927, 13924
5824, 13876, 1353, 1354, 13878, 13923, 1376, 13928, 13926
5825, 1309, 13877, 13879, 1310, 13925, 13929, 13930, 1332
5826, 13877, 13878, 13880, 13879, 13927, 13931, 13932, 13929
5827, 13878, 1354, 1355, 13880, 13928, 1377, 13933, 13931
5828, 1310, 13879, 13881, 1311, 13930, 13934, 13935, 1333
5829, 13879, 13880, 13882, 13881, 13932, 13936, 13937, 13934
5830, 13880, 1355, 1356, 13882, 13933, 1378, 13938, 13936
5831, 1311, 13881, 13883, 1312, 13935, 13939, 13940, 1334
5832, 13881, 13882, 13884, 13883, 13937, 13941, 13942, 13939
5833, 13882, 1356, 1357, 13884, 13938, 1379, 13943, 13941
5834, 1312, 13883, 13885, 1313, 13940, 13944, 13945, 1335
5835, 13883, 13884, 13886, 13885, 13942, 13946, 13947, 13944
5836, 13884, 1357, 1358, 13886, 13943, 1380, 13948, 13946
5837, 1313, 13885, 13887, 1314, 13945, 13949, 13950, 1336
5838, 13885, 13886, 13888, 13887, 13947, 13951, 13952, 13949
5839, 13886, 1358, 1359, 13888, 13948, 1381, 13953, 13951
5840, 1314, 13887, 13889, 1315, 13950, 13954, 13955, 1337
5841, 13887, 13888, 13890, 13889, 13952, 13956, 13957, 13954
5842, 13888, 1359, 1360, 13890, 13953, 1382, 13958, 13956
5843, 1315, 13889, 13891, 1316, 13955, 13959, 13960, 1338
5844, 13889, 13890, 13892, 13891, 13957, 13961, 13962, 13959
5845, 13890, 1360, 1361, 13892, 13958, 1383, 13963, 13961
5846, 1316, 13891, 13893, 1317, 13960, 13964, 13965, 1339
5847, 13891, 13892, 13894, 13893, 13962, 13966, 13967, 13964
5848, 13892, 1361, 1362, 13894, 13963, 1384, 13968, 13966
5849, 1317, 13893, 13895, 1318, 13965, 13969, 13970, 1340
5850, 13893, 13894, 13896, 13895, 13967, 13971, 13972, 13969
5851, 13894, 1362, 1363, 13896, 13968, 1385, 13973, 13971
5852, 1318, 13895, 13897, 1319, 13970, 13974, 13975, 1341
5853, 13895, 13896, 13898, 13897, 13972, 13976, 13977, 13974
5854, 13896, 1363, 1364, 13898, 13973, 1386, 13978, 13976
5855, 1319, 13897, 13899, 1320, 13975, 13979, 13980, 1342
5856, 13897, 13898, 13900, 13899, 13977, 13981, 13982, 13979
5857, 13898, 1364, 1365, 13900, 13978, 1387, 13983, 13981
5858, 1320, 13899, 13901, 1321, 13980, 13984, 13985, 1343
5859, 13899, 13900, 13902, 13901, 13982, 13986, 13987, 13984
5860, 13900, 1365, 1366, 13902, 13983, 1388, 13988, 13986
5861, 1321, 13901, 13903, 1322, 13985, 13989, 13990, 1344
5862, 13901, 13902, 13904, 13903, 13987, 13991, 13992, 13989
5863, 13902, 1366, 1367, 13904, 13988, 1389, 13993, 13991
5864, 1322, 13903, 13905, 1323, 13990, 13994, 13995, 1345
5865, 13903, 13904, 13906, 13905, 13992, 13996, 13997, 13994
5866, 13904, 1367, 1368, 13906, 13993, 1390, 13998, 13996
5867, 1323, 13905, 13907, 1324, 13995, 13999, 14000, 1346
5868, 13905, 13906, 13908, 13907, 13997, 14001, 14002, 13999
5869, 13906, 1368, 1369, 13908, 13998, 1391, 14003, 14001
5870, 1324, 13907, 13909, 1325, 14000, 14004, 14005, 1347
5871, 13907, 13908, 13910, 13909, 14002, 14006, 14007, 14004
5872, 13908, 1369, 1370, 13910, 14003, 1392, 14008, 14006
5873, 1325, 13909, 13911, 1326, 14005, 14009, 14010, 1348
5874, 13909, 13910, 13912, 13911, 14007, 14011, 14012, 14009
5875, 13910, 1370, 1371, 13912, 14008, 1393, 14013, 14011
5876, 1326, 13911, 13913, 1327, 14010, 14014, 14015, 1349
5877, 13911, 13912, 13914, 13913, 14012, 14016, 14017, 14014
5878, 13912, 1371, 1372, 13914, 14013, 1394, 14018, 14016
5879, 1327, 13913, 13915, 1328, 14015, 14019, 14020, 1350
5880, 13913, 13914, 13916, 13915, 14017, 14021, 14022, 14019
5881, 13914, 1372, 1373, 13916, 14018, 1395, 14023, 14021
5882, 1328, 13915, 13917, 1329, 14020, 14024, 14025, 1351
5883, 13915, 13916, 13918, 13917, 14022, 14026, 14027, 14024
5884, 13916, 1373, 1374, 13918, 14023, 1396, 14028, 14026
5885, 1329, 13917, 1398, 31, 14025, 14029, 1400, 1352
5886, 13917, 13918, 1399, 1398, 14027, 14030, 1401, 14029
5887, 13918, 1374, 32, 1399, 14028, 1397, 1402, 14030
*ELEMENT, type=CPS8, ELSET=Surface34
5888, 25, 1180, 14031, 1213, 1191, 14251, 14252, 1235
5889, 1180, 1179, 14032, 14031, 1190, 14253, 14254, 14251
5890, 1179, 1178, 14033, 14032, 1189, 14255, 14256, 14253
5891, 1178, 1177, 14034, 14033, 1188, 14257, 14258, 14255
5892, 1177, 1176, 14035, 14034, 1187, 14259, 14260, 14257
5893, 1176, 1175, 14036, 14035, 1186, 14261, 14262, 14259
5894, 1175, 1174, 14037, 14036, 1185, 14263, 14264, 14261
5895, 1174, 1173, 14038, 14037, 1184, 14265, 14266, 14263
5896, 1173, 1172, 14039, 14038, 1183, 14267, 14268, 14265
5897, 1172, 1171, 14040, 14039, 1182, 14269, 14270, 14267
5898, 1171, 27, 1308, 14040, 1181, 1330, 14271, 14269
5899, 1213, 14031, 14041, 1214, 14252, 14272, 14273, 1236
5900, 14031, 14032, 14042, 14041, 14254, 14274, 14275, 14272
5901, 14032, 14033, 14043, 14042, 14256, 14276, 14277, 14274
5902, 14033, 14034, 14044, 14043, 14258, 14278, 14279, 14276
5903, 14034, 14035, 14045, 14044, 14260, 14280, 14281, 14278
5904, 14035, 14036, 14046, 14045, 14262, 14282, 14283, 14280
5905, 14036, 14037, 14047, 14046, 14264, 14284, 14285, 14282
5906, 14037, 14038, 14048, 14047, 14266, 14286, 14287, 14284
5907, 14038, 14039, 14049, 14048, 14268, 14288, 14289, 14286
5908, 14039, 14040, 14050, 14049, 14270, 14290, 14291, 14288
5909, 14040, 1308, 1309, 14050, 14271, 1331, 14292, 14290
5910, 1214, 14041, 14051, 1215, 14273, 14293, 14294, 1237
5911, 14041, 14042, 14052, 14051, 14275, 14295, 14296, 14293
5912, 14042, 14043, 14053, 14052, 14277, 14297, 14298, 14295
5913, 14043, 14044, 14054, 14053, 14279, 14299, 14300, 14297
5914, 14044, 14045, 14055, 14054, 14281, 14301, 14302, 14299
5915, 14045, 14046, 14056, 14055, 14283, 14303, 14304, 14301
5916, 14046, 14047, 14057, 14056, 14285, 14305, 14306, 14303
5917, 14047, 14048, 14058, 14057, 14287, 14307, 14308, 14305
5918, 14048, 14049, 14059, 14058, 14289, 14309, 14310, 14307
5919, 14049, 14050, 14060, 14059, 14291, 14311, 14312, 14309
5920, 14050, 1309, 1310, 14060, 14292, 1332, 14313, 14311
5921, 1215, 14051, 14061, 1216, 14294, 14314, 14315, 1238
5922, 14051, 14052, 14062, 14061, 14296, 14316, 14317, 14314
5923, 14052, 14053, 14063, 14062, 14298, 14318, 14319, 14316
5924, 14053, 14054, 14064, 14063, 14300, 14320, 14321, 14318
5925, 14054, 14055, 14065, 14064, 14302, 14322, 14323, 14320
5926, 14055, 14056, 14066, 14065, 14304, 14324, 14325, 14322
5927, 14056, 14057, 14067, 14066, 14306, 14326, 14327, 14324
5928, 14057, 14058, 14068, 14067, 14308, 14328, 14329, 14326
5929, 14058, 14059, 14069, 14068, 14310, 14330, 14331, 14328
5930, 14059, 14060, 14070, 14069, 14312, 14332, 14333, 14330
5931, 14060, 1310, 1311, 14070, 14313, 1333, 14334, 14332
5932, 1216, 14061, 14071, 1217, 14315, 14335, 14336, 1239
5933, 14061, 14062, 14072, 14071, 14317, 14337, 14338, 14335
5934, 14062, 14063, 14073, 14072, 14319, 14339, 14340, 14337
5935, 14063, 14064, 14074, 14073, 14321, 14341, 14342, 14339
5936, 14064, 14065, 14075, 14074, 14323, 14343, 14344, 14341
5937, 14065, 14066, 14076, 14075, 14325, 14345, 14346, 14343
5938, 14066, 14067, 14077, 14076, 14327, 14347, 14348, 14345
5939, 14067, 14068, 14078, 14077, 14329, 14349, 14350, 14347
5940, 14068, 14069, 14079, 14078, 14331, 14351, 14352, 14349
5941, 14069, 14070, 14080, 14079, 14333, 14353, 14354, 14351
5942, 14070, 1311, 1312, 14080, 14334, 1334, 14355, 14353
5943, 1217, 14071, 14081, 1218, 14336, 14356, 14357, 1240
5944, 14071, 14072, 14082, 14081, 14338, 14358, 14359, 14356
5945, 14072, 14073, 14083, 14082, 14340, 14360, 14361, 14358
5946, 14073, 14074, 14084, 14083, 14342, 14362, 14363, 14360
5947, 14074, 14075, 14085, 14084, 14344, 14364, 14365, 14362
5948, 14075, 14076, 14086, 14085, 14346, 14366, 14367, 14364
5949, 14076, 14077, 14087, 14086, 14348, 14368, 14369, 14366
5950, 14077, 14078, 14088, 14087, 14350, 14370, 14371, 14368
5951, 14078, 14079, 14089, 14088, 14352, 14372, 14373, 14370
5952, 14079, 14080, 14090, 14089, 14354, 14374, 14375, 14372
5953, 14080, 1312, 1313, 14090, 14355, 1335, 14376, 14374
5954, 1218, 14081, 14091, 1219, 14357, 14377, 14378, 1241
5955, 14081, 14082, 14092, 14091, 14359, 14379, 14380, 14377
5956, 14082, 14083, 14093, 14092, 14361, 14381, 14382, 14379
5957, 14083, 14084, 14094, 14093, 14363, 14383, 14384, 14381
5958, 14084, 14085, 14095, 14094, 14365, 14385, 14386, 14383
5959, 14085, 14086, 14096, 14095, 14367, 14387, 14388, 14385
5960, 14086, 14087, 14097, 14096, 14369, 14389, 14390, 14387
5961, 14087, 14088, 14098, 14097, 14371, 14391, 14392, 14389
5962, 14088, 14089, 14099, 14098, 14373, 14393, 14394, 14391
5963, 14089, 14090, 14100, 14099, 14375, 14395, 14396, 14393
5964, 14090, 1313, 1314, 14100, 14376, 1336, 14397, 14395
5965, 1219, 14091, 14101, 1220, 14378, 14398, 14399, 1242
5966, 14091, 14092, 14102, 14101, 14380, 14400, 14401, 14398
5967, 14092, 14093, 14103, 14102, 14382, 14402, 14403, 14400
5968, 14093, 14094, 14104, 14103, 14384, 14404, 14405, 14402
5969, 14094, 14095, 14105, 14104, 14386, 14406, 14407, 14404
5970, 14095, 14096, 14106, 14105, 14388, 14408, 14409, 14406
5971, 14096, 14097, 14107, 14106, 14390, 14410, 14411, 14408
5972, 14097, 14098, 14108, 14107, 14392, 14412, 14413, 14410
5973, 14098, 14099, 14109, 14108, 14394, 14414, 14415, 14412
5974, 14099, 14100, 14110, 14109, 14396, 14416, 14417, 14414
5975, 14100, 1314, 1315, 14110, 14397, 1337, 14418, 14416
5976, 1220, 14101, 14111, 1221, 14399, 14419, 14420, 1243
5977, 14101, 14102, 14112, 14111, 14401, 14421, 14422, 14419
5978, 14102, 14103, 14113, 14112, 14403, 14423, 14424, 14421
5979, 14103, 14104, 14114, 14113, 14405, 14425, 14426, 14423
5980, 14104, 14105, 14115, 14114, 14407, 14427, 14428, 14425
5981, 14105, 14106, 14116, 14115, 14409, 14429, 14430, 14427
5982, 14106, 14107, 14117, 14116, 14411, 14431, 14432, 14429
5983, 14107, 14108, 14118, 14117, 14413, 14433, 14434, 14431
5984, 14108, 14109, 14119, 14118, 14415, 14435, 14436, 14433
5985, 14109, 14110, 14120, 14119, 14417, 14437, 14438, 14435
5986, 14110, 1315, 1316, 14120, 14418, 1338, 14439, 14437
5987, 1221, 14111, 14121, 1222, 14420, 14440, 14441, 1244
5988, 14111, 14112, 14122, 14121, 14422, 14442, 14443, 14440
5989, 14112, 14113, 14123, 14122, 14424, 14444, 14445, 14442
5990, 14113, 14114, 14124, 14123, 14426, 14446, 14447, 14444
5991, 14114, 14115, 14125, 14124, 14428, 14448, 14449, 14446
5992, 14115, 14116, 14126, 14125, 14430, 14450, 14451, 14448
5993, 14116, 14117, 14127, 14126, 14432, 14452, 14453, 14450
5994, 14117, 14118, 14128, 14127, 14434, 14454, 14455, 14452
5995, 14118, 14119, 14129, 14128, 14436, 14456, 14457, 14454
5996, 14119, 14120, 14130, 14129, 14438, 14458, 14459, 14456
5997, 14120, 1316, 1317, 14130, 14439, 1339, 14460, 14458
5998, 1222, 14121, 14131, 1223, 14441, 14461, 14462, 1245
5999, 14121, 14122, 14132, 14131, 14443, 14463, 14464, 14461
6000, 14122, 14123, 14133, 14132, 14445, 14465, 14466, 14463
6001, 14123, 14124, 14134, 14133, 14447, 14467, 14468, 14465
6002, 14124, 14125, 14135, 14134, 14449, 14469, 14470, 14467
6003, 14125, 14126, 14136, 14135, 14451, 14471, 14472, 14469
6004, 14126, 14127, 14137, 14136, 14453, 14473, 14474, 14471
6005, 14127, 14128, 14138, 14137, 14455, 14475, 14476, 14473
6006, 14128, 14129, 14139, 14138, 14457, 14477, 14478, 14475
6007, 14129, 14130, 14140, 14139, 14459, 14479, 14480, 14477
6008, 14130, 1317, 1318, 14140, 14460, 1340, 14481, 14479
6009, 1223, 14131, 14141, 1224, 14462, 14482, 14483, 1246
6010, 14131, 14132, 14142, 14141, 14464, 14484, 14485, 14482
6011, 14132, 14133, 14143, 14142, 14466, 14486, 14487, 14484
6012, 14133, 14134, 14144, 14143, 14468, 14488, 14489, 14486
6013, 14134, 14135, 14145, 14144, 14470, 14490, 14491, 14488
6014, 14135, 14136, 14146, 14145, 14472, 14492, 14493, 14490
6015, 14136, 14137, 14147, 14146, 14474, 14494, 14495, 14492
6016, 14137, 14138, 14148, 14147, 14476, 14496, 14497, 14494
6017, 14138, 14139, 14149, 14148, 14478, 14498, 14499, 14496
6018, 14139, 14140, 14150, 14149, 14480, 14500, 14501, 14498
6019, 14140, 1318, 1319, 14150, 14481, 1341, 14502, 14500
6020, 1224, 14141, 14151, 1225, 14483, 14503, 14504, 1247
6021, 14141, 14142, 14152, 14151, 14485, 14505, 14506, 14503
6022, 14142, 14143, 14153, 14152, 14487, 14507, 14508, 14505
6023, 14143, 14144, 14154, 14153, 14489, 14509, 14510, 14507
6024, 14144, 14145, 14155, 14154, 14491, 14511, 14512, 14509
6025, 14145, 14146, 14156, 14155, 14493, 14513, 14514, 14511
6026, 14146, 14147, 14157, 14156, 14495, 14515, 14516, 14513
6027, 14147, 14148, 14158, 14157, 14497, 14517, 14518, 14515
6028, 14148, 14149, 14159, 14158, 14499, 14519, 14520, 14517
6029, 14149, 14150, 14160, 14159, 14501, 14521, 14522, 14519
6030, 14150, 1319, 1320, 14160, 14502, 1342, 14523, 14521
6031, 1225, 14151, 14161, 1226, 14504, 14524, 14525, 1248
6032, 14151, 14152, 14162, 14161, 14506, 14526, 14527, 14524
6033, 14152, 14153, 14163, 14162, 14508, 14528, 14529, 14526
6034, 14153, 14154, 14164, 14163, 14510, 14530, 14531, 14528
6035, 14154, 14155, 14165, 14164, 14512, 14532, 14533, 14530
6036, 14155, 14156, 14166, 14165, 14514, 14534, 14535, 14532
6037, 14156, 14157, 14167, 14166, 14516, 14536, 14537, 14534
6038, 14157, 14158, 14168, 14167, 14518, 14538, 14539, 14536
6039, 14158, 14159, 14169, 14168, 14520, 14540, 14541, 14538
6040, 14159, 14160, 14170, 14169, 14522, 14542, 14543, 14540
6041, 14160, 1320, 1321, 14170, 14523, 1343, 14544, 14542
6042, 1226, 14161, 14171, 1227, 14525, 14545, 14546, 1249
6043, 14161, 14162, 14172, 14171, 14527, 14547, 14548, 14545
6044, 14162, 14163, 14173, 14172, 14529, 14549, 14550, 14547
6045, 14163, 14164, 14174, 14173, 14531, 14551, 14552, 14549
6046, 14164, 14165, 14175, 14174, 14533, 14553, 14554, 14551
6047, 14165, 14166, 14176, 14175, 14535, 14555, 14556, 14553
6048, 14166, 14167, 14177, 14176, 14537, 14557, 14558, 14555
6049, 14167, 14168, 14178, 14177, 14539, 14559, 14560, 14557
6050, 14168, 14169, 14179, 14178, 14541, 14561, 14562, 14559
6051, 14169, 14170, 14180, 14179, 14543, 14563, 14564, 14561
6052, 14170, 1321, 1322, 14180, 14544, 1344, 14565, 14563
6053, 1227, 14171, 14181, 1228, 14546, 14566, 14567, 1250
6054, 14171, 14172, 14182, 14181, 14548, 14568, 14569, 14566
6055, 14172, 14173, 14183, 14182, 14550, 14570, 14571, 14568
6056, 14173, 14174, 14184, 14183, 14552, 14572, 14573, 14570
6057, 14174, 14175, 14185, 14184, 14554, 14574, 14575, 14572
6058, 14175, 14176, 14186, 14185, 14556, 14576, 14577, 14574
6059, 14176, 14177, 14187, 14186, 14558, 14578, 14579, 14576
6060, 14177, 14178, 14188, 14187, 14560, 14580, 14581, 14578
6061, 14178, 14179, 14189, 14188, 14562, 14582, 14583, 14580
6062, 14179, 14180, 14190, 14189, 14564, 14584, 14585, 14582
6063, 14180, 1322, 1323, 14190, 14565, 1345, 14586, 14584
6064, 1228, 14181, 14191, 1229, 14567, 14587, 14588, 1251
6065, 14181, 14182, 14192, 14191, 14569, 14589, 14590, 14587
6066, 14182, 14183, 14193, 14192, 14571, 14591, 14592, 14589
6067, 14183, 14184, 14194, 14193, 14573, 14593, 14594, 14591
6068, 14184, 14185, 14195, 14194, 14575, 14595, 14596, 14593
6069, 14185, 14186, 14196, 14195, 14577, 14597, 14598, 14595
6070, 14186, 14187, 14197, 14196, 14579, 14599, 14600, 14597
6071, 14187, 14188, 14198, 14197, 14581, 14601, 14602, 14599
6072, 14188, 14189, 14199, 14198, 14583, 14603, 14604, 14601
6073, 14189, 14190, 14200, 14199, 14585, 14605, 14606, 14603
6074, 14190, 1323, 1324, 14200, 14586, 1346, 14607, 14605
6075, 1229, 14191, 14201, 1230, 14588, 14608, 14609, 1252
6076, 14191, 14192, 14202, 14201, 14590, 14610, 14611, 14608
6077, 14192, 14193, 14203, 14202, 14592, 14612, 14613, 14610
6078, 14193, 14194, 14204, 14203, 14594, 14614, 14615, 14612
6079, 14194, 14195, 14205, 14204, 14596, 14616, 14617, 14614
6080, 14195, 14196, 14206, 14205, 14598, 14618, 14619, 14616
6081, 14196, 14197, 14207, 14206, 14600, 14620, 14621, 14618
6082, 14197, 14198, 14208, 14207, 14602, 14622, 14623, 14620
6083, 14198, 14199, 14209, 14208, 14604, 14624, 14625, 14622
6084, 14199, 14200, 14210, 14209, 14606, 14626, 14627, 14624
6085, 14200, 1324, 1325, 14210, 14607, 1347, 14628, 14626
6086, 1230, 14201, 14211, 1231, 14609, 14629, 14630, 1253
6087, 14201, 14202, 14212, 14211, 14611, 14631, 14632, 14629
6088, 14202, 14203, 14213, 14212, 14613, 14633, 14634, 14631
6089, 14203, 14204, 14214, 14213, 14615, 14635, 14636, 14633
6090, 14204, 14205, 14215, 14214, 14617, 14637, 14638, 14635
6091, 14205, 14206, 14216, 14215, 14619, 14639, 14640, 14637
6092, 14206, 14207, 14217, 14216, 14621, 14641, 14642, 14639
6093, 14207, 14208, 14218, 14217, 14623, 14643, 14644, 14641
6094, 14208, 14209, 14219, 14218, 14625, 14645, 14646, 14643
6095, 14209, 14210, 14220, 14219, 14627, 14647, 14648, 14645
6096, 14210, 1325, 1326, 14220, 14628, 1348, 14649, 14647
6097, 1231, 14211, 14221, 1232, 14630, 14650, 14651, 1254
6098, 14211, 14212, 14222, 14221, 14632, 14652, 14653, 14650
6099, 14212, 14213, 14223, 14222, 14634, 14654, 14655, 14652
6100, 14213, 14214, 14224, 14223, 14636, 14656, 14657, 14654
6101, 14214, 14215, 14225, 14224, 14638, 14658, 14659, 14656
6102, 14215, 14216, 14226, 14225, 14640, 14660, 14661, 14658
6103, 14216, 14217, 14227, 14226, 14642, 14662, 14663, 14660
6104, 14217, 14218, 14228, 14227, 14644, 14664, 14665, 14662
6105, 14218, 14219, 14229, 14228, 14646, 14666, 14667, 14664
6106, 14219, 14220, 14230, 14229, 14648, 14668, 14669, 14666
6107, 14220, 1326, 1327, 14230, 14649, 1349, 14670, 14668
6108, 1232, 14221, 14231, 1233, 14651, 14671, 14672, 1255
6109, 14221, 14222, 14232, 14231, 14653, 14673, 14674, 14671
6110, 14222, 14223, 14233, 14232, 14655, 14675, 14676, 14673
6111, 14223, 14224, 14234, 14233, 14657, 14677, 14678, 14675
6112, 14224, 14225, 14235, 14234, 14659, 14679, 14680, 14677
6113, 14225, 14226, 14236, 14235, 14661, 14681, 14682, 14679
6114, 14226, 14227, 14237, 14236, 14663, 14683, 14684, 14681
6115, 14227, 14228, 14238, 14237, 14665, 14685, 14686, 14683
6116, 14228, 14229, 14239, 14238, 14667, 14687, 14688, 14685
6117, 14229, 14230, 14240, 14239, 14669, 14689, 14690, 14687
6118, 14230, 1327, 1328, 14240, 14670, 1350, 14691, 14689
6119, 1233, 14231, 14241, 1234, 14672, 14692, 14693, 1256
6120, 14231, 14232, 14242, 14241, 14674, 14694, 14695, 14692
6121, 14232, 14233, 14243, 14242, 14676, 14696, 14697, 14694
6122, 14233, 14234, 14244, 14243, 14678, 14698, 14699, 14696
6123, 14234, 14235, 14245, 14244, 14680, 14700, 14701, 14698
6124, 14235, 14236, 14246, 14245, 14682, 14702, 14703, 14700
6125, 14236, 14237, 14247, 14246, 14684, 14704, 14705, 14702
6126, 14237, 14238, 14248, 14247, 14686, 14706, 14707, 14704
6127, 14238, 14239, 14249, 14248, 14688, 14708, 14709, 14706
6128, 14239, 14240, 14250, 14249, 14690, 14710, 14711, 14708
6129, 14240, 1328, 1329, 14250, 14691, 1351, 14712, 14710
6130, 1234, 14241, 1412, 29, 14693, 14713, 1423, 1257
6131, 14241, 14242, 1411, 1412, 14695, 14714, 1422, 14713
6132, 14242, 14243, 1410, 1411, 14697, 14715, 1421, 14714
6133, 14243, 14244, 1409, 1410, 14699, 14716, 1420, 14715
6134, 14244, 14245, 1408, 1409, 14701, 14717, 1419, 14716
6135, 14245, 14246, 1407, 1408, 14703, 14718, 1418, 14717
