38092, 0.17391304347826, 0.98478260869565, 0.18181818181818
38093, 0.17391304347826, 0.98478260869565, 0.22727272727273
38094, 0.17391304347826, 0.98478260869565, 0.27272727272727
38095, 0.17391304347826, 0.98478260869565, 0.31818181818182
38096, 0.17391304347826, 0.98478260869565, 0.36363636363636
38097, 0.17391304347826, 0.98478260869565, 0.40909090909091
38098, 0.17391304347826, 0.98478260869565, 0.45454545454545
38099, 0.1304347826087, 0.98478260869565, 0.045454545454545
38100, 0.1304347826087, 0.98478260869565, 0.090909090909091
38101, 0.1304347826087, 0.98478260869565, 0.13636363636364
38102, 0.1304347826087, 0.98478260869565, 0.18181818181818
38103, 0.1304347826087, 0.98478260869565, 0.22727272727273
38104, 0.1304347826087, 0.98478260869565, 0.27272727272727
38105, 0.1304347826087, 0.98478260869565, 0.31818181818182
38106, 0.1304347826087, 0.98478260869565, 0.36363636363636
38107, 0.1304347826087, 0.98478260869565, 0.40909090909091
38108, 0.1304347826087, 0.98478260869565, 0.45454545454545
38109, 0.08695652173913, 0.98478260869565, 0.045454545454545
38110, 0.08695652173913, 0.98478260869565, 0.090909090909091
38111, 0.08695652173913, 0.98478260869565, 0.13636363636364
38112, 0.08695652173913, 0.98478260869565, 0.18181818181818
38113, 0.08695652173913, 0.98478260869565, 0.22727272727273
38114, 0.08695652173913, 0.98478260869565, 0.27272727272727
38115, 0.08695652173913, 0.98478260869565, 0.31818181818182
38116, 0.08695652173913, 0.98478260869565, 0.36363636363636
38117, 0.08695652173913, 0.98478260869565, 0.40909090909091
38118, 0.08695652173913, 0.98478260869565, 0.45454545454545
38119, 0.043478260869565, 0.98478260869565, 0.045454545454545
38120, 0.043478260869565, 0.98478260869565, 0.090909090909091
38121, 0.043478260869565, 0.98478260869565, 0.13636363636364
38122, 0.043478260869565, 0.98478260869565, 0.18181818181818
38123, 0.043478260869565, 0.98478260869565, 0.22727272727273
38124, 0.043478260869565, 0.98478260869565, 0.27272727272727
38125, 0.043478260869565, 0.98478260869565, 0.31818181818182
38126, 0.043478260869565, 0.98478260869565, 0.36363636363636
38127, 0.043478260869565, 0.98478260869565, 0.40909090909091
38128, 0.043478260869565, 0.98478260869565, 0.45454545454545
38129, 0.95652173913043, 1.0369565217391, 0.045454545454545
38130, 0.95652173913043, 1.0369565217391, 0.090909090909091
38131, 0.95652173913044, 1.0369565217391, 0.13636363636364
38132, 0.95652173913043, 1.0369565217391, 0.18181818181818
38133, 0.95652173913044, 1.0369565217391, 0.22727272727273
38134, 0.95652173913044, 1.0369565217391, 0.27272727272727
38135, 0.95652173913044, 1.0369565217391, 0.31818181818182
38136, 0.95652173913043, 1.0369565217391, 0.36363636363636
38137, 0.95652173913043, 1.0369565217391, 0.40909090909091
38138, 0.95652173913044, 1.0369565217391, 0.45454545454545
38139, 0.91304347826087, 1.0369565217391, 0.045454545454545
38140, 0.91304347826087, 1.0369565217391, 0.090909090909091
38141, 0.91304347826087, 1.0369565217391, 0.13636363636364
38142, 0.91304347826087, 1.0369565217391, 0.18181818181818
38143, 0.91304347826087, 1.0369565217391, 0.22727272727273
38144, 0.91304347826087, 1.0369565217391, 0.27272727272727
38145, 0.91304347826087, 1.0369565217391, 0.31818181818182
38146, 0.91304347826087, 1.0369565217391, 0.36363636363636
38147, 0.91304347826087, 1.0369565217391, 0.40909090909091
38148, 0.91304347826087, 1.0369565217391, 0.45454545454545
38149, 0.8695652173913, 1.0369565217391, 0.045454545454545
38150, 0.8695652173913, 1.0369565217391, 0.090909090909091
38151, 0.8695652173913, 1.0369565217391, 0.13636363636364
38152, 0.8695652173913, 1.0369565217391, 0.18181818181818
38153, 0.8695652173913, 1.0369565217391, 0.22727272727273
38154, 0.8695652173913, 1.0369565217391, 0.27272727272727
38155, 0.8695652173913, 1.0369565217391, 0.31818181818182
38156, 0.8695652173913, 1.0369565217391, 0.36363636363636
38157, 0.8695652173913, 1.0369565217391, 0.40909090909091
38158, 0.8695652173913, 1.0369565217391, 0.45454545454545
38159, 0.82608695652174, 1.0369565217391, 0.045454545454545
38160, 0.82608695652174, 1.0369565217391, 0.090909090909091
38161, 0.82608695652174, 1.0369565217391, 0.13636363636364
38162, 0.82608695652174, 1.0369565217391, 0.18181818181818
38163, 0.82608695652174, 1.0369565217391, 0.22727272727273
38164, 0.82608695652174, 1.0369565217391, 0.27272727272727
38165, 0.82608695652174, 1.0369565217391, 0.31818181818182
38166, 0.82608695652174, 1.0369565217391, 0.36363636363636
38167, 0.82608695652174, 1.0369565217391, 0.40909090909091
38168, 0.82608695652174, 1.0369565217391, 0.45454545454545
38169, 0.78260869565217, 1.0369565217391, 0.045454545454545
38170, 0.78260869565217, 1.0369565217391, 0.090909090909091
38171, 0.78260869565217, 1.0369565217391, 0.13636363636364
38172, 0.78260869565217, 1.0369565217391, 0.18181818181818
38173, 0.78260869565217, 1.0369565217391, 0.22727272727273
38174, 0.78260869565217, 1.0369565217391, 0.27272727272727
38175, 0.78260869565217, 1.0369565217391, 0.31818181818182
38176, 0.78260869565217, 1.0369565217391, 0.36363636363636
38177, 0.78260869565217, 1.0369565217391, 0.40909090909091
38178, 0.78260869565217, 1.0369565217391, 0.45454545454545
38179, 0.73913043478261, 1.0369565217391, 0.045454545454545
38180, 0.73913043478261, 1.0369565217391, 0.090909090909091
38181, 0.73913043478261, 1.0369565217391, 0.13636363636364
38182, 0.73913043478261, 1.0369565217391, 0.18181818181818
38183, 0.73913043478261, 1.0369565217391, 0.22727272727273
38184, 0.73913043478261, 1.0369565217391, 0.27272727272727
38185, 0.73913043478261, 1.0369565217391, 0.31818181818182
38186, 0.73913043478261, 1.0369565217391, 0.36363636363636
38187, 0.73913043478261, 1.0369565217391, 0.40909090909091
38188, 0.73913043478261, 1.0369565217391, 0.45454545454545
38189, 0.69565217391304, 1.0369565217391, 0.045454545454545
38190, 0.69565217391304, 1.0369565217391, 0.090909090909091
38191, 0.69565217391304, 1.0369565217391, 0.13636363636364
38192, 0.69565217391304, 1.0369565217391, 0.18181818181818
38193, 0.69565217391304, 1.0369565217391, 0.22727272727273
38194, 0.69565217391304, 1.0369565217391, 0.27272727272727
38195, 0.69565217391304, 1.0369565217391, 0.31818181818182
38196, 0.69565217391304, 1.0369565217391, 0.36363636363636
38197, 0.69565217391304, 1.0369565217391, 0.40909090909091
38198, 0.69565217391304, 1.0369565217391, 0.45454545454545
38199, 0.65217391304348, 1.0369565217391, 0.045454545454545
38200, 0.65217391304348, 1.0369565217391, 0.090909090909091
38201, 0.65217391304348, 1.0369565217391, 0.13636363636364
38202, 0.65217391304348, 1.0369565217391, 0.18181818181818
38203, 0.65217391304348, 1.0369565217391, 0.22727272727273
38204, 0.65217391304348, 1.0369565217391, 0.27272727272727
38205, 0.65217391304348, 1.0369565217391, 0.31818181818182
38206, 0.65217391304348, 1.0369565217391, 0.36363636363636
38207, 0.65217391304348, 1.0369565217391, 0.40909090909091
38208, 0.65217391304348, 1.0369565217391, 0.45454545454545
38209, 0.60869565217391, 1.0369565217391, 0.045454545454545
38210, 0.60869565217391, 1.0369565217391, 0.090909090909091
38211, 0.60869565217391, 1.0369565217391, 0.13636363636364
38212, 0.60869565217391, 1.0369565217391, 0.18181818181818
38213, 0.60869565217391, 1.0369565217391, 0.22727272727273
38214, 0.60869565217391, 1.0369565217391, 0.27272727272727
38215, 0.60869565217391, 1.0369565217391, 0.31818181818182
38216, 0.60869565217391, 1.0369565217391, 0.36363636363636
38217, 0.60869565217391, 1.0369565217391, 0.40909090909091
38218, 0.60869565217391, 1.0369565217391, 0.45454545454545
38219, 0.56521739130435, 1.0369565217391, 0.045454545454545
38220, 0.56521739130435, 1.0369565217391, 0.090909090909091
38221, 0.56521739130435, 1.0369565217391, 0.13636363636364
38222, 0.56521739130435, 1.0369565217391, 0.18181818181818
38223, 0.56521739130435, 1.0369565217391, 0.22727272727273
38224, 0.56521739130435, 1.0369565217391, 0.27272727272727
38225, 0.56521739130435, 1.0369565217391, 0.31818181818182
38226, 0.56521739130435, 1.0369565217391, 0.36363636363636
38227, 0.56521739130435, 1.0369565217391, 0.40909090909091
38228, 0.56521739130435, 1.0369565217391, 0.45454545454545
38229, 0.52173913043478, 1.0369565217391, 0.045454545454545
38230, 0.52173913043478, 1.0369565217391, 0.090909090909091
38231, 0.52173913043478, 1.0369565217391, 0.13636363636364
38232, 0.52173913043478, 1.0369565217391, 0.18181818181818
38233, 0.52173913043478, 1.0369565217391, 0.22727272727273
38234, 0.52173913043478, 1.0369565217391, 0.27272727272727
38235, 0.52173913043478, 1.0369565217391, 0.31818181818182
38236, 0.52173913043478, 1.0369565217391, 0.36363636363636
38237, 0.52173913043478, 1.0369565217391, 0.40909090909091
38238, 0.52173913043478, 1.0369565217391, 0.45454545454545
38239, 0.47826086956522, 1.0369565217391, 0.045454545454545
38240, 0.47826086956522, 1.0369565217391, 0.090909090909091
38241, 0.47826086956522, 1.0369565217391, 0.13636363636364
38242, 0.47826086956522, 1.0369565217391, 0.18181818181818
38243, 0.47826086956522, 1.0369565217391, 0.22727272727273
38244, 0.47826086956522, 1.0369565217391, 0.27272727272727
38245, 0.47826086956522, 1.0369565217391, 0.31818181818182
38246, 0.47826086956522, 1.0369565217391, 0.36363636363636
38247, 0.47826086956522, 1.0369565217391, 0.40909090909091
38248, 0.47826086956522, 1.0369565217391, 0.45454545454545
38249, 0.43478260869565, 1.0369565217391, 0.045454545454545
38250, 0.43478260869565, 1.0369565217391, 0.090909090909091
38251, 0.43478260869565, 1.0369565217391, 0.13636363636364
38252, 0.43478260869565, 1.0369565217391, 0.18181818181818
38253, 0.43478260869565, 1.0369565217391, 0.22727272727273
38254, 0.43478260869565, 1.0369565217391, 0.27272727272727
38255, 0.43478260869565, 1.0369565217391, 0.31818181818182
38256, 0.43478260869565, 1.0369565217391, 0.36363636363636
38257, 0.43478260869565, 1.0369565217391, 0.40909090909091
38258, 0.43478260869565, 1.0369565217391, 0.45454545454545
38259, 0.39130434782609, 1.0369565217391, 0.045454545454545
38260, 0.39130434782609, 1.0369565217391, 0.090909090909091
38261, 0.39130434782609, 1.0369565217391, 0.13636363636364
38262, 0.39130434782609, 1.0369565217391, 0.18181818181818
38263, 0.39130434782609, 1.0369565217391, 0.22727272727273
38264, 0.39130434782609, 1.0369565217391, 0.27272727272727
38265, 0.39130434782609, 1.0369565217391, 0.31818181818182
38266, 0.39130434782609, 1.0369565217391, 0.36363636363636
38267, 0.39130434782609, 1.0369565217391, 0.40909090909091
38268, 0.39130434782609, 1.0369565217391, 0.45454545454545
38269, 0.34782608695652, 1.0369565217391, 0.045454545454545
38270, 0.34782608695652, 1.0369565217391, 0.090909090909091
38271, 0.34782608695652, 1.0369565217391, 0.13636363636364
38272, 0.34782608695652, 1.0369565217391, 0.18181818181818
38273, 0.34782608695652, 1.0369565217391, 0.22727272727273
38274, 0.34782608695652, 1.0369565217391, 0.27272727272727
38275, 0.34782608695652, 1.0369565217391, 0.31818181818182
38276, 0.34782608695652, 1.0369565217391, 0.36363636363636
38277, 0.34782608695652, 1.0369565217391, 0.40909090909091
38278, 0.34782608695652, 1.0369565217391, 0.45454545454545
38279, 0.30434782608696, 1.0369565217391, 0.045454545454545
38280, 0.30434782608696, 1.0369565217391, 0.090909090909091
38281, 0.30434782608696, 1.0369565217391, 0.13636363636364
38282, 0.30434782608696, 1.0369565217391, 0.18181818181818
38283, 0.30434782608696, 1.0369565217391, 0.22727272727273
38284, 0.30434782608696, 1.0369565217391, 0.27272727272727
38285, 0.30434782608696, 1.0369565217391, 0.31818181818182
38286, 0.30434782608696, 1.0369565217391, 0.36363636363636
38287, 0.30434782608696, 1.0369565217391, 0.40909090909091
38288, 0.30434782608696, 1.0369565217391, 0.45454545454545
38289, 0.26086956521739, 1.0369565217391, 0.045454545454545
38290, 0.26086956521739, 1.0369565217391, 0.090909090909091
38291, 0.26086956521739, 1.0369565217391, 0.13636363636364
38292, 0.26086956521739, 1.0369565217391, 0.18181818181818
38293, 0.26086956521739, 1.0369565217391, 0.22727272727273
38294, 0.26086956521739, 1.0369565217391, 0.27272727272727
38295, 0.26086956521739, 1.0369565217391, 0.31818181818182
38296, 0.26086956521739, 1.0369565217391, 0.36363636363636
38297, 0.26086956521739, 1.0369565217391, 0.40909090909091
38298, 0.26086956521739, 1.0369565217391, 0.45454545454545
38299, 0.21739130434783, 1.0369565217391, 0.045454545454545
38300, 0.21739130434783, 1.0369565217391, 0.090909090909091
38301, 0.21739130434783, 1.0369565217391, 0.13636363636364
38302, 0.21739130434783, 1.0369565217391, 0.18181818181818
38303, 0.21739130434783, 1.0369565217391, 0.22727272727273
38304, 0.21739130434783, 1.0369565217391, 0.27272727272727
38305, 0.21739130434783, 1.0369565217391, 0.31818181818182
38306, 0.21739130434783, 1.0369565217391, 0.36363636363636
38307, 0.21739130434783, 1.0369565217391, 0.40909090909091
38308, 0.21739130434783, 1.0369565217391, 0.45454545454545
38309, 0.17391304347826, 1.0369565217391, 0.045454545454545
38310, 0.17391304347826, 1.0369565217391, 0.090909090909091
38311, 0.17391304347826, 1.0369565217391, 0.13636363636364
38312, 0.17391304347826, 1.0369565217391, 0.18181818181818
38313, 0.17391304347826, 1.0369565217391, 0.22727272727273
38314, 0.17391304347826, 1.0369565217391, 0.27272727272727
38315, 0.17391304347826, 1.0369565217391, 0.31818181818182
38316, 0.17391304347826, 1.0369565217391, 0.36363636363636
38317, 0.17391304347826, 1.0369565217391, 0.40909090909091
38318, 0.17391304347826, 1.0369565217391, 0.45454545454545
38319, 0.1304347826087, 1.0369565217391, 0.045454545454545
38320, 0.1304347826087, 1.0369565217391, 0.090909090909091
38321, 0.1304347826087, 1.0369565217391, 0.13636363636364
38322, 0.1304347826087, 1.0369565217391, 0.18181818181818
38323, 0.1304347826087, 1.0369565217391, 0.22727272727273
38324, 0.1304347826087, 1.0369565217391, 0.27272727272727
38325, 0.1304347826087, 1.0369565217391, 0.31818181818182
38326, 0.1304347826087, 1.0369565217391, 0.36363636363636
38327, 0.1304347826087, 1.0369565217391, 0.40909090909091
38328, 0.1304347826087, 1.0369565217391, 0.45454545454545
38329, 0.08695652173913, 1.0369565217391, 0.045454545454545
38330, 0.08695652173913, 1.0369565217391, 0.090909090909091
38331, 0.08695652173913, 1.0369565217391, 0.13636363636364
38332, 0.08695652173913, 1.0369565217391, 0.18181818181818
38333, 0.08695652173913, 1.0369565217391, 0.22727272727273
38334, 0.08695652173913, 1.0369565217391, 0.27272727272727
38335, 0.08695652173913, 1.0369565217391, 0.31818181818182
38336, 0.08695652173913, 1.0369565217391, 0.36363636363636
38337, 0.08695652173913, 1.0369565217391, 0.40909090909091
38338, 0.08695652173913, 1.0369565217391, 0.45454545454545
38339, 0.043478260869565, 1.0369565217391, 0.045454545454545
38340, 0.043478260869565, 1.0369565217391, 0.090909090909091
38341, 0.043478260869565, 1.0369565217391, 0.13636363636364
38342, 0.043478260869565, 1.0369565217391, 0.18181818181818
38343, 0.043478260869565, 1.0369565217391, 0.22727272727273
38344, 0.043478260869565, 1.0369565217391, 0.27272727272727
38345, 0.043478260869565, 1.0369565217391, 0.31818181818182
38346, 0.043478260869565, 1.0369565217391, 0.36363636363636
38347, 0.043478260869565, 1.0369565217391, 0.40909090909091
38348, 0.043478260869565, 1.0369565217391, 0.45454545454545
38349, 0.95652173913043, 1.0891304347826, 0.045454545454545
38350, 0.95652173913043, 1.0891304347826, 0.090909090909091
38351, 0.95652173913043, 1.0891304347826, 0.13636363636364
38352, 0.95652173913044, 1.0891304347826, 0.18181818181818
38353, 0.95652173913044, 1.0891304347826, 0.22727272727273
38354, 0.95652173913044, 1.0891304347826, 0.27272727272727
38355, 0.95652173913044, 1.0891304347826, 0.31818181818182
38356, 0.95652173913043, 1.0891304347826, 0.36363636363636
38357, 0.95652173913043, 1.0891304347826, 0.40909090909091
38358, 0.95652173913044, 1.0891304347826, 0.45454545454545
38359, 0.91304347826087, 1.0891304347826, 0.045454545454545
38360, 0.91304347826087, 1.0891304347826, 0.090909090909091
38361, 0.91304347826087, 1.0891304347826, 0.13636363636364
38362, 0.91304347826087, 1.0891304347826, 0.18181818181818
38363, 0.91304347826087, 1.0891304347826, 0.22727272727273
38364, 0.91304347826087, 1.0891304347826, 0.27272727272727
38365, 0.91304347826087, 1.0891304347826, 0.31818181818182
38366, 0.91304347826087, 1.0891304347826, 0.36363636363636
38367, 0.91304347826087, 1.0891304347826, 0.40909090909091
38368, 0.91304347826087, 1.0891304347826, 0.45454545454545
38369, 0.8695652173913, 1.0891304347826, 0.045454545454545
38370, 0.8695652173913, 1.0891304347826, 0.090909090909091
38371, 0.8695652173913, 1.0891304347826, 0.13636363636364
38372, 0.8695652173913, 1.0891304347826, 0.18181818181818
38373, 0.8695652173913, 1.0891304347826, 0.22727272727273
38374, 0.8695652173913, 1.0891304347826, 0.27272727272727
38375, 0.8695652173913, 1.0891304347826, 0.31818181818182
38376, 0.8695652173913, 1.0891304347826, 0.36363636363636
38377, 0.8695652173913, 1.0891304347826, 0.40909090909091
38378, 0.8695652173913, 1.0891304347826, 0.45454545454545
38379, 0.82608695652174, 1.0891304347826, 0.045454545454545
38380, 0.82608695652174, 1.0891304347826, 0.090909090909091
38381, 0.82608695652174, 1.0891304347826, 0.13636363636364
38382, 0.82608695652174, 1.0891304347826, 0.18181818181818
38383, 0.82608695652174, 1.0891304347826, 0.22727272727273
38384, 0.82608695652174, 1.0891304347826, 0.27272727272727
38385, 0.82608695652174, 1.0891304347826, 0.31818181818182
38386, 0.82608695652174, 1.0891304347826, 0.36363636363636
38387, 0.82608695652174, 1.0891304347826, 0.40909090909091
38388, 0.82608695652174, 1.0891304347826, 0.45454545454545
38389, 0.78260869565217, 1.0891304347826, 0.045454545454545
38390, 0.78260869565217, 1.0891304347826, 0.090909090909091
38391, 0.78260869565217, 1.0891304347826, 0.13636363636364
38392, 0.78260869565217, 1.0891304347826, 0.18181818181818
38393, 0.78260869565217, 1.0891304347826, 0.22727272727273
38394, 0.78260869565217, 1.0891304347826, 0.27272727272727
38395, 0.78260869565217, 1.0891304347826, 0.31818181818182
38396, 0.78260869565217, 1.0891304347826, 0.36363636363636
38397, 0.78260869565217, 1.0891304347826, 0.40909090909091
38398, 0.78260869565217, 1.0891304347826, 0.45454545454545
38399, 0.73913043478261, 1.0891304347826, 0.045454545454545
38400, 0.73913043478261, 1.0891304347826, 0.090909090909091
38401, 0.73913043478261, 1.0891304347826, 0.13636363636364
38402, 0.73913043478261, 1.0891304347826, 0.18181818181818
38403, 0.73913043478261, 1.0891304347826, 0.22727272727273
38404, 0.73913043478261, 1.0891304347826, 0.27272727272727
38405, 0.73913043478261, 1.0891304347826, 0.31818181818182
38406, 0.73913043478261, 1.0891304347826, 0.36363636363636
38407, 0.73913043478261, 1.0891304347826, 0.40909090909091
38408, 0.73913043478261, 1.0891304347826, 0.45454545454545
38409, 0.69565217391304, 1.0891304347826, 0.045454545454545
38410, 0.69565217391304, 1.0891304347826, 0.090909090909091
38411, 0.69565217391304, 1.0891304347826, 0.13636363636364
38412, 0.69565217391304, 1.0891304347826, 0.18181818181818
38413, 0.69565217391304, 1.0891304347826, 0.22727272727273
38414, 0.69565217391304, 1.0891304347826, 0.27272727272727
38415, 0.69565217391304, 1.0891304347826, 0.31818181818182
38416, 0.69565217391304, 1.0891304347826, 0.36363636363636
38417, 0.69565217391304, 1.0891304347826, 0.40909090909091
38418, 0.69565217391304, 1.0891304347826, 0.45454545454545
38419, 0.65217391304348, 1.0891304347826, 0.045454545454545
38420, 0.65217391304348, 1.0891304347826, 0.090909090909091
38421, 0.65217391304348, 1.0891304347826, 0.13636363636364
38422, 0.65217391304348, 1.0891304347826, 0.18181818181818
38423, 0.65217391304348, 1.0891304347826, 0.22727272727273
38424, 0.65217391304348, 1.0891304347826, 0.27272727272727
38425, 0.65217391304348, 1.0891304347826, 0.31818181818182
38426, 0.65217391304348, 1.0891304347826, 0.36363636363636
38427, 0.65217391304348, 1.0891304347826, 0.40909090909091
38428, 0.65217391304348, 1.0891304347826, 0.45454545454545
38429, 0.60869565217391, 1.0891304347826, 0.045454545454545
38430, 0.60869565217391, 1.0891304347826, 0.090909090909091
38431, 0.60869565217391, 1.0891304347826, 0.13636363636364
38432, 0.60869565217391, 1.0891304347826, 0.18181818181818
38433, 0.60869565217391, 1.0891304347826, 0.22727272727273
38434, 0.60869565217391, 1.0891304347826, 0.27272727272727
38435, 0.60869565217391, 1.0891304347826, 0.31818181818182
38436, 0.60869565217391, 1.0891304347826, 0.36363636363636
38437, 0.60869565217391, 1.0891304347826, 0.40909090909091
38438, 0.60869565217391, 1.0891304347826, 0.45454545454545
38439, 0.56521739130435, 1.0891304347826, 0.045454545454545
38440, 0.56521739130435, 1.0891304347826, 0.090909090909091
38441, 0.56521739130435, 1.0891304347826, 0.13636363636364
38442, 0.56521739130435, 1.0891304347826, 0.18181818181818
38443, 0.56521739130435, 1.0891304347826, 0.22727272727273
38444, 0.56521739130435, 1.0891304347826, 0.27272727272727
38445, 0.56521739130435, 1.0891304347826, 0.31818181818182
38446, 0.56521739130435, 1.0891304347826, 0.36363636363636
38447, 0.56521739130435, 1.0891304347826, 0.40909090909091
38448, 0.56521739130435, 1.0891304347826, 0.45454545454545
38449, 0.52173913043478, 1.0891304347826, 0.045454545454545
38450, 0.52173913043478, 1.0891304347826, 0.090909090909091
38451, 0.52173913043478, 1.0891304347826, 0.13636363636364
38452, 0.52173913043478, 1.0891304347826, 0.18181818181818
38453, 0.52173913043478, 1.0891304347826, 0.22727272727273
38454, 0.52173913043478, 1.0891304347826, 0.27272727272727
38455, 0.52173913043478, 1.0891304347826, 0.31818181818182
38456, 0.52173913043478, 1.0891304347826, 0.36363636363636
38457, 0.52173913043478, 1.0891304347826, 0.40909090909091
38458, 0.52173913043478, 1.0891304347826, 0.45454545454545
38459, 0.47826086956522, 1.0891304347826, 0.045454545454545
38460, 0.47826086956522, 1.0891304347826, 0.090909090909091
38461, 0.47826086956522, 1.0891304347826, 0.13636363636364
38462, 0.47826086956522, 1.0891304347826, 0.18181818181818
38463, 0.47826086956522, 1.0891304347826, 0.22727272727273
38464, 0.47826086956522, 1.0891304347826, 0.27272727272727
38465, 0.47826086956522, 1.0891304347826, 0.31818181818182
38466, 0.47826086956522, 1.0891304347826, 0.36363636363636
38467, 0.47826086956522, 1.0891304347826, 0.40909090909091
38468, 0.47826086956522, 1.0891304347826, 0.45454545454545
38469, 0.43478260869565, 1.0891304347826, 0.045454545454545
38470, 0.43478260869565, 1.0891304347826, 0.090909090909091
38471, 0.43478260869565, 1.0891304347826, 0.13636363636364
38472, 0.43478260869565, 1.0891304347826, 0.18181818181818
38473, 0.43478260869565, 1.0891304347826, 0.22727272727273
38474, 0.43478260869565, 1.0891304347826, 0.27272727272727
38475, 0.43478260869565, 1.0891304347826, 0.31818181818182
38476, 0.43478260869565, 1.0891304347826, 0.36363636363636
38477, 0.43478260869565, 1.0891304347826, 0.40909090909091
38478, 0.43478260869565, 1.0891304347826, 0.45454545454545
38479, 0.39130434782609, 1.0891304347826, 0.045454545454545
38480, 0.39130434782609, 1.0891304347826, 0.090909090909091
38481, 0.39130434782609, 1.0891304347826, 0.13636363636364
38482, 0.39130434782609, 1.0891304347826, 0.18181818181818
38483, 0.39130434782609, 1.0891304347826, 0.22727272727273
38484, 0.39130434782609, 1.0891304347826, 0.27272727272727
38485, 0.39130434782609, 1.0891304347826, 0.31818181818182
38486, 0.39130434782609, 1.0891304347826, 0.36363636363636
38487, 0.39130434782609, 1.0891304347826, 0.40909090909091
38488, 0.39130434782609, 1.0891304347826, 0.45454545454545
38489, 0.34782608695652, 1.0891304347826, 0.045454545454545
38490, 0.34782608695652, 1.0891304347826, 0.090909090909091
38491, 0.34782608695652, 1.0891304347826, 0.13636363636364
38492, 0.34782608695652, 1.0891304347826, 0.18181818181818
38493, 0.34782608695652, 1.0891304347826, 0.22727272727273
38494, 0.34782608695652, 1.0891304347826, 0.27272727272727
38495, 0.34782608695652, 1.0891304347826, 0.31818181818182
38496, 0.34782608695652, 1.0891304347826, 0.36363636363636
38497, 0.34782608695652, 1.0891304347826, 0.40909090909091
38498, 0.34782608695652, 1.0891304347826, 0.45454545454545
38499, 0.30434782608696, 1.0891304347826, 0.045454545454545
38500, 0.30434782608696, 1.0891304347826, 0.090909090909091
38501, 0.30434782608696, 1.0891304347826, 0.13636363636364
38502, 0.30434782608696, 1.0891304347826, 0.18181818181818
38503, 0.30434782608696, 1.0891304347826, 0.22727272727273
38504, 0.30434782608696, 1.0891304347826, 0.27272727272727
38505, 0.30434782608696, 1.0891304347826, 0.31818181818182
38506, 0.30434782608696, 1.0891304347826, 0.36363636363636
38507, 0.30434782608696, 1.0891304347826, 0.40909090909091
38508, 0.30434782608696, 1.0891304347826, 0.45454545454545
38509, 0.26086956521739, 1.0891304347826, 0.045454545454545
38510, 0.26086956521739, 1.0891304347826, 0.090909090909091
38511, 0.26086956521739, 1.0891304347826, 0.13636363636364
38512, 0.26086956521739, 1.0891304347826, 0.18181818181818
38513, 0.26086956521739, 1.0891304347826, 0.22727272727273
38514, 0.26086956521739, 1.0891304347826, 0.27272727272727
38515, 0.26086956521739, 1.0891304347826, 0.31818181818182
38516, 0.26086956521739, 1.0891304347826, 0.36363636363636
38517, 0.26086956521739, 1.0891304347826, 0.40909090909091
38518, 0.26086956521739, 1.0891304347826, 0.45454545454545
38519, 0.21739130434783, 1.0891304347826, 0.045454545454545
38520, 0.21739130434783, 1.0891304347826, 0.090909090909091
38521, 0.21739130434783, 1.0891304347826, 0.13636363636364
38522, 0.21739130434783, 1.0891304347826, 0.18181818181818
38523, 0.21739130434783, 1.0891304347826, 0.22727272727273
38524, 0.21739130434783, 1.0891304347826, 0.27272727272727
38525, 0.21739130434783, 1.0891304347826, 0.31818181818182
38526, 0.21739130434783, 1.0891304347826, 0.36363636363636
38527, 0.21739130434783, 1.0891304347826, 0.40909090909091
38528, 0.21739130434783, 1.0891304347826, 0.45454545454545
38529, 0.17391304347826, 1.0891304347826, 0.045454545454545
38530, 0.17391304347826, 1.0891304347826, 0.090909090909091
38531, 0.17391304347826, 1.0891304347826, 0.13636363636364
38532, 0.17391304347826, 1.0891304347826, 0.18181818181818
38533, 0.17391304347826, 1.0891304347826, 0.22727272727273
38534, 0.17391304347826, 1.0891304347826, 0.27272727272727
38535, 0.17391304347826, 1.0891304347826, 0.31818181818182
38536, 0.17391304347826, 1.0891304347826, 0.36363636363636
38537, 0.17391304347826, 1.0891304347826, 0.40909090909091
38538, 0.17391304347826, 1.0891304347826, 0.45454545454545
38539, 0.1304347826087, 1.0891304347826, 0.045454545454545
38540, 0.1304347826087, 1.0891304347826, 0.090909090909091
38541, 0.1304347826087, 1.0891304347826, 0.13636363636364
38542, 0.1304347826087, 1.0891304347826, 0.18181818181818
38543, 0.1304347826087, 1.0891304347826, 0.22727272727273
38544, 0.1304347826087, 1.0891304347826, 0.27272727272727
38545, 0.1304347826087, 1.0891304347826, 0.31818181818182
38546, 0.1304347826087, 1.0891304347826, 0.36363636363636
38547, 0.1304347826087, 1.0891304347826, 0.40909090909091
38548, 0.1304347826087, 1.0891304347826, 0.45454545454545
38549, 0.08695652173913, 1.0891304347826, 0.045454545454545
38550, 0.08695652173913, 1.0891304347826, 0.090909090909091
38551, 0.08695652173913, 1.0891304347826, 0.13636363636364
38552, 0.08695652173913, 1.0891304347826, 0.18181818181818
38553, 0.08695652173913, 1.0891304347826, 0.22727272727273
38554, 0.08695652173913, 1.0891304347826, 0.27272727272727
38555, 0.08695652173913, 1.0891304347826, 0.31818181818182
38556, 0.08695652173913, 1.0891304347826, 0.36363636363636
38557, 0.08695652173913, 1.0891304347826, 0.40909090909091
38558, 0.08695652173913, 1.0891304347826, 0.45454545454545
38559, 0.043478260869565, 1.0891304347826, 0.045454545454545
38560, 0.043478260869565, 1.0891304347826, 0.090909090909091
38561, 0.043478260869565, 1.0891304347826, 0.13636363636364
38562, 0.043478260869565, 1.0891304347826, 0.18181818181818
38563, 0.043478260869565, 1.0891304347826, 0.22727272727273
38564, 0.043478260869565, 1.0891304347826, 0.27272727272727
38565, 0.043478260869565, 1.0891304347826, 0.31818181818182
38566, 0.043478260869565, 1.0891304347826, 0.36363636363636
38567, 0.043478260869565, 1.0891304347826, 0.40909090909091
38568, 0.043478260869565, 1.0891304347826, 0.45454545454545
38569, 0.95652173913043, 1.1413043478261, 0.045454545454545
38570, 0.95652173913043, 1.1413043478261, 0.090909090909091
38571, 0.95652173913044, 1.1413043478261, 0.13636363636364
38572, 0.95652173913044, 1.1413043478261, 0.18181818181818
38573, 0.95652173913044, 1.1413043478261, 0.22727272727273
38574, 0.95652173913044, 1.1413043478261, 0.27272727272727
38575, 0.95652173913044, 1.1413043478261, 0.31818181818182
38576, 0.95652173913043, 1.1413043478261, 0.36363636363636
38577, 0.95652173913043, 1.1413043478261, 0.40909090909091
38578, 0.95652173913044, 1.1413043478261, 0.45454545454545
38579, 0.91304347826087, 1.1413043478261, 0.045454545454545
38580, 0.91304347826087, 1.1413043478261, 0.090909090909091
38581, 0.91304347826087, 1.1413043478261, 0.13636363636364
38582, 0.91304347826087, 1.1413043478261, 0.18181818181818
38583, 0.91304347826087, 1.1413043478261, 0.22727272727273
38584, 0.91304347826087, 1.1413043478261, 0.27272727272727
38585, 0.91304347826087, 1.1413043478261, 0.31818181818182
38586, 0.91304347826087, 1.1413043478261, 0.36363636363636
38587, 0.91304347826087, 1.1413043478261, 0.40909090909091
38588, 0.91304347826087, 1.1413043478261, 0.45454545454545
38589, 0.8695652173913, 1.1413043478261, 0.045454545454545
38590, 0.8695652173913, 1.1413043478261, 0.090909090909091
38591, 0.8695652173913, 1.1413043478261, 0.13636363636364
38592, 0.8695652173913, 1.1413043478261, 0.18181818181818
38593, 0.8695652173913, 1.1413043478261, 0.22727272727273
38594, 0.8695652173913, 1.1413043478261, 0.27272727272727
38595, 0.8695652173913, 1.1413043478261, 0.31818181818182
38596, 0.8695652173913, 1.1413043478261, 0.36363636363636
38597, 0.8695652173913, 1.1413043478261, 0.40909090909091
38598, 0.8695652173913, 1.1413043478261, 0.45454545454545
38599, 0.82608695652174, 1.1413043478261, 0.045454545454545
38600, 0.82608695652174, 1.1413043478261, 0.090909090909091
38601, 0.82608695652174, 1.1413043478261, 0.13636363636364
38602, 0.82608695652174, 1.1413043478261, 0.18181818181818
38603, 0.82608695652174, 1.1413043478261, 0.22727272727273
38604, 0.82608695652174, 1.1413043478261, 0.27272727272727
38605, 0.82608695652174, 1.1413043478261, 0.31818181818182
38606, 0.82608695652174, 1.1413043478261, 0.36363636363636
38607, 0.82608695652174, 1.1413043478261, 0.40909090909091
38608, 0.82608695652174, 1.1413043478261, 0.45454545454545
38609, 0.78260869565217, 1.1413043478261, 0.045454545454545
38610, 0.78260869565217, 1.1413043478261, 0.090909090909091
38611, 0.78260869565217, 1.1413043478261, 0.13636363636364
38612, 0.78260869565217, 1.1413043478261, 0.18181818181818
38613, 0.78260869565217, 1.1413043478261, 0.22727272727273
38614, 0.78260869565217, 1.1413043478261, 0.27272727272727
38615, 0.78260869565217, 1.1413043478261, 0.31818181818182
38616, 0.78260869565217, 1.1413043478261, 0.36363636363636
38617, 0.78260869565217, 1.1413043478261, 0.40909090909091
38618, 0.78260869565217, 1.1413043478261, 0.45454545454545
38619, 0.73913043478261, 1.1413043478261, 0.045454545454545
38620, 0.73913043478261, 1.1413043478261, 0.090909090909091
38621, 0.73913043478261, 1.1413043478261, 0.13636363636364
38622, 0.73913043478261, 1.1413043478261, 0.18181818181818
38623, 0.73913043478261, 1.1413043478261, 0.22727272727273
38624, 0.73913043478261, 1.1413043478261, 0.27272727272727
38625, 0.73913043478261, 1.1413043478261, 0.31818181818182
38626, 0.73913043478261, 1.1413043478261, 0.36363636363636
38627, 0.73913043478261, 1.1413043478261, 0.40909090909091
38628, 0.73913043478261, 1.1413043478261, 0.45454545454545
38629, 0.69565217391304, 1.1413043478261, 0.045454545454545
38630, 0.69565217391304, 1.1413043478261, 0.090909090909091
38631, 0.69565217391304, 1.1413043478261, 0.13636363636364
38632, 0.69565217391304, 1.1413043478261, 0.18181818181818
38633, 0.69565217391304, 1.1413043478261, 0.22727272727273
38634, 0.69565217391304, 1.1413043478261, 0.27272727272727
38635, 0.69565217391304, 1.1413043478261, 0.31818181818182
38636, 0.69565217391304, 1.1413043478261, 0.36363636363636
38637, 0.69565217391304, 1.1413043478261, 0.40909090909091
38638, 0.69565217391304, 1.1413043478261, 0.45454545454545
38639, 0.65217391304348, 1.1413043478261, 0.045454545454545
38640, 0.65217391304348, 1.1413043478261, 0.090909090909091
38641, 0.65217391304348, 1.1413043478261, 0.13636363636364
38642, 0.65217391304348, 1.1413043478261, 0.18181818181818
38643, 0.65217391304348, 1.1413043478261, 0.22727272727273
38644, 0.65217391304348, 1.1413043478261, 0.27272727272727
38645, 0.65217391304348, 1.1413043478261, 0.31818181818182
38646, 0.65217391304348, 1.1413043478261, 0.36363636363636
38647, 0.65217391304348, 1.1413043478261, 0.40909090909091
38648, 0.65217391304348, 1.1413043478261, 0.45454545454545
38649, 0.60869565217391, 1.1413043478261, 0.045454545454545
38650, 0.60869565217391, 1.1413043478261, 0.090909090909091
38651, 0.60869565217391, 1.1413043478261, 0.13636363636364
38652, 0.60869565217391, 1.1413043478261, 0.18181818181818
38653, 0.60869565217391, 1.1413043478261, 0.22727272727273
38654, 0.60869565217391, 1.1413043478261, 0.27272727272727
38655, 0.60869565217391, 1.1413043478261, 0.31818181818182
38656, 0.60869565217391, 1.1413043478261, 0.36363636363636
38657, 0.60869565217391, 1.1413043478261, 0.40909090909091
38658, 0.60869565217391, 1.1413043478261, 0.45454545454545
38659, 0.56521739130435, 1.1413043478261, 0.045454545454545
38660, 0.56521739130435, 1.1413043478261, 0.090909090909091
38661, 0.56521739130435, 1.1413043478261, 0.13636363636364
38662, 0.56521739130435, 1.1413043478261, 0.18181818181818
38663, 0.56521739130435, 1.1413043478261, 0.22727272727273
38664, 0.56521739130435, 1.1413043478261, 0.27272727272727
38665, 0.56521739130435, 1.1413043478261, 0.31818181818182
38666, 0.56521739130435, 1.1413043478261, 0.36363636363636
38667, 0.56521739130435, 1.1413043478261, 0.40909090909091
38668, 0.56521739130435, 1.1413043478261, 0.45454545454545
38669, 0.52173913043478, 1.1413043478261, 0.045454545454545
38670, 0.52173913043478, 1.1413043478261, 0.090909090909091
38671, 0.52173913043478, 1.1413043478261, 0.13636363636364
38672, 0.52173913043478, 1.1413043478261, 0.18181818181818
38673, 0.52173913043478, 1.1413043478261, 0.22727272727273
38674, 0.52173913043478, 1.1413043478261, 0.27272727272727
38675, 0.52173913043478, 1.1413043478261, 0.31818181818182
38676, 0.52173913043478, 1.1413043478261, 0.36363636363636
38677, 0.52173913043478, 1.1413043478261, 0.40909090909091
38678, 0.52173913043478, 1.1413043478261, 0.45454545454545
38679, 0.47826086956522, 1.1413043478261, 0.045454545454545
38680, 0.47826086956522, 1.1413043478261, 0.090909090909091
38681, 0.47826086956522, 1.1413043478261, 0.13636363636364
38682, 0.47826086956522, 1.1413043478261, 0.18181818181818
38683, 0.47826086956522, 1.1413043478261, 0.22727272727273
38684, 0.47826086956522, 1.1413043478261, 0.27272727272727
38685, 0.47826086956522, 1.1413043478261, 0.31818181818182
38686, 0.47826086956522, 1.1413043478261, 0.36363636363636
38687, 0.47826086956522, 1.1413043478261, 0.40909090909091
38688, 0.47826086956522, 1.1413043478261, 0.45454545454545
38689, 0.43478260869565, 1.1413043478261, 0.045454545454545
38690, 0.43478260869565, 1.1413043478261, 0.090909090909091
38691, 0.43478260869565, 1.1413043478261, 0.13636363636364
38692, 0.43478260869565, 1.1413043478261, 0.18181818181818
38693, 0.43478260869565, 1.1413043478261, 0.22727272727273
38694, 0.43478260869565, 1.1413043478261, 0.27272727272727
38695, 0.43478260869565, 1.1413043478261, 0.31818181818182
38696, 0.43478260869565, 1.1413043478261, 0.36363636363636
38697, 0.43478260869565, 1.1413043478261, 0.40909090909091
38698, 0.43478260869565, 1.1413043478261, 0.45454545454545
38699, 0.39130434782609, 1.1413043478261, 0.045454545454545
38700, 0.39130434782609, 1.1413043478261, 0.090909090909091
38701, 0.39130434782609, 1.1413043478261, 0.13636363636364
38702, 0.39130434782609, 1.1413043478261, 0.18181818181818
38703, 0.39130434782609, 1.1413043478261, 0.22727272727273
38704, 0.39130434782609, 1.1413043478261, 0.27272727272727
38705, 0.39130434782609, 1.1413043478261, 0.31818181818182
38706, 0.39130434782609, 1.1413043478261, 0.36363636363636
38707, 0.39130434782609, 1.1413043478261, 0.40909090909091
38708, 0.39130434782609, 1.1413043478261, 0.45454545454545
38709, 0.34782608695652, 1.1413043478261, 0.045454545454545
38710, 0.34782608695652, 1.1413043478261, 0.090909090909091
38711, 0.34782608695652, 1.1413043478261, 0.13636363636364
38712, 0.34782608695652, 1.1413043478261, 0.18181818181818
38713, 0.34782608695652, 1.1413043478261, 0.22727272727273
38714, 0.34782608695652, 1.1413043478261, 0.27272727272727
38715, 0.34782608695652, 1.1413043478261, 0.31818181818182
38716, 0.34782608695652, 1.1413043478261, 0.36363636363636
38717, 0.34782608695652, 1.1413043478261, 0.40909090909091
38718, 0.34782608695652, 1.1413043478261, 0.45454545454545
38719, 0.30434782608696, 1.1413043478261, 0.045454545454545
38720, 0.30434782608696, 1.1413043478261, 0.090909090909091
38721, 0.30434782608696, 1.1413043478261, 0.13636363636364
38722, 0.30434782608696, 1.1413043478261, 0.18181818181818
38723, 0.30434782608696, 1.1413043478261, 0.22727272727273
38724, 0.30434782608696, 1.1413043478261, 0.27272727272727
38725, 0.30434782608696, 1.1413043478261, 0.31818181818182
38726, 0.30434782608696, 1.1413043478261, 0.36363636363636
38727, 0.30434782608696, 1.1413043478261, 0.40909090909091
38728, 0.30434782608696, 1.1413043478261, 0.45454545454545
38729, 0.26086956521739, 1.1413043478261, 0.045454545454545
38730, 0.26086956521739, 1.1413043478261, 0.090909090909091
38731, 0.26086956521739, 1.1413043478261, 0.13636363636364
38732, 0.26086956521739, 1.1413043478261, 0.18181818181818
38733, 0.26086956521739, 1.1413043478261, 0.22727272727273
38734, 0.26086956521739, 1.1413043478261, 0.27272727272727
38735, 0.26086956521739, 1.1413043478261, 0.31818181818182
38736, 0.26086956521739, 1.1413043478261, 0.36363636363636
38737, 0.26086956521739, 1.1413043478261, 0.40909090909091
38738, 0.26086956521739, 1.1413043478261, 0.45454545454545
38739, 0.21739130434783, 1.1413043478261, 0.045454545454545
38740, 0.21739130434783, 1.1413043478261, 0.090909090909091
38741, 0.21739130434783, 1.1413043478261, 0.13636363636364
38742, 0.21739130434783, 1.1413043478261, 0.18181818181818
38743, 0.21739130434783, 1.1413043478261, 0.22727272727273
38744, 0.21739130434783, 1.1413043478261, 0.27272727272727
38745, 0.21739130434783, 1.1413043478261, 0.31818181818182
38746, 0.21739130434783, 1.1413043478261, 0.36363636363636
38747, 0.21739130434783, 1.1413043478261, 0.40909090909091
38748, 0.21739130434783, 1.1413043478261, 0.45454545454545
38749, 0.17391304347826, 1.1413043478261, 0.045454545454545
38750, 0.17391304347826, 1.1413043478261, 0.090909090909091
38751, 0.17391304347826, 1.1413043478261, 0.13636363636364
38752, 0.17391304347826, 1.1413043478261, 0.18181818181818
38753, 0.17391304347826, 1.1413043478261, 0.22727272727273
38754, 0.17391304347826, 1.1413043478261, 0.27272727272727
38755, 0.17391304347826, 1.1413043478261, 0.31818181818182
38756, 0.17391304347826, 1.1413043478261, 0.36363636363636
38757, 0.17391304347826, 1.1413043478261, 0.40909090909091
38758, 0.17391304347826, 1.1413043478261, 0.45454545454545
38759, 0.1304347826087, 1.1413043478261, 0.045454545454545
38760, 0.1304347826087, 1.1413043478261, 0.090909090909091
38761, 0.1304347826087, 1.1413043478261, 0.13636363636364
38762, 0.1304347826087, 1.1413043478261, 0.18181818181818
38763, 0.1304347826087, 1.1413043478261, 0.22727272727273
38764, 0.1304347826087, 1.1413043478261, 0.27272727272727
38765, 0.1304347826087, 1.1413043478261, 0.31818181818182
38766, 0.1304347826087, 1.1413043478261, 0.36363636363636
38767, 0.1304347826087, 1.1413043478261, 0.40909090909091
38768, 0.1304347826087, 1.1413043478261, 0.45454545454545
38769, 0.08695652173913, 1.1413043478261, 0.045454545454545
38770, 0.08695652173913, 1.1413043478261, 0.090909090909091
38771, 0.08695652173913, 1.1413043478261, 0.13636363636364
38772, 0.08695652173913, 1.1413043478261, 0.18181818181818
38773, 0.08695652173913, 1.1413043478261, 0.22727272727273
38774, 0.08695652173913, 1.1413043478261, 0.27272727272727
38775, 0.08695652173913, 1.1413043478261, 0.31818181818182
38776, 0.08695652173913, 1.1413043478261, 0.36363636363636
38777, 0.08695652173913, 1.1413043478261, 0.40909090909091
38778, 0.08695652173913, 1.1413043478261, 0.45454545454545
38779, 0.043478260869565, 1.1413043478261, 0.045454545454545
38780, 0.043478260869565, 1.1413043478261, 0.090909090909091
38781, 0.043478260869565, 1.1413043478261, 0.13636363636364
38782, 0.043478260869565, 1.1413043478261, 0.18181818181818
38783, 0.043478260869565, 1.1413043478261, 0.22727272727273
38784, 0.043478260869565, 1.1413043478261, 0.27272727272727
38785, 0.043478260869565, 1.1413043478261, 0.31818181818182
38786, 0.043478260869565, 1.1413043478261, 0.36363636363636
38787, 0.043478260869565, 1.1413043478261, 0.40909090909091
38788, 0.043478260869565, 1.1413043478261, 0.45454545454545
38789, 0.95652173913043, 1.1934782608696, 0.045454545454545
38790, 0.95652173913043, 1.1934782608696, 0.090909090909091
38791, 0.95652173913044, 1.1934782608696, 0.13636363636364
38792, 0.95652173913044, 1.1934782608696, 0.18181818181818
38793, 0.95652173913044, 1.1934782608696, 0.22727272727273
38794, 0.95652173913044, 1.1934782608696, 0.27272727272727
38795, 0.95652173913044, 1.1934782608696, 0.31818181818182
38796, 0.95652173913043, 1.1934782608696, 0.36363636363636
38797, 0.95652173913043, 1.1934782608696, 0.40909090909091
38798, 0.95652173913044, 1.1934782608696, 0.45454545454545
38799, 0.91304347826087, 1.1934782608696, 0.045454545454545
38800, 0.91304347826087, 1.1934782608696, 0.090909090909091
38801, 0.91304347826087, 1.1934782608696, 0.13636363636364
38802, 0.91304347826087, 1.1934782608696, 0.18181818181818
38803, 0.91304347826087, 1.1934782608696, 0.22727272727273
38804, 0.91304347826087, 1.1934782608696, 0.27272727272727
38805, 0.91304347826087, 1.1934782608696, 0.31818181818182
38806, 0.91304347826087, 1.1934782608696, 0.36363636363636
38807, 0.91304347826087, 1.1934782608696, 0.40909090909091
38808, 0.91304347826087, 1.1934782608696, 0.45454545454545
38809, 0.8695652173913, 1.1934782608696, 0.045454545454545
38810, 0.8695652173913, 1.1934782608696, 0.090909090909091
38811, 0.8695652173913, 1.1934782608696, 0.13636363636364
38812, 0.8695652173913, 1.1934782608696, 0.18181818181818
38813, 0.8695652173913, 1.1934782608696, 0.22727272727273
38814, 0.8695652173913, 1.1934782608696, 0.27272727272727
38815, 0.8695652173913, 1.1934782608696, 0.31818181818182
38816, 0.8695652173913, 1.1934782608696, 0.36363636363636
38817, 0.8695652173913, 1.1934782608696, 0.40909090909091
38818, 0.8695652173913, 1.1934782608696, 0.45454545454545
38819, 0.82608695652174, 1.1934782608696, 0.045454545454545
38820, 0.82608695652174, 1.1934782608696, 0.090909090909091
38821, 0.82608695652174, 1.1934782608696, 0.13636363636364
38822, 0.82608695652174, 1.1934782608696, 0.18181818181818
38823, 0.82608695652174, 1.1934782608696, 0.22727272727273
38824, 0.82608695652174, 1.1934782608696, 0.27272727272727
38825, 0.82608695652174, 1.1934782608696, 0.31818181818182
38826, 0.82608695652174, 1.1934782608696, 0.36363636363636
38827, 0.82608695652174, 1.1934782608696, 0.40909090909091
38828, 0.82608695652174, 1.1934782608696, 0.45454545454545
38829, 0.78260869565217, 1.1934782608696, 0.045454545454545
38830, 0.78260869565217, 1.1934782608696, 0.090909090909091
38831, 0.78260869565217, 1.1934782608696, 0.13636363636364
38832, 0.78260869565217, 1.1934782608696, 0.18181818181818
38833, 0.78260869565217, 1.1934782608696, 0.22727272727273
38834, 0.78260869565217, 1.1934782608696, 0.27272727272727
38835, 0.78260869565217, 1.1934782608696, 0.31818181818182
38836, 0.78260869565217, 1.1934782608696, 0.36363636363636
38837, 0.78260869565217, 1.1934782608696, 0.40909090909091
38838, 0.78260869565217, 1.1934782608696, 0.45454545454545
38839, 0.73913043478261, 1.1934782608696, 0.045454545454545
38840, 0.73913043478261, 1.1934782608696, 0.090909090909091
38841, 0.73913043478261, 1.1934782608696, 0.13636363636364
38842, 0.73913043478261, 1.1934782608696, 0.18181818181818
38843, 0.73913043478261, 1.1934782608696, 0.22727272727273
38844, 0.73913043478261, 1.1934782608696, 0.27272727272727
38845, 0.73913043478261, 1.1934782608696, 0.31818181818182
38846, 0.73913043478261, 1.1934782608696, 0.36363636363636
38847, 0.73913043478261, 1.1934782608696, 0.40909090909091
38848, 0.73913043478261, 1.1934782608696, 0.45454545454545
38849, 0.69565217391304, 1.1934782608696, 0.045454545454545
38850, 0.69565217391304, 1.1934782608696, 0.090909090909091
38851, 0.69565217391304, 1.1934782608696, 0.13636363636364
38852, 0.69565217391304, 1.1934782608696, 0.18181818181818
38853, 0.69565217391304, 1.1934782608696, 0.22727272727273
38854, 0.69565217391304, 1.1934782608696, 0.27272727272727
38855, 0.69565217391304, 1.1934782608696, 0.31818181818182
38856, 0.69565217391304, 1.1934782608696, 0.36363636363636
38857, 0.69565217391304, 1.1934782608696, 0.40909090909091
38858, 0.69565217391304, 1.1934782608696, 0.45454545454545
38859, 0.65217391304348, 1.1934782608696, 0.045454545454545
38860, 0.65217391304348, 1.1934782608696, 0.090909090909091
38861, 0.65217391304348, 1.1934782608696, 0.13636363636364
38862, 0.65217391304348, 1.1934782608696, 0.18181818181818
38863, 0.65217391304348, 1.1934782608696, 0.22727272727273
38864, 0.65217391304348, 1.1934782608696, 0.27272727272727
38865, 0.65217391304348, 1.1934782608696, 0.31818181818182
38866, 0.65217391304348, 1.1934782608696, 0.36363636363636
38867, 0.65217391304348, 1.1934782608696, 0.40909090909091
38868, 0.65217391304348, 1.1934782608696, 0.45454545454545
38869, 0.60869565217391, 1.1934782608696, 0.045454545454545
38870, 0.60869565217391, 1.1934782608696, 0.090909090909091
38871, 0.60869565217391, 1.1934782608696, 0.13636363636364
38872, 0.60869565217391, 1.1934782608696, 0.18181818181818
38873, 0.60869565217391, 1.1934782608696, 0.22727272727273
38874, 0.60869565217391, 1.1934782608696, 0.27272727272727
38875, 0.60869565217391, 1.1934782608696, 0.31818181818182
38876, 0.60869565217391, 1.1934782608696, 0.36363636363636
38877, 0.60869565217391, 1.1934782608696, 0.40909090909091
38878, 0.60869565217391, 1.1934782608696, 0.45454545454545
38879, 0.56521739130435, 1.1934782608696, 0.045454545454545
38880, 0.56521739130435, 1.1934782608696, 0.090909090909091
38881, 0.56521739130435, 1.1934782608696, 0.13636363636364
38882, 0.56521739130435, 1.1934782608696, 0.18181818181818
38883, 0.56521739130435, 1.1934782608696, 0.22727272727273
38884, 0.56521739130435, 1.1934782608696, 0.27272727272727
38885, 0.56521739130435, 1.1934782608696, 0.31818181818182
38886, 0.56521739130435, 1.1934782608696, 0.36363636363636
38887, 0.56521739130435, 1.1934782608696, 0.40909090909091
38888, 0.56521739130435, 1.1934782608696, 0.45454545454545
38889, 0.52173913043478, 1.1934782608696, 0.045454545454545
38890, 0.52173913043478, 1.1934782608696, 0.090909090909091
38891, 0.52173913043478, 1.1934782608696, 0.13636363636364
38892, 0.52173913043478, 1.1934782608696, 0.18181818181818
38893, 0.52173913043478, 1.1934782608696, 0.22727272727273
38894, 0.52173913043478, 1.1934782608696, 0.27272727272727
38895, 0.52173913043478, 1.1934782608696, 0.31818181818182
38896, 0.52173913043478, 1.1934782608696, 0.36363636363636
38897, 0.52173913043478, 1.1934782608696, 0.40909090909091
38898, 0.52173913043478, 1.1934782608696, 0.45454545454545
38899, 0.47826086956522, 1.1934782608696, 0.045454545454545
38900, 0.47826086956522, 1.1934782608696, 0.090909090909091
38901, 0.47826086956522, 1.1934782608696, 0.13636363636364
38902, 0.47826086956522, 1.1934782608696, 0.18181818181818
38903, 0.47826086956522, 1.1934782608696, 0.22727272727273
38904, 0.47826086956522, 1.1934782608696, 0.27272727272727
38905, 0.47826086956522, 1.1934782608696, 0.31818181818182
38906, 0.47826086956522, 1.1934782608696, 0.36363636363636
38907, 0.47826086956522, 1.1934782608696, 0.40909090909091
38908, 0.47826086956522, 1.1934782608696, 0.45454545454545
38909, 0.43478260869565, 1.1934782608696, 0.045454545454545
38910, 0.43478260869565, 1.1934782608696, 0.090909090909091
38911, 0.43478260869565, 1.1934782608696, 0.13636363636364
38912, 0.43478260869565, 1.1934782608696, 0.18181818181818
38913, 0.43478260869565, 1.1934782608696, 0.22727272727273
38914, 0.43478260869565, 1.1934782608696, 0.27272727272727
38915, 0.43478260869565, 1.1934782608696, 0.31818181818182
38916, 0.43478260869565, 1.1934782608696, 0.36363636363636
38917, 0.43478260869565, 1.1934782608696, 0.40909090909091
38918, 0.43478260869565, 1.1934782608696, 0.45454545454545
38919, 0.39130434782609, 1.1934782608696, 0.045454545454545
38920, 0.39130434782609, 1.1934782608696, 0.090909090909091
38921, 0.39130434782609, 1.1934782608696, 0.13636363636364
38922, 0.39130434782609, 1.1934782608696, 0.18181818181818
38923, 0.39130434782609, 1.1934782608696, 0.22727272727273
38924, 0.39130434782609, 1.1934782608696, 0.27272727272727
38925, 0.39130434782609, 1.1934782608696, 0.31818181818182
38926, 0.39130434782609, 1.1934782608696, 0.36363636363636
38927, 0.39130434782609, 1.1934782608696, 0.40909090909091
38928, 0.39130434782609, 1.1934782608696, 0.45454545454545
38929, 0.34782608695652, 1.1934782608696, 0.045454545454545
38930, 0.34782608695652, 1.1934782608696, 0.090909090909091
38931, 0.34782608695652, 1.1934782608696, 0.13636363636364
38932, 0.34782608695652, 1.1934782608696, 0.18181818181818
38933, 0.34782608695652, 1.1934782608696, 0.22727272727273
38934, 0.34782608695652, 1.1934782608696, 0.27272727272727
38935, 0.34782608695652, 1.1934782608696, 0.31818181818182
38936, 0.34782608695652, 1.1934782608696, 0.36363636363636
38937, 0.34782608695652, 1.1934782608696, 0.40909090909091
38938, 0.34782608695652, 1.1934782608696, 0.45454545454545
38939, 0.30434782608696, 1.1934782608696, 0.045454545454545
38940, 0.30434782608696, 1.1934782608696, 0.090909090909091
38941, 0.30434782608696, 1.1934782608696, 0.13636363636364
38942, 0.30434782608696, 1.1934782608696, 0.18181818181818
38943, 0.30434782608696, 1.1934782608696, 0.22727272727273
38944, 0.30434782608696, 1.1934782608696, 0.27272727272727
38945, 0.30434782608696, 1.1934782608696, 0.31818181818182
38946, 0.30434782608696, 1.1934782608696, 0.36363636363636
38947, 0.30434782608696, 1.1934782608696, 0.40909090909091
38948, 0.30434782608696, 1.1934782608696, 0.45454545454545
38949, 0.26086956521739, 1.1934782608696, 0.045454545454545
38950, 0.26086956521739, 1.1934782608696, 0.090909090909091
38951, 0.26086956521739, 1.1934782608696, 0.13636363636364
38952, 0.26086956521739, 1.1934782608696, 0.18181818181818
38953, 0.26086956521739, 1.1934782608696, 0.22727272727273
38954, 0.26086956521739, 1.1934782608696, 0.27272727272727
38955, 0.26086956521739, 1.1934782608696, 0.31818181818182
38956, 0.26086956521739, 1.1934782608696, 0.36363636363636
38957, 0.26086956521739, 1.1934782608696, 0.40909090909091
38958, 0.26086956521739, 1.1934782608696, 0.45454545454545
38959, 0.21739130434783, 1.1934782608696, 0.045454545454545
38960, 0.21739130434783, 1.1934782608696, 0.090909090909091
38961, 0.21739130434783, 1.1934782608696, 0.13636363636364
38962, 0.21739130434783, 1.1934782608696, 0.18181818181818
38963, 0.21739130434783, 1.1934782608696, 0.22727272727273
38964, 0.21739130434783, 1.1934782608696, 0.27272727272727
38965, 0.21739130434783, 1.1934782608696, 0.31818181818182
38966, 0.21739130434783, 1.1934782608696, 0.36363636363636
38967, 0.21739130434783, 1.1934782608696, 0.40909090909091
38968, 0.21739130434783, 1.1934782608696, 0.45454545454545
38969, 0.17391304347826, 1.1934782608696, 0.045454545454545
38970, 0.17391304347826, 1.1934782608696, 0.090909090909091
38971, 0.17391304347826, 1.1934782608696, 0.13636363636364
38972, 0.17391304347826, 1.1934782608696, 0.18181818181818
38973, 0.17391304347826, 1.1934782608696, 0.22727272727273
38974, 0.17391304347826, 1.1934782608696, 0.27272727272727
38975, 0.17391304347826, 1.1934782608696, 0.31818181818182
38976, 0.17391304347826, 1.1934782608696, 0.36363636363636
38977, 0.17391304347826, 1.1934782608696, 0.40909090909091
38978, 0.17391304347826, 1.1934782608696, 0.45454545454545
38979, 0.1304347826087, 1.1934782608696, 0.045454545454545
38980, 0.1304347826087, 1.1934782608696, 0.090909090909091
38981, 0.1304347826087, 1.1934782608696, 0.13636363636364
38982, 0.1304347826087, 1.1934782608696, 0.18181818181818
38983, 0.1304347826087, 1.1934782608696, 0.22727272727273
38984, 0.1304347826087, 1.1934782608696, 0.27272727272727
38985, 0.1304347826087, 1.1934782608696, 0.31818181818182
38986, 0.1304347826087, 1.1934782608696, 0.36363636363636
38987, 0.1304347826087, 1.1934782608696, 0.40909090909091
38988, 0.1304347826087, 1.1934782608696, 0.45454545454545
38989, 0.08695652173913, 1.1934782608696, 0.045454545454545
38990, 0.08695652173913, 1.1934782608696, 0.090909090909091
38991, 0.08695652173913, 1.1934782608696, 0.13636363636364
38992, 0.08695652173913, 1.1934782608696, 0.18181818181818
38993, 0.08695652173913, 1.1934782608696, 0.22727272727273
38994, 0.08695652173913, 1.1934782608696, 0.27272727272727
38995, 0.08695652173913, 1.1934782608696, 0.31818181818182
38996, 0.08695652173913, 1.1934782608696, 0.36363636363636
38997, 0.08695652173913, 1.1934782608696, 0.40909090909091
38998, 0.08695652173913, 1.1934782608696, 0.45454545454545
38999, 0.043478260869565, 1.1934782608696, 0.045454545454545
39000, 0.043478260869565, 1.1934782608696, 0.090909090909091
39001, 0.043478260869565, 1.1934782608696, 0.13636363636364
39002, 0.043478260869565, 1.1934782608696, 0.18181818181818
39003, 0.043478260869565, 1.1934782608696, 0.22727272727273
39004, 0.043478260869565, 1.1934782608696, 0.27272727272727
39005, 0.043478260869565, 1.1934782608696, 0.31818181818182
39006, 0.043478260869565, 1.1934782608696, 0.36363636363636
39007, 0.043478260869565, 1.1934782608696, 0.40909090909091
39008, 0.043478260869565, 1.1934782608696, 0.45454545454545
39009, 0.95652173913043, 1.245652173913, 0.045454545454545
39010, 0.95652173913043, 1.245652173913, 0.090909090909091
39011, 0.95652173913044, 1.245652173913, 0.13636363636364
39012, 0.95652173913044, 1.245652173913, 0.18181818181818
39013, 0.95652173913044, 1.245652173913, 0.22727272727273
39014, 0.95652173913044, 1.245652173913, 0.27272727272727
39015, 0.95652173913044, 1.245652173913, 0.31818181818182
39016, 0.95652173913043, 1.245652173913, 0.36363636363636
39017, 0.95652173913043, 1.245652173913, 0.40909090909091
39018, 0.95652173913044, 1.245652173913, 0.45454545454545
39019, 0.91304347826087, 1.245652173913, 0.045454545454545
39020, 0.91304347826087, 1.245652173913, 0.090909090909091
39021, 0.91304347826087, 1.245652173913, 0.13636363636364
39022, 0.91304347826087, 1.245652173913, 0.18181818181818
39023, 0.91304347826087, 1.245652173913, 0.22727272727273
39024, 0.91304347826087, 1.245652173913, 0.27272727272727
39025, 0.91304347826087, 1.245652173913, 0.31818181818182
39026, 0.91304347826087, 1.245652173913, 0.36363636363636
39027, 0.91304347826087, 1.245652173913, 0.40909090909091
39028, 0.91304347826087, 1.245652173913, 0.45454545454545
39029, 0.8695652173913, 1.245652173913, 0.045454545454545
39030, 0.8695652173913, 1.245652173913, 0.090909090909091
39031, 0.8695652173913, 1.245652173913, 0.13636363636364
39032, 0.8695652173913, 1.245652173913, 0.18181818181818
39033, 0.8695652173913, 1.245652173913, 0.22727272727273
39034, 0.8695652173913, 1.245652173913, 0.27272727272727
39035, 0.8695652173913, 1.245652173913, 0.31818181818182
39036, 0.8695652173913, 1.245652173913, 0.36363636363636
39037, 0.8695652173913, 1.245652173913, 0.40909090909091
39038, 0.8695652173913, 1.245652173913, 0.45454545454545
39039, 0.82608695652174, 1.245652173913, 0.045454545454545
39040, 0.82608695652174, 1.245652173913, 0.090909090909091
39041, 0.82608695652174, 1.245652173913, 0.13636363636364
39042, 0.82608695652174, 1.245652173913, 0.18181818181818
39043, 0.82608695652174, 1.245652173913, 0.22727272727273
39044, 0.82608695652174, 1.245652173913, 0.27272727272727
39045, 0.82608695652174, 1.245652173913, 0.31818181818182
39046, 0.82608695652174, 1.245652173913, 0.36363636363636
39047, 0.82608695652174, 1.245652173913, 0.40909090909091
39048, 0.82608695652174, 1.245652173913, 0.45454545454545
39049, 0.78260869565217, 1.245652173913, 0.045454545454545
39050, 0.78260869565217, 1.245652173913, 0.090909090909091
39051, 0.78260869565217, 1.245652173913, 0.13636363636364
39052, 0.78260869565217, 1.245652173913, 0.18181818181818
39053, 0.78260869565217, 1.245652173913, 0.22727272727273
39054, 0.78260869565217, 1.245652173913, 0.27272727272727
39055, 0.78260869565217, 1.245652173913, 0.31818181818182
39056, 0.78260869565217, 1.245652173913, 0.36363636363636
39057, 0.78260869565217, 1.245652173913, 0.40909090909091
39058, 0.78260869565217, 1.245652173913, 0.45454545454545
39059, 0.73913043478261, 1.245652173913, 0.045454545454545
39060, 0.73913043478261, 1.245652173913, 0.090909090909091
39061, 0.73913043478261, 1.245652173913, 0.13636363636364
39062, 0.73913043478261, 1.245652173913, 0.18181818181818
39063, 0.73913043478261, 1.245652173913, 0.22727272727273
39064, 0.73913043478261, 1.245652173913, 0.27272727272727
39065, 0.73913043478261, 1.245652173913, 0.31818181818182
39066, 0.73913043478261, 1.245652173913, 0.36363636363636
39067, 0.73913043478261, 1.245652173913, 0.40909090909091
39068, 0.73913043478261, 1.245652173913, 0.45454545454545
39069, 0.69565217391304, 1.245652173913, 0.045454545454545
39070, 0.69565217391304, 1.245652173913, 0.090909090909091
39071, 0.69565217391304, 1.245652173913, 0.13636363636364
39072, 0.69565217391304, 1.245652173913, 0.18181818181818
39073, 0.69565217391304, 1.245652173913, 0.22727272727273
39074, 0.69565217391304, 1.245652173913, 0.27272727272727
39075, 0.69565217391304, 1.245652173913, 0.31818181818182
39076, 0.69565217391304, 1.245652173913, 0.36363636363636
39077, 0.69565217391304, 1.245652173913, 0.40909090909091
39078, 0.69565217391304, 1.245652173913, 0.45454545454545
39079, 0.65217391304348, 1.245652173913, 0.045454545454545
39080, 0.65217391304348, 1.245652173913, 0.090909090909091
39081, 0.65217391304348, 1.245652173913, 0.13636363636364
39082, 0.65217391304348, 1.245652173913, 0.18181818181818
39083, 0.65217391304348, 1.245652173913, 0.22727272727273
39084, 0.65217391304348, 1.245652173913, 0.27272727272727
39085, 0.65217391304348, 1.245652173913, 0.31818181818182
39086, 0.65217391304348, 1.245652173913, 0.36363636363636
39087, 0.65217391304348, 1.245652173913, 0.40909090909091
39088, 0.65217391304348, 1.245652173913, 0.45454545454545
39089, 0.60869565217391, 1.245652173913, 0.045454545454545
39090, 0.60869565217391, 1.245652173913, 0.090909090909091
39091, 0.60869565217391, 1.245652173913, 0.13636363636364
39092, 0.60869565217391, 1.245652173913, 0.18181818181818
39093, 0.60869565217391, 1.245652173913, 0.22727272727273
39094, 0.60869565217391, 1.245652173913, 0.27272727272727
39095, 0.60869565217391, 1.245652173913, 0.31818181818182
39096, 0.60869565217391, 1.245652173913, 0.36363636363636
39097, 0.60869565217391, 1.245652173913, 0.40909090909091
39098, 0.60869565217391, 1.245652173913, 0.45454545454545
39099, 0.56521739130435, 1.245652173913, 0.045454545454545
39100, 0.56521739130435, 1.245652173913, 0.090909090909091
39101, 0.56521739130435, 1.245652173913, 0.13636363636364
39102, 0.56521739130435, 1.245652173913, 0.18181818181818
39103, 0.56521739130435, 1.245652173913, 0.22727272727273
39104, 0.56521739130435, 1.245652173913, 0.27272727272727
39105, 0.56521739130435, 1.245652173913, 0.31818181818182
39106, 0.56521739130435, 1.245652173913, 0.36363636363636
39107, 0.56521739130435, 1.245652173913, 0.40909090909091
39108, 0.56521739130435, 1.245652173913, 0.45454545454545
39109, 0.52173913043478, 1.245652173913, 0.045454545454545
39110, 0.52173913043478, 1.245652173913, 0.090909090909091
39111, 0.52173913043478, 1.245652173913, 0.13636363636364
39112, 0.52173913043478, 1.245652173913, 0.18181818181818
39113, 0.52173913043478, 1.245652173913, 0.22727272727273
39114, 0.52173913043478, 1.245652173913, 0.27272727272727
39115, 0.52173913043478, 1.245652173913, 0.31818181818182
39116, 0.52173913043478, 1.245652173913, 0.36363636363636
39117, 0.52173913043478, 1.245652173913, 0.40909090909091
39118, 0.52173913043478, 1.245652173913, 0.45454545454545
39119, 0.47826086956522, 1.245652173913, 0.045454545454545
39120, 0.47826086956522, 1.245652173913, 0.090909090909091
39121, 0.47826086956522, 1.245652173913, 0.13636363636364
39122, 0.47826086956522, 1.245652173913, 0.18181818181818
39123, 0.47826086956522, 1.245652173913, 0.22727272727273
39124, 0.47826086956522, 1.245652173913, 0.27272727272727
39125, 0.47826086956522, 1.245652173913, 0.31818181818182
39126, 0.47826086956522, 1.245652173913, 0.36363636363636
39127, 0.47826086956522, 1.245652173913, 0.40909090909091
39128, 0.47826086956522, 1.245652173913, 0.45454545454545
39129, 0.43478260869565, 1.245652173913, 0.045454545454545
39130, 0.43478260869565, 1.245652173913, 0.090909090909091
39131, 0.43478260869565, 1.245652173913, 0.13636363636364
39132, 0.43478260869565, 1.245652173913, 0.18181818181818
39133, 0.43478260869565, 1.245652173913, 0.22727272727273
39134, 0.43478260869565, 1.245652173913, 0.27272727272727
39135, 0.43478260869565, 1.245652173913, 0.31818181818182
39136, 0.43478260869565, 1.245652173913, 0.36363636363636
39137, 0.43478260869565, 1.245652173913, 0.40909090909091
39138, 0.43478260869565, 1.245652173913, 0.45454545454545
39139, 0.39130434782609, 1.245652173913, 0.045454545454545
39140, 0.39130434782609, 1.245652173913, 0.090909090909091
39141, 0.39130434782609, 1.245652173913, 0.13636363636364
39142, 0.39130434782609, 1.245652173913, 0.18181818181818
39143, 0.39130434782609, 1.245652173913, 0.22727272727273
39144, 0.39130434782609, 1.245652173913, 0.27272727272727
39145, 0.39130434782609, 1.245652173913, 0.31818181818182
39146, 0.39130434782609, 1.245652173913, 0.36363636363636
39147, 0.39130434782609, 1.245652173913, 0.40909090909091
39148, 0.39130434782609, 1.245652173913, 0.45454545454545
39149, 0.34782608695652, 1.245652173913, 0.045454545454545
39150, 0.34782608695652, 1.245652173913, 0.090909090909091
39151, 0.34782608695652, 1.245652173913, 0.13636363636364
39152, 0.34782608695652, 1.245652173913, 0.18181818181818
39153, 0.34782608695652, 1.245652173913, 0.22727272727273
39154, 0.34782608695652, 1.245652173913, 0.27272727272727
39155, 0.34782608695652, 1.245652173913, 0.31818181818182
39156, 0.34782608695652, 1.245652173913, 0.36363636363636
39157, 0.34782608695652, 1.245652173913, 0.40909090909091
39158, 0.34782608695652, 1.245652173913, 0.45454545454545
39159, 0.30434782608696, 1.245652173913, 0.045454545454545
39160, 0.30434782608696, 1.245652173913, 0.090909090909091
39161, 0.30434782608696, 1.245652173913, 0.13636363636364
39162, 0.30434782608696, 1.245652173913, 0.18181818181818
39163, 0.30434782608696, 1.245652173913, 0.22727272727273
39164, 0.30434782608696, 1.245652173913, 0.27272727272727
39165, 0.30434782608696, 1.245652173913, 0.31818181818182
39166, 0.30434782608696, 1.245652173913, 0.36363636363636
39167, 0.30434782608696, 1.245652173913, 0.40909090909091
39168, 0.30434782608696, 1.245652173913, 0.45454545454545
39169, 0.26086956521739, 1.245652173913, 0.045454545454545
39170, 0.26086956521739, 1.245652173913, 0.090909090909091
39171, 0.26086956521739, 1.245652173913, 0.13636363636364
39172, 0.26086956521739, 1.245652173913, 0.18181818181818
39173, 0.26086956521739, 1.245652173913, 0.22727272727273
39174, 0.26086956521739, 1.245652173913, 0.27272727272727
39175, 0.26086956521739, 1.245652173913, 0.31818181818182
39176, 0.26086956521739, 1.245652173913, 0.36363636363636
39177, 0.26086956521739, 1.245652173913, 0.40909090909091
39178, 0.26086956521739, 1.245652173913, 0.45454545454545
39179, 0.21739130434783, 1.245652173913, 0.045454545454545
39180, 0.21739130434783, 1.245652173913, 0.090909090909091
39181, 0.21739130434783, 1.245652173913, 0.13636363636364
39182, 0.21739130434783, 1.245652173913, 0.18181818181818
39183, 0.21739130434783, 1.245652173913, 0.22727272727273
39184, 0.21739130434783, 1.245652173913, 0.27272727272727
39185, 0.21739130434783, 1.245652173913, 0.31818181818182
39186, 0.21739130434783, 1.245652173913, 0.36363636363636
39187, 0.21739130434783, 1.245652173913, 0.40909090909091
39188, 0.21739130434783, 1.245652173913, 0.45454545454545
39189, 0.17391304347826, 1.245652173913, 0.045454545454545
39190, 0.17391304347826, 1.245652173913, 0.090909090909091
39191, 0.17391304347826, 1.245652173913, 0.13636363636364
39192, 0.17391304347826, 1.245652173913, 0.18181818181818
39193, 0.17391304347826, 1.245652173913, 0.22727272727273
39194, 0.17391304347826, 1.245652173913, 0.27272727272727
39195, 0.17391304347826, 1.245652173913, 0.31818181818182
39196, 0.17391304347826, 1.245652173913, 0.36363636363636
39197, 0.17391304347826, 1.245652173913, 0.40909090909091
39198, 0.17391304347826, 1.245652173913, 0.45454545454545
39199, 0.1304347826087, 1.245652173913, 0.045454545454545
39200, 0.1304347826087, 1.245652173913, 0.090909090909091
39201, 0.1304347826087, 1.245652173913, 0.13636363636364
39202, 0.1304347826087, 1.245652173913, 0.18181818181818
39203, 0.1304347826087, 1.245652173913, 0.22727272727273
39204, 0.1304347826087, 1.245652173913, 0.27272727272727
39205, 0.1304347826087, 1.245652173913, 0.31818181818182
39206, 0.1304347826087, 1.245652173913, 0.36363636363636
39207, 0.1304347826087, 1.245652173913, 0.40909090909091
39208, 0.1304347826087, 1.245652173913, 0.45454545454545
39209, 0.08695652173913, 1.245652173913, 0.045454545454545
39210, 0.08695652173913, 1.245652173913, 0.090909090909091
39211, 0.08695652173913, 1.245652173913, 0.13636363636364
39212, 0.08695652173913, 1.245652173913, 0.18181818181818
39213, 0.08695652173913, 1.245652173913, 0.22727272727273
39214, 0.08695652173913, 1.245652173913, 0.27272727272727
39215, 0.08695652173913, 1.245652173913, 0.31818181818182
39216, 0.08695652173913, 1.245652173913, 0.36363636363636
39217, 0.08695652173913, 1.245652173913, 0.40909090909091
39218, 0.08695652173913, 1.245652173913, 0.45454545454545
39219, 0.043478260869565, 1.245652173913, 0.045454545454545
39220, 0.043478260869565, 1.245652173913, 0.090909090909091
39221, 0.043478260869565, 1.245652173913, 0.13636363636364
39222, 0.043478260869565, 1.245652173913, 0.18181818181818
39223, 0.043478260869565, 1.245652173913, 0.22727272727273
39224, 0.043478260869565, 1.245652173913, 0.27272727272727
39225, 0.043478260869565, 1.245652173913, 0.31818181818182
39226, 0.043478260869565, 1.245652173913, 0.36363636363636
39227, 0.043478260869565, 1.245652173913, 0.40909090909091
39228, 0.043478260869565, 1.245652173913, 0.45454545454545
39229, 0.95652173913043, 1.2978260869565, 0.045454545454545
39230, 0.95652173913043, 1.2978260869565, 0.090909090909091
39231, 0.95652173913044, 1.2978260869565, 0.13636363636364
39232, 0.95652173913044, 1.2978260869565, 0.18181818181818
39233, 0.95652173913044, 1.2978260869565, 0.22727272727273
39234, 0.95652173913044, 1.2978260869565, 0.27272727272727
39235, 0.95652173913044, 1.2978260869565, 0.31818181818182
39236, 0.95652173913043, 1.2978260869565, 0.36363636363636
39237, 0.95652173913043, 1.2978260869565, 0.40909090909091
39238, 0.95652173913044, 1.2978260869565, 0.45454545454545
39239, 0.91304347826087, 1.2978260869565, 0.045454545454545
39240, 0.91304347826087, 1.2978260869565, 0.090909090909091
39241, 0.91304347826087, 1.2978260869565, 0.13636363636364
39242, 0.91304347826087, 1.2978260869565, 0.18181818181818
39243, 0.91304347826087, 1.2978260869565, 0.22727272727273
39244, 0.91304347826087, 1.2978260869565, 0.27272727272727
39245, 0.91304347826087, 1.2978260869565, 0.31818181818182
39246, 0.91304347826087, 1.2978260869565, 0.36363636363636
39247, 0.91304347826087, 1.2978260869565, 0.40909090909091
39248, 0.91304347826087, 1.2978260869565, 0.45454545454545
39249, 0.8695652173913, 1.2978260869565, 0.045454545454545
39250, 0.8695652173913, 1.2978260869565, 0.090909090909091
39251, 0.8695652173913, 1.2978260869565, 0.13636363636364
39252, 0.8695652173913, 1.2978260869565, 0.18181818181818
39253, 0.8695652173913, 1.2978260869565, 0.22727272727273
39254, 0.8695652173913, 1.2978260869565, 0.27272727272727
39255, 0.8695652173913, 1.2978260869565, 0.31818181818182
39256, 0.8695652173913, 1.2978260869565, 0.36363636363636
39257, 0.8695652173913, 1.2978260869565, 0.40909090909091
39258, 0.8695652173913, 1.2978260869565, 0.45454545454545
39259, 0.82608695652174, 1.2978260869565, 0.045454545454545
39260, 0.82608695652174, 1.2978260869565, 0.090909090909091
39261, 0.82608695652174, 1.2978260869565, 0.13636363636364
39262, 0.82608695652174, 1.2978260869565, 0.18181818181818
39263, 0.82608695652174, 1.2978260869565, 0.22727272727273
39264, 0.82608695652174, 1.2978260869565, 0.27272727272727
39265, 0.82608695652174, 1.2978260869565, 0.31818181818182
39266, 0.82608695652174, 1.2978260869565, 0.36363636363636
39267, 0.82608695652174, 1.2978260869565, 0.40909090909091
39268, 0.82608695652174, 1.2978260869565, 0.45454545454545
39269, 0.78260869565217, 1.2978260869565, 0.045454545454545
39270, 0.78260869565217, 1.2978260869565, 0.090909090909091
39271, 0.78260869565217, 1.2978260869565, 0.13636363636364
39272, 0.78260869565217, 1.2978260869565, 0.18181818181818
39273, 0.78260869565217, 1.2978260869565, 0.22727272727273
39274, 0.78260869565217, 1.2978260869565, 0.27272727272727
39275, 0.78260869565217, 1.2978260869565, 0.31818181818182
39276, 0.78260869565217, 1.2978260869565, 0.36363636363636
39277, 0.78260869565217, 1.2978260869565, 0.40909090909091
39278, 0.78260869565217, 1.2978260869565, 0.45454545454545
39279, 0.73913043478261, 1.2978260869565, 0.045454545454545
39280, 0.73913043478261, 1.2978260869565, 0.090909090909091
39281, 0.73913043478261, 1.2978260869565, 0.13636363636364
39282, 0.73913043478261, 1.2978260869565, 0.18181818181818
39283, 0.73913043478261, 1.2978260869565, 0.22727272727273
39284, 0.73913043478261, 1.2978260869565, 0.27272727272727
39285, 0.73913043478261, 1.2978260869565, 0.31818181818182
39286, 0.73913043478261, 1.2978260869565, 0.36363636363636
39287, 0.73913043478261, 1.2978260869565, 0.40909090909091
39288, 0.73913043478261, 1.2978260869565, 0.45454545454545
39289, 0.69565217391304, 1.2978260869565, 0.045454545454545
39290, 0.69565217391304, 1.2978260869565, 0.090909090909091
39291, 0.69565217391304, 1.2978260869565, 0.13636363636364
39292, 0.69565217391304, 1.2978260869565, 0.18181818181818
39293, 0.69565217391304, 1.2978260869565, 0.22727272727273
39294, 0.69565217391304, 1.2978260869565, 0.27272727272727
39295, 0.69565217391304, 1.2978260869565, 0.31818181818182
39296, 0.69565217391304, 1.2978260869565, 0.36363636363636
39297, 0.69565217391304, 1.2978260869565, 0.40909090909091
39298, 0.69565217391304, 1.2978260869565, 0.45454545454545
39299, 0.65217391304348, 1.2978260869565, 0.045454545454545
39300, 0.65217391304348, 1.2978260869565, 0.090909090909091
39301, 0.65217391304348, 1.2978260869565, 0.13636363636364
39302, 0.65217391304348, 1.2978260869565, 0.18181818181818
39303, 0.65217391304348, 1.2978260869565, 0.22727272727273
39304, 0.65217391304348, 1.2978260869565, 0.27272727272727
39305, 0.65217391304348, 1.2978260869565, 0.31818181818182
39306, 0.65217391304348, 1.2978260869565, 0.36363636363636
39307, 0.65217391304348, 1.2978260869565, 0.40909090909091
39308, 0.65217391304348, 1.2978260869565, 0.45454545454545
39309, 0.60869565217391, 1.2978260869565, 0.045454545454545
39310, 0.60869565217391, 1.2978260869565, 0.090909090909091
39311, 0.60869565217391, 1.2978260869565, 0.13636363636364
39312, 0.60869565217391, 1.2978260869565, 0.18181818181818
39313, 0.60869565217391, 1.2978260869565, 0.22727272727273
39314, 0.60869565217391, 1.2978260869565, 0.27272727272727
39315, 0.60869565217391, 1.2978260869565, 0.31818181818182
39316, 0.60869565217391, 1.2978260869565, 0.36363636363636
39317, 0.60869565217391, 1.2978260869565, 0.40909090909091
39318, 0.60869565217391, 1.2978260869565, 0.45454545454545
39319, 0.56521739130435, 1.2978260869565, 0.045454545454545
39320, 0.56521739130435, 1.2978260869565, 0.090909090909091
39321, 0.56521739130435, 1.2978260869565, 0.13636363636364
39322, 0.56521739130435, 1.2978260869565, 0.18181818181818
39323, 0.56521739130435, 1.2978260869565, 0.22727272727273
39324, 0.56521739130435, 1.2978260869565, 0.27272727272727
39325, 0.56521739130435, 1.2978260869565, 0.31818181818182
39326, 0.56521739130435, 1.2978260869565, 0.36363636363636
39327, 0.56521739130435, 1.2978260869565, 0.40909090909091
39328, 0.56521739130435, 1.2978260869565, 0.45454545454545
39329, 0.52173913043478, 1.2978260869565, 0.045454545454545
39330, 0.52173913043478, 1.2978260869565, 0.090909090909091
39331, 0.52173913043478, 1.2978260869565, 0.13636363636364
39332, 0.52173913043478, 1.2978260869565, 0.18181818181818
39333, 0.52173913043478, 1.2978260869565, 0.22727272727273
39334, 0.52173913043478, 1.2978260869565, 0.27272727272727
39335, 0.52173913043478, 1.2978260869565, 0.31818181818182
39336, 0.52173913043478, 1.2978260869565, 0.36363636363636
39337, 0.52173913043478, 1.2978260869565, 0.40909090909091
39338, 0.52173913043478, 1.2978260869565, 0.45454545454545
39339, 0.47826086956522, 1.2978260869565, 0.045454545454545
39340, 0.47826086956522, 1.2978260869565, 0.090909090909091
39341, 0.47826086956522, 1.2978260869565, 0.13636363636364
39342, 0.47826086956522, 1.2978260869565, 0.18181818181818
39343, 0.47826086956522, 1.2978260869565, 0.22727272727273
39344, 0.47826086956522, 1.2978260869565, 0.27272727272727
39345, 0.47826086956522, 1.2978260869565, 0.31818181818182
39346, 0.47826086956522, 1.2978260869565, 0.36363636363636
39347, 0.47826086956522, 1.2978260869565, 0.40909090909091
39348, 0.47826086956522, 1.2978260869565, 0.45454545454545
39349, 0.43478260869565, 1.2978260869565, 0.045454545454545
39350, 0.43478260869565, 1.2978260869565, 0.090909090909091
39351, 0.43478260869565, 1.2978260869565, 0.13636363636364
39352, 0.43478260869565, 1.2978260869565, 0.18181818181818
39353, 0.43478260869565, 1.2978260869565, 0.22727272727273
39354, 0.43478260869565, 1.2978260869565, 0.27272727272727
39355, 0.43478260869565, 1.2978260869565, 0.31818181818182
39356, 0.43478260869565, 1.2978260869565, 0.36363636363636
39357, 0.43478260869565, 1.2978260869565, 0.40909090909091
39358, 0.43478260869565, 1.2978260869565, 0.45454545454545
39359, 0.39130434782609, 1.2978260869565, 0.045454545454545
39360, 0.39130434782609, 1.2978260869565, 0.090909090909091
39361, 0.39130434782609, 1.2978260869565, 0.13636363636364
39362, 0.39130434782609, 1.2978260869565, 0.18181818181818
39363, 0.39130434782609, 1.2978260869565, 0.22727272727273
39364, 0.39130434782609, 1.2978260869565, 0.27272727272727
39365, 0.39130434782609, 1.2978260869565, 0.31818181818182
39366, 0.39130434782609, 1.2978260869565, 0.36363636363636
39367, 0.39130434782609, 1.2978260869565, 0.40909090909091
39368, 0.39130434782609, 1.2978260869565, 0.45454545454545
39369, 0.34782608695652, 1.2978260869565, 0.045454545454545
39370, 0.34782608695652, 1.2978260869565, 0.090909090909091
39371, 0.34782608695652, 1.2978260869565, 0.13636363636364
39372, 0.34782608695652, 1.2978260869565, 0.18181818181818
39373, 0.34782608695652, 1.2978260869565, 0.22727272727273
39374, 0.34782608695652, 1.2978260869565, 0.27272727272727
39375, 0.34782608695652, 1.2978260869565, 0.31818181818182
39376, 0.34782608695652, 1.2978260869565, 0.36363636363636
39377, 0.34782608695652, 1.2978260869565, 0.40909090909091
39378, 0.34782608695652, 1.2978260869565, 0.45454545454545
39379, 0.30434782608696, 1.2978260869565, 0.045454545454545
39380, 0.30434782608696, 1.2978260869565, 0.090909090909091
39381, 0.30434782608696, 1.2978260869565, 0.13636363636364
39382, 0.30434782608696, 1.2978260869565, 0.18181818181818
39383, 0.30434782608696, 1.2978260869565, 0.22727272727273
39384, 0.30434782608696, 1.2978260869565, 0.27272727272727
39385, 0.30434782608696, 1.2978260869565, 0.31818181818182
39386, 0.30434782608696, 1.2978260869565, 0.36363636363636
39387, 0.30434782608696, 1.2978260869565, 0.40909090909091
39388, 0.30434782608696, 1.2978260869565, 0.45454545454545
39389, 0.26086956521739, 1.2978260869565, 0.045454545454545
39390, 0.26086956521739, 1.2978260869565, 0.090909090909091
39391, 0.26086956521739, 1.2978260869565, 0.13636363636364
39392, 0.26086956521739, 1.2978260869565, 0.18181818181818
39393, 0.26086956521739, 1.2978260869565, 0.22727272727273
39394, 0.26086956521739, 1.2978260869565, 0.27272727272727
39395, 0.26086956521739, 1.2978260869565, 0.31818181818182
39396, 0.26086956521739, 1.2978260869565, 0.36363636363636
39397, 0.26086956521739, 1.2978260869565, 0.40909090909091
39398, 0.26086956521739, 1.2978260869565, 0.45454545454545
39399, 0.21739130434783, 1.2978260869565, 0.045454545454545
39400, 0.21739130434783, 1.2978260869565, 0.090909090909091
39401, 0.21739130434783, 1.2978260869565, 0.13636363636364
39402, 0.21739130434783, 1.2978260869565, 0.18181818181818
39403, 0.21739130434783, 1.2978260869565, 0.22727272727273
39404, 0.21739130434783, 1.2978260869565, 0.27272727272727
39405, 0.21739130434783, 1.2978260869565, 0.31818181818182
39406, 0.21739130434783, 1.2978260869565, 0.36363636363636
39407, 0.21739130434783, 1.2978260869565, 0.40909090909091
39408, 0.21739130434783, 1.2978260869565, 0.45454545454545
39409, 0.17391304347826, 1.2978260869565, 0.045454545454545
39410, 0.17391304347826, 1.2978260869565, 0.090909090909091
39411, 0.17391304347826, 1.2978260869565, 0.13636363636364
39412, 0.17391304347826, 1.2978260869565, 0.18181818181818
39413, 0.17391304347826, 1.2978260869565, 0.22727272727273
39414, 0.17391304347826, 1.2978260869565, 0.27272727272727
39415, 0.17391304347826, 1.2978260869565, 0.31818181818182
39416, 0.17391304347826, 1.2978260869565, 0.36363636363636
39417, 0.17391304347826, 1.2978260869565, 0.40909090909091
39418, 0.17391304347826, 1.2978260869565, 0.45454545454545
39419, 0.1304347826087, 1.2978260869565, 0.045454545454545
39420, 0.1304347826087, 1.2978260869565, 0.090909090909091
39421, 0.1304347826087, 1.2978260869565, 0.13636363636364
39422, 0.1304347826087, 1.2978260869565, 0.18181818181818
39423, 0.1304347826087, 1.2978260869565, 0.22727272727273
39424, 0.1304347826087, 1.2978260869565, 0.27272727272727
39425, 0.1304347826087, 1.2978260869565, 0.31818181818182
39426, 0.1304347826087, 1.2978260869565, 0.36363636363636
39427, 0.1304347826087, 1.2978260869565, 0.40909090909091
39428, 0.1304347826087, 1.2978260869565, 0.45454545454545
39429, 0.08695652173913, 1.2978260869565, 0.045454545454545
39430, 0.08695652173913, 1.2978260869565, 0.090909090909091
39431, 0.08695652173913, 1.2978260869565, 0.13636363636364
39432, 0.08695652173913, 1.2978260869565, 0.18181818181818
39433, 0.08695652173913, 1.2978260869565, 0.22727272727273
39434, 0.08695652173913, 1.2978260869565, 0.27272727272727
39435, 0.08695652173913, 1.2978260869565, 0.31818181818182
39436, 0.08695652173913, 1.2978260869565, 0.36363636363636
39437, 0.08695652173913, 1.2978260869565, 0.40909090909091
39438, 0.08695652173913, 1.2978260869565, 0.45454545454545
39439, 0.043478260869565, 1.2978260869565, 0.045454545454545
39440, 0.043478260869565, 1.2978260869565, 0.090909090909091
39441, 0.043478260869565, 1.2978260869565, 0.13636363636364
39442, 0.043478260869565, 1.2978260869565, 0.18181818181818
39443, 0.043478260869565, 1.2978260869565, 0.22727272727273
39444, 0.043478260869565, 1.2978260869565, 0.27272727272727
39445, 0.043478260869565, 1.2978260869565, 0.31818181818182
39446, 0.043478260869565, 1.2978260869565, 0.36363636363636
39447, 0.043478260869565, 1.2978260869565, 0.40909090909091
39448, 0.043478260869565, 1.2978260869565, 0.45454545454545
39449, 0.95652173913043, 0.20217391304348, 0.022727272727273
39450, 0.97826086956522, 0.20217391304348, 0.045454545454545
39451, 0.95652173913043, 0.17608695652174, 0.045454545454545
39452, 0.95652173913043, 0.20217391304348, 0.068181818181818
39453, 0.97826086956522, 0.20217391304348, 0.090909090909091
39454, 0.95652173913043, 0.17608695652174, 0.090909090909091
39455, 0.95652173913043, 0.20217391304348, 0.11363636363636
39456, 0.97826086956522, 0.20217391304348, 0.13636363636364
39457, 0.95652173913044, 0.17608695652174, 0.13636363636364
39458, 0.95652173913044, 0.20217391304348, 0.15909090909091
39459, 0.97826086956522, 0.20217391304348, 0.18181818181818
39460, 0.95652173913043, 0.17608695652174, 0.18181818181818
39461, 0.95652173913044, 0.20217391304348, 0.20454545454545
39462, 0.97826086956522, 0.20217391304348, 0.22727272727273
39463, 0.95652173913043, 0.17608695652174, 0.22727272727273
39464, 0.95652173913044, 0.20217391304348, 0.25
39465, 0.97826086956522, 0.20217391304348, 0.27272727272727
39466, 0.95652173913043, 0.17608695652174, 0.27272727272727
39467, 0.95652173913044, 0.20217391304348, 0.29545454545455
39468, 0.97826086956522, 0.20217391304348, 0.31818181818182
39469, 0.95652173913043, 0.17608695652174, 0.31818181818182
39470, 0.95652173913043, 0.20217391304348, 0.34090909090909
39471, 0.97826086956522, 0.20217391304348, 0.36363636363636
39472, 0.95652173913043, 0.17608695652174, 0.36363636363636
39473, 0.95652173913043, 0.20217391304348, 0.38636363636364
39474, 0.97826086956522, 0.20217391304348, 0.40909090909091
39475, 0.95652173913043, 0.17608695652174, 0.40909090909091
39476, 0.95652173913043, 0.20217391304348, 0.43181818181818
39477, 0.97826086956522, 0.20217391304348, 0.45454545454545
39478, 0.95652173913044, 0.17608695652174, 0.45454545454545
39479, 0.95652173913044, 0.20217391304348, 0.47727272727273
39480, 0.91304347826087, 0.20217391304348, 0.022727272727273
39481, 0.93478260869565, 0.20217391304348, 0.045454545454545
39482, 0.91304347826087, 0.17608695652174, 0.045454545454545
39483, 0.91304347826087, 0.20217391304348, 0.068181818181818
39484, 0.93478260869565, 0.20217391304348, 0.090909090909091
39485, 0.91304347826087, 0.17608695652174, 0.090909090909091
39486, 0.91304347826087, 0.20217391304348, 0.11363636363636
39487, 0.93478260869565, 0.20217391304348, 0.13636363636364
39488, 0.91304347826087, 0.17608695652174, 0.13636363636364
39489, 0.91304347826087, 0.20217391304348, 0.15909090909091
39490, 0.93478260869565, 0.20217391304348, 0.18181818181818
39491, 0.91304347826087, 0.17608695652174, 0.18181818181818
39492, 0.91304347826087, 0.20217391304348, 0.20454545454545
39493, 0.93478260869565, 0.20217391304348, 0.22727272727273
39494, 0.91304347826087, 0.17608695652174, 0.22727272727273
39495, 0.91304347826087, 0.20217391304348, 0.25
39496, 0.93478260869565, 0.20217391304348, 0.27272727272727
39497, 0.91304347826087, 0.17608695652174, 0.27272727272727
39498, 0.91304347826087, 0.20217391304348, 0.29545454545455
39499, 0.93478260869565, 0.20217391304348, 0.31818181818182
39500, 0.91304347826087, 0.17608695652174, 0.31818181818182
39501, 0.91304347826087, 0.20217391304348, 0.34090909090909
39502, 0.93478260869565, 0.20217391304348, 0.36363636363636
39503, 0.91304347826087, 0.17608695652174, 0.36363636363636
39504, 0.91304347826087, 0.20217391304348, 0.38636363636364
39505, 0.93478260869565, 0.20217391304348, 0.40909090909091
39506, 0.91304347826087, 0.17608695652174, 0.40909090909091
39507, 0.91304347826087, 0.20217391304348, 0.43181818181818
39508, 0.93478260869565, 0.20217391304348, 0.45454545454545
39509, 0.91304347826087, 0.17608695652174, 0.45454545454545
39510, 0.91304347826087, 0.20217391304348, 0.47727272727273
39511, 0.8695652173913, 0.20217391304348, 0.022727272727273
39512, 0.89130434782609, 0.20217391304348, 0.045454545454545
39513, 0.8695652173913, 0.17608695652174, 0.045454545454545
39514, 0.8695652173913, 0.20217391304348, 0.068181818181818
39515, 0.89130434782609, 0.20217391304348, 0.090909090909091
39516, 0.8695652173913, 0.17608695652174, 0.090909090909091
39517, 0.8695652173913, 0.20217391304348, 0.11363636363636
39518, 0.89130434782609, 0.20217391304348, 0.13636363636364
39519, 0.8695652173913, 0.17608695652174, 0.13636363636364
39520, 0.8695652173913, 0.20217391304348, 0.15909090909091
39521, 0.89130434782609, 0.20217391304348, 0.18181818181818
39522, 0.8695652173913, 0.17608695652174, 0.18181818181818
39523, 0.8695652173913, 0.20217391304348, 0.20454545454545
39524, 0.89130434782609, 0.20217391304348, 0.22727272727273
39525, 0.8695652173913, 0.17608695652174, 0.22727272727273
39526, 0.8695652173913, 0.20217391304348, 0.25
39527, 0.89130434782609, 0.20217391304348, 0.27272727272727
39528, 0.8695652173913, 0.17608695652174, 0.27272727272727
39529, 0.8695652173913, 0.20217391304348, 0.29545454545455
39530, 0.89130434782609, 0.20217391304348, 0.31818181818182
39531, 0.8695652173913, 0.17608695652174, 0.31818181818182
39532, 0.8695652173913, 0.20217391304348, 0.34090909090909
39533, 0.89130434782609, 0.20217391304348, 0.36363636363636
39534, 0.8695652173913, 0.17608695652174, 0.36363636363636
39535, 0.8695652173913, 0.20217391304348, 0.38636363636364
39536, 0.89130434782609, 0.20217391304348, 0.40909090909091
39537, 0.8695652173913, 0.17608695652174, 0.40909090909091
39538, 0.8695652173913, 0.20217391304348, 0.43181818181818
39539, 0.89130434782609, 0.20217391304348, 0.45454545454545
39540, 0.8695652173913, 0.17608695652174, 0.45454545454545
39541, 0.8695652173913, 0.20217391304348, 0.47727272727273
39542, 0.82608695652174, 0.20217391304348, 0.022727272727273
39543, 0.84782608695652, 0.20217391304348, 0.045454545454545
39544, 0.82608695652174, 0.17608695652174, 0.045454545454545
39545, 0.82608695652174, 0.20217391304348, 0.068181818181818
39546, 0.84782608695652, 0.20217391304348, 0.090909090909091
39547, 0.82608695652174, 0.17608695652174, 0.090909090909091
39548, 0.82608695652174, 0.20217391304348, 0.11363636363636
39549, 0.84782608695652, 0.20217391304348, 0.13636363636364
39550, 0.82608695652174, 0.17608695652174, 0.13636363636364
39551, 0.82608695652174, 0.20217391304348, 0.15909090909091
39552, 0.84782608695652, 0.20217391304348, 0.18181818181818
39553, 0.82608695652174, 0.17608695652174, 0.18181818181818
39554, 0.82608695652174, 0.20217391304348, 0.20454545454545
39555, 0.84782608695652, 0.20217391304348, 0.22727272727273
39556, 0.82608695652174, 0.17608695652174, 0.22727272727273
39557, 0.82608695652174, 0.20217391304348, 0.25
39558, 0.84782608695652, 0.20217391304348, 0.27272727272727
39559, 0.82608695652174, 0.17608695652174, 0.27272727272727
39560, 0.82608695652174, 0.20217391304348, 0.29545454545455
39561, 0.84782608695652, 0.20217391304348, 0.31818181818182
39562, 0.82608695652174, 0.17608695652174, 0.31818181818182
39563, 0.82608695652174, 0.20217391304348, 0.34090909090909
39564, 0.84782608695652, 0.20217391304348, 0.36363636363636
39565, 0.82608695652174, 0.17608695652174, 0.36363636363636
39566, 0.82608695652174, 0.20217391304348, 0.38636363636364
39567, 0.84782608695652, 0.20217391304348, 0.40909090909091
39568, 0.82608695652174, 0.17608695652174, 0.40909090909091
39569, 0.82608695652174, 0.20217391304348, 0.43181818181818
39570, 0.84782608695652, 0.20217391304348, 0.45454545454545
39571, 0.82608695652174, 0.17608695652174, 0.45454545454545
39572, 0.82608695652174, 0.20217391304348, 0.47727272727273
39573, 0.78260869565217, 0.20217391304348, 0.022727272727273
39574, 0.80434782608696, 0.20217391304348, 0.045454545454545
39575, 0.78260869565217, 0.17608695652174, 0.045454545454545
39576, 0.78260869565217, 0.20217391304348, 0.068181818181818
39577, 0.80434782608696, 0.20217391304348, 0.090909090909091
39578, 0.78260869565217, 0.17608695652174, 0.090909090909091
39579, 0.78260869565217, 0.20217391304348, 0.11363636363636
39580, 0.80434782608696, 0.20217391304348, 0.13636363636364
39581, 0.78260869565217, 0.17608695652174, 0.13636363636364
39582, 0.78260869565217, 0.20217391304348, 0.15909090909091
39583, 0.80434782608696, 0.20217391304348, 0.18181818181818
39584, 0.78260869565217, 0.17608695652174, 0.18181818181818
39585, 0.78260869565217, 0.20217391304348, 0.20454545454545
39586, 0.80434782608696, 0.20217391304348, 0.22727272727273
39587, 0.78260869565217, 0.17608695652174, 0.22727272727273
39588, 0.78260869565217, 0.20217391304348, 0.25
39589, 0.80434782608696, 0.20217391304348, 0.27272727272727
39590, 0.78260869565217, 0.17608695652174, 0.27272727272727
39591, 0.78260869565217, 0.20217391304348, 0.29545454545455
39592, 0.80434782608696, 0.20217391304348, 0.31818181818182
39593, 0.78260869565217, 0.17608695652174, 0.31818181818182
39594, 0.78260869565217, 0.20217391304348, 0.34090909090909
39595, 0.80434782608696, 0.20217391304348, 0.36363636363636
39596, 0.78260869565217, 0.17608695652174, 0.36363636363636
39597, 0.78260869565217, 0.20217391304348, 0.38636363636364
39598, 0.80434782608696, 0.20217391304348, 0.40909090909091
39599, 0.78260869565217, 0.17608695652174, 0.40909090909091
39600, 0.78260869565217, 0.20217391304348, 0.43181818181818
39601, 0.80434782608696, 0.20217391304348, 0.45454545454545
39602, 0.78260869565217, 0.17608695652174, 0.45454545454545
39603, 0.78260869565217, 0.20217391304348, 0.47727272727273
39604, 0.73913043478261, 0.20217391304348, 0.022727272727273
39605, 0.76086956521739, 0.20217391304348, 0.045454545454545
39606, 0.73913043478261, 0.17608695652174, 0.045454545454545
39607, 0.73913043478261, 0.20217391304348, 0.068181818181818
39608, 0.76086956521739, 0.20217391304348, 0.090909090909091
39609, 0.73913043478261, 0.17608695652174, 0.090909090909091
39610, 0.73913043478261, 0.20217391304348, 0.11363636363636
39611, 0.76086956521739, 0.20217391304348, 0.13636363636364
39612, 0.73913043478261, 0.17608695652174, 0.13636363636364
39613, 0.73913043478261, 0.20217391304348, 0.15909090909091
39614, 0.76086956521739, 0.20217391304348, 0.18181818181818
39615, 0.73913043478261, 0.17608695652174, 0.18181818181818
39616, 0.73913043478261, 0.20217391304348, 0.20454545454545
39617, 0.76086956521739, 0.20217391304348, 0.22727272727273
39618, 0.73913043478261, 0.17608695652174, 0.22727272727273
39619, 0.73913043478261, 0.20217391304348, 0.25
39620, 0.76086956521739, 0.20217391304348, 0.27272727272727
39621, 0.73913043478261, 0.17608695652174, 0.27272727272727
39622, 0.73913043478261, 0.20217391304348, 0.29545454545455
39623, 0.76086956521739, 0.20217391304348, 0.31818181818182
39624, 0.73913043478261, 0.17608695652174, 0.31818181818182
39625, 0.73913043478261, 0.20217391304348, 0.34090909090909
39626, 0.76086956521739, 0.20217391304348, 0.36363636363636
39627, 0.73913043478261, 0.17608695652174, 0.36363636363636
39628, 0.73913043478261, 0.20217391304348, 0.38636363636364
39629, 0.76086956521739, 0.20217391304348, 0.40909090909091
39630, 0.73913043478261, 0.17608695652174, 0.40909090909091
39631, 0.73913043478261, 0.20217391304348, 0.43181818181818
39632, 0.76086956521739, 0.20217391304348, 0.45454545454545
39633, 0.73913043478261, 0.17608695652174, 0.45454545454545
39634, 0.73913043478261, 0.20217391304348, 0.47727272727273
39635, 0.69565217391304, 0.20217391304348, 0.022727272727273
39636, 0.71739130434783, 0.20217391304348, 0.045454545454545
39637, 0.69565217391304, 0.17608695652174, 0.045454545454545
39638, 0.69565217391304, 0.20217391304348, 0.068181818181818
39639, 0.71739130434783, 0.20217391304348, 0.090909090909091
39640, 0.69565217391304, 0.17608695652174, 0.090909090909091
39641, 0.69565217391304, 0.20217391304348, 0.11363636363636
39642, 0.71739130434783, 0.20217391304348, 0.13636363636364
39643, 0.69565217391304, 0.17608695652174, 0.13636363636364
39644, 0.69565217391304, 0.20217391304348, 0.15909090909091
39645, 0.71739130434783, 0.20217391304348, 0.18181818181818
39646, 0.69565217391304, 0.17608695652174, 0.18181818181818
39647, 0.69565217391304, 0.20217391304348, 0.20454545454545
39648, 0.71739130434783, 0.20217391304348, 0.22727272727273
39649, 0.69565217391304, 0.17608695652174, 0.22727272727273
39650, 0.69565217391304, 0.20217391304348, 0.25
39651, 0.71739130434783, 0.20217391304348, 0.27272727272727
39652, 0.69565217391304, 0.17608695652174, 0.27272727272727
39653, 0.69565217391304, 0.20217391304348, 0.29545454545455
39654, 0.71739130434783, 0.20217391304348, 0.31818181818182
39655, 0.69565217391304, 0.17608695652174, 0.31818181818182
39656, 0.69565217391304, 0.20217391304348, 0.34090909090909
39657, 0.71739130434783, 0.20217391304348, 0.36363636363636
39658, 0.69565217391304, 0.17608695652174, 0.36363636363636
39659, 0.69565217391304, 0.20217391304348, 0.38636363636364
39660, 0.71739130434783, 0.20217391304348, 0.40909090909091
39661, 0.69565217391304, 0.17608695652174, 0.40909090909091
39662, 0.69565217391304, 0.20217391304348, 0.43181818181818
39663, 0.71739130434783, 0.20217391304348, 0.45454545454545
39664, 0.69565217391304, 0.17608695652174, 0.45454545454545
39665, 0.69565217391304, 0.20217391304348, 0.47727272727273
39666, 0.65217391304348, 0.20217391304348, 0.022727272727273
39667, 0.67391304347826, 0.20217391304348, 0.045454545454545
39668, 0.65217391304348, 0.17608695652174, 0.045454545454545
39669, 0.65217391304348, 0.20217391304348, 0.068181818181818
39670, 0.67391304347826, 0.20217391304348, 0.090909090909091
39671, 0.65217391304348, 0.17608695652174, 0.090909090909091
39672, 0.65217391304348, 0.20217391304348, 0.11363636363636
39673, 0.67391304347826, 0.20217391304348, 0.13636363636364
39674, 0.65217391304348, 0.17608695652174, 0.13636363636364
39675, 0.65217391304348, 0.20217391304348, 0.15909090909091
39676, 0.67391304347826, 0.20217391304348, 0.18181818181818
39677, 0.65217391304348, 0.17608695652174, 0.18181818181818
39678, 0.65217391304348, 0.20217391304348, 0.20454545454545
39679, 0.67391304347826, 0.20217391304348, 0.22727272727273
39680, 0.65217391304348, 0.17608695652174, 0.22727272727273
39681, 0.65217391304348, 0.20217391304348, 0.25
39682, 0.67391304347826, 0.20217391304348, 0.27272727272727
39683, 0.65217391304348, 0.17608695652174, 0.27272727272727
39684, 0.65217391304348, 0.20217391304348, 0.29545454545455
39685, 0.67391304347826, 0.20217391304348, 0.31818181818182
39686, 0.65217391304348, 0.17608695652174, 0.31818181818182
39687, 0.65217391304348, 0.20217391304348, 0.34090909090909
39688, 0.67391304347826, 0.20217391304348, 0.36363636363636
39689, 0.65217391304348, 0.17608695652174, 0.36363636363636
39690, 0.65217391304348, 0.20217391304348, 0.38636363636364
39691, 0.67391304347826, 0.20217391304348, 0.40909090909091
39692, 0.65217391304348, 0.17608695652174, 0.40909090909091
39693, 0.65217391304348, 0.20217391304348, 0.43181818181818
39694, 0.67391304347826, 0.20217391304348, 0.45454545454545
39695, 0.65217391304348, 0.17608695652174, 0.45454545454545
39696, 0.65217391304348, 0.20217391304348, 0.47727272727273
39697, 0.60869565217391, 0.20217391304348, 0.022727272727273
39698, 0.6304347826087, 0.20217391304348, 0.045454545454545
39699, 0.60869565217391, 0.17608695652174, 0.045454545454545
39700, 0.60869565217391, 0.20217391304348, 0.068181818181818
39701, 0.6304347826087, 0.20217391304348, 0.090909090909091
39702, 0.60869565217391, 0.17608695652174, 0.090909090909091
39703, 0.60869565217391, 0.20217391304348, 0.11363636363636
39704, 0.6304347826087, 0.20217391304348, 0.13636363636364
39705, 0.60869565217391, 0.17608695652174, 0.13636363636364
39706, 0.60869565217391, 0.20217391304348, 0.15909090909091
39707, 0.6304347826087, 0.20217391304348, 0.18181818181818
39708, 0.60869565217391, 0.17608695652174, 0.18181818181818
39709, 0.60869565217391, 0.20217391304348, 0.20454545454545
39710, 0.6304347826087, 0.20217391304348, 0.22727272727273
39711, 0.60869565217391, 0.17608695652174, 0.22727272727273
39712, 0.60869565217391, 0.20217391304348, 0.25
39713, 0.6304347826087, 0.20217391304348, 0.27272727272727
39714, 0.60869565217391, 0.17608695652174, 0.27272727272727
39715, 0.60869565217391, 0.20217391304348, 0.29545454545455
39716, 0.6304347826087, 0.20217391304348, 0.31818181818182
39717, 0.60869565217391, 0.17608695652174, 0.31818181818182
39718, 0.60869565217391, 0.20217391304348, 0.34090909090909
39719, 0.6304347826087, 0.20217391304348, 0.36363636363636
39720, 0.60869565217391, 0.17608695652174, 0.36363636363636
39721, 0.60869565217391, 0.20217391304348, 0.38636363636364
39722, 0.6304347826087, 0.20217391304348, 0.40909090909091
39723, 0.60869565217391, 0.17608695652174, 0.40909090909091
39724, 0.60869565217391, 0.20217391304348, 0.43181818181818
39725, 0.6304347826087, 0.20217391304348, 0.45454545454545
39726, 0.60869565217391, 0.17608695652174, 0.45454545454545
39727, 0.60869565217391, 0.20217391304348, 0.47727272727273
39728, 0.56521739130435, 0.20217391304348, 0.022727272727273
39729, 0.58695652173913, 0.20217391304348, 0.045454545454545
39730, 0.56521739130435, 0.17608695652174, 0.045454545454545
39731, 0.56521739130435, 0.20217391304348, 0.068181818181818
39732, 0.58695652173913, 0.20217391304348, 0.090909090909091
39733, 0.56521739130435, 0.17608695652174, 0.090909090909091
39734, 0.56521739130435, 0.20217391304348, 0.11363636363636
39735, 0.58695652173913, 0.20217391304348, 0.13636363636364
39736, 0.56521739130435, 0.17608695652174, 0.13636363636364
39737, 0.56521739130435, 0.20217391304348, 0.15909090909091
39738, 0.58695652173913, 0.20217391304348, 0.18181818181818
39739, 0.56521739130435, 0.17608695652174, 0.18181818181818
39740, 0.56521739130435, 0.20217391304348, 0.20454545454545
39741, 0.58695652173913, 0.20217391304348, 0.22727272727273
39742, 0.56521739130435, 0.17608695652174, 0.22727272727273
39743, 0.56521739130435, 0.20217391304348, 0.25
39744, 0.58695652173913, 0.20217391304348, 0.27272727272727
39745, 0.56521739130435, 0.17608695652174, 0.27272727272727
39746, 0.56521739130435, 0.20217391304348, 0.29545454545455
39747, 0.58695652173913, 0.20217391304348, 0.31818181818182
39748, 0.56521739130435, 0.17608695652174, 0.31818181818182
39749, 0.56521739130435, 0.20217391304348, 0.34090909090909
39750, 0.58695652173913, 0.20217391304348, 0.36363636363636
39751, 0.56521739130435, 0.17608695652174, 0.36363636363636
39752, 0.56521739130435, 0.20217391304348, 0.38636363636364
39753, 0.58695652173913, 0.20217391304348, 0.40909090909091
39754, 0.56521739130435, 0.17608695652174, 0.40909090909091
39755, 0.56521739130435, 0.20217391304348, 0.43181818181818
39756, 0.58695652173913, 0.20217391304348, 0.45454545454545
39757, 0.56521739130435, 0.17608695652174, 0.45454545454545
39758, 0.56521739130435, 0.20217391304348, 0.47727272727273
39759, 0.52173913043478, 0.20217391304348, 0.022727272727273
39760, 0.54347826086956, 0.20217391304348, 0.045454545454545
39761, 0.52173913043478, 0.17608695652174, 0.045454545454545
39762, 0.52173913043478, 0.20217391304348, 0.068181818181818
39763, 0.54347826086956, 0.20217391304348, 0.090909090909091
39764, 0.52173913043478, 0.17608695652174, 0.090909090909091
39765, 0.52173913043478, 0.20217391304348, 0.11363636363636
39766, 0.54347826086956, 0.20217391304348, 0.13636363636364
39767, 0.52173913043478, 0.17608695652174, 0.13636363636364
39768, 0.52173913043478, 0.20217391304348, 0.15909090909091
39769, 0.54347826086956, 0.20217391304348, 0.18181818181818
39770, 0.52173913043478, 0.17608695652174, 0.18181818181818
39771, 0.52173913043478, 0.20217391304348, 0.20454545454545
39772, 0.54347826086957, 0.20217391304348, 0.22727272727273
39773, 0.52173913043478, 0.17608695652174, 0.22727272727273
39774, 0.52173913043478, 0.20217391304348, 0.25
39775, 0.54347826086957, 0.20217391304348, 0.27272727272727
39776, 0.52173913043478, 0.17608695652174, 0.27272727272727
39777, 0.52173913043478, 0.20217391304348, 0.29545454545455
39778, 0.54347826086956, 0.20217391304348, 0.31818181818182
39779, 0.52173913043478, 0.17608695652174, 0.31818181818182
39780, 0.52173913043478, 0.20217391304348, 0.34090909090909
39781, 0.54347826086956, 0.20217391304348, 0.36363636363636
