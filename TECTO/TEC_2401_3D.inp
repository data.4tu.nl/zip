43140, 0.65217391304348, 0.43695652173913, 0.22727272727273
43141, 0.65217391304348, 0.46304347826087, 0.25
43142, 0.67391304347826, 0.46304347826087, 0.27272727272727
43143, 0.65217391304348, 0.43695652173913, 0.27272727272727
43144, 0.65217391304348, 0.46304347826087, 0.29545454545455
43145, 0.67391304347826, 0.46304347826087, 0.31818181818182
43146, 0.65217391304348, 0.43695652173913, 0.31818181818182
43147, 0.65217391304348, 0.46304347826087, 0.34090909090909
43148, 0.67391304347826, 0.46304347826087, 0.36363636363636
43149, 0.65217391304348, 0.43695652173913, 0.36363636363636
43150, 0.65217391304348, 0.46304347826087, 0.38636363636364
43151, 0.67391304347826, 0.46304347826087, 0.40909090909091
43152, 0.65217391304348, 0.43695652173913, 0.40909090909091
43153, 0.65217391304348, 0.46304347826087, 0.43181818181818
43154, 0.67391304347826, 0.46304347826087, 0.45454545454545
43155, 0.65217391304348, 0.43695652173913, 0.45454545454545
43156, 0.65217391304348, 0.46304347826087, 0.47727272727273
43157, 0.60869565217391, 0.46304347826087, 0.022727272727273
43158, 0.6304347826087, 0.46304347826087, 0.045454545454545
43159, 0.60869565217391, 0.43695652173913, 0.045454545454545
43160, 0.60869565217391, 0.46304347826087, 0.068181818181818
43161, 0.6304347826087, 0.46304347826087, 0.090909090909091
43162, 0.60869565217391, 0.43695652173913, 0.090909090909091
43163, 0.60869565217391, 0.46304347826087, 0.11363636363636
43164, 0.6304347826087, 0.46304347826087, 0.13636363636364
43165, 0.60869565217391, 0.43695652173913, 0.13636363636364
43166, 0.60869565217391, 0.46304347826087, 0.15909090909091
43167, 0.6304347826087, 0.46304347826087, 0.18181818181818
43168, 0.60869565217391, 0.43695652173913, 0.18181818181818
43169, 0.60869565217391, 0.46304347826087, 0.20454545454545
43170, 0.6304347826087, 0.46304347826087, 0.22727272727273
43171, 0.60869565217391, 0.43695652173913, 0.22727272727273
43172, 0.60869565217391, 0.46304347826087, 0.25
43173, 0.6304347826087, 0.46304347826087, 0.27272727272727
43174, 0.60869565217391, 0.43695652173913, 0.27272727272727
43175, 0.60869565217391, 0.46304347826087, 0.29545454545455
43176, 0.6304347826087, 0.46304347826087, 0.31818181818182
43177, 0.60869565217391, 0.43695652173913, 0.31818181818182
43178, 0.60869565217391, 0.46304347826087, 0.34090909090909
43179, 0.6304347826087, 0.46304347826087, 0.36363636363636
43180, 0.60869565217391, 0.43695652173913, 0.36363636363636
43181, 0.60869565217391, 0.46304347826087, 0.38636363636364
43182, 0.6304347826087, 0.46304347826087, 0.40909090909091
43183, 0.60869565217391, 0.43695652173913, 0.40909090909091
43184, 0.60869565217391, 0.46304347826087, 0.43181818181818
43185, 0.6304347826087, 0.46304347826087, 0.45454545454545
43186, 0.60869565217391, 0.43695652173913, 0.45454545454545
43187, 0.60869565217391, 0.46304347826087, 0.47727272727273
43188, 0.56521739130435, 0.46304347826087, 0.022727272727273
43189, 0.58695652173913, 0.46304347826087, 0.045454545454545
43190, 0.56521739130435, 0.43695652173913, 0.045454545454545
43191, 0.56521739130435, 0.46304347826087, 0.068181818181818
43192, 0.58695652173913, 0.46304347826087, 0.090909090909091
43193, 0.56521739130435, 0.43695652173913, 0.090909090909091
43194, 0.56521739130435, 0.46304347826087, 0.11363636363636
43195, 0.58695652173913, 0.46304347826087, 0.13636363636364
43196, 0.56521739130435, 0.43695652173913, 0.13636363636364
43197, 0.56521739130435, 0.46304347826087, 0.15909090909091
43198, 0.58695652173913, 0.46304347826087, 0.18181818181818
43199, 0.56521739130435, 0.43695652173913, 0.18181818181818
43200, 0.56521739130435, 0.46304347826087, 0.20454545454545
43201, 0.58695652173913, 0.46304347826087, 0.22727272727273
43202, 0.56521739130435, 0.43695652173913, 0.22727272727273
43203, 0.56521739130435, 0.46304347826087, 0.25
43204, 0.58695652173913, 0.46304347826087, 0.27272727272727
43205, 0.56521739130435, 0.43695652173913, 0.27272727272727
43206, 0.56521739130435, 0.46304347826087, 0.29545454545455
43207, 0.58695652173913, 0.46304347826087, 0.31818181818182
43208, 0.56521739130435, 0.43695652173913, 0.31818181818182
43209, 0.56521739130435, 0.46304347826087, 0.34090909090909
43210, 0.58695652173913, 0.46304347826087, 0.36363636363636
43211, 0.56521739130435, 0.43695652173913, 0.36363636363636
43212, 0.56521739130435, 0.46304347826087, 0.38636363636364
43213, 0.58695652173913, 0.46304347826087, 0.40909090909091
43214, 0.56521739130435, 0.43695652173913, 0.40909090909091
43215, 0.56521739130435, 0.46304347826087, 0.43181818181818
43216, 0.58695652173913, 0.46304347826087, 0.45454545454545
43217, 0.56521739130435, 0.43695652173913, 0.45454545454545
43218, 0.56521739130435, 0.46304347826087, 0.47727272727273
43219, 0.52173913043478, 0.46304347826087, 0.022727272727273
43220, 0.54347826086956, 0.46304347826087, 0.045454545454545
43221, 0.52173913043478, 0.43695652173913, 0.045454545454545
43222, 0.52173913043478, 0.46304347826087, 0.068181818181818
43223, 0.54347826086956, 0.46304347826087, 0.090909090909091
43224, 0.52173913043478, 0.43695652173913, 0.090909090909091
43225, 0.52173913043478, 0.46304347826087, 0.11363636363636
43226, 0.54347826086957, 0.46304347826087, 0.13636363636364
43227, 0.52173913043478, 0.43695652173913, 0.13636363636364
43228, 0.52173913043478, 0.46304347826087, 0.15909090909091
43229, 0.54347826086956, 0.46304347826087, 0.18181818181818
43230, 0.52173913043478, 0.43695652173913, 0.18181818181818
43231, 0.52173913043478, 0.46304347826087, 0.20454545454545
43232, 0.54347826086956, 0.46304347826087, 0.22727272727273
43233, 0.52173913043478, 0.43695652173913, 0.22727272727273
43234, 0.52173913043478, 0.46304347826087, 0.25
43235, 0.54347826086956, 0.46304347826087, 0.27272727272727
43236, 0.52173913043478, 0.43695652173913, 0.27272727272727
43237, 0.52173913043478, 0.46304347826087, 0.29545454545455
43238, 0.54347826086956, 0.46304347826087, 0.31818181818182
43239, 0.52173913043478, 0.43695652173913, 0.31818181818182
43240, 0.52173913043478, 0.46304347826087, 0.34090909090909
43241, 0.54347826086957, 0.46304347826087, 0.36363636363636
43242, 0.52173913043478, 0.43695652173913, 0.36363636363636
43243, 0.52173913043478, 0.46304347826087, 0.38636363636364
43244, 0.54347826086956, 0.46304347826087, 0.40909090909091
43245, 0.52173913043478, 0.43695652173913, 0.40909090909091
43246, 0.52173913043478, 0.46304347826087, 0.43181818181818
43247, 0.54347826086956, 0.46304347826087, 0.45454545454545
43248, 0.52173913043478, 0.43695652173913, 0.45454545454545
43249, 0.52173913043478, 0.46304347826087, 0.47727272727273
43250, 0.47826086956522, 0.46304347826087, 0.022727272727273
43251, 0.5, 0.46304347826087, 0.045454545454545
43252, 0.47826086956522, 0.43695652173913, 0.045454545454545
43253, 0.47826086956522, 0.46304347826087, 0.068181818181818
43254, 0.5, 0.46304347826087, 0.090909090909091
43255, 0.47826086956522, 0.43695652173913, 0.090909090909091
43256, 0.47826086956522, 0.46304347826087, 0.11363636363636
43257, 0.5, 0.46304347826087, 0.13636363636364
43258, 0.47826086956522, 0.43695652173913, 0.13636363636364
43259, 0.47826086956522, 0.46304347826087, 0.15909090909091
43260, 0.5, 0.46304347826087, 0.18181818181818
43261, 0.47826086956522, 0.43695652173913, 0.18181818181818
43262, 0.47826086956522, 0.46304347826087, 0.20454545454545
43263, 0.5, 0.46304347826087, 0.22727272727273
43264, 0.47826086956522, 0.43695652173913, 0.22727272727273
43265, 0.47826086956522, 0.46304347826087, 0.25
43266, 0.5, 0.46304347826087, 0.27272727272727
43267, 0.47826086956522, 0.43695652173913, 0.27272727272727
43268, 0.47826086956522, 0.46304347826087, 0.29545454545455
43269, 0.5, 0.46304347826087, 0.31818181818182
43270, 0.47826086956522, 0.43695652173913, 0.31818181818182
43271, 0.47826086956522, 0.46304347826087, 0.34090909090909
43272, 0.5, 0.46304347826087, 0.36363636363636
43273, 0.47826086956522, 0.43695652173913, 0.36363636363636
43274, 0.47826086956522, 0.46304347826087, 0.38636363636364
43275, 0.5, 0.46304347826087, 0.40909090909091
43276, 0.47826086956522, 0.43695652173913, 0.40909090909091
43277, 0.47826086956522, 0.46304347826087, 0.43181818181818
43278, 0.5, 0.46304347826087, 0.45454545454545
43279, 0.47826086956522, 0.43695652173913, 0.45454545454545
43280, 0.47826086956522, 0.46304347826087, 0.47727272727273
43281, 0.43478260869565, 0.46304347826087, 0.022727272727273
43282, 0.45652173913043, 0.46304347826087, 0.045454545454545
43283, 0.43478260869565, 0.43695652173913, 0.045454545454545
43284, 0.43478260869565, 0.46304347826087, 0.068181818181818
43285, 0.45652173913043, 0.46304347826087, 0.090909090909091
43286, 0.43478260869565, 0.43695652173913, 0.090909090909091
43287, 0.43478260869565, 0.46304347826087, 0.11363636363636
43288, 0.45652173913043, 0.46304347826087, 0.13636363636364
43289, 0.43478260869565, 0.43695652173913, 0.13636363636364
43290, 0.43478260869565, 0.46304347826087, 0.15909090909091
43291, 0.45652173913043, 0.46304347826087, 0.18181818181818
43292, 0.43478260869565, 0.43695652173913, 0.18181818181818
43293, 0.43478260869565, 0.46304347826087, 0.20454545454545
43294, 0.45652173913043, 0.46304347826087, 0.22727272727273
43295, 0.43478260869565, 0.43695652173913, 0.22727272727273
43296, 0.43478260869565, 0.46304347826087, 0.25
43297, 0.45652173913043, 0.46304347826087, 0.27272727272727
43298, 0.43478260869565, 0.43695652173913, 0.27272727272727
43299, 0.43478260869565, 0.46304347826087, 0.29545454545455
43300, 0.45652173913043, 0.46304347826087, 0.31818181818182
43301, 0.43478260869565, 0.43695652173913, 0.31818181818182
43302, 0.43478260869565, 0.46304347826087, 0.34090909090909
43303, 0.45652173913043, 0.46304347826087, 0.36363636363636
43304, 0.43478260869565, 0.43695652173913, 0.36363636363636
43305, 0.43478260869565, 0.46304347826087, 0.38636363636364
43306, 0.45652173913043, 0.46304347826087, 0.40909090909091
43307, 0.43478260869565, 0.43695652173913, 0.40909090909091
43308, 0.43478260869565, 0.46304347826087, 0.43181818181818
43309, 0.45652173913043, 0.46304347826087, 0.45454545454545
43310, 0.43478260869565, 0.43695652173913, 0.45454545454545
43311, 0.43478260869565, 0.46304347826087, 0.47727272727273
43312, 0.39130434782609, 0.46304347826087, 0.022727272727273
43313, 0.41304347826087, 0.46304347826087, 0.045454545454545
43314, 0.39130434782609, 0.43695652173913, 0.045454545454545
43315, 0.39130434782609, 0.46304347826087, 0.068181818181818
43316, 0.41304347826087, 0.46304347826087, 0.090909090909091
43317, 0.39130434782609, 0.43695652173913, 0.090909090909091
43318, 0.39130434782609, 0.46304347826087, 0.11363636363636
43319, 0.41304347826087, 0.46304347826087, 0.13636363636364
43320, 0.39130434782609, 0.43695652173913, 0.13636363636364
43321, 0.39130434782609, 0.46304347826087, 0.15909090909091
43322, 0.41304347826087, 0.46304347826087, 0.18181818181818
43323, 0.39130434782609, 0.43695652173913, 0.18181818181818
43324, 0.39130434782609, 0.46304347826087, 0.20454545454545
43325, 0.41304347826087, 0.46304347826087, 0.22727272727273
43326, 0.39130434782609, 0.43695652173913, 0.22727272727273
43327, 0.39130434782609, 0.46304347826087, 0.25
43328, 0.41304347826087, 0.46304347826087, 0.27272727272727
43329, 0.39130434782609, 0.43695652173913, 0.27272727272727
43330, 0.39130434782609, 0.46304347826087, 0.29545454545455
43331, 0.41304347826087, 0.46304347826087, 0.31818181818182
43332, 0.39130434782609, 0.43695652173913, 0.31818181818182
43333, 0.39130434782609, 0.46304347826087, 0.34090909090909
43334, 0.41304347826087, 0.46304347826087, 0.36363636363636
43335, 0.39130434782609, 0.43695652173913, 0.36363636363636
43336, 0.39130434782609, 0.46304347826087, 0.38636363636364
43337, 0.41304347826087, 0.46304347826087, 0.40909090909091
43338, 0.39130434782609, 0.43695652173913, 0.40909090909091
43339, 0.39130434782609, 0.46304347826087, 0.43181818181818
43340, 0.41304347826087, 0.46304347826087, 0.45454545454545
43341, 0.39130434782609, 0.43695652173913, 0.45454545454545
43342, 0.39130434782609, 0.46304347826087, 0.47727272727273
43343, 0.34782608695652, 0.46304347826087, 0.022727272727273
43344, 0.3695652173913, 0.46304347826087, 0.045454545454545
43345, 0.34782608695652, 0.43695652173913, 0.045454545454545
43346, 0.34782608695652, 0.46304347826087, 0.068181818181818
43347, 0.3695652173913, 0.46304347826087, 0.090909090909091
43348, 0.34782608695652, 0.43695652173913, 0.090909090909091
43349, 0.34782608695652, 0.46304347826087, 0.11363636363636
43350, 0.3695652173913, 0.46304347826087, 0.13636363636364
43351, 0.34782608695652, 0.43695652173913, 0.13636363636364
43352, 0.34782608695652, 0.46304347826087, 0.15909090909091
43353, 0.3695652173913, 0.46304347826087, 0.18181818181818
43354, 0.34782608695652, 0.43695652173913, 0.18181818181818
43355, 0.34782608695652, 0.46304347826087, 0.20454545454545
43356, 0.3695652173913, 0.46304347826087, 0.22727272727273
43357, 0.34782608695652, 0.43695652173913, 0.22727272727273
43358, 0.34782608695652, 0.46304347826087, 0.25
43359, 0.3695652173913, 0.46304347826087, 0.27272727272727
43360, 0.34782608695652, 0.43695652173913, 0.27272727272727
43361, 0.34782608695652, 0.46304347826087, 0.29545454545455
43362, 0.3695652173913, 0.46304347826087, 0.31818181818182
43363, 0.34782608695652, 0.43695652173913, 0.31818181818182
43364, 0.34782608695652, 0.46304347826087, 0.34090909090909
43365, 0.3695652173913, 0.46304347826087, 0.36363636363636
43366, 0.34782608695652, 0.43695652173913, 0.36363636363636
43367, 0.34782608695652, 0.46304347826087, 0.38636363636364
43368, 0.3695652173913, 0.46304347826087, 0.40909090909091
43369, 0.34782608695652, 0.43695652173913, 0.40909090909091
43370, 0.34782608695652, 0.46304347826087, 0.43181818181818
43371, 0.3695652173913, 0.46304347826087, 0.45454545454545
43372, 0.34782608695652, 0.43695652173913, 0.45454545454545
43373, 0.34782608695652, 0.46304347826087, 0.47727272727273
43374, 0.30434782608696, 0.46304347826087, 0.022727272727273
43375, 0.32608695652174, 0.46304347826087, 0.045454545454545
43376, 0.30434782608696, 0.43695652173913, 0.045454545454545
43377, 0.30434782608696, 0.46304347826087, 0.068181818181818
43378, 0.32608695652174, 0.46304347826087, 0.090909090909091
43379, 0.30434782608696, 0.43695652173913, 0.090909090909091
43380, 0.30434782608696, 0.46304347826087, 0.11363636363636
43381, 0.32608695652174, 0.46304347826087, 0.13636363636364
43382, 0.30434782608696, 0.43695652173913, 0.13636363636364
43383, 0.30434782608696, 0.46304347826087, 0.15909090909091
43384, 0.32608695652174, 0.46304347826087, 0.18181818181818
43385, 0.30434782608696, 0.43695652173913, 0.18181818181818
43386, 0.30434782608696, 0.46304347826087, 0.20454545454545
43387, 0.32608695652174, 0.46304347826087, 0.22727272727273
43388, 0.30434782608696, 0.43695652173913, 0.22727272727273
43389, 0.30434782608696, 0.46304347826087, 0.25
43390, 0.32608695652174, 0.46304347826087, 0.27272727272727
43391, 0.30434782608696, 0.43695652173913, 0.27272727272727
43392, 0.30434782608696, 0.46304347826087, 0.29545454545455
43393, 0.32608695652174, 0.46304347826087, 0.31818181818182
43394, 0.30434782608696, 0.43695652173913, 0.31818181818182
43395, 0.30434782608696, 0.46304347826087, 0.34090909090909
43396, 0.32608695652174, 0.46304347826087, 0.36363636363636
43397, 0.30434782608696, 0.43695652173913, 0.36363636363636
43398, 0.30434782608696, 0.46304347826087, 0.38636363636364
43399, 0.32608695652174, 0.46304347826087, 0.40909090909091
43400, 0.30434782608696, 0.43695652173913, 0.40909090909091
43401, 0.30434782608696, 0.46304347826087, 0.43181818181818
43402, 0.32608695652174, 0.46304347826087, 0.45454545454545
43403, 0.30434782608696, 0.43695652173913, 0.45454545454545
43404, 0.30434782608696, 0.46304347826087, 0.47727272727273
43405, 0.26086956521739, 0.46304347826087, 0.022727272727273
43406, 0.28260869565217, 0.46304347826087, 0.045454545454545
43407, 0.26086956521739, 0.43695652173913, 0.045454545454545
43408, 0.26086956521739, 0.46304347826087, 0.068181818181818
43409, 0.28260869565217, 0.46304347826087, 0.090909090909091
43410, 0.26086956521739, 0.43695652173913, 0.090909090909091
43411, 0.26086956521739, 0.46304347826087, 0.11363636363636
43412, 0.28260869565217, 0.46304347826087, 0.13636363636364
43413, 0.26086956521739, 0.43695652173913, 0.13636363636364
43414, 0.26086956521739, 0.46304347826087, 0.15909090909091
43415, 0.28260869565217, 0.46304347826087, 0.18181818181818
43416, 0.26086956521739, 0.43695652173913, 0.18181818181818
43417, 0.26086956521739, 0.46304347826087, 0.20454545454545
43418, 0.28260869565217, 0.46304347826087, 0.22727272727273
43419, 0.26086956521739, 0.43695652173913, 0.22727272727273
43420, 0.26086956521739, 0.46304347826087, 0.25
43421, 0.28260869565217, 0.46304347826087, 0.27272727272727
43422, 0.26086956521739, 0.43695652173913, 0.27272727272727
43423, 0.26086956521739, 0.46304347826087, 0.29545454545455
43424, 0.28260869565217, 0.46304347826087, 0.31818181818182
43425, 0.26086956521739, 0.43695652173913, 0.31818181818182
43426, 0.26086956521739, 0.46304347826087, 0.34090909090909
43427, 0.28260869565217, 0.46304347826087, 0.36363636363636
43428, 0.26086956521739, 0.43695652173913, 0.36363636363636
43429, 0.26086956521739, 0.46304347826087, 0.38636363636364
43430, 0.28260869565217, 0.46304347826087, 0.40909090909091
43431, 0.26086956521739, 0.43695652173913, 0.40909090909091
43432, 0.26086956521739, 0.46304347826087, 0.43181818181818
43433, 0.28260869565217, 0.46304347826087, 0.45454545454545
43434, 0.26086956521739, 0.43695652173913, 0.45454545454545
43435, 0.26086956521739, 0.46304347826087, 0.47727272727273
43436, 0.21739130434783, 0.46304347826087, 0.022727272727273
43437, 0.23913043478261, 0.46304347826087, 0.045454545454545
43438, 0.21739130434783, 0.43695652173913, 0.045454545454545
43439, 0.21739130434783, 0.46304347826087, 0.068181818181818
43440, 0.23913043478261, 0.46304347826087, 0.090909090909091
43441, 0.21739130434783, 0.43695652173913, 0.090909090909091
43442, 0.21739130434783, 0.46304347826087, 0.11363636363636
43443, 0.23913043478261, 0.46304347826087, 0.13636363636364
43444, 0.21739130434783, 0.43695652173913, 0.13636363636364
43445, 0.21739130434783, 0.46304347826087, 0.15909090909091
43446, 0.23913043478261, 0.46304347826087, 0.18181818181818
43447, 0.21739130434783, 0.43695652173913, 0.18181818181818
43448, 0.21739130434783, 0.46304347826087, 0.20454545454545
43449, 0.23913043478261, 0.46304347826087, 0.22727272727273
43450, 0.21739130434783, 0.43695652173913, 0.22727272727273
43451, 0.21739130434783, 0.46304347826087, 0.25
43452, 0.23913043478261, 0.46304347826087, 0.27272727272727
43453, 0.21739130434783, 0.43695652173913, 0.27272727272727
43454, 0.21739130434783, 0.46304347826087, 0.29545454545455
43455, 0.23913043478261, 0.46304347826087, 0.31818181818182
43456, 0.21739130434783, 0.43695652173913, 0.31818181818182
43457, 0.21739130434783, 0.46304347826087, 0.34090909090909
43458, 0.23913043478261, 0.46304347826087, 0.36363636363636
43459, 0.21739130434783, 0.43695652173913, 0.36363636363636
43460, 0.21739130434783, 0.46304347826087, 0.38636363636364
43461, 0.23913043478261, 0.46304347826087, 0.40909090909091
43462, 0.21739130434783, 0.43695652173913, 0.40909090909091
43463, 0.21739130434783, 0.46304347826087, 0.43181818181818
43464, 0.23913043478261, 0.46304347826087, 0.45454545454545
43465, 0.21739130434783, 0.43695652173913, 0.45454545454545
43466, 0.21739130434783, 0.46304347826087, 0.47727272727273
43467, 0.17391304347826, 0.46304347826087, 0.022727272727273
43468, 0.19565217391304, 0.46304347826087, 0.045454545454545
43469, 0.17391304347826, 0.43695652173913, 0.045454545454545
43470, 0.17391304347826, 0.46304347826087, 0.068181818181818
43471, 0.19565217391304, 0.46304347826087, 0.090909090909091
43472, 0.17391304347826, 0.43695652173913, 0.090909090909091
43473, 0.17391304347826, 0.46304347826087, 0.11363636363636
43474, 0.19565217391304, 0.46304347826087, 0.13636363636364
43475, 0.17391304347826, 0.43695652173913, 0.13636363636364
43476, 0.17391304347826, 0.46304347826087, 0.15909090909091
43477, 0.19565217391304, 0.46304347826087, 0.18181818181818
43478, 0.17391304347826, 0.43695652173913, 0.18181818181818
43479, 0.17391304347826, 0.46304347826087, 0.20454545454545
43480, 0.19565217391304, 0.46304347826087, 0.22727272727273
43481, 0.17391304347826, 0.43695652173913, 0.22727272727273
43482, 0.17391304347826, 0.46304347826087, 0.25
43483, 0.19565217391304, 0.46304347826087, 0.27272727272727
43484, 0.17391304347826, 0.43695652173913, 0.27272727272727
43485, 0.17391304347826, 0.46304347826087, 0.29545454545455
43486, 0.19565217391304, 0.46304347826087, 0.31818181818182
43487, 0.17391304347826, 0.43695652173913, 0.31818181818182
43488, 0.17391304347826, 0.46304347826087, 0.34090909090909
43489, 0.19565217391304, 0.46304347826087, 0.36363636363636
43490, 0.17391304347826, 0.43695652173913, 0.36363636363636
43491, 0.17391304347826, 0.46304347826087, 0.38636363636364
43492, 0.19565217391304, 0.46304347826087, 0.40909090909091
43493, 0.17391304347826, 0.43695652173913, 0.40909090909091
43494, 0.17391304347826, 0.46304347826087, 0.43181818181818
43495, 0.19565217391304, 0.46304347826087, 0.45454545454545
43496, 0.17391304347826, 0.43695652173913, 0.45454545454545
43497, 0.17391304347826, 0.46304347826087, 0.47727272727273
43498, 0.1304347826087, 0.46304347826087, 0.022727272727273
43499, 0.15217391304348, 0.46304347826087, 0.045454545454545
43500, 0.1304347826087, 0.43695652173913, 0.045454545454545
43501, 0.1304347826087, 0.46304347826087, 0.068181818181818
43502, 0.15217391304348, 0.46304347826087, 0.090909090909091
43503, 0.1304347826087, 0.43695652173913, 0.090909090909091
43504, 0.1304347826087, 0.46304347826087, 0.11363636363636
43505, 0.15217391304348, 0.46304347826087, 0.13636363636364
43506, 0.1304347826087, 0.43695652173913, 0.13636363636364
43507, 0.1304347826087, 0.46304347826087, 0.15909090909091
43508, 0.15217391304348, 0.46304347826087, 0.18181818181818
43509, 0.1304347826087, 0.43695652173913, 0.18181818181818
43510, 0.1304347826087, 0.46304347826087, 0.20454545454545
43511, 0.15217391304348, 0.46304347826087, 0.22727272727273
43512, 0.1304347826087, 0.43695652173913, 0.22727272727273
43513, 0.1304347826087, 0.46304347826087, 0.25
43514, 0.15217391304348, 0.46304347826087, 0.27272727272727
43515, 0.1304347826087, 0.43695652173913, 0.27272727272727
43516, 0.1304347826087, 0.46304347826087, 0.29545454545455
43517, 0.15217391304348, 0.46304347826087, 0.31818181818182
43518, 0.1304347826087, 0.43695652173913, 0.31818181818182
43519, 0.1304347826087, 0.46304347826087, 0.34090909090909
43520, 0.15217391304348, 0.46304347826087, 0.36363636363636
43521, 0.1304347826087, 0.43695652173913, 0.36363636363636
43522, 0.1304347826087, 0.46304347826087, 0.38636363636364
43523, 0.15217391304348, 0.46304347826087, 0.40909090909091
43524, 0.1304347826087, 0.43695652173913, 0.40909090909091
43525, 0.1304347826087, 0.46304347826087, 0.43181818181818
43526, 0.15217391304348, 0.46304347826087, 0.45454545454545
43527, 0.1304347826087, 0.43695652173913, 0.45454545454545
43528, 0.1304347826087, 0.46304347826087, 0.47727272727273
43529, 0.08695652173913, 0.46304347826087, 0.022727272727273
43530, 0.10869565217391, 0.46304347826087, 0.045454545454545
43531, 0.08695652173913, 0.43695652173913, 0.045454545454545
43532, 0.08695652173913, 0.46304347826087, 0.068181818181818
43533, 0.10869565217391, 0.46304347826087, 0.090909090909091
43534, 0.08695652173913, 0.43695652173913, 0.090909090909091
43535, 0.08695652173913, 0.46304347826087, 0.11363636363636
43536, 0.10869565217391, 0.46304347826087, 0.13636363636364
43537, 0.08695652173913, 0.43695652173913, 0.13636363636364
43538, 0.08695652173913, 0.46304347826087, 0.15909090909091
43539, 0.10869565217391, 0.46304347826087, 0.18181818181818
43540, 0.08695652173913, 0.43695652173913, 0.18181818181818
43541, 0.08695652173913, 0.46304347826087, 0.20454545454545
43542, 0.10869565217391, 0.46304347826087, 0.22727272727273
43543, 0.08695652173913, 0.43695652173913, 0.22727272727273
43544, 0.08695652173913, 0.46304347826087, 0.25
43545, 0.10869565217391, 0.46304347826087, 0.27272727272727
43546, 0.08695652173913, 0.43695652173913, 0.27272727272727
43547, 0.08695652173913, 0.46304347826087, 0.29545454545455
43548, 0.10869565217391, 0.46304347826087, 0.31818181818182
43549, 0.08695652173913, 0.43695652173913, 0.31818181818182
43550, 0.08695652173913, 0.46304347826087, 0.34090909090909
43551, 0.10869565217391, 0.46304347826087, 0.36363636363636
43552, 0.08695652173913, 0.43695652173913, 0.36363636363636
43553, 0.08695652173913, 0.46304347826087, 0.38636363636364
43554, 0.10869565217391, 0.46304347826087, 0.40909090909091
43555, 0.08695652173913, 0.43695652173913, 0.40909090909091
43556, 0.08695652173913, 0.46304347826087, 0.43181818181818
43557, 0.10869565217391, 0.46304347826087, 0.45454545454545
43558, 0.08695652173913, 0.43695652173913, 0.45454545454545
43559, 0.08695652173913, 0.46304347826087, 0.47727272727273
43560, 0.043478260869565, 0.46304347826087, 0.022727272727273
43561, 0.065217391304348, 0.46304347826087, 0.045454545454545
43562, 0.043478260869565, 0.43695652173913, 0.045454545454545
43563, 0.043478260869565, 0.46304347826087, 0.068181818181818
43564, 0.065217391304348, 0.46304347826087, 0.090909090909091
43565, 0.043478260869565, 0.43695652173913, 0.090909090909091
43566, 0.043478260869565, 0.46304347826087, 0.11363636363636
43567, 0.065217391304348, 0.46304347826087, 0.13636363636364
43568, 0.043478260869565, 0.43695652173913, 0.13636363636364
43569, 0.043478260869565, 0.46304347826087, 0.15909090909091
43570, 0.065217391304348, 0.46304347826087, 0.18181818181818
43571, 0.043478260869565, 0.43695652173913, 0.18181818181818
43572, 0.043478260869565, 0.46304347826087, 0.20454545454545
43573, 0.065217391304348, 0.46304347826087, 0.22727272727273
43574, 0.043478260869565, 0.43695652173913, 0.22727272727273
43575, 0.043478260869565, 0.46304347826087, 0.25
43576, 0.065217391304348, 0.46304347826087, 0.27272727272727
43577, 0.043478260869565, 0.43695652173913, 0.27272727272727
43578, 0.043478260869565, 0.46304347826087, 0.29545454545455
43579, 0.065217391304348, 0.46304347826087, 0.31818181818182
43580, 0.043478260869565, 0.43695652173913, 0.31818181818182
43581, 0.043478260869565, 0.46304347826087, 0.34090909090909
43582, 0.065217391304348, 0.46304347826087, 0.36363636363636
43583, 0.043478260869565, 0.43695652173913, 0.36363636363636
43584, 0.043478260869565, 0.46304347826087, 0.38636363636364
43585, 0.065217391304348, 0.46304347826087, 0.40909090909091
43586, 0.043478260869565, 0.43695652173913, 0.40909090909091
43587, 0.043478260869565, 0.46304347826087, 0.43181818181818
43588, 0.065217391304348, 0.46304347826087, 0.45454545454545
43589, 0.043478260869565, 0.43695652173913, 0.45454545454545
43590, 0.043478260869565, 0.46304347826087, 0.47727272727273
43591, 0.021739130434783, 0.46304347826087, 0.045454545454545
43592, 0.021739130434783, 0.46304347826087, 0.090909090909091
43593, 0.021739130434783, 0.46304347826087, 0.13636363636364
43594, 0.021739130434783, 0.46304347826087, 0.18181818181818
43595, 0.021739130434783, 0.46304347826087, 0.22727272727273
43596, 0.021739130434783, 0.46304347826087, 0.27272727272727
43597, 0.021739130434783, 0.46304347826087, 0.31818181818182
43598, 0.021739130434783, 0.46304347826087, 0.36363636363636
43599, 0.021739130434783, 0.46304347826087, 0.40909090909091
43600, 0.021739130434783, 0.46304347826087, 0.45454545454545
43601, 0.95652173913043, 0.51521739130435, 0.022727272727273
43602, 0.97826086956522, 0.51521739130435, 0.045454545454545
43603, 0.95652173913043, 0.48913043478261, 0.045454545454545
43604, 0.95652173913043, 0.51521739130435, 0.068181818181818
43605, 0.97826086956522, 0.51521739130435, 0.090909090909091
43606, 0.95652173913043, 0.48913043478261, 0.090909090909091
43607, 0.95652173913043, 0.51521739130435, 0.11363636363636
43608, 0.97826086956522, 0.51521739130435, 0.13636363636364
43609, 0.95652173913043, 0.48913043478261, 0.13636363636364
43610, 0.95652173913043, 0.51521739130435, 0.15909090909091
43611, 0.97826086956522, 0.51521739130435, 0.18181818181818
43612, 0.95652173913043, 0.48913043478261, 0.18181818181818
43613, 0.95652173913044, 0.51521739130435, 0.20454545454545
43614, 0.97826086956522, 0.51521739130435, 0.22727272727273
43615, 0.95652173913044, 0.48913043478261, 0.22727272727273
43616, 0.95652173913044, 0.51521739130435, 0.25
43617, 0.97826086956522, 0.51521739130435, 0.27272727272727
43618, 0.95652173913044, 0.48913043478261, 0.27272727272727
43619, 0.95652173913043, 0.51521739130435, 0.29545454545455
43620, 0.97826086956522, 0.51521739130435, 0.31818181818182
43621, 0.95652173913043, 0.48913043478261, 0.31818181818182
43622, 0.95652173913043, 0.51521739130435, 0.34090909090909
43623, 0.97826086956522, 0.51521739130435, 0.36363636363636
43624, 0.95652173913043, 0.48913043478261, 0.36363636363636
43625, 0.95652173913043, 0.51521739130435, 0.38636363636364
43626, 0.97826086956522, 0.51521739130435, 0.40909090909091
43627, 0.95652173913043, 0.48913043478261, 0.40909090909091
43628, 0.95652173913043, 0.51521739130435, 0.43181818181818
43629, 0.97826086956522, 0.51521739130435, 0.45454545454545
43630, 0.95652173913043, 0.48913043478261, 0.45454545454545
43631, 0.95652173913043, 0.51521739130435, 0.47727272727273
43632, 0.91304347826087, 0.51521739130435, 0.022727272727273
43633, 0.93478260869565, 0.51521739130435, 0.045454545454545
43634, 0.91304347826087, 0.48913043478261, 0.045454545454545
43635, 0.91304347826087, 0.51521739130435, 0.068181818181818
43636, 0.93478260869565, 0.51521739130435, 0.090909090909091
43637, 0.91304347826087, 0.48913043478261, 0.090909090909091
43638, 0.91304347826087, 0.51521739130435, 0.11363636363636
43639, 0.93478260869565, 0.51521739130435, 0.13636363636364
43640, 0.91304347826087, 0.48913043478261, 0.13636363636364
43641, 0.91304347826087, 0.51521739130435, 0.15909090909091
43642, 0.93478260869565, 0.51521739130435, 0.18181818181818
43643, 0.91304347826087, 0.48913043478261, 0.18181818181818
43644, 0.91304347826087, 0.51521739130435, 0.20454545454545
43645, 0.93478260869565, 0.51521739130435, 0.22727272727273
43646, 0.91304347826087, 0.48913043478261, 0.22727272727273
43647, 0.91304347826087, 0.51521739130435, 0.25
43648, 0.93478260869565, 0.51521739130435, 0.27272727272727
43649, 0.91304347826087, 0.48913043478261, 0.27272727272727
43650, 0.91304347826087, 0.51521739130435, 0.29545454545455
43651, 0.93478260869565, 0.51521739130435, 0.31818181818182
43652, 0.91304347826087, 0.48913043478261, 0.31818181818182
43653, 0.91304347826087, 0.51521739130435, 0.34090909090909
43654, 0.93478260869565, 0.51521739130435, 0.36363636363636
43655, 0.91304347826087, 0.48913043478261, 0.36363636363636
43656, 0.91304347826087, 0.51521739130435, 0.38636363636364
43657, 0.93478260869565, 0.51521739130435, 0.40909090909091
43658, 0.91304347826087, 0.48913043478261, 0.40909090909091
43659, 0.91304347826087, 0.51521739130435, 0.43181818181818
43660, 0.93478260869565, 0.51521739130435, 0.45454545454545
43661, 0.91304347826087, 0.48913043478261, 0.45454545454545
43662, 0.91304347826087, 0.51521739130435, 0.47727272727273
43663, 0.8695652173913, 0.51521739130435, 0.022727272727273
43664, 0.89130434782609, 0.51521739130435, 0.045454545454545
43665, 0.8695652173913, 0.48913043478261, 0.045454545454545
43666, 0.8695652173913, 0.51521739130435, 0.068181818181818
43667, 0.89130434782609, 0.51521739130435, 0.090909090909091
43668, 0.8695652173913, 0.48913043478261, 0.090909090909091
43669, 0.8695652173913, 0.51521739130435, 0.11363636363636
43670, 0.89130434782609, 0.51521739130435, 0.13636363636364
43671, 0.8695652173913, 0.48913043478261, 0.13636363636364
43672, 0.8695652173913, 0.51521739130435, 0.15909090909091
43673, 0.89130434782609, 0.51521739130435, 0.18181818181818
43674, 0.8695652173913, 0.48913043478261, 0.18181818181818
43675, 0.8695652173913, 0.51521739130435, 0.20454545454545
43676, 0.89130434782609, 0.51521739130435, 0.22727272727273
43677, 0.8695652173913, 0.48913043478261, 0.22727272727273
43678, 0.8695652173913, 0.51521739130435, 0.25
43679, 0.89130434782609, 0.51521739130435, 0.27272727272727
43680, 0.8695652173913, 0.48913043478261, 0.27272727272727
43681, 0.8695652173913, 0.51521739130435, 0.29545454545455
43682, 0.89130434782609, 0.51521739130435, 0.31818181818182
43683, 0.8695652173913, 0.48913043478261, 0.31818181818182
43684, 0.8695652173913, 0.51521739130435, 0.34090909090909
43685, 0.89130434782609, 0.51521739130435, 0.36363636363636
43686, 0.8695652173913, 0.48913043478261, 0.36363636363636
43687, 0.8695652173913, 0.51521739130435, 0.38636363636364
43688, 0.89130434782609, 0.51521739130435, 0.40909090909091
43689, 0.8695652173913, 0.48913043478261, 0.40909090909091
43690, 0.8695652173913, 0.51521739130435, 0.43181818181818
43691, 0.89130434782609, 0.51521739130435, 0.45454545454545
43692, 0.8695652173913, 0.48913043478261, 0.45454545454545
43693, 0.8695652173913, 0.51521739130435, 0.47727272727273
43694, 0.82608695652174, 0.51521739130435, 0.022727272727273
43695, 0.84782608695652, 0.51521739130435, 0.045454545454545
43696, 0.82608695652174, 0.48913043478261, 0.045454545454545
43697, 0.82608695652174, 0.51521739130435, 0.068181818181818
43698, 0.84782608695652, 0.51521739130435, 0.090909090909091
43699, 0.82608695652174, 0.48913043478261, 0.090909090909091
43700, 0.82608695652174, 0.51521739130435, 0.11363636363636
43701, 0.84782608695652, 0.51521739130435, 0.13636363636364
43702, 0.82608695652174, 0.48913043478261, 0.13636363636364
43703, 0.82608695652174, 0.51521739130435, 0.15909090909091
43704, 0.84782608695652, 0.51521739130435, 0.18181818181818
43705, 0.82608695652174, 0.48913043478261, 0.18181818181818
43706, 0.82608695652174, 0.51521739130435, 0.20454545454545
43707, 0.84782608695652, 0.51521739130435, 0.22727272727273
43708, 0.82608695652174, 0.48913043478261, 0.22727272727273
43709, 0.82608695652174, 0.51521739130435, 0.25
43710, 0.84782608695652, 0.51521739130435, 0.27272727272727
43711, 0.82608695652174, 0.48913043478261, 0.27272727272727
43712, 0.82608695652174, 0.51521739130435, 0.29545454545455
43713, 0.84782608695652, 0.51521739130435, 0.31818181818182
43714, 0.82608695652174, 0.48913043478261, 0.31818181818182
43715, 0.82608695652174, 0.51521739130435, 0.34090909090909
43716, 0.84782608695652, 0.51521739130435, 0.36363636363636
43717, 0.82608695652174, 0.48913043478261, 0.36363636363636
43718, 0.82608695652174, 0.51521739130435, 0.38636363636364
43719, 0.84782608695652, 0.51521739130435, 0.40909090909091
43720, 0.82608695652174, 0.48913043478261, 0.40909090909091
43721, 0.82608695652174, 0.51521739130435, 0.43181818181818
43722, 0.84782608695652, 0.51521739130435, 0.45454545454545
43723, 0.82608695652174, 0.48913043478261, 0.45454545454545
43724, 0.82608695652174, 0.51521739130435, 0.47727272727273
43725, 0.78260869565217, 0.51521739130435, 0.022727272727273
43726, 0.80434782608696, 0.51521739130435, 0.045454545454545
43727, 0.78260869565217, 0.48913043478261, 0.045454545454545
43728, 0.78260869565217, 0.51521739130435, 0.068181818181818
43729, 0.80434782608696, 0.51521739130435, 0.090909090909091
43730, 0.78260869565217, 0.48913043478261, 0.090909090909091
43731, 0.78260869565217, 0.51521739130435, 0.11363636363636
43732, 0.80434782608696, 0.51521739130435, 0.13636363636364
43733, 0.78260869565217, 0.48913043478261, 0.13636363636364
43734, 0.78260869565217, 0.51521739130435, 0.15909090909091
43735, 0.80434782608696, 0.51521739130435, 0.18181818181818
43736, 0.78260869565217, 0.48913043478261, 0.18181818181818
43737, 0.78260869565217, 0.51521739130435, 0.20454545454545
43738, 0.80434782608696, 0.51521739130435, 0.22727272727273
43739, 0.78260869565217, 0.48913043478261, 0.22727272727273
43740, 0.78260869565217, 0.51521739130435, 0.25
43741, 0.80434782608696, 0.51521739130435, 0.27272727272727
43742, 0.78260869565217, 0.48913043478261, 0.27272727272727
43743, 0.78260869565217, 0.51521739130435, 0.29545454545455
43744, 0.80434782608696, 0.51521739130435, 0.31818181818182
43745, 0.78260869565217, 0.48913043478261, 0.31818181818182
43746, 0.78260869565217, 0.51521739130435, 0.34090909090909
43747, 0.80434782608696, 0.51521739130435, 0.36363636363636
43748, 0.78260869565217, 0.48913043478261, 0.36363636363636
43749, 0.78260869565217, 0.51521739130435, 0.38636363636364
43750, 0.80434782608696, 0.51521739130435, 0.40909090909091
43751, 0.78260869565217, 0.48913043478261, 0.40909090909091
43752, 0.78260869565217, 0.51521739130435, 0.43181818181818
43753, 0.80434782608696, 0.51521739130435, 0.45454545454545
43754, 0.78260869565217, 0.48913043478261, 0.45454545454545
43755, 0.78260869565217, 0.51521739130435, 0.47727272727273
43756, 0.73913043478261, 0.51521739130435, 0.022727272727273
43757, 0.76086956521739, 0.51521739130435, 0.045454545454545
43758, 0.73913043478261, 0.48913043478261, 0.045454545454545
43759, 0.73913043478261, 0.51521739130435, 0.068181818181818
43760, 0.76086956521739, 0.51521739130435, 0.090909090909091
43761, 0.73913043478261, 0.48913043478261, 0.090909090909091
43762, 0.73913043478261, 0.51521739130435, 0.11363636363636
43763, 0.76086956521739, 0.51521739130435, 0.13636363636364
43764, 0.73913043478261, 0.48913043478261, 0.13636363636364
43765, 0.73913043478261, 0.51521739130435, 0.15909090909091
43766, 0.76086956521739, 0.51521739130435, 0.18181818181818
43767, 0.73913043478261, 0.48913043478261, 0.18181818181818
43768, 0.73913043478261, 0.51521739130435, 0.20454545454545
43769, 0.76086956521739, 0.51521739130435, 0.22727272727273
43770, 0.73913043478261, 0.48913043478261, 0.22727272727273
43771, 0.73913043478261, 0.51521739130435, 0.25
43772, 0.76086956521739, 0.51521739130435, 0.27272727272727
43773, 0.73913043478261, 0.48913043478261, 0.27272727272727
43774, 0.73913043478261, 0.51521739130435, 0.29545454545455
43775, 0.76086956521739, 0.51521739130435, 0.31818181818182
43776, 0.73913043478261, 0.48913043478261, 0.31818181818182
43777, 0.73913043478261, 0.51521739130435, 0.34090909090909
43778, 0.76086956521739, 0.51521739130435, 0.36363636363636
43779, 0.73913043478261, 0.48913043478261, 0.36363636363636
43780, 0.73913043478261, 0.51521739130435, 0.38636363636364
43781, 0.76086956521739, 0.51521739130435, 0.40909090909091
43782, 0.73913043478261, 0.48913043478261, 0.40909090909091
43783, 0.73913043478261, 0.51521739130435, 0.43181818181818
43784, 0.76086956521739, 0.51521739130435, 0.45454545454545
43785, 0.73913043478261, 0.48913043478261, 0.45454545454545
43786, 0.73913043478261, 0.51521739130435, 0.47727272727273
43787, 0.69565217391304, 0.51521739130435, 0.022727272727273
43788, 0.71739130434783, 0.51521739130435, 0.045454545454545
43789, 0.69565217391304, 0.48913043478261, 0.045454545454545
43790, 0.69565217391304, 0.51521739130435, 0.068181818181818
43791, 0.71739130434783, 0.51521739130435, 0.090909090909091
43792, 0.69565217391304, 0.48913043478261, 0.090909090909091
43793, 0.69565217391304, 0.51521739130435, 0.11363636363636
43794, 0.71739130434783, 0.51521739130435, 0.13636363636364
43795, 0.69565217391304, 0.48913043478261, 0.13636363636364
43796, 0.69565217391304, 0.51521739130435, 0.15909090909091
43797, 0.71739130434783, 0.51521739130435, 0.18181818181818
43798, 0.69565217391304, 0.48913043478261, 0.18181818181818
43799, 0.69565217391304, 0.51521739130435, 0.20454545454545
43800, 0.71739130434783, 0.51521739130435, 0.22727272727273
43801, 0.69565217391304, 0.48913043478261, 0.22727272727273
43802, 0.69565217391304, 0.51521739130435, 0.25
43803, 0.71739130434783, 0.51521739130435, 0.27272727272727
43804, 0.69565217391304, 0.48913043478261, 0.27272727272727
43805, 0.69565217391304, 0.51521739130435, 0.29545454545455
43806, 0.71739130434783, 0.51521739130435, 0.31818181818182
43807, 0.69565217391304, 0.48913043478261, 0.31818181818182
43808, 0.69565217391304, 0.51521739130435, 0.34090909090909
43809, 0.71739130434783, 0.51521739130435, 0.36363636363636
43810, 0.69565217391304, 0.48913043478261, 0.36363636363636
43811, 0.69565217391304, 0.51521739130435, 0.38636363636364
43812, 0.71739130434783, 0.51521739130435, 0.40909090909091
43813, 0.69565217391304, 0.48913043478261, 0.40909090909091
43814, 0.69565217391304, 0.51521739130435, 0.43181818181818
43815, 0.71739130434783, 0.51521739130435, 0.45454545454545
43816, 0.69565217391304, 0.48913043478261, 0.45454545454545
43817, 0.69565217391304, 0.51521739130435, 0.47727272727273
43818, 0.65217391304348, 0.51521739130435, 0.022727272727273
43819, 0.67391304347826, 0.51521739130435, 0.045454545454545
43820, 0.65217391304348, 0.48913043478261, 0.045454545454545
43821, 0.65217391304348, 0.51521739130435, 0.068181818181818
43822, 0.67391304347826, 0.51521739130435, 0.090909090909091
43823, 0.65217391304348, 0.48913043478261, 0.090909090909091
43824, 0.65217391304348, 0.51521739130435, 0.11363636363636
43825, 0.67391304347826, 0.51521739130435, 0.13636363636364
43826, 0.65217391304348, 0.48913043478261, 0.13636363636364
43827, 0.65217391304348, 0.51521739130435, 0.15909090909091
43828, 0.67391304347826, 0.51521739130435, 0.18181818181818
43829, 0.65217391304348, 0.48913043478261, 0.18181818181818
43830, 0.65217391304348, 0.51521739130435, 0.20454545454545
43831, 0.67391304347826, 0.51521739130435, 0.22727272727273
43832, 0.65217391304348, 0.48913043478261, 0.22727272727273
43833, 0.65217391304348, 0.51521739130435, 0.25
43834, 0.67391304347826, 0.51521739130435, 0.27272727272727
43835, 0.65217391304348, 0.48913043478261, 0.27272727272727
43836, 0.65217391304348, 0.51521739130435, 0.29545454545455
43837, 0.67391304347826, 0.51521739130435, 0.31818181818182
43838, 0.65217391304348, 0.48913043478261, 0.31818181818182
43839, 0.65217391304348, 0.51521739130435, 0.34090909090909
43840, 0.67391304347826, 0.51521739130435, 0.36363636363636
43841, 0.65217391304348, 0.48913043478261, 0.36363636363636
43842, 0.65217391304348, 0.51521739130435, 0.38636363636364
43843, 0.67391304347826, 0.51521739130435, 0.40909090909091
43844, 0.65217391304348, 0.48913043478261, 0.40909090909091
43845, 0.65217391304348, 0.51521739130435, 0.43181818181818
43846, 0.67391304347826, 0.51521739130435, 0.45454545454545
43847, 0.65217391304348, 0.48913043478261, 0.45454545454545
43848, 0.65217391304348, 0.51521739130435, 0.47727272727273
43849, 0.60869565217391, 0.51521739130435, 0.022727272727273
43850, 0.6304347826087, 0.51521739130435, 0.045454545454545
43851, 0.60869565217391, 0.48913043478261, 0.045454545454545
43852, 0.60869565217391, 0.51521739130435, 0.068181818181818
43853, 0.6304347826087, 0.51521739130435, 0.090909090909091
43854, 0.60869565217391, 0.48913043478261, 0.090909090909091
43855, 0.60869565217391, 0.51521739130435, 0.11363636363636
43856, 0.6304347826087, 0.51521739130435, 0.13636363636364
43857, 0.60869565217391, 0.48913043478261, 0.13636363636364
43858, 0.60869565217391, 0.51521739130435, 0.15909090909091
43859, 0.6304347826087, 0.51521739130435, 0.18181818181818
43860, 0.60869565217391, 0.48913043478261, 0.18181818181818
43861, 0.60869565217391, 0.51521739130435, 0.20454545454545
43862, 0.6304347826087, 0.51521739130435, 0.22727272727273
43863, 0.60869565217391, 0.48913043478261, 0.22727272727273
43864, 0.60869565217391, 0.51521739130435, 0.25
43865, 0.6304347826087, 0.51521739130435, 0.27272727272727
43866, 0.60869565217391, 0.48913043478261, 0.27272727272727
43867, 0.60869565217391, 0.51521739130435, 0.29545454545455
43868, 0.6304347826087, 0.51521739130435, 0.31818181818182
43869, 0.60869565217391, 0.48913043478261, 0.31818181818182
43870, 0.60869565217391, 0.51521739130435, 0.34090909090909
43871, 0.6304347826087, 0.51521739130435, 0.36363636363636
43872, 0.60869565217391, 0.48913043478261, 0.36363636363636
43873, 0.60869565217391, 0.51521739130435, 0.38636363636364
43874, 0.6304347826087, 0.51521739130435, 0.40909090909091
43875, 0.60869565217391, 0.48913043478261, 0.40909090909091
43876, 0.60869565217391, 0.51521739130435, 0.43181818181818
43877, 0.6304347826087, 0.51521739130435, 0.45454545454545
43878, 0.60869565217391, 0.48913043478261, 0.45454545454545
43879, 0.60869565217391, 0.51521739130435, 0.47727272727273
43880, 0.56521739130435, 0.51521739130435, 0.022727272727273
43881, 0.58695652173913, 0.51521739130435, 0.045454545454545
43882, 0.56521739130435, 0.48913043478261, 0.045454545454545
43883, 0.56521739130435, 0.51521739130435, 0.068181818181818
43884, 0.58695652173913, 0.51521739130435, 0.090909090909091
43885, 0.56521739130435, 0.48913043478261, 0.090909090909091
43886, 0.56521739130435, 0.51521739130435, 0.11363636363636
43887, 0.58695652173913, 0.51521739130435, 0.13636363636364
43888, 0.56521739130435, 0.48913043478261, 0.13636363636364
43889, 0.56521739130435, 0.51521739130435, 0.15909090909091
43890, 0.58695652173913, 0.51521739130435, 0.18181818181818
43891, 0.56521739130435, 0.48913043478261, 0.18181818181818
43892, 0.56521739130435, 0.51521739130435, 0.20454545454545
43893, 0.58695652173913, 0.51521739130435, 0.22727272727273
43894, 0.56521739130435, 0.48913043478261, 0.22727272727273
43895, 0.56521739130435, 0.51521739130435, 0.25
43896, 0.58695652173913, 0.51521739130435, 0.27272727272727
43897, 0.56521739130435, 0.48913043478261, 0.27272727272727
43898, 0.56521739130435, 0.51521739130435, 0.29545454545455
43899, 0.58695652173913, 0.51521739130435, 0.31818181818182
43900, 0.56521739130435, 0.48913043478261, 0.31818181818182
43901, 0.56521739130435, 0.51521739130435, 0.34090909090909
43902, 0.58695652173913, 0.51521739130435, 0.36363636363636
43903, 0.56521739130435, 0.48913043478261, 0.36363636363636
43904, 0.56521739130435, 0.51521739130435, 0.38636363636364
43905, 0.58695652173913, 0.51521739130435, 0.40909090909091
43906, 0.56521739130435, 0.48913043478261, 0.40909090909091
43907, 0.56521739130435, 0.51521739130435, 0.43181818181818
43908, 0.58695652173913, 0.51521739130435, 0.45454545454545
43909, 0.56521739130435, 0.48913043478261, 0.45454545454545
43910, 0.56521739130435, 0.51521739130435, 0.47727272727273
43911, 0.52173913043478, 0.51521739130435, 0.022727272727273
43912, 0.54347826086956, 0.51521739130435, 0.045454545454545
43913, 0.52173913043478, 0.48913043478261, 0.045454545454545
43914, 0.52173913043478, 0.51521739130435, 0.068181818181818
43915, 0.54347826086956, 0.51521739130435, 0.090909090909091
43916, 0.52173913043478, 0.48913043478261, 0.090909090909091
43917, 0.52173913043478, 0.51521739130435, 0.11363636363636
43918, 0.54347826086957, 0.51521739130435, 0.13636363636364
43919, 0.52173913043478, 0.48913043478261, 0.13636363636364
43920, 0.52173913043478, 0.51521739130435, 0.15909090909091
43921, 0.54347826086956, 0.51521739130435, 0.18181818181818
43922, 0.52173913043478, 0.48913043478261, 0.18181818181818
43923, 0.52173913043478, 0.51521739130435, 0.20454545454545
43924, 0.54347826086956, 0.51521739130435, 0.22727272727273
43925, 0.52173913043478, 0.48913043478261, 0.22727272727273
43926, 0.52173913043478, 0.51521739130435, 0.25
43927, 0.54347826086956, 0.51521739130435, 0.27272727272727
43928, 0.52173913043478, 0.48913043478261, 0.27272727272727
43929, 0.52173913043478, 0.51521739130435, 0.29545454545455
43930, 0.54347826086956, 0.51521739130435, 0.31818181818182
43931, 0.52173913043478, 0.48913043478261, 0.31818181818182
43932, 0.52173913043478, 0.51521739130435, 0.34090909090909
43933, 0.54347826086956, 0.51521739130435, 0.36363636363636
43934, 0.52173913043478, 0.48913043478261, 0.36363636363636
43935, 0.52173913043478, 0.51521739130435, 0.38636363636364
43936, 0.54347826086956, 0.51521739130435, 0.40909090909091
43937, 0.52173913043478, 0.48913043478261, 0.40909090909091
43938, 0.52173913043478, 0.51521739130435, 0.43181818181818
43939, 0.54347826086956, 0.51521739130435, 0.45454545454545
43940, 0.52173913043478, 0.48913043478261, 0.45454545454545
43941, 0.52173913043478, 0.51521739130435, 0.47727272727273
43942, 0.47826086956522, 0.51521739130435, 0.022727272727273
43943, 0.5, 0.51521739130435, 0.045454545454545
43944, 0.47826086956522, 0.48913043478261, 0.045454545454545
43945, 0.47826086956522, 0.51521739130435, 0.068181818181818
43946, 0.5, 0.51521739130435, 0.090909090909091
43947, 0.47826086956522, 0.48913043478261, 0.090909090909091
43948, 0.47826086956522, 0.51521739130435, 0.11363636363636
43949, 0.5, 0.51521739130435, 0.13636363636364
43950, 0.47826086956522, 0.48913043478261, 0.13636363636364
43951, 0.47826086956522, 0.51521739130435, 0.15909090909091
43952, 0.5, 0.51521739130435, 0.18181818181818
43953, 0.47826086956522, 0.48913043478261, 0.18181818181818
43954, 0.47826086956522, 0.51521739130435, 0.20454545454545
43955, 0.5, 0.51521739130435, 0.22727272727273
43956, 0.47826086956522, 0.48913043478261, 0.22727272727273
43957, 0.47826086956522, 0.51521739130435, 0.25
43958, 0.5, 0.51521739130435, 0.27272727272727
43959, 0.47826086956522, 0.48913043478261, 0.27272727272727
43960, 0.47826086956522, 0.51521739130435, 0.29545454545455
43961, 0.5, 0.51521739130435, 0.31818181818182
43962, 0.47826086956522, 0.48913043478261, 0.31818181818182
43963, 0.47826086956522, 0.51521739130435, 0.34090909090909
43964, 0.5, 0.51521739130435, 0.36363636363636
43965, 0.47826086956522, 0.48913043478261, 0.36363636363636
43966, 0.47826086956522, 0.51521739130435, 0.38636363636364
43967, 0.5, 0.51521739130435, 0.40909090909091
43968, 0.47826086956522, 0.48913043478261, 0.40909090909091
43969, 0.47826086956522, 0.51521739130435, 0.43181818181818
43970, 0.5, 0.51521739130435, 0.45454545454545
43971, 0.47826086956522, 0.48913043478261, 0.45454545454545
43972, 0.47826086956522, 0.51521739130435, 0.47727272727273
43973, 0.43478260869565, 0.51521739130435, 0.022727272727273
43974, 0.45652173913043, 0.51521739130435, 0.045454545454545
43975, 0.43478260869565, 0.48913043478261, 0.045454545454545
43976, 0.43478260869565, 0.51521739130435, 0.068181818181818
43977, 0.45652173913043, 0.51521739130435, 0.090909090909091
43978, 0.43478260869565, 0.48913043478261, 0.090909090909091
43979, 0.43478260869565, 0.51521739130435, 0.11363636363636
43980, 0.45652173913043, 0.51521739130435, 0.13636363636364
43981, 0.43478260869565, 0.48913043478261, 0.13636363636364
43982, 0.43478260869565, 0.51521739130435, 0.15909090909091
43983, 0.45652173913043, 0.51521739130435, 0.18181818181818
43984, 0.43478260869565, 0.48913043478261, 0.18181818181818
43985, 0.43478260869565, 0.51521739130435, 0.20454545454545
43986, 0.45652173913043, 0.51521739130435, 0.22727272727273
43987, 0.43478260869565, 0.48913043478261, 0.22727272727273
43988, 0.43478260869565, 0.51521739130435, 0.25
43989, 0.45652173913043, 0.51521739130435, 0.27272727272727
43990, 0.43478260869565, 0.48913043478261, 0.27272727272727
43991, 0.43478260869565, 0.51521739130435, 0.29545454545455
43992, 0.45652173913043, 0.51521739130435, 0.31818181818182
43993, 0.43478260869565, 0.48913043478261, 0.31818181818182
43994, 0.43478260869565, 0.51521739130435, 0.34090909090909
43995, 0.45652173913043, 0.51521739130435, 0.36363636363636
43996, 0.43478260869565, 0.48913043478261, 0.36363636363636
43997, 0.43478260869565, 0.51521739130435, 0.38636363636364
43998, 0.45652173913043, 0.51521739130435, 0.40909090909091
43999, 0.43478260869565, 0.48913043478261, 0.40909090909091
44000, 0.43478260869565, 0.51521739130435, 0.43181818181818
44001, 0.45652173913043, 0.51521739130435, 0.45454545454545
44002, 0.43478260869565, 0.48913043478261, 0.45454545454545
44003, 0.43478260869565, 0.51521739130435, 0.47727272727273
44004, 0.39130434782609, 0.51521739130435, 0.022727272727273
44005, 0.41304347826087, 0.51521739130435, 0.045454545454545
44006, 0.39130434782609, 0.48913043478261, 0.045454545454545
44007, 0.39130434782609, 0.51521739130435, 0.068181818181818
44008, 0.41304347826087, 0.51521739130435, 0.090909090909091
44009, 0.39130434782609, 0.48913043478261, 0.090909090909091
44010, 0.39130434782609, 0.51521739130435, 0.11363636363636
44011, 0.41304347826087, 0.51521739130435, 0.13636363636364
44012, 0.39130434782609, 0.48913043478261, 0.13636363636364
44013, 0.39130434782609, 0.51521739130435, 0.15909090909091
44014, 0.41304347826087, 0.51521739130435, 0.18181818181818
44015, 0.39130434782609, 0.48913043478261, 0.18181818181818
44016, 0.39130434782609, 0.51521739130435, 0.20454545454545
44017, 0.41304347826087, 0.51521739130435, 0.22727272727273
44018, 0.39130434782609, 0.48913043478261, 0.22727272727273
44019, 0.39130434782609, 0.51521739130435, 0.25
44020, 0.41304347826087, 0.51521739130435, 0.27272727272727
44021, 0.39130434782609, 0.48913043478261, 0.27272727272727
44022, 0.39130434782609, 0.51521739130435, 0.29545454545455
44023, 0.41304347826087, 0.51521739130435, 0.31818181818182
44024, 0.39130434782609, 0.48913043478261, 0.31818181818182
44025, 0.39130434782609, 0.51521739130435, 0.34090909090909
44026, 0.41304347826087, 0.51521739130435, 0.36363636363636
44027, 0.39130434782609, 0.48913043478261, 0.36363636363636
44028, 0.39130434782609, 0.51521739130435, 0.38636363636364
44029, 0.41304347826087, 0.51521739130435, 0.40909090909091
44030, 0.39130434782609, 0.48913043478261, 0.40909090909091
44031, 0.39130434782609, 0.51521739130435, 0.43181818181818
44032, 0.41304347826087, 0.51521739130435, 0.45454545454545
44033, 0.39130434782609, 0.48913043478261, 0.45454545454545
44034, 0.39130434782609, 0.51521739130435, 0.47727272727273
44035, 0.34782608695652, 0.51521739130435, 0.022727272727273
44036, 0.3695652173913, 0.51521739130435, 0.045454545454545
44037, 0.34782608695652, 0.48913043478261, 0.045454545454545
44038, 0.34782608695652, 0.51521739130435, 0.068181818181818
44039, 0.3695652173913, 0.51521739130435, 0.090909090909091
44040, 0.34782608695652, 0.48913043478261, 0.090909090909091
44041, 0.34782608695652, 0.51521739130435, 0.11363636363636
44042, 0.3695652173913, 0.51521739130435, 0.13636363636364
44043, 0.34782608695652, 0.48913043478261, 0.13636363636364
44044, 0.34782608695652, 0.51521739130435, 0.15909090909091
44045, 0.3695652173913, 0.51521739130435, 0.18181818181818
44046, 0.34782608695652, 0.48913043478261, 0.18181818181818
44047, 0.34782608695652, 0.51521739130435, 0.20454545454545
44048, 0.3695652173913, 0.51521739130435, 0.22727272727273
44049, 0.34782608695652, 0.48913043478261, 0.22727272727273
44050, 0.34782608695652, 0.51521739130435, 0.25
44051, 0.3695652173913, 0.51521739130435, 0.27272727272727
44052, 0.34782608695652, 0.48913043478261, 0.27272727272727
44053, 0.34782608695652, 0.51521739130435, 0.29545454545455
44054, 0.3695652173913, 0.51521739130435, 0.31818181818182
44055, 0.34782608695652, 0.48913043478261, 0.31818181818182
44056, 0.34782608695652, 0.51521739130435, 0.34090909090909
44057, 0.3695652173913, 0.51521739130435, 0.36363636363636
44058, 0.34782608695652, 0.48913043478261, 0.36363636363636
44059, 0.34782608695652, 0.51521739130435, 0.38636363636364
44060, 0.3695652173913, 0.51521739130435, 0.40909090909091
44061, 0.34782608695652, 0.48913043478261, 0.40909090909091
44062, 0.34782608695652, 0.51521739130435, 0.43181818181818
44063, 0.3695652173913, 0.51521739130435, 0.45454545454545
44064, 0.34782608695652, 0.48913043478261, 0.45454545454545
44065, 0.34782608695652, 0.51521739130435, 0.47727272727273
44066, 0.30434782608696, 0.51521739130435, 0.022727272727273
44067, 0.32608695652174, 0.51521739130435, 0.045454545454545
44068, 0.30434782608696, 0.48913043478261, 0.045454545454545
44069, 0.30434782608696, 0.51521739130435, 0.068181818181818
44070, 0.32608695652174, 0.51521739130435, 0.090909090909091
44071, 0.30434782608696, 0.48913043478261, 0.090909090909091
44072, 0.30434782608696, 0.51521739130435, 0.11363636363636
44073, 0.32608695652174, 0.51521739130435, 0.13636363636364
44074, 0.30434782608696, 0.48913043478261, 0.13636363636364
44075, 0.30434782608696, 0.51521739130435, 0.15909090909091
44076, 0.32608695652174, 0.51521739130435, 0.18181818181818
44077, 0.30434782608696, 0.48913043478261, 0.18181818181818
44078, 0.30434782608696, 0.51521739130435, 0.20454545454545
44079, 0.32608695652174, 0.51521739130435, 0.22727272727273
44080, 0.30434782608696, 0.48913043478261, 0.22727272727273
44081, 0.30434782608696, 0.51521739130435, 0.25
44082, 0.32608695652174, 0.51521739130435, 0.27272727272727
44083, 0.30434782608696, 0.48913043478261, 0.27272727272727
44084, 0.30434782608696, 0.51521739130435, 0.29545454545455
44085, 0.32608695652174, 0.51521739130435, 0.31818181818182
44086, 0.30434782608696, 0.48913043478261, 0.31818181818182
44087, 0.30434782608696, 0.51521739130435, 0.34090909090909
44088, 0.32608695652174, 0.51521739130435, 0.36363636363636
44089, 0.30434782608696, 0.48913043478261, 0.36363636363636
44090, 0.30434782608696, 0.51521739130435, 0.38636363636364
44091, 0.32608695652174, 0.51521739130435, 0.40909090909091
44092, 0.30434782608696, 0.48913043478261, 0.40909090909091
44093, 0.30434782608696, 0.51521739130435, 0.43181818181818
44094, 0.32608695652174, 0.51521739130435, 0.45454545454545
44095, 0.30434782608696, 0.48913043478261, 0.45454545454545
44096, 0.30434782608696, 0.51521739130435, 0.47727272727273
44097, 0.26086956521739, 0.51521739130435, 0.022727272727273
44098, 0.28260869565217, 0.51521739130435, 0.045454545454545
44099, 0.26086956521739, 0.48913043478261, 0.045454545454545
44100, 0.26086956521739, 0.51521739130435, 0.068181818181818
44101, 0.28260869565217, 0.51521739130435, 0.090909090909091
44102, 0.26086956521739, 0.48913043478261, 0.090909090909091
44103, 0.26086956521739, 0.51521739130435, 0.11363636363636
44104, 0.28260869565217, 0.51521739130435, 0.13636363636364
44105, 0.26086956521739, 0.48913043478261, 0.13636363636364
44106, 0.26086956521739, 0.51521739130435, 0.15909090909091
44107, 0.28260869565217, 0.51521739130435, 0.18181818181818
44108, 0.26086956521739, 0.48913043478261, 0.18181818181818
44109, 0.26086956521739, 0.51521739130435, 0.20454545454545
44110, 0.28260869565217, 0.51521739130435, 0.22727272727273
44111, 0.26086956521739, 0.48913043478261, 0.22727272727273
44112, 0.26086956521739, 0.51521739130435, 0.25
44113, 0.28260869565217, 0.51521739130435, 0.27272727272727
44114, 0.26086956521739, 0.48913043478261, 0.27272727272727
44115, 0.26086956521739, 0.51521739130435, 0.29545454545455
44116, 0.28260869565217, 0.51521739130435, 0.31818181818182
44117, 0.26086956521739, 0.48913043478261, 0.31818181818182
44118, 0.26086956521739, 0.51521739130435, 0.34090909090909
44119, 0.28260869565217, 0.51521739130435, 0.36363636363636
44120, 0.26086956521739, 0.48913043478261, 0.36363636363636
44121, 0.26086956521739, 0.51521739130435, 0.38636363636364
44122, 0.28260869565217, 0.51521739130435, 0.40909090909091
44123, 0.26086956521739, 0.48913043478261, 0.40909090909091
44124, 0.26086956521739, 0.51521739130435, 0.43181818181818
44125, 0.28260869565217, 0.51521739130435, 0.45454545454545
44126, 0.26086956521739, 0.48913043478261, 0.45454545454545
44127, 0.26086956521739, 0.51521739130435, 0.47727272727273
44128, 0.21739130434783, 0.51521739130435, 0.022727272727273
44129, 0.23913043478261, 0.51521739130435, 0.045454545454545
44130, 0.21739130434783, 0.48913043478261, 0.045454545454545
44131, 0.21739130434783, 0.51521739130435, 0.068181818181818
44132, 0.23913043478261, 0.51521739130435, 0.090909090909091
44133, 0.21739130434783, 0.48913043478261, 0.090909090909091
44134, 0.21739130434783, 0.51521739130435, 0.11363636363636
44135, 0.23913043478261, 0.51521739130435, 0.13636363636364
44136, 0.21739130434783, 0.48913043478261, 0.13636363636364
44137, 0.21739130434783, 0.51521739130435, 0.15909090909091
44138, 0.23913043478261, 0.51521739130435, 0.18181818181818
44139, 0.21739130434783, 0.48913043478261, 0.18181818181818
44140, 0.21739130434783, 0.51521739130435, 0.20454545454545
44141, 0.23913043478261, 0.51521739130435, 0.22727272727273
44142, 0.21739130434783, 0.48913043478261, 0.22727272727273
44143, 0.21739130434783, 0.51521739130435, 0.25
44144, 0.23913043478261, 0.51521739130435, 0.27272727272727
44145, 0.21739130434783, 0.48913043478261, 0.27272727272727
44146, 0.21739130434783, 0.51521739130435, 0.29545454545455
44147, 0.23913043478261, 0.51521739130435, 0.31818181818182
44148, 0.21739130434783, 0.48913043478261, 0.31818181818182
44149, 0.21739130434783, 0.51521739130435, 0.34090909090909
44150, 0.23913043478261, 0.51521739130435, 0.36363636363636
44151, 0.21739130434783, 0.48913043478261, 0.36363636363636
44152, 0.21739130434783, 0.51521739130435, 0.38636363636364
44153, 0.23913043478261, 0.51521739130435, 0.40909090909091
44154, 0.21739130434783, 0.48913043478261, 0.40909090909091
44155, 0.21739130434783, 0.51521739130435, 0.43181818181818
44156, 0.23913043478261, 0.51521739130435, 0.45454545454545
44157, 0.21739130434783, 0.48913043478261, 0.45454545454545
44158, 0.21739130434783, 0.51521739130435, 0.47727272727273
44159, 0.17391304347826, 0.51521739130435, 0.022727272727273
44160, 0.19565217391304, 0.51521739130435, 0.045454545454545
44161, 0.17391304347826, 0.48913043478261, 0.045454545454545
44162, 0.17391304347826, 0.51521739130435, 0.068181818181818
44163, 0.19565217391304, 0.51521739130435, 0.090909090909091
44164, 0.17391304347826, 0.48913043478261, 0.090909090909091
44165, 0.17391304347826, 0.51521739130435, 0.11363636363636
44166, 0.19565217391304, 0.51521739130435, 0.13636363636364
44167, 0.17391304347826, 0.48913043478261, 0.13636363636364
44168, 0.17391304347826, 0.51521739130435, 0.15909090909091
44169, 0.19565217391304, 0.51521739130435, 0.18181818181818
44170, 0.17391304347826, 0.48913043478261, 0.18181818181818
44171, 0.17391304347826, 0.51521739130435, 0.20454545454545
44172, 0.19565217391304, 0.51521739130435, 0.22727272727273
44173, 0.17391304347826, 0.48913043478261, 0.22727272727273
44174, 0.17391304347826, 0.51521739130435, 0.25
44175, 0.19565217391304, 0.51521739130435, 0.27272727272727
44176, 0.17391304347826, 0.48913043478261, 0.27272727272727
44177, 0.17391304347826, 0.51521739130435, 0.29545454545455
44178, 0.19565217391304, 0.51521739130435, 0.31818181818182
44179, 0.17391304347826, 0.48913043478261, 0.31818181818182
44180, 0.17391304347826, 0.51521739130435, 0.34090909090909
44181, 0.19565217391304, 0.51521739130435, 0.36363636363636
44182, 0.17391304347826, 0.48913043478261, 0.36363636363636
44183, 0.17391304347826, 0.51521739130435, 0.38636363636364
44184, 0.19565217391304, 0.51521739130435, 0.40909090909091
44185, 0.17391304347826, 0.48913043478261, 0.40909090909091
44186, 0.17391304347826, 0.51521739130435, 0.43181818181818
44187, 0.19565217391304, 0.51521739130435, 0.45454545454545
44188, 0.17391304347826, 0.48913043478261, 0.45454545454545
44189, 0.17391304347826, 0.51521739130435, 0.47727272727273
44190, 0.1304347826087, 0.51521739130435, 0.022727272727273
44191, 0.15217391304348, 0.51521739130435, 0.045454545454545
44192, 0.1304347826087, 0.48913043478261, 0.045454545454545
44193, 0.1304347826087, 0.51521739130435, 0.068181818181818
44194, 0.15217391304348, 0.51521739130435, 0.090909090909091
44195, 0.1304347826087, 0.48913043478261, 0.090909090909091
44196, 0.1304347826087, 0.51521739130435, 0.11363636363636
44197, 0.15217391304348, 0.51521739130435, 0.13636363636364
44198, 0.1304347826087, 0.48913043478261, 0.13636363636364
44199, 0.1304347826087, 0.51521739130435, 0.15909090909091
44200, 0.15217391304348, 0.51521739130435, 0.18181818181818
44201, 0.1304347826087, 0.48913043478261, 0.18181818181818
44202, 0.1304347826087, 0.51521739130435, 0.20454545454545
44203, 0.15217391304348, 0.51521739130435, 0.22727272727273
44204, 0.1304347826087, 0.48913043478261, 0.22727272727273
44205, 0.1304347826087, 0.51521739130435, 0.25
44206, 0.15217391304348, 0.51521739130435, 0.27272727272727
44207, 0.1304347826087, 0.48913043478261, 0.27272727272727
44208, 0.1304347826087, 0.51521739130435, 0.29545454545455
44209, 0.15217391304348, 0.51521739130435, 0.31818181818182
44210, 0.1304347826087, 0.48913043478261, 0.31818181818182
44211, 0.1304347826087, 0.51521739130435, 0.34090909090909
44212, 0.15217391304348, 0.51521739130435, 0.36363636363636
44213, 0.1304347826087, 0.48913043478261, 0.36363636363636
44214, 0.1304347826087, 0.51521739130435, 0.38636363636364
44215, 0.15217391304348, 0.51521739130435, 0.40909090909091
44216, 0.1304347826087, 0.48913043478261, 0.40909090909091
44217, 0.1304347826087, 0.51521739130435, 0.43181818181818
44218, 0.15217391304348, 0.51521739130435, 0.45454545454545
44219, 0.1304347826087, 0.48913043478261, 0.45454545454545
44220, 0.1304347826087, 0.51521739130435, 0.47727272727273
44221, 0.08695652173913, 0.51521739130435, 0.022727272727273
44222, 0.10869565217391, 0.51521739130435, 0.045454545454545
44223, 0.08695652173913, 0.48913043478261, 0.045454545454545
44224, 0.08695652173913, 0.51521739130435, 0.068181818181818
44225, 0.10869565217391, 0.51521739130435, 0.090909090909091
44226, 0.08695652173913, 0.48913043478261, 0.090909090909091
44227, 0.08695652173913, 0.51521739130435, 0.11363636363636
44228, 0.10869565217391, 0.51521739130435, 0.13636363636364
44229, 0.08695652173913, 0.48913043478261, 0.13636363636364
44230, 0.08695652173913, 0.51521739130435, 0.15909090909091
44231, 0.10869565217391, 0.51521739130435, 0.18181818181818
44232, 0.08695652173913, 0.48913043478261, 0.18181818181818
44233, 0.08695652173913, 0.51521739130435, 0.20454545454545
44234, 0.10869565217391, 0.51521739130435, 0.22727272727273
44235, 0.08695652173913, 0.48913043478261, 0.22727272727273
44236, 0.08695652173913, 0.51521739130435, 0.25
44237, 0.10869565217391, 0.51521739130435, 0.27272727272727
44238, 0.08695652173913, 0.48913043478261, 0.27272727272727
44239, 0.08695652173913, 0.51521739130435, 0.29545454545455
44240, 0.10869565217391, 0.51521739130435, 0.31818181818182
44241, 0.08695652173913, 0.48913043478261, 0.31818181818182
44242, 0.08695652173913, 0.51521739130435, 0.34090909090909
44243, 0.10869565217391, 0.51521739130435, 0.36363636363636
44244, 0.08695652173913, 0.48913043478261, 0.36363636363636
44245, 0.08695652173913, 0.51521739130435, 0.38636363636364
44246, 0.10869565217391, 0.51521739130435, 0.40909090909091
44247, 0.08695652173913, 0.48913043478261, 0.40909090909091
44248, 0.08695652173913, 0.51521739130435, 0.43181818181818
44249, 0.10869565217391, 0.51521739130435, 0.45454545454545
44250, 0.08695652173913, 0.48913043478261, 0.45454545454545
44251, 0.08695652173913, 0.51521739130435, 0.47727272727273
44252, 0.043478260869565, 0.51521739130435, 0.022727272727273
44253, 0.065217391304348, 0.51521739130435, 0.045454545454545
44254, 0.043478260869565, 0.48913043478261, 0.045454545454545
44255, 0.043478260869565, 0.51521739130435, 0.068181818181818
44256, 0.065217391304348, 0.51521739130435, 0.090909090909091
44257, 0.043478260869565, 0.48913043478261, 0.090909090909091
44258, 0.043478260869565, 0.51521739130435, 0.11363636363636
44259, 0.065217391304348, 0.51521739130435, 0.13636363636364
44260, 0.043478260869565, 0.48913043478261, 0.13636363636364
44261, 0.043478260869565, 0.51521739130435, 0.15909090909091
44262, 0.065217391304348, 0.51521739130435, 0.18181818181818
44263, 0.043478260869565, 0.48913043478261, 0.18181818181818
44264, 0.043478260869565, 0.51521739130435, 0.20454545454545
44265, 0.065217391304348, 0.51521739130435, 0.22727272727273
44266, 0.043478260869565, 0.48913043478261, 0.22727272727273
44267, 0.043478260869565, 0.51521739130435, 0.25
44268, 0.065217391304348, 0.51521739130435, 0.27272727272727
44269, 0.043478260869565, 0.48913043478261, 0.27272727272727
44270, 0.043478260869565, 0.51521739130435, 0.29545454545455
44271, 0.065217391304348, 0.51521739130435, 0.31818181818182
44272, 0.043478260869565, 0.48913043478261, 0.31818181818182
44273, 0.043478260869565, 0.51521739130435, 0.34090909090909
44274, 0.065217391304348, 0.51521739130435, 0.36363636363636
44275, 0.043478260869565, 0.48913043478261, 0.36363636363636
44276, 0.043478260869565, 0.51521739130435, 0.38636363636364
44277, 0.065217391304348, 0.51521739130435, 0.40909090909091
44278, 0.043478260869565, 0.48913043478261, 0.40909090909091
44279, 0.043478260869565, 0.51521739130435, 0.43181818181818
44280, 0.065217391304348, 0.51521739130435, 0.45454545454545
44281, 0.043478260869565, 0.48913043478261, 0.45454545454545
44282, 0.043478260869565, 0.51521739130435, 0.47727272727273
44283, 0.021739130434783, 0.51521739130435, 0.045454545454545
44284, 0.021739130434783, 0.51521739130435, 0.090909090909091
44285, 0.021739130434783, 0.51521739130435, 0.13636363636364
44286, 0.021739130434783, 0.51521739130435, 0.18181818181818
44287, 0.021739130434783, 0.51521739130435, 0.22727272727273
44288, 0.021739130434783, 0.51521739130435, 0.27272727272727
44289, 0.021739130434783, 0.51521739130435, 0.31818181818182
44290, 0.021739130434783, 0.51521739130435, 0.36363636363636
44291, 0.021739130434783, 0.51521739130435, 0.40909090909091
44292, 0.021739130434783, 0.51521739130435, 0.45454545454545
44293, 0.95652173913043, 0.56739130434783, 0.022727272727273
44294, 0.97826086956522, 0.56739130434783, 0.045454545454545
44295, 0.95652173913043, 0.54130434782609, 0.045454545454545
44296, 0.95652173913043, 0.56739130434783, 0.068181818181818
44297, 0.97826086956522, 0.56739130434783, 0.090909090909091
44298, 0.95652173913043, 0.54130434782609, 0.090909090909091
44299, 0.95652173913043, 0.56739130434783, 0.11363636363636
44300, 0.97826086956522, 0.56739130434783, 0.13636363636364
44301, 0.95652173913043, 0.54130434782609, 0.13636363636364
44302, 0.95652173913043, 0.56739130434783, 0.15909090909091
44303, 0.97826086956522, 0.56739130434783, 0.18181818181818
44304, 0.95652173913043, 0.54130434782609, 0.18181818181818
44305, 0.95652173913043, 0.56739130434783, 0.20454545454545
44306, 0.97826086956522, 0.56739130434783, 0.22727272727273
44307, 0.95652173913043, 0.54130434782609, 0.22727272727273
44308, 0.95652173913044, 0.56739130434783, 0.25
44309, 0.97826086956522, 0.56739130434783, 0.27272727272727
44310, 0.95652173913044, 0.54130434782609, 0.27272727272727
44311, 0.95652173913044, 0.56739130434783, 0.29545454545455
44312, 0.97826086956522, 0.56739130434783, 0.31818181818182
44313, 0.95652173913043, 0.54130434782609, 0.31818181818182
44314, 0.95652173913043, 0.56739130434783, 0.34090909090909
44315, 0.97826086956522, 0.56739130434783, 0.36363636363636
44316, 0.95652173913043, 0.54130434782609, 0.36363636363636
44317, 0.95652173913043, 0.56739130434783, 0.38636363636364
44318, 0.97826086956522, 0.56739130434783, 0.40909090909091
44319, 0.95652173913043, 0.54130434782609, 0.40909090909091
44320, 0.95652173913043, 0.56739130434783, 0.43181818181818
44321, 0.97826086956522, 0.56739130434783, 0.45454545454545
44322, 0.95652173913043, 0.54130434782609, 0.45454545454545
44323, 0.95652173913043, 0.56739130434783, 0.47727272727273
44324, 0.91304347826087, 0.56739130434783, 0.022727272727273
44325, 0.93478260869565, 0.56739130434783, 0.045454545454545
44326, 0.91304347826087, 0.54130434782609, 0.045454545454545
44327, 0.91304347826087, 0.56739130434783, 0.068181818181818
44328, 0.93478260869565, 0.56739130434783, 0.090909090909091
44329, 0.91304347826087, 0.54130434782609, 0.090909090909091
44330, 0.91304347826087, 0.56739130434783, 0.11363636363636
44331, 0.93478260869565, 0.56739130434783, 0.13636363636364
44332, 0.91304347826087, 0.54130434782609, 0.13636363636364
44333, 0.91304347826087, 0.56739130434783, 0.15909090909091
44334, 0.93478260869565, 0.56739130434783, 0.18181818181818
44335, 0.91304347826087, 0.54130434782609, 0.18181818181818
44336, 0.91304347826087, 0.56739130434783, 0.20454545454545
44337, 0.93478260869565, 0.56739130434783, 0.22727272727273
44338, 0.91304347826087, 0.54130434782609, 0.22727272727273
44339, 0.91304347826087, 0.56739130434783, 0.25
44340, 0.93478260869565, 0.56739130434783, 0.27272727272727
44341, 0.91304347826087, 0.54130434782609, 0.27272727272727
44342, 0.91304347826087, 0.56739130434783, 0.29545454545455
44343, 0.93478260869565, 0.56739130434783, 0.31818181818182
44344, 0.91304347826087, 0.54130434782609, 0.31818181818182
44345, 0.91304347826087, 0.56739130434783, 0.34090909090909
44346, 0.93478260869565, 0.56739130434783, 0.36363636363636
44347, 0.91304347826087, 0.54130434782609, 0.36363636363636
44348, 0.91304347826087, 0.56739130434783, 0.38636363636364
44349, 0.93478260869565, 0.56739130434783, 0.40909090909091
44350, 0.91304347826087, 0.54130434782609, 0.40909090909091
44351, 0.91304347826087, 0.56739130434783, 0.43181818181818
44352, 0.93478260869565, 0.56739130434783, 0.45454545454545
44353, 0.91304347826087, 0.54130434782609, 0.45454545454545
44354, 0.91304347826087, 0.56739130434783, 0.47727272727273
44355, 0.8695652173913, 0.56739130434783, 0.022727272727273
44356, 0.89130434782609, 0.56739130434783, 0.045454545454545
44357, 0.8695652173913, 0.54130434782609, 0.045454545454545
44358, 0.8695652173913, 0.56739130434783, 0.068181818181818
44359, 0.89130434782609, 0.56739130434783, 0.090909090909091
44360, 0.8695652173913, 0.54130434782609, 0.090909090909091
44361, 0.8695652173913, 0.56739130434783, 0.11363636363636
44362, 0.89130434782609, 0.56739130434783, 0.13636363636364
44363, 0.8695652173913, 0.54130434782609, 0.13636363636364
44364, 0.8695652173913, 0.56739130434783, 0.15909090909091
44365, 0.89130434782609, 0.56739130434783, 0.18181818181818
44366, 0.8695652173913, 0.54130434782609, 0.18181818181818
44367, 0.8695652173913, 0.56739130434783, 0.20454545454545
44368, 0.89130434782609, 0.56739130434783, 0.22727272727273
44369, 0.8695652173913, 0.54130434782609, 0.22727272727273
44370, 0.8695652173913, 0.56739130434783, 0.25
44371, 0.89130434782609, 0.56739130434783, 0.27272727272727
44372, 0.8695652173913, 0.54130434782609, 0.27272727272727
44373, 0.8695652173913, 0.56739130434783, 0.29545454545455
44374, 0.89130434782609, 0.56739130434783, 0.31818181818182
44375, 0.8695652173913, 0.54130434782609, 0.31818181818182
44376, 0.8695652173913, 0.56739130434783, 0.34090909090909
44377, 0.89130434782609, 0.56739130434783, 0.36363636363636
44378, 0.8695652173913, 0.54130434782609, 0.36363636363636
44379, 0.8695652173913, 0.56739130434783, 0.38636363636364
44380, 0.89130434782609, 0.56739130434783, 0.40909090909091
44381, 0.8695652173913, 0.54130434782609, 0.40909090909091
44382, 0.8695652173913, 0.56739130434783, 0.43181818181818
44383, 0.89130434782609, 0.56739130434783, 0.45454545454545
44384, 0.8695652173913, 0.54130434782609, 0.45454545454545
44385, 0.8695652173913, 0.56739130434783, 0.47727272727273
44386, 0.82608695652174, 0.56739130434783, 0.022727272727273
44387, 0.84782608695652, 0.56739130434783, 0.045454545454545
44388, 0.82608695652174, 0.54130434782609, 0.045454545454545
44389, 0.82608695652174, 0.56739130434783, 0.068181818181818
44390, 0.84782608695652, 0.56739130434783, 0.090909090909091
44391, 0.82608695652174, 0.54130434782609, 0.090909090909091
44392, 0.82608695652174, 0.56739130434783, 0.11363636363636
44393, 0.84782608695652, 0.56739130434783, 0.13636363636364
44394, 0.82608695652174, 0.54130434782609, 0.13636363636364
44395, 0.82608695652174, 0.56739130434783, 0.15909090909091
44396, 0.84782608695652, 0.56739130434783, 0.18181818181818
44397, 0.82608695652174, 0.54130434782609, 0.18181818181818
44398, 0.82608695652174, 0.56739130434783, 0.20454545454545
44399, 0.84782608695652, 0.56739130434783, 0.22727272727273
44400, 0.82608695652174, 0.54130434782609, 0.22727272727273
44401, 0.82608695652174, 0.56739130434783, 0.25
44402, 0.84782608695652, 0.56739130434783, 0.27272727272727
44403, 0.82608695652174, 0.54130434782609, 0.27272727272727
44404, 0.82608695652174, 0.56739130434783, 0.29545454545455
44405, 0.84782608695652, 0.56739130434783, 0.31818181818182
44406, 0.82608695652174, 0.54130434782609, 0.31818181818182
44407, 0.82608695652174, 0.56739130434783, 0.34090909090909
44408, 0.84782608695652, 0.56739130434783, 0.36363636363636
44409, 0.82608695652174, 0.54130434782609, 0.36363636363636
44410, 0.82608695652174, 0.56739130434783, 0.38636363636364
44411, 0.84782608695652, 0.56739130434783, 0.40909090909091
44412, 0.82608695652174, 0.54130434782609, 0.40909090909091
44413, 0.82608695652174, 0.56739130434783, 0.43181818181818
44414, 0.84782608695652, 0.56739130434783, 0.45454545454545
44415, 0.82608695652174, 0.54130434782609, 0.45454545454545
44416, 0.82608695652174, 0.56739130434783, 0.47727272727273
44417, 0.78260869565217, 0.56739130434783, 0.022727272727273
44418, 0.80434782608696, 0.56739130434783, 0.045454545454545
44419, 0.78260869565217, 0.54130434782609, 0.045454545454545
44420, 0.78260869565217, 0.56739130434783, 0.068181818181818
44421, 0.80434782608696, 0.56739130434783, 0.090909090909091
44422, 0.78260869565217, 0.54130434782609, 0.090909090909091
44423, 0.78260869565217, 0.56739130434783, 0.11363636363636
44424, 0.80434782608696, 0.56739130434783, 0.13636363636364
44425, 0.78260869565217, 0.54130434782609, 0.13636363636364
44426, 0.78260869565217, 0.56739130434783, 0.15909090909091
44427, 0.80434782608696, 0.56739130434783, 0.18181818181818
44428, 0.78260869565217, 0.54130434782609, 0.18181818181818
44429, 0.78260869565217, 0.56739130434783, 0.20454545454545
44430, 0.80434782608696, 0.56739130434783, 0.22727272727273
44431, 0.78260869565217, 0.54130434782609, 0.22727272727273
44432, 0.78260869565217, 0.56739130434783, 0.25
44433, 0.80434782608696, 0.56739130434783, 0.27272727272727
44434, 0.78260869565217, 0.54130434782609, 0.27272727272727
44435, 0.78260869565217, 0.56739130434783, 0.29545454545455
44436, 0.80434782608696, 0.56739130434783, 0.31818181818182
44437, 0.78260869565217, 0.54130434782609, 0.31818181818182
44438, 0.78260869565217, 0.56739130434783, 0.34090909090909
44439, 0.80434782608696, 0.56739130434783, 0.36363636363636
44440, 0.78260869565217, 0.54130434782609, 0.36363636363636
44441, 0.78260869565217, 0.56739130434783, 0.38636363636364
44442, 0.80434782608696, 0.56739130434783, 0.40909090909091
44443, 0.78260869565217, 0.54130434782609, 0.40909090909091
44444, 0.78260869565217, 0.56739130434783, 0.43181818181818
44445, 0.80434782608696, 0.56739130434783, 0.45454545454545
44446, 0.78260869565217, 0.54130434782609, 0.45454545454545
44447, 0.78260869565217, 0.56739130434783, 0.47727272727273
44448, 0.73913043478261, 0.56739130434783, 0.022727272727273
44449, 0.76086956521739, 0.56739130434783, 0.045454545454545
44450, 0.73913043478261, 0.54130434782609, 0.045454545454545
44451, 0.73913043478261, 0.56739130434783, 0.068181818181818
44452, 0.76086956521739, 0.56739130434783, 0.090909090909091
44453, 0.73913043478261, 0.54130434782609, 0.090909090909091
44454, 0.73913043478261, 0.56739130434783, 0.11363636363636
44455, 0.76086956521739, 0.56739130434783, 0.13636363636364
44456, 0.73913043478261, 0.54130434782609, 0.13636363636364
44457, 0.73913043478261, 0.56739130434783, 0.15909090909091
44458, 0.76086956521739, 0.56739130434783, 0.18181818181818
44459, 0.73913043478261, 0.54130434782609, 0.18181818181818
44460, 0.73913043478261, 0.56739130434783, 0.20454545454545
44461, 0.76086956521739, 0.56739130434783, 0.22727272727273
44462, 0.73913043478261, 0.54130434782609, 0.22727272727273
44463, 0.73913043478261, 0.56739130434783, 0.25
44464, 0.76086956521739, 0.56739130434783, 0.27272727272727
44465, 0.73913043478261, 0.54130434782609, 0.27272727272727
44466, 0.73913043478261, 0.56739130434783, 0.29545454545455
44467, 0.76086956521739, 0.56739130434783, 0.31818181818182
44468, 0.73913043478261, 0.54130434782609, 0.31818181818182
44469, 0.73913043478261, 0.56739130434783, 0.34090909090909
44470, 0.76086956521739, 0.56739130434783, 0.36363636363636
44471, 0.73913043478261, 0.54130434782609, 0.36363636363636
44472, 0.73913043478261, 0.56739130434783, 0.38636363636364
44473, 0.76086956521739, 0.56739130434783, 0.40909090909091
44474, 0.73913043478261, 0.54130434782609, 0.40909090909091
44475, 0.73913043478261, 0.56739130434783, 0.43181818181818
44476, 0.76086956521739, 0.56739130434783, 0.45454545454545
44477, 0.73913043478261, 0.54130434782609, 0.45454545454545
44478, 0.73913043478261, 0.56739130434783, 0.47727272727273
44479, 0.69565217391304, 0.56739130434783, 0.022727272727273
44480, 0.71739130434783, 0.56739130434783, 0.045454545454545
44481, 0.69565217391304, 0.54130434782609, 0.045454545454545
44482, 0.69565217391304, 0.56739130434783, 0.068181818181818
44483, 0.71739130434783, 0.56739130434783, 0.090909090909091
44484, 0.69565217391304, 0.54130434782609, 0.090909090909091
44485, 0.69565217391304, 0.56739130434783, 0.11363636363636
44486, 0.71739130434783, 0.56739130434783, 0.13636363636364
44487, 0.69565217391304, 0.54130434782609, 0.13636363636364
44488, 0.69565217391304, 0.56739130434783, 0.15909090909091
44489, 0.71739130434783, 0.56739130434783, 0.18181818181818
44490, 0.69565217391304, 0.54130434782609, 0.18181818181818
44491, 0.69565217391304, 0.56739130434783, 0.20454545454545
44492, 0.71739130434783, 0.56739130434783, 0.22727272727273
44493, 0.69565217391304, 0.54130434782609, 0.22727272727273
44494, 0.69565217391304, 0.56739130434783, 0.25
44495, 0.71739130434783, 0.56739130434783, 0.27272727272727
44496, 0.69565217391304, 0.54130434782609, 0.27272727272727
44497, 0.69565217391304, 0.56739130434783, 0.29545454545455
44498, 0.71739130434783, 0.56739130434783, 0.31818181818182
44499, 0.69565217391304, 0.54130434782609, 0.31818181818182
44500, 0.69565217391304, 0.56739130434783, 0.34090909090909
44501, 0.71739130434783, 0.56739130434783, 0.36363636363636
44502, 0.69565217391304, 0.54130434782609, 0.36363636363636
44503, 0.69565217391304, 0.56739130434783, 0.38636363636364
44504, 0.71739130434783, 0.56739130434783, 0.40909090909091
44505, 0.69565217391304, 0.54130434782609, 0.40909090909091
44506, 0.69565217391304, 0.56739130434783, 0.43181818181818
44507, 0.71739130434783, 0.56739130434783, 0.45454545454545
44508, 0.69565217391304, 0.54130434782609, 0.45454545454545
44509, 0.69565217391304, 0.56739130434783, 0.47727272727273
44510, 0.65217391304348, 0.56739130434783, 0.022727272727273
44511, 0.67391304347826, 0.56739130434783, 0.045454545454545
44512, 0.65217391304348, 0.54130434782609, 0.045454545454545
44513, 0.65217391304348, 0.56739130434783, 0.068181818181818
44514, 0.67391304347826, 0.56739130434783, 0.090909090909091
44515, 0.65217391304348, 0.54130434782609, 0.090909090909091
44516, 0.65217391304348, 0.56739130434783, 0.11363636363636
44517, 0.67391304347826, 0.56739130434783, 0.13636363636364
44518, 0.65217391304348, 0.54130434782609, 0.13636363636364
44519, 0.65217391304348, 0.56739130434783, 0.15909090909091
44520, 0.67391304347826, 0.56739130434783, 0.18181818181818
44521, 0.65217391304348, 0.54130434782609, 0.18181818181818
44522, 0.65217391304348, 0.56739130434783, 0.20454545454545
44523, 0.67391304347826, 0.56739130434783, 0.22727272727273
44524, 0.65217391304348, 0.54130434782609, 0.22727272727273
44525, 0.65217391304348, 0.56739130434783, 0.25
44526, 0.67391304347826, 0.56739130434783, 0.27272727272727
44527, 0.65217391304348, 0.54130434782609, 0.27272727272727
44528, 0.65217391304348, 0.56739130434783, 0.29545454545455
44529, 0.67391304347826, 0.56739130434783, 0.31818181818182
44530, 0.65217391304348, 0.54130434782609, 0.31818181818182
44531, 0.65217391304348, 0.56739130434783, 0.34090909090909
44532, 0.67391304347826, 0.56739130434783, 0.36363636363636
44533, 0.65217391304348, 0.54130434782609, 0.36363636363636
44534, 0.65217391304348, 0.56739130434783, 0.38636363636364
44535, 0.67391304347826, 0.56739130434783, 0.40909090909091
44536, 0.65217391304348, 0.54130434782609, 0.40909090909091
44537, 0.65217391304348, 0.56739130434783, 0.43181818181818
44538, 0.67391304347826, 0.56739130434783, 0.45454545454545
44539, 0.65217391304348, 0.54130434782609, 0.45454545454545
44540, 0.65217391304348, 0.56739130434783, 0.47727272727273
44541, 0.60869565217391, 0.56739130434783, 0.022727272727273
44542, 0.6304347826087, 0.56739130434783, 0.045454545454545
44543, 0.60869565217391, 0.54130434782609, 0.045454545454545
44544, 0.60869565217391, 0.56739130434783, 0.068181818181818
44545, 0.6304347826087, 0.56739130434783, 0.090909090909091
44546, 0.60869565217391, 0.54130434782609, 0.090909090909091
44547, 0.60869565217391, 0.56739130434783, 0.11363636363636
44548, 0.6304347826087, 0.56739130434783, 0.13636363636364
44549, 0.60869565217391, 0.54130434782609, 0.13636363636364
44550, 0.60869565217391, 0.56739130434783, 0.15909090909091
44551, 0.6304347826087, 0.56739130434783, 0.18181818181818
44552, 0.60869565217391, 0.54130434782609, 0.18181818181818
44553, 0.60869565217391, 0.56739130434783, 0.20454545454545
44554, 0.6304347826087, 0.56739130434783, 0.22727272727273
44555, 0.60869565217391, 0.54130434782609, 0.22727272727273
44556, 0.60869565217391, 0.56739130434783, 0.25
44557, 0.6304347826087, 0.56739130434783, 0.27272727272727
44558, 0.60869565217391, 0.54130434782609, 0.27272727272727
44559, 0.60869565217391, 0.56739130434783, 0.29545454545455
44560, 0.6304347826087, 0.56739130434783, 0.31818181818182
44561, 0.60869565217391, 0.54130434782609, 0.31818181818182
44562, 0.60869565217391, 0.56739130434783, 0.34090909090909
44563, 0.6304347826087, 0.56739130434783, 0.36363636363636
44564, 0.60869565217391, 0.54130434782609, 0.36363636363636
44565, 0.60869565217391, 0.56739130434783, 0.38636363636364
44566, 0.6304347826087, 0.56739130434783, 0.40909090909091
44567, 0.60869565217391, 0.54130434782609, 0.40909090909091
44568, 0.60869565217391, 0.56739130434783, 0.43181818181818
44569, 0.6304347826087, 0.56739130434783, 0.45454545454545
44570, 0.60869565217391, 0.54130434782609, 0.45454545454545
44571, 0.60869565217391, 0.56739130434783, 0.47727272727273
44572, 0.56521739130435, 0.56739130434783, 0.022727272727273
44573, 0.58695652173913, 0.56739130434783, 0.045454545454545
44574, 0.56521739130435, 0.54130434782609, 0.045454545454545
44575, 0.56521739130435, 0.56739130434783, 0.068181818181818
44576, 0.58695652173913, 0.56739130434783, 0.090909090909091
44577, 0.56521739130435, 0.54130434782609, 0.090909090909091
44578, 0.56521739130435, 0.56739130434783, 0.11363636363636
44579, 0.58695652173913, 0.56739130434783, 0.13636363636364
44580, 0.56521739130435, 0.54130434782609, 0.13636363636364
44581, 0.56521739130435, 0.56739130434783, 0.15909090909091
44582, 0.58695652173913, 0.56739130434783, 0.18181818181818
44583, 0.56521739130435, 0.54130434782609, 0.18181818181818
44584, 0.56521739130435, 0.56739130434783, 0.20454545454545
44585, 0.58695652173913, 0.56739130434783, 0.22727272727273
44586, 0.56521739130435, 0.54130434782609, 0.22727272727273
44587, 0.56521739130435, 0.56739130434783, 0.25
44588, 0.58695652173913, 0.56739130434783, 0.27272727272727
44589, 0.56521739130435, 0.54130434782609, 0.27272727272727
44590, 0.56521739130435, 0.56739130434783, 0.29545454545455
44591, 0.58695652173913, 0.56739130434783, 0.31818181818182
44592, 0.56521739130435, 0.54130434782609, 0.31818181818182
44593, 0.56521739130435, 0.56739130434783, 0.34090909090909
44594, 0.58695652173913, 0.56739130434783, 0.36363636363636
44595, 0.56521739130435, 0.54130434782609, 0.36363636363636
44596, 0.56521739130435, 0.56739130434783, 0.38636363636364
44597, 0.58695652173913, 0.56739130434783, 0.40909090909091
44598, 0.56521739130435, 0.54130434782609, 0.40909090909091
44599, 0.56521739130435, 0.56739130434783, 0.43181818181818
44600, 0.58695652173913, 0.56739130434783, 0.45454545454545
44601, 0.56521739130435, 0.54130434782609, 0.45454545454545
44602, 0.56521739130435, 0.56739130434783, 0.47727272727273
44603, 0.52173913043478, 0.56739130434783, 0.022727272727273
44604, 0.54347826086956, 0.56739130434783, 0.045454545454545
44605, 0.52173913043478, 0.54130434782609, 0.045454545454545
44606, 0.52173913043478, 0.56739130434783, 0.068181818181818
44607, 0.54347826086956, 0.56739130434783, 0.090909090909091
44608, 0.52173913043478, 0.54130434782609, 0.090909090909091
44609, 0.52173913043478, 0.56739130434783, 0.11363636363636
44610, 0.54347826086957, 0.56739130434783, 0.13636363636364
44611, 0.52173913043478, 0.54130434782609, 0.13636363636364
44612, 0.52173913043478, 0.56739130434783, 0.15909090909091
44613, 0.54347826086956, 0.56739130434783, 0.18181818181818
44614, 0.52173913043478, 0.54130434782609, 0.18181818181818
44615, 0.52173913043478, 0.56739130434783, 0.20454545454545
44616, 0.54347826086956, 0.56739130434783, 0.22727272727273
44617, 0.52173913043478, 0.54130434782609, 0.22727272727273
44618, 0.52173913043478, 0.56739130434783, 0.25
44619, 0.54347826086956, 0.56739130434783, 0.27272727272727
44620, 0.52173913043478, 0.54130434782609, 0.27272727272727
44621, 0.52173913043478, 0.56739130434783, 0.29545454545455
44622, 0.54347826086956, 0.56739130434783, 0.31818181818182
44623, 0.52173913043478, 0.54130434782609, 0.31818181818182
44624, 0.52173913043478, 0.56739130434783, 0.34090909090909
44625, 0.54347826086957, 0.56739130434783, 0.36363636363636
44626, 0.52173913043478, 0.54130434782609, 0.36363636363636
44627, 0.52173913043478, 0.56739130434783, 0.38636363636364
44628, 0.54347826086956, 0.56739130434783, 0.40909090909091
44629, 0.52173913043478, 0.54130434782609, 0.40909090909091
44630, 0.52173913043478, 0.56739130434783, 0.43181818181818
44631, 0.54347826086956, 0.56739130434783, 0.45454545454545
44632, 0.52173913043478, 0.54130434782609, 0.45454545454545
44633, 0.52173913043478, 0.56739130434783, 0.47727272727273
44634, 0.47826086956522, 0.56739130434783, 0.022727272727273
44635, 0.5, 0.56739130434783, 0.045454545454545
44636, 0.47826086956522, 0.54130434782609, 0.045454545454545
44637, 0.47826086956522, 0.56739130434783, 0.068181818181818
44638, 0.5, 0.56739130434783, 0.090909090909091
44639, 0.47826086956522, 0.54130434782609, 0.090909090909091
44640, 0.47826086956522, 0.56739130434783, 0.11363636363636
44641, 0.5, 0.56739130434783, 0.13636363636364
44642, 0.47826086956522, 0.54130434782609, 0.13636363636364
44643, 0.47826086956522, 0.56739130434783, 0.15909090909091
44644, 0.5, 0.56739130434783, 0.18181818181818
44645, 0.47826086956522, 0.54130434782609, 0.18181818181818
44646, 0.47826086956522, 0.56739130434783, 0.20454545454545
44647, 0.5, 0.56739130434783, 0.22727272727273
44648, 0.47826086956522, 0.54130434782609, 0.22727272727273
44649, 0.47826086956522, 0.56739130434783, 0.25
44650, 0.5, 0.56739130434783, 0.27272727272727
44651, 0.47826086956522, 0.54130434782609, 0.27272727272727
44652, 0.47826086956522, 0.56739130434783, 0.29545454545455
44653, 0.5, 0.56739130434783, 0.31818181818182
44654, 0.47826086956522, 0.54130434782609, 0.31818181818182
44655, 0.47826086956522, 0.56739130434783, 0.34090909090909
44656, 0.5, 0.56739130434783, 0.36363636363636
44657, 0.47826086956522, 0.54130434782609, 0.36363636363636
44658, 0.47826086956522, 0.56739130434783, 0.38636363636364
44659, 0.5, 0.56739130434783, 0.40909090909091
44660, 0.47826086956522, 0.54130434782609, 0.40909090909091
44661, 0.47826086956522, 0.56739130434783, 0.43181818181818
44662, 0.5, 0.56739130434783, 0.45454545454545
44663, 0.47826086956522, 0.54130434782609, 0.45454545454545
44664, 0.47826086956522, 0.56739130434783, 0.47727272727273
44665, 0.43478260869565, 0.56739130434783, 0.022727272727273
44666, 0.45652173913043, 0.56739130434783, 0.045454545454545
44667, 0.43478260869565, 0.54130434782609, 0.045454545454545
44668, 0.43478260869565, 0.56739130434783, 0.068181818181818
44669, 0.45652173913043, 0.56739130434783, 0.090909090909091
44670, 0.43478260869565, 0.54130434782609, 0.090909090909091
44671, 0.43478260869565, 0.56739130434783, 0.11363636363636
44672, 0.45652173913043, 0.56739130434783, 0.13636363636364
44673, 0.43478260869565, 0.54130434782609, 0.13636363636364
44674, 0.43478260869565, 0.56739130434783, 0.15909090909091
44675, 0.45652173913043, 0.56739130434783, 0.18181818181818
44676, 0.43478260869565, 0.54130434782609, 0.18181818181818
44677, 0.43478260869565, 0.56739130434783, 0.20454545454545
44678, 0.45652173913043, 0.56739130434783, 0.22727272727273
44679, 0.43478260869565, 0.54130434782609, 0.22727272727273
44680, 0.43478260869565, 0.56739130434783, 0.25
44681, 0.45652173913043, 0.56739130434783, 0.27272727272727
44682, 0.43478260869565, 0.54130434782609, 0.27272727272727
44683, 0.43478260869565, 0.56739130434783, 0.29545454545455
44684, 0.45652173913043, 0.56739130434783, 0.31818181818182
44685, 0.43478260869565, 0.54130434782609, 0.31818181818182
44686, 0.43478260869565, 0.56739130434783, 0.34090909090909
44687, 0.45652173913043, 0.56739130434783, 0.36363636363636
44688, 0.43478260869565, 0.54130434782609, 0.36363636363636
44689, 0.43478260869565, 0.56739130434783, 0.38636363636364
44690, 0.45652173913043, 0.56739130434783, 0.40909090909091
44691, 0.43478260869565, 0.54130434782609, 0.40909090909091
44692, 0.43478260869565, 0.56739130434783, 0.43181818181818
44693, 0.45652173913043, 0.56739130434783, 0.45454545454545
44694, 0.43478260869565, 0.54130434782609, 0.45454545454545
44695, 0.43478260869565, 0.56739130434783, 0.47727272727273
44696, 0.39130434782609, 0.56739130434783, 0.022727272727273
44697, 0.41304347826087, 0.56739130434783, 0.045454545454545
44698, 0.39130434782609, 0.54130434782609, 0.045454545454545
44699, 0.39130434782609, 0.56739130434783, 0.068181818181818
44700, 0.41304347826087, 0.56739130434783, 0.090909090909091
44701, 0.39130434782609, 0.54130434782609, 0.090909090909091
44702, 0.39130434782609, 0.56739130434783, 0.11363636363636
44703, 0.41304347826087, 0.56739130434783, 0.13636363636364
44704, 0.39130434782609, 0.54130434782609, 0.13636363636364
44705, 0.39130434782609, 0.56739130434783, 0.15909090909091
44706, 0.41304347826087, 0.56739130434783, 0.18181818181818
44707, 0.39130434782609, 0.54130434782609, 0.18181818181818
44708, 0.39130434782609, 0.56739130434783, 0.20454545454545
44709, 0.41304347826087, 0.56739130434783, 0.22727272727273
44710, 0.39130434782609, 0.54130434782609, 0.22727272727273
44711, 0.39130434782609, 0.56739130434783, 0.25
44712, 0.41304347826087, 0.56739130434783, 0.27272727272727
44713, 0.39130434782609, 0.54130434782609, 0.27272727272727
44714, 0.39130434782609, 0.56739130434783, 0.29545454545455
44715, 0.41304347826087, 0.56739130434783, 0.31818181818182
44716, 0.39130434782609, 0.54130434782609, 0.31818181818182
44717, 0.39130434782609, 0.56739130434783, 0.34090909090909
44718, 0.41304347826087, 0.56739130434783, 0.36363636363636
44719, 0.39130434782609, 0.54130434782609, 0.36363636363636
44720, 0.39130434782609, 0.56739130434783, 0.38636363636364
44721, 0.41304347826087, 0.56739130434783, 0.40909090909091
44722, 0.39130434782609, 0.54130434782609, 0.40909090909091
44723, 0.39130434782609, 0.56739130434783, 0.43181818181818
44724, 0.41304347826087, 0.56739130434783, 0.45454545454545
44725, 0.39130434782609, 0.54130434782609, 0.45454545454545
44726, 0.39130434782609, 0.56739130434783, 0.47727272727273
44727, 0.34782608695652, 0.56739130434783, 0.022727272727273
44728, 0.3695652173913, 0.56739130434783, 0.045454545454545
44729, 0.34782608695652, 0.54130434782609, 0.045454545454545
44730, 0.34782608695652, 0.56739130434783, 0.068181818181818
44731, 0.3695652173913, 0.56739130434783, 0.090909090909091
44732, 0.34782608695652, 0.54130434782609, 0.090909090909091
44733, 0.34782608695652, 0.56739130434783, 0.11363636363636
44734, 0.3695652173913, 0.56739130434783, 0.13636363636364
44735, 0.34782608695652, 0.54130434782609, 0.13636363636364
44736, 0.34782608695652, 0.56739130434783, 0.15909090909091
44737, 0.3695652173913, 0.56739130434783, 0.18181818181818
44738, 0.34782608695652, 0.54130434782609, 0.18181818181818
44739, 0.34782608695652, 0.56739130434783, 0.20454545454545
44740, 0.3695652173913, 0.56739130434783, 0.22727272727273
44741, 0.34782608695652, 0.54130434782609, 0.22727272727273
44742, 0.34782608695652, 0.56739130434783, 0.25
44743, 0.3695652173913, 0.56739130434783, 0.27272727272727
44744, 0.34782608695652, 0.54130434782609, 0.27272727272727
44745, 0.34782608695652, 0.56739130434783, 0.29545454545455
44746, 0.3695652173913, 0.56739130434783, 0.31818181818182
44747, 0.34782608695652, 0.54130434782609, 0.31818181818182
44748, 0.34782608695652, 0.56739130434783, 0.34090909090909
44749, 0.3695652173913, 0.56739130434783, 0.36363636363636
44750, 0.34782608695652, 0.54130434782609, 0.36363636363636
44751, 0.34782608695652, 0.56739130434783, 0.38636363636364
44752, 0.3695652173913, 0.56739130434783, 0.40909090909091
44753, 0.34782608695652, 0.54130434782609, 0.40909090909091
44754, 0.34782608695652, 0.56739130434783, 0.43181818181818
44755, 0.3695652173913, 0.56739130434783, 0.45454545454545
44756, 0.34782608695652, 0.54130434782609, 0.45454545454545
44757, 0.34782608695652, 0.56739130434783, 0.47727272727273
44758, 0.30434782608696, 0.56739130434783, 0.022727272727273
44759, 0.32608695652174, 0.56739130434783, 0.045454545454545
44760, 0.30434782608696, 0.54130434782609, 0.045454545454545
44761, 0.30434782608696, 0.56739130434783, 0.068181818181818
44762, 0.32608695652174, 0.56739130434783, 0.090909090909091
44763, 0.30434782608696, 0.54130434782609, 0.090909090909091
44764, 0.30434782608696, 0.56739130434783, 0.11363636363636
44765, 0.32608695652174, 0.56739130434783, 0.13636363636364
44766, 0.30434782608696, 0.54130434782609, 0.13636363636364
44767, 0.30434782608696, 0.56739130434783, 0.15909090909091
44768, 0.32608695652174, 0.56739130434783, 0.18181818181818
44769, 0.30434782608696, 0.54130434782609, 0.18181818181818
44770, 0.30434782608696, 0.56739130434783, 0.20454545454545
44771, 0.32608695652174, 0.56739130434783, 0.22727272727273
44772, 0.30434782608696, 0.54130434782609, 0.22727272727273
44773, 0.30434782608696, 0.56739130434783, 0.25
44774, 0.32608695652174, 0.56739130434783, 0.27272727272727
44775, 0.30434782608696, 0.54130434782609, 0.27272727272727
44776, 0.30434782608696, 0.56739130434783, 0.29545454545455
44777, 0.32608695652174, 0.56739130434783, 0.31818181818182
44778, 0.30434782608696, 0.54130434782609, 0.31818181818182
44779, 0.30434782608696, 0.56739130434783, 0.34090909090909
44780, 0.32608695652174, 0.56739130434783, 0.36363636363636
44781, 0.30434782608696, 0.54130434782609, 0.36363636363636
44782, 0.30434782608696, 0.56739130434783, 0.38636363636364
44783, 0.32608695652174, 0.56739130434783, 0.40909090909091
44784, 0.30434782608696, 0.54130434782609, 0.40909090909091
44785, 0.30434782608696, 0.56739130434783, 0.43181818181818
44786, 0.32608695652174, 0.56739130434783, 0.45454545454545
44787, 0.30434782608696, 0.54130434782609, 0.45454545454545
44788, 0.30434782608696, 0.56739130434783, 0.47727272727273
44789, 0.26086956521739, 0.56739130434783, 0.022727272727273
44790, 0.28260869565217, 0.56739130434783, 0.045454545454545
44791, 0.26086956521739, 0.54130434782609, 0.045454545454545
44792, 0.26086956521739, 0.56739130434783, 0.068181818181818
44793, 0.28260869565217, 0.56739130434783, 0.090909090909091
44794, 0.26086956521739, 0.54130434782609, 0.090909090909091
44795, 0.26086956521739, 0.56739130434783, 0.11363636363636
44796, 0.28260869565217, 0.56739130434783, 0.13636363636364
44797, 0.26086956521739, 0.54130434782609, 0.13636363636364
44798, 0.26086956521739, 0.56739130434783, 0.15909090909091
44799, 0.28260869565217, 0.56739130434783, 0.18181818181818
44800, 0.26086956521739, 0.54130434782609, 0.18181818181818
44801, 0.26086956521739, 0.56739130434783, 0.20454545454545
44802, 0.28260869565217, 0.56739130434783, 0.22727272727273
44803, 0.26086956521739, 0.54130434782609, 0.22727272727273
44804, 0.26086956521739, 0.56739130434783, 0.25
44805, 0.28260869565217, 0.56739130434783, 0.27272727272727
44806, 0.26086956521739, 0.54130434782609, 0.27272727272727
44807, 0.26086956521739, 0.56739130434783, 0.29545454545455
44808, 0.28260869565217, 0.56739130434783, 0.31818181818182
44809, 0.26086956521739, 0.54130434782609, 0.31818181818182
44810, 0.26086956521739, 0.56739130434783, 0.34090909090909
44811, 0.28260869565217, 0.56739130434783, 0.36363636363636
44812, 0.26086956521739, 0.54130434782609, 0.36363636363636
44813, 0.26086956521739, 0.56739130434783, 0.38636363636364
44814, 0.28260869565217, 0.56739130434783, 0.40909090909091
44815, 0.26086956521739, 0.54130434782609, 0.40909090909091
44816, 0.26086956521739, 0.56739130434783, 0.43181818181818
44817, 0.28260869565217, 0.56739130434783, 0.45454545454545
44818, 0.26086956521739, 0.54130434782609, 0.45454545454545
