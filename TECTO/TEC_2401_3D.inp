48226, 0.30434782608696, 0.80217391304348, 0.13636363636364
48227, 0.30434782608696, 0.82826086956522, 0.15909090909091
48228, 0.32608695652174, 0.82826086956522, 0.18181818181818
48229, 0.30434782608696, 0.80217391304348, 0.18181818181818
48230, 0.30434782608696, 0.82826086956522, 0.20454545454545
48231, 0.32608695652174, 0.82826086956522, 0.22727272727273
48232, 0.30434782608696, 0.80217391304348, 0.22727272727273
48233, 0.30434782608696, 0.82826086956522, 0.25
48234, 0.32608695652174, 0.82826086956522, 0.27272727272727
48235, 0.30434782608696, 0.80217391304348, 0.27272727272727
48236, 0.30434782608696, 0.82826086956522, 0.29545454545455
48237, 0.32608695652174, 0.82826086956522, 0.31818181818182
48238, 0.30434782608696, 0.80217391304348, 0.31818181818182
48239, 0.30434782608696, 0.82826086956522, 0.34090909090909
48240, 0.32608695652174, 0.82826086956522, 0.36363636363636
48241, 0.30434782608696, 0.80217391304348, 0.36363636363636
48242, 0.30434782608696, 0.82826086956522, 0.38636363636364
48243, 0.32608695652174, 0.82826086956522, 0.40909090909091
48244, 0.30434782608696, 0.80217391304348, 0.40909090909091
48245, 0.30434782608696, 0.82826086956522, 0.43181818181818
48246, 0.32608695652174, 0.82826086956522, 0.45454545454545
48247, 0.30434782608696, 0.80217391304348, 0.45454545454545
48248, 0.30434782608696, 0.82826086956522, 0.47727272727273
48249, 0.26086956521739, 0.82826086956522, 0.022727272727273
48250, 0.28260869565217, 0.82826086956522, 0.045454545454545
48251, 0.26086956521739, 0.80217391304348, 0.045454545454545
48252, 0.26086956521739, 0.82826086956522, 0.068181818181818
48253, 0.28260869565217, 0.82826086956522, 0.090909090909091
48254, 0.26086956521739, 0.80217391304348, 0.090909090909091
48255, 0.26086956521739, 0.82826086956522, 0.11363636363636
48256, 0.28260869565217, 0.82826086956522, 0.13636363636364
48257, 0.26086956521739, 0.80217391304348, 0.13636363636364
48258, 0.26086956521739, 0.82826086956522, 0.15909090909091
48259, 0.28260869565217, 0.82826086956522, 0.18181818181818
48260, 0.26086956521739, 0.80217391304348, 0.18181818181818
48261, 0.26086956521739, 0.82826086956522, 0.20454545454545
48262, 0.28260869565217, 0.82826086956522, 0.22727272727273
48263, 0.26086956521739, 0.80217391304348, 0.22727272727273
48264, 0.26086956521739, 0.82826086956522, 0.25
48265, 0.28260869565217, 0.82826086956522, 0.27272727272727
48266, 0.26086956521739, 0.80217391304348, 0.27272727272727
48267, 0.26086956521739, 0.82826086956522, 0.29545454545455
48268, 0.28260869565217, 0.82826086956522, 0.31818181818182
48269, 0.26086956521739, 0.80217391304348, 0.31818181818182
48270, 0.26086956521739, 0.82826086956522, 0.34090909090909
48271, 0.28260869565217, 0.82826086956522, 0.36363636363636
48272, 0.26086956521739, 0.80217391304348, 0.36363636363636
48273, 0.26086956521739, 0.82826086956522, 0.38636363636364
48274, 0.28260869565217, 0.82826086956522, 0.40909090909091
48275, 0.26086956521739, 0.80217391304348, 0.40909090909091
48276, 0.26086956521739, 0.82826086956522, 0.43181818181818
48277, 0.28260869565217, 0.82826086956522, 0.45454545454545
48278, 0.26086956521739, 0.80217391304348, 0.45454545454545
48279, 0.26086956521739, 0.82826086956522, 0.47727272727273
48280, 0.21739130434783, 0.82826086956522, 0.022727272727273
48281, 0.23913043478261, 0.82826086956522, 0.045454545454545
48282, 0.21739130434783, 0.80217391304348, 0.045454545454545
48283, 0.21739130434783, 0.82826086956522, 0.068181818181818
48284, 0.23913043478261, 0.82826086956522, 0.090909090909091
48285, 0.21739130434783, 0.80217391304348, 0.090909090909091
48286, 0.21739130434783, 0.82826086956522, 0.11363636363636
48287, 0.23913043478261, 0.82826086956522, 0.13636363636364
48288, 0.21739130434783, 0.80217391304348, 0.13636363636364
48289, 0.21739130434783, 0.82826086956522, 0.15909090909091
48290, 0.23913043478261, 0.82826086956522, 0.18181818181818
48291, 0.21739130434783, 0.80217391304348, 0.18181818181818
48292, 0.21739130434783, 0.82826086956522, 0.20454545454545
48293, 0.23913043478261, 0.82826086956522, 0.22727272727273
48294, 0.21739130434783, 0.80217391304348, 0.22727272727273
48295, 0.21739130434783, 0.82826086956522, 0.25
48296, 0.23913043478261, 0.82826086956522, 0.27272727272727
48297, 0.21739130434783, 0.80217391304348, 0.27272727272727
48298, 0.21739130434783, 0.82826086956522, 0.29545454545455
48299, 0.23913043478261, 0.82826086956522, 0.31818181818182
48300, 0.21739130434783, 0.80217391304348, 0.31818181818182
48301, 0.21739130434783, 0.82826086956522, 0.34090909090909
48302, 0.23913043478261, 0.82826086956522, 0.36363636363636
48303, 0.21739130434783, 0.80217391304348, 0.36363636363636
48304, 0.21739130434783, 0.82826086956522, 0.38636363636364
48305, 0.23913043478261, 0.82826086956522, 0.40909090909091
48306, 0.21739130434783, 0.80217391304348, 0.40909090909091
48307, 0.21739130434783, 0.82826086956522, 0.43181818181818
48308, 0.23913043478261, 0.82826086956522, 0.45454545454545
48309, 0.21739130434783, 0.80217391304348, 0.45454545454545
48310, 0.21739130434783, 0.82826086956522, 0.47727272727273
48311, 0.17391304347826, 0.82826086956522, 0.022727272727273
48312, 0.19565217391304, 0.82826086956522, 0.045454545454545
48313, 0.17391304347826, 0.80217391304348, 0.045454545454545
48314, 0.17391304347826, 0.82826086956522, 0.068181818181818
48315, 0.19565217391304, 0.82826086956522, 0.090909090909091
48316, 0.17391304347826, 0.80217391304348, 0.090909090909091
48317, 0.17391304347826, 0.82826086956522, 0.11363636363636
48318, 0.19565217391304, 0.82826086956522, 0.13636363636364
48319, 0.17391304347826, 0.80217391304348, 0.13636363636364
48320, 0.17391304347826, 0.82826086956522, 0.15909090909091
48321, 0.19565217391304, 0.82826086956522, 0.18181818181818
48322, 0.17391304347826, 0.80217391304348, 0.18181818181818
48323, 0.17391304347826, 0.82826086956522, 0.20454545454545
48324, 0.19565217391304, 0.82826086956522, 0.22727272727273
48325, 0.17391304347826, 0.80217391304348, 0.22727272727273
48326, 0.17391304347826, 0.82826086956522, 0.25
48327, 0.19565217391304, 0.82826086956522, 0.27272727272727
48328, 0.17391304347826, 0.80217391304348, 0.27272727272727
48329, 0.17391304347826, 0.82826086956522, 0.29545454545455
48330, 0.19565217391304, 0.82826086956522, 0.31818181818182
48331, 0.17391304347826, 0.80217391304348, 0.31818181818182
48332, 0.17391304347826, 0.82826086956522, 0.34090909090909
48333, 0.19565217391304, 0.82826086956522, 0.36363636363636
48334, 0.17391304347826, 0.80217391304348, 0.36363636363636
48335, 0.17391304347826, 0.82826086956522, 0.38636363636364
48336, 0.19565217391304, 0.82826086956522, 0.40909090909091
48337, 0.17391304347826, 0.80217391304348, 0.40909090909091
48338, 0.17391304347826, 0.82826086956522, 0.43181818181818
48339, 0.19565217391304, 0.82826086956522, 0.45454545454545
48340, 0.17391304347826, 0.80217391304348, 0.45454545454545
48341, 0.17391304347826, 0.82826086956522, 0.47727272727273
48342, 0.1304347826087, 0.82826086956522, 0.022727272727273
48343, 0.15217391304348, 0.82826086956522, 0.045454545454545
48344, 0.1304347826087, 0.80217391304348, 0.045454545454545
48345, 0.1304347826087, 0.82826086956522, 0.068181818181818
48346, 0.15217391304348, 0.82826086956522, 0.090909090909091
48347, 0.1304347826087, 0.80217391304348, 0.090909090909091
48348, 0.1304347826087, 0.82826086956522, 0.11363636363636
48349, 0.15217391304348, 0.82826086956522, 0.13636363636364
48350, 0.1304347826087, 0.80217391304348, 0.13636363636364
48351, 0.1304347826087, 0.82826086956522, 0.15909090909091
48352, 0.15217391304348, 0.82826086956522, 0.18181818181818
48353, 0.1304347826087, 0.80217391304348, 0.18181818181818
48354, 0.1304347826087, 0.82826086956522, 0.20454545454545
48355, 0.15217391304348, 0.82826086956522, 0.22727272727273
48356, 0.1304347826087, 0.80217391304348, 0.22727272727273
48357, 0.1304347826087, 0.82826086956522, 0.25
48358, 0.15217391304348, 0.82826086956522, 0.27272727272727
48359, 0.1304347826087, 0.80217391304348, 0.27272727272727
48360, 0.1304347826087, 0.82826086956522, 0.29545454545455
48361, 0.15217391304348, 0.82826086956522, 0.31818181818182
48362, 0.1304347826087, 0.80217391304348, 0.31818181818182
48363, 0.1304347826087, 0.82826086956522, 0.34090909090909
48364, 0.15217391304348, 0.82826086956522, 0.36363636363636
48365, 0.1304347826087, 0.80217391304348, 0.36363636363636
48366, 0.1304347826087, 0.82826086956522, 0.38636363636364
48367, 0.15217391304348, 0.82826086956522, 0.40909090909091
48368, 0.1304347826087, 0.80217391304348, 0.40909090909091
48369, 0.1304347826087, 0.82826086956522, 0.43181818181818
48370, 0.15217391304348, 0.82826086956522, 0.45454545454545
48371, 0.1304347826087, 0.80217391304348, 0.45454545454545
48372, 0.1304347826087, 0.82826086956522, 0.47727272727273
48373, 0.08695652173913, 0.82826086956522, 0.022727272727273
48374, 0.10869565217391, 0.82826086956522, 0.045454545454545
48375, 0.08695652173913, 0.80217391304348, 0.045454545454545
48376, 0.08695652173913, 0.82826086956522, 0.068181818181818
48377, 0.10869565217391, 0.82826086956522, 0.090909090909091
48378, 0.08695652173913, 0.80217391304348, 0.090909090909091
48379, 0.08695652173913, 0.82826086956522, 0.11363636363636
48380, 0.10869565217391, 0.82826086956522, 0.13636363636364
48381, 0.08695652173913, 0.80217391304348, 0.13636363636364
48382, 0.08695652173913, 0.82826086956522, 0.15909090909091
48383, 0.10869565217391, 0.82826086956522, 0.18181818181818
48384, 0.08695652173913, 0.80217391304348, 0.18181818181818
48385, 0.08695652173913, 0.82826086956522, 0.20454545454545
48386, 0.10869565217391, 0.82826086956522, 0.22727272727273
48387, 0.08695652173913, 0.80217391304348, 0.22727272727273
48388, 0.08695652173913, 0.82826086956522, 0.25
48389, 0.10869565217391, 0.82826086956522, 0.27272727272727
48390, 0.08695652173913, 0.80217391304348, 0.27272727272727
48391, 0.08695652173913, 0.82826086956522, 0.29545454545455
48392, 0.10869565217391, 0.82826086956522, 0.31818181818182
48393, 0.08695652173913, 0.80217391304348, 0.31818181818182
48394, 0.08695652173913, 0.82826086956522, 0.34090909090909
48395, 0.10869565217391, 0.82826086956522, 0.36363636363636
48396, 0.08695652173913, 0.80217391304348, 0.36363636363636
48397, 0.08695652173913, 0.82826086956522, 0.38636363636364
48398, 0.10869565217391, 0.82826086956522, 0.40909090909091
48399, 0.08695652173913, 0.80217391304348, 0.40909090909091
48400, 0.08695652173913, 0.82826086956522, 0.43181818181818
48401, 0.10869565217391, 0.82826086956522, 0.45454545454545
48402, 0.08695652173913, 0.80217391304348, 0.45454545454545
48403, 0.08695652173913, 0.82826086956522, 0.47727272727273
48404, 0.043478260869565, 0.82826086956522, 0.022727272727273
48405, 0.065217391304348, 0.82826086956522, 0.045454545454545
48406, 0.043478260869565, 0.80217391304348, 0.045454545454545
48407, 0.043478260869565, 0.82826086956522, 0.068181818181818
48408, 0.065217391304348, 0.82826086956522, 0.090909090909091
48409, 0.043478260869565, 0.80217391304348, 0.090909090909091
48410, 0.043478260869565, 0.82826086956522, 0.11363636363636
48411, 0.065217391304348, 0.82826086956522, 0.13636363636364
48412, 0.043478260869565, 0.80217391304348, 0.13636363636364
48413, 0.043478260869565, 0.82826086956522, 0.15909090909091
48414, 0.065217391304348, 0.82826086956522, 0.18181818181818
48415, 0.043478260869565, 0.80217391304348, 0.18181818181818
48416, 0.043478260869565, 0.82826086956522, 0.20454545454545
48417, 0.065217391304348, 0.82826086956522, 0.22727272727273
48418, 0.043478260869565, 0.80217391304348, 0.22727272727273
48419, 0.043478260869565, 0.82826086956522, 0.25
48420, 0.065217391304348, 0.82826086956522, 0.27272727272727
48421, 0.043478260869565, 0.80217391304348, 0.27272727272727
48422, 0.043478260869565, 0.82826086956522, 0.29545454545455
48423, 0.065217391304348, 0.82826086956522, 0.31818181818182
48424, 0.043478260869565, 0.80217391304348, 0.31818181818182
48425, 0.043478260869565, 0.82826086956522, 0.34090909090909
48426, 0.065217391304348, 0.82826086956522, 0.36363636363636
48427, 0.043478260869565, 0.80217391304348, 0.36363636363636
48428, 0.043478260869565, 0.82826086956522, 0.38636363636364
48429, 0.065217391304348, 0.82826086956522, 0.40909090909091
48430, 0.043478260869565, 0.80217391304348, 0.40909090909091
48431, 0.043478260869565, 0.82826086956522, 0.43181818181818
48432, 0.065217391304348, 0.82826086956522, 0.45454545454545
48433, 0.043478260869565, 0.80217391304348, 0.45454545454545
48434, 0.043478260869565, 0.82826086956522, 0.47727272727273
48435, 0.021739130434783, 0.82826086956522, 0.045454545454545
48436, 0.021739130434783, 0.82826086956522, 0.090909090909091
48437, 0.021739130434783, 0.82826086956522, 0.13636363636364
48438, 0.021739130434783, 0.82826086956522, 0.18181818181818
48439, 0.021739130434783, 0.82826086956522, 0.22727272727273
48440, 0.021739130434783, 0.82826086956522, 0.27272727272727
48441, 0.021739130434783, 0.82826086956522, 0.31818181818182
48442, 0.021739130434783, 0.82826086956522, 0.36363636363636
48443, 0.021739130434783, 0.82826086956522, 0.40909090909091
48444, 0.021739130434783, 0.82826086956522, 0.45454545454545
48445, 0.95652173913043, 0.8804347826087, 0.022727272727273
48446, 0.97826086956522, 0.8804347826087, 0.045454545454545
48447, 0.95652173913043, 0.85434782608696, 0.045454545454545
48448, 0.95652173913043, 0.8804347826087, 0.068181818181818
48449, 0.97826086956522, 0.8804347826087, 0.090909090909091
48450, 0.95652173913043, 0.85434782608696, 0.090909090909091
48451, 0.95652173913043, 0.8804347826087, 0.11363636363636
48452, 0.97826086956522, 0.8804347826087, 0.13636363636364
48453, 0.95652173913044, 0.85434782608696, 0.13636363636364
48454, 0.95652173913044, 0.88043478260869, 0.15909090909091
48455, 0.97826086956522, 0.88043478260869, 0.18181818181818
48456, 0.95652173913044, 0.85434782608696, 0.18181818181818
48457, 0.95652173913044, 0.8804347826087, 0.20454545454545
48458, 0.97826086956522, 0.8804347826087, 0.22727272727273
48459, 0.95652173913044, 0.85434782608696, 0.22727272727273
48460, 0.95652173913044, 0.8804347826087, 0.25
48461, 0.97826086956522, 0.8804347826087, 0.27272727272727
48462, 0.95652173913044, 0.85434782608696, 0.27272727272727
48463, 0.95652173913044, 0.8804347826087, 0.29545454545455
48464, 0.97826086956522, 0.8804347826087, 0.31818181818182
48465, 0.95652173913044, 0.85434782608696, 0.31818181818182
48466, 0.95652173913043, 0.8804347826087, 0.34090909090909
48467, 0.97826086956522, 0.8804347826087, 0.36363636363636
48468, 0.95652173913043, 0.85434782608696, 0.36363636363636
48469, 0.95652173913043, 0.8804347826087, 0.38636363636364
48470, 0.97826086956522, 0.8804347826087, 0.40909090909091
48471, 0.95652173913043, 0.85434782608696, 0.40909090909091
48472, 0.95652173913043, 0.8804347826087, 0.43181818181818
48473, 0.97826086956522, 0.8804347826087, 0.45454545454545
48474, 0.95652173913044, 0.85434782608696, 0.45454545454545
48475, 0.95652173913044, 0.8804347826087, 0.47727272727273
48476, 0.91304347826087, 0.88043478260869, 0.022727272727273
48477, 0.93478260869565, 0.88043478260869, 0.045454545454545
48478, 0.91304347826087, 0.85434782608696, 0.045454545454545
48479, 0.91304347826087, 0.8804347826087, 0.068181818181818
48480, 0.93478260869565, 0.8804347826087, 0.090909090909091
48481, 0.91304347826087, 0.85434782608696, 0.090909090909091
48482, 0.91304347826087, 0.8804347826087, 0.11363636363636
48483, 0.93478260869565, 0.8804347826087, 0.13636363636364
48484, 0.91304347826087, 0.85434782608696, 0.13636363636364
48485, 0.91304347826087, 0.8804347826087, 0.15909090909091
48486, 0.93478260869565, 0.88043478260869, 0.18181818181818
48487, 0.91304347826087, 0.85434782608696, 0.18181818181818
48488, 0.91304347826087, 0.8804347826087, 0.20454545454545
48489, 0.93478260869565, 0.8804347826087, 0.22727272727273
48490, 0.91304347826087, 0.85434782608696, 0.22727272727273
48491, 0.91304347826087, 0.88043478260869, 0.25
48492, 0.93478260869565, 0.88043478260869, 0.27272727272727
48493, 0.91304347826087, 0.85434782608696, 0.27272727272727
48494, 0.91304347826087, 0.8804347826087, 0.29545454545455
48495, 0.93478260869565, 0.8804347826087, 0.31818181818182
48496, 0.91304347826087, 0.85434782608696, 0.31818181818182
48497, 0.91304347826087, 0.8804347826087, 0.34090909090909
48498, 0.93478260869565, 0.8804347826087, 0.36363636363636
48499, 0.91304347826087, 0.85434782608696, 0.36363636363636
48500, 0.91304347826087, 0.8804347826087, 0.38636363636364
48501, 0.93478260869565, 0.8804347826087, 0.40909090909091
48502, 0.91304347826087, 0.85434782608696, 0.40909090909091
48503, 0.91304347826087, 0.88043478260869, 0.43181818181818
48504, 0.93478260869565, 0.8804347826087, 0.45454545454545
48505, 0.91304347826087, 0.85434782608696, 0.45454545454545
48506, 0.91304347826087, 0.88043478260869, 0.47727272727273
48507, 0.8695652173913, 0.88043478260869, 0.022727272727273
48508, 0.89130434782609, 0.88043478260869, 0.045454545454545
48509, 0.8695652173913, 0.85434782608696, 0.045454545454545
48510, 0.8695652173913, 0.8804347826087, 0.068181818181818
48511, 0.89130434782609, 0.8804347826087, 0.090909090909091
48512, 0.8695652173913, 0.85434782608696, 0.090909090909091
48513, 0.8695652173913, 0.8804347826087, 0.11363636363636
48514, 0.89130434782609, 0.8804347826087, 0.13636363636364
48515, 0.8695652173913, 0.85434782608696, 0.13636363636364
48516, 0.8695652173913, 0.8804347826087, 0.15909090909091
48517, 0.89130434782609, 0.88043478260869, 0.18181818181818
48518, 0.8695652173913, 0.85434782608696, 0.18181818181818
48519, 0.8695652173913, 0.8804347826087, 0.20454545454545
48520, 0.89130434782609, 0.8804347826087, 0.22727272727273
48521, 0.8695652173913, 0.85434782608696, 0.22727272727273
48522, 0.8695652173913, 0.8804347826087, 0.25
48523, 0.89130434782609, 0.88043478260869, 0.27272727272727
48524, 0.8695652173913, 0.85434782608696, 0.27272727272727
48525, 0.8695652173913, 0.8804347826087, 0.29545454545455
48526, 0.89130434782609, 0.8804347826087, 0.31818181818182
48527, 0.8695652173913, 0.85434782608696, 0.31818181818182
48528, 0.8695652173913, 0.8804347826087, 0.34090909090909
48529, 0.89130434782609, 0.8804347826087, 0.36363636363636
48530, 0.8695652173913, 0.85434782608696, 0.36363636363636
48531, 0.8695652173913, 0.8804347826087, 0.38636363636364
48532, 0.89130434782609, 0.8804347826087, 0.40909090909091
48533, 0.8695652173913, 0.85434782608696, 0.40909090909091
48534, 0.8695652173913, 0.8804347826087, 0.43181818181818
48535, 0.89130434782609, 0.8804347826087, 0.45454545454545
48536, 0.8695652173913, 0.85434782608696, 0.45454545454545
48537, 0.8695652173913, 0.8804347826087, 0.47727272727273
48538, 0.82608695652174, 0.8804347826087, 0.022727272727273
48539, 0.84782608695652, 0.8804347826087, 0.045454545454545
48540, 0.82608695652174, 0.85434782608696, 0.045454545454545
48541, 0.82608695652174, 0.8804347826087, 0.068181818181818
48542, 0.84782608695652, 0.8804347826087, 0.090909090909091
48543, 0.82608695652174, 0.85434782608696, 0.090909090909091
48544, 0.82608695652174, 0.8804347826087, 0.11363636363636
48545, 0.84782608695652, 0.8804347826087, 0.13636363636364
48546, 0.82608695652174, 0.85434782608696, 0.13636363636364
48547, 0.82608695652174, 0.8804347826087, 0.15909090909091
48548, 0.84782608695652, 0.8804347826087, 0.18181818181818
48549, 0.82608695652174, 0.85434782608696, 0.18181818181818
48550, 0.82608695652174, 0.8804347826087, 0.20454545454545
48551, 0.84782608695652, 0.8804347826087, 0.22727272727273
48552, 0.82608695652174, 0.85434782608696, 0.22727272727273
48553, 0.82608695652174, 0.8804347826087, 0.25
48554, 0.84782608695652, 0.8804347826087, 0.27272727272727
48555, 0.82608695652174, 0.85434782608696, 0.27272727272727
48556, 0.82608695652174, 0.8804347826087, 0.29545454545455
48557, 0.84782608695652, 0.8804347826087, 0.31818181818182
48558, 0.82608695652174, 0.85434782608696, 0.31818181818182
48559, 0.82608695652174, 0.8804347826087, 0.34090909090909
48560, 0.84782608695652, 0.8804347826087, 0.36363636363636
48561, 0.82608695652174, 0.85434782608696, 0.36363636363636
48562, 0.82608695652174, 0.8804347826087, 0.38636363636364
48563, 0.84782608695652, 0.8804347826087, 0.40909090909091
48564, 0.82608695652174, 0.85434782608696, 0.40909090909091
48565, 0.82608695652174, 0.8804347826087, 0.43181818181818
48566, 0.84782608695652, 0.8804347826087, 0.45454545454545
48567, 0.82608695652174, 0.85434782608696, 0.45454545454545
48568, 0.82608695652174, 0.8804347826087, 0.47727272727273
48569, 0.78260869565217, 0.8804347826087, 0.022727272727273
48570, 0.80434782608696, 0.8804347826087, 0.045454545454545
48571, 0.78260869565217, 0.85434782608696, 0.045454545454545
48572, 0.78260869565217, 0.8804347826087, 0.068181818181818
48573, 0.80434782608696, 0.8804347826087, 0.090909090909091
48574, 0.78260869565217, 0.85434782608696, 0.090909090909091
48575, 0.78260869565217, 0.8804347826087, 0.11363636363636
48576, 0.80434782608696, 0.8804347826087, 0.13636363636364
48577, 0.78260869565217, 0.85434782608696, 0.13636363636364
48578, 0.78260869565217, 0.88043478260869, 0.15909090909091
48579, 0.80434782608696, 0.8804347826087, 0.18181818181818
48580, 0.78260869565217, 0.85434782608696, 0.18181818181818
48581, 0.78260869565217, 0.88043478260869, 0.20454545454545
48582, 0.80434782608696, 0.8804347826087, 0.22727272727273
48583, 0.78260869565217, 0.85434782608696, 0.22727272727273
48584, 0.78260869565217, 0.88043478260869, 0.25
48585, 0.80434782608696, 0.8804347826087, 0.27272727272727
48586, 0.78260869565217, 0.85434782608696, 0.27272727272727
48587, 0.78260869565217, 0.8804347826087, 0.29545454545455
48588, 0.80434782608696, 0.8804347826087, 0.31818181818182
48589, 0.78260869565217, 0.85434782608696, 0.31818181818182
48590, 0.78260869565217, 0.8804347826087, 0.34090909090909
48591, 0.80434782608696, 0.8804347826087, 0.36363636363636
48592, 0.78260869565217, 0.85434782608696, 0.36363636363636
48593, 0.78260869565217, 0.88043478260869, 0.38636363636364
48594, 0.80434782608696, 0.8804347826087, 0.40909090909091
48595, 0.78260869565217, 0.85434782608696, 0.40909090909091
48596, 0.78260869565217, 0.88043478260869, 0.43181818181818
48597, 0.80434782608696, 0.8804347826087, 0.45454545454545
48598, 0.78260869565217, 0.85434782608696, 0.45454545454545
48599, 0.78260869565217, 0.88043478260869, 0.47727272727273
48600, 0.73913043478261, 0.8804347826087, 0.022727272727273
48601, 0.76086956521739, 0.8804347826087, 0.045454545454545
48602, 0.73913043478261, 0.85434782608696, 0.045454545454545
48603, 0.73913043478261, 0.88043478260869, 0.068181818181818
48604, 0.76086956521739, 0.8804347826087, 0.090909090909091
48605, 0.73913043478261, 0.85434782608696, 0.090909090909091
48606, 0.73913043478261, 0.88043478260869, 0.11363636363636
48607, 0.76086956521739, 0.88043478260869, 0.13636363636364
48608, 0.73913043478261, 0.85434782608696, 0.13636363636364
48609, 0.73913043478261, 0.88043478260869, 0.15909090909091
48610, 0.76086956521739, 0.88043478260869, 0.18181818181818
48611, 0.73913043478261, 0.85434782608696, 0.18181818181818
48612, 0.73913043478261, 0.8804347826087, 0.20454545454545
48613, 0.76086956521739, 0.8804347826087, 0.22727272727273
48614, 0.73913043478261, 0.85434782608696, 0.22727272727273
48615, 0.73913043478261, 0.8804347826087, 0.25
48616, 0.76086956521739, 0.88043478260869, 0.27272727272727
48617, 0.73913043478261, 0.85434782608696, 0.27272727272727
48618, 0.73913043478261, 0.8804347826087, 0.29545454545455
48619, 0.76086956521739, 0.8804347826087, 0.31818181818182
48620, 0.73913043478261, 0.85434782608696, 0.31818181818182
48621, 0.73913043478261, 0.8804347826087, 0.34090909090909
48622, 0.76086956521739, 0.88043478260869, 0.36363636363636
48623, 0.73913043478261, 0.85434782608696, 0.36363636363636
48624, 0.73913043478261, 0.88043478260869, 0.38636363636364
48625, 0.76086956521739, 0.88043478260869, 0.40909090909091
48626, 0.73913043478261, 0.85434782608696, 0.40909090909091
48627, 0.73913043478261, 0.88043478260869, 0.43181818181818
48628, 0.76086956521739, 0.88043478260869, 0.45454545454545
48629, 0.73913043478261, 0.85434782608696, 0.45454545454545
48630, 0.73913043478261, 0.88043478260869, 0.47727272727273
48631, 0.69565217391304, 0.88043478260869, 0.022727272727273
48632, 0.71739130434783, 0.88043478260869, 0.045454545454545
48633, 0.69565217391304, 0.85434782608696, 0.045454545454545
48634, 0.69565217391304, 0.88043478260869, 0.068181818181818
48635, 0.71739130434783, 0.88043478260869, 0.090909090909091
48636, 0.69565217391304, 0.85434782608696, 0.090909090909091
48637, 0.69565217391304, 0.8804347826087, 0.11363636363636
48638, 0.71739130434783, 0.88043478260869, 0.13636363636364
48639, 0.69565217391304, 0.85434782608696, 0.13636363636364
48640, 0.69565217391304, 0.88043478260869, 0.15909090909091
48641, 0.71739130434783, 0.88043478260869, 0.18181818181818
48642, 0.69565217391304, 0.85434782608696, 0.18181818181818
48643, 0.69565217391304, 0.88043478260869, 0.20454545454545
48644, 0.71739130434783, 0.8804347826087, 0.22727272727273
48645, 0.69565217391304, 0.85434782608696, 0.22727272727273
48646, 0.69565217391304, 0.8804347826087, 0.25
48647, 0.71739130434783, 0.8804347826087, 0.27272727272727
48648, 0.69565217391304, 0.85434782608696, 0.27272727272727
48649, 0.69565217391304, 0.8804347826087, 0.29545454545455
48650, 0.71739130434783, 0.8804347826087, 0.31818181818182
48651, 0.69565217391304, 0.85434782608696, 0.31818181818182
48652, 0.69565217391304, 0.8804347826087, 0.34090909090909
48653, 0.71739130434783, 0.8804347826087, 0.36363636363636
48654, 0.69565217391304, 0.85434782608696, 0.36363636363636
48655, 0.69565217391304, 0.8804347826087, 0.38636363636364
48656, 0.71739130434783, 0.8804347826087, 0.40909090909091
48657, 0.69565217391304, 0.85434782608696, 0.40909090909091
48658, 0.69565217391304, 0.8804347826087, 0.43181818181818
48659, 0.71739130434783, 0.8804347826087, 0.45454545454545
48660, 0.69565217391304, 0.85434782608696, 0.45454545454545
48661, 0.69565217391304, 0.8804347826087, 0.47727272727273
48662, 0.65217391304348, 0.8804347826087, 0.022727272727273
48663, 0.67391304347826, 0.8804347826087, 0.045454545454545
48664, 0.65217391304348, 0.85434782608696, 0.045454545454545
48665, 0.65217391304348, 0.8804347826087, 0.068181818181818
48666, 0.67391304347826, 0.8804347826087, 0.090909090909091
48667, 0.65217391304348, 0.85434782608696, 0.090909090909091
48668, 0.65217391304348, 0.8804347826087, 0.11363636363636
48669, 0.67391304347826, 0.8804347826087, 0.13636363636364
48670, 0.65217391304348, 0.85434782608696, 0.13636363636364
48671, 0.65217391304348, 0.8804347826087, 0.15909090909091
48672, 0.67391304347826, 0.8804347826087, 0.18181818181818
48673, 0.65217391304348, 0.85434782608696, 0.18181818181818
48674, 0.65217391304348, 0.8804347826087, 0.20454545454545
48675, 0.67391304347826, 0.8804347826087, 0.22727272727273
48676, 0.65217391304348, 0.85434782608696, 0.22727272727273
48677, 0.65217391304348, 0.8804347826087, 0.25
48678, 0.67391304347826, 0.8804347826087, 0.27272727272727
48679, 0.65217391304348, 0.85434782608696, 0.27272727272727
48680, 0.65217391304348, 0.8804347826087, 0.29545454545455
48681, 0.67391304347826, 0.8804347826087, 0.31818181818182
48682, 0.65217391304348, 0.85434782608696, 0.31818181818182
48683, 0.65217391304348, 0.8804347826087, 0.34090909090909
48684, 0.67391304347826, 0.8804347826087, 0.36363636363636
48685, 0.65217391304348, 0.85434782608696, 0.36363636363636
48686, 0.65217391304348, 0.8804347826087, 0.38636363636364
48687, 0.67391304347826, 0.8804347826087, 0.40909090909091
48688, 0.65217391304348, 0.85434782608696, 0.40909090909091
48689, 0.65217391304348, 0.8804347826087, 0.43181818181818
48690, 0.67391304347826, 0.8804347826087, 0.45454545454545
48691, 0.65217391304348, 0.85434782608696, 0.45454545454545
48692, 0.65217391304348, 0.8804347826087, 0.47727272727273
48693, 0.60869565217391, 0.8804347826087, 0.022727272727273
48694, 0.6304347826087, 0.8804347826087, 0.045454545454545
48695, 0.60869565217391, 0.85434782608696, 0.045454545454545
48696, 0.60869565217391, 0.8804347826087, 0.068181818181818
48697, 0.6304347826087, 0.8804347826087, 0.090909090909091
48698, 0.60869565217391, 0.85434782608696, 0.090909090909091
48699, 0.60869565217391, 0.8804347826087, 0.11363636363636
48700, 0.6304347826087, 0.8804347826087, 0.13636363636364
48701, 0.60869565217391, 0.85434782608696, 0.13636363636364
48702, 0.60869565217391, 0.8804347826087, 0.15909090909091
48703, 0.6304347826087, 0.8804347826087, 0.18181818181818
48704, 0.60869565217391, 0.85434782608696, 0.18181818181818
48705, 0.60869565217391, 0.8804347826087, 0.20454545454545
48706, 0.6304347826087, 0.8804347826087, 0.22727272727273
48707, 0.60869565217391, 0.85434782608696, 0.22727272727273
48708, 0.60869565217391, 0.8804347826087, 0.25
48709, 0.6304347826087, 0.8804347826087, 0.27272727272727
48710, 0.60869565217391, 0.85434782608696, 0.27272727272727
48711, 0.60869565217391, 0.8804347826087, 0.29545454545455
48712, 0.6304347826087, 0.8804347826087, 0.31818181818182
48713, 0.60869565217391, 0.85434782608696, 0.31818181818182
48714, 0.60869565217391, 0.8804347826087, 0.34090909090909
48715, 0.6304347826087, 0.8804347826087, 0.36363636363636
48716, 0.60869565217391, 0.85434782608696, 0.36363636363636
48717, 0.60869565217391, 0.8804347826087, 0.38636363636364
48718, 0.6304347826087, 0.8804347826087, 0.40909090909091
48719, 0.60869565217391, 0.85434782608696, 0.40909090909091
48720, 0.60869565217391, 0.8804347826087, 0.43181818181818
48721, 0.6304347826087, 0.8804347826087, 0.45454545454545
48722, 0.60869565217391, 0.85434782608696, 0.45454545454545
48723, 0.60869565217391, 0.8804347826087, 0.47727272727273
48724, 0.56521739130435, 0.88043478260869, 0.022727272727273
48725, 0.58695652173913, 0.8804347826087, 0.045454545454545
48726, 0.56521739130435, 0.85434782608696, 0.045454545454545
48727, 0.56521739130435, 0.88043478260869, 0.068181818181818
48728, 0.58695652173913, 0.8804347826087, 0.090909090909091
48729, 0.56521739130435, 0.85434782608696, 0.090909090909091
48730, 0.56521739130435, 0.8804347826087, 0.11363636363636
48731, 0.58695652173913, 0.8804347826087, 0.13636363636364
48732, 0.56521739130435, 0.85434782608696, 0.13636363636364
48733, 0.56521739130435, 0.88043478260869, 0.15909090909091
48734, 0.58695652173913, 0.88043478260869, 0.18181818181818
48735, 0.56521739130435, 0.85434782608696, 0.18181818181818
48736, 0.56521739130435, 0.88043478260869, 0.20454545454545
48737, 0.58695652173913, 0.8804347826087, 0.22727272727273
48738, 0.56521739130435, 0.85434782608696, 0.22727272727273
48739, 0.56521739130435, 0.8804347826087, 0.25
48740, 0.58695652173913, 0.8804347826087, 0.27272727272727
48741, 0.56521739130435, 0.85434782608696, 0.27272727272727
48742, 0.56521739130435, 0.8804347826087, 0.29545454545455
48743, 0.58695652173913, 0.8804347826087, 0.31818181818182
48744, 0.56521739130435, 0.85434782608696, 0.31818181818182
48745, 0.56521739130435, 0.8804347826087, 0.34090909090909
48746, 0.58695652173913, 0.8804347826087, 0.36363636363636
48747, 0.56521739130435, 0.85434782608696, 0.36363636363636
48748, 0.56521739130435, 0.88043478260869, 0.38636363636364
48749, 0.58695652173913, 0.8804347826087, 0.40909090909091
48750, 0.56521739130435, 0.85434782608696, 0.40909090909091
48751, 0.56521739130435, 0.88043478260869, 0.43181818181818
48752, 0.58695652173913, 0.8804347826087, 0.45454545454545
48753, 0.56521739130435, 0.85434782608696, 0.45454545454545
48754, 0.56521739130435, 0.88043478260869, 0.47727272727273
48755, 0.52173913043478, 0.88043478260869, 0.022727272727273
48756, 0.54347826086956, 0.88043478260869, 0.045454545454545
48757, 0.52173913043478, 0.85434782608696, 0.045454545454545
48758, 0.52173913043478, 0.88043478260869, 0.068181818181818
48759, 0.54347826086956, 0.8804347826087, 0.090909090909091
48760, 0.52173913043478, 0.85434782608696, 0.090909090909091
48761, 0.52173913043478, 0.88043478260869, 0.11363636363636
48762, 0.54347826086957, 0.88043478260869, 0.13636363636364
48763, 0.52173913043478, 0.85434782608696, 0.13636363636364
48764, 0.52173913043478, 0.88043478260869, 0.15909090909091
48765, 0.54347826086956, 0.88043478260869, 0.18181818181818
48766, 0.52173913043478, 0.85434782608696, 0.18181818181818
48767, 0.52173913043478, 0.88043478260869, 0.20454545454545
48768, 0.54347826086956, 0.8804347826087, 0.22727272727273
48769, 0.52173913043478, 0.85434782608696, 0.22727272727273
48770, 0.52173913043478, 0.8804347826087, 0.25
48771, 0.54347826086956, 0.88043478260869, 0.27272727272727
48772, 0.52173913043478, 0.85434782608696, 0.27272727272727
48773, 0.52173913043478, 0.88043478260869, 0.29545454545455
48774, 0.54347826086956, 0.88043478260869, 0.31818181818182
48775, 0.52173913043478, 0.85434782608696, 0.31818181818182
48776, 0.52173913043478, 0.88043478260869, 0.34090909090909
48777, 0.54347826086957, 0.88043478260869, 0.36363636363636
48778, 0.52173913043478, 0.85434782608696, 0.36363636363636
48779, 0.52173913043478, 0.88043478260869, 0.38636363636364
48780, 0.54347826086956, 0.88043478260869, 0.40909090909091
48781, 0.52173913043478, 0.85434782608696, 0.40909090909091
48782, 0.52173913043478, 0.88043478260869, 0.43181818181818
48783, 0.54347826086956, 0.88043478260869, 0.45454545454545
48784, 0.52173913043478, 0.85434782608696, 0.45454545454545
48785, 0.52173913043478, 0.88043478260869, 0.47727272727273
48786, 0.47826086956522, 0.88043478260869, 0.022727272727273
48787, 0.5, 0.88043478260869, 0.045454545454545
48788, 0.47826086956522, 0.85434782608696, 0.045454545454545
48789, 0.47826086956522, 0.8804347826087, 0.068181818181818
48790, 0.5, 0.8804347826087, 0.090909090909091
48791, 0.47826086956522, 0.85434782608696, 0.090909090909091
48792, 0.47826086956522, 0.8804347826087, 0.11363636363636
48793, 0.5, 0.88043478260869, 0.13636363636364
48794, 0.47826086956522, 0.85434782608696, 0.13636363636364
48795, 0.47826086956522, 0.88043478260869, 0.15909090909091
48796, 0.5, 0.88043478260869, 0.18181818181818
48797, 0.47826086956522, 0.85434782608696, 0.18181818181818
48798, 0.47826086956522, 0.88043478260869, 0.20454545454545
48799, 0.5, 0.8804347826087, 0.22727272727273
48800, 0.47826086956522, 0.85434782608696, 0.22727272727273
48801, 0.47826086956522, 0.8804347826087, 0.25
48802, 0.5, 0.88043478260869, 0.27272727272727
48803, 0.47826086956522, 0.85434782608696, 0.27272727272727
48804, 0.47826086956522, 0.8804347826087, 0.29545454545455
48805, 0.5, 0.88043478260869, 0.31818181818182
48806, 0.47826086956522, 0.85434782608696, 0.31818181818182
48807, 0.47826086956522, 0.8804347826087, 0.34090909090909
48808, 0.5, 0.88043478260869, 0.36363636363636
48809, 0.47826086956522, 0.85434782608696, 0.36363636363636
48810, 0.47826086956522, 0.8804347826087, 0.38636363636364
48811, 0.5, 0.88043478260869, 0.40909090909091
48812, 0.47826086956522, 0.85434782608696, 0.40909090909091
48813, 0.47826086956522, 0.8804347826087, 0.43181818181818
48814, 0.5, 0.88043478260869, 0.45454545454545
48815, 0.47826086956522, 0.85434782608696, 0.45454545454545
48816, 0.47826086956522, 0.8804347826087, 0.47727272727273
48817, 0.43478260869565, 0.88043478260869, 0.022727272727273
48818, 0.45652173913043, 0.88043478260869, 0.045454545454545
48819, 0.43478260869565, 0.85434782608696, 0.045454545454545
48820, 0.43478260869565, 0.8804347826087, 0.068181818181818
48821, 0.45652173913043, 0.8804347826087, 0.090909090909091
48822, 0.43478260869565, 0.85434782608696, 0.090909090909091
48823, 0.43478260869565, 0.8804347826087, 0.11363636363636
48824, 0.45652173913043, 0.8804347826087, 0.13636363636364
48825, 0.43478260869565, 0.85434782608696, 0.13636363636364
48826, 0.43478260869565, 0.8804347826087, 0.15909090909091
48827, 0.45652173913043, 0.88043478260869, 0.18181818181818
48828, 0.43478260869565, 0.85434782608696, 0.18181818181818
48829, 0.43478260869565, 0.88043478260869, 0.20454545454545
48830, 0.45652173913043, 0.8804347826087, 0.22727272727273
48831, 0.43478260869565, 0.85434782608696, 0.22727272727273
48832, 0.43478260869565, 0.8804347826087, 0.25
48833, 0.45652173913043, 0.8804347826087, 0.27272727272727
48834, 0.43478260869565, 0.85434782608696, 0.27272727272727
48835, 0.43478260869565, 0.8804347826087, 0.29545454545455
48836, 0.45652173913043, 0.8804347826087, 0.31818181818182
48837, 0.43478260869565, 0.85434782608696, 0.31818181818182
48838, 0.43478260869565, 0.8804347826087, 0.34090909090909
48839, 0.45652173913043, 0.88043478260869, 0.36363636363636
48840, 0.43478260869565, 0.85434782608696, 0.36363636363636
48841, 0.43478260869565, 0.8804347826087, 0.38636363636364
48842, 0.45652173913043, 0.8804347826087, 0.40909090909091
48843, 0.43478260869565, 0.85434782608696, 0.40909090909091
48844, 0.43478260869565, 0.8804347826087, 0.43181818181818
48845, 0.45652173913043, 0.8804347826087, 0.45454545454545
48846, 0.43478260869565, 0.85434782608696, 0.45454545454545
48847, 0.43478260869565, 0.8804347826087, 0.47727272727273
48848, 0.39130434782609, 0.88043478260869, 0.022727272727273
48849, 0.41304347826087, 0.88043478260869, 0.045454545454545
48850, 0.39130434782609, 0.85434782608696, 0.045454545454545
48851, 0.39130434782609, 0.88043478260869, 0.068181818181818
48852, 0.41304347826087, 0.8804347826087, 0.090909090909091
48853, 0.39130434782609, 0.85434782608696, 0.090909090909091
48854, 0.39130434782609, 0.8804347826087, 0.11363636363636
48855, 0.41304347826087, 0.8804347826087, 0.13636363636364
48856, 0.39130434782609, 0.85434782608696, 0.13636363636364
48857, 0.39130434782609, 0.88043478260869, 0.15909090909091
48858, 0.41304347826087, 0.88043478260869, 0.18181818181818
48859, 0.39130434782609, 0.85434782608696, 0.18181818181818
48860, 0.39130434782609, 0.88043478260869, 0.20454545454545
48861, 0.41304347826087, 0.8804347826087, 0.22727272727273
48862, 0.39130434782609, 0.85434782608696, 0.22727272727273
48863, 0.39130434782609, 0.8804347826087, 0.25
48864, 0.41304347826087, 0.8804347826087, 0.27272727272727
48865, 0.39130434782609, 0.85434782608696, 0.27272727272727
48866, 0.39130434782609, 0.88043478260869, 0.29545454545455
48867, 0.41304347826087, 0.88043478260869, 0.31818181818182
48868, 0.39130434782609, 0.85434782608696, 0.31818181818182
48869, 0.39130434782609, 0.88043478260869, 0.34090909090909
48870, 0.41304347826087, 0.88043478260869, 0.36363636363636
48871, 0.39130434782609, 0.85434782608696, 0.36363636363636
48872, 0.39130434782609, 0.88043478260869, 0.38636363636364
48873, 0.41304347826087, 0.88043478260869, 0.40909090909091
48874, 0.39130434782609, 0.85434782608696, 0.40909090909091
48875, 0.39130434782609, 0.88043478260869, 0.43181818181818
48876, 0.41304347826087, 0.8804347826087, 0.45454545454545
48877, 0.39130434782609, 0.85434782608696, 0.45454545454545
48878, 0.39130434782609, 0.88043478260869, 0.47727272727273
48879, 0.34782608695652, 0.8804347826087, 0.022727272727273
48880, 0.3695652173913, 0.8804347826087, 0.045454545454545
48881, 0.34782608695652, 0.85434782608696, 0.045454545454545
48882, 0.34782608695652, 0.8804347826087, 0.068181818181818
48883, 0.3695652173913, 0.8804347826087, 0.090909090909091
48884, 0.34782608695652, 0.85434782608696, 0.090909090909091
48885, 0.34782608695652, 0.8804347826087, 0.11363636363636
48886, 0.3695652173913, 0.8804347826087, 0.13636363636364
48887, 0.34782608695652, 0.85434782608696, 0.13636363636364
48888, 0.34782608695652, 0.8804347826087, 0.15909090909091
48889, 0.3695652173913, 0.88043478260869, 0.18181818181818
48890, 0.34782608695652, 0.85434782608696, 0.18181818181818
48891, 0.34782608695652, 0.8804347826087, 0.20454545454545
48892, 0.3695652173913, 0.8804347826087, 0.22727272727273
48893, 0.34782608695652, 0.85434782608696, 0.22727272727273
48894, 0.34782608695652, 0.8804347826087, 0.25
48895, 0.3695652173913, 0.8804347826087, 0.27272727272727
48896, 0.34782608695652, 0.85434782608696, 0.27272727272727
48897, 0.34782608695652, 0.8804347826087, 0.29545454545455
48898, 0.3695652173913, 0.88043478260869, 0.31818181818182
48899, 0.34782608695652, 0.85434782608696, 0.31818181818182
48900, 0.34782608695652, 0.8804347826087, 0.34090909090909
48901, 0.3695652173913, 0.8804347826087, 0.36363636363636
48902, 0.34782608695652, 0.85434782608696, 0.36363636363636
48903, 0.34782608695652, 0.8804347826087, 0.38636363636364
48904, 0.3695652173913, 0.88043478260869, 0.40909090909091
48905, 0.34782608695652, 0.85434782608696, 0.40909090909091
48906, 0.34782608695652, 0.8804347826087, 0.43181818181818
48907, 0.3695652173913, 0.8804347826087, 0.45454545454545
48908, 0.34782608695652, 0.85434782608696, 0.45454545454545
48909, 0.34782608695652, 0.8804347826087, 0.47727272727273
48910, 0.30434782608696, 0.88043478260869, 0.022727272727273
48911, 0.32608695652174, 0.8804347826087, 0.045454545454545
48912, 0.30434782608696, 0.85434782608696, 0.045454545454545
48913, 0.30434782608696, 0.88043478260869, 0.068181818181818
48914, 0.32608695652174, 0.88043478260869, 0.090909090909091
48915, 0.30434782608696, 0.85434782608696, 0.090909090909091
48916, 0.30434782608696, 0.88043478260869, 0.11363636363636
48917, 0.32608695652174, 0.8804347826087, 0.13636363636364
48918, 0.30434782608696, 0.85434782608696, 0.13636363636364
48919, 0.30434782608696, 0.88043478260869, 0.15909090909091
48920, 0.32608695652174, 0.8804347826087, 0.18181818181818
48921, 0.30434782608696, 0.85434782608696, 0.18181818181818
48922, 0.30434782608696, 0.8804347826087, 0.20454545454545
48923, 0.32608695652174, 0.8804347826087, 0.22727272727273
48924, 0.30434782608696, 0.85434782608696, 0.22727272727273
48925, 0.30434782608696, 0.8804347826087, 0.25
48926, 0.32608695652174, 0.8804347826087, 0.27272727272727
48927, 0.30434782608696, 0.85434782608696, 0.27272727272727
48928, 0.30434782608696, 0.8804347826087, 0.29545454545455
48929, 0.32608695652174, 0.8804347826087, 0.31818181818182
48930, 0.30434782608696, 0.85434782608696, 0.31818181818182
48931, 0.30434782608696, 0.8804347826087, 0.34090909090909
48932, 0.32608695652174, 0.8804347826087, 0.36363636363636
48933, 0.30434782608696, 0.85434782608696, 0.36363636363636
48934, 0.30434782608696, 0.88043478260869, 0.38636363636364
48935, 0.32608695652174, 0.88043478260869, 0.40909090909091
48936, 0.30434782608696, 0.85434782608696, 0.40909090909091
48937, 0.30434782608696, 0.88043478260869, 0.43181818181818
48938, 0.32608695652174, 0.8804347826087, 0.45454545454545
48939, 0.30434782608696, 0.85434782608696, 0.45454545454545
48940, 0.30434782608696, 0.88043478260869, 0.47727272727273
48941, 0.26086956521739, 0.88043478260869, 0.022727272727273
48942, 0.28260869565217, 0.88043478260869, 0.045454545454545
48943, 0.26086956521739, 0.85434782608696, 0.045454545454545
48944, 0.26086956521739, 0.88043478260869, 0.068181818181818
48945, 0.28260869565217, 0.8804347826087, 0.090909090909091
48946, 0.26086956521739, 0.85434782608696, 0.090909090909091
48947, 0.26086956521739, 0.88043478260869, 0.11363636363636
48948, 0.28260869565217, 0.88043478260869, 0.13636363636364
48949, 0.26086956521739, 0.85434782608696, 0.13636363636364
48950, 0.26086956521739, 0.88043478260869, 0.15909090909091
48951, 0.28260869565217, 0.88043478260869, 0.18181818181818
48952, 0.26086956521739, 0.85434782608696, 0.18181818181818
48953, 0.26086956521739, 0.88043478260869, 0.20454545454545
48954, 0.28260869565217, 0.8804347826087, 0.22727272727273
48955, 0.26086956521739, 0.85434782608696, 0.22727272727273
48956, 0.26086956521739, 0.88043478260869, 0.25
48957, 0.28260869565217, 0.88043478260869, 0.27272727272727
48958, 0.26086956521739, 0.85434782608696, 0.27272727272727
48959, 0.26086956521739, 0.8804347826087, 0.29545454545455
48960, 0.28260869565217, 0.8804347826087, 0.31818181818182
48961, 0.26086956521739, 0.85434782608696, 0.31818181818182
48962, 0.26086956521739, 0.8804347826087, 0.34090909090909
48963, 0.28260869565217, 0.88043478260869, 0.36363636363636
48964, 0.26086956521739, 0.85434782608696, 0.36363636363636
48965, 0.26086956521739, 0.88043478260869, 0.38636363636364
48966, 0.28260869565217, 0.88043478260869, 0.40909090909091
48967, 0.26086956521739, 0.85434782608696, 0.40909090909091
48968, 0.26086956521739, 0.88043478260869, 0.43181818181818
48969, 0.28260869565217, 0.88043478260869, 0.45454545454545
48970, 0.26086956521739, 0.85434782608696, 0.45454545454545
48971, 0.26086956521739, 0.8804347826087, 0.47727272727273
48972, 0.21739130434783, 0.8804347826087, 0.022727272727273
48973, 0.23913043478261, 0.8804347826087, 0.045454545454545
48974, 0.21739130434783, 0.85434782608696, 0.045454545454545
48975, 0.21739130434783, 0.8804347826087, 0.068181818181818
48976, 0.23913043478261, 0.8804347826087, 0.090909090909091
48977, 0.21739130434783, 0.85434782608696, 0.090909090909091
48978, 0.21739130434783, 0.88043478260869, 0.11363636363636
48979, 0.23913043478261, 0.88043478260869, 0.13636363636364
48980, 0.21739130434783, 0.85434782608696, 0.13636363636364
48981, 0.21739130434783, 0.88043478260869, 0.15909090909091
48982, 0.23913043478261, 0.88043478260869, 0.18181818181818
48983, 0.21739130434783, 0.85434782608696, 0.18181818181818
48984, 0.21739130434783, 0.88043478260869, 0.20454545454545
48985, 0.23913043478261, 0.88043478260869, 0.22727272727273
48986, 0.21739130434783, 0.85434782608696, 0.22727272727273
48987, 0.21739130434783, 0.8804347826087, 0.25
48988, 0.23913043478261, 0.88043478260869, 0.27272727272727
48989, 0.21739130434783, 0.85434782608696, 0.27272727272727
48990, 0.21739130434783, 0.8804347826087, 0.29545454545455
48991, 0.23913043478261, 0.8804347826087, 0.31818181818182
48992, 0.21739130434783, 0.85434782608696, 0.31818181818182
48993, 0.21739130434783, 0.8804347826087, 0.34090909090909
48994, 0.23913043478261, 0.88043478260869, 0.36363636363636
48995, 0.21739130434783, 0.85434782608696, 0.36363636363636
48996, 0.21739130434783, 0.88043478260869, 0.38636363636364
48997, 0.23913043478261, 0.88043478260869, 0.40909090909091
48998, 0.21739130434783, 0.85434782608696, 0.40909090909091
48999, 0.21739130434783, 0.88043478260869, 0.43181818181818
49000, 0.23913043478261, 0.8804347826087, 0.45454545454545
49001, 0.21739130434783, 0.85434782608696, 0.45454545454545
49002, 0.21739130434783, 0.8804347826087, 0.47727272727273
49003, 0.17391304347826, 0.88043478260869, 0.022727272727273
49004, 0.19565217391304, 0.8804347826087, 0.045454545454545
49005, 0.17391304347826, 0.85434782608696, 0.045454545454545
49006, 0.17391304347826, 0.8804347826087, 0.068181818181818
49007, 0.19565217391304, 0.8804347826087, 0.090909090909091
49008, 0.17391304347826, 0.85434782608696, 0.090909090909091
49009, 0.17391304347826, 0.8804347826087, 0.11363636363636
49010, 0.19565217391304, 0.88043478260869, 0.13636363636364
49011, 0.17391304347826, 0.85434782608696, 0.13636363636364
49012, 0.17391304347826, 0.88043478260869, 0.15909090909091
49013, 0.19565217391304, 0.88043478260869, 0.18181818181818
49014, 0.17391304347826, 0.85434782608696, 0.18181818181818
49015, 0.17391304347826, 0.88043478260869, 0.20454545454545
49016, 0.19565217391304, 0.88043478260869, 0.22727272727273
49017, 0.17391304347826, 0.85434782608696, 0.22727272727273
49018, 0.17391304347826, 0.88043478260869, 0.25
49019, 0.19565217391304, 0.88043478260869, 0.27272727272727
49020, 0.17391304347826, 0.85434782608696, 0.27272727272727
49021, 0.17391304347826, 0.8804347826087, 0.29545454545455
49022, 0.19565217391304, 0.8804347826087, 0.31818181818182
49023, 0.17391304347826, 0.85434782608696, 0.31818181818182
49024, 0.17391304347826, 0.8804347826087, 0.34090909090909
49025, 0.19565217391304, 0.88043478260869, 0.36363636363636
49026, 0.17391304347826, 0.85434782608696, 0.36363636363636
49027, 0.17391304347826, 0.8804347826087, 0.38636363636364
49028, 0.19565217391304, 0.88043478260869, 0.40909090909091
49029, 0.17391304347826, 0.85434782608696, 0.40909090909091
49030, 0.17391304347826, 0.88043478260869, 0.43181818181818
49031, 0.19565217391304, 0.88043478260869, 0.45454545454545
49032, 0.17391304347826, 0.85434782608696, 0.45454545454545
49033, 0.17391304347826, 0.88043478260869, 0.47727272727273
49034, 0.1304347826087, 0.88043478260869, 0.022727272727273
49035, 0.15217391304348, 0.88043478260869, 0.045454545454545
49036, 0.1304347826087, 0.85434782608696, 0.045454545454545
49037, 0.1304347826087, 0.8804347826087, 0.068181818181818
49038, 0.15217391304348, 0.8804347826087, 0.090909090909091
49039, 0.1304347826087, 0.85434782608696, 0.090909090909091
49040, 0.1304347826087, 0.8804347826087, 0.11363636363636
49041, 0.15217391304348, 0.88043478260869, 0.13636363636364
49042, 0.1304347826087, 0.85434782608696, 0.13636363636364
49043, 0.1304347826087, 0.88043478260869, 0.15909090909091
49044, 0.15217391304348, 0.88043478260869, 0.18181818181818
49045, 0.1304347826087, 0.85434782608696, 0.18181818181818
49046, 0.1304347826087, 0.88043478260869, 0.20454545454545
49047, 0.15217391304348, 0.88043478260869, 0.22727272727273
49048, 0.1304347826087, 0.85434782608696, 0.22727272727273
49049, 0.1304347826087, 0.88043478260869, 0.25
49050, 0.15217391304348, 0.88043478260869, 0.27272727272727
49051, 0.1304347826087, 0.85434782608696, 0.27272727272727
49052, 0.1304347826087, 0.8804347826087, 0.29545454545455
49053, 0.15217391304348, 0.8804347826087, 0.31818181818182
49054, 0.1304347826087, 0.85434782608696, 0.31818181818182
49055, 0.1304347826087, 0.8804347826087, 0.34090909090909
49056, 0.15217391304348, 0.88043478260869, 0.36363636363636
49057, 0.1304347826087, 0.85434782608696, 0.36363636363636
49058, 0.1304347826087, 0.88043478260869, 0.38636363636364
49059, 0.15217391304348, 0.8804347826087, 0.40909090909091
49060, 0.1304347826087, 0.85434782608696, 0.40909090909091
49061, 0.1304347826087, 0.88043478260869, 0.43181818181818
49062, 0.15217391304348, 0.88043478260869, 0.45454545454545
49063, 0.1304347826087, 0.85434782608696, 0.45454545454545
49064, 0.1304347826087, 0.88043478260869, 0.47727272727273
49065, 0.08695652173913, 0.8804347826087, 0.022727272727273
49066, 0.10869565217391, 0.8804347826087, 0.045454545454545
49067, 0.08695652173913, 0.85434782608696, 0.045454545454545
49068, 0.08695652173913, 0.8804347826087, 0.068181818181818
49069, 0.10869565217391, 0.8804347826087, 0.090909090909091
49070, 0.08695652173913, 0.85434782608696, 0.090909090909091
49071, 0.08695652173913, 0.8804347826087, 0.11363636363636
49072, 0.10869565217391, 0.8804347826087, 0.13636363636364
49073, 0.08695652173913, 0.85434782608696, 0.13636363636364
49074, 0.08695652173913, 0.8804347826087, 0.15909090909091
49075, 0.10869565217391, 0.88043478260869, 0.18181818181818
49076, 0.08695652173913, 0.85434782608696, 0.18181818181818
49077, 0.08695652173913, 0.8804347826087, 0.20454545454545
49078, 0.10869565217391, 0.8804347826087, 0.22727272727273
49079, 0.08695652173913, 0.85434782608696, 0.22727272727273
49080, 0.08695652173913, 0.8804347826087, 0.25
49081, 0.10869565217391, 0.8804347826087, 0.27272727272727
49082, 0.08695652173913, 0.85434782608696, 0.27272727272727
49083, 0.08695652173913, 0.8804347826087, 0.29545454545455
49084, 0.10869565217391, 0.8804347826087, 0.31818181818182
49085, 0.08695652173913, 0.85434782608696, 0.31818181818182
49086, 0.08695652173913, 0.8804347826087, 0.34090909090909
49087, 0.10869565217391, 0.8804347826087, 0.36363636363636
49088, 0.08695652173913, 0.85434782608696, 0.36363636363636
49089, 0.08695652173913, 0.8804347826087, 0.38636363636364
49090, 0.10869565217391, 0.8804347826087, 0.40909090909091
49091, 0.08695652173913, 0.85434782608696, 0.40909090909091
49092, 0.08695652173913, 0.8804347826087, 0.43181818181818
49093, 0.10869565217391, 0.8804347826087, 0.45454545454545
49094, 0.08695652173913, 0.85434782608696, 0.45454545454545
49095, 0.08695652173913, 0.8804347826087, 0.47727272727273
49096, 0.043478260869565, 0.8804347826087, 0.022727272727273
49097, 0.065217391304348, 0.8804347826087, 0.045454545454545
49098, 0.043478260869565, 0.85434782608696, 0.045454545454545
49099, 0.043478260869565, 0.8804347826087, 0.068181818181818
49100, 0.065217391304348, 0.8804347826087, 0.090909090909091
49101, 0.043478260869565, 0.85434782608696, 0.090909090909091
49102, 0.043478260869565, 0.8804347826087, 0.11363636363636
49103, 0.065217391304348, 0.8804347826087, 0.13636363636364
49104, 0.043478260869565, 0.85434782608696, 0.13636363636364
49105, 0.043478260869565, 0.88043478260869, 0.15909090909091
49106, 0.065217391304348, 0.88043478260869, 0.18181818181818
49107, 0.043478260869565, 0.85434782608696, 0.18181818181818
49108, 0.043478260869565, 0.88043478260869, 0.20454545454545
49109, 0.065217391304348, 0.8804347826087, 0.22727272727273
49110, 0.043478260869565, 0.85434782608696, 0.22727272727273
49111, 0.043478260869565, 0.8804347826087, 0.25
49112, 0.065217391304348, 0.8804347826087, 0.27272727272727
49113, 0.043478260869565, 0.85434782608696, 0.27272727272727
49114, 0.043478260869565, 0.8804347826087, 0.29545454545455
49115, 0.065217391304348, 0.8804347826087, 0.31818181818182
49116, 0.043478260869565, 0.85434782608696, 0.31818181818182
49117, 0.043478260869565, 0.8804347826087, 0.34090909090909
49118, 0.065217391304348, 0.8804347826087, 0.36363636363636
49119, 0.043478260869565, 0.85434782608696, 0.36363636363636
49120, 0.043478260869565, 0.88043478260869, 0.38636363636364
49121, 0.065217391304348, 0.8804347826087, 0.40909090909091
49122, 0.043478260869565, 0.85434782608696, 0.40909090909091
49123, 0.043478260869565, 0.8804347826087, 0.43181818181818
49124, 0.065217391304348, 0.8804347826087, 0.45454545454545
49125, 0.043478260869565, 0.85434782608696, 0.45454545454545
49126, 0.043478260869565, 0.8804347826087, 0.47727272727273
49127, 0.021739130434783, 0.8804347826087, 0.045454545454545
49128, 0.021739130434783, 0.8804347826087, 0.090909090909091
49129, 0.021739130434783, 0.8804347826087, 0.13636363636364
49130, 0.021739130434783, 0.88043478260869, 0.18181818181818
49131, 0.021739130434783, 0.8804347826087, 0.22727272727273
49132, 0.021739130434783, 0.8804347826087, 0.27272727272727
49133, 0.021739130434783, 0.8804347826087, 0.31818181818182
49134, 0.021739130434783, 0.88043478260869, 0.36363636363636
49135, 0.021739130434783, 0.8804347826087, 0.40909090909091
49136, 0.021739130434783, 0.8804347826087, 0.45454545454545
49137, 0.95652173913043, 0.93260869565217, 0.022727272727273
49138, 0.97826086956522, 0.93260869565217, 0.045454545454545
49139, 0.95652173913043, 0.90652173913043, 0.045454545454545
49140, 0.95652173913043, 0.93260869565217, 0.068181818181818
49141, 0.97826086956522, 0.93260869565217, 0.090909090909091
49142, 0.95652173913044, 0.90652173913043, 0.090909090909091
49143, 0.95652173913044, 0.93260869565217, 0.11363636363636
49144, 0.97826086956522, 0.93260869565217, 0.13636363636364
49145, 0.95652173913044, 0.90652173913043, 0.13636363636364
49146, 0.95652173913044, 0.93260869565217, 0.15909090909091
49147, 0.97826086956522, 0.93260869565217, 0.18181818181818
49148, 0.95652173913044, 0.90652173913043, 0.18181818181818
49149, 0.95652173913044, 0.93260869565217, 0.20454545454545
49150, 0.97826086956522, 0.93260869565217, 0.22727272727273
49151, 0.95652173913044, 0.90652173913043, 0.22727272727273
49152, 0.95652173913044, 0.93260869565217, 0.25
49153, 0.97826086956522, 0.93260869565217, 0.27272727272727
49154, 0.95652173913044, 0.90652173913043, 0.27272727272727
49155, 0.95652173913044, 0.93260869565217, 0.29545454545455
49156, 0.97826086956522, 0.93260869565217, 0.31818181818182
49157, 0.95652173913044, 0.90652173913043, 0.31818181818182
49158, 0.95652173913043, 0.93260869565217, 0.34090909090909
49159, 0.97826086956522, 0.93260869565217, 0.36363636363636
49160, 0.95652173913043, 0.90652173913043, 0.36363636363636
49161, 0.95652173913043, 0.93260869565217, 0.38636363636364
49162, 0.97826086956522, 0.93260869565217, 0.40909090909091
49163, 0.95652173913043, 0.90652173913043, 0.40909090909091
49164, 0.95652173913043, 0.93260869565217, 0.43181818181818
49165, 0.97826086956522, 0.93260869565217, 0.45454545454545
49166, 0.95652173913044, 0.90652173913043, 0.45454545454545
49167, 0.95652173913043, 0.93260869565217, 0.47727272727273
49168, 0.91304347826087, 0.93260869565217, 0.022727272727273
49169, 0.93478260869565, 0.93260869565217, 0.045454545454545
49170, 0.91304347826087, 0.90652173913043, 0.045454545454545
49171, 0.91304347826087, 0.93260869565217, 0.068181818181818
49172, 0.93478260869565, 0.93260869565217, 0.090909090909091
49173, 0.91304347826087, 0.90652173913043, 0.090909090909091
49174, 0.91304347826087, 0.93260869565217, 0.11363636363636
49175, 0.93478260869565, 0.93260869565217, 0.13636363636364
49176, 0.91304347826087, 0.90652173913043, 0.13636363636364
49177, 0.91304347826087, 0.93260869565217, 0.15909090909091
49178, 0.93478260869565, 0.93260869565217, 0.18181818181818
49179, 0.91304347826087, 0.90652173913043, 0.18181818181818
49180, 0.91304347826087, 0.93260869565217, 0.20454545454545
49181, 0.93478260869565, 0.93260869565217, 0.22727272727273
49182, 0.91304347826087, 0.90652173913043, 0.22727272727273
49183, 0.91304347826087, 0.93260869565217, 0.25
49184, 0.93478260869565, 0.93260869565217, 0.27272727272727
49185, 0.91304347826087, 0.90652173913043, 0.27272727272727
49186, 0.91304347826087, 0.93260869565217, 0.29545454545455
49187, 0.93478260869565, 0.93260869565217, 0.31818181818182
49188, 0.91304347826087, 0.90652173913043, 0.31818181818182
49189, 0.91304347826087, 0.93260869565217, 0.34090909090909
49190, 0.93478260869565, 0.93260869565217, 0.36363636363636
49191, 0.91304347826087, 0.90652173913043, 0.36363636363636
49192, 0.91304347826087, 0.93260869565217, 0.38636363636364
49193, 0.93478260869565, 0.93260869565217, 0.40909090909091
49194, 0.91304347826087, 0.90652173913043, 0.40909090909091
49195, 0.91304347826087, 0.93260869565217, 0.43181818181818
49196, 0.93478260869565, 0.93260869565217, 0.45454545454545
49197, 0.91304347826087, 0.90652173913043, 0.45454545454545
49198, 0.91304347826087, 0.93260869565217, 0.47727272727273
49199, 0.8695652173913, 0.93260869565217, 0.022727272727273
49200, 0.89130434782609, 0.93260869565217, 0.045454545454545
49201, 0.8695652173913, 0.90652173913043, 0.045454545454545
49202, 0.8695652173913, 0.93260869565217, 0.068181818181818
49203, 0.89130434782609, 0.93260869565217, 0.090909090909091
49204, 0.8695652173913, 0.90652173913043, 0.090909090909091
49205, 0.8695652173913, 0.93260869565217, 0.11363636363636
49206, 0.89130434782609, 0.93260869565217, 0.13636363636364
49207, 0.8695652173913, 0.90652173913043, 0.13636363636364
49208, 0.8695652173913, 0.93260869565217, 0.15909090909091
49209, 0.89130434782609, 0.93260869565217, 0.18181818181818
49210, 0.8695652173913, 0.90652173913043, 0.18181818181818
49211, 0.8695652173913, 0.93260869565217, 0.20454545454545
49212, 0.89130434782609, 0.93260869565217, 0.22727272727273
49213, 0.8695652173913, 0.90652173913043, 0.22727272727273
49214, 0.8695652173913, 0.93260869565217, 0.25
49215, 0.89130434782609, 0.93260869565217, 0.27272727272727
49216, 0.8695652173913, 0.90652173913043, 0.27272727272727
49217, 0.8695652173913, 0.93260869565217, 0.29545454545455
49218, 0.89130434782609, 0.93260869565217, 0.31818181818182
49219, 0.8695652173913, 0.90652173913043, 0.31818181818182
49220, 0.8695652173913, 0.93260869565217, 0.34090909090909
49221, 0.89130434782609, 0.93260869565217, 0.36363636363636
49222, 0.8695652173913, 0.90652173913043, 0.36363636363636
49223, 0.8695652173913, 0.93260869565217, 0.38636363636364
49224, 0.89130434782609, 0.93260869565217, 0.40909090909091
49225, 0.8695652173913, 0.90652173913043, 0.40909090909091
49226, 0.8695652173913, 0.93260869565217, 0.43181818181818
49227, 0.89130434782609, 0.93260869565217, 0.45454545454545
49228, 0.8695652173913, 0.90652173913043, 0.45454545454545
49229, 0.8695652173913, 0.93260869565217, 0.47727272727273
49230, 0.82608695652174, 0.93260869565217, 0.022727272727273
49231, 0.84782608695652, 0.93260869565217, 0.045454545454545
49232, 0.82608695652174, 0.90652173913043, 0.045454545454545
49233, 0.82608695652174, 0.93260869565217, 0.068181818181818
49234, 0.84782608695652, 0.93260869565217, 0.090909090909091
49235, 0.82608695652174, 0.90652173913043, 0.090909090909091
49236, 0.82608695652174, 0.93260869565217, 0.11363636363636
49237, 0.84782608695652, 0.93260869565217, 0.13636363636364
49238, 0.82608695652174, 0.90652173913043, 0.13636363636364
49239, 0.82608695652174, 0.93260869565217, 0.15909090909091
49240, 0.84782608695652, 0.93260869565217, 0.18181818181818
49241, 0.82608695652174, 0.90652173913043, 0.18181818181818
49242, 0.82608695652174, 0.93260869565217, 0.20454545454545
49243, 0.84782608695652, 0.93260869565217, 0.22727272727273
49244, 0.82608695652174, 0.90652173913043, 0.22727272727273
49245, 0.82608695652174, 0.93260869565217, 0.25
49246, 0.84782608695652, 0.93260869565217, 0.27272727272727
49247, 0.82608695652174, 0.90652173913043, 0.27272727272727
49248, 0.82608695652174, 0.93260869565217, 0.29545454545455
49249, 0.84782608695652, 0.93260869565217, 0.31818181818182
49250, 0.82608695652174, 0.90652173913043, 0.31818181818182
49251, 0.82608695652174, 0.93260869565217, 0.34090909090909
49252, 0.84782608695652, 0.93260869565217, 0.36363636363636
49253, 0.82608695652174, 0.90652173913043, 0.36363636363636
49254, 0.82608695652174, 0.93260869565217, 0.38636363636364
49255, 0.84782608695652, 0.93260869565217, 0.40909090909091
49256, 0.82608695652174, 0.90652173913043, 0.40909090909091
49257, 0.82608695652174, 0.93260869565217, 0.43181818181818
49258, 0.84782608695652, 0.93260869565217, 0.45454545454545
49259, 0.82608695652174, 0.90652173913043, 0.45454545454545
49260, 0.82608695652174, 0.93260869565217, 0.47727272727273
49261, 0.78260869565217, 0.93260869565217, 0.022727272727273
49262, 0.80434782608696, 0.93260869565217, 0.045454545454545
49263, 0.78260869565217, 0.90652173913043, 0.045454545454545
49264, 0.78260869565217, 0.93260869565217, 0.068181818181818
49265, 0.80434782608696, 0.93260869565217, 0.090909090909091
49266, 0.78260869565217, 0.90652173913043, 0.090909090909091
49267, 0.78260869565217, 0.93260869565217, 0.11363636363636
49268, 0.80434782608696, 0.93260869565217, 0.13636363636364
49269, 0.78260869565217, 0.90652173913043, 0.13636363636364
49270, 0.78260869565217, 0.93260869565217, 0.15909090909091
49271, 0.80434782608696, 0.93260869565217, 0.18181818181818
49272, 0.78260869565217, 0.90652173913043, 0.18181818181818
49273, 0.78260869565217, 0.93260869565217, 0.20454545454545
49274, 0.80434782608696, 0.93260869565217, 0.22727272727273
49275, 0.78260869565217, 0.90652173913043, 0.22727272727273
49276, 0.78260869565217, 0.93260869565217, 0.25
49277, 0.80434782608696, 0.93260869565217, 0.27272727272727
49278, 0.78260869565217, 0.90652173913043, 0.27272727272727
49279, 0.78260869565217, 0.93260869565217, 0.29545454545455
49280, 0.80434782608696, 0.93260869565217, 0.31818181818182
49281, 0.78260869565217, 0.90652173913043, 0.31818181818182
49282, 0.78260869565217, 0.93260869565217, 0.34090909090909
49283, 0.80434782608696, 0.93260869565217, 0.36363636363636
49284, 0.78260869565217, 0.90652173913043, 0.36363636363636
49285, 0.78260869565217, 0.93260869565217, 0.38636363636364
49286, 0.80434782608696, 0.93260869565217, 0.40909090909091
49287, 0.78260869565217, 0.90652173913043, 0.40909090909091
49288, 0.78260869565217, 0.93260869565217, 0.43181818181818
49289, 0.80434782608696, 0.93260869565217, 0.45454545454545
49290, 0.78260869565217, 0.90652173913043, 0.45454545454545
49291, 0.78260869565217, 0.93260869565217, 0.47727272727273
49292, 0.73913043478261, 0.93260869565217, 0.022727272727273
49293, 0.76086956521739, 0.93260869565217, 0.045454545454545
49294, 0.73913043478261, 0.90652173913043, 0.045454545454545
49295, 0.73913043478261, 0.93260869565217, 0.068181818181818
49296, 0.76086956521739, 0.93260869565217, 0.090909090909091
49297, 0.73913043478261, 0.90652173913043, 0.090909090909091
49298, 0.73913043478261, 0.93260869565217, 0.11363636363636
49299, 0.76086956521739, 0.93260869565217, 0.13636363636364
49300, 0.73913043478261, 0.90652173913043, 0.13636363636364
49301, 0.73913043478261, 0.93260869565217, 0.15909090909091
49302, 0.76086956521739, 0.93260869565217, 0.18181818181818
49303, 0.73913043478261, 0.90652173913043, 0.18181818181818
49304, 0.73913043478261, 0.93260869565217, 0.20454545454545
49305, 0.76086956521739, 0.93260869565217, 0.22727272727273
49306, 0.73913043478261, 0.90652173913043, 0.22727272727273
49307, 0.73913043478261, 0.93260869565217, 0.25
49308, 0.76086956521739, 0.93260869565217, 0.27272727272727
49309, 0.73913043478261, 0.90652173913043, 0.27272727272727
49310, 0.73913043478261, 0.93260869565217, 0.29545454545455
49311, 0.76086956521739, 0.93260869565217, 0.31818181818182
49312, 0.73913043478261, 0.90652173913043, 0.31818181818182
49313, 0.73913043478261, 0.93260869565217, 0.34090909090909
49314, 0.76086956521739, 0.93260869565217, 0.36363636363636
49315, 0.73913043478261, 0.90652173913043, 0.36363636363636
49316, 0.73913043478261, 0.93260869565217, 0.38636363636364
49317, 0.76086956521739, 0.93260869565217, 0.40909090909091
49318, 0.73913043478261, 0.90652173913043, 0.40909090909091
49319, 0.73913043478261, 0.93260869565217, 0.43181818181818
49320, 0.76086956521739, 0.93260869565217, 0.45454545454545
49321, 0.73913043478261, 0.90652173913043, 0.45454545454545
49322, 0.73913043478261, 0.93260869565217, 0.47727272727273
49323, 0.69565217391304, 0.93260869565217, 0.022727272727273
49324, 0.71739130434783, 0.93260869565217, 0.045454545454545
49325, 0.69565217391304, 0.90652173913043, 0.045454545454545
49326, 0.69565217391304, 0.93260869565217, 0.068181818181818
49327, 0.71739130434783, 0.93260869565217, 0.090909090909091
49328, 0.69565217391304, 0.90652173913043, 0.090909090909091
49329, 0.69565217391304, 0.93260869565217, 0.11363636363636
49330, 0.71739130434783, 0.93260869565217, 0.13636363636364
49331, 0.69565217391304, 0.90652173913043, 0.13636363636364
49332, 0.69565217391304, 0.93260869565217, 0.15909090909091
49333, 0.71739130434783, 0.93260869565217, 0.18181818181818
49334, 0.69565217391304, 0.90652173913043, 0.18181818181818
49335, 0.69565217391304, 0.93260869565217, 0.20454545454545
49336, 0.71739130434783, 0.93260869565217, 0.22727272727273
49337, 0.69565217391304, 0.90652173913043, 0.22727272727273
49338, 0.69565217391304, 0.93260869565217, 0.25
49339, 0.71739130434783, 0.93260869565217, 0.27272727272727
49340, 0.69565217391304, 0.90652173913043, 0.27272727272727
49341, 0.69565217391304, 0.93260869565217, 0.29545454545455
49342, 0.71739130434783, 0.93260869565217, 0.31818181818182
49343, 0.69565217391304, 0.90652173913043, 0.31818181818182
49344, 0.69565217391304, 0.93260869565217, 0.34090909090909
49345, 0.71739130434783, 0.93260869565217, 0.36363636363636
49346, 0.69565217391304, 0.90652173913043, 0.36363636363636
49347, 0.69565217391304, 0.93260869565217, 0.38636363636364
49348, 0.71739130434783, 0.93260869565217, 0.40909090909091
49349, 0.69565217391304, 0.90652173913043, 0.40909090909091
49350, 0.69565217391304, 0.93260869565217, 0.43181818181818
49351, 0.71739130434783, 0.93260869565217, 0.45454545454545
49352, 0.69565217391304, 0.90652173913043, 0.45454545454545
49353, 0.69565217391304, 0.93260869565217, 0.47727272727273
49354, 0.65217391304348, 0.93260869565217, 0.022727272727273
49355, 0.67391304347826, 0.93260869565217, 0.045454545454545
49356, 0.65217391304348, 0.90652173913043, 0.045454545454545
49357, 0.65217391304348, 0.93260869565217, 0.068181818181818
49358, 0.67391304347826, 0.93260869565217, 0.090909090909091
49359, 0.65217391304348, 0.90652173913043, 0.090909090909091
49360, 0.65217391304348, 0.93260869565217, 0.11363636363636
49361, 0.67391304347826, 0.93260869565217, 0.13636363636364
49362, 0.65217391304348, 0.90652173913043, 0.13636363636364
49363, 0.65217391304348, 0.93260869565217, 0.15909090909091
49364, 0.67391304347826, 0.93260869565217, 0.18181818181818
49365, 0.65217391304348, 0.90652173913043, 0.18181818181818
49366, 0.65217391304348, 0.93260869565217, 0.20454545454545
49367, 0.67391304347826, 0.93260869565217, 0.22727272727273
49368, 0.65217391304348, 0.90652173913043, 0.22727272727273
49369, 0.65217391304348, 0.93260869565217, 0.25
49370, 0.67391304347826, 0.93260869565217, 0.27272727272727
49371, 0.65217391304348, 0.90652173913043, 0.27272727272727
49372, 0.65217391304348, 0.93260869565217, 0.29545454545455
49373, 0.67391304347826, 0.93260869565217, 0.31818181818182
49374, 0.65217391304348, 0.90652173913043, 0.31818181818182
49375, 0.65217391304348, 0.93260869565217, 0.34090909090909
49376, 0.67391304347826, 0.93260869565217, 0.36363636363636
49377, 0.65217391304348, 0.90652173913043, 0.36363636363636
49378, 0.65217391304348, 0.93260869565217, 0.38636363636364
49379, 0.67391304347826, 0.93260869565217, 0.40909090909091
49380, 0.65217391304348, 0.90652173913043, 0.40909090909091
49381, 0.65217391304348, 0.93260869565217, 0.43181818181818
49382, 0.67391304347826, 0.93260869565217, 0.45454545454545
49383, 0.65217391304348, 0.90652173913043, 0.45454545454545
49384, 0.65217391304348, 0.93260869565217, 0.47727272727273
49385, 0.60869565217391, 0.93260869565217, 0.022727272727273
49386, 0.6304347826087, 0.93260869565217, 0.045454545454545
49387, 0.60869565217391, 0.90652173913043, 0.045454545454545
49388, 0.60869565217391, 0.93260869565217, 0.068181818181818
49389, 0.6304347826087, 0.93260869565217, 0.090909090909091
49390, 0.60869565217391, 0.90652173913043, 0.090909090909091
49391, 0.60869565217391, 0.93260869565217, 0.11363636363636
49392, 0.6304347826087, 0.93260869565217, 0.13636363636364
49393, 0.60869565217391, 0.90652173913043, 0.13636363636364
49394, 0.60869565217391, 0.93260869565217, 0.15909090909091
49395, 0.6304347826087, 0.93260869565217, 0.18181818181818
49396, 0.60869565217391, 0.90652173913043, 0.18181818181818
49397, 0.60869565217391, 0.93260869565217, 0.20454545454545
49398, 0.6304347826087, 0.93260869565217, 0.22727272727273
49399, 0.60869565217391, 0.90652173913043, 0.22727272727273
49400, 0.60869565217391, 0.93260869565217, 0.25
49401, 0.6304347826087, 0.93260869565217, 0.27272727272727
49402, 0.60869565217391, 0.90652173913043, 0.27272727272727
49403, 0.60869565217391, 0.93260869565217, 0.29545454545455
49404, 0.6304347826087, 0.93260869565217, 0.31818181818182
49405, 0.60869565217391, 0.90652173913043, 0.31818181818182
49406, 0.60869565217391, 0.93260869565217, 0.34090909090909
49407, 0.6304347826087, 0.93260869565217, 0.36363636363636
49408, 0.60869565217391, 0.90652173913043, 0.36363636363636
49409, 0.60869565217391, 0.93260869565217, 0.38636363636364
49410, 0.6304347826087, 0.93260869565217, 0.40909090909091
49411, 0.60869565217391, 0.90652173913043, 0.40909090909091
49412, 0.60869565217391, 0.93260869565217, 0.43181818181818
49413, 0.6304347826087, 0.93260869565217, 0.45454545454545
49414, 0.60869565217391, 0.90652173913043, 0.45454545454545
49415, 0.60869565217391, 0.93260869565217, 0.47727272727273
49416, 0.56521739130435, 0.93260869565217, 0.022727272727273
49417, 0.58695652173913, 0.93260869565217, 0.045454545454545
49418, 0.56521739130435, 0.90652173913043, 0.045454545454545
49419, 0.56521739130435, 0.93260869565217, 0.068181818181818
49420, 0.58695652173913, 0.93260869565217, 0.090909090909091
49421, 0.56521739130435, 0.90652173913043, 0.090909090909091
49422, 0.56521739130435, 0.93260869565217, 0.11363636363636
49423, 0.58695652173913, 0.93260869565217, 0.13636363636364
49424, 0.56521739130435, 0.90652173913043, 0.13636363636364
49425, 0.56521739130435, 0.93260869565217, 0.15909090909091
49426, 0.58695652173913, 0.93260869565217, 0.18181818181818
49427, 0.56521739130435, 0.90652173913043, 0.18181818181818
49428, 0.56521739130435, 0.93260869565217, 0.20454545454545
49429, 0.58695652173913, 0.93260869565217, 0.22727272727273
49430, 0.56521739130435, 0.90652173913043, 0.22727272727273
49431, 0.56521739130435, 0.93260869565217, 0.25
49432, 0.58695652173913, 0.93260869565217, 0.27272727272727
49433, 0.56521739130435, 0.90652173913043, 0.27272727272727
49434, 0.56521739130435, 0.93260869565217, 0.29545454545455
49435, 0.58695652173913, 0.93260869565217, 0.31818181818182
49436, 0.56521739130435, 0.90652173913043, 0.31818181818182
49437, 0.56521739130435, 0.93260869565217, 0.34090909090909
49438, 0.58695652173913, 0.93260869565217, 0.36363636363636
49439, 0.56521739130435, 0.90652173913043, 0.36363636363636
49440, 0.56521739130435, 0.93260869565217, 0.38636363636364
49441, 0.58695652173913, 0.93260869565217, 0.40909090909091
49442, 0.56521739130435, 0.90652173913043, 0.40909090909091
49443, 0.56521739130435, 0.93260869565217, 0.43181818181818
49444, 0.58695652173913, 0.93260869565217, 0.45454545454545
49445, 0.56521739130435, 0.90652173913043, 0.45454545454545
49446, 0.56521739130435, 0.93260869565217, 0.47727272727273
49447, 0.52173913043478, 0.93260869565217, 0.022727272727273
49448, 0.54347826086956, 0.93260869565217, 0.045454545454545
49449, 0.52173913043478, 0.90652173913043, 0.045454545454545
49450, 0.52173913043478, 0.93260869565217, 0.068181818181818
49451, 0.54347826086956, 0.93260869565217, 0.090909090909091
49452, 0.52173913043478, 0.90652173913043, 0.090909090909091
49453, 0.52173913043478, 0.93260869565217, 0.11363636363636
49454, 0.54347826086956, 0.93260869565217, 0.13636363636364
49455, 0.52173913043478, 0.90652173913043, 0.13636363636364
49456, 0.52173913043478, 0.93260869565217, 0.15909090909091
49457, 0.54347826086956, 0.93260869565217, 0.18181818181818
49458, 0.52173913043478, 0.90652173913043, 0.18181818181818
49459, 0.52173913043478, 0.93260869565217, 0.20454545454545
49460, 0.54347826086956, 0.93260869565217, 0.22727272727273
49461, 0.52173913043478, 0.90652173913043, 0.22727272727273
49462, 0.52173913043478, 0.93260869565217, 0.25
49463, 0.54347826086956, 0.93260869565217, 0.27272727272727
49464, 0.52173913043478, 0.90652173913043, 0.27272727272727
49465, 0.52173913043478, 0.93260869565217, 0.29545454545455
49466, 0.54347826086956, 0.93260869565217, 0.31818181818182
49467, 0.52173913043478, 0.90652173913043, 0.31818181818182
49468, 0.52173913043478, 0.93260869565217, 0.34090909090909
49469, 0.54347826086957, 0.93260869565217, 0.36363636363636
49470, 0.52173913043478, 0.90652173913043, 0.36363636363636
49471, 0.52173913043478, 0.93260869565217, 0.38636363636364
49472, 0.54347826086956, 0.93260869565217, 0.40909090909091
49473, 0.52173913043478, 0.90652173913043, 0.40909090909091
49474, 0.52173913043478, 0.93260869565217, 0.43181818181818
49475, 0.54347826086956, 0.93260869565217, 0.45454545454545
49476, 0.52173913043478, 0.90652173913043, 0.45454545454545
49477, 0.52173913043478, 0.93260869565217, 0.47727272727273
49478, 0.47826086956522, 0.93260869565217, 0.022727272727273
49479, 0.5, 0.93260869565217, 0.045454545454545
49480, 0.47826086956522, 0.90652173913043, 0.045454545454545
49481, 0.47826086956522, 0.93260869565217, 0.068181818181818
49482, 0.5, 0.93260869565217, 0.090909090909091
49483, 0.47826086956522, 0.90652173913043, 0.090909090909091
49484, 0.47826086956522, 0.93260869565217, 0.11363636363636
49485, 0.5, 0.93260869565217, 0.13636363636364
49486, 0.47826086956522, 0.90652173913043, 0.13636363636364
49487, 0.47826086956522, 0.93260869565217, 0.15909090909091
49488, 0.5, 0.93260869565217, 0.18181818181818
49489, 0.47826086956522, 0.90652173913043, 0.18181818181818
49490, 0.47826086956522, 0.93260869565217, 0.20454545454545
49491, 0.5, 0.93260869565217, 0.22727272727273
49492, 0.47826086956522, 0.90652173913043, 0.22727272727273
49493, 0.47826086956522, 0.93260869565217, 0.25
49494, 0.5, 0.93260869565217, 0.27272727272727
49495, 0.47826086956522, 0.90652173913043, 0.27272727272727
49496, 0.47826086956522, 0.93260869565217, 0.29545454545455
49497, 0.5, 0.93260869565217, 0.31818181818182
49498, 0.47826086956522, 0.90652173913043, 0.31818181818182
49499, 0.47826086956522, 0.93260869565217, 0.34090909090909
49500, 0.5, 0.93260869565217, 0.36363636363636
49501, 0.47826086956522, 0.90652173913043, 0.36363636363636
49502, 0.47826086956522, 0.93260869565217, 0.38636363636364
49503, 0.5, 0.93260869565217, 0.40909090909091
49504, 0.47826086956522, 0.90652173913043, 0.40909090909091
49505, 0.47826086956522, 0.93260869565217, 0.43181818181818
49506, 0.5, 0.93260869565217, 0.45454545454545
49507, 0.47826086956522, 0.90652173913043, 0.45454545454545
49508, 0.47826086956522, 0.93260869565217, 0.47727272727273
49509, 0.43478260869565, 0.93260869565217, 0.022727272727273
49510, 0.45652173913043, 0.93260869565217, 0.045454545454545
49511, 0.43478260869565, 0.90652173913043, 0.045454545454545
49512, 0.43478260869565, 0.93260869565217, 0.068181818181818
49513, 0.45652173913043, 0.93260869565217, 0.090909090909091
49514, 0.43478260869565, 0.90652173913043, 0.090909090909091
49515, 0.43478260869565, 0.93260869565217, 0.11363636363636
49516, 0.45652173913043, 0.93260869565217, 0.13636363636364
49517, 0.43478260869565, 0.90652173913043, 0.13636363636364
49518, 0.43478260869565, 0.93260869565217, 0.15909090909091
49519, 0.45652173913043, 0.93260869565217, 0.18181818181818
49520, 0.43478260869565, 0.90652173913043, 0.18181818181818
49521, 0.43478260869565, 0.93260869565217, 0.20454545454545
49522, 0.45652173913043, 0.93260869565217, 0.22727272727273
49523, 0.43478260869565, 0.90652173913043, 0.22727272727273
49524, 0.43478260869565, 0.93260869565217, 0.25
49525, 0.45652173913043, 0.93260869565217, 0.27272727272727
49526, 0.43478260869565, 0.90652173913043, 0.27272727272727
49527, 0.43478260869565, 0.93260869565217, 0.29545454545455
49528, 0.45652173913043, 0.93260869565217, 0.31818181818182
49529, 0.43478260869565, 0.90652173913043, 0.31818181818182
49530, 0.43478260869565, 0.93260869565217, 0.34090909090909
49531, 0.45652173913043, 0.93260869565217, 0.36363636363636
49532, 0.43478260869565, 0.90652173913043, 0.36363636363636
49533, 0.43478260869565, 0.93260869565217, 0.38636363636364
49534, 0.45652173913043, 0.93260869565217, 0.40909090909091
49535, 0.43478260869565, 0.90652173913043, 0.40909090909091
49536, 0.43478260869565, 0.93260869565217, 0.43181818181818
49537, 0.45652173913043, 0.93260869565217, 0.45454545454545
49538, 0.43478260869565, 0.90652173913043, 0.45454545454545
49539, 0.43478260869565, 0.93260869565217, 0.47727272727273
49540, 0.39130434782609, 0.93260869565217, 0.022727272727273
49541, 0.41304347826087, 0.93260869565217, 0.045454545454545
49542, 0.39130434782609, 0.90652173913043, 0.045454545454545
49543, 0.39130434782609, 0.93260869565217, 0.068181818181818
49544, 0.41304347826087, 0.93260869565217, 0.090909090909091
49545, 0.39130434782609, 0.90652173913043, 0.090909090909091
49546, 0.39130434782609, 0.93260869565217, 0.11363636363636
49547, 0.41304347826087, 0.93260869565217, 0.13636363636364
49548, 0.39130434782609, 0.90652173913043, 0.13636363636364
49549, 0.39130434782609, 0.93260869565217, 0.15909090909091
49550, 0.41304347826087, 0.93260869565217, 0.18181818181818
49551, 0.39130434782609, 0.90652173913043, 0.18181818181818
49552, 0.39130434782609, 0.93260869565217, 0.20454545454545
49553, 0.41304347826087, 0.93260869565217, 0.22727272727273
49554, 0.39130434782609, 0.90652173913043, 0.22727272727273
49555, 0.39130434782609, 0.93260869565217, 0.25
49556, 0.41304347826087, 0.93260869565217, 0.27272727272727
49557, 0.39130434782609, 0.90652173913043, 0.27272727272727
49558, 0.39130434782609, 0.93260869565217, 0.29545454545455
49559, 0.41304347826087, 0.93260869565217, 0.31818181818182
49560, 0.39130434782609, 0.90652173913043, 0.31818181818182
49561, 0.39130434782609, 0.93260869565217, 0.34090909090909
49562, 0.41304347826087, 0.93260869565217, 0.36363636363636
49563, 0.39130434782609, 0.90652173913043, 0.36363636363636
49564, 0.39130434782609, 0.93260869565217, 0.38636363636364
49565, 0.41304347826087, 0.93260869565217, 0.40909090909091
49566, 0.39130434782609, 0.90652173913043, 0.40909090909091
49567, 0.39130434782609, 0.93260869565217, 0.43181818181818
49568, 0.41304347826087, 0.93260869565217, 0.45454545454545
49569, 0.39130434782609, 0.90652173913043, 0.45454545454545
49570, 0.39130434782609, 0.93260869565217, 0.47727272727273
49571, 0.34782608695652, 0.93260869565217, 0.022727272727273
49572, 0.3695652173913, 0.93260869565217, 0.045454545454545
49573, 0.34782608695652, 0.90652173913043, 0.045454545454545
49574, 0.34782608695652, 0.93260869565217, 0.068181818181818
49575, 0.3695652173913, 0.93260869565217, 0.090909090909091
49576, 0.34782608695652, 0.90652173913043, 0.090909090909091
49577, 0.34782608695652, 0.93260869565217, 0.11363636363636
49578, 0.3695652173913, 0.93260869565217, 0.13636363636364
49579, 0.34782608695652, 0.90652173913043, 0.13636363636364
49580, 0.34782608695652, 0.93260869565217, 0.15909090909091
49581, 0.3695652173913, 0.93260869565217, 0.18181818181818
49582, 0.34782608695652, 0.90652173913043, 0.18181818181818
49583, 0.34782608695652, 0.93260869565217, 0.20454545454545
49584, 0.3695652173913, 0.93260869565217, 0.22727272727273
49585, 0.34782608695652, 0.90652173913043, 0.22727272727273
49586, 0.34782608695652, 0.93260869565217, 0.25
49587, 0.3695652173913, 0.93260869565217, 0.27272727272727
49588, 0.34782608695652, 0.90652173913043, 0.27272727272727
49589, 0.34782608695652, 0.93260869565217, 0.29545454545455
49590, 0.3695652173913, 0.93260869565217, 0.31818181818182
49591, 0.34782608695652, 0.90652173913043, 0.31818181818182
49592, 0.34782608695652, 0.93260869565217, 0.34090909090909
49593, 0.3695652173913, 0.93260869565217, 0.36363636363636
49594, 0.34782608695652, 0.90652173913043, 0.36363636363636
49595, 0.34782608695652, 0.93260869565217, 0.38636363636364
49596, 0.3695652173913, 0.93260869565217, 0.40909090909091
49597, 0.34782608695652, 0.90652173913043, 0.40909090909091
49598, 0.34782608695652, 0.93260869565217, 0.43181818181818
49599, 0.3695652173913, 0.93260869565217, 0.45454545454545
49600, 0.34782608695652, 0.90652173913043, 0.45454545454545
49601, 0.34782608695652, 0.93260869565217, 0.47727272727273
49602, 0.30434782608696, 0.93260869565217, 0.022727272727273
49603, 0.32608695652174, 0.93260869565217, 0.045454545454545
49604, 0.30434782608696, 0.90652173913043, 0.045454545454545
49605, 0.30434782608696, 0.93260869565217, 0.068181818181818
49606, 0.32608695652174, 0.93260869565217, 0.090909090909091
49607, 0.30434782608696, 0.90652173913043, 0.090909090909091
49608, 0.30434782608696, 0.93260869565217, 0.11363636363636
49609, 0.32608695652174, 0.93260869565217, 0.13636363636364
49610, 0.30434782608696, 0.90652173913043, 0.13636363636364
49611, 0.30434782608696, 0.93260869565217, 0.15909090909091
49612, 0.32608695652174, 0.93260869565217, 0.18181818181818
49613, 0.30434782608696, 0.90652173913043, 0.18181818181818
49614, 0.30434782608696, 0.93260869565217, 0.20454545454545
49615, 0.32608695652174, 0.93260869565217, 0.22727272727273
49616, 0.30434782608696, 0.90652173913043, 0.22727272727273
49617, 0.30434782608696, 0.93260869565217, 0.25
49618, 0.32608695652174, 0.93260869565217, 0.27272727272727
49619, 0.30434782608696, 0.90652173913043, 0.27272727272727
49620, 0.30434782608696, 0.93260869565217, 0.29545454545455
49621, 0.32608695652174, 0.93260869565217, 0.31818181818182
49622, 0.30434782608696, 0.90652173913043, 0.31818181818182
49623, 0.30434782608696, 0.93260869565217, 0.34090909090909
49624, 0.32608695652174, 0.93260869565217, 0.36363636363636
49625, 0.30434782608696, 0.90652173913043, 0.36363636363636
49626, 0.30434782608696, 0.93260869565217, 0.38636363636364
49627, 0.32608695652174, 0.93260869565217, 0.40909090909091
49628, 0.30434782608696, 0.90652173913043, 0.40909090909091
49629, 0.30434782608696, 0.93260869565217, 0.43181818181818
49630, 0.32608695652174, 0.93260869565217, 0.45454545454545
49631, 0.30434782608696, 0.90652173913043, 0.45454545454545
49632, 0.30434782608696, 0.93260869565217, 0.47727272727273
49633, 0.26086956521739, 0.93260869565217, 0.022727272727273
49634, 0.28260869565217, 0.93260869565217, 0.045454545454545
49635, 0.26086956521739, 0.90652173913043, 0.045454545454545
49636, 0.26086956521739, 0.93260869565217, 0.068181818181818
49637, 0.28260869565217, 0.93260869565217, 0.090909090909091
49638, 0.26086956521739, 0.90652173913043, 0.090909090909091
49639, 0.26086956521739, 0.93260869565217, 0.11363636363636
49640, 0.28260869565217, 0.93260869565217, 0.13636363636364
49641, 0.26086956521739, 0.90652173913043, 0.13636363636364
49642, 0.26086956521739, 0.93260869565217, 0.15909090909091
49643, 0.28260869565217, 0.93260869565217, 0.18181818181818
49644, 0.26086956521739, 0.90652173913043, 0.18181818181818
49645, 0.26086956521739, 0.93260869565217, 0.20454545454545
49646, 0.28260869565217, 0.93260869565217, 0.22727272727273
49647, 0.26086956521739, 0.90652173913043, 0.22727272727273
49648, 0.26086956521739, 0.93260869565217, 0.25
49649, 0.28260869565217, 0.93260869565217, 0.27272727272727
49650, 0.26086956521739, 0.90652173913043, 0.27272727272727
49651, 0.26086956521739, 0.93260869565217, 0.29545454545455
49652, 0.28260869565217, 0.93260869565217, 0.31818181818182
49653, 0.26086956521739, 0.90652173913043, 0.31818181818182
49654, 0.26086956521739, 0.93260869565217, 0.34090909090909
49655, 0.28260869565217, 0.93260869565217, 0.36363636363636
49656, 0.26086956521739, 0.90652173913043, 0.36363636363636
49657, 0.26086956521739, 0.93260869565217, 0.38636363636364
49658, 0.28260869565217, 0.93260869565217, 0.40909090909091
49659, 0.26086956521739, 0.90652173913043, 0.40909090909091
49660, 0.26086956521739, 0.93260869565217, 0.43181818181818
49661, 0.28260869565217, 0.93260869565217, 0.45454545454545
49662, 0.26086956521739, 0.90652173913043, 0.45454545454545
49663, 0.26086956521739, 0.93260869565217, 0.47727272727273
49664, 0.21739130434783, 0.93260869565217, 0.022727272727273
49665, 0.23913043478261, 0.93260869565217, 0.045454545454545
49666, 0.21739130434783, 0.90652173913043, 0.045454545454545
49667, 0.21739130434783, 0.93260869565217, 0.068181818181818
49668, 0.23913043478261, 0.93260869565217, 0.090909090909091
49669, 0.21739130434783, 0.90652173913043, 0.090909090909091
49670, 0.21739130434783, 0.93260869565217, 0.11363636363636
49671, 0.23913043478261, 0.93260869565217, 0.13636363636364
49672, 0.21739130434783, 0.90652173913043, 0.13636363636364
49673, 0.21739130434783, 0.93260869565217, 0.15909090909091
49674, 0.23913043478261, 0.93260869565217, 0.18181818181818
49675, 0.21739130434783, 0.90652173913043, 0.18181818181818
49676, 0.21739130434783, 0.93260869565217, 0.20454545454545
49677, 0.23913043478261, 0.93260869565217, 0.22727272727273
49678, 0.21739130434783, 0.90652173913043, 0.22727272727273
49679, 0.21739130434783, 0.93260869565217, 0.25
49680, 0.23913043478261, 0.93260869565217, 0.27272727272727
49681, 0.21739130434783, 0.90652173913043, 0.27272727272727
49682, 0.21739130434783, 0.93260869565217, 0.29545454545455
49683, 0.23913043478261, 0.93260869565217, 0.31818181818182
49684, 0.21739130434783, 0.90652173913043, 0.31818181818182
49685, 0.21739130434783, 0.93260869565217, 0.34090909090909
49686, 0.23913043478261, 0.93260869565217, 0.36363636363636
49687, 0.21739130434783, 0.90652173913043, 0.36363636363636
49688, 0.21739130434783, 0.93260869565217, 0.38636363636364
49689, 0.23913043478261, 0.93260869565217, 0.40909090909091
49690, 0.21739130434783, 0.90652173913043, 0.40909090909091
49691, 0.21739130434783, 0.93260869565217, 0.43181818181818
49692, 0.23913043478261, 0.93260869565217, 0.45454545454545
49693, 0.21739130434783, 0.90652173913043, 0.45454545454545
49694, 0.21739130434783, 0.93260869565217, 0.47727272727273
49695, 0.17391304347826, 0.93260869565217, 0.022727272727273
49696, 0.19565217391304, 0.93260869565217, 0.045454545454545
49697, 0.17391304347826, 0.90652173913043, 0.045454545454545
49698, 0.17391304347826, 0.93260869565217, 0.068181818181818
49699, 0.19565217391304, 0.93260869565217, 0.090909090909091
49700, 0.17391304347826, 0.90652173913043, 0.090909090909091
49701, 0.17391304347826, 0.93260869565217, 0.11363636363636
49702, 0.19565217391304, 0.93260869565217, 0.13636363636364
49703, 0.17391304347826, 0.90652173913043, 0.13636363636364
49704, 0.17391304347826, 0.93260869565217, 0.15909090909091
49705, 0.19565217391304, 0.93260869565217, 0.18181818181818
49706, 0.17391304347826, 0.90652173913043, 0.18181818181818
49707, 0.17391304347826, 0.93260869565217, 0.20454545454545
49708, 0.19565217391304, 0.93260869565217, 0.22727272727273
49709, 0.17391304347826, 0.90652173913043, 0.22727272727273
49710, 0.17391304347826, 0.93260869565217, 0.25
49711, 0.19565217391304, 0.93260869565217, 0.27272727272727
49712, 0.17391304347826, 0.90652173913043, 0.27272727272727
49713, 0.17391304347826, 0.93260869565217, 0.29545454545455
49714, 0.19565217391304, 0.93260869565217, 0.31818181818182
49715, 0.17391304347826, 0.90652173913043, 0.31818181818182
49716, 0.17391304347826, 0.93260869565217, 0.34090909090909
49717, 0.19565217391304, 0.93260869565217, 0.36363636363636
49718, 0.17391304347826, 0.90652173913043, 0.36363636363636
49719, 0.17391304347826, 0.93260869565217, 0.38636363636364
49720, 0.19565217391304, 0.93260869565217, 0.40909090909091
49721, 0.17391304347826, 0.90652173913043, 0.40909090909091
49722, 0.17391304347826, 0.93260869565217, 0.43181818181818
49723, 0.19565217391304, 0.93260869565217, 0.45454545454545
49724, 0.17391304347826, 0.90652173913043, 0.45454545454545
49725, 0.17391304347826, 0.93260869565217, 0.47727272727273
49726, 0.1304347826087, 0.93260869565217, 0.022727272727273
49727, 0.15217391304348, 0.93260869565217, 0.045454545454545
49728, 0.1304347826087, 0.90652173913043, 0.045454545454545
49729, 0.1304347826087, 0.93260869565217, 0.068181818181818
49730, 0.15217391304348, 0.93260869565217, 0.090909090909091
49731, 0.1304347826087, 0.90652173913043, 0.090909090909091
49732, 0.1304347826087, 0.93260869565217, 0.11363636363636
49733, 0.15217391304348, 0.93260869565217, 0.13636363636364
49734, 0.1304347826087, 0.90652173913043, 0.13636363636364
49735, 0.1304347826087, 0.93260869565217, 0.15909090909091
49736, 0.15217391304348, 0.93260869565217, 0.18181818181818
49737, 0.1304347826087, 0.90652173913043, 0.18181818181818
49738, 0.1304347826087, 0.93260869565217, 0.20454545454545
49739, 0.15217391304348, 0.93260869565217, 0.22727272727273
49740, 0.1304347826087, 0.90652173913043, 0.22727272727273
49741, 0.1304347826087, 0.93260869565217, 0.25
49742, 0.15217391304348, 0.93260869565217, 0.27272727272727
49743, 0.1304347826087, 0.90652173913043, 0.27272727272727
49744, 0.1304347826087, 0.93260869565217, 0.29545454545455
49745, 0.15217391304348, 0.93260869565217, 0.31818181818182
49746, 0.1304347826087, 0.90652173913043, 0.31818181818182
49747, 0.1304347826087, 0.93260869565217, 0.34090909090909
49748, 0.15217391304348, 0.93260869565217, 0.36363636363636
49749, 0.1304347826087, 0.90652173913043, 0.36363636363636
49750, 0.1304347826087, 0.93260869565217, 0.38636363636364
49751, 0.15217391304348, 0.93260869565217, 0.40909090909091
49752, 0.1304347826087, 0.90652173913043, 0.40909090909091
49753, 0.1304347826087, 0.93260869565217, 0.43181818181818
49754, 0.15217391304348, 0.93260869565217, 0.45454545454545
49755, 0.1304347826087, 0.90652173913043, 0.45454545454545
49756, 0.1304347826087, 0.93260869565217, 0.47727272727273
49757, 0.08695652173913, 0.93260869565217, 0.022727272727273
49758, 0.10869565217391, 0.93260869565217, 0.045454545454545
49759, 0.08695652173913, 0.90652173913043, 0.045454545454545
49760, 0.08695652173913, 0.93260869565217, 0.068181818181818
49761, 0.10869565217391, 0.93260869565217, 0.090909090909091
49762, 0.08695652173913, 0.90652173913043, 0.090909090909091
49763, 0.08695652173913, 0.93260869565217, 0.11363636363636
49764, 0.10869565217391, 0.93260869565217, 0.13636363636364
49765, 0.08695652173913, 0.90652173913043, 0.13636363636364
49766, 0.08695652173913, 0.93260869565217, 0.15909090909091
49767, 0.10869565217391, 0.93260869565217, 0.18181818181818
49768, 0.08695652173913, 0.90652173913043, 0.18181818181818
49769, 0.08695652173913, 0.93260869565217, 0.20454545454545
49770, 0.10869565217391, 0.93260869565217, 0.22727272727273
49771, 0.08695652173913, 0.90652173913043, 0.22727272727273
49772, 0.08695652173913, 0.93260869565217, 0.25
49773, 0.10869565217391, 0.93260869565217, 0.27272727272727
49774, 0.08695652173913, 0.90652173913043, 0.27272727272727
49775, 0.08695652173913, 0.93260869565217, 0.29545454545455
49776, 0.10869565217391, 0.93260869565217, 0.31818181818182
49777, 0.08695652173913, 0.90652173913043, 0.31818181818182
49778, 0.08695652173913, 0.93260869565217, 0.34090909090909
49779, 0.10869565217391, 0.93260869565217, 0.36363636363636
49780, 0.08695652173913, 0.90652173913043, 0.36363636363636
49781, 0.08695652173913, 0.93260869565217, 0.38636363636364
49782, 0.10869565217391, 0.93260869565217, 0.40909090909091
49783, 0.08695652173913, 0.90652173913043, 0.40909090909091
49784, 0.08695652173913, 0.93260869565217, 0.43181818181818
49785, 0.10869565217391, 0.93260869565217, 0.45454545454545
49786, 0.08695652173913, 0.90652173913043, 0.45454545454545
49787, 0.08695652173913, 0.93260869565217, 0.47727272727273
49788, 0.043478260869565, 0.93260869565217, 0.022727272727273
49789, 0.065217391304348, 0.93260869565217, 0.045454545454545
49790, 0.043478260869565, 0.90652173913043, 0.045454545454545
49791, 0.043478260869565, 0.93260869565217, 0.068181818181818
49792, 0.065217391304348, 0.93260869565217, 0.090909090909091
49793, 0.043478260869565, 0.90652173913043, 0.090909090909091
49794, 0.043478260869565, 0.93260869565217, 0.11363636363636
49795, 0.065217391304348, 0.93260869565217, 0.13636363636364
49796, 0.043478260869565, 0.90652173913043, 0.13636363636364
49797, 0.043478260869565, 0.93260869565217, 0.15909090909091
49798, 0.065217391304348, 0.93260869565217, 0.18181818181818
49799, 0.043478260869565, 0.90652173913043, 0.18181818181818
49800, 0.043478260869565, 0.93260869565217, 0.20454545454545
49801, 0.065217391304348, 0.93260869565217, 0.22727272727273
49802, 0.043478260869565, 0.90652173913043, 0.22727272727273
49803, 0.043478260869565, 0.93260869565217, 0.25
49804, 0.065217391304348, 0.93260869565217, 0.27272727272727
49805, 0.043478260869565, 0.90652173913043, 0.27272727272727
49806, 0.043478260869565, 0.93260869565217, 0.29545454545455
49807, 0.065217391304348, 0.93260869565217, 0.31818181818182
49808, 0.043478260869565, 0.90652173913043, 0.31818181818182
49809, 0.043478260869565, 0.93260869565217, 0.34090909090909
49810, 0.065217391304348, 0.93260869565217, 0.36363636363636
49811, 0.043478260869565, 0.90652173913043, 0.36363636363636
49812, 0.043478260869565, 0.93260869565217, 0.38636363636364
49813, 0.065217391304348, 0.93260869565217, 0.40909090909091
49814, 0.043478260869565, 0.90652173913043, 0.40909090909091
49815, 0.043478260869565, 0.93260869565217, 0.43181818181818
49816, 0.065217391304348, 0.93260869565217, 0.45454545454545
49817, 0.043478260869565, 0.90652173913043, 0.45454545454545
49818, 0.043478260869565, 0.93260869565217, 0.47727272727273
49819, 0.021739130434783, 0.93260869565217, 0.045454545454545
49820, 0.021739130434783, 0.93260869565217, 0.090909090909091
49821, 0.021739130434783, 0.93260869565217, 0.13636363636364
49822, 0.021739130434783, 0.93260869565217, 0.18181818181818
49823, 0.021739130434783, 0.93260869565217, 0.22727272727273
49824, 0.021739130434783, 0.93260869565217, 0.27272727272727
49825, 0.021739130434783, 0.93260869565217, 0.31818181818182
49826, 0.021739130434783, 0.93260869565217, 0.36363636363636
49827, 0.021739130434783, 0.93260869565217, 0.40909090909091
49828, 0.021739130434783, 0.93260869565217, 0.45454545454545
49829, 0.95652173913043, 0.98478260869565, 0.022727272727273
49830, 0.97826086956522, 0.98478260869565, 0.045454545454545
49831, 0.95652173913043, 0.95869565217391, 0.045454545454545
49832, 0.95652173913043, 0.98478260869565, 0.068181818181818
49833, 0.97826086956522, 0.98478260869565, 0.090909090909091
49834, 0.95652173913044, 0.95869565217391, 0.090909090909091
49835, 0.95652173913044, 0.98478260869565, 0.11363636363636
49836, 0.97826086956522, 0.98478260869565, 0.13636363636364
49837, 0.95652173913044, 0.95869565217391, 0.13636363636364
49838, 0.95652173913044, 0.98478260869565, 0.15909090909091
49839, 0.97826086956522, 0.98478260869565, 0.18181818181818
49840, 0.95652173913044, 0.95869565217391, 0.18181818181818
49841, 0.95652173913044, 0.98478260869565, 0.20454545454545
49842, 0.97826086956522, 0.98478260869565, 0.22727272727273
49843, 0.95652173913044, 0.95869565217391, 0.22727272727273
49844, 0.95652173913044, 0.98478260869565, 0.25
49845, 0.97826086956522, 0.98478260869565, 0.27272727272727
49846, 0.95652173913044, 0.95869565217391, 0.27272727272727
49847, 0.95652173913044, 0.98478260869565, 0.29545454545455
49848, 0.97826086956522, 0.98478260869565, 0.31818181818182
49849, 0.95652173913044, 0.95869565217391, 0.31818181818182
49850, 0.95652173913043, 0.98478260869565, 0.34090909090909
49851, 0.97826086956522, 0.98478260869565, 0.36363636363636
49852, 0.95652173913043, 0.95869565217391, 0.36363636363636
49853, 0.95652173913043, 0.98478260869565, 0.38636363636364
49854, 0.97826086956522, 0.98478260869565, 0.40909090909091
49855, 0.95652173913043, 0.95869565217391, 0.40909090909091
49856, 0.95652173913043, 0.98478260869565, 0.43181818181818
49857, 0.97826086956522, 0.98478260869565, 0.45454545454545
49858, 0.95652173913044, 0.95869565217391, 0.45454545454545
49859, 0.95652173913043, 0.98478260869565, 0.47727272727273
49860, 0.91304347826087, 0.98478260869565, 0.022727272727273
49861, 0.93478260869565, 0.98478260869565, 0.045454545454545
49862, 0.91304347826087, 0.95869565217391, 0.045454545454545
49863, 0.91304347826087, 0.98478260869565, 0.068181818181818
49864, 0.93478260869565, 0.98478260869565, 0.090909090909091
49865, 0.91304347826087, 0.95869565217391, 0.090909090909091
49866, 0.91304347826087, 0.98478260869565, 0.11363636363636
49867, 0.93478260869565, 0.98478260869565, 0.13636363636364
49868, 0.91304347826087, 0.95869565217391, 0.13636363636364
49869, 0.91304347826087, 0.98478260869565, 0.15909090909091
49870, 0.93478260869565, 0.98478260869565, 0.18181818181818
49871, 0.91304347826087, 0.95869565217391, 0.18181818181818
49872, 0.91304347826087, 0.98478260869565, 0.20454545454545
49873, 0.93478260869565, 0.98478260869565, 0.22727272727273
49874, 0.91304347826087, 0.95869565217391, 0.22727272727273
49875, 0.91304347826087, 0.98478260869565, 0.25
49876, 0.93478260869565, 0.98478260869565, 0.27272727272727
49877, 0.91304347826087, 0.95869565217391, 0.27272727272727
49878, 0.91304347826087, 0.98478260869565, 0.29545454545455
49879, 0.93478260869565, 0.98478260869565, 0.31818181818182
49880, 0.91304347826087, 0.95869565217391, 0.31818181818182
49881, 0.91304347826087, 0.98478260869565, 0.34090909090909
49882, 0.93478260869565, 0.98478260869565, 0.36363636363636
49883, 0.91304347826087, 0.95869565217391, 0.36363636363636
49884, 0.91304347826087, 0.98478260869565, 0.38636363636364
49885, 0.93478260869565, 0.98478260869565, 0.40909090909091
49886, 0.91304347826087, 0.95869565217391, 0.40909090909091
49887, 0.91304347826087, 0.98478260869565, 0.43181818181818
49888, 0.93478260869565, 0.98478260869565, 0.45454545454545
49889, 0.91304347826087, 0.95869565217391, 0.45454545454545
49890, 0.91304347826087, 0.98478260869565, 0.47727272727273
49891, 0.8695652173913, 0.98478260869565, 0.022727272727273
49892, 0.89130434782609, 0.98478260869565, 0.045454545454545
49893, 0.8695652173913, 0.95869565217391, 0.045454545454545
49894, 0.8695652173913, 0.98478260869565, 0.068181818181818
49895, 0.89130434782609, 0.98478260869565, 0.090909090909091
49896, 0.8695652173913, 0.95869565217391, 0.090909090909091
49897, 0.8695652173913, 0.98478260869565, 0.11363636363636
49898, 0.89130434782609, 0.98478260869565, 0.13636363636364
49899, 0.8695652173913, 0.95869565217391, 0.13636363636364
49900, 0.8695652173913, 0.98478260869565, 0.15909090909091
49901, 0.89130434782609, 0.98478260869565, 0.18181818181818
49902, 0.8695652173913, 0.95869565217391, 0.18181818181818
49903, 0.8695652173913, 0.98478260869565, 0.20454545454545
49904, 0.89130434782609, 0.98478260869565, 0.22727272727273
49905, 0.8695652173913, 0.95869565217391, 0.22727272727273
49906, 0.8695652173913, 0.98478260869565, 0.25
49907, 0.89130434782609, 0.98478260869565, 0.27272727272727
