99456, 28194, 2957, 28245, 99455
34710, 28161, 2946, 28223, 99359, 28162, 2945, 28224, 99360, 28213, 28246, 99523, 99456, 28214, 28248, 99524, 
99459, 28196, 2956, 28247, 99458
34711, 28162, 2945, 28224, 99360, 28163, 2944, 28225, 99361, 28214, 28248, 99524, 99459, 28215, 28250, 99525, 
99462, 28198, 2955, 28249, 99461
34712, 28163, 2944, 28225, 99361, 28164, 2943, 28226, 99362, 28215, 28250, 99525, 99462, 28216, 28252, 99526, 
99465, 28200, 2954, 28251, 99464
34713, 28164, 2943, 28226, 99362, 28165, 2942, 28227, 99363, 28216, 28252, 99526, 99465, 28217, 28254, 99527, 
99468, 28202, 2953, 28253, 99467
34714, 28165, 2942, 28227, 99363, 28166, 2941, 28228, 99364, 28217, 28254, 99527, 99468, 28218, 28256, 99528, 
99471, 28204, 2952, 28255, 99470
34715, 28166, 2941, 28228, 99364, 28167, 2940, 28229, 99365, 28218, 28256, 99528, 99471, 28219, 28258, 99529, 
99474, 28206, 2951, 28257, 99473
34716, 28167, 2940, 28229, 99365, 28168, 2939, 28230, 99366, 28219, 28258, 99529, 99474, 28220, 28260, 99530, 
99477, 28208, 2950, 28259, 99476
34717, 28168, 2939, 28230, 99366, 2930, 78, 2934, 28135, 28220, 28260, 99530, 99477, 2933, 2936, 28147, 
28142, 28210, 2949, 28261, 99479
34718, 28119, 2924, 2925, 28120, 99357, 28221, 28231, 99367, 28131, 2927, 28132, 28129, 99521, 28263, 99531, 
99481, 99449, 28241, 28262, 99480
34719, 99357, 28221, 28231, 99367, 99358, 28222, 28232, 99368, 99521, 28263, 99531, 99481, 99522, 28265, 99532, 
99484, 99452, 28243, 28264, 99483
34720, 99358, 28222, 28232, 99368, 99359, 28223, 28233, 99369, 99522, 28265, 99532, 99484, 99523, 28267, 99533, 
99487, 99455, 28245, 28266, 99486
34721, 99359, 28223, 28233, 99369, 99360, 28224, 28234, 99370, 99523, 28267, 99533, 99487, 99524, 28269, 99534, 
99490, 99458, 28247, 28268, 99489
34722, 99360, 28224, 28234, 99370, 99361, 28225, 28235, 99371, 99524, 28269, 99534, 99490, 99525, 28271, 99535, 
99493, 99461, 28249, 28270, 99492
34723, 99361, 28225, 28235, 99371, 99362, 28226, 28236, 99372, 99525, 28271, 99535, 99493, 99526, 28273, 99536, 
99496, 99464, 28251, 28272, 99495
34724, 99362, 28226, 28236, 99372, 99363, 28227, 28237, 99373, 99526, 28273, 99536, 99496, 99527, 28275, 99537, 
99499, 99467, 28253, 28274, 99498
34725, 99363, 28227, 28237, 99373, 99364, 28228, 28238, 99374, 99527, 28275, 99537, 99499, 99528, 28277, 99538, 
99502, 99470, 28255, 28276, 99501
34726, 99364, 28228, 28238, 99374, 99365, 28229, 28239, 99375, 99528, 28277, 99538, 99502, 99529, 28279, 99539, 
99505, 99473, 28257, 28278, 99504
34727, 99365, 28229, 28239, 99375, 99366, 28230, 28240, 99376, 99529, 28279, 99539, 99505, 99530, 28281, 99540, 
99508, 99476, 28259, 28280, 99507
34728, 99366, 28230, 28240, 99376, 28135, 2934, 2935, 28136, 99530, 28281, 99540, 99508, 28147, 2937, 28148, 
28144, 99479, 28261, 28282, 99510
34729, 28120, 2925, 73, 2844, 99367, 28231, 2886, 27880, 28132, 2928, 2847, 28130, 99531, 28283, 27932, 
99511, 99480, 28262, 2897, 27911
34730, 99367, 28231, 2886, 27880, 99368, 28232, 2885, 27881, 99531, 28283, 27932, 99511, 99532, 28284, 27933, 
99512, 99483, 28264, 2896, 27913
34731, 99368, 28232, 2885, 27881, 99369, 28233, 2884, 27882, 99532, 28284, 27933, 99512, 99533, 28285, 27934, 
99513, 99486, 28266, 2895, 27915
34732, 99369, 28233, 2884, 27882, 99370, 28234, 2883, 27883, 99533, 28285, 27934, 99513, 99534, 28286, 27935, 
99514, 99489, 28268, 2894, 27917
34733, 99370, 28234, 2883, 27883, 99371, 28235, 2882, 27884, 99534, 28286, 27935, 99514, 99535, 28287, 27936, 
99515, 99492, 28270, 2893, 27919
34734, 99371, 28235, 2882, 27884, 99372, 28236, 2881, 27885, 99535, 28287, 27936, 99515, 99536, 28288, 27937, 
99516, 99495, 28272, 2892, 27921
34735, 99372, 28236, 2881, 27885, 99373, 28237, 2880, 27886, 99536, 28288, 27937, 99516, 99537, 28289, 27938, 
99517, 99498, 28274, 2891, 27923
34736, 99373, 28237, 2880, 27886, 99374, 28238, 2879, 27887, 99537, 28289, 27938, 99517, 99538, 28290, 27939, 
99518, 99501, 28276, 2890, 27925
34737, 99374, 28238, 2879, 27887, 99375, 28239, 2878, 27888, 99538, 28290, 27939, 99518, 99539, 28291, 27940, 
99519, 99504, 28278, 2889, 27927
34738, 99375, 28239, 2878, 27888, 99376, 28240, 2877, 27889, 99539, 28291, 27940, 99519, 99540, 28292, 27941, 
99520, 99507, 28280, 2888, 27929
34739, 99376, 28240, 2877, 27889, 28136, 2935, 75, 2861, 99540, 28292, 27941, 99520, 28148, 2938, 2864, 
28146, 99510, 28282, 2887, 27931
*ELEMENT, type=C3D20, ELSET=Volume30
34740, 28293, 2960, 30, 2433, 99541, 28339, 1433, 25140, 28299, 2962, 2436, 28300, 99602, 28359, 25170, 
99603, 99601, 28360, 1444, 25171
34741, 99541, 28339, 1433, 25140, 99542, 28340, 1432, 25141, 99602, 28359, 25170, 99603, 99605, 28361, 25172, 
99606, 99604, 28362, 1443, 25173
34742, 99542, 28340, 1432, 25141, 99543, 28341, 1431, 25142, 99605, 28361, 25172, 99606, 99608, 28363, 25174, 
99609, 99607, 28364, 1442, 25175
34743, 99543, 28341, 1431, 25142, 99544, 28342, 1430, 25143, 99608, 28363, 25174, 99609, 99611, 28365, 25176, 
99612, 99610, 28366, 1441, 25177
34744, 99544, 28342, 1430, 25143, 99545, 28343, 1429, 25144, 99611, 28365, 25176, 99612, 99614, 28367, 25178, 
99615, 99613, 28368, 1440, 25179
34745, 99545, 28343, 1429, 25144, 99546, 28344, 1428, 25145, 99614, 28367, 25178, 99615, 99617, 28369, 25180, 
99618, 99616, 28370, 1439, 25181
34746, 99546, 28344, 1428, 25145, 99547, 28345, 1427, 25146, 99617, 28369, 25180, 99618, 99620, 28371, 25182, 
99621, 99619, 28372, 1438, 25183
34747, 99547, 28345, 1427, 25146, 99548, 28346, 1426, 25147, 99620, 28371, 25182, 99621, 99623, 28373, 25184, 
99624, 99622, 28374, 1437, 25185
34748, 99548, 28346, 1426, 25147, 99549, 28347, 1425, 25148, 99623, 28373, 25184, 99624, 99626, 28375, 25186, 
99627, 99625, 28376, 1436, 25187
34749, 99549, 28347, 1425, 25148, 99550, 28348, 1424, 25149, 99626, 28375, 25186, 99627, 99629, 28377, 25188, 
99630, 99628, 28378, 1435, 25189
34750, 99550, 28348, 1424, 25149, 28316, 2977, 32, 2485, 99629, 28377, 25188, 99630, 28323, 2979, 2488, 
28322, 99631, 28379, 1434, 25190
34751, 28294, 28293, 2433, 2434, 99551, 99541, 25140, 25150, 28301, 28300, 2437, 28302, 99633, 99603, 25191, 
99634, 99632, 99601, 25171, 25192
34752, 99551, 99541, 25140, 25150, 99552, 99542, 25141, 25151, 99633, 99603, 25191, 99634, 99636, 99606, 25193, 
99637, 99635, 99604, 25173, 25194
34753, 99552, 99542, 25141, 25151, 99553, 99543, 25142, 25152, 99636, 99606, 25193, 99637, 99639, 99609, 25195, 
99640, 99638, 99607, 25175, 25196
34754, 99553, 99543, 25142, 25152, 99554, 99544, 25143, 25153, 99639, 99609, 25195, 99640, 99642, 99612, 25197, 
99643, 99641, 99610, 25177, 25198
34755, 99554, 99544, 25143, 25153, 99555, 99545, 25144, 25154, 99642, 99612, 25197, 99643, 99645, 99615, 25199, 
99646, 99644, 99613, 25179, 25200
34756, 99555, 99545, 25144, 25154, 99556, 99546, 25145, 25155, 99645, 99615, 25199, 99646, 99648, 99618, 25201, 
99649, 99647, 99616, 25181, 25202
34757, 99556, 99546, 25145, 25155, 99557, 99547, 25146, 25156, 99648, 99618, 25201, 99649, 99651, 99621, 25203, 
99652, 99650, 99619, 25183, 25204
34758, 99557, 99547, 25146, 25156, 99558, 99548, 25147, 25157, 99651, 99621, 25203, 99652, 99654, 99624, 25205, 
99655, 99653, 99622, 25185, 25206
34759, 99558, 99548, 25147, 25157, 99559, 99549, 25148, 25158, 99654, 99624, 25205, 99655, 99657, 99627, 25207, 
99658, 99656, 99625, 25187, 25208
34760, 99559, 99549, 25148, 25158, 99560, 99550, 25149, 25159, 99657, 99627, 25207, 99658, 99660, 99630, 25209, 
99661, 99659, 99628, 25189, 25210
34761, 99560, 99550, 25149, 25159, 28317, 28316, 2485, 2486, 99660, 99630, 25209, 99661, 28325, 28322, 2489, 
28324, 99662, 99631, 25190, 25211
34762, 28295, 28294, 2434, 2435, 99561, 99551, 25150, 25160, 28303, 28302, 2438, 28304, 99664, 99634, 25212, 
99665, 99663, 99632, 25192, 25213
34763, 99561, 99551, 25150, 25160, 99562, 99552, 25151, 25161, 99664, 99634, 25212, 99665, 99667, 99637, 25214, 
99668, 99666, 99635, 25194, 25215
34764, 99562, 99552, 25151, 25161, 99563, 99553, 25152, 25162, 99667, 99637, 25214, 99668, 99670, 99640, 25216, 
99671, 99669, 99638, 25196, 25217
34765, 99563, 99553, 25152, 25162, 99564, 99554, 25153, 25163, 99670, 99640, 25216, 99671, 99673, 99643, 25218, 
99674, 99672, 99641, 25198, 25219
34766, 99564, 99554, 25153, 25163, 99565, 99555, 25154, 25164, 99673, 99643, 25218, 99674, 99676, 99646, 25220, 
99677, 99675, 99644, 25200, 25221
34767, 99565, 99555, 25154, 25164, 99566, 99556, 25155, 25165, 99676, 99646, 25220, 99677, 99679, 99649, 25222, 
99680, 99678, 99647, 25202, 25223
34768, 99566, 99556, 25155, 25165, 99567, 99557, 25156, 25166, 99679, 99649, 25222, 99680, 99682, 99652, 25224, 
99683, 99681, 99650, 25204, 25225
34769, 99567, 99557, 25156, 25166, 99568, 99558, 25157, 25167, 99682, 99652, 25224, 99683, 99685, 99655, 25226, 
99686, 99684, 99653, 25206, 25227
34770, 99568, 99558, 25157, 25167, 99569, 99559, 25158, 25168, 99685, 99655, 25226, 99686, 99688, 99658, 25228, 
99689, 99687, 99656, 25208, 25229
34771, 99569, 99559, 25158, 25168, 99570, 99560, 25159, 25169, 99688, 99658, 25228, 99689, 99691, 99661, 25230, 
99692, 99690, 99659, 25210, 25231
34772, 99570, 99560, 25159, 25169, 28318, 28317, 2486, 2487, 99691, 99661, 25230, 99692, 28327, 28324, 2490, 
28326, 99693, 99662, 25211, 25232
34773, 2965, 28295, 2435, 61, 28411, 99561, 25160, 2546, 28305, 28304, 2439, 2967, 99694, 99665, 25233, 
28432, 28431, 99663, 25213, 2557
34774, 28411, 99561, 25160, 2546, 28412, 99562, 25161, 2545, 99694, 99665, 25233, 28432, 99695, 99668, 25234, 
28434, 28433, 99666, 25215, 2556
34775, 28412, 99562, 25161, 2545, 28413, 99563, 25162, 2544, 99695, 99668, 25234, 28434, 99696, 99671, 25235, 
28436, 28435, 99669, 25217, 2555
34776, 28413, 99563, 25162, 2544, 28414, 99564, 25163, 2543, 99696, 99671, 25235, 28436, 99697, 99674, 25236, 
28438, 28437, 99672, 25219, 2554
34777, 28414, 99564, 25163, 2543, 28415, 99565, 25164, 2542, 99697, 99674, 25236, 28438, 99698, 99677, 25237, 
28440, 28439, 99675, 25221, 2553
34778, 28415, 99565, 25164, 2542, 28416, 99566, 25165, 2541, 99698, 99677, 25237, 28440, 99699, 99680, 25238, 
28442, 28441, 99678, 25223, 2552
34779, 28416, 99566, 25165, 2541, 28417, 99567, 25166, 2540, 99699, 99680, 25238, 28442, 99700, 99683, 25239, 
28444, 28443, 99681, 25225, 2551
34780, 28417, 99567, 25166, 2540, 28418, 99568, 25167, 2539, 99700, 99683, 25239, 28444, 99701, 99686, 25240, 
28446, 28445, 99684, 25227, 2550
34781, 28418, 99568, 25167, 2539, 28419, 99569, 25168, 2538, 99701, 99686, 25240, 28446, 99702, 99689, 25241, 
28448, 28447, 99687, 25229, 2549
34782, 28419, 99569, 25168, 2538, 28420, 99570, 25169, 2537, 99702, 99689, 25241, 28448, 99703, 99692, 25242, 
28450, 28449, 99690, 25231, 2548
34783, 28420, 99570, 25169, 2537, 2982, 28318, 2487, 62, 99703, 99692, 25242, 28450, 28328, 28326, 2491, 
2984, 28451, 99693, 25232, 2547
34784, 28296, 2961, 2960, 28293, 99571, 28349, 28339, 99541, 28306, 2963, 28299, 28307, 99705, 28380, 99602, 
99706, 99704, 28381, 28360, 99601
34785, 99571, 28349, 28339, 99541, 99572, 28350, 28340, 99542, 99705, 28380, 99602, 99706, 99708, 28382, 99605, 
99709, 99707, 28383, 28362, 99604
34786, 99572, 28350, 28340, 99542, 99573, 28351, 28341, 99543, 99708, 28382, 99605, 99709, 99711, 28384, 99608, 
99712, 99710, 28385, 28364, 99607
34787, 99573, 28351, 28341, 99543, 99574, 28352, 28342, 99544, 99711, 28384, 99608, 99712, 99714, 28386, 99611, 
99715, 99713, 28387, 28366, 99610
34788, 99574, 28352, 28342, 99544, 99575, 28353, 28343, 99545, 99714, 28386, 99611, 99715, 99717, 28388, 99614, 
99718, 99716, 28389, 28368, 99613
34789, 99575, 28353, 28343, 99545, 99576, 28354, 28344, 99546, 99717, 28388, 99614, 99718, 99720, 28390, 99617, 
99721, 99719, 28391, 28370, 99616
34790, 99576, 28354, 28344, 99546, 99577, 28355, 28345, 99547, 99720, 28390, 99617, 99721, 99723, 28392, 99620, 
99724, 99722, 28393, 28372, 99619
34791, 99577, 28355, 28345, 99547, 99578, 28356, 28346, 99548, 99723, 28392, 99620, 99724, 99726, 28394, 99623, 
99727, 99725, 28395, 28374, 99622
34792, 99578, 28356, 28346, 99548, 99579, 28357, 28347, 99549, 99726, 28394, 99623, 99727, 99729, 28396, 99626, 
99730, 99728, 28397, 28376, 99625
34793, 99579, 28357, 28347, 99549, 99580, 28358, 28348, 99550, 99729, 28396, 99626, 99730, 99732, 28398, 99629, 
99733, 99731, 28399, 28378, 99628
34794, 99580, 28358, 28348, 99550, 28319, 2978, 2977, 28316, 99732, 28398, 99629, 99733, 28330, 2980, 28323, 
28329, 99734, 28400, 28379, 99631
34795, 28297, 28296, 28293, 28294, 99581, 99571, 99541, 99551, 28308, 28307, 28301, 28309, 99736, 99706, 99633, 
99737, 99735, 99704, 99601, 99632
34796, 99581, 99571, 99541, 99551, 99582, 99572, 99542, 99552, 99736, 99706, 99633, 99737, 99739, 99709, 99636, 
99740, 99738, 99707, 99604, 99635
34797, 99582, 99572, 99542, 99552, 99583, 99573, 99543, 99553, 99739, 99709, 99636, 99740, 99742, 99712, 99639, 
99743, 99741, 99710, 99607, 99638
34798, 99583, 99573, 99543, 99553, 99584, 99574, 99544, 99554, 99742, 99712, 99639, 99743, 99745, 99715, 99642, 
99746, 99744, 99713, 99610, 99641
34799, 99584, 99574, 99544, 99554, 99585, 99575, 99545, 99555, 99745, 99715, 99642, 99746, 99748, 99718, 99645, 
99749, 99747, 99716, 99613, 99644
34800, 99585, 99575, 99545, 99555, 99586, 99576, 99546, 99556, 99748, 99718, 99645, 99749, 99751, 99721, 99648, 
99752, 99750, 99719, 99616, 99647
34801, 99586, 99576, 99546, 99556, 99587, 99577, 99547, 99557, 99751, 99721, 99648, 99752, 99754, 99724, 99651, 
99755, 99753, 99722, 99619, 99650
34802, 99587, 99577, 99547, 99557, 99588, 99578, 99548, 99558, 99754, 99724, 99651, 99755, 99757, 99727, 99654, 
99758, 99756, 99725, 99622, 99653
34803, 99588, 99578, 99548, 99558, 99589, 99579, 99549, 99559, 99757, 99727, 99654, 99758, 99760, 99730, 99657, 
99761, 99759, 99728, 99625, 99656
34804, 99589, 99579, 99549, 99559, 99590, 99580, 99550, 99560, 99760, 99730, 99657, 99761, 99763, 99733, 99660, 
99764, 99762, 99731, 99628, 99659
34805, 99590, 99580, 99550, 99560, 28320, 28319, 28316, 28317, 99763, 99733, 99660, 99764, 28332, 28329, 28325, 
28331, 99765, 99734, 99631, 99662
34806, 28298, 28297, 28294, 28295, 99591, 99581, 99551, 99561, 28310, 28309, 28303, 28311, 99767, 99737, 99664, 
99768, 99766, 99735, 99632, 99663
34807, 99591, 99581, 99551, 99561, 99592, 99582, 99552, 99562, 99767, 99737, 99664, 99768, 99770, 99740, 99667, 
99771, 99769, 99738, 99635, 99666
34808, 99592, 99582, 99552, 99562, 99593, 99583, 99553, 99563, 99770, 99740, 99667, 99771, 99773, 99743, 99670, 
99774, 99772, 99741, 99638, 99669
34809, 99593, 99583, 99553, 99563, 99594, 99584, 99554, 99564, 99773, 99743, 99670, 99774, 99776, 99746, 99673, 
99777, 99775, 99744, 99641, 99672
34810, 99594, 99584, 99554, 99564, 99595, 99585, 99555, 99565, 99776, 99746, 99673, 99777, 99779, 99749, 99676, 
99780, 99778, 99747, 99644, 99675
34811, 99595, 99585, 99555, 99565, 99596, 99586, 99556, 99566, 99779, 99749, 99676, 99780, 99782, 99752, 99679, 
99783, 99781, 99750, 99647, 99678
34812, 99596, 99586, 99556, 99566, 99597, 99587, 99557, 99567, 99782, 99752, 99679, 99783, 99785, 99755, 99682, 
99786, 99784, 99753, 99650, 99681
34813, 99597, 99587, 99557, 99567, 99598, 99588, 99558, 99568, 99785, 99755, 99682, 99786, 99788, 99758, 99685, 
99789, 99787, 99756, 99653, 99684
34814, 99598, 99588, 99558, 99568, 99599, 99589, 99559, 99569, 99788, 99758, 99685, 99789, 99791, 99761, 99688, 
99792, 99790, 99759, 99656, 99687
34815, 99599, 99589, 99559, 99569, 99600, 99590, 99560, 99570, 99791, 99761, 99688, 99792, 99794, 99764, 99691, 
99795, 99793, 99762, 99659, 99690
34816, 99600, 99590, 99560, 99570, 28321, 28320, 28317, 28318, 99794, 99764, 99691, 99795, 28334, 28331, 28327, 
28333, 99796, 99765, 99662, 99693
34817, 2966, 28298, 28295, 2965, 28421, 99591, 99561, 28411, 28312, 28311, 28305, 2968, 99797, 99768, 99694, 
28453, 28452, 99766, 99663, 28431
34818, 28421, 99591, 99561, 28411, 28422, 99592, 99562, 28412, 99797, 99768, 99694, 28453, 99798, 99771, 99695, 
28455, 28454, 99769, 99666, 28433
34819, 28422, 99592, 99562, 28412, 28423, 99593, 99563, 28413, 99798, 99771, 99695, 28455, 99799, 99774, 99696, 
28457, 28456, 99772, 99669, 28435
34820, 28423, 99593, 99563, 28413, 28424, 99594, 99564, 28414, 99799, 99774, 99696, 28457, 99800, 99777, 99697, 
28459, 28458, 99775, 99672, 28437
34821, 28424, 99594, 99564, 28414, 28425, 99595, 99565, 28415, 99800, 99777, 99697, 28459, 99801, 99780, 99698, 
28461, 28460, 99778, 99675, 28439
34822, 28425, 99595, 99565, 28415, 28426, 99596, 99566, 28416, 99801, 99780, 99698, 28461, 99802, 99783, 99699, 
28463, 28462, 99781, 99678, 28441
34823, 28426, 99596, 99566, 28416, 28427, 99597, 99567, 28417, 99802, 99783, 99699, 28463, 99803, 99786, 99700, 
28465, 28464, 99784, 99681, 28443
34824, 28427, 99597, 99567, 28417, 28428, 99598, 99568, 28418, 99803, 99786, 99700, 28465, 99804, 99789, 99701, 
28467, 28466, 99787, 99684, 28445
34825, 28428, 99598, 99568, 28418, 28429, 99599, 99569, 28419, 99804, 99789, 99701, 28467, 99805, 99792, 99702, 
28469, 28468, 99790, 99687, 28447
34826, 28429, 99599, 99569, 28419, 28430, 99600, 99570, 28420, 99805, 99792, 99702, 28469, 99806, 99795, 99703, 
28471, 28470, 99793, 99690, 28449
34827, 28430, 99600, 99570, 28420, 2983, 28321, 28318, 2982, 99806, 99795, 99703, 28471, 28335, 28333, 28328, 
2985, 28472, 99796, 99693, 28451
34828, 2970, 79, 2961, 28296, 28483, 3003, 28349, 99571, 2973, 2964, 28306, 28313, 28513, 28401, 99705, 
99807, 28514, 3014, 28381, 99704
34829, 28483, 3003, 28349, 99571, 28484, 3002, 28350, 99572, 28513, 28401, 99705, 99807, 28515, 28402, 99708, 
99808, 28516, 3013, 28383, 99707
34830, 28484, 3002, 28350, 99572, 28485, 3001, 28351, 99573, 28515, 28402, 99708, 99808, 28517, 28403, 99711, 
99809, 28518, 3012, 28385, 99710
34831, 28485, 3001, 28351, 99573, 28486, 3000, 28352, 99574, 28517, 28403, 99711, 99809, 28519, 28404, 99714, 
99810, 28520, 3011, 28387, 99713
34832, 28486, 3000, 28352, 99574, 28487, 2999, 28353, 99575, 28519, 28404, 99714, 99810, 28521, 28405, 99717, 
99811, 28522, 3010, 28389, 99716
34833, 28487, 2999, 28353, 99575, 28488, 2998, 28354, 99576, 28521, 28405, 99717, 99811, 28523, 28406, 99720, 
99812, 28524, 3009, 28391, 99719
34834, 28488, 2998, 28354, 99576, 28489, 2997, 28355, 99577, 28523, 28406, 99720, 99812, 28525, 28407, 99723, 
99813, 28526, 3008, 28393, 99722
34835, 28489, 2997, 28355, 99577, 28490, 2996, 28356, 99578, 28525, 28407, 99723, 99813, 28527, 28408, 99726, 
99814, 28528, 3007, 28395, 99725
34836, 28490, 2996, 28356, 99578, 28491, 2995, 28357, 99579, 28527, 28408, 99726, 99814, 28529, 28409, 99729, 
99815, 28530, 3006, 28397, 99728
34837, 28491, 2995, 28357, 99579, 28492, 2994, 28358, 99580, 28529, 28409, 99729, 99815, 28531, 28410, 99732, 
99816, 28532, 3005, 28399, 99731
34838, 28492, 2994, 28358, 99580, 2987, 81, 2978, 28319, 28531, 28410, 99732, 99816, 2990, 2981, 28330, 
28336, 28533, 3004, 28400, 99734
34839, 2971, 2970, 28296, 28297, 28493, 28483, 99571, 99581, 2974, 28313, 28308, 28314, 28534, 99807, 99736, 
99817, 28535, 28514, 99704, 99735
34840, 28493, 28483, 99571, 99581, 28494, 28484, 99572, 99582, 28534, 99807, 99736, 99817, 28536, 99808, 99739, 
99818, 28537, 28516, 99707, 99738
34841, 28494, 28484, 99572, 99582, 28495, 28485, 99573, 99583, 28536, 99808, 99739, 99818, 28538, 99809, 99742, 
99819, 28539, 28518, 99710, 99741
34842, 28495, 28485, 99573, 99583, 28496, 28486, 99574, 99584, 28538, 99809, 99742, 99819, 28540, 99810, 99745, 
99820, 28541, 28520, 99713, 99744
34843, 28496, 28486, 99574, 99584, 28497, 28487, 99575, 99585, 28540, 99810, 99745, 99820, 28542, 99811, 99748, 
99821, 28543, 28522, 99716, 99747
34844, 28497, 28487, 99575, 99585, 28498, 28488, 99576, 99586, 28542, 99811, 99748, 99821, 28544, 99812, 99751, 
99822, 28545, 28524, 99719, 99750
34845, 28498, 28488, 99576, 99586, 28499, 28489, 99577, 99587, 28544, 99812, 99751, 99822, 28546, 99813, 99754, 
99823, 28547, 28526, 99722, 99753
34846, 28499, 28489, 99577, 99587, 28500, 28490, 99578, 99588, 28546, 99813, 99754, 99823, 28548, 99814, 99757, 
99824, 28549, 28528, 99725, 99756
34847, 28500, 28490, 99578, 99588, 28501, 28491, 99579, 99589, 28548, 99814, 99757, 99824, 28550, 99815, 99760, 
99825, 28551, 28530, 99728, 99759
34848, 28501, 28491, 99579, 99589, 28502, 28492, 99580, 99590, 28550, 99815, 99760, 99825, 28552, 99816, 99763, 
99826, 28553, 28532, 99731, 99762
34849, 28502, 28492, 99580, 99590, 2988, 2987, 28319, 28320, 28552, 99816, 99763, 99826, 2991, 28336, 28332, 
28337, 28554, 28533, 99734, 99765
34850, 2972, 2971, 28297, 28298, 28503, 28493, 99581, 99591, 2975, 28314, 28310, 28315, 28555, 99817, 99767, 
99827, 28556, 28535, 99735, 99766
34851, 28503, 28493, 99581, 99591, 28504, 28494, 99582, 99592, 28555, 99817, 99767, 99827, 28557, 99818, 99770, 
99828, 28558, 28537, 99738, 99769
34852, 28504, 28494, 99582, 99592, 28505, 28495, 99583, 99593, 28557, 99818, 99770, 99828, 28559, 99819, 99773, 
99829, 28560, 28539, 99741, 99772
34853, 28505, 28495, 99583, 99593, 28506, 28496, 99584, 99594, 28559, 99819, 99773, 99829, 28561, 99820, 99776, 
99830, 28562, 28541, 99744, 99775
34854, 28506, 28496, 99584, 99594, 28507, 28497, 99585, 99595, 28561, 99820, 99776, 99830, 28563, 99821, 99779, 
99831, 28564, 28543, 99747, 99778
34855, 28507, 28497, 99585, 99595, 28508, 28498, 99586, 99596, 28563, 99821, 99779, 99831, 28565, 99822, 99782, 
99832, 28566, 28545, 99750, 99781
34856, 28508, 28498, 99586, 99596, 28509, 28499, 99587, 99597, 28565, 99822, 99782, 99832, 28567, 99823, 99785, 
99833, 28568, 28547, 99753, 99784
34857, 28509, 28499, 99587, 99597, 28510, 28500, 99588, 99598, 28567, 99823, 99785, 99833, 28569, 99824, 99788, 
99834, 28570, 28549, 99756, 99787
34858, 28510, 28500, 99588, 99598, 28511, 28501, 99589, 99599, 28569, 99824, 99788, 99834, 28571, 99825, 99791, 
99835, 28572, 28551, 99759, 99790
34859, 28511, 28501, 99589, 99599, 28512, 28502, 99590, 99600, 28571, 99825, 99791, 99835, 28573, 99826, 99794, 
99836, 28574, 28553, 99762, 99793
34860, 28512, 28502, 99590, 99600, 2989, 2988, 28320, 28321, 28573, 99826, 99794, 99836, 2992, 28337, 28334, 
28338, 28575, 28554, 99765, 99796
34861, 80, 2972, 28298, 2966, 3024, 28503, 99591, 28421, 2976, 28315, 28312, 2969, 28576, 99827, 99797, 
28473, 3035, 28556, 99766, 28452
34862, 3024, 28503, 99591, 28421, 3023, 28504, 99592, 28422, 28576, 99827, 99797, 28473, 28577, 99828, 99798, 
28474, 3034, 28558, 99769, 28454
34863, 3023, 28504, 99592, 28422, 3022, 28505, 99593, 28423, 28577, 99828, 99798, 28474, 28578, 99829, 99799, 
28475, 3033, 28560, 99772, 28456
34864, 3022, 28505, 99593, 28423, 3021, 28506, 99594, 28424, 28578, 99829, 99799, 28475, 28579, 99830, 99800, 
28476, 3032, 28562, 99775, 28458
34865, 3021, 28506, 99594, 28424, 3020, 28507, 99595, 28425, 28579, 99830, 99800, 28476, 28580, 99831, 99801, 
28477, 3031, 28564, 99778, 28460
34866, 3020, 28507, 99595, 28425, 3019, 28508, 99596, 28426, 28580, 99831, 99801, 28477, 28581, 99832, 99802, 
28478, 3030, 28566, 99781, 28462
34867, 3019, 28508, 99596, 28426, 3018, 28509, 99597, 28427, 28581, 99832, 99802, 28478, 28582, 99833, 99803, 
28479, 3029, 28568, 99784, 28464
34868, 3018, 28509, 99597, 28427, 3017, 28510, 99598, 28428, 28582, 99833, 99803, 28479, 28583, 99834, 99804, 
28480, 3028, 28570, 99787, 28466
34869, 3017, 28510, 99598, 28428, 3016, 28511, 99599, 28429, 28583, 99834, 99804, 28480, 28584, 99835, 99805, 
28481, 3027, 28572, 99790, 28468
34870, 3016, 28511, 99599, 28429, 3015, 28512, 99600, 28430, 28584, 99835, 99805, 28481, 28585, 99836, 99806, 
28482, 3026, 28574, 99793, 28470
34871, 3015, 28512, 99600, 28430, 82, 2989, 28321, 2983, 28585, 99836, 99806, 28482, 2993, 28338, 28335, 
2986, 3025, 28575, 99796, 28472
*ELEMENT, type=C3D20, ELSET=Volume31
34872, 28586, 3036, 29, 1303, 99837, 28618, 1412, 15415, 28590, 3038, 1305, 28591, 99878, 28638, 15435, 
99879, 99877, 28639, 1423, 15436
34873, 99837, 28618, 1412, 15415, 99838, 28619, 1411, 15416, 99878, 28638, 15435, 99879, 99881, 28640, 15437, 
99882, 99880, 28641, 1422, 15438
34874, 99838, 28619, 1411, 15416, 99839, 28620, 1410, 15417, 99881, 28640, 15437, 99882, 99884, 28642, 15439, 
99885, 99883, 28643, 1421, 15440
34875, 99839, 28620, 1410, 15417, 99840, 28621, 1409, 15418, 99884, 28642, 15439, 99885, 99887, 28644, 15441, 
99888, 99886, 28645, 1420, 15442
34876, 99840, 28621, 1409, 15418, 99841, 28622, 1408, 15419, 99887, 28644, 15441, 99888, 99890, 28646, 15443, 
99891, 99889, 28647, 1419, 15444
34877, 99841, 28622, 1408, 15419, 99842, 28623, 1407, 15420, 99890, 28646, 15443, 99891, 99893, 28648, 15445, 
99894, 99892, 28649, 1418, 15446
34878, 99842, 28623, 1407, 15420, 99843, 28624, 1406, 15421, 99893, 28648, 15445, 99894, 99896, 28650, 15447, 
99897, 99895, 28651, 1417, 15448
34879, 99843, 28624, 1406, 15421, 99844, 28625, 1405, 15422, 99896, 28650, 15447, 99897, 99899, 28652, 15449, 
99900, 99898, 28653, 1416, 15450
34880, 99844, 28625, 1405, 15422, 99845, 28626, 1404, 15423, 99899, 28652, 15449, 99900, 99902, 28654, 15451, 
99903, 99901, 28655, 1415, 15452
34881, 99845, 28626, 1404, 15423, 99846, 28627, 1403, 15424, 99902, 28654, 15451, 99903, 99905, 28656, 15453, 
99906, 99904, 28657, 1414, 15454
34882, 99846, 28627, 1403, 15424, 28602, 3046, 31, 1398, 99905, 28656, 15453, 99906, 28607, 3048, 1400, 
28606, 99907, 28658, 1413, 15455
34883, 28587, 28586, 1303, 1304, 99847, 99837, 15415, 15425, 28592, 28591, 1306, 28593, 99909, 99879, 15456, 
99910, 99908, 99877, 15436, 15457
34884, 99847, 99837, 15415, 15425, 99848, 99838, 15416, 15426, 99909, 99879, 15456, 99910, 99912, 99882, 15458, 
99913, 99911, 99880, 15438, 15459
34885, 99848, 99838, 15416, 15426, 99849, 99839, 15417, 15427, 99912, 99882, 15458, 99913, 99915, 99885, 15460, 
99916, 99914, 99883, 15440, 15461
34886, 99849, 99839, 15417, 15427, 99850, 99840, 15418, 15428, 99915, 99885, 15460, 99916, 99918, 99888, 15462, 
99919, 99917, 99886, 15442, 15463
34887, 99850, 99840, 15418, 15428, 99851, 99841, 15419, 15429, 99918, 99888, 15462, 99919, 99921, 99891, 15464, 
99922, 99920, 99889, 15444, 15465
34888, 99851, 99841, 15419, 15429, 99852, 99842, 15420, 15430, 99921, 99891, 15464, 99922, 99924, 99894, 15466, 
99925, 99923, 99892, 15446, 15467
34889, 99852, 99842, 15420, 15430, 99853, 99843, 15421, 15431, 99924, 99894, 15466, 99925, 99927, 99897, 15468, 
99928, 99926, 99895, 15448, 15469
34890, 99853, 99843, 15421, 15431, 99854, 99844, 15422, 15432, 99927, 99897, 15468, 99928, 99930, 99900, 15470, 
99931, 99929, 99898, 15450, 15471
34891, 99854, 99844, 15422, 15432, 99855, 99845, 15423, 15433, 99930, 99900, 15470, 99931, 99933, 99903, 15472, 
99934, 99932, 99901, 15452, 15473
34892, 99855, 99845, 15423, 15433, 99856, 99846, 15424, 15434, 99933, 99903, 15472, 99934, 99936, 99906, 15474, 
99937, 99935, 99904, 15454, 15475
34893, 99856, 99846, 15424, 15434, 28603, 28602, 1398, 1399, 99936, 99906, 15474, 99937, 28609, 28606, 1401, 
28608, 99938, 99907, 15455, 15476
34894, 2960, 28587, 1304, 30, 28339, 99847, 15425, 1433, 28594, 28593, 1307, 2962, 99939, 99910, 15477, 
28359, 28360, 99908, 15457, 1444
34895, 28339, 99847, 15425, 1433, 28340, 99848, 15426, 1432, 99939, 99910, 15477, 28359, 99940, 99913, 15478, 
28361, 28362, 99911, 15459, 1443
34896, 28340, 99848, 15426, 1432, 28341, 99849, 15427, 1431, 99940, 99913, 15478, 28361, 99941, 99916, 15479, 
28363, 28364, 99914, 15461, 1442
34897, 28341, 99849, 15427, 1431, 28342, 99850, 15428, 1430, 99941, 99916, 15479, 28363, 99942, 99919, 15480, 
28365, 28366, 99917, 15463, 1441
34898, 28342, 99850, 15428, 1430, 28343, 99851, 15429, 1429, 99942, 99919, 15480, 28365, 99943, 99922, 15481, 
28367, 28368, 99920, 15465, 1440
34899, 28343, 99851, 15429, 1429, 28344, 99852, 15430, 1428, 99943, 99922, 15481, 28367, 99944, 99925, 15482, 
28369, 28370, 99923, 15467, 1439
34900, 28344, 99852, 15430, 1428, 28345, 99853, 15431, 1427, 99944, 99925, 15482, 28369, 99945, 99928, 15483, 
28371, 28372, 99926, 15469, 1438
34901, 28345, 99853, 15431, 1427, 28346, 99854, 15432, 1426, 99945, 99928, 15483, 28371, 99946, 99931, 15484, 
28373, 28374, 99929, 15471, 1437
34902, 28346, 99854, 15432, 1426, 28347, 99855, 15433, 1425, 99946, 99931, 15484, 28373, 99947, 99934, 15485, 
28375, 28376, 99932, 15473, 1436
34903, 28347, 99855, 15433, 1425, 28348, 99856, 15434, 1424, 99947, 99934, 15485, 28375, 99948, 99937, 15486, 
28377, 28378, 99935, 15475, 1435
34904, 28348, 99856, 15434, 1424, 2977, 28603, 1399, 32, 99948, 99937, 15486, 28377, 28610, 28608, 1402, 
2979, 28379, 99938, 15476, 1434
34905, 28588, 3037, 3036, 28586, 99857, 28628, 28618, 99837, 28595, 3039, 28590, 28596, 99950, 28659, 99878, 
99951, 99949, 28660, 28639, 99877
34906, 99857, 28628, 28618, 99837, 99858, 28629, 28619, 99838, 99950, 28659, 99878, 99951, 99953, 28661, 99881, 
99954, 99952, 28662, 28641, 99880
34907, 99858, 28629, 28619, 99838, 99859, 28630, 28620, 99839, 99953, 28661, 99881, 99954, 99956, 28663, 99884, 
99957, 99955, 28664, 28643, 99883
34908, 99859, 28630, 28620, 99839, 99860, 28631, 28621, 99840, 99956, 28663, 99884, 99957, 99959, 28665, 99887, 
99960, 99958, 28666, 28645, 99886
34909, 99860, 28631, 28621, 99840, 99861, 28632, 28622, 99841, 99959, 28665, 99887, 99960, 99962, 28667, 99890, 
99963, 99961, 28668, 28647, 99889
34910, 99861, 28632, 28622, 99841, 99862, 28633, 28623, 99842, 99962, 28667, 99890, 99963, 99965, 28669, 99893, 
99966, 99964, 28670, 28649, 99892
34911, 99862, 28633, 28623, 99842, 99863, 28634, 28624, 99843, 99965, 28669, 99893, 99966, 99968, 28671, 99896, 
99969, 99967, 28672, 28651, 99895
34912, 99863, 28634, 28624, 99843, 99864, 28635, 28625, 99844, 99968, 28671, 99896, 99969, 99971, 28673, 99899, 
99972, 99970, 28674, 28653, 99898
34913, 99864, 28635, 28625, 99844, 99865, 28636, 28626, 99845, 99971, 28673, 99899, 99972, 99974, 28675, 99902, 
99975, 99973, 28676, 28655, 99901
34914, 99865, 28636, 28626, 99845, 99866, 28637, 28627, 99846, 99974, 28675, 99902, 99975, 99977, 28677, 99905, 
99978, 99976, 28678, 28657, 99904
34915, 99866, 28637, 28627, 99846, 28604, 3047, 3046, 28602, 99977, 28677, 99905, 99978, 28612, 3049, 28607, 
28611, 99979, 28679, 28658, 99907
34916, 28589, 28588, 28586, 28587, 99867, 99857, 99837, 99847, 28597, 28596, 28592, 28598, 99981, 99951, 99909, 
99982, 99980, 99949, 99877, 99908
34917, 99867, 99857, 99837, 99847, 99868, 99858, 99838, 99848, 99981, 99951, 99909, 99982, 99984, 99954, 99912, 
99985, 99983, 99952, 99880, 99911
34918, 99868, 99858, 99838, 99848, 99869, 99859, 99839, 99849, 99984, 99954, 99912, 99985, 99987, 99957, 99915, 
99988, 99986, 99955, 99883, 99914
34919, 99869, 99859, 99839, 99849, 99870, 99860, 99840, 99850, 99987, 99957, 99915, 99988, 99990, 99960, 99918, 
99991, 99989, 99958, 99886, 99917
34920, 99870, 99860, 99840, 99850, 99871, 99861, 99841, 99851, 99990, 99960, 99918, 99991, 99993, 99963, 99921, 
99994, 99992, 99961, 99889, 99920
34921, 99871, 99861, 99841, 99851, 99872, 99862, 99842, 99852, 99993, 99963, 99921, 99994, 99996, 99966, 99924, 
99997, 99995, 99964, 99892, 99923
34922, 99872, 99862, 99842, 99852, 99873, 99863, 99843, 99853, 99996, 99966, 99924, 99997, 99999, 99969, 99927, 
100000, 99998, 99967, 99895, 99926
34923, 99873, 99863, 99843, 99853, 99874, 99864, 99844, 99854, 99999, 99969, 99927, 100000, 100002, 99972, 99930, 
100003, 100001, 99970, 99898, 99929
34924, 99874, 99864, 99844, 99854, 99875, 99865, 99845, 99855, 100002, 99972, 99930, 100003, 100005, 99975, 99933, 
100006, 100004, 99973, 99901, 99932
34925, 99875, 99865, 99845, 99855, 99876, 99866, 99846, 99856, 100005, 99975, 99933, 100006, 100008, 99978, 99936, 
100009, 100007, 99976, 99904, 99935
34926, 99876, 99866, 99846, 99856, 28605, 28604, 28602, 28603, 100008, 99978, 99936, 100009, 28614, 28611, 28609, 
28613, 100010, 99979, 99907, 99938
34927, 2961, 28589, 28587, 2960, 28349, 99867, 99847, 28339, 28599, 28598, 28594, 2963, 100011, 99982, 99939, 
28380, 28381, 99980, 99908, 28360
34928, 28349, 99867, 99847, 28339, 28350, 99868, 99848, 28340, 100011, 99982, 99939, 28380, 100012, 99985, 99940, 
28382, 28383, 99983, 99911, 28362
34929, 28350, 99868, 99848, 28340, 28351, 99869, 99849, 28341, 100012, 99985, 99940, 28382, 100013, 99988, 99941, 
28384, 28385, 99986, 99914, 28364
34930, 28351, 99869, 99849, 28341, 28352, 99870, 99850, 28342, 100013, 99988, 99941, 28384, 100014, 99991, 99942, 
28386, 28387, 99989, 99917, 28366
34931, 28352, 99870, 99850, 28342, 28353, 99871, 99851, 28343, 100014, 99991, 99942, 28386, 100015, 99994, 99943, 
28388, 28389, 99992, 99920, 28368
34932, 28353, 99871, 99851, 28343, 28354, 99872, 99852, 28344, 100015, 99994, 99943, 28388, 100016, 99997, 99944, 
28390, 28391, 99995, 99923, 28370
34933, 28354, 99872, 99852, 28344, 28355, 99873, 99853, 28345, 100016, 99997, 99944, 28390, 100017, 100000, 99945, 
28392, 28393, 99998, 99926, 28372
34934, 28355, 99873, 99853, 28345, 28356, 99874, 99854, 28346, 100017, 100000, 99945, 28392, 100018, 100003, 99946, 
28394, 28395, 100001, 99929, 28374
34935, 28356, 99874, 99854, 28346, 28357, 99875, 99855, 28347, 100018, 100003, 99946, 28394, 100019, 100006, 99947, 
28396, 28397, 100004, 99932, 28376
34936, 28357, 99875, 99855, 28347, 28358, 99876, 99856, 28348, 100019, 100006, 99947, 28396, 100020, 100009, 99948, 
28398, 28399, 100007, 99935, 28378
34937, 28358, 99876, 99856, 28348, 2978, 28605, 28603, 2977, 100020, 100009, 99948, 28398, 28615, 28613, 28610, 
2980, 28400, 100010, 99938, 28379
34938, 3041, 83, 3037, 28588, 28690, 3065, 28628, 99857, 3043, 3040, 28595, 28600, 28710, 28680, 99950, 
100021, 28711, 3076, 28660, 99949
34939, 28690, 3065, 28628, 99857, 28691, 3064, 28629, 99858, 28710, 28680, 99950, 100021, 28712, 28681, 99953, 
100022, 28713, 3075, 28662, 99952
34940, 28691, 3064, 28629, 99858, 28692, 3063, 28630, 99859, 28712, 28681, 99953, 100022, 28714, 28682, 99956, 
100023, 28715, 3074, 28664, 99955
34941, 28692, 3063, 28630, 99859, 28693, 3062, 28631, 99860, 28714, 28682, 99956, 100023, 28716, 28683, 99959, 
100024, 28717, 3073, 28666, 99958
34942, 28693, 3062, 28631, 99860, 28694, 3061, 28632, 99861, 28716, 28683, 99959, 100024, 28718, 28684, 99962, 
100025, 28719, 3072, 28668, 99961
34943, 28694, 3061, 28632, 99861, 28695, 3060, 28633, 99862, 28718, 28684, 99962, 100025, 28720, 28685, 99965, 
100026, 28721, 3071, 28670, 99964
34944, 28695, 3060, 28633, 99862, 28696, 3059, 28634, 99863, 28720, 28685, 99965, 100026, 28722, 28686, 99968, 
100027, 28723, 3070, 28672, 99967
34945, 28696, 3059, 28634, 99863, 28697, 3058, 28635, 99864, 28722, 28686, 99968, 100027, 28724, 28687, 99971, 
100028, 28725, 3069, 28674, 99970
34946, 28697, 3058, 28635, 99864, 28698, 3057, 28636, 99865, 28724, 28687, 99971, 100028, 28726, 28688, 99974, 
100029, 28727, 3068, 28676, 99973
34947, 28698, 3057, 28636, 99865, 28699, 3056, 28637, 99866, 28726, 28688, 99974, 100029, 28728, 28689, 99977, 
100030, 28729, 3067, 28678, 99976
34948, 28699, 3056, 28637, 99866, 3051, 84, 3047, 28604, 28728, 28689, 99977, 100030, 3053, 3050, 28612, 
28616, 28730, 3066, 28679, 99979
34949, 3042, 3041, 28588, 28589, 28700, 28690, 99857, 99867, 3044, 28600, 28597, 28601, 28731, 100021, 99981, 
100031, 28732, 28711, 99949, 99980
34950, 28700, 28690, 99857, 99867, 28701, 28691, 99858, 99868, 28731, 100021, 99981, 100031, 28733, 100022, 99984, 
100032, 28734, 28713, 99952, 99983
34951, 28701, 28691, 99858, 99868, 28702, 28692, 99859, 99869, 28733, 100022, 99984, 100032, 28735, 100023, 99987, 
100033, 28736, 28715, 99955, 99986
34952, 28702, 28692, 99859, 99869, 28703, 28693, 99860, 99870, 28735, 100023, 99987, 100033, 28737, 100024, 99990, 
100034, 28738, 28717, 99958, 99989
34953, 28703, 28693, 99860, 99870, 28704, 28694, 99861, 99871, 28737, 100024, 99990, 100034, 28739, 100025, 99993, 
100035, 28740, 28719, 99961, 99992
34954, 28704, 28694, 99861, 99871, 28705, 28695, 99862, 99872, 28739, 100025, 99993, 100035, 28741, 100026, 99996, 
100036, 28742, 28721, 99964, 99995
34955, 28705, 28695, 99862, 99872, 28706, 28696, 99863, 99873, 28741, 100026, 99996, 100036, 28743, 100027, 99999, 
100037, 28744, 28723, 99967, 99998
34956, 28706, 28696, 99863, 99873, 28707, 28697, 99864, 99874, 28743, 100027, 99999, 100037, 28745, 100028, 100002, 
100038, 28746, 28725, 99970, 100001
34957, 28707, 28697, 99864, 99874, 28708, 28698, 99865, 99875, 28745, 100028, 100002, 100038, 28747, 100029, 100005, 
100039, 28748, 28727, 99973, 100004
34958, 28708, 28698, 99865, 99875, 28709, 28699, 99866, 99876, 28747, 100029, 100005, 100039, 28749, 100030, 100008, 
100040, 28750, 28729, 99976, 100007
34959, 28709, 28699, 99866, 99876, 3052, 3051, 28604, 28605, 28749, 100030, 100008, 100040, 3054, 28616, 28614, 
28617, 28751, 28730, 99979, 100010
34960, 79, 3042, 28589, 2961, 3003, 28700, 99867, 28349, 3045, 28601, 28599, 2964, 28752, 100031, 100011, 
28401, 3014, 28732, 99980, 28381
34961, 3003, 28700, 99867, 28349, 3002, 28701, 99868, 28350, 28752, 100031, 100011, 28401, 28753, 100032, 100012, 
28402, 3013, 28734, 99983, 28383
34962, 3002, 28701, 99868, 28350, 3001, 28702, 99869, 28351, 28753, 100032, 100012, 28402, 28754, 100033, 100013, 
28403, 3012, 28736, 99986, 28385
34963, 3001, 28702, 99869, 28351, 3000, 28703, 99870, 28352, 28754, 100033, 100013, 28403, 28755, 100034, 100014, 
28404, 3011, 28738, 99989, 28387
34964, 3000, 28703, 99870, 28352, 2999, 28704, 99871, 28353, 28755, 100034, 100014, 28404, 28756, 100035, 100015, 
28405, 3010, 28740, 99992, 28389
34965, 2999, 28704, 99871, 28353, 2998, 28705, 99872, 28354, 28756, 100035, 100015, 28405, 28757, 100036, 100016, 
28406, 3009, 28742, 99995, 28391
34966, 2998, 28705, 99872, 28354, 2997, 28706, 99873, 28355, 28757, 100036, 100016, 28406, 28758, 100037, 100017, 
28407, 3008, 28744, 99998, 28393
34967, 2997, 28706, 99873, 28355, 2996, 28707, 99874, 28356, 28758, 100037, 100017, 28407, 28759, 100038, 100018, 
28408, 3007, 28746, 100001, 28395
34968, 2996, 28707, 99874, 28356, 2995, 28708, 99875, 28357, 28759, 100038, 100018, 28408, 28760, 100039, 100019, 
28409, 3006, 28748, 100004, 28397
34969, 2995, 28708, 99875, 28357, 2994, 28709, 99876, 28358, 28760, 100039, 100019, 28409, 28761, 100040, 100020, 
28410, 3005, 28750, 100007, 28399
34970, 2994, 28709, 99876, 28358, 81, 3052, 28605, 2978, 28761, 100040, 100020, 28410, 3055, 28617, 28615, 
2981, 3004, 28751, 100010, 28400
*ELSET,ELSET=Contact_CeramicCopper
1881, 1882, 1883, 1884, 1885, 1886, 1887, 1888, 1889, 1890, 
1891, 1892, 1893, 1894, 1895, 1896, 1897, 1898, 1899, 1900, 
1901, 1902, 1903, 1904, 1905, 1906, 1907, 1908, 1909, 1910, 
1911, 1912, 1913, 1914, 1915, 1916, 1917, 1918, 1919, 1920, 
1921, 1922, 1923, 1924, 1925, 1926, 1927, 1928, 1929, 1930, 
1931, 1932, 1933, 1934, 1935, 1936, 1937, 1938, 1939, 1940, 
1941, 1942, 1943, 1944, 1945, 1946, 1947, 1948, 1949, 1950, 
1951, 1952, 1953, 1954, 1955, 1956, 1957, 1958, 1959, 1960, 
1961, 1962, 1963, 1964, 1965, 1966, 1967, 1968, 1969, 1970, 
1971, 1972, 1973, 1974, 1975, 1976, 1977, 1978, 1979, 1980, 
1981, 1982, 1983, 1984, 1985, 1986, 1987, 1988, 1989, 1990, 
1991, 1992, 1993, 1994, 1995, 1996, 1997, 1998, 1999, 2000, 
2001, 2002, 2003, 2004, 2005, 2006, 2007, 2008, 2009, 2010, 
2011, 2012, 2013, 2014, 2015, 2016, 2017, 2018, 2019, 2020, 
2021, 2022, 2023, 2024, 2025, 2026, 2027, 2028, 2029, 2030, 
2031, 2032, 2033, 2034, 2035, 2036, 2037, 2038, 2039, 2040, 
2041, 2042, 2043, 2044, 2045, 2046, 2047, 2048, 2049, 2050, 
2051, 2052, 2053, 2054, 2055, 2056, 2057, 2058, 2059, 2060, 
2061, 2062, 2063, 2064, 2065, 2066, 2067, 2068, 2069, 2070, 
2071, 2072, 2073, 2074, 2075, 2076, 2077, 2078, 2079, 2080, 
2081, 2082, 2083, 2084, 2085, 2086, 2087, 2088, 2089, 2090, 
2091, 2092, 2093, 2094, 2095, 2096, 2097, 2098, 2099, 2100, 
2101, 2102, 2103, 2104, 2105, 2106, 2107, 2108, 2109, 2110, 
2111, 2112, 2113, 2114, 2115, 2116, 2117, 2118, 2119, 2120, 
2121, 2122, 2123, 2124, 2125, 2126, 2127, 2128, 2129, 2130, 
2131, 2132, 2133, 5324, 5325, 5326, 5327, 5328, 5329, 5330, 
5331, 5332, 5333, 5334, 5335, 5336, 5337, 5338, 5339, 5340, 
5341, 5342, 5343, 5344, 5345, 5346, 5347, 5348, 5349, 5350, 
5351, 5352, 5353, 5354, 5355, 5356, 5357, 5358, 5359, 5360, 
5361, 5362, 5363, 5364, 5365, 5366, 5367, 5368, 5369, 5370, 
5371, 5372, 5373, 5374, 5375, 5376, 5377, 5378, 5379, 5380, 
5381, 5382, 5383, 5384, 5385, 5386, 5387, 5388, 5389, 5390, 
5391, 5392, 5393, 5394, 5395, 5396, 5397, 5398, 5399, 5400, 
5401, 5402, 5403, 5404, 5405, 5406, 5407, 5408, 5409, 5410, 
5411, 5412, 5413, 5414, 5415, 5416, 5417, 5418, 5419, 5420, 
5421, 5422, 5423, 5424, 5425, 5426, 5427, 5428, 5429, 5430, 
5431, 5432, 5433, 5434, 5435, 5436, 5437, 5438, 5439, 5440, 
5441, 5442, 5443, 5444, 5445, 5446, 5447, 5448, 5449, 5450, 
5451, 5452, 5453, 5454, 5455, 5456, 5457, 5458, 5459, 5460, 
5461, 5462, 5463, 5464, 5465, 5466, 5467, 5468, 5469, 5470, 
5471, 5472, 5473, 5474, 5475, 5476, 5477, 5478, 5479, 5480, 
5481, 5482, 5483, 5484, 5485, 5486, 5487, 5488, 5489, 5490, 
5491, 5492, 5493, 5494, 5495, 5496, 5497, 5498, 5499, 5500, 
5501, 5502, 5503, 5504, 5505, 5506, 5507, 5508, 5509, 5510, 
5511, 5512, 5513, 5514, 5515, 5516, 5517, 5518, 5519, 5520, 
5521, 5522, 5523, 5524, 5525, 5526, 5527, 5528, 5529, 5530, 
5531, 5532, 5533, 5534, 5535, 5536, 5537, 5538, 5539, 5540, 
5541, 5542, 5543, 5544, 5545, 5546, 5547, 5548, 5549, 5550, 
5551, 5552, 5553, 5554, 5555, 5556, 5557, 5558, 5559, 5560, 
5561, 5562, 5563, 5564, 5565, 5566, 5567, 5568, 5569, 5570, 
5571, 5572, 5573, 5574, 5575, 5576, 5662, 5663, 5664, 5665, 
5666, 5667, 5668, 5669, 5670, 5671, 5672, 5673, 5674, 5675, 
5676, 5677, 5678, 5679, 5680, 5681, 5682, 5683, 5684, 5685, 
5686, 5687, 5688, 5689, 5690, 5691, 5692, 5693, 5694, 5695, 
5696, 5697, 5698, 5699, 5700, 5701, 5702, 5703, 5704, 5705, 
5706, 5707, 5708, 5709, 5710, 5711, 5712, 5713, 5714, 5715, 
5716, 6141, 6142, 6143, 6144, 6145, 6146, 6147, 6148, 6149, 
6150, 6151, 6152, 6153, 6154, 6155, 6156, 6157, 6158, 6159, 
6160, 6161, 6162, 6163, 6164, 6165, 6166, 6167, 6168, 6169, 
6170, 6171, 6172, 6173, 6174, 6175, 6176, 6177, 6178, 6179, 
6180, 6181, 6182, 6183, 6184, 6185, 6186, 6187, 6188, 6189, 
6190, 6191, 6192, 6193, 6194, 6195, 6196, 6197, 6198, 6199, 
6200, 6201, 6202, 6203, 6204, 6205, 6206, 6207, 6208, 6209, 
6210, 6211, 6212, 6213, 6214, 6215, 6216, 6217, 6218, 6219, 
6220, 6221, 6222, 6223, 6224, 6225, 6226, 6227, 6228, 6229, 
6230, 6231, 6232, 6233, 6234, 6235, 6236, 6237, 6238, 6239, 
6240, 6241, 6242, 6243, 6244, 6245, 6246, 6247, 6248, 6249, 
6250, 6251, 6252, 6253, 6254, 6255, 6256, 6257, 6258, 6259, 
6260, 6261, 6262, 6263, 6264, 6265, 6266, 6267, 6268, 6269, 
6270, 6271, 6272, 6273, 6274, 6275, 6276, 6277, 6278, 6279, 
6280, 6281, 6282, 6283, 6284, 6285, 6286, 6287, 6288, 6289, 
6290, 6291, 6292, 6293, 6294, 6295, 6296, 6297, 6298, 6299, 
6300, 6301, 6302, 6303, 6304, 6305, 6306, 6307, 6308, 6309, 
6310, 6311, 6312, 6313, 6314, 6315, 6316, 6317, 6318, 6319, 
6320, 6321, 6322, 6323, 6324, 6325, 6326, 6327, 6328, 6329, 
6330, 6331, 6332, 6333, 6334, 6335, 6336, 6337, 6338, 6339, 
6340, 6341, 6342, 6343, 6344, 6345, 6346, 6347, 6348, 6349, 
6350, 6351, 6352, 6353, 6354, 6355, 6356, 6357, 6358, 6359, 
6360, 6361, 6362, 6363, 6364, 6365, 6366, 6367, 6368, 6369, 
6370, 6371, 6372, 6373, 6374, 6375, 6376, 6377, 6378, 6379, 
6380, 6381, 6382, 6383, 6384, 6385, 6386, 6387, 6388, 6389, 
6390, 6391, 6392, 6393, 9106, 9107, 9108, 9109, 9110, 9111, 
9112, 9113, 9114, 9115, 9116, 9117, 9118, 9119, 9120, 9121, 
9122, 9123, 9124, 9125, 9126, 9127, 9128, 9129, 9130, 9131, 
9132, 9133, 9134, 9135, 9136, 9137, 9138, 9172, 9173, 9174, 
9175, 9176, 9177, 9178, 9179, 9180, 9181, 9182, 9183, 9184, 
9185, 9186, 9187, 9188, 9189, 9190, 9191, 9192, 9193, 9194, 
9195, 9196, 9197, 9198, 9199, 9200, 9201, 9202, 9203, 9204, 
11229, 11230, 11231, 11232, 11233, 11234, 11235, 11236, 11237, 11238, 
11239, 11240, 11241, 11242, 11243, 11244, 11245, 11246, 11247, 11248, 
11249, 11250, 11251, 11252, 11253, 11254, 11255, 11256, 11257, 11258, 
11259, 11260, 11261, 11447, 11448, 11449, 11450, 11451, 11452, 11453, 
11454, 11455, 11456, 11457, 11458, 11459, 11460, 11461, 11462, 11463, 
11464, 11465, 11466, 11467, 11468, 11469, 11470, 11471, 11472, 11473, 
11474, 11475, 11476, 11477, 11478, 11479, 11812, 11813, 11814, 11815, 
11816, 11817, 11818, 11819, 11820, 11821, 11822, 11823, 11824, 11825, 
11826, 11827, 11828, 11829, 11830, 11831, 11832, 11833, 11834, 11835, 
11836, 11837, 11838, 11839, 11840, 11841, 11842, 11843, 11844, 11845, 
11846, 11847, 11848, 11849, 11850, 11851, 11852, 11853, 11854, 11855, 
11856, 11857, 11858, 11859, 11860, 11861, 11862, 11863, 11864, 11865, 
11866, 11867, 11868, 11869, 11870, 11871, 11872, 11873, 11874, 11875, 
11876, 11877, 11878, 11879, 11880, 11881, 11882, 11883, 11884, 11885, 
11886, 11887, 11888, 11889, 11890, 11891, 11892, 11893, 11894, 11895, 
11896, 11897, 11898, 11899, 11900, 11901, 11902, 11903, 11904, 11905, 
11906, 11907, 11908, 11909, 11910, 11911, 11912, 11913, 11914, 11915, 
11916, 11917, 11918, 11919, 11920, 11921, 11922, 11923, 11924, 11925, 
11926, 11927, 11928, 11929, 11930, 11931, 11932, 11933, 11934, 11935, 
11936, 11937, 11938, 11939, 11940, 11941, 11942, 11943, 11944, 11945, 
11946, 11947, 11948, 11949, 11950, 11951, 11952, 11953, 11954, 11955, 
11956, 11957, 11958, 11959, 11960, 11961, 11962, 11963, 11964, 11965, 
11966, 11967, 11968, 11969, 11970, 11971, 11972, 11973, 11974, 11975, 
11976, 11977, 11978, 11979, 11980, 11981, 11982, 11983, 11984, 11985, 
11986, 11987, 11988, 11989, 11990, 11991, 11992, 11993, 11994, 11995, 
11996, 11997, 11998, 11999, 12000, 12001, 12002, 12003, 12004, 12005, 
12006, 12007, 12008, 12009, 12010, 12011, 12012, 12013, 12014, 12015, 
12016, 12017, 12018, 12019, 12020, 12021, 12022, 12023, 12024, 12025, 
12026, 12027, 12028, 12029, 12030, 12031, 12032, 12033, 12034, 12035, 
12036, 12037, 12038, 12039, 12040, 12041, 12042, 12043, 12044, 12045, 
12046, 12047, 12048, 12049, 12050, 12051, 12052, 12053, 12054, 12055, 
12056, 12057, 12058, 12059, 12060, 12061, 12062, 12063, 12064, 
*ELSET,ELSET=ElectrodeMinX
9256, 9257, 9258, 9259, 9260, 9261, 9262, 9263, 9264, 9265, 
9266, 9267, 9268, 9269, 9270, 9271, 9272, 9273, 9274, 9275, 
9276, 9277, 9278, 9279, 9280, 9281, 9282, 9283, 9284, 9285, 
9286, 9287, 9288, 
*ELSET,ELSET=ElectrodeMaxX
9139, 9140, 9141, 9142, 9143, 9144, 9145, 9146, 9147, 9148, 
9149, 9150, 9151, 9152, 9153, 9154, 9155, 9156, 9157, 9158, 
9159, 9160, 9161, 9162, 9163, 9164, 9165, 9166, 9167, 9168, 
9169, 9170, 9171, 
*ELSET,ELSET=Ceramic_Top
9561, 9562, 9563, 9564, 9565, 9566, 9567, 9568, 9569, 9570, 
9571, 9572, 9573, 9574, 9575, 9576, 9577, 9578, 9579, 9580, 
9581, 9582, 9583, 9584, 9585, 9586, 9587, 9588, 9589, 9590, 
9591, 9592, 9593, 9594, 9595, 9596, 9597, 9598, 9599, 9600, 
9601, 9602, 9603, 9604, 9605, 9606, 9607, 9608, 9609, 9610, 
9611, 9612, 9613, 9614, 9615, 9616, 9617, 9618, 9619, 9620, 
9621, 9622, 9623, 9624, 9625, 9626, 9627, 9628, 9629, 9630, 
9631, 9632, 9633, 9634, 9635, 9636, 9637, 9638, 9639, 9640, 
9641, 9642, 9643, 9644, 9645, 9646, 9647, 9648, 9649, 9650, 
9651, 9652, 9653, 9654, 9655, 9656, 9657, 9658, 9659, 9660, 
9661, 9662, 9663, 9664, 9665, 9666, 9667, 9668, 9669, 9670, 
9671, 9672, 9673, 9674, 9675, 9676, 9677, 9678, 9679, 9680, 
9681, 9682, 9683, 9684, 9685, 9686, 9687, 9688, 9689, 9690, 
9691, 9692, 9693, 9694, 9695, 9696, 9697, 9698, 9699, 9700, 
9701, 9702, 9703, 9704, 9705, 9706, 9707, 9708, 9709, 9710, 
9711, 9712, 9713, 9714, 9715, 9716, 9717, 9718, 9719, 9720, 
9721, 9722, 9723, 9724, 9725, 9726, 9727, 9728, 9729, 9730, 
9731, 9732, 9733, 9734, 9735, 9736, 9737, 9738, 9739, 9740, 
9741, 9742, 9743, 9744, 9745, 9746, 9747, 9748, 9749, 9750, 
9751, 9752, 9753, 9754, 9755, 9756, 9757, 9758, 9759, 9760, 
9761, 9762, 9763, 9764, 9765, 9766, 9767, 9768, 9769, 9770, 
9771, 9772, 9773, 9774, 9775, 9776, 9777, 9778, 9779, 9780, 
9781, 9782, 9783, 9784, 9785, 9786, 9787, 9788, 9789, 9790, 
9791, 9792, 9793, 9794, 9795, 9796, 9797, 9798, 9799, 9800, 
9801, 9802, 9803, 9804, 9805, 9806, 9807, 9808, 9809, 9810, 
9811, 9812, 9813, 9898, 9899, 9900, 9901, 9902, 9903, 9904, 
9905, 9906, 9907, 9908, 9909, 9910, 9911, 9912, 9913, 9914, 
9915, 9916, 9917, 9918, 9919, 9920, 9921, 9922, 9923, 9924, 
9925, 9926, 9927, 9928, 9929, 9930, 9931, 9932, 9933, 9934, 
9935, 9936, 9937, 9938, 9939, 9940, 9941, 9942, 9943, 9944, 
9945, 9946, 9947, 9948, 9949, 9950, 9951, 9952, 10181, 10182, 
10183, 10184, 10185, 10186, 10187, 10188, 10189, 10190, 10191, 10192, 
10193, 10194, 10195, 10196, 10197, 10198, 10199, 10200, 10201, 10202, 
10203, 10204, 10205, 10206, 10207, 10208, 10209, 10210, 10211, 10212, 
10213, 10214, 10215, 10216, 10217, 10218, 10219, 10220, 10221, 10222, 
10223, 10224, 10225, 10226, 10227, 10228, 10229, 10230, 10231, 10232, 
10233, 10234, 10235, 10236, 10237, 10238, 10239, 10240, 10241, 10242, 
10243, 10244, 10245, 10246, 10247, 10248, 10249, 10250, 10251, 10252, 
10253, 10254, 10255, 10256, 10257, 10258, 10259, 10260, 10261, 10262, 
10263, 10264, 10265, 10266, 10267, 10268, 10269, 10270, 10271, 10272, 
10273, 10274, 10275, 10276, 10277, 10278, 10279, 10280, 10281, 10282, 
10283, 10284, 10285, 10286, 10287, 10288, 10289, 10290, 10291, 10292, 
10293, 10294, 10295, 10296, 10297, 10298, 10299, 10300, 10301, 10302, 
10303, 10304, 10305, 10306, 10307, 10308, 10309, 10310, 10311, 10312, 
10313, 10314, 10315, 10316, 10317, 10318, 10319, 10320, 10321, 10322, 
10323, 10324, 10325, 10326, 10327, 10328, 10329, 10330, 10331, 10332, 
10333, 10334, 10335, 10336, 10337, 10338, 10339, 10340, 10341, 10342, 
10343, 10344, 10345, 10346, 10347, 10348, 10349, 10350, 10351, 10352, 
10353, 10354, 10355, 10356, 10357, 10358, 10359, 10360, 10361, 10362, 
10363, 10364, 10365, 10366, 10367, 10368, 10369, 10370, 10371, 10372, 
10373, 10374, 10375, 10376, 10377, 10378, 10379, 10380, 10381, 10382, 
10383, 10384, 10385, 10386, 10387, 10388, 10389, 10390, 10391, 10392, 
10393, 10394, 10395, 10396, 10397, 10398, 10399, 10400, 10401, 10402, 
10403, 10404, 10405, 10406, 10407, 10408, 10409, 10410, 10411, 10412, 
10413, 10414, 10415, 10416, 10417, 10418, 10419, 10420, 10421, 10422, 
10423, 10424, 10425, 10426, 10427, 10428, 10429, 10430, 10431, 10432, 
10433, 11262, 11263, 11264, 11265, 11266, 11267, 11268, 11269, 11270, 
11271, 11272, 11273, 11274, 11275, 11276, 11277, 11278, 11279, 11280, 
11281, 11282, 11283, 11284, 11285, 11286, 11287, 11288, 11289, 11290, 
11291, 11292, 11293, 11294, 11480, 11481, 11482, 11483, 11484, 11485, 
11486, 11487, 11488, 11489, 11490, 11491, 11492, 11493, 11494, 11495, 
11496, 11497, 11498, 11499, 11500, 11501, 11502, 11503, 11504, 11505, 
11506, 11507, 11508, 11509, 11510, 11511, 11512, 
*ELSET,ELSET=Ceramic_Bottom
10706, 10707, 10708, 10709, 10710, 10711, 10712, 10713, 10714, 10715, 
10716, 10717, 10718, 10719, 10720, 10721, 10722, 10723, 10724, 10725, 
10726, 10727, 10728, 10729, 10730, 10731, 10732, 10733, 10734, 10735, 
10736, 10737, 10738, 10739, 10740, 10741, 10742, 10743, 10744, 10745, 
10746, 10747, 10748, 10749, 10750, 10751, 10752, 10753, 10754, 10755, 
10756, 10757, 10758, 10759, 10760, 10761, 10762, 10763, 10764, 10765, 
10766, 10767, 10768, 10769, 10770, 10771, 10772, 10773, 10774, 10775, 
10776, 10777, 10778, 10779, 10780, 10781, 10782, 10783, 10784, 10785, 
10786, 10787, 10788, 10789, 10790, 10791, 10792, 10793, 10794, 10795, 
10796, 10797, 10798, 10799, 10800, 10801, 10802, 10803, 10804, 10805, 
10806, 10807, 10808, 10809, 10810, 10811, 10812, 10813, 10814, 10815, 
10816, 10817, 10818, 10819, 10820, 10821, 10822, 10823, 10824, 10825, 
10826, 10827, 10828, 10829, 10830, 10831, 10832, 10833, 10834, 10835, 
10836, 10837, 10838, 10839, 10840, 10841, 10842, 10843, 10844, 10845, 
10846, 10847, 10848, 10849, 10850, 10851, 10852, 10853, 10854, 10855, 
10856, 10857, 10858, 10859, 10860, 10861, 10862, 10863, 10864, 10865, 
10866, 10867, 10868, 10869, 10870, 10871, 10872, 10873, 10874, 10875, 
10876, 10877, 10878, 10879, 10880, 10881, 10882, 10883, 10884, 10885, 
10886, 10887, 10888, 10889, 10890, 10891, 10892, 10893, 10894, 10895, 
10896, 10897, 10898, 10899, 10900, 10901, 10902, 10903, 10904, 10905, 
10906, 10907, 10908, 10909, 10910, 10911, 10912, 10913, 10914, 10915, 
10916, 10917, 10918, 10919, 10920, 10921, 10922, 10923, 10924, 10925, 
10926, 10927, 10928, 10929, 10930, 10931, 10932, 10933, 10934, 10935, 
10936, 10937, 10938, 10939, 10940, 10941, 10942, 10943, 10944, 10945, 
10946, 10947, 10948, 10949, 10950, 10951, 10952, 10953, 10954, 10955, 
10956, 10957, 10958, 11027, 11028, 11029, 11030, 11031, 11032, 11033, 
11034, 11035, 11036, 11037, 11038, 11039, 11040, 11041, 11042, 11043, 
11044, 11045, 11046, 11047, 11048, 11049, 11050, 11051, 11052, 11053, 
11054, 11055, 11056, 11057, 11058, 11059, 11172, 11173, 11174, 11175, 
11176, 11177, 11178, 11179, 11180, 11181, 11182, 11183, 11184, 11185, 
11186, 11187, 11188, 11189, 11190, 11191, 11192, 11193, 11194, 11195, 
11196, 11197, 11198, 11199, 11200, 11201, 11202, 11203, 11204, 12293, 
12294, 12295, 12296, 12297, 12298, 12299, 12300, 12301, 12302, 12303, 
12304, 12305, 12306, 12307, 12308, 12309, 12310, 12311, 12312, 12313, 
12314, 12315, 12316, 12317, 12318, 12319, 12320, 12321, 12322, 12323, 
12324, 12325, 12326, 12327, 12328, 12329, 12330, 12331, 12332, 12333, 
12334, 12335, 12336, 12337, 12338, 12339, 12340, 12341, 12342, 12343, 
12344, 12345, 12346, 12347, 12348, 12349, 12350, 12351, 12352, 12353, 
12354, 12355, 12356, 12357, 12358, 12359, 12360, 12361, 12362, 12363, 
12364, 12365, 12366, 12367, 12368, 12369, 12370, 12371, 12372, 12373, 
12374, 12375, 12376, 12377, 12378, 12379, 12380, 12381, 12382, 12383, 
12384, 12385, 12386, 12387, 12388, 12389, 12390, 12391, 12392, 12393, 
12394, 12395, 12396, 12397, 12398, 12399, 12400, 12401, 12402, 12403, 
12404, 12405, 12406, 12407, 12408, 12409, 12410, 12411, 12412, 12413, 
12414, 12415, 12416, 12417, 12418, 12419, 12420, 12421, 12422, 12423, 
12424, 12425, 12426, 12427, 12428, 12429, 12430, 12431, 12432, 12433, 
12434, 12435, 12436, 12437, 12438, 12439, 12440, 12441, 12442, 12443, 
12444, 12445, 12446, 12447, 12448, 12449, 12450, 12451, 12452, 12453, 
12454, 12455, 12456, 12457, 12458, 12459, 12460, 12461, 12462, 12463, 
12464, 12465, 12466, 12467, 12468, 12469, 12470, 12471, 12472, 12473, 
12474, 12475, 12476, 12477, 12478, 12479, 12480, 12481, 12482, 12483, 
12484, 12485, 12486, 12487, 12488, 12489, 12490, 12491, 12492, 12493, 
12494, 12495, 12496, 12497, 12498, 12499, 12500, 12501, 12502, 12503, 
12504, 12505, 12506, 12507, 12508, 12509, 12510, 12511, 12512, 12513, 
12514, 12515, 12516, 12517, 12518, 12519, 12520, 12521, 12522, 12523, 
12524, 12525, 12526, 12527, 12528, 12529, 12530, 12531, 12532, 12533, 
12534, 12535, 12536, 12537, 12538, 12539, 12540, 12541, 12542, 12543, 
12544, 12545, 12641, 12642, 12643, 12644, 12645, 12646, 12647, 12648, 
12649, 12650, 12651, 12652, 12653, 12654, 12655, 12656, 12657, 12658, 
12659, 12660, 12661, 12662, 12663, 12664, 12665, 12666, 12667, 12668, 
12669, 12670, 12671, 12672, 12673, 12674, 12675, 12676, 12677, 12678, 
12679, 12680, 12681, 12682, 12683, 12684, 12685, 12686, 12687, 12688, 
12689, 12690, 12691, 12692, 12693, 12694, 12695, 
*ELSET,ELSET=Symmetry
2456, 2457, 2458, 2459, 2460, 2461, 2462, 2463, 2464, 2465, 
2466, 2467, 2468, 2469, 2470, 2471, 2472, 2473, 2474, 2475, 
2476, 2477, 2478, 2479, 2480, 2481, 2482, 2483, 2484, 2485, 
2486, 2487, 2488, 2489, 2490, 2491, 2492, 2493, 2494, 2495, 
2496, 2497, 2498, 2499, 2500, 2501, 2502, 2503, 2504, 2505, 
2506, 2507, 2508, 2509, 2510, 2511, 2512, 2513, 2514, 2515, 
2516, 2517, 2518, 2519, 2520, 2521, 2522, 2523, 2524, 2593, 
2594, 2595, 2596, 2597, 2598, 2599, 2600, 2601, 2602, 2603, 
2604, 2605, 2606, 2607, 2608, 2609, 2610, 2611, 2612, 2613, 
2614, 2615, 2616, 2617, 2618, 2619, 2620, 2621, 2622, 2623, 
2624, 2625, 2626, 2627, 2628, 2629, 2630, 2631, 2632, 2633, 
2634, 2635, 2636, 2637, 2638, 3696, 3697, 3698, 3699, 3700, 
3701, 3702, 3703, 3704, 3705, 3706, 3707, 3708, 3709, 3710, 
3711, 3712, 3713, 3714, 3715, 3716, 3717, 3718, 3719, 3720, 
3721, 3722, 3723, 3724, 3725, 3726, 3727, 3728, 3729, 3730, 
3731, 3732, 3733, 3734, 3735, 3736, 3737, 3738, 3739, 3740, 
3741, 3742, 3743, 3744, 3745, 3746, 3747, 3748, 3749, 3750, 
3751, 3752, 3753, 3754, 3755, 3756, 3757, 3758, 3759, 3760, 
3761, 3762, 3763, 3764, 3765, 3766, 3767, 3768, 3769, 3770, 
3771, 3772, 3773, 3774, 3775, 3776, 3777, 3778, 3779, 3780, 
3781, 3782, 3783, 3784, 3785, 3786, 3787, 3788, 3789, 3790, 
3791, 3792, 3793, 3794, 3795, 3796, 3797, 3798, 3799, 3800, 
3801, 3802, 3803, 3804, 3805, 3806, 3807, 3808, 3809, 3810, 
3811, 3812, 3813, 3814, 3815, 3816, 3817, 3818, 3819, 3820, 
3821, 3822, 3823, 3824, 3825, 3826, 3827, 3828, 3829, 3830, 
3831, 3832, 3833, 3834, 3835, 3836, 3837, 3838, 3839, 3840, 
3841, 3842, 3843, 3844, 3845, 3846, 3847, 3848, 3849, 3850, 
3851, 3852, 3853, 3854, 3855, 3856, 3857, 3858, 3859, 3860, 
3861, 3862, 3863, 3864, 3865, 3866, 3867, 3868, 3869, 3870, 
3871, 3872, 3873, 3874, 3875, 3876, 3877, 3878, 3879, 3880, 
3881, 3882, 3883, 3884, 3885, 3886, 3887, 3888, 3889, 3890, 
3891, 3892, 3893, 3894, 3895, 3896, 3897, 3898, 3899, 3900, 
3901, 3902, 3903, 3904, 3905, 3906, 3907, 3908, 3909, 3910, 
3911, 3912, 3913, 3914, 3915, 3916, 3917, 3918, 3919, 3920, 
3921, 3922, 3923, 3924, 3925, 3926, 3927, 3928, 3929, 3930, 
3931, 3932, 3933, 3934, 3935, 3936, 3937, 3938, 3939, 3940, 
3941, 3942, 3943, 3944, 3945, 3946, 3947, 3948, 3949, 3950, 
3951, 3952, 3953, 3954, 3955, 3956, 3957, 3958, 3959, 3960, 
3961, 3962, 3963, 3964, 3965, 3966, 3967, 3968, 3969, 3970, 
3971, 3972, 3973, 3974, 3975, 3976, 3977, 3978, 3979, 3980, 
3981, 3982, 3983, 3984, 3985, 3986, 3987, 3988, 3989, 3990, 
3991, 3992, 3993, 3994, 3995, 3996, 3997, 3998, 3999, 4000, 
4001, 4002, 4003, 4004, 4005, 4006, 4007, 4008, 4009, 4010, 
4011, 4012, 4013, 4014, 4015, 4016, 4017, 4018, 4019, 4020, 
4021, 4022, 4023, 4024, 4025, 4026, 4027, 4028, 4029, 4030, 
4031, 4032, 4033, 4034, 4035, 4036, 4037, 4038, 4039, 4040, 
4041, 4042, 4043, 4044, 4045, 4046, 4047, 4048, 4049, 4050, 
4051, 4052, 4053, 4054, 4055, 4056, 4057, 4058, 4059, 4060, 
4061, 4062, 4063, 4064, 4065, 4066, 4067, 4068, 4069, 4070, 
4071, 4072, 4073, 4074, 4075, 4076, 4077, 4078, 4079, 4080, 
4081, 4082, 4083, 4084, 4085, 4086, 4087, 4088, 4089, 4090, 
4091, 4092, 4093, 4094, 4095, 4096, 4097, 4098, 4099, 4100, 
4101, 4102, 4103, 4104, 4105, 4106, 4107, 4108, 4109, 4110, 
4111, 4112, 4113, 4114, 4115, 4116, 4117, 4118, 4119, 4120, 
4121, 4122, 4123, 4124, 4125, 4126, 4127, 4128, 4129, 4130, 
4131, 4132, 4133, 4134, 4135, 4136, 4137, 4138, 4139, 4140, 
4141, 4142, 4143, 4144, 4145, 4146, 4147, 4148, 4149, 4150, 
4151, 4152, 4153, 4154, 4155, 4156, 4157, 4158, 4159, 4160, 
4161, 4162, 4163, 4164, 4165, 4166, 4167, 4168, 4169, 4170, 
4171, 4172, 4173, 4174, 4175, 4176, 4177, 4178, 4179, 4180, 
4181, 4182, 4183, 4184, 4185, 4186, 4187, 4188, 4189, 4190, 
4191, 4192, 4193, 4194, 4195, 4196, 4197, 4198, 4199, 4200, 
4201, 4202, 4203, 4204, 4205, 4206, 4207, 4208, 4209, 4210, 
4211, 4212, 4213, 4214, 4215, 4216, 4217, 4218, 4219, 4220, 
4221, 4222, 4223, 4224, 4799, 4800, 4801, 4802, 4803, 4804, 
4805, 4806, 4807, 4808, 4809, 4810, 4811, 4812, 4813, 4814, 
4815, 4816, 4817, 4818, 4819, 4820, 4821, 4822, 4823, 4824, 
4825, 4826, 4827, 4828, 4829, 4830, 4831, 4832, 4833, 4834, 
4835, 4836, 4837, 4838, 4839, 4840, 4841, 4842, 4843, 4844, 
5222, 5223, 5224, 5225, 5226, 5227, 5228, 5229, 5230, 5231, 
5232, 5233, 5234, 5235, 5236, 5237, 5238, 5239, 5240, 5241, 
5242, 5243, 5244, 5245, 5246, 5247, 5248, 5249, 5250, 5251, 
5252, 5253, 5254, 5255, 5256, 5257, 5258, 5259, 5260, 5261, 
5262, 5263, 5264, 5265, 5266, 5267, 5268, 5269, 5270, 5271, 
5272, 5273, 5274, 5275, 5276, 5277, 5278, 5279, 5280, 5281, 
5282, 5283, 5284, 5285, 5286, 5287, 5288, 5289, 5290, 5577, 
5578, 5579, 5580, 5581, 5582, 5583, 5584, 5585, 5586, 5587, 
5588, 5589, 5590, 5591, 5750, 5751, 5752, 5753, 5754, 5755, 
5756, 5757, 5758, 5759, 5760, 5761, 5762, 5763, 5764, 5765, 
5766, 5767, 5768, 5769, 5770, 5771, 5772, 5773, 5774, 5775, 
5776, 5777, 5778, 5779, 5780, 5781, 5782, 5783, 5784, 5785, 
5786, 5787, 5788, 5789, 5790, 5791, 5792, 5793, 5794, 5795, 
5796, 5797, 5798, 5799, 5800, 5801, 5802, 5803, 5804, 5805, 
5806, 5807, 5808, 5809, 5810, 5811, 5812, 5813, 5814, 5815, 
5816, 5817, 5818, 6427, 6428, 6429, 6430, 6431, 6432, 6433, 
6434, 6435, 6436, 6437, 6438, 6439, 6440, 6441, 6442, 6443, 
6444, 6445, 6446, 6447, 6448, 6449, 6450, 6451, 6452, 6453, 
6454, 6455, 6456, 6457, 6458, 6459, 6460, 6461, 6462, 6463, 
6464, 6465, 6466, 6467, 6468, 6469, 6470, 6471, 6472, 6816, 
6817, 6818, 6819, 6820, 6821, 6822, 6823, 6824, 6825, 6826, 
6827, 6828, 6829, 6830, 6831, 6832, 6833, 6834, 6835, 6836, 
6837, 6838, 6839, 6840, 6841, 6842, 6843, 6844, 6845, 6846, 
6847, 6848, 6849, 6850, 6851, 6852, 6853, 6854, 6855, 6856, 
6857, 6858, 6859, 6860, 6861, 6862, 6863, 6864, 6865, 6866, 
6867, 6868, 6869, 6870, 6871, 6872, 6873, 6874, 6875, 6876, 
6877, 6878, 6879, 6880, 6881, 6882, 6883, 6884, 6885, 6886, 
6887, 6888, 6889, 6890, 6891, 6892, 6893, 6894, 6895, 6896, 
6897, 6898, 6899, 6900, 6901, 6902, 6903, 6904, 6905, 6906, 
6907, 6908, 6909, 6910, 6911, 6912, 6913, 6914, 6915, 6916, 
6917, 6918, 6919, 6920, 6921, 6922, 6923, 6924, 6925, 6926, 
6927, 6928, 6929, 6930, 6931, 6932, 6933, 6934, 6935, 6936, 
6937, 6938, 6939, 6940, 6941, 6942, 6943, 6944, 6945, 6946, 
6947, 6948, 6949, 6950, 6951, 6952, 6953, 6954, 6955, 6956, 
6957, 6958, 6959, 6960, 6961, 6962, 6963, 6964, 6965, 6966, 
6967, 6968, 6969, 6970, 6971, 6972, 6973, 6974, 6975, 6976, 
6977, 6978, 6979, 6980, 6981, 6982, 6983, 6984, 6985, 6986, 
6987, 6988, 6989, 6990, 6991, 6992, 6993, 6994, 6995, 6996, 
6997, 6998, 6999, 7000, 7001, 7002, 7003, 7004, 7005, 7006, 
7007, 7008, 7009, 7010, 7011, 7012, 7013, 7014, 7015, 7016, 
7017, 7018, 7019, 7020, 7021, 7022, 7023, 7024, 7025, 7026, 
7027, 7028, 7029, 7030, 7031, 7032, 7033, 7034, 7035, 7036, 
7037, 7038, 7039, 7040, 7041, 7042, 7043, 7044, 7045, 7046, 
7047, 7048, 7049, 7050, 7051, 7052, 7053, 7054, 7055, 7056, 
7057, 7058, 7059, 7060, 7061, 7062, 7063, 7064, 7065, 7066, 
7067, 7068, 7069, 7070, 7071, 7072, 7073, 7074, 7075, 7076, 
7077, 7078, 7079, 7080, 7081, 7082, 7083, 7084, 7085, 7086, 
7087, 7088, 7089, 7090, 7091, 7092, 7093, 7094, 7095, 7096, 
7097, 7098, 7099, 7100, 7101, 7102, 7103, 7104, 7105, 7106, 
7107, 7108, 7109, 7110, 7111, 7112, 7113, 7114, 7115, 7116, 
7117, 7118, 7119, 7120, 7121, 7122, 7123, 7124, 7125, 7126, 
7127, 7128, 7129, 7130, 7131, 7132, 7133, 7134, 7135, 7136, 
7137, 7138, 7139, 7140, 7141, 7142, 7143, 7144, 7145, 7146, 
7147, 7148, 7149, 7150, 7151, 7152, 7153, 7154, 7155, 7156, 
7157, 7158, 7159, 7160, 7161, 7162, 7163, 7164, 7165, 7166, 
7167, 7168, 7169, 7170, 7171, 7172, 7173, 7174, 7175, 7176, 
7177, 7178, 7179, 7180, 7181, 7182, 7183, 7184, 7185, 7186, 
7187, 7188, 7189, 7190, 7191, 7192, 7193, 7194, 7195, 7196, 
7197, 7198, 7199, 7200, 7201, 7202, 7203, 7204, 7205, 7206, 
7207, 7208, 7209, 7210, 7211, 7212, 7213, 7214, 7215, 7216, 
7217, 7218, 7219, 7220, 7221, 7222, 7223, 7224, 7225, 7226, 
7227, 7228, 7229, 7230, 7231, 7232, 7233, 7234, 7235, 7236, 
7237, 7238, 7239, 7240, 7241, 7242, 7243, 7244, 7245, 7246, 
7247, 7248, 7249, 7250, 7251, 7252, 7253, 7254, 7255, 7256, 
7257, 7258, 7259, 7260, 7261, 7262, 7263, 7264, 7265, 7266, 
7267, 7268, 7269, 7270, 7271, 7272, 7273, 7274, 7275, 7276, 
7277, 7278, 7279, 7280, 7281, 7282, 7283, 7284, 7285, 7286, 
7287, 7288, 7289, 7290, 7291, 7292, 7293, 7294, 7295, 7296, 
7297, 7298, 7299, 7300, 7301, 7302, 7303, 7304, 7305, 7306, 
7307, 7308, 7309, 7310, 7311, 7312, 7313, 7314, 7315, 7316, 
7317, 7318, 7319, 7320, 7321, 7322, 7323, 7324, 7325, 7326, 
7327, 7328, 7329, 7330, 7331, 7332, 7333, 7334, 7335, 7336, 
7337, 7338, 7339, 7340, 7341, 7342, 7343, 7344, 8633, 8634, 
8635, 8636, 8637, 8638, 8639, 8640, 8641, 8642, 8643, 8644, 
8645, 8646, 8647, 8648, 8649, 8650, 8651, 8652, 8653, 8654, 
8655, 8656, 8657, 8658, 8659, 8660, 8661, 8662, 8663, 8664, 
8665, 8666, 8667, 8668, 8669, 8670, 8671, 8672, 8673, 8674, 
8675, 8676, 8677, 8678, 9055, 9056, 9057, 9058, 9059, 9060, 
9061, 9062, 9063, 9205, 9206, 9207, 9208, 9209, 9210, 9211, 
9212, 9213, 9425, 9426, 9427, 9428, 9429, 9430, 9431, 9432, 
9433, 9434, 9435, 9436, 9437, 9438, 9439, 9440, 9441, 9442, 
9443, 9444, 9445, 9446, 9447, 9448, 9449, 9450, 9451, 9452, 
9453, 9454, 9455, 9456, 9457, 9458, 9459, 9460, 9461, 9462, 
9463, 9464, 9465, 9466, 9467, 9468, 9469, 9470, 9471, 9472, 
9473, 9474, 9475, 9476, 9477, 9478, 9479, 9480, 9481, 9482, 
9483, 9484, 9485, 9486, 9487, 9488, 9489, 9490, 9491, 9492, 
9493, 9494, 9495, 9496, 9497, 9498, 9499, 9500, 9501, 9502, 
9503, 9504, 9505, 9506, 9507, 9508, 9509, 9510, 9511, 9512, 
9513, 9514, 9515, 9516, 9814, 9815, 9816, 9817, 9818, 9819, 
9820, 9821, 9822, 9823, 9824, 9825, 9826, 9827, 9828, 9829, 
9830, 9831, 9832, 9833, 9953, 9954, 9955, 9956, 9957, 9958, 
9959, 9960, 9961, 9962, 9963, 9964, 9965, 9966, 9967, 9968, 
9969, 9970, 9971, 9972, 9973, 9974, 9975, 9976, 9977, 9978, 
9979, 9980, 9981, 9982, 9983, 9984, 9985, 9986, 9987, 9988, 
9989, 9990, 9991, 9992, 9993, 9994, 9995, 9996, 9997, 9998, 
9999, 10000, 10001, 10002, 10003, 10004, 10005, 10006, 10007, 10008, 
10009, 10010, 10011, 10012, 10013, 10014, 10015, 10016, 10017, 10018, 
10019, 10020, 10021, 10022, 10023, 10024, 10025, 10026, 10027, 10028, 
10029, 10030, 10031, 10032, 10033, 10034, 10035, 10036, 10037, 10038, 
10039, 10040, 10041, 10042, 10043, 10044, 10570, 10571, 10572, 10573, 
10574, 10575, 10576, 10577, 10578, 10579, 10580, 10581, 10582, 10583, 
10584, 10585, 10586, 10587, 10588, 10589, 10590, 10591, 10592, 10593, 
10594, 10595, 10596, 10597, 10598, 10599, 10600, 10601, 10602, 10603, 
10604, 10605, 10606, 10607, 10608, 10609, 10610, 10611, 10612, 10613, 
10614, 10615, 10616, 10617, 10618, 10619, 10620, 10621, 10622, 10623, 
10624, 10625, 10626, 10627, 10628, 10629, 10630, 10631, 10632, 10633, 
10634, 10635, 10636, 10637, 10638, 10639, 10640, 10641, 10642, 10643, 
10644, 10645, 10646, 10647, 10648, 10649, 10650, 10651, 10652, 10653, 
10654, 10655, 10656, 10657, 10658, 10659, 10660, 10661, 10959, 10960, 
10961, 10962, 10963, 10964, 10965, 10966, 10967, 10968, 10969, 10970, 
11104, 11105, 11106, 11107, 11108, 11109, 11110, 11111, 11112, 11113, 
11114, 11115, 11205, 11206, 11207, 11208, 11209, 11210, 11211, 11212, 
11213, 11214, 11215, 11216, 11339, 11340, 11341, 11342, 11343, 11344, 
11345, 11346, 11347, 11423, 11424, 11425, 11426, 11427, 11428, 11429, 
11430, 11431, 11432, 11433, 11434, 11557, 11558, 11559, 11560, 11561, 
11562, 11563, 11564, 11565, 11641, 11642, 11643, 11644, 11645, 11646, 
11647, 11648, 11649, 11650, 11651, 11652, 11653, 11654, 11655, 11656, 
11657, 11658, 11659, 11660, 11661, 11662, 11663, 11664, 11665, 11666, 
11667, 11668, 11669, 11670, 11671, 11672, 11673, 11674, 11675, 11676, 
11677, 11678, 11679, 11680, 11681, 11682, 11683, 11684, 11685, 11686, 
11687, 11688, 11689, 11690, 11691, 11692, 11693, 11694, 11695, 11696, 
11697, 11698, 11699, 11700, 11701, 11702, 11703, 11704, 11705, 11706, 
11707, 11708, 11709, 12065, 12066, 12067, 12068, 12069, 12070, 12071, 
12072, 12073, 12074, 12075, 12076, 12077, 12078, 12079, 12080, 12081, 
12082, 12083, 12084, 12085, 12086, 12087, 12088, 12089, 12090, 12091, 
12092, 12093, 12094, 12095, 12096, 12097, 12098, 12099, 12100, 12101, 
12102, 12103, 12104, 12105, 12106, 12107, 12108, 12109, 12110, 12111, 
12112, 12113, 12114, 12115, 12116, 12117, 12118, 12119, 12120, 12121, 
12122, 12123, 12124, 12125, 12126, 12127, 12128, 12129, 12130, 12131, 
12132, 12133, 12134, 12135, 12136, 12137, 12138, 12139, 12140, 12141, 
12142, 12143, 12144, 12145, 12146, 12147, 12148, 12149, 12150, 12151, 
12152, 12153, 12154, 12155, 12156, 12546, 12547, 12548, 12549, 12550, 
12551, 12552, 12553, 12554, 12555, 12556, 12557, 12558, 12559, 12560, 
12561, 12562, 12563, 12564, 12565, 
*ELSET,ELSET=Symmetry_X
9139, 9140, 9141, 9142, 9143, 9144, 9145, 9146, 9147, 9148, 
9149, 9150, 9151, 9152, 9153, 9154, 9155, 9156, 9157, 9158, 
9159, 9160, 9161, 9162, 9163, 9164, 9165, 9166, 9167, 9168, 
9169, 9170, 9171, 9256, 9257, 9258, 9259, 9260, 9261, 9262, 
9263, 9264, 9265, 9266, 9267, 9268, 9269, 9270, 9271, 9272, 
9273, 9274, 9275, 9276, 9277, 9278, 9279, 9280, 9281, 9282, 
9283, 9284, 9285, 9286, 9287, 9288, 10983, 10984, 10985, 10986, 
10987, 10988, 10989, 10990, 10991, 10992, 10993, 10994, 10995, 10996, 
10997, 10998, 10999, 11000, 11001, 11002, 11003, 11004, 11005, 11006, 
11007, 11008, 11009, 11010, 11011, 11012, 11013, 11014, 11015, 11016, 
11017, 11018, 11019, 11020, 11021, 11022, 11023, 11024, 11025, 11026, 
11128, 11129, 11130, 11131, 11132, 11133, 11134, 11135, 11136, 11137, 
11138, 11139, 11140, 11141, 11142, 11143, 11144, 11145, 11146, 11147, 
11148, 11149, 11150, 11151, 11152, 11153, 11154, 11155, 11156, 11157, 
11158, 11159, 11160, 11161, 11162, 11163, 11164, 11165, 11166, 11167, 
11168, 11169, 11170, 11171, 11295, 11296, 11297, 11298, 11299, 11300, 
11301, 11302, 11303, 11304, 11305, 11306, 11307, 11308, 11309, 11310, 
11311, 11312, 11313, 11314, 11315, 11316, 11317, 11318, 11319, 11320, 
11321, 11322, 11323, 11324, 11325, 11326, 11327, 11328, 11329, 11330, 
11331, 11332, 11333, 11334, 11335, 11336, 11337, 11338, 11390, 11391, 
11392, 11393, 11394, 11395, 11396, 11397, 11398, 11399, 11400, 11401, 
11402, 11403, 11404, 11405, 11406, 11407, 11408, 11409, 11410, 11411, 
11412, 11413, 11414, 11415, 11416, 11417, 11418, 11419, 11420, 11421, 
11422, 11513, 11514, 11515, 11516, 11517, 11518, 11519, 11520, 11521, 
11522, 11523, 11524, 11525, 11526, 11527, 11528, 11529, 11530, 11531, 
11532, 11533, 11534, 11535, 11536, 11537, 11538, 11539, 11540, 11541, 
11542, 11543, 11544, 11545, 11546, 11547, 11548, 11549, 11550, 11551, 
11552, 11553, 11554, 11555, 11556, 11608, 11609, 11610, 11611, 11612, 
11613, 11614, 11615, 11616, 11617, 11618, 11619, 11620, 11621, 11622, 
11623, 11624, 11625, 11626, 11627, 11628, 11629, 11630, 11631, 11632, 
11633, 11634, 11635, 11636, 11637, 11638, 11639, 11640, 
*ELSET,ELSET=Volume
12696, 12697, 12698, 12699, 12700, 12701, 12702, 12703, 12704, 12705, 
12706, 12707, 12708, 12709, 12710, 12711, 12712, 12713, 12714, 12715, 
12716, 12717, 12718, 12719, 12720, 12721, 12722, 12723, 12724, 12725, 
12726, 12727, 12728, 12729, 12730, 12731, 12732, 12733, 12734, 12735, 
12736, 12737, 12738, 12739, 12740, 12741, 12742, 12743, 12744, 12745, 
12746, 12747, 12748, 12749, 12750, 12751, 12752, 12753, 12754, 12755, 
12756, 12757, 12758, 12759, 12760, 12761, 12762, 12763, 12764, 12765, 
12766, 12767, 12768, 12769, 12770, 12771, 12772, 12773, 12774, 12775, 
12776, 12777, 12778, 12779, 12780, 12781, 12782, 12783, 12784, 12785, 
12786, 12787, 12788, 12789, 12790, 12791, 12792, 12793, 12794, 12795, 
12796, 12797, 12798, 12799, 12800, 12801, 12802, 12803, 12804, 12805, 
12806, 12807, 12808, 12809, 12810, 12811, 12812, 12813, 12814, 12815, 
12816, 12817, 12818, 12819, 12820, 12821, 12822, 12823, 12824, 12825, 
12826, 12827, 12828, 12829, 12830, 12831, 12832, 12833, 12834, 12835, 
12836, 12837, 12838, 12839, 12840, 12841, 12842, 12843, 12844, 12845, 
12846, 12847, 12848, 12849, 12850, 12851, 12852, 12853, 12854, 12855, 
12856, 12857, 12858, 12859, 12860, 12861, 12862, 12863, 12864, 12865, 
12866, 12867, 12868, 12869, 12870, 12871, 12872, 12873, 12874, 12875, 
12876, 12877, 12878, 12879, 12880, 12881, 12882, 12883, 12884, 12885, 
12886, 12887, 12888, 12889, 12890, 12891, 12892, 12893, 12894, 12895, 
12896, 12897, 12898, 12899, 12900, 12901, 12902, 12903, 12904, 12905, 
12906, 12907, 12908, 12909, 12910, 12911, 12912, 12913, 12914, 12915, 
12916, 12917, 12918, 12919, 12920, 12921, 12922, 12923, 12924, 12925, 
12926, 12927, 12928, 12929, 12930, 12931, 12932, 12933, 12934, 12935, 
12936, 12937, 12938, 12939, 12940, 12941, 12942, 12943, 12944, 12945, 
12946, 12947, 12948, 12949, 12950, 12951, 12952, 12953, 12954, 12955, 
12956, 12957, 12958, 12959, 12960, 12961, 12962, 12963, 12964, 12965, 
12966, 12967, 12968, 12969, 12970, 12971, 12972, 12973, 12974, 12975, 
12976, 12977, 12978, 12979, 12980, 12981, 12982, 12983, 12984, 12985, 
12986, 12987, 12988, 12989, 12990, 12991, 12992, 12993, 12994, 12995, 
12996, 12997, 12998, 12999, 13000, 13001, 13002, 13003, 13004, 13005, 
13006, 13007, 13008, 13009, 13010, 13011, 13012, 13013, 13014, 13015, 
13016, 13017, 13018, 13019, 13020, 13021, 13022, 13023, 13024, 13025, 
13026, 13027, 13028, 13029, 13030, 13031, 13032, 13033, 13034, 13035, 
13036, 13037, 13038, 13039, 13040, 13041, 13042, 13043, 13044, 13045, 
13046, 13047, 13048, 13049, 13050, 13051, 13052, 13053, 13054, 13055, 
13056, 13057, 13058, 13059, 13060, 13061, 13062, 13063, 13064, 13065, 
13066, 13067, 13068, 13069, 13070, 13071, 13072, 13073, 13074, 13075, 
13076, 13077, 13078, 13079, 13080, 13081, 13082, 13083, 13084, 13085, 
13086, 13087, 13088, 13089, 13090, 13091, 13092, 13093, 13094, 13095, 
13096, 13097, 13098, 13099, 13100, 13101, 13102, 13103, 13104, 13105, 
13106, 13107, 13108, 13109, 13110, 13111, 13112, 13113, 13114, 13115, 
13116, 13117, 13118, 13119, 13120, 13121, 13122, 13123, 13124, 13125, 
13126, 13127, 13128, 13129, 13130, 13131, 13132, 13133, 13134, 13135, 
13136, 13137, 13138, 13139, 13140, 13141, 13142, 13143, 13144, 13145, 
13146, 13147, 13148, 13149, 13150, 13151, 13152, 13153, 13154, 13155, 
13156, 13157, 13158, 13159, 13160, 13161, 13162, 13163, 13164, 13165, 
13166, 13167, 13168, 13169, 13170, 13171, 13172, 13173, 13174, 13175, 
13176, 13177, 13178, 13179, 13180, 13181, 13182, 13183, 13184, 13185, 
13186, 13187, 13188, 13189, 13190, 13191, 13192, 13193, 13194, 13195, 
13196, 13197, 13198, 13199, 13200, 13201, 13202, 13203, 13204, 13205, 
13206, 13207, 13208, 13209, 13210, 13211, 13212, 13213, 13214, 13215, 
13216, 13217, 13218, 13219, 13220, 13221, 13222, 13223, 13224, 13225, 
13226, 13227, 13228, 13229, 13230, 13231, 13232, 13233, 13234, 13235, 
13236, 13237, 13238, 13239, 13240, 13241, 13242, 13243, 13244, 13245, 
13246, 13247, 13248, 13249, 13250, 13251, 13252, 13253, 13254, 13255, 
13256, 13257, 13258, 13259, 13260, 13261, 13262, 13263, 13264, 13265, 
13266, 13267, 13268, 13269, 13270, 13271, 13272, 13273, 13274, 13275, 
13276, 13277, 13278, 13279, 13280, 13281, 13282, 13283, 13284, 13285, 
13286, 13287, 13288, 13289, 13290, 13291, 13292, 13293, 13294, 13295, 
13296, 13297, 13298, 13299, 13300, 13301, 13302, 13303, 13304, 13305, 
13306, 13307, 13308, 13309, 13310, 13311, 13312, 13313, 13314, 13315, 
13316, 13317, 13318, 13319, 13320, 13321, 13322, 13323, 13324, 13325, 
13326, 13327, 13328, 13329, 13330, 13331, 13332, 13333, 13334, 13335, 
13336, 13337, 13338, 13339, 13340, 13341, 13342, 13343, 13344, 13345, 
13346, 13347, 13348, 13349, 13350, 13351, 13352, 13353, 13354, 13355, 
13356, 13357, 13358, 13359, 13360, 13361, 13362, 13363, 13364, 13365, 
13366, 13367, 13368, 13369, 13370, 13371, 13372, 13373, 13374, 13375, 
13376, 13377, 13378, 13379, 13380, 13381, 13382, 13383, 13384, 13385, 
13386, 13387, 13388, 13389, 13390, 13391, 13392, 13393, 13394, 13395, 
13396, 13397, 13398, 13399, 13400, 13401, 13402, 13403, 13404, 13405, 
13406, 13407, 13408, 13409, 13410, 13411, 13412, 13413, 13414, 13415, 
13416, 13417, 13418, 13419, 13420, 13421, 13422, 13423, 13424, 13425, 
13426, 13427, 13428, 13429, 13430, 13431, 13432, 13433, 13434, 13435, 
13436, 13437, 13438, 13439, 13440, 13441, 13442, 13443, 13444, 13445, 
13446, 13447, 13448, 13449, 13450, 13451, 13452, 13453, 13454, 13455, 
13456, 13457, 13458, 13459, 13460, 13461, 13462, 13463, 13464, 13465, 
13466, 13467, 13468, 13469, 13470, 13471, 13472, 13473, 13474, 13475, 
13476, 13477, 13478, 13479, 13480, 13481, 13482, 13483, 13484, 13485, 
13486, 13487, 13488, 13489, 13490, 13491, 13492, 13493, 13494, 13495, 
13496, 13497, 13498, 13499, 13500, 13501, 13502, 13503, 13504, 13505, 
13506, 13507, 13508, 13509, 13510, 13511, 13512, 13513, 13514, 13515, 
13516, 13517, 13518, 13519, 13520, 13521, 13522, 13523, 13524, 13525, 
13526, 13527, 13528, 13529, 13530, 13531, 13532, 13533, 13534, 13535, 
13536, 13537, 13538, 13539, 13540, 13541, 13542, 13543, 13544, 13545, 
13546, 13547, 13548, 13549, 13550, 13551, 13552, 13553, 13554, 13555, 
13556, 13557, 13558, 13559, 13560, 13561, 13562, 13563, 13564, 13565, 
13566, 13567, 13568, 13569, 13570, 13571, 13572, 13573, 13574, 13575, 
13576, 13577, 13578, 13579, 13580, 13581, 13582, 13583, 13584, 13585, 
13586, 13587, 13588, 13589, 13590, 13591, 13592, 13593, 13594, 13595, 
13596, 13597, 13598, 13599, 13600, 13601, 13602, 13603, 13604, 13605, 
13606, 13607, 13608, 13609, 13610, 13611, 13612, 13613, 13614, 13615, 
13616, 13617, 13618, 13619, 13620, 13621, 13622, 13623, 13624, 13625, 
13626, 13627, 13628, 13629, 13630, 13631, 13632, 13633, 13634, 13635, 
13636, 13637, 13638, 13639, 13640, 13641, 13642, 13643, 13644, 13645, 
13646, 13647, 13648, 13649, 13650, 13651, 13652, 13653, 13654, 13655, 
13656, 13657, 13658, 13659, 13660, 13661, 13662, 13663, 13664, 13665, 
13666, 13667, 13668, 13669, 13670, 13671, 13672, 13673, 13674, 13675, 
13676, 13677, 13678, 13679, 13680, 13681, 13682, 13683, 13684, 13685, 
13686, 13687, 13688, 13689, 13690, 13691, 13692, 13693, 13694, 13695, 
13696, 13697, 13698, 13699, 13700, 13701, 13702, 13703, 13704, 13705, 
13706, 13707, 13708, 13709, 13710, 13711, 13712, 13713, 13714, 13715, 
13716, 13717, 13718, 13719, 13720, 13721, 13722, 13723, 13724, 13725, 
13726, 13727, 13728, 13729, 13730, 13731, 13732, 13733, 13734, 13735, 
13736, 13737, 13738, 13739, 13740, 13741, 13742, 13743, 13744, 13745, 
13746, 13747, 13748, 13749, 13750, 13751, 13752, 13753, 13754, 13755, 
13756, 13757, 13758, 13759, 13760, 13761, 13762, 13763, 13764, 13765, 
13766, 13767, 13768, 13769, 13770, 13771, 13772, 13773, 13774, 13775, 
13776, 13777, 13778, 13779, 13780, 13781, 13782, 13783, 13784, 13785, 
13786, 13787, 13788, 13789, 13790, 13791, 13792, 13793, 13794, 13795, 
13796, 13797, 13798, 13799, 13800, 13801, 13802, 13803, 13804, 13805, 
13806, 13807, 13808, 13809, 13810, 13811, 13812, 13813, 13814, 13815, 
13816, 13817, 13818, 13819, 13820, 13821, 13822, 13823, 13824, 13825, 
13826, 13827, 13828, 13829, 13830, 13831, 13832, 13833, 13834, 13835, 
13836, 13837, 13838, 13839, 13840, 13841, 13842, 13843, 13844, 13845, 
13846, 13847, 13848, 13849, 13850, 13851, 13852, 13853, 13854, 13855, 
13856, 13857, 13858, 13859, 13860, 13861, 13862, 13863, 13864, 13865, 
13866, 13867, 13868, 13869, 13870, 13871, 13872, 13873, 13874, 13875, 
13876, 13877, 13878, 13879, 13880, 13881, 13882, 13883, 13884, 13885, 
13886, 13887, 13888, 13889, 13890, 13891, 13892, 13893, 13894, 13895, 
13896, 13897, 13898, 13899, 13900, 13901, 13902, 13903, 13904, 13905, 
13906, 13907, 13908, 13909, 13910, 13911, 13912, 13913, 13914, 13915, 
13916, 13917, 13918, 13919, 13920, 13921, 13922, 13923, 13924, 13925, 
13926, 13927, 13928, 13929, 13930, 13931, 13932, 13933, 13934, 13935, 
13936, 13937, 13938, 13939, 13940, 13941, 13942, 13943, 13944, 13945, 
13946, 13947, 13948, 13949, 13950, 13951, 13952, 13953, 13954, 13955, 
13956, 13957, 13958, 13959, 13960, 13961, 13962, 13963, 13964, 13965, 
13966, 13967, 13968, 13969, 13970, 13971, 13972, 13973, 13974, 13975, 
13976, 13977, 13978, 13979, 13980, 13981, 13982, 13983, 13984, 13985, 
13986, 13987, 13988, 13989, 13990, 13991, 13992, 13993, 13994, 13995, 
13996, 13997, 13998, 13999, 14000, 14001, 14002, 14003, 14004, 14005, 
14006, 14007, 14008, 14009, 14010, 14011, 14012, 14013, 14014, 14015, 
14016, 14017, 14018, 14019, 14020, 14021, 14022, 14023, 14024, 14025, 
14026, 14027, 14028, 14029, 14030, 14031, 14032, 14033, 14034, 14035, 
14036, 14037, 14038, 14039, 14040, 14041, 14042, 14043, 14044, 14045, 
14046, 14047, 14048, 14049, 14050, 14051, 14052, 14053, 14054, 14055, 
14056, 14057, 14058, 14059, 14060, 14061, 14062, 14063, 14064, 14065, 
14066, 14067, 14068, 14069, 14070, 14071, 14072, 14073, 14074, 14075, 
14076, 14077, 14078, 14079, 14080, 14081, 14082, 14083, 14084, 14085, 
14086, 14087, 14088, 14089, 14090, 14091, 14092, 14093, 14094, 14095, 
14096, 14097, 14098, 14099, 14100, 14101, 14102, 14103, 14104, 14105, 
14106, 14107, 14108, 14109, 14110, 14111, 14112, 14113, 14114, 14115, 
14116, 14117, 14118, 14119, 14120, 14121, 14122, 14123, 14124, 14125, 
14126, 14127, 14128, 14129, 14130, 14131, 14132, 14133, 14134, 14135, 
14136, 14137, 14138, 14139, 14140, 14141, 14142, 14143, 14144, 14145, 
14146, 14147, 14148, 14149, 14150, 14151, 14152, 14153, 14154, 14155, 
14156, 14157, 14158, 14159, 14160, 14161, 14162, 14163, 14164, 14165, 
14166, 14167, 14168, 14169, 14170, 14171, 14172, 14173, 14174, 14175, 
14176, 14177, 14178, 14179, 14180, 14181, 14182, 14183, 14184, 14185, 
14186, 14187, 14188, 14189, 14190, 14191, 14192, 14193, 14194, 14195, 
14196, 14197, 14198, 14199, 14200, 14201, 14202, 14203, 14204, 14205, 
14206, 14207, 14208, 14209, 14210, 14211, 14212, 14213, 14214, 14215, 
14216, 14217, 14218, 14219, 14220, 14221, 14222, 14223, 14224, 14225, 
14226, 14227, 14228, 14229, 14230, 14231, 14232, 14233, 14234, 14235, 
14236, 14237, 14238, 14239, 14240, 14241, 14242, 14243, 14244, 14245, 
14246, 14247, 14248, 14249, 14250, 14251, 14252, 14253, 14254, 14255, 
14256, 14257, 14258, 14259, 14260, 14261, 14262, 14263, 14264, 14265, 
14266, 14267, 14268, 14269, 14270, 14271, 14272, 14273, 14274, 14275, 
14276, 14277, 14278, 14279, 14280, 14281, 14282, 14283, 14284, 14285, 
14286, 14287, 14288, 14289, 14290, 14291, 14292, 14293, 14294, 14295, 
14296, 14297, 14298, 14299, 14300, 14301, 14302, 14303, 14304, 14305, 
14306, 14307, 14308, 14309, 14310, 14311, 14312, 14313, 14314, 14315, 
14316, 14317, 14318, 14319, 14320, 14321, 14322, 14323, 14324, 14325, 
14326, 14327, 14328, 14329, 14330, 14331, 14332, 14333, 14334, 14335, 
14336, 14337, 14338, 14339, 14340, 14341, 14342, 14343, 14344, 14345, 
14346, 14347, 14348, 14349, 14350, 14351, 14352, 14353, 14354, 14355, 
14356, 14357, 14358, 14359, 14360, 14361, 14362, 14363, 14364, 14365, 
14366, 14367, 14368, 14369, 14370, 14371, 14372, 14373, 14374, 14375, 
14376, 14377, 14378, 14379, 14380, 14381, 14382, 14383, 14384, 14385, 
14386, 14387, 14388, 14389, 14390, 14391, 14392, 14393, 14394, 14395, 
14396, 14397, 14398, 14399, 14400, 14401, 14402, 14403, 14404, 14405, 
14406, 14407, 14408, 14409, 14410, 14411, 14412, 14413, 14414, 14415, 
14416, 14417, 14418, 14419, 14420, 14421, 14422, 14423, 14424, 14425, 
14426, 14427, 14428, 14429, 14430, 14431, 14432, 14433, 14434, 14435, 
14436, 14437, 14438, 14439, 14440, 14441, 14442, 14443, 14444, 14445, 
14446, 14447, 14448, 14449, 14450, 14451, 14452, 14453, 14454, 14455, 
14456, 14457, 14458, 14459, 14460, 14461, 14462, 14463, 14464, 14465, 
14466, 14467, 14468, 14469, 14470, 14471, 14472, 14473, 14474, 14475, 
14476, 14477, 14478, 14479, 14480, 14481, 14482, 14483, 14484, 14485, 
14486, 14487, 14488, 14489, 14490, 14491, 14492, 14493, 14494, 14495, 
14496, 14497, 14498, 14499, 14500, 14501, 14502, 14503, 14504, 14505, 
14506, 14507, 14508, 14509, 14510, 14511, 14512, 14513, 14514, 14515, 
14516, 14517, 14518, 14519, 14520, 14521, 14522, 14523, 14524, 14525, 
14526, 14527, 14528, 14529, 14530, 14531, 14532, 14533, 14534, 14535, 
14536, 14537, 14538, 14539, 14540, 14541, 14542, 14543, 14544, 14545, 
14546, 14547, 14548, 14549, 14550, 14551, 14552, 14553, 14554, 14555, 
14556, 14557, 14558, 14559, 14560, 14561, 14562, 14563, 14564, 14565, 
14566, 14567, 14568, 14569, 14570, 14571, 14572, 14573, 14574, 14575, 
14576, 14577, 14578, 14579, 14580, 14581, 14582, 14583, 14584, 14585, 
14586, 14587, 14588, 14589, 14590, 14591, 14592, 14593, 14594, 14595, 
14596, 14597, 14598, 14599, 14600, 14601, 14602, 14603, 14604, 14605, 
14606, 14607, 14608, 14609, 14610, 14611, 14612, 14613, 14614, 14615, 
14616, 14617, 14618, 14619, 14620, 14621, 14622, 14623, 14624, 14625, 
14626, 14627, 14628, 14629, 14630, 14631, 14632, 14633, 14634, 14635, 
14636, 14637, 14638, 14639, 14640, 14641, 14642, 14643, 14644, 14645, 
14646, 14647, 14648, 14649, 14650, 14651, 14652, 14653, 14654, 14655, 
14656, 14657, 14658, 14659, 14660, 14661, 14662, 14663, 14664, 14665, 
14666, 14667, 14668, 14669, 14670, 14671, 14672, 14673, 14674, 14675, 
14676, 14677, 14678, 14679, 14680, 14681, 14682, 14683, 14684, 14685, 
14686, 14687, 14688, 14689, 14690, 14691, 14692, 14693, 14694, 14695, 
14696, 14697, 14698, 14699, 14700, 14701, 14702, 14703, 14704, 14705, 
14706, 14707, 14708, 14709, 14710, 14711, 14712, 14713, 14714, 14715, 
14716, 14717, 14718, 14719, 14720, 14721, 14722, 14723, 14724, 14725, 
14726, 14727, 14728, 14729, 14730, 14731, 14732, 14733, 14734, 14735, 
14736, 14737, 14738, 14739, 14740, 14741, 14742, 14743, 14744, 14745, 
14746, 14747, 14748, 14749, 14750, 14751, 14752, 14753, 14754, 14755, 
14756, 14757, 14758, 14759, 14760, 14761, 14762, 14763, 14764, 14765, 
14766, 14767, 14768, 14769, 14770, 14771, 14772, 14773, 14774, 14775, 
14776, 14777, 14778, 14779, 14780, 14781, 14782, 14783, 14784, 14785, 
14786, 14787, 14788, 14789, 14790, 14791, 14792, 14793, 14794, 14795, 
14796, 14797, 14798, 14799, 14800, 14801, 14802, 14803, 14804, 14805, 
14806, 14807, 14808, 14809, 14810, 14811, 14812, 14813, 14814, 14815, 
14816, 14817, 14818, 14819, 14820, 14821, 14822, 14823, 14824, 14825, 
14826, 14827, 14828, 14829, 14830, 14831, 14832, 14833, 14834, 14835, 
14836, 14837, 14838, 14839, 14840, 14841, 14842, 14843, 14844, 14845, 
14846, 14847, 14848, 14849, 14850, 14851, 14852, 14853, 14854, 14855, 
14856, 14857, 14858, 14859, 14860, 14861, 14862, 14863, 14864, 14865, 
14866, 14867, 14868, 14869, 14870, 14871, 14872, 14873, 14874, 14875, 
14876, 14877, 14878, 14879, 14880, 14881, 14882, 14883, 14884, 14885, 
14886, 14887, 14888, 14889, 14890, 14891, 14892, 14893, 14894, 14895, 
14896, 14897, 14898, 14899, 14900, 14901, 14902, 14903, 14904, 14905, 
14906, 14907, 14908, 14909, 14910, 14911, 14912, 14913, 14914, 14915, 
14916, 14917, 14918, 14919, 14920, 14921, 14922, 14923, 14924, 14925, 
14926, 14927, 14928, 14929, 14930, 14931, 14932, 14933, 14934, 14935, 
14936, 14937, 14938, 14939, 14940, 14941, 14942, 14943, 14944, 14945, 
14946, 14947, 14948, 14949, 14950, 14951, 14952, 14953, 14954, 14955, 
14956, 14957, 14958, 14959, 14960, 14961, 14962, 14963, 14964, 14965, 
14966, 14967, 14968, 14969, 14970, 14971, 14972, 14973, 14974, 14975, 
14976, 14977, 14978, 14979, 14980, 14981, 14982, 14983, 14984, 14985, 
14986, 14987, 14988, 14989, 14990, 14991, 14992, 14993, 14994, 14995, 
14996, 14997, 14998, 14999, 15000, 15001, 15002, 15003, 15004, 15005, 
15006, 15007, 15008, 15009, 15010, 15011, 15012, 15013, 15014, 15015, 
15016, 15017, 15018, 15019, 15020, 15021, 15022, 15023, 15024, 15025, 
15026, 15027, 15028, 15029, 15030, 15031, 15032, 15033, 15034, 15035, 
15036, 15037, 15038, 15039, 15040, 15041, 15042, 15043, 15044, 15045, 
15046, 15047, 15048, 15049, 15050, 15051, 15052, 15053, 15054, 15055, 
15056, 15057, 15058, 15059, 15060, 15061, 15062, 15063, 15064, 15065, 
15066, 15067, 15068, 15069, 15070, 15071, 15072, 15073, 15074, 15075, 
15076, 15077, 15078, 15079, 15080, 15081, 15082, 15083, 15084, 15085, 
15086, 15087, 15088, 15089, 15090, 15091, 15092, 15093, 15094, 15095, 
15096, 15097, 15098, 15099, 15100, 15101, 15102, 15103, 15104, 15105, 
15106, 15107, 15108, 15109, 15110, 15111, 15112, 15113, 15114, 15115, 
15116, 15117, 15118, 15119, 15120, 15121, 15122, 15123, 15124, 15125, 
15126, 15127, 15128, 15129, 15130, 15131, 15132, 15133, 15134, 15135, 
15136, 15137, 15138, 15139, 15140, 15141, 15142, 15143, 15144, 15145, 
15146, 15147, 15148, 15149, 15150, 15151, 15152, 15153, 15154, 15155, 
15156, 15157, 15158, 15159, 15160, 15161, 15162, 15163, 15164, 15165, 
15166, 15167, 15168, 15169, 15170, 15171, 15172, 15173, 15174, 15175, 
15176, 15177, 15178, 15179, 15180, 15181, 15182, 15183, 15184, 15185, 
15186, 15187, 15188, 15189, 15190, 15191, 15192, 15193, 15194, 15195, 
15196, 15197, 15198, 15199, 15200, 15201, 15202, 15203, 15204, 15205, 
15206, 15207, 15208, 15209, 15210, 15211, 15212, 15213, 15214, 15215, 
15216, 15217, 15218, 15219, 15220, 15221, 15222, 15223, 15224, 15225, 
15226, 15227, 15228, 15229, 15230, 15231, 15232, 15233, 15234, 15235, 
15236, 15237, 15238, 15239, 15240, 15241, 15242, 15243, 15244, 15245, 
15246, 15247, 15248, 15249, 15250, 15251, 15252, 15253, 15254, 15255, 
15256, 15257, 15258, 15259, 15260, 15261, 15262, 15263, 15264, 15265, 
15266, 15267, 15268, 15269, 15270, 15271, 15272, 15273, 15274, 15275, 
15276, 15277, 15278, 15279, 15280, 15281, 15282, 15283, 15284, 15285, 
15286, 15287, 15288, 15289, 15290, 15291, 15292, 15293, 15294, 15295, 
15296, 15297, 15298, 15299, 15300, 15301, 15302, 15303, 15304, 15305, 
15306, 15307, 15308, 15309, 15310, 15311, 15312, 15313, 15314, 15315, 
15316, 15317, 15318, 15319, 15320, 15321, 15322, 15323, 15324, 15325, 
15326, 15327, 15328, 15329, 15330, 15331, 15332, 15333, 15334, 15335, 
15336, 15337, 15338, 15339, 15340, 15341, 15342, 15343, 15344, 15345, 
15346, 15347, 15348, 15349, 15350, 15351, 15352, 15353, 15354, 15355, 
15356, 15357, 15358, 15359, 15360, 15361, 15362, 15363, 15364, 15365, 
15366, 15367, 15368, 15369, 15370, 15371, 15372, 15373, 15374, 15375, 
15376, 15377, 15378, 15379, 15380, 15381, 15382, 15383, 15384, 15385, 
15386, 15387, 15388, 15389, 15390, 15391, 15392, 15393, 15394, 15395, 
15396, 15397, 15398, 15399, 15400, 15401, 15402, 15403, 15404, 15405, 
15406, 15407, 15408, 15409, 15410, 15411, 15412, 15413, 15414, 15415, 
15416, 15417, 15418, 15419, 15420, 15421, 15422, 15423, 15424, 15425, 
15426, 15427, 15428, 15429, 15430, 15431, 15432, 15433, 15434, 15435, 
15436, 15437, 15438, 15439, 15440, 15441, 15442, 15443, 15444, 15445, 
15446, 15447, 15448, 15449, 15450, 15451, 15452, 15453, 15454, 15455, 
15456, 15457, 15458, 15459, 15460, 15461, 15462, 15463, 15464, 15465, 
15466, 15467, 15468, 15469, 15470, 15471, 15472, 15473, 15474, 15475, 
15476, 15477, 15478, 15479, 15480, 15481, 15482, 15483, 15484, 15485, 
15486, 15487, 15488, 15489, 15490, 15491, 15492, 15493, 15494, 15495, 
15496, 15497, 15498, 15499, 15500, 15501, 15502, 15503, 15504, 15505, 
15506, 15507, 15508, 15509, 15510, 15511, 15512, 15513, 15514, 15515, 
15516, 15517, 15518, 15519, 15520, 15521, 15522, 15523, 15524, 15525, 
15526, 15527, 15528, 15529, 15530, 15531, 15532, 15533, 15534, 15535, 
15536, 15537, 15538, 15539, 15540, 15541, 15542, 15543, 15544, 15545, 
15546, 15547, 15548, 15549, 15550, 15551, 15552, 15553, 15554, 15555, 
15556, 15557, 15558, 15559, 15560, 15561, 15562, 15563, 15564, 15565, 
15566, 15567, 15568, 15569, 15570, 15571, 15572, 15573, 15574, 15575, 
15576, 15577, 15578, 15579, 15580, 15581, 15582, 15583, 15584, 15585, 
15586, 15587, 15588, 15589, 15590, 15591, 15592, 15593, 15594, 15595, 
15596, 15597, 15598, 15599, 15600, 15601, 15602, 15603, 15604, 15605, 
15606, 15607, 15608, 15609, 15610, 15611, 15612, 15613, 15614, 15615, 
15616, 15617, 15618, 15619, 15620, 15621, 15622, 15623, 15624, 15625, 
15626, 15627, 15628, 15629, 15630, 15631, 15632, 15633, 15634, 15635, 
15636, 15637, 15638, 15639, 15640, 15641, 15642, 15643, 15644, 15645, 
15646, 15647, 15648, 15649, 15650, 15651, 15652, 15653, 15654, 15655, 
15656, 15657, 15658, 15659, 15660, 15661, 15662, 15663, 15664, 15665, 
15666, 15667, 15668, 15669, 15670, 15671, 15672, 15673, 15674, 15675, 
15676, 15677, 15678, 15679, 15680, 15681, 15682, 15683, 15684, 15685, 
15686, 15687, 15688, 15689, 15690, 15691, 15692, 15693, 15694, 15695, 
15696, 15697, 15698, 15699, 15700, 15701, 15702, 15703, 15704, 15705, 
15706, 15707, 15708, 15709, 15710, 15711, 15712, 15713, 15714, 15715, 
15716, 15717, 15718, 15719, 15720, 15721, 15722, 15723, 15724, 15725, 
15726, 15727, 15728, 15729, 15730, 15731, 15732, 15733, 15734, 15735, 
15736, 15737, 15738, 15739, 15740, 15741, 15742, 15743, 15744, 15745, 
15746, 15747, 15748, 15749, 15750, 15751, 15752, 15753, 15754, 15755, 
15756, 15757, 15758, 15759, 15760, 15761, 15762, 15763, 15764, 15765, 
15766, 15767, 15768, 15769, 15770, 15771, 15772, 15773, 15774, 15775, 
15776, 15777, 15778, 15779, 15780, 15781, 15782, 15783, 15784, 15785, 
15786, 15787, 15788, 15789, 15790, 15791, 15792, 15793, 15794, 15795, 
15796, 15797, 15798, 15799, 15800, 15801, 15802, 15803, 15804, 15805, 
15806, 15807, 15808, 15809, 15810, 15811, 15812, 15813, 15814, 15815, 
15816, 15817, 15818, 15819, 15820, 15821, 15822, 15823, 15824, 15825, 
15826, 15827, 15828, 15829, 15830, 15831, 15832, 15833, 15834, 15835, 
15836, 15837, 15838, 15839, 15840, 15841, 15842, 15843, 15844, 15845, 
15846, 15847, 15848, 15849, 15850, 15851, 15852, 15853, 15854, 15855, 
15856, 15857, 15858, 15859, 15860, 15861, 15862, 15863, 15864, 15865, 
15866, 15867, 15868, 15869, 15870, 15871, 15872, 15873, 15874, 15875, 
15876, 15877, 15878, 15879, 15880, 15881, 15882, 15883, 15884, 15885, 
15886, 15887, 15888, 15889, 15890, 15891, 15892, 15893, 15894, 15895, 
15896, 15897, 15898, 15899, 15900, 15901, 15902, 15903, 15904, 15905, 
15906, 15907, 15908, 15909, 15910, 15911, 15912, 15913, 15914, 15915, 
15916, 15917, 15918, 15919, 15920, 15921, 15922, 15923, 15924, 15925, 
15926, 15927, 15928, 15929, 15930, 15931, 15932, 15933, 15934, 15935, 
15936, 15937, 15938, 15939, 15940, 15941, 15942, 15943, 15944, 15945, 
15946, 15947, 15948, 15949, 15950, 15951, 15952, 15953, 15954, 15955, 
15956, 15957, 15958, 15959, 15960, 15961, 15962, 15963, 15964, 15965, 
15966, 15967, 15968, 15969, 15970, 15971, 15972, 15973, 15974, 15975, 
15976, 15977, 15978, 15979, 15980, 15981, 15982, 15983, 15984, 15985, 
15986, 15987, 15988, 15989, 15990, 15991, 15992, 15993, 15994, 15995, 
15996, 15997, 15998, 15999, 16000, 16001, 16002, 16003, 16004, 16005, 
16006, 16007, 16008, 16009, 16010, 16011, 16012, 16013, 16014, 16015, 
16016, 16017, 16018, 16019, 16020, 16021, 16022, 16023, 16024, 16025, 
16026, 16027, 16028, 16029, 16030, 16031, 16032, 16033, 16034, 16035, 
16036, 16037, 16038, 16039, 16040, 16041, 16042, 16043, 16044, 16045, 
16046, 16047, 16048, 16049, 16050, 16051, 16052, 16053, 16054, 16055, 
16056, 16057, 16058, 16059, 16060, 16061, 16062, 16063, 16064, 16065, 
16066, 16067, 16068, 16069, 16070, 16071, 16072, 16073, 16074, 16075, 
16076, 16077, 16078, 16079, 16080, 16081, 16082, 16083, 16084, 16085, 
16086, 16087, 16088, 16089, 16090, 16091, 16092, 16093, 16094, 16095, 
16096, 16097, 16098, 16099, 16100, 16101, 16102, 16103, 16104, 16105, 
16106, 16107, 16108, 16109, 16110, 16111, 16112, 16113, 16114, 16115, 
16116, 16117, 16118, 16119, 16120, 16121, 16122, 16123, 16124, 16125, 
16126, 16127, 16128, 16129, 16130, 16131, 16132, 16133, 16134, 16135, 
16136, 16137, 16138, 16139, 16140, 16141, 16142, 16143, 16144, 16145, 
16146, 16147, 16148, 16149, 16150, 16151, 16152, 16153, 16154, 16155, 
16156, 16157, 16158, 16159, 16160, 16161, 16162, 16163, 16164, 16165, 
16166, 16167, 16168, 16169, 16170, 16171, 16172, 16173, 16174, 16175, 
16176, 16177, 16178, 16179, 16180, 16181, 16182, 16183, 16184, 16185, 
16186, 16187, 16188, 16189, 16190, 16191, 16192, 16193, 16194, 16195, 
16196, 16197, 16198, 16199, 16200, 16201, 16202, 16203, 16204, 16205, 
16206, 16207, 16208, 16209, 16210, 16211, 16212, 16213, 16214, 16215, 
16216, 16217, 16218, 16219, 16220, 16221, 16222, 16223, 16224, 16225, 
16226, 16227, 16228, 16229, 16230, 16231, 16232, 16233, 16234, 16235, 
16236, 16237, 16238, 16239, 16240, 16241, 16242, 16243, 16244, 16245, 
16246, 16247, 16248, 16249, 16250, 16251, 16252, 16253, 16254, 16255, 
16256, 16257, 16258, 16259, 16260, 16261, 16262, 16263, 16264, 16265, 
16266, 16267, 16268, 16269, 16270, 16271, 16272, 16273, 16274, 16275, 
16276, 16277, 16278, 16279, 16280, 16281, 16282, 16283, 16284, 16285, 
16286, 16287, 16288, 16289, 16290, 16291, 16292, 16293, 16294, 16295, 
16296, 16297, 16298, 16299, 16300, 16301, 16302, 16303, 16304, 16305, 
16306, 16307, 16308, 16309, 16310, 16311, 16312, 16313, 16314, 16315, 
16316, 16317, 16318, 16319, 16320, 16321, 16322, 16323, 16324, 16325, 
16326, 16327, 16328, 16329, 16330, 16331, 16332, 16333, 16334, 16335, 
16336, 16337, 16338, 16339, 16340, 16341, 16342, 16343, 16344, 16345, 
16346, 16347, 16348, 16349, 16350, 16351, 16352, 16353, 16354, 16355, 
16356, 16357, 16358, 16359, 16360, 16361, 16362, 16363, 16364, 16365, 
16366, 16367, 16368, 16369, 16370, 16371, 16372, 16373, 16374, 16375, 
16376, 16377, 16378, 16379, 16380, 16381, 16382, 16383, 16384, 16385, 
16386, 16387, 16388, 16389, 16390, 16391, 16392, 16393, 16394, 16395, 
16396, 16397, 16398, 16399, 16400, 16401, 16402, 16403, 16404, 16405, 
16406, 16407, 16408, 16409, 16410, 16411, 16412, 16413, 16414, 16415, 
16416, 16417, 16418, 16419, 16420, 16421, 16422, 16423, 16424, 16425, 
16426, 16427, 16428, 16429, 16430, 16431, 16432, 16433, 16434, 16435, 
16436, 16437, 16438, 16439, 16440, 16441, 16442, 16443, 16444, 16445, 
16446, 16447, 16448, 16449, 16450, 16451, 16452, 16453, 16454, 16455, 
16456, 16457, 16458, 16459, 16460, 16461, 16462, 16463, 16464, 16465, 
16466, 16467, 16468, 16469, 16470, 16471, 16472, 16473, 16474, 16475, 
16476, 16477, 16478, 16479, 16480, 16481, 16482, 16483, 16484, 16485, 
16486, 16487, 16488, 16489, 16490, 16491, 16492, 16493, 16494, 16495, 
16496, 16497, 16498, 16499, 16500, 16501, 16502, 16503, 16504, 16505, 
16506, 16507, 16508, 16509, 16510, 16511, 16512, 16513, 16514, 16515, 
16516, 16517, 16518, 16519, 16520, 16521, 16522, 16523, 16524, 16525, 
16526, 16527, 16528, 16529, 16530, 16531, 16532, 16533, 16534, 16535, 
16536, 16537, 16538, 16539, 16540, 16541, 16542, 16543, 16544, 16545, 
16546, 16547, 16548, 16549, 16550, 16551, 16552, 16553, 16554, 16555, 
16556, 16557, 16558, 16559, 16560, 16561, 16562, 16563, 16564, 16565, 
16566, 16567, 16568, 16569, 16570, 16571, 16572, 16573, 16574, 16575, 
16576, 16577, 16578, 16579, 16580, 16581, 16582, 16583, 16584, 16585, 
16586, 16587, 16588, 16589, 16590, 16591, 16592, 16593, 16594, 16595, 
16596, 16597, 16598, 16599, 16600, 16601, 16602, 16603, 16604, 16605, 
16606, 16607, 16608, 16609, 16610, 16611, 16612, 16613, 16614, 16615, 
16616, 16617, 16618, 16619, 16620, 16621, 16622, 16623, 16624, 16625, 
16626, 16627, 16628, 16629, 16630, 16631, 16632, 16633, 16634, 16635, 
16636, 16637, 16638, 16639, 16640, 16641, 16642, 16643, 16644, 16645, 
16646, 16647, 16648, 16649, 16650, 16651, 16652, 16653, 16654, 16655, 
16656, 16657, 16658, 16659, 16660, 16661, 16662, 16663, 16664, 16665, 
16666, 16667, 16668, 16669, 16670, 16671, 16672, 16673, 16674, 16675, 
16676, 16677, 16678, 16679, 16680, 16681, 16682, 16683, 16684, 16685, 
16686, 16687, 16688, 16689, 16690, 16691, 16692, 16693, 16694, 16695, 
16696, 16697, 16698, 16699, 16700, 16701, 16702, 16703, 16704, 16705, 
16706, 16707, 16708, 16709, 16710, 16711, 16712, 16713, 16714, 16715, 
16716, 16717, 16718, 16719, 16720, 16721, 16722, 16723, 16724, 16725, 
16726, 16727, 16728, 16729, 16730, 16731, 16732, 16733, 16734, 16735, 
16736, 16737, 16738, 16739, 16740, 16741, 16742, 16743, 16744, 16745, 
16746, 16747, 16748, 16749, 16750, 16751, 16752, 16753, 16754, 16755, 
16756, 16757, 16758, 16759, 16760, 16761, 16762, 16763, 16764, 16765, 
16766, 16767, 16768, 16769, 16770, 16771, 16772, 16773, 16774, 16775, 
16776, 16777, 16778, 16779, 16780, 16781, 16782, 16783, 16784, 16785, 
16786, 16787, 16788, 16789, 16790, 16791, 16792, 16793, 16794, 16795, 
16796, 16797, 16798, 16799, 16800, 16801, 16802, 16803, 16804, 16805, 
16806, 16807, 16808, 16809, 16810, 16811, 16812, 16813, 16814, 16815, 
16816, 16817, 16818, 16819, 16820, 16821, 16822, 16823, 16824, 16825, 
16826, 16827, 16828, 16829, 16830, 16831, 16832, 16833, 16834, 16835, 
16836, 16837, 16838, 16839, 16840, 16841, 16842, 16843, 16844, 16845, 
16846, 16847, 16848, 16849, 16850, 16851, 16852, 16853, 16854, 16855, 
16856, 16857, 16858, 16859, 16860, 16861, 16862, 16863, 16864, 16865, 
16866, 16867, 16868, 16869, 16870, 16871, 16872, 16873, 16874, 16875, 
16876, 16877, 16878, 16879, 16880, 16881, 16882, 16883, 16884, 16885, 
16886, 16887, 16888, 16889, 16890, 16891, 16892, 16893, 16894, 16895, 
16896, 16897, 16898, 16899, 16900, 16901, 16902, 16903, 16904, 16905, 
16906, 16907, 16908, 16909, 16910, 16911, 16912, 16913, 16914, 16915, 
16916, 16917, 16918, 16919, 16920, 16921, 16922, 16923, 16924, 16925, 
16926, 16927, 16928, 16929, 16930, 16931, 16932, 16933, 16934, 16935, 
