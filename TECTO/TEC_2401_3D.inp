69294, 1.2652173913043, 1.0891304347826, 0.13636363636364
69295, 1.2869565217391, 1.1152173913043, 0.13636363636364
69296, 1.2869565217391, 1.0891304347826, 0.11363636363636
69297, 1.2652173913043, 1.0891304347826, 0.090909090909091
69298, 1.2869565217391, 1.1152173913043, 0.090909090909091
69299, 1.2869565217391, 1.0891304347826, 0.068181818181818
69300, 1.2652173913043, 1.0891304347826, 0.045454545454545
69301, 1.2869565217391, 1.1152173913043, 0.045454545454545
69302, 1.2869565217391, 1.0891304347826, 0.022727272727273
69303, 1.3304347826087, 1.0891304347826, 0.47727272727273
69304, 1.3086956521739, 1.0891304347826, 0.45454545454545
69305, 1.3304347826087, 1.1152173913043, 0.45454545454545
69306, 1.3304347826087, 1.0891304347826, 0.43181818181818
69307, 1.3086956521739, 1.0891304347826, 0.40909090909091
69308, 1.3304347826087, 1.1152173913043, 0.40909090909091
69309, 1.3304347826087, 1.0891304347826, 0.38636363636364
69310, 1.3086956521739, 1.0891304347826, 0.36363636363636
69311, 1.3304347826087, 1.1152173913043, 0.36363636363636
69312, 1.3304347826087, 1.0891304347826, 0.34090909090909
69313, 1.3086956521739, 1.0891304347826, 0.31818181818182
69314, 1.3304347826087, 1.1152173913043, 0.31818181818182
69315, 1.3304347826087, 1.0891304347826, 0.29545454545455
69316, 1.3086956521739, 1.0891304347826, 0.27272727272727
69317, 1.3304347826087, 1.1152173913043, 0.27272727272727
69318, 1.3304347826087, 1.0891304347826, 0.25
69319, 1.3086956521739, 1.0891304347826, 0.22727272727273
69320, 1.3304347826087, 1.1152173913043, 0.22727272727273
69321, 1.3304347826087, 1.0891304347826, 0.20454545454545
69322, 1.3086956521739, 1.0891304347826, 0.18181818181818
69323, 1.3304347826087, 1.1152173913043, 0.18181818181818
69324, 1.3304347826087, 1.0891304347826, 0.15909090909091
69325, 1.3086956521739, 1.0891304347826, 0.13636363636364
69326, 1.3304347826087, 1.1152173913043, 0.13636363636364
69327, 1.3304347826087, 1.0891304347826, 0.11363636363636
69328, 1.3086956521739, 1.0891304347826, 0.090909090909091
69329, 1.3304347826087, 1.1152173913043, 0.090909090909091
69330, 1.3304347826087, 1.0891304347826, 0.068181818181818
69331, 1.3086956521739, 1.0891304347826, 0.045454545454545
69332, 1.3304347826087, 1.1152173913043, 0.045454545454545
69333, 1.3304347826087, 1.0891304347826, 0.022727272727273
69334, 1.3739130434783, 1.0891304347826, 0.47727272727273
69335, 1.3521739130435, 1.0891304347826, 0.45454545454545
69336, 1.3739130434783, 1.1152173913043, 0.45454545454545
69337, 1.3739130434783, 1.0891304347826, 0.43181818181818
69338, 1.3521739130435, 1.0891304347826, 0.40909090909091
69339, 1.3739130434783, 1.1152173913043, 0.40909090909091
69340, 1.3739130434783, 1.0891304347826, 0.38636363636364
69341, 1.3521739130435, 1.0891304347826, 0.36363636363636
69342, 1.3739130434783, 1.1152173913043, 0.36363636363636
69343, 1.3739130434783, 1.0891304347826, 0.34090909090909
69344, 1.3521739130435, 1.0891304347826, 0.31818181818182
69345, 1.3739130434783, 1.1152173913043, 0.31818181818182
69346, 1.3739130434783, 1.0891304347826, 0.29545454545455
69347, 1.3521739130435, 1.0891304347826, 0.27272727272727
69348, 1.3739130434783, 1.1152173913043, 0.27272727272727
69349, 1.3739130434783, 1.0891304347826, 0.25
69350, 1.3521739130435, 1.0891304347826, 0.22727272727273
69351, 1.3739130434783, 1.1152173913043, 0.22727272727273
69352, 1.3739130434783, 1.0891304347826, 0.20454545454545
69353, 1.3521739130435, 1.0891304347826, 0.18181818181818
69354, 1.3739130434783, 1.1152173913043, 0.18181818181818
69355, 1.3739130434783, 1.0891304347826, 0.15909090909091
69356, 1.3521739130435, 1.0891304347826, 0.13636363636364
69357, 1.3739130434783, 1.1152173913043, 0.13636363636364
69358, 1.3739130434783, 1.0891304347826, 0.11363636363636
69359, 1.3521739130435, 1.0891304347826, 0.090909090909091
69360, 1.3739130434783, 1.1152173913043, 0.090909090909091
69361, 1.3739130434783, 1.0891304347826, 0.068181818181818
69362, 1.3521739130435, 1.0891304347826, 0.045454545454545
69363, 1.3739130434783, 1.1152173913043, 0.045454545454545
69364, 1.3739130434783, 1.0891304347826, 0.022727272727273
69365, 1.4173913043478, 1.0891304347826, 0.47727272727273
69366, 1.395652173913, 1.0891304347826, 0.45454545454545
69367, 1.4173913043478, 1.1152173913043, 0.45454545454545
69368, 1.4173913043478, 1.0891304347826, 0.43181818181818
69369, 1.395652173913, 1.0891304347826, 0.40909090909091
69370, 1.4173913043478, 1.1152173913043, 0.40909090909091
69371, 1.4173913043478, 1.0891304347826, 0.38636363636364
69372, 1.395652173913, 1.0891304347826, 0.36363636363636
69373, 1.4173913043478, 1.1152173913043, 0.36363636363636
69374, 1.4173913043478, 1.0891304347826, 0.34090909090909
69375, 1.395652173913, 1.0891304347826, 0.31818181818182
69376, 1.4173913043478, 1.1152173913043, 0.31818181818182
69377, 1.4173913043478, 1.0891304347826, 0.29545454545455
69378, 1.395652173913, 1.0891304347826, 0.27272727272727
69379, 1.4173913043478, 1.1152173913043, 0.27272727272727
69380, 1.4173913043478, 1.0891304347826, 0.25
69381, 1.395652173913, 1.0891304347826, 0.22727272727273
69382, 1.4173913043478, 1.1152173913043, 0.22727272727273
69383, 1.4173913043478, 1.0891304347826, 0.20454545454545
69384, 1.395652173913, 1.0891304347826, 0.18181818181818
69385, 1.4173913043478, 1.1152173913043, 0.18181818181818
69386, 1.4173913043478, 1.0891304347826, 0.15909090909091
69387, 1.395652173913, 1.0891304347826, 0.13636363636364
69388, 1.4173913043478, 1.1152173913043, 0.13636363636364
69389, 1.4173913043478, 1.0891304347826, 0.11363636363636
69390, 1.395652173913, 1.0891304347826, 0.090909090909091
69391, 1.4173913043478, 1.1152173913043, 0.090909090909091
69392, 1.4173913043478, 1.0891304347826, 0.068181818181818
69393, 1.395652173913, 1.0891304347826, 0.045454545454545
69394, 1.4173913043478, 1.1152173913043, 0.045454545454545
69395, 1.4173913043478, 1.0891304347826, 0.022727272727273
69396, 1.4608695652174, 1.0891304347826, 0.47727272727273
69397, 1.4391304347826, 1.0891304347826, 0.45454545454545
69398, 1.4608695652174, 1.1152173913043, 0.45454545454545
69399, 1.4608695652174, 1.0891304347826, 0.43181818181818
69400, 1.4391304347826, 1.0891304347826, 0.40909090909091
69401, 1.4608695652174, 1.1152173913043, 0.40909090909091
69402, 1.4608695652174, 1.0891304347826, 0.38636363636364
69403, 1.4391304347826, 1.0891304347826, 0.36363636363636
69404, 1.4608695652174, 1.1152173913043, 0.36363636363636
69405, 1.4608695652174, 1.0891304347826, 0.34090909090909
69406, 1.4391304347826, 1.0891304347826, 0.31818181818182
69407, 1.4608695652174, 1.1152173913043, 0.31818181818182
69408, 1.4608695652174, 1.0891304347826, 0.29545454545455
69409, 1.4391304347826, 1.0891304347826, 0.27272727272727
69410, 1.4608695652174, 1.1152173913043, 0.27272727272727
69411, 1.4608695652174, 1.0891304347826, 0.25
69412, 1.4391304347826, 1.0891304347826, 0.22727272727273
69413, 1.4608695652174, 1.1152173913043, 0.22727272727273
69414, 1.4608695652174, 1.0891304347826, 0.20454545454545
69415, 1.4391304347826, 1.0891304347826, 0.18181818181818
69416, 1.4608695652174, 1.1152173913043, 0.18181818181818
69417, 1.4608695652174, 1.0891304347826, 0.15909090909091
69418, 1.4391304347826, 1.0891304347826, 0.13636363636364
69419, 1.4608695652174, 1.1152173913043, 0.13636363636364
69420, 1.4608695652174, 1.0891304347826, 0.11363636363636
69421, 1.4391304347826, 1.0891304347826, 0.090909090909091
69422, 1.4608695652174, 1.1152173913043, 0.090909090909091
69423, 1.4608695652174, 1.0891304347826, 0.068181818181818
69424, 1.4391304347826, 1.0891304347826, 0.045454545454545
69425, 1.4608695652174, 1.1152173913043, 0.045454545454545
69426, 1.4608695652174, 1.0891304347826, 0.022727272727273
69427, 1.504347826087, 1.0891304347826, 0.47727272727273
69428, 1.4826086956522, 1.0891304347826, 0.45454545454545
69429, 1.504347826087, 1.1152173913043, 0.45454545454545
69430, 1.504347826087, 1.0891304347826, 0.43181818181818
69431, 1.4826086956522, 1.0891304347826, 0.40909090909091
69432, 1.504347826087, 1.1152173913043, 0.40909090909091
69433, 1.504347826087, 1.0891304347826, 0.38636363636364
69434, 1.4826086956522, 1.0891304347826, 0.36363636363636
69435, 1.504347826087, 1.1152173913043, 0.36363636363636
69436, 1.504347826087, 1.0891304347826, 0.34090909090909
69437, 1.4826086956522, 1.0891304347826, 0.31818181818182
69438, 1.504347826087, 1.1152173913043, 0.31818181818182
69439, 1.504347826087, 1.0891304347826, 0.29545454545455
69440, 1.4826086956522, 1.0891304347826, 0.27272727272727
69441, 1.504347826087, 1.1152173913043, 0.27272727272727
69442, 1.504347826087, 1.0891304347826, 0.25
69443, 1.4826086956522, 1.0891304347826, 0.22727272727273
69444, 1.504347826087, 1.1152173913043, 0.22727272727273
69445, 1.504347826087, 1.0891304347826, 0.20454545454545
69446, 1.4826086956522, 1.0891304347826, 0.18181818181818
69447, 1.504347826087, 1.1152173913043, 0.18181818181818
69448, 1.504347826087, 1.0891304347826, 0.15909090909091
69449, 1.4826086956522, 1.0891304347826, 0.13636363636364
69450, 1.504347826087, 1.1152173913043, 0.13636363636364
69451, 1.504347826087, 1.0891304347826, 0.11363636363636
69452, 1.4826086956522, 1.0891304347826, 0.090909090909091
69453, 1.504347826087, 1.1152173913043, 0.090909090909091
69454, 1.504347826087, 1.0891304347826, 0.068181818181818
69455, 1.4826086956522, 1.0891304347826, 0.045454545454545
69456, 1.504347826087, 1.1152173913043, 0.045454545454545
69457, 1.504347826087, 1.0891304347826, 0.022727272727273
69458, 1.5478260869565, 1.0891304347826, 0.47727272727273
69459, 1.5260869565217, 1.0891304347826, 0.45454545454545
69460, 1.5478260869565, 1.1152173913043, 0.45454545454545
69461, 1.5478260869565, 1.0891304347826, 0.43181818181818
69462, 1.5260869565217, 1.0891304347826, 0.40909090909091
69463, 1.5478260869565, 1.1152173913043, 0.40909090909091
69464, 1.5478260869565, 1.0891304347826, 0.38636363636364
69465, 1.5260869565217, 1.0891304347826, 0.36363636363636
69466, 1.5478260869565, 1.1152173913043, 0.36363636363636
69467, 1.5478260869565, 1.0891304347826, 0.34090909090909
69468, 1.5260869565217, 1.0891304347826, 0.31818181818182
69469, 1.5478260869565, 1.1152173913043, 0.31818181818182
69470, 1.5478260869565, 1.0891304347826, 0.29545454545455
69471, 1.5260869565217, 1.0891304347826, 0.27272727272727
69472, 1.5478260869565, 1.1152173913043, 0.27272727272727
69473, 1.5478260869565, 1.0891304347826, 0.25
69474, 1.5260869565217, 1.0891304347826, 0.22727272727273
69475, 1.5478260869565, 1.1152173913043, 0.22727272727273
69476, 1.5478260869565, 1.0891304347826, 0.20454545454545
69477, 1.5260869565217, 1.0891304347826, 0.18181818181818
69478, 1.5478260869565, 1.1152173913043, 0.18181818181818
69479, 1.5478260869565, 1.0891304347826, 0.15909090909091
69480, 1.5260869565217, 1.0891304347826, 0.13636363636364
69481, 1.5478260869565, 1.1152173913043, 0.13636363636364
69482, 1.5478260869565, 1.0891304347826, 0.11363636363636
69483, 1.5260869565217, 1.0891304347826, 0.090909090909091
69484, 1.5478260869565, 1.1152173913043, 0.090909090909091
69485, 1.5478260869565, 1.0891304347826, 0.068181818181818
69486, 1.5260869565217, 1.0891304347826, 0.045454545454545
69487, 1.5478260869565, 1.1152173913043, 0.045454545454545
69488, 1.5478260869565, 1.0891304347826, 0.022727272727273
69489, 1.5913043478261, 1.0891304347826, 0.47727272727273
69490, 1.5695652173913, 1.0891304347826, 0.45454545454545
69491, 1.5913043478261, 1.1152173913043, 0.45454545454545
69492, 1.5913043478261, 1.0891304347826, 0.43181818181818
69493, 1.5695652173913, 1.0891304347826, 0.40909090909091
69494, 1.5913043478261, 1.1152173913043, 0.40909090909091
69495, 1.5913043478261, 1.0891304347826, 0.38636363636364
69496, 1.5695652173913, 1.0891304347826, 0.36363636363636
69497, 1.5913043478261, 1.1152173913043, 0.36363636363636
69498, 1.5913043478261, 1.0891304347826, 0.34090909090909
69499, 1.5695652173913, 1.0891304347826, 0.31818181818182
69500, 1.5913043478261, 1.1152173913043, 0.31818181818182
69501, 1.5913043478261, 1.0891304347826, 0.29545454545455
69502, 1.5695652173913, 1.0891304347826, 0.27272727272727
69503, 1.5913043478261, 1.1152173913043, 0.27272727272727
69504, 1.5913043478261, 1.0891304347826, 0.25
69505, 1.5695652173913, 1.0891304347826, 0.22727272727273
69506, 1.5913043478261, 1.1152173913043, 0.22727272727273
69507, 1.5913043478261, 1.0891304347826, 0.20454545454545
69508, 1.5695652173913, 1.0891304347826, 0.18181818181818
69509, 1.5913043478261, 1.1152173913043, 0.18181818181818
69510, 1.5913043478261, 1.0891304347826, 0.15909090909091
69511, 1.5695652173913, 1.0891304347826, 0.13636363636364
69512, 1.5913043478261, 1.1152173913043, 0.13636363636364
69513, 1.5913043478261, 1.0891304347826, 0.11363636363636
69514, 1.5695652173913, 1.0891304347826, 0.090909090909091
69515, 1.5913043478261, 1.1152173913043, 0.090909090909091
69516, 1.5913043478261, 1.0891304347826, 0.068181818181818
69517, 1.5695652173913, 1.0891304347826, 0.045454545454545
69518, 1.5913043478261, 1.1152173913043, 0.045454545454545
69519, 1.5913043478261, 1.0891304347826, 0.022727272727273
69520, 1.6347826086957, 1.0891304347826, 0.47727272727273
69521, 1.6130434782609, 1.0891304347826, 0.45454545454545
69522, 1.6347826086957, 1.1152173913043, 0.45454545454545
69523, 1.6347826086957, 1.0891304347826, 0.43181818181818
69524, 1.6130434782609, 1.0891304347826, 0.40909090909091
69525, 1.6347826086957, 1.1152173913043, 0.40909090909091
69526, 1.6347826086957, 1.0891304347826, 0.38636363636364
69527, 1.6130434782609, 1.0891304347826, 0.36363636363636
69528, 1.6347826086957, 1.1152173913043, 0.36363636363636
69529, 1.6347826086957, 1.0891304347826, 0.34090909090909
69530, 1.6130434782609, 1.0891304347826, 0.31818181818182
69531, 1.6347826086957, 1.1152173913043, 0.31818181818182
69532, 1.6347826086957, 1.0891304347826, 0.29545454545455
69533, 1.6130434782609, 1.0891304347826, 0.27272727272727
69534, 1.6347826086957, 1.1152173913043, 0.27272727272727
69535, 1.6347826086957, 1.0891304347826, 0.25
69536, 1.6130434782609, 1.0891304347826, 0.22727272727273
69537, 1.6347826086957, 1.1152173913043, 0.22727272727273
69538, 1.6347826086957, 1.0891304347826, 0.20454545454545
69539, 1.6130434782609, 1.0891304347826, 0.18181818181818
69540, 1.6347826086957, 1.1152173913043, 0.18181818181818
69541, 1.6347826086957, 1.0891304347826, 0.15909090909091
69542, 1.6130434782609, 1.0891304347826, 0.13636363636364
69543, 1.6347826086957, 1.1152173913043, 0.13636363636364
69544, 1.6347826086957, 1.0891304347826, 0.11363636363636
69545, 1.6130434782609, 1.0891304347826, 0.090909090909091
69546, 1.6347826086957, 1.1152173913043, 0.090909090909091
69547, 1.6347826086957, 1.0891304347826, 0.068181818181818
69548, 1.6130434782609, 1.0891304347826, 0.045454545454545
69549, 1.6347826086957, 1.1152173913043, 0.045454545454545
69550, 1.6347826086957, 1.0891304347826, 0.022727272727273
69551, 1.6782608695652, 1.0891304347826, 0.47727272727273
69552, 1.6565217391304, 1.0891304347826, 0.45454545454545
69553, 1.6782608695652, 1.1152173913043, 0.45454545454545
69554, 1.6782608695652, 1.0891304347826, 0.43181818181818
69555, 1.6565217391304, 1.0891304347826, 0.40909090909091
69556, 1.6782608695652, 1.1152173913043, 0.40909090909091
69557, 1.6782608695652, 1.0891304347826, 0.38636363636364
69558, 1.6565217391304, 1.0891304347826, 0.36363636363636
69559, 1.6782608695652, 1.1152173913043, 0.36363636363636
69560, 1.6782608695652, 1.0891304347826, 0.34090909090909
69561, 1.6565217391304, 1.0891304347826, 0.31818181818182
69562, 1.6782608695652, 1.1152173913043, 0.31818181818182
69563, 1.6782608695652, 1.0891304347826, 0.29545454545455
69564, 1.6565217391304, 1.0891304347826, 0.27272727272727
69565, 1.6782608695652, 1.1152173913043, 0.27272727272727
69566, 1.6782608695652, 1.0891304347826, 0.25
69567, 1.6565217391304, 1.0891304347826, 0.22727272727273
69568, 1.6782608695652, 1.1152173913043, 0.22727272727273
69569, 1.6782608695652, 1.0891304347826, 0.20454545454545
69570, 1.6565217391304, 1.0891304347826, 0.18181818181818
69571, 1.6782608695652, 1.1152173913043, 0.18181818181818
69572, 1.6782608695652, 1.0891304347826, 0.15909090909091
69573, 1.6565217391304, 1.0891304347826, 0.13636363636364
69574, 1.6782608695652, 1.1152173913043, 0.13636363636364
69575, 1.6782608695652, 1.0891304347826, 0.11363636363636
69576, 1.6565217391304, 1.0891304347826, 0.090909090909091
69577, 1.6782608695652, 1.1152173913043, 0.090909090909091
69578, 1.6782608695652, 1.0891304347826, 0.068181818181818
69579, 1.6565217391304, 1.0891304347826, 0.045454545454545
69580, 1.6782608695652, 1.1152173913043, 0.045454545454545
69581, 1.6782608695652, 1.0891304347826, 0.022727272727273
69582, 1.7217391304348, 1.0891304347826, 0.47727272727273
69583, 1.7, 1.0891304347826, 0.45454545454545
69584, 1.7217391304348, 1.1152173913043, 0.45454545454545
69585, 1.7217391304348, 1.0891304347826, 0.43181818181818
69586, 1.7, 1.0891304347826, 0.40909090909091
69587, 1.7217391304348, 1.1152173913043, 0.40909090909091
69588, 1.7217391304348, 1.0891304347826, 0.38636363636364
69589, 1.7, 1.0891304347826, 0.36363636363636
69590, 1.7217391304348, 1.1152173913043, 0.36363636363636
69591, 1.7217391304348, 1.0891304347826, 0.34090909090909
69592, 1.7, 1.0891304347826, 0.31818181818182
69593, 1.7217391304348, 1.1152173913043, 0.31818181818182
69594, 1.7217391304348, 1.0891304347826, 0.29545454545455
69595, 1.7, 1.0891304347826, 0.27272727272727
69596, 1.7217391304348, 1.1152173913043, 0.27272727272727
69597, 1.7217391304348, 1.0891304347826, 0.25
69598, 1.7, 1.0891304347826, 0.22727272727273
69599, 1.7217391304348, 1.1152173913043, 0.22727272727273
69600, 1.7217391304348, 1.0891304347826, 0.20454545454545
69601, 1.7, 1.0891304347826, 0.18181818181818
69602, 1.7217391304348, 1.1152173913043, 0.18181818181818
69603, 1.7217391304348, 1.0891304347826, 0.15909090909091
69604, 1.7, 1.0891304347826, 0.13636363636364
69605, 1.7217391304348, 1.1152173913043, 0.13636363636364
69606, 1.7217391304348, 1.0891304347826, 0.11363636363636
69607, 1.7, 1.0891304347826, 0.090909090909091
69608, 1.7217391304348, 1.1152173913043, 0.090909090909091
69609, 1.7217391304348, 1.0891304347826, 0.068181818181818
69610, 1.7, 1.0891304347826, 0.045454545454545
69611, 1.7217391304348, 1.1152173913043, 0.045454545454545
69612, 1.7217391304348, 1.0891304347826, 0.022727272727273
69613, 1.7652173913043, 1.0891304347826, 0.47727272727273
69614, 1.7434782608696, 1.0891304347826, 0.45454545454545
69615, 1.7652173913043, 1.1152173913043, 0.45454545454545
69616, 1.7652173913043, 1.0891304347826, 0.43181818181818
69617, 1.7434782608696, 1.0891304347826, 0.40909090909091
69618, 1.7652173913043, 1.1152173913043, 0.40909090909091
69619, 1.7652173913043, 1.0891304347826, 0.38636363636364
69620, 1.7434782608696, 1.0891304347826, 0.36363636363636
69621, 1.7652173913043, 1.1152173913043, 0.36363636363636
69622, 1.7652173913043, 1.0891304347826, 0.34090909090909
69623, 1.7434782608696, 1.0891304347826, 0.31818181818182
69624, 1.7652173913043, 1.1152173913043, 0.31818181818182
69625, 1.7652173913043, 1.0891304347826, 0.29545454545455
69626, 1.7434782608696, 1.0891304347826, 0.27272727272727
69627, 1.7652173913043, 1.1152173913043, 0.27272727272727
69628, 1.7652173913043, 1.0891304347826, 0.25
69629, 1.7434782608696, 1.0891304347826, 0.22727272727273
69630, 1.7652173913043, 1.1152173913043, 0.22727272727273
69631, 1.7652173913043, 1.0891304347826, 0.20454545454545
69632, 1.7434782608696, 1.0891304347826, 0.18181818181818
69633, 1.7652173913043, 1.1152173913043, 0.18181818181818
69634, 1.7652173913043, 1.0891304347826, 0.15909090909091
69635, 1.7434782608696, 1.0891304347826, 0.13636363636364
69636, 1.7652173913043, 1.1152173913043, 0.13636363636364
69637, 1.7652173913043, 1.0891304347826, 0.11363636363636
69638, 1.7434782608696, 1.0891304347826, 0.090909090909091
69639, 1.7652173913043, 1.1152173913043, 0.090909090909091
69640, 1.7652173913043, 1.0891304347826, 0.068181818181818
69641, 1.7434782608696, 1.0891304347826, 0.045454545454545
69642, 1.7652173913043, 1.1152173913043, 0.045454545454545
69643, 1.7652173913043, 1.0891304347826, 0.022727272727273
69644, 1.8086956521739, 1.0891304347826, 0.47727272727273
69645, 1.7869565217391, 1.0891304347826, 0.45454545454545
69646, 1.8086956521739, 1.1152173913043, 0.45454545454545
69647, 1.8086956521739, 1.0891304347826, 0.43181818181818
69648, 1.7869565217391, 1.0891304347826, 0.40909090909091
69649, 1.8086956521739, 1.1152173913043, 0.40909090909091
69650, 1.8086956521739, 1.0891304347826, 0.38636363636364
69651, 1.7869565217391, 1.0891304347826, 0.36363636363636
69652, 1.8086956521739, 1.1152173913043, 0.36363636363636
69653, 1.8086956521739, 1.0891304347826, 0.34090909090909
69654, 1.7869565217391, 1.0891304347826, 0.31818181818182
69655, 1.8086956521739, 1.1152173913043, 0.31818181818182
69656, 1.8086956521739, 1.0891304347826, 0.29545454545455
69657, 1.7869565217391, 1.0891304347826, 0.27272727272727
69658, 1.8086956521739, 1.1152173913043, 0.27272727272727
69659, 1.8086956521739, 1.0891304347826, 0.25
69660, 1.7869565217391, 1.0891304347826, 0.22727272727273
69661, 1.8086956521739, 1.1152173913043, 0.22727272727273
69662, 1.8086956521739, 1.0891304347826, 0.20454545454545
69663, 1.7869565217391, 1.0891304347826, 0.18181818181818
69664, 1.8086956521739, 1.1152173913043, 0.18181818181818
69665, 1.8086956521739, 1.0891304347826, 0.15909090909091
69666, 1.7869565217391, 1.0891304347826, 0.13636363636364
69667, 1.8086956521739, 1.1152173913043, 0.13636363636364
69668, 1.8086956521739, 1.0891304347826, 0.11363636363636
69669, 1.7869565217391, 1.0891304347826, 0.090909090909091
69670, 1.8086956521739, 1.1152173913043, 0.090909090909091
69671, 1.8086956521739, 1.0891304347826, 0.068181818181818
69672, 1.7869565217391, 1.0891304347826, 0.045454545454545
69673, 1.8086956521739, 1.1152173913043, 0.045454545454545
69674, 1.8086956521739, 1.0891304347826, 0.022727272727273
69675, 1.8521739130435, 1.0891304347826, 0.47727272727273
69676, 1.8304347826087, 1.0891304347826, 0.45454545454545
69677, 1.8521739130435, 1.1152173913043, 0.45454545454545
69678, 1.8521739130435, 1.0891304347826, 0.43181818181818
69679, 1.8304347826087, 1.0891304347826, 0.40909090909091
69680, 1.8521739130435, 1.1152173913043, 0.40909090909091
69681, 1.8521739130435, 1.0891304347826, 0.38636363636364
69682, 1.8304347826087, 1.0891304347826, 0.36363636363636
69683, 1.8521739130435, 1.1152173913043, 0.36363636363636
69684, 1.8521739130435, 1.0891304347826, 0.34090909090909
69685, 1.8304347826087, 1.0891304347826, 0.31818181818182
69686, 1.8521739130435, 1.1152173913043, 0.31818181818182
69687, 1.8521739130435, 1.0891304347826, 0.29545454545455
69688, 1.8304347826087, 1.0891304347826, 0.27272727272727
69689, 1.8521739130435, 1.1152173913043, 0.27272727272727
69690, 1.8521739130435, 1.0891304347826, 0.25
69691, 1.8304347826087, 1.0891304347826, 0.22727272727273
69692, 1.8521739130435, 1.1152173913043, 0.22727272727273
69693, 1.8521739130435, 1.0891304347826, 0.20454545454545
69694, 1.8304347826087, 1.0891304347826, 0.18181818181818
69695, 1.8521739130435, 1.1152173913043, 0.18181818181818
69696, 1.8521739130435, 1.0891304347826, 0.15909090909091
69697, 1.8304347826087, 1.0891304347826, 0.13636363636364
69698, 1.8521739130435, 1.1152173913043, 0.13636363636364
69699, 1.8521739130435, 1.0891304347826, 0.11363636363636
69700, 1.8304347826087, 1.0891304347826, 0.090909090909091
69701, 1.8521739130435, 1.1152173913043, 0.090909090909091
69702, 1.8521739130435, 1.0891304347826, 0.068181818181818
69703, 1.8304347826087, 1.0891304347826, 0.045454545454545
69704, 1.8521739130435, 1.1152173913043, 0.045454545454545
69705, 1.8521739130435, 1.0891304347826, 0.022727272727273
69706, 1.895652173913, 1.0891304347826, 0.47727272727273
69707, 1.8739130434783, 1.0891304347826, 0.45454545454545
69708, 1.895652173913, 1.1152173913043, 0.45454545454545
69709, 1.895652173913, 1.0891304347826, 0.43181818181818
69710, 1.8739130434783, 1.0891304347826, 0.40909090909091
69711, 1.895652173913, 1.1152173913043, 0.40909090909091
69712, 1.895652173913, 1.0891304347826, 0.38636363636364
69713, 1.8739130434783, 1.0891304347826, 0.36363636363636
69714, 1.895652173913, 1.1152173913043, 0.36363636363636
69715, 1.895652173913, 1.0891304347826, 0.34090909090909
69716, 1.8739130434783, 1.0891304347826, 0.31818181818182
69717, 1.895652173913, 1.1152173913043, 0.31818181818182
69718, 1.895652173913, 1.0891304347826, 0.29545454545455
69719, 1.8739130434783, 1.0891304347826, 0.27272727272727
69720, 1.895652173913, 1.1152173913043, 0.27272727272727
69721, 1.895652173913, 1.0891304347826, 0.25
69722, 1.8739130434783, 1.0891304347826, 0.22727272727273
69723, 1.895652173913, 1.1152173913043, 0.22727272727273
69724, 1.895652173913, 1.0891304347826, 0.20454545454545
69725, 1.8739130434783, 1.0891304347826, 0.18181818181818
69726, 1.895652173913, 1.1152173913043, 0.18181818181818
69727, 1.895652173913, 1.0891304347826, 0.15909090909091
69728, 1.8739130434783, 1.0891304347826, 0.13636363636364
69729, 1.895652173913, 1.1152173913043, 0.13636363636364
69730, 1.895652173913, 1.0891304347826, 0.11363636363636
69731, 1.8739130434783, 1.0891304347826, 0.090909090909091
69732, 1.895652173913, 1.1152173913043, 0.090909090909091
69733, 1.895652173913, 1.0891304347826, 0.068181818181818
69734, 1.8739130434783, 1.0891304347826, 0.045454545454545
69735, 1.895652173913, 1.1152173913043, 0.045454545454545
69736, 1.895652173913, 1.0891304347826, 0.022727272727273
69737, 1.9391304347826, 1.0891304347826, 0.47727272727273
69738, 1.9173913043478, 1.0891304347826, 0.45454545454545
69739, 1.9391304347826, 1.1152173913043, 0.45454545454545
69740, 1.9391304347826, 1.0891304347826, 0.43181818181818
69741, 1.9173913043478, 1.0891304347826, 0.40909090909091
69742, 1.9391304347826, 1.1152173913043, 0.40909090909091
69743, 1.9391304347826, 1.0891304347826, 0.38636363636364
69744, 1.9173913043478, 1.0891304347826, 0.36363636363636
69745, 1.9391304347826, 1.1152173913043, 0.36363636363636
69746, 1.9391304347826, 1.0891304347826, 0.34090909090909
69747, 1.9173913043478, 1.0891304347826, 0.31818181818182
69748, 1.9391304347826, 1.1152173913043, 0.31818181818182
69749, 1.9391304347826, 1.0891304347826, 0.29545454545455
69750, 1.9173913043478, 1.0891304347826, 0.27272727272727
69751, 1.9391304347826, 1.1152173913043, 0.27272727272727
69752, 1.9391304347826, 1.0891304347826, 0.25
69753, 1.9173913043478, 1.0891304347826, 0.22727272727273
69754, 1.9391304347826, 1.1152173913043, 0.22727272727273
69755, 1.9391304347826, 1.0891304347826, 0.20454545454545
69756, 1.9173913043478, 1.0891304347826, 0.18181818181818
69757, 1.9391304347826, 1.1152173913043, 0.18181818181818
69758, 1.9391304347826, 1.0891304347826, 0.15909090909091
69759, 1.9173913043478, 1.0891304347826, 0.13636363636364
69760, 1.9391304347826, 1.1152173913043, 0.13636363636364
69761, 1.9391304347826, 1.0891304347826, 0.11363636363636
69762, 1.9173913043478, 1.0891304347826, 0.090909090909091
69763, 1.9391304347826, 1.1152173913043, 0.090909090909091
69764, 1.9391304347826, 1.0891304347826, 0.068181818181818
69765, 1.9173913043478, 1.0891304347826, 0.045454545454545
69766, 1.9391304347826, 1.1152173913043, 0.045454545454545
69767, 1.9391304347826, 1.0891304347826, 0.022727272727273
69768, 1.9826086956522, 1.0891304347826, 0.47727272727273
69769, 1.9608695652174, 1.0891304347826, 0.45454545454545
69770, 1.9826086956522, 1.1152173913043, 0.45454545454545
69771, 1.9826086956522, 1.0891304347826, 0.43181818181818
69772, 1.9608695652174, 1.0891304347826, 0.40909090909091
69773, 1.9826086956522, 1.1152173913043, 0.40909090909091
69774, 1.9826086956522, 1.0891304347826, 0.38636363636364
69775, 1.9608695652174, 1.0891304347826, 0.36363636363636
69776, 1.9826086956522, 1.1152173913043, 0.36363636363636
69777, 1.9826086956522, 1.0891304347826, 0.34090909090909
69778, 1.9608695652174, 1.0891304347826, 0.31818181818182
69779, 1.9826086956522, 1.1152173913043, 0.31818181818182
69780, 1.9826086956522, 1.0891304347826, 0.29545454545455
69781, 1.9608695652174, 1.0891304347826, 0.27272727272727
69782, 1.9826086956522, 1.1152173913043, 0.27272727272727
69783, 1.9826086956522, 1.0891304347826, 0.25
69784, 1.9608695652174, 1.0891304347826, 0.22727272727273
69785, 1.9826086956522, 1.1152173913043, 0.22727272727273
69786, 1.9826086956522, 1.0891304347826, 0.20454545454545
69787, 1.9608695652174, 1.0891304347826, 0.18181818181818
69788, 1.9826086956522, 1.1152173913043, 0.18181818181818
69789, 1.9826086956522, 1.0891304347826, 0.15909090909091
69790, 1.9608695652174, 1.0891304347826, 0.13636363636364
69791, 1.9826086956522, 1.1152173913043, 0.13636363636364
69792, 1.9826086956522, 1.0891304347826, 0.11363636363636
69793, 1.9608695652174, 1.0891304347826, 0.090909090909091
69794, 1.9826086956522, 1.1152173913043, 0.090909090909091
69795, 1.9826086956522, 1.0891304347826, 0.068181818181818
69796, 1.9608695652174, 1.0891304347826, 0.045454545454545
69797, 1.9826086956522, 1.1152173913043, 0.045454545454545
69798, 1.9826086956522, 1.0891304347826, 0.022727272727273
69799, 2.0260869565217, 1.0891304347826, 0.47727272727273
69800, 2.004347826087, 1.0891304347826, 0.45454545454545
69801, 2.0260869565217, 1.1152173913043, 0.45454545454545
69802, 2.0260869565217, 1.0891304347826, 0.43181818181818
69803, 2.004347826087, 1.0891304347826, 0.40909090909091
69804, 2.0260869565217, 1.1152173913043, 0.40909090909091
69805, 2.0260869565217, 1.0891304347826, 0.38636363636364
69806, 2.004347826087, 1.0891304347826, 0.36363636363636
69807, 2.0260869565217, 1.1152173913043, 0.36363636363636
69808, 2.0260869565217, 1.0891304347826, 0.34090909090909
69809, 2.004347826087, 1.0891304347826, 0.31818181818182
69810, 2.0260869565217, 1.1152173913043, 0.31818181818182
69811, 2.0260869565217, 1.0891304347826, 0.29545454545455
69812, 2.004347826087, 1.0891304347826, 0.27272727272727
69813, 2.0260869565217, 1.1152173913043, 0.27272727272727
69814, 2.0260869565217, 1.0891304347826, 0.25
69815, 2.004347826087, 1.0891304347826, 0.22727272727273
69816, 2.0260869565217, 1.1152173913043, 0.22727272727273
69817, 2.0260869565217, 1.0891304347826, 0.20454545454545
69818, 2.004347826087, 1.0891304347826, 0.18181818181818
69819, 2.0260869565217, 1.1152173913043, 0.18181818181818
69820, 2.0260869565217, 1.0891304347826, 0.15909090909091
69821, 2.004347826087, 1.0891304347826, 0.13636363636364
69822, 2.0260869565217, 1.1152173913043, 0.13636363636364
69823, 2.0260869565217, 1.0891304347826, 0.11363636363636
69824, 2.004347826087, 1.0891304347826, 0.090909090909091
69825, 2.0260869565217, 1.1152173913043, 0.090909090909091
69826, 2.0260869565217, 1.0891304347826, 0.068181818181818
69827, 2.004347826087, 1.0891304347826, 0.045454545454545
69828, 2.0260869565217, 1.1152173913043, 0.045454545454545
69829, 2.0260869565217, 1.0891304347826, 0.022727272727273
69830, 2.0695652173913, 1.0891304347826, 0.47727272727273
69831, 2.0478260869565, 1.0891304347826, 0.45454545454545
69832, 2.0695652173913, 1.1152173913043, 0.45454545454545
69833, 2.0695652173913, 1.0891304347826, 0.43181818181818
69834, 2.0478260869565, 1.0891304347826, 0.40909090909091
69835, 2.0695652173913, 1.1152173913043, 0.40909090909091
69836, 2.0695652173913, 1.0891304347826, 0.38636363636364
69837, 2.0478260869565, 1.0891304347826, 0.36363636363636
69838, 2.0695652173913, 1.1152173913043, 0.36363636363636
69839, 2.0695652173913, 1.0891304347826, 0.34090909090909
69840, 2.0478260869565, 1.0891304347826, 0.31818181818182
69841, 2.0695652173913, 1.1152173913043, 0.31818181818182
69842, 2.0695652173913, 1.0891304347826, 0.29545454545455
69843, 2.0478260869565, 1.0891304347826, 0.27272727272727
69844, 2.0695652173913, 1.1152173913043, 0.27272727272727
69845, 2.0695652173913, 1.0891304347826, 0.25
69846, 2.0478260869565, 1.0891304347826, 0.22727272727273
69847, 2.0695652173913, 1.1152173913043, 0.22727272727273
69848, 2.0695652173913, 1.0891304347826, 0.20454545454545
69849, 2.0478260869565, 1.0891304347826, 0.18181818181818
69850, 2.0695652173913, 1.1152173913043, 0.18181818181818
69851, 2.0695652173913, 1.0891304347826, 0.15909090909091
69852, 2.0478260869565, 1.0891304347826, 0.13636363636364
69853, 2.0695652173913, 1.1152173913043, 0.13636363636364
69854, 2.0695652173913, 1.0891304347826, 0.11363636363636
69855, 2.0478260869565, 1.0891304347826, 0.090909090909091
69856, 2.0695652173913, 1.1152173913043, 0.090909090909091
69857, 2.0695652173913, 1.0891304347826, 0.068181818181818
69858, 2.0478260869565, 1.0891304347826, 0.045454545454545
69859, 2.0695652173913, 1.1152173913043, 0.045454545454545
69860, 2.0695652173913, 1.0891304347826, 0.022727272727273
69861, 2.1130434782609, 1.0891304347826, 0.47727272727273
69862, 2.0913043478261, 1.0891304347826, 0.45454545454545
69863, 2.1130434782609, 1.1152173913043, 0.45454545454545
69864, 2.1130434782609, 1.0891304347826, 0.43181818181818
69865, 2.0913043478261, 1.0891304347826, 0.40909090909091
69866, 2.1130434782609, 1.1152173913043, 0.40909090909091
69867, 2.1130434782609, 1.0891304347826, 0.38636363636364
69868, 2.0913043478261, 1.0891304347826, 0.36363636363636
69869, 2.1130434782609, 1.1152173913043, 0.36363636363636
69870, 2.1130434782609, 1.0891304347826, 0.34090909090909
69871, 2.0913043478261, 1.0891304347826, 0.31818181818182
69872, 2.1130434782609, 1.1152173913043, 0.31818181818182
69873, 2.1130434782609, 1.0891304347826, 0.29545454545455
69874, 2.0913043478261, 1.0891304347826, 0.27272727272727
69875, 2.1130434782609, 1.1152173913043, 0.27272727272727
69876, 2.1130434782609, 1.0891304347826, 0.25
69877, 2.0913043478261, 1.0891304347826, 0.22727272727273
69878, 2.1130434782609, 1.1152173913043, 0.22727272727273
69879, 2.1130434782609, 1.0891304347826, 0.20454545454545
69880, 2.0913043478261, 1.0891304347826, 0.18181818181818
69881, 2.1130434782609, 1.1152173913043, 0.18181818181818
69882, 2.1130434782609, 1.0891304347826, 0.15909090909091
69883, 2.0913043478261, 1.0891304347826, 0.13636363636364
69884, 2.1130434782609, 1.1152173913043, 0.13636363636364
69885, 2.1130434782609, 1.0891304347826, 0.11363636363636
69886, 2.0913043478261, 1.0891304347826, 0.090909090909091
69887, 2.1130434782609, 1.1152173913043, 0.090909090909091
69888, 2.1130434782609, 1.0891304347826, 0.068181818181818
69889, 2.0913043478261, 1.0891304347826, 0.045454545454545
69890, 2.1130434782609, 1.1152173913043, 0.045454545454545
69891, 2.1130434782609, 1.0891304347826, 0.022727272727273
69892, 2.1565217391304, 1.0891304347826, 0.47727272727273
69893, 2.1347826086957, 1.0891304347826, 0.45454545454545
69894, 2.1565217391304, 1.1152173913043, 0.45454545454545
69895, 2.1565217391304, 1.0891304347826, 0.43181818181818
69896, 2.1347826086957, 1.0891304347826, 0.40909090909091
69897, 2.1565217391304, 1.1152173913043, 0.40909090909091
69898, 2.1565217391304, 1.0891304347826, 0.38636363636364
69899, 2.1347826086957, 1.0891304347826, 0.36363636363636
69900, 2.1565217391304, 1.1152173913043, 0.36363636363636
69901, 2.1565217391304, 1.0891304347826, 0.34090909090909
69902, 2.1347826086957, 1.0891304347826, 0.31818181818182
69903, 2.1565217391304, 1.1152173913043, 0.31818181818182
69904, 2.1565217391304, 1.0891304347826, 0.29545454545455
69905, 2.1347826086957, 1.0891304347826, 0.27272727272727
69906, 2.1565217391304, 1.1152173913043, 0.27272727272727
69907, 2.1565217391304, 1.0891304347826, 0.25
69908, 2.1347826086957, 1.0891304347826, 0.22727272727273
69909, 2.1565217391304, 1.1152173913043, 0.22727272727273
69910, 2.1565217391304, 1.0891304347826, 0.20454545454545
69911, 2.1347826086957, 1.0891304347826, 0.18181818181818
69912, 2.1565217391304, 1.1152173913043, 0.18181818181818
69913, 2.1565217391304, 1.0891304347826, 0.15909090909091
69914, 2.1347826086957, 1.0891304347826, 0.13636363636364
69915, 2.1565217391304, 1.1152173913043, 0.13636363636364
69916, 2.1565217391304, 1.0891304347826, 0.11363636363636
69917, 2.1347826086957, 1.0891304347826, 0.090909090909091
69918, 2.1565217391304, 1.1152173913043, 0.090909090909091
69919, 2.1565217391304, 1.0891304347826, 0.068181818181818
69920, 2.1347826086957, 1.0891304347826, 0.045454545454545
69921, 2.1565217391304, 1.1152173913043, 0.045454545454545
69922, 2.1565217391304, 1.0891304347826, 0.022727272727273
69923, 2.1782608695652, 1.0891304347826, 0.45454545454545
69924, 2.1782608695652, 1.0891304347826, 0.40909090909091
69925, 2.1782608695652, 1.0891304347826, 0.36363636363636
69926, 2.1782608695652, 1.0891304347826, 0.31818181818182
69927, 2.1782608695652, 1.0891304347826, 0.27272727272727
69928, 2.1782608695652, 1.0891304347826, 0.22727272727273
69929, 2.1782608695652, 1.0891304347826, 0.18181818181818
69930, 2.1782608695652, 1.0891304347826, 0.13636363636364
69931, 2.1782608695652, 1.0891304347826, 0.090909090909091
69932, 2.1782608695652, 1.0891304347826, 0.045454545454545
69933, 1.2434782608696, 1.0369565217391, 0.47727272727273
69934, 1.2217391304348, 1.0369565217391, 0.45454545454545
69935, 1.2434782608696, 1.0630434782609, 0.45454545454545
69936, 1.2434782608696, 1.0369565217391, 0.43181818181818
69937, 1.2217391304348, 1.0369565217391, 0.40909090909091
69938, 1.2434782608696, 1.0630434782609, 0.40909090909091
69939, 1.2434782608696, 1.0369565217391, 0.38636363636364
69940, 1.2217391304348, 1.0369565217391, 0.36363636363636
69941, 1.2434782608696, 1.0630434782609, 0.36363636363636
69942, 1.2434782608696, 1.0369565217391, 0.34090909090909
69943, 1.2217391304348, 1.0369565217391, 0.31818181818182
69944, 1.2434782608696, 1.0630434782609, 0.31818181818182
69945, 1.2434782608696, 1.0369565217391, 0.29545454545455
69946, 1.2217391304348, 1.0369565217391, 0.27272727272727
69947, 1.2434782608696, 1.0630434782609, 0.27272727272727
69948, 1.2434782608696, 1.0369565217391, 0.25
69949, 1.2217391304348, 1.0369565217391, 0.22727272727273
69950, 1.2434782608696, 1.0630434782609, 0.22727272727273
69951, 1.2434782608696, 1.0369565217391, 0.20454545454545
69952, 1.2217391304348, 1.0369565217391, 0.18181818181818
69953, 1.2434782608696, 1.0630434782609, 0.18181818181818
69954, 1.2434782608696, 1.0369565217391, 0.15909090909091
69955, 1.2217391304348, 1.0369565217391, 0.13636363636364
69956, 1.2434782608696, 1.0630434782609, 0.13636363636364
69957, 1.2434782608696, 1.0369565217391, 0.11363636363636
69958, 1.2217391304348, 1.0369565217391, 0.090909090909091
69959, 1.2434782608696, 1.0630434782609, 0.090909090909091
69960, 1.2434782608696, 1.0369565217391, 0.068181818181818
69961, 1.2217391304348, 1.0369565217391, 0.045454545454545
69962, 1.2434782608696, 1.0630434782609, 0.045454545454545
69963, 1.2434782608696, 1.0369565217391, 0.022727272727273
69964, 1.2869565217391, 1.0369565217391, 0.47727272727273
69965, 1.2652173913043, 1.0369565217391, 0.45454545454545
69966, 1.2869565217391, 1.0630434782609, 0.45454545454545
69967, 1.2869565217391, 1.0369565217391, 0.43181818181818
69968, 1.2652173913043, 1.0369565217391, 0.40909090909091
69969, 1.2869565217391, 1.0630434782609, 0.40909090909091
69970, 1.2869565217391, 1.0369565217391, 0.38636363636364
69971, 1.2652173913043, 1.0369565217391, 0.36363636363636
69972, 1.2869565217391, 1.0630434782609, 0.36363636363636
69973, 1.2869565217391, 1.0369565217391, 0.34090909090909
69974, 1.2652173913043, 1.0369565217391, 0.31818181818182
69975, 1.2869565217391, 1.0630434782609, 0.31818181818182
69976, 1.2869565217391, 1.0369565217391, 0.29545454545455
69977, 1.2652173913043, 1.0369565217391, 0.27272727272727
69978, 1.2869565217391, 1.0630434782609, 0.27272727272727
69979, 1.2869565217391, 1.0369565217391, 0.25
69980, 1.2652173913043, 1.0369565217391, 0.22727272727273
69981, 1.2869565217391, 1.0630434782609, 0.22727272727273
69982, 1.2869565217391, 1.0369565217391, 0.20454545454545
69983, 1.2652173913043, 1.0369565217391, 0.18181818181818
69984, 1.2869565217391, 1.0630434782609, 0.18181818181818
69985, 1.2869565217391, 1.0369565217391, 0.15909090909091
69986, 1.2652173913043, 1.0369565217391, 0.13636363636364
69987, 1.2869565217391, 1.0630434782609, 0.13636363636364
69988, 1.2869565217391, 1.0369565217391, 0.11363636363636
69989, 1.2652173913043, 1.0369565217391, 0.090909090909091
69990, 1.2869565217391, 1.0630434782609, 0.090909090909091
69991, 1.2869565217391, 1.0369565217391, 0.068181818181818
69992, 1.2652173913043, 1.0369565217391, 0.045454545454545
69993, 1.2869565217391, 1.0630434782609, 0.045454545454545
69994, 1.2869565217391, 1.0369565217391, 0.022727272727273
69995, 1.3304347826087, 1.0369565217391, 0.47727272727273
69996, 1.3086956521739, 1.0369565217391, 0.45454545454545
69997, 1.3304347826087, 1.0630434782609, 0.45454545454545
69998, 1.3304347826087, 1.0369565217391, 0.43181818181818
69999, 1.3086956521739, 1.0369565217391, 0.40909090909091
70000, 1.3304347826087, 1.0630434782609, 0.40909090909091
70001, 1.3304347826087, 1.0369565217391, 0.38636363636364
70002, 1.3086956521739, 1.0369565217391, 0.36363636363636
70003, 1.3304347826087, 1.0630434782609, 0.36363636363636
70004, 1.3304347826087, 1.0369565217391, 0.34090909090909
70005, 1.3086956521739, 1.0369565217391, 0.31818181818182
70006, 1.3304347826087, 1.0630434782609, 0.31818181818182
70007, 1.3304347826087, 1.0369565217391, 0.29545454545455
70008, 1.3086956521739, 1.0369565217391, 0.27272727272727
70009, 1.3304347826087, 1.0630434782609, 0.27272727272727
70010, 1.3304347826087, 1.0369565217391, 0.25
70011, 1.3086956521739, 1.0369565217391, 0.22727272727273
70012, 1.3304347826087, 1.0630434782609, 0.22727272727273
70013, 1.3304347826087, 1.0369565217391, 0.20454545454545
70014, 1.3086956521739, 1.0369565217391, 0.18181818181818
70015, 1.3304347826087, 1.0630434782609, 0.18181818181818
70016, 1.3304347826087, 1.0369565217391, 0.15909090909091
70017, 1.3086956521739, 1.0369565217391, 0.13636363636364
70018, 1.3304347826087, 1.0630434782609, 0.13636363636364
70019, 1.3304347826087, 1.0369565217391, 0.11363636363636
70020, 1.3086956521739, 1.0369565217391, 0.090909090909091
70021, 1.3304347826087, 1.0630434782609, 0.090909090909091
70022, 1.3304347826087, 1.0369565217391, 0.068181818181818
70023, 1.3086956521739, 1.0369565217391, 0.045454545454545
70024, 1.3304347826087, 1.0630434782609, 0.045454545454545
70025, 1.3304347826087, 1.0369565217391, 0.022727272727273
70026, 1.3739130434783, 1.0369565217391, 0.47727272727273
70027, 1.3521739130435, 1.0369565217391, 0.45454545454545
70028, 1.3739130434783, 1.0630434782609, 0.45454545454545
70029, 1.3739130434783, 1.0369565217391, 0.43181818181818
70030, 1.3521739130435, 1.0369565217391, 0.40909090909091
70031, 1.3739130434783, 1.0630434782609, 0.40909090909091
70032, 1.3739130434783, 1.0369565217391, 0.38636363636364
70033, 1.3521739130435, 1.0369565217391, 0.36363636363636
70034, 1.3739130434783, 1.0630434782609, 0.36363636363636
70035, 1.3739130434783, 1.0369565217391, 0.34090909090909
70036, 1.3521739130435, 1.0369565217391, 0.31818181818182
70037, 1.3739130434783, 1.0630434782609, 0.31818181818182
70038, 1.3739130434783, 1.0369565217391, 0.29545454545455
70039, 1.3521739130435, 1.0369565217391, 0.27272727272727
70040, 1.3739130434783, 1.0630434782609, 0.27272727272727
70041, 1.3739130434783, 1.0369565217391, 0.25
70042, 1.3521739130435, 1.0369565217391, 0.22727272727273
70043, 1.3739130434783, 1.0630434782609, 0.22727272727273
70044, 1.3739130434783, 1.0369565217391, 0.20454545454545
70045, 1.3521739130435, 1.0369565217391, 0.18181818181818
70046, 1.3739130434783, 1.0630434782609, 0.18181818181818
70047, 1.3739130434783, 1.0369565217391, 0.15909090909091
70048, 1.3521739130435, 1.0369565217391, 0.13636363636364
70049, 1.3739130434783, 1.0630434782609, 0.13636363636364
70050, 1.3739130434783, 1.0369565217391, 0.11363636363636
70051, 1.3521739130435, 1.0369565217391, 0.090909090909091
70052, 1.3739130434783, 1.0630434782609, 0.090909090909091
70053, 1.3739130434783, 1.0369565217391, 0.068181818181818
70054, 1.3521739130435, 1.0369565217391, 0.045454545454545
70055, 1.3739130434783, 1.0630434782609, 0.045454545454545
70056, 1.3739130434783, 1.0369565217391, 0.022727272727273
70057, 1.4173913043478, 1.0369565217391, 0.47727272727273
70058, 1.395652173913, 1.0369565217391, 0.45454545454545
70059, 1.4173913043478, 1.0630434782609, 0.45454545454545
70060, 1.4173913043478, 1.0369565217391, 0.43181818181818
70061, 1.395652173913, 1.0369565217391, 0.40909090909091
70062, 1.4173913043478, 1.0630434782609, 0.40909090909091
70063, 1.4173913043478, 1.0369565217391, 0.38636363636364
70064, 1.395652173913, 1.0369565217391, 0.36363636363636
70065, 1.4173913043478, 1.0630434782609, 0.36363636363636
70066, 1.4173913043478, 1.0369565217391, 0.34090909090909
70067, 1.395652173913, 1.0369565217391, 0.31818181818182
70068, 1.4173913043478, 1.0630434782609, 0.31818181818182
70069, 1.4173913043478, 1.0369565217391, 0.29545454545455
70070, 1.395652173913, 1.0369565217391, 0.27272727272727
70071, 1.4173913043478, 1.0630434782609, 0.27272727272727
70072, 1.4173913043478, 1.0369565217391, 0.25
70073, 1.395652173913, 1.0369565217391, 0.22727272727273
70074, 1.4173913043478, 1.0630434782609, 0.22727272727273
70075, 1.4173913043478, 1.0369565217391, 0.20454545454545
70076, 1.395652173913, 1.0369565217391, 0.18181818181818
70077, 1.4173913043478, 1.0630434782609, 0.18181818181818
70078, 1.4173913043478, 1.0369565217391, 0.15909090909091
70079, 1.395652173913, 1.0369565217391, 0.13636363636364
70080, 1.4173913043478, 1.0630434782609, 0.13636363636364
70081, 1.4173913043478, 1.0369565217391, 0.11363636363636
70082, 1.395652173913, 1.0369565217391, 0.090909090909091
70083, 1.4173913043478, 1.0630434782609, 0.090909090909091
70084, 1.4173913043478, 1.0369565217391, 0.068181818181818
70085, 1.395652173913, 1.0369565217391, 0.045454545454545
70086, 1.4173913043478, 1.0630434782609, 0.045454545454545
70087, 1.4173913043478, 1.0369565217391, 0.022727272727273
70088, 1.4608695652174, 1.0369565217391, 0.47727272727273
70089, 1.4391304347826, 1.0369565217391, 0.45454545454545
70090, 1.4608695652174, 1.0630434782609, 0.45454545454545
70091, 1.4608695652174, 1.0369565217391, 0.43181818181818
70092, 1.4391304347826, 1.0369565217391, 0.40909090909091
70093, 1.4608695652174, 1.0630434782609, 0.40909090909091
70094, 1.4608695652174, 1.0369565217391, 0.38636363636364
70095, 1.4391304347826, 1.0369565217391, 0.36363636363636
70096, 1.4608695652174, 1.0630434782609, 0.36363636363636
70097, 1.4608695652174, 1.0369565217391, 0.34090909090909
70098, 1.4391304347826, 1.0369565217391, 0.31818181818182
70099, 1.4608695652174, 1.0630434782609, 0.31818181818182
70100, 1.4608695652174, 1.0369565217391, 0.29545454545455
70101, 1.4391304347826, 1.0369565217391, 0.27272727272727
70102, 1.4608695652174, 1.0630434782609, 0.27272727272727
70103, 1.4608695652174, 1.0369565217391, 0.25
70104, 1.4391304347826, 1.0369565217391, 0.22727272727273
70105, 1.4608695652174, 1.0630434782609, 0.22727272727273
70106, 1.4608695652174, 1.0369565217391, 0.20454545454545
70107, 1.4391304347826, 1.0369565217391, 0.18181818181818
70108, 1.4608695652174, 1.0630434782609, 0.18181818181818
70109, 1.4608695652174, 1.0369565217391, 0.15909090909091
70110, 1.4391304347826, 1.0369565217391, 0.13636363636364
70111, 1.4608695652174, 1.0630434782609, 0.13636363636364
70112, 1.4608695652174, 1.0369565217391, 0.11363636363636
70113, 1.4391304347826, 1.0369565217391, 0.090909090909091
70114, 1.4608695652174, 1.0630434782609, 0.090909090909091
70115, 1.4608695652174, 1.0369565217391, 0.068181818181818
70116, 1.4391304347826, 1.0369565217391, 0.045454545454545
70117, 1.4608695652174, 1.0630434782609, 0.045454545454545
70118, 1.4608695652174, 1.0369565217391, 0.022727272727273
70119, 1.504347826087, 1.0369565217391, 0.47727272727273
70120, 1.4826086956522, 1.0369565217391, 0.45454545454545
70121, 1.504347826087, 1.0630434782609, 0.45454545454545
70122, 1.504347826087, 1.0369565217391, 0.43181818181818
70123, 1.4826086956522, 1.0369565217391, 0.40909090909091
70124, 1.504347826087, 1.0630434782609, 0.40909090909091
70125, 1.504347826087, 1.0369565217391, 0.38636363636364
70126, 1.4826086956522, 1.0369565217391, 0.36363636363636
70127, 1.504347826087, 1.0630434782609, 0.36363636363636
70128, 1.504347826087, 1.0369565217391, 0.34090909090909
70129, 1.4826086956522, 1.0369565217391, 0.31818181818182
70130, 1.504347826087, 1.0630434782609, 0.31818181818182
70131, 1.504347826087, 1.0369565217391, 0.29545454545455
70132, 1.4826086956522, 1.0369565217391, 0.27272727272727
70133, 1.504347826087, 1.0630434782609, 0.27272727272727
70134, 1.504347826087, 1.0369565217391, 0.25
70135, 1.4826086956522, 1.0369565217391, 0.22727272727273
70136, 1.504347826087, 1.0630434782609, 0.22727272727273
70137, 1.504347826087, 1.0369565217391, 0.20454545454545
70138, 1.4826086956522, 1.0369565217391, 0.18181818181818
70139, 1.504347826087, 1.0630434782609, 0.18181818181818
70140, 1.504347826087, 1.0369565217391, 0.15909090909091
70141, 1.4826086956522, 1.0369565217391, 0.13636363636364
70142, 1.504347826087, 1.0630434782609, 0.13636363636364
70143, 1.504347826087, 1.0369565217391, 0.11363636363636
70144, 1.4826086956522, 1.0369565217391, 0.090909090909091
70145, 1.504347826087, 1.0630434782609, 0.090909090909091
70146, 1.504347826087, 1.0369565217391, 0.068181818181818
70147, 1.4826086956522, 1.0369565217391, 0.045454545454545
70148, 1.504347826087, 1.0630434782609, 0.045454545454545
70149, 1.504347826087, 1.0369565217391, 0.022727272727273
70150, 1.5478260869565, 1.0369565217391, 0.47727272727273
70151, 1.5260869565217, 1.0369565217391, 0.45454545454545
70152, 1.5478260869565, 1.0630434782609, 0.45454545454545
70153, 1.5478260869565, 1.0369565217391, 0.43181818181818
70154, 1.5260869565217, 1.0369565217391, 0.40909090909091
70155, 1.5478260869565, 1.0630434782609, 0.40909090909091
70156, 1.5478260869565, 1.0369565217391, 0.38636363636364
70157, 1.5260869565217, 1.0369565217391, 0.36363636363636
70158, 1.5478260869565, 1.0630434782609, 0.36363636363636
70159, 1.5478260869565, 1.0369565217391, 0.34090909090909
70160, 1.5260869565217, 1.0369565217391, 0.31818181818182
70161, 1.5478260869565, 1.0630434782609, 0.31818181818182
70162, 1.5478260869565, 1.0369565217391, 0.29545454545455
70163, 1.5260869565217, 1.0369565217391, 0.27272727272727
70164, 1.5478260869565, 1.0630434782609, 0.27272727272727
70165, 1.5478260869565, 1.0369565217391, 0.25
70166, 1.5260869565217, 1.0369565217391, 0.22727272727273
70167, 1.5478260869565, 1.0630434782609, 0.22727272727273
70168, 1.5478260869565, 1.0369565217391, 0.20454545454545
70169, 1.5260869565217, 1.0369565217391, 0.18181818181818
70170, 1.5478260869565, 1.0630434782609, 0.18181818181818
70171, 1.5478260869565, 1.0369565217391, 0.15909090909091
70172, 1.5260869565217, 1.0369565217391, 0.13636363636364
70173, 1.5478260869565, 1.0630434782609, 0.13636363636364
70174, 1.5478260869565, 1.0369565217391, 0.11363636363636
70175, 1.5260869565217, 1.0369565217391, 0.090909090909091
70176, 1.5478260869565, 1.0630434782609, 0.090909090909091
70177, 1.5478260869565, 1.0369565217391, 0.068181818181818
70178, 1.5260869565217, 1.0369565217391, 0.045454545454545
70179, 1.5478260869565, 1.0630434782609, 0.045454545454545
70180, 1.5478260869565, 1.0369565217391, 0.022727272727273
70181, 1.5913043478261, 1.0369565217391, 0.47727272727273
70182, 1.5695652173913, 1.0369565217391, 0.45454545454545
70183, 1.5913043478261, 1.0630434782609, 0.45454545454545
70184, 1.5913043478261, 1.0369565217391, 0.43181818181818
70185, 1.5695652173913, 1.0369565217391, 0.40909090909091
70186, 1.5913043478261, 1.0630434782609, 0.40909090909091
70187, 1.5913043478261, 1.0369565217391, 0.38636363636364
70188, 1.5695652173913, 1.0369565217391, 0.36363636363636
70189, 1.5913043478261, 1.0630434782609, 0.36363636363636
70190, 1.5913043478261, 1.0369565217391, 0.34090909090909
70191, 1.5695652173913, 1.0369565217391, 0.31818181818182
70192, 1.5913043478261, 1.0630434782609, 0.31818181818182
70193, 1.5913043478261, 1.0369565217391, 0.29545454545455
70194, 1.5695652173913, 1.0369565217391, 0.27272727272727
70195, 1.5913043478261, 1.0630434782609, 0.27272727272727
70196, 1.5913043478261, 1.0369565217391, 0.25
70197, 1.5695652173913, 1.0369565217391, 0.22727272727273
70198, 1.5913043478261, 1.0630434782609, 0.22727272727273
70199, 1.5913043478261, 1.0369565217391, 0.20454545454545
70200, 1.5695652173913, 1.0369565217391, 0.18181818181818
70201, 1.5913043478261, 1.0630434782609, 0.18181818181818
70202, 1.5913043478261, 1.0369565217391, 0.15909090909091
70203, 1.5695652173913, 1.0369565217391, 0.13636363636364
70204, 1.5913043478261, 1.0630434782609, 0.13636363636364
70205, 1.5913043478261, 1.0369565217391, 0.11363636363636
70206, 1.5695652173913, 1.0369565217391, 0.090909090909091
70207, 1.5913043478261, 1.0630434782609, 0.090909090909091
70208, 1.5913043478261, 1.0369565217391, 0.068181818181818
70209, 1.5695652173913, 1.0369565217391, 0.045454545454545
70210, 1.5913043478261, 1.0630434782609, 0.045454545454545
70211, 1.5913043478261, 1.0369565217391, 0.022727272727273
70212, 1.6347826086957, 1.0369565217391, 0.47727272727273
70213, 1.6130434782609, 1.0369565217391, 0.45454545454545
70214, 1.6347826086957, 1.0630434782609, 0.45454545454545
70215, 1.6347826086957, 1.0369565217391, 0.43181818181818
70216, 1.6130434782609, 1.0369565217391, 0.40909090909091
70217, 1.6347826086957, 1.0630434782609, 0.40909090909091
70218, 1.6347826086957, 1.0369565217391, 0.38636363636364
70219, 1.6130434782609, 1.0369565217391, 0.36363636363636
70220, 1.6347826086957, 1.0630434782609, 0.36363636363636
70221, 1.6347826086957, 1.0369565217391, 0.34090909090909
70222, 1.6130434782609, 1.0369565217391, 0.31818181818182
70223, 1.6347826086957, 1.0630434782609, 0.31818181818182
70224, 1.6347826086957, 1.0369565217391, 0.29545454545455
70225, 1.6130434782609, 1.0369565217391, 0.27272727272727
70226, 1.6347826086957, 1.0630434782609, 0.27272727272727
70227, 1.6347826086957, 1.0369565217391, 0.25
70228, 1.6130434782609, 1.0369565217391, 0.22727272727273
70229, 1.6347826086957, 1.0630434782609, 0.22727272727273
70230, 1.6347826086957, 1.0369565217391, 0.20454545454545
70231, 1.6130434782609, 1.0369565217391, 0.18181818181818
70232, 1.6347826086957, 1.0630434782609, 0.18181818181818
70233, 1.6347826086957, 1.0369565217391, 0.15909090909091
70234, 1.6130434782609, 1.0369565217391, 0.13636363636364
70235, 1.6347826086957, 1.0630434782609, 0.13636363636364
70236, 1.6347826086957, 1.0369565217391, 0.11363636363636
70237, 1.6130434782609, 1.0369565217391, 0.090909090909091
70238, 1.6347826086957, 1.0630434782609, 0.090909090909091
70239, 1.6347826086957, 1.0369565217391, 0.068181818181818
70240, 1.6130434782609, 1.0369565217391, 0.045454545454545
70241, 1.6347826086957, 1.0630434782609, 0.045454545454545
70242, 1.6347826086957, 1.0369565217391, 0.022727272727273
70243, 1.6782608695652, 1.0369565217391, 0.47727272727273
70244, 1.6565217391304, 1.0369565217391, 0.45454545454545
70245, 1.6782608695652, 1.0630434782609, 0.45454545454545
70246, 1.6782608695652, 1.0369565217391, 0.43181818181818
70247, 1.6565217391304, 1.0369565217391, 0.40909090909091
70248, 1.6782608695652, 1.0630434782609, 0.40909090909091
70249, 1.6782608695652, 1.0369565217391, 0.38636363636364
70250, 1.6565217391304, 1.0369565217391, 0.36363636363636
70251, 1.6782608695652, 1.0630434782609, 0.36363636363636
70252, 1.6782608695652, 1.0369565217391, 0.34090909090909
70253, 1.6565217391304, 1.0369565217391, 0.31818181818182
70254, 1.6782608695652, 1.0630434782609, 0.31818181818182
70255, 1.6782608695652, 1.0369565217391, 0.29545454545455
70256, 1.6565217391304, 1.0369565217391, 0.27272727272727
70257, 1.6782608695652, 1.0630434782609, 0.27272727272727
70258, 1.6782608695652, 1.0369565217391, 0.25
70259, 1.6565217391304, 1.0369565217391, 0.22727272727273
70260, 1.6782608695652, 1.0630434782609, 0.22727272727273
70261, 1.6782608695652, 1.0369565217391, 0.20454545454545
70262, 1.6565217391304, 1.0369565217391, 0.18181818181818
70263, 1.6782608695652, 1.0630434782609, 0.18181818181818
70264, 1.6782608695652, 1.0369565217391, 0.15909090909091
70265, 1.6565217391304, 1.0369565217391, 0.13636363636364
70266, 1.6782608695652, 1.0630434782609, 0.13636363636364
70267, 1.6782608695652, 1.0369565217391, 0.11363636363636
70268, 1.6565217391304, 1.0369565217391, 0.090909090909091
70269, 1.6782608695652, 1.0630434782609, 0.090909090909091
70270, 1.6782608695652, 1.0369565217391, 0.068181818181818
70271, 1.6565217391304, 1.0369565217391, 0.045454545454545
70272, 1.6782608695652, 1.0630434782609, 0.045454545454545
70273, 1.6782608695652, 1.0369565217391, 0.022727272727273
70274, 1.7217391304348, 1.0369565217391, 0.47727272727273
70275, 1.7, 1.0369565217391, 0.45454545454545
70276, 1.7217391304348, 1.0630434782609, 0.45454545454545
70277, 1.7217391304348, 1.0369565217391, 0.43181818181818
70278, 1.7, 1.0369565217391, 0.40909090909091
70279, 1.7217391304348, 1.0630434782609, 0.40909090909091
70280, 1.7217391304348, 1.0369565217391, 0.38636363636364
70281, 1.7, 1.0369565217391, 0.36363636363636
70282, 1.7217391304348, 1.0630434782609, 0.36363636363636
70283, 1.7217391304348, 1.0369565217391, 0.34090909090909
70284, 1.7, 1.0369565217391, 0.31818181818182
70285, 1.7217391304348, 1.0630434782609, 0.31818181818182
70286, 1.7217391304348, 1.0369565217391, 0.29545454545455
70287, 1.7, 1.0369565217391, 0.27272727272727
70288, 1.7217391304348, 1.0630434782609, 0.27272727272727
70289, 1.7217391304348, 1.0369565217391, 0.25
70290, 1.7, 1.0369565217391, 0.22727272727273
70291, 1.7217391304348, 1.0630434782609, 0.22727272727273
70292, 1.7217391304348, 1.0369565217391, 0.20454545454545
70293, 1.7, 1.0369565217391, 0.18181818181818
70294, 1.7217391304348, 1.0630434782609, 0.18181818181818
70295, 1.7217391304348, 1.0369565217391, 0.15909090909091
70296, 1.7, 1.0369565217391, 0.13636363636364
70297, 1.7217391304348, 1.0630434782609, 0.13636363636364
70298, 1.7217391304348, 1.0369565217391, 0.11363636363636
70299, 1.7, 1.0369565217391, 0.090909090909091
70300, 1.7217391304348, 1.0630434782609, 0.090909090909091
70301, 1.7217391304348, 1.0369565217391, 0.068181818181818
70302, 1.7, 1.0369565217391, 0.045454545454545
70303, 1.7217391304348, 1.0630434782609, 0.045454545454545
70304, 1.7217391304348, 1.0369565217391, 0.022727272727273
70305, 1.7652173913043, 1.0369565217391, 0.47727272727273
70306, 1.7434782608696, 1.0369565217391, 0.45454545454545
70307, 1.7652173913043, 1.0630434782609, 0.45454545454545
70308, 1.7652173913043, 1.0369565217391, 0.43181818181818
70309, 1.7434782608696, 1.0369565217391, 0.40909090909091
70310, 1.7652173913043, 1.0630434782609, 0.40909090909091
70311, 1.7652173913043, 1.0369565217391, 0.38636363636364
70312, 1.7434782608696, 1.0369565217391, 0.36363636363636
70313, 1.7652173913043, 1.0630434782609, 0.36363636363636
70314, 1.7652173913043, 1.0369565217391, 0.34090909090909
70315, 1.7434782608696, 1.0369565217391, 0.31818181818182
70316, 1.7652173913043, 1.0630434782609, 0.31818181818182
70317, 1.7652173913043, 1.0369565217391, 0.29545454545455
70318, 1.7434782608696, 1.0369565217391, 0.27272727272727
70319, 1.7652173913043, 1.0630434782609, 0.27272727272727
70320, 1.7652173913043, 1.0369565217391, 0.25
70321, 1.7434782608696, 1.0369565217391, 0.22727272727273
70322, 1.7652173913043, 1.0630434782609, 0.22727272727273
70323, 1.7652173913043, 1.0369565217391, 0.20454545454545
70324, 1.7434782608696, 1.0369565217391, 0.18181818181818
70325, 1.7652173913043, 1.0630434782609, 0.18181818181818
70326, 1.7652173913043, 1.0369565217391, 0.15909090909091
70327, 1.7434782608696, 1.0369565217391, 0.13636363636364
70328, 1.7652173913043, 1.0630434782609, 0.13636363636364
70329, 1.7652173913043, 1.0369565217391, 0.11363636363636
70330, 1.7434782608696, 1.0369565217391, 0.090909090909091
70331, 1.7652173913043, 1.0630434782609, 0.090909090909091
70332, 1.7652173913043, 1.0369565217391, 0.068181818181818
70333, 1.7434782608696, 1.0369565217391, 0.045454545454545
70334, 1.7652173913043, 1.0630434782609, 0.045454545454545
70335, 1.7652173913043, 1.0369565217391, 0.022727272727273
70336, 1.8086956521739, 1.0369565217391, 0.47727272727273
70337, 1.7869565217391, 1.0369565217391, 0.45454545454545
70338, 1.8086956521739, 1.0630434782609, 0.45454545454545
70339, 1.8086956521739, 1.0369565217391, 0.43181818181818
70340, 1.7869565217391, 1.0369565217391, 0.40909090909091
70341, 1.8086956521739, 1.0630434782609, 0.40909090909091
70342, 1.8086956521739, 1.0369565217391, 0.38636363636364
70343, 1.7869565217391, 1.0369565217391, 0.36363636363636
70344, 1.8086956521739, 1.0630434782609, 0.36363636363636
70345, 1.8086956521739, 1.0369565217391, 0.34090909090909
70346, 1.7869565217391, 1.0369565217391, 0.31818181818182
70347, 1.8086956521739, 1.0630434782609, 0.31818181818182
70348, 1.8086956521739, 1.0369565217391, 0.29545454545455
70349, 1.7869565217391, 1.0369565217391, 0.27272727272727
70350, 1.8086956521739, 1.0630434782609, 0.27272727272727
70351, 1.8086956521739, 1.0369565217391, 0.25
70352, 1.7869565217391, 1.0369565217391, 0.22727272727273
70353, 1.8086956521739, 1.0630434782609, 0.22727272727273
70354, 1.8086956521739, 1.0369565217391, 0.20454545454545
70355, 1.7869565217391, 1.0369565217391, 0.18181818181818
70356, 1.8086956521739, 1.0630434782609, 0.18181818181818
70357, 1.8086956521739, 1.0369565217391, 0.15909090909091
70358, 1.7869565217391, 1.0369565217391, 0.13636363636364
70359, 1.8086956521739, 1.0630434782609, 0.13636363636364
70360, 1.8086956521739, 1.0369565217391, 0.11363636363636
70361, 1.7869565217391, 1.0369565217391, 0.090909090909091
70362, 1.8086956521739, 1.0630434782609, 0.090909090909091
70363, 1.8086956521739, 1.0369565217391, 0.068181818181818
70364, 1.7869565217391, 1.0369565217391, 0.045454545454545
70365, 1.8086956521739, 1.0630434782609, 0.045454545454545
70366, 1.8086956521739, 1.0369565217391, 0.022727272727273
70367, 1.8521739130435, 1.0369565217391, 0.47727272727273
70368, 1.8304347826087, 1.0369565217391, 0.45454545454545
70369, 1.8521739130435, 1.0630434782609, 0.45454545454545
70370, 1.8521739130435, 1.0369565217391, 0.43181818181818
70371, 1.8304347826087, 1.0369565217391, 0.40909090909091
70372, 1.8521739130435, 1.0630434782609, 0.40909090909091
70373, 1.8521739130435, 1.0369565217391, 0.38636363636364
70374, 1.8304347826087, 1.0369565217391, 0.36363636363636
70375, 1.8521739130435, 1.0630434782609, 0.36363636363636
70376, 1.8521739130435, 1.0369565217391, 0.34090909090909
70377, 1.8304347826087, 1.0369565217391, 0.31818181818182
70378, 1.8521739130435, 1.0630434782609, 0.31818181818182
70379, 1.8521739130435, 1.0369565217391, 0.29545454545455
70380, 1.8304347826087, 1.0369565217391, 0.27272727272727
70381, 1.8521739130435, 1.0630434782609, 0.27272727272727
70382, 1.8521739130435, 1.0369565217391, 0.25
70383, 1.8304347826087, 1.0369565217391, 0.22727272727273
70384, 1.8521739130435, 1.0630434782609, 0.22727272727273
70385, 1.8521739130435, 1.0369565217391, 0.20454545454545
70386, 1.8304347826087, 1.0369565217391, 0.18181818181818
70387, 1.8521739130435, 1.0630434782609, 0.18181818181818
70388, 1.8521739130435, 1.0369565217391, 0.15909090909091
70389, 1.8304347826087, 1.0369565217391, 0.13636363636364
70390, 1.8521739130435, 1.0630434782609, 0.13636363636364
70391, 1.8521739130435, 1.0369565217391, 0.11363636363636
70392, 1.8304347826087, 1.0369565217391, 0.090909090909091
70393, 1.8521739130435, 1.0630434782609, 0.090909090909091
70394, 1.8521739130435, 1.0369565217391, 0.068181818181818
70395, 1.8304347826087, 1.0369565217391, 0.045454545454545
70396, 1.8521739130435, 1.0630434782609, 0.045454545454545
70397, 1.8521739130435, 1.0369565217391, 0.022727272727273
70398, 1.895652173913, 1.0369565217391, 0.47727272727273
70399, 1.8739130434783, 1.0369565217391, 0.45454545454545
70400, 1.895652173913, 1.0630434782609, 0.45454545454545
70401, 1.895652173913, 1.0369565217391, 0.43181818181818
70402, 1.8739130434783, 1.0369565217391, 0.40909090909091
70403, 1.895652173913, 1.0630434782609, 0.40909090909091
70404, 1.895652173913, 1.0369565217391, 0.38636363636364
70405, 1.8739130434783, 1.0369565217391, 0.36363636363636
70406, 1.895652173913, 1.0630434782609, 0.36363636363636
70407, 1.895652173913, 1.0369565217391, 0.34090909090909
70408, 1.8739130434783, 1.0369565217391, 0.31818181818182
70409, 1.895652173913, 1.0630434782609, 0.31818181818182
70410, 1.895652173913, 1.0369565217391, 0.29545454545455
70411, 1.8739130434783, 1.0369565217391, 0.27272727272727
70412, 1.895652173913, 1.0630434782609, 0.27272727272727
70413, 1.895652173913, 1.0369565217391, 0.25
70414, 1.8739130434783, 1.0369565217391, 0.22727272727273
70415, 1.895652173913, 1.0630434782609, 0.22727272727273
70416, 1.895652173913, 1.0369565217391, 0.20454545454545
70417, 1.8739130434783, 1.0369565217391, 0.18181818181818
70418, 1.895652173913, 1.0630434782609, 0.18181818181818
70419, 1.895652173913, 1.0369565217391, 0.15909090909091
70420, 1.8739130434783, 1.0369565217391, 0.13636363636364
70421, 1.895652173913, 1.0630434782609, 0.13636363636364
70422, 1.895652173913, 1.0369565217391, 0.11363636363636
70423, 1.8739130434783, 1.0369565217391, 0.090909090909091
70424, 1.895652173913, 1.0630434782609, 0.090909090909091
70425, 1.895652173913, 1.0369565217391, 0.068181818181818
70426, 1.8739130434783, 1.0369565217391, 0.045454545454545
70427, 1.895652173913, 1.0630434782609, 0.045454545454545
70428, 1.895652173913, 1.0369565217391, 0.022727272727273
70429, 1.9391304347826, 1.0369565217391, 0.47727272727273
70430, 1.9173913043478, 1.0369565217391, 0.45454545454545
70431, 1.9391304347826, 1.0630434782609, 0.45454545454545
70432, 1.9391304347826, 1.0369565217391, 0.43181818181818
70433, 1.9173913043478, 1.0369565217391, 0.40909090909091
70434, 1.9391304347826, 1.0630434782609, 0.40909090909091
70435, 1.9391304347826, 1.0369565217391, 0.38636363636364
70436, 1.9173913043478, 1.0369565217391, 0.36363636363636
70437, 1.9391304347826, 1.0630434782609, 0.36363636363636
70438, 1.9391304347826, 1.0369565217391, 0.34090909090909
70439, 1.9173913043478, 1.0369565217391, 0.31818181818182
70440, 1.9391304347826, 1.0630434782609, 0.31818181818182
70441, 1.9391304347826, 1.0369565217391, 0.29545454545455
70442, 1.9173913043478, 1.0369565217391, 0.27272727272727
70443, 1.9391304347826, 1.0630434782609, 0.27272727272727
70444, 1.9391304347826, 1.0369565217391, 0.25
70445, 1.9173913043478, 1.0369565217391, 0.22727272727273
70446, 1.9391304347826, 1.0630434782609, 0.22727272727273
70447, 1.9391304347826, 1.0369565217391, 0.20454545454545
70448, 1.9173913043478, 1.0369565217391, 0.18181818181818
70449, 1.9391304347826, 1.0630434782609, 0.18181818181818
70450, 1.9391304347826, 1.0369565217391, 0.15909090909091
70451, 1.9173913043478, 1.0369565217391, 0.13636363636364
70452, 1.9391304347826, 1.0630434782609, 0.13636363636364
70453, 1.9391304347826, 1.0369565217391, 0.11363636363636
70454, 1.9173913043478, 1.0369565217391, 0.090909090909091
70455, 1.9391304347826, 1.0630434782609, 0.090909090909091
70456, 1.9391304347826, 1.0369565217391, 0.068181818181818
70457, 1.9173913043478, 1.0369565217391, 0.045454545454545
70458, 1.9391304347826, 1.0630434782609, 0.045454545454545
70459, 1.9391304347826, 1.0369565217391, 0.022727272727273
70460, 1.9826086956522, 1.0369565217391, 0.47727272727273
70461, 1.9608695652174, 1.0369565217391, 0.45454545454545
70462, 1.9826086956522, 1.0630434782609, 0.45454545454545
70463, 1.9826086956522, 1.0369565217391, 0.43181818181818
70464, 1.9608695652174, 1.0369565217391, 0.40909090909091
70465, 1.9826086956522, 1.0630434782609, 0.40909090909091
70466, 1.9826086956522, 1.0369565217391, 0.38636363636364
70467, 1.9608695652174, 1.0369565217391, 0.36363636363636
70468, 1.9826086956522, 1.0630434782609, 0.36363636363636
70469, 1.9826086956522, 1.0369565217391, 0.34090909090909
70470, 1.9608695652174, 1.0369565217391, 0.31818181818182
70471, 1.9826086956522, 1.0630434782609, 0.31818181818182
70472, 1.9826086956522, 1.0369565217391, 0.29545454545455
70473, 1.9608695652174, 1.0369565217391, 0.27272727272727
70474, 1.9826086956522, 1.0630434782609, 0.27272727272727
70475, 1.9826086956522, 1.0369565217391, 0.25
70476, 1.9608695652174, 1.0369565217391, 0.22727272727273
70477, 1.9826086956522, 1.0630434782609, 0.22727272727273
70478, 1.9826086956522, 1.0369565217391, 0.20454545454545
70479, 1.9608695652174, 1.0369565217391, 0.18181818181818
70480, 1.9826086956522, 1.0630434782609, 0.18181818181818
70481, 1.9826086956522, 1.0369565217391, 0.15909090909091
70482, 1.9608695652174, 1.0369565217391, 0.13636363636364
70483, 1.9826086956522, 1.0630434782609, 0.13636363636364
70484, 1.9826086956522, 1.0369565217391, 0.11363636363636
70485, 1.9608695652174, 1.0369565217391, 0.090909090909091
70486, 1.9826086956522, 1.0630434782609, 0.090909090909091
70487, 1.9826086956522, 1.0369565217391, 0.068181818181818
70488, 1.9608695652174, 1.0369565217391, 0.045454545454545
70489, 1.9826086956522, 1.0630434782609, 0.045454545454545
70490, 1.9826086956522, 1.0369565217391, 0.022727272727273
70491, 2.0260869565217, 1.0369565217391, 0.47727272727273
70492, 2.004347826087, 1.0369565217391, 0.45454545454545
70493, 2.0260869565217, 1.0630434782609, 0.45454545454545
70494, 2.0260869565217, 1.0369565217391, 0.43181818181818
70495, 2.004347826087, 1.0369565217391, 0.40909090909091
70496, 2.0260869565217, 1.0630434782609, 0.40909090909091
70497, 2.0260869565217, 1.0369565217391, 0.38636363636364
70498, 2.004347826087, 1.0369565217391, 0.36363636363636
70499, 2.0260869565217, 1.0630434782609, 0.36363636363636
70500, 2.0260869565217, 1.0369565217391, 0.34090909090909
70501, 2.004347826087, 1.0369565217391, 0.31818181818182
70502, 2.0260869565217, 1.0630434782609, 0.31818181818182
70503, 2.0260869565217, 1.0369565217391, 0.29545454545455
70504, 2.004347826087, 1.0369565217391, 0.27272727272727
70505, 2.0260869565217, 1.0630434782609, 0.27272727272727
70506, 2.0260869565217, 1.0369565217391, 0.25
70507, 2.004347826087, 1.0369565217391, 0.22727272727273
70508, 2.0260869565217, 1.0630434782609, 0.22727272727273
70509, 2.0260869565217, 1.0369565217391, 0.20454545454545
70510, 2.004347826087, 1.0369565217391, 0.18181818181818
70511, 2.0260869565217, 1.0630434782609, 0.18181818181818
70512, 2.0260869565217, 1.0369565217391, 0.15909090909091
70513, 2.004347826087, 1.0369565217391, 0.13636363636364
70514, 2.0260869565217, 1.0630434782609, 0.13636363636364
70515, 2.0260869565217, 1.0369565217391, 0.11363636363636
70516, 2.004347826087, 1.0369565217391, 0.090909090909091
70517, 2.0260869565217, 1.0630434782609, 0.090909090909091
70518, 2.0260869565217, 1.0369565217391, 0.068181818181818
70519, 2.004347826087, 1.0369565217391, 0.045454545454545
70520, 2.0260869565217, 1.0630434782609, 0.045454545454545
70521, 2.0260869565217, 1.0369565217391, 0.022727272727273
70522, 2.0695652173913, 1.0369565217391, 0.47727272727273
70523, 2.0478260869565, 1.0369565217391, 0.45454545454545
70524, 2.0695652173913, 1.0630434782609, 0.45454545454545
70525, 2.0695652173913, 1.0369565217391, 0.43181818181818
70526, 2.0478260869565, 1.0369565217391, 0.40909090909091
70527, 2.0695652173913, 1.0630434782609, 0.40909090909091
70528, 2.0695652173913, 1.0369565217391, 0.38636363636364
70529, 2.0478260869565, 1.0369565217391, 0.36363636363636
70530, 2.0695652173913, 1.0630434782609, 0.36363636363636
70531, 2.0695652173913, 1.0369565217391, 0.34090909090909
70532, 2.0478260869565, 1.0369565217391, 0.31818181818182
70533, 2.0695652173913, 1.0630434782609, 0.31818181818182
70534, 2.0695652173913, 1.0369565217391, 0.29545454545455
70535, 2.0478260869565, 1.0369565217391, 0.27272727272727
70536, 2.0695652173913, 1.0630434782609, 0.27272727272727
70537, 2.0695652173913, 1.0369565217391, 0.25
70538, 2.0478260869565, 1.0369565217391, 0.22727272727273
70539, 2.0695652173913, 1.0630434782609, 0.22727272727273
70540, 2.0695652173913, 1.0369565217391, 0.20454545454545
70541, 2.0478260869565, 1.0369565217391, 0.18181818181818
70542, 2.0695652173913, 1.0630434782609, 0.18181818181818
70543, 2.0695652173913, 1.0369565217391, 0.15909090909091
70544, 2.0478260869565, 1.0369565217391, 0.13636363636364
70545, 2.0695652173913, 1.0630434782609, 0.13636363636364
70546, 2.0695652173913, 1.0369565217391, 0.11363636363636
70547, 2.0478260869565, 1.0369565217391, 0.090909090909091
70548, 2.0695652173913, 1.0630434782609, 0.090909090909091
70549, 2.0695652173913, 1.0369565217391, 0.068181818181818
70550, 2.0478260869565, 1.0369565217391, 0.045454545454545
70551, 2.0695652173913, 1.0630434782609, 0.045454545454545
70552, 2.0695652173913, 1.0369565217391, 0.022727272727273
70553, 2.1130434782609, 1.0369565217391, 0.47727272727273
70554, 2.0913043478261, 1.0369565217391, 0.45454545454545
70555, 2.1130434782609, 1.0630434782609, 0.45454545454545
70556, 2.1130434782609, 1.0369565217391, 0.43181818181818
70557, 2.0913043478261, 1.0369565217391, 0.40909090909091
70558, 2.1130434782609, 1.0630434782609, 0.40909090909091
70559, 2.1130434782609, 1.0369565217391, 0.38636363636364
70560, 2.0913043478261, 1.0369565217391, 0.36363636363636
70561, 2.1130434782609, 1.0630434782609, 0.36363636363636
70562, 2.1130434782609, 1.0369565217391, 0.34090909090909
70563, 2.0913043478261, 1.0369565217391, 0.31818181818182
70564, 2.1130434782609, 1.0630434782609, 0.31818181818182
70565, 2.1130434782609, 1.0369565217391, 0.29545454545455
70566, 2.0913043478261, 1.0369565217391, 0.27272727272727
70567, 2.1130434782609, 1.0630434782609, 0.27272727272727
70568, 2.1130434782609, 1.0369565217391, 0.25
70569, 2.0913043478261, 1.0369565217391, 0.22727272727273
70570, 2.1130434782609, 1.0630434782609, 0.22727272727273
70571, 2.1130434782609, 1.0369565217391, 0.20454545454545
70572, 2.0913043478261, 1.0369565217391, 0.18181818181818
70573, 2.1130434782609, 1.0630434782609, 0.18181818181818
70574, 2.1130434782609, 1.0369565217391, 0.15909090909091
70575, 2.0913043478261, 1.0369565217391, 0.13636363636364
70576, 2.1130434782609, 1.0630434782609, 0.13636363636364
70577, 2.1130434782609, 1.0369565217391, 0.11363636363636
70578, 2.0913043478261, 1.0369565217391, 0.090909090909091
70579, 2.1130434782609, 1.0630434782609, 0.090909090909091
70580, 2.1130434782609, 1.0369565217391, 0.068181818181818
70581, 2.0913043478261, 1.0369565217391, 0.045454545454545
70582, 2.1130434782609, 1.0630434782609, 0.045454545454545
70583, 2.1130434782609, 1.0369565217391, 0.022727272727273
70584, 2.1565217391304, 1.0369565217391, 0.47727272727273
70585, 2.1347826086957, 1.0369565217391, 0.45454545454545
70586, 2.1565217391304, 1.0630434782609, 0.45454545454545
70587, 2.1565217391304, 1.0369565217391, 0.43181818181818
70588, 2.1347826086957, 1.0369565217391, 0.40909090909091
70589, 2.1565217391304, 1.0630434782609, 0.40909090909091
70590, 2.1565217391304, 1.0369565217391, 0.38636363636364
70591, 2.1347826086957, 1.0369565217391, 0.36363636363636
70592, 2.1565217391304, 1.0630434782609, 0.36363636363636
70593, 2.1565217391304, 1.0369565217391, 0.34090909090909
70594, 2.1347826086957, 1.0369565217391, 0.31818181818182
70595, 2.1565217391304, 1.0630434782609, 0.31818181818182
70596, 2.1565217391304, 1.0369565217391, 0.29545454545455
70597, 2.1347826086957, 1.0369565217391, 0.27272727272727
70598, 2.1565217391304, 1.0630434782609, 0.27272727272727
70599, 2.1565217391304, 1.0369565217391, 0.25
70600, 2.1347826086957, 1.0369565217391, 0.22727272727273
70601, 2.1565217391304, 1.0630434782609, 0.22727272727273
70602, 2.1565217391304, 1.0369565217391, 0.20454545454545
70603, 2.1347826086957, 1.0369565217391, 0.18181818181818
70604, 2.1565217391304, 1.0630434782609, 0.18181818181818
70605, 2.1565217391304, 1.0369565217391, 0.15909090909091
70606, 2.1347826086957, 1.0369565217391, 0.13636363636364
70607, 2.1565217391304, 1.0630434782609, 0.13636363636364
70608, 2.1565217391304, 1.0369565217391, 0.11363636363636
70609, 2.1347826086957, 1.0369565217391, 0.090909090909091
70610, 2.1565217391304, 1.0630434782609, 0.090909090909091
70611, 2.1565217391304, 1.0369565217391, 0.068181818181818
70612, 2.1347826086957, 1.0369565217391, 0.045454545454545
70613, 2.1565217391304, 1.0630434782609, 0.045454545454545
70614, 2.1565217391304, 1.0369565217391, 0.022727272727273
70615, 2.1782608695652, 1.0369565217391, 0.45454545454545
70616, 2.1782608695652, 1.0369565217391, 0.40909090909091
70617, 2.1782608695652, 1.0369565217391, 0.36363636363636
70618, 2.1782608695652, 1.0369565217391, 0.31818181818182
70619, 2.1782608695652, 1.0369565217391, 0.27272727272727
70620, 2.1782608695652, 1.0369565217391, 0.22727272727273
70621, 2.1782608695652, 1.0369565217391, 0.18181818181818
70622, 2.1782608695652, 1.0369565217391, 0.13636363636364
70623, 2.1782608695652, 1.0369565217391, 0.090909090909091
70624, 2.1782608695652, 1.0369565217391, 0.045454545454545
70625, 1.2434782608696, 0.98478260869565, 0.47727272727273
70626, 1.2217391304348, 0.98478260869565, 0.45454545454545
70627, 1.2434782608696, 1.0108695652174, 0.45454545454545
70628, 1.2434782608696, 0.98478260869565, 0.43181818181818
70629, 1.2217391304348, 0.98478260869565, 0.40909090909091
70630, 1.2434782608696, 1.0108695652174, 0.40909090909091
70631, 1.2434782608696, 0.98478260869565, 0.38636363636364
70632, 1.2217391304348, 0.98478260869565, 0.36363636363636
70633, 1.2434782608696, 1.0108695652174, 0.36363636363636
70634, 1.2434782608696, 0.98478260869565, 0.34090909090909
70635, 1.2217391304348, 0.98478260869565, 0.31818181818182
70636, 1.2434782608696, 1.0108695652174, 0.31818181818182
70637, 1.2434782608696, 0.98478260869565, 0.29545454545455
70638, 1.2217391304348, 0.98478260869565, 0.27272727272727
70639, 1.2434782608696, 1.0108695652174, 0.27272727272727
70640, 1.2434782608696, 0.98478260869565, 0.25
70641, 1.2217391304348, 0.98478260869565, 0.22727272727273
70642, 1.2434782608696, 1.0108695652174, 0.22727272727273
70643, 1.2434782608696, 0.98478260869565, 0.20454545454545
70644, 1.2217391304348, 0.98478260869565, 0.18181818181818
70645, 1.2434782608696, 1.0108695652174, 0.18181818181818
70646, 1.2434782608696, 0.98478260869565, 0.15909090909091
70647, 1.2217391304348, 0.98478260869565, 0.13636363636364
70648, 1.2434782608696, 1.0108695652174, 0.13636363636364
70649, 1.2434782608696, 0.98478260869565, 0.11363636363636
70650, 1.2217391304348, 0.98478260869565, 0.090909090909091
70651, 1.2434782608696, 1.0108695652174, 0.090909090909091
70652, 1.2434782608696, 0.98478260869565, 0.068181818181818
70653, 1.2217391304348, 0.98478260869565, 0.045454545454545
70654, 1.2434782608696, 1.0108695652174, 0.045454545454545
70655, 1.2434782608696, 0.98478260869565, 0.022727272727273
70656, 1.2869565217391, 0.98478260869565, 0.47727272727273
70657, 1.2652173913043, 0.98478260869565, 0.45454545454545
70658, 1.2869565217391, 1.0108695652174, 0.45454545454545
70659, 1.2869565217391, 0.98478260869565, 0.43181818181818
70660, 1.2652173913043, 0.98478260869565, 0.40909090909091
70661, 1.2869565217391, 1.0108695652174, 0.40909090909091
70662, 1.2869565217391, 0.98478260869565, 0.38636363636364
70663, 1.2652173913043, 0.98478260869565, 0.36363636363636
70664, 1.2869565217391, 1.0108695652174, 0.36363636363636
70665, 1.2869565217391, 0.98478260869565, 0.34090909090909
70666, 1.2652173913043, 0.98478260869565, 0.31818181818182
70667, 1.2869565217391, 1.0108695652174, 0.31818181818182
70668, 1.2869565217391, 0.98478260869565, 0.29545454545455
70669, 1.2652173913043, 0.98478260869565, 0.27272727272727
70670, 1.2869565217391, 1.0108695652174, 0.27272727272727
70671, 1.2869565217391, 0.98478260869565, 0.25
70672, 1.2652173913043, 0.98478260869565, 0.22727272727273
70673, 1.2869565217391, 1.0108695652174, 0.22727272727273
70674, 1.2869565217391, 0.98478260869565, 0.20454545454545
70675, 1.2652173913043, 0.98478260869565, 0.18181818181818
70676, 1.2869565217391, 1.0108695652174, 0.18181818181818
70677, 1.2869565217391, 0.98478260869565, 0.15909090909091
70678, 1.2652173913043, 0.98478260869565, 0.13636363636364
70679, 1.2869565217391, 1.0108695652174, 0.13636363636364
70680, 1.2869565217391, 0.98478260869565, 0.11363636363636
70681, 1.2652173913043, 0.98478260869565, 0.090909090909091
70682, 1.2869565217391, 1.0108695652174, 0.090909090909091
70683, 1.2869565217391, 0.98478260869565, 0.068181818181818
70684, 1.2652173913043, 0.98478260869565, 0.045454545454545
70685, 1.2869565217391, 1.0108695652174, 0.045454545454545
70686, 1.2869565217391, 0.98478260869565, 0.022727272727273
70687, 1.3304347826087, 0.98478260869565, 0.47727272727273
70688, 1.3086956521739, 0.98478260869565, 0.45454545454545
70689, 1.3304347826087, 1.0108695652174, 0.45454545454545
70690, 1.3304347826087, 0.98478260869565, 0.43181818181818
70691, 1.3086956521739, 0.98478260869565, 0.40909090909091
70692, 1.3304347826087, 1.0108695652174, 0.40909090909091
70693, 1.3304347826087, 0.98478260869565, 0.38636363636364
70694, 1.3086956521739, 0.98478260869565, 0.36363636363636
70695, 1.3304347826087, 1.0108695652174, 0.36363636363636
70696, 1.3304347826087, 0.98478260869565, 0.34090909090909
70697, 1.3086956521739, 0.98478260869565, 0.31818181818182
70698, 1.3304347826087, 1.0108695652174, 0.31818181818182
70699, 1.3304347826087, 0.98478260869565, 0.29545454545455
70700, 1.3086956521739, 0.98478260869565, 0.27272727272727
70701, 1.3304347826087, 1.0108695652174, 0.27272727272727
70702, 1.3304347826087, 0.98478260869565, 0.25
70703, 1.3086956521739, 0.98478260869565, 0.22727272727273
70704, 1.3304347826087, 1.0108695652174, 0.22727272727273
70705, 1.3304347826087, 0.98478260869565, 0.20454545454545
70706, 1.3086956521739, 0.98478260869565, 0.18181818181818
70707, 1.3304347826087, 1.0108695652174, 0.18181818181818
70708, 1.3304347826087, 0.98478260869565, 0.15909090909091
70709, 1.3086956521739, 0.98478260869565, 0.13636363636364
70710, 1.3304347826087, 1.0108695652174, 0.13636363636364
70711, 1.3304347826087, 0.98478260869565, 0.11363636363636
70712, 1.3086956521739, 0.98478260869565, 0.090909090909091
70713, 1.3304347826087, 1.0108695652174, 0.090909090909091
70714, 1.3304347826087, 0.98478260869565, 0.068181818181818
70715, 1.3086956521739, 0.98478260869565, 0.045454545454545
70716, 1.3304347826087, 1.0108695652174, 0.045454545454545
70717, 1.3304347826087, 0.98478260869565, 0.022727272727273
70718, 1.3739130434783, 0.98478260869565, 0.47727272727273
70719, 1.3521739130435, 0.98478260869565, 0.45454545454545
70720, 1.3739130434783, 1.0108695652174, 0.45454545454545
70721, 1.3739130434783, 0.98478260869565, 0.43181818181818
70722, 1.3521739130435, 0.98478260869565, 0.40909090909091
70723, 1.3739130434783, 1.0108695652174, 0.40909090909091
70724, 1.3739130434783, 0.98478260869565, 0.38636363636364
70725, 1.3521739130435, 0.98478260869565, 0.36363636363636
70726, 1.3739130434783, 1.0108695652174, 0.36363636363636
70727, 1.3739130434783, 0.98478260869565, 0.34090909090909
70728, 1.3521739130435, 0.98478260869565, 0.31818181818182
70729, 1.3739130434783, 1.0108695652174, 0.31818181818182
70730, 1.3739130434783, 0.98478260869565, 0.29545454545455
70731, 1.3521739130435, 0.98478260869565, 0.27272727272727
70732, 1.3739130434783, 1.0108695652174, 0.27272727272727
70733, 1.3739130434783, 0.98478260869565, 0.25
70734, 1.3521739130435, 0.98478260869565, 0.22727272727273
70735, 1.3739130434783, 1.0108695652174, 0.22727272727273
70736, 1.3739130434783, 0.98478260869565, 0.20454545454545
70737, 1.3521739130435, 0.98478260869565, 0.18181818181818
70738, 1.3739130434783, 1.0108695652174, 0.18181818181818
70739, 1.3739130434783, 0.98478260869565, 0.15909090909091
70740, 1.3521739130435, 0.98478260869565, 0.13636363636364
70741, 1.3739130434783, 1.0108695652174, 0.13636363636364
70742, 1.3739130434783, 0.98478260869565, 0.11363636363636
70743, 1.3521739130435, 0.98478260869565, 0.090909090909091
70744, 1.3739130434783, 1.0108695652174, 0.090909090909091
70745, 1.3739130434783, 0.98478260869565, 0.068181818181818
70746, 1.3521739130435, 0.98478260869565, 0.045454545454545
70747, 1.3739130434783, 1.0108695652174, 0.045454545454545
70748, 1.3739130434783, 0.98478260869565, 0.022727272727273
70749, 1.4173913043478, 0.98478260869565, 0.47727272727273
70750, 1.395652173913, 0.98478260869565, 0.45454545454545
70751, 1.4173913043478, 1.0108695652174, 0.45454545454545
70752, 1.4173913043478, 0.98478260869565, 0.43181818181818
70753, 1.395652173913, 0.98478260869565, 0.40909090909091
70754, 1.4173913043478, 1.0108695652174, 0.40909090909091
70755, 1.4173913043478, 0.98478260869565, 0.38636363636364
70756, 1.395652173913, 0.98478260869565, 0.36363636363636
70757, 1.4173913043478, 1.0108695652174, 0.36363636363636
70758, 1.4173913043478, 0.98478260869565, 0.34090909090909
70759, 1.395652173913, 0.98478260869565, 0.31818181818182
70760, 1.4173913043478, 1.0108695652174, 0.31818181818182
70761, 1.4173913043478, 0.98478260869565, 0.29545454545455
70762, 1.395652173913, 0.98478260869565, 0.27272727272727
70763, 1.4173913043478, 1.0108695652174, 0.27272727272727
70764, 1.4173913043478, 0.98478260869565, 0.25
70765, 1.395652173913, 0.98478260869565, 0.22727272727273
70766, 1.4173913043478, 1.0108695652174, 0.22727272727273
70767, 1.4173913043478, 0.98478260869565, 0.20454545454545
70768, 1.395652173913, 0.98478260869565, 0.18181818181818
70769, 1.4173913043478, 1.0108695652174, 0.18181818181818
70770, 1.4173913043478, 0.98478260869565, 0.15909090909091
70771, 1.395652173913, 0.98478260869565, 0.13636363636364
70772, 1.4173913043478, 1.0108695652174, 0.13636363636364
70773, 1.4173913043478, 0.98478260869565, 0.11363636363636
70774, 1.395652173913, 0.98478260869565, 0.090909090909091
70775, 1.4173913043478, 1.0108695652174, 0.090909090909091
70776, 1.4173913043478, 0.98478260869565, 0.068181818181818
70777, 1.395652173913, 0.98478260869565, 0.045454545454545
70778, 1.4173913043478, 1.0108695652174, 0.045454545454545
70779, 1.4173913043478, 0.98478260869565, 0.022727272727273
70780, 1.4608695652174, 0.98478260869565, 0.47727272727273
70781, 1.4391304347826, 0.98478260869565, 0.45454545454545
70782, 1.4608695652174, 1.0108695652174, 0.45454545454545
70783, 1.4608695652174, 0.98478260869565, 0.43181818181818
70784, 1.4391304347826, 0.98478260869565, 0.40909090909091
70785, 1.4608695652174, 1.0108695652174, 0.40909090909091
70786, 1.4608695652174, 0.98478260869565, 0.38636363636364
70787, 1.4391304347826, 0.98478260869565, 0.36363636363636
70788, 1.4608695652174, 1.0108695652174, 0.36363636363636
70789, 1.4608695652174, 0.98478260869565, 0.34090909090909
70790, 1.4391304347826, 0.98478260869565, 0.31818181818182
70791, 1.4608695652174, 1.0108695652174, 0.31818181818182
70792, 1.4608695652174, 0.98478260869565, 0.29545454545455
70793, 1.4391304347826, 0.98478260869565, 0.27272727272727
70794, 1.4608695652174, 1.0108695652174, 0.27272727272727
70795, 1.4608695652174, 0.98478260869565, 0.25
70796, 1.4391304347826, 0.98478260869565, 0.22727272727273
70797, 1.4608695652174, 1.0108695652174, 0.22727272727273
70798, 1.4608695652174, 0.98478260869565, 0.20454545454545
70799, 1.4391304347826, 0.98478260869565, 0.18181818181818
70800, 1.4608695652174, 1.0108695652174, 0.18181818181818
70801, 1.4608695652174, 0.98478260869565, 0.15909090909091
70802, 1.4391304347826, 0.98478260869565, 0.13636363636364
70803, 1.4608695652174, 1.0108695652174, 0.13636363636364
70804, 1.4608695652174, 0.98478260869565, 0.11363636363636
70805, 1.4391304347826, 0.98478260869565, 0.090909090909091
70806, 1.4608695652174, 1.0108695652174, 0.090909090909091
70807, 1.4608695652174, 0.98478260869565, 0.068181818181818
70808, 1.4391304347826, 0.98478260869565, 0.045454545454545
70809, 1.4608695652174, 1.0108695652174, 0.045454545454545
70810, 1.4608695652174, 0.98478260869565, 0.022727272727273
70811, 1.504347826087, 0.98478260869565, 0.47727272727273
70812, 1.4826086956522, 0.98478260869565, 0.45454545454545
70813, 1.504347826087, 1.0108695652174, 0.45454545454545
70814, 1.504347826087, 0.98478260869565, 0.43181818181818
70815, 1.4826086956522, 0.98478260869565, 0.40909090909091
70816, 1.504347826087, 1.0108695652174, 0.40909090909091
70817, 1.504347826087, 0.98478260869565, 0.38636363636364
70818, 1.4826086956522, 0.98478260869565, 0.36363636363636
70819, 1.504347826087, 1.0108695652174, 0.36363636363636
70820, 1.504347826087, 0.98478260869565, 0.34090909090909
70821, 1.4826086956522, 0.98478260869565, 0.31818181818182
70822, 1.504347826087, 1.0108695652174, 0.31818181818182
70823, 1.504347826087, 0.98478260869565, 0.29545454545455
70824, 1.4826086956522, 0.98478260869565, 0.27272727272727
70825, 1.504347826087, 1.0108695652174, 0.27272727272727
70826, 1.504347826087, 0.98478260869565, 0.25
70827, 1.4826086956522, 0.98478260869565, 0.22727272727273
70828, 1.504347826087, 1.0108695652174, 0.22727272727273
70829, 1.504347826087, 0.98478260869565, 0.20454545454545
70830, 1.4826086956522, 0.98478260869565, 0.18181818181818
70831, 1.504347826087, 1.0108695652174, 0.18181818181818
70832, 1.504347826087, 0.98478260869565, 0.15909090909091
70833, 1.4826086956522, 0.98478260869565, 0.13636363636364
70834, 1.504347826087, 1.0108695652174, 0.13636363636364
70835, 1.504347826087, 0.98478260869565, 0.11363636363636
70836, 1.4826086956522, 0.98478260869565, 0.090909090909091
70837, 1.504347826087, 1.0108695652174, 0.090909090909091
70838, 1.504347826087, 0.98478260869565, 0.068181818181818
70839, 1.4826086956522, 0.98478260869565, 0.045454545454545
70840, 1.504347826087, 1.0108695652174, 0.045454545454545
70841, 1.504347826087, 0.98478260869565, 0.022727272727273
70842, 1.5478260869565, 0.98478260869565, 0.47727272727273
70843, 1.5260869565217, 0.98478260869565, 0.45454545454545
70844, 1.5478260869565, 1.0108695652174, 0.45454545454545
70845, 1.5478260869565, 0.98478260869565, 0.43181818181818
70846, 1.5260869565217, 0.98478260869565, 0.40909090909091
70847, 1.5478260869565, 1.0108695652174, 0.40909090909091
70848, 1.5478260869565, 0.98478260869565, 0.38636363636364
70849, 1.5260869565217, 0.98478260869565, 0.36363636363636
70850, 1.5478260869565, 1.0108695652174, 0.36363636363636
70851, 1.5478260869565, 0.98478260869565, 0.34090909090909
70852, 1.5260869565217, 0.98478260869565, 0.31818181818182
70853, 1.5478260869565, 1.0108695652174, 0.31818181818182
70854, 1.5478260869565, 0.98478260869565, 0.29545454545455
70855, 1.5260869565217, 0.98478260869565, 0.27272727272727
70856, 1.5478260869565, 1.0108695652174, 0.27272727272727
70857, 1.5478260869565, 0.98478260869565, 0.25
70858, 1.5260869565217, 0.98478260869565, 0.22727272727273
70859, 1.5478260869565, 1.0108695652174, 0.22727272727273
70860, 1.5478260869565, 0.98478260869565, 0.20454545454545
70861, 1.5260869565217, 0.98478260869565, 0.18181818181818
70862, 1.5478260869565, 1.0108695652174, 0.18181818181818
70863, 1.5478260869565, 0.98478260869565, 0.15909090909091
70864, 1.5260869565217, 0.98478260869565, 0.13636363636364
70865, 1.5478260869565, 1.0108695652174, 0.13636363636364
70866, 1.5478260869565, 0.98478260869565, 0.11363636363636
70867, 1.5260869565217, 0.98478260869565, 0.090909090909091
70868, 1.5478260869565, 1.0108695652174, 0.090909090909091
70869, 1.5478260869565, 0.98478260869565, 0.068181818181818
70870, 1.5260869565217, 0.98478260869565, 0.045454545454545
70871, 1.5478260869565, 1.0108695652174, 0.045454545454545
70872, 1.5478260869565, 0.98478260869565, 0.022727272727273
70873, 1.5913043478261, 0.98478260869565, 0.47727272727273
70874, 1.5695652173913, 0.98478260869565, 0.45454545454545
70875, 1.5913043478261, 1.0108695652174, 0.45454545454545
70876, 1.5913043478261, 0.98478260869565, 0.43181818181818
70877, 1.5695652173913, 0.98478260869565, 0.40909090909091
70878, 1.5913043478261, 1.0108695652174, 0.40909090909091
70879, 1.5913043478261, 0.98478260869565, 0.38636363636364
70880, 1.5695652173913, 0.98478260869565, 0.36363636363636
70881, 1.5913043478261, 1.0108695652174, 0.36363636363636
70882, 1.5913043478261, 0.98478260869565, 0.34090909090909
70883, 1.5695652173913, 0.98478260869565, 0.31818181818182
70884, 1.5913043478261, 1.0108695652174, 0.31818181818182
70885, 1.5913043478261, 0.98478260869565, 0.29545454545455
70886, 1.5695652173913, 0.98478260869565, 0.27272727272727
70887, 1.5913043478261, 1.0108695652174, 0.27272727272727
70888, 1.5913043478261, 0.98478260869565, 0.25
70889, 1.5695652173913, 0.98478260869565, 0.22727272727273
70890, 1.5913043478261, 1.0108695652174, 0.22727272727273
70891, 1.5913043478261, 0.98478260869565, 0.20454545454545
70892, 1.5695652173913, 0.98478260869565, 0.18181818181818
70893, 1.5913043478261, 1.0108695652174, 0.18181818181818
70894, 1.5913043478261, 0.98478260869565, 0.15909090909091
70895, 1.5695652173913, 0.98478260869565, 0.13636363636364
70896, 1.5913043478261, 1.0108695652174, 0.13636363636364
70897, 1.5913043478261, 0.98478260869565, 0.11363636363636
70898, 1.5695652173913, 0.98478260869565, 0.090909090909091
70899, 1.5913043478261, 1.0108695652174, 0.090909090909091
70900, 1.5913043478261, 0.98478260869565, 0.068181818181818
70901, 1.5695652173913, 0.98478260869565, 0.045454545454545
70902, 1.5913043478261, 1.0108695652174, 0.045454545454545
70903, 1.5913043478261, 0.98478260869565, 0.022727272727273
70904, 1.6347826086957, 0.98478260869565, 0.47727272727273
70905, 1.6130434782609, 0.98478260869565, 0.45454545454545
70906, 1.6347826086957, 1.0108695652174, 0.45454545454545
70907, 1.6347826086957, 0.98478260869565, 0.43181818181818
70908, 1.6130434782609, 0.98478260869565, 0.40909090909091
70909, 1.6347826086957, 1.0108695652174, 0.40909090909091
70910, 1.6347826086957, 0.98478260869565, 0.38636363636364
70911, 1.6130434782609, 0.98478260869565, 0.36363636363636
70912, 1.6347826086957, 1.0108695652174, 0.36363636363636
70913, 1.6347826086957, 0.98478260869565, 0.34090909090909
70914, 1.6130434782609, 0.98478260869565, 0.31818181818182
70915, 1.6347826086957, 1.0108695652174, 0.31818181818182
70916, 1.6347826086957, 0.98478260869565, 0.29545454545455
70917, 1.6130434782609, 0.98478260869565, 0.27272727272727
70918, 1.6347826086957, 1.0108695652174, 0.27272727272727
70919, 1.6347826086957, 0.98478260869565, 0.25
70920, 1.6130434782609, 0.98478260869565, 0.22727272727273
70921, 1.6347826086957, 1.0108695652174, 0.22727272727273
70922, 1.6347826086957, 0.98478260869565, 0.20454545454545
70923, 1.6130434782609, 0.98478260869565, 0.18181818181818
70924, 1.6347826086957, 1.0108695652174, 0.18181818181818
70925, 1.6347826086957, 0.98478260869565, 0.15909090909091
70926, 1.6130434782609, 0.98478260869565, 0.13636363636364
70927, 1.6347826086957, 1.0108695652174, 0.13636363636364
70928, 1.6347826086957, 0.98478260869565, 0.11363636363636
70929, 1.6130434782609, 0.98478260869565, 0.090909090909091
70930, 1.6347826086957, 1.0108695652174, 0.090909090909091
70931, 1.6347826086957, 0.98478260869565, 0.068181818181818
70932, 1.6130434782609, 0.98478260869565, 0.045454545454545
70933, 1.6347826086957, 1.0108695652174, 0.045454545454545
70934, 1.6347826086957, 0.98478260869565, 0.022727272727273
70935, 1.6782608695652, 0.98478260869565, 0.47727272727273
70936, 1.6565217391304, 0.98478260869565, 0.45454545454545
70937, 1.6782608695652, 1.0108695652174, 0.45454545454545
70938, 1.6782608695652, 0.98478260869565, 0.43181818181818
70939, 1.6565217391304, 0.98478260869565, 0.40909090909091
70940, 1.6782608695652, 1.0108695652174, 0.40909090909091
70941, 1.6782608695652, 0.98478260869565, 0.38636363636364
70942, 1.6565217391304, 0.98478260869565, 0.36363636363636
70943, 1.6782608695652, 1.0108695652174, 0.36363636363636
70944, 1.6782608695652, 0.98478260869565, 0.34090909090909
70945, 1.6565217391304, 0.98478260869565, 0.31818181818182
70946, 1.6782608695652, 1.0108695652174, 0.31818181818182
70947, 1.6782608695652, 0.98478260869565, 0.29545454545455
70948, 1.6565217391304, 0.98478260869565, 0.27272727272727
70949, 1.6782608695652, 1.0108695652174, 0.27272727272727
70950, 1.6782608695652, 0.98478260869565, 0.25
70951, 1.6565217391304, 0.98478260869565, 0.22727272727273
70952, 1.6782608695652, 1.0108695652174, 0.22727272727273
70953, 1.6782608695652, 0.98478260869565, 0.20454545454545
70954, 1.6565217391304, 0.98478260869565, 0.18181818181818
70955, 1.6782608695652, 1.0108695652174, 0.18181818181818
70956, 1.6782608695652, 0.98478260869565, 0.15909090909091
70957, 1.6565217391304, 0.98478260869565, 0.13636363636364
70958, 1.6782608695652, 1.0108695652174, 0.13636363636364
70959, 1.6782608695652, 0.98478260869565, 0.11363636363636
70960, 1.6565217391304, 0.98478260869565, 0.090909090909091
70961, 1.6782608695652, 1.0108695652174, 0.090909090909091
70962, 1.6782608695652, 0.98478260869565, 0.068181818181818
70963, 1.6565217391304, 0.98478260869565, 0.045454545454545
70964, 1.6782608695652, 1.0108695652174, 0.045454545454545
70965, 1.6782608695652, 0.98478260869565, 0.022727272727273
70966, 1.7217391304348, 0.98478260869565, 0.47727272727273
70967, 1.7, 0.98478260869565, 0.45454545454545
70968, 1.7217391304348, 1.0108695652174, 0.45454545454545
70969, 1.7217391304348, 0.98478260869565, 0.43181818181818
70970, 1.7, 0.98478260869565, 0.40909090909091
70971, 1.7217391304348, 1.0108695652174, 0.40909090909091
70972, 1.7217391304348, 0.98478260869565, 0.38636363636364
70973, 1.7, 0.98478260869565, 0.36363636363636
70974, 1.7217391304348, 1.0108695652174, 0.36363636363636
70975, 1.7217391304348, 0.98478260869565, 0.34090909090909
70976, 1.7, 0.98478260869565, 0.31818181818182
70977, 1.7217391304348, 1.0108695652174, 0.31818181818182
70978, 1.7217391304348, 0.98478260869565, 0.29545454545455
70979, 1.7, 0.98478260869565, 0.27272727272727
70980, 1.7217391304348, 1.0108695652174, 0.27272727272727
70981, 1.7217391304348, 0.98478260869565, 0.25
70982, 1.7, 0.98478260869565, 0.22727272727273
70983, 1.7217391304348, 1.0108695652174, 0.22727272727273
70984, 1.7217391304348, 0.98478260869565, 0.20454545454545
70985, 1.7, 0.98478260869565, 0.18181818181818
70986, 1.7217391304348, 1.0108695652174, 0.18181818181818
70987, 1.7217391304348, 0.98478260869565, 0.15909090909091
70988, 1.7, 0.98478260869565, 0.13636363636364
70989, 1.7217391304348, 1.0108695652174, 0.13636363636364
70990, 1.7217391304348, 0.98478260869565, 0.11363636363636
70991, 1.7, 0.98478260869565, 0.090909090909091
70992, 1.7217391304348, 1.0108695652174, 0.090909090909091
70993, 1.7217391304348, 0.98478260869565, 0.068181818181818
70994, 1.7, 0.98478260869565, 0.045454545454545
70995, 1.7217391304348, 1.0108695652174, 0.045454545454545
70996, 1.7217391304348, 0.98478260869565, 0.022727272727273
70997, 1.7652173913043, 0.98478260869565, 0.47727272727273
70998, 1.7434782608696, 0.98478260869565, 0.45454545454545
70999, 1.7652173913043, 1.0108695652174, 0.45454545454545
71000, 1.7652173913043, 0.98478260869565, 0.43181818181818
71001, 1.7434782608696, 0.98478260869565, 0.40909090909091
71002, 1.7652173913043, 1.0108695652174, 0.40909090909091
71003, 1.7652173913043, 0.98478260869565, 0.38636363636364
71004, 1.7434782608696, 0.98478260869565, 0.36363636363636
71005, 1.7652173913043, 1.0108695652174, 0.36363636363636
71006, 1.7652173913043, 0.98478260869565, 0.34090909090909
71007, 1.7434782608696, 0.98478260869565, 0.31818181818182
71008, 1.7652173913043, 1.0108695652174, 0.31818181818182
71009, 1.7652173913043, 0.98478260869565, 0.29545454545455
71010, 1.7434782608696, 0.98478260869565, 0.27272727272727
71011, 1.7652173913043, 1.0108695652174, 0.27272727272727
71012, 1.7652173913043, 0.98478260869565, 0.25
71013, 1.7434782608696, 0.98478260869565, 0.22727272727273
71014, 1.7652173913043, 1.0108695652174, 0.22727272727273
71015, 1.7652173913043, 0.98478260869565, 0.20454545454545
71016, 1.7434782608696, 0.98478260869565, 0.18181818181818
71017, 1.7652173913043, 1.0108695652174, 0.18181818181818
71018, 1.7652173913043, 0.98478260869565, 0.15909090909091
71019, 1.7434782608696, 0.98478260869565, 0.13636363636364
71020, 1.7652173913043, 1.0108695652174, 0.13636363636364
71021, 1.7652173913043, 0.98478260869565, 0.11363636363636
71022, 1.7434782608696, 0.98478260869565, 0.090909090909091
71023, 1.7652173913043, 1.0108695652174, 0.090909090909091
71024, 1.7652173913043, 0.98478260869565, 0.068181818181818
71025, 1.7434782608696, 0.98478260869565, 0.045454545454545
71026, 1.7652173913043, 1.0108695652174, 0.045454545454545
