93363, 0.91304347826087, -0.075, 0.090909090909091
93364, 0.91304347826087, -0.1, 0.11363636363636
93365, 0.93478260869565, -0.1, 0.13636363636364
93366, 0.91304347826087, -0.075, 0.13636363636364
93367, 0.91304347826087, -0.1, 0.15909090909091
93368, 0.93478260869565, -0.1, 0.18181818181818
93369, 0.91304347826087, -0.075, 0.18181818181818
93370, 0.91304347826087, -0.1, 0.20454545454545
93371, 0.93478260869565, -0.1, 0.22727272727273
93372, 0.91304347826087, -0.075, 0.22727272727273
93373, 0.91304347826087, -0.1, 0.25
93374, 0.93478260869565, -0.1, 0.27272727272727
93375, 0.91304347826087, -0.075, 0.27272727272727
93376, 0.91304347826087, -0.1, 0.29545454545455
93377, 0.93478260869565, -0.1, 0.31818181818182
93378, 0.91304347826087, -0.075, 0.31818181818182
93379, 0.91304347826087, -0.1, 0.34090909090909
93380, 0.93478260869565, -0.1, 0.36363636363636
93381, 0.91304347826087, -0.075, 0.36363636363636
93382, 0.91304347826087, -0.1, 0.38636363636364
93383, 0.93478260869565, -0.1, 0.40909090909091
93384, 0.91304347826087, -0.075, 0.40909090909091
93385, 0.91304347826087, -0.1, 0.43181818181818
93386, 0.93478260869565, -0.1, 0.45454545454545
93387, 0.91304347826087, -0.075, 0.45454545454545
93388, 0.91304347826087, -0.1, 0.47727272727273
93389, 0.8695652173913, -0.1, 0.022727272727273
93390, 0.89130434782609, -0.1, 0.045454545454545
93391, 0.8695652173913, -0.075, 0.045454545454545
93392, 0.8695652173913, -0.1, 0.068181818181818
93393, 0.89130434782609, -0.1, 0.090909090909091
93394, 0.8695652173913, -0.075, 0.090909090909091
93395, 0.8695652173913, -0.1, 0.11363636363636
93396, 0.89130434782609, -0.1, 0.13636363636364
93397, 0.8695652173913, -0.075, 0.13636363636364
93398, 0.8695652173913, -0.1, 0.15909090909091
93399, 0.89130434782609, -0.1, 0.18181818181818
93400, 0.8695652173913, -0.075, 0.18181818181818
93401, 0.8695652173913, -0.1, 0.20454545454545
93402, 0.89130434782609, -0.1, 0.22727272727273
93403, 0.8695652173913, -0.075, 0.22727272727273
93404, 0.8695652173913, -0.1, 0.25
93405, 0.89130434782609, -0.1, 0.27272727272727
93406, 0.8695652173913, -0.075, 0.27272727272727
93407, 0.8695652173913, -0.1, 0.29545454545455
93408, 0.89130434782609, -0.1, 0.31818181818182
93409, 0.8695652173913, -0.075, 0.31818181818182
93410, 0.8695652173913, -0.1, 0.34090909090909
93411, 0.89130434782609, -0.1, 0.36363636363636
93412, 0.8695652173913, -0.075, 0.36363636363636
93413, 0.8695652173913, -0.1, 0.38636363636364
93414, 0.89130434782609, -0.1, 0.40909090909091
93415, 0.8695652173913, -0.075, 0.40909090909091
93416, 0.8695652173913, -0.1, 0.43181818181818
93417, 0.89130434782609, -0.1, 0.45454545454545
93418, 0.8695652173913, -0.075, 0.45454545454545
93419, 0.8695652173913, -0.1, 0.47727272727273
93420, 0.82608695652174, -0.1, 0.022727272727273
93421, 0.84782608695652, -0.1, 0.045454545454545
93422, 0.82608695652174, -0.075, 0.045454545454545
93423, 0.82608695652174, -0.1, 0.068181818181818
93424, 0.84782608695652, -0.1, 0.090909090909091
93425, 0.82608695652174, -0.075, 0.090909090909091
93426, 0.82608695652174, -0.1, 0.11363636363636
93427, 0.84782608695652, -0.1, 0.13636363636364
93428, 0.82608695652174, -0.075, 0.13636363636364
93429, 0.82608695652174, -0.1, 0.15909090909091
93430, 0.84782608695652, -0.1, 0.18181818181818
93431, 0.82608695652174, -0.075, 0.18181818181818
93432, 0.82608695652174, -0.1, 0.20454545454545
93433, 0.84782608695652, -0.1, 0.22727272727273
93434, 0.82608695652174, -0.075, 0.22727272727273
93435, 0.82608695652174, -0.1, 0.25
93436, 0.84782608695652, -0.1, 0.27272727272727
93437, 0.82608695652174, -0.075, 0.27272727272727
93438, 0.82608695652174, -0.1, 0.29545454545455
93439, 0.84782608695652, -0.1, 0.31818181818182
93440, 0.82608695652174, -0.075, 0.31818181818182
93441, 0.82608695652174, -0.1, 0.34090909090909
93442, 0.84782608695652, -0.1, 0.36363636363636
93443, 0.82608695652174, -0.075, 0.36363636363636
93444, 0.82608695652174, -0.1, 0.38636363636364
93445, 0.84782608695652, -0.1, 0.40909090909091
93446, 0.82608695652174, -0.075, 0.40909090909091
93447, 0.82608695652174, -0.1, 0.43181818181818
93448, 0.84782608695652, -0.1, 0.45454545454545
93449, 0.82608695652174, -0.075, 0.45454545454545
93450, 0.82608695652174, -0.1, 0.47727272727273
93451, 0.78260869565217, -0.1, 0.022727272727273
93452, 0.80434782608696, -0.1, 0.045454545454545
93453, 0.78260869565217, -0.075, 0.045454545454545
93454, 0.78260869565217, -0.1, 0.068181818181818
93455, 0.80434782608696, -0.1, 0.090909090909091
93456, 0.78260869565217, -0.075, 0.090909090909091
93457, 0.78260869565217, -0.1, 0.11363636363636
93458, 0.80434782608696, -0.1, 0.13636363636364
93459, 0.78260869565217, -0.075, 0.13636363636364
93460, 0.78260869565217, -0.1, 0.15909090909091
93461, 0.80434782608696, -0.1, 0.18181818181818
93462, 0.78260869565217, -0.075, 0.18181818181818
93463, 0.78260869565217, -0.1, 0.20454545454545
93464, 0.80434782608696, -0.1, 0.22727272727273
93465, 0.78260869565217, -0.075, 0.22727272727273
93466, 0.78260869565217, -0.1, 0.25
93467, 0.80434782608696, -0.1, 0.27272727272727
93468, 0.78260869565217, -0.075, 0.27272727272727
93469, 0.78260869565217, -0.1, 0.29545454545455
93470, 0.80434782608696, -0.1, 0.31818181818182
93471, 0.78260869565217, -0.075, 0.31818181818182
93472, 0.78260869565217, -0.1, 0.34090909090909
93473, 0.80434782608696, -0.1, 0.36363636363636
93474, 0.78260869565217, -0.075, 0.36363636363636
93475, 0.78260869565217, -0.1, 0.38636363636364
93476, 0.80434782608696, -0.1, 0.40909090909091
93477, 0.78260869565217, -0.075, 0.40909090909091
93478, 0.78260869565217, -0.1, 0.43181818181818
93479, 0.80434782608696, -0.1, 0.45454545454545
93480, 0.78260869565217, -0.075, 0.45454545454545
93481, 0.78260869565217, -0.1, 0.47727272727273
93482, 0.73913043478261, -0.1, 0.022727272727273
93483, 0.76086956521739, -0.1, 0.045454545454545
93484, 0.73913043478261, -0.075, 0.045454545454545
93485, 0.73913043478261, -0.1, 0.068181818181818
93486, 0.76086956521739, -0.1, 0.090909090909091
93487, 0.73913043478261, -0.075, 0.090909090909091
93488, 0.73913043478261, -0.1, 0.11363636363636
93489, 0.76086956521739, -0.1, 0.13636363636364
93490, 0.73913043478261, -0.075, 0.13636363636364
93491, 0.73913043478261, -0.1, 0.15909090909091
93492, 0.76086956521739, -0.1, 0.18181818181818
93493, 0.73913043478261, -0.075, 0.18181818181818
93494, 0.73913043478261, -0.1, 0.20454545454545
93495, 0.76086956521739, -0.1, 0.22727272727273
93496, 0.73913043478261, -0.075, 0.22727272727273
93497, 0.73913043478261, -0.1, 0.25
93498, 0.76086956521739, -0.1, 0.27272727272727
93499, 0.73913043478261, -0.075, 0.27272727272727
93500, 0.73913043478261, -0.1, 0.29545454545455
93501, 0.76086956521739, -0.1, 0.31818181818182
93502, 0.73913043478261, -0.075, 0.31818181818182
93503, 0.73913043478261, -0.1, 0.34090909090909
93504, 0.76086956521739, -0.1, 0.36363636363636
93505, 0.73913043478261, -0.075, 0.36363636363636
93506, 0.73913043478261, -0.1, 0.38636363636364
93507, 0.76086956521739, -0.1, 0.40909090909091
93508, 0.73913043478261, -0.075, 0.40909090909091
93509, 0.73913043478261, -0.1, 0.43181818181818
93510, 0.76086956521739, -0.1, 0.45454545454545
93511, 0.73913043478261, -0.075, 0.45454545454545
93512, 0.73913043478261, -0.1, 0.47727272727273
93513, 0.69565217391304, -0.1, 0.022727272727273
93514, 0.71739130434783, -0.1, 0.045454545454545
93515, 0.69565217391304, -0.075, 0.045454545454545
93516, 0.69565217391304, -0.1, 0.068181818181818
93517, 0.71739130434783, -0.1, 0.090909090909091
93518, 0.69565217391304, -0.075, 0.090909090909091
93519, 0.69565217391304, -0.1, 0.11363636363636
93520, 0.71739130434783, -0.1, 0.13636363636364
93521, 0.69565217391304, -0.075, 0.13636363636364
93522, 0.69565217391304, -0.1, 0.15909090909091
93523, 0.71739130434783, -0.1, 0.18181818181818
93524, 0.69565217391304, -0.075, 0.18181818181818
93525, 0.69565217391304, -0.1, 0.20454545454545
93526, 0.71739130434783, -0.1, 0.22727272727273
93527, 0.69565217391304, -0.075, 0.22727272727273
93528, 0.69565217391304, -0.1, 0.25
93529, 0.71739130434783, -0.1, 0.27272727272727
93530, 0.69565217391304, -0.075, 0.27272727272727
93531, 0.69565217391304, -0.1, 0.29545454545455
93532, 0.71739130434783, -0.1, 0.31818181818182
93533, 0.69565217391304, -0.075, 0.31818181818182
93534, 0.69565217391304, -0.1, 0.34090909090909
93535, 0.71739130434783, -0.1, 0.36363636363636
93536, 0.69565217391304, -0.075, 0.36363636363636
93537, 0.69565217391304, -0.1, 0.38636363636364
93538, 0.71739130434783, -0.1, 0.40909090909091
93539, 0.69565217391304, -0.075, 0.40909090909091
93540, 0.69565217391304, -0.1, 0.43181818181818
93541, 0.71739130434783, -0.1, 0.45454545454545
93542, 0.69565217391304, -0.075, 0.45454545454545
93543, 0.69565217391304, -0.1, 0.47727272727273
93544, 0.65217391304348, -0.1, 0.022727272727273
93545, 0.67391304347826, -0.1, 0.045454545454545
93546, 0.65217391304348, -0.075, 0.045454545454545
93547, 0.65217391304348, -0.1, 0.068181818181818
93548, 0.67391304347826, -0.1, 0.090909090909091
93549, 0.65217391304348, -0.075, 0.090909090909091
93550, 0.65217391304348, -0.1, 0.11363636363636
93551, 0.67391304347826, -0.1, 0.13636363636364
93552, 0.65217391304348, -0.075, 0.13636363636364
93553, 0.65217391304348, -0.1, 0.15909090909091
93554, 0.67391304347826, -0.1, 0.18181818181818
93555, 0.65217391304348, -0.075, 0.18181818181818
93556, 0.65217391304348, -0.1, 0.20454545454545
93557, 0.67391304347826, -0.1, 0.22727272727273
93558, 0.65217391304348, -0.075, 0.22727272727273
93559, 0.65217391304348, -0.1, 0.25
93560, 0.67391304347826, -0.1, 0.27272727272727
93561, 0.65217391304348, -0.075, 0.27272727272727
93562, 0.65217391304348, -0.1, 0.29545454545455
93563, 0.67391304347826, -0.1, 0.31818181818182
93564, 0.65217391304348, -0.075, 0.31818181818182
93565, 0.65217391304348, -0.1, 0.34090909090909
93566, 0.67391304347826, -0.1, 0.36363636363636
93567, 0.65217391304348, -0.075, 0.36363636363636
93568, 0.65217391304348, -0.1, 0.38636363636364
93569, 0.67391304347826, -0.1, 0.40909090909091
93570, 0.65217391304348, -0.075, 0.40909090909091
93571, 0.65217391304348, -0.1, 0.43181818181818
93572, 0.67391304347826, -0.1, 0.45454545454545
93573, 0.65217391304348, -0.075, 0.45454545454545
93574, 0.65217391304348, -0.1, 0.47727272727273
93575, 0.60869565217391, -0.1, 0.022727272727273
93576, 0.6304347826087, -0.1, 0.045454545454545
93577, 0.60869565217391, -0.075, 0.045454545454545
93578, 0.60869565217391, -0.1, 0.068181818181818
93579, 0.6304347826087, -0.1, 0.090909090909091
93580, 0.60869565217391, -0.075, 0.090909090909091
93581, 0.60869565217391, -0.1, 0.11363636363636
93582, 0.6304347826087, -0.1, 0.13636363636364
93583, 0.60869565217391, -0.075, 0.13636363636364
93584, 0.60869565217391, -0.1, 0.15909090909091
93585, 0.6304347826087, -0.1, 0.18181818181818
93586, 0.60869565217391, -0.075, 0.18181818181818
93587, 0.60869565217391, -0.1, 0.20454545454545
93588, 0.6304347826087, -0.1, 0.22727272727273
93589, 0.60869565217391, -0.075, 0.22727272727273
93590, 0.60869565217391, -0.1, 0.25
93591, 0.6304347826087, -0.1, 0.27272727272727
93592, 0.60869565217391, -0.075, 0.27272727272727
93593, 0.60869565217391, -0.1, 0.29545454545455
93594, 0.6304347826087, -0.1, 0.31818181818182
93595, 0.60869565217391, -0.075, 0.31818181818182
93596, 0.60869565217391, -0.1, 0.34090909090909
93597, 0.6304347826087, -0.1, 0.36363636363636
93598, 0.60869565217391, -0.075, 0.36363636363636
93599, 0.60869565217391, -0.1, 0.38636363636364
93600, 0.6304347826087, -0.1, 0.40909090909091
93601, 0.60869565217391, -0.075, 0.40909090909091
93602, 0.60869565217391, -0.1, 0.43181818181818
93603, 0.6304347826087, -0.1, 0.45454545454545
93604, 0.60869565217391, -0.075, 0.45454545454545
93605, 0.60869565217391, -0.1, 0.47727272727273
93606, 0.56521739130435, -0.1, 0.022727272727273
93607, 0.58695652173913, -0.1, 0.045454545454545
93608, 0.56521739130435, -0.075, 0.045454545454545
93609, 0.56521739130435, -0.1, 0.068181818181818
93610, 0.58695652173913, -0.1, 0.090909090909091
93611, 0.56521739130435, -0.075, 0.090909090909091
93612, 0.56521739130435, -0.1, 0.11363636363636
93613, 0.58695652173913, -0.1, 0.13636363636364
93614, 0.56521739130435, -0.075, 0.13636363636364
93615, 0.56521739130435, -0.1, 0.15909090909091
93616, 0.58695652173913, -0.1, 0.18181818181818
93617, 0.56521739130435, -0.075, 0.18181818181818
93618, 0.56521739130435, -0.1, 0.20454545454545
93619, 0.58695652173913, -0.1, 0.22727272727273
93620, 0.56521739130435, -0.075, 0.22727272727273
93621, 0.56521739130435, -0.1, 0.25
93622, 0.58695652173913, -0.1, 0.27272727272727
93623, 0.56521739130435, -0.075, 0.27272727272727
93624, 0.56521739130435, -0.1, 0.29545454545455
93625, 0.58695652173913, -0.1, 0.31818181818182
93626, 0.56521739130435, -0.075, 0.31818181818182
93627, 0.56521739130435, -0.1, 0.34090909090909
93628, 0.58695652173913, -0.1, 0.36363636363636
93629, 0.56521739130435, -0.075, 0.36363636363636
93630, 0.56521739130435, -0.1, 0.38636363636364
93631, 0.58695652173913, -0.1, 0.40909090909091
93632, 0.56521739130435, -0.075, 0.40909090909091
93633, 0.56521739130435, -0.1, 0.43181818181818
93634, 0.58695652173913, -0.1, 0.45454545454545
93635, 0.56521739130435, -0.075, 0.45454545454545
93636, 0.56521739130435, -0.1, 0.47727272727273
93637, 0.52173913043478, -0.1, 0.022727272727273
93638, 0.54347826086956, -0.1, 0.045454545454545
93639, 0.52173913043478, -0.075, 0.045454545454545
93640, 0.52173913043478, -0.1, 0.068181818181818
93641, 0.54347826086956, -0.1, 0.090909090909091
93642, 0.52173913043478, -0.075, 0.090909090909091
93643, 0.52173913043478, -0.1, 0.11363636363636
93644, 0.54347826086957, -0.1, 0.13636363636364
93645, 0.52173913043478, -0.075, 0.13636363636364
93646, 0.52173913043478, -0.1, 0.15909090909091
93647, 0.54347826086956, -0.1, 0.18181818181818
93648, 0.52173913043478, -0.075, 0.18181818181818
93649, 0.52173913043478, -0.1, 0.20454545454545
93650, 0.54347826086956, -0.1, 0.22727272727273
93651, 0.52173913043478, -0.075, 0.22727272727273
93652, 0.52173913043478, -0.1, 0.25
93653, 0.54347826086956, -0.1, 0.27272727272727
93654, 0.52173913043478, -0.075, 0.27272727272727
93655, 0.52173913043478, -0.1, 0.29545454545455
93656, 0.54347826086956, -0.1, 0.31818181818182
93657, 0.52173913043478, -0.075, 0.31818181818182
93658, 0.52173913043478, -0.1, 0.34090909090909
93659, 0.54347826086957, -0.1, 0.36363636363636
93660, 0.52173913043478, -0.075, 0.36363636363636
93661, 0.52173913043478, -0.1, 0.38636363636364
93662, 0.54347826086956, -0.1, 0.40909090909091
93663, 0.52173913043478, -0.075, 0.40909090909091
93664, 0.52173913043478, -0.1, 0.43181818181818
93665, 0.54347826086956, -0.1, 0.45454545454545
93666, 0.52173913043478, -0.075, 0.45454545454545
93667, 0.52173913043478, -0.1, 0.47727272727273
93668, 0.47826086956522, -0.1, 0.022727272727273
93669, 0.5, -0.1, 0.045454545454545
93670, 0.47826086956522, -0.075, 0.045454545454545
93671, 0.47826086956522, -0.1, 0.068181818181818
93672, 0.5, -0.1, 0.090909090909091
93673, 0.47826086956522, -0.075, 0.090909090909091
93674, 0.47826086956522, -0.1, 0.11363636363636
93675, 0.5, -0.1, 0.13636363636364
93676, 0.47826086956522, -0.075, 0.13636363636364
93677, 0.47826086956522, -0.1, 0.15909090909091
93678, 0.5, -0.1, 0.18181818181818
93679, 0.47826086956522, -0.075, 0.18181818181818
93680, 0.47826086956522, -0.1, 0.20454545454545
93681, 0.5, -0.1, 0.22727272727273
93682, 0.47826086956522, -0.075, 0.22727272727273
93683, 0.47826086956522, -0.1, 0.25
93684, 0.5, -0.1, 0.27272727272727
93685, 0.47826086956522, -0.075, 0.27272727272727
93686, 0.47826086956522, -0.1, 0.29545454545455
93687, 0.5, -0.1, 0.31818181818182
93688, 0.47826086956522, -0.075, 0.31818181818182
93689, 0.47826086956522, -0.1, 0.34090909090909
93690, 0.5, -0.1, 0.36363636363636
93691, 0.47826086956522, -0.075, 0.36363636363636
93692, 0.47826086956522, -0.1, 0.38636363636364
93693, 0.5, -0.1, 0.40909090909091
93694, 0.47826086956522, -0.075, 0.40909090909091
93695, 0.47826086956522, -0.1, 0.43181818181818
93696, 0.5, -0.1, 0.45454545454545
93697, 0.47826086956522, -0.075, 0.45454545454545
93698, 0.47826086956522, -0.1, 0.47727272727273
93699, 0.43478260869565, -0.1, 0.022727272727273
93700, 0.45652173913043, -0.1, 0.045454545454545
93701, 0.43478260869565, -0.075, 0.045454545454545
93702, 0.43478260869565, -0.1, 0.068181818181818
93703, 0.45652173913043, -0.1, 0.090909090909091
93704, 0.43478260869565, -0.075, 0.090909090909091
93705, 0.43478260869565, -0.1, 0.11363636363636
93706, 0.45652173913043, -0.1, 0.13636363636364
93707, 0.43478260869565, -0.075, 0.13636363636364
93708, 0.43478260869565, -0.1, 0.15909090909091
93709, 0.45652173913043, -0.1, 0.18181818181818
93710, 0.43478260869565, -0.075, 0.18181818181818
93711, 0.43478260869565, -0.1, 0.20454545454545
93712, 0.45652173913043, -0.1, 0.22727272727273
93713, 0.43478260869565, -0.075, 0.22727272727273
93714, 0.43478260869565, -0.1, 0.25
93715, 0.45652173913043, -0.1, 0.27272727272727
93716, 0.43478260869565, -0.075, 0.27272727272727
93717, 0.43478260869565, -0.1, 0.29545454545455
93718, 0.45652173913043, -0.1, 0.31818181818182
93719, 0.43478260869565, -0.075, 0.31818181818182
93720, 0.43478260869565, -0.1, 0.34090909090909
93721, 0.45652173913043, -0.1, 0.36363636363636
93722, 0.43478260869565, -0.075, 0.36363636363636
93723, 0.43478260869565, -0.1, 0.38636363636364
93724, 0.45652173913043, -0.1, 0.40909090909091
93725, 0.43478260869565, -0.075, 0.40909090909091
93726, 0.43478260869565, -0.1, 0.43181818181818
93727, 0.45652173913043, -0.1, 0.45454545454545
93728, 0.43478260869565, -0.075, 0.45454545454545
93729, 0.43478260869565, -0.1, 0.47727272727273
93730, 0.39130434782609, -0.1, 0.022727272727273
93731, 0.41304347826087, -0.1, 0.045454545454545
93732, 0.39130434782609, -0.075, 0.045454545454545
93733, 0.39130434782609, -0.1, 0.068181818181818
93734, 0.41304347826087, -0.1, 0.090909090909091
93735, 0.39130434782609, -0.075, 0.090909090909091
93736, 0.39130434782609, -0.1, 0.11363636363636
93737, 0.41304347826087, -0.1, 0.13636363636364
93738, 0.39130434782609, -0.075, 0.13636363636364
93739, 0.39130434782609, -0.1, 0.15909090909091
93740, 0.41304347826087, -0.1, 0.18181818181818
93741, 0.39130434782609, -0.075, 0.18181818181818
93742, 0.39130434782609, -0.1, 0.20454545454545
93743, 0.41304347826087, -0.1, 0.22727272727273
93744, 0.39130434782609, -0.075, 0.22727272727273
93745, 0.39130434782609, -0.1, 0.25
93746, 0.41304347826087, -0.1, 0.27272727272727
93747, 0.39130434782609, -0.075, 0.27272727272727
93748, 0.39130434782609, -0.1, 0.29545454545455
93749, 0.41304347826087, -0.1, 0.31818181818182
93750, 0.39130434782609, -0.075, 0.31818181818182
93751, 0.39130434782609, -0.1, 0.34090909090909
93752, 0.41304347826087, -0.1, 0.36363636363636
93753, 0.39130434782609, -0.075, 0.36363636363636
93754, 0.39130434782609, -0.1, 0.38636363636364
93755, 0.41304347826087, -0.1, 0.40909090909091
93756, 0.39130434782609, -0.075, 0.40909090909091
93757, 0.39130434782609, -0.1, 0.43181818181818
93758, 0.41304347826087, -0.1, 0.45454545454545
93759, 0.39130434782609, -0.075, 0.45454545454545
93760, 0.39130434782609, -0.1, 0.47727272727273
93761, 0.34782608695652, -0.1, 0.022727272727273
93762, 0.3695652173913, -0.1, 0.045454545454545
93763, 0.34782608695652, -0.075, 0.045454545454545
93764, 0.34782608695652, -0.1, 0.068181818181818
93765, 0.3695652173913, -0.1, 0.090909090909091
93766, 0.34782608695652, -0.075, 0.090909090909091
93767, 0.34782608695652, -0.1, 0.11363636363636
93768, 0.3695652173913, -0.1, 0.13636363636364
93769, 0.34782608695652, -0.075, 0.13636363636364
93770, 0.34782608695652, -0.1, 0.15909090909091
93771, 0.3695652173913, -0.1, 0.18181818181818
93772, 0.34782608695652, -0.075, 0.18181818181818
93773, 0.34782608695652, -0.1, 0.20454545454545
93774, 0.3695652173913, -0.1, 0.22727272727273
93775, 0.34782608695652, -0.075, 0.22727272727273
93776, 0.34782608695652, -0.1, 0.25
93777, 0.3695652173913, -0.1, 0.27272727272727
93778, 0.34782608695652, -0.075, 0.27272727272727
93779, 0.34782608695652, -0.1, 0.29545454545455
93780, 0.3695652173913, -0.1, 0.31818181818182
93781, 0.34782608695652, -0.075, 0.31818181818182
93782, 0.34782608695652, -0.1, 0.34090909090909
93783, 0.3695652173913, -0.1, 0.36363636363636
93784, 0.34782608695652, -0.075, 0.36363636363636
93785, 0.34782608695652, -0.1, 0.38636363636364
93786, 0.3695652173913, -0.1, 0.40909090909091
93787, 0.34782608695652, -0.075, 0.40909090909091
93788, 0.34782608695652, -0.1, 0.43181818181818
93789, 0.3695652173913, -0.1, 0.45454545454545
93790, 0.34782608695652, -0.075, 0.45454545454545
93791, 0.34782608695652, -0.1, 0.47727272727273
93792, 0.30434782608696, -0.1, 0.022727272727273
93793, 0.32608695652174, -0.1, 0.045454545454545
93794, 0.30434782608696, -0.075, 0.045454545454545
93795, 0.30434782608696, -0.1, 0.068181818181818
93796, 0.32608695652174, -0.1, 0.090909090909091
93797, 0.30434782608696, -0.075, 0.090909090909091
93798, 0.30434782608696, -0.1, 0.11363636363636
93799, 0.32608695652174, -0.1, 0.13636363636364
93800, 0.30434782608696, -0.075, 0.13636363636364
93801, 0.30434782608696, -0.1, 0.15909090909091
93802, 0.32608695652174, -0.1, 0.18181818181818
93803, 0.30434782608696, -0.075, 0.18181818181818
93804, 0.30434782608696, -0.1, 0.20454545454545
93805, 0.32608695652174, -0.1, 0.22727272727273
93806, 0.30434782608696, -0.075, 0.22727272727273
93807, 0.30434782608696, -0.1, 0.25
93808, 0.32608695652174, -0.1, 0.27272727272727
93809, 0.30434782608696, -0.075, 0.27272727272727
93810, 0.30434782608696, -0.1, 0.29545454545455
93811, 0.32608695652174, -0.1, 0.31818181818182
93812, 0.30434782608696, -0.075, 0.31818181818182
93813, 0.30434782608696, -0.1, 0.34090909090909
93814, 0.32608695652174, -0.1, 0.36363636363636
93815, 0.30434782608696, -0.075, 0.36363636363636
93816, 0.30434782608696, -0.1, 0.38636363636364
93817, 0.32608695652174, -0.1, 0.40909090909091
93818, 0.30434782608696, -0.075, 0.40909090909091
93819, 0.30434782608696, -0.1, 0.43181818181818
93820, 0.32608695652174, -0.1, 0.45454545454545
93821, 0.30434782608696, -0.075, 0.45454545454545
93822, 0.30434782608696, -0.1, 0.47727272727273
93823, 0.26086956521739, -0.1, 0.022727272727273
93824, 0.28260869565217, -0.1, 0.045454545454545
93825, 0.26086956521739, -0.075, 0.045454545454545
93826, 0.26086956521739, -0.1, 0.068181818181818
93827, 0.28260869565217, -0.1, 0.090909090909091
93828, 0.26086956521739, -0.075, 0.090909090909091
93829, 0.26086956521739, -0.1, 0.11363636363636
93830, 0.28260869565217, -0.1, 0.13636363636364
93831, 0.26086956521739, -0.075, 0.13636363636364
93832, 0.26086956521739, -0.1, 0.15909090909091
93833, 0.28260869565217, -0.1, 0.18181818181818
93834, 0.26086956521739, -0.075, 0.18181818181818
93835, 0.26086956521739, -0.1, 0.20454545454545
93836, 0.28260869565217, -0.1, 0.22727272727273
93837, 0.26086956521739, -0.075, 0.22727272727273
93838, 0.26086956521739, -0.1, 0.25
93839, 0.28260869565217, -0.1, 0.27272727272727
93840, 0.26086956521739, -0.075, 0.27272727272727
93841, 0.26086956521739, -0.1, 0.29545454545455
93842, 0.28260869565217, -0.1, 0.31818181818182
93843, 0.26086956521739, -0.075, 0.31818181818182
93844, 0.26086956521739, -0.1, 0.34090909090909
93845, 0.28260869565217, -0.1, 0.36363636363636
93846, 0.26086956521739, -0.075, 0.36363636363636
93847, 0.26086956521739, -0.1, 0.38636363636364
93848, 0.28260869565217, -0.1, 0.40909090909091
93849, 0.26086956521739, -0.075, 0.40909090909091
93850, 0.26086956521739, -0.1, 0.43181818181818
93851, 0.28260869565217, -0.1, 0.45454545454545
93852, 0.26086956521739, -0.075, 0.45454545454545
93853, 0.26086956521739, -0.1, 0.47727272727273
93854, 0.21739130434783, -0.1, 0.022727272727273
93855, 0.23913043478261, -0.1, 0.045454545454545
93856, 0.21739130434783, -0.075, 0.045454545454545
93857, 0.21739130434783, -0.1, 0.068181818181818
93858, 0.23913043478261, -0.1, 0.090909090909091
93859, 0.21739130434783, -0.075, 0.090909090909091
93860, 0.21739130434783, -0.1, 0.11363636363636
93861, 0.23913043478261, -0.1, 0.13636363636364
93862, 0.21739130434783, -0.075, 0.13636363636364
93863, 0.21739130434783, -0.1, 0.15909090909091
93864, 0.23913043478261, -0.1, 0.18181818181818
93865, 0.21739130434783, -0.075, 0.18181818181818
93866, 0.21739130434783, -0.1, 0.20454545454545
93867, 0.23913043478261, -0.1, 0.22727272727273
93868, 0.21739130434783, -0.075, 0.22727272727273
93869, 0.21739130434783, -0.1, 0.25
93870, 0.23913043478261, -0.1, 0.27272727272727
93871, 0.21739130434783, -0.075, 0.27272727272727
93872, 0.21739130434783, -0.1, 0.29545454545455
93873, 0.23913043478261, -0.1, 0.31818181818182
93874, 0.21739130434783, -0.075, 0.31818181818182
93875, 0.21739130434783, -0.1, 0.34090909090909
93876, 0.23913043478261, -0.1, 0.36363636363636
93877, 0.21739130434783, -0.075, 0.36363636363636
93878, 0.21739130434783, -0.1, 0.38636363636364
93879, 0.23913043478261, -0.1, 0.40909090909091
93880, 0.21739130434783, -0.075, 0.40909090909091
93881, 0.21739130434783, -0.1, 0.43181818181818
93882, 0.23913043478261, -0.1, 0.45454545454545
93883, 0.21739130434783, -0.075, 0.45454545454545
93884, 0.21739130434783, -0.1, 0.47727272727273
93885, 0.17391304347826, -0.1, 0.022727272727273
93886, 0.19565217391304, -0.1, 0.045454545454545
93887, 0.17391304347826, -0.075, 0.045454545454545
93888, 0.17391304347826, -0.1, 0.068181818181818
93889, 0.19565217391304, -0.1, 0.090909090909091
93890, 0.17391304347826, -0.075, 0.090909090909091
93891, 0.17391304347826, -0.1, 0.11363636363636
93892, 0.19565217391304, -0.1, 0.13636363636364
93893, 0.17391304347826, -0.075, 0.13636363636364
93894, 0.17391304347826, -0.1, 0.15909090909091
93895, 0.19565217391304, -0.1, 0.18181818181818
93896, 0.17391304347826, -0.075, 0.18181818181818
93897, 0.17391304347826, -0.1, 0.20454545454545
93898, 0.19565217391304, -0.1, 0.22727272727273
93899, 0.17391304347826, -0.075, 0.22727272727273
93900, 0.17391304347826, -0.1, 0.25
93901, 0.19565217391304, -0.1, 0.27272727272727
93902, 0.17391304347826, -0.075, 0.27272727272727
93903, 0.17391304347826, -0.1, 0.29545454545455
93904, 0.19565217391304, -0.1, 0.31818181818182
93905, 0.17391304347826, -0.075, 0.31818181818182
93906, 0.17391304347826, -0.1, 0.34090909090909
93907, 0.19565217391304, -0.1, 0.36363636363636
93908, 0.17391304347826, -0.075, 0.36363636363636
93909, 0.17391304347826, -0.1, 0.38636363636364
93910, 0.19565217391304, -0.1, 0.40909090909091
93911, 0.17391304347826, -0.075, 0.40909090909091
93912, 0.17391304347826, -0.1, 0.43181818181818
93913, 0.19565217391304, -0.1, 0.45454545454545
93914, 0.17391304347826, -0.075, 0.45454545454545
93915, 0.17391304347826, -0.1, 0.47727272727273
93916, 0.1304347826087, -0.1, 0.022727272727273
93917, 0.15217391304348, -0.1, 0.045454545454545
93918, 0.1304347826087, -0.075, 0.045454545454545
93919, 0.1304347826087, -0.1, 0.068181818181818
93920, 0.15217391304348, -0.1, 0.090909090909091
93921, 0.1304347826087, -0.075, 0.090909090909091
93922, 0.1304347826087, -0.1, 0.11363636363636
93923, 0.15217391304348, -0.1, 0.13636363636364
93924, 0.1304347826087, -0.075, 0.13636363636364
93925, 0.1304347826087, -0.1, 0.15909090909091
93926, 0.15217391304348, -0.1, 0.18181818181818
93927, 0.1304347826087, -0.075, 0.18181818181818
93928, 0.1304347826087, -0.1, 0.20454545454545
93929, 0.15217391304348, -0.1, 0.22727272727273
93930, 0.1304347826087, -0.075, 0.22727272727273
93931, 0.1304347826087, -0.1, 0.25
93932, 0.15217391304348, -0.1, 0.27272727272727
93933, 0.1304347826087, -0.075, 0.27272727272727
93934, 0.1304347826087, -0.1, 0.29545454545455
93935, 0.15217391304348, -0.1, 0.31818181818182
93936, 0.1304347826087, -0.075, 0.31818181818182
93937, 0.1304347826087, -0.1, 0.34090909090909
93938, 0.15217391304348, -0.1, 0.36363636363636
93939, 0.1304347826087, -0.075, 0.36363636363636
93940, 0.1304347826087, -0.1, 0.38636363636364
93941, 0.15217391304348, -0.1, 0.40909090909091
93942, 0.1304347826087, -0.075, 0.40909090909091
93943, 0.1304347826087, -0.1, 0.43181818181818
93944, 0.15217391304348, -0.1, 0.45454545454545
93945, 0.1304347826087, -0.075, 0.45454545454545
93946, 0.1304347826087, -0.1, 0.47727272727273
93947, 0.08695652173913, -0.1, 0.022727272727273
93948, 0.10869565217391, -0.1, 0.045454545454545
93949, 0.08695652173913, -0.075, 0.045454545454545
93950, 0.08695652173913, -0.1, 0.068181818181818
93951, 0.10869565217391, -0.1, 0.090909090909091
93952, 0.08695652173913, -0.075, 0.090909090909091
93953, 0.08695652173913, -0.1, 0.11363636363636
93954, 0.10869565217391, -0.1, 0.13636363636364
93955, 0.08695652173913, -0.075, 0.13636363636364
93956, 0.08695652173913, -0.1, 0.15909090909091
93957, 0.10869565217391, -0.1, 0.18181818181818
93958, 0.08695652173913, -0.075, 0.18181818181818
93959, 0.08695652173913, -0.1, 0.20454545454545
93960, 0.10869565217391, -0.1, 0.22727272727273
93961, 0.08695652173913, -0.075, 0.22727272727273
93962, 0.08695652173913, -0.1, 0.25
93963, 0.10869565217391, -0.1, 0.27272727272727
93964, 0.08695652173913, -0.075, 0.27272727272727
93965, 0.08695652173913, -0.1, 0.29545454545455
93966, 0.10869565217391, -0.1, 0.31818181818182
93967, 0.08695652173913, -0.075, 0.31818181818182
93968, 0.08695652173913, -0.1, 0.34090909090909
93969, 0.10869565217391, -0.1, 0.36363636363636
93970, 0.08695652173913, -0.075, 0.36363636363636
93971, 0.08695652173913, -0.1, 0.38636363636364
93972, 0.10869565217391, -0.1, 0.40909090909091
93973, 0.08695652173913, -0.075, 0.40909090909091
93974, 0.08695652173913, -0.1, 0.43181818181818
93975, 0.10869565217391, -0.1, 0.45454545454545
93976, 0.08695652173913, -0.075, 0.45454545454545
93977, 0.08695652173913, -0.1, 0.47727272727273
93978, 0.043478260869565, -0.1, 0.022727272727273
93979, 0.065217391304348, -0.1, 0.045454545454545
93980, 0.043478260869565, -0.075, 0.045454545454545
93981, 0.043478260869565, -0.1, 0.068181818181818
93982, 0.065217391304348, -0.1, 0.090909090909091
93983, 0.043478260869565, -0.075, 0.090909090909091
93984, 0.043478260869565, -0.1, 0.11363636363636
93985, 0.065217391304348, -0.1, 0.13636363636364
93986, 0.043478260869565, -0.075, 0.13636363636364
93987, 0.043478260869565, -0.1, 0.15909090909091
93988, 0.065217391304348, -0.1, 0.18181818181818
93989, 0.043478260869565, -0.075, 0.18181818181818
93990, 0.043478260869565, -0.1, 0.20454545454545
93991, 0.065217391304348, -0.1, 0.22727272727273
93992, 0.043478260869565, -0.075, 0.22727272727273
93993, 0.043478260869565, -0.1, 0.25
93994, 0.065217391304348, -0.1, 0.27272727272727
93995, 0.043478260869565, -0.075, 0.27272727272727
93996, 0.043478260869565, -0.1, 0.29545454545455
93997, 0.065217391304348, -0.1, 0.31818181818182
93998, 0.043478260869565, -0.075, 0.31818181818182
93999, 0.043478260869565, -0.1, 0.34090909090909
94000, 0.065217391304348, -0.1, 0.36363636363636
94001, 0.043478260869565, -0.075, 0.36363636363636
94002, 0.043478260869565, -0.1, 0.38636363636364
94003, 0.065217391304348, -0.1, 0.40909090909091
94004, 0.043478260869565, -0.075, 0.40909090909091
94005, 0.043478260869565, -0.1, 0.43181818181818
94006, 0.065217391304348, -0.1, 0.45454545454545
94007, 0.043478260869565, -0.075, 0.45454545454545
94008, 0.043478260869565, -0.1, 0.47727272727273
94009, 0.021739130434783, -0.1, 0.045454545454545
94010, 0.021739130434783, -0.1, 0.090909090909091
94011, 0.021739130434783, -0.1, 0.13636363636364
94012, 0.021739130434783, -0.1, 0.18181818181818
94013, 0.021739130434783, -0.1, 0.22727272727273
94014, 0.021739130434783, -0.1, 0.27272727272727
94015, 0.021739130434783, -0.1, 0.31818181818182
94016, 0.021739130434783, -0.1, 0.36363636363636
94017, 0.021739130434783, -0.1, 0.40909090909091
94018, 0.021739130434783, -0.1, 0.45454545454545
94019, 0.95652173913043, -0.15, 0.022727272727273
94020, 0.97826086956522, -0.15, 0.045454545454545
94021, 0.95652173913043, -0.125, 0.045454545454545
94022, 0.95652173913043, -0.15, 0.068181818181818
94023, 0.97826086956522, -0.15, 0.090909090909091
94024, 0.95652173913043, -0.125, 0.090909090909091
94025, 0.95652173913043, -0.15, 0.11363636363636
94026, 0.97826086956522, -0.15, 0.13636363636364
94027, 0.95652173913044, -0.125, 0.13636363636364
94028, 0.95652173913044, -0.15, 0.15909090909091
94029, 0.97826086956522, -0.15, 0.18181818181818
94030, 0.95652173913044, -0.125, 0.18181818181818
94031, 0.95652173913044, -0.15, 0.20454545454545
94032, 0.97826086956522, -0.15, 0.22727272727273
94033, 0.95652173913044, -0.125, 0.22727272727273
94034, 0.95652173913044, -0.15, 0.25
94035, 0.97826086956522, -0.15, 0.27272727272727
94036, 0.95652173913044, -0.125, 0.27272727272727
94037, 0.95652173913044, -0.15, 0.29545454545455
94038, 0.97826086956522, -0.15, 0.31818181818182
94039, 0.95652173913044, -0.125, 0.31818181818182
94040, 0.95652173913043, -0.15, 0.34090909090909
94041, 0.97826086956522, -0.15, 0.36363636363636
94042, 0.95652173913043, -0.125, 0.36363636363636
94043, 0.95652173913043, -0.15, 0.38636363636364
94044, 0.97826086956522, -0.15, 0.40909090909091
94045, 0.95652173913043, -0.125, 0.40909090909091
94046, 0.95652173913043, -0.15, 0.43181818181818
94047, 0.97826086956522, -0.15, 0.45454545454545
94048, 0.95652173913044, -0.125, 0.45454545454545
94049, 0.95652173913043, -0.15, 0.47727272727273
94050, 0.91304347826087, -0.15, 0.022727272727273
94051, 0.93478260869565, -0.15, 0.045454545454545
94052, 0.91304347826087, -0.125, 0.045454545454545
94053, 0.91304347826087, -0.15, 0.068181818181818
94054, 0.93478260869565, -0.15, 0.090909090909091
94055, 0.91304347826087, -0.125, 0.090909090909091
94056, 0.91304347826087, -0.15, 0.11363636363636
94057, 0.93478260869565, -0.15, 0.13636363636364
94058, 0.91304347826087, -0.125, 0.13636363636364
94059, 0.91304347826087, -0.15, 0.15909090909091
94060, 0.93478260869565, -0.15, 0.18181818181818
94061, 0.91304347826087, -0.125, 0.18181818181818
94062, 0.91304347826087, -0.15, 0.20454545454545
94063, 0.93478260869565, -0.15, 0.22727272727273
94064, 0.91304347826087, -0.125, 0.22727272727273
94065, 0.91304347826087, -0.15, 0.25
94066, 0.93478260869565, -0.15, 0.27272727272727
94067, 0.91304347826087, -0.125, 0.27272727272727
94068, 0.91304347826087, -0.15, 0.29545454545455
94069, 0.93478260869565, -0.15, 0.31818181818182
94070, 0.91304347826087, -0.125, 0.31818181818182
94071, 0.91304347826087, -0.15, 0.34090909090909
94072, 0.93478260869565, -0.15, 0.36363636363636
94073, 0.91304347826087, -0.125, 0.36363636363636
94074, 0.91304347826087, -0.15, 0.38636363636364
94075, 0.93478260869565, -0.15, 0.40909090909091
94076, 0.91304347826087, -0.125, 0.40909090909091
94077, 0.91304347826087, -0.15, 0.43181818181818
94078, 0.93478260869565, -0.15, 0.45454545454545
94079, 0.91304347826087, -0.125, 0.45454545454545
94080, 0.91304347826087, -0.15, 0.47727272727273
94081, 0.8695652173913, -0.15, 0.022727272727273
94082, 0.89130434782609, -0.15, 0.045454545454545
94083, 0.8695652173913, -0.125, 0.045454545454545
94084, 0.8695652173913, -0.15, 0.068181818181818
94085, 0.89130434782609, -0.15, 0.090909090909091
94086, 0.8695652173913, -0.125, 0.090909090909091
94087, 0.8695652173913, -0.15, 0.11363636363636
94088, 0.89130434782609, -0.15, 0.13636363636364
94089, 0.8695652173913, -0.125, 0.13636363636364
94090, 0.8695652173913, -0.15, 0.15909090909091
94091, 0.89130434782609, -0.15, 0.18181818181818
94092, 0.8695652173913, -0.125, 0.18181818181818
94093, 0.8695652173913, -0.15, 0.20454545454545
94094, 0.89130434782609, -0.15, 0.22727272727273
94095, 0.8695652173913, -0.125, 0.22727272727273
94096, 0.8695652173913, -0.15, 0.25
94097, 0.89130434782609, -0.15, 0.27272727272727
94098, 0.8695652173913, -0.125, 0.27272727272727
94099, 0.8695652173913, -0.15, 0.29545454545455
94100, 0.89130434782609, -0.15, 0.31818181818182
94101, 0.8695652173913, -0.125, 0.31818181818182
94102, 0.8695652173913, -0.15, 0.34090909090909
94103, 0.89130434782609, -0.15, 0.36363636363636
94104, 0.8695652173913, -0.125, 0.36363636363636
94105, 0.8695652173913, -0.15, 0.38636363636364
94106, 0.89130434782609, -0.15, 0.40909090909091
94107, 0.8695652173913, -0.125, 0.40909090909091
94108, 0.8695652173913, -0.15, 0.43181818181818
94109, 0.89130434782609, -0.15, 0.45454545454545
94110, 0.8695652173913, -0.125, 0.45454545454545
94111, 0.8695652173913, -0.15, 0.47727272727273
94112, 0.82608695652174, -0.15, 0.022727272727273
94113, 0.84782608695652, -0.15, 0.045454545454545
94114, 0.82608695652174, -0.125, 0.045454545454545
94115, 0.82608695652174, -0.15, 0.068181818181818
94116, 0.84782608695652, -0.15, 0.090909090909091
94117, 0.82608695652174, -0.125, 0.090909090909091
94118, 0.82608695652174, -0.15, 0.11363636363636
94119, 0.84782608695652, -0.15, 0.13636363636364
94120, 0.82608695652174, -0.125, 0.13636363636364
94121, 0.82608695652174, -0.15, 0.15909090909091
94122, 0.84782608695652, -0.15, 0.18181818181818
94123, 0.82608695652174, -0.125, 0.18181818181818
94124, 0.82608695652174, -0.15, 0.20454545454545
94125, 0.84782608695652, -0.15, 0.22727272727273
94126, 0.82608695652174, -0.125, 0.22727272727273
94127, 0.82608695652174, -0.15, 0.25
94128, 0.84782608695652, -0.15, 0.27272727272727
94129, 0.82608695652174, -0.125, 0.27272727272727
94130, 0.82608695652174, -0.15, 0.29545454545455
94131, 0.84782608695652, -0.15, 0.31818181818182
94132, 0.82608695652174, -0.125, 0.31818181818182
94133, 0.82608695652174, -0.15, 0.34090909090909
94134, 0.84782608695652, -0.15, 0.36363636363636
94135, 0.82608695652174, -0.125, 0.36363636363636
94136, 0.82608695652174, -0.15, 0.38636363636364
94137, 0.84782608695652, -0.15, 0.40909090909091
94138, 0.82608695652174, -0.125, 0.40909090909091
94139, 0.82608695652174, -0.15, 0.43181818181818
94140, 0.84782608695652, -0.15, 0.45454545454545
94141, 0.82608695652174, -0.125, 0.45454545454545
94142, 0.82608695652174, -0.15, 0.47727272727273
94143, 0.78260869565217, -0.15, 0.022727272727273
94144, 0.80434782608696, -0.15, 0.045454545454545
94145, 0.78260869565217, -0.125, 0.045454545454545
94146, 0.78260869565217, -0.15, 0.068181818181818
94147, 0.80434782608696, -0.15, 0.090909090909091
94148, 0.78260869565217, -0.125, 0.090909090909091
94149, 0.78260869565217, -0.15, 0.11363636363636
94150, 0.80434782608696, -0.15, 0.13636363636364
94151, 0.78260869565217, -0.125, 0.13636363636364
94152, 0.78260869565217, -0.15, 0.15909090909091
94153, 0.80434782608696, -0.15, 0.18181818181818
94154, 0.78260869565217, -0.125, 0.18181818181818
94155, 0.78260869565217, -0.15, 0.20454545454545
94156, 0.80434782608696, -0.15, 0.22727272727273
94157, 0.78260869565217, -0.125, 0.22727272727273
94158, 0.78260869565217, -0.15, 0.25
94159, 0.80434782608696, -0.15, 0.27272727272727
94160, 0.78260869565217, -0.125, 0.27272727272727
94161, 0.78260869565217, -0.15, 0.29545454545455
94162, 0.80434782608696, -0.15, 0.31818181818182
94163, 0.78260869565217, -0.125, 0.31818181818182
94164, 0.78260869565217, -0.15, 0.34090909090909
94165, 0.80434782608696, -0.15, 0.36363636363636
94166, 0.78260869565217, -0.125, 0.36363636363636
94167, 0.78260869565217, -0.15, 0.38636363636364
94168, 0.80434782608696, -0.15, 0.40909090909091
94169, 0.78260869565217, -0.125, 0.40909090909091
94170, 0.78260869565217, -0.15, 0.43181818181818
94171, 0.80434782608696, -0.15, 0.45454545454545
94172, 0.78260869565217, -0.125, 0.45454545454545
94173, 0.78260869565217, -0.15, 0.47727272727273
94174, 0.73913043478261, -0.15, 0.022727272727273
94175, 0.76086956521739, -0.15, 0.045454545454545
94176, 0.73913043478261, -0.125, 0.045454545454545
94177, 0.73913043478261, -0.15, 0.068181818181818
94178, 0.76086956521739, -0.15, 0.090909090909091
94179, 0.73913043478261, -0.125, 0.090909090909091
94180, 0.73913043478261, -0.15, 0.11363636363636
94181, 0.76086956521739, -0.15, 0.13636363636364
94182, 0.73913043478261, -0.125, 0.13636363636364
94183, 0.73913043478261, -0.15, 0.15909090909091
94184, 0.76086956521739, -0.15, 0.18181818181818
94185, 0.73913043478261, -0.125, 0.18181818181818
94186, 0.73913043478261, -0.15, 0.20454545454545
94187, 0.76086956521739, -0.15, 0.22727272727273
94188, 0.73913043478261, -0.125, 0.22727272727273
94189, 0.73913043478261, -0.15, 0.25
94190, 0.76086956521739, -0.15, 0.27272727272727
94191, 0.73913043478261, -0.125, 0.27272727272727
94192, 0.73913043478261, -0.15, 0.29545454545455
94193, 0.76086956521739, -0.15, 0.31818181818182
94194, 0.73913043478261, -0.125, 0.31818181818182
94195, 0.73913043478261, -0.15, 0.34090909090909
94196, 0.76086956521739, -0.15, 0.36363636363636
94197, 0.73913043478261, -0.125, 0.36363636363636
94198, 0.73913043478261, -0.15, 0.38636363636364
94199, 0.76086956521739, -0.15, 0.40909090909091
94200, 0.73913043478261, -0.125, 0.40909090909091
94201, 0.73913043478261, -0.15, 0.43181818181818
94202, 0.76086956521739, -0.15, 0.45454545454545
94203, 0.73913043478261, -0.125, 0.45454545454545
94204, 0.73913043478261, -0.15, 0.47727272727273
94205, 0.69565217391304, -0.15, 0.022727272727273
94206, 0.71739130434783, -0.15, 0.045454545454545
94207, 0.69565217391304, -0.125, 0.045454545454545
94208, 0.69565217391304, -0.15, 0.068181818181818
94209, 0.71739130434783, -0.15, 0.090909090909091
94210, 0.69565217391304, -0.125, 0.090909090909091
94211, 0.69565217391304, -0.15, 0.11363636363636
94212, 0.71739130434783, -0.15, 0.13636363636364
94213, 0.69565217391304, -0.125, 0.13636363636364
94214, 0.69565217391304, -0.15, 0.15909090909091
94215, 0.71739130434783, -0.15, 0.18181818181818
94216, 0.69565217391304, -0.125, 0.18181818181818
94217, 0.69565217391304, -0.15, 0.20454545454545
94218, 0.71739130434783, -0.15, 0.22727272727273
94219, 0.69565217391304, -0.125, 0.22727272727273
94220, 0.69565217391304, -0.15, 0.25
94221, 0.71739130434783, -0.15, 0.27272727272727
94222, 0.69565217391304, -0.125, 0.27272727272727
94223, 0.69565217391304, -0.15, 0.29545454545455
94224, 0.71739130434783, -0.15, 0.31818181818182
94225, 0.69565217391304, -0.125, 0.31818181818182
94226, 0.69565217391304, -0.15, 0.34090909090909
94227, 0.71739130434783, -0.15, 0.36363636363636
94228, 0.69565217391304, -0.125, 0.36363636363636
94229, 0.69565217391304, -0.15, 0.38636363636364
94230, 0.71739130434783, -0.15, 0.40909090909091
94231, 0.69565217391304, -0.125, 0.40909090909091
94232, 0.69565217391304, -0.15, 0.43181818181818
94233, 0.71739130434783, -0.15, 0.45454545454545
94234, 0.69565217391304, -0.125, 0.45454545454545
94235, 0.69565217391304, -0.15, 0.47727272727273
94236, 0.65217391304348, -0.15, 0.022727272727273
94237, 0.67391304347826, -0.15, 0.045454545454545
94238, 0.65217391304348, -0.125, 0.045454545454545
94239, 0.65217391304348, -0.15, 0.068181818181818
94240, 0.67391304347826, -0.15, 0.090909090909091
94241, 0.65217391304348, -0.125, 0.090909090909091
94242, 0.65217391304348, -0.15, 0.11363636363636
94243, 0.67391304347826, -0.15, 0.13636363636364
94244, 0.65217391304348, -0.125, 0.13636363636364
94245, 0.65217391304348, -0.15, 0.15909090909091
94246, 0.67391304347826, -0.15, 0.18181818181818
94247, 0.65217391304348, -0.125, 0.18181818181818
94248, 0.65217391304348, -0.15, 0.20454545454545
94249, 0.67391304347826, -0.15, 0.22727272727273
94250, 0.65217391304348, -0.125, 0.22727272727273
94251, 0.65217391304348, -0.15, 0.25
94252, 0.67391304347826, -0.15, 0.27272727272727
94253, 0.65217391304348, -0.125, 0.27272727272727
94254, 0.65217391304348, -0.15, 0.29545454545455
94255, 0.67391304347826, -0.15, 0.31818181818182
94256, 0.65217391304348, -0.125, 0.31818181818182
94257, 0.65217391304348, -0.15, 0.34090909090909
94258, 0.67391304347826, -0.15, 0.36363636363636
94259, 0.65217391304348, -0.125, 0.36363636363636
94260, 0.65217391304348, -0.15, 0.38636363636364
94261, 0.67391304347826, -0.15, 0.40909090909091
94262, 0.65217391304348, -0.125, 0.40909090909091
94263, 0.65217391304348, -0.15, 0.43181818181818
94264, 0.67391304347826, -0.15, 0.45454545454545
94265, 0.65217391304348, -0.125, 0.45454545454545
94266, 0.65217391304348, -0.15, 0.47727272727273
94267, 0.60869565217391, -0.15, 0.022727272727273
94268, 0.6304347826087, -0.15, 0.045454545454545
94269, 0.60869565217391, -0.125, 0.045454545454545
94270, 0.60869565217391, -0.15, 0.068181818181818
94271, 0.6304347826087, -0.15, 0.090909090909091
94272, 0.60869565217391, -0.125, 0.090909090909091
94273, 0.60869565217391, -0.15, 0.11363636363636
94274, 0.6304347826087, -0.15, 0.13636363636364
94275, 0.60869565217391, -0.125, 0.13636363636364
94276, 0.60869565217391, -0.15, 0.15909090909091
94277, 0.6304347826087, -0.15, 0.18181818181818
94278, 0.60869565217391, -0.125, 0.18181818181818
94279, 0.60869565217391, -0.15, 0.20454545454545
94280, 0.6304347826087, -0.15, 0.22727272727273
94281, 0.60869565217391, -0.125, 0.22727272727273
94282, 0.60869565217391, -0.15, 0.25
94283, 0.6304347826087, -0.15, 0.27272727272727
94284, 0.60869565217391, -0.125, 0.27272727272727
94285, 0.60869565217391, -0.15, 0.29545454545455
94286, 0.6304347826087, -0.15, 0.31818181818182
94287, 0.60869565217391, -0.125, 0.31818181818182
94288, 0.60869565217391, -0.15, 0.34090909090909
94289, 0.6304347826087, -0.15, 0.36363636363636
94290, 0.60869565217391, -0.125, 0.36363636363636
94291, 0.60869565217391, -0.15, 0.38636363636364
94292, 0.6304347826087, -0.15, 0.40909090909091
94293, 0.60869565217391, -0.125, 0.40909090909091
94294, 0.60869565217391, -0.15, 0.43181818181818
94295, 0.6304347826087, -0.15, 0.45454545454545
94296, 0.60869565217391, -0.125, 0.45454545454545
94297, 0.60869565217391, -0.15, 0.47727272727273
94298, 0.56521739130435, -0.15, 0.022727272727273
94299, 0.58695652173913, -0.15, 0.045454545454545
94300, 0.56521739130435, -0.125, 0.045454545454545
94301, 0.56521739130435, -0.15, 0.068181818181818
94302, 0.58695652173913, -0.15, 0.090909090909091
94303, 0.56521739130435, -0.125, 0.090909090909091
94304, 0.56521739130435, -0.15, 0.11363636363636
94305, 0.58695652173913, -0.15, 0.13636363636364
94306, 0.56521739130435, -0.125, 0.13636363636364
94307, 0.56521739130435, -0.15, 0.15909090909091
94308, 0.58695652173913, -0.15, 0.18181818181818
94309, 0.56521739130435, -0.125, 0.18181818181818
94310, 0.56521739130435, -0.15, 0.20454545454545
94311, 0.58695652173913, -0.15, 0.22727272727273
94312, 0.56521739130435, -0.125, 0.22727272727273
94313, 0.56521739130435, -0.15, 0.25
94314, 0.58695652173913, -0.15, 0.27272727272727
94315, 0.56521739130435, -0.125, 0.27272727272727
94316, 0.56521739130435, -0.15, 0.29545454545455
94317, 0.58695652173913, -0.15, 0.31818181818182
94318, 0.56521739130435, -0.125, 0.31818181818182
94319, 0.56521739130435, -0.15, 0.34090909090909
94320, 0.58695652173913, -0.15, 0.36363636363636
94321, 0.56521739130435, -0.125, 0.36363636363636
94322, 0.56521739130435, -0.15, 0.38636363636364
94323, 0.58695652173913, -0.15, 0.40909090909091
94324, 0.56521739130435, -0.125, 0.40909090909091
94325, 0.56521739130435, -0.15, 0.43181818181818
94326, 0.58695652173913, -0.15, 0.45454545454545
94327, 0.56521739130435, -0.125, 0.45454545454545
94328, 0.56521739130435, -0.15, 0.47727272727273
94329, 0.52173913043478, -0.15, 0.022727272727273
94330, 0.54347826086956, -0.15, 0.045454545454545
94331, 0.52173913043478, -0.125, 0.045454545454545
94332, 0.52173913043478, -0.15, 0.068181818181818
94333, 0.54347826086956, -0.15, 0.090909090909091
94334, 0.52173913043478, -0.125, 0.090909090909091
94335, 0.52173913043478, -0.15, 0.11363636363636
94336, 0.54347826086957, -0.15, 0.13636363636364
94337, 0.52173913043478, -0.125, 0.13636363636364
94338, 0.52173913043478, -0.15, 0.15909090909091
94339, 0.54347826086956, -0.15, 0.18181818181818
94340, 0.52173913043478, -0.125, 0.18181818181818
94341, 0.52173913043478, -0.15, 0.20454545454545
94342, 0.54347826086956, -0.15, 0.22727272727273
94343, 0.52173913043478, -0.125, 0.22727272727273
94344, 0.52173913043478, -0.15, 0.25
94345, 0.54347826086956, -0.15, 0.27272727272727
94346, 0.52173913043478, -0.125, 0.27272727272727
94347, 0.52173913043478, -0.15, 0.29545454545455
94348, 0.54347826086956, -0.15, 0.31818181818182
94349, 0.52173913043478, -0.125, 0.31818181818182
94350, 0.52173913043478, -0.15, 0.34090909090909
94351, 0.54347826086956, -0.15, 0.36363636363636
94352, 0.52173913043478, -0.125, 0.36363636363636
94353, 0.52173913043478, -0.15, 0.38636363636364
94354, 0.54347826086956, -0.15, 0.40909090909091
94355, 0.52173913043478, -0.125, 0.40909090909091
94356, 0.52173913043478, -0.15, 0.43181818181818
94357, 0.54347826086956, -0.15, 0.45454545454545
94358, 0.52173913043478, -0.125, 0.45454545454545
94359, 0.52173913043478, -0.15, 0.47727272727273
94360, 0.47826086956522, -0.15, 0.022727272727273
94361, 0.5, -0.15, 0.045454545454545
94362, 0.47826086956522, -0.125, 0.045454545454545
94363, 0.47826086956522, -0.15, 0.068181818181818
94364, 0.5, -0.15, 0.090909090909091
94365, 0.47826086956522, -0.125, 0.090909090909091
94366, 0.47826086956522, -0.15, 0.11363636363636
94367, 0.5, -0.15, 0.13636363636364
94368, 0.47826086956522, -0.125, 0.13636363636364
94369, 0.47826086956522, -0.15, 0.15909090909091
94370, 0.5, -0.15, 0.18181818181818
94371, 0.47826086956522, -0.125, 0.18181818181818
94372, 0.47826086956522, -0.15, 0.20454545454545
94373, 0.5, -0.15, 0.22727272727273
94374, 0.47826086956522, -0.125, 0.22727272727273
94375, 0.47826086956522, -0.15, 0.25
94376, 0.5, -0.15, 0.27272727272727
94377, 0.47826086956522, -0.125, 0.27272727272727
94378, 0.47826086956522, -0.15, 0.29545454545455
94379, 0.5, -0.15, 0.31818181818182
94380, 0.47826086956522, -0.125, 0.31818181818182
94381, 0.47826086956522, -0.15, 0.34090909090909
94382, 0.5, -0.15, 0.36363636363636
94383, 0.47826086956522, -0.125, 0.36363636363636
94384, 0.47826086956522, -0.15, 0.38636363636364
94385, 0.5, -0.15, 0.40909090909091
94386, 0.47826086956522, -0.125, 0.40909090909091
94387, 0.47826086956522, -0.15, 0.43181818181818
94388, 0.5, -0.15, 0.45454545454545
94389, 0.47826086956522, -0.125, 0.45454545454545
94390, 0.47826086956522, -0.15, 0.47727272727273
94391, 0.43478260869565, -0.15, 0.022727272727273
94392, 0.45652173913043, -0.15, 0.045454545454545
94393, 0.43478260869565, -0.125, 0.045454545454545
94394, 0.43478260869565, -0.15, 0.068181818181818
94395, 0.45652173913043, -0.15, 0.090909090909091
94396, 0.43478260869565, -0.125, 0.090909090909091
94397, 0.43478260869565, -0.15, 0.11363636363636
94398, 0.45652173913043, -0.15, 0.13636363636364
94399, 0.43478260869565, -0.125, 0.13636363636364
94400, 0.43478260869565, -0.15, 0.15909090909091
94401, 0.45652173913043, -0.15, 0.18181818181818
94402, 0.43478260869565, -0.125, 0.18181818181818
94403, 0.43478260869565, -0.15, 0.20454545454545
94404, 0.45652173913043, -0.15, 0.22727272727273
94405, 0.43478260869565, -0.125, 0.22727272727273
94406, 0.43478260869565, -0.15, 0.25
94407, 0.45652173913043, -0.15, 0.27272727272727
94408, 0.43478260869565, -0.125, 0.27272727272727
94409, 0.43478260869565, -0.15, 0.29545454545455
94410, 0.45652173913043, -0.15, 0.31818181818182
94411, 0.43478260869565, -0.125, 0.31818181818182
94412, 0.43478260869565, -0.15, 0.34090909090909
94413, 0.45652173913043, -0.15, 0.36363636363636
94414, 0.43478260869565, -0.125, 0.36363636363636
94415, 0.43478260869565, -0.15, 0.38636363636364
94416, 0.45652173913043, -0.15, 0.40909090909091
94417, 0.43478260869565, -0.125, 0.40909090909091
94418, 0.43478260869565, -0.15, 0.43181818181818
94419, 0.45652173913043, -0.15, 0.45454545454545
94420, 0.43478260869565, -0.125, 0.45454545454545
94421, 0.43478260869565, -0.15, 0.47727272727273
94422, 0.39130434782609, -0.15, 0.022727272727273
94423, 0.41304347826087, -0.15, 0.045454545454545
94424, 0.39130434782609, -0.125, 0.045454545454545
94425, 0.39130434782609, -0.15, 0.068181818181818
94426, 0.41304347826087, -0.15, 0.090909090909091
94427, 0.39130434782609, -0.125, 0.090909090909091
94428, 0.39130434782609, -0.15, 0.11363636363636
94429, 0.41304347826087, -0.15, 0.13636363636364
94430, 0.39130434782609, -0.125, 0.13636363636364
94431, 0.39130434782609, -0.15, 0.15909090909091
94432, 0.41304347826087, -0.15, 0.18181818181818
94433, 0.39130434782609, -0.125, 0.18181818181818
94434, 0.39130434782609, -0.15, 0.20454545454545
94435, 0.41304347826087, -0.15, 0.22727272727273
94436, 0.39130434782609, -0.125, 0.22727272727273
94437, 0.39130434782609, -0.15, 0.25
94438, 0.41304347826087, -0.15, 0.27272727272727
94439, 0.39130434782609, -0.125, 0.27272727272727
94440, 0.39130434782609, -0.15, 0.29545454545455
94441, 0.41304347826087, -0.15, 0.31818181818182
94442, 0.39130434782609, -0.125, 0.31818181818182
94443, 0.39130434782609, -0.15, 0.34090909090909
94444, 0.41304347826087, -0.15, 0.36363636363636
94445, 0.39130434782609, -0.125, 0.36363636363636
94446, 0.39130434782609, -0.15, 0.38636363636364
94447, 0.41304347826087, -0.15, 0.40909090909091
94448, 0.39130434782609, -0.125, 0.40909090909091
94449, 0.39130434782609, -0.15, 0.43181818181818
94450, 0.41304347826087, -0.15, 0.45454545454545
94451, 0.39130434782609, -0.125, 0.45454545454545
94452, 0.39130434782609, -0.15, 0.47727272727273
94453, 0.34782608695652, -0.15, 0.022727272727273
94454, 0.3695652173913, -0.15, 0.045454545454545
94455, 0.34782608695652, -0.125, 0.045454545454545
94456, 0.34782608695652, -0.15, 0.068181818181818
94457, 0.3695652173913, -0.15, 0.090909090909091
94458, 0.34782608695652, -0.125, 0.090909090909091
94459, 0.34782608695652, -0.15, 0.11363636363636
94460, 0.3695652173913, -0.15, 0.13636363636364
94461, 0.34782608695652, -0.125, 0.13636363636364
94462, 0.34782608695652, -0.15, 0.15909090909091
94463, 0.3695652173913, -0.15, 0.18181818181818
94464, 0.34782608695652, -0.125, 0.18181818181818
94465, 0.34782608695652, -0.15, 0.20454545454545
94466, 0.3695652173913, -0.15, 0.22727272727273
94467, 0.34782608695652, -0.125, 0.22727272727273
94468, 0.34782608695652, -0.15, 0.25
94469, 0.3695652173913, -0.15, 0.27272727272727
94470, 0.34782608695652, -0.125, 0.27272727272727
94471, 0.34782608695652, -0.15, 0.29545454545455
94472, 0.3695652173913, -0.15, 0.31818181818182
94473, 0.34782608695652, -0.125, 0.31818181818182
94474, 0.34782608695652, -0.15, 0.34090909090909
94475, 0.3695652173913, -0.15, 0.36363636363636
94476, 0.34782608695652, -0.125, 0.36363636363636
94477, 0.34782608695652, -0.15, 0.38636363636364
94478, 0.3695652173913, -0.15, 0.40909090909091
94479, 0.34782608695652, -0.125, 0.40909090909091
94480, 0.34782608695652, -0.15, 0.43181818181818
94481, 0.3695652173913, -0.15, 0.45454545454545
94482, 0.34782608695652, -0.125, 0.45454545454545
94483, 0.34782608695652, -0.15, 0.47727272727273
94484, 0.30434782608696, -0.15, 0.022727272727273
94485, 0.32608695652174, -0.15, 0.045454545454545
94486, 0.30434782608696, -0.125, 0.045454545454545
94487, 0.30434782608696, -0.15, 0.068181818181818
94488, 0.32608695652174, -0.15, 0.090909090909091
94489, 0.30434782608696, -0.125, 0.090909090909091
94490, 0.30434782608696, -0.15, 0.11363636363636
94491, 0.32608695652174, -0.15, 0.13636363636364
94492, 0.30434782608696, -0.125, 0.13636363636364
94493, 0.30434782608696, -0.15, 0.15909090909091
94494, 0.32608695652174, -0.15, 0.18181818181818
94495, 0.30434782608696, -0.125, 0.18181818181818
94496, 0.30434782608696, -0.15, 0.20454545454545
94497, 0.32608695652174, -0.15, 0.22727272727273
94498, 0.30434782608696, -0.125, 0.22727272727273
94499, 0.30434782608696, -0.15, 0.25
94500, 0.32608695652174, -0.15, 0.27272727272727
94501, 0.30434782608696, -0.125, 0.27272727272727
94502, 0.30434782608696, -0.15, 0.29545454545455
94503, 0.32608695652174, -0.15, 0.31818181818182
94504, 0.30434782608696, -0.125, 0.31818181818182
94505, 0.30434782608696, -0.15, 0.34090909090909
94506, 0.32608695652174, -0.15, 0.36363636363636
94507, 0.30434782608696, -0.125, 0.36363636363636
94508, 0.30434782608696, -0.15, 0.38636363636364
94509, 0.32608695652174, -0.15, 0.40909090909091
94510, 0.30434782608696, -0.125, 0.40909090909091
94511, 0.30434782608696, -0.15, 0.43181818181818
94512, 0.32608695652174, -0.15, 0.45454545454545
94513, 0.30434782608696, -0.125, 0.45454545454545
94514, 0.30434782608696, -0.15, 0.47727272727273
94515, 0.26086956521739, -0.15, 0.022727272727273
94516, 0.28260869565217, -0.15, 0.045454545454545
94517, 0.26086956521739, -0.125, 0.045454545454545
94518, 0.26086956521739, -0.15, 0.068181818181818
94519, 0.28260869565217, -0.15, 0.090909090909091
94520, 0.26086956521739, -0.125, 0.090909090909091
94521, 0.26086956521739, -0.15, 0.11363636363636
94522, 0.28260869565217, -0.15, 0.13636363636364
94523, 0.26086956521739, -0.125, 0.13636363636364
94524, 0.26086956521739, -0.15, 0.15909090909091
94525, 0.28260869565217, -0.15, 0.18181818181818
94526, 0.26086956521739, -0.125, 0.18181818181818
94527, 0.26086956521739, -0.15, 0.20454545454545
94528, 0.28260869565217, -0.15, 0.22727272727273
94529, 0.26086956521739, -0.125, 0.22727272727273
94530, 0.26086956521739, -0.15, 0.25
94531, 0.28260869565217, -0.15, 0.27272727272727
94532, 0.26086956521739, -0.125, 0.27272727272727
94533, 0.26086956521739, -0.15, 0.29545454545455
94534, 0.28260869565217, -0.15, 0.31818181818182
94535, 0.26086956521739, -0.125, 0.31818181818182
94536, 0.26086956521739, -0.15, 0.34090909090909
94537, 0.28260869565217, -0.15, 0.36363636363636
94538, 0.26086956521739, -0.125, 0.36363636363636
94539, 0.26086956521739, -0.15, 0.38636363636364
94540, 0.28260869565217, -0.15, 0.40909090909091
94541, 0.26086956521739, -0.125, 0.40909090909091
94542, 0.26086956521739, -0.15, 0.43181818181818
94543, 0.28260869565217, -0.15, 0.45454545454545
94544, 0.26086956521739, -0.125, 0.45454545454545
94545, 0.26086956521739, -0.15, 0.47727272727273
94546, 0.21739130434783, -0.15, 0.022727272727273
94547, 0.23913043478261, -0.15, 0.045454545454545
94548, 0.21739130434783, -0.125, 0.045454545454545
94549, 0.21739130434783, -0.15, 0.068181818181818
94550, 0.23913043478261, -0.15, 0.090909090909091
94551, 0.21739130434783, -0.125, 0.090909090909091
94552, 0.21739130434783, -0.15, 0.11363636363636
94553, 0.23913043478261, -0.15, 0.13636363636364
94554, 0.21739130434783, -0.125, 0.13636363636364
94555, 0.21739130434783, -0.15, 0.15909090909091
94556, 0.23913043478261, -0.15, 0.18181818181818
94557, 0.21739130434783, -0.125, 0.18181818181818
94558, 0.21739130434783, -0.15, 0.20454545454545
94559, 0.23913043478261, -0.15, 0.22727272727273
94560, 0.21739130434783, -0.125, 0.22727272727273
94561, 0.21739130434783, -0.15, 0.25
94562, 0.23913043478261, -0.15, 0.27272727272727
94563, 0.21739130434783, -0.125, 0.27272727272727
94564, 0.21739130434783, -0.15, 0.29545454545455
94565, 0.23913043478261, -0.15, 0.31818181818182
94566, 0.21739130434783, -0.125, 0.31818181818182
94567, 0.21739130434783, -0.15, 0.34090909090909
94568, 0.23913043478261, -0.15, 0.36363636363636
94569, 0.21739130434783, -0.125, 0.36363636363636
94570, 0.21739130434783, -0.15, 0.38636363636364
94571, 0.23913043478261, -0.15, 0.40909090909091
94572, 0.21739130434783, -0.125, 0.40909090909091
94573, 0.21739130434783, -0.15, 0.43181818181818
94574, 0.23913043478261, -0.15, 0.45454545454545
94575, 0.21739130434783, -0.125, 0.45454545454545
94576, 0.21739130434783, -0.15, 0.47727272727273
94577, 0.17391304347826, -0.15, 0.022727272727273
94578, 0.19565217391304, -0.15, 0.045454545454545
94579, 0.17391304347826, -0.125, 0.045454545454545
94580, 0.17391304347826, -0.15, 0.068181818181818
94581, 0.19565217391304, -0.15, 0.090909090909091
94582, 0.17391304347826, -0.125, 0.090909090909091
94583, 0.17391304347826, -0.15, 0.11363636363636
94584, 0.19565217391304, -0.15, 0.13636363636364
94585, 0.17391304347826, -0.125, 0.13636363636364
94586, 0.17391304347826, -0.15, 0.15909090909091
94587, 0.19565217391304, -0.15, 0.18181818181818
94588, 0.17391304347826, -0.125, 0.18181818181818
94589, 0.17391304347826, -0.15, 0.20454545454545
94590, 0.19565217391304, -0.15, 0.22727272727273
94591, 0.17391304347826, -0.125, 0.22727272727273
94592, 0.17391304347826, -0.15, 0.25
94593, 0.19565217391304, -0.15, 0.27272727272727
94594, 0.17391304347826, -0.125, 0.27272727272727
94595, 0.17391304347826, -0.15, 0.29545454545455
94596, 0.19565217391304, -0.15, 0.31818181818182
94597, 0.17391304347826, -0.125, 0.31818181818182
94598, 0.17391304347826, -0.15, 0.34090909090909
94599, 0.19565217391304, -0.15, 0.36363636363636
94600, 0.17391304347826, -0.125, 0.36363636363636
94601, 0.17391304347826, -0.15, 0.38636363636364
94602, 0.19565217391304, -0.15, 0.40909090909091
94603, 0.17391304347826, -0.125, 0.40909090909091
94604, 0.17391304347826, -0.15, 0.43181818181818
94605, 0.19565217391304, -0.15, 0.45454545454545
94606, 0.17391304347826, -0.125, 0.45454545454545
94607, 0.17391304347826, -0.15, 0.47727272727273
94608, 0.1304347826087, -0.15, 0.022727272727273
94609, 0.15217391304348, -0.15, 0.045454545454545
94610, 0.1304347826087, -0.125, 0.045454545454545
94611, 0.1304347826087, -0.15, 0.068181818181818
94612, 0.15217391304348, -0.15, 0.090909090909091
94613, 0.1304347826087, -0.125, 0.090909090909091
94614, 0.1304347826087, -0.15, 0.11363636363636
94615, 0.15217391304348, -0.15, 0.13636363636364
94616, 0.1304347826087, -0.125, 0.13636363636364
94617, 0.1304347826087, -0.15, 0.15909090909091
94618, 0.15217391304348, -0.15, 0.18181818181818
94619, 0.1304347826087, -0.125, 0.18181818181818
94620, 0.1304347826087, -0.15, 0.20454545454545
94621, 0.15217391304348, -0.15, 0.22727272727273
94622, 0.1304347826087, -0.125, 0.22727272727273
94623, 0.1304347826087, -0.15, 0.25
94624, 0.15217391304348, -0.15, 0.27272727272727
94625, 0.1304347826087, -0.125, 0.27272727272727
94626, 0.1304347826087, -0.15, 0.29545454545455
94627, 0.15217391304348, -0.15, 0.31818181818182
94628, 0.1304347826087, -0.125, 0.31818181818182
94629, 0.1304347826087, -0.15, 0.34090909090909
94630, 0.15217391304348, -0.15, 0.36363636363636
94631, 0.1304347826087, -0.125, 0.36363636363636
94632, 0.1304347826087, -0.15, 0.38636363636364
94633, 0.15217391304348, -0.15, 0.40909090909091
94634, 0.1304347826087, -0.125, 0.40909090909091
94635, 0.1304347826087, -0.15, 0.43181818181818
94636, 0.15217391304348, -0.15, 0.45454545454545
94637, 0.1304347826087, -0.125, 0.45454545454545
94638, 0.1304347826087, -0.15, 0.47727272727273
94639, 0.08695652173913, -0.15, 0.022727272727273
94640, 0.10869565217391, -0.15, 0.045454545454545
94641, 0.08695652173913, -0.125, 0.045454545454545
94642, 0.08695652173913, -0.15, 0.068181818181818
94643, 0.10869565217391, -0.15, 0.090909090909091
94644, 0.08695652173913, -0.125, 0.090909090909091
94645, 0.08695652173913, -0.15, 0.11363636363636
94646, 0.10869565217391, -0.15, 0.13636363636364
94647, 0.08695652173913, -0.125, 0.13636363636364
94648, 0.08695652173913, -0.15, 0.15909090909091
94649, 0.10869565217391, -0.15, 0.18181818181818
94650, 0.08695652173913, -0.125, 0.18181818181818
94651, 0.08695652173913, -0.15, 0.20454545454545
94652, 0.10869565217391, -0.15, 0.22727272727273
94653, 0.08695652173913, -0.125, 0.22727272727273
94654, 0.08695652173913, -0.15, 0.25
94655, 0.10869565217391, -0.15, 0.27272727272727
94656, 0.08695652173913, -0.125, 0.27272727272727
94657, 0.08695652173913, -0.15, 0.29545454545455
94658, 0.10869565217391, -0.15, 0.31818181818182
94659, 0.08695652173913, -0.125, 0.31818181818182
94660, 0.08695652173913, -0.15, 0.34090909090909
94661, 0.10869565217391, -0.15, 0.36363636363636
94662, 0.08695652173913, -0.125, 0.36363636363636
94663, 0.08695652173913, -0.15, 0.38636363636364
94664, 0.10869565217391, -0.15, 0.40909090909091
94665, 0.08695652173913, -0.125, 0.40909090909091
94666, 0.08695652173913, -0.15, 0.43181818181818
94667, 0.10869565217391, -0.15, 0.45454545454545
94668, 0.08695652173913, -0.125, 0.45454545454545
94669, 0.08695652173913, -0.15, 0.47727272727273
94670, 0.043478260869565, -0.15, 0.022727272727273
94671, 0.065217391304348, -0.15, 0.045454545454545
94672, 0.043478260869565, -0.125, 0.045454545454545
94673, 0.043478260869565, -0.15, 0.068181818181818
94674, 0.065217391304348, -0.15, 0.090909090909091
94675, 0.043478260869565, -0.125, 0.090909090909091
94676, 0.043478260869565, -0.15, 0.11363636363636
94677, 0.065217391304348, -0.15, 0.13636363636364
94678, 0.043478260869565, -0.125, 0.13636363636364
94679, 0.043478260869565, -0.15, 0.15909090909091
94680, 0.065217391304348, -0.15, 0.18181818181818
94681, 0.043478260869565, -0.125, 0.18181818181818
94682, 0.043478260869565, -0.15, 0.20454545454545
94683, 0.065217391304348, -0.15, 0.22727272727273
94684, 0.043478260869565, -0.125, 0.22727272727273
94685, 0.043478260869565, -0.15, 0.25
94686, 0.065217391304348, -0.15, 0.27272727272727
94687, 0.043478260869565, -0.125, 0.27272727272727
94688, 0.043478260869565, -0.15, 0.29545454545455
94689, 0.065217391304348, -0.15, 0.31818181818182
94690, 0.043478260869565, -0.125, 0.31818181818182
94691, 0.043478260869565, -0.15, 0.34090909090909
94692, 0.065217391304348, -0.15, 0.36363636363636
94693, 0.043478260869565, -0.125, 0.36363636363636
94694, 0.043478260869565, -0.15, 0.38636363636364
94695, 0.065217391304348, -0.15, 0.40909090909091
94696, 0.043478260869565, -0.125, 0.40909090909091
94697, 0.043478260869565, -0.15, 0.43181818181818
94698, 0.065217391304348, -0.15, 0.45454545454545
94699, 0.043478260869565, -0.125, 0.45454545454545
94700, 0.043478260869565, -0.15, 0.47727272727273
94701, 0.021739130434783, -0.15, 0.045454545454545
94702, 0.021739130434783, -0.15, 0.090909090909091
94703, 0.021739130434783, -0.15, 0.13636363636364
94704, 0.021739130434783, -0.15, 0.18181818181818
94705, 0.021739130434783, -0.15, 0.22727272727273
94706, 0.021739130434783, -0.15, 0.27272727272727
94707, 0.021739130434783, -0.15, 0.31818181818182
94708, 0.021739130434783, -0.15, 0.36363636363636
94709, 0.021739130434783, -0.15, 0.40909090909091
94710, 0.021739130434783, -0.15, 0.45454545454545
94711, 0.95652173913043, -0.175, 0.045454545454545
94712, 0.95652173913043, -0.175, 0.090909090909091
94713, 0.95652173913044, -0.175, 0.13636363636364
94714, 0.95652173913043, -0.175, 0.18181818181818
94715, 0.95652173913044, -0.175, 0.22727272727273
94716, 0.95652173913043, -0.175, 0.27272727272727
94717, 0.95652173913043, -0.175, 0.31818181818182
94718, 0.95652173913043, -0.175, 0.36363636363636
94719, 0.95652173913043, -0.175, 0.40909090909091
94720, 0.95652173913043, -0.175, 0.45454545454545
94721, 0.91304347826087, -0.175, 0.045454545454545
94722, 0.91304347826087, -0.175, 0.090909090909091
94723, 0.91304347826087, -0.175, 0.13636363636364
94724, 0.91304347826087, -0.175, 0.18181818181818
94725, 0.91304347826087, -0.175, 0.22727272727273
94726, 0.91304347826087, -0.175, 0.27272727272727
94727, 0.91304347826087, -0.175, 0.31818181818182
94728, 0.91304347826087, -0.175, 0.36363636363636
94729, 0.91304347826087, -0.175, 0.40909090909091
94730, 0.91304347826087, -0.175, 0.45454545454545
94731, 0.8695652173913, -0.175, 0.045454545454545
94732, 0.8695652173913, -0.175, 0.090909090909091
94733, 0.8695652173913, -0.175, 0.13636363636364
94734, 0.8695652173913, -0.175, 0.18181818181818
94735, 0.8695652173913, -0.175, 0.22727272727273
94736, 0.8695652173913, -0.175, 0.27272727272727
94737, 0.8695652173913, -0.175, 0.31818181818182
94738, 0.8695652173913, -0.175, 0.36363636363636
94739, 0.8695652173913, -0.175, 0.40909090909091
94740, 0.8695652173913, -0.175, 0.45454545454545
94741, 0.82608695652174, -0.175, 0.045454545454545
94742, 0.82608695652174, -0.175, 0.090909090909091
94743, 0.82608695652174, -0.175, 0.13636363636364
94744, 0.82608695652174, -0.175, 0.18181818181818
94745, 0.82608695652174, -0.175, 0.22727272727273
94746, 0.82608695652174, -0.175, 0.27272727272727
94747, 0.82608695652174, -0.175, 0.31818181818182
94748, 0.82608695652174, -0.175, 0.36363636363636
94749, 0.82608695652174, -0.175, 0.40909090909091
94750, 0.82608695652174, -0.175, 0.45454545454545
94751, 0.78260869565217, -0.175, 0.045454545454545
94752, 0.78260869565217, -0.175, 0.090909090909091
94753, 0.78260869565217, -0.175, 0.13636363636364
94754, 0.78260869565217, -0.175, 0.18181818181818
94755, 0.78260869565217, -0.175, 0.22727272727273
94756, 0.78260869565217, -0.175, 0.27272727272727
94757, 0.78260869565217, -0.175, 0.31818181818182
94758, 0.78260869565217, -0.175, 0.36363636363636
94759, 0.78260869565217, -0.175, 0.40909090909091
94760, 0.78260869565217, -0.175, 0.45454545454545
94761, 0.73913043478261, -0.175, 0.045454545454545
94762, 0.73913043478261, -0.175, 0.090909090909091
94763, 0.73913043478261, -0.175, 0.13636363636364
94764, 0.73913043478261, -0.175, 0.18181818181818
94765, 0.73913043478261, -0.175, 0.22727272727273
94766, 0.73913043478261, -0.175, 0.27272727272727
94767, 0.73913043478261, -0.175, 0.31818181818182
94768, 0.73913043478261, -0.175, 0.36363636363636
94769, 0.73913043478261, -0.175, 0.40909090909091
94770, 0.73913043478261, -0.175, 0.45454545454545
94771, 0.69565217391304, -0.175, 0.045454545454545
94772, 0.69565217391304, -0.175, 0.090909090909091
94773, 0.69565217391304, -0.175, 0.13636363636364
94774, 0.69565217391304, -0.175, 0.18181818181818
94775, 0.69565217391304, -0.175, 0.22727272727273
94776, 0.69565217391304, -0.175, 0.27272727272727
94777, 0.69565217391304, -0.175, 0.31818181818182
94778, 0.69565217391304, -0.175, 0.36363636363636
94779, 0.69565217391304, -0.175, 0.40909090909091
94780, 0.69565217391304, -0.175, 0.45454545454545
94781, 0.65217391304348, -0.175, 0.045454545454545
94782, 0.65217391304348, -0.175, 0.090909090909091
94783, 0.65217391304348, -0.175, 0.13636363636364
94784, 0.65217391304348, -0.175, 0.18181818181818
94785, 0.65217391304348, -0.175, 0.22727272727273
94786, 0.65217391304348, -0.175, 0.27272727272727
94787, 0.65217391304348, -0.175, 0.31818181818182
94788, 0.65217391304348, -0.175, 0.36363636363636
94789, 0.65217391304348, -0.175, 0.40909090909091
94790, 0.65217391304348, -0.175, 0.45454545454545
94791, 0.60869565217391, -0.175, 0.045454545454545
94792, 0.60869565217391, -0.175, 0.090909090909091
94793, 0.60869565217391, -0.175, 0.13636363636364
94794, 0.60869565217391, -0.175, 0.18181818181818
94795, 0.60869565217391, -0.175, 0.22727272727273
94796, 0.60869565217391, -0.175, 0.27272727272727
94797, 0.60869565217391, -0.175, 0.31818181818182
94798, 0.60869565217391, -0.175, 0.36363636363636
94799, 0.60869565217391, -0.175, 0.40909090909091
94800, 0.60869565217391, -0.175, 0.45454545454545
94801, 0.56521739130435, -0.175, 0.045454545454545
94802, 0.56521739130435, -0.175, 0.090909090909091
94803, 0.56521739130435, -0.175, 0.13636363636364
94804, 0.56521739130435, -0.175, 0.18181818181818
94805, 0.56521739130435, -0.175, 0.22727272727273
94806, 0.56521739130435, -0.175, 0.27272727272727
94807, 0.56521739130435, -0.175, 0.31818181818182
94808, 0.56521739130435, -0.175, 0.36363636363636
94809, 0.56521739130435, -0.175, 0.40909090909091
94810, 0.56521739130435, -0.175, 0.45454545454545
94811, 0.52173913043478, -0.175, 0.045454545454545
94812, 0.52173913043478, -0.175, 0.090909090909091
94813, 0.52173913043478, -0.175, 0.13636363636364
94814, 0.52173913043478, -0.175, 0.18181818181818
94815, 0.52173913043478, -0.175, 0.22727272727273
94816, 0.52173913043478, -0.175, 0.27272727272727
94817, 0.52173913043478, -0.175, 0.31818181818182
94818, 0.52173913043478, -0.175, 0.36363636363636
94819, 0.52173913043478, -0.175, 0.40909090909091
94820, 0.52173913043478, -0.175, 0.45454545454545
94821, 0.47826086956522, -0.175, 0.045454545454545
94822, 0.47826086956522, -0.175, 0.090909090909091
94823, 0.47826086956522, -0.175, 0.13636363636364
94824, 0.47826086956522, -0.175, 0.18181818181818
94825, 0.47826086956522, -0.175, 0.22727272727273
94826, 0.47826086956522, -0.175, 0.27272727272727
94827, 0.47826086956522, -0.175, 0.31818181818182
94828, 0.47826086956522, -0.175, 0.36363636363636
94829, 0.47826086956522, -0.175, 0.40909090909091
94830, 0.47826086956522, -0.175, 0.45454545454545
94831, 0.43478260869565, -0.175, 0.045454545454545
94832, 0.43478260869565, -0.175, 0.090909090909091
94833, 0.43478260869565, -0.175, 0.13636363636364
94834, 0.43478260869565, -0.175, 0.18181818181818
94835, 0.43478260869565, -0.175, 0.22727272727273
94836, 0.43478260869565, -0.175, 0.27272727272727
94837, 0.43478260869565, -0.175, 0.31818181818182
94838, 0.43478260869565, -0.175, 0.36363636363636
94839, 0.43478260869565, -0.175, 0.40909090909091
94840, 0.43478260869565, -0.175, 0.45454545454545
94841, 0.39130434782609, -0.175, 0.045454545454545
94842, 0.39130434782609, -0.175, 0.090909090909091
94843, 0.39130434782609, -0.175, 0.13636363636364
94844, 0.39130434782609, -0.175, 0.18181818181818
94845, 0.39130434782609, -0.175, 0.22727272727273
94846, 0.39130434782609, -0.175, 0.27272727272727
94847, 0.39130434782609, -0.175, 0.31818181818182
94848, 0.39130434782609, -0.175, 0.36363636363636
94849, 0.39130434782609, -0.175, 0.40909090909091
94850, 0.39130434782609, -0.175, 0.45454545454545
94851, 0.34782608695652, -0.175, 0.045454545454545
94852, 0.34782608695652, -0.175, 0.090909090909091
94853, 0.34782608695652, -0.175, 0.13636363636364
94854, 0.34782608695652, -0.175, 0.18181818181818
94855, 0.34782608695652, -0.175, 0.22727272727273
94856, 0.34782608695652, -0.175, 0.27272727272727
94857, 0.34782608695652, -0.175, 0.31818181818182
94858, 0.34782608695652, -0.175, 0.36363636363636
94859, 0.34782608695652, -0.175, 0.40909090909091
94860, 0.34782608695652, -0.175, 0.45454545454545
94861, 0.30434782608696, -0.175, 0.045454545454545
94862, 0.30434782608696, -0.175, 0.090909090909091
94863, 0.30434782608696, -0.175, 0.13636363636364
94864, 0.30434782608696, -0.175, 0.18181818181818
94865, 0.30434782608696, -0.175, 0.22727272727273
94866, 0.30434782608696, -0.175, 0.27272727272727
94867, 0.30434782608696, -0.175, 0.31818181818182
94868, 0.30434782608696, -0.175, 0.36363636363636
94869, 0.30434782608696, -0.175, 0.40909090909091
94870, 0.30434782608696, -0.175, 0.45454545454545
94871, 0.26086956521739, -0.175, 0.045454545454545
94872, 0.26086956521739, -0.175, 0.090909090909091
94873, 0.26086956521739, -0.175, 0.13636363636364
94874, 0.26086956521739, -0.175, 0.18181818181818
94875, 0.26086956521739, -0.175, 0.22727272727273
94876, 0.26086956521739, -0.175, 0.27272727272727
94877, 0.26086956521739, -0.175, 0.31818181818182
94878, 0.26086956521739, -0.175, 0.36363636363636
94879, 0.26086956521739, -0.175, 0.40909090909091
94880, 0.26086956521739, -0.175, 0.45454545454545
94881, 0.21739130434783, -0.175, 0.045454545454545
94882, 0.21739130434783, -0.175, 0.090909090909091
94883, 0.21739130434783, -0.175, 0.13636363636364
94884, 0.21739130434783, -0.175, 0.18181818181818
94885, 0.21739130434783, -0.175, 0.22727272727273
94886, 0.21739130434783, -0.175, 0.27272727272727
94887, 0.21739130434783, -0.175, 0.31818181818182
94888, 0.21739130434783, -0.175, 0.36363636363636
94889, 0.21739130434783, -0.175, 0.40909090909091
94890, 0.21739130434783, -0.175, 0.45454545454545
94891, 0.17391304347826, -0.175, 0.045454545454545
94892, 0.17391304347826, -0.175, 0.090909090909091
94893, 0.17391304347826, -0.175, 0.13636363636364
94894, 0.17391304347826, -0.175, 0.18181818181818
94895, 0.17391304347826, -0.175, 0.22727272727273
94896, 0.17391304347826, -0.175, 0.27272727272727
94897, 0.17391304347826, -0.175, 0.31818181818182
94898, 0.17391304347826, -0.175, 0.36363636363636
94899, 0.17391304347826, -0.175, 0.40909090909091
94900, 0.17391304347826, -0.175, 0.45454545454545
94901, 0.1304347826087, -0.175, 0.045454545454545
94902, 0.1304347826087, -0.175, 0.090909090909091
94903, 0.1304347826087, -0.175, 0.13636363636364
94904, 0.1304347826087, -0.175, 0.18181818181818
94905, 0.1304347826087, -0.175, 0.22727272727273
94906, 0.1304347826087, -0.175, 0.27272727272727
94907, 0.1304347826087, -0.175, 0.31818181818182
94908, 0.1304347826087, -0.175, 0.36363636363636
94909, 0.1304347826087, -0.175, 0.40909090909091
94910, 0.1304347826087, -0.175, 0.45454545454545
94911, 0.08695652173913, -0.175, 0.045454545454545
94912, 0.08695652173913, -0.175, 0.090909090909091
94913, 0.08695652173913, -0.175, 0.13636363636364
94914, 0.08695652173913, -0.175, 0.18181818181818
94915, 0.08695652173913, -0.175, 0.22727272727273
94916, 0.08695652173913, -0.175, 0.27272727272727
94917, 0.08695652173913, -0.175, 0.31818181818182
94918, 0.08695652173913, -0.175, 0.36363636363636
94919, 0.08695652173913, -0.175, 0.40909090909091
94920, 0.08695652173913, -0.175, 0.45454545454545
94921, 0.043478260869565, -0.175, 0.045454545454545
94922, 0.043478260869565, -0.175, 0.090909090909091
94923, 0.043478260869565, -0.175, 0.13636363636364
94924, 0.043478260869565, -0.175, 0.18181818181818
94925, 0.043478260869565, -0.175, 0.22727272727273
94926, 0.043478260869565, -0.175, 0.27272727272727
94927, 0.043478260869565, -0.175, 0.31818181818182
94928, 0.043478260869565, -0.175, 0.36363636363636
94929, 0.043478260869565, -0.175, 0.40909090909091
94930, 0.043478260869565, -0.175, 0.45454545454545
94931, -0.033333333333333, -0.05, 0.45454545454545
94932, -0.033333333333333, -0.05, 0.40909090909091
94933, -0.033333333333333, -0.05, 0.36363636363636
94934, -0.033333333333333, -0.05, 0.31818181818182
94935, -0.033333333333333, -0.05, 0.27272727272727
94936, -0.033333333333333, -0.05, 0.22727272727273
94937, -0.033333333333333, -0.05, 0.18181818181818
94938, -0.033333333333333, -0.05, 0.13636363636364
94939, -0.033333333333333, -0.05, 0.090909090909091
94940, -0.033333333333333, -0.05, 0.045454545454545
94941, -0.066666666666667, -0.05, 0.45454545454545
94942, -0.066666666666667, -0.05, 0.40909090909091
94943, -0.066666666666667, -0.05, 0.36363636363636
94944, -0.066666666666667, -0.05, 0.31818181818182
94945, -0.066666666666667, -0.05, 0.27272727272727
94946, -0.066666666666667, -0.05, 0.22727272727273
94947, -0.066666666666667, -0.05, 0.18181818181818
94948, -0.066666666666667, -0.05, 0.13636363636364
94949, -0.066666666666667, -0.05, 0.090909090909091
94950, -0.066666666666667, -0.05, 0.045454545454545
94951, -0.033333333333333, -0.1, 0.45454545454545
94952, -0.033333333333333, -0.1, 0.40909090909091
94953, -0.033333333333333, -0.1, 0.36363636363636
94954, -0.033333333333333, -0.1, 0.31818181818182
94955, -0.033333333333333, -0.1, 0.27272727272727
94956, -0.033333333333333, -0.1, 0.22727272727273
94957, -0.033333333333333, -0.1, 0.18181818181818
94958, -0.033333333333333, -0.1, 0.13636363636364
94959, -0.033333333333333, -0.1, 0.090909090909091
94960, -0.033333333333333, -0.1, 0.045454545454545
94961, -0.066666666666667, -0.1, 0.45454545454545
94962, -0.066666666666667, -0.1, 0.40909090909091
94963, -0.066666666666667, -0.1, 0.36363636363636
94964, -0.066666666666667, -0.1, 0.31818181818182
94965, -0.066666666666667, -0.1, 0.27272727272727
94966, -0.066666666666667, -0.1, 0.22727272727273
94967, -0.066666666666667, -0.1, 0.18181818181818
94968, -0.066666666666667, -0.1, 0.13636363636364
94969, -0.066666666666667, -0.1, 0.090909090909091
94970, -0.066666666666667, -0.1, 0.045454545454545
94971, -0.033333333333333, -0.15, 0.45454545454545
94972, -0.033333333333333, -0.15, 0.40909090909091
94973, -0.033333333333333, -0.15, 0.36363636363636
94974, -0.033333333333333, -0.15, 0.31818181818182
94975, -0.033333333333333, -0.15, 0.27272727272727
94976, -0.033333333333333, -0.15, 0.22727272727273
94977, -0.033333333333333, -0.15, 0.18181818181818
94978, -0.033333333333333, -0.15, 0.13636363636364
94979, -0.033333333333333, -0.15, 0.090909090909091
94980, -0.033333333333333, -0.15, 0.045454545454545
94981, -0.066666666666667, -0.15, 0.45454545454545
94982, -0.066666666666667, -0.15, 0.40909090909091
94983, -0.066666666666667, -0.15, 0.36363636363636
94984, -0.066666666666667, -0.15, 0.31818181818182
94985, -0.066666666666667, -0.15, 0.27272727272727
94986, -0.066666666666667, -0.15, 0.22727272727273
94987, -0.066666666666667, -0.15, 0.18181818181818
94988, -0.066666666666667, -0.15, 0.13636363636364
94989, -0.066666666666667, -0.15, 0.090909090909091
94990, -0.066666666666667, -0.15, 0.045454545454545
94991, -0.033333333333333, -0.05, 0.47727272727273
94992, -0.016666666666667, -0.05, 0.45454545454545
94993, -0.033333333333333, -0.025, 0.45454545454545
94994, -0.033333333333333, -0.05, 0.43181818181818
94995, -0.016666666666667, -0.05, 0.40909090909091
94996, -0.033333333333333, -0.025, 0.40909090909091
94997, -0.033333333333333, -0.05, 0.38636363636364
94998, -0.016666666666667, -0.05, 0.36363636363636
94999, -0.033333333333333, -0.025, 0.36363636363636
95000, -0.033333333333333, -0.05, 0.34090909090909
95001, -0.016666666666667, -0.05, 0.31818181818182
95002, -0.033333333333333, -0.025, 0.31818181818182
95003, -0.033333333333333, -0.05, 0.29545454545455
95004, -0.016666666666667, -0.05, 0.27272727272727
95005, -0.033333333333333, -0.025, 0.27272727272727
95006, -0.033333333333333, -0.05, 0.25
95007, -0.016666666666667, -0.05, 0.22727272727273
95008, -0.033333333333333, -0.025, 0.22727272727273
95009, -0.033333333333333, -0.05, 0.20454545454545
95010, -0.016666666666667, -0.05, 0.18181818181818
95011, -0.033333333333333, -0.025, 0.18181818181818
95012, -0.033333333333333, -0.05, 0.15909090909091
95013, -0.016666666666667, -0.05, 0.13636363636364
95014, -0.033333333333333, -0.025, 0.13636363636364
95015, -0.033333333333333, -0.05, 0.11363636363636
95016, -0.016666666666667, -0.05, 0.090909090909091
95017, -0.033333333333333, -0.025, 0.090909090909091
95018, -0.033333333333333, -0.05, 0.068181818181818
95019, -0.016666666666667, -0.05, 0.045454545454545
95020, -0.033333333333333, -0.025, 0.045454545454545
95021, -0.033333333333333, -0.05, 0.022727272727273
95022, -0.066666666666667, -0.05, 0.47727272727273
95023, -0.05, -0.05, 0.45454545454545
95024, -0.066666666666667, -0.025, 0.45454545454545
95025, -0.066666666666667, -0.05, 0.43181818181818
95026, -0.05, -0.05, 0.40909090909091
95027, -0.066666666666667, -0.025, 0.40909090909091
95028, -0.066666666666667, -0.05, 0.38636363636364
95029, -0.05, -0.05, 0.36363636363636
95030, -0.066666666666667, -0.025, 0.36363636363636
95031, -0.066666666666667, -0.05, 0.34090909090909
95032, -0.05, -0.05, 0.31818181818182
95033, -0.066666666666667, -0.025, 0.31818181818182
95034, -0.066666666666667, -0.05, 0.29545454545455
95035, -0.05, -0.05, 0.27272727272727
95036, -0.066666666666667, -0.025, 0.27272727272727
95037, -0.066666666666667, -0.05, 0.25
95038, -0.05, -0.05, 0.22727272727273
95039, -0.066666666666667, -0.025, 0.22727272727273
95040, -0.066666666666667, -0.05, 0.20454545454545
95041, -0.05, -0.05, 0.18181818181818
95042, -0.066666666666667, -0.025, 0.18181818181818
95043, -0.066666666666667, -0.05, 0.15909090909091
95044, -0.05, -0.05, 0.13636363636364
95045, -0.066666666666667, -0.025, 0.13636363636364
95046, -0.066666666666667, -0.05, 0.11363636363636
95047, -0.05, -0.05, 0.090909090909091
95048, -0.066666666666667, -0.025, 0.090909090909091
95049, -0.066666666666667, -0.05, 0.068181818181818
95050, -0.05, -0.05, 0.045454545454545
95051, -0.066666666666667, -0.025, 0.045454545454545
95052, -0.066666666666667, -0.05, 0.022727272727273
95053, -0.083333333333333, -0.05, 0.45454545454545
95054, -0.083333333333333, -0.05, 0.40909090909091
95055, -0.083333333333333, -0.05, 0.36363636363636
95056, -0.083333333333333, -0.05, 0.31818181818182
95057, -0.083333333333333, -0.05, 0.27272727272727
95058, -0.083333333333333, -0.05, 0.22727272727273
95059, -0.083333333333333, -0.05, 0.18181818181818
95060, -0.083333333333333, -0.05, 0.13636363636364
95061, -0.083333333333333, -0.05, 0.090909090909091
95062, -0.083333333333333, -0.05, 0.045454545454545
95063, -0.033333333333333, -0.1, 0.47727272727273
95064, -0.016666666666667, -0.1, 0.45454545454545
95065, -0.033333333333333, -0.075, 0.45454545454545
95066, -0.033333333333333, -0.1, 0.43181818181818
95067, -0.016666666666667, -0.1, 0.40909090909091
95068, -0.033333333333333, -0.075, 0.40909090909091
95069, -0.033333333333333, -0.1, 0.38636363636364
95070, -0.016666666666667, -0.1, 0.36363636363636
95071, -0.033333333333333, -0.075, 0.36363636363636
95072, -0.033333333333333, -0.1, 0.34090909090909
95073, -0.016666666666667, -0.1, 0.31818181818182
95074, -0.033333333333333, -0.075, 0.31818181818182
95075, -0.033333333333333, -0.1, 0.29545454545455
95076, -0.016666666666667, -0.1, 0.27272727272727
95077, -0.033333333333333, -0.075, 0.27272727272727
95078, -0.033333333333333, -0.1, 0.25
95079, -0.016666666666667, -0.1, 0.22727272727273
95080, -0.033333333333333, -0.075, 0.22727272727273
95081, -0.033333333333333, -0.1, 0.20454545454545
95082, -0.016666666666667, -0.1, 0.18181818181818
95083, -0.033333333333333, -0.075, 0.18181818181818
95084, -0.033333333333333, -0.1, 0.15909090909091
95085, -0.016666666666667, -0.1, 0.13636363636364
95086, -0.033333333333333, -0.075, 0.13636363636364
95087, -0.033333333333333, -0.1, 0.11363636363636
95088, -0.016666666666667, -0.1, 0.090909090909091
95089, -0.033333333333333, -0.075, 0.090909090909091
95090, -0.033333333333333, -0.1, 0.068181818181818
95091, -0.016666666666667, -0.1, 0.045454545454545
95092, -0.033333333333333, -0.075, 0.045454545454545
95093, -0.033333333333333, -0.1, 0.022727272727273
95094, -0.066666666666667, -0.1, 0.47727272727273
95095, -0.05, -0.1, 0.45454545454545
95096, -0.066666666666667, -0.075, 0.45454545454545
95097, -0.066666666666667, -0.1, 0.43181818181818
95098, -0.05, -0.1, 0.40909090909091
95099, -0.066666666666667, -0.075, 0.40909090909091
95100, -0.066666666666667, -0.1, 0.38636363636364
95101, -0.05, -0.1, 0.36363636363636
95102, -0.066666666666667, -0.075, 0.36363636363636
95103, -0.066666666666667, -0.1, 0.34090909090909
95104, -0.05, -0.1, 0.31818181818182
95105, -0.066666666666667, -0.075, 0.31818181818182
95106, -0.066666666666667, -0.1, 0.29545454545455
95107, -0.05, -0.1, 0.27272727272727
95108, -0.066666666666667, -0.075, 0.27272727272727
95109, -0.066666666666667, -0.1, 0.25
95110, -0.05, -0.1, 0.22727272727273
95111, -0.066666666666667, -0.075, 0.22727272727273
95112, -0.066666666666667, -0.1, 0.20454545454545
95113, -0.05, -0.1, 0.18181818181818
95114, -0.066666666666667, -0.075, 0.18181818181818
95115, -0.066666666666667, -0.1, 0.15909090909091
95116, -0.05, -0.1, 0.13636363636364
95117, -0.066666666666667, -0.075, 0.13636363636364
95118, -0.066666666666667, -0.1, 0.11363636363636
95119, -0.05, -0.1, 0.090909090909091
95120, -0.066666666666667, -0.075, 0.090909090909091
95121, -0.066666666666667, -0.1, 0.068181818181818
95122, -0.05, -0.1, 0.045454545454545
95123, -0.066666666666667, -0.075, 0.045454545454545
95124, -0.066666666666667, -0.1, 0.022727272727273
95125, -0.083333333333333, -0.1, 0.45454545454545
95126, -0.083333333333333, -0.1, 0.40909090909091
95127, -0.083333333333333, -0.1, 0.36363636363636
95128, -0.083333333333333, -0.1, 0.31818181818182
95129, -0.083333333333333, -0.1, 0.27272727272727
95130, -0.083333333333333, -0.1, 0.22727272727273
95131, -0.083333333333333, -0.1, 0.18181818181818
95132, -0.083333333333333, -0.1, 0.13636363636364
95133, -0.083333333333333, -0.1, 0.090909090909091
95134, -0.083333333333333, -0.1, 0.045454545454545
95135, -0.033333333333333, -0.15, 0.47727272727273
95136, -0.016666666666667, -0.15, 0.45454545454545
95137, -0.033333333333333, -0.125, 0.45454545454545
95138, -0.033333333333333, -0.15, 0.43181818181818
95139, -0.016666666666667, -0.15, 0.40909090909091
95140, -0.033333333333333, -0.125, 0.40909090909091
95141, -0.033333333333333, -0.15, 0.38636363636364
95142, -0.016666666666667, -0.15, 0.36363636363636
95143, -0.033333333333333, -0.125, 0.36363636363636
95144, -0.033333333333333, -0.15, 0.34090909090909
95145, -0.016666666666667, -0.15, 0.31818181818182
95146, -0.033333333333333, -0.125, 0.31818181818182
95147, -0.033333333333333, -0.15, 0.29545454545455
95148, -0.016666666666667, -0.15, 0.27272727272727
95149, -0.033333333333333, -0.125, 0.27272727272727
95150, -0.033333333333333, -0.15, 0.25
95151, -0.016666666666667, -0.15, 0.22727272727273
95152, -0.033333333333333, -0.125, 0.22727272727273
95153, -0.033333333333333, -0.15, 0.20454545454545
95154, -0.016666666666667, -0.15, 0.18181818181818
95155, -0.033333333333333, -0.125, 0.18181818181818
95156, -0.033333333333333, -0.15, 0.15909090909091
95157, -0.016666666666667, -0.15, 0.13636363636364
95158, -0.033333333333333, -0.125, 0.13636363636364
95159, -0.033333333333333, -0.15, 0.11363636363636
95160, -0.016666666666667, -0.15, 0.090909090909091
95161, -0.033333333333333, -0.125, 0.090909090909091
95162, -0.033333333333333, -0.15, 0.068181818181818
95163, -0.016666666666667, -0.15, 0.045454545454545
95164, -0.033333333333333, -0.125, 0.045454545454545
95165, -0.033333333333333, -0.15, 0.022727272727273
95166, -0.066666666666667, -0.15, 0.47727272727273
95167, -0.05, -0.15, 0.45454545454545
95168, -0.066666666666667, -0.125, 0.45454545454545
95169, -0.066666666666667, -0.15, 0.43181818181818
95170, -0.05, -0.15, 0.40909090909091
95171, -0.066666666666667, -0.125, 0.40909090909091
95172, -0.066666666666667, -0.15, 0.38636363636364
95173, -0.05, -0.15, 0.36363636363636
95174, -0.066666666666667, -0.125, 0.36363636363636
95175, -0.066666666666667, -0.15, 0.34090909090909
95176, -0.05, -0.15, 0.31818181818182
95177, -0.066666666666667, -0.125, 0.31818181818182
95178, -0.066666666666667, -0.15, 0.29545454545455
95179, -0.05, -0.15, 0.27272727272727
95180, -0.066666666666667, -0.125, 0.27272727272727
95181, -0.066666666666667, -0.15, 0.25
95182, -0.05, -0.15, 0.22727272727273
95183, -0.066666666666667, -0.125, 0.22727272727273
95184, -0.066666666666667, -0.15, 0.20454545454545
95185, -0.05, -0.15, 0.18181818181818
95186, -0.066666666666667, -0.125, 0.18181818181818
95187, -0.066666666666667, -0.15, 0.15909090909091
95188, -0.05, -0.15, 0.13636363636364
95189, -0.066666666666667, -0.125, 0.13636363636364
95190, -0.066666666666667, -0.15, 0.11363636363636
95191, -0.05, -0.15, 0.090909090909091
95192, -0.066666666666667, -0.125, 0.090909090909091
95193, -0.066666666666667, -0.15, 0.068181818181818
95194, -0.05, -0.15, 0.045454545454545
95195, -0.066666666666667, -0.125, 0.045454545454545
95196, -0.066666666666667, -0.15, 0.022727272727273
95197, -0.083333333333333, -0.15, 0.45454545454545
95198, -0.083333333333333, -0.15, 0.40909090909091
95199, -0.083333333333333, -0.15, 0.36363636363636
95200, -0.083333333333333, -0.15, 0.31818181818182
95201, -0.083333333333333, -0.15, 0.27272727272727
95202, -0.083333333333333, -0.15, 0.22727272727273
95203, -0.083333333333333, -0.15, 0.18181818181818
95204, -0.083333333333333, -0.15, 0.13636363636364
95205, -0.083333333333333, -0.15, 0.090909090909091
95206, -0.083333333333333, -0.15, 0.045454545454545
95207, -0.033333333333333, -0.175, 0.45454545454545
95208, -0.033333333333333, -0.175, 0.40909090909091
95209, -0.033333333333333, -0.175, 0.36363636363636
95210, -0.033333333333333, -0.175, 0.31818181818182
95211, -0.033333333333333, -0.175, 0.27272727272727
95212, -0.033333333333333, -0.175, 0.22727272727273
95213, -0.033333333333333, -0.175, 0.18181818181818
95214, -0.033333333333333, -0.175, 0.13636363636364
95215, -0.033333333333333, -0.175, 0.090909090909091
95216, -0.033333333333333, -0.175, 0.045454545454545
95217, -0.066666666666667, -0.175, 0.45454545454545
95218, -0.066666666666667, -0.175, 0.40909090909091
95219, -0.066666666666667, -0.175, 0.36363636363636
95220, -0.066666666666667, -0.175, 0.31818181818182
95221, -0.066666666666667, -0.175, 0.27272727272727
95222, -0.066666666666667, -0.175, 0.22727272727273
95223, -0.066666666666667, -0.175, 0.18181818181818
95224, -0.066666666666667, -0.175, 0.13636363636364
95225, -0.066666666666667, -0.175, 0.090909090909091
95226, -0.066666666666667, -0.175, 0.045454545454545
95227, 1.2434782608696, -0.05, 0.45454545454545
95228, 1.2434782608696, -0.05, 0.40909090909091
95229, 1.2434782608696, -0.05, 0.36363636363636
95230, 1.2434782608696, -0.05, 0.31818181818182
95231, 1.2434782608696, -0.05, 0.27272727272727
95232, 1.2434782608696, -0.05, 0.22727272727273
95233, 1.2434782608696, -0.05, 0.18181818181818
95234, 1.2434782608696, -0.05, 0.13636363636364
95235, 1.2434782608696, -0.05, 0.090909090909091
95236, 1.2434782608696, -0.05, 0.045454545454545
95237, 1.2869565217391, -0.05, 0.45454545454545
95238, 1.2869565217391, -0.05, 0.40909090909091
95239, 1.2869565217391, -0.05, 0.36363636363636
95240, 1.2869565217391, -0.05, 0.31818181818182
95241, 1.2869565217391, -0.05, 0.27272727272727
95242, 1.2869565217391, -0.05, 0.22727272727273
95243, 1.2869565217391, -0.05, 0.18181818181818
95244, 1.2869565217391, -0.05, 0.13636363636364
95245, 1.2869565217391, -0.05, 0.090909090909091
95246, 1.2869565217391, -0.05, 0.045454545454545
95247, 1.3304347826087, -0.05, 0.45454545454545
95248, 1.3304347826087, -0.05, 0.40909090909091
95249, 1.3304347826087, -0.05, 0.36363636363636
95250, 1.3304347826087, -0.05, 0.31818181818182
95251, 1.3304347826087, -0.05, 0.27272727272727
95252, 1.3304347826087, -0.05, 0.22727272727273
95253, 1.3304347826087, -0.05, 0.18181818181818
95254, 1.3304347826087, -0.05, 0.13636363636364
95255, 1.3304347826087, -0.05, 0.090909090909091
95256, 1.3304347826087, -0.05, 0.045454545454545
95257, 1.3739130434783, -0.05, 0.45454545454545
95258, 1.3739130434783, -0.05, 0.40909090909091
95259, 1.3739130434783, -0.05, 0.36363636363636
95260, 1.3739130434783, -0.05, 0.31818181818182
95261, 1.3739130434783, -0.05, 0.27272727272727
95262, 1.3739130434783, -0.05, 0.22727272727273
95263, 1.3739130434783, -0.05, 0.18181818181818
95264, 1.3739130434783, -0.05, 0.13636363636364
95265, 1.3739130434783, -0.05, 0.090909090909091
95266, 1.3739130434783, -0.05, 0.045454545454545
95267, 1.4173913043478, -0.05, 0.45454545454545
95268, 1.4173913043478, -0.05, 0.40909090909091
95269, 1.4173913043478, -0.05, 0.36363636363636
95270, 1.4173913043478, -0.05, 0.31818181818182
95271, 1.4173913043478, -0.05, 0.27272727272727
95272, 1.4173913043478, -0.05, 0.22727272727273
95273, 1.4173913043478, -0.05, 0.18181818181818
95274, 1.4173913043478, -0.05, 0.13636363636364
95275, 1.4173913043478, -0.05, 0.090909090909091
95276, 1.4173913043478, -0.05, 0.045454545454545
95277, 1.4608695652174, -0.05, 0.45454545454545
95278, 1.4608695652174, -0.05, 0.40909090909091
95279, 1.4608695652174, -0.05, 0.36363636363636
95280, 1.4608695652174, -0.05, 0.31818181818182
95281, 1.4608695652174, -0.05, 0.27272727272727
95282, 1.4608695652174, -0.05, 0.22727272727273
95283, 1.4608695652174, -0.05, 0.18181818181818
95284, 1.4608695652174, -0.05, 0.13636363636364
95285, 1.4608695652174, -0.05, 0.090909090909091
95286, 1.4608695652174, -0.05, 0.045454545454545
95287, 1.504347826087, -0.05, 0.45454545454545
95288, 1.504347826087, -0.05, 0.40909090909091
95289, 1.504347826087, -0.05, 0.36363636363636
95290, 1.504347826087, -0.05, 0.31818181818182
95291, 1.504347826087, -0.05, 0.27272727272727
95292, 1.504347826087, -0.05, 0.22727272727273
95293, 1.504347826087, -0.05, 0.18181818181818
95294, 1.504347826087, -0.05, 0.13636363636364
95295, 1.504347826087, -0.05, 0.090909090909091
95296, 1.504347826087, -0.05, 0.045454545454545
95297, 1.5478260869565, -0.05, 0.45454545454545
95298, 1.5478260869565, -0.05, 0.40909090909091
95299, 1.5478260869565, -0.05, 0.36363636363636
95300, 1.5478260869565, -0.05, 0.31818181818182
95301, 1.5478260869565, -0.05, 0.27272727272727
95302, 1.5478260869565, -0.05, 0.22727272727273
95303, 1.5478260869565, -0.05, 0.18181818181818
95304, 1.5478260869565, -0.05, 0.13636363636364
95305, 1.5478260869565, -0.05, 0.090909090909091
95306, 1.5478260869565, -0.05, 0.045454545454545
95307, 1.5913043478261, -0.05, 0.45454545454545
95308, 1.5913043478261, -0.05, 0.40909090909091
95309, 1.5913043478261, -0.05, 0.36363636363636
95310, 1.5913043478261, -0.05, 0.31818181818182
95311, 1.5913043478261, -0.05, 0.27272727272727
95312, 1.5913043478261, -0.05, 0.22727272727273
95313, 1.5913043478261, -0.05, 0.18181818181818
95314, 1.5913043478261, -0.05, 0.13636363636364
95315, 1.5913043478261, -0.05, 0.090909090909091
95316, 1.5913043478261, -0.05, 0.045454545454545
95317, 1.6347826086957, -0.05, 0.45454545454545
95318, 1.6347826086957, -0.05, 0.40909090909091
95319, 1.6347826086957, -0.05, 0.36363636363636
95320, 1.6347826086957, -0.05, 0.31818181818182
95321, 1.6347826086957, -0.05, 0.27272727272727
95322, 1.6347826086957, -0.05, 0.22727272727273
95323, 1.6347826086957, -0.05, 0.18181818181818
95324, 1.6347826086957, -0.05, 0.13636363636364
95325, 1.6347826086957, -0.05, 0.090909090909091
95326, 1.6347826086957, -0.05, 0.045454545454545
95327, 1.6782608695652, -0.05, 0.45454545454545
95328, 1.6782608695652, -0.05, 0.40909090909091
95329, 1.6782608695652, -0.05, 0.36363636363636
95330, 1.6782608695652, -0.05, 0.31818181818182
95331, 1.6782608695652, -0.05, 0.27272727272727
95332, 1.6782608695652, -0.05, 0.22727272727273
95333, 1.6782608695652, -0.05, 0.18181818181818
95334, 1.6782608695652, -0.05, 0.13636363636364
95335, 1.6782608695652, -0.05, 0.090909090909091
95336, 1.6782608695652, -0.05, 0.045454545454545
95337, 1.7217391304348, -0.05, 0.45454545454545
95338, 1.7217391304348, -0.05, 0.40909090909091
95339, 1.7217391304348, -0.05, 0.36363636363636
95340, 1.7217391304348, -0.05, 0.31818181818182
95341, 1.7217391304348, -0.05, 0.27272727272727
95342, 1.7217391304348, -0.05, 0.22727272727273
95343, 1.7217391304348, -0.05, 0.18181818181818
95344, 1.7217391304348, -0.05, 0.13636363636364
95345, 1.7217391304348, -0.05, 0.090909090909091
95346, 1.7217391304348, -0.05, 0.045454545454545
95347, 1.7652173913043, -0.05, 0.45454545454545
95348, 1.7652173913043, -0.05, 0.40909090909091
95349, 1.7652173913043, -0.05, 0.36363636363636
95350, 1.7652173913043, -0.05, 0.31818181818182
95351, 1.7652173913043, -0.05, 0.27272727272727
95352, 1.7652173913043, -0.05, 0.22727272727273
95353, 1.7652173913043, -0.05, 0.18181818181818
95354, 1.7652173913043, -0.05, 0.13636363636364
95355, 1.7652173913043, -0.05, 0.090909090909091
95356, 1.7652173913043, -0.05, 0.045454545454545
95357, 1.8086956521739, -0.05, 0.45454545454545
95358, 1.8086956521739, -0.05, 0.40909090909091
95359, 1.8086956521739, -0.05, 0.36363636363636
95360, 1.8086956521739, -0.05, 0.31818181818182
95361, 1.8086956521739, -0.05, 0.27272727272727
95362, 1.8086956521739, -0.05, 0.22727272727273
95363, 1.8086956521739, -0.05, 0.18181818181818
95364, 1.8086956521739, -0.05, 0.13636363636364
95365, 1.8086956521739, -0.05, 0.090909090909091
95366, 1.8086956521739, -0.05, 0.045454545454545
95367, 1.8521739130435, -0.05, 0.45454545454545
95368, 1.8521739130435, -0.05, 0.40909090909091
95369, 1.8521739130435, -0.05, 0.36363636363636
95370, 1.8521739130435, -0.05, 0.31818181818182
95371, 1.8521739130435, -0.05, 0.27272727272727
95372, 1.8521739130435, -0.05, 0.22727272727273
95373, 1.8521739130435, -0.05, 0.18181818181818
95374, 1.8521739130435, -0.05, 0.13636363636364
95375, 1.8521739130435, -0.05, 0.090909090909091
95376, 1.8521739130435, -0.05, 0.045454545454545
95377, 1.895652173913, -0.05, 0.45454545454545
95378, 1.895652173913, -0.05, 0.40909090909091
95379, 1.895652173913, -0.05, 0.36363636363636
95380, 1.895652173913, -0.05, 0.31818181818182
95381, 1.895652173913, -0.05, 0.27272727272727
95382, 1.895652173913, -0.05, 0.22727272727273
95383, 1.895652173913, -0.05, 0.18181818181818
95384, 1.895652173913, -0.05, 0.13636363636364
95385, 1.895652173913, -0.05, 0.090909090909091
95386, 1.895652173913, -0.05, 0.045454545454545
95387, 1.9391304347826, -0.05, 0.45454545454545
95388, 1.9391304347826, -0.05, 0.40909090909091
95389, 1.9391304347826, -0.05, 0.36363636363636
95390, 1.9391304347826, -0.05, 0.31818181818182
95391, 1.9391304347826, -0.05, 0.27272727272727
95392, 1.9391304347826, -0.05, 0.22727272727273
95393, 1.9391304347826, -0.05, 0.18181818181818
95394, 1.9391304347826, -0.05, 0.13636363636364
95395, 1.9391304347826, -0.05, 0.090909090909091
95396, 1.9391304347826, -0.05, 0.045454545454545
95397, 1.9826086956522, -0.05, 0.45454545454545
95398, 1.9826086956522, -0.05, 0.40909090909091
95399, 1.9826086956522, -0.05, 0.36363636363636
95400, 1.9826086956522, -0.05, 0.31818181818182
95401, 1.9826086956522, -0.05, 0.27272727272727
95402, 1.9826086956522, -0.05, 0.22727272727273
95403, 1.9826086956522, -0.05, 0.18181818181818
95404, 1.9826086956522, -0.05, 0.13636363636364
95405, 1.9826086956522, -0.05, 0.090909090909091
95406, 1.9826086956522, -0.05, 0.045454545454545
95407, 2.0260869565217, -0.05, 0.45454545454545
95408, 2.0260869565217, -0.05, 0.40909090909091
