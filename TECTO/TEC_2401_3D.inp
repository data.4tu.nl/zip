97509, 1.5478260869565, -0.15, 0.15909090909091
97510, 1.5260869565217, -0.15, 0.13636363636364
97511, 1.5478260869565, -0.125, 0.13636363636364
97512, 1.5478260869565, -0.15, 0.11363636363636
97513, 1.5260869565217, -0.15, 0.090909090909091
97514, 1.5478260869565, -0.125, 0.090909090909091
97515, 1.5478260869565, -0.15, 0.068181818181818
97516, 1.5260869565217, -0.15, 0.045454545454545
97517, 1.5478260869565, -0.125, 0.045454545454545
97518, 1.5478260869565, -0.15, 0.022727272727273
97519, 1.5913043478261, -0.15, 0.47727272727273
97520, 1.5695652173913, -0.15, 0.45454545454545
97521, 1.5913043478261, -0.125, 0.45454545454545
97522, 1.5913043478261, -0.15, 0.43181818181818
97523, 1.5695652173913, -0.15, 0.40909090909091
97524, 1.5913043478261, -0.125, 0.40909090909091
97525, 1.5913043478261, -0.15, 0.38636363636364
97526, 1.5695652173913, -0.15, 0.36363636363636
97527, 1.5913043478261, -0.125, 0.36363636363636
97528, 1.5913043478261, -0.15, 0.34090909090909
97529, 1.5695652173913, -0.15, 0.31818181818182
97530, 1.5913043478261, -0.125, 0.31818181818182
97531, 1.5913043478261, -0.15, 0.29545454545455
97532, 1.5695652173913, -0.15, 0.27272727272727
97533, 1.5913043478261, -0.125, 0.27272727272727
97534, 1.5913043478261, -0.15, 0.25
97535, 1.5695652173913, -0.15, 0.22727272727273
97536, 1.5913043478261, -0.125, 0.22727272727273
97537, 1.5913043478261, -0.15, 0.20454545454545
97538, 1.5695652173913, -0.15, 0.18181818181818
97539, 1.5913043478261, -0.125, 0.18181818181818
97540, 1.5913043478261, -0.15, 0.15909090909091
97541, 1.5695652173913, -0.15, 0.13636363636364
97542, 1.5913043478261, -0.125, 0.13636363636364
97543, 1.5913043478261, -0.15, 0.11363636363636
97544, 1.5695652173913, -0.15, 0.090909090909091
97545, 1.5913043478261, -0.125, 0.090909090909091
97546, 1.5913043478261, -0.15, 0.068181818181818
97547, 1.5695652173913, -0.15, 0.045454545454545
97548, 1.5913043478261, -0.125, 0.045454545454545
97549, 1.5913043478261, -0.15, 0.022727272727273
97550, 1.6347826086957, -0.15, 0.47727272727273
97551, 1.6130434782609, -0.15, 0.45454545454545
97552, 1.6347826086957, -0.125, 0.45454545454545
97553, 1.6347826086957, -0.15, 0.43181818181818
97554, 1.6130434782609, -0.15, 0.40909090909091
97555, 1.6347826086957, -0.125, 0.40909090909091
97556, 1.6347826086957, -0.15, 0.38636363636364
97557, 1.6130434782609, -0.15, 0.36363636363636
97558, 1.6347826086957, -0.125, 0.36363636363636
97559, 1.6347826086957, -0.15, 0.34090909090909
97560, 1.6130434782609, -0.15, 0.31818181818182
97561, 1.6347826086957, -0.125, 0.31818181818182
97562, 1.6347826086957, -0.15, 0.29545454545455
97563, 1.6130434782609, -0.15, 0.27272727272727
97564, 1.6347826086957, -0.125, 0.27272727272727
97565, 1.6347826086957, -0.15, 0.25
97566, 1.6130434782609, -0.15, 0.22727272727273
97567, 1.6347826086957, -0.125, 0.22727272727273
97568, 1.6347826086957, -0.15, 0.20454545454545
97569, 1.6130434782609, -0.15, 0.18181818181818
97570, 1.6347826086957, -0.125, 0.18181818181818
97571, 1.6347826086957, -0.15, 0.15909090909091
97572, 1.6130434782609, -0.15, 0.13636363636364
97573, 1.6347826086957, -0.125, 0.13636363636364
97574, 1.6347826086957, -0.15, 0.11363636363636
97575, 1.6130434782609, -0.15, 0.090909090909091
97576, 1.6347826086957, -0.125, 0.090909090909091
97577, 1.6347826086957, -0.15, 0.068181818181818
97578, 1.6130434782609, -0.15, 0.045454545454545
97579, 1.6347826086957, -0.125, 0.045454545454545
97580, 1.6347826086957, -0.15, 0.022727272727273
97581, 1.6782608695652, -0.15, 0.47727272727273
97582, 1.6565217391304, -0.15, 0.45454545454545
97583, 1.6782608695652, -0.125, 0.45454545454545
97584, 1.6782608695652, -0.15, 0.43181818181818
97585, 1.6565217391304, -0.15, 0.40909090909091
97586, 1.6782608695652, -0.125, 0.40909090909091
97587, 1.6782608695652, -0.15, 0.38636363636364
97588, 1.6565217391304, -0.15, 0.36363636363636
97589, 1.6782608695652, -0.125, 0.36363636363636
97590, 1.6782608695652, -0.15, 0.34090909090909
97591, 1.6565217391304, -0.15, 0.31818181818182
97592, 1.6782608695652, -0.125, 0.31818181818182
97593, 1.6782608695652, -0.15, 0.29545454545455
97594, 1.6565217391304, -0.15, 0.27272727272727
97595, 1.6782608695652, -0.125, 0.27272727272727
97596, 1.6782608695652, -0.15, 0.25
97597, 1.6565217391304, -0.15, 0.22727272727273
97598, 1.6782608695652, -0.125, 0.22727272727273
97599, 1.6782608695652, -0.15, 0.20454545454545
97600, 1.6565217391304, -0.15, 0.18181818181818
97601, 1.6782608695652, -0.125, 0.18181818181818
97602, 1.6782608695652, -0.15, 0.15909090909091
97603, 1.6565217391304, -0.15, 0.13636363636364
97604, 1.6782608695652, -0.125, 0.13636363636364
97605, 1.6782608695652, -0.15, 0.11363636363636
97606, 1.6565217391304, -0.15, 0.090909090909091
97607, 1.6782608695652, -0.125, 0.090909090909091
97608, 1.6782608695652, -0.15, 0.068181818181818
97609, 1.6565217391304, -0.15, 0.045454545454545
97610, 1.6782608695652, -0.125, 0.045454545454545
97611, 1.6782608695652, -0.15, 0.022727272727273
97612, 1.7217391304348, -0.15, 0.47727272727273
97613, 1.7, -0.15, 0.45454545454545
97614, 1.7217391304348, -0.125, 0.45454545454545
97615, 1.7217391304348, -0.15, 0.43181818181818
97616, 1.7, -0.15, 0.40909090909091
97617, 1.7217391304348, -0.125, 0.40909090909091
97618, 1.7217391304348, -0.15, 0.38636363636364
97619, 1.7, -0.15, 0.36363636363636
97620, 1.7217391304348, -0.125, 0.36363636363636
97621, 1.7217391304348, -0.15, 0.34090909090909
97622, 1.7, -0.15, 0.31818181818182
97623, 1.7217391304348, -0.125, 0.31818181818182
97624, 1.7217391304348, -0.15, 0.29545454545455
97625, 1.7, -0.15, 0.27272727272727
97626, 1.7217391304348, -0.125, 0.27272727272727
97627, 1.7217391304348, -0.15, 0.25
97628, 1.7, -0.15, 0.22727272727273
97629, 1.7217391304348, -0.125, 0.22727272727273
97630, 1.7217391304348, -0.15, 0.20454545454545
97631, 1.7, -0.15, 0.18181818181818
97632, 1.7217391304348, -0.125, 0.18181818181818
97633, 1.7217391304348, -0.15, 0.15909090909091
97634, 1.7, -0.15, 0.13636363636364
97635, 1.7217391304348, -0.125, 0.13636363636364
97636, 1.7217391304348, -0.15, 0.11363636363636
97637, 1.7, -0.15, 0.090909090909091
97638, 1.7217391304348, -0.125, 0.090909090909091
97639, 1.7217391304348, -0.15, 0.068181818181818
97640, 1.7, -0.15, 0.045454545454545
97641, 1.7217391304348, -0.125, 0.045454545454545
97642, 1.7217391304348, -0.15, 0.022727272727273
97643, 1.7652173913043, -0.15, 0.47727272727273
97644, 1.7434782608696, -0.15, 0.45454545454545
97645, 1.7652173913043, -0.125, 0.45454545454545
97646, 1.7652173913043, -0.15, 0.43181818181818
97647, 1.7434782608696, -0.15, 0.40909090909091
97648, 1.7652173913043, -0.125, 0.40909090909091
97649, 1.7652173913043, -0.15, 0.38636363636364
97650, 1.7434782608696, -0.15, 0.36363636363636
97651, 1.7652173913043, -0.125, 0.36363636363636
97652, 1.7652173913043, -0.15, 0.34090909090909
97653, 1.7434782608696, -0.15, 0.31818181818182
97654, 1.7652173913043, -0.125, 0.31818181818182
97655, 1.7652173913043, -0.15, 0.29545454545455
97656, 1.7434782608696, -0.15, 0.27272727272727
97657, 1.7652173913043, -0.125, 0.27272727272727
97658, 1.7652173913043, -0.15, 0.25
97659, 1.7434782608696, -0.15, 0.22727272727273
97660, 1.7652173913043, -0.125, 0.22727272727273
97661, 1.7652173913043, -0.15, 0.20454545454545
97662, 1.7434782608696, -0.15, 0.18181818181818
97663, 1.7652173913043, -0.125, 0.18181818181818
97664, 1.7652173913043, -0.15, 0.15909090909091
97665, 1.7434782608696, -0.15, 0.13636363636364
97666, 1.7652173913043, -0.125, 0.13636363636364
97667, 1.7652173913043, -0.15, 0.11363636363636
97668, 1.7434782608696, -0.15, 0.090909090909091
97669, 1.7652173913043, -0.125, 0.090909090909091
97670, 1.7652173913043, -0.15, 0.068181818181818
97671, 1.7434782608696, -0.15, 0.045454545454545
97672, 1.7652173913043, -0.125, 0.045454545454545
97673, 1.7652173913043, -0.15, 0.022727272727273
97674, 1.8086956521739, -0.15, 0.47727272727273
97675, 1.7869565217391, -0.15, 0.45454545454545
97676, 1.8086956521739, -0.125, 0.45454545454545
97677, 1.8086956521739, -0.15, 0.43181818181818
97678, 1.7869565217391, -0.15, 0.40909090909091
97679, 1.8086956521739, -0.125, 0.40909090909091
97680, 1.8086956521739, -0.15, 0.38636363636364
97681, 1.7869565217391, -0.15, 0.36363636363636
97682, 1.8086956521739, -0.125, 0.36363636363636
97683, 1.8086956521739, -0.15, 0.34090909090909
97684, 1.7869565217391, -0.15, 0.31818181818182
97685, 1.8086956521739, -0.125, 0.31818181818182
97686, 1.8086956521739, -0.15, 0.29545454545455
97687, 1.7869565217391, -0.15, 0.27272727272727
97688, 1.8086956521739, -0.125, 0.27272727272727
97689, 1.8086956521739, -0.15, 0.25
97690, 1.7869565217391, -0.15, 0.22727272727273
97691, 1.8086956521739, -0.125, 0.22727272727273
97692, 1.8086956521739, -0.15, 0.20454545454545
97693, 1.7869565217391, -0.15, 0.18181818181818
97694, 1.8086956521739, -0.125, 0.18181818181818
97695, 1.8086956521739, -0.15, 0.15909090909091
97696, 1.7869565217391, -0.15, 0.13636363636364
97697, 1.8086956521739, -0.125, 0.13636363636364
97698, 1.8086956521739, -0.15, 0.11363636363636
97699, 1.7869565217391, -0.15, 0.090909090909091
97700, 1.8086956521739, -0.125, 0.090909090909091
97701, 1.8086956521739, -0.15, 0.068181818181818
97702, 1.7869565217391, -0.15, 0.045454545454545
97703, 1.8086956521739, -0.125, 0.045454545454545
97704, 1.8086956521739, -0.15, 0.022727272727273
97705, 1.8521739130435, -0.15, 0.47727272727273
97706, 1.8304347826087, -0.15, 0.45454545454545
97707, 1.8521739130435, -0.125, 0.45454545454545
97708, 1.8521739130435, -0.15, 0.43181818181818
97709, 1.8304347826087, -0.15, 0.40909090909091
97710, 1.8521739130435, -0.125, 0.40909090909091
97711, 1.8521739130435, -0.15, 0.38636363636364
97712, 1.8304347826087, -0.15, 0.36363636363636
97713, 1.8521739130435, -0.125, 0.36363636363636
97714, 1.8521739130435, -0.15, 0.34090909090909
97715, 1.8304347826087, -0.15, 0.31818181818182
97716, 1.8521739130435, -0.125, 0.31818181818182
97717, 1.8521739130435, -0.15, 0.29545454545455
97718, 1.8304347826087, -0.15, 0.27272727272727
97719, 1.8521739130435, -0.125, 0.27272727272727
97720, 1.8521739130435, -0.15, 0.25
97721, 1.8304347826087, -0.15, 0.22727272727273
97722, 1.8521739130435, -0.125, 0.22727272727273
97723, 1.8521739130435, -0.15, 0.20454545454545
97724, 1.8304347826087, -0.15, 0.18181818181818
97725, 1.8521739130435, -0.125, 0.18181818181818
97726, 1.8521739130435, -0.15, 0.15909090909091
97727, 1.8304347826087, -0.15, 0.13636363636364
97728, 1.8521739130435, -0.125, 0.13636363636364
97729, 1.8521739130435, -0.15, 0.11363636363636
97730, 1.8304347826087, -0.15, 0.090909090909091
97731, 1.8521739130435, -0.125, 0.090909090909091
97732, 1.8521739130435, -0.15, 0.068181818181818
97733, 1.8304347826087, -0.15, 0.045454545454545
97734, 1.8521739130435, -0.125, 0.045454545454545
97735, 1.8521739130435, -0.15, 0.022727272727273
97736, 1.895652173913, -0.15, 0.47727272727273
97737, 1.8739130434783, -0.15, 0.45454545454545
97738, 1.895652173913, -0.125, 0.45454545454545
97739, 1.895652173913, -0.15, 0.43181818181818
97740, 1.8739130434783, -0.15, 0.40909090909091
97741, 1.895652173913, -0.125, 0.40909090909091
97742, 1.895652173913, -0.15, 0.38636363636364
97743, 1.8739130434783, -0.15, 0.36363636363636
97744, 1.895652173913, -0.125, 0.36363636363636
97745, 1.895652173913, -0.15, 0.34090909090909
97746, 1.8739130434783, -0.15, 0.31818181818182
97747, 1.895652173913, -0.125, 0.31818181818182
97748, 1.895652173913, -0.15, 0.29545454545455
97749, 1.8739130434783, -0.15, 0.27272727272727
97750, 1.895652173913, -0.125, 0.27272727272727
97751, 1.895652173913, -0.15, 0.25
97752, 1.8739130434783, -0.15, 0.22727272727273
97753, 1.895652173913, -0.125, 0.22727272727273
97754, 1.895652173913, -0.15, 0.20454545454545
97755, 1.8739130434783, -0.15, 0.18181818181818
97756, 1.895652173913, -0.125, 0.18181818181818
97757, 1.895652173913, -0.15, 0.15909090909091
97758, 1.8739130434783, -0.15, 0.13636363636364
97759, 1.895652173913, -0.125, 0.13636363636364
97760, 1.895652173913, -0.15, 0.11363636363636
97761, 1.8739130434783, -0.15, 0.090909090909091
97762, 1.895652173913, -0.125, 0.090909090909091
97763, 1.895652173913, -0.15, 0.068181818181818
97764, 1.8739130434783, -0.15, 0.045454545454545
97765, 1.895652173913, -0.125, 0.045454545454545
97766, 1.895652173913, -0.15, 0.022727272727273
97767, 1.9391304347826, -0.15, 0.47727272727273
97768, 1.9173913043478, -0.15, 0.45454545454545
97769, 1.9391304347826, -0.125, 0.45454545454545
97770, 1.9391304347826, -0.15, 0.43181818181818
97771, 1.9173913043478, -0.15, 0.40909090909091
97772, 1.9391304347826, -0.125, 0.40909090909091
97773, 1.9391304347826, -0.15, 0.38636363636364
97774, 1.9173913043478, -0.15, 0.36363636363636
97775, 1.9391304347826, -0.125, 0.36363636363636
97776, 1.9391304347826, -0.15, 0.34090909090909
97777, 1.9173913043478, -0.15, 0.31818181818182
97778, 1.9391304347826, -0.125, 0.31818181818182
97779, 1.9391304347826, -0.15, 0.29545454545455
97780, 1.9173913043478, -0.15, 0.27272727272727
97781, 1.9391304347826, -0.125, 0.27272727272727
97782, 1.9391304347826, -0.15, 0.25
97783, 1.9173913043478, -0.15, 0.22727272727273
97784, 1.9391304347826, -0.125, 0.22727272727273
97785, 1.9391304347826, -0.15, 0.20454545454545
97786, 1.9173913043478, -0.15, 0.18181818181818
97787, 1.9391304347826, -0.125, 0.18181818181818
97788, 1.9391304347826, -0.15, 0.15909090909091
97789, 1.9173913043478, -0.15, 0.13636363636364
97790, 1.9391304347826, -0.125, 0.13636363636364
97791, 1.9391304347826, -0.15, 0.11363636363636
97792, 1.9173913043478, -0.15, 0.090909090909091
97793, 1.9391304347826, -0.125, 0.090909090909091
97794, 1.9391304347826, -0.15, 0.068181818181818
97795, 1.9173913043478, -0.15, 0.045454545454545
97796, 1.9391304347826, -0.125, 0.045454545454545
97797, 1.9391304347826, -0.15, 0.022727272727273
97798, 1.9826086956522, -0.15, 0.47727272727273
97799, 1.9608695652174, -0.15, 0.45454545454545
97800, 1.9826086956522, -0.125, 0.45454545454545
97801, 1.9826086956522, -0.15, 0.43181818181818
97802, 1.9608695652174, -0.15, 0.40909090909091
97803, 1.9826086956522, -0.125, 0.40909090909091
97804, 1.9826086956522, -0.15, 0.38636363636364
97805, 1.9608695652174, -0.15, 0.36363636363636
97806, 1.9826086956522, -0.125, 0.36363636363636
97807, 1.9826086956522, -0.15, 0.34090909090909
97808, 1.9608695652174, -0.15, 0.31818181818182
97809, 1.9826086956522, -0.125, 0.31818181818182
97810, 1.9826086956522, -0.15, 0.29545454545455
97811, 1.9608695652174, -0.15, 0.27272727272727
97812, 1.9826086956522, -0.125, 0.27272727272727
97813, 1.9826086956522, -0.15, 0.25
97814, 1.9608695652174, -0.15, 0.22727272727273
97815, 1.9826086956522, -0.125, 0.22727272727273
97816, 1.9826086956522, -0.15, 0.20454545454545
97817, 1.9608695652174, -0.15, 0.18181818181818
97818, 1.9826086956522, -0.125, 0.18181818181818
97819, 1.9826086956522, -0.15, 0.15909090909091
97820, 1.9608695652174, -0.15, 0.13636363636364
97821, 1.9826086956522, -0.125, 0.13636363636364
97822, 1.9826086956522, -0.15, 0.11363636363636
97823, 1.9608695652174, -0.15, 0.090909090909091
97824, 1.9826086956522, -0.125, 0.090909090909091
97825, 1.9826086956522, -0.15, 0.068181818181818
97826, 1.9608695652174, -0.15, 0.045454545454545
97827, 1.9826086956522, -0.125, 0.045454545454545
97828, 1.9826086956522, -0.15, 0.022727272727273
97829, 2.0260869565217, -0.15, 0.47727272727273
97830, 2.004347826087, -0.15, 0.45454545454545
97831, 2.0260869565217, -0.125, 0.45454545454545
97832, 2.0260869565217, -0.15, 0.43181818181818
97833, 2.004347826087, -0.15, 0.40909090909091
97834, 2.0260869565217, -0.125, 0.40909090909091
97835, 2.0260869565217, -0.15, 0.38636363636364
97836, 2.004347826087, -0.15, 0.36363636363636
97837, 2.0260869565217, -0.125, 0.36363636363636
97838, 2.0260869565217, -0.15, 0.34090909090909
97839, 2.004347826087, -0.15, 0.31818181818182
97840, 2.0260869565217, -0.125, 0.31818181818182
97841, 2.0260869565217, -0.15, 0.29545454545455
97842, 2.004347826087, -0.15, 0.27272727272727
97843, 2.0260869565217, -0.125, 0.27272727272727
97844, 2.0260869565217, -0.15, 0.25
97845, 2.004347826087, -0.15, 0.22727272727273
97846, 2.0260869565217, -0.125, 0.22727272727273
97847, 2.0260869565217, -0.15, 0.20454545454545
97848, 2.004347826087, -0.15, 0.18181818181818
97849, 2.0260869565217, -0.125, 0.18181818181818
97850, 2.0260869565217, -0.15, 0.15909090909091
97851, 2.004347826087, -0.15, 0.13636363636364
97852, 2.0260869565217, -0.125, 0.13636363636364
97853, 2.0260869565217, -0.15, 0.11363636363636
97854, 2.004347826087, -0.15, 0.090909090909091
97855, 2.0260869565217, -0.125, 0.090909090909091
97856, 2.0260869565217, -0.15, 0.068181818181818
97857, 2.004347826087, -0.15, 0.045454545454545
97858, 2.0260869565217, -0.125, 0.045454545454545
97859, 2.0260869565217, -0.15, 0.022727272727273
97860, 2.0695652173913, -0.15, 0.47727272727273
97861, 2.0478260869565, -0.15, 0.45454545454545
97862, 2.0695652173913, -0.125, 0.45454545454545
97863, 2.0695652173913, -0.15, 0.43181818181818
97864, 2.0478260869565, -0.15, 0.40909090909091
97865, 2.0695652173913, -0.125, 0.40909090909091
97866, 2.0695652173913, -0.15, 0.38636363636364
97867, 2.0478260869565, -0.15, 0.36363636363636
97868, 2.0695652173913, -0.125, 0.36363636363636
97869, 2.0695652173913, -0.15, 0.34090909090909
97870, 2.0478260869565, -0.15, 0.31818181818182
97871, 2.0695652173913, -0.125, 0.31818181818182
97872, 2.0695652173913, -0.15, 0.29545454545455
97873, 2.0478260869565, -0.15, 0.27272727272727
97874, 2.0695652173913, -0.125, 0.27272727272727
97875, 2.0695652173913, -0.15, 0.25
97876, 2.0478260869565, -0.15, 0.22727272727273
97877, 2.0695652173913, -0.125, 0.22727272727273
97878, 2.0695652173913, -0.15, 0.20454545454545
97879, 2.0478260869565, -0.15, 0.18181818181818
97880, 2.0695652173913, -0.125, 0.18181818181818
97881, 2.0695652173913, -0.15, 0.15909090909091
97882, 2.0478260869565, -0.15, 0.13636363636364
97883, 2.0695652173913, -0.125, 0.13636363636364
97884, 2.0695652173913, -0.15, 0.11363636363636
97885, 2.0478260869565, -0.15, 0.090909090909091
97886, 2.0695652173913, -0.125, 0.090909090909091
97887, 2.0695652173913, -0.15, 0.068181818181818
97888, 2.0478260869565, -0.15, 0.045454545454545
97889, 2.0695652173913, -0.125, 0.045454545454545
97890, 2.0695652173913, -0.15, 0.022727272727273
97891, 2.1130434782609, -0.15, 0.47727272727273
97892, 2.0913043478261, -0.15, 0.45454545454545
97893, 2.1130434782609, -0.125, 0.45454545454545
97894, 2.1130434782609, -0.15, 0.43181818181818
97895, 2.0913043478261, -0.15, 0.40909090909091
97896, 2.1130434782609, -0.125, 0.40909090909091
97897, 2.1130434782609, -0.15, 0.38636363636364
97898, 2.0913043478261, -0.15, 0.36363636363636
97899, 2.1130434782609, -0.125, 0.36363636363636
97900, 2.1130434782609, -0.15, 0.34090909090909
97901, 2.0913043478261, -0.15, 0.31818181818182
97902, 2.1130434782609, -0.125, 0.31818181818182
97903, 2.1130434782609, -0.15, 0.29545454545455
97904, 2.0913043478261, -0.15, 0.27272727272727
97905, 2.1130434782609, -0.125, 0.27272727272727
97906, 2.1130434782609, -0.15, 0.25
97907, 2.0913043478261, -0.15, 0.22727272727273
97908, 2.1130434782609, -0.125, 0.22727272727273
97909, 2.1130434782609, -0.15, 0.20454545454545
97910, 2.0913043478261, -0.15, 0.18181818181818
97911, 2.1130434782609, -0.125, 0.18181818181818
97912, 2.1130434782609, -0.15, 0.15909090909091
97913, 2.0913043478261, -0.15, 0.13636363636364
97914, 2.1130434782609, -0.125, 0.13636363636364
97915, 2.1130434782609, -0.15, 0.11363636363636
97916, 2.0913043478261, -0.15, 0.090909090909091
97917, 2.1130434782609, -0.125, 0.090909090909091
97918, 2.1130434782609, -0.15, 0.068181818181818
97919, 2.0913043478261, -0.15, 0.045454545454545
97920, 2.1130434782609, -0.125, 0.045454545454545
97921, 2.1130434782609, -0.15, 0.022727272727273
97922, 2.1565217391304, -0.15, 0.47727272727273
97923, 2.1347826086957, -0.15, 0.45454545454545
97924, 2.1565217391304, -0.125, 0.45454545454545
97925, 2.1565217391304, -0.15, 0.43181818181818
97926, 2.1347826086957, -0.15, 0.40909090909091
97927, 2.1565217391304, -0.125, 0.40909090909091
97928, 2.1565217391304, -0.15, 0.38636363636364
97929, 2.1347826086957, -0.15, 0.36363636363636
97930, 2.1565217391304, -0.125, 0.36363636363636
97931, 2.1565217391304, -0.15, 0.34090909090909
97932, 2.1347826086957, -0.15, 0.31818181818182
97933, 2.1565217391304, -0.125, 0.31818181818182
97934, 2.1565217391304, -0.15, 0.29545454545455
97935, 2.1347826086957, -0.15, 0.27272727272727
97936, 2.1565217391304, -0.125, 0.27272727272727
97937, 2.1565217391304, -0.15, 0.25
97938, 2.1347826086957, -0.15, 0.22727272727273
97939, 2.1565217391304, -0.125, 0.22727272727273
97940, 2.1565217391304, -0.15, 0.20454545454545
97941, 2.1347826086957, -0.15, 0.18181818181818
97942, 2.1565217391304, -0.125, 0.18181818181818
97943, 2.1565217391304, -0.15, 0.15909090909091
97944, 2.1347826086957, -0.15, 0.13636363636364
97945, 2.1565217391304, -0.125, 0.13636363636364
97946, 2.1565217391304, -0.15, 0.11363636363636
97947, 2.1347826086957, -0.15, 0.090909090909091
97948, 2.1565217391304, -0.125, 0.090909090909091
97949, 2.1565217391304, -0.15, 0.068181818181818
97950, 2.1347826086957, -0.15, 0.045454545454545
97951, 2.1565217391304, -0.125, 0.045454545454545
97952, 2.1565217391304, -0.15, 0.022727272727273
97953, 2.1782608695652, -0.15, 0.45454545454545
97954, 2.1782608695652, -0.15, 0.40909090909091
97955, 2.1782608695652, -0.15, 0.36363636363636
97956, 2.1782608695652, -0.15, 0.31818181818182
97957, 2.1782608695652, -0.15, 0.27272727272727
97958, 2.1782608695652, -0.15, 0.22727272727273
97959, 2.1782608695652, -0.15, 0.18181818181818
97960, 2.1782608695652, -0.15, 0.13636363636364
97961, 2.1782608695652, -0.15, 0.090909090909091
97962, 2.1782608695652, -0.15, 0.045454545454545
97963, 1.2434782608696, -0.175, 0.45454545454545
97964, 1.2434782608696, -0.175, 0.40909090909091
97965, 1.2434782608696, -0.175, 0.36363636363636
97966, 1.2434782608696, -0.175, 0.31818181818182
97967, 1.2434782608696, -0.175, 0.27272727272727
97968, 1.2434782608696, -0.175, 0.22727272727273
97969, 1.2434782608696, -0.175, 0.18181818181818
97970, 1.2434782608696, -0.175, 0.13636363636364
97971, 1.2434782608696, -0.175, 0.090909090909091
97972, 1.2434782608696, -0.175, 0.045454545454545
97973, 1.2869565217391, -0.175, 0.45454545454545
97974, 1.2869565217391, -0.175, 0.40909090909091
97975, 1.2869565217391, -0.175, 0.36363636363636
97976, 1.2869565217391, -0.175, 0.31818181818182
97977, 1.2869565217391, -0.175, 0.27272727272727
97978, 1.2869565217391, -0.175, 0.22727272727273
97979, 1.2869565217391, -0.175, 0.18181818181818
97980, 1.2869565217391, -0.175, 0.13636363636364
97981, 1.2869565217391, -0.175, 0.090909090909091
97982, 1.2869565217391, -0.175, 0.045454545454545
97983, 1.3304347826087, -0.175, 0.45454545454545
97984, 1.3304347826087, -0.175, 0.40909090909091
97985, 1.3304347826087, -0.175, 0.36363636363636
97986, 1.3304347826087, -0.175, 0.31818181818182
97987, 1.3304347826087, -0.175, 0.27272727272727
97988, 1.3304347826087, -0.175, 0.22727272727273
97989, 1.3304347826087, -0.175, 0.18181818181818
97990, 1.3304347826087, -0.175, 0.13636363636364
97991, 1.3304347826087, -0.175, 0.090909090909091
97992, 1.3304347826087, -0.175, 0.045454545454545
97993, 1.3739130434783, -0.175, 0.45454545454545
97994, 1.3739130434783, -0.175, 0.40909090909091
97995, 1.3739130434783, -0.175, 0.36363636363636
97996, 1.3739130434783, -0.175, 0.31818181818182
97997, 1.3739130434783, -0.175, 0.27272727272727
97998, 1.3739130434783, -0.175, 0.22727272727273
97999, 1.3739130434783, -0.175, 0.18181818181818
98000, 1.3739130434783, -0.175, 0.13636363636364
98001, 1.3739130434783, -0.175, 0.090909090909091
98002, 1.3739130434783, -0.175, 0.045454545454545
98003, 1.4173913043478, -0.175, 0.45454545454545
98004, 1.4173913043478, -0.175, 0.40909090909091
98005, 1.4173913043478, -0.175, 0.36363636363636
98006, 1.4173913043478, -0.175, 0.31818181818182
98007, 1.4173913043478, -0.175, 0.27272727272727
98008, 1.4173913043478, -0.175, 0.22727272727273
98009, 1.4173913043478, -0.175, 0.18181818181818
98010, 1.4173913043478, -0.175, 0.13636363636364
98011, 1.4173913043478, -0.175, 0.090909090909091
98012, 1.4173913043478, -0.175, 0.045454545454545
98013, 1.4608695652174, -0.175, 0.45454545454545
98014, 1.4608695652174, -0.175, 0.40909090909091
98015, 1.4608695652174, -0.175, 0.36363636363636
98016, 1.4608695652174, -0.175, 0.31818181818182
98017, 1.4608695652174, -0.175, 0.27272727272727
98018, 1.4608695652174, -0.175, 0.22727272727273
98019, 1.4608695652174, -0.175, 0.18181818181818
98020, 1.4608695652174, -0.175, 0.13636363636364
98021, 1.4608695652174, -0.175, 0.090909090909091
98022, 1.4608695652174, -0.175, 0.045454545454545
98023, 1.504347826087, -0.175, 0.45454545454545
98024, 1.504347826087, -0.175, 0.40909090909091
98025, 1.504347826087, -0.175, 0.36363636363636
98026, 1.504347826087, -0.175, 0.31818181818182
98027, 1.504347826087, -0.175, 0.27272727272727
98028, 1.504347826087, -0.175, 0.22727272727273
98029, 1.504347826087, -0.175, 0.18181818181818
98030, 1.504347826087, -0.175, 0.13636363636364
98031, 1.504347826087, -0.175, 0.090909090909091
98032, 1.504347826087, -0.175, 0.045454545454545
98033, 1.5478260869565, -0.175, 0.45454545454545
98034, 1.5478260869565, -0.175, 0.40909090909091
98035, 1.5478260869565, -0.175, 0.36363636363636
98036, 1.5478260869565, -0.175, 0.31818181818182
98037, 1.5478260869565, -0.175, 0.27272727272727
98038, 1.5478260869565, -0.175, 0.22727272727273
98039, 1.5478260869565, -0.175, 0.18181818181818
98040, 1.5478260869565, -0.175, 0.13636363636364
98041, 1.5478260869565, -0.175, 0.090909090909091
98042, 1.5478260869565, -0.175, 0.045454545454545
98043, 1.5913043478261, -0.175, 0.45454545454545
98044, 1.5913043478261, -0.175, 0.40909090909091
98045, 1.5913043478261, -0.175, 0.36363636363636
98046, 1.5913043478261, -0.175, 0.31818181818182
98047, 1.5913043478261, -0.175, 0.27272727272727
98048, 1.5913043478261, -0.175, 0.22727272727273
98049, 1.5913043478261, -0.175, 0.18181818181818
98050, 1.5913043478261, -0.175, 0.13636363636364
98051, 1.5913043478261, -0.175, 0.090909090909091
98052, 1.5913043478261, -0.175, 0.045454545454545
98053, 1.6347826086957, -0.175, 0.45454545454545
98054, 1.6347826086957, -0.175, 0.40909090909091
98055, 1.6347826086957, -0.175, 0.36363636363636
98056, 1.6347826086957, -0.175, 0.31818181818182
98057, 1.6347826086957, -0.175, 0.27272727272727
98058, 1.6347826086957, -0.175, 0.22727272727273
98059, 1.6347826086957, -0.175, 0.18181818181818
98060, 1.6347826086957, -0.175, 0.13636363636364
98061, 1.6347826086957, -0.175, 0.090909090909091
98062, 1.6347826086957, -0.175, 0.045454545454545
98063, 1.6782608695652, -0.175, 0.45454545454545
98064, 1.6782608695652, -0.175, 0.40909090909091
98065, 1.6782608695652, -0.175, 0.36363636363636
98066, 1.6782608695652, -0.175, 0.31818181818182
98067, 1.6782608695652, -0.175, 0.27272727272727
98068, 1.6782608695652, -0.175, 0.22727272727273
98069, 1.6782608695652, -0.175, 0.18181818181818
98070, 1.6782608695652, -0.175, 0.13636363636364
98071, 1.6782608695652, -0.175, 0.090909090909091
98072, 1.6782608695652, -0.175, 0.045454545454545
98073, 1.7217391304348, -0.175, 0.45454545454545
98074, 1.7217391304348, -0.175, 0.40909090909091
98075, 1.7217391304348, -0.175, 0.36363636363636
98076, 1.7217391304348, -0.175, 0.31818181818182
98077, 1.7217391304348, -0.175, 0.27272727272727
98078, 1.7217391304348, -0.175, 0.22727272727273
98079, 1.7217391304348, -0.175, 0.18181818181818
98080, 1.7217391304348, -0.175, 0.13636363636364
98081, 1.7217391304348, -0.175, 0.090909090909091
98082, 1.7217391304348, -0.175, 0.045454545454545
98083, 1.7652173913043, -0.175, 0.45454545454545
98084, 1.7652173913043, -0.175, 0.40909090909091
98085, 1.7652173913043, -0.175, 0.36363636363636
98086, 1.7652173913043, -0.175, 0.31818181818182
98087, 1.7652173913043, -0.175, 0.27272727272727
98088, 1.7652173913043, -0.175, 0.22727272727273
98089, 1.7652173913043, -0.175, 0.18181818181818
98090, 1.7652173913043, -0.175, 0.13636363636364
98091, 1.7652173913043, -0.175, 0.090909090909091
98092, 1.7652173913043, -0.175, 0.045454545454545
98093, 1.8086956521739, -0.175, 0.45454545454545
98094, 1.8086956521739, -0.175, 0.40909090909091
98095, 1.8086956521739, -0.175, 0.36363636363636
98096, 1.8086956521739, -0.175, 0.31818181818182
98097, 1.8086956521739, -0.175, 0.27272727272727
98098, 1.8086956521739, -0.175, 0.22727272727273
98099, 1.8086956521739, -0.175, 0.18181818181818
98100, 1.8086956521739, -0.175, 0.13636363636364
98101, 1.8086956521739, -0.175, 0.090909090909091
98102, 1.8086956521739, -0.175, 0.045454545454545
98103, 1.8521739130435, -0.175, 0.45454545454545
98104, 1.8521739130435, -0.175, 0.40909090909091
98105, 1.8521739130435, -0.175, 0.36363636363636
98106, 1.8521739130435, -0.175, 0.31818181818182
98107, 1.8521739130435, -0.175, 0.27272727272727
98108, 1.8521739130435, -0.175, 0.22727272727273
98109, 1.8521739130435, -0.175, 0.18181818181818
98110, 1.8521739130435, -0.175, 0.13636363636364
98111, 1.8521739130435, -0.175, 0.090909090909091
98112, 1.8521739130435, -0.175, 0.045454545454545
98113, 1.895652173913, -0.175, 0.45454545454545
98114, 1.895652173913, -0.175, 0.40909090909091
98115, 1.895652173913, -0.175, 0.36363636363636
98116, 1.895652173913, -0.175, 0.31818181818182
98117, 1.895652173913, -0.175, 0.27272727272727
98118, 1.895652173913, -0.175, 0.22727272727273
98119, 1.895652173913, -0.175, 0.18181818181818
98120, 1.895652173913, -0.175, 0.13636363636364
98121, 1.895652173913, -0.175, 0.090909090909091
98122, 1.895652173913, -0.175, 0.045454545454545
98123, 1.9391304347826, -0.175, 0.45454545454545
98124, 1.9391304347826, -0.175, 0.40909090909091
98125, 1.9391304347826, -0.175, 0.36363636363636
98126, 1.9391304347826, -0.175, 0.31818181818182
98127, 1.9391304347826, -0.175, 0.27272727272727
98128, 1.9391304347826, -0.175, 0.22727272727273
98129, 1.9391304347826, -0.175, 0.18181818181818
98130, 1.9391304347826, -0.175, 0.13636363636364
98131, 1.9391304347826, -0.175, 0.090909090909091
98132, 1.9391304347826, -0.175, 0.045454545454545
98133, 1.9826086956522, -0.175, 0.45454545454545
98134, 1.9826086956522, -0.175, 0.40909090909091
98135, 1.9826086956522, -0.175, 0.36363636363636
98136, 1.9826086956522, -0.175, 0.31818181818182
98137, 1.9826086956522, -0.175, 0.27272727272727
98138, 1.9826086956522, -0.175, 0.22727272727273
98139, 1.9826086956522, -0.175, 0.18181818181818
98140, 1.9826086956522, -0.175, 0.13636363636364
98141, 1.9826086956522, -0.175, 0.090909090909091
98142, 1.9826086956522, -0.175, 0.045454545454545
98143, 2.0260869565217, -0.175, 0.45454545454545
98144, 2.0260869565217, -0.175, 0.40909090909091
98145, 2.0260869565217, -0.175, 0.36363636363636
98146, 2.0260869565217, -0.175, 0.31818181818182
98147, 2.0260869565217, -0.175, 0.27272727272727
98148, 2.0260869565217, -0.175, 0.22727272727273
98149, 2.0260869565217, -0.175, 0.18181818181818
98150, 2.0260869565217, -0.175, 0.13636363636364
98151, 2.0260869565217, -0.175, 0.090909090909091
98152, 2.0260869565217, -0.175, 0.045454545454545
98153, 2.0695652173913, -0.175, 0.45454545454545
98154, 2.0695652173913, -0.175, 0.40909090909091
98155, 2.0695652173913, -0.175, 0.36363636363636
98156, 2.0695652173913, -0.175, 0.31818181818182
98157, 2.0695652173913, -0.175, 0.27272727272727
98158, 2.0695652173913, -0.175, 0.22727272727273
98159, 2.0695652173913, -0.175, 0.18181818181818
98160, 2.0695652173913, -0.175, 0.13636363636364
98161, 2.0695652173913, -0.175, 0.090909090909091
98162, 2.0695652173913, -0.175, 0.045454545454545
98163, 2.1130434782609, -0.175, 0.45454545454545
98164, 2.1130434782609, -0.175, 0.40909090909091
98165, 2.1130434782609, -0.175, 0.36363636363636
98166, 2.1130434782609, -0.175, 0.31818181818182
98167, 2.1130434782609, -0.175, 0.27272727272727
98168, 2.1130434782609, -0.175, 0.22727272727273
98169, 2.1130434782609, -0.175, 0.18181818181818
98170, 2.1130434782609, -0.175, 0.13636363636364
98171, 2.1130434782609, -0.175, 0.090909090909091
98172, 2.1130434782609, -0.175, 0.045454545454545
98173, 2.1565217391304, -0.175, 0.45454545454545
98174, 2.1565217391304, -0.175, 0.40909090909091
98175, 2.1565217391304, -0.175, 0.36363636363636
98176, 2.1565217391304, -0.175, 0.31818181818182
98177, 2.1565217391304, -0.175, 0.27272727272727
98178, 2.1565217391304, -0.175, 0.22727272727273
98179, 2.1565217391304, -0.175, 0.18181818181818
98180, 2.1565217391304, -0.175, 0.13636363636364
98181, 2.1565217391304, -0.175, 0.090909090909091
98182, 2.1565217391304, -0.175, 0.045454545454545
98183, 2.2333333333333, -0.05, 0.45454545454545
98184, 2.2333333333333, -0.05, 0.40909090909091
98185, 2.2333333333333, -0.05, 0.36363636363636
98186, 2.2333333333333, -0.05, 0.31818181818182
98187, 2.2333333333333, -0.05, 0.27272727272727
98188, 2.2333333333333, -0.05, 0.22727272727273
98189, 2.2333333333333, -0.05, 0.18181818181818
98190, 2.2333333333333, -0.05, 0.13636363636364
98191, 2.2333333333333, -0.05, 0.090909090909091
98192, 2.2333333333333, -0.05, 0.045454545454545
98193, 2.2666666666667, -0.05, 0.45454545454545
98194, 2.2666666666667, -0.05, 0.40909090909091
98195, 2.2666666666667, -0.05, 0.36363636363636
98196, 2.2666666666667, -0.05, 0.31818181818182
98197, 2.2666666666667, -0.05, 0.27272727272727
98198, 2.2666666666667, -0.05, 0.22727272727273
98199, 2.2666666666667, -0.05, 0.18181818181818
98200, 2.2666666666667, -0.05, 0.13636363636364
98201, 2.2666666666667, -0.05, 0.090909090909091
98202, 2.2666666666667, -0.05, 0.045454545454545
98203, 2.2333333333333, -0.1, 0.45454545454545
98204, 2.2333333333333, -0.1, 0.40909090909091
98205, 2.2333333333333, -0.1, 0.36363636363636
98206, 2.2333333333333, -0.1, 0.31818181818182
98207, 2.2333333333333, -0.1, 0.27272727272727
98208, 2.2333333333333, -0.1, 0.22727272727273
98209, 2.2333333333333, -0.1, 0.18181818181818
98210, 2.2333333333333, -0.1, 0.13636363636364
98211, 2.2333333333333, -0.1, 0.090909090909091
98212, 2.2333333333333, -0.1, 0.045454545454545
98213, 2.2666666666667, -0.1, 0.45454545454545
98214, 2.2666666666667, -0.1, 0.40909090909091
98215, 2.2666666666667, -0.1, 0.36363636363636
98216, 2.2666666666667, -0.1, 0.31818181818182
98217, 2.2666666666667, -0.1, 0.27272727272727
98218, 2.2666666666667, -0.1, 0.22727272727273
98219, 2.2666666666667, -0.1, 0.18181818181818
98220, 2.2666666666667, -0.1, 0.13636363636364
98221, 2.2666666666667, -0.1, 0.090909090909091
98222, 2.2666666666667, -0.1, 0.045454545454545
98223, 2.2333333333333, -0.15, 0.45454545454545
98224, 2.2333333333333, -0.15, 0.40909090909091
98225, 2.2333333333333, -0.15, 0.36363636363636
98226, 2.2333333333333, -0.15, 0.31818181818182
98227, 2.2333333333333, -0.15, 0.27272727272727
98228, 2.2333333333333, -0.15, 0.22727272727273
98229, 2.2333333333333, -0.15, 0.18181818181818
98230, 2.2333333333333, -0.15, 0.13636363636364
98231, 2.2333333333333, -0.15, 0.090909090909091
98232, 2.2333333333333, -0.15, 0.045454545454545
98233, 2.2666666666667, -0.15, 0.45454545454545
98234, 2.2666666666667, -0.15, 0.40909090909091
98235, 2.2666666666667, -0.15, 0.36363636363636
98236, 2.2666666666667, -0.15, 0.31818181818182
98237, 2.2666666666667, -0.15, 0.27272727272727
98238, 2.2666666666667, -0.15, 0.22727272727273
98239, 2.2666666666667, -0.15, 0.18181818181818
98240, 2.2666666666667, -0.15, 0.13636363636364
98241, 2.2666666666667, -0.15, 0.090909090909091
98242, 2.2666666666667, -0.15, 0.045454545454545
98243, 2.2333333333333, -0.05, 0.47727272727273
98244, 2.2166666666667, -0.05, 0.45454545454545
98245, 2.2333333333333, -0.025, 0.45454545454545
98246, 2.2333333333333, -0.05, 0.43181818181818
98247, 2.2166666666667, -0.05, 0.40909090909091
98248, 2.2333333333333, -0.025, 0.40909090909091
98249, 2.2333333333333, -0.05, 0.38636363636364
98250, 2.2166666666667, -0.05, 0.36363636363636
98251, 2.2333333333333, -0.025, 0.36363636363636
98252, 2.2333333333333, -0.05, 0.34090909090909
98253, 2.2166666666667, -0.05, 0.31818181818182
98254, 2.2333333333333, -0.025, 0.31818181818182
98255, 2.2333333333333, -0.05, 0.29545454545455
98256, 2.2166666666667, -0.05, 0.27272727272727
98257, 2.2333333333333, -0.025, 0.27272727272727
98258, 2.2333333333333, -0.05, 0.25
98259, 2.2166666666667, -0.05, 0.22727272727273
98260, 2.2333333333333, -0.025, 0.22727272727273
98261, 2.2333333333333, -0.05, 0.20454545454545
98262, 2.2166666666667, -0.05, 0.18181818181818
98263, 2.2333333333333, -0.025, 0.18181818181818
98264, 2.2333333333333, -0.05, 0.15909090909091
98265, 2.2166666666667, -0.05, 0.13636363636364
98266, 2.2333333333333, -0.025, 0.13636363636364
98267, 2.2333333333333, -0.05, 0.11363636363636
98268, 2.2166666666667, -0.05, 0.090909090909091
98269, 2.2333333333333, -0.025, 0.090909090909091
98270, 2.2333333333333, -0.05, 0.068181818181818
98271, 2.2166666666667, -0.05, 0.045454545454545
98272, 2.2333333333333, -0.025, 0.045454545454545
98273, 2.2333333333333, -0.05, 0.022727272727273
98274, 2.2666666666667, -0.05, 0.47727272727273
98275, 2.25, -0.05, 0.45454545454545
98276, 2.2666666666667, -0.025, 0.45454545454545
98277, 2.2666666666667, -0.05, 0.43181818181818
98278, 2.25, -0.05, 0.40909090909091
98279, 2.2666666666667, -0.025, 0.40909090909091
98280, 2.2666666666667, -0.05, 0.38636363636364
98281, 2.25, -0.05, 0.36363636363636
98282, 2.2666666666667, -0.025, 0.36363636363636
98283, 2.2666666666667, -0.05, 0.34090909090909
98284, 2.25, -0.05, 0.31818181818182
98285, 2.2666666666667, -0.025, 0.31818181818182
98286, 2.2666666666667, -0.05, 0.29545454545455
98287, 2.25, -0.05, 0.27272727272727
98288, 2.2666666666667, -0.025, 0.27272727272727
98289, 2.2666666666667, -0.05, 0.25
98290, 2.25, -0.05, 0.22727272727273
98291, 2.2666666666667, -0.025, 0.22727272727273
98292, 2.2666666666667, -0.05, 0.20454545454545
98293, 2.25, -0.05, 0.18181818181818
98294, 2.2666666666667, -0.025, 0.18181818181818
98295, 2.2666666666667, -0.05, 0.15909090909091
98296, 2.25, -0.05, 0.13636363636364
98297, 2.2666666666667, -0.025, 0.13636363636364
98298, 2.2666666666667, -0.05, 0.11363636363636
98299, 2.25, -0.05, 0.090909090909091
98300, 2.2666666666667, -0.025, 0.090909090909091
98301, 2.2666666666667, -0.05, 0.068181818181818
98302, 2.25, -0.05, 0.045454545454545
98303, 2.2666666666667, -0.025, 0.045454545454545
98304, 2.2666666666667, -0.05, 0.022727272727273
98305, 2.2833333333333, -0.05, 0.45454545454545
98306, 2.2833333333333, -0.05, 0.40909090909091
98307, 2.2833333333333, -0.05, 0.36363636363636
98308, 2.2833333333333, -0.05, 0.31818181818182
98309, 2.2833333333333, -0.05, 0.27272727272727
98310, 2.2833333333333, -0.05, 0.22727272727273
98311, 2.2833333333333, -0.05, 0.18181818181818
98312, 2.2833333333333, -0.05, 0.13636363636364
98313, 2.2833333333333, -0.05, 0.090909090909091
98314, 2.2833333333333, -0.05, 0.045454545454545
98315, 2.2333333333333, -0.1, 0.47727272727273
98316, 2.2166666666667, -0.1, 0.45454545454545
98317, 2.2333333333333, -0.075, 0.45454545454545
98318, 2.2333333333333, -0.1, 0.43181818181818
98319, 2.2166666666667, -0.1, 0.40909090909091
98320, 2.2333333333333, -0.075, 0.40909090909091
98321, 2.2333333333333, -0.1, 0.38636363636364
98322, 2.2166666666667, -0.1, 0.36363636363636
98323, 2.2333333333333, -0.075, 0.36363636363636
98324, 2.2333333333333, -0.1, 0.34090909090909
98325, 2.2166666666667, -0.1, 0.31818181818182
98326, 2.2333333333333, -0.075, 0.31818181818182
98327, 2.2333333333333, -0.1, 0.29545454545455
98328, 2.2166666666667, -0.1, 0.27272727272727
98329, 2.2333333333333, -0.075, 0.27272727272727
98330, 2.2333333333333, -0.1, 0.25
98331, 2.2166666666667, -0.1, 0.22727272727273
98332, 2.2333333333333, -0.075, 0.22727272727273
98333, 2.2333333333333, -0.1, 0.20454545454545
98334, 2.2166666666667, -0.1, 0.18181818181818
98335, 2.2333333333333, -0.075, 0.18181818181818
98336, 2.2333333333333, -0.1, 0.15909090909091
98337, 2.2166666666667, -0.1, 0.13636363636364
98338, 2.2333333333333, -0.075, 0.13636363636364
98339, 2.2333333333333, -0.1, 0.11363636363636
98340, 2.2166666666667, -0.1, 0.090909090909091
98341, 2.2333333333333, -0.075, 0.090909090909091
98342, 2.2333333333333, -0.1, 0.068181818181818
98343, 2.2166666666667, -0.1, 0.045454545454545
98344, 2.2333333333333, -0.075, 0.045454545454545
98345, 2.2333333333333, -0.1, 0.022727272727273
98346, 2.2666666666667, -0.1, 0.47727272727273
98347, 2.25, -0.1, 0.45454545454545
98348, 2.2666666666667, -0.075, 0.45454545454545
98349, 2.2666666666667, -0.1, 0.43181818181818
98350, 2.25, -0.1, 0.40909090909091
98351, 2.2666666666667, -0.075, 0.40909090909091
98352, 2.2666666666667, -0.1, 0.38636363636364
98353, 2.25, -0.1, 0.36363636363636
98354, 2.2666666666667, -0.075, 0.36363636363636
98355, 2.2666666666667, -0.1, 0.34090909090909
98356, 2.25, -0.1, 0.31818181818182
98357, 2.2666666666667, -0.075, 0.31818181818182
98358, 2.2666666666667, -0.1, 0.29545454545455
98359, 2.25, -0.1, 0.27272727272727
98360, 2.2666666666667, -0.075, 0.27272727272727
98361, 2.2666666666667, -0.1, 0.25
98362, 2.25, -0.1, 0.22727272727273
98363, 2.2666666666667, -0.075, 0.22727272727273
98364, 2.2666666666667, -0.1, 0.20454545454545
98365, 2.25, -0.1, 0.18181818181818
98366, 2.2666666666667, -0.075, 0.18181818181818
98367, 2.2666666666667, -0.1, 0.15909090909091
98368, 2.25, -0.1, 0.13636363636364
98369, 2.2666666666667, -0.075, 0.13636363636364
98370, 2.2666666666667, -0.1, 0.11363636363636
98371, 2.25, -0.1, 0.090909090909091
98372, 2.2666666666667, -0.075, 0.090909090909091
98373, 2.2666666666667, -0.1, 0.068181818181818
98374, 2.25, -0.1, 0.045454545454545
98375, 2.2666666666667, -0.075, 0.045454545454545
98376, 2.2666666666667, -0.1, 0.022727272727273
98377, 2.2833333333333, -0.1, 0.45454545454545
98378, 2.2833333333333, -0.1, 0.40909090909091
98379, 2.2833333333333, -0.1, 0.36363636363636
98380, 2.2833333333333, -0.1, 0.31818181818182
98381, 2.2833333333333, -0.1, 0.27272727272727
98382, 2.2833333333333, -0.1, 0.22727272727273
98383, 2.2833333333333, -0.1, 0.18181818181818
98384, 2.2833333333333, -0.1, 0.13636363636364
98385, 2.2833333333333, -0.1, 0.090909090909091
98386, 2.2833333333333, -0.1, 0.045454545454545
98387, 2.2333333333333, -0.15, 0.47727272727273
98388, 2.2166666666667, -0.15, 0.45454545454545
98389, 2.2333333333333, -0.125, 0.45454545454545
98390, 2.2333333333333, -0.15, 0.43181818181818
98391, 2.2166666666667, -0.15, 0.40909090909091
98392, 2.2333333333333, -0.125, 0.40909090909091
98393, 2.2333333333333, -0.15, 0.38636363636364
98394, 2.2166666666667, -0.15, 0.36363636363636
98395, 2.2333333333333, -0.125, 0.36363636363636
98396, 2.2333333333333, -0.15, 0.34090909090909
98397, 2.2166666666667, -0.15, 0.31818181818182
98398, 2.2333333333333, -0.125, 0.31818181818182
98399, 2.2333333333333, -0.15, 0.29545454545455
98400, 2.2166666666667, -0.15, 0.27272727272727
98401, 2.2333333333333, -0.125, 0.27272727272727
98402, 2.2333333333333, -0.15, 0.25
98403, 2.2166666666667, -0.15, 0.22727272727273
98404, 2.2333333333333, -0.125, 0.22727272727273
98405, 2.2333333333333, -0.15, 0.20454545454545
98406, 2.2166666666667, -0.15, 0.18181818181818
98407, 2.2333333333333, -0.125, 0.18181818181818
98408, 2.2333333333333, -0.15, 0.15909090909091
98409, 2.2166666666667, -0.15, 0.13636363636364
98410, 2.2333333333333, -0.125, 0.13636363636364
98411, 2.2333333333333, -0.15, 0.11363636363636
98412, 2.2166666666667, -0.15, 0.090909090909091
98413, 2.2333333333333, -0.125, 0.090909090909091
98414, 2.2333333333333, -0.15, 0.068181818181818
98415, 2.2166666666667, -0.15, 0.045454545454545
98416, 2.2333333333333, -0.125, 0.045454545454545
98417, 2.2333333333333, -0.15, 0.022727272727273
98418, 2.2666666666667, -0.15, 0.47727272727273
98419, 2.25, -0.15, 0.45454545454545
98420, 2.2666666666667, -0.125, 0.45454545454545
98421, 2.2666666666667, -0.15, 0.43181818181818
98422, 2.25, -0.15, 0.40909090909091
98423, 2.2666666666667, -0.125, 0.40909090909091
98424, 2.2666666666667, -0.15, 0.38636363636364
98425, 2.25, -0.15, 0.36363636363636
98426, 2.2666666666667, -0.125, 0.36363636363636
98427, 2.2666666666667, -0.15, 0.34090909090909
98428, 2.25, -0.15, 0.31818181818182
98429, 2.2666666666667, -0.125, 0.31818181818182
98430, 2.2666666666667, -0.15, 0.29545454545455
98431, 2.25, -0.15, 0.27272727272727
98432, 2.2666666666667, -0.125, 0.27272727272727
98433, 2.2666666666667, -0.15, 0.25
98434, 2.25, -0.15, 0.22727272727273
98435, 2.2666666666667, -0.125, 0.22727272727273
98436, 2.2666666666667, -0.15, 0.20454545454545
98437, 2.25, -0.15, 0.18181818181818
98438, 2.2666666666667, -0.125, 0.18181818181818
98439, 2.2666666666667, -0.15, 0.15909090909091
98440, 2.25, -0.15, 0.13636363636364
98441, 2.2666666666667, -0.125, 0.13636363636364
98442, 2.2666666666667, -0.15, 0.11363636363636
98443, 2.25, -0.15, 0.090909090909091
98444, 2.2666666666667, -0.125, 0.090909090909091
98445, 2.2666666666667, -0.15, 0.068181818181818
98446, 2.25, -0.15, 0.045454545454545
98447, 2.2666666666667, -0.125, 0.045454545454545
98448, 2.2666666666667, -0.15, 0.022727272727273
98449, 2.2833333333333, -0.15, 0.45454545454545
98450, 2.2833333333333, -0.15, 0.40909090909091
98451, 2.2833333333333, -0.15, 0.36363636363636
98452, 2.2833333333333, -0.15, 0.31818181818182
98453, 2.2833333333333, -0.15, 0.27272727272727
98454, 2.2833333333333, -0.15, 0.22727272727273
98455, 2.2833333333333, -0.15, 0.18181818181818
98456, 2.2833333333333, -0.15, 0.13636363636364
98457, 2.2833333333333, -0.15, 0.090909090909091
98458, 2.2833333333333, -0.15, 0.045454545454545
98459, 2.2333333333333, -0.175, 0.45454545454545
98460, 2.2333333333333, -0.175, 0.40909090909091
98461, 2.2333333333333, -0.175, 0.36363636363636
98462, 2.2333333333333, -0.175, 0.31818181818182
98463, 2.2333333333333, -0.175, 0.27272727272727
98464, 2.2333333333333, -0.175, 0.22727272727273
98465, 2.2333333333333, -0.175, 0.18181818181818
98466, 2.2333333333333, -0.175, 0.13636363636364
98467, 2.2333333333333, -0.175, 0.090909090909091
98468, 2.2333333333333, -0.175, 0.045454545454545
98469, 2.2666666666667, -0.175, 0.45454545454545
98470, 2.2666666666667, -0.175, 0.40909090909091
98471, 2.2666666666667, -0.175, 0.36363636363636
98472, 2.2666666666667, -0.175, 0.31818181818182
98473, 2.2666666666667, -0.175, 0.27272727272727
98474, 2.2666666666667, -0.175, 0.22727272727273
98475, 2.2666666666667, -0.175, 0.18181818181818
98476, 2.2666666666667, -0.175, 0.13636363636364
98477, 2.2666666666667, -0.175, 0.090909090909091
98478, 2.2666666666667, -0.175, 0.045454545454545
98479, 1.04, -0.05, 0.45454545454545
98480, 1.04, -0.05, 0.40909090909091
98481, 1.04, -0.05, 0.36363636363636
98482, 1.04, -0.05, 0.31818181818182
98483, 1.04, -0.05, 0.27272727272727
98484, 1.04, -0.05, 0.22727272727273
98485, 1.04, -0.05, 0.18181818181818
98486, 1.04, -0.05, 0.13636363636364
98487, 1.04, -0.05, 0.090909090909091
98488, 1.04, -0.05, 0.045454545454545
98489, 1.04, -0.1, 0.45454545454545
98490, 1.04, -0.1, 0.40909090909091
98491, 1.04, -0.1, 0.36363636363636
98492, 1.04, -0.1, 0.31818181818182
98493, 1.04, -0.1, 0.27272727272727
98494, 1.04, -0.1, 0.22727272727273
98495, 1.04, -0.1, 0.18181818181818
98496, 1.04, -0.1, 0.13636363636364
98497, 1.04, -0.1, 0.090909090909091
98498, 1.04, -0.1, 0.045454545454545
98499, 1.04, -0.15, 0.45454545454545
98500, 1.04, -0.15, 0.40909090909091
98501, 1.04, -0.15, 0.36363636363636
98502, 1.04, -0.15, 0.31818181818182
98503, 1.04, -0.15, 0.27272727272727
98504, 1.04, -0.15, 0.22727272727273
98505, 1.04, -0.15, 0.18181818181818
98506, 1.04, -0.15, 0.13636363636364
98507, 1.04, -0.15, 0.090909090909091
98508, 1.04, -0.15, 0.045454545454545
98509, 1.08, -0.05, 0.45454545454545
98510, 1.08, -0.05, 0.40909090909091
98511, 1.08, -0.05, 0.36363636363636
98512, 1.08, -0.05, 0.31818181818182
98513, 1.08, -0.05, 0.27272727272727
98514, 1.08, -0.05, 0.22727272727273
98515, 1.08, -0.05, 0.18181818181818
98516, 1.08, -0.05, 0.13636363636364
98517, 1.08, -0.05, 0.090909090909091
98518, 1.08, -0.05, 0.045454545454545
98519, 1.08, -0.1, 0.45454545454545
98520, 1.08, -0.1, 0.40909090909091
98521, 1.08, -0.1, 0.36363636363636
98522, 1.08, -0.1, 0.31818181818182
98523, 1.08, -0.1, 0.27272727272727
98524, 1.08, -0.1, 0.22727272727273
98525, 1.08, -0.1, 0.18181818181818
98526, 1.08, -0.1, 0.13636363636364
98527, 1.08, -0.1, 0.090909090909091
98528, 1.08, -0.1, 0.045454545454545
98529, 1.08, -0.15, 0.45454545454545
98530, 1.08, -0.15, 0.40909090909091
98531, 1.08, -0.15, 0.36363636363636
98532, 1.08, -0.15, 0.31818181818182
98533, 1.08, -0.15, 0.27272727272727
98534, 1.08, -0.15, 0.22727272727273
98535, 1.08, -0.15, 0.18181818181818
98536, 1.08, -0.15, 0.13636363636364
98537, 1.08, -0.15, 0.090909090909091
98538, 1.08, -0.15, 0.045454545454545
98539, 1.12, -0.05, 0.45454545454545
98540, 1.12, -0.05, 0.40909090909091
98541, 1.12, -0.05, 0.36363636363636
98542, 1.12, -0.05, 0.31818181818182
98543, 1.12, -0.05, 0.27272727272727
98544, 1.12, -0.05, 0.22727272727273
98545, 1.12, -0.05, 0.18181818181818
98546, 1.12, -0.05, 0.13636363636364
98547, 1.12, -0.05, 0.090909090909091
98548, 1.12, -0.05, 0.045454545454545
98549, 1.12, -0.1, 0.45454545454545
98550, 1.12, -0.1, 0.40909090909091
98551, 1.12, -0.1, 0.36363636363636
98552, 1.12, -0.1, 0.31818181818182
98553, 1.12, -0.1, 0.27272727272727
98554, 1.12, -0.1, 0.22727272727273
98555, 1.12, -0.1, 0.18181818181818
98556, 1.12, -0.1, 0.13636363636364
98557, 1.12, -0.1, 0.090909090909091
98558, 1.12, -0.1, 0.045454545454545
98559, 1.12, -0.15, 0.45454545454545
98560, 1.12, -0.15, 0.40909090909091
98561, 1.12, -0.15, 0.36363636363636
98562, 1.12, -0.15, 0.31818181818182
98563, 1.12, -0.15, 0.27272727272727
98564, 1.12, -0.15, 0.22727272727273
98565, 1.12, -0.15, 0.18181818181818
98566, 1.12, -0.15, 0.13636363636364
98567, 1.12, -0.15, 0.090909090909091
98568, 1.12, -0.15, 0.045454545454545
98569, 1.16, -0.05, 0.45454545454545
98570, 1.16, -0.05, 0.40909090909091
98571, 1.16, -0.05, 0.36363636363636
98572, 1.16, -0.05, 0.31818181818182
98573, 1.16, -0.05, 0.27272727272727
98574, 1.16, -0.05, 0.22727272727273
98575, 1.16, -0.05, 0.18181818181818
98576, 1.16, -0.05, 0.13636363636364
98577, 1.16, -0.05, 0.090909090909091
98578, 1.16, -0.05, 0.045454545454545
98579, 1.16, -0.1, 0.45454545454545
98580, 1.16, -0.1, 0.40909090909091
98581, 1.16, -0.1, 0.36363636363636
98582, 1.16, -0.1, 0.31818181818182
98583, 1.16, -0.1, 0.27272727272727
98584, 1.16, -0.1, 0.22727272727273
98585, 1.16, -0.1, 0.18181818181818
98586, 1.16, -0.1, 0.13636363636364
98587, 1.16, -0.1, 0.090909090909091
98588, 1.16, -0.1, 0.045454545454545
98589, 1.16, -0.15, 0.45454545454545
98590, 1.16, -0.15, 0.40909090909091
98591, 1.16, -0.15, 0.36363636363636
98592, 1.16, -0.15, 0.31818181818182
98593, 1.16, -0.15, 0.27272727272727
98594, 1.16, -0.15, 0.22727272727273
98595, 1.16, -0.15, 0.18181818181818
98596, 1.16, -0.15, 0.13636363636364
98597, 1.16, -0.15, 0.090909090909091
98598, 1.16, -0.15, 0.045454545454545
98599, 1.04, -0.05, 0.47727272727273
98600, 1.04, -0.025, 0.45454545454545
98601, 1.02, -0.05, 0.45454545454545
98602, 1.04, -0.05, 0.43181818181818
98603, 1.04, -0.025, 0.40909090909091
98604, 1.02, -0.05, 0.40909090909091
98605, 1.04, -0.05, 0.38636363636364
98606, 1.04, -0.025, 0.36363636363636
98607, 1.02, -0.05, 0.36363636363636
98608, 1.04, -0.05, 0.34090909090909
98609, 1.04, -0.025, 0.31818181818182
98610, 1.02, -0.05, 0.31818181818182
98611, 1.04, -0.05, 0.29545454545455
98612, 1.04, -0.025, 0.27272727272727
98613, 1.02, -0.05, 0.27272727272727
98614, 1.04, -0.05, 0.25
98615, 1.04, -0.025, 0.22727272727273
98616, 1.02, -0.05, 0.22727272727273
98617, 1.04, -0.05, 0.20454545454545
98618, 1.04, -0.025, 0.18181818181818
98619, 1.02, -0.05, 0.18181818181818
98620, 1.04, -0.05, 0.15909090909091
98621, 1.04, -0.025, 0.13636363636364
98622, 1.02, -0.05, 0.13636363636364
98623, 1.04, -0.05, 0.11363636363636
98624, 1.04, -0.025, 0.090909090909091
98625, 1.02, -0.05, 0.090909090909091
98626, 1.04, -0.05, 0.068181818181818
98627, 1.04, -0.025, 0.045454545454545
98628, 1.02, -0.05, 0.045454545454545
98629, 1.04, -0.05, 0.022727272727273
98630, 1.04, -0.1, 0.47727272727273
98631, 1.04, -0.075, 0.45454545454545
98632, 1.02, -0.1, 0.45454545454545
98633, 1.04, -0.1, 0.43181818181818
98634, 1.04, -0.075, 0.40909090909091
98635, 1.02, -0.1, 0.40909090909091
98636, 1.04, -0.1, 0.38636363636364
98637, 1.04, -0.075, 0.36363636363636
98638, 1.02, -0.1, 0.36363636363636
98639, 1.04, -0.1, 0.34090909090909
98640, 1.04, -0.075, 0.31818181818182
98641, 1.02, -0.1, 0.31818181818182
98642, 1.04, -0.1, 0.29545454545455
98643, 1.04, -0.075, 0.27272727272727
98644, 1.02, -0.1, 0.27272727272727
98645, 1.04, -0.1, 0.25
98646, 1.04, -0.075, 0.22727272727273
98647, 1.02, -0.1, 0.22727272727273
98648, 1.04, -0.1, 0.20454545454545
98649, 1.04, -0.075, 0.18181818181818
98650, 1.02, -0.1, 0.18181818181818
98651, 1.04, -0.1, 0.15909090909091
98652, 1.04, -0.075, 0.13636363636364
98653, 1.02, -0.1, 0.13636363636364
98654, 1.04, -0.1, 0.11363636363636
98655, 1.04, -0.075, 0.090909090909091
98656, 1.02, -0.1, 0.090909090909091
98657, 1.04, -0.1, 0.068181818181818
98658, 1.04, -0.075, 0.045454545454545
98659, 1.02, -0.1, 0.045454545454545
98660, 1.04, -0.1, 0.022727272727273
98661, 1.04, -0.15, 0.47727272727273
98662, 1.04, -0.125, 0.45454545454545
98663, 1.02, -0.15, 0.45454545454545
98664, 1.04, -0.15, 0.43181818181818
98665, 1.04, -0.125, 0.40909090909091
98666, 1.02, -0.15, 0.40909090909091
98667, 1.04, -0.15, 0.38636363636364
98668, 1.04, -0.125, 0.36363636363636
98669, 1.02, -0.15, 0.36363636363636
98670, 1.04, -0.15, 0.34090909090909
98671, 1.04, -0.125, 0.31818181818182
98672, 1.02, -0.15, 0.31818181818182
98673, 1.04, -0.15, 0.29545454545455
98674, 1.04, -0.125, 0.27272727272727
98675, 1.02, -0.15, 0.27272727272727
98676, 1.04, -0.15, 0.25
98677, 1.04, -0.125, 0.22727272727273
98678, 1.02, -0.15, 0.22727272727273
98679, 1.04, -0.15, 0.20454545454545
98680, 1.04, -0.125, 0.18181818181818
98681, 1.02, -0.15, 0.18181818181818
98682, 1.04, -0.15, 0.15909090909091
98683, 1.04, -0.125, 0.13636363636364
98684, 1.02, -0.15, 0.13636363636364
98685, 1.04, -0.15, 0.11363636363636
98686, 1.04, -0.125, 0.090909090909091
98687, 1.02, -0.15, 0.090909090909091
98688, 1.04, -0.15, 0.068181818181818
98689, 1.04, -0.125, 0.045454545454545
98690, 1.02, -0.15, 0.045454545454545
98691, 1.04, -0.15, 0.022727272727273
98692, 1.04, -0.175, 0.45454545454545
98693, 1.04, -0.175, 0.40909090909091
98694, 1.04, -0.175, 0.36363636363636
98695, 1.04, -0.175, 0.31818181818182
98696, 1.04, -0.175, 0.27272727272727
98697, 1.04, -0.175, 0.22727272727273
98698, 1.04, -0.175, 0.18181818181818
98699, 1.04, -0.175, 0.13636363636364
98700, 1.04, -0.175, 0.090909090909091
98701, 1.04, -0.175, 0.045454545454545
98702, 1.08, -0.05, 0.47727272727273
98703, 1.08, -0.025, 0.45454545454545
98704, 1.06, -0.05, 0.45454545454545
98705, 1.08, -0.05, 0.43181818181818
98706, 1.08, -0.025, 0.40909090909091
98707, 1.06, -0.05, 0.40909090909091
98708, 1.08, -0.05, 0.38636363636364
98709, 1.08, -0.025, 0.36363636363636
98710, 1.06, -0.05, 0.36363636363636
98711, 1.08, -0.05, 0.34090909090909
98712, 1.08, -0.025, 0.31818181818182
98713, 1.06, -0.05, 0.31818181818182
98714, 1.08, -0.05, 0.29545454545455
98715, 1.08, -0.025, 0.27272727272727
98716, 1.06, -0.05, 0.27272727272727
98717, 1.08, -0.05, 0.25
98718, 1.08, -0.025, 0.22727272727273
98719, 1.06, -0.05, 0.22727272727273
98720, 1.08, -0.05, 0.20454545454545
98721, 1.08, -0.025, 0.18181818181818
98722, 1.06, -0.05, 0.18181818181818
98723, 1.08, -0.05, 0.15909090909091
98724, 1.08, -0.025, 0.13636363636364
98725, 1.06, -0.05, 0.13636363636364
98726, 1.08, -0.05, 0.11363636363636
98727, 1.08, -0.025, 0.090909090909091
98728, 1.06, -0.05, 0.090909090909091
98729, 1.08, -0.05, 0.068181818181818
98730, 1.08, -0.025, 0.045454545454545
98731, 1.06, -0.05, 0.045454545454545
98732, 1.08, -0.05, 0.022727272727273
98733, 1.08, -0.1, 0.47727272727273
98734, 1.08, -0.075, 0.45454545454545
98735, 1.06, -0.1, 0.45454545454545
98736, 1.08, -0.1, 0.43181818181818
98737, 1.08, -0.075, 0.40909090909091
98738, 1.06, -0.1, 0.40909090909091
98739, 1.08, -0.1, 0.38636363636364
98740, 1.08, -0.075, 0.36363636363636
98741, 1.06, -0.1, 0.36363636363636
98742, 1.08, -0.1, 0.34090909090909
98743, 1.08, -0.075, 0.31818181818182
98744, 1.06, -0.1, 0.31818181818182
98745, 1.08, -0.1, 0.29545454545455
98746, 1.08, -0.075, 0.27272727272727
98747, 1.06, -0.1, 0.27272727272727
98748, 1.08, -0.1, 0.25
98749, 1.08, -0.075, 0.22727272727273
98750, 1.06, -0.1, 0.22727272727273
98751, 1.08, -0.1, 0.20454545454545
98752, 1.08, -0.075, 0.18181818181818
98753, 1.06, -0.1, 0.18181818181818
98754, 1.08, -0.1, 0.15909090909091
98755, 1.08, -0.075, 0.13636363636364
98756, 1.06, -0.1, 0.13636363636364
98757, 1.08, -0.1, 0.11363636363636
98758, 1.08, -0.075, 0.090909090909091
98759, 1.06, -0.1, 0.090909090909091
98760, 1.08, -0.1, 0.068181818181818
98761, 1.08, -0.075, 0.045454545454545
98762, 1.06, -0.1, 0.045454545454545
98763, 1.08, -0.1, 0.022727272727273
98764, 1.08, -0.15, 0.47727272727273
98765, 1.08, -0.125, 0.45454545454545
98766, 1.06, -0.15, 0.45454545454545
98767, 1.08, -0.15, 0.43181818181818
98768, 1.08, -0.125, 0.40909090909091
98769, 1.06, -0.15, 0.40909090909091
98770, 1.08, -0.15, 0.38636363636364
98771, 1.08, -0.125, 0.36363636363636
98772, 1.06, -0.15, 0.36363636363636
98773, 1.08, -0.15, 0.34090909090909
98774, 1.08, -0.125, 0.31818181818182
98775, 1.06, -0.15, 0.31818181818182
98776, 1.08, -0.15, 0.29545454545455
98777, 1.08, -0.125, 0.27272727272727
98778, 1.06, -0.15, 0.27272727272727
98779, 1.08, -0.15, 0.25
98780, 1.08, -0.125, 0.22727272727273
98781, 1.06, -0.15, 0.22727272727273
98782, 1.08, -0.15, 0.20454545454545
98783, 1.08, -0.125, 0.18181818181818
98784, 1.06, -0.15, 0.18181818181818
98785, 1.08, -0.15, 0.15909090909091
98786, 1.08, -0.125, 0.13636363636364
98787, 1.06, -0.15, 0.13636363636364
98788, 1.08, -0.15, 0.11363636363636
98789, 1.08, -0.125, 0.090909090909091
98790, 1.06, -0.15, 0.090909090909091
98791, 1.08, -0.15, 0.068181818181818
98792, 1.08, -0.125, 0.045454545454545
98793, 1.06, -0.15, 0.045454545454545
98794, 1.08, -0.15, 0.022727272727273
98795, 1.08, -0.175, 0.45454545454545
98796, 1.08, -0.175, 0.40909090909091
98797, 1.08, -0.175, 0.36363636363636
98798, 1.08, -0.175, 0.31818181818182
98799, 1.08, -0.175, 0.27272727272727
98800, 1.08, -0.175, 0.22727272727273
98801, 1.08, -0.175, 0.18181818181818
98802, 1.08, -0.175, 0.13636363636364
98803, 1.08, -0.175, 0.090909090909091
98804, 1.08, -0.175, 0.045454545454545
98805, 1.12, -0.05, 0.47727272727273
98806, 1.12, -0.025, 0.45454545454545
98807, 1.1, -0.05, 0.45454545454545
98808, 1.12, -0.05, 0.43181818181818
98809, 1.12, -0.025, 0.40909090909091
98810, 1.1, -0.05, 0.40909090909091
98811, 1.12, -0.05, 0.38636363636364
98812, 1.12, -0.025, 0.36363636363636
98813, 1.1, -0.05, 0.36363636363636
98814, 1.12, -0.05, 0.34090909090909
98815, 1.12, -0.025, 0.31818181818182
98816, 1.1, -0.05, 0.31818181818182
98817, 1.12, -0.05, 0.29545454545455
98818, 1.12, -0.025, 0.27272727272727
98819, 1.1, -0.05, 0.27272727272727
98820, 1.12, -0.05, 0.25
98821, 1.12, -0.025, 0.22727272727273
98822, 1.1, -0.05, 0.22727272727273
98823, 1.12, -0.05, 0.20454545454545
98824, 1.12, -0.025, 0.18181818181818
98825, 1.1, -0.05, 0.18181818181818
98826, 1.12, -0.05, 0.15909090909091
98827, 1.12, -0.025, 0.13636363636364
98828, 1.1, -0.05, 0.13636363636364
98829, 1.12, -0.05, 0.11363636363636
98830, 1.12, -0.025, 0.090909090909091
98831, 1.1, -0.05, 0.090909090909091
98832, 1.12, -0.05, 0.068181818181818
98833, 1.12, -0.025, 0.045454545454545
98834, 1.1, -0.05, 0.045454545454545
98835, 1.12, -0.05, 0.022727272727273
98836, 1.12, -0.1, 0.47727272727273
98837, 1.12, -0.075, 0.45454545454545
98838, 1.1, -0.1, 0.45454545454545
98839, 1.12, -0.1, 0.43181818181818
98840, 1.12, -0.075, 0.40909090909091
98841, 1.1, -0.1, 0.40909090909091
98842, 1.12, -0.1, 0.38636363636364
98843, 1.12, -0.075, 0.36363636363636
98844, 1.1, -0.1, 0.36363636363636
98845, 1.12, -0.1, 0.34090909090909
98846, 1.12, -0.075, 0.31818181818182
98847, 1.1, -0.1, 0.31818181818182
98848, 1.12, -0.1, 0.29545454545455
98849, 1.12, -0.075, 0.27272727272727
98850, 1.1, -0.1, 0.27272727272727
98851, 1.12, -0.1, 0.25
98852, 1.12, -0.075, 0.22727272727273
98853, 1.1, -0.1, 0.22727272727273
98854, 1.12, -0.1, 0.20454545454545
98855, 1.12, -0.075, 0.18181818181818
98856, 1.1, -0.1, 0.18181818181818
98857, 1.12, -0.1, 0.15909090909091
98858, 1.12, -0.075, 0.13636363636364
98859, 1.1, -0.1, 0.13636363636364
98860, 1.12, -0.1, 0.11363636363636
98861, 1.12, -0.075, 0.090909090909091
98862, 1.1, -0.1, 0.090909090909091
98863, 1.12, -0.1, 0.068181818181818
98864, 1.12, -0.075, 0.045454545454545
98865, 1.1, -0.1, 0.045454545454545
98866, 1.12, -0.1, 0.022727272727273
98867, 1.12, -0.15, 0.47727272727273
98868, 1.12, -0.125, 0.45454545454545
98869, 1.1, -0.15, 0.45454545454545
98870, 1.12, -0.15, 0.43181818181818
98871, 1.12, -0.125, 0.40909090909091
98872, 1.1, -0.15, 0.40909090909091
98873, 1.12, -0.15, 0.38636363636364
98874, 1.12, -0.125, 0.36363636363636
98875, 1.1, -0.15, 0.36363636363636
98876, 1.12, -0.15, 0.34090909090909
98877, 1.12, -0.125, 0.31818181818182
98878, 1.1, -0.15, 0.31818181818182
98879, 1.12, -0.15, 0.29545454545455
98880, 1.12, -0.125, 0.27272727272727
98881, 1.1, -0.15, 0.27272727272727
98882, 1.12, -0.15, 0.25
98883, 1.12, -0.125, 0.22727272727273
98884, 1.1, -0.15, 0.22727272727273
98885, 1.12, -0.15, 0.20454545454545
98886, 1.12, -0.125, 0.18181818181818
98887, 1.1, -0.15, 0.18181818181818
98888, 1.12, -0.15, 0.15909090909091
98889, 1.12, -0.125, 0.13636363636364
98890, 1.1, -0.15, 0.13636363636364
98891, 1.12, -0.15, 0.11363636363636
98892, 1.12, -0.125, 0.090909090909091
98893, 1.1, -0.15, 0.090909090909091
98894, 1.12, -0.15, 0.068181818181818
98895, 1.12, -0.125, 0.045454545454545
98896, 1.1, -0.15, 0.045454545454545
98897, 1.12, -0.15, 0.022727272727273
98898, 1.12, -0.175, 0.45454545454545
98899, 1.12, -0.175, 0.40909090909091
98900, 1.12, -0.175, 0.36363636363636
98901, 1.12, -0.175, 0.31818181818182
98902, 1.12, -0.175, 0.27272727272727
98903, 1.12, -0.175, 0.22727272727273
98904, 1.12, -0.175, 0.18181818181818
98905, 1.12, -0.175, 0.13636363636364
98906, 1.12, -0.175, 0.090909090909091
98907, 1.12, -0.175, 0.045454545454545
98908, 1.16, -0.05, 0.47727272727273
98909, 1.16, -0.025, 0.45454545454545
98910, 1.14, -0.05, 0.45454545454545
98911, 1.16, -0.05, 0.43181818181818
98912, 1.16, -0.025, 0.40909090909091
98913, 1.14, -0.05, 0.40909090909091
98914, 1.16, -0.05, 0.38636363636364
98915, 1.16, -0.025, 0.36363636363636
98916, 1.14, -0.05, 0.36363636363636
98917, 1.16, -0.05, 0.34090909090909
98918, 1.16, -0.025, 0.31818181818182
98919, 1.14, -0.05, 0.31818181818182
98920, 1.16, -0.05, 0.29545454545455
98921, 1.16, -0.025, 0.27272727272727
98922, 1.14, -0.05, 0.27272727272727
98923, 1.16, -0.05, 0.25
98924, 1.16, -0.025, 0.22727272727273
98925, 1.14, -0.05, 0.22727272727273
98926, 1.16, -0.05, 0.20454545454545
98927, 1.16, -0.025, 0.18181818181818
98928, 1.14, -0.05, 0.18181818181818
98929, 1.16, -0.05, 0.15909090909091
98930, 1.16, -0.025, 0.13636363636364
98931, 1.14, -0.05, 0.13636363636364
98932, 1.16, -0.05, 0.11363636363636
98933, 1.16, -0.025, 0.090909090909091
98934, 1.14, -0.05, 0.090909090909091
98935, 1.16, -0.05, 0.068181818181818
98936, 1.16, -0.025, 0.045454545454545
98937, 1.14, -0.05, 0.045454545454545
98938, 1.16, -0.05, 0.022727272727273
98939, 1.16, -0.1, 0.47727272727273
98940, 1.16, -0.075, 0.45454545454545
98941, 1.14, -0.1, 0.45454545454545
98942, 1.16, -0.1, 0.43181818181818
98943, 1.16, -0.075, 0.40909090909091
98944, 1.14, -0.1, 0.40909090909091
98945, 1.16, -0.1, 0.38636363636364
98946, 1.16, -0.075, 0.36363636363636
98947, 1.14, -0.1, 0.36363636363636
98948, 1.16, -0.1, 0.34090909090909
98949, 1.16, -0.075, 0.31818181818182
98950, 1.14, -0.1, 0.31818181818182
98951, 1.16, -0.1, 0.29545454545455
98952, 1.16, -0.075, 0.27272727272727
98953, 1.14, -0.1, 0.27272727272727
98954, 1.16, -0.1, 0.25
98955, 1.16, -0.075, 0.22727272727273
98956, 1.14, -0.1, 0.22727272727273
98957, 1.16, -0.1, 0.20454545454545
98958, 1.16, -0.075, 0.18181818181818
98959, 1.14, -0.1, 0.18181818181818
98960, 1.16, -0.1, 0.15909090909091
98961, 1.16, -0.075, 0.13636363636364
98962, 1.14, -0.1, 0.13636363636364
98963, 1.16, -0.1, 0.11363636363636
98964, 1.16, -0.075, 0.090909090909091
98965, 1.14, -0.1, 0.090909090909091
98966, 1.16, -0.1, 0.068181818181818
98967, 1.16, -0.075, 0.045454545454545
98968, 1.14, -0.1, 0.045454545454545
98969, 1.16, -0.1, 0.022727272727273
98970, 1.16, -0.15, 0.47727272727273
98971, 1.16, -0.125, 0.45454545454545
98972, 1.14, -0.15, 0.45454545454545
98973, 1.16, -0.15, 0.43181818181818
98974, 1.16, -0.125, 0.40909090909091
98975, 1.14, -0.15, 0.40909090909091
98976, 1.16, -0.15, 0.38636363636364
98977, 1.16, -0.125, 0.36363636363636
98978, 1.14, -0.15, 0.36363636363636
98979, 1.16, -0.15, 0.34090909090909
98980, 1.16, -0.125, 0.31818181818182
98981, 1.14, -0.15, 0.31818181818182
98982, 1.16, -0.15, 0.29545454545455
98983, 1.16, -0.125, 0.27272727272727
98984, 1.14, -0.15, 0.27272727272727
98985, 1.16, -0.15, 0.25
98986, 1.16, -0.125, 0.22727272727273
98987, 1.14, -0.15, 0.22727272727273
98988, 1.16, -0.15, 0.20454545454545
98989, 1.16, -0.125, 0.18181818181818
98990, 1.14, -0.15, 0.18181818181818
98991, 1.16, -0.15, 0.15909090909091
98992, 1.16, -0.125, 0.13636363636364
98993, 1.14, -0.15, 0.13636363636364
98994, 1.16, -0.15, 0.11363636363636
98995, 1.16, -0.125, 0.090909090909091
98996, 1.14, -0.15, 0.090909090909091
98997, 1.16, -0.15, 0.068181818181818
98998, 1.16, -0.125, 0.045454545454545
98999, 1.14, -0.15, 0.045454545454545
99000, 1.16, -0.15, 0.022727272727273
99001, 1.16, -0.175, 0.45454545454545
99002, 1.16, -0.175, 0.40909090909091
99003, 1.16, -0.175, 0.36363636363636
99004, 1.16, -0.175, 0.31818181818182
99005, 1.16, -0.175, 0.27272727272727
99006, 1.16, -0.175, 0.22727272727273
99007, 1.16, -0.175, 0.18181818181818
99008, 1.16, -0.175, 0.13636363636364
99009, 1.16, -0.175, 0.090909090909091
99010, 1.16, -0.175, 0.045454545454545
99011, 1.18, -0.05, 0.45454545454545
99012, 1.18, -0.05, 0.40909090909091
99013, 1.18, -0.05, 0.36363636363636
99014, 1.18, -0.05, 0.31818181818182
99015, 1.18, -0.05, 0.27272727272727
99016, 1.18, -0.05, 0.22727272727273
99017, 1.18, -0.05, 0.18181818181818
99018, 1.18, -0.05, 0.13636363636364
99019, 1.18, -0.05, 0.090909090909091
99020, 1.18, -0.05, 0.045454545454545
99021, 1.18, -0.1, 0.45454545454545
99022, 1.18, -0.1, 0.40909090909091
99023, 1.18, -0.1, 0.36363636363636
99024, 1.18, -0.1, 0.31818181818182
99025, 1.18, -0.1, 0.27272727272727
99026, 1.18, -0.1, 0.22727272727273
99027, 1.18, -0.1, 0.18181818181818
99028, 1.18, -0.1, 0.13636363636364
99029, 1.18, -0.1, 0.090909090909091
99030, 1.18, -0.1, 0.045454545454545
99031, 1.18, -0.15, 0.45454545454545
99032, 1.18, -0.15, 0.40909090909091
99033, 1.18, -0.15, 0.36363636363636
99034, 1.18, -0.15, 0.31818181818182
99035, 1.18, -0.15, 0.27272727272727
99036, 1.18, -0.15, 0.22727272727273
99037, 1.18, -0.15, 0.18181818181818
99038, 1.18, -0.15, 0.13636363636364
99039, 1.18, -0.15, 0.090909090909091
99040, 1.18, -0.15, 0.045454545454545
99041, -0.033333333333333, 1.55, 0.45454545454545
99042, -0.033333333333333, 1.55, 0.40909090909091
99043, -0.033333333333333, 1.55, 0.36363636363636
99044, -0.033333333333333, 1.55, 0.31818181818182
99045, -0.033333333333333, 1.55, 0.27272727272727
99046, -0.033333333333333, 1.55, 0.22727272727273
99047, -0.033333333333333, 1.55, 0.18181818181818
99048, -0.033333333333333, 1.55, 0.13636363636364
99049, -0.033333333333333, 1.55, 0.090909090909091
99050, -0.033333333333333, 1.55, 0.045454545454545
99051, -0.033333333333333, 1.6, 0.45454545454545
99052, -0.033333333333333, 1.6, 0.40909090909091
99053, -0.033333333333333, 1.6, 0.36363636363636
99054, -0.033333333333333, 1.6, 0.31818181818182
99055, -0.033333333333333, 1.6, 0.27272727272727
99056, -0.033333333333333, 1.6, 0.22727272727273
99057, -0.033333333333333, 1.6, 0.18181818181818
99058, -0.033333333333333, 1.6, 0.13636363636364
99059, -0.033333333333333, 1.6, 0.090909090909091
99060, -0.033333333333333, 1.6, 0.045454545454545
99061, -0.033333333333333, 1.65, 0.45454545454545
99062, -0.033333333333333, 1.65, 0.40909090909091
99063, -0.033333333333333, 1.65, 0.36363636363636
99064, -0.033333333333333, 1.65, 0.31818181818182
99065, -0.033333333333333, 1.65, 0.27272727272727
99066, -0.033333333333333, 1.65, 0.22727272727273
99067, -0.033333333333333, 1.65, 0.18181818181818
99068, -0.033333333333333, 1.65, 0.13636363636364
99069, -0.033333333333333, 1.65, 0.090909090909091
99070, -0.033333333333333, 1.65, 0.045454545454545
99071, -0.066666666666667, 1.55, 0.45454545454545
99072, -0.066666666666667, 1.55, 0.40909090909091
99073, -0.066666666666667, 1.55, 0.36363636363636
99074, -0.066666666666667, 1.55, 0.31818181818182
99075, -0.066666666666667, 1.55, 0.27272727272727
99076, -0.066666666666667, 1.55, 0.22727272727273
99077, -0.066666666666667, 1.55, 0.18181818181818
99078, -0.066666666666667, 1.55, 0.13636363636364
99079, -0.066666666666667, 1.55, 0.090909090909091
99080, -0.066666666666667, 1.55, 0.045454545454545
99081, -0.066666666666667, 1.6, 0.45454545454545
99082, -0.066666666666667, 1.6, 0.40909090909091
99083, -0.066666666666667, 1.6, 0.36363636363636
99084, -0.066666666666667, 1.6, 0.31818181818182
99085, -0.066666666666667, 1.6, 0.27272727272727
99086, -0.066666666666667, 1.6, 0.22727272727273
99087, -0.066666666666667, 1.6, 0.18181818181818
99088, -0.066666666666667, 1.6, 0.13636363636364
99089, -0.066666666666667, 1.6, 0.090909090909091
99090, -0.066666666666667, 1.6, 0.045454545454545
99091, -0.066666666666667, 1.65, 0.45454545454545
99092, -0.066666666666667, 1.65, 0.40909090909091
99093, -0.066666666666667, 1.65, 0.36363636363636
99094, -0.066666666666667, 1.65, 0.31818181818182
99095, -0.066666666666667, 1.65, 0.27272727272727
99096, -0.066666666666667, 1.65, 0.22727272727273
99097, -0.066666666666667, 1.65, 0.18181818181818
99098, -0.066666666666667, 1.65, 0.13636363636364
99099, -0.066666666666667, 1.65, 0.090909090909091
99100, -0.066666666666667, 1.65, 0.045454545454545
99101, -0.033333333333333, 1.55, 0.47727272727273
99102, -0.033333333333333, 1.525, 0.45454545454545
99103, -0.016666666666667, 1.55, 0.45454545454545
99104, -0.033333333333333, 1.55, 0.43181818181818
99105, -0.033333333333333, 1.525, 0.40909090909091
99106, -0.016666666666667, 1.55, 0.40909090909091
99107, -0.033333333333333, 1.55, 0.38636363636364
99108, -0.033333333333333, 1.525, 0.36363636363636
99109, -0.016666666666667, 1.55, 0.36363636363636
99110, -0.033333333333333, 1.55, 0.34090909090909
99111, -0.033333333333333, 1.525, 0.31818181818182
99112, -0.016666666666667, 1.55, 0.31818181818182
99113, -0.033333333333333, 1.55, 0.29545454545455
99114, -0.033333333333333, 1.525, 0.27272727272727
99115, -0.016666666666667, 1.55, 0.27272727272727
99116, -0.033333333333333, 1.55, 0.25
99117, -0.033333333333333, 1.525, 0.22727272727273
99118, -0.016666666666667, 1.55, 0.22727272727273
99119, -0.033333333333333, 1.55, 0.20454545454545
99120, -0.033333333333333, 1.525, 0.18181818181818
99121, -0.016666666666667, 1.55, 0.18181818181818
99122, -0.033333333333333, 1.55, 0.15909090909091
99123, -0.033333333333333, 1.525, 0.13636363636364
99124, -0.016666666666667, 1.55, 0.13636363636364
99125, -0.033333333333333, 1.55, 0.11363636363636
99126, -0.033333333333333, 1.525, 0.090909090909091
99127, -0.016666666666667, 1.55, 0.090909090909091
99128, -0.033333333333333, 1.55, 0.068181818181818
99129, -0.033333333333333, 1.525, 0.045454545454545
99130, -0.016666666666667, 1.55, 0.045454545454545
99131, -0.033333333333333, 1.55, 0.022727272727273
99132, -0.033333333333333, 1.6, 0.47727272727273
99133, -0.033333333333333, 1.575, 0.45454545454545
99134, -0.016666666666667, 1.6, 0.45454545454545
99135, -0.033333333333333, 1.6, 0.43181818181818
99136, -0.033333333333333, 1.575, 0.40909090909091
99137, -0.016666666666667, 1.6, 0.40909090909091
99138, -0.033333333333333, 1.6, 0.38636363636364
99139, -0.033333333333333, 1.575, 0.36363636363636
99140, -0.016666666666667, 1.6, 0.36363636363636
99141, -0.033333333333333, 1.6, 0.34090909090909
99142, -0.033333333333333, 1.575, 0.31818181818182
99143, -0.016666666666667, 1.6, 0.31818181818182
99144, -0.033333333333333, 1.6, 0.29545454545455
99145, -0.033333333333333, 1.575, 0.27272727272727
99146, -0.016666666666667, 1.6, 0.27272727272727
99147, -0.033333333333333, 1.6, 0.25
99148, -0.033333333333333, 1.575, 0.22727272727273
99149, -0.016666666666667, 1.6, 0.22727272727273
99150, -0.033333333333333, 1.6, 0.20454545454545
99151, -0.033333333333333, 1.575, 0.18181818181818
99152, -0.016666666666667, 1.6, 0.18181818181818
99153, -0.033333333333333, 1.6, 0.15909090909091
99154, -0.033333333333333, 1.575, 0.13636363636364
99155, -0.016666666666667, 1.6, 0.13636363636364
99156, -0.033333333333333, 1.6, 0.11363636363636
99157, -0.033333333333333, 1.575, 0.090909090909091
99158, -0.016666666666667, 1.6, 0.090909090909091
99159, -0.033333333333333, 1.6, 0.068181818181818
99160, -0.033333333333333, 1.575, 0.045454545454545
99161, -0.016666666666667, 1.6, 0.045454545454545
99162, -0.033333333333333, 1.6, 0.022727272727273
99163, -0.033333333333333, 1.65, 0.47727272727273
99164, -0.033333333333333, 1.625, 0.45454545454545
99165, -0.016666666666667, 1.65, 0.45454545454545
99166, -0.033333333333333, 1.65, 0.43181818181818
99167, -0.033333333333333, 1.625, 0.40909090909091
99168, -0.016666666666667, 1.65, 0.40909090909091
99169, -0.033333333333333, 1.65, 0.38636363636364
99170, -0.033333333333333, 1.625, 0.36363636363636
99171, -0.016666666666667, 1.65, 0.36363636363636
99172, -0.033333333333333, 1.65, 0.34090909090909
99173, -0.033333333333333, 1.625, 0.31818181818182
99174, -0.016666666666667, 1.65, 0.31818181818182
99175, -0.033333333333333, 1.65, 0.29545454545455
99176, -0.033333333333333, 1.625, 0.27272727272727
99177, -0.016666666666667, 1.65, 0.27272727272727
99178, -0.033333333333333, 1.65, 0.25
99179, -0.033333333333333, 1.625, 0.22727272727273
99180, -0.016666666666667, 1.65, 0.22727272727273
99181, -0.033333333333333, 1.65, 0.20454545454545
99182, -0.033333333333333, 1.625, 0.18181818181818
99183, -0.016666666666667, 1.65, 0.18181818181818
99184, -0.033333333333333, 1.65, 0.15909090909091
99185, -0.033333333333333, 1.625, 0.13636363636364
99186, -0.016666666666667, 1.65, 0.13636363636364
99187, -0.033333333333333, 1.65, 0.11363636363636
99188, -0.033333333333333, 1.625, 0.090909090909091
99189, -0.016666666666667, 1.65, 0.090909090909091
99190, -0.033333333333333, 1.65, 0.068181818181818
99191, -0.033333333333333, 1.625, 0.045454545454545
99192, -0.016666666666667, 1.65, 0.045454545454545
99193, -0.033333333333333, 1.65, 0.022727272727273
99194, -0.033333333333333, 1.675, 0.45454545454545
99195, -0.033333333333333, 1.675, 0.40909090909091
99196, -0.033333333333333, 1.675, 0.36363636363636
99197, -0.033333333333333, 1.675, 0.31818181818182
99198, -0.033333333333333, 1.675, 0.27272727272727
99199, -0.033333333333333, 1.675, 0.22727272727273
99200, -0.033333333333333, 1.675, 0.18181818181818
99201, -0.033333333333333, 1.675, 0.13636363636364
99202, -0.033333333333333, 1.675, 0.090909090909091
99203, -0.033333333333333, 1.675, 0.045454545454545
99204, -0.066666666666667, 1.55, 0.47727272727273
99205, -0.066666666666667, 1.525, 0.45454545454545
99206, -0.05, 1.55, 0.45454545454545
99207, -0.066666666666667, 1.55, 0.43181818181818
99208, -0.066666666666667, 1.525, 0.40909090909091
99209, -0.05, 1.55, 0.40909090909091
99210, -0.066666666666667, 1.55, 0.38636363636364
99211, -0.066666666666667, 1.525, 0.36363636363636
99212, -0.05, 1.55, 0.36363636363636
99213, -0.066666666666667, 1.55, 0.34090909090909
99214, -0.066666666666667, 1.525, 0.31818181818182
99215, -0.05, 1.55, 0.31818181818182
99216, -0.066666666666667, 1.55, 0.29545454545455
99217, -0.066666666666667, 1.525, 0.27272727272727
99218, -0.05, 1.55, 0.27272727272727
99219, -0.066666666666667, 1.55, 0.25
99220, -0.066666666666667, 1.525, 0.22727272727273
99221, -0.05, 1.55, 0.22727272727273
99222, -0.066666666666667, 1.55, 0.20454545454545
99223, -0.066666666666667, 1.525, 0.18181818181818
99224, -0.05, 1.55, 0.18181818181818
99225, -0.066666666666667, 1.55, 0.15909090909091
99226, -0.066666666666667, 1.525, 0.13636363636364
99227, -0.05, 1.55, 0.13636363636364
99228, -0.066666666666667, 1.55, 0.11363636363636
99229, -0.066666666666667, 1.525, 0.090909090909091
99230, -0.05, 1.55, 0.090909090909091
99231, -0.066666666666667, 1.55, 0.068181818181818
99232, -0.066666666666667, 1.525, 0.045454545454545
99233, -0.05, 1.55, 0.045454545454545
99234, -0.066666666666667, 1.55, 0.022727272727273
99235, -0.066666666666667, 1.6, 0.47727272727273
99236, -0.066666666666667, 1.575, 0.45454545454545
99237, -0.05, 1.6, 0.45454545454545
99238, -0.066666666666667, 1.6, 0.43181818181818
99239, -0.066666666666667, 1.575, 0.40909090909091
99240, -0.05, 1.6, 0.40909090909091
99241, -0.066666666666667, 1.6, 0.38636363636364
99242, -0.066666666666667, 1.575, 0.36363636363636
99243, -0.05, 1.6, 0.36363636363636
99244, -0.066666666666667, 1.6, 0.34090909090909
99245, -0.066666666666667, 1.575, 0.31818181818182
99246, -0.05, 1.6, 0.31818181818182
99247, -0.066666666666667, 1.6, 0.29545454545455
99248, -0.066666666666667, 1.575, 0.27272727272727
99249, -0.05, 1.6, 0.27272727272727
99250, -0.066666666666667, 1.6, 0.25
99251, -0.066666666666667, 1.575, 0.22727272727273
99252, -0.05, 1.6, 0.22727272727273
99253, -0.066666666666667, 1.6, 0.20454545454545
99254, -0.066666666666667, 1.575, 0.18181818181818
99255, -0.05, 1.6, 0.18181818181818
99256, -0.066666666666667, 1.6, 0.15909090909091
99257, -0.066666666666667, 1.575, 0.13636363636364
99258, -0.05, 1.6, 0.13636363636364
99259, -0.066666666666667, 1.6, 0.11363636363636
99260, -0.066666666666667, 1.575, 0.090909090909091
99261, -0.05, 1.6, 0.090909090909091
99262, -0.066666666666667, 1.6, 0.068181818181818
99263, -0.066666666666667, 1.575, 0.045454545454545
99264, -0.05, 1.6, 0.045454545454545
99265, -0.066666666666667, 1.6, 0.022727272727273
99266, -0.066666666666667, 1.65, 0.47727272727273
99267, -0.066666666666667, 1.625, 0.45454545454545
99268, -0.05, 1.65, 0.45454545454545
99269, -0.066666666666667, 1.65, 0.43181818181818
99270, -0.066666666666667, 1.625, 0.40909090909091
99271, -0.05, 1.65, 0.40909090909091
99272, -0.066666666666667, 1.65, 0.38636363636364
99273, -0.066666666666667, 1.625, 0.36363636363636
99274, -0.05, 1.65, 0.36363636363636
99275, -0.066666666666667, 1.65, 0.34090909090909
99276, -0.066666666666667, 1.625, 0.31818181818182
99277, -0.05, 1.65, 0.31818181818182
99278, -0.066666666666667, 1.65, 0.29545454545455
99279, -0.066666666666667, 1.625, 0.27272727272727
99280, -0.05, 1.65, 0.27272727272727
99281, -0.066666666666667, 1.65, 0.25
99282, -0.066666666666667, 1.625, 0.22727272727273
99283, -0.05, 1.65, 0.22727272727273
99284, -0.066666666666667, 1.65, 0.20454545454545
99285, -0.066666666666667, 1.625, 0.18181818181818
99286, -0.05, 1.65, 0.18181818181818
99287, -0.066666666666667, 1.65, 0.15909090909091
99288, -0.066666666666667, 1.625, 0.13636363636364
99289, -0.05, 1.65, 0.13636363636364
99290, -0.066666666666667, 1.65, 0.11363636363636
99291, -0.066666666666667, 1.625, 0.090909090909091
99292, -0.05, 1.65, 0.090909090909091
99293, -0.066666666666667, 1.65, 0.068181818181818
99294, -0.066666666666667, 1.625, 0.045454545454545
99295, -0.05, 1.65, 0.045454545454545
99296, -0.066666666666667, 1.65, 0.022727272727273
99297, -0.066666666666667, 1.675, 0.45454545454545
99298, -0.066666666666667, 1.675, 0.40909090909091
99299, -0.066666666666667, 1.675, 0.36363636363636
99300, -0.066666666666667, 1.675, 0.31818181818182
99301, -0.066666666666667, 1.675, 0.27272727272727
99302, -0.066666666666667, 1.675, 0.22727272727273
99303, -0.066666666666667, 1.675, 0.18181818181818
99304, -0.066666666666667, 1.675, 0.13636363636364
99305, -0.066666666666667, 1.675, 0.090909090909091
99306, -0.066666666666667, 1.675, 0.045454545454545
99307, -0.083333333333333, 1.55, 0.45454545454545
99308, -0.083333333333333, 1.55, 0.40909090909091
99309, -0.083333333333333, 1.55, 0.36363636363636
99310, -0.083333333333333, 1.55, 0.31818181818182
99311, -0.083333333333333, 1.55, 0.27272727272727
99312, -0.083333333333333, 1.55, 0.22727272727273
99313, -0.083333333333333, 1.55, 0.18181818181818
99314, -0.083333333333333, 1.55, 0.13636363636364
99315, -0.083333333333333, 1.55, 0.090909090909091
99316, -0.083333333333333, 1.55, 0.045454545454545
99317, -0.083333333333333, 1.6, 0.45454545454545
99318, -0.083333333333333, 1.6, 0.40909090909091
99319, -0.083333333333333, 1.6, 0.36363636363636
99320, -0.083333333333333, 1.6, 0.31818181818182
99321, -0.083333333333333, 1.6, 0.27272727272727
99322, -0.083333333333333, 1.6, 0.22727272727273
99323, -0.083333333333333, 1.6, 0.18181818181818
99324, -0.083333333333333, 1.6, 0.13636363636364
99325, -0.083333333333333, 1.6, 0.090909090909091
99326, -0.083333333333333, 1.6, 0.045454545454545
99327, -0.083333333333333, 1.65, 0.45454545454545
99328, -0.083333333333333, 1.65, 0.40909090909091
99329, -0.083333333333333, 1.65, 0.36363636363636
99330, -0.083333333333333, 1.65, 0.31818181818182
99331, -0.083333333333333, 1.65, 0.27272727272727
99332, -0.083333333333333, 1.65, 0.22727272727273
99333, -0.083333333333333, 1.65, 0.18181818181818
99334, -0.083333333333333, 1.65, 0.13636363636364
99335, -0.083333333333333, 1.65, 0.090909090909091
99336, -0.083333333333333, 1.65, 0.045454545454545
99337, -0.033333333333333, 1.4333333333333, 0.45454545454545
99338, -0.033333333333333, 1.4333333333333, 0.40909090909091
99339, -0.033333333333333, 1.4333333333333, 0.36363636363636
99340, -0.033333333333333, 1.4333333333333, 0.31818181818182
99341, -0.033333333333333, 1.4333333333333, 0.27272727272727
99342, -0.033333333333333, 1.4333333333333, 0.22727272727273
99343, -0.033333333333333, 1.4333333333333, 0.18181818181818
99344, -0.033333333333333, 1.4333333333333, 0.13636363636364
99345, -0.033333333333333, 1.4333333333333, 0.090909090909091
99346, -0.033333333333333, 1.4333333333333, 0.045454545454545
99347, -0.033333333333333, 1.4666666666667, 0.45454545454545
99348, -0.033333333333333, 1.4666666666667, 0.40909090909091
99349, -0.033333333333333, 1.4666666666667, 0.36363636363636
99350, -0.033333333333333, 1.4666666666667, 0.31818181818182
99351, -0.033333333333333, 1.4666666666667, 0.27272727272727
99352, -0.033333333333333, 1.4666666666667, 0.22727272727273
99353, -0.033333333333333, 1.4666666666667, 0.18181818181818
99354, -0.033333333333333, 1.4666666666667, 0.13636363636364
99355, -0.033333333333333, 1.4666666666667, 0.090909090909091
99356, -0.033333333333333, 1.4666666666667, 0.045454545454545
99357, -0.066666666666667, 1.4333333333333, 0.45454545454545
99358, -0.066666666666667, 1.4333333333333, 0.40909090909091
99359, -0.066666666666667, 1.4333333333333, 0.36363636363636
99360, -0.066666666666667, 1.4333333333333, 0.31818181818182
99361, -0.066666666666667, 1.4333333333333, 0.27272727272727
99362, -0.066666666666667, 1.4333333333333, 0.22727272727273
99363, -0.066666666666667, 1.4333333333333, 0.18181818181818
99364, -0.066666666666667, 1.4333333333333, 0.13636363636364
99365, -0.066666666666667, 1.4333333333333, 0.090909090909091
99366, -0.066666666666667, 1.4333333333333, 0.045454545454545
99367, -0.066666666666667, 1.4666666666667, 0.45454545454545
99368, -0.066666666666667, 1.4666666666667, 0.40909090909091
99369, -0.066666666666667, 1.4666666666667, 0.36363636363636
99370, -0.066666666666667, 1.4666666666667, 0.31818181818182
99371, -0.066666666666667, 1.4666666666667, 0.27272727272727
99372, -0.066666666666667, 1.4666666666667, 0.22727272727273
99373, -0.066666666666667, 1.4666666666667, 0.18181818181818
99374, -0.066666666666667, 1.4666666666667, 0.13636363636364
99375, -0.066666666666667, 1.4666666666667, 0.090909090909091
99376, -0.066666666666667, 1.4666666666667, 0.045454545454545
99377, -0.033333333333333, 1.4333333333333, 0.47727272727273
99378, -0.033333333333333, 1.4166666666667, 0.45454545454545
99379, -0.016666666666667, 1.4333333333333, 0.45454545454545
99380, -0.033333333333333, 1.4333333333333, 0.43181818181818
99381, -0.033333333333333, 1.4166666666667, 0.40909090909091
99382, -0.016666666666667, 1.4333333333333, 0.40909090909091
99383, -0.033333333333333, 1.4333333333333, 0.38636363636364
99384, -0.033333333333333, 1.4166666666667, 0.36363636363636
99385, -0.016666666666667, 1.4333333333333, 0.36363636363636
99386, -0.033333333333333, 1.4333333333333, 0.34090909090909
99387, -0.033333333333333, 1.4166666666667, 0.31818181818182
99388, -0.016666666666667, 1.4333333333333, 0.31818181818182
99389, -0.033333333333333, 1.4333333333333, 0.29545454545455
99390, -0.033333333333333, 1.4166666666667, 0.27272727272727
99391, -0.016666666666667, 1.4333333333333, 0.27272727272727
99392, -0.033333333333333, 1.4333333333333, 0.25
99393, -0.033333333333333, 1.4166666666667, 0.22727272727273
99394, -0.016666666666667, 1.4333333333333, 0.22727272727273
99395, -0.033333333333333, 1.4333333333333, 0.20454545454545
99396, -0.033333333333333, 1.4166666666667, 0.18181818181818
99397, -0.016666666666667, 1.4333333333333, 0.18181818181818
99398, -0.033333333333333, 1.4333333333333, 0.15909090909091
99399, -0.033333333333333, 1.4166666666667, 0.13636363636364
99400, -0.016666666666667, 1.4333333333333, 0.13636363636364
99401, -0.033333333333333, 1.4333333333333, 0.11363636363636
99402, -0.033333333333333, 1.4166666666667, 0.090909090909091
99403, -0.016666666666667, 1.4333333333333, 0.090909090909091
99404, -0.033333333333333, 1.4333333333333, 0.068181818181818
99405, -0.033333333333333, 1.4166666666667, 0.045454545454545
99406, -0.016666666666667, 1.4333333333333, 0.045454545454545
99407, -0.033333333333333, 1.4333333333333, 0.022727272727273
99408, -0.033333333333333, 1.4666666666667, 0.47727272727273
99409, -0.033333333333333, 1.45, 0.45454545454545
99410, -0.016666666666667, 1.4666666666667, 0.45454545454545
99411, -0.033333333333333, 1.4666666666667, 0.43181818181818
99412, -0.033333333333333, 1.45, 0.40909090909091
99413, -0.016666666666667, 1.4666666666667, 0.40909090909091
99414, -0.033333333333333, 1.4666666666667, 0.38636363636364
99415, -0.033333333333333, 1.45, 0.36363636363636
99416, -0.016666666666667, 1.4666666666667, 0.36363636363636
99417, -0.033333333333333, 1.4666666666667, 0.34090909090909
99418, -0.033333333333333, 1.45, 0.31818181818182
99419, -0.016666666666667, 1.4666666666667, 0.31818181818182
99420, -0.033333333333333, 1.4666666666667, 0.29545454545455
99421, -0.033333333333333, 1.45, 0.27272727272727
99422, -0.016666666666667, 1.4666666666667, 0.27272727272727
99423, -0.033333333333333, 1.4666666666667, 0.25
99424, -0.033333333333333, 1.45, 0.22727272727273
99425, -0.016666666666667, 1.4666666666667, 0.22727272727273
99426, -0.033333333333333, 1.4666666666667, 0.20454545454545
99427, -0.033333333333333, 1.45, 0.18181818181818
99428, -0.016666666666667, 1.4666666666667, 0.18181818181818
99429, -0.033333333333333, 1.4666666666667, 0.15909090909091
99430, -0.033333333333333, 1.45, 0.13636363636364
99431, -0.016666666666667, 1.4666666666667, 0.13636363636364
99432, -0.033333333333333, 1.4666666666667, 0.11363636363636
99433, -0.033333333333333, 1.45, 0.090909090909091
99434, -0.016666666666667, 1.4666666666667, 0.090909090909091
99435, -0.033333333333333, 1.4666666666667, 0.068181818181818
99436, -0.033333333333333, 1.45, 0.045454545454545
99437, -0.016666666666667, 1.4666666666667, 0.045454545454545
99438, -0.033333333333333, 1.4666666666667, 0.022727272727273
99439, -0.033333333333333, 1.4833333333333, 0.45454545454545
99440, -0.033333333333333, 1.4833333333333, 0.40909090909091
99441, -0.033333333333333, 1.4833333333333, 0.36363636363636
99442, -0.033333333333333, 1.4833333333333, 0.31818181818182
99443, -0.033333333333333, 1.4833333333333, 0.27272727272727
99444, -0.033333333333333, 1.4833333333333, 0.22727272727273
99445, -0.033333333333333, 1.4833333333333, 0.18181818181818
99446, -0.033333333333333, 1.4833333333333, 0.13636363636364
99447, -0.033333333333333, 1.4833333333333, 0.090909090909091
99448, -0.033333333333333, 1.4833333333333, 0.045454545454545
99449, -0.066666666666667, 1.4333333333333, 0.47727272727273
99450, -0.066666666666667, 1.4166666666667, 0.45454545454545
99451, -0.05, 1.4333333333333, 0.45454545454545
99452, -0.066666666666667, 1.4333333333333, 0.43181818181818
99453, -0.066666666666667, 1.4166666666667, 0.40909090909091
99454, -0.05, 1.4333333333333, 0.40909090909091
99455, -0.066666666666667, 1.4333333333333, 0.38636363636364
99456, -0.066666666666667, 1.4166666666667, 0.36363636363636
99457, -0.05, 1.4333333333333, 0.36363636363636
99458, -0.066666666666667, 1.4333333333333, 0.34090909090909
99459, -0.066666666666667, 1.4166666666667, 0.31818181818182
99460, -0.05, 1.4333333333333, 0.31818181818182
99461, -0.066666666666667, 1.4333333333333, 0.29545454545455
99462, -0.066666666666667, 1.4166666666667, 0.27272727272727
99463, -0.05, 1.4333333333333, 0.27272727272727
99464, -0.066666666666667, 1.4333333333333, 0.25
99465, -0.066666666666667, 1.4166666666667, 0.22727272727273
99466, -0.05, 1.4333333333333, 0.22727272727273
99467, -0.066666666666667, 1.4333333333333, 0.20454545454545
99468, -0.066666666666667, 1.4166666666667, 0.18181818181818
99469, -0.05, 1.4333333333333, 0.18181818181818
99470, -0.066666666666667, 1.4333333333333, 0.15909090909091
99471, -0.066666666666667, 1.4166666666667, 0.13636363636364
99472, -0.05, 1.4333333333333, 0.13636363636364
99473, -0.066666666666667, 1.4333333333333, 0.11363636363636
99474, -0.066666666666667, 1.4166666666667, 0.090909090909091
99475, -0.05, 1.4333333333333, 0.090909090909091
99476, -0.066666666666667, 1.4333333333333, 0.068181818181818
99477, -0.066666666666667, 1.4166666666667, 0.045454545454545
99478, -0.05, 1.4333333333333, 0.045454545454545
99479, -0.066666666666667, 1.4333333333333, 0.022727272727273
99480, -0.066666666666667, 1.4666666666667, 0.47727272727273
99481, -0.066666666666667, 1.45, 0.45454545454545
99482, -0.05, 1.4666666666667, 0.45454545454545
99483, -0.066666666666667, 1.4666666666667, 0.43181818181818
99484, -0.066666666666667, 1.45, 0.40909090909091
99485, -0.05, 1.4666666666667, 0.40909090909091
99486, -0.066666666666667, 1.4666666666667, 0.38636363636364
99487, -0.066666666666667, 1.45, 0.36363636363636
99488, -0.05, 1.4666666666667, 0.36363636363636
99489, -0.066666666666667, 1.4666666666667, 0.34090909090909
99490, -0.066666666666667, 1.45, 0.31818181818182
99491, -0.05, 1.4666666666667, 0.31818181818182
99492, -0.066666666666667, 1.4666666666667, 0.29545454545455
99493, -0.066666666666667, 1.45, 0.27272727272727
99494, -0.05, 1.4666666666667, 0.27272727272727
99495, -0.066666666666667, 1.4666666666667, 0.25
99496, -0.066666666666667, 1.45, 0.22727272727273
99497, -0.05, 1.4666666666667, 0.22727272727273
99498, -0.066666666666667, 1.4666666666667, 0.20454545454545
99499, -0.066666666666667, 1.45, 0.18181818181818
99500, -0.05, 1.4666666666667, 0.18181818181818
99501, -0.066666666666667, 1.4666666666667, 0.15909090909091
99502, -0.066666666666667, 1.45, 0.13636363636364
99503, -0.05, 1.4666666666667, 0.13636363636364
99504, -0.066666666666667, 1.4666666666667, 0.11363636363636
99505, -0.066666666666667, 1.45, 0.090909090909091
99506, -0.05, 1.4666666666667, 0.090909090909091
99507, -0.066666666666667, 1.4666666666667, 0.068181818181818
99508, -0.066666666666667, 1.45, 0.045454545454545
99509, -0.05, 1.4666666666667, 0.045454545454545
99510, -0.066666666666667, 1.4666666666667, 0.022727272727273
99511, -0.066666666666667, 1.4833333333333, 0.45454545454545
99512, -0.066666666666667, 1.4833333333333, 0.40909090909091
99513, -0.066666666666667, 1.4833333333333, 0.36363636363636
99514, -0.066666666666667, 1.4833333333333, 0.31818181818182
99515, -0.066666666666667, 1.4833333333333, 0.27272727272727
99516, -0.066666666666667, 1.4833333333333, 0.22727272727273
99517, -0.066666666666667, 1.4833333333333, 0.18181818181818
99518, -0.066666666666667, 1.4833333333333, 0.13636363636364
99519, -0.066666666666667, 1.4833333333333, 0.090909090909091
99520, -0.066666666666667, 1.4833333333333, 0.045454545454545
99521, -0.083333333333333, 1.4333333333333, 0.45454545454545
99522, -0.083333333333333, 1.4333333333333, 0.40909090909091
99523, -0.083333333333333, 1.4333333333333, 0.36363636363636
99524, -0.083333333333333, 1.4333333333333, 0.31818181818182
99525, -0.083333333333333, 1.4333333333333, 0.27272727272727
99526, -0.083333333333333, 1.4333333333333, 0.22727272727273
99527, -0.083333333333333, 1.4333333333333, 0.18181818181818
99528, -0.083333333333333, 1.4333333333333, 0.13636363636364
99529, -0.083333333333333, 1.4333333333333, 0.090909090909091
99530, -0.083333333333333, 1.4333333333333, 0.045454545454545
99531, -0.083333333333333, 1.4666666666667, 0.45454545454545
99532, -0.083333333333333, 1.4666666666667, 0.40909090909091
99533, -0.083333333333333, 1.4666666666667, 0.36363636363636
99534, -0.083333333333333, 1.4666666666667, 0.31818181818182
99535, -0.083333333333333, 1.4666666666667, 0.27272727272727
99536, -0.083333333333333, 1.4666666666667, 0.22727272727273
99537, -0.083333333333333, 1.4666666666667, 0.18181818181818
99538, -0.083333333333333, 1.4666666666667, 0.13636363636364
99539, -0.083333333333333, 1.4666666666667, 0.090909090909091
99540, -0.083333333333333, 1.4666666666667, 0.045454545454545
99541, 2.2333333333333, 1.55, 0.45454545454545
99542, 2.2333333333333, 1.55, 0.40909090909091
99543, 2.2333333333333, 1.55, 0.36363636363636
99544, 2.2333333333333, 1.55, 0.31818181818182
99545, 2.2333333333333, 1.55, 0.27272727272727
99546, 2.2333333333333, 1.55, 0.22727272727273
99547, 2.2333333333333, 1.55, 0.18181818181818
99548, 2.2333333333333, 1.55, 0.13636363636364
99549, 2.2333333333333, 1.55, 0.090909090909091
99550, 2.2333333333333, 1.55, 0.045454545454545
99551, 2.2333333333333, 1.6, 0.45454545454545
99552, 2.2333333333333, 1.6, 0.40909090909091
99553, 2.2333333333333, 1.6, 0.36363636363636
99554, 2.2333333333333, 1.6, 0.31818181818182
99555, 2.2333333333333, 1.6, 0.27272727272727
99556, 2.2333333333333, 1.6, 0.22727272727273
99557, 2.2333333333333, 1.6, 0.18181818181818
99558, 2.2333333333333, 1.6, 0.13636363636364
99559, 2.2333333333333, 1.6, 0.090909090909091
99560, 2.2333333333333, 1.6, 0.045454545454545
99561, 2.2333333333333, 1.65, 0.45454545454545
99562, 2.2333333333333, 1.65, 0.40909090909091
99563, 2.2333333333333, 1.65, 0.36363636363636
99564, 2.2333333333333, 1.65, 0.31818181818182
99565, 2.2333333333333, 1.65, 0.27272727272727
99566, 2.2333333333333, 1.65, 0.22727272727273
99567, 2.2333333333333, 1.65, 0.18181818181818
99568, 2.2333333333333, 1.65, 0.13636363636364
99569, 2.2333333333333, 1.65, 0.090909090909091
99570, 2.2333333333333, 1.65, 0.045454545454545
99571, 2.2666666666667, 1.55, 0.45454545454545
99572, 2.2666666666667, 1.55, 0.40909090909091
99573, 2.2666666666667, 1.55, 0.36363636363636
99574, 2.2666666666667, 1.55, 0.31818181818182
99575, 2.2666666666667, 1.55, 0.27272727272727
99576, 2.2666666666667, 1.55, 0.22727272727273
99577, 2.2666666666667, 1.55, 0.18181818181818
99578, 2.2666666666667, 1.55, 0.13636363636364
99579, 2.2666666666667, 1.55, 0.090909090909091
99580, 2.2666666666667, 1.55, 0.045454545454545
99581, 2.2666666666667, 1.6, 0.45454545454545
99582, 2.2666666666667, 1.6, 0.40909090909091
99583, 2.2666666666667, 1.6, 0.36363636363636
99584, 2.2666666666667, 1.6, 0.31818181818182
99585, 2.2666666666667, 1.6, 0.27272727272727
99586, 2.2666666666667, 1.6, 0.22727272727273
99587, 2.2666666666667, 1.6, 0.18181818181818
99588, 2.2666666666667, 1.6, 0.13636363636364
99589, 2.2666666666667, 1.6, 0.090909090909091
99590, 2.2666666666667, 1.6, 0.045454545454545
99591, 2.2666666666667, 1.65, 0.45454545454545
99592, 2.2666666666667, 1.65, 0.40909090909091
99593, 2.2666666666667, 1.65, 0.36363636363636
99594, 2.2666666666667, 1.65, 0.31818181818182
99595, 2.2666666666667, 1.65, 0.27272727272727
99596, 2.2666666666667, 1.65, 0.22727272727273
99597, 2.2666666666667, 1.65, 0.18181818181818
99598, 2.2666666666667, 1.65, 0.13636363636364
99599, 2.2666666666667, 1.65, 0.090909090909091
99600, 2.2666666666667, 1.65, 0.045454545454545
99601, 2.2333333333333, 1.55, 0.47727272727273
99602, 2.2333333333333, 1.525, 0.45454545454545
99603, 2.2166666666667, 1.55, 0.45454545454545
99604, 2.2333333333333, 1.55, 0.43181818181818
99605, 2.2333333333333, 1.525, 0.40909090909091
99606, 2.2166666666667, 1.55, 0.40909090909091
99607, 2.2333333333333, 1.55, 0.38636363636364
99608, 2.2333333333333, 1.525, 0.36363636363636
99609, 2.2166666666667, 1.55, 0.36363636363636
99610, 2.2333333333333, 1.55, 0.34090909090909
99611, 2.2333333333333, 1.525, 0.31818181818182
99612, 2.2166666666667, 1.55, 0.31818181818182
99613, 2.2333333333333, 1.55, 0.29545454545455
99614, 2.2333333333333, 1.525, 0.27272727272727
99615, 2.2166666666667, 1.55, 0.27272727272727
99616, 2.2333333333333, 1.55, 0.25
99617, 2.2333333333333, 1.525, 0.22727272727273
99618, 2.2166666666667, 1.55, 0.22727272727273
99619, 2.2333333333333, 1.55, 0.20454545454545
99620, 2.2333333333333, 1.525, 0.18181818181818
99621, 2.2166666666667, 1.55, 0.18181818181818
99622, 2.2333333333333, 1.55, 0.15909090909091
99623, 2.2333333333333, 1.525, 0.13636363636364
99624, 2.2166666666667, 1.55, 0.13636363636364
99625, 2.2333333333333, 1.55, 0.11363636363636
99626, 2.2333333333333, 1.525, 0.090909090909091
99627, 2.2166666666667, 1.55, 0.090909090909091
99628, 2.2333333333333, 1.55, 0.068181818181818
99629, 2.2333333333333, 1.525, 0.045454545454545
99630, 2.2166666666667, 1.55, 0.045454545454545
99631, 2.2333333333333, 1.55, 0.022727272727273
99632, 2.2333333333333, 1.6, 0.47727272727273
99633, 2.2333333333333, 1.575, 0.45454545454545
99634, 2.2166666666667, 1.6, 0.45454545454545
99635, 2.2333333333333, 1.6, 0.43181818181818
99636, 2.2333333333333, 1.575, 0.40909090909091
99637, 2.2166666666667, 1.6, 0.40909090909091
99638, 2.2333333333333, 1.6, 0.38636363636364
99639, 2.2333333333333, 1.575, 0.36363636363636
99640, 2.2166666666667, 1.6, 0.36363636363636
99641, 2.2333333333333, 1.6, 0.34090909090909
99642, 2.2333333333333, 1.575, 0.31818181818182
99643, 2.2166666666667, 1.6, 0.31818181818182
99644, 2.2333333333333, 1.6, 0.29545454545455
99645, 2.2333333333333, 1.575, 0.27272727272727
99646, 2.2166666666667, 1.6, 0.27272727272727
99647, 2.2333333333333, 1.6, 0.25
99648, 2.2333333333333, 1.575, 0.22727272727273
99649, 2.2166666666667, 1.6, 0.22727272727273
99650, 2.2333333333333, 1.6, 0.20454545454545
99651, 2.2333333333333, 1.575, 0.18181818181818
99652, 2.2166666666667, 1.6, 0.18181818181818
99653, 2.2333333333333, 1.6, 0.15909090909091
99654, 2.2333333333333, 1.575, 0.13636363636364
99655, 2.2166666666667, 1.6, 0.13636363636364
99656, 2.2333333333333, 1.6, 0.11363636363636
99657, 2.2333333333333, 1.575, 0.090909090909091
99658, 2.2166666666667, 1.6, 0.090909090909091
99659, 2.2333333333333, 1.6, 0.068181818181818
99660, 2.2333333333333, 1.575, 0.045454545454545
99661, 2.2166666666667, 1.6, 0.045454545454545
99662, 2.2333333333333, 1.6, 0.022727272727273
99663, 2.2333333333333, 1.65, 0.47727272727273
99664, 2.2333333333333, 1.625, 0.45454545454545
99665, 2.2166666666667, 1.65, 0.45454545454545
99666, 2.2333333333333, 1.65, 0.43181818181818
99667, 2.2333333333333, 1.625, 0.40909090909091
99668, 2.2166666666667, 1.65, 0.40909090909091
99669, 2.2333333333333, 1.65, 0.38636363636364
99670, 2.2333333333333, 1.625, 0.36363636363636
99671, 2.2166666666667, 1.65, 0.36363636363636
99672, 2.2333333333333, 1.65, 0.34090909090909
99673, 2.2333333333333, 1.625, 0.31818181818182
99674, 2.2166666666667, 1.65, 0.31818181818182
99675, 2.2333333333333, 1.65, 0.29545454545455
99676, 2.2333333333333, 1.625, 0.27272727272727
99677, 2.2166666666667, 1.65, 0.27272727272727
99678, 2.2333333333333, 1.65, 0.25
