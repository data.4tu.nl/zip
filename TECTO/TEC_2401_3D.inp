31963, 89644, 25428, 25438, 89654, 89645, 25429, 25439, 89655, 91940, 25873, 91950, 91668, 91941, 25875, 91951, 
91671, 91639, 25853, 25874, 91670
31964, 89645, 25429, 25439, 89655, 89646, 25430, 25440, 89656, 91941, 25875, 91951, 91671, 91942, 25877, 91952, 
91674, 91642, 25855, 25876, 91673
31965, 89646, 25430, 25440, 89656, 89647, 25431, 25441, 89657, 91942, 25877, 91952, 91674, 91943, 25879, 91953, 
91677, 91645, 25857, 25878, 91676
31966, 89647, 25431, 25441, 89657, 89648, 25432, 25442, 89658, 91943, 25879, 91953, 91677, 91944, 25881, 91954, 
91680, 91648, 25859, 25880, 91679
31967, 89648, 25432, 25442, 89658, 24979, 2510, 2511, 24980, 91944, 25881, 91954, 91680, 25136, 2533, 25137, 
25111, 91651, 25861, 25882, 91682
31968, 24757, 2459, 2460, 24758, 89649, 25433, 25443, 89659, 24914, 2482, 24915, 24891, 91945, 25884, 91955, 
91684, 91652, 25862, 25883, 91683
31969, 89649, 25433, 25443, 89659, 89650, 25434, 25444, 89660, 91945, 25884, 91955, 91684, 91946, 25886, 91956, 
91687, 91655, 25864, 25885, 91686
31970, 89650, 25434, 25444, 89660, 89651, 25435, 25445, 89661, 91946, 25886, 91956, 91687, 91947, 25888, 91957, 
91690, 91658, 25866, 25887, 91689
31971, 89651, 25435, 25445, 89661, 89652, 25436, 25446, 89662, 91947, 25888, 91957, 91690, 91948, 25890, 91958, 
91693, 91661, 25868, 25889, 91692
31972, 89652, 25436, 25446, 89662, 89653, 25437, 25447, 89663, 91948, 25890, 91958, 91693, 91949, 25892, 91959, 
91696, 91664, 25870, 25891, 91695
31973, 89653, 25437, 25447, 89663, 89654, 25438, 25448, 89664, 91949, 25892, 91959, 91696, 91950, 25894, 91960, 
91699, 91667, 25872, 25893, 91698
31974, 89654, 25438, 25448, 89664, 89655, 25439, 25449, 89665, 91950, 25894, 91960, 91699, 91951, 25896, 91961, 
91702, 91670, 25874, 25895, 91701
31975, 89655, 25439, 25449, 89665, 89656, 25440, 25450, 89666, 91951, 25896, 91961, 91702, 91952, 25898, 91962, 
91705, 91673, 25876, 25897, 91704
31976, 89656, 25440, 25450, 89666, 89657, 25441, 25451, 89667, 91952, 25898, 91962, 91705, 91953, 25900, 91963, 
91708, 91676, 25878, 25899, 91707
31977, 89657, 25441, 25451, 89667, 89658, 25442, 25452, 89668, 91953, 25900, 91963, 91708, 91954, 25902, 91964, 
91711, 91679, 25880, 25901, 91710
31978, 89658, 25442, 25452, 89668, 24980, 2511, 2512, 24981, 91954, 25902, 91964, 91711, 25137, 2534, 25138, 
25113, 91682, 25882, 25903, 91713
31979, 24758, 2460, 2461, 24759, 89659, 25443, 25453, 89669, 24915, 2483, 24916, 24893, 91955, 25905, 91965, 
91715, 91683, 25883, 25904, 91714
31980, 89659, 25443, 25453, 89669, 89660, 25444, 25454, 89670, 91955, 25905, 91965, 91715, 91956, 25907, 91966, 
91718, 91686, 25885, 25906, 91717
31981, 89660, 25444, 25454, 89670, 89661, 25445, 25455, 89671, 91956, 25907, 91966, 91718, 91957, 25909, 91967, 
91721, 91689, 25887, 25908, 91720
31982, 89661, 25445, 25455, 89671, 89662, 25446, 25456, 89672, 91957, 25909, 91967, 91721, 91958, 25911, 91968, 
91724, 91692, 25889, 25910, 91723
31983, 89662, 25446, 25456, 89672, 89663, 25447, 25457, 89673, 91958, 25911, 91968, 91724, 91959, 25913, 91969, 
91727, 91695, 25891, 25912, 91726
31984, 89663, 25447, 25457, 89673, 89664, 25448, 25458, 89674, 91959, 25913, 91969, 91727, 91960, 25915, 91970, 
91730, 91698, 25893, 25914, 91729
31985, 89664, 25448, 25458, 89674, 89665, 25449, 25459, 89675, 91960, 25915, 91970, 91730, 91961, 25917, 91971, 
91733, 91701, 25895, 25916, 91732
31986, 89665, 25449, 25459, 89675, 89666, 25450, 25460, 89676, 91961, 25917, 91971, 91733, 91962, 25919, 91972, 
91736, 91704, 25897, 25918, 91735
31987, 89666, 25450, 25460, 89676, 89667, 25451, 25461, 89677, 91962, 25919, 91972, 91736, 91963, 25921, 91973, 
91739, 91707, 25899, 25920, 91738
31988, 89667, 25451, 25461, 89677, 89668, 25452, 25462, 89678, 91963, 25921, 91973, 91739, 91964, 25923, 91974, 
91742, 91710, 25901, 25922, 91741
31989, 89668, 25452, 25462, 89678, 24981, 2512, 2513, 24982, 91964, 25923, 91974, 91742, 25138, 2535, 25139, 
25115, 91713, 25903, 25924, 91744
31990, 24759, 2461, 61, 2435, 89669, 25453, 2546, 25160, 24916, 2484, 2439, 24894, 91965, 25925, 25233, 
91745, 91714, 25904, 2557, 25213
31991, 89669, 25453, 2546, 25160, 89670, 25454, 2545, 25161, 91965, 25925, 25233, 91745, 91966, 25926, 25234, 
91746, 91717, 25906, 2556, 25215
31992, 89670, 25454, 2545, 25161, 89671, 25455, 2544, 25162, 91966, 25926, 25234, 91746, 91967, 25927, 25235, 
91747, 91720, 25908, 2555, 25217
31993, 89671, 25455, 2544, 25162, 89672, 25456, 2543, 25163, 91967, 25927, 25235, 91747, 91968, 25928, 25236, 
91748, 91723, 25910, 2554, 25219
31994, 89672, 25456, 2543, 25163, 89673, 25457, 2542, 25164, 91968, 25928, 25236, 91748, 91969, 25929, 25237, 
91749, 91726, 25912, 2553, 25221
31995, 89673, 25457, 2542, 25164, 89674, 25458, 2541, 25165, 91969, 25929, 25237, 91749, 91970, 25930, 25238, 
91750, 91729, 25914, 2552, 25223
31996, 89674, 25458, 2541, 25165, 89675, 25459, 2540, 25166, 91970, 25930, 25238, 91750, 91971, 25931, 25239, 
91751, 91732, 25916, 2551, 25225
31997, 89675, 25459, 2540, 25166, 89676, 25460, 2539, 25167, 91971, 25931, 25239, 91751, 91972, 25932, 25240, 
91752, 91735, 25918, 2550, 25227
31998, 89676, 25460, 2539, 25167, 89677, 25461, 2538, 25168, 91972, 25932, 25240, 91752, 91973, 25933, 25241, 
91753, 91738, 25920, 2549, 25229
31999, 89677, 25461, 2538, 25168, 89678, 25462, 2537, 25169, 91973, 25933, 25241, 91753, 91974, 25934, 25242, 
91754, 91741, 25922, 2548, 25231
32000, 89678, 25462, 2537, 25169, 24982, 2513, 62, 2487, 91974, 25934, 25242, 91754, 25139, 2536, 2491, 
25117, 91744, 25924, 2547, 25232
*ELEMENT, type=C3D20, ELSET=Volume23
32001, 25935, 2558, 6, 214, 91975, 26167, 141, 3713, 26001, 2561, 237, 26002, 92636, 26207, 4185, 
92637, 92635, 26208, 151, 4164
32002, 91975, 26167, 141, 3713, 91976, 26166, 142, 3714, 92636, 26207, 4185, 92637, 92639, 26205, 4186, 
92640, 92638, 26206, 152, 4166
32003, 91976, 26166, 142, 3714, 91977, 26165, 143, 3715, 92639, 26205, 4186, 92640, 92642, 26203, 4187, 
92643, 92641, 26204, 153, 4168
32004, 91977, 26165, 143, 3715, 91978, 26164, 144, 3716, 92642, 26203, 4187, 92643, 92645, 26201, 4188, 
92646, 92644, 26202, 154, 4170
32005, 91978, 26164, 144, 3716, 91979, 26163, 145, 3717, 92645, 26201, 4188, 92646, 92648, 26199, 4189, 
92649, 92647, 26200, 155, 4172
32006, 91979, 26163, 145, 3717, 91980, 26162, 146, 3718, 92648, 26199, 4189, 92649, 92651, 26197, 4190, 
92652, 92650, 26198, 156, 4174
32007, 91980, 26162, 146, 3718, 91981, 26161, 147, 3719, 92651, 26197, 4190, 92652, 92654, 26195, 4191, 
92655, 92653, 26196, 157, 4176
32008, 91981, 26161, 147, 3719, 91982, 26160, 148, 3720, 92654, 26195, 4191, 92655, 92657, 26193, 4192, 
92658, 92656, 26194, 158, 4178
32009, 91982, 26160, 148, 3720, 91983, 26159, 149, 3721, 92657, 26193, 4192, 92658, 92660, 26191, 4193, 
92661, 92659, 26192, 159, 4180
32010, 91983, 26159, 149, 3721, 91984, 26158, 150, 3722, 92660, 26191, 4193, 92661, 92663, 26189, 4194, 
92664, 92662, 26190, 160, 4182
32011, 91984, 26158, 150, 3722, 26261, 2617, 5, 259, 92663, 26189, 4194, 92664, 26328, 2620, 282, 
26327, 92665, 26188, 161, 4184
32012, 25936, 25935, 214, 213, 91985, 91975, 3713, 3703, 26003, 26002, 236, 26004, 92667, 92637, 4165, 
92668, 92666, 92635, 4164, 4143
32013, 91985, 91975, 3713, 3703, 91986, 91976, 3714, 3704, 92667, 92637, 4165, 92668, 92670, 92640, 4167, 
92671, 92669, 92638, 4166, 4145
32014, 91986, 91976, 3714, 3704, 91987, 91977, 3715, 3705, 92670, 92640, 4167, 92671, 92673, 92643, 4169, 
92674, 92672, 92641, 4168, 4147
32015, 91987, 91977, 3715, 3705, 91988, 91978, 3716, 3706, 92673, 92643, 4169, 92674, 92676, 92646, 4171, 
92677, 92675, 92644, 4170, 4149
32016, 91988, 91978, 3716, 3706, 91989, 91979, 3717, 3707, 92676, 92646, 4171, 92677, 92679, 92649, 4173, 
92680, 92678, 92647, 4172, 4151
32017, 91989, 91979, 3717, 3707, 91990, 91980, 3718, 3708, 92679, 92649, 4173, 92680, 92682, 92652, 4175, 
92683, 92681, 92650, 4174, 4153
32018, 91990, 91980, 3718, 3708, 91991, 91981, 3719, 3709, 92682, 92652, 4175, 92683, 92685, 92655, 4177, 
92686, 92684, 92653, 4176, 4155
32019, 91991, 91981, 3719, 3709, 91992, 91982, 3720, 3710, 92685, 92655, 4177, 92686, 92688, 92658, 4179, 
92689, 92687, 92656, 4178, 4157
32020, 91992, 91982, 3720, 3710, 91993, 91983, 3721, 3711, 92688, 92658, 4179, 92689, 92691, 92661, 4181, 
92692, 92690, 92659, 4180, 4159
32021, 91993, 91983, 3721, 3711, 91994, 91984, 3722, 3712, 92691, 92661, 4181, 92692, 92694, 92664, 4183, 
92695, 92693, 92662, 4182, 4161
32022, 91994, 91984, 3722, 3712, 26262, 26261, 259, 258, 92694, 92664, 4183, 92695, 26330, 26327, 281, 
26329, 92696, 92665, 4184, 4163
32023, 25937, 25936, 213, 212, 91995, 91985, 3703, 3693, 26005, 26004, 235, 26006, 92698, 92668, 4144, 
92699, 92697, 92666, 4143, 4122
32024, 91995, 91985, 3703, 3693, 91996, 91986, 3704, 3694, 92698, 92668, 4144, 92699, 92701, 92671, 4146, 
92702, 92700, 92669, 4145, 4124
32025, 91996, 91986, 3704, 3694, 91997, 91987, 3705, 3695, 92701, 92671, 4146, 92702, 92704, 92674, 4148, 
92705, 92703, 92672, 4147, 4126
32026, 91997, 91987, 3705, 3695, 91998, 91988, 3706, 3696, 92704, 92674, 4148, 92705, 92707, 92677, 4150, 
92708, 92706, 92675, 4149, 4128
32027, 91998, 91988, 3706, 3696, 91999, 91989, 3707, 3697, 92707, 92677, 4150, 92708, 92710, 92680, 4152, 
92711, 92709, 92678, 4151, 4130
32028, 91999, 91989, 3707, 3697, 92000, 91990, 3708, 3698, 92710, 92680, 4152, 92711, 92713, 92683, 4154, 
92714, 92712, 92681, 4153, 4132
32029, 92000, 91990, 3708, 3698, 92001, 91991, 3709, 3699, 92713, 92683, 4154, 92714, 92716, 92686, 4156, 
92717, 92715, 92684, 4155, 4134
32030, 92001, 91991, 3709, 3699, 92002, 91992, 3710, 3700, 92716, 92686, 4156, 92717, 92719, 92689, 4158, 
92720, 92718, 92687, 4157, 4136
32031, 92002, 91992, 3710, 3700, 92003, 91993, 3711, 3701, 92719, 92689, 4158, 92720, 92722, 92692, 4160, 
92723, 92721, 92690, 4159, 4138
32032, 92003, 91993, 3711, 3701, 92004, 91994, 3712, 3702, 92722, 92692, 4160, 92723, 92725, 92695, 4162, 
92726, 92724, 92693, 4161, 4140
32033, 92004, 91994, 3712, 3702, 26263, 26262, 258, 257, 92725, 92695, 4162, 92726, 26332, 26329, 280, 
26331, 92727, 92696, 4163, 4142
32034, 25938, 25937, 212, 211, 92005, 91995, 3693, 3683, 26007, 26006, 234, 26008, 92729, 92699, 4123, 
92730, 92728, 92697, 4122, 4101
32035, 92005, 91995, 3693, 3683, 92006, 91996, 3694, 3684, 92729, 92699, 4123, 92730, 92732, 92702, 4125, 
92733, 92731, 92700, 4124, 4103
32036, 92006, 91996, 3694, 3684, 92007, 91997, 3695, 3685, 92732, 92702, 4125, 92733, 92735, 92705, 4127, 
92736, 92734, 92703, 4126, 4105
32037, 92007, 91997, 3695, 3685, 92008, 91998, 3696, 3686, 92735, 92705, 4127, 92736, 92738, 92708, 4129, 
92739, 92737, 92706, 4128, 4107
32038, 92008, 91998, 3696, 3686, 92009, 91999, 3697, 3687, 92738, 92708, 4129, 92739, 92741, 92711, 4131, 
92742, 92740, 92709, 4130, 4109
32039, 92009, 91999, 3697, 3687, 92010, 92000, 3698, 3688, 92741, 92711, 4131, 92742, 92744, 92714, 4133, 
92745, 92743, 92712, 4132, 4111
32040, 92010, 92000, 3698, 3688, 92011, 92001, 3699, 3689, 92744, 92714, 4133, 92745, 92747, 92717, 4135, 
92748, 92746, 92715, 4134, 4113
32041, 92011, 92001, 3699, 3689, 92012, 92002, 3700, 3690, 92747, 92717, 4135, 92748, 92750, 92720, 4137, 
92751, 92749, 92718, 4136, 4115
32042, 92012, 92002, 3700, 3690, 92013, 92003, 3701, 3691, 92750, 92720, 4137, 92751, 92753, 92723, 4139, 
92754, 92752, 92721, 4138, 4117
32043, 92013, 92003, 3701, 3691, 92014, 92004, 3702, 3692, 92753, 92723, 4139, 92754, 92756, 92726, 4141, 
92757, 92755, 92724, 4140, 4119
32044, 92014, 92004, 3702, 3692, 26264, 26263, 257, 256, 92756, 92726, 4141, 92757, 26334, 26331, 279, 
26333, 92758, 92727, 4142, 4121
32045, 25939, 25938, 211, 210, 92015, 92005, 3683, 3673, 26009, 26008, 233, 26010, 92760, 92730, 4102, 
92761, 92759, 92728, 4101, 4080
32046, 92015, 92005, 3683, 3673, 92016, 92006, 3684, 3674, 92760, 92730, 4102, 92761, 92763, 92733, 4104, 
92764, 92762, 92731, 4103, 4082
32047, 92016, 92006, 3684, 3674, 92017, 92007, 3685, 3675, 92763, 92733, 4104, 92764, 92766, 92736, 4106, 
92767, 92765, 92734, 4105, 4084
32048, 92017, 92007, 3685, 3675, 92018, 92008, 3686, 3676, 92766, 92736, 4106, 92767, 92769, 92739, 4108, 
92770, 92768, 92737, 4107, 4086
32049, 92018, 92008, 3686, 3676, 92019, 92009, 3687, 3677, 92769, 92739, 4108, 92770, 92772, 92742, 4110, 
92773, 92771, 92740, 4109, 4088
32050, 92019, 92009, 3687, 3677, 92020, 92010, 3688, 3678, 92772, 92742, 4110, 92773, 92775, 92745, 4112, 
92776, 92774, 92743, 4111, 4090
32051, 92020, 92010, 3688, 3678, 92021, 92011, 3689, 3679, 92775, 92745, 4112, 92776, 92778, 92748, 4114, 
92779, 92777, 92746, 4113, 4092
32052, 92021, 92011, 3689, 3679, 92022, 92012, 3690, 3680, 92778, 92748, 4114, 92779, 92781, 92751, 4116, 
92782, 92780, 92749, 4115, 4094
32053, 92022, 92012, 3690, 3680, 92023, 92013, 3691, 3681, 92781, 92751, 4116, 92782, 92784, 92754, 4118, 
92785, 92783, 92752, 4117, 4096
32054, 92023, 92013, 3691, 3681, 92024, 92014, 3692, 3682, 92784, 92754, 4118, 92785, 92787, 92757, 4120, 
92788, 92786, 92755, 4119, 4098
32055, 92024, 92014, 3692, 3682, 26265, 26264, 256, 255, 92787, 92757, 4120, 92788, 26336, 26333, 278, 
26335, 92789, 92758, 4121, 4100
32056, 25940, 25939, 210, 209, 92025, 92015, 3673, 3663, 26011, 26010, 232, 26012, 92791, 92761, 4081, 
92792, 92790, 92759, 4080, 4059
32057, 92025, 92015, 3673, 3663, 92026, 92016, 3674, 3664, 92791, 92761, 4081, 92792, 92794, 92764, 4083, 
92795, 92793, 92762, 4082, 4061
32058, 92026, 92016, 3674, 3664, 92027, 92017, 3675, 3665, 92794, 92764, 4083, 92795, 92797, 92767, 4085, 
92798, 92796, 92765, 4084, 4063
32059, 92027, 92017, 3675, 3665, 92028, 92018, 3676, 3666, 92797, 92767, 4085, 92798, 92800, 92770, 4087, 
92801, 92799, 92768, 4086, 4065
32060, 92028, 92018, 3676, 3666, 92029, 92019, 3677, 3667, 92800, 92770, 4087, 92801, 92803, 92773, 4089, 
92804, 92802, 92771, 4088, 4067
32061, 92029, 92019, 3677, 3667, 92030, 92020, 3678, 3668, 92803, 92773, 4089, 92804, 92806, 92776, 4091, 
92807, 92805, 92774, 4090, 4069
32062, 92030, 92020, 3678, 3668, 92031, 92021, 3679, 3669, 92806, 92776, 4091, 92807, 92809, 92779, 4093, 
92810, 92808, 92777, 4092, 4071
32063, 92031, 92021, 3679, 3669, 92032, 92022, 3680, 3670, 92809, 92779, 4093, 92810, 92812, 92782, 4095, 
92813, 92811, 92780, 4094, 4073
32064, 92032, 92022, 3680, 3670, 92033, 92023, 3681, 3671, 92812, 92782, 4095, 92813, 92815, 92785, 4097, 
92816, 92814, 92783, 4096, 4075
32065, 92033, 92023, 3681, 3671, 92034, 92024, 3682, 3672, 92815, 92785, 4097, 92816, 92818, 92788, 4099, 
92819, 92817, 92786, 4098, 4077
32066, 92034, 92024, 3682, 3672, 26266, 26265, 255, 254, 92818, 92788, 4099, 92819, 26338, 26335, 277, 
26337, 92820, 92789, 4100, 4079
32067, 25941, 25940, 209, 208, 92035, 92025, 3663, 3653, 26013, 26012, 231, 26014, 92822, 92792, 4060, 
92823, 92821, 92790, 4059, 4038
32068, 92035, 92025, 3663, 3653, 92036, 92026, 3664, 3654, 92822, 92792, 4060, 92823, 92825, 92795, 4062, 
92826, 92824, 92793, 4061, 4040
32069, 92036, 92026, 3664, 3654, 92037, 92027, 3665, 3655, 92825, 92795, 4062, 92826, 92828, 92798, 4064, 
92829, 92827, 92796, 4063, 4042
32070, 92037, 92027, 3665, 3655, 92038, 92028, 3666, 3656, 92828, 92798, 4064, 92829, 92831, 92801, 4066, 
92832, 92830, 92799, 4065, 4044
32071, 92038, 92028, 3666, 3656, 92039, 92029, 3667, 3657, 92831, 92801, 4066, 92832, 92834, 92804, 4068, 
92835, 92833, 92802, 4067, 4046
32072, 92039, 92029, 3667, 3657, 92040, 92030, 3668, 3658, 92834, 92804, 4068, 92835, 92837, 92807, 4070, 
92838, 92836, 92805, 4069, 4048
32073, 92040, 92030, 3668, 3658, 92041, 92031, 3669, 3659, 92837, 92807, 4070, 92838, 92840, 92810, 4072, 
92841, 92839, 92808, 4071, 4050
32074, 92041, 92031, 3669, 3659, 92042, 92032, 3670, 3660, 92840, 92810, 4072, 92841, 92843, 92813, 4074, 
92844, 92842, 92811, 4073, 4052
32075, 92042, 92032, 3670, 3660, 92043, 92033, 3671, 3661, 92843, 92813, 4074, 92844, 92846, 92816, 4076, 
92847, 92845, 92814, 4075, 4054
32076, 92043, 92033, 3671, 3661, 92044, 92034, 3672, 3662, 92846, 92816, 4076, 92847, 92849, 92819, 4078, 
92850, 92848, 92817, 4077, 4056
32077, 92044, 92034, 3672, 3662, 26267, 26266, 254, 253, 92849, 92819, 4078, 92850, 26340, 26337, 276, 
26339, 92851, 92820, 4079, 4058
32078, 25942, 25941, 208, 207, 92045, 92035, 3653, 3643, 26015, 26014, 230, 26016, 92853, 92823, 4039, 
92854, 92852, 92821, 4038, 4017
32079, 92045, 92035, 3653, 3643, 92046, 92036, 3654, 3644, 92853, 92823, 4039, 92854, 92856, 92826, 4041, 
92857, 92855, 92824, 4040, 4019
32080, 92046, 92036, 3654, 3644, 92047, 92037, 3655, 3645, 92856, 92826, 4041, 92857, 92859, 92829, 4043, 
92860, 92858, 92827, 4042, 4021
32081, 92047, 92037, 3655, 3645, 92048, 92038, 3656, 3646, 92859, 92829, 4043, 92860, 92862, 92832, 4045, 
92863, 92861, 92830, 4044, 4023
32082, 92048, 92038, 3656, 3646, 92049, 92039, 3657, 3647, 92862, 92832, 4045, 92863, 92865, 92835, 4047, 
92866, 92864, 92833, 4046, 4025
32083, 92049, 92039, 3657, 3647, 92050, 92040, 3658, 3648, 92865, 92835, 4047, 92866, 92868, 92838, 4049, 
92869, 92867, 92836, 4048, 4027
32084, 92050, 92040, 3658, 3648, 92051, 92041, 3659, 3649, 92868, 92838, 4049, 92869, 92871, 92841, 4051, 
92872, 92870, 92839, 4050, 4029
32085, 92051, 92041, 3659, 3649, 92052, 92042, 3660, 3650, 92871, 92841, 4051, 92872, 92874, 92844, 4053, 
92875, 92873, 92842, 4052, 4031
32086, 92052, 92042, 3660, 3650, 92053, 92043, 3661, 3651, 92874, 92844, 4053, 92875, 92877, 92847, 4055, 
92878, 92876, 92845, 4054, 4033
32087, 92053, 92043, 3661, 3651, 92054, 92044, 3662, 3652, 92877, 92847, 4055, 92878, 92880, 92850, 4057, 
92881, 92879, 92848, 4056, 4035
32088, 92054, 92044, 3662, 3652, 26268, 26267, 253, 252, 92880, 92850, 4057, 92881, 26342, 26339, 275, 
26341, 92882, 92851, 4058, 4037
32089, 25943, 25942, 207, 206, 92055, 92045, 3643, 3633, 26017, 26016, 229, 26018, 92884, 92854, 4018, 
92885, 92883, 92852, 4017, 3996
32090, 92055, 92045, 3643, 3633, 92056, 92046, 3644, 3634, 92884, 92854, 4018, 92885, 92887, 92857, 4020, 
92888, 92886, 92855, 4019, 3998
32091, 92056, 92046, 3644, 3634, 92057, 92047, 3645, 3635, 92887, 92857, 4020, 92888, 92890, 92860, 4022, 
92891, 92889, 92858, 4021, 4000
32092, 92057, 92047, 3645, 3635, 92058, 92048, 3646, 3636, 92890, 92860, 4022, 92891, 92893, 92863, 4024, 
92894, 92892, 92861, 4023, 4002
32093, 92058, 92048, 3646, 3636, 92059, 92049, 3647, 3637, 92893, 92863, 4024, 92894, 92896, 92866, 4026, 
92897, 92895, 92864, 4025, 4004
32094, 92059, 92049, 3647, 3637, 92060, 92050, 3648, 3638, 92896, 92866, 4026, 92897, 92899, 92869, 4028, 
92900, 92898, 92867, 4027, 4006
32095, 92060, 92050, 3648, 3638, 92061, 92051, 3649, 3639, 92899, 92869, 4028, 92900, 92902, 92872, 4030, 
92903, 92901, 92870, 4029, 4008
32096, 92061, 92051, 3649, 3639, 92062, 92052, 3650, 3640, 92902, 92872, 4030, 92903, 92905, 92875, 4032, 
92906, 92904, 92873, 4031, 4010
32097, 92062, 92052, 3650, 3640, 92063, 92053, 3651, 3641, 92905, 92875, 4032, 92906, 92908, 92878, 4034, 
92909, 92907, 92876, 4033, 4012
32098, 92063, 92053, 3651, 3641, 92064, 92054, 3652, 3642, 92908, 92878, 4034, 92909, 92911, 92881, 4036, 
92912, 92910, 92879, 4035, 4014
32099, 92064, 92054, 3652, 3642, 26269, 26268, 252, 251, 92911, 92881, 4036, 92912, 26344, 26341, 274, 
26343, 92913, 92882, 4037, 4016
32100, 25944, 25943, 206, 205, 92065, 92055, 3633, 3623, 26019, 26018, 228, 26020, 92915, 92885, 3997, 
92916, 92914, 92883, 3996, 3975
32101, 92065, 92055, 3633, 3623, 92066, 92056, 3634, 3624, 92915, 92885, 3997, 92916, 92918, 92888, 3999, 
92919, 92917, 92886, 3998, 3977
32102, 92066, 92056, 3634, 3624, 92067, 92057, 3635, 3625, 92918, 92888, 3999, 92919, 92921, 92891, 4001, 
92922, 92920, 92889, 4000, 3979
32103, 92067, 92057, 3635, 3625, 92068, 92058, 3636, 3626, 92921, 92891, 4001, 92922, 92924, 92894, 4003, 
92925, 92923, 92892, 4002, 3981
32104, 92068, 92058, 3636, 3626, 92069, 92059, 3637, 3627, 92924, 92894, 4003, 92925, 92927, 92897, 4005, 
92928, 92926, 92895, 4004, 3983
32105, 92069, 92059, 3637, 3627, 92070, 92060, 3638, 3628, 92927, 92897, 4005, 92928, 92930, 92900, 4007, 
92931, 92929, 92898, 4006, 3985
32106, 92070, 92060, 3638, 3628, 92071, 92061, 3639, 3629, 92930, 92900, 4007, 92931, 92933, 92903, 4009, 
92934, 92932, 92901, 4008, 3987
32107, 92071, 92061, 3639, 3629, 92072, 92062, 3640, 3630, 92933, 92903, 4009, 92934, 92936, 92906, 4011, 
92937, 92935, 92904, 4010, 3989
32108, 92072, 92062, 3640, 3630, 92073, 92063, 3641, 3631, 92936, 92906, 4011, 92937, 92939, 92909, 4013, 
92940, 92938, 92907, 4012, 3991
32109, 92073, 92063, 3641, 3631, 92074, 92064, 3642, 3632, 92939, 92909, 4013, 92940, 92942, 92912, 4015, 
92943, 92941, 92910, 4014, 3993
32110, 92074, 92064, 3642, 3632, 26270, 26269, 251, 250, 92942, 92912, 4015, 92943, 26346, 26343, 273, 
26345, 92944, 92913, 4016, 3995
32111, 25945, 25944, 205, 204, 92075, 92065, 3623, 3613, 26021, 26020, 227, 26022, 92946, 92916, 3976, 
92947, 92945, 92914, 3975, 3954
32112, 92075, 92065, 3623, 3613, 92076, 92066, 3624, 3614, 92946, 92916, 3976, 92947, 92949, 92919, 3978, 
92950, 92948, 92917, 3977, 3956
32113, 92076, 92066, 3624, 3614, 92077, 92067, 3625, 3615, 92949, 92919, 3978, 92950, 92952, 92922, 3980, 
92953, 92951, 92920, 3979, 3958
32114, 92077, 92067, 3625, 3615, 92078, 92068, 3626, 3616, 92952, 92922, 3980, 92953, 92955, 92925, 3982, 
92956, 92954, 92923, 3981, 3960
32115, 92078, 92068, 3626, 3616, 92079, 92069, 3627, 3617, 92955, 92925, 3982, 92956, 92958, 92928, 3984, 
92959, 92957, 92926, 3983, 3962
32116, 92079, 92069, 3627, 3617, 92080, 92070, 3628, 3618, 92958, 92928, 3984, 92959, 92961, 92931, 3986, 
92962, 92960, 92929, 3985, 3964
32117, 92080, 92070, 3628, 3618, 92081, 92071, 3629, 3619, 92961, 92931, 3986, 92962, 92964, 92934, 3988, 
92965, 92963, 92932, 3987, 3966
32118, 92081, 92071, 3629, 3619, 92082, 92072, 3630, 3620, 92964, 92934, 3988, 92965, 92967, 92937, 3990, 
92968, 92966, 92935, 3989, 3968
32119, 92082, 92072, 3630, 3620, 92083, 92073, 3631, 3621, 92967, 92937, 3990, 92968, 92970, 92940, 3992, 
92971, 92969, 92938, 3991, 3970
32120, 92083, 92073, 3631, 3621, 92084, 92074, 3632, 3622, 92970, 92940, 3992, 92971, 92973, 92943, 3994, 
92974, 92972, 92941, 3993, 3972
32121, 92084, 92074, 3632, 3622, 26271, 26270, 250, 249, 92973, 92943, 3994, 92974, 26348, 26345, 272, 
26347, 92975, 92944, 3995, 3974
32122, 25946, 25945, 204, 203, 92085, 92075, 3613, 3603, 26023, 26022, 226, 26024, 92977, 92947, 3955, 
92978, 92976, 92945, 3954, 3933
32123, 92085, 92075, 3613, 3603, 92086, 92076, 3614, 3604, 92977, 92947, 3955, 92978, 92980, 92950, 3957, 
92981, 92979, 92948, 3956, 3935
32124, 92086, 92076, 3614, 3604, 92087, 92077, 3615, 3605, 92980, 92950, 3957, 92981, 92983, 92953, 3959, 
92984, 92982, 92951, 3958, 3937
32125, 92087, 92077, 3615, 3605, 92088, 92078, 3616, 3606, 92983, 92953, 3959, 92984, 92986, 92956, 3961, 
92987, 92985, 92954, 3960, 3939
32126, 92088, 92078, 3616, 3606, 92089, 92079, 3617, 3607, 92986, 92956, 3961, 92987, 92989, 92959, 3963, 
92990, 92988, 92957, 3962, 3941
32127, 92089, 92079, 3617, 3607, 92090, 92080, 3618, 3608, 92989, 92959, 3963, 92990, 92992, 92962, 3965, 
92993, 92991, 92960, 3964, 3943
32128, 92090, 92080, 3618, 3608, 92091, 92081, 3619, 3609, 92992, 92962, 3965, 92993, 92995, 92965, 3967, 
92996, 92994, 92963, 3966, 3945
32129, 92091, 92081, 3619, 3609, 92092, 92082, 3620, 3610, 92995, 92965, 3967, 92996, 92998, 92968, 3969, 
92999, 92997, 92966, 3968, 3947
32130, 92092, 92082, 3620, 3610, 92093, 92083, 3621, 3611, 92998, 92968, 3969, 92999, 93001, 92971, 3971, 
93002, 93000, 92969, 3970, 3949
32131, 92093, 92083, 3621, 3611, 92094, 92084, 3622, 3612, 93001, 92971, 3971, 93002, 93004, 92974, 3973, 
93005, 93003, 92972, 3972, 3951
32132, 92094, 92084, 3622, 3612, 26272, 26271, 249, 248, 93004, 92974, 3973, 93005, 26350, 26347, 271, 
26349, 93006, 92975, 3974, 3953
32133, 25947, 25946, 203, 202, 92095, 92085, 3603, 3593, 26025, 26024, 225, 26026, 93008, 92978, 3934, 
93009, 93007, 92976, 3933, 3912
32134, 92095, 92085, 3603, 3593, 92096, 92086, 3604, 3594, 93008, 92978, 3934, 93009, 93011, 92981, 3936, 
93012, 93010, 92979, 3935, 3914
32135, 92096, 92086, 3604, 3594, 92097, 92087, 3605, 3595, 93011, 92981, 3936, 93012, 93014, 92984, 3938, 
93015, 93013, 92982, 3937, 3916
32136, 92097, 92087, 3605, 3595, 92098, 92088, 3606, 3596, 93014, 92984, 3938, 93015, 93017, 92987, 3940, 
93018, 93016, 92985, 3939, 3918
32137, 92098, 92088, 3606, 3596, 92099, 92089, 3607, 3597, 93017, 92987, 3940, 93018, 93020, 92990, 3942, 
93021, 93019, 92988, 3941, 3920
32138, 92099, 92089, 3607, 3597, 92100, 92090, 3608, 3598, 93020, 92990, 3942, 93021, 93023, 92993, 3944, 
93024, 93022, 92991, 3943, 3922
32139, 92100, 92090, 3608, 3598, 92101, 92091, 3609, 3599, 93023, 92993, 3944, 93024, 93026, 92996, 3946, 
93027, 93025, 92994, 3945, 3924
32140, 92101, 92091, 3609, 3599, 92102, 92092, 3610, 3600, 93026, 92996, 3946, 93027, 93029, 92999, 3948, 
93030, 93028, 92997, 3947, 3926
32141, 92102, 92092, 3610, 3600, 92103, 92093, 3611, 3601, 93029, 92999, 3948, 93030, 93032, 93002, 3950, 
93033, 93031, 93000, 3949, 3928
32142, 92103, 92093, 3611, 3601, 92104, 92094, 3612, 3602, 93032, 93002, 3950, 93033, 93035, 93005, 3952, 
93036, 93034, 93003, 3951, 3930
32143, 92104, 92094, 3612, 3602, 26273, 26272, 248, 247, 93035, 93005, 3952, 93036, 26352, 26349, 270, 
26351, 93037, 93006, 3953, 3932
32144, 25948, 25947, 202, 201, 92105, 92095, 3593, 3583, 26027, 26026, 224, 26028, 93039, 93009, 3913, 
93040, 93038, 93007, 3912, 3891
32145, 92105, 92095, 3593, 3583, 92106, 92096, 3594, 3584, 93039, 93009, 3913, 93040, 93042, 93012, 3915, 
93043, 93041, 93010, 3914, 3893
32146, 92106, 92096, 3594, 3584, 92107, 92097, 3595, 3585, 93042, 93012, 3915, 93043, 93045, 93015, 3917, 
93046, 93044, 93013, 3916, 3895
32147, 92107, 92097, 3595, 3585, 92108, 92098, 3596, 3586, 93045, 93015, 3917, 93046, 93048, 93018, 3919, 
93049, 93047, 93016, 3918, 3897
32148, 92108, 92098, 3596, 3586, 92109, 92099, 3597, 3587, 93048, 93018, 3919, 93049, 93051, 93021, 3921, 
93052, 93050, 93019, 3920, 3899
32149, 92109, 92099, 3597, 3587, 92110, 92100, 3598, 3588, 93051, 93021, 3921, 93052, 93054, 93024, 3923, 
93055, 93053, 93022, 3922, 3901
32150, 92110, 92100, 3598, 3588, 92111, 92101, 3599, 3589, 93054, 93024, 3923, 93055, 93057, 93027, 3925, 
93058, 93056, 93025, 3924, 3903
32151, 92111, 92101, 3599, 3589, 92112, 92102, 3600, 3590, 93057, 93027, 3925, 93058, 93060, 93030, 3927, 
93061, 93059, 93028, 3926, 3905
32152, 92112, 92102, 3600, 3590, 92113, 92103, 3601, 3591, 93060, 93030, 3927, 93061, 93063, 93033, 3929, 
93064, 93062, 93031, 3928, 3907
32153, 92113, 92103, 3601, 3591, 92114, 92104, 3602, 3592, 93063, 93033, 3929, 93064, 93066, 93036, 3931, 
93067, 93065, 93034, 3930, 3909
32154, 92114, 92104, 3602, 3592, 26274, 26273, 247, 246, 93066, 93036, 3931, 93067, 26354, 26351, 269, 
26353, 93068, 93037, 3932, 3911
32155, 25949, 25948, 201, 200, 92115, 92105, 3583, 3573, 26029, 26028, 223, 26030, 93070, 93040, 3892, 
93071, 93069, 93038, 3891, 3870
32156, 92115, 92105, 3583, 3573, 92116, 92106, 3584, 3574, 93070, 93040, 3892, 93071, 93073, 93043, 3894, 
93074, 93072, 93041, 3893, 3872
32157, 92116, 92106, 3584, 3574, 92117, 92107, 3585, 3575, 93073, 93043, 3894, 93074, 93076, 93046, 3896, 
93077, 93075, 93044, 3895, 3874
32158, 92117, 92107, 3585, 3575, 92118, 92108, 3586, 3576, 93076, 93046, 3896, 93077, 93079, 93049, 3898, 
93080, 93078, 93047, 3897, 3876
32159, 92118, 92108, 3586, 3576, 92119, 92109, 3587, 3577, 93079, 93049, 3898, 93080, 93082, 93052, 3900, 
93083, 93081, 93050, 3899, 3878
32160, 92119, 92109, 3587, 3577, 92120, 92110, 3588, 3578, 93082, 93052, 3900, 93083, 93085, 93055, 3902, 
93086, 93084, 93053, 3901, 3880
32161, 92120, 92110, 3588, 3578, 92121, 92111, 3589, 3579, 93085, 93055, 3902, 93086, 93088, 93058, 3904, 
93089, 93087, 93056, 3903, 3882
32162, 92121, 92111, 3589, 3579, 92122, 92112, 3590, 3580, 93088, 93058, 3904, 93089, 93091, 93061, 3906, 
93092, 93090, 93059, 3905, 3884
32163, 92122, 92112, 3590, 3580, 92123, 92113, 3591, 3581, 93091, 93061, 3906, 93092, 93094, 93064, 3908, 
93095, 93093, 93062, 3907, 3886
32164, 92123, 92113, 3591, 3581, 92124, 92114, 3592, 3582, 93094, 93064, 3908, 93095, 93097, 93067, 3910, 
93098, 93096, 93065, 3909, 3888
32165, 92124, 92114, 3592, 3582, 26275, 26274, 246, 245, 93097, 93067, 3910, 93098, 26356, 26353, 268, 
26355, 93099, 93068, 3911, 3890
32166, 25950, 25949, 200, 199, 92125, 92115, 3573, 3563, 26031, 26030, 222, 26032, 93101, 93071, 3871, 
93102, 93100, 93069, 3870, 3849
32167, 92125, 92115, 3573, 3563, 92126, 92116, 3574, 3564, 93101, 93071, 3871, 93102, 93104, 93074, 3873, 
93105, 93103, 93072, 3872, 3851
32168, 92126, 92116, 3574, 3564, 92127, 92117, 3575, 3565, 93104, 93074, 3873, 93105, 93107, 93077, 3875, 
93108, 93106, 93075, 3874, 3853
32169, 92127, 92117, 3575, 3565, 92128, 92118, 3576, 3566, 93107, 93077, 3875, 93108, 93110, 93080, 3877, 
93111, 93109, 93078, 3876, 3855
32170, 92128, 92118, 3576, 3566, 92129, 92119, 3577, 3567, 93110, 93080, 3877, 93111, 93113, 93083, 3879, 
93114, 93112, 93081, 3878, 3857
32171, 92129, 92119, 3577, 3567, 92130, 92120, 3578, 3568, 93113, 93083, 3879, 93114, 93116, 93086, 3881, 
93117, 93115, 93084, 3880, 3859
32172, 92130, 92120, 3578, 3568, 92131, 92121, 3579, 3569, 93116, 93086, 3881, 93117, 93119, 93089, 3883, 
93120, 93118, 93087, 3882, 3861
32173, 92131, 92121, 3579, 3569, 92132, 92122, 3580, 3570, 93119, 93089, 3883, 93120, 93122, 93092, 3885, 
93123, 93121, 93090, 3884, 3863
32174, 92132, 92122, 3580, 3570, 92133, 92123, 3581, 3571, 93122, 93092, 3885, 93123, 93125, 93095, 3887, 
93126, 93124, 93093, 3886, 3865
32175, 92133, 92123, 3581, 3571, 92134, 92124, 3582, 3572, 93125, 93095, 3887, 93126, 93128, 93098, 3889, 
93129, 93127, 93096, 3888, 3867
32176, 92134, 92124, 3582, 3572, 26276, 26275, 245, 244, 93128, 93098, 3889, 93129, 26358, 26355, 267, 
26357, 93130, 93099, 3890, 3869
32177, 25951, 25950, 199, 198, 92135, 92125, 3563, 3553, 26033, 26032, 221, 26034, 93132, 93102, 3850, 
93133, 93131, 93100, 3849, 3828
32178, 92135, 92125, 3563, 3553, 92136, 92126, 3564, 3554, 93132, 93102, 3850, 93133, 93135, 93105, 3852, 
93136, 93134, 93103, 3851, 3830
32179, 92136, 92126, 3564, 3554, 92137, 92127, 3565, 3555, 93135, 93105, 3852, 93136, 93138, 93108, 3854, 
93139, 93137, 93106, 3853, 3832
32180, 92137, 92127, 3565, 3555, 92138, 92128, 3566, 3556, 93138, 93108, 3854, 93139, 93141, 93111, 3856, 
93142, 93140, 93109, 3855, 3834
32181, 92138, 92128, 3566, 3556, 92139, 92129, 3567, 3557, 93141, 93111, 3856, 93142, 93144, 93114, 3858, 
93145, 93143, 93112, 3857, 3836
32182, 92139, 92129, 3567, 3557, 92140, 92130, 3568, 3558, 93144, 93114, 3858, 93145, 93147, 93117, 3860, 
93148, 93146, 93115, 3859, 3838
32183, 92140, 92130, 3568, 3558, 92141, 92131, 3569, 3559, 93147, 93117, 3860, 93148, 93150, 93120, 3862, 
93151, 93149, 93118, 3861, 3840
32184, 92141, 92131, 3569, 3559, 92142, 92132, 3570, 3560, 93150, 93120, 3862, 93151, 93153, 93123, 3864, 
93154, 93152, 93121, 3863, 3842
32185, 92142, 92132, 3570, 3560, 92143, 92133, 3571, 3561, 93153, 93123, 3864, 93154, 93156, 93126, 3866, 
93157, 93155, 93124, 3865, 3844
32186, 92143, 92133, 3571, 3561, 92144, 92134, 3572, 3562, 93156, 93126, 3866, 93157, 93159, 93129, 3868, 
93160, 93158, 93127, 3867, 3846
32187, 92144, 92134, 3572, 3562, 26277, 26276, 244, 243, 93159, 93129, 3868, 93160, 26360, 26357, 266, 
26359, 93161, 93130, 3869, 3848
32188, 25952, 25951, 198, 197, 92145, 92135, 3553, 3543, 26035, 26034, 220, 26036, 93163, 93133, 3829, 
93164, 93162, 93131, 3828, 3807
32189, 92145, 92135, 3553, 3543, 92146, 92136, 3554, 3544, 93163, 93133, 3829, 93164, 93166, 93136, 3831, 
93167, 93165, 93134, 3830, 3809
32190, 92146, 92136, 3554, 3544, 92147, 92137, 3555, 3545, 93166, 93136, 3831, 93167, 93169, 93139, 3833, 
93170, 93168, 93137, 3832, 3811
32191, 92147, 92137, 3555, 3545, 92148, 92138, 3556, 3546, 93169, 93139, 3833, 93170, 93172, 93142, 3835, 
93173, 93171, 93140, 3834, 3813
32192, 92148, 92138, 3556, 3546, 92149, 92139, 3557, 3547, 93172, 93142, 3835, 93173, 93175, 93145, 3837, 
93176, 93174, 93143, 3836, 3815
32193, 92149, 92139, 3557, 3547, 92150, 92140, 3558, 3548, 93175, 93145, 3837, 93176, 93178, 93148, 3839, 
93179, 93177, 93146, 3838, 3817
32194, 92150, 92140, 3558, 3548, 92151, 92141, 3559, 3549, 93178, 93148, 3839, 93179, 93181, 93151, 3841, 
93182, 93180, 93149, 3840, 3819
32195, 92151, 92141, 3559, 3549, 92152, 92142, 3560, 3550, 93181, 93151, 3841, 93182, 93184, 93154, 3843, 
93185, 93183, 93152, 3842, 3821
32196, 92152, 92142, 3560, 3550, 92153, 92143, 3561, 3551, 93184, 93154, 3843, 93185, 93187, 93157, 3845, 
93188, 93186, 93155, 3844, 3823
32197, 92153, 92143, 3561, 3551, 92154, 92144, 3562, 3552, 93187, 93157, 3845, 93188, 93190, 93160, 3847, 
93191, 93189, 93158, 3846, 3825
32198, 92154, 92144, 3562, 3552, 26278, 26277, 243, 242, 93190, 93160, 3847, 93191, 26362, 26359, 265, 
26361, 93192, 93161, 3848, 3827
32199, 25953, 25952, 197, 196, 92155, 92145, 3543, 3533, 26037, 26036, 219, 26038, 93194, 93164, 3808, 
93195, 93193, 93162, 3807, 3786
32200, 92155, 92145, 3543, 3533, 92156, 92146, 3544, 3534, 93194, 93164, 3808, 93195, 93197, 93167, 3810, 
93198, 93196, 93165, 3809, 3788
32201, 92156, 92146, 3544, 3534, 92157, 92147, 3545, 3535, 93197, 93167, 3810, 93198, 93200, 93170, 3812, 
93201, 93199, 93168, 3811, 3790
32202, 92157, 92147, 3545, 3535, 92158, 92148, 3546, 3536, 93200, 93170, 3812, 93201, 93203, 93173, 3814, 
93204, 93202, 93171, 3813, 3792
32203, 92158, 92148, 3546, 3536, 92159, 92149, 3547, 3537, 93203, 93173, 3814, 93204, 93206, 93176, 3816, 
93207, 93205, 93174, 3815, 3794
32204, 92159, 92149, 3547, 3537, 92160, 92150, 3548, 3538, 93206, 93176, 3816, 93207, 93209, 93179, 3818, 
93210, 93208, 93177, 3817, 3796
32205, 92160, 92150, 3548, 3538, 92161, 92151, 3549, 3539, 93209, 93179, 3818, 93210, 93212, 93182, 3820, 
93213, 93211, 93180, 3819, 3798
32206, 92161, 92151, 3549, 3539, 92162, 92152, 3550, 3540, 93212, 93182, 3820, 93213, 93215, 93185, 3822, 
93216, 93214, 93183, 3821, 3800
32207, 92162, 92152, 3550, 3540, 92163, 92153, 3551, 3541, 93215, 93185, 3822, 93216, 93218, 93188, 3824, 
93219, 93217, 93186, 3823, 3802
32208, 92163, 92153, 3551, 3541, 92164, 92154, 3552, 3542, 93218, 93188, 3824, 93219, 93221, 93191, 3826, 
93222, 93220, 93189, 3825, 3804
32209, 92164, 92154, 3552, 3542, 26279, 26278, 242, 241, 93221, 93191, 3826, 93222, 26364, 26361, 264, 
26363, 93223, 93192, 3827, 3806
32210, 25954, 25953, 196, 195, 92165, 92155, 3533, 3523, 26039, 26038, 218, 26040, 93225, 93195, 3787, 
93226, 93224, 93193, 3786, 3765
32211, 92165, 92155, 3533, 3523, 92166, 92156, 3534, 3524, 93225, 93195, 3787, 93226, 93228, 93198, 3789, 
93229, 93227, 93196, 3788, 3767
32212, 92166, 92156, 3534, 3524, 92167, 92157, 3535, 3525, 93228, 93198, 3789, 93229, 93231, 93201, 3791, 
93232, 93230, 93199, 3790, 3769
32213, 92167, 92157, 3535, 3525, 92168, 92158, 3536, 3526, 93231, 93201, 3791, 93232, 93234, 93204, 3793, 
93235, 93233, 93202, 3792, 3771
32214, 92168, 92158, 3536, 3526, 92169, 92159, 3537, 3527, 93234, 93204, 3793, 93235, 93237, 93207, 3795, 
93238, 93236, 93205, 3794, 3773
32215, 92169, 92159, 3537, 3527, 92170, 92160, 3538, 3528, 93237, 93207, 3795, 93238, 93240, 93210, 3797, 
93241, 93239, 93208, 3796, 3775
32216, 92170, 92160, 3538, 3528, 92171, 92161, 3539, 3529, 93240, 93210, 3797, 93241, 93243, 93213, 3799, 
93244, 93242, 93211, 3798, 3777
32217, 92171, 92161, 3539, 3529, 92172, 92162, 3540, 3530, 93243, 93213, 3799, 93244, 93246, 93216, 3801, 
93247, 93245, 93214, 3800, 3779
32218, 92172, 92162, 3540, 3530, 92173, 92163, 3541, 3531, 93246, 93216, 3801, 93247, 93249, 93219, 3803, 
93250, 93248, 93217, 3802, 3781
32219, 92173, 92163, 3541, 3531, 92174, 92164, 3542, 3532, 93249, 93219, 3803, 93250, 93252, 93222, 3805, 
93253, 93251, 93220, 3804, 3783
32220, 92174, 92164, 3542, 3532, 26280, 26279, 241, 240, 93252, 93222, 3805, 93253, 26366, 26363, 263, 
26365, 93254, 93223, 3806, 3785
32221, 25955, 25954, 195, 194, 92175, 92165, 3523, 3513, 26041, 26040, 217, 26042, 93256, 93226, 3766, 
93257, 93255, 93224, 3765, 3744
32222, 92175, 92165, 3523, 3513, 92176, 92166, 3524, 3514, 93256, 93226, 3766, 93257, 93259, 93229, 3768, 
93260, 93258, 93227, 3767, 3746
32223, 92176, 92166, 3524, 3514, 92177, 92167, 3525, 3515, 93259, 93229, 3768, 93260, 93262, 93232, 3770, 
93263, 93261, 93230, 3769, 3748
32224, 92177, 92167, 3525, 3515, 92178, 92168, 3526, 3516, 93262, 93232, 3770, 93263, 93265, 93235, 3772, 
93266, 93264, 93233, 3771, 3750
32225, 92178, 92168, 3526, 3516, 92179, 92169, 3527, 3517, 93265, 93235, 3772, 93266, 93268, 93238, 3774, 
93269, 93267, 93236, 3773, 3752
32226, 92179, 92169, 3527, 3517, 92180, 92170, 3528, 3518, 93268, 93238, 3774, 93269, 93271, 93241, 3776, 
93272, 93270, 93239, 3775, 3754
32227, 92180, 92170, 3528, 3518, 92181, 92171, 3529, 3519, 93271, 93241, 3776, 93272, 93274, 93244, 3778, 
93275, 93273, 93242, 3777, 3756
32228, 92181, 92171, 3529, 3519, 92182, 92172, 3530, 3520, 93274, 93244, 3778, 93275, 93277, 93247, 3780, 
93278, 93276, 93245, 3779, 3758
32229, 92182, 92172, 3530, 3520, 92183, 92173, 3531, 3521, 93277, 93247, 3780, 93278, 93280, 93250, 3782, 
93281, 93279, 93248, 3781, 3760
32230, 92183, 92173, 3531, 3521, 92184, 92174, 3532, 3522, 93280, 93250, 3782, 93281, 93283, 93253, 3784, 
93284, 93282, 93251, 3783, 3762
32231, 92184, 92174, 3532, 3522, 26281, 26280, 240, 239, 93283, 93253, 3784, 93284, 26368, 26365, 262, 
26367, 93285, 93254, 3785, 3764
32232, 25956, 25955, 194, 193, 92185, 92175, 3513, 3503, 26043, 26042, 216, 26044, 93287, 93257, 3745, 
93288, 93286, 93255, 3744, 3723
32233, 92185, 92175, 3513, 3503, 92186, 92176, 3514, 3504, 93287, 93257, 3745, 93288, 93290, 93260, 3747, 
93291, 93289, 93258, 3746, 3725
32234, 92186, 92176, 3514, 3504, 92187, 92177, 3515, 3505, 93290, 93260, 3747, 93291, 93293, 93263, 3749, 
93294, 93292, 93261, 3748, 3727
32235, 92187, 92177, 3515, 3505, 92188, 92178, 3516, 3506, 93293, 93263, 3749, 93294, 93296, 93266, 3751, 
93297, 93295, 93264, 3750, 3729
32236, 92188, 92178, 3516, 3506, 92189, 92179, 3517, 3507, 93296, 93266, 3751, 93297, 93299, 93269, 3753, 
93300, 93298, 93267, 3752, 3731
32237, 92189, 92179, 3517, 3507, 92190, 92180, 3518, 3508, 93299, 93269, 3753, 93300, 93302, 93272, 3755, 
93303, 93301, 93270, 3754, 3733
32238, 92190, 92180, 3518, 3508, 92191, 92181, 3519, 3509, 93302, 93272, 3755, 93303, 93305, 93275, 3757, 
93306, 93304, 93273, 3756, 3735
32239, 92191, 92181, 3519, 3509, 92192, 92182, 3520, 3510, 93305, 93275, 3757, 93306, 93308, 93278, 3759, 
93309, 93307, 93276, 3758, 3737
32240, 92192, 92182, 3520, 3510, 92193, 92183, 3521, 3511, 93308, 93278, 3759, 93309, 93311, 93281, 3761, 
93312, 93310, 93279, 3760, 3739
32241, 92193, 92183, 3521, 3511, 92194, 92184, 3522, 3512, 93311, 93281, 3761, 93312, 93314, 93284, 3763, 
93315, 93313, 93282, 3762, 3741
32242, 92194, 92184, 3522, 3512, 26282, 26281, 239, 238, 93314, 93284, 3763, 93315, 26370, 26367, 261, 
26369, 93316, 93285, 3764, 3743
32243, 2565, 25956, 193, 2, 26493, 92185, 3503, 89, 26045, 26044, 215, 2568, 93317, 93288, 3724, 
26532, 26534, 93286, 3723, 99
32244, 26493, 92185, 3503, 89, 26492, 92186, 3504, 90, 93317, 93288, 3724, 26532, 93318, 93291, 3726, 
26530, 26533, 93289, 3725, 100
32245, 26492, 92186, 3504, 90, 26491, 92187, 3505, 91, 93318, 93291, 3726, 26530, 93319, 93294, 3728, 
26528, 26531, 93292, 3727, 101
32246, 26491, 92187, 3505, 91, 26490, 92188, 3506, 92, 93319, 93294, 3728, 26528, 93320, 93297, 3730, 
26526, 26529, 93295, 3729, 102
32247, 26490, 92188, 3506, 92, 26489, 92189, 3507, 93, 93320, 93297, 3730, 26526, 93321, 93300, 3732, 
26524, 26527, 93298, 3731, 103
32248, 26489, 92189, 3507, 93, 26488, 92190, 3508, 94, 93321, 93300, 3732, 26524, 93322, 93303, 3734, 
26522, 26525, 93301, 3733, 104
32249, 26488, 92190, 3508, 94, 26487, 92191, 3509, 95, 93322, 93303, 3734, 26522, 93323, 93306, 3736, 
26520, 26523, 93304, 3735, 105
32250, 26487, 92191, 3509, 95, 26486, 92192, 3510, 96, 93323, 93306, 3736, 26520, 93324, 93309, 3738, 
26518, 26521, 93307, 3737, 106
32251, 26486, 92192, 3510, 96, 26485, 92193, 3511, 97, 93324, 93309, 3738, 26518, 93325, 93312, 3740, 
26516, 26519, 93310, 3739, 107
32252, 26485, 92193, 3511, 97, 26484, 92194, 3512, 98, 93325, 93312, 3740, 26516, 93326, 93315, 3742, 
26514, 26517, 93313, 3741, 108
32253, 26484, 92194, 3512, 98, 2645, 26282, 238, 1, 93326, 93315, 3742, 26514, 26371, 26369, 260, 
2648, 26515, 93316, 3743, 109
32254, 25957, 2559, 2558, 25935, 92195, 26177, 26167, 91975, 26046, 2562, 26001, 26047, 93328, 26228, 92636, 
93329, 93327, 26229, 26208, 92635
32255, 92195, 26177, 26167, 91975, 92196, 26176, 26166, 91976, 93328, 26228, 92636, 93329, 93331, 26226, 92639, 
93332, 93330, 26227, 26206, 92638
32256, 92196, 26176, 26166, 91976, 92197, 26175, 26165, 91977, 93331, 26226, 92639, 93332, 93334, 26224, 92642, 
93335, 93333, 26225, 26204, 92641
32257, 92197, 26175, 26165, 91977, 92198, 26174, 26164, 91978, 93334, 26224, 92642, 93335, 93337, 26222, 92645, 
93338, 93336, 26223, 26202, 92644
32258, 92198, 26174, 26164, 91978, 92199, 26173, 26163, 91979, 93337, 26222, 92645, 93338, 93340, 26220, 92648, 
93341, 93339, 26221, 26200, 92647
32259, 92199, 26173, 26163, 91979, 92200, 26172, 26162, 91980, 93340, 26220, 92648, 93341, 93343, 26218, 92651, 
93344, 93342, 26219, 26198, 92650
32260, 92200, 26172, 26162, 91980, 92201, 26171, 26161, 91981, 93343, 26218, 92651, 93344, 93346, 26216, 92654, 
93347, 93345, 26217, 26196, 92653
32261, 92201, 26171, 26161, 91981, 92202, 26170, 26160, 91982, 93346, 26216, 92654, 93347, 93349, 26214, 92657, 
93350, 93348, 26215, 26194, 92656
32262, 92202, 26170, 26160, 91982, 92203, 26169, 26159, 91983, 93349, 26214, 92657, 93350, 93352, 26212, 92660, 
93353, 93351, 26213, 26192, 92659
32263, 92203, 26169, 26159, 91983, 92204, 26168, 26158, 91984, 93352, 26212, 92660, 93353, 93355, 26210, 92663, 
93356, 93354, 26211, 26190, 92662
32264, 92204, 26168, 26158, 91984, 26283, 2618, 2617, 26261, 93355, 26210, 92663, 93356, 26373, 2621, 26328, 
26372, 93357, 26209, 26188, 92665
32265, 25958, 25957, 25935, 25936, 92205, 92195, 91975, 91985, 26048, 26047, 26003, 26049, 93359, 93329, 92667, 
93360, 93358, 93327, 92635, 92666
32266, 92205, 92195, 91975, 91985, 92206, 92196, 91976, 91986, 93359, 93329, 92667, 93360, 93362, 93332, 92670, 
93363, 93361, 93330, 92638, 92669
32267, 92206, 92196, 91976, 91986, 92207, 92197, 91977, 91987, 93362, 93332, 92670, 93363, 93365, 93335, 92673, 
93366, 93364, 93333, 92641, 92672
32268, 92207, 92197, 91977, 91987, 92208, 92198, 91978, 91988, 93365, 93335, 92673, 93366, 93368, 93338, 92676, 
93369, 93367, 93336, 92644, 92675
32269, 92208, 92198, 91978, 91988, 92209, 92199, 91979, 91989, 93368, 93338, 92676, 93369, 93371, 93341, 92679, 
93372, 93370, 93339, 92647, 92678
32270, 92209, 92199, 91979, 91989, 92210, 92200, 91980, 91990, 93371, 93341, 92679, 93372, 93374, 93344, 92682, 
93375, 93373, 93342, 92650, 92681
32271, 92210, 92200, 91980, 91990, 92211, 92201, 91981, 91991, 93374, 93344, 92682, 93375, 93377, 93347, 92685, 
93378, 93376, 93345, 92653, 92684
32272, 92211, 92201, 91981, 91991, 92212, 92202, 91982, 91992, 93377, 93347, 92685, 93378, 93380, 93350, 92688, 
93381, 93379, 93348, 92656, 92687
32273, 92212, 92202, 91982, 91992, 92213, 92203, 91983, 91993, 93380, 93350, 92688, 93381, 93383, 93353, 92691, 
93384, 93382, 93351, 92659, 92690
32274, 92213, 92203, 91983, 91993, 92214, 92204, 91984, 91994, 93383, 93353, 92691, 93384, 93386, 93356, 92694, 
93387, 93385, 93354, 92662, 92693
32275, 92214, 92204, 91984, 91994, 26284, 26283, 26261, 26262, 93386, 93356, 92694, 93387, 26375, 26372, 26330, 
26374, 93388, 93357, 92665, 92696
32276, 25959, 25958, 25936, 25937, 92215, 92205, 91985, 91995, 26050, 26049, 26005, 26051, 93390, 93360, 92698, 
93391, 93389, 93358, 92666, 92697
32277, 92215, 92205, 91985, 91995, 92216, 92206, 91986, 91996, 93390, 93360, 92698, 93391, 93393, 93363, 92701, 
93394, 93392, 93361, 92669, 92700
32278, 92216, 92206, 91986, 91996, 92217, 92207, 91987, 91997, 93393, 93363, 92701, 93394, 93396, 93366, 92704, 
93397, 93395, 93364, 92672, 92703
32279, 92217, 92207, 91987, 91997, 92218, 92208, 91988, 91998, 93396, 93366, 92704, 93397, 93399, 93369, 92707, 
93400, 93398, 93367, 92675, 92706
32280, 92218, 92208, 91988, 91998, 92219, 92209, 91989, 91999, 93399, 93369, 92707, 93400, 93402, 93372, 92710, 
93403, 93401, 93370, 92678, 92709
32281, 92219, 92209, 91989, 91999, 92220, 92210, 91990, 92000, 93402, 93372, 92710, 93403, 93405, 93375, 92713, 
93406, 93404, 93373, 92681, 92712
32282, 92220, 92210, 91990, 92000, 92221, 92211, 91991, 92001, 93405, 93375, 92713, 93406, 93408, 93378, 92716, 
93409, 93407, 93376, 92684, 92715
32283, 92221, 92211, 91991, 92001, 92222, 92212, 91992, 92002, 93408, 93378, 92716, 93409, 93411, 93381, 92719, 
93412, 93410, 93379, 92687, 92718
32284, 92222, 92212, 91992, 92002, 92223, 92213, 91993, 92003, 93411, 93381, 92719, 93412, 93414, 93384, 92722, 
93415, 93413, 93382, 92690, 92721
32285, 92223, 92213, 91993, 92003, 92224, 92214, 91994, 92004, 93414, 93384, 92722, 93415, 93417, 93387, 92725, 
93418, 93416, 93385, 92693, 92724
32286, 92224, 92214, 91994, 92004, 26285, 26284, 26262, 26263, 93417, 93387, 92725, 93418, 26377, 26374, 26332, 
26376, 93419, 93388, 92696, 92727
32287, 25960, 25959, 25937, 25938, 92225, 92215, 91995, 92005, 26052, 26051, 26007, 26053, 93421, 93391, 92729, 
93422, 93420, 93389, 92697, 92728
32288, 92225, 92215, 91995, 92005, 92226, 92216, 91996, 92006, 93421, 93391, 92729, 93422, 93424, 93394, 92732, 
93425, 93423, 93392, 92700, 92731
32289, 92226, 92216, 91996, 92006, 92227, 92217, 91997, 92007, 93424, 93394, 92732, 93425, 93427, 93397, 92735, 
93428, 93426, 93395, 92703, 92734
32290, 92227, 92217, 91997, 92007, 92228, 92218, 91998, 92008, 93427, 93397, 92735, 93428, 93430, 93400, 92738, 
93431, 93429, 93398, 92706, 92737
32291, 92228, 92218, 91998, 92008, 92229, 92219, 91999, 92009, 93430, 93400, 92738, 93431, 93433, 93403, 92741, 
93434, 93432, 93401, 92709, 92740
32292, 92229, 92219, 91999, 92009, 92230, 92220, 92000, 92010, 93433, 93403, 92741, 93434, 93436, 93406, 92744, 
93437, 93435, 93404, 92712, 92743
32293, 92230, 92220, 92000, 92010, 92231, 92221, 92001, 92011, 93436, 93406, 92744, 93437, 93439, 93409, 92747, 
93440, 93438, 93407, 92715, 92746
32294, 92231, 92221, 92001, 92011, 92232, 92222, 92002, 92012, 93439, 93409, 92747, 93440, 93442, 93412, 92750, 
93443, 93441, 93410, 92718, 92749
32295, 92232, 92222, 92002, 92012, 92233, 92223, 92003, 92013, 93442, 93412, 92750, 93443, 93445, 93415, 92753, 
93446, 93444, 93413, 92721, 92752
32296, 92233, 92223, 92003, 92013, 92234, 92224, 92004, 92014, 93445, 93415, 92753, 93446, 93448, 93418, 92756, 
93449, 93447, 93416, 92724, 92755
32297, 92234, 92224, 92004, 92014, 26286, 26285, 26263, 26264, 93448, 93418, 92756, 93449, 26379, 26376, 26334, 
26378, 93450, 93419, 92727, 92758
32298, 25961, 25960, 25938, 25939, 92235, 92225, 92005, 92015, 26054, 26053, 26009, 26055, 93452, 93422, 92760, 
93453, 93451, 93420, 92728, 92759
32299, 92235, 92225, 92005, 92015, 92236, 92226, 92006, 92016, 93452, 93422, 92760, 93453, 93455, 93425, 92763, 
93456, 93454, 93423, 92731, 92762
32300, 92236, 92226, 92006, 92016, 92237, 92227, 92007, 92017, 93455, 93425, 92763, 93456, 93458, 93428, 92766, 
93459, 93457, 93426, 92734, 92765
32301, 92237, 92227, 92007, 92017, 92238, 92228, 92008, 92018, 93458, 93428, 92766, 93459, 93461, 93431, 92769, 
93462, 93460, 93429, 92737, 92768
32302, 92238, 92228, 92008, 92018, 92239, 92229, 92009, 92019, 93461, 93431, 92769, 93462, 93464, 93434, 92772, 
93465, 93463, 93432, 92740, 92771
32303, 92239, 92229, 92009, 92019, 92240, 92230, 92010, 92020, 93464, 93434, 92772, 93465, 93467, 93437, 92775, 
93468, 93466, 93435, 92743, 92774
32304, 92240, 92230, 92010, 92020, 92241, 92231, 92011, 92021, 93467, 93437, 92775, 93468, 93470, 93440, 92778, 
93471, 93469, 93438, 92746, 92777
32305, 92241, 92231, 92011, 92021, 92242, 92232, 92012, 92022, 93470, 93440, 92778, 93471, 93473, 93443, 92781, 
93474, 93472, 93441, 92749, 92780
32306, 92242, 92232, 92012, 92022, 92243, 92233, 92013, 92023, 93473, 93443, 92781, 93474, 93476, 93446, 92784, 
93477, 93475, 93444, 92752, 92783
32307, 92243, 92233, 92013, 92023, 92244, 92234, 92014, 92024, 93476, 93446, 92784, 93477, 93479, 93449, 92787, 
93480, 93478, 93447, 92755, 92786
32308, 92244, 92234, 92014, 92024, 26287, 26286, 26264, 26265, 93479, 93449, 92787, 93480, 26381, 26378, 26336, 
26380, 93481, 93450, 92758, 92789
32309, 25962, 25961, 25939, 25940, 92245, 92235, 92015, 92025, 26056, 26055, 26011, 26057, 93483, 93453, 92791, 
93484, 93482, 93451, 92759, 92790
32310, 92245, 92235, 92015, 92025, 92246, 92236, 92016, 92026, 93483, 93453, 92791, 93484, 93486, 93456, 92794, 
93487, 93485, 93454, 92762, 92793
32311, 92246, 92236, 92016, 92026, 92247, 92237, 92017, 92027, 93486, 93456, 92794, 93487, 93489, 93459, 92797, 
93490, 93488, 93457, 92765, 92796
32312, 92247, 92237, 92017, 92027, 92248, 92238, 92018, 92028, 93489, 93459, 92797, 93490, 93492, 93462, 92800, 
93493, 93491, 93460, 92768, 92799
32313, 92248, 92238, 92018, 92028, 92249, 92239, 92019, 92029, 93492, 93462, 92800, 93493, 93495, 93465, 92803, 
93496, 93494, 93463, 92771, 92802
32314, 92249, 92239, 92019, 92029, 92250, 92240, 92020, 92030, 93495, 93465, 92803, 93496, 93498, 93468, 92806, 
93499, 93497, 93466, 92774, 92805
32315, 92250, 92240, 92020, 92030, 92251, 92241, 92021, 92031, 93498, 93468, 92806, 93499, 93501, 93471, 92809, 
93502, 93500, 93469, 92777, 92808
32316, 92251, 92241, 92021, 92031, 92252, 92242, 92022, 92032, 93501, 93471, 92809, 93502, 93504, 93474, 92812, 
93505, 93503, 93472, 92780, 92811
32317, 92252, 92242, 92022, 92032, 92253, 92243, 92023, 92033, 93504, 93474, 92812, 93505, 93507, 93477, 92815, 
93508, 93506, 93475, 92783, 92814
32318, 92253, 92243, 92023, 92033, 92254, 92244, 92024, 92034, 93507, 93477, 92815, 93508, 93510, 93480, 92818, 
93511, 93509, 93478, 92786, 92817
32319, 92254, 92244, 92024, 92034, 26288, 26287, 26265, 26266, 93510, 93480, 92818, 93511, 26383, 26380, 26338, 
26382, 93512, 93481, 92789, 92820
32320, 25963, 25962, 25940, 25941, 92255, 92245, 92025, 92035, 26058, 26057, 26013, 26059, 93514, 93484, 92822, 
93515, 93513, 93482, 92790, 92821
32321, 92255, 92245, 92025, 92035, 92256, 92246, 92026, 92036, 93514, 93484, 92822, 93515, 93517, 93487, 92825, 
93518, 93516, 93485, 92793, 92824
32322, 92256, 92246, 92026, 92036, 92257, 92247, 92027, 92037, 93517, 93487, 92825, 93518, 93520, 93490, 92828, 
93521, 93519, 93488, 92796, 92827
32323, 92257, 92247, 92027, 92037, 92258, 92248, 92028, 92038, 93520, 93490, 92828, 93521, 93523, 93493, 92831, 
93524, 93522, 93491, 92799, 92830
32324, 92258, 92248, 92028, 92038, 92259, 92249, 92029, 92039, 93523, 93493, 92831, 93524, 93526, 93496, 92834, 
93527, 93525, 93494, 92802, 92833
32325, 92259, 92249, 92029, 92039, 92260, 92250, 92030, 92040, 93526, 93496, 92834, 93527, 93529, 93499, 92837, 
93530, 93528, 93497, 92805, 92836
32326, 92260, 92250, 92030, 92040, 92261, 92251, 92031, 92041, 93529, 93499, 92837, 93530, 93532, 93502, 92840, 
93533, 93531, 93500, 92808, 92839
32327, 92261, 92251, 92031, 92041, 92262, 92252, 92032, 92042, 93532, 93502, 92840, 93533, 93535, 93505, 92843, 
93536, 93534, 93503, 92811, 92842
32328, 92262, 92252, 92032, 92042, 92263, 92253, 92033, 92043, 93535, 93505, 92843, 93536, 93538, 93508, 92846, 
93539, 93537, 93506, 92814, 92845
32329, 92263, 92253, 92033, 92043, 92264, 92254, 92034, 92044, 93538, 93508, 92846, 93539, 93541, 93511, 92849, 
93542, 93540, 93509, 92817, 92848
32330, 92264, 92254, 92034, 92044, 26289, 26288, 26266, 26267, 93541, 93511, 92849, 93542, 26385, 26382, 26340, 
26384, 93543, 93512, 92820, 92851
32331, 25964, 25963, 25941, 25942, 92265, 92255, 92035, 92045, 26060, 26059, 26015, 26061, 93545, 93515, 92853, 
93546, 93544, 93513, 92821, 92852
32332, 92265, 92255, 92035, 92045, 92266, 92256, 92036, 92046, 93545, 93515, 92853, 93546, 93548, 93518, 92856, 
93549, 93547, 93516, 92824, 92855
32333, 92266, 92256, 92036, 92046, 92267, 92257, 92037, 92047, 93548, 93518, 92856, 93549, 93551, 93521, 92859, 
93552, 93550, 93519, 92827, 92858
32334, 92267, 92257, 92037, 92047, 92268, 92258, 92038, 92048, 93551, 93521, 92859, 93552, 93554, 93524, 92862, 
93555, 93553, 93522, 92830, 92861
32335, 92268, 92258, 92038, 92048, 92269, 92259, 92039, 92049, 93554, 93524, 92862, 93555, 93557, 93527, 92865, 
93558, 93556, 93525, 92833, 92864
32336, 92269, 92259, 92039, 92049, 92270, 92260, 92040, 92050, 93557, 93527, 92865, 93558, 93560, 93530, 92868, 
93561, 93559, 93528, 92836, 92867
32337, 92270, 92260, 92040, 92050, 92271, 92261, 92041, 92051, 93560, 93530, 92868, 93561, 93563, 93533, 92871, 
93564, 93562, 93531, 92839, 92870
32338, 92271, 92261, 92041, 92051, 92272, 92262, 92042, 92052, 93563, 93533, 92871, 93564, 93566, 93536, 92874, 
93567, 93565, 93534, 92842, 92873
32339, 92272, 92262, 92042, 92052, 92273, 92263, 92043, 92053, 93566, 93536, 92874, 93567, 93569, 93539, 92877, 
93570, 93568, 93537, 92845, 92876
32340, 92273, 92263, 92043, 92053, 92274, 92264, 92044, 92054, 93569, 93539, 92877, 93570, 93572, 93542, 92880, 
93573, 93571, 93540, 92848, 92879
32341, 92274, 92264, 92044, 92054, 26290, 26289, 26267, 26268, 93572, 93542, 92880, 93573, 26387, 26384, 26342, 
26386, 93574, 93543, 92851, 92882
32342, 25965, 25964, 25942, 25943, 92275, 92265, 92045, 92055, 26062, 26061, 26017, 26063, 93576, 93546, 92884, 
93577, 93575, 93544, 92852, 92883
32343, 92275, 92265, 92045, 92055, 92276, 92266, 92046, 92056, 93576, 93546, 92884, 93577, 93579, 93549, 92887, 
93580, 93578, 93547, 92855, 92886
32344, 92276, 92266, 92046, 92056, 92277, 92267, 92047, 92057, 93579, 93549, 92887, 93580, 93582, 93552, 92890, 
93583, 93581, 93550, 92858, 92889
32345, 92277, 92267, 92047, 92057, 92278, 92268, 92048, 92058, 93582, 93552, 92890, 93583, 93585, 93555, 92893, 
93586, 93584, 93553, 92861, 92892
32346, 92278, 92268, 92048, 92058, 92279, 92269, 92049, 92059, 93585, 93555, 92893, 93586, 93588, 93558, 92896, 
93589, 93587, 93556, 92864, 92895
32347, 92279, 92269, 92049, 92059, 92280, 92270, 92050, 92060, 93588, 93558, 92896, 93589, 93591, 93561, 92899, 
93592, 93590, 93559, 92867, 92898
32348, 92280, 92270, 92050, 92060, 92281, 92271, 92051, 92061, 93591, 93561, 92899, 93592, 93594, 93564, 92902, 
93595, 93593, 93562, 92870, 92901
32349, 92281, 92271, 92051, 92061, 92282, 92272, 92052, 92062, 93594, 93564, 92902, 93595, 93597, 93567, 92905, 
93598, 93596, 93565, 92873, 92904
32350, 92282, 92272, 92052, 92062, 92283, 92273, 92053, 92063, 93597, 93567, 92905, 93598, 93600, 93570, 92908, 
93601, 93599, 93568, 92876, 92907
32351, 92283, 92273, 92053, 92063, 92284, 92274, 92054, 92064, 93600, 93570, 92908, 93601, 93603, 93573, 92911, 
93604, 93602, 93571, 92879, 92910
32352, 92284, 92274, 92054, 92064, 26291, 26290, 26268, 26269, 93603, 93573, 92911, 93604, 26389, 26386, 26344, 
26388, 93605, 93574, 92882, 92913
32353, 25966, 25965, 25943, 25944, 92285, 92275, 92055, 92065, 26064, 26063, 26019, 26065, 93607, 93577, 92915, 
93608, 93606, 93575, 92883, 92914
32354, 92285, 92275, 92055, 92065, 92286, 92276, 92056, 92066, 93607, 93577, 92915, 93608, 93610, 93580, 92918, 
93611, 93609, 93578, 92886, 92917
32355, 92286, 92276, 92056, 92066, 92287, 92277, 92057, 92067, 93610, 93580, 92918, 93611, 93613, 93583, 92921, 
93614, 93612, 93581, 92889, 92920
32356, 92287, 92277, 92057, 92067, 92288, 92278, 92058, 92068, 93613, 93583, 92921, 93614, 93616, 93586, 92924, 
93617, 93615, 93584, 92892, 92923
32357, 92288, 92278, 92058, 92068, 92289, 92279, 92059, 92069, 93616, 93586, 92924, 93617, 93619, 93589, 92927, 
93620, 93618, 93587, 92895, 92926
32358, 92289, 92279, 92059, 92069, 92290, 92280, 92060, 92070, 93619, 93589, 92927, 93620, 93622, 93592, 92930, 
93623, 93621, 93590, 92898, 92929
32359, 92290, 92280, 92060, 92070, 92291, 92281, 92061, 92071, 93622, 93592, 92930, 93623, 93625, 93595, 92933, 
93626, 93624, 93593, 92901, 92932
32360, 92291, 92281, 92061, 92071, 92292, 92282, 92062, 92072, 93625, 93595, 92933, 93626, 93628, 93598, 92936, 
93629, 93627, 93596, 92904, 92935
32361, 92292, 92282, 92062, 92072, 92293, 92283, 92063, 92073, 93628, 93598, 92936, 93629, 93631, 93601, 92939, 
93632, 93630, 93599, 92907, 92938
32362, 92293, 92283, 92063, 92073, 92294, 92284, 92064, 92074, 93631, 93601, 92939, 93632, 93634, 93604, 92942, 
93635, 93633, 93602, 92910, 92941
32363, 92294, 92284, 92064, 92074, 26292, 26291, 26269, 26270, 93634, 93604, 92942, 93635, 26391, 26388, 26346, 
26390, 93636, 93605, 92913, 92944
32364, 25967, 25966, 25944, 25945, 92295, 92285, 92065, 92075, 26066, 26065, 26021, 26067, 93638, 93608, 92946, 
93639, 93637, 93606, 92914, 92945
32365, 92295, 92285, 92065, 92075, 92296, 92286, 92066, 92076, 93638, 93608, 92946, 93639, 93641, 93611, 92949, 
93642, 93640, 93609, 92917, 92948
32366, 92296, 92286, 92066, 92076, 92297, 92287, 92067, 92077, 93641, 93611, 92949, 93642, 93644, 93614, 92952, 
93645, 93643, 93612, 92920, 92951
32367, 92297, 92287, 92067, 92077, 92298, 92288, 92068, 92078, 93644, 93614, 92952, 93645, 93647, 93617, 92955, 
93648, 93646, 93615, 92923, 92954
32368, 92298, 92288, 92068, 92078, 92299, 92289, 92069, 92079, 93647, 93617, 92955, 93648, 93650, 93620, 92958, 
93651, 93649, 93618, 92926, 92957
32369, 92299, 92289, 92069, 92079, 92300, 92290, 92070, 92080, 93650, 93620, 92958, 93651, 93653, 93623, 92961, 
93654, 93652, 93621, 92929, 92960
32370, 92300, 92290, 92070, 92080, 92301, 92291, 92071, 92081, 93653, 93623, 92961, 93654, 93656, 93626, 92964, 
93657, 93655, 93624, 92932, 92963
32371, 92301, 92291, 92071, 92081, 92302, 92292, 92072, 92082, 93656, 93626, 92964, 93657, 93659, 93629, 92967, 
93660, 93658, 93627, 92935, 92966
32372, 92302, 92292, 92072, 92082, 92303, 92293, 92073, 92083, 93659, 93629, 92967, 93660, 93662, 93632, 92970, 
93663, 93661, 93630, 92938, 92969
32373, 92303, 92293, 92073, 92083, 92304, 92294, 92074, 92084, 93662, 93632, 92970, 93663, 93665, 93635, 92973, 
93666, 93664, 93633, 92941, 92972
32374, 92304, 92294, 92074, 92084, 26293, 26292, 26270, 26271, 93665, 93635, 92973, 93666, 26393, 26390, 26348, 
26392, 93667, 93636, 92944, 92975
32375, 25968, 25967, 25945, 25946, 92305, 92295, 92075, 92085, 26068, 26067, 26023, 26069, 93669, 93639, 92977, 
93670, 93668, 93637, 92945, 92976
32376, 92305, 92295, 92075, 92085, 92306, 92296, 92076, 92086, 93669, 93639, 92977, 93670, 93672, 93642, 92980, 
93673, 93671, 93640, 92948, 92979
32377, 92306, 92296, 92076, 92086, 92307, 92297, 92077, 92087, 93672, 93642, 92980, 93673, 93675, 93645, 92983, 
93676, 93674, 93643, 92951, 92982
32378, 92307, 92297, 92077, 92087, 92308, 92298, 92078, 92088, 93675, 93645, 92983, 93676, 93678, 93648, 92986, 
93679, 93677, 93646, 92954, 92985
32379, 92308, 92298, 92078, 92088, 92309, 92299, 92079, 92089, 93678, 93648, 92986, 93679, 93681, 93651, 92989, 
93682, 93680, 93649, 92957, 92988
32380, 92309, 92299, 92079, 92089, 92310, 92300, 92080, 92090, 93681, 93651, 92989, 93682, 93684, 93654, 92992, 
93685, 93683, 93652, 92960, 92991
32381, 92310, 92300, 92080, 92090, 92311, 92301, 92081, 92091, 93684, 93654, 92992, 93685, 93687, 93657, 92995, 
93688, 93686, 93655, 92963, 92994
32382, 92311, 92301, 92081, 92091, 92312, 92302, 92082, 92092, 93687, 93657, 92995, 93688, 93690, 93660, 92998, 
93691, 93689, 93658, 92966, 92997
32383, 92312, 92302, 92082, 92092, 92313, 92303, 92083, 92093, 93690, 93660, 92998, 93691, 93693, 93663, 93001, 
93694, 93692, 93661, 92969, 93000
32384, 92313, 92303, 92083, 92093, 92314, 92304, 92084, 92094, 93693, 93663, 93001, 93694, 93696, 93666, 93004, 
93697, 93695, 93664, 92972, 93003
32385, 92314, 92304, 92084, 92094, 26294, 26293, 26271, 26272, 93696, 93666, 93004, 93697, 26395, 26392, 26350, 
26394, 93698, 93667, 92975, 93006
32386, 25969, 25968, 25946, 25947, 92315, 92305, 92085, 92095, 26070, 26069, 26025, 26071, 93700, 93670, 93008, 
93701, 93699, 93668, 92976, 93007
32387, 92315, 92305, 92085, 92095, 92316, 92306, 92086, 92096, 93700, 93670, 93008, 93701, 93703, 93673, 93011, 
93704, 93702, 93671, 92979, 93010
32388, 92316, 92306, 92086, 92096, 92317, 92307, 92087, 92097, 93703, 93673, 93011, 93704, 93706, 93676, 93014, 
93707, 93705, 93674, 92982, 93013
32389, 92317, 92307, 92087, 92097, 92318, 92308, 92088, 92098, 93706, 93676, 93014, 93707, 93709, 93679, 93017, 
93710, 93708, 93677, 92985, 93016
32390, 92318, 92308, 92088, 92098, 92319, 92309, 92089, 92099, 93709, 93679, 93017, 93710, 93712, 93682, 93020, 
93713, 93711, 93680, 92988, 93019
32391, 92319, 92309, 92089, 92099, 92320, 92310, 92090, 92100, 93712, 93682, 93020, 93713, 93715, 93685, 93023, 
93716, 93714, 93683, 92991, 93022
32392, 92320, 92310, 92090, 92100, 92321, 92311, 92091, 92101, 93715, 93685, 93023, 93716, 93718, 93688, 93026, 
93719, 93717, 93686, 92994, 93025
32393, 92321, 92311, 92091, 92101, 92322, 92312, 92092, 92102, 93718, 93688, 93026, 93719, 93721, 93691, 93029, 
93722, 93720, 93689, 92997, 93028
32394, 92322, 92312, 92092, 92102, 92323, 92313, 92093, 92103, 93721, 93691, 93029, 93722, 93724, 93694, 93032, 
93725, 93723, 93692, 93000, 93031
32395, 92323, 92313, 92093, 92103, 92324, 92314, 92094, 92104, 93724, 93694, 93032, 93725, 93727, 93697, 93035, 
93728, 93726, 93695, 93003, 93034
32396, 92324, 92314, 92094, 92104, 26295, 26294, 26272, 26273, 93727, 93697, 93035, 93728, 26397, 26394, 26352, 
26396, 93729, 93698, 93006, 93037
32397, 25970, 25969, 25947, 25948, 92325, 92315, 92095, 92105, 26072, 26071, 26027, 26073, 93731, 93701, 93039, 
93732, 93730, 93699, 93007, 93038
32398, 92325, 92315, 92095, 92105, 92326, 92316, 92096, 92106, 93731, 93701, 93039, 93732, 93734, 93704, 93042, 
93735, 93733, 93702, 93010, 93041
32399, 92326, 92316, 92096, 92106, 92327, 92317, 92097, 92107, 93734, 93704, 93042, 93735, 93737, 93707, 93045, 
93738, 93736, 93705, 93013, 93044
32400, 92327, 92317, 92097, 92107, 92328, 92318, 92098, 92108, 93737, 93707, 93045, 93738, 93740, 93710, 93048, 
93741, 93739, 93708, 93016, 93047
32401, 92328, 92318, 92098, 92108, 92329, 92319, 92099, 92109, 93740, 93710, 93048, 93741, 93743, 93713, 93051, 
93744, 93742, 93711, 93019, 93050
32402, 92329, 92319, 92099, 92109, 92330, 92320, 92100, 92110, 93743, 93713, 93051, 93744, 93746, 93716, 93054, 
93747, 93745, 93714, 93022, 93053
32403, 92330, 92320, 92100, 92110, 92331, 92321, 92101, 92111, 93746, 93716, 93054, 93747, 93749, 93719, 93057, 
93750, 93748, 93717, 93025, 93056
32404, 92331, 92321, 92101, 92111, 92332, 92322, 92102, 92112, 93749, 93719, 93057, 93750, 93752, 93722, 93060, 
93753, 93751, 93720, 93028, 93059
32405, 92332, 92322, 92102, 92112, 92333, 92323, 92103, 92113, 93752, 93722, 93060, 93753, 93755, 93725, 93063, 
93756, 93754, 93723, 93031, 93062
32406, 92333, 92323, 92103, 92113, 92334, 92324, 92104, 92114, 93755, 93725, 93063, 93756, 93758, 93728, 93066, 
93759, 93757, 93726, 93034, 93065
32407, 92334, 92324, 92104, 92114, 26296, 26295, 26273, 26274, 93758, 93728, 93066, 93759, 26399, 26396, 26354, 
26398, 93760, 93729, 93037, 93068
32408, 25971, 25970, 25948, 25949, 92335, 92325, 92105, 92115, 26074, 26073, 26029, 26075, 93762, 93732, 93070, 
93763, 93761, 93730, 93038, 93069
32409, 92335, 92325, 92105, 92115, 92336, 92326, 92106, 92116, 93762, 93732, 93070, 93763, 93765, 93735, 93073, 
93766, 93764, 93733, 93041, 93072
32410, 92336, 92326, 92106, 92116, 92337, 92327, 92107, 92117, 93765, 93735, 93073, 93766, 93768, 93738, 93076, 
93769, 93767, 93736, 93044, 93075
32411, 92337, 92327, 92107, 92117, 92338, 92328, 92108, 92118, 93768, 93738, 93076, 93769, 93771, 93741, 93079, 
93772, 93770, 93739, 93047, 93078
32412, 92338, 92328, 92108, 92118, 92339, 92329, 92109, 92119, 93771, 93741, 93079, 93772, 93774, 93744, 93082, 
93775, 93773, 93742, 93050, 93081
32413, 92339, 92329, 92109, 92119, 92340, 92330, 92110, 92120, 93774, 93744, 93082, 93775, 93777, 93747, 93085, 
93778, 93776, 93745, 93053, 93084
32414, 92340, 92330, 92110, 92120, 92341, 92331, 92111, 92121, 93777, 93747, 93085, 93778, 93780, 93750, 93088, 
93781, 93779, 93748, 93056, 93087
32415, 92341, 92331, 92111, 92121, 92342, 92332, 92112, 92122, 93780, 93750, 93088, 93781, 93783, 93753, 93091, 
93784, 93782, 93751, 93059, 93090
32416, 92342, 92332, 92112, 92122, 92343, 92333, 92113, 92123, 93783, 93753, 93091, 93784, 93786, 93756, 93094, 
93787, 93785, 93754, 93062, 93093
32417, 92343, 92333, 92113, 92123, 92344, 92334, 92114, 92124, 93786, 93756, 93094, 93787, 93789, 93759, 93097, 
93790, 93788, 93757, 93065, 93096
32418, 92344, 92334, 92114, 92124, 26297, 26296, 26274, 26275, 93789, 93759, 93097, 93790, 26401, 26398, 26356, 
26400, 93791, 93760, 93068, 93099
32419, 25972, 25971, 25949, 25950, 92345, 92335, 92115, 92125, 26076, 26075, 26031, 26077, 93793, 93763, 93101, 
93794, 93792, 93761, 93069, 93100
32420, 92345, 92335, 92115, 92125, 92346, 92336, 92116, 92126, 93793, 93763, 93101, 93794, 93796, 93766, 93104, 
93797, 93795, 93764, 93072, 93103
32421, 92346, 92336, 92116, 92126, 92347, 92337, 92117, 92127, 93796, 93766, 93104, 93797, 93799, 93769, 93107, 
93800, 93798, 93767, 93075, 93106
32422, 92347, 92337, 92117, 92127, 92348, 92338, 92118, 92128, 93799, 93769, 93107, 93800, 93802, 93772, 93110, 
93803, 93801, 93770, 93078, 93109
32423, 92348, 92338, 92118, 92128, 92349, 92339, 92119, 92129, 93802, 93772, 93110, 93803, 93805, 93775, 93113, 
93806, 93804, 93773, 93081, 93112
32424, 92349, 92339, 92119, 92129, 92350, 92340, 92120, 92130, 93805, 93775, 93113, 93806, 93808, 93778, 93116, 
93809, 93807, 93776, 93084, 93115
32425, 92350, 92340, 92120, 92130, 92351, 92341, 92121, 92131, 93808, 93778, 93116, 93809, 93811, 93781, 93119, 
93812, 93810, 93779, 93087, 93118
32426, 92351, 92341, 92121, 92131, 92352, 92342, 92122, 92132, 93811, 93781, 93119, 93812, 93814, 93784, 93122, 
93815, 93813, 93782, 93090, 93121
32427, 92352, 92342, 92122, 92132, 92353, 92343, 92123, 92133, 93814, 93784, 93122, 93815, 93817, 93787, 93125, 
93818, 93816, 93785, 93093, 93124
32428, 92353, 92343, 92123, 92133, 92354, 92344, 92124, 92134, 93817, 93787, 93125, 93818, 93820, 93790, 93128, 
93821, 93819, 93788, 93096, 93127
32429, 92354, 92344, 92124, 92134, 26298, 26297, 26275, 26276, 93820, 93790, 93128, 93821, 26403, 26400, 26358, 
26402, 93822, 93791, 93099, 93130
32430, 25973, 25972, 25950, 25951, 92355, 92345, 92125, 92135, 26078, 26077, 26033, 26079, 93824, 93794, 93132, 
93825, 93823, 93792, 93100, 93131
32431, 92355, 92345, 92125, 92135, 92356, 92346, 92126, 92136, 93824, 93794, 93132, 93825, 93827, 93797, 93135, 
93828, 93826, 93795, 93103, 93134
32432, 92356, 92346, 92126, 92136, 92357, 92347, 92127, 92137, 93827, 93797, 93135, 93828, 93830, 93800, 93138, 
93831, 93829, 93798, 93106, 93137
32433, 92357, 92347, 92127, 92137, 92358, 92348, 92128, 92138, 93830, 93800, 93138, 93831, 93833, 93803, 93141, 
93834, 93832, 93801, 93109, 93140
32434, 92358, 92348, 92128, 92138, 92359, 92349, 92129, 92139, 93833, 93803, 93141, 93834, 93836, 93806, 93144, 
93837, 93835, 93804, 93112, 93143
32435, 92359, 92349, 92129, 92139, 92360, 92350, 92130, 92140, 93836, 93806, 93144, 93837, 93839, 93809, 93147, 
93840, 93838, 93807, 93115, 93146
32436, 92360, 92350, 92130, 92140, 92361, 92351, 92131, 92141, 93839, 93809, 93147, 93840, 93842, 93812, 93150, 
93843, 93841, 93810, 93118, 93149
32437, 92361, 92351, 92131, 92141, 92362, 92352, 92132, 92142, 93842, 93812, 93150, 93843, 93845, 93815, 93153, 
93846, 93844, 93813, 93121, 93152
32438, 92362, 92352, 92132, 92142, 92363, 92353, 92133, 92143, 93845, 93815, 93153, 93846, 93848, 93818, 93156, 
93849, 93847, 93816, 93124, 93155
32439, 92363, 92353, 92133, 92143, 92364, 92354, 92134, 92144, 93848, 93818, 93156, 93849, 93851, 93821, 93159, 
93852, 93850, 93819, 93127, 93158
32440, 92364, 92354, 92134, 92144, 26299, 26298, 26276, 26277, 93851, 93821, 93159, 93852, 26405, 26402, 26360, 
26404, 93853, 93822, 93130, 93161
32441, 25974, 25973, 25951, 25952, 92365, 92355, 92135, 92145, 26080, 26079, 26035, 26081, 93855, 93825, 93163, 
93856, 93854, 93823, 93131, 93162
32442, 92365, 92355, 92135, 92145, 92366, 92356, 92136, 92146, 93855, 93825, 93163, 93856, 93858, 93828, 93166, 
93859, 93857, 93826, 93134, 93165
32443, 92366, 92356, 92136, 92146, 92367, 92357, 92137, 92147, 93858, 93828, 93166, 93859, 93861, 93831, 93169, 
93862, 93860, 93829, 93137, 93168
32444, 92367, 92357, 92137, 92147, 92368, 92358, 92138, 92148, 93861, 93831, 93169, 93862, 93864, 93834, 93172, 
93865, 93863, 93832, 93140, 93171
32445, 92368, 92358, 92138, 92148, 92369, 92359, 92139, 92149, 93864, 93834, 93172, 93865, 93867, 93837, 93175, 
93868, 93866, 93835, 93143, 93174
32446, 92369, 92359, 92139, 92149, 92370, 92360, 92140, 92150, 93867, 93837, 93175, 93868, 93870, 93840, 93178, 
93871, 93869, 93838, 93146, 93177
32447, 92370, 92360, 92140, 92150, 92371, 92361, 92141, 92151, 93870, 93840, 93178, 93871, 93873, 93843, 93181, 
93874, 93872, 93841, 93149, 93180
32448, 92371, 92361, 92141, 92151, 92372, 92362, 92142, 92152, 93873, 93843, 93181, 93874, 93876, 93846, 93184, 
93877, 93875, 93844, 93152, 93183
32449, 92372, 92362, 92142, 92152, 92373, 92363, 92143, 92153, 93876, 93846, 93184, 93877, 93879, 93849, 93187, 
93880, 93878, 93847, 93155, 93186
32450, 92373, 92363, 92143, 92153, 92374, 92364, 92144, 92154, 93879, 93849, 93187, 93880, 93882, 93852, 93190, 
93883, 93881, 93850, 93158, 93189
32451, 92374, 92364, 92144, 92154, 26300, 26299, 26277, 26278, 93882, 93852, 93190, 93883, 26407, 26404, 26362, 
26406, 93884, 93853, 93161, 93192
32452, 25975, 25974, 25952, 25953, 92375, 92365, 92145, 92155, 26082, 26081, 26037, 26083, 93886, 93856, 93194, 
93887, 93885, 93854, 93162, 93193
32453, 92375, 92365, 92145, 92155, 92376, 92366, 92146, 92156, 93886, 93856, 93194, 93887, 93889, 93859, 93197, 
93890, 93888, 93857, 93165, 93196
32454, 92376, 92366, 92146, 92156, 92377, 92367, 92147, 92157, 93889, 93859, 93197, 93890, 93892, 93862, 93200, 
93893, 93891, 93860, 93168, 93199
32455, 92377, 92367, 92147, 92157, 92378, 92368, 92148, 92158, 93892, 93862, 93200, 93893, 93895, 93865, 93203, 
93896, 93894, 93863, 93171, 93202
32456, 92378, 92368, 92148, 92158, 92379, 92369, 92149, 92159, 93895, 93865, 93203, 93896, 93898, 93868, 93206, 
93899, 93897, 93866, 93174, 93205
32457, 92379, 92369, 92149, 92159, 92380, 92370, 92150, 92160, 93898, 93868, 93206, 93899, 93901, 93871, 93209, 
93902, 93900, 93869, 93177, 93208
32458, 92380, 92370, 92150, 92160, 92381, 92371, 92151, 92161, 93901, 93871, 93209, 93902, 93904, 93874, 93212, 
93905, 93903, 93872, 93180, 93211
32459, 92381, 92371, 92151, 92161, 92382, 92372, 92152, 92162, 93904, 93874, 93212, 93905, 93907, 93877, 93215, 
93908, 93906, 93875, 93183, 93214
32460, 92382, 92372, 92152, 92162, 92383, 92373, 92153, 92163, 93907, 93877, 93215, 93908, 93910, 93880, 93218, 
93911, 93909, 93878, 93186, 93217
32461, 92383, 92373, 92153, 92163, 92384, 92374, 92154, 92164, 93910, 93880, 93218, 93911, 93913, 93883, 93221, 
93914, 93912, 93881, 93189, 93220
32462, 92384, 92374, 92154, 92164, 26301, 26300, 26278, 26279, 93913, 93883, 93221, 93914, 26409, 26406, 26364, 
26408, 93915, 93884, 93192, 93223
32463, 25976, 25975, 25953, 25954, 92385, 92375, 92155, 92165, 26084, 26083, 26039, 26085, 93917, 93887, 93225, 
93918, 93916, 93885, 93193, 93224
32464, 92385, 92375, 92155, 92165, 92386, 92376, 92156, 92166, 93917, 93887, 93225, 93918, 93920, 93890, 93228, 
93921, 93919, 93888, 93196, 93227
32465, 92386, 92376, 92156, 92166, 92387, 92377, 92157, 92167, 93920, 93890, 93228, 93921, 93923, 93893, 93231, 
93924, 93922, 93891, 93199, 93230
32466, 92387, 92377, 92157, 92167, 92388, 92378, 92158, 92168, 93923, 93893, 93231, 93924, 93926, 93896, 93234, 
93927, 93925, 93894, 93202, 93233
32467, 92388, 92378, 92158, 92168, 92389, 92379, 92159, 92169, 93926, 93896, 93234, 93927, 93929, 93899, 93237, 
93930, 93928, 93897, 93205, 93236
32468, 92389, 92379, 92159, 92169, 92390, 92380, 92160, 92170, 93929, 93899, 93237, 93930, 93932, 93902, 93240, 
93933, 93931, 93900, 93208, 93239
32469, 92390, 92380, 92160, 92170, 92391, 92381, 92161, 92171, 93932, 93902, 93240, 93933, 93935, 93905, 93243, 
93936, 93934, 93903, 93211, 93242
32470, 92391, 92381, 92161, 92171, 92392, 92382, 92162, 92172, 93935, 93905, 93243, 93936, 93938, 93908, 93246, 
93939, 93937, 93906, 93214, 93245
32471, 92392, 92382, 92162, 92172, 92393, 92383, 92163, 92173, 93938, 93908, 93246, 93939, 93941, 93911, 93249, 
93942, 93940, 93909, 93217, 93248
32472, 92393, 92383, 92163, 92173, 92394, 92384, 92164, 92174, 93941, 93911, 93249, 93942, 93944, 93914, 93252, 
93945, 93943, 93912, 93220, 93251
32473, 92394, 92384, 92164, 92174, 26302, 26301, 26279, 26280, 93944, 93914, 93252, 93945, 26411, 26408, 26366, 
26410, 93946, 93915, 93223, 93254
32474, 25977, 25976, 25954, 25955, 92395, 92385, 92165, 92175, 26086, 26085, 26041, 26087, 93948, 93918, 93256, 
93949, 93947, 93916, 93224, 93255
32475, 92395, 92385, 92165, 92175, 92396, 92386, 92166, 92176, 93948, 93918, 93256, 93949, 93951, 93921, 93259, 
93952, 93950, 93919, 93227, 93258
32476, 92396, 92386, 92166, 92176, 92397, 92387, 92167, 92177, 93951, 93921, 93259, 93952, 93954, 93924, 93262, 
93955, 93953, 93922, 93230, 93261
32477, 92397, 92387, 92167, 92177, 92398, 92388, 92168, 92178, 93954, 93924, 93262, 93955, 93957, 93927, 93265, 
93958, 93956, 93925, 93233, 93264
32478, 92398, 92388, 92168, 92178, 92399, 92389, 92169, 92179, 93957, 93927, 93265, 93958, 93960, 93930, 93268, 
93961, 93959, 93928, 93236, 93267
32479, 92399, 92389, 92169, 92179, 92400, 92390, 92170, 92180, 93960, 93930, 93268, 93961, 93963, 93933, 93271, 
93964, 93962, 93931, 93239, 93270
32480, 92400, 92390, 92170, 92180, 92401, 92391, 92171, 92181, 93963, 93933, 93271, 93964, 93966, 93936, 93274, 
93967, 93965, 93934, 93242, 93273
32481, 92401, 92391, 92171, 92181, 92402, 92392, 92172, 92182, 93966, 93936, 93274, 93967, 93969, 93939, 93277, 
93970, 93968, 93937, 93245, 93276
32482, 92402, 92392, 92172, 92182, 92403, 92393, 92173, 92183, 93969, 93939, 93277, 93970, 93972, 93942, 93280, 
93973, 93971, 93940, 93248, 93279
32483, 92403, 92393, 92173, 92183, 92404, 92394, 92174, 92184, 93972, 93942, 93280, 93973, 93975, 93945, 93283, 
93976, 93974, 93943, 93251, 93282
32484, 92404, 92394, 92174, 92184, 26303, 26302, 26280, 26281, 93975, 93945, 93283, 93976, 26413, 26410, 26368, 
26412, 93977, 93946, 93254, 93285
32485, 25978, 25977, 25955, 25956, 92405, 92395, 92175, 92185, 26088, 26087, 26043, 26089, 93979, 93949, 93287, 
93980, 93978, 93947, 93255, 93286
32486, 92405, 92395, 92175, 92185, 92406, 92396, 92176, 92186, 93979, 93949, 93287, 93980, 93982, 93952, 93290, 
93983, 93981, 93950, 93258, 93289
32487, 92406, 92396, 92176, 92186, 92407, 92397, 92177, 92187, 93982, 93952, 93290, 93983, 93985, 93955, 93293, 
93986, 93984, 93953, 93261, 93292
32488, 92407, 92397, 92177, 92187, 92408, 92398, 92178, 92188, 93985, 93955, 93293, 93986, 93988, 93958, 93296, 
93989, 93987, 93956, 93264, 93295
32489, 92408, 92398, 92178, 92188, 92409, 92399, 92179, 92189, 93988, 93958, 93296, 93989, 93991, 93961, 93299, 
93992, 93990, 93959, 93267, 93298
32490, 92409, 92399, 92179, 92189, 92410, 92400, 92180, 92190, 93991, 93961, 93299, 93992, 93994, 93964, 93302, 
93995, 93993, 93962, 93270, 93301
32491, 92410, 92400, 92180, 92190, 92411, 92401, 92181, 92191, 93994, 93964, 93302, 93995, 93997, 93967, 93305, 
93998, 93996, 93965, 93273, 93304
32492, 92411, 92401, 92181, 92191, 92412, 92402, 92182, 92192, 93997, 93967, 93305, 93998, 94000, 93970, 93308, 
94001, 93999, 93968, 93276, 93307
32493, 92412, 92402, 92182, 92192, 92413, 92403, 92183, 92193, 94000, 93970, 93308, 94001, 94003, 93973, 93311, 
94004, 94002, 93971, 93279, 93310
32494, 92413, 92403, 92183, 92193, 92414, 92404, 92184, 92194, 94003, 93973, 93311, 94004, 94006, 93976, 93314, 
94007, 94005, 93974, 93282, 93313
32495, 92414, 92404, 92184, 92194, 26304, 26303, 26281, 26282, 94006, 93976, 93314, 94007, 26415, 26412, 26370, 
26414, 94008, 93977, 93285, 93316
32496, 2566, 25978, 25956, 2565, 26503, 92405, 92185, 26493, 26090, 26089, 26045, 2569, 94009, 93980, 93317, 
26553, 26555, 93978, 93286, 26534
32497, 26503, 92405, 92185, 26493, 26502, 92406, 92186, 26492, 94009, 93980, 93317, 26553, 94010, 93983, 93318, 
26551, 26554, 93981, 93289, 26533
32498, 26502, 92406, 92186, 26492, 26501, 92407, 92187, 26491, 94010, 93983, 93318, 26551, 94011, 93986, 93319, 
26549, 26552, 93984, 93292, 26531
32499, 26501, 92407, 92187, 26491, 26500, 92408, 92188, 26490, 94011, 93986, 93319, 26549, 94012, 93989, 93320, 
26547, 26550, 93987, 93295, 26529
32500, 26500, 92408, 92188, 26490, 26499, 92409, 92189, 26489, 94012, 93989, 93320, 26547, 94013, 93992, 93321, 
26545, 26548, 93990, 93298, 26527
32501, 26499, 92409, 92189, 26489, 26498, 92410, 92190, 26488, 94013, 93992, 93321, 26545, 94014, 93995, 93322, 
26543, 26546, 93993, 93301, 26525
32502, 26498, 92410, 92190, 26488, 26497, 92411, 92191, 26487, 94014, 93995, 93322, 26543, 94015, 93998, 93323, 
26541, 26544, 93996, 93304, 26523
32503, 26497, 92411, 92191, 26487, 26496, 92412, 92192, 26486, 94015, 93998, 93323, 26541, 94016, 94001, 93324, 
26539, 26542, 93999, 93307, 26521
32504, 26496, 92412, 92192, 26486, 26495, 92413, 92193, 26485, 94016, 94001, 93324, 26539, 94017, 94004, 93325, 
26537, 26540, 94002, 93310, 26519
32505, 26495, 92413, 92193, 26485, 26494, 92414, 92194, 26484, 94017, 94004, 93325, 26537, 94018, 94007, 93326, 
26535, 26538, 94005, 93313, 26517
32506, 26494, 92414, 92194, 26484, 2646, 26304, 26282, 2645, 94018, 94007, 93326, 26535, 26416, 26414, 26371, 
2649, 26536, 94008, 93316, 26515
32507, 25979, 2560, 2559, 25957, 92415, 26187, 26177, 92195, 26091, 2563, 26046, 26092, 94020, 26249, 93328, 
94021, 94019, 26250, 26229, 93327
32508, 92415, 26187, 26177, 92195, 92416, 26186, 26176, 92196, 94020, 26249, 93328, 94021, 94023, 26247, 93331, 
94024, 94022, 26248, 26227, 93330
32509, 92416, 26186, 26176, 92196, 92417, 26185, 26175, 92197, 94023, 26247, 93331, 94024, 94026, 26245, 93334, 
94027, 94025, 26246, 26225, 93333
32510, 92417, 26185, 26175, 92197, 92418, 26184, 26174, 92198, 94026, 26245, 93334, 94027, 94029, 26243, 93337, 
94030, 94028, 26244, 26223, 93336
32511, 92418, 26184, 26174, 92198, 92419, 26183, 26173, 92199, 94029, 26243, 93337, 94030, 94032, 26241, 93340, 
94033, 94031, 26242, 26221, 93339
32512, 92419, 26183, 26173, 92199, 92420, 26182, 26172, 92200, 94032, 26241, 93340, 94033, 94035, 26239, 93343, 
94036, 94034, 26240, 26219, 93342
32513, 92420, 26182, 26172, 92200, 92421, 26181, 26171, 92201, 94035, 26239, 93343, 94036, 94038, 26237, 93346, 
94039, 94037, 26238, 26217, 93345
32514, 92421, 26181, 26171, 92201, 92422, 26180, 26170, 92202, 94038, 26237, 93346, 94039, 94041, 26235, 93349, 
94042, 94040, 26236, 26215, 93348
32515, 92422, 26180, 26170, 92202, 92423, 26179, 26169, 92203, 94041, 26235, 93349, 94042, 94044, 26233, 93352, 
94045, 94043, 26234, 26213, 93351
32516, 92423, 26179, 26169, 92203, 92424, 26178, 26168, 92204, 94044, 26233, 93352, 94045, 94047, 26231, 93355, 
94048, 94046, 26232, 26211, 93354
32517, 92424, 26178, 26168, 92204, 26305, 2619, 2618, 26283, 94047, 26231, 93355, 94048, 26418, 2622, 26373, 
26417, 94049, 26230, 26209, 93357
32518, 25980, 25979, 25957, 25958, 92425, 92415, 92195, 92205, 26093, 26092, 26048, 26094, 94051, 94021, 93359, 
94052, 94050, 94019, 93327, 93358
32519, 92425, 92415, 92195, 92205, 92426, 92416, 92196, 92206, 94051, 94021, 93359, 94052, 94054, 94024, 93362, 
94055, 94053, 94022, 93330, 93361
32520, 92426, 92416, 92196, 92206, 92427, 92417, 92197, 92207, 94054, 94024, 93362, 94055, 94057, 94027, 93365, 
94058, 94056, 94025, 93333, 93364
32521, 92427, 92417, 92197, 92207, 92428, 92418, 92198, 92208, 94057, 94027, 93365, 94058, 94060, 94030, 93368, 
94061, 94059, 94028, 93336, 93367
32522, 92428, 92418, 92198, 92208, 92429, 92419, 92199, 92209, 94060, 94030, 93368, 94061, 94063, 94033, 93371, 
94064, 94062, 94031, 93339, 93370
32523, 92429, 92419, 92199, 92209, 92430, 92420, 92200, 92210, 94063, 94033, 93371, 94064, 94066, 94036, 93374, 
94067, 94065, 94034, 93342, 93373
32524, 92430, 92420, 92200, 92210, 92431, 92421, 92201, 92211, 94066, 94036, 93374, 94067, 94069, 94039, 93377, 
94070, 94068, 94037, 93345, 93376
32525, 92431, 92421, 92201, 92211, 92432, 92422, 92202, 92212, 94069, 94039, 93377, 94070, 94072, 94042, 93380, 
94073, 94071, 94040, 93348, 93379
32526, 92432, 92422, 92202, 92212, 92433, 92423, 92203, 92213, 94072, 94042, 93380, 94073, 94075, 94045, 93383, 
94076, 94074, 94043, 93351, 93382
32527, 92433, 92423, 92203, 92213, 92434, 92424, 92204, 92214, 94075, 94045, 93383, 94076, 94078, 94048, 93386, 
94079, 94077, 94046, 93354, 93385
32528, 92434, 92424, 92204, 92214, 26306, 26305, 26283, 26284, 94078, 94048, 93386, 94079, 26420, 26417, 26375, 
26419, 94080, 94049, 93357, 93388
32529, 25981, 25980, 25958, 25959, 92435, 92425, 92205, 92215, 26095, 26094, 26050, 26096, 94082, 94052, 93390, 
94083, 94081, 94050, 93358, 93389
32530, 92435, 92425, 92205, 92215, 92436, 92426, 92206, 92216, 94082, 94052, 93390, 94083, 94085, 94055, 93393, 
94086, 94084, 94053, 93361, 93392
32531, 92436, 92426, 92206, 92216, 92437, 92427, 92207, 92217, 94085, 94055, 93393, 94086, 94088, 94058, 93396, 
94089, 94087, 94056, 93364, 93395
32532, 92437, 92427, 92207, 92217, 92438, 92428, 92208, 92218, 94088, 94058, 93396, 94089, 94091, 94061, 93399, 
94092, 94090, 94059, 93367, 93398
32533, 92438, 92428, 92208, 92218, 92439, 92429, 92209, 92219, 94091, 94061, 93399, 94092, 94094, 94064, 93402, 
94095, 94093, 94062, 93370, 93401
32534, 92439, 92429, 92209, 92219, 92440, 92430, 92210, 92220, 94094, 94064, 93402, 94095, 94097, 94067, 93405, 
94098, 94096, 94065, 93373, 93404
32535, 92440, 92430, 92210, 92220, 92441, 92431, 92211, 92221, 94097, 94067, 93405, 94098, 94100, 94070, 93408, 
94101, 94099, 94068, 93376, 93407
32536, 92441, 92431, 92211, 92221, 92442, 92432, 92212, 92222, 94100, 94070, 93408, 94101, 94103, 94073, 93411, 
94104, 94102, 94071, 93379, 93410
32537, 92442, 92432, 92212, 92222, 92443, 92433, 92213, 92223, 94103, 94073, 93411, 94104, 94106, 94076, 93414, 
94107, 94105, 94074, 93382, 93413
32538, 92443, 92433, 92213, 92223, 92444, 92434, 92214, 92224, 94106, 94076, 93414, 94107, 94109, 94079, 93417, 
94110, 94108, 94077, 93385, 93416
32539, 92444, 92434, 92214, 92224, 26307, 26306, 26284, 26285, 94109, 94079, 93417, 94110, 26422, 26419, 26377, 
26421, 94111, 94080, 93388, 93419
32540, 25982, 25981, 25959, 25960, 92445, 92435, 92215, 92225, 26097, 26096, 26052, 26098, 94113, 94083, 93421, 
94114, 94112, 94081, 93389, 93420
32541, 92445, 92435, 92215, 92225, 92446, 92436, 92216, 92226, 94113, 94083, 93421, 94114, 94116, 94086, 93424, 
94117, 94115, 94084, 93392, 93423
32542, 92446, 92436, 92216, 92226, 92447, 92437, 92217, 92227, 94116, 94086, 93424, 94117, 94119, 94089, 93427, 
94120, 94118, 94087, 93395, 93426
32543, 92447, 92437, 92217, 92227, 92448, 92438, 92218, 92228, 94119, 94089, 93427, 94120, 94122, 94092, 93430, 
94123, 94121, 94090, 93398, 93429
32544, 92448, 92438, 92218, 92228, 92449, 92439, 92219, 92229, 94122, 94092, 93430, 94123, 94125, 94095, 93433, 
94126, 94124, 94093, 93401, 93432
32545, 92449, 92439, 92219, 92229, 92450, 92440, 92220, 92230, 94125, 94095, 93433, 94126, 94128, 94098, 93436, 
94129, 94127, 94096, 93404, 93435
32546, 92450, 92440, 92220, 92230, 92451, 92441, 92221, 92231, 94128, 94098, 93436, 94129, 94131, 94101, 93439, 
94132, 94130, 94099, 93407, 93438
32547, 92451, 92441, 92221, 92231, 92452, 92442, 92222, 92232, 94131, 94101, 93439, 94132, 94134, 94104, 93442, 
94135, 94133, 94102, 93410, 93441
32548, 92452, 92442, 92222, 92232, 92453, 92443, 92223, 92233, 94134, 94104, 93442, 94135, 94137, 94107, 93445, 
94138, 94136, 94105, 93413, 93444
32549, 92453, 92443, 92223, 92233, 92454, 92444, 92224, 92234, 94137, 94107, 93445, 94138, 94140, 94110, 93448, 
94141, 94139, 94108, 93416, 93447
32550, 92454, 92444, 92224, 92234, 26308, 26307, 26285, 26286, 94140, 94110, 93448, 94141, 26424, 26421, 26379, 
26423, 94142, 94111, 93419, 93450
32551, 25983, 25982, 25960, 25961, 92455, 92445, 92225, 92235, 26099, 26098, 26054, 26100, 94144, 94114, 93452, 
94145, 94143, 94112, 93420, 93451
32552, 92455, 92445, 92225, 92235, 92456, 92446, 92226, 92236, 94144, 94114, 93452, 94145, 94147, 94117, 93455, 
94148, 94146, 94115, 93423, 93454
32553, 92456, 92446, 92226, 92236, 92457, 92447, 92227, 92237, 94147, 94117, 93455, 94148, 94150, 94120, 93458, 
94151, 94149, 94118, 93426, 93457
32554, 92457, 92447, 92227, 92237, 92458, 92448, 92228, 92238, 94150, 94120, 93458, 94151, 94153, 94123, 93461, 
94154, 94152, 94121, 93429, 93460
32555, 92458, 92448, 92228, 92238, 92459, 92449, 92229, 92239, 94153, 94123, 93461, 94154, 94156, 94126, 93464, 
94157, 94155, 94124, 93432, 93463
32556, 92459, 92449, 92229, 92239, 92460, 92450, 92230, 92240, 94156, 94126, 93464, 94157, 94159, 94129, 93467, 
94160, 94158, 94127, 93435, 93466
32557, 92460, 92450, 92230, 92240, 92461, 92451, 92231, 92241, 94159, 94129, 93467, 94160, 94162, 94132, 93470, 
94163, 94161, 94130, 93438, 93469
32558, 92461, 92451, 92231, 92241, 92462, 92452, 92232, 92242, 94162, 94132, 93470, 94163, 94165, 94135, 93473, 
94166, 94164, 94133, 93441, 93472
32559, 92462, 92452, 92232, 92242, 92463, 92453, 92233, 92243, 94165, 94135, 93473, 94166, 94168, 94138, 93476, 
94169, 94167, 94136, 93444, 93475
32560, 92463, 92453, 92233, 92243, 92464, 92454, 92234, 92244, 94168, 94138, 93476, 94169, 94171, 94141, 93479, 
94172, 94170, 94139, 93447, 93478
32561, 92464, 92454, 92234, 92244, 26309, 26308, 26286, 26287, 94171, 94141, 93479, 94172, 26426, 26423, 26381, 
26425, 94173, 94142, 93450, 93481
32562, 25984, 25983, 25961, 25962, 92465, 92455, 92235, 92245, 26101, 26100, 26056, 26102, 94175, 94145, 93483, 
94176, 94174, 94143, 93451, 93482
32563, 92465, 92455, 92235, 92245, 92466, 92456, 92236, 92246, 94175, 94145, 93483, 94176, 94178, 94148, 93486, 
94179, 94177, 94146, 93454, 93485
32564, 92466, 92456, 92236, 92246, 92467, 92457, 92237, 92247, 94178, 94148, 93486, 94179, 94181, 94151, 93489, 
94182, 94180, 94149, 93457, 93488
32565, 92467, 92457, 92237, 92247, 92468, 92458, 92238, 92248, 94181, 94151, 93489, 94182, 94184, 94154, 93492, 
94185, 94183, 94152, 93460, 93491
32566, 92468, 92458, 92238, 92248, 92469, 92459, 92239, 92249, 94184, 94154, 93492, 94185, 94187, 94157, 93495, 
94188, 94186, 94155, 93463, 93494
32567, 92469, 92459, 92239, 92249, 92470, 92460, 92240, 92250, 94187, 94157, 93495, 94188, 94190, 94160, 93498, 
94191, 94189, 94158, 93466, 93497
32568, 92470, 92460, 92240, 92250, 92471, 92461, 92241, 92251, 94190, 94160, 93498, 94191, 94193, 94163, 93501, 
94194, 94192, 94161, 93469, 93500
32569, 92471, 92461, 92241, 92251, 92472, 92462, 92242, 92252, 94193, 94163, 93501, 94194, 94196, 94166, 93504, 
94197, 94195, 94164, 93472, 93503
32570, 92472, 92462, 92242, 92252, 92473, 92463, 92243, 92253, 94196, 94166, 93504, 94197, 94199, 94169, 93507, 
94200, 94198, 94167, 93475, 93506
32571, 92473, 92463, 92243, 92253, 92474, 92464, 92244, 92254, 94199, 94169, 93507, 94200, 94202, 94172, 93510, 
94203, 94201, 94170, 93478, 93509
32572, 92474, 92464, 92244, 92254, 26310, 26309, 26287, 26288, 94202, 94172, 93510, 94203, 26428, 26425, 26383, 
26427, 94204, 94173, 93481, 93512
32573, 25985, 25984, 25962, 25963, 92475, 92465, 92245, 92255, 26103, 26102, 26058, 26104, 94206, 94176, 93514, 
94207, 94205, 94174, 93482, 93513
32574, 92475, 92465, 92245, 92255, 92476, 92466, 92246, 92256, 94206, 94176, 93514, 94207, 94209, 94179, 93517, 
94210, 94208, 94177, 93485, 93516
32575, 92476, 92466, 92246, 92256, 92477, 92467, 92247, 92257, 94209, 94179, 93517, 94210, 94212, 94182, 93520, 
94213, 94211, 94180, 93488, 93519
32576, 92477, 92467, 92247, 92257, 92478, 92468, 92248, 92258, 94212, 94182, 93520, 94213, 94215, 94185, 93523, 
94216, 94214, 94183, 93491, 93522
32577, 92478, 92468, 92248, 92258, 92479, 92469, 92249, 92259, 94215, 94185, 93523, 94216, 94218, 94188, 93526, 
94219, 94217, 94186, 93494, 93525
32578, 92479, 92469, 92249, 92259, 92480, 92470, 92250, 92260, 94218, 94188, 93526, 94219, 94221, 94191, 93529, 
94222, 94220, 94189, 93497, 93528
32579, 92480, 92470, 92250, 92260, 92481, 92471, 92251, 92261, 94221, 94191, 93529, 94222, 94224, 94194, 93532, 
94225, 94223, 94192, 93500, 93531
32580, 92481, 92471, 92251, 92261, 92482, 92472, 92252, 92262, 94224, 94194, 93532, 94225, 94227, 94197, 93535, 
94228, 94226, 94195, 93503, 93534
32581, 92482, 92472, 92252, 92262, 92483, 92473, 92253, 92263, 94227, 94197, 93535, 94228, 94230, 94200, 93538, 
94231, 94229, 94198, 93506, 93537
32582, 92483, 92473, 92253, 92263, 92484, 92474, 92254, 92264, 94230, 94200, 93538, 94231, 94233, 94203, 93541, 
94234, 94232, 94201, 93509, 93540
32583, 92484, 92474, 92254, 92264, 26311, 26310, 26288, 26289, 94233, 94203, 93541, 94234, 26430, 26427, 26385, 
26429, 94235, 94204, 93512, 93543
32584, 25986, 25985, 25963, 25964, 92485, 92475, 92255, 92265, 26105, 26104, 26060, 26106, 94237, 94207, 93545, 
94238, 94236, 94205, 93513, 93544
32585, 92485, 92475, 92255, 92265, 92486, 92476, 92256, 92266, 94237, 94207, 93545, 94238, 94240, 94210, 93548, 
94241, 94239, 94208, 93516, 93547
32586, 92486, 92476, 92256, 92266, 92487, 92477, 92257, 92267, 94240, 94210, 93548, 94241, 94243, 94213, 93551, 
94244, 94242, 94211, 93519, 93550
32587, 92487, 92477, 92257, 92267, 92488, 92478, 92258, 92268, 94243, 94213, 93551, 94244, 94246, 94216, 93554, 
94247, 94245, 94214, 93522, 93553
32588, 92488, 92478, 92258, 92268, 92489, 92479, 92259, 92269, 94246, 94216, 93554, 94247, 94249, 94219, 93557, 
94250, 94248, 94217, 93525, 93556
32589, 92489, 92479, 92259, 92269, 92490, 92480, 92260, 92270, 94249, 94219, 93557, 94250, 94252, 94222, 93560, 
94253, 94251, 94220, 93528, 93559
32590, 92490, 92480, 92260, 92270, 92491, 92481, 92261, 92271, 94252, 94222, 93560, 94253, 94255, 94225, 93563, 
94256, 94254, 94223, 93531, 93562
32591, 92491, 92481, 92261, 92271, 92492, 92482, 92262, 92272, 94255, 94225, 93563, 94256, 94258, 94228, 93566, 
94259, 94257, 94226, 93534, 93565
32592, 92492, 92482, 92262, 92272, 92493, 92483, 92263, 92273, 94258, 94228, 93566, 94259, 94261, 94231, 93569, 
94262, 94260, 94229, 93537, 93568
32593, 92493, 92483, 92263, 92273, 92494, 92484, 92264, 92274, 94261, 94231, 93569, 94262, 94264, 94234, 93572, 
94265, 94263, 94232, 93540, 93571
32594, 92494, 92484, 92264, 92274, 26312, 26311, 26289, 26290, 94264, 94234, 93572, 94265, 26432, 26429, 26387, 
26431, 94266, 94235, 93543, 93574
32595, 25987, 25986, 25964, 25965, 92495, 92485, 92265, 92275, 26107, 26106, 26062, 26108, 94268, 94238, 93576, 
94269, 94267, 94236, 93544, 93575
32596, 92495, 92485, 92265, 92275, 92496, 92486, 92266, 92276, 94268, 94238, 93576, 94269, 94271, 94241, 93579, 
94272, 94270, 94239, 93547, 93578
32597, 92496, 92486, 92266, 92276, 92497, 92487, 92267, 92277, 94271, 94241, 93579, 94272, 94274, 94244, 93582, 
94275, 94273, 94242, 93550, 93581
32598, 92497, 92487, 92267, 92277, 92498, 92488, 92268, 92278, 94274, 94244, 93582, 94275, 94277, 94247, 93585, 
94278, 94276, 94245, 93553, 93584
32599, 92498, 92488, 92268, 92278, 92499, 92489, 92269, 92279, 94277, 94247, 93585, 94278, 94280, 94250, 93588, 
94281, 94279, 94248, 93556, 93587
32600, 92499, 92489, 92269, 92279, 92500, 92490, 92270, 92280, 94280, 94250, 93588, 94281, 94283, 94253, 93591, 
94284, 94282, 94251, 93559, 93590
32601, 92500, 92490, 92270, 92280, 92501, 92491, 92271, 92281, 94283, 94253, 93591, 94284, 94286, 94256, 93594, 
94287, 94285, 94254, 93562, 93593
32602, 92501, 92491, 92271, 92281, 92502, 92492, 92272, 92282, 94286, 94256, 93594, 94287, 94289, 94259, 93597, 
94290, 94288, 94257, 93565, 93596
32603, 92502, 92492, 92272, 92282, 92503, 92493, 92273, 92283, 94289, 94259, 93597, 94290, 94292, 94262, 93600, 
94293, 94291, 94260, 93568, 93599
32604, 92503, 92493, 92273, 92283, 92504, 92494, 92274, 92284, 94292, 94262, 93600, 94293, 94295, 94265, 93603, 
94296, 94294, 94263, 93571, 93602
32605, 92504, 92494, 92274, 92284, 26313, 26312, 26290, 26291, 94295, 94265, 93603, 94296, 26434, 26431, 26389, 
26433, 94297, 94266, 93574, 93605
32606, 25988, 25987, 25965, 25966, 92505, 92495, 92275, 92285, 26109, 26108, 26064, 26110, 94299, 94269, 93607, 
94300, 94298, 94267, 93575, 93606
32607, 92505, 92495, 92275, 92285, 92506, 92496, 92276, 92286, 94299, 94269, 93607, 94300, 94302, 94272, 93610, 
94303, 94301, 94270, 93578, 93609
32608, 92506, 92496, 92276, 92286, 92507, 92497, 92277, 92287, 94302, 94272, 93610, 94303, 94305, 94275, 93613, 
94306, 94304, 94273, 93581, 93612
32609, 92507, 92497, 92277, 92287, 92508, 92498, 92278, 92288, 94305, 94275, 93613, 94306, 94308, 94278, 93616, 
94309, 94307, 94276, 93584, 93615
32610, 92508, 92498, 92278, 92288, 92509, 92499, 92279, 92289, 94308, 94278, 93616, 94309, 94311, 94281, 93619, 
94312, 94310, 94279, 93587, 93618
32611, 92509, 92499, 92279, 92289, 92510, 92500, 92280, 92290, 94311, 94281, 93619, 94312, 94314, 94284, 93622, 
94315, 94313, 94282, 93590, 93621
32612, 92510, 92500, 92280, 92290, 92511, 92501, 92281, 92291, 94314, 94284, 93622, 94315, 94317, 94287, 93625, 
94318, 94316, 94285, 93593, 93624
32613, 92511, 92501, 92281, 92291, 92512, 92502, 92282, 92292, 94317, 94287, 93625, 94318, 94320, 94290, 93628, 
94321, 94319, 94288, 93596, 93627
32614, 92512, 92502, 92282, 92292, 92513, 92503, 92283, 92293, 94320, 94290, 93628, 94321, 94323, 94293, 93631, 
94324, 94322, 94291, 93599, 93630
32615, 92513, 92503, 92283, 92293, 92514, 92504, 92284, 92294, 94323, 94293, 93631, 94324, 94326, 94296, 93634, 
94327, 94325, 94294, 93602, 93633
32616, 92514, 92504, 92284, 92294, 26314, 26313, 26291, 26292, 94326, 94296, 93634, 94327, 26436, 26433, 26391, 
26435, 94328, 94297, 93605, 93636
32617, 25989, 25988, 25966, 25967, 92515, 92505, 92285, 92295, 26111, 26110, 26066, 26112, 94330, 94300, 93638, 
94331, 94329, 94298, 93606, 93637
32618, 92515, 92505, 92285, 92295, 92516, 92506, 92286, 92296, 94330, 94300, 93638, 94331, 94333, 94303, 93641, 
94334, 94332, 94301, 93609, 93640
32619, 92516, 92506, 92286, 92296, 92517, 92507, 92287, 92297, 94333, 94303, 93641, 94334, 94336, 94306, 93644, 
94337, 94335, 94304, 93612, 93643
32620, 92517, 92507, 92287, 92297, 92518, 92508, 92288, 92298, 94336, 94306, 93644, 94337, 94339, 94309, 93647, 
94340, 94338, 94307, 93615, 93646
32621, 92518, 92508, 92288, 92298, 92519, 92509, 92289, 92299, 94339, 94309, 93647, 94340, 94342, 94312, 93650, 
94343, 94341, 94310, 93618, 93649
32622, 92519, 92509, 92289, 92299, 92520, 92510, 92290, 92300, 94342, 94312, 93650, 94343, 94345, 94315, 93653, 
94346, 94344, 94313, 93621, 93652
32623, 92520, 92510, 92290, 92300, 92521, 92511, 92291, 92301, 94345, 94315, 93653, 94346, 94348, 94318, 93656, 
94349, 94347, 94316, 93624, 93655
32624, 92521, 92511, 92291, 92301, 92522, 92512, 92292, 92302, 94348, 94318, 93656, 94349, 94351, 94321, 93659, 
94352, 94350, 94319, 93627, 93658
32625, 92522, 92512, 92292, 92302, 92523, 92513, 92293, 92303, 94351, 94321, 93659, 94352, 94354, 94324, 93662, 
94355, 94353, 94322, 93630, 93661
32626, 92523, 92513, 92293, 92303, 92524, 92514, 92294, 92304, 94354, 94324, 93662, 94355, 94357, 94327, 93665, 
94358, 94356, 94325, 93633, 93664
32627, 92524, 92514, 92294, 92304, 26315, 26314, 26292, 26293, 94357, 94327, 93665, 94358, 26438, 26435, 26393, 
26437, 94359, 94328, 93636, 93667
32628, 25990, 25989, 25967, 25968, 92525, 92515, 92295, 92305, 26113, 26112, 26068, 26114, 94361, 94331, 93669, 
94362, 94360, 94329, 93637, 93668
32629, 92525, 92515, 92295, 92305, 92526, 92516, 92296, 92306, 94361, 94331, 93669, 94362, 94364, 94334, 93672, 
94365, 94363, 94332, 93640, 93671
32630, 92526, 92516, 92296, 92306, 92527, 92517, 92297, 92307, 94364, 94334, 93672, 94365, 94367, 94337, 93675, 
94368, 94366, 94335, 93643, 93674
32631, 92527, 92517, 92297, 92307, 92528, 92518, 92298, 92308, 94367, 94337, 93675, 94368, 94370, 94340, 93678, 
94371, 94369, 94338, 93646, 93677
32632, 92528, 92518, 92298, 92308, 92529, 92519, 92299, 92309, 94370, 94340, 93678, 94371, 94373, 94343, 93681, 
94374, 94372, 94341, 93649, 93680
32633, 92529, 92519, 92299, 92309, 92530, 92520, 92300, 92310, 94373, 94343, 93681, 94374, 94376, 94346, 93684, 
94377, 94375, 94344, 93652, 93683
32634, 92530, 92520, 92300, 92310, 92531, 92521, 92301, 92311, 94376, 94346, 93684, 94377, 94379, 94349, 93687, 
94380, 94378, 94347, 93655, 93686
32635, 92531, 92521, 92301, 92311, 92532, 92522, 92302, 92312, 94379, 94349, 93687, 94380, 94382, 94352, 93690, 
94383, 94381, 94350, 93658, 93689
32636, 92532, 92522, 92302, 92312, 92533, 92523, 92303, 92313, 94382, 94352, 93690, 94383, 94385, 94355, 93693, 
94386, 94384, 94353, 93661, 93692
32637, 92533, 92523, 92303, 92313, 92534, 92524, 92304, 92314, 94385, 94355, 93693, 94386, 94388, 94358, 93696, 
94389, 94387, 94356, 93664, 93695
32638, 92534, 92524, 92304, 92314, 26316, 26315, 26293, 26294, 94388, 94358, 93696, 94389, 26440, 26437, 26395, 
26439, 94390, 94359, 93667, 93698
32639, 25991, 25990, 25968, 25969, 92535, 92525, 92305, 92315, 26115, 26114, 26070, 26116, 94392, 94362, 93700, 
94393, 94391, 94360, 93668, 93699
32640, 92535, 92525, 92305, 92315, 92536, 92526, 92306, 92316, 94392, 94362, 93700, 94393, 94395, 94365, 93703, 
94396, 94394, 94363, 93671, 93702
32641, 92536, 92526, 92306, 92316, 92537, 92527, 92307, 92317, 94395, 94365, 93703, 94396, 94398, 94368, 93706, 
94399, 94397, 94366, 93674, 93705
32642, 92537, 92527, 92307, 92317, 92538, 92528, 92308, 92318, 94398, 94368, 93706, 94399, 94401, 94371, 93709, 
94402, 94400, 94369, 93677, 93708
32643, 92538, 92528, 92308, 92318, 92539, 92529, 92309, 92319, 94401, 94371, 93709, 94402, 94404, 94374, 93712, 
94405, 94403, 94372, 93680, 93711
32644, 92539, 92529, 92309, 92319, 92540, 92530, 92310, 92320, 94404, 94374, 93712, 94405, 94407, 94377, 93715, 
94408, 94406, 94375, 93683, 93714
32645, 92540, 92530, 92310, 92320, 92541, 92531, 92311, 92321, 94407, 94377, 93715, 94408, 94410, 94380, 93718, 
94411, 94409, 94378, 93686, 93717
32646, 92541, 92531, 92311, 92321, 92542, 92532, 92312, 92322, 94410, 94380, 93718, 94411, 94413, 94383, 93721, 
94414, 94412, 94381, 93689, 93720
32647, 92542, 92532, 92312, 92322, 92543, 92533, 92313, 92323, 94413, 94383, 93721, 94414, 94416, 94386, 93724, 
94417, 94415, 94384, 93692, 93723
32648, 92543, 92533, 92313, 92323, 92544, 92534, 92314, 92324, 94416, 94386, 93724, 94417, 94419, 94389, 93727, 
94420, 94418, 94387, 93695, 93726
32649, 92544, 92534, 92314, 92324, 26317, 26316, 26294, 26295, 94419, 94389, 93727, 94420, 26442, 26439, 26397, 
26441, 94421, 94390, 93698, 93729
32650, 25992, 25991, 25969, 25970, 92545, 92535, 92315, 92325, 26117, 26116, 26072, 26118, 94423, 94393, 93731, 
94424, 94422, 94391, 93699, 93730
32651, 92545, 92535, 92315, 92325, 92546, 92536, 92316, 92326, 94423, 94393, 93731, 94424, 94426, 94396, 93734, 
94427, 94425, 94394, 93702, 93733
32652, 92546, 92536, 92316, 92326, 92547, 92537, 92317, 92327, 94426, 94396, 93734, 94427, 94429, 94399, 93737, 
94430, 94428, 94397, 93705, 93736
32653, 92547, 92537, 92317, 92327, 92548, 92538, 92318, 92328, 94429, 94399, 93737, 94430, 94432, 94402, 93740, 
94433, 94431, 94400, 93708, 93739
32654, 92548, 92538, 92318, 92328, 92549, 92539, 92319, 92329, 94432, 94402, 93740, 94433, 94435, 94405, 93743, 
94436, 94434, 94403, 93711, 93742
32655, 92549, 92539, 92319, 92329, 92550, 92540, 92320, 92330, 94435, 94405, 93743, 94436, 94438, 94408, 93746, 
94439, 94437, 94406, 93714, 93745
32656, 92550, 92540, 92320, 92330, 92551, 92541, 92321, 92331, 94438, 94408, 93746, 94439, 94441, 94411, 93749, 
94442, 94440, 94409, 93717, 93748
32657, 92551, 92541, 92321, 92331, 92552, 92542, 92322, 92332, 94441, 94411, 93749, 94442, 94444, 94414, 93752, 
94445, 94443, 94412, 93720, 93751
32658, 92552, 92542, 92322, 92332, 92553, 92543, 92323, 92333, 94444, 94414, 93752, 94445, 94447, 94417, 93755, 
