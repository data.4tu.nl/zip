99679, 2.2333333333333, 1.625, 0.22727272727273
99680, 2.2166666666667, 1.65, 0.22727272727273
99681, 2.2333333333333, 1.65, 0.20454545454545
99682, 2.2333333333333, 1.625, 0.18181818181818
99683, 2.2166666666667, 1.65, 0.18181818181818
99684, 2.2333333333333, 1.65, 0.15909090909091
99685, 2.2333333333333, 1.625, 0.13636363636364
99686, 2.2166666666667, 1.65, 0.13636363636364
99687, 2.2333333333333, 1.65, 0.11363636363636
99688, 2.2333333333333, 1.625, 0.090909090909091
99689, 2.2166666666667, 1.65, 0.090909090909091
99690, 2.2333333333333, 1.65, 0.068181818181818
99691, 2.2333333333333, 1.625, 0.045454545454545
99692, 2.2166666666667, 1.65, 0.045454545454545
99693, 2.2333333333333, 1.65, 0.022727272727273
99694, 2.2333333333333, 1.675, 0.45454545454545
99695, 2.2333333333333, 1.675, 0.40909090909091
99696, 2.2333333333333, 1.675, 0.36363636363636
99697, 2.2333333333333, 1.675, 0.31818181818182
99698, 2.2333333333333, 1.675, 0.27272727272727
99699, 2.2333333333333, 1.675, 0.22727272727273
99700, 2.2333333333333, 1.675, 0.18181818181818
99701, 2.2333333333333, 1.675, 0.13636363636364
99702, 2.2333333333333, 1.675, 0.090909090909091
99703, 2.2333333333333, 1.675, 0.045454545454545
99704, 2.2666666666667, 1.55, 0.47727272727273
99705, 2.2666666666667, 1.525, 0.45454545454545
99706, 2.25, 1.55, 0.45454545454545
99707, 2.2666666666667, 1.55, 0.43181818181818
99708, 2.2666666666667, 1.525, 0.40909090909091
99709, 2.25, 1.55, 0.40909090909091
99710, 2.2666666666667, 1.55, 0.38636363636364
99711, 2.2666666666667, 1.525, 0.36363636363636
99712, 2.25, 1.55, 0.36363636363636
99713, 2.2666666666667, 1.55, 0.34090909090909
99714, 2.2666666666667, 1.525, 0.31818181818182
99715, 2.25, 1.55, 0.31818181818182
99716, 2.2666666666667, 1.55, 0.29545454545455
99717, 2.2666666666667, 1.525, 0.27272727272727
99718, 2.25, 1.55, 0.27272727272727
99719, 2.2666666666667, 1.55, 0.25
99720, 2.2666666666667, 1.525, 0.22727272727273
99721, 2.25, 1.55, 0.22727272727273
99722, 2.2666666666667, 1.55, 0.20454545454545
99723, 2.2666666666667, 1.525, 0.18181818181818
99724, 2.25, 1.55, 0.18181818181818
99725, 2.2666666666667, 1.55, 0.15909090909091
99726, 2.2666666666667, 1.525, 0.13636363636364
99727, 2.25, 1.55, 0.13636363636364
99728, 2.2666666666667, 1.55, 0.11363636363636
99729, 2.2666666666667, 1.525, 0.090909090909091
99730, 2.25, 1.55, 0.090909090909091
99731, 2.2666666666667, 1.55, 0.068181818181818
99732, 2.2666666666667, 1.525, 0.045454545454545
99733, 2.25, 1.55, 0.045454545454545
99734, 2.2666666666667, 1.55, 0.022727272727273
99735, 2.2666666666667, 1.6, 0.47727272727273
99736, 2.2666666666667, 1.575, 0.45454545454545
99737, 2.25, 1.6, 0.45454545454545
99738, 2.2666666666667, 1.6, 0.43181818181818
99739, 2.2666666666667, 1.575, 0.40909090909091
99740, 2.25, 1.6, 0.40909090909091
99741, 2.2666666666667, 1.6, 0.38636363636364
99742, 2.2666666666667, 1.575, 0.36363636363636
99743, 2.25, 1.6, 0.36363636363636
99744, 2.2666666666667, 1.6, 0.34090909090909
99745, 2.2666666666667, 1.575, 0.31818181818182
99746, 2.25, 1.6, 0.31818181818182
99747, 2.2666666666667, 1.6, 0.29545454545455
99748, 2.2666666666667, 1.575, 0.27272727272727
99749, 2.25, 1.6, 0.27272727272727
99750, 2.2666666666667, 1.6, 0.25
99751, 2.2666666666667, 1.575, 0.22727272727273
99752, 2.25, 1.6, 0.22727272727273
99753, 2.2666666666667, 1.6, 0.20454545454545
99754, 2.2666666666667, 1.575, 0.18181818181818
99755, 2.25, 1.6, 0.18181818181818
99756, 2.2666666666667, 1.6, 0.15909090909091
99757, 2.2666666666667, 1.575, 0.13636363636364
99758, 2.25, 1.6, 0.13636363636364
99759, 2.2666666666667, 1.6, 0.11363636363636
99760, 2.2666666666667, 1.575, 0.090909090909091
99761, 2.25, 1.6, 0.090909090909091
99762, 2.2666666666667, 1.6, 0.068181818181818
99763, 2.2666666666667, 1.575, 0.045454545454545
99764, 2.25, 1.6, 0.045454545454545
99765, 2.2666666666667, 1.6, 0.022727272727273
99766, 2.2666666666667, 1.65, 0.47727272727273
99767, 2.2666666666667, 1.625, 0.45454545454545
99768, 2.25, 1.65, 0.45454545454545
99769, 2.2666666666667, 1.65, 0.43181818181818
99770, 2.2666666666667, 1.625, 0.40909090909091
99771, 2.25, 1.65, 0.40909090909091
99772, 2.2666666666667, 1.65, 0.38636363636364
99773, 2.2666666666667, 1.625, 0.36363636363636
99774, 2.25, 1.65, 0.36363636363636
99775, 2.2666666666667, 1.65, 0.34090909090909
99776, 2.2666666666667, 1.625, 0.31818181818182
99777, 2.25, 1.65, 0.31818181818182
99778, 2.2666666666667, 1.65, 0.29545454545455
99779, 2.2666666666667, 1.625, 0.27272727272727
99780, 2.25, 1.65, 0.27272727272727
99781, 2.2666666666667, 1.65, 0.25
99782, 2.2666666666667, 1.625, 0.22727272727273
99783, 2.25, 1.65, 0.22727272727273
99784, 2.2666666666667, 1.65, 0.20454545454545
99785, 2.2666666666667, 1.625, 0.18181818181818
99786, 2.25, 1.65, 0.18181818181818
99787, 2.2666666666667, 1.65, 0.15909090909091
99788, 2.2666666666667, 1.625, 0.13636363636364
99789, 2.25, 1.65, 0.13636363636364
99790, 2.2666666666667, 1.65, 0.11363636363636
99791, 2.2666666666667, 1.625, 0.090909090909091
99792, 2.25, 1.65, 0.090909090909091
99793, 2.2666666666667, 1.65, 0.068181818181818
99794, 2.2666666666667, 1.625, 0.045454545454545
99795, 2.25, 1.65, 0.045454545454545
99796, 2.2666666666667, 1.65, 0.022727272727273
99797, 2.2666666666667, 1.675, 0.45454545454545
99798, 2.2666666666667, 1.675, 0.40909090909091
99799, 2.2666666666667, 1.675, 0.36363636363636
99800, 2.2666666666667, 1.675, 0.31818181818182
99801, 2.2666666666667, 1.675, 0.27272727272727
99802, 2.2666666666667, 1.675, 0.22727272727273
99803, 2.2666666666667, 1.675, 0.18181818181818
99804, 2.2666666666667, 1.675, 0.13636363636364
99805, 2.2666666666667, 1.675, 0.090909090909091
99806, 2.2666666666667, 1.675, 0.045454545454545
99807, 2.2833333333333, 1.55, 0.45454545454545
99808, 2.2833333333333, 1.55, 0.40909090909091
99809, 2.2833333333333, 1.55, 0.36363636363636
99810, 2.2833333333333, 1.55, 0.31818181818182
99811, 2.2833333333333, 1.55, 0.27272727272727
99812, 2.2833333333333, 1.55, 0.22727272727273
99813, 2.2833333333333, 1.55, 0.18181818181818
99814, 2.2833333333333, 1.55, 0.13636363636364
99815, 2.2833333333333, 1.55, 0.090909090909091
99816, 2.2833333333333, 1.55, 0.045454545454545
99817, 2.2833333333333, 1.6, 0.45454545454545
99818, 2.2833333333333, 1.6, 0.40909090909091
99819, 2.2833333333333, 1.6, 0.36363636363636
99820, 2.2833333333333, 1.6, 0.31818181818182
99821, 2.2833333333333, 1.6, 0.27272727272727
99822, 2.2833333333333, 1.6, 0.22727272727273
99823, 2.2833333333333, 1.6, 0.18181818181818
99824, 2.2833333333333, 1.6, 0.13636363636364
99825, 2.2833333333333, 1.6, 0.090909090909091
99826, 2.2833333333333, 1.6, 0.045454545454545
99827, 2.2833333333333, 1.65, 0.45454545454545
99828, 2.2833333333333, 1.65, 0.40909090909091
99829, 2.2833333333333, 1.65, 0.36363636363636
99830, 2.2833333333333, 1.65, 0.31818181818182
99831, 2.2833333333333, 1.65, 0.27272727272727
99832, 2.2833333333333, 1.65, 0.22727272727273
99833, 2.2833333333333, 1.65, 0.18181818181818
99834, 2.2833333333333, 1.65, 0.13636363636364
99835, 2.2833333333333, 1.65, 0.090909090909091
99836, 2.2833333333333, 1.65, 0.045454545454545
99837, 2.2333333333333, 1.4333333333333, 0.45454545454545
99838, 2.2333333333333, 1.4333333333333, 0.40909090909091
99839, 2.2333333333333, 1.4333333333333, 0.36363636363636
99840, 2.2333333333333, 1.4333333333333, 0.31818181818182
99841, 2.2333333333333, 1.4333333333333, 0.27272727272727
99842, 2.2333333333333, 1.4333333333333, 0.22727272727273
99843, 2.2333333333333, 1.4333333333333, 0.18181818181818
99844, 2.2333333333333, 1.4333333333333, 0.13636363636364
99845, 2.2333333333333, 1.4333333333333, 0.090909090909091
99846, 2.2333333333333, 1.4333333333333, 0.045454545454545
99847, 2.2333333333333, 1.4666666666667, 0.45454545454545
99848, 2.2333333333333, 1.4666666666667, 0.40909090909091
99849, 2.2333333333333, 1.4666666666667, 0.36363636363636
99850, 2.2333333333333, 1.4666666666667, 0.31818181818182
99851, 2.2333333333333, 1.4666666666667, 0.27272727272727
99852, 2.2333333333333, 1.4666666666667, 0.22727272727273
99853, 2.2333333333333, 1.4666666666667, 0.18181818181818
99854, 2.2333333333333, 1.4666666666667, 0.13636363636364
99855, 2.2333333333333, 1.4666666666667, 0.090909090909091
99856, 2.2333333333333, 1.4666666666667, 0.045454545454545
99857, 2.2666666666667, 1.4333333333333, 0.45454545454545
99858, 2.2666666666667, 1.4333333333333, 0.40909090909091
99859, 2.2666666666667, 1.4333333333333, 0.36363636363636
99860, 2.2666666666667, 1.4333333333333, 0.31818181818182
99861, 2.2666666666667, 1.4333333333333, 0.27272727272727
99862, 2.2666666666667, 1.4333333333333, 0.22727272727273
99863, 2.2666666666667, 1.4333333333333, 0.18181818181818
99864, 2.2666666666667, 1.4333333333333, 0.13636363636364
99865, 2.2666666666667, 1.4333333333333, 0.090909090909091
99866, 2.2666666666667, 1.4333333333333, 0.045454545454545
99867, 2.2666666666667, 1.4666666666667, 0.45454545454545
99868, 2.2666666666667, 1.4666666666667, 0.40909090909091
99869, 2.2666666666667, 1.4666666666667, 0.36363636363636
99870, 2.2666666666667, 1.4666666666667, 0.31818181818182
99871, 2.2666666666667, 1.4666666666667, 0.27272727272727
99872, 2.2666666666667, 1.4666666666667, 0.22727272727273
99873, 2.2666666666667, 1.4666666666667, 0.18181818181818
99874, 2.2666666666667, 1.4666666666667, 0.13636363636364
99875, 2.2666666666667, 1.4666666666667, 0.090909090909091
99876, 2.2666666666667, 1.4666666666667, 0.045454545454545
99877, 2.2333333333333, 1.4333333333333, 0.47727272727273
99878, 2.2333333333333, 1.4166666666667, 0.45454545454545
99879, 2.2166666666667, 1.4333333333333, 0.45454545454545
99880, 2.2333333333333, 1.4333333333333, 0.43181818181818
99881, 2.2333333333333, 1.4166666666667, 0.40909090909091
99882, 2.2166666666667, 1.4333333333333, 0.40909090909091
99883, 2.2333333333333, 1.4333333333333, 0.38636363636364
99884, 2.2333333333333, 1.4166666666667, 0.36363636363636
99885, 2.2166666666667, 1.4333333333333, 0.36363636363636
99886, 2.2333333333333, 1.4333333333333, 0.34090909090909
99887, 2.2333333333333, 1.4166666666667, 0.31818181818182
99888, 2.2166666666667, 1.4333333333333, 0.31818181818182
99889, 2.2333333333333, 1.4333333333333, 0.29545454545455
99890, 2.2333333333333, 1.4166666666667, 0.27272727272727
99891, 2.2166666666667, 1.4333333333333, 0.27272727272727
99892, 2.2333333333333, 1.4333333333333, 0.25
99893, 2.2333333333333, 1.4166666666667, 0.22727272727273
99894, 2.2166666666667, 1.4333333333333, 0.22727272727273
99895, 2.2333333333333, 1.4333333333333, 0.20454545454545
99896, 2.2333333333333, 1.4166666666667, 0.18181818181818
99897, 2.2166666666667, 1.4333333333333, 0.18181818181818
99898, 2.2333333333333, 1.4333333333333, 0.15909090909091
99899, 2.2333333333333, 1.4166666666667, 0.13636363636364
99900, 2.2166666666667, 1.4333333333333, 0.13636363636364
99901, 2.2333333333333, 1.4333333333333, 0.11363636363636
99902, 2.2333333333333, 1.4166666666667, 0.090909090909091
99903, 2.2166666666667, 1.4333333333333, 0.090909090909091
99904, 2.2333333333333, 1.4333333333333, 0.068181818181818
99905, 2.2333333333333, 1.4166666666667, 0.045454545454545
99906, 2.2166666666667, 1.4333333333333, 0.045454545454545
99907, 2.2333333333333, 1.4333333333333, 0.022727272727273
99908, 2.2333333333333, 1.4666666666667, 0.47727272727273
99909, 2.2333333333333, 1.45, 0.45454545454545
99910, 2.2166666666667, 1.4666666666667, 0.45454545454545
99911, 2.2333333333333, 1.4666666666667, 0.43181818181818
99912, 2.2333333333333, 1.45, 0.40909090909091
99913, 2.2166666666667, 1.4666666666667, 0.40909090909091
99914, 2.2333333333333, 1.4666666666667, 0.38636363636364
99915, 2.2333333333333, 1.45, 0.36363636363636
99916, 2.2166666666667, 1.4666666666667, 0.36363636363636
99917, 2.2333333333333, 1.4666666666667, 0.34090909090909
99918, 2.2333333333333, 1.45, 0.31818181818182
99919, 2.2166666666667, 1.4666666666667, 0.31818181818182
99920, 2.2333333333333, 1.4666666666667, 0.29545454545455
99921, 2.2333333333333, 1.45, 0.27272727272727
99922, 2.2166666666667, 1.4666666666667, 0.27272727272727
99923, 2.2333333333333, 1.4666666666667, 0.25
99924, 2.2333333333333, 1.45, 0.22727272727273
99925, 2.2166666666667, 1.4666666666667, 0.22727272727273
99926, 2.2333333333333, 1.4666666666667, 0.20454545454545
99927, 2.2333333333333, 1.45, 0.18181818181818
99928, 2.2166666666667, 1.4666666666667, 0.18181818181818
99929, 2.2333333333333, 1.4666666666667, 0.15909090909091
99930, 2.2333333333333, 1.45, 0.13636363636364
99931, 2.2166666666667, 1.4666666666667, 0.13636363636364
99932, 2.2333333333333, 1.4666666666667, 0.11363636363636
99933, 2.2333333333333, 1.45, 0.090909090909091
99934, 2.2166666666667, 1.4666666666667, 0.090909090909091
99935, 2.2333333333333, 1.4666666666667, 0.068181818181818
99936, 2.2333333333333, 1.45, 0.045454545454545
99937, 2.2166666666667, 1.4666666666667, 0.045454545454545
99938, 2.2333333333333, 1.4666666666667, 0.022727272727273
99939, 2.2333333333333, 1.4833333333333, 0.45454545454545
99940, 2.2333333333333, 1.4833333333333, 0.40909090909091
99941, 2.2333333333333, 1.4833333333333, 0.36363636363636
99942, 2.2333333333333, 1.4833333333333, 0.31818181818182
99943, 2.2333333333333, 1.4833333333333, 0.27272727272727
99944, 2.2333333333333, 1.4833333333333, 0.22727272727273
99945, 2.2333333333333, 1.4833333333333, 0.18181818181818
99946, 2.2333333333333, 1.4833333333333, 0.13636363636364
99947, 2.2333333333333, 1.4833333333333, 0.090909090909091
99948, 2.2333333333333, 1.4833333333333, 0.045454545454545
99949, 2.2666666666667, 1.4333333333333, 0.47727272727273
99950, 2.2666666666667, 1.4166666666667, 0.45454545454545
99951, 2.25, 1.4333333333333, 0.45454545454545
99952, 2.2666666666667, 1.4333333333333, 0.43181818181818
99953, 2.2666666666667, 1.4166666666667, 0.40909090909091
99954, 2.25, 1.4333333333333, 0.40909090909091
99955, 2.2666666666667, 1.4333333333333, 0.38636363636364
99956, 2.2666666666667, 1.4166666666667, 0.36363636363636
99957, 2.25, 1.4333333333333, 0.36363636363636
99958, 2.2666666666667, 1.4333333333333, 0.34090909090909
99959, 2.2666666666667, 1.4166666666667, 0.31818181818182
99960, 2.25, 1.4333333333333, 0.31818181818182
99961, 2.2666666666667, 1.4333333333333, 0.29545454545455
99962, 2.2666666666667, 1.4166666666667, 0.27272727272727
99963, 2.25, 1.4333333333333, 0.27272727272727
99964, 2.2666666666667, 1.4333333333333, 0.25
99965, 2.2666666666667, 1.4166666666667, 0.22727272727273
99966, 2.25, 1.4333333333333, 0.22727272727273
99967, 2.2666666666667, 1.4333333333333, 0.20454545454545
99968, 2.2666666666667, 1.4166666666667, 0.18181818181818
99969, 2.25, 1.4333333333333, 0.18181818181818
99970, 2.2666666666667, 1.4333333333333, 0.15909090909091
99971, 2.2666666666667, 1.4166666666667, 0.13636363636364
99972, 2.25, 1.4333333333333, 0.13636363636364
99973, 2.2666666666667, 1.4333333333333, 0.11363636363636
99974, 2.2666666666667, 1.4166666666667, 0.090909090909091
99975, 2.25, 1.4333333333333, 0.090909090909091
99976, 2.2666666666667, 1.4333333333333, 0.068181818181818
99977, 2.2666666666667, 1.4166666666667, 0.045454545454545
99978, 2.25, 1.4333333333333, 0.045454545454545
99979, 2.2666666666667, 1.4333333333333, 0.022727272727273
99980, 2.2666666666667, 1.4666666666667, 0.47727272727273
99981, 2.2666666666667, 1.45, 0.45454545454545
99982, 2.25, 1.4666666666667, 0.45454545454545
99983, 2.2666666666667, 1.4666666666667, 0.43181818181818
99984, 2.2666666666667, 1.45, 0.40909090909091
99985, 2.25, 1.4666666666667, 0.40909090909091
99986, 2.2666666666667, 1.4666666666667, 0.38636363636364
99987, 2.2666666666667, 1.45, 0.36363636363636
99988, 2.25, 1.4666666666667, 0.36363636363636
99989, 2.2666666666667, 1.4666666666667, 0.34090909090909
99990, 2.2666666666667, 1.45, 0.31818181818182
99991, 2.25, 1.4666666666667, 0.31818181818182
99992, 2.2666666666667, 1.4666666666667, 0.29545454545455
99993, 2.2666666666667, 1.45, 0.27272727272727
99994, 2.25, 1.4666666666667, 0.27272727272727
99995, 2.2666666666667, 1.4666666666667, 0.25
99996, 2.2666666666667, 1.45, 0.22727272727273
99997, 2.25, 1.4666666666667, 0.22727272727273
99998, 2.2666666666667, 1.4666666666667, 0.20454545454545
99999, 2.2666666666667, 1.45, 0.18181818181818
100000, 2.25, 1.4666666666667, 0.18181818181818
100001, 2.2666666666667, 1.4666666666667, 0.15909090909091
100002, 2.2666666666667, 1.45, 0.13636363636364
100003, 2.25, 1.4666666666667, 0.13636363636364
100004, 2.2666666666667, 1.4666666666667, 0.11363636363636
100005, 2.2666666666667, 1.45, 0.090909090909091
100006, 2.25, 1.4666666666667, 0.090909090909091
100007, 2.2666666666667, 1.4666666666667, 0.068181818181818
100008, 2.2666666666667, 1.45, 0.045454545454545
100009, 2.25, 1.4666666666667, 0.045454545454545
100010, 2.2666666666667, 1.4666666666667, 0.022727272727273
100011, 2.2666666666667, 1.4833333333333, 0.45454545454545
100012, 2.2666666666667, 1.4833333333333, 0.40909090909091
100013, 2.2666666666667, 1.4833333333333, 0.36363636363636
100014, 2.2666666666667, 1.4833333333333, 0.31818181818182
100015, 2.2666666666667, 1.4833333333333, 0.27272727272727
100016, 2.2666666666667, 1.4833333333333, 0.22727272727273
100017, 2.2666666666667, 1.4833333333333, 0.18181818181818
100018, 2.2666666666667, 1.4833333333333, 0.13636363636364
100019, 2.2666666666667, 1.4833333333333, 0.090909090909091
100020, 2.2666666666667, 1.4833333333333, 0.045454545454545
100021, 2.2833333333333, 1.4333333333333, 0.45454545454545
100022, 2.2833333333333, 1.4333333333333, 0.40909090909091
100023, 2.2833333333333, 1.4333333333333, 0.36363636363636
100024, 2.2833333333333, 1.4333333333333, 0.31818181818182
100025, 2.2833333333333, 1.4333333333333, 0.27272727272727
100026, 2.2833333333333, 1.4333333333333, 0.22727272727273
100027, 2.2833333333333, 1.4333333333333, 0.18181818181818
100028, 2.2833333333333, 1.4333333333333, 0.13636363636364
100029, 2.2833333333333, 1.4333333333333, 0.090909090909091
100030, 2.2833333333333, 1.4333333333333, 0.045454545454545
100031, 2.2833333333333, 1.4666666666667, 0.45454545454545
100032, 2.2833333333333, 1.4666666666667, 0.40909090909091
100033, 2.2833333333333, 1.4666666666667, 0.36363636363636
100034, 2.2833333333333, 1.4666666666667, 0.31818181818182
100035, 2.2833333333333, 1.4666666666667, 0.27272727272727
100036, 2.2833333333333, 1.4666666666667, 0.22727272727273
100037, 2.2833333333333, 1.4666666666667, 0.18181818181818
100038, 2.2833333333333, 1.4666666666667, 0.13636363636364
100039, 2.2833333333333, 1.4666666666667, 0.090909090909091
100040, 2.2833333333333, 1.4666666666667, 0.045454545454545
******* E L E M E N T S *************
*ELEMENT, type=T3D3, ELSET=Line1
89, 2, 99, 89
90, 89, 100, 90
91, 90, 101, 91
92, 91, 102, 92
93, 92, 103, 93
94, 93, 104, 94
95, 94, 105, 95
96, 95, 106, 96
97, 96, 107, 97
98, 97, 108, 98
99, 98, 109, 1
*ELEMENT, type=T3D3, ELSET=Line2
100, 1, 112, 110
101, 110, 113, 111
102, 111, 114, 3
*ELEMENT, type=T3D3, ELSET=Line3
103, 4, 125, 115
104, 115, 126, 116
105, 116, 127, 117
106, 117, 128, 118
107, 118, 129, 119
108, 119, 130, 120
109, 120, 131, 121
110, 121, 132, 122
111, 122, 133, 123
112, 123, 134, 124
113, 124, 135, 3
*ELEMENT, type=T3D3, ELSET=Line4
114, 2, 138, 136
115, 136, 139, 137
116, 137, 140, 4
*ELEMENT, type=T3D3, ELSET=Line5
117, 6, 151, 141
118, 141, 152, 142
119, 142, 153, 143
120, 143, 154, 144
121, 144, 155, 145
122, 145, 156, 146
123, 146, 157, 147
124, 147, 158, 148
125, 148, 159, 149
126, 149, 160, 150
127, 150, 161, 5
*ELEMENT, type=T3D3, ELSET=Line6
128, 5, 164, 162
129, 162, 165, 163
130, 163, 166, 7
*ELEMENT, type=T3D3, ELSET=Line7
131, 8, 177, 167
132, 167, 178, 168
133, 168, 179, 169
134, 169, 180, 170
135, 170, 181, 171
136, 171, 182, 172
137, 172, 183, 173
138, 173, 184, 174
139, 174, 185, 175
140, 175, 186, 176
141, 176, 187, 7
*ELEMENT, type=T3D3, ELSET=Line8
142, 6, 190, 188
143, 188, 191, 189
144, 189, 192, 8
*ELEMENT, type=T3D3, ELSET=Line9
145, 2, 215, 193
146, 193, 216, 194
147, 194, 217, 195
148, 195, 218, 196
149, 196, 219, 197
150, 197, 220, 198
151, 198, 221, 199
152, 199, 222, 200
153, 200, 223, 201
154, 201, 224, 202
155, 202, 225, 203
156, 203, 226, 204
157, 204, 227, 205
158, 205, 228, 206
159, 206, 229, 207
160, 207, 230, 208
161, 208, 231, 209
162, 209, 232, 210
163, 210, 233, 211
164, 211, 234, 212
165, 212, 235, 213
166, 213, 236, 214
167, 214, 237, 6
*ELEMENT, type=T3D3, ELSET=Line10
168, 1, 260, 238
169, 238, 261, 239
170, 239, 262, 240
171, 240, 263, 241
172, 241, 264, 242
173, 242, 265, 243
174, 243, 266, 244
175, 244, 267, 245
176, 245, 268, 246
177, 246, 269, 247
178, 247, 270, 248
179, 248, 271, 249
180, 249, 272, 250
181, 250, 273, 251
182, 251, 274, 252
183, 252, 275, 253
184, 253, 276, 254
185, 254, 277, 255
186, 255, 278, 256
187, 256, 279, 257
188, 257, 280, 258
189, 258, 281, 259
190, 259, 282, 5
*ELEMENT, type=T3D3, ELSET=Line11
191, 4, 305, 283
192, 283, 306, 284
193, 284, 307, 285
194, 285, 308, 286
195, 286, 309, 287
196, 287, 310, 288
197, 288, 311, 289
198, 289, 312, 290
199, 290, 313, 291
200, 291, 314, 292
201, 292, 315, 293
202, 293, 316, 294
203, 294, 317, 295
204, 295, 318, 296
205, 296, 319, 297
206, 297, 320, 298
207, 298, 321, 299
208, 299, 322, 300
209, 300, 323, 301
210, 301, 324, 302
211, 302, 325, 303
212, 303, 326, 304
213, 304, 327, 8
*ELEMENT, type=T3D3, ELSET=Line12
214, 3, 350, 328
215, 328, 351, 329
216, 329, 352, 330
217, 330, 353, 331
218, 331, 354, 332
219, 332, 355, 333
220, 333, 356, 334
221, 334, 357, 335
222, 335, 358, 336
223, 336, 359, 337
224, 337, 360, 338
225, 338, 361, 339
226, 339, 362, 340
227, 340, 363, 341
228, 341, 364, 342
229, 342, 365, 343
230, 343, 366, 344
231, 344, 367, 345
232, 345, 368, 346
233, 346, 369, 347
234, 347, 370, 348
235, 348, 371, 349
236, 349, 372, 7
*ELEMENT, type=T3D3, ELSET=Line13
237, 8, 374, 373
238, 373, 375, 9
*ELEMENT, type=T3D3, ELSET=Line14
239, 4, 377, 376
240, 376, 378, 10
*ELEMENT, type=T3D3, ELSET=Line15
241, 10, 401, 379
242, 379, 402, 380
243, 380, 403, 381
244, 381, 404, 382
245, 382, 405, 383
246, 383, 406, 384
247, 384, 407, 385
248, 385, 408, 386
249, 386, 409, 387
250, 387, 410, 388
251, 388, 411, 389
252, 389, 412, 390
253, 390, 413, 391
254, 391, 414, 392
255, 392, 415, 393
256, 393, 416, 394
257, 394, 417, 395
258, 395, 418, 396
259, 396, 419, 397
260, 397, 420, 398
261, 398, 421, 399
262, 399, 422, 400
263, 400, 423, 9
*ELEMENT, type=T3D3, ELSET=Line16
264, 7, 425, 424
265, 424, 426, 11
*ELEMENT, type=T3D3, ELSET=Line17
266, 9, 437, 427
267, 427, 438, 428
268, 428, 439, 429
269, 429, 440, 430
270, 430, 441, 431
271, 431, 442, 432
272, 432, 443, 433
273, 433, 444, 434
274, 434, 445, 435
275, 435, 446, 436
276, 436, 447, 11
*ELEMENT, type=T3D3, ELSET=Line18
277, 3, 449, 448
278, 448, 450, 12
*ELEMENT, type=T3D3, ELSET=Line19
279, 12, 473, 451
280, 451, 474, 452
281, 452, 475, 453
282, 453, 476, 454
283, 454, 477, 455
284, 455, 478, 456
285, 456, 479, 457
286, 457, 480, 458
287, 458, 481, 459
288, 459, 482, 460
289, 460, 483, 461
290, 461, 484, 462
291, 462, 485, 463
292, 463, 486, 464
293, 464, 487, 465
294, 465, 488, 466
295, 466, 489, 467
296, 467, 490, 468
297, 468, 491, 469
298, 469, 492, 470
299, 470, 493, 471
300, 471, 494, 472
301, 472, 495, 11
*ELEMENT, type=T3D3, ELSET=Line20
302, 10, 506, 496
303, 496, 507, 497
304, 497, 508, 498
305, 498, 509, 499
306, 499, 510, 500
307, 500, 511, 501
308, 501, 512, 502
309, 502, 513, 503
310, 503, 514, 504
311, 504, 515, 505
312, 505, 516, 12
*ELEMENT, type=T3D3, ELSET=Line21
313, 9, 539, 517
314, 517, 540, 518
315, 518, 541, 519
316, 519, 542, 520
317, 520, 543, 521
318, 521, 544, 522
319, 522, 545, 523
320, 523, 546, 524
321, 524, 547, 525
322, 525, 548, 526
323, 526, 549, 527
324, 527, 550, 528
325, 528, 551, 529
326, 529, 552, 530
327, 530, 553, 531
328, 531, 554, 532
329, 532, 555, 533
330, 533, 556, 534
331, 534, 557, 535
332, 535, 558, 536
333, 536, 559, 537
334, 537, 560, 538
335, 538, 561, 13
*ELEMENT, type=T3D3, ELSET=Line22
336, 10, 584, 562
337, 562, 585, 563
338, 563, 586, 564
339, 564, 587, 565
340, 565, 588, 566
341, 566, 589, 567
342, 567, 590, 568
343, 568, 591, 569
344, 569, 592, 570
345, 570, 593, 571
346, 571, 594, 572
347, 572, 595, 573
348, 573, 596, 574
349, 574, 597, 575
350, 575, 598, 576
351, 576, 599, 577
352, 577, 600, 578
353, 578, 601, 579
354, 579, 602, 580
355, 580, 603, 581
356, 581, 604, 582
357, 582, 605, 583
358, 583, 606, 14
*ELEMENT, type=T3D3, ELSET=Line23
359, 14, 629, 607
360, 607, 630, 608
361, 608, 631, 609
362, 609, 632, 610
363, 610, 633, 611
364, 611, 634, 612
365, 612, 635, 613
366, 613, 636, 614
367, 614, 637, 615
368, 615, 638, 616
369, 616, 639, 617
370, 617, 640, 618
371, 618, 641, 619
372, 619, 642, 620
373, 620, 643, 621
374, 621, 644, 622
375, 622, 645, 623
376, 623, 646, 624
377, 624, 647, 625
378, 625, 648, 626
379, 626, 649, 627
380, 627, 650, 628
381, 628, 651, 13
*ELEMENT, type=T3D3, ELSET=Line24
382, 11, 674, 652
383, 652, 675, 653
384, 653, 676, 654
385, 654, 677, 655
386, 655, 678, 656
387, 656, 679, 657
388, 657, 680, 658
389, 658, 681, 659
390, 659, 682, 660
391, 660, 683, 661
392, 661, 684, 662
393, 662, 685, 663
394, 663, 686, 664
395, 664, 687, 665
396, 665, 688, 666
397, 666, 689, 667
398, 667, 690, 668
399, 668, 691, 669
400, 669, 692, 670
401, 670, 693, 671
402, 671, 694, 672
403, 672, 695, 673
404, 673, 696, 15
*ELEMENT, type=T3D3, ELSET=Line25
405, 13, 707, 697
406, 697, 708, 698
407, 698, 709, 699
408, 699, 710, 700
409, 700, 711, 701
410, 701, 712, 702
411, 702, 713, 703
412, 703, 714, 704
413, 704, 715, 705
414, 705, 716, 706
415, 706, 717, 15
*ELEMENT, type=T3D3, ELSET=Line26
416, 12, 740, 718
417, 718, 741, 719
418, 719, 742, 720
419, 720, 743, 721
420, 721, 744, 722
421, 722, 745, 723
422, 723, 746, 724
423, 724, 747, 725
424, 725, 748, 726
425, 726, 749, 727
426, 727, 750, 728
427, 728, 751, 729
428, 729, 752, 730
429, 730, 753, 731
430, 731, 754, 732
431, 732, 755, 733
432, 733, 756, 734
433, 734, 757, 735
434, 735, 758, 736
435, 736, 759, 737
436, 737, 760, 738
437, 738, 761, 739
438, 739, 762, 16
*ELEMENT, type=T3D3, ELSET=Line27
439, 16, 785, 763
440, 763, 786, 764
441, 764, 787, 765
442, 765, 788, 766
443, 766, 789, 767
444, 767, 790, 768
445, 768, 791, 769
446, 769, 792, 770
447, 770, 793, 771
448, 771, 794, 772
449, 772, 795, 773
450, 773, 796, 774
451, 774, 797, 775
452, 775, 798, 776
453, 776, 799, 777
454, 777, 800, 778
455, 778, 801, 779
456, 779, 802, 780
457, 780, 803, 781
458, 781, 804, 782
459, 782, 805, 783
460, 783, 806, 784
461, 784, 807, 15
*ELEMENT, type=T3D3, ELSET=Line28
462, 14, 818, 808
463, 808, 819, 809
464, 809, 820, 810
465, 810, 821, 811
466, 811, 822, 812
467, 812, 823, 813
468, 813, 824, 814
469, 814, 825, 815
470, 815, 826, 816
471, 816, 827, 817
472, 817, 828, 16
*ELEMENT, type=T3D3, ELSET=Line29
473, 13, 830, 829
474, 829, 831, 17
*ELEMENT, type=T3D3, ELSET=Line30
475, 14, 833, 832
476, 832, 834, 18
*ELEMENT, type=T3D3, ELSET=Line31
477, 18, 857, 835
478, 835, 858, 836
479, 836, 859, 837
480, 837, 860, 838
481, 838, 861, 839
482, 839, 862, 840
483, 840, 863, 841
484, 841, 864, 842
485, 842, 865, 843
486, 843, 866, 844
487, 844, 867, 845
488, 845, 868, 846
489, 846, 869, 847
490, 847, 870, 848
491, 848, 871, 849
492, 849, 872, 850
493, 850, 873, 851
494, 851, 874, 852
495, 852, 875, 853
496, 853, 876, 854
497, 854, 877, 855
498, 855, 878, 856
499, 856, 879, 17
*ELEMENT, type=T3D3, ELSET=Line32
500, 15, 881, 880
501, 880, 882, 19
*ELEMENT, type=T3D3, ELSET=Line33
502, 17, 893, 883
503, 883, 894, 884
504, 884, 895, 885
505, 885, 896, 886
506, 886, 897, 887
507, 887, 898, 888
508, 888, 899, 889
509, 889, 900, 890
510, 890, 901, 891
511, 891, 902, 892
512, 892, 903, 19
*ELEMENT, type=T3D3, ELSET=Line34
513, 16, 905, 904
514, 904, 906, 20
*ELEMENT, type=T3D3, ELSET=Line35
515, 20, 929, 907
516, 907, 930, 908
517, 908, 931, 909
518, 909, 932, 910
519, 910, 933, 911
520, 911, 934, 912
521, 912, 935, 913
522, 913, 936, 914
523, 914, 937, 915
524, 915, 938, 916
525, 916, 939, 917
526, 917, 940, 918
527, 918, 941, 919
528, 919, 942, 920
529, 920, 943, 921
530, 921, 944, 922
531, 922, 945, 923
532, 923, 946, 924
533, 924, 947, 925
534, 925, 948, 926
535, 926, 949, 927
536, 927, 950, 928
537, 928, 951, 19
*ELEMENT, type=T3D3, ELSET=Line36
538, 18, 962, 952
539, 952, 963, 953
540, 953, 964, 954
541, 954, 965, 955
542, 955, 966, 956
543, 956, 967, 957
544, 957, 968, 958
545, 958, 969, 959
546, 959, 970, 960
547, 960, 971, 961
548, 961, 972, 20
*ELEMENT, type=T3D3, ELSET=Line37
549, 17, 975, 973
550, 973, 976, 974
551, 974, 977, 21
*ELEMENT, type=T3D3, ELSET=Line38
552, 18, 980, 978
553, 978, 981, 979
554, 979, 982, 22
*ELEMENT, type=T3D3, ELSET=Line39
555, 22, 1005, 983
556, 983, 1006, 984
557, 984, 1007, 985
558, 985, 1008, 986
559, 986, 1009, 987
560, 987, 1010, 988
561, 988, 1011, 989
562, 989, 1012, 990
563, 990, 1013, 991
564, 991, 1014, 992
565, 992, 1015, 993
566, 993, 1016, 994
567, 994, 1017, 995
568, 995, 1018, 996
569, 996, 1019, 997
570, 997, 1020, 998
571, 998, 1021, 999
572, 999, 1022, 1000
573, 1000, 1023, 1001
574, 1001, 1024, 1002
575, 1002, 1025, 1003
576, 1003, 1026, 1004
577, 1004, 1027, 21
*ELEMENT, type=T3D3, ELSET=Line40
578, 19, 1030, 1028
579, 1028, 1031, 1029
580, 1029, 1032, 23
*ELEMENT, type=T3D3, ELSET=Line41
581, 21, 1043, 1033
582, 1033, 1044, 1034
583, 1034, 1045, 1035
584, 1035, 1046, 1036
585, 1036, 1047, 1037
586, 1037, 1048, 1038
587, 1038, 1049, 1039
588, 1039, 1050, 1040
589, 1040, 1051, 1041
590, 1041, 1052, 1042
591, 1042, 1053, 23
*ELEMENT, type=T3D3, ELSET=Line42
592, 20, 1056, 1054
593, 1054, 1057, 1055
594, 1055, 1058, 24
*ELEMENT, type=T3D3, ELSET=Line43
595, 24, 1081, 1059
596, 1059, 1082, 1060
597, 1060, 1083, 1061
598, 1061, 1084, 1062
599, 1062, 1085, 1063
600, 1063, 1086, 1064
601, 1064, 1087, 1065
602, 1065, 1088, 1066
603, 1066, 1089, 1067
604, 1067, 1090, 1068
605, 1068, 1091, 1069
606, 1069, 1092, 1070
607, 1070, 1093, 1071
608, 1071, 1094, 1072
609, 1072, 1095, 1073
610, 1073, 1096, 1074
611, 1074, 1097, 1075
612, 1075, 1098, 1076
613, 1076, 1099, 1077
614, 1077, 1100, 1078
615, 1078, 1101, 1079
616, 1079, 1102, 1080
617, 1080, 1103, 23
*ELEMENT, type=T3D3, ELSET=Line44
618, 22, 1114, 1104
619, 1104, 1115, 1105
620, 1105, 1116, 1106
621, 1106, 1117, 1107
622, 1107, 1118, 1108
623, 1108, 1119, 1109
624, 1109, 1120, 1110
625, 1110, 1121, 1111
626, 1111, 1122, 1112
627, 1112, 1123, 1113
628, 1113, 1124, 24
*ELEMENT, type=T3D3, ELSET=Line45
629, 19, 1129, 1125
630, 1125, 1130, 1126
631, 1126, 1131, 1127
632, 1127, 1132, 1128
633, 1128, 1133, 25
*ELEMENT, type=T3D3, ELSET=Line46
634, 23, 1138, 1134
635, 1134, 1139, 1135
636, 1135, 1140, 1136
637, 1136, 1141, 1137
638, 1137, 1142, 26
*ELEMENT, type=T3D3, ELSET=Line47
639, 25, 1145, 1143
640, 1143, 1146, 1144
641, 1144, 1147, 26
*ELEMENT, type=T3D3, ELSET=Line48
642, 17, 1152, 1148
643, 1148, 1153, 1149
644, 1149, 1154, 1150
645, 1150, 1155, 1151
646, 1151, 1156, 27
*ELEMENT, type=T3D3, ELSET=Line49
647, 21, 1161, 1157
648, 1157, 1162, 1158
649, 1158, 1163, 1159
650, 1159, 1164, 1160
651, 1160, 1165, 28
*ELEMENT, type=T3D3, ELSET=Line50
652, 27, 1168, 1166
653, 1166, 1169, 1167
654, 1167, 1170, 28
*ELEMENT, type=T3D3, ELSET=Line51
655, 27, 1181, 1171
656, 1171, 1182, 1172
657, 1172, 1183, 1173
658, 1173, 1184, 1174
659, 1174, 1185, 1175
660, 1175, 1186, 1176
661, 1176, 1187, 1177
662, 1177, 1188, 1178
663, 1178, 1189, 1179
664, 1179, 1190, 1180
665, 1180, 1191, 25
*ELEMENT, type=T3D3, ELSET=Line52
666, 28, 1202, 1192
667, 1192, 1203, 1193
668, 1193, 1204, 1194
669, 1194, 1205, 1195
670, 1195, 1206, 1196
671, 1196, 1207, 1197
672, 1197, 1208, 1198
673, 1198, 1209, 1199
674, 1199, 1210, 1200
675, 1200, 1211, 1201
676, 1201, 1212, 26
*ELEMENT, type=T3D3, ELSET=Line53
677, 25, 1235, 1213
678, 1213, 1236, 1214
679, 1214, 1237, 1215
680, 1215, 1238, 1216
681, 1216, 1239, 1217
682, 1217, 1240, 1218
683, 1218, 1241, 1219
684, 1219, 1242, 1220
685, 1220, 1243, 1221
686, 1221, 1244, 1222
687, 1222, 1245, 1223
688, 1223, 1246, 1224
689, 1224, 1247, 1225
690, 1225, 1248, 1226
691, 1226, 1249, 1227
692, 1227, 1250, 1228
693, 1228, 1251, 1229
694, 1229, 1252, 1230
695, 1230, 1253, 1231
696, 1231, 1254, 1232
697, 1232, 1255, 1233
698, 1233, 1256, 1234
699, 1234, 1257, 29
*ELEMENT, type=T3D3, ELSET=Line54
700, 26, 1280, 1258
701, 1258, 1281, 1259
702, 1259, 1282, 1260
703, 1260, 1283, 1261
704, 1261, 1284, 1262
705, 1262, 1285, 1263
706, 1263, 1286, 1264
707, 1264, 1287, 1265
708, 1265, 1288, 1266
709, 1266, 1289, 1267
710, 1267, 1290, 1268
711, 1268, 1291, 1269
712, 1269, 1292, 1270
713, 1270, 1293, 1271
714, 1271, 1294, 1272
715, 1272, 1295, 1273
716, 1273, 1296, 1274
717, 1274, 1297, 1275
718, 1275, 1298, 1276
719, 1276, 1299, 1277
720, 1277, 1300, 1278
721, 1278, 1301, 1279
722, 1279, 1302, 30
*ELEMENT, type=T3D3, ELSET=Line55
723, 29, 1305, 1303
724, 1303, 1306, 1304
725, 1304, 1307, 30
*ELEMENT, type=T3D3, ELSET=Line56
726, 27, 1330, 1308
727, 1308, 1331, 1309
728, 1309, 1332, 1310
729, 1310, 1333, 1311
730, 1311, 1334, 1312
731, 1312, 1335, 1313
732, 1313, 1336, 1314
733, 1314, 1337, 1315
734, 1315, 1338, 1316
735, 1316, 1339, 1317
736, 1317, 1340, 1318
737, 1318, 1341, 1319
738, 1319, 1342, 1320
739, 1320, 1343, 1321
740, 1321, 1344, 1322
741, 1322, 1345, 1323
742, 1323, 1346, 1324
743, 1324, 1347, 1325
744, 1325, 1348, 1326
745, 1326, 1349, 1327
746, 1327, 1350, 1328
747, 1328, 1351, 1329
748, 1329, 1352, 31
*ELEMENT, type=T3D3, ELSET=Line57
749, 28, 1375, 1353
750, 1353, 1376, 1354
751, 1354, 1377, 1355
752, 1355, 1378, 1356
753, 1356, 1379, 1357
754, 1357, 1380, 1358
755, 1358, 1381, 1359
756, 1359, 1382, 1360
757, 1360, 1383, 1361
758, 1361, 1384, 1362
759, 1362, 1385, 1363
760, 1363, 1386, 1364
761, 1364, 1387, 1365
762, 1365, 1388, 1366
763, 1366, 1389, 1367
764, 1367, 1390, 1368
765, 1368, 1391, 1369
766, 1369, 1392, 1370
767, 1370, 1393, 1371
768, 1371, 1394, 1372
769, 1372, 1395, 1373
770, 1373, 1396, 1374
771, 1374, 1397, 32
*ELEMENT, type=T3D3, ELSET=Line58
772, 31, 1400, 1398
773, 1398, 1401, 1399
774, 1399, 1402, 32
*ELEMENT, type=T3D3, ELSET=Line59
775, 31, 1413, 1403
776, 1403, 1414, 1404
777, 1404, 1415, 1405
778, 1405, 1416, 1406
779, 1406, 1417, 1407
780, 1407, 1418, 1408
781, 1408, 1419, 1409
782, 1409, 1420, 1410
783, 1410, 1421, 1411
784, 1411, 1422, 1412
785, 1412, 1423, 29
*ELEMENT, type=T3D3, ELSET=Line60
786, 32, 1434, 1424
787, 1424, 1435, 1425
788, 1425, 1436, 1426
789, 1426, 1437, 1427
790, 1427, 1438, 1428
791, 1428, 1439, 1429
792, 1429, 1440, 1430
793, 1430, 1441, 1431
794, 1431, 1442, 1432
795, 1432, 1443, 1433
796, 1433, 1444, 30
*ELEMENT, type=T3D3, ELSET=Line61
797, 25, 1446, 1445
798, 1445, 1447, 33
*ELEMENT, type=T3D3, ELSET=Line62
799, 29, 1449, 1448
800, 1448, 1450, 34
*ELEMENT, type=T3D3, ELSET=Line63
801, 33, 1473, 1451
802, 1451, 1474, 1452
803, 1452, 1475, 1453
804, 1453, 1476, 1454
805, 1454, 1477, 1455
806, 1455, 1478, 1456
807, 1456, 1479, 1457
808, 1457, 1480, 1458
809, 1458, 1481, 1459
810, 1459, 1482, 1460
811, 1460, 1483, 1461
812, 1461, 1484, 1462
813, 1462, 1485, 1463
814, 1463, 1486, 1464
815, 1464, 1487, 1465
816, 1465, 1488, 1466
817, 1466, 1489, 1467
818, 1467, 1490, 1468
819, 1468, 1491, 1469
820, 1469, 1492, 1470
821, 1470, 1493, 1471
822, 1471, 1494, 1472
823, 1472, 1495, 34
*ELEMENT, type=T3D3, ELSET=Line64
824, 27, 1497, 1496
825, 1496, 1498, 35
*ELEMENT, type=T3D3, ELSET=Line65
826, 31, 1500, 1499
827, 1499, 1501, 36
*ELEMENT, type=T3D3, ELSET=Line66
828, 35, 1524, 1502
829, 1502, 1525, 1503
830, 1503, 1526, 1504
831, 1504, 1527, 1505
832, 1505, 1528, 1506
833, 1506, 1529, 1507
834, 1507, 1530, 1508
835, 1508, 1531, 1509
836, 1509, 1532, 1510
837, 1510, 1533, 1511
838, 1511, 1534, 1512
839, 1512, 1535, 1513
840, 1513, 1536, 1514
841, 1514, 1537, 1515
842, 1515, 1538, 1516
843, 1516, 1539, 1517
844, 1517, 1540, 1518
845, 1518, 1541, 1519
846, 1519, 1542, 1520
847, 1520, 1543, 1521
848, 1521, 1544, 1522
849, 1522, 1545, 1523
850, 1523, 1546, 36
*ELEMENT, type=T3D3, ELSET=Line67
851, 35, 1557, 1547
852, 1547, 1558, 1548
853, 1548, 1559, 1549
854, 1549, 1560, 1550
855, 1550, 1561, 1551
856, 1551, 1562, 1552
857, 1552, 1563, 1553
858, 1553, 1564, 1554
859, 1554, 1565, 1555
860, 1555, 1566, 1556
861, 1556, 1567, 33
*ELEMENT, type=T3D3, ELSET=Line68
862, 36, 1578, 1568
863, 1568, 1579, 1569
864, 1569, 1580, 1570
865, 1570, 1581, 1571
866, 1571, 1582, 1572
867, 1572, 1583, 1573
868, 1573, 1584, 1574
869, 1574, 1585, 1575
870, 1575, 1586, 1576
871, 1576, 1587, 1577
872, 1577, 1588, 34
*ELEMENT, type=T3D3, ELSET=Line69
873, 33, 1611, 1589
874, 1589, 1612, 1590
875, 1590, 1613, 1591
876, 1591, 1614, 1592
877, 1592, 1615, 1593
878, 1593, 1616, 1594
879, 1594, 1617, 1595
880, 1595, 1618, 1596
881, 1596, 1619, 1597
882, 1597, 1620, 1598
883, 1598, 1621, 1599
884, 1599, 1622, 1600
885, 1600, 1623, 1601
886, 1601, 1624, 1602
887, 1602, 1625, 1603
888, 1603, 1626, 1604
889, 1604, 1627, 1605
890, 1605, 1628, 1606
891, 1606, 1629, 1607
892, 1607, 1630, 1608
893, 1608, 1631, 1609
894, 1609, 1632, 1610
895, 1610, 1633, 37
*ELEMENT, type=T3D3, ELSET=Line70
896, 34, 1656, 1634
897, 1634, 1657, 1635
898, 1635, 1658, 1636
899, 1636, 1659, 1637
900, 1637, 1660, 1638
901, 1638, 1661, 1639
902, 1639, 1662, 1640
903, 1640, 1663, 1641
904, 1641, 1664, 1642
905, 1642, 1665, 1643
906, 1643, 1666, 1644
907, 1644, 1667, 1645
908, 1645, 1668, 1646
909, 1646, 1669, 1647
910, 1647, 1670, 1648
911, 1648, 1671, 1649
912, 1649, 1672, 1650
913, 1650, 1673, 1651
914, 1651, 1674, 1652
915, 1652, 1675, 1653
916, 1653, 1676, 1654
917, 1654, 1677, 1655
918, 1655, 1678, 38
*ELEMENT, type=T3D3, ELSET=Line71
919, 37, 1701, 1679
920, 1679, 1702, 1680
921, 1680, 1703, 1681
922, 1681, 1704, 1682
923, 1682, 1705, 1683
924, 1683, 1706, 1684
925, 1684, 1707, 1685
926, 1685, 1708, 1686
927, 1686, 1709, 1687
928, 1687, 1710, 1688
929, 1688, 1711, 1689
930, 1689, 1712, 1690
931, 1690, 1713, 1691
932, 1691, 1714, 1692
933, 1692, 1715, 1693
934, 1693, 1716, 1694
935, 1694, 1717, 1695
936, 1695, 1718, 1696
937, 1696, 1719, 1697
938, 1697, 1720, 1698
939, 1698, 1721, 1699
940, 1699, 1722, 1700
941, 1700, 1723, 38
*ELEMENT, type=T3D3, ELSET=Line72
942, 35, 1746, 1724
943, 1724, 1747, 1725
944, 1725, 1748, 1726
945, 1726, 1749, 1727
946, 1727, 1750, 1728
947, 1728, 1751, 1729
948, 1729, 1752, 1730
949, 1730, 1753, 1731
950, 1731, 1754, 1732
951, 1732, 1755, 1733
952, 1733, 1756, 1734
953, 1734, 1757, 1735
954, 1735, 1758, 1736
955, 1736, 1759, 1737
956, 1737, 1760, 1738
957, 1738, 1761, 1739
958, 1739, 1762, 1740
959, 1740, 1763, 1741
960, 1741, 1764, 1742
961, 1742, 1765, 1743
962, 1743, 1766, 1744
963, 1744, 1767, 1745
964, 1745, 1768, 39
*ELEMENT, type=T3D3, ELSET=Line73
965, 36, 1791, 1769
966, 1769, 1792, 1770
967, 1770, 1793, 1771
968, 1771, 1794, 1772
969, 1772, 1795, 1773
970, 1773, 1796, 1774
971, 1774, 1797, 1775
972, 1775, 1798, 1776
973, 1776, 1799, 1777
974, 1777, 1800, 1778
975, 1778, 1801, 1779
976, 1779, 1802, 1780
977, 1780, 1803, 1781
978, 1781, 1804, 1782
979, 1782, 1805, 1783
980, 1783, 1806, 1784
981, 1784, 1807, 1785
982, 1785, 1808, 1786
983, 1786, 1809, 1787
984, 1787, 1810, 1788
985, 1788, 1811, 1789
986, 1789, 1812, 1790
987, 1790, 1813, 40
*ELEMENT, type=T3D3, ELSET=Line74
988, 39, 1836, 1814
989, 1814, 1837, 1815
990, 1815, 1838, 1816
991, 1816, 1839, 1817
992, 1817, 1840, 1818
993, 1818, 1841, 1819
994, 1819, 1842, 1820
995, 1820, 1843, 1821
996, 1821, 1844, 1822
997, 1822, 1845, 1823
998, 1823, 1846, 1824
999, 1824, 1847, 1825
1000, 1825, 1848, 1826
1001, 1826, 1849, 1827
1002, 1827, 1850, 1828
1003, 1828, 1851, 1829
1004, 1829, 1852, 1830
1005, 1830, 1853, 1831
1006, 1831, 1854, 1832
1007, 1832, 1855, 1833
1008, 1833, 1856, 1834
1009, 1834, 1857, 1835
1010, 1835, 1858, 40
*ELEMENT, type=T3D3, ELSET=Line75
1011, 39, 1869, 1859
1012, 1859, 1870, 1860
1013, 1860, 1871, 1861
1014, 1861, 1872, 1862
1015, 1862, 1873, 1863
1016, 1863, 1874, 1864
1017, 1864, 1875, 1865
1018, 1865, 1876, 1866
1019, 1866, 1877, 1867
1020, 1867, 1878, 1868
1021, 1868, 1879, 37
*ELEMENT, type=T3D3, ELSET=Line76
1022, 40, 1890, 1880
1023, 1880, 1891, 1881
1024, 1881, 1892, 1882
1025, 1882, 1893, 1883
1026, 1883, 1894, 1884
1027, 1884, 1895, 1885
1028, 1885, 1896, 1886
1029, 1886, 1897, 1887
1030, 1887, 1898, 1888
1031, 1888, 1899, 1889
1032, 1889, 1900, 38
*ELEMENT, type=T3D3, ELSET=Line77
1033, 37, 1902, 1901
1034, 1901, 1903, 41
*ELEMENT, type=T3D3, ELSET=Line78
1035, 38, 1905, 1904
1036, 1904, 1906, 42
*ELEMENT, type=T3D3, ELSET=Line79
1037, 41, 1929, 1907
1038, 1907, 1930, 1908
1039, 1908, 1931, 1909
1040, 1909, 1932, 1910
1041, 1910, 1933, 1911
1042, 1911, 1934, 1912
1043, 1912, 1935, 1913
1044, 1913, 1936, 1914
1045, 1914, 1937, 1915
1046, 1915, 1938, 1916
1047, 1916, 1939, 1917
1048, 1917, 1940, 1918
1049, 1918, 1941, 1919
1050, 1919, 1942, 1920
1051, 1920, 1943, 1921
1052, 1921, 1944, 1922
1053, 1922, 1945, 1923
1054, 1923, 1946, 1924
1055, 1924, 1947, 1925
1056, 1925, 1948, 1926
1057, 1926, 1949, 1927
1058, 1927, 1950, 1928
1059, 1928, 1951, 42
*ELEMENT, type=T3D3, ELSET=Line80
1060, 39, 1953, 1952
1061, 1952, 1954, 43
*ELEMENT, type=T3D3, ELSET=Line81
1062, 40, 1956, 1955
1063, 1955, 1957, 44
*ELEMENT, type=T3D3, ELSET=Line82
1064, 43, 1980, 1958
1065, 1958, 1981, 1959
1066, 1959, 1982, 1960
1067, 1960, 1983, 1961
1068, 1961, 1984, 1962
1069, 1962, 1985, 1963
1070, 1963, 1986, 1964
1071, 1964, 1987, 1965
1072, 1965, 1988, 1966
1073, 1966, 1989, 1967
1074, 1967, 1990, 1968
1075, 1968, 1991, 1969
1076, 1969, 1992, 1970
1077, 1970, 1993, 1971
1078, 1971, 1994, 1972
1079, 1972, 1995, 1973
1080, 1973, 1996, 1974
1081, 1974, 1997, 1975
1082, 1975, 1998, 1976
1083, 1976, 1999, 1977
1084, 1977, 2000, 1978
1085, 1978, 2001, 1979
1086, 1979, 2002, 44
*ELEMENT, type=T3D3, ELSET=Line83
1087, 43, 2013, 2003
1088, 2003, 2014, 2004
1089, 2004, 2015, 2005
1090, 2005, 2016, 2006
1091, 2006, 2017, 2007
1092, 2007, 2018, 2008
1093, 2008, 2019, 2009
1094, 2009, 2020, 2010
1095, 2010, 2021, 2011
1096, 2011, 2022, 2012
1097, 2012, 2023, 41
*ELEMENT, type=T3D3, ELSET=Line84
1098, 44, 2034, 2024
1099, 2024, 2035, 2025
1100, 2025, 2036, 2026
1101, 2026, 2037, 2027
1102, 2027, 2038, 2028
1103, 2028, 2039, 2029
1104, 2029, 2040, 2030
1105, 2030, 2041, 2031
1106, 2031, 2042, 2032
1107, 2032, 2043, 2033
1108, 2033, 2044, 42
*ELEMENT, type=T3D3, ELSET=Line86
1109, 42, 2047, 2045
1110, 2045, 2048, 2046
1111, 2046, 2049, 45
*ELEMENT, type=T3D3, ELSET=Line89
1112, 44, 2052, 2050
1113, 2050, 2053, 2051
1114, 2051, 2054, 46
*ELEMENT, type=T3D3, ELSET=Line92
1115, 46, 2065, 2055
1116, 2055, 2066, 2056
1117, 2056, 2067, 2057
1118, 2057, 2068, 2058
1119, 2058, 2069, 2059
1120, 2059, 2070, 2060
1121, 2060, 2071, 2061
1122, 2061, 2072, 2062
1123, 2062, 2073, 2063
1124, 2063, 2074, 2064
1125, 2064, 2075, 45
*ELEMENT, type=T3D3, ELSET=Line93
1126, 42, 2078, 2076
1127, 2076, 2079, 2077
1128, 2077, 2080, 47
*ELEMENT, type=T3D3, ELSET=Line94
1129, 45, 2083, 2081
1130, 2081, 2084, 2082
1131, 2082, 2085, 48
*ELEMENT, type=T3D3, ELSET=Line95
1132, 47, 2088, 2086
1133, 2086, 2089, 2087
1134, 2087, 2090, 48
*ELEMENT, type=T3D3, ELSET=Line96
1135, 44, 2093, 2091
1136, 2091, 2094, 2092
1137, 2092, 2095, 49
*ELEMENT, type=T3D3, ELSET=Line97
1138, 46, 2098, 2096
1139, 2096, 2099, 2097
1140, 2097, 2100, 50
*ELEMENT, type=T3D3, ELSET=Line98
1141, 49, 2103, 2101
1142, 2101, 2104, 2102
1143, 2102, 2105, 50
*ELEMENT, type=T3D3, ELSET=Line99
1144, 49, 2116, 2106
1145, 2106, 2117, 2107
1146, 2107, 2118, 2108
1147, 2108, 2119, 2109
1148, 2109, 2120, 2110
1149, 2110, 2121, 2111
1150, 2111, 2122, 2112
1151, 2112, 2123, 2113
1152, 2113, 2124, 2114
1153, 2114, 2125, 2115
1154, 2115, 2126, 47
*ELEMENT, type=T3D3, ELSET=Line100
1155, 50, 2137, 2127
1156, 2127, 2138, 2128
1157, 2128, 2139, 2129
1158, 2129, 2140, 2130
1159, 2130, 2141, 2131
1160, 2131, 2142, 2132
1161, 2132, 2143, 2133
1162, 2133, 2144, 2134
1163, 2134, 2145, 2135
1164, 2135, 2146, 2136
1165, 2136, 2147, 48
*ELEMENT, type=T3D3, ELSET=Line101
1166, 1, 2150, 2148
1167, 2148, 2151, 2149
1168, 2149, 2152, 51
*ELEMENT, type=T3D3, ELSET=Line102
1169, 2, 2155, 2153
1170, 2153, 2156, 2154
1171, 2154, 2157, 52
*ELEMENT, type=T3D3, ELSET=Line103
1172, 52, 2168, 2158
1173, 2158, 2169, 2159
1174, 2159, 2170, 2160
1175, 2160, 2171, 2161
1176, 2161, 2172, 2162
1177, 2162, 2173, 2163
1178, 2163, 2174, 2164
1179, 2164, 2175, 2165
1180, 2165, 2176, 2166
1181, 2166, 2177, 2167
1182, 2167, 2178, 51
*ELEMENT, type=T3D3, ELSET=Line104
1183, 3, 2181, 2179
1184, 2179, 2182, 2180
1185, 2180, 2183, 53
*ELEMENT, type=T3D3, ELSET=Line105
1186, 51, 2186, 2184
1187, 2184, 2187, 2185
1188, 2185, 2188, 53
*ELEMENT, type=T3D3, ELSET=Line106
1189, 4, 2191, 2189
1190, 2189, 2192, 2190
1191, 2190, 2193, 54
*ELEMENT, type=T3D3, ELSET=Line107
1192, 54, 2204, 2194
1193, 2194, 2205, 2195
1194, 2195, 2206, 2196
1195, 2196, 2207, 2197
1196, 2197, 2208, 2198
1197, 2198, 2209, 2199
1198, 2199, 2210, 2200
1199, 2200, 2211, 2201
1200, 2201, 2212, 2202
1201, 2202, 2213, 2203
1202, 2203, 2214, 53
*ELEMENT, type=T3D3, ELSET=Line108
1203, 52, 2217, 2215
1204, 2215, 2218, 2216
1205, 2216, 2219, 54
*ELEMENT, type=T3D3, ELSET=Line167
1206, 21, 2223, 2220
1207, 2220, 2224, 2221
1208, 2221, 2225, 2222
1209, 2222, 2226, 55
*ELEMENT, type=T3D3, ELSET=Line168
1210, 22, 2230, 2227
1211, 2227, 2231, 2228
1212, 2228, 2232, 2229
1213, 2229, 2233, 56
*ELEMENT, type=T3D3, ELSET=Line169
1214, 56, 2256, 2234
1215, 2234, 2257, 2235
1216, 2235, 2258, 2236
1217, 2236, 2259, 2237
1218, 2237, 2260, 2238
1219, 2238, 2261, 2239
1220, 2239, 2262, 2240
1221, 2240, 2263, 2241
1222, 2241, 2264, 2242
1223, 2242, 2265, 2243
1224, 2243, 2266, 2244
1225, 2244, 2267, 2245
1226, 2245, 2268, 2246
1227, 2246, 2269, 2247
1228, 2247, 2270, 2248
1229, 2248, 2271, 2249
1230, 2249, 2272, 2250
1231, 2250, 2273, 2251
1232, 2251, 2274, 2252
1233, 2252, 2275, 2253
1234, 2253, 2276, 2254
1235, 2254, 2277, 2255
1236, 2255, 2278, 55
*ELEMENT, type=T3D3, ELSET=Line170
1237, 23, 2282, 2279
1238, 2279, 2283, 2280
1239, 2280, 2284, 2281
1240, 2281, 2285, 57
*ELEMENT, type=T3D3, ELSET=Line171
1241, 55, 2296, 2286
1242, 2286, 2297, 2287
1243, 2287, 2298, 2288
1244, 2288, 2299, 2289
1245, 2289, 2300, 2290
1246, 2290, 2301, 2291
1247, 2291, 2302, 2292
1248, 2292, 2303, 2293
1249, 2293, 2304, 2294
1250, 2294, 2305, 2295
1251, 2295, 2306, 57
*ELEMENT, type=T3D3, ELSET=Line172
1252, 24, 2310, 2307
1253, 2307, 2311, 2308
1254, 2308, 2312, 2309
1255, 2309, 2313, 58
*ELEMENT, type=T3D3, ELSET=Line173
1256, 58, 2336, 2314
1257, 2314, 2337, 2315
1258, 2315, 2338, 2316
1259, 2316, 2339, 2317
1260, 2317, 2340, 2318
1261, 2318, 2341, 2319
1262, 2319, 2342, 2320
1263, 2320, 2343, 2321
1264, 2321, 2344, 2322
1265, 2322, 2345, 2323
1266, 2323, 2346, 2324
1267, 2324, 2347, 2325
1268, 2325, 2348, 2326
1269, 2326, 2349, 2327
1270, 2327, 2350, 2328
1271, 2328, 2351, 2329
1272, 2329, 2352, 2330
1273, 2330, 2353, 2331
1274, 2331, 2354, 2332
1275, 2332, 2355, 2333
1276, 2333, 2356, 2334
1277, 2334, 2357, 2335
1278, 2335, 2358, 57
*ELEMENT, type=T3D3, ELSET=Line174
1279, 56, 2369, 2359
1280, 2359, 2370, 2360
1281, 2360, 2371, 2361
1282, 2361, 2372, 2362
1283, 2362, 2373, 2363
1284, 2363, 2374, 2364
1285, 2364, 2375, 2365
1286, 2365, 2376, 2366
1287, 2366, 2377, 2367
1288, 2367, 2378, 2368
1289, 2368, 2379, 58
*ELEMENT, type=T3D3, ELSET=Line175
1290, 26, 2383, 2380
1291, 2380, 2384, 2381
1292, 2381, 2385, 2382
1293, 2382, 2386, 59
*ELEMENT, type=T3D3, ELSET=Line176
1294, 57, 2391, 2387
1295, 2387, 2392, 2388
1296, 2388, 2393, 2389
1297, 2389, 2394, 2390
1298, 2390, 2395, 59
*ELEMENT, type=T3D3, ELSET=Line177
1299, 28, 2399, 2396
1300, 2396, 2400, 2397
1301, 2397, 2401, 2398
1302, 2398, 2402, 60
*ELEMENT, type=T3D3, ELSET=Line178
1303, 55, 2407, 2403
1304, 2403, 2408, 2404
1305, 2404, 2409, 2405
1306, 2405, 2410, 2406
1307, 2406, 2411, 60
*ELEMENT, type=T3D3, ELSET=Line179
1308, 60, 2422, 2412
1309, 2412, 2423, 2413
1310, 2413, 2424, 2414
1311, 2414, 2425, 2415
1312, 2415, 2426, 2416
1313, 2416, 2427, 2417
1314, 2417, 2428, 2418
1315, 2418, 2429, 2419
1316, 2419, 2430, 2420
1317, 2420, 2431, 2421
1318, 2421, 2432, 59
*ELEMENT, type=T3D3, ELSET=Line180
1319, 30, 2436, 2433
1320, 2433, 2437, 2434
1321, 2434, 2438, 2435
1322, 2435, 2439, 61
*ELEMENT, type=T3D3, ELSET=Line181
1323, 59, 2462, 2440
1324, 2440, 2463, 2441
1325, 2441, 2464, 2442
1326, 2442, 2465, 2443
1327, 2443, 2466, 2444
1328, 2444, 2467, 2445
1329, 2445, 2468, 2446
1330, 2446, 2469, 2447
1331, 2447, 2470, 2448
1332, 2448, 2471, 2449
1333, 2449, 2472, 2450
1334, 2450, 2473, 2451
1335, 2451, 2474, 2452
1336, 2452, 2475, 2453
1337, 2453, 2476, 2454
1338, 2454, 2477, 2455
1339, 2455, 2478, 2456
1340, 2456, 2479, 2457
1341, 2457, 2480, 2458
1342, 2458, 2481, 2459
1343, 2459, 2482, 2460
1344, 2460, 2483, 2461
1345, 2461, 2484, 61
*ELEMENT, type=T3D3, ELSET=Line182
1346, 32, 2488, 2485
1347, 2485, 2489, 2486
1348, 2486, 2490, 2487
1349, 2487, 2491, 62
*ELEMENT, type=T3D3, ELSET=Line183
1350, 60, 2514, 2492
1351, 2492, 2515, 2493
1352, 2493, 2516, 2494
1353, 2494, 2517, 2495
1354, 2495, 2518, 2496
1355, 2496, 2519, 2497
1356, 2497, 2520, 2498
1357, 2498, 2521, 2499
1358, 2499, 2522, 2500
1359, 2500, 2523, 2501
1360, 2501, 2524, 2502
1361, 2502, 2525, 2503
1362, 2503, 2526, 2504
1363, 2504, 2527, 2505
1364, 2505, 2528, 2506
1365, 2506, 2529, 2507
1366, 2507, 2530, 2508
1367, 2508, 2531, 2509
1368, 2509, 2532, 2510
1369, 2510, 2533, 2511
1370, 2511, 2534, 2512
1371, 2512, 2535, 2513
1372, 2513, 2536, 62
*ELEMENT, type=T3D3, ELSET=Line184
1373, 62, 2547, 2537
1374, 2537, 2548, 2538
1375, 2538, 2549, 2539
1376, 2539, 2550, 2540
1377, 2540, 2551, 2541
1378, 2541, 2552, 2542
1379, 2542, 2553, 2543
1380, 2543, 2554, 2544
1381, 2544, 2555, 2545
1382, 2545, 2556, 2546
1383, 2546, 2557, 61
*ELEMENT, type=T3D3, ELSET=Line185
1384, 6, 2561, 2558
1385, 2558, 2562, 2559
1386, 2559, 2563, 2560
1387, 2560, 2564, 63
*ELEMENT, type=T3D3, ELSET=Line186
1388, 2, 2568, 2565
1389, 2565, 2569, 2566
1390, 2566, 2570, 2567
1391, 2567, 2571, 64
*ELEMENT, type=T3D3, ELSET=Line187
1392, 64, 2594, 2572
1393, 2572, 2595, 2573
1394, 2573, 2596, 2574
1395, 2574, 2597, 2575
1396, 2575, 2598, 2576
1397, 2576, 2599, 2577
1398, 2577, 2600, 2578
1399, 2578, 2601, 2579
1400, 2579, 2602, 2580
1401, 2580, 2603, 2581
1402, 2581, 2604, 2582
1403, 2582, 2605, 2583
1404, 2583, 2606, 2584
1405, 2584, 2607, 2585
1406, 2585, 2608, 2586
1407, 2586, 2609, 2587
1408, 2587, 2610, 2588
1409, 2588, 2611, 2589
1410, 2589, 2612, 2590
1411, 2590, 2613, 2591
1412, 2591, 2614, 2592
1413, 2592, 2615, 2593
1414, 2593, 2616, 63
*ELEMENT, type=T3D3, ELSET=Line188
1415, 5, 2620, 2617
1416, 2617, 2621, 2618
1417, 2618, 2622, 2619
1418, 2619, 2623, 65
*ELEMENT, type=T3D3, ELSET=Line189
1419, 63, 2634, 2624
1420, 2624, 2635, 2625
1421, 2625, 2636, 2626
1422, 2626, 2637, 2627
1423, 2627, 2638, 2628
1424, 2628, 2639, 2629
1425, 2629, 2640, 2630
1426, 2630, 2641, 2631
1427, 2631, 2642, 2632
1428, 2632, 2643, 2633
1429, 2633, 2644, 65
*ELEMENT, type=T3D3, ELSET=Line190
1430, 1, 2648, 2645
1431, 2645, 2649, 2646
1432, 2646, 2650, 2647
1433, 2647, 2651, 66
*ELEMENT, type=T3D3, ELSET=Line191
1434, 66, 2674, 2652
1435, 2652, 2675, 2653
1436, 2653, 2676, 2654
1437, 2654, 2677, 2655
1438, 2655, 2678, 2656
1439, 2656, 2679, 2657
1440, 2657, 2680, 2658
1441, 2658, 2681, 2659
1442, 2659, 2682, 2660
1443, 2660, 2683, 2661
1444, 2661, 2684, 2662
1445, 2662, 2685, 2663
1446, 2663, 2686, 2664
1447, 2664, 2687, 2665
1448, 2665, 2688, 2666
1449, 2666, 2689, 2667
1450, 2667, 2690, 2668
1451, 2668, 2691, 2669
1452, 2669, 2692, 2670
1453, 2670, 2693, 2671
1454, 2671, 2694, 2672
1455, 2672, 2695, 2673
1456, 2673, 2696, 65
*ELEMENT, type=T3D3, ELSET=Line192
1457, 64, 2707, 2697
1458, 2697, 2708, 2698
1459, 2698, 2709, 2699
1460, 2699, 2710, 2700
1461, 2700, 2711, 2701
1462, 2701, 2712, 2702
1463, 2702, 2713, 2703
1464, 2703, 2714, 2704
1465, 2704, 2715, 2705
1466, 2705, 2716, 2706
1467, 2706, 2717, 66
*ELEMENT, type=T3D3, ELSET=Line193
1468, 51, 2721, 2718
1469, 2718, 2722, 2719
1470, 2719, 2723, 2720
1471, 2720, 2724, 67
*ELEMENT, type=T3D3, ELSET=Line194
1472, 66, 2727, 2725
1473, 2725, 2728, 2726
1474, 2726, 2729, 67
*ELEMENT, type=T3D3, ELSET=Line195
1475, 52, 2733, 2730
1476, 2730, 2734, 2731
1477, 2731, 2735, 2732
1478, 2732, 2736, 68
*ELEMENT, type=T3D3, ELSET=Line196
1479, 64, 2739, 2737
1480, 2737, 2740, 2738
1481, 2738, 2741, 68
*ELEMENT, type=T3D3, ELSET=Line197
1482, 68, 2752, 2742
1483, 2742, 2753, 2743
1484, 2743, 2754, 2744
1485, 2744, 2755, 2745
1486, 2745, 2756, 2746
1487, 2746, 2757, 2747
1488, 2747, 2758, 2748
1489, 2748, 2759, 2749
1490, 2749, 2760, 2750
1491, 2750, 2761, 2751
1492, 2751, 2762, 67
*ELEMENT, type=T3D3, ELSET=Line199
1493, 45, 2766, 2763
1494, 2763, 2767, 2764
1495, 2764, 2768, 2765
1496, 2765, 2769, 69
*ELEMENT, type=T3D3, ELSET=Line202
1497, 46, 2773, 2770
1498, 2770, 2774, 2771
1499, 2771, 2775, 2772
1500, 2772, 2776, 70
*ELEMENT, type=T3D3, ELSET=Line205
1501, 70, 2787, 2777
1502, 2777, 2788, 2778
1503, 2778, 2789, 2779
1504, 2779, 2790, 2780
1505, 2780, 2791, 2781
1506, 2781, 2792, 2782
1507, 2782, 2793, 2783
1508, 2783, 2794, 2784
1509, 2784, 2795, 2785
1510, 2785, 2796, 2786
1511, 2786, 2797, 69
*ELEMENT, type=T3D3, ELSET=Line206
1512, 48, 2801, 2798
1513, 2798, 2802, 2799
1514, 2799, 2803, 2800
1515, 2800, 2804, 71
*ELEMENT, type=T3D3, ELSET=Line207
1516, 69, 2807, 2805
1517, 2805, 2808, 2806
1518, 2806, 2809, 71
*ELEMENT, type=T3D3, ELSET=Line208
1519, 50, 2813, 2810
1520, 2810, 2814, 2811
1521, 2811, 2815, 2812
1522, 2812, 2816, 72
*ELEMENT, type=T3D3, ELSET=Line209
1523, 70, 2819, 2817
1524, 2817, 2820, 2818
1525, 2818, 2821, 72
*ELEMENT, type=T3D3, ELSET=Line210
1526, 72, 2832, 2822
1527, 2822, 2833, 2823
1528, 2823, 2834, 2824
1529, 2824, 2835, 2825
1530, 2825, 2836, 2826
1531, 2826, 2837, 2827
1532, 2827, 2838, 2828
1533, 2828, 2839, 2829
1534, 2829, 2840, 2830
1535, 2830, 2841, 2831
1536, 2831, 2842, 71
*ELEMENT, type=T3D3, ELSET=Line219
1537, 24, 2845, 2843
1538, 2843, 2846, 2844
1539, 2844, 2847, 73
*ELEMENT, type=T3D3, ELSET=Line220
1540, 58, 2850, 2848
1541, 2848, 2851, 2849
1542, 2849, 2852, 74
*ELEMENT, type=T3D3, ELSET=Line221
1543, 73, 2856, 2853
1544, 2853, 2857, 2854
1545, 2854, 2858, 2855
1546, 2855, 2859, 74
*ELEMENT, type=T3D3, ELSET=Line222
1547, 22, 2862, 2860
1548, 2860, 2863, 2861
1549, 2861, 2864, 75
*ELEMENT, type=T3D3, ELSET=Line223
1550, 56, 2867, 2865
1551, 2865, 2868, 2866
1552, 2866, 2869, 76
*ELEMENT, type=T3D3, ELSET=Line224
1553, 75, 2873, 2870
1554, 2870, 2874, 2871
1555, 2871, 2875, 2872
1556, 2872, 2876, 76
*ELEMENT, type=T3D3, ELSET=Line225
1557, 75, 2887, 2877
1558, 2877, 2888, 2878
1559, 2878, 2889, 2879
1560, 2879, 2890, 2880
1561, 2880, 2891, 2881
1562, 2881, 2892, 2882
1563, 2882, 2893, 2883
1564, 2883, 2894, 2884
1565, 2884, 2895, 2885
1566, 2885, 2896, 2886
1567, 2886, 2897, 73
*ELEMENT, type=T3D3, ELSET=Line226
1568, 76, 2908, 2898
1569, 2898, 2909, 2899
1570, 2899, 2910, 2900
1571, 2900, 2911, 2901
1572, 2901, 2912, 2902
1573, 2902, 2913, 2903
1574, 2903, 2914, 2904
1575, 2904, 2915, 2905
1576, 2905, 2916, 2906
1577, 2906, 2917, 2907
1578, 2907, 2918, 74
*ELEMENT, type=T3D3, ELSET=Line227
1579, 20, 2921, 2919
1580, 2919, 2922, 2920
1581, 2920, 2923, 77
*ELEMENT, type=T3D3, ELSET=Line228
1582, 77, 2926, 2924
1583, 2924, 2927, 2925
1584, 2925, 2928, 73
*ELEMENT, type=T3D3, ELSET=Line229
1585, 18, 2931, 2929
1586, 2929, 2932, 2930
1587, 2930, 2933, 78
*ELEMENT, type=T3D3, ELSET=Line230
1588, 78, 2936, 2934
1589, 2934, 2937, 2935
1590, 2935, 2938, 75
*ELEMENT, type=T3D3, ELSET=Line231
1591, 78, 2949, 2939
1592, 2939, 2950, 2940
1593, 2940, 2951, 2941
1594, 2941, 2952, 2942
1595, 2942, 2953, 2943
1596, 2943, 2954, 2944
1597, 2944, 2955, 2945
1598, 2945, 2956, 2946
1599, 2946, 2957, 2947
1600, 2947, 2958, 2948
1601, 2948, 2959, 77
*ELEMENT, type=T3D3, ELSET=Line232
1602, 30, 2962, 2960
1603, 2960, 2963, 2961
1604, 2961, 2964, 79
*ELEMENT, type=T3D3, ELSET=Line233
1605, 61, 2967, 2965
1606, 2965, 2968, 2966
1607, 2966, 2969, 80
*ELEMENT, type=T3D3, ELSET=Line234
1608, 79, 2973, 2970
1609, 2970, 2974, 2971
1610, 2971, 2975, 2972
1611, 2972, 2976, 80
*ELEMENT, type=T3D3, ELSET=Line235
1612, 32, 2979, 2977
1613, 2977, 2980, 2978
1614, 2978, 2981, 81
*ELEMENT, type=T3D3, ELSET=Line236
1615, 62, 2984, 2982
1616, 2982, 2985, 2983
1617, 2983, 2986, 82
*ELEMENT, type=T3D3, ELSET=Line237
1618, 81, 2990, 2987
1619, 2987, 2991, 2988
1620, 2988, 2992, 2989
1621, 2989, 2993, 82
*ELEMENT, type=T3D3, ELSET=Line238
1622, 81, 3004, 2994
1623, 2994, 3005, 2995
1624, 2995, 3006, 2996
1625, 2996, 3007, 2997
1626, 2997, 3008, 2998
1627, 2998, 3009, 2999
1628, 2999, 3010, 3000
1629, 3000, 3011, 3001
1630, 3001, 3012, 3002
1631, 3002, 3013, 3003
1632, 3003, 3014, 79
*ELEMENT, type=T3D3, ELSET=Line239
1633, 82, 3025, 3015
1634, 3015, 3026, 3016
1635, 3016, 3027, 3017
1636, 3017, 3028, 3018
1637, 3018, 3029, 3019
1638, 3019, 3030, 3020
1639, 3020, 3031, 3021
1640, 3021, 3032, 3022
1641, 3022, 3033, 3023
1642, 3023, 3034, 3024
1643, 3024, 3035, 80
*ELEMENT, type=T3D3, ELSET=Line240
1644, 29, 3038, 3036
1645, 3036, 3039, 3037
1646, 3037, 3040, 83
*ELEMENT, type=T3D3, ELSET=Line241
1647, 83, 3043, 3041
1648, 3041, 3044, 3042
1649, 3042, 3045, 79
*ELEMENT, type=T3D3, ELSET=Line242
1650, 31, 3048, 3046
1651, 3046, 3049, 3047
1652, 3047, 3050, 84
*ELEMENT, type=T3D3, ELSET=Line243
1653, 84, 3053, 3051
1654, 3051, 3054, 3052
1655, 3052, 3055, 81
*ELEMENT, type=T3D3, ELSET=Line244
1656, 84, 3066, 3056
1657, 3056, 3067, 3057
1658, 3057, 3068, 3058
1659, 3058, 3069, 3059
1660, 3059, 3070, 3060
1661, 3060, 3071, 3061
1662, 3061, 3072, 3062
1663, 3062, 3073, 3063
1664, 3063, 3074, 3064
1665, 3064, 3075, 3065
1666, 3065, 3076, 83
*ELEMENT, type=T3D3, ELSET=Line245
1667, 41, 3079, 3077
1668, 3077, 3080, 3078
1669, 3078, 3081, 85
*ELEMENT, type=T3D3, ELSET=Line246
1670, 85, 3104, 3082
1671, 3082, 3105, 3083
1672, 3083, 3106, 3084
1673, 3084, 3107, 3085
1674, 3085, 3108, 3086
1675, 3086, 3109, 3087
1676, 3087, 3110, 3088
1677, 3088, 3111, 3089
1678, 3089, 3112, 3090
1679, 3090, 3113, 3091
1680, 3091, 3114, 3092
1681, 3092, 3115, 3093
1682, 3093, 3116, 3094
1683, 3094, 3117, 3095
1684, 3095, 3118, 3096
1685, 3096, 3119, 3097
1686, 3097, 3120, 3098
1687, 3098, 3121, 3099
1688, 3099, 3122, 3100
1689, 3100, 3123, 3101
1690, 3101, 3124, 3102
1691, 3102, 3125, 3103
1692, 3103, 3126, 45
*ELEMENT, type=T3D3, ELSET=Line247
1693, 43, 3129, 3127
1694, 3127, 3130, 3128
1695, 3128, 3131, 86
*ELEMENT, type=T3D3, ELSET=Line248
1696, 86, 3154, 3132
1697, 3132, 3155, 3133
1698, 3133, 3156, 3134
1699, 3134, 3157, 3135
1700, 3135, 3158, 3136
1701, 3136, 3159, 3137
1702, 3137, 3160, 3138
1703, 3138, 3161, 3139
1704, 3139, 3162, 3140
1705, 3140, 3163, 3141
1706, 3141, 3164, 3142
1707, 3142, 3165, 3143
1708, 3143, 3166, 3144
1709, 3144, 3167, 3145
1710, 3145, 3168, 3146
1711, 3146, 3169, 3147
1712, 3147, 3170, 3148
1713, 3148, 3171, 3149
1714, 3149, 3172, 3150
1715, 3150, 3173, 3151
1716, 3151, 3174, 3152
1717, 3152, 3175, 3153
1718, 3153, 3176, 46
*ELEMENT, type=T3D3, ELSET=Line249
1719, 86, 3187, 3177
1720, 3177, 3188, 3178
1721, 3178, 3189, 3179
1722, 3179, 3190, 3180
1723, 3180, 3191, 3181
1724, 3181, 3192, 3182
1725, 3182, 3193, 3183
1726, 3183, 3194, 3184
1727, 3184, 3195, 3185
1728, 3185, 3196, 3186
1729, 3186, 3197, 85
*ELEMENT, type=T3D3, ELSET=Line250
1730, 85, 3201, 3198
1731, 3198, 3202, 3199
1732, 3199, 3203, 3200
1733, 3200, 3204, 87
*ELEMENT, type=T3D3, ELSET=Line251
1734, 87, 3227, 3205
1735, 3205, 3228, 3206
1736, 3206, 3229, 3207
1737, 3207, 3230, 3208
1738, 3208, 3231, 3209
1739, 3209, 3232, 3210
1740, 3210, 3233, 3211
1741, 3211, 3234, 3212
1742, 3212, 3235, 3213
1743, 3213, 3236, 3214
1744, 3214, 3237, 3215
1745, 3215, 3238, 3216
1746, 3216, 3239, 3217
1747, 3217, 3240, 3218
1748, 3218, 3241, 3219
1749, 3219, 3242, 3220
1750, 3220, 3243, 3221
1751, 3221, 3244, 3222
1752, 3222, 3245, 3223
1753, 3223, 3246, 3224
1754, 3224, 3247, 3225
1755, 3225, 3248, 3226
1756, 3226, 3249, 69
*ELEMENT, type=T3D3, ELSET=Line252
1757, 86, 3253, 3250
1758, 3250, 3254, 3251
1759, 3251, 3255, 3252
1760, 3252, 3256, 88
*ELEMENT, type=T3D3, ELSET=Line253
1761, 88, 3279, 3257
1762, 3257, 3280, 3258
1763, 3258, 3281, 3259
1764, 3259, 3282, 3260
1765, 3260, 3283, 3261
1766, 3261, 3284, 3262
1767, 3262, 3285, 3263
1768, 3263, 3286, 3264
1769, 3264, 3287, 3265
1770, 3265, 3288, 3266
1771, 3266, 3289, 3267
1772, 3267, 3290, 3268
1773, 3268, 3291, 3269
1774, 3269, 3292, 3270
1775, 3270, 3293, 3271
1776, 3271, 3294, 3272
1777, 3272, 3295, 3273
1778, 3273, 3296, 3274
1779, 3274, 3297, 3275
1780, 3275, 3298, 3276
1781, 3276, 3299, 3277
1782, 3277, 3300, 3278
1783, 3278, 3301, 70
*ELEMENT, type=T3D3, ELSET=Line254
1784, 88, 3312, 3302
1785, 3302, 3313, 3303
1786, 3303, 3314, 3304
1787, 3304, 3315, 3305
1788, 3305, 3316, 3306
1789, 3306, 3317, 3307
1790, 3307, 3318, 3308
1791, 3308, 3319, 3309
1792, 3309, 3320, 3310
1793, 3310, 3321, 3311
1794, 3311, 3322, 87
*ELEMENT, type=T3D3, ELSET=Line255
1795, 5, 3327, 3323
1796, 3323, 3328, 3324
1797, 3324, 3329, 3325
1798, 3325, 3330, 3326
1799, 3326, 3331, 85
*ELEMENT, type=T3D3, ELSET=Line256
1800, 65, 3336, 3332
1801, 3332, 3337, 3333
1802, 3333, 3338, 3334
1803, 3334, 3339, 3335
1804, 3335, 3340, 87
*ELEMENT, type=T3D3, ELSET=Line257
1805, 6, 3345, 3341
1806, 3341, 3346, 3342
1807, 3342, 3347, 3343
1808, 3343, 3348, 3344
1809, 3344, 3349, 86
*ELEMENT, type=T3D3, ELSET=Line258
1810, 63, 3354, 3350
1811, 3350, 3355, 3351
1812, 3351, 3356, 3352
1813, 3352, 3357, 3353
1814, 3353, 3358, 88
*ELEMENT, type=CPS8, ELSET=Surface1
1815, 2, 89, 3359, 136, 99, 3379, 3380, 138
1816, 136, 3359, 3360, 137, 3380, 3381, 3382, 139
1817, 137, 3360, 115, 4, 3382, 3383, 125, 140
1818, 89, 90, 3361, 3359, 100, 3384, 3385, 3379
1819, 3359, 3361, 3362, 3360, 3385, 3386, 3387, 3381
1820, 3360, 3362, 116, 115, 3387, 3388, 126, 3383
1821, 90, 91, 3363, 3361, 101, 3389, 3390, 3384
1822, 3361, 3363, 3364, 3362, 3390, 3391, 3392, 3386
1823, 3362, 3364, 117, 116, 3392, 3393, 127, 3388
1824, 91, 92, 3365, 3363, 102, 3394, 3395, 3389
1825, 3363, 3365, 3366, 3364, 3395, 3396, 3397, 3391
1826, 3364, 3366, 118, 117, 3397, 3398, 128, 3393
1827, 92, 93, 3367, 3365, 103, 3399, 3400, 3394
1828, 3365, 3367, 3368, 3366, 3400, 3401, 3402, 3396
1829, 3366, 3368, 119, 118, 3402, 3403, 129, 3398
1830, 93, 94, 3369, 3367, 104, 3404, 3405, 3399
1831, 3367, 3369, 3370, 3368, 3405, 3406, 3407, 3401
1832, 3368, 3370, 120, 119, 3407, 3408, 130, 3403
1833, 94, 95, 3371, 3369, 105, 3409, 3410, 3404
1834, 3369, 3371, 3372, 3370, 3410, 3411, 3412, 3406
1835, 3370, 3372, 121, 120, 3412, 3413, 131, 3408
1836, 95, 96, 3373, 3371, 106, 3414, 3415, 3409
1837, 3371, 3373, 3374, 3372, 3415, 3416, 3417, 3411
1838, 3372, 3374, 122, 121, 3417, 3418, 132, 3413
1839, 96, 97, 3375, 3373, 107, 3419, 3420, 3414
1840, 3373, 3375, 3376, 3374, 3420, 3421, 3422, 3416
1841, 3374, 3376, 123, 122, 3422, 3423, 133, 3418
1842, 97, 98, 3377, 3375, 108, 3424, 3425, 3419
1843, 3375, 3377, 3378, 3376, 3425, 3426, 3427, 3421
1844, 3376, 3378, 124, 123, 3427, 3428, 134, 3423
1845, 98, 1, 110, 3377, 109, 112, 3429, 3424
1846, 3377, 110, 111, 3378, 3429, 113, 3430, 3426
1847, 3378, 111, 3, 124, 3430, 114, 135, 3428
*ELEMENT, type=CPS8, ELSET=Surface2
1848, 6, 188, 3431, 141, 190, 3451, 3452, 151
1849, 188, 189, 3432, 3431, 191, 3453, 3454, 3451
1850, 189, 8, 167, 3432, 192, 177, 3455, 3453
1851, 141, 3431, 3433, 142, 3452, 3456, 3457, 152
1852, 3431, 3432, 3434, 3433, 3454, 3458, 3459, 3456
1853, 3432, 167, 168, 3434, 3455, 178, 3460, 3458
1854, 142, 3433, 3435, 143, 3457, 3461, 3462, 153
1855, 3433, 3434, 3436, 3435, 3459, 3463, 3464, 3461
1856, 3434, 168, 169, 3436, 3460, 179, 3465, 3463
1857, 143, 3435, 3437, 144, 3462, 3466, 3467, 154
1858, 3435, 3436, 3438, 3437, 3464, 3468, 3469, 3466
1859, 3436, 169, 170, 3438, 3465, 180, 3470, 3468
1860, 144, 3437, 3439, 145, 3467, 3471, 3472, 155
1861, 3437, 3438, 3440, 3439, 3469, 3473, 3474, 3471
1862, 3438, 170, 171, 3440, 3470, 181, 3475, 3473
1863, 145, 3439, 3441, 146, 3472, 3476, 3477, 156
1864, 3439, 3440, 3442, 3441, 3474, 3478, 3479, 3476
1865, 3440, 171, 172, 3442, 3475, 182, 3480, 3478
1866, 146, 3441, 3443, 147, 3477, 3481, 3482, 157
1867, 3441, 3442, 3444, 3443, 3479, 3483, 3484, 3481
1868, 3442, 172, 173, 3444, 3480, 183, 3485, 3483
1869, 147, 3443, 3445, 148, 3482, 3486, 3487, 158
1870, 3443, 3444, 3446, 3445, 3484, 3488, 3489, 3486
1871, 3444, 173, 174, 3446, 3485, 184, 3490, 3488
1872, 148, 3445, 3447, 149, 3487, 3491, 3492, 159
1873, 3445, 3446, 3448, 3447, 3489, 3493, 3494, 3491
1874, 3446, 174, 175, 3448, 3490, 185, 3495, 3493
1875, 149, 3447, 3449, 150, 3492, 3496, 3497, 160
1876, 3447, 3448, 3450, 3449, 3494, 3498, 3499, 3496
1877, 3448, 175, 176, 3450, 3495, 186, 3500, 3498
1878, 150, 3449, 162, 5, 3497, 3501, 164, 161
1879, 3449, 3450, 163, 162, 3499, 3502, 165, 3501
1880, 3450, 176, 7, 163, 3500, 187, 166, 3502
*ELEMENT, type=CPS8, ELSET=Surface3
1881, 2, 193, 3503, 89, 215, 3723, 3724, 99
1882, 89, 3503, 3504, 90, 3724, 3725, 3726, 100
1883, 90, 3504, 3505, 91, 3726, 3727, 3728, 101
1884, 91, 3505, 3506, 92, 3728, 3729, 3730, 102
1885, 92, 3506, 3507, 93, 3730, 3731, 3732, 103
1886, 93, 3507, 3508, 94, 3732, 3733, 3734, 104
1887, 94, 3508, 3509, 95, 3734, 3735, 3736, 105
1888, 95, 3509, 3510, 96, 3736, 3737, 3738, 106
1889, 96, 3510, 3511, 97, 3738, 3739, 3740, 107
1890, 97, 3511, 3512, 98, 3740, 3741, 3742, 108
1891, 98, 3512, 238, 1, 3742, 3743, 260, 109
1892, 193, 194, 3513, 3503, 216, 3744, 3745, 3723
1893, 3503, 3513, 3514, 3504, 3745, 3746, 3747, 3725
1894, 3504, 3514, 3515, 3505, 3747, 3748, 3749, 3727
1895, 3505, 3515, 3516, 3506, 3749, 3750, 3751, 3729
1896, 3506, 3516, 3517, 3507, 3751, 3752, 3753, 3731
1897, 3507, 3517, 3518, 3508, 3753, 3754, 3755, 3733
1898, 3508, 3518, 3519, 3509, 3755, 3756, 3757, 3735
1899, 3509, 3519, 3520, 3510, 3757, 3758, 3759, 3737
1900, 3510, 3520, 3521, 3511, 3759, 3760, 3761, 3739
1901, 3511, 3521, 3522, 3512, 3761, 3762, 3763, 3741
1902, 3512, 3522, 239, 238, 3763, 3764, 261, 3743
1903, 194, 195, 3523, 3513, 217, 3765, 3766, 3744
1904, 3513, 3523, 3524, 3514, 3766, 3767, 3768, 3746
1905, 3514, 3524, 3525, 3515, 3768, 3769, 3770, 3748
1906, 3515, 3525, 3526, 3516, 3770, 3771, 3772, 3750
1907, 3516, 3526, 3527, 3517, 3772, 3773, 3774, 3752
1908, 3517, 3527, 3528, 3518, 3774, 3775, 3776, 3754
1909, 3518, 3528, 3529, 3519, 3776, 3777, 3778, 3756
1910, 3519, 3529, 3530, 3520, 3778, 3779, 3780, 3758
1911, 3520, 3530, 3531, 3521, 3780, 3781, 3782, 3760
1912, 3521, 3531, 3532, 3522, 3782, 3783, 3784, 3762
1913, 3522, 3532, 240, 239, 3784, 3785, 262, 3764
1914, 195, 196, 3533, 3523, 218, 3786, 3787, 3765
1915, 3523, 3533, 3534, 3524, 3787, 3788, 3789, 3767
1916, 3524, 3534, 3535, 3525, 3789, 3790, 3791, 3769
1917, 3525, 3535, 3536, 3526, 3791, 3792, 3793, 3771
1918, 3526, 3536, 3537, 3527, 3793, 3794, 3795, 3773
1919, 3527, 3537, 3538, 3528, 3795, 3796, 3797, 3775
1920, 3528, 3538, 3539, 3529, 3797, 3798, 3799, 3777
1921, 3529, 3539, 3540, 3530, 3799, 3800, 3801, 3779
1922, 3530, 3540, 3541, 3531, 3801, 3802, 3803, 3781
1923, 3531, 3541, 3542, 3532, 3803, 3804, 3805, 3783
1924, 3532, 3542, 241, 240, 3805, 3806, 263, 3785
1925, 196, 197, 3543, 3533, 219, 3807, 3808, 3786
1926, 3533, 3543, 3544, 3534, 3808, 3809, 3810, 3788
1927, 3534, 3544, 3545, 3535, 3810, 3811, 3812, 3790
1928, 3535, 3545, 3546, 3536, 3812, 3813, 3814, 3792
1929, 3536, 3546, 3547, 3537, 3814, 3815, 3816, 3794
1930, 3537, 3547, 3548, 3538, 3816, 3817, 3818, 3796
1931, 3538, 3548, 3549, 3539, 3818, 3819, 3820, 3798
1932, 3539, 3549, 3550, 3540, 3820, 3821, 3822, 3800
1933, 3540, 3550, 3551, 3541, 3822, 3823, 3824, 3802
1934, 3541, 3551, 3552, 3542, 3824, 3825, 3826, 3804
1935, 3542, 3552, 242, 241, 3826, 3827, 264, 3806
1936, 197, 198, 3553, 3543, 220, 3828, 3829, 3807
1937, 3543, 3553, 3554, 3544, 3829, 3830, 3831, 3809
1938, 3544, 3554, 3555, 3545, 3831, 3832, 3833, 3811
1939, 3545, 3555, 3556, 3546, 3833, 3834, 3835, 3813
1940, 3546, 3556, 3557, 3547, 3835, 3836, 3837, 3815
1941, 3547, 3557, 3558, 3548, 3837, 3838, 3839, 3817
1942, 3548, 3558, 3559, 3549, 3839, 3840, 3841, 3819
1943, 3549, 3559, 3560, 3550, 3841, 3842, 3843, 3821
1944, 3550, 3560, 3561, 3551, 3843, 3844, 3845, 3823
1945, 3551, 3561, 3562, 3552, 3845, 3846, 3847, 3825
1946, 3552, 3562, 243, 242, 3847, 3848, 265, 3827
1947, 198, 199, 3563, 3553, 221, 3849, 3850, 3828
1948, 3553, 3563, 3564, 3554, 3850, 3851, 3852, 3830
1949, 3554, 3564, 3565, 3555, 3852, 3853, 3854, 3832
1950, 3555, 3565, 3566, 3556, 3854, 3855, 3856, 3834
1951, 3556, 3566, 3567, 3557, 3856, 3857, 3858, 3836
1952, 3557, 3567, 3568, 3558, 3858, 3859, 3860, 3838
1953, 3558, 3568, 3569, 3559, 3860, 3861, 3862, 3840
1954, 3559, 3569, 3570, 3560, 3862, 3863, 3864, 3842
1955, 3560, 3570, 3571, 3561, 3864, 3865, 3866, 3844
1956, 3561, 3571, 3572, 3562, 3866, 3867, 3868, 3846
1957, 3562, 3572, 244, 243, 3868, 3869, 266, 3848
1958, 199, 200, 3573, 3563, 222, 3870, 3871, 3849
1959, 3563, 3573, 3574, 3564, 3871, 3872, 3873, 3851
1960, 3564, 3574, 3575, 3565, 3873, 3874, 3875, 3853
1961, 3565, 3575, 3576, 3566, 3875, 3876, 3877, 3855
1962, 3566, 3576, 3577, 3567, 3877, 3878, 3879, 3857
1963, 3567, 3577, 3578, 3568, 3879, 3880, 3881, 3859
1964, 3568, 3578, 3579, 3569, 3881, 3882, 3883, 3861
1965, 3569, 3579, 3580, 3570, 3883, 3884, 3885, 3863
1966, 3570, 3580, 3581, 3571, 3885, 3886, 3887, 3865
1967, 3571, 3581, 3582, 3572, 3887, 3888, 3889, 3867
1968, 3572, 3582, 245, 244, 3889, 3890, 267, 3869
1969, 200, 201, 3583, 3573, 223, 3891, 3892, 3870
1970, 3573, 3583, 3584, 3574, 3892, 3893, 3894, 3872
1971, 3574, 3584, 3585, 3575, 3894, 3895, 3896, 3874
1972, 3575, 3585, 3586, 3576, 3896, 3897, 3898, 3876
1973, 3576, 3586, 3587, 3577, 3898, 3899, 3900, 3878
1974, 3577, 3587, 3588, 3578, 3900, 3901, 3902, 3880
1975, 3578, 3588, 3589, 3579, 3902, 3903, 3904, 3882
1976, 3579, 3589, 3590, 3580, 3904, 3905, 3906, 3884
1977, 3580, 3590, 3591, 3581, 3906, 3907, 3908, 3886
1978, 3581, 3591, 3592, 3582, 3908, 3909, 3910, 3888
1979, 3582, 3592, 246, 245, 3910, 3911, 268, 3890
1980, 201, 202, 3593, 3583, 224, 3912, 3913, 3891
1981, 3583, 3593, 3594, 3584, 3913, 3914, 3915, 3893
1982, 3584, 3594, 3595, 3585, 3915, 3916, 3917, 3895
1983, 3585, 3595, 3596, 3586, 3917, 3918, 3919, 3897
1984, 3586, 3596, 3597, 3587, 3919, 3920, 3921, 3899
1985, 3587, 3597, 3598, 3588, 3921, 3922, 3923, 3901
1986, 3588, 3598, 3599, 3589, 3923, 3924, 3925, 3903
1987, 3589, 3599, 3600, 3590, 3925, 3926, 3927, 3905
1988, 3590, 3600, 3601, 3591, 3927, 3928, 3929, 3907
1989, 3591, 3601, 3602, 3592, 3929, 3930, 3931, 3909
1990, 3592, 3602, 247, 246, 3931, 3932, 269, 3911
1991, 202, 203, 3603, 3593, 225, 3933, 3934, 3912
1992, 3593, 3603, 3604, 3594, 3934, 3935, 3936, 3914
1993, 3594, 3604, 3605, 3595, 3936, 3937, 3938, 3916
1994, 3595, 3605, 3606, 3596, 3938, 3939, 3940, 3918
1995, 3596, 3606, 3607, 3597, 3940, 3941, 3942, 3920
1996, 3597, 3607, 3608, 3598, 3942, 3943, 3944, 3922
1997, 3598, 3608, 3609, 3599, 3944, 3945, 3946, 3924
1998, 3599, 3609, 3610, 3600, 3946, 3947, 3948, 3926
1999, 3600, 3610, 3611, 3601, 3948, 3949, 3950, 3928
2000, 3601, 3611, 3612, 3602, 3950, 3951, 3952, 3930
2001, 3602, 3612, 248, 247, 3952, 3953, 270, 3932
2002, 203, 204, 3613, 3603, 226, 3954, 3955, 3933
2003, 3603, 3613, 3614, 3604, 3955, 3956, 3957, 3935
2004, 3604, 3614, 3615, 3605, 3957, 3958, 3959, 3937
2005, 3605, 3615, 3616, 3606, 3959, 3960, 3961, 3939
2006, 3606, 3616, 3617, 3607, 3961, 3962, 3963, 3941
2007, 3607, 3617, 3618, 3608, 3963, 3964, 3965, 3943
2008, 3608, 3618, 3619, 3609, 3965, 3966, 3967, 3945
2009, 3609, 3619, 3620, 3610, 3967, 3968, 3969, 3947
2010, 3610, 3620, 3621, 3611, 3969, 3970, 3971, 3949
2011, 3611, 3621, 3622, 3612, 3971, 3972, 3973, 3951
2012, 3612, 3622, 249, 248, 3973, 3974, 271, 3953
2013, 204, 205, 3623, 3613, 227, 3975, 3976, 3954
2014, 3613, 3623, 3624, 3614, 3976, 3977, 3978, 3956
2015, 3614, 3624, 3625, 3615, 3978, 3979, 3980, 3958
2016, 3615, 3625, 3626, 3616, 3980, 3981, 3982, 3960
2017, 3616, 3626, 3627, 3617, 3982, 3983, 3984, 3962
2018, 3617, 3627, 3628, 3618, 3984, 3985, 3986, 3964
2019, 3618, 3628, 3629, 3619, 3986, 3987, 3988, 3966
2020, 3619, 3629, 3630, 3620, 3988, 3989, 3990, 3968
2021, 3620, 3630, 3631, 3621, 3990, 3991, 3992, 3970
2022, 3621, 3631, 3632, 3622, 3992, 3993, 3994, 3972
2023, 3622, 3632, 250, 249, 3994, 3995, 272, 3974
2024, 205, 206, 3633, 3623, 228, 3996, 3997, 3975
2025, 3623, 3633, 3634, 3624, 3997, 3998, 3999, 3977
2026, 3624, 3634, 3635, 3625, 3999, 4000, 4001, 3979
2027, 3625, 3635, 3636, 3626, 4001, 4002, 4003, 3981
2028, 3626, 3636, 3637, 3627, 4003, 4004, 4005, 3983
2029, 3627, 3637, 3638, 3628, 4005, 4006, 4007, 3985
2030, 3628, 3638, 3639, 3629, 4007, 4008, 4009, 3987
2031, 3629, 3639, 3640, 3630, 4009, 4010, 4011, 3989
2032, 3630, 3640, 3641, 3631, 4011, 4012, 4013, 3991
2033, 3631, 3641, 3642, 3632, 4013, 4014, 4015, 3993
2034, 3632, 3642, 251, 250, 4015, 4016, 273, 3995
2035, 206, 207, 3643, 3633, 229, 4017, 4018, 3996
2036, 3633, 3643, 3644, 3634, 4018, 4019, 4020, 3998
2037, 3634, 3644, 3645, 3635, 4020, 4021, 4022, 4000
2038, 3635, 3645, 3646, 3636, 4022, 4023, 4024, 4002
2039, 3636, 3646, 3647, 3637, 4024, 4025, 4026, 4004
2040, 3637, 3647, 3648, 3638, 4026, 4027, 4028, 4006
2041, 3638, 3648, 3649, 3639, 4028, 4029, 4030, 4008
2042, 3639, 3649, 3650, 3640, 4030, 4031, 4032, 4010
2043, 3640, 3650, 3651, 3641, 4032, 4033, 4034, 4012
2044, 3641, 3651, 3652, 3642, 4034, 4035, 4036, 4014
2045, 3642, 3652, 252, 251, 4036, 4037, 274, 4016
2046, 207, 208, 3653, 3643, 230, 4038, 4039, 4017
2047, 3643, 3653, 3654, 3644, 4039, 4040, 4041, 4019
2048, 3644, 3654, 3655, 3645, 4041, 4042, 4043, 4021
2049, 3645, 3655, 3656, 3646, 4043, 4044, 4045, 4023
2050, 3646, 3656, 3657, 3647, 4045, 4046, 4047, 4025
2051, 3647, 3657, 3658, 3648, 4047, 4048, 4049, 4027
2052, 3648, 3658, 3659, 3649, 4049, 4050, 4051, 4029
2053, 3649, 3659, 3660, 3650, 4051, 4052, 4053, 4031
2054, 3650, 3660, 3661, 3651, 4053, 4054, 4055, 4033
2055, 3651, 3661, 3662, 3652, 4055, 4056, 4057, 4035
2056, 3652, 3662, 253, 252, 4057, 4058, 275, 4037
2057, 208, 209, 3663, 3653, 231, 4059, 4060, 4038
2058, 3653, 3663, 3664, 3654, 4060, 4061, 4062, 4040
2059, 3654, 3664, 3665, 3655, 4062, 4063, 4064, 4042
2060, 3655, 3665, 3666, 3656, 4064, 4065, 4066, 4044
2061, 3656, 3666, 3667, 3657, 4066, 4067, 4068, 4046
2062, 3657, 3667, 3668, 3658, 4068, 4069, 4070, 4048
2063, 3658, 3668, 3669, 3659, 4070, 4071, 4072, 4050
2064, 3659, 3669, 3670, 3660, 4072, 4073, 4074, 4052
2065, 3660, 3670, 3671, 3661, 4074, 4075, 4076, 4054
2066, 3661, 3671, 3672, 3662, 4076, 4077, 4078, 4056
2067, 3662, 3672, 254, 253, 4078, 4079, 276, 4058
2068, 209, 210, 3673, 3663, 232, 4080, 4081, 4059
2069, 3663, 3673, 3674, 3664, 4081, 4082, 4083, 4061
2070, 3664, 3674, 3675, 3665, 4083, 4084, 4085, 4063
2071, 3665, 3675, 3676, 3666, 4085, 4086, 4087, 4065
2072, 3666, 3676, 3677, 3667, 4087, 4088, 4089, 4067
2073, 3667, 3677, 3678, 3668, 4089, 4090, 4091, 4069
2074, 3668, 3678, 3679, 3669, 4091, 4092, 4093, 4071
2075, 3669, 3679, 3680, 3670, 4093, 4094, 4095, 4073
2076, 3670, 3680, 3681, 3671, 4095, 4096, 4097, 4075
2077, 3671, 3681, 3682, 3672, 4097, 4098, 4099, 4077
2078, 3672, 3682, 255, 254, 4099, 4100, 277, 4079
2079, 210, 211, 3683, 3673, 233, 4101, 4102, 4080
2080, 3673, 3683, 3684, 3674, 4102, 4103, 4104, 4082
2081, 3674, 3684, 3685, 3675, 4104, 4105, 4106, 4084
2082, 3675, 3685, 3686, 3676, 4106, 4107, 4108, 4086
2083, 3676, 3686, 3687, 3677, 4108, 4109, 4110, 4088
2084, 3677, 3687, 3688, 3678, 4110, 4111, 4112, 4090
2085, 3678, 3688, 3689, 3679, 4112, 4113, 4114, 4092
2086, 3679, 3689, 3690, 3680, 4114, 4115, 4116, 4094
2087, 3680, 3690, 3691, 3681, 4116, 4117, 4118, 4096
2088, 3681, 3691, 3692, 3682, 4118, 4119, 4120, 4098
2089, 3682, 3692, 256, 255, 4120, 4121, 278, 4100
2090, 211, 212, 3693, 3683, 234, 4122, 4123, 4101
2091, 3683, 3693, 3694, 3684, 4123, 4124, 4125, 4103
2092, 3684, 3694, 3695, 3685, 4125, 4126, 4127, 4105
2093, 3685, 3695, 3696, 3686, 4127, 4128, 4129, 4107
2094, 3686, 3696, 3697, 3687, 4129, 4130, 4131, 4109
2095, 3687, 3697, 3698, 3688, 4131, 4132, 4133, 4111
2096, 3688, 3698, 3699, 3689, 4133, 4134, 4135, 4113
2097, 3689, 3699, 3700, 3690, 4135, 4136, 4137, 4115
2098, 3690, 3700, 3701, 3691, 4137, 4138, 4139, 4117
2099, 3691, 3701, 3702, 3692, 4139, 4140, 4141, 4119
2100, 3692, 3702, 257, 256, 4141, 4142, 279, 4121
2101, 212, 213, 3703, 3693, 235, 4143, 4144, 4122
2102, 3693, 3703, 3704, 3694, 4144, 4145, 4146, 4124
2103, 3694, 3704, 3705, 3695, 4146, 4147, 4148, 4126
2104, 3695, 3705, 3706, 3696, 4148, 4149, 4150, 4128
2105, 3696, 3706, 3707, 3697, 4150, 4151, 4152, 4130
2106, 3697, 3707, 3708, 3698, 4152, 4153, 4154, 4132
2107, 3698, 3708, 3709, 3699, 4154, 4155, 4156, 4134
2108, 3699, 3709, 3710, 3700, 4156, 4157, 4158, 4136
2109, 3700, 3710, 3711, 3701, 4158, 4159, 4160, 4138
2110, 3701, 3711, 3712, 3702, 4160, 4161, 4162, 4140
2111, 3702, 3712, 258, 257, 4162, 4163, 280, 4142
2112, 213, 214, 3713, 3703, 236, 4164, 4165, 4143
2113, 3703, 3713, 3714, 3704, 4165, 4166, 4167, 4145
2114, 3704, 3714, 3715, 3705, 4167, 4168, 4169, 4147
2115, 3705, 3715, 3716, 3706, 4169, 4170, 4171, 4149
2116, 3706, 3716, 3717, 3707, 4171, 4172, 4173, 4151
2117, 3707, 3717, 3718, 3708, 4173, 4174, 4175, 4153
2118, 3708, 3718, 3719, 3709, 4175, 4176, 4177, 4155
2119, 3709, 3719, 3720, 3710, 4177, 4178, 4179, 4157
2120, 3710, 3720, 3721, 3711, 4179, 4180, 4181, 4159
2121, 3711, 3721, 3722, 3712, 4181, 4182, 4183, 4161
2122, 3712, 3722, 259, 258, 4183, 4184, 281, 4163
2123, 214, 6, 141, 3713, 237, 151, 4185, 4164
2124, 3713, 141, 142, 3714, 4185, 152, 4186, 4166
2125, 3714, 142, 143, 3715, 4186, 153, 4187, 4168
2126, 3715, 143, 144, 3716, 4187, 154, 4188, 4170
2127, 3716, 144, 145, 3717, 4188, 155, 4189, 4172
2128, 3717, 145, 146, 3718, 4189, 156, 4190, 4174
2129, 3718, 146, 147, 3719, 4190, 157, 4191, 4176
2130, 3719, 147, 148, 3720, 4191, 158, 4192, 4178
2131, 3720, 148, 149, 3721, 4192, 159, 4193, 4180
2132, 3721, 149, 150, 3722, 4193, 160, 4194, 4182
2133, 3722, 150, 5, 259, 4194, 161, 282, 4184
*ELEMENT, type=CPS8, ELSET=Surface4
2134, 4, 115, 4195, 283, 125, 4415, 4416, 305
2135, 115, 116, 4196, 4195, 126, 4417, 4418, 4415
2136, 116, 117, 4197, 4196, 127, 4419, 4420, 4417
2137, 117, 118, 4198, 4197, 128, 4421, 4422, 4419
2138, 118, 119, 4199, 4198, 129, 4423, 4424, 4421
2139, 119, 120, 4200, 4199, 130, 4425, 4426, 4423
2140, 120, 121, 4201, 4200, 131, 4427, 4428, 4425
2141, 121, 122, 4202, 4201, 132, 4429, 4430, 4427
2142, 122, 123, 4203, 4202, 133, 4431, 4432, 4429
2143, 123, 124, 4204, 4203, 134, 4433, 4434, 4431
2144, 124, 3, 328, 4204, 135, 350, 4435, 4433
2145, 283, 4195, 4205, 284, 4416, 4436, 4437, 306
2146, 4195, 4196, 4206, 4205, 4418, 4438, 4439, 4436
2147, 4196, 4197, 4207, 4206, 4420, 4440, 4441, 4438
2148, 4197, 4198, 4208, 4207, 4422, 4442, 4443, 4440
2149, 4198, 4199, 4209, 4208, 4424, 4444, 4445, 4442
2150, 4199, 4200, 4210, 4209, 4426, 4446, 4447, 4444
2151, 4200, 4201, 4211, 4210, 4428, 4448, 4449, 4446
2152, 4201, 4202, 4212, 4211, 4430, 4450, 4451, 4448
2153, 4202, 4203, 4213, 4212, 4432, 4452, 4453, 4450
2154, 4203, 4204, 4214, 4213, 4434, 4454, 4455, 4452
2155, 4204, 328, 329, 4214, 4435, 351, 4456, 4454
2156, 284, 4205, 4215, 285, 4437, 4457, 4458, 307
2157, 4205, 4206, 4216, 4215, 4439, 4459, 4460, 4457
2158, 4206, 4207, 4217, 4216, 4441, 4461, 4462, 4459
2159, 4207, 4208, 4218, 4217, 4443, 4463, 4464, 4461
2160, 4208, 4209, 4219, 4218, 4445, 4465, 4466, 4463
2161, 4209, 4210, 4220, 4219, 4447, 4467, 4468, 4465
2162, 4210, 4211, 4221, 4220, 4449, 4469, 4470, 4467
2163, 4211, 4212, 4222, 4221, 4451, 4471, 4472, 4469
2164, 4212, 4213, 4223, 4222, 4453, 4473, 4474, 4471
2165, 4213, 4214, 4224, 4223, 4455, 4475, 4476, 4473
2166, 4214, 329, 330, 4224, 4456, 352, 4477, 4475
2167, 285, 4215, 4225, 286, 4458, 4478, 4479, 308
2168, 4215, 4216, 4226, 4225, 4460, 4480, 4481, 4478
2169, 4216, 4217, 4227, 4226, 4462, 4482, 4483, 4480
2170, 4217, 4218, 4228, 4227, 4464, 4484, 4485, 4482
2171, 4218, 4219, 4229, 4228, 4466, 4486, 4487, 4484
2172, 4219, 4220, 4230, 4229, 4468, 4488, 4489, 4486
2173, 4220, 4221, 4231, 4230, 4470, 4490, 4491, 4488
2174, 4221, 4222, 4232, 4231, 4472, 4492, 4493, 4490
2175, 4222, 4223, 4233, 4232, 4474, 4494, 4495, 4492
2176, 4223, 4224, 4234, 4233, 4476, 4496, 4497, 4494
2177, 4224, 330, 331, 4234, 4477, 353, 4498, 4496
2178, 286, 4225, 4235, 287, 4479, 4499, 4500, 309
2179, 4225, 4226, 4236, 4235, 4481, 4501, 4502, 4499
2180, 4226, 4227, 4237, 4236, 4483, 4503, 4504, 4501
2181, 4227, 4228, 4238, 4237, 4485, 4505, 4506, 4503
2182, 4228, 4229, 4239, 4238, 4487, 4507, 4508, 4505
2183, 4229, 4230, 4240, 4239, 4489, 4509, 4510, 4507
2184, 4230, 4231, 4241, 4240, 4491, 4511, 4512, 4509
2185, 4231, 4232, 4242, 4241, 4493, 4513, 4514, 4511
2186, 4232, 4233, 4243, 4242, 4495, 4515, 4516, 4513
2187, 4233, 4234, 4244, 4243, 4497, 4517, 4518, 4515
2188, 4234, 331, 332, 4244, 4498, 354, 4519, 4517
2189, 287, 4235, 4245, 288, 4500, 4520, 4521, 310
2190, 4235, 4236, 4246, 4245, 4502, 4522, 4523, 4520
2191, 4236, 4237, 4247, 4246, 4504, 4524, 4525, 4522
2192, 4237, 4238, 4248, 4247, 4506, 4526, 4527, 4524
2193, 4238, 4239, 4249, 4248, 4508, 4528, 4529, 4526
2194, 4239, 4240, 4250, 4249, 4510, 4530, 4531, 4528
2195, 4240, 4241, 4251, 4250, 4512, 4532, 4533, 4530
2196, 4241, 4242, 4252, 4251, 4514, 4534, 4535, 4532
2197, 4242, 4243, 4253, 4252, 4516, 4536, 4537, 4534
2198, 4243, 4244, 4254, 4253, 4518, 4538, 4539, 4536
2199, 4244, 332, 333, 4254, 4519, 355, 4540, 4538
2200, 288, 4245, 4255, 289, 4521, 4541, 4542, 311
2201, 4245, 4246, 4256, 4255, 4523, 4543, 4544, 4541
2202, 4246, 4247, 4257, 4256, 4525, 4545, 4546, 4543
2203, 4247, 4248, 4258, 4257, 4527, 4547, 4548, 4545
2204, 4248, 4249, 4259, 4258, 4529, 4549, 4550, 4547
2205, 4249, 4250, 4260, 4259, 4531, 4551, 4552, 4549
2206, 4250, 4251, 4261, 4260, 4533, 4553, 4554, 4551
2207, 4251, 4252, 4262, 4261, 4535, 4555, 4556, 4553
2208, 4252, 4253, 4263, 4262, 4537, 4557, 4558, 4555
2209, 4253, 4254, 4264, 4263, 4539, 4559, 4560, 4557
2210, 4254, 333, 334, 4264, 4540, 356, 4561, 4559
2211, 289, 4255, 4265, 290, 4542, 4562, 4563, 312
2212, 4255, 4256, 4266, 4265, 4544, 4564, 4565, 4562
2213, 4256, 4257, 4267, 4266, 4546, 4566, 4567, 4564
2214, 4257, 4258, 4268, 4267, 4548, 4568, 4569, 4566
2215, 4258, 4259, 4269, 4268, 4550, 4570, 4571, 4568
2216, 4259, 4260, 4270, 4269, 4552, 4572, 4573, 4570
2217, 4260, 4261, 4271, 4270, 4554, 4574, 4575, 4572
2218, 4261, 4262, 4272, 4271, 4556, 4576, 4577, 4574
2219, 4262, 4263, 4273, 4272, 4558, 4578, 4579, 4576
2220, 4263, 4264, 4274, 4273, 4560, 4580, 4581, 4578
2221, 4264, 334, 335, 4274, 4561, 357, 4582, 4580
2222, 290, 4265, 4275, 291, 4563, 4583, 4584, 313
2223, 4265, 4266, 4276, 4275, 4565, 4585, 4586, 4583
2224, 4266, 4267, 4277, 4276, 4567, 4587, 4588, 4585
2225, 4267, 4268, 4278, 4277, 4569, 4589, 4590, 4587
2226, 4268, 4269, 4279, 4278, 4571, 4591, 4592, 4589
2227, 4269, 4270, 4280, 4279, 4573, 4593, 4594, 4591
2228, 4270, 4271, 4281, 4280, 4575, 4595, 4596, 4593
2229, 4271, 4272, 4282, 4281, 4577, 4597, 4598, 4595
2230, 4272, 4273, 4283, 4282, 4579, 4599, 4600, 4597
2231, 4273, 4274, 4284, 4283, 4581, 4601, 4602, 4599
2232, 4274, 335, 336, 4284, 4582, 358, 4603, 4601
2233, 291, 4275, 4285, 292, 4584, 4604, 4605, 314
2234, 4275, 4276, 4286, 4285, 4586, 4606, 4607, 4604
2235, 4276, 4277, 4287, 4286, 4588, 4608, 4609, 4606
2236, 4277, 4278, 4288, 4287, 4590, 4610, 4611, 4608
2237, 4278, 4279, 4289, 4288, 4592, 4612, 4613, 4610
2238, 4279, 4280, 4290, 4289, 4594, 4614, 4615, 4612
2239, 4280, 4281, 4291, 4290, 4596, 4616, 4617, 4614
2240, 4281, 4282, 4292, 4291, 4598, 4618, 4619, 4616
2241, 4282, 4283, 4293, 4292, 4600, 4620, 4621, 4618
2242, 4283, 4284, 4294, 4293, 4602, 4622, 4623, 4620
2243, 4284, 336, 337, 4294, 4603, 359, 4624, 4622
2244, 292, 4285, 4295, 293, 4605, 4625, 4626, 315
2245, 4285, 4286, 4296, 4295, 4607, 4627, 4628, 4625
2246, 4286, 4287, 4297, 4296, 4609, 4629, 4630, 4627
2247, 4287, 4288, 4298, 4297, 4611, 4631, 4632, 4629
2248, 4288, 4289, 4299, 4298, 4613, 4633, 4634, 4631
2249, 4289, 4290, 4300, 4299, 4615, 4635, 4636, 4633
2250, 4290, 4291, 4301, 4300, 4617, 4637, 4638, 4635
2251, 4291, 4292, 4302, 4301, 4619, 4639, 4640, 4637
2252, 4292, 4293, 4303, 4302, 4621, 4641, 4642, 4639
2253, 4293, 4294, 4304, 4303, 4623, 4643, 4644, 4641
2254, 4294, 337, 338, 4304, 4624, 360, 4645, 4643
2255, 293, 4295, 4305, 294, 4626, 4646, 4647, 316
2256, 4295, 4296, 4306, 4305, 4628, 4648, 4649, 4646
2257, 4296, 4297, 4307, 4306, 4630, 4650, 4651, 4648
2258, 4297, 4298, 4308, 4307, 4632, 4652, 4653, 4650
2259, 4298, 4299, 4309, 4308, 4634, 4654, 4655, 4652
2260, 4299, 4300, 4310, 4309, 4636, 4656, 4657, 4654
2261, 4300, 4301, 4311, 4310, 4638, 4658, 4659, 4656
2262, 4301, 4302, 4312, 4311, 4640, 4660, 4661, 4658
2263, 4302, 4303, 4313, 4312, 4642, 4662, 4663, 4660
2264, 4303, 4304, 4314, 4313, 4644, 4664, 4665, 4662
2265, 4304, 338, 339, 4314, 4645, 361, 4666, 4664
2266, 294, 4305, 4315, 295, 4647, 4667, 4668, 317
2267, 4305, 4306, 4316, 4315, 4649, 4669, 4670, 4667
2268, 4306, 4307, 4317, 4316, 4651, 4671, 4672, 4669
2269, 4307, 4308, 4318, 4317, 4653, 4673, 4674, 4671
2270, 4308, 4309, 4319, 4318, 4655, 4675, 4676, 4673
2271, 4309, 4310, 4320, 4319, 4657, 4677, 4678, 4675
2272, 4310, 4311, 4321, 4320, 4659, 4679, 4680, 4677
2273, 4311, 4312, 4322, 4321, 4661, 4681, 4682, 4679
2274, 4312, 4313, 4323, 4322, 4663, 4683, 4684, 4681
2275, 4313, 4314, 4324, 4323, 4665, 4685, 4686, 4683
2276, 4314, 339, 340, 4324, 4666, 362, 4687, 4685
2277, 295, 4315, 4325, 296, 4668, 4688, 4689, 318
2278, 4315, 4316, 4326, 4325, 4670, 4690, 4691, 4688
2279, 4316, 4317, 4327, 4326, 4672, 4692, 4693, 4690
2280, 4317, 4318, 4328, 4327, 4674, 4694, 4695, 4692
2281, 4318, 4319, 4329, 4328, 4676, 4696, 4697, 4694
2282, 4319, 4320, 4330, 4329, 4678, 4698, 4699, 4696
2283, 4320, 4321, 4331, 4330, 4680, 4700, 4701, 4698
2284, 4321, 4322, 4332, 4331, 4682, 4702, 4703, 4700
2285, 4322, 4323, 4333, 4332, 4684, 4704, 4705, 4702
2286, 4323, 4324, 4334, 4333, 4686, 4706, 4707, 4704
2287, 4324, 340, 341, 4334, 4687, 363, 4708, 4706
2288, 296, 4325, 4335, 297, 4689, 4709, 4710, 319
2289, 4325, 4326, 4336, 4335, 4691, 4711, 4712, 4709
2290, 4326, 4327, 4337, 4336, 4693, 4713, 4714, 4711
2291, 4327, 4328, 4338, 4337, 4695, 4715, 4716, 4713
2292, 4328, 4329, 4339, 4338, 4697, 4717, 4718, 4715
2293, 4329, 4330, 4340, 4339, 4699, 4719, 4720, 4717
2294, 4330, 4331, 4341, 4340, 4701, 4721, 4722, 4719
2295, 4331, 4332, 4342, 4341, 4703, 4723, 4724, 4721
2296, 4332, 4333, 4343, 4342, 4705, 4725, 4726, 4723
2297, 4333, 4334, 4344, 4343, 4707, 4727, 4728, 4725
2298, 4334, 341, 342, 4344, 4708, 364, 4729, 4727
2299, 297, 4335, 4345, 298, 4710, 4730, 4731, 320
2300, 4335, 4336, 4346, 4345, 4712, 4732, 4733, 4730
2301, 4336, 4337, 4347, 4346, 4714, 4734, 4735, 4732
2302, 4337, 4338, 4348, 4347, 4716, 4736, 4737, 4734
2303, 4338, 4339, 4349, 4348, 4718, 4738, 4739, 4736
2304, 4339, 4340, 4350, 4349, 4720, 4740, 4741, 4738
2305, 4340, 4341, 4351, 4350, 4722, 4742, 4743, 4740
2306, 4341, 4342, 4352, 4351, 4724, 4744, 4745, 4742
2307, 4342, 4343, 4353, 4352, 4726, 4746, 4747, 4744
2308, 4343, 4344, 4354, 4353, 4728, 4748, 4749, 4746
2309, 4344, 342, 343, 4354, 4729, 365, 4750, 4748
2310, 298, 4345, 4355, 299, 4731, 4751, 4752, 321
2311, 4345, 4346, 4356, 4355, 4733, 4753, 4754, 4751
2312, 4346, 4347, 4357, 4356, 4735, 4755, 4756, 4753
2313, 4347, 4348, 4358, 4357, 4737, 4757, 4758, 4755
2314, 4348, 4349, 4359, 4358, 4739, 4759, 4760, 4757
2315, 4349, 4350, 4360, 4359, 4741, 4761, 4762, 4759
2316, 4350, 4351, 4361, 4360, 4743, 4763, 4764, 4761
2317, 4351, 4352, 4362, 4361, 4745, 4765, 4766, 4763
2318, 4352, 4353, 4363, 4362, 4747, 4767, 4768, 4765
2319, 4353, 4354, 4364, 4363, 4749, 4769, 4770, 4767
2320, 4354, 343, 344, 4364, 4750, 366, 4771, 4769
2321, 299, 4355, 4365, 300, 4752, 4772, 4773, 322
2322, 4355, 4356, 4366, 4365, 4754, 4774, 4775, 4772
2323, 4356, 4357, 4367, 4366, 4756, 4776, 4777, 4774
2324, 4357, 4358, 4368, 4367, 4758, 4778, 4779, 4776
2325, 4358, 4359, 4369, 4368, 4760, 4780, 4781, 4778
2326, 4359, 4360, 4370, 4369, 4762, 4782, 4783, 4780
2327, 4360, 4361, 4371, 4370, 4764, 4784, 4785, 4782
2328, 4361, 4362, 4372, 4371, 4766, 4786, 4787, 4784
2329, 4362, 4363, 4373, 4372, 4768, 4788, 4789, 4786
2330, 4363, 4364, 4374, 4373, 4770, 4790, 4791, 4788
2331, 4364, 344, 345, 4374, 4771, 367, 4792, 4790
2332, 300, 4365, 4375, 301, 4773, 4793, 4794, 323
2333, 4365, 4366, 4376, 4375, 4775, 4795, 4796, 4793
2334, 4366, 4367, 4377, 4376, 4777, 4797, 4798, 4795
2335, 4367, 4368, 4378, 4377, 4779, 4799, 4800, 4797
2336, 4368, 4369, 4379, 4378, 4781, 4801, 4802, 4799
2337, 4369, 4370, 4380, 4379, 4783, 4803, 4804, 4801
2338, 4370, 4371, 4381, 4380, 4785, 4805, 4806, 4803
2339, 4371, 4372, 4382, 4381, 4787, 4807, 4808, 4805
2340, 4372, 4373, 4383, 4382, 4789, 4809, 4810, 4807
2341, 4373, 4374, 4384, 4383, 4791, 4811, 4812, 4809
2342, 4374, 345, 346, 4384, 4792, 368, 4813, 4811
2343, 301, 4375, 4385, 302, 4794, 4814, 4815, 324
2344, 4375, 4376, 4386, 4385, 4796, 4816, 4817, 4814
2345, 4376, 4377, 4387, 4386, 4798, 4818, 4819, 4816
2346, 4377, 4378, 4388, 4387, 4800, 4820, 4821, 4818
2347, 4378, 4379, 4389, 4388, 4802, 4822, 4823, 4820
2348, 4379, 4380, 4390, 4389, 4804, 4824, 4825, 4822
2349, 4380, 4381, 4391, 4390, 4806, 4826, 4827, 4824
2350, 4381, 4382, 4392, 4391, 4808, 4828, 4829, 4826
2351, 4382, 4383, 4393, 4392, 4810, 4830, 4831, 4828
2352, 4383, 4384, 4394, 4393, 4812, 4832, 4833, 4830
2353, 4384, 346, 347, 4394, 4813, 369, 4834, 4832
2354, 302, 4385, 4395, 303, 4815, 4835, 4836, 325
2355, 4385, 4386, 4396, 4395, 4817, 4837, 4838, 4835
2356, 4386, 4387, 4397, 4396, 4819, 4839, 4840, 4837
2357, 4387, 4388, 4398, 4397, 4821, 4841, 4842, 4839
2358, 4388, 4389, 4399, 4398, 4823, 4843, 4844, 4841
2359, 4389, 4390, 4400, 4399, 4825, 4845, 4846, 4843
2360, 4390, 4391, 4401, 4400, 4827, 4847, 4848, 4845
2361, 4391, 4392, 4402, 4401, 4829, 4849, 4850, 4847
2362, 4392, 4393, 4403, 4402, 4831, 4851, 4852, 4849
2363, 4393, 4394, 4404, 4403, 4833, 4853, 4854, 4851
2364, 4394, 347, 348, 4404, 4834, 370, 4855, 4853
2365, 303, 4395, 4405, 304, 4836, 4856, 4857, 326
2366, 4395, 4396, 4406, 4405, 4838, 4858, 4859, 4856
2367, 4396, 4397, 4407, 4406, 4840, 4860, 4861, 4858
2368, 4397, 4398, 4408, 4407, 4842, 4862, 4863, 4860
2369, 4398, 4399, 4409, 4408, 4844, 4864, 4865, 4862
2370, 4399, 4400, 4410, 4409, 4846, 4866, 4867, 4864
2371, 4400, 4401, 4411, 4410, 4848, 4868, 4869, 4866
2372, 4401, 4402, 4412, 4411, 4850, 4870, 4871, 4868
2373, 4402, 4403, 4413, 4412, 4852, 4872, 4873, 4870
2374, 4403, 4404, 4414, 4413, 4854, 4874, 4875, 4872
2375, 4404, 348, 349, 4414, 4855, 371, 4876, 4874
2376, 304, 4405, 167, 8, 4857, 4877, 177, 327
2377, 4405, 4406, 168, 167, 4859, 4878, 178, 4877
2378, 4406, 4407, 169, 168, 4861, 4879, 179, 4878
2379, 4407, 4408, 170, 169, 4863, 4880, 180, 4879
2380, 4408, 4409, 171, 170, 4865, 4881, 181, 4880
2381, 4409, 4410, 172, 171, 4867, 4882, 182, 4881
2382, 4410, 4411, 173, 172, 4869, 4883, 183, 4882
2383, 4411, 4412, 174, 173, 4871, 4884, 184, 4883
2384, 4412, 4413, 175, 174, 4873, 4885, 185, 4884
2385, 4413, 4414, 176, 175, 4875, 4886, 186, 4885
2386, 4414, 349, 7, 176, 4876, 372, 187, 4886
*ELEMENT, type=CPS8, ELSET=Surface5
2387, 2, 136, 4887, 193, 138, 4931, 4932, 215
2388, 193, 4887, 4888, 194, 4932, 4933, 4934, 216
2389, 194, 4888, 4889, 195, 4934, 4935, 4936, 217
2390, 195, 4889, 4890, 196, 4936, 4937, 4938, 218
2391, 196, 4890, 4891, 197, 4938, 4939, 4940, 219
2392, 197, 4891, 4892, 198, 4940, 4941, 4942, 220
2393, 198, 4892, 4893, 199, 4942, 4943, 4944, 221
2394, 199, 4893, 4894, 200, 4944, 4945, 4946, 222
2395, 200, 4894, 4895, 201, 4946, 4947, 4948, 223
2396, 201, 4895, 4896, 202, 4948, 4949, 4950, 224
2397, 202, 4896, 4897, 203, 4950, 4951, 4952, 225
2398, 203, 4897, 4898, 204, 4952, 4953, 4954, 226
2399, 204, 4898, 4899, 205, 4954, 4955, 4956, 227
2400, 205, 4899, 4900, 206, 4956, 4957, 4958, 228
2401, 206, 4900, 4901, 207, 4958, 4959, 4960, 229
2402, 207, 4901, 4902, 208, 4960, 4961, 4962, 230
2403, 208, 4902, 4903, 209, 4962, 4963, 4964, 231
2404, 209, 4903, 4904, 210, 4964, 4965, 4966, 232
2405, 210, 4904, 4905, 211, 4966, 4967, 4968, 233
2406, 211, 4905, 4906, 212, 4968, 4969, 4970, 234
2407, 212, 4906, 4907, 213, 4970, 4971, 4972, 235
2408, 213, 4907, 4908, 214, 4972, 4973, 4974, 236
2409, 214, 4908, 188, 6, 4974, 4975, 190, 237
2410, 136, 137, 4909, 4887, 139, 4976, 4977, 4931
2411, 4887, 4909, 4910, 4888, 4977, 4978, 4979, 4933
2412, 4888, 4910, 4911, 4889, 4979, 4980, 4981, 4935
2413, 4889, 4911, 4912, 4890, 4981, 4982, 4983, 4937
2414, 4890, 4912, 4913, 4891, 4983, 4984, 4985, 4939
2415, 4891, 4913, 4914, 4892, 4985, 4986, 4987, 4941
2416, 4892, 4914, 4915, 4893, 4987, 4988, 4989, 4943
2417, 4893, 4915, 4916, 4894, 4989, 4990, 4991, 4945
2418, 4894, 4916, 4917, 4895, 4991, 4992, 4993, 4947
2419, 4895, 4917, 4918, 4896, 4993, 4994, 4995, 4949
2420, 4896, 4918, 4919, 4897, 4995, 4996, 4997, 4951
2421, 4897, 4919, 4920, 4898, 4997, 4998, 4999, 4953
2422, 4898, 4920, 4921, 4899, 4999, 5000, 5001, 4955
2423, 4899, 4921, 4922, 4900, 5001, 5002, 5003, 4957
2424, 4900, 4922, 4923, 4901, 5003, 5004, 5005, 4959
2425, 4901, 4923, 4924, 4902, 5005, 5006, 5007, 4961
2426, 4902, 4924, 4925, 4903, 5007, 5008, 5009, 4963
2427, 4903, 4925, 4926, 4904, 5009, 5010, 5011, 4965
2428, 4904, 4926, 4927, 4905, 5011, 5012, 5013, 4967
2429, 4905, 4927, 4928, 4906, 5013, 5014, 5015, 4969
2430, 4906, 4928, 4929, 4907, 5015, 5016, 5017, 4971
2431, 4907, 4929, 4930, 4908, 5017, 5018, 5019, 4973
2432, 4908, 4930, 189, 188, 5019, 5020, 191, 4975
2433, 137, 4, 283, 4909, 140, 305, 5021, 4976
2434, 4909, 283, 284, 4910, 5021, 306, 5022, 4978
2435, 4910, 284, 285, 4911, 5022, 307, 5023, 4980
2436, 4911, 285, 286, 4912, 5023, 308, 5024, 4982
2437, 4912, 286, 287, 4913, 5024, 309, 5025, 4984
2438, 4913, 287, 288, 4914, 5025, 310, 5026, 4986
2439, 4914, 288, 289, 4915, 5026, 311, 5027, 4988
2440, 4915, 289, 290, 4916, 5027, 312, 5028, 4990
2441, 4916, 290, 291, 4917, 5028, 313, 5029, 4992
2442, 4917, 291, 292, 4918, 5029, 314, 5030, 4994
2443, 4918, 292, 293, 4919, 5030, 315, 5031, 4996
2444, 4919, 293, 294, 4920, 5031, 316, 5032, 4998
2445, 4920, 294, 295, 4921, 5032, 317, 5033, 5000
2446, 4921, 295, 296, 4922, 5033, 318, 5034, 5002
2447, 4922, 296, 297, 4923, 5034, 319, 5035, 5004
2448, 4923, 297, 298, 4924, 5035, 320, 5036, 5006
2449, 4924, 298, 299, 4925, 5036, 321, 5037, 5008
2450, 4925, 299, 300, 4926, 5037, 322, 5038, 5010
2451, 4926, 300, 301, 4927, 5038, 323, 5039, 5012
2452, 4927, 301, 302, 4928, 5039, 324, 5040, 5014
2453, 4928, 302, 303, 4929, 5040, 325, 5041, 5016
2454, 4929, 303, 304, 4930, 5041, 326, 5042, 5018
2455, 4930, 304, 8, 189, 5042, 327, 192, 5020
*ELEMENT, type=CPS8, ELSET=Surface6
2456, 1, 238, 5043, 110, 260, 5087, 5088, 112
2457, 238, 239, 5044, 5043, 261, 5089, 5090, 5087
2458, 239, 240, 5045, 5044, 262, 5091, 5092, 5089
2459, 240, 241, 5046, 5045, 263, 5093, 5094, 5091
2460, 241, 242, 5047, 5046, 264, 5095, 5096, 5093
2461, 242, 243, 5048, 5047, 265, 5097, 5098, 5095
2462, 243, 244, 5049, 5048, 266, 5099, 5100, 5097
2463, 244, 245, 5050, 5049, 267, 5101, 5102, 5099
2464, 245, 246, 5051, 5050, 268, 5103, 5104, 5101
2465, 246, 247, 5052, 5051, 269, 5105, 5106, 5103
2466, 247, 248, 5053, 5052, 270, 5107, 5108, 5105
2467, 248, 249, 5054, 5053, 271, 5109, 5110, 5107
2468, 249, 250, 5055, 5054, 272, 5111, 5112, 5109
2469, 250, 251, 5056, 5055, 273, 5113, 5114, 5111
2470, 251, 252, 5057, 5056, 274, 5115, 5116, 5113
2471, 252, 253, 5058, 5057, 275, 5117, 5118, 5115
2472, 253, 254, 5059, 5058, 276, 5119, 5120, 5117
2473, 254, 255, 5060, 5059, 277, 5121, 5122, 5119
2474, 255, 256, 5061, 5060, 278, 5123, 5124, 5121
2475, 256, 257, 5062, 5061, 279, 5125, 5126, 5123
2476, 257, 258, 5063, 5062, 280, 5127, 5128, 5125
2477, 258, 259, 5064, 5063, 281, 5129, 5130, 5127
2478, 259, 5, 162, 5064, 282, 164, 5131, 5129
2479, 110, 5043, 5065, 111, 5088, 5132, 5133, 113
2480, 5043, 5044, 5066, 5065, 5090, 5134, 5135, 5132
2481, 5044, 5045, 5067, 5066, 5092, 5136, 5137, 5134
2482, 5045, 5046, 5068, 5067, 5094, 5138, 5139, 5136
2483, 5046, 5047, 5069, 5068, 5096, 5140, 5141, 5138
2484, 5047, 5048, 5070, 5069, 5098, 5142, 5143, 5140
2485, 5048, 5049, 5071, 5070, 5100, 5144, 5145, 5142
2486, 5049, 5050, 5072, 5071, 5102, 5146, 5147, 5144
2487, 5050, 5051, 5073, 5072, 5104, 5148, 5149, 5146
2488, 5051, 5052, 5074, 5073, 5106, 5150, 5151, 5148
2489, 5052, 5053, 5075, 5074, 5108, 5152, 5153, 5150
2490, 5053, 5054, 5076, 5075, 5110, 5154, 5155, 5152
2491, 5054, 5055, 5077, 5076, 5112, 5156, 5157, 5154
2492, 5055, 5056, 5078, 5077, 5114, 5158, 5159, 5156
2493, 5056, 5057, 5079, 5078, 5116, 5160, 5161, 5158
2494, 5057, 5058, 5080, 5079, 5118, 5162, 5163, 5160
2495, 5058, 5059, 5081, 5080, 5120, 5164, 5165, 5162
2496, 5059, 5060, 5082, 5081, 5122, 5166, 5167, 5164
2497, 5060, 5061, 5083, 5082, 5124, 5168, 5169, 5166
2498, 5061, 5062, 5084, 5083, 5126, 5170, 5171, 5168
2499, 5062, 5063, 5085, 5084, 5128, 5172, 5173, 5170
2500, 5063, 5064, 5086, 5085, 5130, 5174, 5175, 5172
2501, 5064, 162, 163, 5086, 5131, 165, 5176, 5174
2502, 111, 5065, 328, 3, 5133, 5177, 350, 114
2503, 5065, 5066, 329, 328, 5135, 5178, 351, 5177
2504, 5066, 5067, 330, 329, 5137, 5179, 352, 5178
2505, 5067, 5068, 331, 330, 5139, 5180, 353, 5179
2506, 5068, 5069, 332, 331, 5141, 5181, 354, 5180
2507, 5069, 5070, 333, 332, 5143, 5182, 355, 5181
2508, 5070, 5071, 334, 333, 5145, 5183, 356, 5182
2509, 5071, 5072, 335, 334, 5147, 5184, 357, 5183
2510, 5072, 5073, 336, 335, 5149, 5185, 358, 5184
2511, 5073, 5074, 337, 336, 5151, 5186, 359, 5185
2512, 5074, 5075, 338, 337, 5153, 5187, 360, 5186
2513, 5075, 5076, 339, 338, 5155, 5188, 361, 5187
2514, 5076, 5077, 340, 339, 5157, 5189, 362, 5188
2515, 5077, 5078, 341, 340, 5159, 5190, 363, 5189
2516, 5078, 5079, 342, 341, 5161, 5191, 364, 5190
2517, 5079, 5080, 343, 342, 5163, 5192, 365, 5191
2518, 5080, 5081, 344, 343, 5165, 5193, 366, 5192
2519, 5081, 5082, 345, 344, 5167, 5194, 367, 5193
2520, 5082, 5083, 346, 345, 5169, 5195, 368, 5194
2521, 5083, 5084, 347, 346, 5171, 5196, 369, 5195
2522, 5084, 5085, 348, 347, 5173, 5197, 370, 5196
2523, 5085, 5086, 349, 348, 5175, 5198, 371, 5197
2524, 5086, 163, 7, 349, 5176, 166, 372, 5198
*ELEMENT, type=CPS8, ELSET=Surface7
2525, 8, 304, 5199, 373, 327, 5221, 5222, 374
2526, 304, 303, 5200, 5199, 326, 5223, 5224, 5221
2527, 303, 302, 5201, 5200, 325, 5225, 5226, 5223
2528, 302, 301, 5202, 5201, 324, 5227, 5228, 5225
2529, 301, 300, 5203, 5202, 323, 5229, 5230, 5227
2530, 300, 299, 5204, 5203, 322, 5231, 5232, 5229
2531, 299, 298, 5205, 5204, 321, 5233, 5234, 5231
2532, 298, 297, 5206, 5205, 320, 5235, 5236, 5233
2533, 297, 296, 5207, 5206, 319, 5237, 5238, 5235
2534, 296, 295, 5208, 5207, 318, 5239, 5240, 5237
2535, 295, 294, 5209, 5208, 317, 5241, 5242, 5239
2536, 294, 293, 5210, 5209, 316, 5243, 5244, 5241
2537, 293, 292, 5211, 5210, 315, 5245, 5246, 5243
2538, 292, 291, 5212, 5211, 314, 5247, 5248, 5245
2539, 291, 290, 5213, 5212, 313, 5249, 5250, 5247
2540, 290, 289, 5214, 5213, 312, 5251, 5252, 5249
2541, 289, 288, 5215, 5214, 311, 5253, 5254, 5251
2542, 288, 287, 5216, 5215, 310, 5255, 5256, 5253
2543, 287, 286, 5217, 5216, 309, 5257, 5258, 5255
2544, 286, 285, 5218, 5217, 308, 5259, 5260, 5257
2545, 285, 284, 5219, 5218, 307, 5261, 5262, 5259
2546, 284, 283, 5220, 5219, 306, 5263, 5264, 5261
2547, 283, 4, 376, 5220, 305, 377, 5265, 5263
2548, 373, 5199, 400, 9, 5222, 5266, 423, 375
2549, 5199, 5200, 399, 400, 5224, 5267, 422, 5266
2550, 5200, 5201, 398, 399, 5226, 5268, 421, 5267
2551, 5201, 5202, 397, 398, 5228, 5269, 420, 5268
2552, 5202, 5203, 396, 397, 5230, 5270, 419, 5269
2553, 5203, 5204, 395, 396, 5232, 5271, 418, 5270
2554, 5204, 5205, 394, 395, 5234, 5272, 417, 5271
2555, 5205, 5206, 393, 394, 5236, 5273, 416, 5272
2556, 5206, 5207, 392, 393, 5238, 5274, 415, 5273
