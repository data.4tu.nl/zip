31025, 2.0695652173913, -0.2, 0.068181818181818
31026, 2.0695652173913, -0.2, 0.022727272727273
31027, 2.0913043478261, -0.2, 0.45454545454545
31028, 2.1130434782609, -0.2, 0.47727272727273
31029, 2.0913043478261, -0.2, 0.40909090909091
31030, 2.1130434782609, -0.2, 0.43181818181818
31031, 2.0913043478261, -0.2, 0.36363636363636
31032, 2.1130434782609, -0.2, 0.38636363636364
31033, 2.0913043478261, -0.2, 0.31818181818182
31034, 2.1130434782609, -0.2, 0.34090909090909
31035, 2.0913043478261, -0.2, 0.27272727272727
31036, 2.1130434782609, -0.2, 0.29545454545455
31037, 2.0913043478261, -0.2, 0.22727272727273
31038, 2.1130434782609, -0.2, 0.25
31039, 2.0913043478261, -0.2, 0.18181818181818
31040, 2.1130434782609, -0.2, 0.20454545454545
31041, 2.0913043478261, -0.2, 0.13636363636364
31042, 2.1130434782609, -0.2, 0.15909090909091
31043, 2.0913043478261, -0.2, 0.090909090909091
31044, 2.1130434782609, -0.2, 0.11363636363636
31045, 2.0913043478261, -0.2, 0.045454545454545
31046, 2.1130434782609, -0.2, 0.068181818181818
31047, 2.1130434782609, -0.2, 0.022727272727273
31048, 2.1347826086957, -0.2, 0.45454545454545
31049, 2.1565217391304, -0.2, 0.47727272727273
31050, 2.1347826086957, -0.2, 0.40909090909091
31051, 2.1565217391304, -0.2, 0.43181818181818
31052, 2.1347826086957, -0.2, 0.36363636363636
31053, 2.1565217391304, -0.2, 0.38636363636364
31054, 2.1347826086957, -0.2, 0.31818181818182
31055, 2.1565217391304, -0.2, 0.34090909090909
31056, 2.1347826086957, -0.2, 0.27272727272727
31057, 2.1565217391304, -0.2, 0.29545454545455
31058, 2.1347826086957, -0.2, 0.22727272727273
31059, 2.1565217391304, -0.2, 0.25
31060, 2.1347826086957, -0.2, 0.18181818181818
31061, 2.1565217391304, -0.2, 0.20454545454545
31062, 2.1347826086957, -0.2, 0.13636363636364
31063, 2.1565217391304, -0.2, 0.15909090909091
31064, 2.1347826086957, -0.2, 0.090909090909091
31065, 2.1565217391304, -0.2, 0.11363636363636
31066, 2.1347826086957, -0.2, 0.045454545454545
31067, 2.1565217391304, -0.2, 0.068181818181818
31068, 2.1565217391304, -0.2, 0.022727272727273
31069, 2.1782608695652, -0.2, 0.45454545454545
31070, 2.1782608695652, -0.2, 0.40909090909091
31071, 2.1782608695652, -0.2, 0.36363636363636
31072, 2.1782608695652, -0.2, 0.31818181818182
31073, 2.1782608695652, -0.2, 0.27272727272727
31074, 2.1782608695652, -0.2, 0.22727272727273
31075, 2.1782608695652, -0.2, 0.18181818181818
31076, 2.1782608695652, -0.2, 0.13636363636364
31077, 2.1782608695652, -0.2, 0.090909090909091
31078, 2.1782608695652, -0.2, 0.045454545454545
31079, 1.04, -0.05, 0.5
31080, 1.04, -0.1, 0.5
31081, 1.04, -0.15, 0.5
31082, 1.08, -0.05, 0.5
31083, 1.08, -0.1, 0.5
31084, 1.08, -0.15, 0.5
31085, 1.12, -0.05, 0.5
31086, 1.12, -0.1, 0.5
31087, 1.12, -0.15, 0.5
31088, 1.16, -0.05, 0.5
31089, 1.16, -0.1, 0.5
31090, 1.16, -0.15, 0.5
31091, 1.02, -0.05, 0.5
31092, 1.04, -0.025, 0.5
31093, 1.02, -0.1, 0.5
31094, 1.04, -0.075, 0.5
31095, 1.02, -0.15, 0.5
31096, 1.04, -0.125, 0.5
31097, 1.04, -0.175, 0.5
31098, 1.06, -0.05, 0.5
31099, 1.08, -0.025, 0.5
31100, 1.06, -0.1, 0.5
31101, 1.08, -0.075, 0.5
31102, 1.06, -0.15, 0.5
31103, 1.08, -0.125, 0.5
31104, 1.08, -0.175, 0.5
31105, 1.1, -0.05, 0.5
31106, 1.12, -0.025, 0.5
31107, 1.1, -0.1, 0.5
31108, 1.12, -0.075, 0.5
31109, 1.1, -0.15, 0.5
31110, 1.12, -0.125, 0.5
31111, 1.12, -0.175, 0.5
31112, 1.14, -0.05, 0.5
31113, 1.16, -0.025, 0.5
31114, 1.14, -0.1, 0.5
31115, 1.16, -0.075, 0.5
31116, 1.14, -0.15, 0.5
31117, 1.16, -0.125, 0.5
31118, 1.16, -0.175, 0.5
31119, 1.18, -0.05, 0.5
31120, 1.18, -0.1, 0.5
31121, 1.18, -0.15, 0.5
31122, 1.04, -0.05, 0
31123, 1.04, -0.1, 0
31124, 1.04, -0.15, 0
31125, 1.08, -0.05, 0
31126, 1.08, -0.1, 0
31127, 1.08, -0.15, 0
31128, 1.12, -0.05, 0
31129, 1.12, -0.1, 0
31130, 1.12, -0.15, 0
31131, 1.16, -0.05, 0
31132, 1.16, -0.1, 0
31133, 1.16, -0.15, 0
31134, 1.04, -0.025, 0
31135, 1.02, -0.05, 0
31136, 1.04, -0.075, 0
31137, 1.02, -0.1, 0
31138, 1.04, -0.125, 0
31139, 1.02, -0.15, 0
31140, 1.04, -0.175, 0
31141, 1.08, -0.025, 0
31142, 1.06, -0.05, 0
31143, 1.08, -0.075, 0
31144, 1.06, -0.1, 0
31145, 1.08, -0.125, 0
31146, 1.06, -0.15, 0
31147, 1.08, -0.175, 0
31148, 1.12, -0.025, 0
31149, 1.1, -0.05, 0
31150, 1.12, -0.075, 0
31151, 1.1, -0.1, 0
31152, 1.12, -0.125, 0
31153, 1.1, -0.15, 0
31154, 1.12, -0.175, 0
31155, 1.16, -0.025, 0
31156, 1.14, -0.05, 0
31157, 1.16, -0.075, 0
31158, 1.14, -0.1, 0
31159, 1.16, -0.125, 0
31160, 1.14, -0.15, 0
31161, 1.16, -0.175, 0
31162, 1.18, -0.05, 0
31163, 1.18, -0.1, 0
31164, 1.18, -0.15, 0
31165, 1.04, 0, 0.45454545454545
31166, 1.04, 0, 0.40909090909091
31167, 1.04, 0, 0.36363636363636
31168, 1.04, 0, 0.31818181818182
31169, 1.04, 0, 0.27272727272727
31170, 1.04, 0, 0.22727272727273
31171, 1.04, 0, 0.18181818181818
31172, 1.04, 0, 0.13636363636364
31173, 1.04, 0, 0.090909090909091
31174, 1.04, 0, 0.045454545454545
31175, 1.08, 0, 0.45454545454545
31176, 1.08, 0, 0.40909090909091
31177, 1.08, 0, 0.36363636363636
31178, 1.08, 0, 0.31818181818182
31179, 1.08, 0, 0.27272727272727
31180, 1.08, 0, 0.22727272727273
31181, 1.08, 0, 0.18181818181818
31182, 1.08, 0, 0.13636363636364
31183, 1.08, 0, 0.090909090909091
31184, 1.08, 0, 0.045454545454545
31185, 1.12, 0, 0.45454545454545
31186, 1.12, 0, 0.40909090909091
31187, 1.12, 0, 0.36363636363636
31188, 1.12, 0, 0.31818181818182
31189, 1.12, 0, 0.27272727272727
31190, 1.12, 0, 0.22727272727273
31191, 1.12, 0, 0.18181818181818
31192, 1.12, 0, 0.13636363636364
31193, 1.12, 0, 0.090909090909091
31194, 1.12, 0, 0.045454545454545
31195, 1.16, 0, 0.45454545454545
31196, 1.16, 0, 0.40909090909091
31197, 1.16, 0, 0.36363636363636
31198, 1.16, 0, 0.31818181818182
31199, 1.16, 0, 0.27272727272727
31200, 1.16, 0, 0.22727272727273
31201, 1.16, 0, 0.18181818181818
31202, 1.16, 0, 0.13636363636364
31203, 1.16, 0, 0.090909090909091
31204, 1.16, 0, 0.045454545454545
31205, 1.04, 0, 0.47727272727273
31206, 1.02, 0, 0.45454545454545
31207, 1.04, 0, 0.43181818181818
31208, 1.02, 0, 0.40909090909091
31209, 1.04, 0, 0.38636363636364
31210, 1.02, 0, 0.36363636363636
31211, 1.04, 0, 0.34090909090909
31212, 1.02, 0, 0.31818181818182
31213, 1.04, 0, 0.29545454545455
31214, 1.02, 0, 0.27272727272727
31215, 1.04, 0, 0.25
31216, 1.02, 0, 0.22727272727273
31217, 1.04, 0, 0.20454545454545
31218, 1.02, 0, 0.18181818181818
31219, 1.04, 0, 0.15909090909091
31220, 1.02, 0, 0.13636363636364
31221, 1.04, 0, 0.11363636363636
31222, 1.02, 0, 0.090909090909091
31223, 1.04, 0, 0.068181818181818
31224, 1.02, 0, 0.045454545454545
31225, 1.04, 0, 0.022727272727273
31226, 1.08, 0, 0.47727272727273
31227, 1.06, 0, 0.45454545454545
31228, 1.08, 0, 0.43181818181818
31229, 1.06, 0, 0.40909090909091
31230, 1.08, 0, 0.38636363636364
31231, 1.06, 0, 0.36363636363636
31232, 1.08, 0, 0.34090909090909
31233, 1.06, 0, 0.31818181818182
31234, 1.08, 0, 0.29545454545455
31235, 1.06, 0, 0.27272727272727
31236, 1.08, 0, 0.25
31237, 1.06, 0, 0.22727272727273
31238, 1.08, 0, 0.20454545454545
31239, 1.06, 0, 0.18181818181818
31240, 1.08, 0, 0.15909090909091
31241, 1.06, 0, 0.13636363636364
31242, 1.08, 0, 0.11363636363636
31243, 1.06, 0, 0.090909090909091
31244, 1.08, 0, 0.068181818181818
31245, 1.06, 0, 0.045454545454545
31246, 1.08, 0, 0.022727272727273
31247, 1.12, 0, 0.47727272727273
31248, 1.1, 0, 0.45454545454545
31249, 1.12, 0, 0.43181818181818
31250, 1.1, 0, 0.40909090909091
31251, 1.12, 0, 0.38636363636364
31252, 1.1, 0, 0.36363636363636
31253, 1.12, 0, 0.34090909090909
31254, 1.1, 0, 0.31818181818182
31255, 1.12, 0, 0.29545454545455
31256, 1.1, 0, 0.27272727272727
31257, 1.12, 0, 0.25
31258, 1.1, 0, 0.22727272727273
31259, 1.12, 0, 0.20454545454545
31260, 1.1, 0, 0.18181818181818
31261, 1.12, 0, 0.15909090909091
31262, 1.1, 0, 0.13636363636364
31263, 1.12, 0, 0.11363636363636
31264, 1.1, 0, 0.090909090909091
31265, 1.12, 0, 0.068181818181818
31266, 1.1, 0, 0.045454545454545
31267, 1.12, 0, 0.022727272727273
31268, 1.16, 0, 0.47727272727273
31269, 1.14, 0, 0.45454545454545
31270, 1.16, 0, 0.43181818181818
31271, 1.14, 0, 0.40909090909091
31272, 1.16, 0, 0.38636363636364
31273, 1.14, 0, 0.36363636363636
31274, 1.16, 0, 0.34090909090909
31275, 1.14, 0, 0.31818181818182
31276, 1.16, 0, 0.29545454545455
31277, 1.14, 0, 0.27272727272727
31278, 1.16, 0, 0.25
31279, 1.14, 0, 0.22727272727273
31280, 1.16, 0, 0.20454545454545
31281, 1.14, 0, 0.18181818181818
31282, 1.16, 0, 0.15909090909091
31283, 1.14, 0, 0.13636363636364
31284, 1.16, 0, 0.11363636363636
31285, 1.14, 0, 0.090909090909091
31286, 1.16, 0, 0.068181818181818
31287, 1.14, 0, 0.045454545454545
31288, 1.16, 0, 0.022727272727273
31289, 1.18, 0, 0.45454545454545
31290, 1.18, 0, 0.40909090909091
31291, 1.18, 0, 0.36363636363636
31292, 1.18, 0, 0.31818181818182
31293, 1.18, 0, 0.27272727272727
31294, 1.18, 0, 0.22727272727273
31295, 1.18, 0, 0.18181818181818
31296, 1.18, 0, 0.13636363636364
31297, 1.18, 0, 0.090909090909091
31298, 1.18, 0, 0.045454545454545
31299, 1.04, -0.2, 0.45454545454545
31300, 1.04, -0.2, 0.40909090909091
31301, 1.04, -0.2, 0.36363636363636
31302, 1.04, -0.2, 0.31818181818182
31303, 1.04, -0.2, 0.27272727272727
31304, 1.04, -0.2, 0.22727272727273
31305, 1.04, -0.2, 0.18181818181818
31306, 1.04, -0.2, 0.13636363636364
31307, 1.04, -0.2, 0.090909090909091
31308, 1.04, -0.2, 0.045454545454545
31309, 1.08, -0.2, 0.45454545454545
31310, 1.08, -0.2, 0.40909090909091
31311, 1.08, -0.2, 0.36363636363636
31312, 1.08, -0.2, 0.31818181818182
31313, 1.08, -0.2, 0.27272727272727
31314, 1.08, -0.2, 0.22727272727273
31315, 1.08, -0.2, 0.18181818181818
31316, 1.08, -0.2, 0.13636363636364
31317, 1.08, -0.2, 0.090909090909091
31318, 1.08, -0.2, 0.045454545454545
31319, 1.12, -0.2, 0.45454545454545
31320, 1.12, -0.2, 0.40909090909091
31321, 1.12, -0.2, 0.36363636363636
31322, 1.12, -0.2, 0.31818181818182
31323, 1.12, -0.2, 0.27272727272727
31324, 1.12, -0.2, 0.22727272727273
31325, 1.12, -0.2, 0.18181818181818
31326, 1.12, -0.2, 0.13636363636364
31327, 1.12, -0.2, 0.090909090909091
31328, 1.12, -0.2, 0.045454545454545
31329, 1.16, -0.2, 0.45454545454545
31330, 1.16, -0.2, 0.40909090909091
31331, 1.16, -0.2, 0.36363636363636
31332, 1.16, -0.2, 0.31818181818182
31333, 1.16, -0.2, 0.27272727272727
31334, 1.16, -0.2, 0.22727272727273
31335, 1.16, -0.2, 0.18181818181818
31336, 1.16, -0.2, 0.13636363636364
31337, 1.16, -0.2, 0.090909090909091
31338, 1.16, -0.2, 0.045454545454545
31339, 1.02, -0.2, 0.45454545454545
31340, 1.04, -0.2, 0.47727272727273
31341, 1.02, -0.2, 0.40909090909091
31342, 1.04, -0.2, 0.43181818181818
31343, 1.02, -0.2, 0.36363636363636
31344, 1.04, -0.2, 0.38636363636364
31345, 1.02, -0.2, 0.31818181818182
31346, 1.04, -0.2, 0.34090909090909
31347, 1.02, -0.2, 0.27272727272727
31348, 1.04, -0.2, 0.29545454545455
31349, 1.02, -0.2, 0.22727272727273
31350, 1.04, -0.2, 0.25
31351, 1.02, -0.2, 0.18181818181818
31352, 1.04, -0.2, 0.20454545454545
31353, 1.02, -0.2, 0.13636363636364
31354, 1.04, -0.2, 0.15909090909091
31355, 1.02, -0.2, 0.090909090909091
31356, 1.04, -0.2, 0.11363636363636
31357, 1.02, -0.2, 0.045454545454545
31358, 1.04, -0.2, 0.068181818181818
31359, 1.04, -0.2, 0.022727272727273
31360, 1.06, -0.2, 0.45454545454545
31361, 1.08, -0.2, 0.47727272727273
31362, 1.06, -0.2, 0.40909090909091
31363, 1.08, -0.2, 0.43181818181818
31364, 1.06, -0.2, 0.36363636363636
31365, 1.08, -0.2, 0.38636363636364
31366, 1.06, -0.2, 0.31818181818182
31367, 1.08, -0.2, 0.34090909090909
31368, 1.06, -0.2, 0.27272727272727
31369, 1.08, -0.2, 0.29545454545455
31370, 1.06, -0.2, 0.22727272727273
31371, 1.08, -0.2, 0.25
31372, 1.06, -0.2, 0.18181818181818
31373, 1.08, -0.2, 0.20454545454545
31374, 1.06, -0.2, 0.13636363636364
31375, 1.08, -0.2, 0.15909090909091
31376, 1.06, -0.2, 0.090909090909091
31377, 1.08, -0.2, 0.11363636363636
31378, 1.06, -0.2, 0.045454545454545
31379, 1.08, -0.2, 0.068181818181818
31380, 1.08, -0.2, 0.022727272727273
31381, 1.1, -0.2, 0.45454545454545
31382, 1.12, -0.2, 0.47727272727273
31383, 1.1, -0.2, 0.40909090909091
31384, 1.12, -0.2, 0.43181818181818
31385, 1.1, -0.2, 0.36363636363636
31386, 1.12, -0.2, 0.38636363636364
31387, 1.1, -0.2, 0.31818181818182
31388, 1.12, -0.2, 0.34090909090909
31389, 1.1, -0.2, 0.27272727272727
31390, 1.12, -0.2, 0.29545454545455
31391, 1.1, -0.2, 0.22727272727273
31392, 1.12, -0.2, 0.25
31393, 1.1, -0.2, 0.18181818181818
31394, 1.12, -0.2, 0.20454545454545
31395, 1.1, -0.2, 0.13636363636364
31396, 1.12, -0.2, 0.15909090909091
31397, 1.1, -0.2, 0.090909090909091
31398, 1.12, -0.2, 0.11363636363636
31399, 1.1, -0.2, 0.045454545454545
31400, 1.12, -0.2, 0.068181818181818
31401, 1.12, -0.2, 0.022727272727273
31402, 1.14, -0.2, 0.45454545454545
31403, 1.16, -0.2, 0.47727272727273
31404, 1.14, -0.2, 0.40909090909091
31405, 1.16, -0.2, 0.43181818181818
31406, 1.14, -0.2, 0.36363636363636
31407, 1.16, -0.2, 0.38636363636364
31408, 1.14, -0.2, 0.31818181818182
31409, 1.16, -0.2, 0.34090909090909
31410, 1.14, -0.2, 0.27272727272727
31411, 1.16, -0.2, 0.29545454545455
31412, 1.14, -0.2, 0.22727272727273
31413, 1.16, -0.2, 0.25
31414, 1.14, -0.2, 0.18181818181818
31415, 1.16, -0.2, 0.20454545454545
31416, 1.14, -0.2, 0.13636363636364
31417, 1.16, -0.2, 0.15909090909091
31418, 1.14, -0.2, 0.090909090909091
31419, 1.16, -0.2, 0.11363636363636
31420, 1.14, -0.2, 0.045454545454545
31421, 1.16, -0.2, 0.068181818181818
31422, 1.16, -0.2, 0.022727272727273
31423, 1.18, -0.2, 0.45454545454545
31424, 1.18, -0.2, 0.40909090909091
31425, 1.18, -0.2, 0.36363636363636
31426, 1.18, -0.2, 0.31818181818182
31427, 1.18, -0.2, 0.27272727272727
31428, 1.18, -0.2, 0.22727272727273
31429, 1.18, -0.2, 0.18181818181818
31430, 1.18, -0.2, 0.13636363636364
31431, 1.18, -0.2, 0.090909090909091
31432, 1.18, -0.2, 0.045454545454545
31433, 0.043478260869565, 0.033333333333333, 0.045454545454545
31434, 0.08695652173913, 0.033333333333333, 0.045454545454545
31435, 0.1304347826087, 0.033333333333333, 0.045454545454545
31436, 0.17391304347826, 0.033333333333333, 0.045454545454545
31437, 0.21739130434783, 0.033333333333333, 0.045454545454545
31438, 0.26086956521739, 0.033333333333333, 0.045454545454545
31439, 0.30434782608696, 0.033333333333333, 0.045454545454545
31440, 0.34782608695652, 0.033333333333333, 0.045454545454545
31441, 0.39130434782609, 0.033333333333333, 0.045454545454545
31442, 0.43478260869565, 0.033333333333333, 0.045454545454545
31443, 0.47826086956522, 0.033333333333333, 0.045454545454545
31444, 0.52173913043478, 0.033333333333333, 0.045454545454545
31445, 0.56521739130435, 0.033333333333333, 0.045454545454545
31446, 0.60869565217391, 0.033333333333333, 0.045454545454545
31447, 0.65217391304348, 0.033333333333333, 0.045454545454545
31448, 0.69565217391304, 0.033333333333333, 0.045454545454545
31449, 0.73913043478261, 0.033333333333333, 0.045454545454545
31450, 0.78260869565217, 0.033333333333333, 0.045454545454545
31451, 0.82608695652174, 0.033333333333333, 0.045454545454545
31452, 0.8695652173913, 0.033333333333333, 0.045454545454545
31453, 0.91304347826087, 0.033333333333333, 0.045454545454545
31454, 0.95652173913044, 0.033333333333333, 0.045454545454545
31455, 0.043478260869565, 0.066666666666667, 0.045454545454545
31456, 0.08695652173913, 0.066666666666667, 0.045454545454545
31457, 0.1304347826087, 0.066666666666667, 0.045454545454545
31458, 0.17391304347826, 0.066666666666667, 0.045454545454545
31459, 0.21739130434783, 0.066666666666667, 0.045454545454545
31460, 0.26086956521739, 0.066666666666667, 0.045454545454545
31461, 0.30434782608696, 0.066666666666667, 0.045454545454545
31462, 0.34782608695652, 0.066666666666667, 0.045454545454545
31463, 0.39130434782609, 0.066666666666667, 0.045454545454545
31464, 0.43478260869565, 0.066666666666667, 0.045454545454545
31465, 0.47826086956522, 0.066666666666667, 0.045454545454545
31466, 0.52173913043478, 0.066666666666667, 0.045454545454545
31467, 0.56521739130435, 0.066666666666667, 0.045454545454545
31468, 0.60869565217391, 0.066666666666667, 0.045454545454545
31469, 0.65217391304348, 0.066666666666667, 0.045454545454545
31470, 0.69565217391304, 0.066666666666667, 0.045454545454545
31471, 0.73913043478261, 0.066666666666667, 0.045454545454545
31472, 0.78260869565217, 0.066666666666667, 0.045454545454545
31473, 0.82608695652174, 0.066666666666667, 0.045454545454545
31474, 0.8695652173913, 0.066666666666667, 0.045454545454545
31475, 0.91304347826087, 0.066666666666667, 0.045454545454545
31476, 0.95652173913044, 0.066666666666667, 0.045454545454545
31477, 0.043478260869565, 0.033333333333333, 0.090909090909091
31478, 0.08695652173913, 0.033333333333333, 0.090909090909091
31479, 0.1304347826087, 0.033333333333333, 0.090909090909091
31480, 0.17391304347826, 0.033333333333333, 0.090909090909091
31481, 0.21739130434783, 0.033333333333333, 0.090909090909091
31482, 0.26086956521739, 0.033333333333333, 0.090909090909091
31483, 0.30434782608696, 0.033333333333333, 0.090909090909091
31484, 0.34782608695652, 0.033333333333333, 0.090909090909091
31485, 0.39130434782609, 0.033333333333333, 0.090909090909091
31486, 0.43478260869565, 0.033333333333333, 0.090909090909091
31487, 0.47826086956522, 0.033333333333333, 0.090909090909091
31488, 0.52173913043478, 0.033333333333333, 0.090909090909091
31489, 0.56521739130435, 0.033333333333333, 0.090909090909091
31490, 0.60869565217391, 0.033333333333333, 0.090909090909091
31491, 0.65217391304348, 0.033333333333333, 0.090909090909091
31492, 0.69565217391304, 0.033333333333333, 0.090909090909091
31493, 0.73913043478261, 0.033333333333333, 0.090909090909091
31494, 0.78260869565217, 0.033333333333333, 0.090909090909091
31495, 0.82608695652174, 0.033333333333333, 0.090909090909091
31496, 0.8695652173913, 0.033333333333333, 0.090909090909091
31497, 0.91304347826087, 0.033333333333333, 0.090909090909091
31498, 0.95652173913043, 0.033333333333333, 0.090909090909091
31499, 0.043478260869565, 0.066666666666667, 0.090909090909091
31500, 0.08695652173913, 0.066666666666667, 0.090909090909091
31501, 0.1304347826087, 0.066666666666667, 0.090909090909091
31502, 0.17391304347826, 0.066666666666667, 0.090909090909091
31503, 0.21739130434783, 0.066666666666667, 0.090909090909091
31504, 0.26086956521739, 0.066666666666667, 0.090909090909091
31505, 0.30434782608696, 0.066666666666667, 0.090909090909091
31506, 0.34782608695652, 0.066666666666667, 0.090909090909091
31507, 0.39130434782609, 0.066666666666667, 0.090909090909091
31508, 0.43478260869565, 0.066666666666667, 0.090909090909091
31509, 0.47826086956522, 0.066666666666667, 0.090909090909091
31510, 0.52173913043478, 0.066666666666667, 0.090909090909091
31511, 0.56521739130435, 0.066666666666667, 0.090909090909091
31512, 0.60869565217391, 0.066666666666667, 0.090909090909091
31513, 0.65217391304348, 0.066666666666667, 0.090909090909091
31514, 0.69565217391304, 0.066666666666667, 0.090909090909091
31515, 0.73913043478261, 0.066666666666667, 0.090909090909091
31516, 0.78260869565217, 0.066666666666667, 0.090909090909091
31517, 0.82608695652174, 0.066666666666667, 0.090909090909091
31518, 0.8695652173913, 0.066666666666667, 0.090909090909091
31519, 0.91304347826087, 0.066666666666667, 0.090909090909091
31520, 0.95652173913044, 0.066666666666667, 0.090909090909091
31521, 0.043478260869565, 0.033333333333333, 0.13636363636364
31522, 0.08695652173913, 0.033333333333333, 0.13636363636364
31523, 0.1304347826087, 0.033333333333333, 0.13636363636364
31524, 0.17391304347826, 0.033333333333333, 0.13636363636364
31525, 0.21739130434783, 0.033333333333333, 0.13636363636364
31526, 0.26086956521739, 0.033333333333333, 0.13636363636364
31527, 0.30434782608696, 0.033333333333333, 0.13636363636364
31528, 0.34782608695652, 0.033333333333333, 0.13636363636364
31529, 0.39130434782609, 0.033333333333333, 0.13636363636364
31530, 0.43478260869565, 0.033333333333333, 0.13636363636364
31531, 0.47826086956522, 0.033333333333333, 0.13636363636364
31532, 0.52173913043478, 0.033333333333333, 0.13636363636364
31533, 0.56521739130435, 0.033333333333333, 0.13636363636364
31534, 0.60869565217391, 0.033333333333333, 0.13636363636364
31535, 0.65217391304348, 0.033333333333333, 0.13636363636364
31536, 0.69565217391304, 0.033333333333333, 0.13636363636364
31537, 0.73913043478261, 0.033333333333333, 0.13636363636364
31538, 0.78260869565217, 0.033333333333333, 0.13636363636364
31539, 0.82608695652174, 0.033333333333333, 0.13636363636364
31540, 0.8695652173913, 0.033333333333333, 0.13636363636364
31541, 0.91304347826087, 0.033333333333333, 0.13636363636364
31542, 0.95652173913043, 0.033333333333333, 0.13636363636364
31543, 0.043478260869565, 0.066666666666667, 0.13636363636364
31544, 0.08695652173913, 0.066666666666667, 0.13636363636364
31545, 0.1304347826087, 0.066666666666667, 0.13636363636364
31546, 0.17391304347826, 0.066666666666667, 0.13636363636364
31547, 0.21739130434783, 0.066666666666667, 0.13636363636364
31548, 0.26086956521739, 0.066666666666667, 0.13636363636364
31549, 0.30434782608696, 0.066666666666667, 0.13636363636364
31550, 0.34782608695652, 0.066666666666667, 0.13636363636364
31551, 0.39130434782609, 0.066666666666667, 0.13636363636364
31552, 0.43478260869565, 0.066666666666667, 0.13636363636364
31553, 0.47826086956522, 0.066666666666667, 0.13636363636364
31554, 0.52173913043478, 0.066666666666667, 0.13636363636364
31555, 0.56521739130435, 0.066666666666667, 0.13636363636364
31556, 0.60869565217391, 0.066666666666667, 0.13636363636364
31557, 0.65217391304348, 0.066666666666667, 0.13636363636364
31558, 0.69565217391304, 0.066666666666667, 0.13636363636364
31559, 0.73913043478261, 0.066666666666667, 0.13636363636364
31560, 0.78260869565217, 0.066666666666667, 0.13636363636364
31561, 0.82608695652174, 0.066666666666667, 0.13636363636364
31562, 0.8695652173913, 0.066666666666667, 0.13636363636364
31563, 0.91304347826087, 0.066666666666667, 0.13636363636364
31564, 0.95652173913044, 0.066666666666667, 0.13636363636364
31565, 0.043478260869565, 0.033333333333333, 0.18181818181818
31566, 0.08695652173913, 0.033333333333333, 0.18181818181818
31567, 0.1304347826087, 0.033333333333333, 0.18181818181818
31568, 0.17391304347826, 0.033333333333333, 0.18181818181818
31569, 0.21739130434783, 0.033333333333333, 0.18181818181818
31570, 0.26086956521739, 0.033333333333333, 0.18181818181818
31571, 0.30434782608696, 0.033333333333333, 0.18181818181818
31572, 0.34782608695652, 0.033333333333333, 0.18181818181818
31573, 0.39130434782609, 0.033333333333333, 0.18181818181818
31574, 0.43478260869565, 0.033333333333333, 0.18181818181818
31575, 0.47826086956522, 0.033333333333333, 0.18181818181818
31576, 0.52173913043478, 0.033333333333333, 0.18181818181818
31577, 0.56521739130435, 0.033333333333333, 0.18181818181818
31578, 0.60869565217391, 0.033333333333333, 0.18181818181818
31579, 0.65217391304348, 0.033333333333333, 0.18181818181818
31580, 0.69565217391304, 0.033333333333333, 0.18181818181818
31581, 0.73913043478261, 0.033333333333333, 0.18181818181818
31582, 0.78260869565217, 0.033333333333333, 0.18181818181818
31583, 0.82608695652174, 0.033333333333333, 0.18181818181818
31584, 0.8695652173913, 0.033333333333333, 0.18181818181818
31585, 0.91304347826087, 0.033333333333333, 0.18181818181818
31586, 0.95652173913044, 0.033333333333333, 0.18181818181818
31587, 0.043478260869565, 0.066666666666667, 0.18181818181818
31588, 0.08695652173913, 0.066666666666667, 0.18181818181818
31589, 0.1304347826087, 0.066666666666667, 0.18181818181818
31590, 0.17391304347826, 0.066666666666667, 0.18181818181818
31591, 0.21739130434783, 0.066666666666667, 0.18181818181818
31592, 0.26086956521739, 0.066666666666667, 0.18181818181818
31593, 0.30434782608696, 0.066666666666667, 0.18181818181818
31594, 0.34782608695652, 0.066666666666667, 0.18181818181818
31595, 0.39130434782609, 0.066666666666667, 0.18181818181818
31596, 0.43478260869565, 0.066666666666667, 0.18181818181818
31597, 0.47826086956522, 0.066666666666667, 0.18181818181818
31598, 0.52173913043478, 0.066666666666667, 0.18181818181818
31599, 0.56521739130435, 0.066666666666667, 0.18181818181818
31600, 0.60869565217391, 0.066666666666667, 0.18181818181818
31601, 0.65217391304348, 0.066666666666667, 0.18181818181818
31602, 0.69565217391304, 0.066666666666667, 0.18181818181818
31603, 0.73913043478261, 0.066666666666667, 0.18181818181818
31604, 0.78260869565217, 0.066666666666667, 0.18181818181818
31605, 0.82608695652174, 0.066666666666667, 0.18181818181818
31606, 0.8695652173913, 0.066666666666667, 0.18181818181818
31607, 0.91304347826087, 0.066666666666667, 0.18181818181818
31608, 0.95652173913044, 0.066666666666667, 0.18181818181818
31609, 0.043478260869565, 0.033333333333333, 0.22727272727273
31610, 0.08695652173913, 0.033333333333333, 0.22727272727273
31611, 0.1304347826087, 0.033333333333333, 0.22727272727273
31612, 0.17391304347826, 0.033333333333333, 0.22727272727273
31613, 0.21739130434783, 0.033333333333333, 0.22727272727273
31614, 0.26086956521739, 0.033333333333333, 0.22727272727273
31615, 0.30434782608696, 0.033333333333333, 0.22727272727273
31616, 0.34782608695652, 0.033333333333333, 0.22727272727273
31617, 0.39130434782609, 0.033333333333333, 0.22727272727273
31618, 0.43478260869565, 0.033333333333333, 0.22727272727273
31619, 0.47826086956522, 0.033333333333333, 0.22727272727273
31620, 0.52173913043478, 0.033333333333333, 0.22727272727273
31621, 0.56521739130435, 0.033333333333333, 0.22727272727273
31622, 0.60869565217391, 0.033333333333333, 0.22727272727273
31623, 0.65217391304348, 0.033333333333333, 0.22727272727273
31624, 0.69565217391304, 0.033333333333333, 0.22727272727273
31625, 0.73913043478261, 0.033333333333333, 0.22727272727273
31626, 0.78260869565217, 0.033333333333333, 0.22727272727273
31627, 0.82608695652174, 0.033333333333333, 0.22727272727273
31628, 0.8695652173913, 0.033333333333333, 0.22727272727273
31629, 0.91304347826087, 0.033333333333333, 0.22727272727273
31630, 0.95652173913044, 0.033333333333333, 0.22727272727273
31631, 0.043478260869565, 0.066666666666667, 0.22727272727273
31632, 0.08695652173913, 0.066666666666667, 0.22727272727273
31633, 0.1304347826087, 0.066666666666667, 0.22727272727273
31634, 0.17391304347826, 0.066666666666667, 0.22727272727273
31635, 0.21739130434783, 0.066666666666667, 0.22727272727273
31636, 0.26086956521739, 0.066666666666667, 0.22727272727273
31637, 0.30434782608696, 0.066666666666667, 0.22727272727273
31638, 0.34782608695652, 0.066666666666667, 0.22727272727273
31639, 0.39130434782609, 0.066666666666667, 0.22727272727273
31640, 0.43478260869565, 0.066666666666667, 0.22727272727273
31641, 0.47826086956522, 0.066666666666667, 0.22727272727273
31642, 0.52173913043478, 0.066666666666667, 0.22727272727273
31643, 0.56521739130435, 0.066666666666667, 0.22727272727273
31644, 0.60869565217391, 0.066666666666667, 0.22727272727273
31645, 0.65217391304348, 0.066666666666667, 0.22727272727273
31646, 0.69565217391304, 0.066666666666667, 0.22727272727273
31647, 0.73913043478261, 0.066666666666667, 0.22727272727273
31648, 0.78260869565217, 0.066666666666667, 0.22727272727273
31649, 0.82608695652174, 0.066666666666667, 0.22727272727273
31650, 0.8695652173913, 0.066666666666667, 0.22727272727273
31651, 0.91304347826087, 0.066666666666667, 0.22727272727273
31652, 0.95652173913044, 0.066666666666667, 0.22727272727273
31653, 0.043478260869565, 0.033333333333333, 0.27272727272727
31654, 0.08695652173913, 0.033333333333333, 0.27272727272727
31655, 0.1304347826087, 0.033333333333333, 0.27272727272727
31656, 0.17391304347826, 0.033333333333333, 0.27272727272727
31657, 0.21739130434783, 0.033333333333333, 0.27272727272727
31658, 0.26086956521739, 0.033333333333333, 0.27272727272727
31659, 0.30434782608696, 0.033333333333333, 0.27272727272727
31660, 0.34782608695652, 0.033333333333333, 0.27272727272727
31661, 0.39130434782609, 0.033333333333333, 0.27272727272727
31662, 0.43478260869565, 0.033333333333333, 0.27272727272727
31663, 0.47826086956522, 0.033333333333333, 0.27272727272727
31664, 0.52173913043478, 0.033333333333333, 0.27272727272727
31665, 0.56521739130435, 0.033333333333333, 0.27272727272727
31666, 0.60869565217391, 0.033333333333333, 0.27272727272727
31667, 0.65217391304348, 0.033333333333333, 0.27272727272727
31668, 0.69565217391304, 0.033333333333333, 0.27272727272727
31669, 0.73913043478261, 0.033333333333333, 0.27272727272727
31670, 0.78260869565217, 0.033333333333333, 0.27272727272727
31671, 0.82608695652174, 0.033333333333333, 0.27272727272727
31672, 0.8695652173913, 0.033333333333333, 0.27272727272727
31673, 0.91304347826087, 0.033333333333333, 0.27272727272727
31674, 0.95652173913044, 0.033333333333333, 0.27272727272727
31675, 0.043478260869565, 0.066666666666667, 0.27272727272727
31676, 0.08695652173913, 0.066666666666667, 0.27272727272727
31677, 0.1304347826087, 0.066666666666667, 0.27272727272727
31678, 0.17391304347826, 0.066666666666667, 0.27272727272727
31679, 0.21739130434783, 0.066666666666667, 0.27272727272727
31680, 0.26086956521739, 0.066666666666667, 0.27272727272727
31681, 0.30434782608696, 0.066666666666667, 0.27272727272727
31682, 0.34782608695652, 0.066666666666667, 0.27272727272727
31683, 0.39130434782609, 0.066666666666667, 0.27272727272727
31684, 0.43478260869565, 0.066666666666667, 0.27272727272727
31685, 0.47826086956522, 0.066666666666667, 0.27272727272727
31686, 0.52173913043478, 0.066666666666667, 0.27272727272727
31687, 0.56521739130435, 0.066666666666667, 0.27272727272727
31688, 0.60869565217391, 0.066666666666667, 0.27272727272727
31689, 0.65217391304348, 0.066666666666667, 0.27272727272727
31690, 0.69565217391304, 0.066666666666667, 0.27272727272727
31691, 0.73913043478261, 0.066666666666667, 0.27272727272727
31692, 0.78260869565217, 0.066666666666667, 0.27272727272727
31693, 0.82608695652174, 0.066666666666667, 0.27272727272727
31694, 0.8695652173913, 0.066666666666667, 0.27272727272727
31695, 0.91304347826087, 0.066666666666667, 0.27272727272727
31696, 0.95652173913044, 0.066666666666667, 0.27272727272727
31697, 0.043478260869565, 0.033333333333333, 0.31818181818182
31698, 0.08695652173913, 0.033333333333333, 0.31818181818182
31699, 0.1304347826087, 0.033333333333333, 0.31818181818182
31700, 0.17391304347826, 0.033333333333333, 0.31818181818182
31701, 0.21739130434783, 0.033333333333333, 0.31818181818182
31702, 0.26086956521739, 0.033333333333333, 0.31818181818182
31703, 0.30434782608696, 0.033333333333333, 0.31818181818182
31704, 0.34782608695652, 0.033333333333333, 0.31818181818182
31705, 0.39130434782609, 0.033333333333333, 0.31818181818182
31706, 0.43478260869565, 0.033333333333333, 0.31818181818182
31707, 0.47826086956522, 0.033333333333333, 0.31818181818182
31708, 0.52173913043478, 0.033333333333333, 0.31818181818182
31709, 0.56521739130435, 0.033333333333333, 0.31818181818182
31710, 0.60869565217391, 0.033333333333333, 0.31818181818182
31711, 0.65217391304348, 0.033333333333333, 0.31818181818182
31712, 0.69565217391304, 0.033333333333333, 0.31818181818182
31713, 0.73913043478261, 0.033333333333333, 0.31818181818182
31714, 0.78260869565217, 0.033333333333333, 0.31818181818182
31715, 0.82608695652174, 0.033333333333333, 0.31818181818182
31716, 0.8695652173913, 0.033333333333333, 0.31818181818182
31717, 0.91304347826087, 0.033333333333333, 0.31818181818182
31718, 0.95652173913044, 0.033333333333333, 0.31818181818182
31719, 0.043478260869565, 0.066666666666667, 0.31818181818182
31720, 0.08695652173913, 0.066666666666667, 0.31818181818182
31721, 0.1304347826087, 0.066666666666667, 0.31818181818182
31722, 0.17391304347826, 0.066666666666667, 0.31818181818182
31723, 0.21739130434783, 0.066666666666667, 0.31818181818182
31724, 0.26086956521739, 0.066666666666667, 0.31818181818182
31725, 0.30434782608696, 0.066666666666667, 0.31818181818182
31726, 0.34782608695652, 0.066666666666667, 0.31818181818182
31727, 0.39130434782609, 0.066666666666667, 0.31818181818182
31728, 0.43478260869565, 0.066666666666667, 0.31818181818182
31729, 0.47826086956522, 0.066666666666667, 0.31818181818182
31730, 0.52173913043478, 0.066666666666667, 0.31818181818182
31731, 0.56521739130435, 0.066666666666667, 0.31818181818182
31732, 0.60869565217391, 0.066666666666667, 0.31818181818182
31733, 0.65217391304348, 0.066666666666667, 0.31818181818182
31734, 0.69565217391304, 0.066666666666667, 0.31818181818182
31735, 0.73913043478261, 0.066666666666667, 0.31818181818182
31736, 0.78260869565217, 0.066666666666667, 0.31818181818182
31737, 0.82608695652174, 0.066666666666667, 0.31818181818182
31738, 0.8695652173913, 0.066666666666667, 0.31818181818182
31739, 0.91304347826087, 0.066666666666667, 0.31818181818182
31740, 0.95652173913044, 0.066666666666667, 0.31818181818182
31741, 0.043478260869565, 0.033333333333333, 0.36363636363636
31742, 0.08695652173913, 0.033333333333333, 0.36363636363636
31743, 0.1304347826087, 0.033333333333333, 0.36363636363636
31744, 0.17391304347826, 0.033333333333333, 0.36363636363636
31745, 0.21739130434783, 0.033333333333333, 0.36363636363636
31746, 0.26086956521739, 0.033333333333333, 0.36363636363636
31747, 0.30434782608696, 0.033333333333333, 0.36363636363636
31748, 0.34782608695652, 0.033333333333333, 0.36363636363636
31749, 0.39130434782609, 0.033333333333333, 0.36363636363636
31750, 0.43478260869565, 0.033333333333333, 0.36363636363636
31751, 0.47826086956522, 0.033333333333333, 0.36363636363636
31752, 0.52173913043478, 0.033333333333333, 0.36363636363636
31753, 0.56521739130435, 0.033333333333333, 0.36363636363636
31754, 0.60869565217391, 0.033333333333333, 0.36363636363636
31755, 0.65217391304348, 0.033333333333333, 0.36363636363636
31756, 0.69565217391304, 0.033333333333333, 0.36363636363636
31757, 0.73913043478261, 0.033333333333333, 0.36363636363636
31758, 0.78260869565217, 0.033333333333333, 0.36363636363636
31759, 0.82608695652174, 0.033333333333333, 0.36363636363636
31760, 0.8695652173913, 0.033333333333333, 0.36363636363636
31761, 0.91304347826087, 0.033333333333333, 0.36363636363636
31762, 0.95652173913043, 0.033333333333333, 0.36363636363636
31763, 0.043478260869565, 0.066666666666667, 0.36363636363636
31764, 0.08695652173913, 0.066666666666667, 0.36363636363636
31765, 0.1304347826087, 0.066666666666667, 0.36363636363636
31766, 0.17391304347826, 0.066666666666667, 0.36363636363636
31767, 0.21739130434783, 0.066666666666667, 0.36363636363636
31768, 0.26086956521739, 0.066666666666667, 0.36363636363636
31769, 0.30434782608696, 0.066666666666667, 0.36363636363636
31770, 0.34782608695652, 0.066666666666667, 0.36363636363636
31771, 0.39130434782609, 0.066666666666667, 0.36363636363636
31772, 0.43478260869565, 0.066666666666667, 0.36363636363636
31773, 0.47826086956522, 0.066666666666667, 0.36363636363636
31774, 0.52173913043478, 0.066666666666667, 0.36363636363636
31775, 0.56521739130435, 0.066666666666667, 0.36363636363636
31776, 0.60869565217391, 0.066666666666667, 0.36363636363636
31777, 0.65217391304348, 0.066666666666667, 0.36363636363636
31778, 0.69565217391304, 0.066666666666667, 0.36363636363636
31779, 0.73913043478261, 0.066666666666667, 0.36363636363636
31780, 0.78260869565217, 0.066666666666667, 0.36363636363636
31781, 0.82608695652174, 0.066666666666667, 0.36363636363636
31782, 0.8695652173913, 0.066666666666667, 0.36363636363636
31783, 0.91304347826087, 0.066666666666667, 0.36363636363636
31784, 0.95652173913044, 0.066666666666667, 0.36363636363636
31785, 0.043478260869565, 0.033333333333333, 0.40909090909091
31786, 0.08695652173913, 0.033333333333333, 0.40909090909091
31787, 0.1304347826087, 0.033333333333333, 0.40909090909091
31788, 0.17391304347826, 0.033333333333333, 0.40909090909091
31789, 0.21739130434783, 0.033333333333333, 0.40909090909091
31790, 0.26086956521739, 0.033333333333333, 0.40909090909091
31791, 0.30434782608696, 0.033333333333333, 0.40909090909091
31792, 0.34782608695652, 0.033333333333333, 0.40909090909091
31793, 0.39130434782609, 0.033333333333333, 0.40909090909091
31794, 0.43478260869565, 0.033333333333333, 0.40909090909091
31795, 0.47826086956522, 0.033333333333333, 0.40909090909091
31796, 0.52173913043478, 0.033333333333333, 0.40909090909091
31797, 0.56521739130435, 0.033333333333333, 0.40909090909091
31798, 0.60869565217391, 0.033333333333333, 0.40909090909091
31799, 0.65217391304348, 0.033333333333333, 0.40909090909091
31800, 0.69565217391304, 0.033333333333333, 0.40909090909091
31801, 0.73913043478261, 0.033333333333333, 0.40909090909091
31802, 0.78260869565217, 0.033333333333333, 0.40909090909091
31803, 0.82608695652174, 0.033333333333333, 0.40909090909091
31804, 0.8695652173913, 0.033333333333333, 0.40909090909091
31805, 0.91304347826087, 0.033333333333333, 0.40909090909091
31806, 0.95652173913044, 0.033333333333333, 0.40909090909091
31807, 0.043478260869565, 0.066666666666667, 0.40909090909091
31808, 0.08695652173913, 0.066666666666667, 0.40909090909091
31809, 0.1304347826087, 0.066666666666667, 0.40909090909091
31810, 0.17391304347826, 0.066666666666667, 0.40909090909091
31811, 0.21739130434783, 0.066666666666667, 0.40909090909091
31812, 0.26086956521739, 0.066666666666667, 0.40909090909091
31813, 0.30434782608696, 0.066666666666667, 0.40909090909091
31814, 0.34782608695652, 0.066666666666667, 0.40909090909091
31815, 0.39130434782609, 0.066666666666667, 0.40909090909091
31816, 0.43478260869565, 0.066666666666667, 0.40909090909091
31817, 0.47826086956522, 0.066666666666667, 0.40909090909091
31818, 0.52173913043478, 0.066666666666667, 0.40909090909091
31819, 0.56521739130435, 0.066666666666667, 0.40909090909091
31820, 0.60869565217391, 0.066666666666667, 0.40909090909091
31821, 0.65217391304348, 0.066666666666667, 0.40909090909091
31822, 0.69565217391304, 0.066666666666667, 0.40909090909091
31823, 0.73913043478261, 0.066666666666667, 0.40909090909091
31824, 0.78260869565217, 0.066666666666667, 0.40909090909091
31825, 0.82608695652174, 0.066666666666667, 0.40909090909091
31826, 0.8695652173913, 0.066666666666667, 0.40909090909091
31827, 0.91304347826087, 0.066666666666667, 0.40909090909091
31828, 0.95652173913044, 0.066666666666667, 0.40909090909091
31829, 0.043478260869565, 0.033333333333333, 0.45454545454545
31830, 0.08695652173913, 0.033333333333333, 0.45454545454545
31831, 0.1304347826087, 0.033333333333333, 0.45454545454545
31832, 0.17391304347826, 0.033333333333333, 0.45454545454545
31833, 0.21739130434783, 0.033333333333333, 0.45454545454545
31834, 0.26086956521739, 0.033333333333333, 0.45454545454545
31835, 0.30434782608696, 0.033333333333333, 0.45454545454545
31836, 0.34782608695652, 0.033333333333333, 0.45454545454545
31837, 0.39130434782609, 0.033333333333333, 0.45454545454545
31838, 0.43478260869565, 0.033333333333333, 0.45454545454545
31839, 0.47826086956522, 0.033333333333333, 0.45454545454545
31840, 0.52173913043478, 0.033333333333333, 0.45454545454545
31841, 0.56521739130435, 0.033333333333333, 0.45454545454545
31842, 0.60869565217391, 0.033333333333333, 0.45454545454545
31843, 0.65217391304348, 0.033333333333333, 0.45454545454545
31844, 0.69565217391304, 0.033333333333333, 0.45454545454545
31845, 0.73913043478261, 0.033333333333333, 0.45454545454545
31846, 0.78260869565217, 0.033333333333333, 0.45454545454545
31847, 0.82608695652174, 0.033333333333333, 0.45454545454545
31848, 0.8695652173913, 0.033333333333333, 0.45454545454545
31849, 0.91304347826087, 0.033333333333333, 0.45454545454545
31850, 0.95652173913043, 0.033333333333333, 0.45454545454545
31851, 0.043478260869565, 0.066666666666667, 0.45454545454545
31852, 0.08695652173913, 0.066666666666667, 0.45454545454545
31853, 0.1304347826087, 0.066666666666667, 0.45454545454545
31854, 0.17391304347826, 0.066666666666667, 0.45454545454545
31855, 0.21739130434783, 0.066666666666667, 0.45454545454545
31856, 0.26086956521739, 0.066666666666667, 0.45454545454545
31857, 0.30434782608696, 0.066666666666667, 0.45454545454545
31858, 0.34782608695652, 0.066666666666667, 0.45454545454545
31859, 0.39130434782609, 0.066666666666667, 0.45454545454545
31860, 0.43478260869565, 0.066666666666667, 0.45454545454545
31861, 0.47826086956522, 0.066666666666667, 0.45454545454545
31862, 0.52173913043478, 0.066666666666667, 0.45454545454545
31863, 0.56521739130435, 0.066666666666667, 0.45454545454545
31864, 0.60869565217391, 0.066666666666667, 0.45454545454545
31865, 0.65217391304348, 0.066666666666667, 0.45454545454545
31866, 0.69565217391304, 0.066666666666667, 0.45454545454545
31867, 0.73913043478261, 0.066666666666667, 0.45454545454545
31868, 0.78260869565217, 0.066666666666667, 0.45454545454545
31869, 0.82608695652174, 0.066666666666667, 0.45454545454545
31870, 0.8695652173913, 0.066666666666667, 0.45454545454545
31871, 0.91304347826087, 0.066666666666667, 0.45454545454545
31872, 0.95652173913044, 0.066666666666667, 0.45454545454545
31873, 0.021739130434783, 0.033333333333333, 0.045454545454545
31874, 0.043478260869565, 0.016666666666667, 0.045454545454545
31875, 0.043478260869565, 0.033333333333333, 0.022727272727273
31876, 0.065217391304348, 0.033333333333333, 0.045454545454545
31877, 0.08695652173913, 0.016666666666667, 0.045454545454545
31878, 0.08695652173913, 0.033333333333333, 0.022727272727273
31879, 0.10869565217391, 0.033333333333333, 0.045454545454545
31880, 0.1304347826087, 0.016666666666667, 0.045454545454545
31881, 0.1304347826087, 0.033333333333333, 0.022727272727273
31882, 0.15217391304348, 0.033333333333333, 0.045454545454545
31883, 0.17391304347826, 0.016666666666667, 0.045454545454545
31884, 0.17391304347826, 0.033333333333333, 0.022727272727273
31885, 0.19565217391304, 0.033333333333333, 0.045454545454545
31886, 0.21739130434783, 0.016666666666667, 0.045454545454545
31887, 0.21739130434783, 0.033333333333333, 0.022727272727273
31888, 0.23913043478261, 0.033333333333333, 0.045454545454545
31889, 0.26086956521739, 0.016666666666667, 0.045454545454545
31890, 0.26086956521739, 0.033333333333333, 0.022727272727273
31891, 0.28260869565217, 0.033333333333333, 0.045454545454545
31892, 0.30434782608696, 0.016666666666667, 0.045454545454545
31893, 0.30434782608696, 0.033333333333333, 0.022727272727273
31894, 0.32608695652174, 0.033333333333333, 0.045454545454545
31895, 0.34782608695652, 0.016666666666667, 0.045454545454545
31896, 0.34782608695652, 0.033333333333333, 0.022727272727273
31897, 0.3695652173913, 0.033333333333333, 0.045454545454545
31898, 0.39130434782609, 0.016666666666667, 0.045454545454545
31899, 0.39130434782609, 0.033333333333333, 0.022727272727273
31900, 0.41304347826087, 0.033333333333333, 0.045454545454545
31901, 0.43478260869565, 0.016666666666667, 0.045454545454545
31902, 0.43478260869565, 0.033333333333333, 0.022727272727273
31903, 0.45652173913043, 0.033333333333333, 0.045454545454545
31904, 0.47826086956522, 0.016666666666667, 0.045454545454545
31905, 0.47826086956522, 0.033333333333333, 0.022727272727273
31906, 0.5, 0.033333333333333, 0.045454545454545
31907, 0.52173913043478, 0.016666666666667, 0.045454545454545
31908, 0.52173913043478, 0.033333333333333, 0.022727272727273
31909, 0.54347826086957, 0.033333333333333, 0.045454545454545
31910, 0.56521739130435, 0.016666666666667, 0.045454545454545
31911, 0.56521739130435, 0.033333333333333, 0.022727272727273
31912, 0.58695652173913, 0.033333333333333, 0.045454545454545
31913, 0.60869565217391, 0.016666666666667, 0.045454545454545
31914, 0.60869565217391, 0.033333333333333, 0.022727272727273
31915, 0.6304347826087, 0.033333333333333, 0.045454545454545
31916, 0.65217391304348, 0.016666666666667, 0.045454545454545
31917, 0.65217391304348, 0.033333333333333, 0.022727272727273
31918, 0.67391304347826, 0.033333333333333, 0.045454545454545
31919, 0.69565217391304, 0.016666666666667, 0.045454545454545
31920, 0.69565217391304, 0.033333333333333, 0.022727272727273
31921, 0.71739130434783, 0.033333333333333, 0.045454545454545
31922, 0.73913043478261, 0.016666666666667, 0.045454545454545
31923, 0.73913043478261, 0.033333333333333, 0.022727272727273
31924, 0.76086956521739, 0.033333333333333, 0.045454545454545
31925, 0.78260869565217, 0.016666666666667, 0.045454545454545
31926, 0.78260869565217, 0.033333333333333, 0.022727272727273
31927, 0.80434782608696, 0.033333333333333, 0.045454545454545
31928, 0.82608695652174, 0.016666666666667, 0.045454545454545
31929, 0.82608695652174, 0.033333333333333, 0.022727272727273
31930, 0.84782608695652, 0.033333333333333, 0.045454545454545
31931, 0.8695652173913, 0.016666666666667, 0.045454545454545
31932, 0.8695652173913, 0.033333333333333, 0.022727272727273
31933, 0.89130434782609, 0.033333333333333, 0.045454545454545
31934, 0.91304347826087, 0.016666666666667, 0.045454545454545
31935, 0.91304347826087, 0.033333333333333, 0.022727272727273
31936, 0.93478260869565, 0.033333333333333, 0.045454545454545
31937, 0.95652173913044, 0.016666666666667, 0.045454545454545
31938, 0.95652173913044, 0.033333333333333, 0.022727272727273
31939, 0.97826086956522, 0.033333333333333, 0.045454545454545
31940, 0.021739130434783, 0.066666666666667, 0.045454545454545
31941, 0.043478260869565, 0.05, 0.045454545454545
31942, 0.043478260869565, 0.066666666666667, 0.022727272727273
31943, 0.065217391304348, 0.066666666666667, 0.045454545454545
31944, 0.08695652173913, 0.05, 0.045454545454545
31945, 0.08695652173913, 0.066666666666667, 0.022727272727273
31946, 0.10869565217391, 0.066666666666667, 0.045454545454545
31947, 0.1304347826087, 0.05, 0.045454545454545
31948, 0.1304347826087, 0.066666666666667, 0.022727272727273
31949, 0.15217391304348, 0.066666666666667, 0.045454545454545
31950, 0.17391304347826, 0.05, 0.045454545454545
31951, 0.17391304347826, 0.066666666666667, 0.022727272727273
31952, 0.19565217391304, 0.066666666666667, 0.045454545454545
31953, 0.21739130434783, 0.05, 0.045454545454545
31954, 0.21739130434783, 0.066666666666667, 0.022727272727273
31955, 0.23913043478261, 0.066666666666667, 0.045454545454545
31956, 0.26086956521739, 0.05, 0.045454545454545
31957, 0.26086956521739, 0.066666666666667, 0.022727272727273
31958, 0.28260869565217, 0.066666666666667, 0.045454545454545
31959, 0.30434782608696, 0.05, 0.045454545454545
31960, 0.30434782608696, 0.066666666666667, 0.022727272727273
31961, 0.32608695652174, 0.066666666666667, 0.045454545454545
31962, 0.34782608695652, 0.05, 0.045454545454545
31963, 0.34782608695652, 0.066666666666667, 0.022727272727273
31964, 0.3695652173913, 0.066666666666667, 0.045454545454545
31965, 0.39130434782609, 0.05, 0.045454545454545
31966, 0.39130434782609, 0.066666666666667, 0.022727272727273
31967, 0.41304347826087, 0.066666666666667, 0.045454545454545
31968, 0.43478260869565, 0.05, 0.045454545454545
31969, 0.43478260869565, 0.066666666666667, 0.022727272727273
31970, 0.45652173913043, 0.066666666666667, 0.045454545454545
31971, 0.47826086956522, 0.05, 0.045454545454545
31972, 0.47826086956522, 0.066666666666667, 0.022727272727273
31973, 0.5, 0.066666666666667, 0.045454545454545
31974, 0.52173913043478, 0.05, 0.045454545454545
31975, 0.52173913043478, 0.066666666666667, 0.022727272727273
31976, 0.54347826086957, 0.066666666666667, 0.045454545454545
31977, 0.56521739130435, 0.05, 0.045454545454545
31978, 0.56521739130435, 0.066666666666667, 0.022727272727273
31979, 0.58695652173913, 0.066666666666667, 0.045454545454545
31980, 0.60869565217391, 0.05, 0.045454545454545
31981, 0.60869565217391, 0.066666666666667, 0.022727272727273
31982, 0.6304347826087, 0.066666666666667, 0.045454545454545
31983, 0.65217391304348, 0.05, 0.045454545454545
31984, 0.65217391304348, 0.066666666666667, 0.022727272727273
31985, 0.67391304347826, 0.066666666666667, 0.045454545454545
31986, 0.69565217391304, 0.05, 0.045454545454545
31987, 0.69565217391304, 0.066666666666667, 0.022727272727273
31988, 0.71739130434783, 0.066666666666667, 0.045454545454545
31989, 0.73913043478261, 0.05, 0.045454545454545
31990, 0.73913043478261, 0.066666666666667, 0.022727272727273
31991, 0.76086956521739, 0.066666666666667, 0.045454545454545
31992, 0.78260869565217, 0.05, 0.045454545454545
31993, 0.78260869565217, 0.066666666666667, 0.022727272727273
31994, 0.80434782608696, 0.066666666666667, 0.045454545454545
31995, 0.82608695652174, 0.05, 0.045454545454545
31996, 0.82608695652174, 0.066666666666667, 0.022727272727273
31997, 0.84782608695652, 0.066666666666667, 0.045454545454545
31998, 0.8695652173913, 0.05, 0.045454545454545
31999, 0.8695652173913, 0.066666666666667, 0.022727272727273
32000, 0.89130434782609, 0.066666666666667, 0.045454545454545
32001, 0.91304347826087, 0.05, 0.045454545454545
32002, 0.91304347826087, 0.066666666666667, 0.022727272727273
32003, 0.93478260869565, 0.066666666666667, 0.045454545454545
32004, 0.95652173913044, 0.05, 0.045454545454545
32005, 0.95652173913043, 0.066666666666667, 0.022727272727273
32006, 0.97826086956522, 0.066666666666667, 0.045454545454545
32007, 0.043478260869565, 0.083333333333333, 0.045454545454545
32008, 0.08695652173913, 0.083333333333333, 0.045454545454545
32009, 0.1304347826087, 0.083333333333333, 0.045454545454545
32010, 0.17391304347826, 0.083333333333333, 0.045454545454545
32011, 0.21739130434783, 0.083333333333333, 0.045454545454545
32012, 0.26086956521739, 0.083333333333333, 0.045454545454545
32013, 0.30434782608696, 0.083333333333333, 0.045454545454545
32014, 0.34782608695652, 0.083333333333333, 0.045454545454545
32015, 0.39130434782609, 0.083333333333333, 0.045454545454545
32016, 0.43478260869565, 0.083333333333333, 0.045454545454545
32017, 0.47826086956522, 0.083333333333333, 0.045454545454545
32018, 0.52173913043478, 0.083333333333333, 0.045454545454545
32019, 0.56521739130435, 0.083333333333333, 0.045454545454545
32020, 0.60869565217391, 0.083333333333333, 0.045454545454545
32021, 0.65217391304348, 0.083333333333333, 0.045454545454545
32022, 0.69565217391304, 0.083333333333333, 0.045454545454545
32023, 0.73913043478261, 0.083333333333333, 0.045454545454545
32024, 0.78260869565217, 0.083333333333333, 0.045454545454545
32025, 0.82608695652174, 0.083333333333333, 0.045454545454545
32026, 0.8695652173913, 0.083333333333333, 0.045454545454545
32027, 0.91304347826087, 0.083333333333333, 0.045454545454545
32028, 0.95652173913043, 0.083333333333333, 0.045454545454545
32029, 0.021739130434783, 0.033333333333333, 0.090909090909091
32030, 0.043478260869565, 0.016666666666667, 0.090909090909091
32031, 0.043478260869565, 0.033333333333333, 0.068181818181818
32032, 0.065217391304348, 0.033333333333333, 0.090909090909091
32033, 0.08695652173913, 0.016666666666667, 0.090909090909091
32034, 0.08695652173913, 0.033333333333333, 0.068181818181818
32035, 0.10869565217391, 0.033333333333333, 0.090909090909091
32036, 0.1304347826087, 0.016666666666667, 0.090909090909091
32037, 0.1304347826087, 0.033333333333333, 0.068181818181818
32038, 0.15217391304348, 0.033333333333333, 0.090909090909091
32039, 0.17391304347826, 0.016666666666667, 0.090909090909091
32040, 0.17391304347826, 0.033333333333333, 0.068181818181818
32041, 0.19565217391304, 0.033333333333333, 0.090909090909091
32042, 0.21739130434783, 0.016666666666667, 0.090909090909091
32043, 0.21739130434783, 0.033333333333333, 0.068181818181818
32044, 0.23913043478261, 0.033333333333333, 0.090909090909091
32045, 0.26086956521739, 0.016666666666667, 0.090909090909091
32046, 0.26086956521739, 0.033333333333333, 0.068181818181818
32047, 0.28260869565217, 0.033333333333333, 0.090909090909091
32048, 0.30434782608696, 0.016666666666667, 0.090909090909091
32049, 0.30434782608696, 0.033333333333333, 0.068181818181818
32050, 0.32608695652174, 0.033333333333333, 0.090909090909091
32051, 0.34782608695652, 0.016666666666667, 0.090909090909091
32052, 0.34782608695652, 0.033333333333333, 0.068181818181818
32053, 0.3695652173913, 0.033333333333333, 0.090909090909091
32054, 0.39130434782609, 0.016666666666667, 0.090909090909091
32055, 0.39130434782609, 0.033333333333333, 0.068181818181818
32056, 0.41304347826087, 0.033333333333333, 0.090909090909091
32057, 0.43478260869565, 0.016666666666667, 0.090909090909091
32058, 0.43478260869565, 0.033333333333333, 0.068181818181818
32059, 0.45652173913043, 0.033333333333333, 0.090909090909091
32060, 0.47826086956522, 0.016666666666667, 0.090909090909091
32061, 0.47826086956522, 0.033333333333333, 0.068181818181818
32062, 0.5, 0.033333333333333, 0.090909090909091
32063, 0.52173913043478, 0.016666666666667, 0.090909090909091
32064, 0.52173913043478, 0.033333333333333, 0.068181818181818
32065, 0.54347826086957, 0.033333333333333, 0.090909090909091
32066, 0.56521739130435, 0.016666666666667, 0.090909090909091
32067, 0.56521739130435, 0.033333333333333, 0.068181818181818
32068, 0.58695652173913, 0.033333333333333, 0.090909090909091
32069, 0.60869565217391, 0.016666666666667, 0.090909090909091
32070, 0.60869565217391, 0.033333333333333, 0.068181818181818
32071, 0.6304347826087, 0.033333333333333, 0.090909090909091
32072, 0.65217391304348, 0.016666666666667, 0.090909090909091
32073, 0.65217391304348, 0.033333333333333, 0.068181818181818
32074, 0.67391304347826, 0.033333333333333, 0.090909090909091
32075, 0.69565217391304, 0.016666666666667, 0.090909090909091
32076, 0.69565217391304, 0.033333333333333, 0.068181818181818
32077, 0.71739130434783, 0.033333333333333, 0.090909090909091
32078, 0.73913043478261, 0.016666666666667, 0.090909090909091
32079, 0.73913043478261, 0.033333333333333, 0.068181818181818
32080, 0.76086956521739, 0.033333333333333, 0.090909090909091
32081, 0.78260869565217, 0.016666666666667, 0.090909090909091
32082, 0.78260869565217, 0.033333333333333, 0.068181818181818
32083, 0.80434782608696, 0.033333333333333, 0.090909090909091
32084, 0.82608695652174, 0.016666666666667, 0.090909090909091
32085, 0.82608695652174, 0.033333333333333, 0.068181818181818
32086, 0.84782608695652, 0.033333333333333, 0.090909090909091
32087, 0.8695652173913, 0.016666666666667, 0.090909090909091
32088, 0.8695652173913, 0.033333333333333, 0.068181818181818
32089, 0.89130434782609, 0.033333333333333, 0.090909090909091
32090, 0.91304347826087, 0.016666666666667, 0.090909090909091
32091, 0.91304347826087, 0.033333333333333, 0.068181818181818
32092, 0.93478260869565, 0.033333333333333, 0.090909090909091
32093, 0.95652173913043, 0.016666666666667, 0.090909090909091
32094, 0.95652173913044, 0.033333333333333, 0.068181818181818
32095, 0.97826086956522, 0.033333333333333, 0.090909090909091
32096, 0.021739130434783, 0.066666666666667, 0.090909090909091
32097, 0.043478260869565, 0.05, 0.090909090909091
32098, 0.043478260869565, 0.066666666666667, 0.068181818181818
32099, 0.065217391304348, 0.066666666666667, 0.090909090909091
32100, 0.08695652173913, 0.05, 0.090909090909091
32101, 0.08695652173913, 0.066666666666667, 0.068181818181818
32102, 0.10869565217391, 0.066666666666667, 0.090909090909091
32103, 0.1304347826087, 0.05, 0.090909090909091
32104, 0.1304347826087, 0.066666666666667, 0.068181818181818
32105, 0.15217391304348, 0.066666666666667, 0.090909090909091
32106, 0.17391304347826, 0.05, 0.090909090909091
32107, 0.17391304347826, 0.066666666666667, 0.068181818181818
32108, 0.19565217391304, 0.066666666666667, 0.090909090909091
32109, 0.21739130434783, 0.05, 0.090909090909091
32110, 0.21739130434783, 0.066666666666667, 0.068181818181818
32111, 0.23913043478261, 0.066666666666667, 0.090909090909091
32112, 0.26086956521739, 0.05, 0.090909090909091
32113, 0.26086956521739, 0.066666666666667, 0.068181818181818
32114, 0.28260869565217, 0.066666666666667, 0.090909090909091
32115, 0.30434782608696, 0.05, 0.090909090909091
32116, 0.30434782608696, 0.066666666666667, 0.068181818181818
32117, 0.32608695652174, 0.066666666666667, 0.090909090909091
32118, 0.34782608695652, 0.05, 0.090909090909091
32119, 0.34782608695652, 0.066666666666667, 0.068181818181818
32120, 0.3695652173913, 0.066666666666667, 0.090909090909091
32121, 0.39130434782609, 0.05, 0.090909090909091
32122, 0.39130434782609, 0.066666666666667, 0.068181818181818
32123, 0.41304347826087, 0.066666666666667, 0.090909090909091
32124, 0.43478260869565, 0.05, 0.090909090909091
32125, 0.43478260869565, 0.066666666666667, 0.068181818181818
32126, 0.45652173913043, 0.066666666666667, 0.090909090909091
32127, 0.47826086956522, 0.05, 0.090909090909091
32128, 0.47826086956522, 0.066666666666667, 0.068181818181818
32129, 0.5, 0.066666666666667, 0.090909090909091
32130, 0.52173913043478, 0.05, 0.090909090909091
32131, 0.52173913043478, 0.066666666666667, 0.068181818181818
32132, 0.54347826086957, 0.066666666666667, 0.090909090909091
32133, 0.56521739130435, 0.05, 0.090909090909091
32134, 0.56521739130435, 0.066666666666667, 0.068181818181818
32135, 0.58695652173913, 0.066666666666667, 0.090909090909091
32136, 0.60869565217391, 0.05, 0.090909090909091
32137, 0.60869565217391, 0.066666666666667, 0.068181818181818
32138, 0.6304347826087, 0.066666666666667, 0.090909090909091
32139, 0.65217391304348, 0.05, 0.090909090909091
32140, 0.65217391304348, 0.066666666666667, 0.068181818181818
32141, 0.67391304347826, 0.066666666666667, 0.090909090909091
32142, 0.69565217391304, 0.05, 0.090909090909091
32143, 0.69565217391304, 0.066666666666667, 0.068181818181818
32144, 0.71739130434783, 0.066666666666667, 0.090909090909091
32145, 0.73913043478261, 0.05, 0.090909090909091
32146, 0.73913043478261, 0.066666666666667, 0.068181818181818
32147, 0.76086956521739, 0.066666666666667, 0.090909090909091
32148, 0.78260869565217, 0.05, 0.090909090909091
32149, 0.78260869565217, 0.066666666666667, 0.068181818181818
32150, 0.80434782608696, 0.066666666666667, 0.090909090909091
32151, 0.82608695652174, 0.05, 0.090909090909091
32152, 0.82608695652174, 0.066666666666667, 0.068181818181818
32153, 0.84782608695652, 0.066666666666667, 0.090909090909091
32154, 0.8695652173913, 0.05, 0.090909090909091
32155, 0.8695652173913, 0.066666666666667, 0.068181818181818
32156, 0.89130434782609, 0.066666666666667, 0.090909090909091
32157, 0.91304347826087, 0.05, 0.090909090909091
32158, 0.91304347826087, 0.066666666666667, 0.068181818181818
32159, 0.93478260869565, 0.066666666666667, 0.090909090909091
32160, 0.95652173913044, 0.05, 0.090909090909091
32161, 0.95652173913044, 0.066666666666667, 0.068181818181818
32162, 0.97826086956522, 0.066666666666667, 0.090909090909091
32163, 0.043478260869565, 0.083333333333333, 0.090909090909091
32164, 0.08695652173913, 0.083333333333333, 0.090909090909091
32165, 0.1304347826087, 0.083333333333333, 0.090909090909091
32166, 0.17391304347826, 0.083333333333333, 0.090909090909091
32167, 0.21739130434783, 0.083333333333333, 0.090909090909091
32168, 0.26086956521739, 0.083333333333333, 0.090909090909091
32169, 0.30434782608696, 0.083333333333333, 0.090909090909091
32170, 0.34782608695652, 0.083333333333333, 0.090909090909091
32171, 0.39130434782609, 0.083333333333333, 0.090909090909091
32172, 0.43478260869565, 0.083333333333333, 0.090909090909091
32173, 0.47826086956522, 0.083333333333333, 0.090909090909091
32174, 0.52173913043478, 0.083333333333333, 0.090909090909091
32175, 0.56521739130435, 0.083333333333333, 0.090909090909091
32176, 0.60869565217391, 0.083333333333333, 0.090909090909091
32177, 0.65217391304348, 0.083333333333333, 0.090909090909091
32178, 0.69565217391304, 0.083333333333333, 0.090909090909091
32179, 0.73913043478261, 0.083333333333333, 0.090909090909091
32180, 0.78260869565217, 0.083333333333333, 0.090909090909091
32181, 0.82608695652174, 0.083333333333333, 0.090909090909091
32182, 0.8695652173913, 0.083333333333333, 0.090909090909091
32183, 0.91304347826087, 0.083333333333333, 0.090909090909091
32184, 0.95652173913044, 0.083333333333333, 0.090909090909091
32185, 0.021739130434783, 0.033333333333333, 0.13636363636364
32186, 0.043478260869565, 0.016666666666667, 0.13636363636364
32187, 0.043478260869565, 0.033333333333333, 0.11363636363636
32188, 0.065217391304348, 0.033333333333333, 0.13636363636364
32189, 0.08695652173913, 0.016666666666667, 0.13636363636364
32190, 0.08695652173913, 0.033333333333333, 0.11363636363636
32191, 0.10869565217391, 0.033333333333333, 0.13636363636364
32192, 0.1304347826087, 0.016666666666667, 0.13636363636364
32193, 0.1304347826087, 0.033333333333333, 0.11363636363636
32194, 0.15217391304348, 0.033333333333333, 0.13636363636364
32195, 0.17391304347826, 0.016666666666667, 0.13636363636364
32196, 0.17391304347826, 0.033333333333333, 0.11363636363636
32197, 0.19565217391304, 0.033333333333333, 0.13636363636364
32198, 0.21739130434783, 0.016666666666667, 0.13636363636364
32199, 0.21739130434783, 0.033333333333333, 0.11363636363636
32200, 0.23913043478261, 0.033333333333333, 0.13636363636364
32201, 0.26086956521739, 0.016666666666667, 0.13636363636364
32202, 0.26086956521739, 0.033333333333333, 0.11363636363636
32203, 0.28260869565217, 0.033333333333333, 0.13636363636364
32204, 0.30434782608696, 0.016666666666667, 0.13636363636364
32205, 0.30434782608696, 0.033333333333333, 0.11363636363636
32206, 0.32608695652174, 0.033333333333333, 0.13636363636364
32207, 0.34782608695652, 0.016666666666667, 0.13636363636364
32208, 0.34782608695652, 0.033333333333333, 0.11363636363636
32209, 0.3695652173913, 0.033333333333333, 0.13636363636364
32210, 0.39130434782609, 0.016666666666667, 0.13636363636364
32211, 0.39130434782609, 0.033333333333333, 0.11363636363636
32212, 0.41304347826087, 0.033333333333333, 0.13636363636364
32213, 0.43478260869565, 0.016666666666667, 0.13636363636364
32214, 0.43478260869565, 0.033333333333333, 0.11363636363636
32215, 0.45652173913043, 0.033333333333333, 0.13636363636364
32216, 0.47826086956522, 0.016666666666667, 0.13636363636364
32217, 0.47826086956522, 0.033333333333333, 0.11363636363636
32218, 0.5, 0.033333333333333, 0.13636363636364
32219, 0.52173913043478, 0.016666666666667, 0.13636363636364
32220, 0.52173913043478, 0.033333333333333, 0.11363636363636
32221, 0.54347826086957, 0.033333333333333, 0.13636363636364
32222, 0.56521739130435, 0.016666666666667, 0.13636363636364
32223, 0.56521739130435, 0.033333333333333, 0.11363636363636
32224, 0.58695652173913, 0.033333333333333, 0.13636363636364
32225, 0.60869565217391, 0.016666666666667, 0.13636363636364
32226, 0.60869565217391, 0.033333333333333, 0.11363636363636
32227, 0.6304347826087, 0.033333333333333, 0.13636363636364
32228, 0.65217391304348, 0.016666666666667, 0.13636363636364
32229, 0.65217391304348, 0.033333333333333, 0.11363636363636
32230, 0.67391304347826, 0.033333333333333, 0.13636363636364
32231, 0.69565217391304, 0.016666666666667, 0.13636363636364
32232, 0.69565217391304, 0.033333333333333, 0.11363636363636
32233, 0.71739130434783, 0.033333333333333, 0.13636363636364
32234, 0.73913043478261, 0.016666666666667, 0.13636363636364
32235, 0.73913043478261, 0.033333333333333, 0.11363636363636
32236, 0.76086956521739, 0.033333333333333, 0.13636363636364
32237, 0.78260869565217, 0.016666666666667, 0.13636363636364
32238, 0.78260869565217, 0.033333333333333, 0.11363636363636
32239, 0.80434782608696, 0.033333333333333, 0.13636363636364
32240, 0.82608695652174, 0.016666666666667, 0.13636363636364
32241, 0.82608695652174, 0.033333333333333, 0.11363636363636
32242, 0.84782608695652, 0.033333333333333, 0.13636363636364
32243, 0.8695652173913, 0.016666666666667, 0.13636363636364
32244, 0.8695652173913, 0.033333333333333, 0.11363636363636
32245, 0.89130434782609, 0.033333333333333, 0.13636363636364
32246, 0.91304347826087, 0.016666666666667, 0.13636363636364
32247, 0.91304347826087, 0.033333333333333, 0.11363636363636
32248, 0.93478260869565, 0.033333333333333, 0.13636363636364
32249, 0.95652173913044, 0.016666666666667, 0.13636363636364
32250, 0.95652173913043, 0.033333333333333, 0.11363636363636
32251, 0.97826086956522, 0.033333333333333, 0.13636363636364
32252, 0.021739130434783, 0.066666666666667, 0.13636363636364
32253, 0.043478260869565, 0.05, 0.13636363636364
32254, 0.043478260869565, 0.066666666666667, 0.11363636363636
32255, 0.065217391304348, 0.066666666666667, 0.13636363636364
32256, 0.08695652173913, 0.05, 0.13636363636364
32257, 0.08695652173913, 0.066666666666667, 0.11363636363636
32258, 0.10869565217391, 0.066666666666667, 0.13636363636364
32259, 0.1304347826087, 0.05, 0.13636363636364
32260, 0.1304347826087, 0.066666666666667, 0.11363636363636
32261, 0.15217391304348, 0.066666666666667, 0.13636363636364
32262, 0.17391304347826, 0.05, 0.13636363636364
32263, 0.17391304347826, 0.066666666666667, 0.11363636363636
32264, 0.19565217391304, 0.066666666666667, 0.13636363636364
32265, 0.21739130434783, 0.05, 0.13636363636364
32266, 0.21739130434783, 0.066666666666667, 0.11363636363636
32267, 0.23913043478261, 0.066666666666667, 0.13636363636364
32268, 0.26086956521739, 0.05, 0.13636363636364
32269, 0.26086956521739, 0.066666666666667, 0.11363636363636
32270, 0.28260869565217, 0.066666666666667, 0.13636363636364
32271, 0.30434782608696, 0.05, 0.13636363636364
32272, 0.30434782608696, 0.066666666666667, 0.11363636363636
32273, 0.32608695652174, 0.066666666666667, 0.13636363636364
32274, 0.34782608695652, 0.05, 0.13636363636364
32275, 0.34782608695652, 0.066666666666667, 0.11363636363636
32276, 0.3695652173913, 0.066666666666667, 0.13636363636364
32277, 0.39130434782609, 0.05, 0.13636363636364
32278, 0.39130434782609, 0.066666666666667, 0.11363636363636
32279, 0.41304347826087, 0.066666666666667, 0.13636363636364
32280, 0.43478260869565, 0.05, 0.13636363636364
32281, 0.43478260869565, 0.066666666666667, 0.11363636363636
32282, 0.45652173913043, 0.066666666666667, 0.13636363636364
32283, 0.47826086956522, 0.05, 0.13636363636364
32284, 0.47826086956522, 0.066666666666667, 0.11363636363636
32285, 0.5, 0.066666666666667, 0.13636363636364
32286, 0.52173913043478, 0.05, 0.13636363636364
32287, 0.52173913043478, 0.066666666666667, 0.11363636363636
32288, 0.54347826086957, 0.066666666666667, 0.13636363636364
32289, 0.56521739130435, 0.05, 0.13636363636364
32290, 0.56521739130435, 0.066666666666667, 0.11363636363636
32291, 0.58695652173913, 0.066666666666667, 0.13636363636364
32292, 0.60869565217391, 0.05, 0.13636363636364
32293, 0.60869565217391, 0.066666666666667, 0.11363636363636
32294, 0.6304347826087, 0.066666666666667, 0.13636363636364
32295, 0.65217391304348, 0.05, 0.13636363636364
32296, 0.65217391304348, 0.066666666666667, 0.11363636363636
32297, 0.67391304347826, 0.066666666666667, 0.13636363636364
32298, 0.69565217391304, 0.05, 0.13636363636364
32299, 0.69565217391304, 0.066666666666667, 0.11363636363636
32300, 0.71739130434783, 0.066666666666667, 0.13636363636364
32301, 0.73913043478261, 0.05, 0.13636363636364
32302, 0.73913043478261, 0.066666666666667, 0.11363636363636
32303, 0.76086956521739, 0.066666666666667, 0.13636363636364
32304, 0.78260869565217, 0.05, 0.13636363636364
32305, 0.78260869565217, 0.066666666666667, 0.11363636363636
32306, 0.80434782608696, 0.066666666666667, 0.13636363636364
32307, 0.82608695652174, 0.05, 0.13636363636364
32308, 0.82608695652174, 0.066666666666667, 0.11363636363636
32309, 0.84782608695652, 0.066666666666667, 0.13636363636364
32310, 0.8695652173913, 0.05, 0.13636363636364
32311, 0.8695652173913, 0.066666666666667, 0.11363636363636
32312, 0.89130434782609, 0.066666666666667, 0.13636363636364
32313, 0.91304347826087, 0.05, 0.13636363636364
32314, 0.91304347826087, 0.066666666666667, 0.11363636363636
32315, 0.93478260869565, 0.066666666666667, 0.13636363636364
32316, 0.95652173913044, 0.05, 0.13636363636364
32317, 0.95652173913044, 0.066666666666667, 0.11363636363636
32318, 0.97826086956522, 0.066666666666667, 0.13636363636364
32319, 0.043478260869565, 0.083333333333333, 0.13636363636364
32320, 0.08695652173913, 0.083333333333333, 0.13636363636364
32321, 0.1304347826087, 0.083333333333333, 0.13636363636364
32322, 0.17391304347826, 0.083333333333333, 0.13636363636364
32323, 0.21739130434783, 0.083333333333333, 0.13636363636364
32324, 0.26086956521739, 0.083333333333333, 0.13636363636364
32325, 0.30434782608696, 0.083333333333333, 0.13636363636364
32326, 0.34782608695652, 0.083333333333333, 0.13636363636364
32327, 0.39130434782609, 0.083333333333333, 0.13636363636364
32328, 0.43478260869565, 0.083333333333333, 0.13636363636364
32329, 0.47826086956522, 0.083333333333333, 0.13636363636364
32330, 0.52173913043478, 0.083333333333333, 0.13636363636364
32331, 0.56521739130435, 0.083333333333333, 0.13636363636364
32332, 0.60869565217391, 0.083333333333333, 0.13636363636364
32333, 0.65217391304348, 0.083333333333333, 0.13636363636364
32334, 0.69565217391304, 0.083333333333333, 0.13636363636364
32335, 0.73913043478261, 0.083333333333333, 0.13636363636364
32336, 0.78260869565217, 0.083333333333333, 0.13636363636364
32337, 0.82608695652174, 0.083333333333333, 0.13636363636364
32338, 0.8695652173913, 0.083333333333333, 0.13636363636364
32339, 0.91304347826087, 0.083333333333333, 0.13636363636364
32340, 0.95652173913044, 0.083333333333333, 0.13636363636364
32341, 0.021739130434783, 0.033333333333333, 0.18181818181818
32342, 0.043478260869565, 0.016666666666667, 0.18181818181818
32343, 0.043478260869565, 0.033333333333333, 0.15909090909091
32344, 0.065217391304348, 0.033333333333333, 0.18181818181818
32345, 0.08695652173913, 0.016666666666667, 0.18181818181818
32346, 0.08695652173913, 0.033333333333333, 0.15909090909091
32347, 0.10869565217391, 0.033333333333333, 0.18181818181818
32348, 0.1304347826087, 0.016666666666667, 0.18181818181818
32349, 0.1304347826087, 0.033333333333333, 0.15909090909091
32350, 0.15217391304348, 0.033333333333333, 0.18181818181818
32351, 0.17391304347826, 0.016666666666667, 0.18181818181818
32352, 0.17391304347826, 0.033333333333333, 0.15909090909091
32353, 0.19565217391304, 0.033333333333333, 0.18181818181818
32354, 0.21739130434783, 0.016666666666667, 0.18181818181818
32355, 0.21739130434783, 0.033333333333333, 0.15909090909091
32356, 0.23913043478261, 0.033333333333333, 0.18181818181818
32357, 0.26086956521739, 0.016666666666667, 0.18181818181818
32358, 0.26086956521739, 0.033333333333333, 0.15909090909091
32359, 0.28260869565217, 0.033333333333333, 0.18181818181818
32360, 0.30434782608696, 0.016666666666667, 0.18181818181818
32361, 0.30434782608696, 0.033333333333333, 0.15909090909091
32362, 0.32608695652174, 0.033333333333333, 0.18181818181818
32363, 0.34782608695652, 0.016666666666667, 0.18181818181818
32364, 0.34782608695652, 0.033333333333333, 0.15909090909091
32365, 0.3695652173913, 0.033333333333333, 0.18181818181818
32366, 0.39130434782609, 0.016666666666667, 0.18181818181818
32367, 0.39130434782609, 0.033333333333333, 0.15909090909091
32368, 0.41304347826087, 0.033333333333333, 0.18181818181818
32369, 0.43478260869565, 0.016666666666667, 0.18181818181818
32370, 0.43478260869565, 0.033333333333333, 0.15909090909091
32371, 0.45652173913043, 0.033333333333333, 0.18181818181818
32372, 0.47826086956522, 0.016666666666667, 0.18181818181818
32373, 0.47826086956522, 0.033333333333333, 0.15909090909091
32374, 0.5, 0.033333333333333, 0.18181818181818
32375, 0.52173913043478, 0.016666666666667, 0.18181818181818
32376, 0.52173913043478, 0.033333333333333, 0.15909090909091
32377, 0.54347826086957, 0.033333333333333, 0.18181818181818
32378, 0.56521739130435, 0.016666666666667, 0.18181818181818
32379, 0.56521739130435, 0.033333333333333, 0.15909090909091
32380, 0.58695652173913, 0.033333333333333, 0.18181818181818
32381, 0.60869565217391, 0.016666666666667, 0.18181818181818
32382, 0.60869565217391, 0.033333333333333, 0.15909090909091
32383, 0.6304347826087, 0.033333333333333, 0.18181818181818
32384, 0.65217391304348, 0.016666666666667, 0.18181818181818
32385, 0.65217391304348, 0.033333333333333, 0.15909090909091
32386, 0.67391304347826, 0.033333333333333, 0.18181818181818
32387, 0.69565217391304, 0.016666666666667, 0.18181818181818
32388, 0.69565217391304, 0.033333333333333, 0.15909090909091
32389, 0.71739130434783, 0.033333333333333, 0.18181818181818
32390, 0.73913043478261, 0.016666666666667, 0.18181818181818
32391, 0.73913043478261, 0.033333333333333, 0.15909090909091
32392, 0.76086956521739, 0.033333333333333, 0.18181818181818
32393, 0.78260869565217, 0.016666666666667, 0.18181818181818
32394, 0.78260869565217, 0.033333333333333, 0.15909090909091
32395, 0.80434782608696, 0.033333333333333, 0.18181818181818
32396, 0.82608695652174, 0.016666666666667, 0.18181818181818
32397, 0.82608695652174, 0.033333333333333, 0.15909090909091
32398, 0.84782608695652, 0.033333333333333, 0.18181818181818
32399, 0.8695652173913, 0.016666666666667, 0.18181818181818
32400, 0.8695652173913, 0.033333333333333, 0.15909090909091
32401, 0.89130434782609, 0.033333333333333, 0.18181818181818
32402, 0.91304347826087, 0.016666666666667, 0.18181818181818
32403, 0.91304347826087, 0.033333333333333, 0.15909090909091
32404, 0.93478260869565, 0.033333333333333, 0.18181818181818
32405, 0.95652173913043, 0.016666666666667, 0.18181818181818
32406, 0.95652173913044, 0.033333333333333, 0.15909090909091
32407, 0.97826086956522, 0.033333333333333, 0.18181818181818
32408, 0.021739130434783, 0.066666666666667, 0.18181818181818
32409, 0.043478260869565, 0.05, 0.18181818181818
32410, 0.043478260869565, 0.066666666666667, 0.15909090909091
32411, 0.065217391304348, 0.066666666666667, 0.18181818181818
32412, 0.08695652173913, 0.05, 0.18181818181818
32413, 0.08695652173913, 0.066666666666667, 0.15909090909091
32414, 0.10869565217391, 0.066666666666667, 0.18181818181818
32415, 0.1304347826087, 0.05, 0.18181818181818
32416, 0.1304347826087, 0.066666666666667, 0.15909090909091
32417, 0.15217391304348, 0.066666666666667, 0.18181818181818
32418, 0.17391304347826, 0.05, 0.18181818181818
32419, 0.17391304347826, 0.066666666666667, 0.15909090909091
32420, 0.19565217391304, 0.066666666666667, 0.18181818181818
32421, 0.21739130434783, 0.05, 0.18181818181818
32422, 0.21739130434783, 0.066666666666667, 0.15909090909091
32423, 0.23913043478261, 0.066666666666667, 0.18181818181818
32424, 0.26086956521739, 0.05, 0.18181818181818
32425, 0.26086956521739, 0.066666666666667, 0.15909090909091
32426, 0.28260869565217, 0.066666666666667, 0.18181818181818
32427, 0.30434782608696, 0.05, 0.18181818181818
32428, 0.30434782608696, 0.066666666666667, 0.15909090909091
32429, 0.32608695652174, 0.066666666666667, 0.18181818181818
32430, 0.34782608695652, 0.05, 0.18181818181818
32431, 0.34782608695652, 0.066666666666667, 0.15909090909091
32432, 0.3695652173913, 0.066666666666667, 0.18181818181818
32433, 0.39130434782609, 0.05, 0.18181818181818
32434, 0.39130434782609, 0.066666666666667, 0.15909090909091
32435, 0.41304347826087, 0.066666666666667, 0.18181818181818
32436, 0.43478260869565, 0.05, 0.18181818181818
32437, 0.43478260869565, 0.066666666666667, 0.15909090909091
32438, 0.45652173913043, 0.066666666666667, 0.18181818181818
32439, 0.47826086956522, 0.05, 0.18181818181818
32440, 0.47826086956522, 0.066666666666667, 0.15909090909091
32441, 0.5, 0.066666666666667, 0.18181818181818
32442, 0.52173913043478, 0.05, 0.18181818181818
32443, 0.52173913043478, 0.066666666666667, 0.15909090909091
32444, 0.54347826086957, 0.066666666666667, 0.18181818181818
32445, 0.56521739130435, 0.05, 0.18181818181818
32446, 0.56521739130435, 0.066666666666667, 0.15909090909091
32447, 0.58695652173913, 0.066666666666667, 0.18181818181818
32448, 0.60869565217391, 0.05, 0.18181818181818
32449, 0.60869565217391, 0.066666666666667, 0.15909090909091
32450, 0.6304347826087, 0.066666666666667, 0.18181818181818
32451, 0.65217391304348, 0.05, 0.18181818181818
32452, 0.65217391304348, 0.066666666666667, 0.15909090909091
32453, 0.67391304347826, 0.066666666666667, 0.18181818181818
32454, 0.69565217391304, 0.05, 0.18181818181818
32455, 0.69565217391304, 0.066666666666667, 0.15909090909091
32456, 0.71739130434783, 0.066666666666667, 0.18181818181818
32457, 0.73913043478261, 0.05, 0.18181818181818
32458, 0.73913043478261, 0.066666666666667, 0.15909090909091
32459, 0.76086956521739, 0.066666666666667, 0.18181818181818
32460, 0.78260869565217, 0.05, 0.18181818181818
32461, 0.78260869565217, 0.066666666666667, 0.15909090909091
32462, 0.80434782608696, 0.066666666666667, 0.18181818181818
32463, 0.82608695652174, 0.05, 0.18181818181818
32464, 0.82608695652174, 0.066666666666667, 0.15909090909091
32465, 0.84782608695652, 0.066666666666667, 0.18181818181818
32466, 0.8695652173913, 0.05, 0.18181818181818
32467, 0.8695652173913, 0.066666666666667, 0.15909090909091
32468, 0.89130434782609, 0.066666666666667, 0.18181818181818
32469, 0.91304347826087, 0.05, 0.18181818181818
32470, 0.91304347826087, 0.066666666666667, 0.15909090909091
32471, 0.93478260869565, 0.066666666666667, 0.18181818181818
32472, 0.95652173913044, 0.05, 0.18181818181818
32473, 0.95652173913044, 0.066666666666667, 0.15909090909091
32474, 0.97826086956522, 0.066666666666667, 0.18181818181818
32475, 0.043478260869565, 0.083333333333333, 0.18181818181818
32476, 0.08695652173913, 0.083333333333333, 0.18181818181818
32477, 0.1304347826087, 0.083333333333333, 0.18181818181818
32478, 0.17391304347826, 0.083333333333333, 0.18181818181818
32479, 0.21739130434783, 0.083333333333333, 0.18181818181818
32480, 0.26086956521739, 0.083333333333333, 0.18181818181818
32481, 0.30434782608696, 0.083333333333333, 0.18181818181818
32482, 0.34782608695652, 0.083333333333333, 0.18181818181818
32483, 0.39130434782609, 0.083333333333333, 0.18181818181818
32484, 0.43478260869565, 0.083333333333333, 0.18181818181818
32485, 0.47826086956522, 0.083333333333333, 0.18181818181818
32486, 0.52173913043478, 0.083333333333333, 0.18181818181818
32487, 0.56521739130435, 0.083333333333333, 0.18181818181818
32488, 0.60869565217391, 0.083333333333333, 0.18181818181818
32489, 0.65217391304348, 0.083333333333333, 0.18181818181818
32490, 0.69565217391304, 0.083333333333333, 0.18181818181818
32491, 0.73913043478261, 0.083333333333333, 0.18181818181818
32492, 0.78260869565217, 0.083333333333333, 0.18181818181818
32493, 0.82608695652174, 0.083333333333333, 0.18181818181818
32494, 0.8695652173913, 0.083333333333333, 0.18181818181818
32495, 0.91304347826087, 0.083333333333333, 0.18181818181818
32496, 0.95652173913044, 0.083333333333333, 0.18181818181818
32497, 0.021739130434783, 0.033333333333333, 0.22727272727273
32498, 0.043478260869565, 0.016666666666667, 0.22727272727273
32499, 0.043478260869565, 0.033333333333333, 0.20454545454545
32500, 0.065217391304348, 0.033333333333333, 0.22727272727273
32501, 0.08695652173913, 0.016666666666667, 0.22727272727273
32502, 0.08695652173913, 0.033333333333333, 0.20454545454545
32503, 0.10869565217391, 0.033333333333333, 0.22727272727273
32504, 0.1304347826087, 0.016666666666667, 0.22727272727273
32505, 0.1304347826087, 0.033333333333333, 0.20454545454545
32506, 0.15217391304348, 0.033333333333333, 0.22727272727273
32507, 0.17391304347826, 0.016666666666667, 0.22727272727273
32508, 0.17391304347826, 0.033333333333333, 0.20454545454545
32509, 0.19565217391304, 0.033333333333333, 0.22727272727273
32510, 0.21739130434783, 0.016666666666667, 0.22727272727273
32511, 0.21739130434783, 0.033333333333333, 0.20454545454545
32512, 0.23913043478261, 0.033333333333333, 0.22727272727273
32513, 0.26086956521739, 0.016666666666667, 0.22727272727273
32514, 0.26086956521739, 0.033333333333333, 0.20454545454545
32515, 0.28260869565217, 0.033333333333333, 0.22727272727273
32516, 0.30434782608696, 0.016666666666667, 0.22727272727273
32517, 0.30434782608696, 0.033333333333333, 0.20454545454545
32518, 0.32608695652174, 0.033333333333333, 0.22727272727273
32519, 0.34782608695652, 0.016666666666667, 0.22727272727273
32520, 0.34782608695652, 0.033333333333333, 0.20454545454545
32521, 0.3695652173913, 0.033333333333333, 0.22727272727273
32522, 0.39130434782609, 0.016666666666667, 0.22727272727273
32523, 0.39130434782609, 0.033333333333333, 0.20454545454545
32524, 0.41304347826087, 0.033333333333333, 0.22727272727273
32525, 0.43478260869565, 0.016666666666667, 0.22727272727273
32526, 0.43478260869565, 0.033333333333333, 0.20454545454545
32527, 0.45652173913043, 0.033333333333333, 0.22727272727273
32528, 0.47826086956522, 0.016666666666667, 0.22727272727273
32529, 0.47826086956522, 0.033333333333333, 0.20454545454545
32530, 0.5, 0.033333333333333, 0.22727272727273
32531, 0.52173913043478, 0.016666666666667, 0.22727272727273
32532, 0.52173913043478, 0.033333333333333, 0.20454545454545
32533, 0.54347826086957, 0.033333333333333, 0.22727272727273
32534, 0.56521739130435, 0.016666666666667, 0.22727272727273
32535, 0.56521739130435, 0.033333333333333, 0.20454545454545
32536, 0.58695652173913, 0.033333333333333, 0.22727272727273
32537, 0.60869565217391, 0.016666666666667, 0.22727272727273
32538, 0.60869565217391, 0.033333333333333, 0.20454545454545
32539, 0.6304347826087, 0.033333333333333, 0.22727272727273
32540, 0.65217391304348, 0.016666666666667, 0.22727272727273
32541, 0.65217391304348, 0.033333333333333, 0.20454545454545
32542, 0.67391304347826, 0.033333333333333, 0.22727272727273
32543, 0.69565217391304, 0.016666666666667, 0.22727272727273
32544, 0.69565217391304, 0.033333333333333, 0.20454545454545
32545, 0.71739130434783, 0.033333333333333, 0.22727272727273
32546, 0.73913043478261, 0.016666666666667, 0.22727272727273
32547, 0.73913043478261, 0.033333333333333, 0.20454545454545
32548, 0.76086956521739, 0.033333333333333, 0.22727272727273
32549, 0.78260869565217, 0.016666666666667, 0.22727272727273
32550, 0.78260869565217, 0.033333333333333, 0.20454545454545
32551, 0.80434782608696, 0.033333333333333, 0.22727272727273
32552, 0.82608695652174, 0.016666666666667, 0.22727272727273
32553, 0.82608695652174, 0.033333333333333, 0.20454545454545
32554, 0.84782608695652, 0.033333333333333, 0.22727272727273
32555, 0.8695652173913, 0.016666666666667, 0.22727272727273
32556, 0.8695652173913, 0.033333333333333, 0.20454545454545
32557, 0.89130434782609, 0.033333333333333, 0.22727272727273
32558, 0.91304347826087, 0.016666666666667, 0.22727272727273
32559, 0.91304347826087, 0.033333333333333, 0.20454545454545
32560, 0.93478260869565, 0.033333333333333, 0.22727272727273
32561, 0.95652173913044, 0.016666666666667, 0.22727272727273
32562, 0.95652173913044, 0.033333333333333, 0.20454545454545
32563, 0.97826086956522, 0.033333333333333, 0.22727272727273
32564, 0.021739130434783, 0.066666666666667, 0.22727272727273
32565, 0.043478260869565, 0.05, 0.22727272727273
32566, 0.043478260869565, 0.066666666666667, 0.20454545454545
32567, 0.065217391304348, 0.066666666666667, 0.22727272727273
32568, 0.08695652173913, 0.05, 0.22727272727273
32569, 0.08695652173913, 0.066666666666667, 0.20454545454545
32570, 0.10869565217391, 0.066666666666667, 0.22727272727273
32571, 0.1304347826087, 0.05, 0.22727272727273
32572, 0.1304347826087, 0.066666666666667, 0.20454545454545
32573, 0.15217391304348, 0.066666666666667, 0.22727272727273
32574, 0.17391304347826, 0.05, 0.22727272727273
32575, 0.17391304347826, 0.066666666666667, 0.20454545454545
32576, 0.19565217391304, 0.066666666666667, 0.22727272727273
32577, 0.21739130434783, 0.05, 0.22727272727273
32578, 0.21739130434783, 0.066666666666667, 0.20454545454545
32579, 0.23913043478261, 0.066666666666667, 0.22727272727273
32580, 0.26086956521739, 0.05, 0.22727272727273
32581, 0.26086956521739, 0.066666666666667, 0.20454545454545
32582, 0.28260869565217, 0.066666666666667, 0.22727272727273
32583, 0.30434782608696, 0.05, 0.22727272727273
32584, 0.30434782608696, 0.066666666666667, 0.20454545454545
32585, 0.32608695652174, 0.066666666666667, 0.22727272727273
32586, 0.34782608695652, 0.05, 0.22727272727273
32587, 0.34782608695652, 0.066666666666667, 0.20454545454545
32588, 0.3695652173913, 0.066666666666667, 0.22727272727273
32589, 0.39130434782609, 0.05, 0.22727272727273
32590, 0.39130434782609, 0.066666666666667, 0.20454545454545
32591, 0.41304347826087, 0.066666666666667, 0.22727272727273
32592, 0.43478260869565, 0.05, 0.22727272727273
32593, 0.43478260869565, 0.066666666666667, 0.20454545454545
32594, 0.45652173913043, 0.066666666666667, 0.22727272727273
32595, 0.47826086956522, 0.05, 0.22727272727273
32596, 0.47826086956522, 0.066666666666667, 0.20454545454545
32597, 0.5, 0.066666666666667, 0.22727272727273
32598, 0.52173913043478, 0.05, 0.22727272727273
32599, 0.52173913043478, 0.066666666666667, 0.20454545454545
32600, 0.54347826086957, 0.066666666666667, 0.22727272727273
32601, 0.56521739130435, 0.05, 0.22727272727273
32602, 0.56521739130435, 0.066666666666667, 0.20454545454545
32603, 0.58695652173913, 0.066666666666667, 0.22727272727273
32604, 0.60869565217391, 0.05, 0.22727272727273
32605, 0.60869565217391, 0.066666666666667, 0.20454545454545
32606, 0.6304347826087, 0.066666666666667, 0.22727272727273
32607, 0.65217391304348, 0.05, 0.22727272727273
32608, 0.65217391304348, 0.066666666666667, 0.20454545454545
32609, 0.67391304347826, 0.066666666666667, 0.22727272727273
32610, 0.69565217391304, 0.05, 0.22727272727273
32611, 0.69565217391304, 0.066666666666667, 0.20454545454545
32612, 0.71739130434783, 0.066666666666667, 0.22727272727273
32613, 0.73913043478261, 0.05, 0.22727272727273
32614, 0.73913043478261, 0.066666666666667, 0.20454545454545
32615, 0.76086956521739, 0.066666666666667, 0.22727272727273
32616, 0.78260869565217, 0.05, 0.22727272727273
32617, 0.78260869565217, 0.066666666666667, 0.20454545454545
32618, 0.80434782608696, 0.066666666666667, 0.22727272727273
32619, 0.82608695652174, 0.05, 0.22727272727273
32620, 0.82608695652174, 0.066666666666667, 0.20454545454545
32621, 0.84782608695652, 0.066666666666667, 0.22727272727273
32622, 0.8695652173913, 0.05, 0.22727272727273
32623, 0.8695652173913, 0.066666666666667, 0.20454545454545
32624, 0.89130434782609, 0.066666666666667, 0.22727272727273
32625, 0.91304347826087, 0.05, 0.22727272727273
32626, 0.91304347826087, 0.066666666666667, 0.20454545454545
32627, 0.93478260869565, 0.066666666666667, 0.22727272727273
32628, 0.95652173913044, 0.05, 0.22727272727273
32629, 0.95652173913044, 0.066666666666667, 0.20454545454545
32630, 0.97826086956522, 0.066666666666667, 0.22727272727273
32631, 0.043478260869565, 0.083333333333333, 0.22727272727273
32632, 0.08695652173913, 0.083333333333333, 0.22727272727273
32633, 0.1304347826087, 0.083333333333333, 0.22727272727273
32634, 0.17391304347826, 0.083333333333333, 0.22727272727273
32635, 0.21739130434783, 0.083333333333333, 0.22727272727273
32636, 0.26086956521739, 0.083333333333333, 0.22727272727273
32637, 0.30434782608696, 0.083333333333333, 0.22727272727273
32638, 0.34782608695652, 0.083333333333333, 0.22727272727273
32639, 0.39130434782609, 0.083333333333333, 0.22727272727273
32640, 0.43478260869565, 0.083333333333333, 0.22727272727273
32641, 0.47826086956522, 0.083333333333333, 0.22727272727273
32642, 0.52173913043478, 0.083333333333333, 0.22727272727273
32643, 0.56521739130435, 0.083333333333333, 0.22727272727273
32644, 0.60869565217391, 0.083333333333333, 0.22727272727273
32645, 0.65217391304348, 0.083333333333333, 0.22727272727273
32646, 0.69565217391304, 0.083333333333333, 0.22727272727273
32647, 0.73913043478261, 0.083333333333333, 0.22727272727273
32648, 0.78260869565217, 0.083333333333333, 0.22727272727273
32649, 0.82608695652174, 0.083333333333333, 0.22727272727273
32650, 0.8695652173913, 0.083333333333333, 0.22727272727273
32651, 0.91304347826087, 0.083333333333333, 0.22727272727273
32652, 0.95652173913044, 0.083333333333333, 0.22727272727273
32653, 0.021739130434783, 0.033333333333333, 0.27272727272727
32654, 0.043478260869565, 0.016666666666667, 0.27272727272727
32655, 0.043478260869565, 0.033333333333333, 0.25
32656, 0.065217391304348, 0.033333333333333, 0.27272727272727
32657, 0.08695652173913, 0.016666666666667, 0.27272727272727
32658, 0.08695652173913, 0.033333333333333, 0.25
32659, 0.10869565217391, 0.033333333333333, 0.27272727272727
32660, 0.1304347826087, 0.016666666666667, 0.27272727272727
32661, 0.1304347826087, 0.033333333333333, 0.25
32662, 0.15217391304348, 0.033333333333333, 0.27272727272727
32663, 0.17391304347826, 0.016666666666667, 0.27272727272727
32664, 0.17391304347826, 0.033333333333333, 0.25
32665, 0.19565217391304, 0.033333333333333, 0.27272727272727
32666, 0.21739130434783, 0.016666666666667, 0.27272727272727
32667, 0.21739130434783, 0.033333333333333, 0.25
32668, 0.23913043478261, 0.033333333333333, 0.27272727272727
32669, 0.26086956521739, 0.016666666666667, 0.27272727272727
32670, 0.26086956521739, 0.033333333333333, 0.25
32671, 0.28260869565217, 0.033333333333333, 0.27272727272727
32672, 0.30434782608696, 0.016666666666667, 0.27272727272727
32673, 0.30434782608696, 0.033333333333333, 0.25
32674, 0.32608695652174, 0.033333333333333, 0.27272727272727
32675, 0.34782608695652, 0.016666666666667, 0.27272727272727
32676, 0.34782608695652, 0.033333333333333, 0.25
32677, 0.3695652173913, 0.033333333333333, 0.27272727272727
32678, 0.39130434782609, 0.016666666666667, 0.27272727272727
32679, 0.39130434782609, 0.033333333333333, 0.25
32680, 0.41304347826087, 0.033333333333333, 0.27272727272727
32681, 0.43478260869565, 0.016666666666667, 0.27272727272727
32682, 0.43478260869565, 0.033333333333333, 0.25
32683, 0.45652173913043, 0.033333333333333, 0.27272727272727
32684, 0.47826086956522, 0.016666666666667, 0.27272727272727
32685, 0.47826086956522, 0.033333333333333, 0.25
32686, 0.5, 0.033333333333333, 0.27272727272727
32687, 0.52173913043478, 0.016666666666667, 0.27272727272727
32688, 0.52173913043478, 0.033333333333333, 0.25
32689, 0.54347826086957, 0.033333333333333, 0.27272727272727
32690, 0.56521739130435, 0.016666666666667, 0.27272727272727
32691, 0.56521739130435, 0.033333333333333, 0.25
32692, 0.58695652173913, 0.033333333333333, 0.27272727272727
32693, 0.60869565217391, 0.016666666666667, 0.27272727272727
32694, 0.60869565217391, 0.033333333333333, 0.25
32695, 0.6304347826087, 0.033333333333333, 0.27272727272727
32696, 0.65217391304348, 0.016666666666667, 0.27272727272727
32697, 0.65217391304348, 0.033333333333333, 0.25
32698, 0.67391304347826, 0.033333333333333, 0.27272727272727
32699, 0.69565217391304, 0.016666666666667, 0.27272727272727
32700, 0.69565217391304, 0.033333333333333, 0.25
32701, 0.71739130434783, 0.033333333333333, 0.27272727272727
32702, 0.73913043478261, 0.016666666666667, 0.27272727272727
32703, 0.73913043478261, 0.033333333333333, 0.25
32704, 0.76086956521739, 0.033333333333333, 0.27272727272727
32705, 0.78260869565217, 0.016666666666667, 0.27272727272727
32706, 0.78260869565217, 0.033333333333333, 0.25
32707, 0.80434782608696, 0.033333333333333, 0.27272727272727
32708, 0.82608695652174, 0.016666666666667, 0.27272727272727
32709, 0.82608695652174, 0.033333333333333, 0.25
32710, 0.84782608695652, 0.033333333333333, 0.27272727272727
32711, 0.8695652173913, 0.016666666666667, 0.27272727272727
32712, 0.8695652173913, 0.033333333333333, 0.25
32713, 0.89130434782609, 0.033333333333333, 0.27272727272727
32714, 0.91304347826087, 0.016666666666667, 0.27272727272727
32715, 0.91304347826087, 0.033333333333333, 0.25
32716, 0.93478260869565, 0.033333333333333, 0.27272727272727
32717, 0.95652173913044, 0.016666666666667, 0.27272727272727
32718, 0.95652173913044, 0.033333333333333, 0.25
32719, 0.97826086956522, 0.033333333333333, 0.27272727272727
32720, 0.021739130434783, 0.066666666666667, 0.27272727272727
32721, 0.043478260869565, 0.05, 0.27272727272727
32722, 0.043478260869565, 0.066666666666667, 0.25
32723, 0.065217391304348, 0.066666666666667, 0.27272727272727
32724, 0.08695652173913, 0.05, 0.27272727272727
32725, 0.08695652173913, 0.066666666666667, 0.25
32726, 0.10869565217391, 0.066666666666667, 0.27272727272727
32727, 0.1304347826087, 0.05, 0.27272727272727
32728, 0.1304347826087, 0.066666666666667, 0.25
32729, 0.15217391304348, 0.066666666666667, 0.27272727272727
32730, 0.17391304347826, 0.05, 0.27272727272727
32731, 0.17391304347826, 0.066666666666667, 0.25
32732, 0.19565217391304, 0.066666666666667, 0.27272727272727
32733, 0.21739130434783, 0.05, 0.27272727272727
32734, 0.21739130434783, 0.066666666666667, 0.25
32735, 0.23913043478261, 0.066666666666667, 0.27272727272727
32736, 0.26086956521739, 0.05, 0.27272727272727
32737, 0.26086956521739, 0.066666666666667, 0.25
32738, 0.28260869565217, 0.066666666666667, 0.27272727272727
32739, 0.30434782608696, 0.05, 0.27272727272727
32740, 0.30434782608696, 0.066666666666667, 0.25
32741, 0.32608695652174, 0.066666666666667, 0.27272727272727
32742, 0.34782608695652, 0.05, 0.27272727272727
32743, 0.34782608695652, 0.066666666666667, 0.25
32744, 0.3695652173913, 0.066666666666667, 0.27272727272727
32745, 0.39130434782609, 0.05, 0.27272727272727
32746, 0.39130434782609, 0.066666666666667, 0.25
32747, 0.41304347826087, 0.066666666666667, 0.27272727272727
32748, 0.43478260869565, 0.05, 0.27272727272727
32749, 0.43478260869565, 0.066666666666667, 0.25
32750, 0.45652173913043, 0.066666666666667, 0.27272727272727
32751, 0.47826086956522, 0.05, 0.27272727272727
32752, 0.47826086956522, 0.066666666666667, 0.25
32753, 0.5, 0.066666666666667, 0.27272727272727
32754, 0.52173913043478, 0.05, 0.27272727272727
32755, 0.52173913043478, 0.066666666666667, 0.25
32756, 0.54347826086957, 0.066666666666667, 0.27272727272727
32757, 0.56521739130435, 0.05, 0.27272727272727
32758, 0.56521739130435, 0.066666666666667, 0.25
32759, 0.58695652173913, 0.066666666666667, 0.27272727272727
32760, 0.60869565217391, 0.05, 0.27272727272727
32761, 0.60869565217391, 0.066666666666667, 0.25
32762, 0.6304347826087, 0.066666666666667, 0.27272727272727
32763, 0.65217391304348, 0.05, 0.27272727272727
32764, 0.65217391304348, 0.066666666666667, 0.25
32765, 0.67391304347826, 0.066666666666667, 0.27272727272727
32766, 0.69565217391304, 0.05, 0.27272727272727
32767, 0.69565217391304, 0.066666666666667, 0.25
32768, 0.71739130434783, 0.066666666666667, 0.27272727272727
32769, 0.73913043478261, 0.05, 0.27272727272727
32770, 0.73913043478261, 0.066666666666667, 0.25
32771, 0.76086956521739, 0.066666666666667, 0.27272727272727
32772, 0.78260869565217, 0.05, 0.27272727272727
32773, 0.78260869565217, 0.066666666666667, 0.25
32774, 0.80434782608696, 0.066666666666667, 0.27272727272727
32775, 0.82608695652174, 0.05, 0.27272727272727
32776, 0.82608695652174, 0.066666666666667, 0.25
32777, 0.84782608695652, 0.066666666666667, 0.27272727272727
32778, 0.8695652173913, 0.05, 0.27272727272727
32779, 0.8695652173913, 0.066666666666667, 0.25
32780, 0.89130434782609, 0.066666666666667, 0.27272727272727
32781, 0.91304347826087, 0.05, 0.27272727272727
32782, 0.91304347826087, 0.066666666666667, 0.25
32783, 0.93478260869565, 0.066666666666667, 0.27272727272727
32784, 0.95652173913044, 0.05, 0.27272727272727
32785, 0.95652173913044, 0.066666666666667, 0.25
32786, 0.97826086956522, 0.066666666666667, 0.27272727272727
32787, 0.043478260869565, 0.083333333333333, 0.27272727272727
32788, 0.08695652173913, 0.083333333333333, 0.27272727272727
32789, 0.1304347826087, 0.083333333333333, 0.27272727272727
32790, 0.17391304347826, 0.083333333333333, 0.27272727272727
32791, 0.21739130434783, 0.083333333333333, 0.27272727272727
32792, 0.26086956521739, 0.083333333333333, 0.27272727272727
32793, 0.30434782608696, 0.083333333333333, 0.27272727272727
32794, 0.34782608695652, 0.083333333333333, 0.27272727272727
32795, 0.39130434782609, 0.083333333333333, 0.27272727272727
32796, 0.43478260869565, 0.083333333333333, 0.27272727272727
32797, 0.47826086956522, 0.083333333333333, 0.27272727272727
32798, 0.52173913043478, 0.083333333333333, 0.27272727272727
32799, 0.56521739130435, 0.083333333333333, 0.27272727272727
32800, 0.60869565217391, 0.083333333333333, 0.27272727272727
32801, 0.65217391304348, 0.083333333333333, 0.27272727272727
32802, 0.69565217391304, 0.083333333333333, 0.27272727272727
32803, 0.73913043478261, 0.083333333333333, 0.27272727272727
32804, 0.78260869565217, 0.083333333333333, 0.27272727272727
32805, 0.82608695652174, 0.083333333333333, 0.27272727272727
32806, 0.8695652173913, 0.083333333333333, 0.27272727272727
32807, 0.91304347826087, 0.083333333333333, 0.27272727272727
32808, 0.95652173913043, 0.083333333333333, 0.27272727272727
32809, 0.021739130434783, 0.033333333333333, 0.31818181818182
32810, 0.043478260869565, 0.016666666666667, 0.31818181818182
32811, 0.043478260869565, 0.033333333333333, 0.29545454545455
32812, 0.065217391304348, 0.033333333333333, 0.31818181818182
32813, 0.08695652173913, 0.016666666666667, 0.31818181818182
32814, 0.08695652173913, 0.033333333333333, 0.29545454545455
32815, 0.10869565217391, 0.033333333333333, 0.31818181818182
32816, 0.1304347826087, 0.016666666666667, 0.31818181818182
32817, 0.1304347826087, 0.033333333333333, 0.29545454545455
32818, 0.15217391304348, 0.033333333333333, 0.31818181818182
32819, 0.17391304347826, 0.016666666666667, 0.31818181818182
32820, 0.17391304347826, 0.033333333333333, 0.29545454545455
32821, 0.19565217391304, 0.033333333333333, 0.31818181818182
32822, 0.21739130434783, 0.016666666666667, 0.31818181818182
32823, 0.21739130434783, 0.033333333333333, 0.29545454545455
32824, 0.23913043478261, 0.033333333333333, 0.31818181818182
32825, 0.26086956521739, 0.016666666666667, 0.31818181818182
32826, 0.26086956521739, 0.033333333333333, 0.29545454545455
32827, 0.28260869565217, 0.033333333333333, 0.31818181818182
32828, 0.30434782608696, 0.016666666666667, 0.31818181818182
32829, 0.30434782608696, 0.033333333333333, 0.29545454545455
32830, 0.32608695652174, 0.033333333333333, 0.31818181818182
32831, 0.34782608695652, 0.016666666666667, 0.31818181818182
32832, 0.34782608695652, 0.033333333333333, 0.29545454545455
32833, 0.3695652173913, 0.033333333333333, 0.31818181818182
32834, 0.39130434782609, 0.016666666666667, 0.31818181818182
32835, 0.39130434782609, 0.033333333333333, 0.29545454545455
32836, 0.41304347826087, 0.033333333333333, 0.31818181818182
32837, 0.43478260869565, 0.016666666666667, 0.31818181818182
32838, 0.43478260869565, 0.033333333333333, 0.29545454545455
32839, 0.45652173913043, 0.033333333333333, 0.31818181818182
32840, 0.47826086956522, 0.016666666666667, 0.31818181818182
32841, 0.47826086956522, 0.033333333333333, 0.29545454545455
32842, 0.5, 0.033333333333333, 0.31818181818182
32843, 0.52173913043478, 0.016666666666667, 0.31818181818182
32844, 0.52173913043478, 0.033333333333333, 0.29545454545455
32845, 0.54347826086957, 0.033333333333333, 0.31818181818182
32846, 0.56521739130435, 0.016666666666667, 0.31818181818182
32847, 0.56521739130435, 0.033333333333333, 0.29545454545455
32848, 0.58695652173913, 0.033333333333333, 0.31818181818182
32849, 0.60869565217391, 0.016666666666667, 0.31818181818182
32850, 0.60869565217391, 0.033333333333333, 0.29545454545455
32851, 0.6304347826087, 0.033333333333333, 0.31818181818182
32852, 0.65217391304348, 0.016666666666667, 0.31818181818182
32853, 0.65217391304348, 0.033333333333333, 0.29545454545455
32854, 0.67391304347826, 0.033333333333333, 0.31818181818182
32855, 0.69565217391304, 0.016666666666667, 0.31818181818182
32856, 0.69565217391304, 0.033333333333333, 0.29545454545455
32857, 0.71739130434783, 0.033333333333333, 0.31818181818182
32858, 0.73913043478261, 0.016666666666667, 0.31818181818182
32859, 0.73913043478261, 0.033333333333333, 0.29545454545455
32860, 0.76086956521739, 0.033333333333333, 0.31818181818182
32861, 0.78260869565217, 0.016666666666667, 0.31818181818182
32862, 0.78260869565217, 0.033333333333333, 0.29545454545455
32863, 0.80434782608696, 0.033333333333333, 0.31818181818182
32864, 0.82608695652174, 0.016666666666667, 0.31818181818182
32865, 0.82608695652174, 0.033333333333333, 0.29545454545455
32866, 0.84782608695652, 0.033333333333333, 0.31818181818182
32867, 0.8695652173913, 0.016666666666667, 0.31818181818182
32868, 0.8695652173913, 0.033333333333333, 0.29545454545455
32869, 0.89130434782609, 0.033333333333333, 0.31818181818182
32870, 0.91304347826087, 0.016666666666667, 0.31818181818182
32871, 0.91304347826087, 0.033333333333333, 0.29545454545455
32872, 0.93478260869565, 0.033333333333333, 0.31818181818182
32873, 0.95652173913043, 0.016666666666667, 0.31818181818182
32874, 0.95652173913044, 0.033333333333333, 0.29545454545455
32875, 0.97826086956522, 0.033333333333333, 0.31818181818182
32876, 0.021739130434783, 0.066666666666667, 0.31818181818182
32877, 0.043478260869565, 0.05, 0.31818181818182
32878, 0.043478260869565, 0.066666666666667, 0.29545454545455
32879, 0.065217391304348, 0.066666666666667, 0.31818181818182
32880, 0.08695652173913, 0.05, 0.31818181818182
32881, 0.08695652173913, 0.066666666666667, 0.29545454545455
