49908, 0.8695652173913, 0.95869565217391, 0.27272727272727
49909, 0.8695652173913, 0.98478260869565, 0.29545454545455
49910, 0.89130434782609, 0.98478260869565, 0.31818181818182
49911, 0.8695652173913, 0.95869565217391, 0.31818181818182
49912, 0.8695652173913, 0.98478260869565, 0.34090909090909
49913, 0.89130434782609, 0.98478260869565, 0.36363636363636
49914, 0.8695652173913, 0.95869565217391, 0.36363636363636
49915, 0.8695652173913, 0.98478260869565, 0.38636363636364
49916, 0.89130434782609, 0.98478260869565, 0.40909090909091
49917, 0.8695652173913, 0.95869565217391, 0.40909090909091
49918, 0.8695652173913, 0.98478260869565, 0.43181818181818
49919, 0.89130434782609, 0.98478260869565, 0.45454545454545
49920, 0.8695652173913, 0.95869565217391, 0.45454545454545
49921, 0.8695652173913, 0.98478260869565, 0.47727272727273
49922, 0.82608695652174, 0.98478260869565, 0.022727272727273
49923, 0.84782608695652, 0.98478260869565, 0.045454545454545
49924, 0.82608695652174, 0.95869565217391, 0.045454545454545
49925, 0.82608695652174, 0.98478260869565, 0.068181818181818
49926, 0.84782608695652, 0.98478260869565, 0.090909090909091
49927, 0.82608695652174, 0.95869565217391, 0.090909090909091
49928, 0.82608695652174, 0.98478260869565, 0.11363636363636
49929, 0.84782608695652, 0.98478260869565, 0.13636363636364
49930, 0.82608695652174, 0.95869565217391, 0.13636363636364
49931, 0.82608695652174, 0.98478260869565, 0.15909090909091
49932, 0.84782608695652, 0.98478260869565, 0.18181818181818
49933, 0.82608695652174, 0.95869565217391, 0.18181818181818
49934, 0.82608695652174, 0.98478260869565, 0.20454545454545
49935, 0.84782608695652, 0.98478260869565, 0.22727272727273
49936, 0.82608695652174, 0.95869565217391, 0.22727272727273
49937, 0.82608695652174, 0.98478260869565, 0.25
49938, 0.84782608695652, 0.98478260869565, 0.27272727272727
49939, 0.82608695652174, 0.95869565217391, 0.27272727272727
49940, 0.82608695652174, 0.98478260869565, 0.29545454545455
49941, 0.84782608695652, 0.98478260869565, 0.31818181818182
49942, 0.82608695652174, 0.95869565217391, 0.31818181818182
49943, 0.82608695652174, 0.98478260869565, 0.34090909090909
49944, 0.84782608695652, 0.98478260869565, 0.36363636363636
49945, 0.82608695652174, 0.95869565217391, 0.36363636363636
49946, 0.82608695652174, 0.98478260869565, 0.38636363636364
49947, 0.84782608695652, 0.98478260869565, 0.40909090909091
49948, 0.82608695652174, 0.95869565217391, 0.40909090909091
49949, 0.82608695652174, 0.98478260869565, 0.43181818181818
49950, 0.84782608695652, 0.98478260869565, 0.45454545454545
49951, 0.82608695652174, 0.95869565217391, 0.45454545454545
49952, 0.82608695652174, 0.98478260869565, 0.47727272727273
49953, 0.78260869565217, 0.98478260869565, 0.022727272727273
49954, 0.80434782608696, 0.98478260869565, 0.045454545454545
49955, 0.78260869565217, 0.95869565217391, 0.045454545454545
49956, 0.78260869565217, 0.98478260869565, 0.068181818181818
49957, 0.80434782608696, 0.98478260869565, 0.090909090909091
49958, 0.78260869565217, 0.95869565217391, 0.090909090909091
49959, 0.78260869565217, 0.98478260869565, 0.11363636363636
49960, 0.80434782608696, 0.98478260869565, 0.13636363636364
49961, 0.78260869565217, 0.95869565217391, 0.13636363636364
49962, 0.78260869565217, 0.98478260869565, 0.15909090909091
49963, 0.80434782608696, 0.98478260869565, 0.18181818181818
49964, 0.78260869565217, 0.95869565217391, 0.18181818181818
49965, 0.78260869565217, 0.98478260869565, 0.20454545454545
49966, 0.80434782608696, 0.98478260869565, 0.22727272727273
49967, 0.78260869565217, 0.95869565217391, 0.22727272727273
49968, 0.78260869565217, 0.98478260869565, 0.25
49969, 0.80434782608696, 0.98478260869565, 0.27272727272727
49970, 0.78260869565217, 0.95869565217391, 0.27272727272727
49971, 0.78260869565217, 0.98478260869565, 0.29545454545455
49972, 0.80434782608696, 0.98478260869565, 0.31818181818182
49973, 0.78260869565217, 0.95869565217391, 0.31818181818182
49974, 0.78260869565217, 0.98478260869565, 0.34090909090909
49975, 0.80434782608696, 0.98478260869565, 0.36363636363636
49976, 0.78260869565217, 0.95869565217391, 0.36363636363636
49977, 0.78260869565217, 0.98478260869565, 0.38636363636364
49978, 0.80434782608696, 0.98478260869565, 0.40909090909091
49979, 0.78260869565217, 0.95869565217391, 0.40909090909091
49980, 0.78260869565217, 0.98478260869565, 0.43181818181818
49981, 0.80434782608696, 0.98478260869565, 0.45454545454545
49982, 0.78260869565217, 0.95869565217391, 0.45454545454545
49983, 0.78260869565217, 0.98478260869565, 0.47727272727273
49984, 0.73913043478261, 0.98478260869565, 0.022727272727273
49985, 0.76086956521739, 0.98478260869565, 0.045454545454545
49986, 0.73913043478261, 0.95869565217391, 0.045454545454545
49987, 0.73913043478261, 0.98478260869565, 0.068181818181818
49988, 0.76086956521739, 0.98478260869565, 0.090909090909091
49989, 0.73913043478261, 0.95869565217391, 0.090909090909091
49990, 0.73913043478261, 0.98478260869565, 0.11363636363636
49991, 0.76086956521739, 0.98478260869565, 0.13636363636364
49992, 0.73913043478261, 0.95869565217391, 0.13636363636364
49993, 0.73913043478261, 0.98478260869565, 0.15909090909091
49994, 0.76086956521739, 0.98478260869565, 0.18181818181818
49995, 0.73913043478261, 0.95869565217391, 0.18181818181818
49996, 0.73913043478261, 0.98478260869565, 0.20454545454545
49997, 0.76086956521739, 0.98478260869565, 0.22727272727273
49998, 0.73913043478261, 0.95869565217391, 0.22727272727273
49999, 0.73913043478261, 0.98478260869565, 0.25
50000, 0.76086956521739, 0.98478260869565, 0.27272727272727
50001, 0.73913043478261, 0.95869565217391, 0.27272727272727
50002, 0.73913043478261, 0.98478260869565, 0.29545454545455
50003, 0.76086956521739, 0.98478260869565, 0.31818181818182
50004, 0.73913043478261, 0.95869565217391, 0.31818181818182
50005, 0.73913043478261, 0.98478260869565, 0.34090909090909
50006, 0.76086956521739, 0.98478260869565, 0.36363636363636
50007, 0.73913043478261, 0.95869565217391, 0.36363636363636
50008, 0.73913043478261, 0.98478260869565, 0.38636363636364
50009, 0.76086956521739, 0.98478260869565, 0.40909090909091
50010, 0.73913043478261, 0.95869565217391, 0.40909090909091
50011, 0.73913043478261, 0.98478260869565, 0.43181818181818
50012, 0.76086956521739, 0.98478260869565, 0.45454545454545
50013, 0.73913043478261, 0.95869565217391, 0.45454545454545
50014, 0.73913043478261, 0.98478260869565, 0.47727272727273
50015, 0.69565217391304, 0.98478260869565, 0.022727272727273
50016, 0.71739130434783, 0.98478260869565, 0.045454545454545
50017, 0.69565217391304, 0.95869565217391, 0.045454545454545
50018, 0.69565217391304, 0.98478260869565, 0.068181818181818
50019, 0.71739130434783, 0.98478260869565, 0.090909090909091
50020, 0.69565217391304, 0.95869565217391, 0.090909090909091
50021, 0.69565217391304, 0.98478260869565, 0.11363636363636
50022, 0.71739130434783, 0.98478260869565, 0.13636363636364
50023, 0.69565217391304, 0.95869565217391, 0.13636363636364
50024, 0.69565217391304, 0.98478260869565, 0.15909090909091
50025, 0.71739130434783, 0.98478260869565, 0.18181818181818
50026, 0.69565217391304, 0.95869565217391, 0.18181818181818
50027, 0.69565217391304, 0.98478260869565, 0.20454545454545
50028, 0.71739130434783, 0.98478260869565, 0.22727272727273
50029, 0.69565217391304, 0.95869565217391, 0.22727272727273
50030, 0.69565217391304, 0.98478260869565, 0.25
50031, 0.71739130434783, 0.98478260869565, 0.27272727272727
50032, 0.69565217391304, 0.95869565217391, 0.27272727272727
50033, 0.69565217391304, 0.98478260869565, 0.29545454545455
50034, 0.71739130434783, 0.98478260869565, 0.31818181818182
50035, 0.69565217391304, 0.95869565217391, 0.31818181818182
50036, 0.69565217391304, 0.98478260869565, 0.34090909090909
50037, 0.71739130434783, 0.98478260869565, 0.36363636363636
50038, 0.69565217391304, 0.95869565217391, 0.36363636363636
50039, 0.69565217391304, 0.98478260869565, 0.38636363636364
50040, 0.71739130434783, 0.98478260869565, 0.40909090909091
50041, 0.69565217391304, 0.95869565217391, 0.40909090909091
50042, 0.69565217391304, 0.98478260869565, 0.43181818181818
50043, 0.71739130434783, 0.98478260869565, 0.45454545454545
50044, 0.69565217391304, 0.95869565217391, 0.45454545454545
50045, 0.69565217391304, 0.98478260869565, 0.47727272727273
50046, 0.65217391304348, 0.98478260869565, 0.022727272727273
50047, 0.67391304347826, 0.98478260869565, 0.045454545454545
50048, 0.65217391304348, 0.95869565217391, 0.045454545454545
50049, 0.65217391304348, 0.98478260869565, 0.068181818181818
50050, 0.67391304347826, 0.98478260869565, 0.090909090909091
50051, 0.65217391304348, 0.95869565217391, 0.090909090909091
50052, 0.65217391304348, 0.98478260869565, 0.11363636363636
50053, 0.67391304347826, 0.98478260869565, 0.13636363636364
50054, 0.65217391304348, 0.95869565217391, 0.13636363636364
50055, 0.65217391304348, 0.98478260869565, 0.15909090909091
50056, 0.67391304347826, 0.98478260869565, 0.18181818181818
50057, 0.65217391304348, 0.95869565217391, 0.18181818181818
50058, 0.65217391304348, 0.98478260869565, 0.20454545454545
50059, 0.67391304347826, 0.98478260869565, 0.22727272727273
50060, 0.65217391304348, 0.95869565217391, 0.22727272727273
50061, 0.65217391304348, 0.98478260869565, 0.25
50062, 0.67391304347826, 0.98478260869565, 0.27272727272727
50063, 0.65217391304348, 0.95869565217391, 0.27272727272727
50064, 0.65217391304348, 0.98478260869565, 0.29545454545455
50065, 0.67391304347826, 0.98478260869565, 0.31818181818182
50066, 0.65217391304348, 0.95869565217391, 0.31818181818182
50067, 0.65217391304348, 0.98478260869565, 0.34090909090909
50068, 0.67391304347826, 0.98478260869565, 0.36363636363636
50069, 0.65217391304348, 0.95869565217391, 0.36363636363636
50070, 0.65217391304348, 0.98478260869565, 0.38636363636364
50071, 0.67391304347826, 0.98478260869565, 0.40909090909091
50072, 0.65217391304348, 0.95869565217391, 0.40909090909091
50073, 0.65217391304348, 0.98478260869565, 0.43181818181818
50074, 0.67391304347826, 0.98478260869565, 0.45454545454545
50075, 0.65217391304348, 0.95869565217391, 0.45454545454545
50076, 0.65217391304348, 0.98478260869565, 0.47727272727273
50077, 0.60869565217391, 0.98478260869565, 0.022727272727273
50078, 0.6304347826087, 0.98478260869565, 0.045454545454545
50079, 0.60869565217391, 0.95869565217391, 0.045454545454545
50080, 0.60869565217391, 0.98478260869565, 0.068181818181818
50081, 0.6304347826087, 0.98478260869565, 0.090909090909091
50082, 0.60869565217391, 0.95869565217391, 0.090909090909091
50083, 0.60869565217391, 0.98478260869565, 0.11363636363636
50084, 0.6304347826087, 0.98478260869565, 0.13636363636364
50085, 0.60869565217391, 0.95869565217391, 0.13636363636364
50086, 0.60869565217391, 0.98478260869565, 0.15909090909091
50087, 0.6304347826087, 0.98478260869565, 0.18181818181818
50088, 0.60869565217391, 0.95869565217391, 0.18181818181818
50089, 0.60869565217391, 0.98478260869565, 0.20454545454545
50090, 0.6304347826087, 0.98478260869565, 0.22727272727273
50091, 0.60869565217391, 0.95869565217391, 0.22727272727273
50092, 0.60869565217391, 0.98478260869565, 0.25
50093, 0.6304347826087, 0.98478260869565, 0.27272727272727
50094, 0.60869565217391, 0.95869565217391, 0.27272727272727
50095, 0.60869565217391, 0.98478260869565, 0.29545454545455
50096, 0.6304347826087, 0.98478260869565, 0.31818181818182
50097, 0.60869565217391, 0.95869565217391, 0.31818181818182
50098, 0.60869565217391, 0.98478260869565, 0.34090909090909
50099, 0.6304347826087, 0.98478260869565, 0.36363636363636
50100, 0.60869565217391, 0.95869565217391, 0.36363636363636
50101, 0.60869565217391, 0.98478260869565, 0.38636363636364
50102, 0.6304347826087, 0.98478260869565, 0.40909090909091
50103, 0.60869565217391, 0.95869565217391, 0.40909090909091
50104, 0.60869565217391, 0.98478260869565, 0.43181818181818
50105, 0.6304347826087, 0.98478260869565, 0.45454545454545
50106, 0.60869565217391, 0.95869565217391, 0.45454545454545
50107, 0.60869565217391, 0.98478260869565, 0.47727272727273
50108, 0.56521739130435, 0.98478260869565, 0.022727272727273
50109, 0.58695652173913, 0.98478260869565, 0.045454545454545
50110, 0.56521739130435, 0.95869565217391, 0.045454545454545
50111, 0.56521739130435, 0.98478260869565, 0.068181818181818
50112, 0.58695652173913, 0.98478260869565, 0.090909090909091
50113, 0.56521739130435, 0.95869565217391, 0.090909090909091
50114, 0.56521739130435, 0.98478260869565, 0.11363636363636
50115, 0.58695652173913, 0.98478260869565, 0.13636363636364
50116, 0.56521739130435, 0.95869565217391, 0.13636363636364
50117, 0.56521739130435, 0.98478260869565, 0.15909090909091
50118, 0.58695652173913, 0.98478260869565, 0.18181818181818
50119, 0.56521739130435, 0.95869565217391, 0.18181818181818
50120, 0.56521739130435, 0.98478260869565, 0.20454545454545
50121, 0.58695652173913, 0.98478260869565, 0.22727272727273
50122, 0.56521739130435, 0.95869565217391, 0.22727272727273
50123, 0.56521739130435, 0.98478260869565, 0.25
50124, 0.58695652173913, 0.98478260869565, 0.27272727272727
50125, 0.56521739130435, 0.95869565217391, 0.27272727272727
50126, 0.56521739130435, 0.98478260869565, 0.29545454545455
50127, 0.58695652173913, 0.98478260869565, 0.31818181818182
50128, 0.56521739130435, 0.95869565217391, 0.31818181818182
50129, 0.56521739130435, 0.98478260869565, 0.34090909090909
50130, 0.58695652173913, 0.98478260869565, 0.36363636363636
50131, 0.56521739130435, 0.95869565217391, 0.36363636363636
50132, 0.56521739130435, 0.98478260869565, 0.38636363636364
50133, 0.58695652173913, 0.98478260869565, 0.40909090909091
50134, 0.56521739130435, 0.95869565217391, 0.40909090909091
50135, 0.56521739130435, 0.98478260869565, 0.43181818181818
50136, 0.58695652173913, 0.98478260869565, 0.45454545454545
50137, 0.56521739130435, 0.95869565217391, 0.45454545454545
50138, 0.56521739130435, 0.98478260869565, 0.47727272727273
50139, 0.52173913043478, 0.98478260869565, 0.022727272727273
50140, 0.54347826086956, 0.98478260869565, 0.045454545454545
50141, 0.52173913043478, 0.95869565217391, 0.045454545454545
50142, 0.52173913043478, 0.98478260869565, 0.068181818181818
50143, 0.54347826086956, 0.98478260869565, 0.090909090909091
50144, 0.52173913043478, 0.95869565217391, 0.090909090909091
50145, 0.52173913043478, 0.98478260869565, 0.11363636363636
50146, 0.54347826086957, 0.98478260869565, 0.13636363636364
50147, 0.52173913043478, 0.95869565217391, 0.13636363636364
50148, 0.52173913043478, 0.98478260869565, 0.15909090909091
50149, 0.54347826086956, 0.98478260869565, 0.18181818181818
50150, 0.52173913043478, 0.95869565217391, 0.18181818181818
50151, 0.52173913043478, 0.98478260869565, 0.20454545454545
50152, 0.54347826086956, 0.98478260869565, 0.22727272727273
50153, 0.52173913043478, 0.95869565217391, 0.22727272727273
50154, 0.52173913043478, 0.98478260869565, 0.25
50155, 0.54347826086956, 0.98478260869565, 0.27272727272727
50156, 0.52173913043478, 0.95869565217391, 0.27272727272727
50157, 0.52173913043478, 0.98478260869565, 0.29545454545455
50158, 0.54347826086956, 0.98478260869565, 0.31818181818182
50159, 0.52173913043478, 0.95869565217391, 0.31818181818182
50160, 0.52173913043478, 0.98478260869565, 0.34090909090909
50161, 0.54347826086957, 0.98478260869565, 0.36363636363636
50162, 0.52173913043478, 0.95869565217391, 0.36363636363636
50163, 0.52173913043478, 0.98478260869565, 0.38636363636364
50164, 0.54347826086956, 0.98478260869565, 0.40909090909091
50165, 0.52173913043478, 0.95869565217391, 0.40909090909091
50166, 0.52173913043478, 0.98478260869565, 0.43181818181818
50167, 0.54347826086956, 0.98478260869565, 0.45454545454545
50168, 0.52173913043478, 0.95869565217391, 0.45454545454545
50169, 0.52173913043478, 0.98478260869565, 0.47727272727273
50170, 0.47826086956522, 0.98478260869565, 0.022727272727273
50171, 0.5, 0.98478260869565, 0.045454545454545
50172, 0.47826086956522, 0.95869565217391, 0.045454545454545
50173, 0.47826086956522, 0.98478260869565, 0.068181818181818
50174, 0.5, 0.98478260869565, 0.090909090909091
50175, 0.47826086956522, 0.95869565217391, 0.090909090909091
50176, 0.47826086956522, 0.98478260869565, 0.11363636363636
50177, 0.5, 0.98478260869565, 0.13636363636364
50178, 0.47826086956522, 0.95869565217391, 0.13636363636364
50179, 0.47826086956522, 0.98478260869565, 0.15909090909091
50180, 0.5, 0.98478260869565, 0.18181818181818
50181, 0.47826086956522, 0.95869565217391, 0.18181818181818
50182, 0.47826086956522, 0.98478260869565, 0.20454545454545
50183, 0.5, 0.98478260869565, 0.22727272727273
50184, 0.47826086956522, 0.95869565217391, 0.22727272727273
50185, 0.47826086956522, 0.98478260869565, 0.25
50186, 0.5, 0.98478260869565, 0.27272727272727
50187, 0.47826086956522, 0.95869565217391, 0.27272727272727
50188, 0.47826086956522, 0.98478260869565, 0.29545454545455
50189, 0.5, 0.98478260869565, 0.31818181818182
50190, 0.47826086956522, 0.95869565217391, 0.31818181818182
50191, 0.47826086956522, 0.98478260869565, 0.34090909090909
50192, 0.5, 0.98478260869565, 0.36363636363636
50193, 0.47826086956522, 0.95869565217391, 0.36363636363636
50194, 0.47826086956522, 0.98478260869565, 0.38636363636364
50195, 0.5, 0.98478260869565, 0.40909090909091
50196, 0.47826086956522, 0.95869565217391, 0.40909090909091
50197, 0.47826086956522, 0.98478260869565, 0.43181818181818
50198, 0.5, 0.98478260869565, 0.45454545454545
50199, 0.47826086956522, 0.95869565217391, 0.45454545454545
50200, 0.47826086956522, 0.98478260869565, 0.47727272727273
50201, 0.43478260869565, 0.98478260869565, 0.022727272727273
50202, 0.45652173913043, 0.98478260869565, 0.045454545454545
50203, 0.43478260869565, 0.95869565217391, 0.045454545454545
50204, 0.43478260869565, 0.98478260869565, 0.068181818181818
50205, 0.45652173913043, 0.98478260869565, 0.090909090909091
50206, 0.43478260869565, 0.95869565217391, 0.090909090909091
50207, 0.43478260869565, 0.98478260869565, 0.11363636363636
50208, 0.45652173913043, 0.98478260869565, 0.13636363636364
50209, 0.43478260869565, 0.95869565217391, 0.13636363636364
50210, 0.43478260869565, 0.98478260869565, 0.15909090909091
50211, 0.45652173913043, 0.98478260869565, 0.18181818181818
50212, 0.43478260869565, 0.95869565217391, 0.18181818181818
50213, 0.43478260869565, 0.98478260869565, 0.20454545454545
50214, 0.45652173913043, 0.98478260869565, 0.22727272727273
50215, 0.43478260869565, 0.95869565217391, 0.22727272727273
50216, 0.43478260869565, 0.98478260869565, 0.25
50217, 0.45652173913043, 0.98478260869565, 0.27272727272727
50218, 0.43478260869565, 0.95869565217391, 0.27272727272727
50219, 0.43478260869565, 0.98478260869565, 0.29545454545455
50220, 0.45652173913043, 0.98478260869565, 0.31818181818182
50221, 0.43478260869565, 0.95869565217391, 0.31818181818182
50222, 0.43478260869565, 0.98478260869565, 0.34090909090909
50223, 0.45652173913043, 0.98478260869565, 0.36363636363636
50224, 0.43478260869565, 0.95869565217391, 0.36363636363636
50225, 0.43478260869565, 0.98478260869565, 0.38636363636364
50226, 0.45652173913043, 0.98478260869565, 0.40909090909091
50227, 0.43478260869565, 0.95869565217391, 0.40909090909091
50228, 0.43478260869565, 0.98478260869565, 0.43181818181818
50229, 0.45652173913043, 0.98478260869565, 0.45454545454545
50230, 0.43478260869565, 0.95869565217391, 0.45454545454545
50231, 0.43478260869565, 0.98478260869565, 0.47727272727273
50232, 0.39130434782609, 0.98478260869565, 0.022727272727273
50233, 0.41304347826087, 0.98478260869565, 0.045454545454545
50234, 0.39130434782609, 0.95869565217391, 0.045454545454545
50235, 0.39130434782609, 0.98478260869565, 0.068181818181818
50236, 0.41304347826087, 0.98478260869565, 0.090909090909091
50237, 0.39130434782609, 0.95869565217391, 0.090909090909091
50238, 0.39130434782609, 0.98478260869565, 0.11363636363636
50239, 0.41304347826087, 0.98478260869565, 0.13636363636364
50240, 0.39130434782609, 0.95869565217391, 0.13636363636364
50241, 0.39130434782609, 0.98478260869565, 0.15909090909091
50242, 0.41304347826087, 0.98478260869565, 0.18181818181818
50243, 0.39130434782609, 0.95869565217391, 0.18181818181818
50244, 0.39130434782609, 0.98478260869565, 0.20454545454545
50245, 0.41304347826087, 0.98478260869565, 0.22727272727273
50246, 0.39130434782609, 0.95869565217391, 0.22727272727273
50247, 0.39130434782609, 0.98478260869565, 0.25
50248, 0.41304347826087, 0.98478260869565, 0.27272727272727
50249, 0.39130434782609, 0.95869565217391, 0.27272727272727
50250, 0.39130434782609, 0.98478260869565, 0.29545454545455
50251, 0.41304347826087, 0.98478260869565, 0.31818181818182
50252, 0.39130434782609, 0.95869565217391, 0.31818181818182
50253, 0.39130434782609, 0.98478260869565, 0.34090909090909
50254, 0.41304347826087, 0.98478260869565, 0.36363636363636
50255, 0.39130434782609, 0.95869565217391, 0.36363636363636
50256, 0.39130434782609, 0.98478260869565, 0.38636363636364
50257, 0.41304347826087, 0.98478260869565, 0.40909090909091
50258, 0.39130434782609, 0.95869565217391, 0.40909090909091
50259, 0.39130434782609, 0.98478260869565, 0.43181818181818
50260, 0.41304347826087, 0.98478260869565, 0.45454545454545
50261, 0.39130434782609, 0.95869565217391, 0.45454545454545
50262, 0.39130434782609, 0.98478260869565, 0.47727272727273
50263, 0.34782608695652, 0.98478260869565, 0.022727272727273
50264, 0.3695652173913, 0.98478260869565, 0.045454545454545
50265, 0.34782608695652, 0.95869565217391, 0.045454545454545
50266, 0.34782608695652, 0.98478260869565, 0.068181818181818
50267, 0.3695652173913, 0.98478260869565, 0.090909090909091
50268, 0.34782608695652, 0.95869565217391, 0.090909090909091
50269, 0.34782608695652, 0.98478260869565, 0.11363636363636
50270, 0.3695652173913, 0.98478260869565, 0.13636363636364
50271, 0.34782608695652, 0.95869565217391, 0.13636363636364
50272, 0.34782608695652, 0.98478260869565, 0.15909090909091
50273, 0.3695652173913, 0.98478260869565, 0.18181818181818
50274, 0.34782608695652, 0.95869565217391, 0.18181818181818
50275, 0.34782608695652, 0.98478260869565, 0.20454545454545
50276, 0.3695652173913, 0.98478260869565, 0.22727272727273
50277, 0.34782608695652, 0.95869565217391, 0.22727272727273
50278, 0.34782608695652, 0.98478260869565, 0.25
50279, 0.3695652173913, 0.98478260869565, 0.27272727272727
50280, 0.34782608695652, 0.95869565217391, 0.27272727272727
50281, 0.34782608695652, 0.98478260869565, 0.29545454545455
50282, 0.3695652173913, 0.98478260869565, 0.31818181818182
50283, 0.34782608695652, 0.95869565217391, 0.31818181818182
50284, 0.34782608695652, 0.98478260869565, 0.34090909090909
50285, 0.3695652173913, 0.98478260869565, 0.36363636363636
50286, 0.34782608695652, 0.95869565217391, 0.36363636363636
50287, 0.34782608695652, 0.98478260869565, 0.38636363636364
50288, 0.3695652173913, 0.98478260869565, 0.40909090909091
50289, 0.34782608695652, 0.95869565217391, 0.40909090909091
50290, 0.34782608695652, 0.98478260869565, 0.43181818181818
50291, 0.3695652173913, 0.98478260869565, 0.45454545454545
50292, 0.34782608695652, 0.95869565217391, 0.45454545454545
50293, 0.34782608695652, 0.98478260869565, 0.47727272727273
50294, 0.30434782608696, 0.98478260869565, 0.022727272727273
50295, 0.32608695652174, 0.98478260869565, 0.045454545454545
50296, 0.30434782608696, 0.95869565217391, 0.045454545454545
50297, 0.30434782608696, 0.98478260869565, 0.068181818181818
50298, 0.32608695652174, 0.98478260869565, 0.090909090909091
50299, 0.30434782608696, 0.95869565217391, 0.090909090909091
50300, 0.30434782608696, 0.98478260869565, 0.11363636363636
50301, 0.32608695652174, 0.98478260869565, 0.13636363636364
50302, 0.30434782608696, 0.95869565217391, 0.13636363636364
50303, 0.30434782608696, 0.98478260869565, 0.15909090909091
50304, 0.32608695652174, 0.98478260869565, 0.18181818181818
50305, 0.30434782608696, 0.95869565217391, 0.18181818181818
50306, 0.30434782608696, 0.98478260869565, 0.20454545454545
50307, 0.32608695652174, 0.98478260869565, 0.22727272727273
50308, 0.30434782608696, 0.95869565217391, 0.22727272727273
50309, 0.30434782608696, 0.98478260869565, 0.25
50310, 0.32608695652174, 0.98478260869565, 0.27272727272727
50311, 0.30434782608696, 0.95869565217391, 0.27272727272727
50312, 0.30434782608696, 0.98478260869565, 0.29545454545455
50313, 0.32608695652174, 0.98478260869565, 0.31818181818182
50314, 0.30434782608696, 0.95869565217391, 0.31818181818182
50315, 0.30434782608696, 0.98478260869565, 0.34090909090909
50316, 0.32608695652174, 0.98478260869565, 0.36363636363636
50317, 0.30434782608696, 0.95869565217391, 0.36363636363636
50318, 0.30434782608696, 0.98478260869565, 0.38636363636364
50319, 0.32608695652174, 0.98478260869565, 0.40909090909091
50320, 0.30434782608696, 0.95869565217391, 0.40909090909091
50321, 0.30434782608696, 0.98478260869565, 0.43181818181818
50322, 0.32608695652174, 0.98478260869565, 0.45454545454545
50323, 0.30434782608696, 0.95869565217391, 0.45454545454545
50324, 0.30434782608696, 0.98478260869565, 0.47727272727273
50325, 0.26086956521739, 0.98478260869565, 0.022727272727273
50326, 0.28260869565217, 0.98478260869565, 0.045454545454545
50327, 0.26086956521739, 0.95869565217391, 0.045454545454545
50328, 0.26086956521739, 0.98478260869565, 0.068181818181818
50329, 0.28260869565217, 0.98478260869565, 0.090909090909091
50330, 0.26086956521739, 0.95869565217391, 0.090909090909091
50331, 0.26086956521739, 0.98478260869565, 0.11363636363636
50332, 0.28260869565217, 0.98478260869565, 0.13636363636364
50333, 0.26086956521739, 0.95869565217391, 0.13636363636364
50334, 0.26086956521739, 0.98478260869565, 0.15909090909091
50335, 0.28260869565217, 0.98478260869565, 0.18181818181818
50336, 0.26086956521739, 0.95869565217391, 0.18181818181818
50337, 0.26086956521739, 0.98478260869565, 0.20454545454545
50338, 0.28260869565217, 0.98478260869565, 0.22727272727273
50339, 0.26086956521739, 0.95869565217391, 0.22727272727273
50340, 0.26086956521739, 0.98478260869565, 0.25
50341, 0.28260869565217, 0.98478260869565, 0.27272727272727
50342, 0.26086956521739, 0.95869565217391, 0.27272727272727
50343, 0.26086956521739, 0.98478260869565, 0.29545454545455
50344, 0.28260869565217, 0.98478260869565, 0.31818181818182
50345, 0.26086956521739, 0.95869565217391, 0.31818181818182
50346, 0.26086956521739, 0.98478260869565, 0.34090909090909
50347, 0.28260869565217, 0.98478260869565, 0.36363636363636
50348, 0.26086956521739, 0.95869565217391, 0.36363636363636
50349, 0.26086956521739, 0.98478260869565, 0.38636363636364
50350, 0.28260869565217, 0.98478260869565, 0.40909090909091
50351, 0.26086956521739, 0.95869565217391, 0.40909090909091
50352, 0.26086956521739, 0.98478260869565, 0.43181818181818
50353, 0.28260869565217, 0.98478260869565, 0.45454545454545
50354, 0.26086956521739, 0.95869565217391, 0.45454545454545
50355, 0.26086956521739, 0.98478260869565, 0.47727272727273
50356, 0.21739130434783, 0.98478260869565, 0.022727272727273
50357, 0.23913043478261, 0.98478260869565, 0.045454545454545
50358, 0.21739130434783, 0.95869565217391, 0.045454545454545
50359, 0.21739130434783, 0.98478260869565, 0.068181818181818
50360, 0.23913043478261, 0.98478260869565, 0.090909090909091
50361, 0.21739130434783, 0.95869565217391, 0.090909090909091
50362, 0.21739130434783, 0.98478260869565, 0.11363636363636
50363, 0.23913043478261, 0.98478260869565, 0.13636363636364
50364, 0.21739130434783, 0.95869565217391, 0.13636363636364
50365, 0.21739130434783, 0.98478260869565, 0.15909090909091
50366, 0.23913043478261, 0.98478260869565, 0.18181818181818
50367, 0.21739130434783, 0.95869565217391, 0.18181818181818
50368, 0.21739130434783, 0.98478260869565, 0.20454545454545
50369, 0.23913043478261, 0.98478260869565, 0.22727272727273
50370, 0.21739130434783, 0.95869565217391, 0.22727272727273
50371, 0.21739130434783, 0.98478260869565, 0.25
50372, 0.23913043478261, 0.98478260869565, 0.27272727272727
50373, 0.21739130434783, 0.95869565217391, 0.27272727272727
50374, 0.21739130434783, 0.98478260869565, 0.29545454545455
50375, 0.23913043478261, 0.98478260869565, 0.31818181818182
50376, 0.21739130434783, 0.95869565217391, 0.31818181818182
50377, 0.21739130434783, 0.98478260869565, 0.34090909090909
50378, 0.23913043478261, 0.98478260869565, 0.36363636363636
50379, 0.21739130434783, 0.95869565217391, 0.36363636363636
50380, 0.21739130434783, 0.98478260869565, 0.38636363636364
50381, 0.23913043478261, 0.98478260869565, 0.40909090909091
50382, 0.21739130434783, 0.95869565217391, 0.40909090909091
50383, 0.21739130434783, 0.98478260869565, 0.43181818181818
50384, 0.23913043478261, 0.98478260869565, 0.45454545454545
50385, 0.21739130434783, 0.95869565217391, 0.45454545454545
50386, 0.21739130434783, 0.98478260869565, 0.47727272727273
50387, 0.17391304347826, 0.98478260869565, 0.022727272727273
50388, 0.19565217391304, 0.98478260869565, 0.045454545454545
50389, 0.17391304347826, 0.95869565217391, 0.045454545454545
50390, 0.17391304347826, 0.98478260869565, 0.068181818181818
50391, 0.19565217391304, 0.98478260869565, 0.090909090909091
50392, 0.17391304347826, 0.95869565217391, 0.090909090909091
50393, 0.17391304347826, 0.98478260869565, 0.11363636363636
50394, 0.19565217391304, 0.98478260869565, 0.13636363636364
50395, 0.17391304347826, 0.95869565217391, 0.13636363636364
50396, 0.17391304347826, 0.98478260869565, 0.15909090909091
50397, 0.19565217391304, 0.98478260869565, 0.18181818181818
50398, 0.17391304347826, 0.95869565217391, 0.18181818181818
50399, 0.17391304347826, 0.98478260869565, 0.20454545454545
50400, 0.19565217391304, 0.98478260869565, 0.22727272727273
50401, 0.17391304347826, 0.95869565217391, 0.22727272727273
50402, 0.17391304347826, 0.98478260869565, 0.25
50403, 0.19565217391304, 0.98478260869565, 0.27272727272727
50404, 0.17391304347826, 0.95869565217391, 0.27272727272727
50405, 0.17391304347826, 0.98478260869565, 0.29545454545455
50406, 0.19565217391304, 0.98478260869565, 0.31818181818182
50407, 0.17391304347826, 0.95869565217391, 0.31818181818182
50408, 0.17391304347826, 0.98478260869565, 0.34090909090909
50409, 0.19565217391304, 0.98478260869565, 0.36363636363636
50410, 0.17391304347826, 0.95869565217391, 0.36363636363636
50411, 0.17391304347826, 0.98478260869565, 0.38636363636364
50412, 0.19565217391304, 0.98478260869565, 0.40909090909091
50413, 0.17391304347826, 0.95869565217391, 0.40909090909091
50414, 0.17391304347826, 0.98478260869565, 0.43181818181818
50415, 0.19565217391304, 0.98478260869565, 0.45454545454545
50416, 0.17391304347826, 0.95869565217391, 0.45454545454545
50417, 0.17391304347826, 0.98478260869565, 0.47727272727273
50418, 0.1304347826087, 0.98478260869565, 0.022727272727273
50419, 0.15217391304348, 0.98478260869565, 0.045454545454545
50420, 0.1304347826087, 0.95869565217391, 0.045454545454545
50421, 0.1304347826087, 0.98478260869565, 0.068181818181818
50422, 0.15217391304348, 0.98478260869565, 0.090909090909091
50423, 0.1304347826087, 0.95869565217391, 0.090909090909091
50424, 0.1304347826087, 0.98478260869565, 0.11363636363636
50425, 0.15217391304348, 0.98478260869565, 0.13636363636364
50426, 0.1304347826087, 0.95869565217391, 0.13636363636364
50427, 0.1304347826087, 0.98478260869565, 0.15909090909091
50428, 0.15217391304348, 0.98478260869565, 0.18181818181818
50429, 0.1304347826087, 0.95869565217391, 0.18181818181818
50430, 0.1304347826087, 0.98478260869565, 0.20454545454545
50431, 0.15217391304348, 0.98478260869565, 0.22727272727273
50432, 0.1304347826087, 0.95869565217391, 0.22727272727273
50433, 0.1304347826087, 0.98478260869565, 0.25
50434, 0.15217391304348, 0.98478260869565, 0.27272727272727
50435, 0.1304347826087, 0.95869565217391, 0.27272727272727
50436, 0.1304347826087, 0.98478260869565, 0.29545454545455
50437, 0.15217391304348, 0.98478260869565, 0.31818181818182
50438, 0.1304347826087, 0.95869565217391, 0.31818181818182
50439, 0.1304347826087, 0.98478260869565, 0.34090909090909
50440, 0.15217391304348, 0.98478260869565, 0.36363636363636
50441, 0.1304347826087, 0.95869565217391, 0.36363636363636
50442, 0.1304347826087, 0.98478260869565, 0.38636363636364
50443, 0.15217391304348, 0.98478260869565, 0.40909090909091
50444, 0.1304347826087, 0.95869565217391, 0.40909090909091
50445, 0.1304347826087, 0.98478260869565, 0.43181818181818
50446, 0.15217391304348, 0.98478260869565, 0.45454545454545
50447, 0.1304347826087, 0.95869565217391, 0.45454545454545
50448, 0.1304347826087, 0.98478260869565, 0.47727272727273
50449, 0.08695652173913, 0.98478260869565, 0.022727272727273
50450, 0.10869565217391, 0.98478260869565, 0.045454545454545
50451, 0.08695652173913, 0.95869565217391, 0.045454545454545
50452, 0.08695652173913, 0.98478260869565, 0.068181818181818
50453, 0.10869565217391, 0.98478260869565, 0.090909090909091
50454, 0.08695652173913, 0.95869565217391, 0.090909090909091
50455, 0.08695652173913, 0.98478260869565, 0.11363636363636
50456, 0.10869565217391, 0.98478260869565, 0.13636363636364
50457, 0.08695652173913, 0.95869565217391, 0.13636363636364
50458, 0.08695652173913, 0.98478260869565, 0.15909090909091
50459, 0.10869565217391, 0.98478260869565, 0.18181818181818
50460, 0.08695652173913, 0.95869565217391, 0.18181818181818
50461, 0.08695652173913, 0.98478260869565, 0.20454545454545
50462, 0.10869565217391, 0.98478260869565, 0.22727272727273
50463, 0.08695652173913, 0.95869565217391, 0.22727272727273
50464, 0.08695652173913, 0.98478260869565, 0.25
50465, 0.10869565217391, 0.98478260869565, 0.27272727272727
50466, 0.08695652173913, 0.95869565217391, 0.27272727272727
50467, 0.08695652173913, 0.98478260869565, 0.29545454545455
50468, 0.10869565217391, 0.98478260869565, 0.31818181818182
50469, 0.08695652173913, 0.95869565217391, 0.31818181818182
50470, 0.08695652173913, 0.98478260869565, 0.34090909090909
50471, 0.10869565217391, 0.98478260869565, 0.36363636363636
50472, 0.08695652173913, 0.95869565217391, 0.36363636363636
50473, 0.08695652173913, 0.98478260869565, 0.38636363636364
50474, 0.10869565217391, 0.98478260869565, 0.40909090909091
50475, 0.08695652173913, 0.95869565217391, 0.40909090909091
50476, 0.08695652173913, 0.98478260869565, 0.43181818181818
50477, 0.10869565217391, 0.98478260869565, 0.45454545454545
50478, 0.08695652173913, 0.95869565217391, 0.45454545454545
50479, 0.08695652173913, 0.98478260869565, 0.47727272727273
50480, 0.043478260869565, 0.98478260869565, 0.022727272727273
50481, 0.065217391304348, 0.98478260869565, 0.045454545454545
50482, 0.043478260869565, 0.95869565217391, 0.045454545454545
50483, 0.043478260869565, 0.98478260869565, 0.068181818181818
50484, 0.065217391304348, 0.98478260869565, 0.090909090909091
50485, 0.043478260869565, 0.95869565217391, 0.090909090909091
50486, 0.043478260869565, 0.98478260869565, 0.11363636363636
50487, 0.065217391304348, 0.98478260869565, 0.13636363636364
50488, 0.043478260869565, 0.95869565217391, 0.13636363636364
50489, 0.043478260869565, 0.98478260869565, 0.15909090909091
50490, 0.065217391304348, 0.98478260869565, 0.18181818181818
50491, 0.043478260869565, 0.95869565217391, 0.18181818181818
50492, 0.043478260869565, 0.98478260869565, 0.20454545454545
50493, 0.065217391304348, 0.98478260869565, 0.22727272727273
50494, 0.043478260869565, 0.95869565217391, 0.22727272727273
50495, 0.043478260869565, 0.98478260869565, 0.25
50496, 0.065217391304348, 0.98478260869565, 0.27272727272727
50497, 0.043478260869565, 0.95869565217391, 0.27272727272727
50498, 0.043478260869565, 0.98478260869565, 0.29545454545455
50499, 0.065217391304348, 0.98478260869565, 0.31818181818182
50500, 0.043478260869565, 0.95869565217391, 0.31818181818182
50501, 0.043478260869565, 0.98478260869565, 0.34090909090909
50502, 0.065217391304348, 0.98478260869565, 0.36363636363636
50503, 0.043478260869565, 0.95869565217391, 0.36363636363636
50504, 0.043478260869565, 0.98478260869565, 0.38636363636364
50505, 0.065217391304348, 0.98478260869565, 0.40909090909091
50506, 0.043478260869565, 0.95869565217391, 0.40909090909091
50507, 0.043478260869565, 0.98478260869565, 0.43181818181818
50508, 0.065217391304348, 0.98478260869565, 0.45454545454545
50509, 0.043478260869565, 0.95869565217391, 0.45454545454545
50510, 0.043478260869565, 0.98478260869565, 0.47727272727273
50511, 0.021739130434783, 0.98478260869565, 0.045454545454545
50512, 0.021739130434783, 0.98478260869565, 0.090909090909091
50513, 0.021739130434783, 0.98478260869565, 0.13636363636364
50514, 0.021739130434783, 0.98478260869565, 0.18181818181818
50515, 0.021739130434783, 0.98478260869565, 0.22727272727273
50516, 0.021739130434783, 0.98478260869565, 0.27272727272727
50517, 0.021739130434783, 0.98478260869565, 0.31818181818182
50518, 0.021739130434783, 0.98478260869565, 0.36363636363636
50519, 0.021739130434783, 0.98478260869565, 0.40909090909091
50520, 0.021739130434783, 0.98478260869565, 0.45454545454545
50521, 0.95652173913043, 1.0369565217391, 0.022727272727273
50522, 0.97826086956522, 1.0369565217391, 0.045454545454545
50523, 0.95652173913043, 1.0108695652174, 0.045454545454545
50524, 0.95652173913043, 1.0369565217391, 0.068181818181818
50525, 0.97826086956522, 1.0369565217391, 0.090909090909091
50526, 0.95652173913043, 1.0108695652174, 0.090909090909091
50527, 0.95652173913043, 1.0369565217391, 0.11363636363636
50528, 0.97826086956522, 1.0369565217391, 0.13636363636364
50529, 0.95652173913044, 1.0108695652174, 0.13636363636364
50530, 0.95652173913044, 1.0369565217391, 0.15909090909091
50531, 0.97826086956522, 1.0369565217391, 0.18181818181818
50532, 0.95652173913044, 1.0108695652174, 0.18181818181818
50533, 0.95652173913044, 1.0369565217391, 0.20454545454545
50534, 0.97826086956522, 1.0369565217391, 0.22727272727273
50535, 0.95652173913044, 1.0108695652174, 0.22727272727273
50536, 0.95652173913044, 1.0369565217391, 0.25
50537, 0.97826086956522, 1.0369565217391, 0.27272727272727
50538, 0.95652173913044, 1.0108695652174, 0.27272727272727
50539, 0.95652173913044, 1.0369565217391, 0.29545454545455
50540, 0.97826086956522, 1.0369565217391, 0.31818181818182
50541, 0.95652173913044, 1.0108695652174, 0.31818181818182
50542, 0.95652173913043, 1.0369565217391, 0.34090909090909
50543, 0.97826086956522, 1.0369565217391, 0.36363636363636
50544, 0.95652173913043, 1.0108695652174, 0.36363636363636
50545, 0.95652173913043, 1.0369565217391, 0.38636363636364
50546, 0.97826086956522, 1.0369565217391, 0.40909090909091
50547, 0.95652173913043, 1.0108695652174, 0.40909090909091
50548, 0.95652173913043, 1.0369565217391, 0.43181818181818
50549, 0.97826086956522, 1.0369565217391, 0.45454545454545
50550, 0.95652173913044, 1.0108695652174, 0.45454545454545
50551, 0.95652173913043, 1.0369565217391, 0.47727272727273
50552, 0.91304347826087, 1.0369565217391, 0.022727272727273
50553, 0.93478260869565, 1.0369565217391, 0.045454545454545
50554, 0.91304347826087, 1.0108695652174, 0.045454545454545
50555, 0.91304347826087, 1.0369565217391, 0.068181818181818
50556, 0.93478260869565, 1.0369565217391, 0.090909090909091
50557, 0.91304347826087, 1.0108695652174, 0.090909090909091
50558, 0.91304347826087, 1.0369565217391, 0.11363636363636
50559, 0.93478260869565, 1.0369565217391, 0.13636363636364
50560, 0.91304347826087, 1.0108695652174, 0.13636363636364
50561, 0.91304347826087, 1.0369565217391, 0.15909090909091
50562, 0.93478260869565, 1.0369565217391, 0.18181818181818
50563, 0.91304347826087, 1.0108695652174, 0.18181818181818
50564, 0.91304347826087, 1.0369565217391, 0.20454545454545
50565, 0.93478260869565, 1.0369565217391, 0.22727272727273
50566, 0.91304347826087, 1.0108695652174, 0.22727272727273
50567, 0.91304347826087, 1.0369565217391, 0.25
50568, 0.93478260869565, 1.0369565217391, 0.27272727272727
50569, 0.91304347826087, 1.0108695652174, 0.27272727272727
50570, 0.91304347826087, 1.0369565217391, 0.29545454545455
50571, 0.93478260869565, 1.0369565217391, 0.31818181818182
50572, 0.91304347826087, 1.0108695652174, 0.31818181818182
50573, 0.91304347826087, 1.0369565217391, 0.34090909090909
50574, 0.93478260869565, 1.0369565217391, 0.36363636363636
50575, 0.91304347826087, 1.0108695652174, 0.36363636363636
50576, 0.91304347826087, 1.0369565217391, 0.38636363636364
50577, 0.93478260869565, 1.0369565217391, 0.40909090909091
50578, 0.91304347826087, 1.0108695652174, 0.40909090909091
50579, 0.91304347826087, 1.0369565217391, 0.43181818181818
50580, 0.93478260869565, 1.0369565217391, 0.45454545454545
50581, 0.91304347826087, 1.0108695652174, 0.45454545454545
50582, 0.91304347826087, 1.0369565217391, 0.47727272727273
50583, 0.8695652173913, 1.0369565217391, 0.022727272727273
50584, 0.89130434782609, 1.0369565217391, 0.045454545454545
50585, 0.8695652173913, 1.0108695652174, 0.045454545454545
50586, 0.8695652173913, 1.0369565217391, 0.068181818181818
50587, 0.89130434782609, 1.0369565217391, 0.090909090909091
50588, 0.8695652173913, 1.0108695652174, 0.090909090909091
50589, 0.8695652173913, 1.0369565217391, 0.11363636363636
50590, 0.89130434782609, 1.0369565217391, 0.13636363636364
50591, 0.8695652173913, 1.0108695652174, 0.13636363636364
50592, 0.8695652173913, 1.0369565217391, 0.15909090909091
50593, 0.89130434782609, 1.0369565217391, 0.18181818181818
50594, 0.8695652173913, 1.0108695652174, 0.18181818181818
50595, 0.8695652173913, 1.0369565217391, 0.20454545454545
50596, 0.89130434782609, 1.0369565217391, 0.22727272727273
50597, 0.8695652173913, 1.0108695652174, 0.22727272727273
50598, 0.8695652173913, 1.0369565217391, 0.25
50599, 0.89130434782609, 1.0369565217391, 0.27272727272727
50600, 0.8695652173913, 1.0108695652174, 0.27272727272727
50601, 0.8695652173913, 1.0369565217391, 0.29545454545455
50602, 0.89130434782609, 1.0369565217391, 0.31818181818182
50603, 0.8695652173913, 1.0108695652174, 0.31818181818182
50604, 0.8695652173913, 1.0369565217391, 0.34090909090909
50605, 0.89130434782609, 1.0369565217391, 0.36363636363636
50606, 0.8695652173913, 1.0108695652174, 0.36363636363636
50607, 0.8695652173913, 1.0369565217391, 0.38636363636364
50608, 0.89130434782609, 1.0369565217391, 0.40909090909091
50609, 0.8695652173913, 1.0108695652174, 0.40909090909091
50610, 0.8695652173913, 1.0369565217391, 0.43181818181818
50611, 0.89130434782609, 1.0369565217391, 0.45454545454545
50612, 0.8695652173913, 1.0108695652174, 0.45454545454545
50613, 0.8695652173913, 1.0369565217391, 0.47727272727273
50614, 0.82608695652174, 1.0369565217391, 0.022727272727273
50615, 0.84782608695652, 1.0369565217391, 0.045454545454545
50616, 0.82608695652174, 1.0108695652174, 0.045454545454545
50617, 0.82608695652174, 1.0369565217391, 0.068181818181818
50618, 0.84782608695652, 1.0369565217391, 0.090909090909091
50619, 0.82608695652174, 1.0108695652174, 0.090909090909091
50620, 0.82608695652174, 1.0369565217391, 0.11363636363636
50621, 0.84782608695652, 1.0369565217391, 0.13636363636364
50622, 0.82608695652174, 1.0108695652174, 0.13636363636364
50623, 0.82608695652174, 1.0369565217391, 0.15909090909091
50624, 0.84782608695652, 1.0369565217391, 0.18181818181818
50625, 0.82608695652174, 1.0108695652174, 0.18181818181818
50626, 0.82608695652174, 1.0369565217391, 0.20454545454545
50627, 0.84782608695652, 1.0369565217391, 0.22727272727273
50628, 0.82608695652174, 1.0108695652174, 0.22727272727273
50629, 0.82608695652174, 1.0369565217391, 0.25
50630, 0.84782608695652, 1.0369565217391, 0.27272727272727
50631, 0.82608695652174, 1.0108695652174, 0.27272727272727
50632, 0.82608695652174, 1.0369565217391, 0.29545454545455
50633, 0.84782608695652, 1.0369565217391, 0.31818181818182
50634, 0.82608695652174, 1.0108695652174, 0.31818181818182
50635, 0.82608695652174, 1.0369565217391, 0.34090909090909
50636, 0.84782608695652, 1.0369565217391, 0.36363636363636
50637, 0.82608695652174, 1.0108695652174, 0.36363636363636
50638, 0.82608695652174, 1.0369565217391, 0.38636363636364
50639, 0.84782608695652, 1.0369565217391, 0.40909090909091
50640, 0.82608695652174, 1.0108695652174, 0.40909090909091
50641, 0.82608695652174, 1.0369565217391, 0.43181818181818
50642, 0.84782608695652, 1.0369565217391, 0.45454545454545
50643, 0.82608695652174, 1.0108695652174, 0.45454545454545
50644, 0.82608695652174, 1.0369565217391, 0.47727272727273
50645, 0.78260869565217, 1.0369565217391, 0.022727272727273
50646, 0.80434782608696, 1.0369565217391, 0.045454545454545
50647, 0.78260869565217, 1.0108695652174, 0.045454545454545
50648, 0.78260869565217, 1.0369565217391, 0.068181818181818
50649, 0.80434782608696, 1.0369565217391, 0.090909090909091
50650, 0.78260869565217, 1.0108695652174, 0.090909090909091
50651, 0.78260869565217, 1.0369565217391, 0.11363636363636
50652, 0.80434782608696, 1.0369565217391, 0.13636363636364
50653, 0.78260869565217, 1.0108695652174, 0.13636363636364
50654, 0.78260869565217, 1.0369565217391, 0.15909090909091
50655, 0.80434782608696, 1.0369565217391, 0.18181818181818
50656, 0.78260869565217, 1.0108695652174, 0.18181818181818
50657, 0.78260869565217, 1.0369565217391, 0.20454545454545
50658, 0.80434782608696, 1.0369565217391, 0.22727272727273
50659, 0.78260869565217, 1.0108695652174, 0.22727272727273
50660, 0.78260869565217, 1.0369565217391, 0.25
50661, 0.80434782608696, 1.0369565217391, 0.27272727272727
50662, 0.78260869565217, 1.0108695652174, 0.27272727272727
50663, 0.78260869565217, 1.0369565217391, 0.29545454545455
50664, 0.80434782608696, 1.0369565217391, 0.31818181818182
50665, 0.78260869565217, 1.0108695652174, 0.31818181818182
50666, 0.78260869565217, 1.0369565217391, 0.34090909090909
50667, 0.80434782608696, 1.0369565217391, 0.36363636363636
50668, 0.78260869565217, 1.0108695652174, 0.36363636363636
50669, 0.78260869565217, 1.0369565217391, 0.38636363636364
50670, 0.80434782608696, 1.0369565217391, 0.40909090909091
50671, 0.78260869565217, 1.0108695652174, 0.40909090909091
50672, 0.78260869565217, 1.0369565217391, 0.43181818181818
50673, 0.80434782608696, 1.0369565217391, 0.45454545454545
50674, 0.78260869565217, 1.0108695652174, 0.45454545454545
50675, 0.78260869565217, 1.0369565217391, 0.47727272727273
50676, 0.73913043478261, 1.0369565217391, 0.022727272727273
50677, 0.76086956521739, 1.0369565217391, 0.045454545454545
50678, 0.73913043478261, 1.0108695652174, 0.045454545454545
50679, 0.73913043478261, 1.0369565217391, 0.068181818181818
50680, 0.76086956521739, 1.0369565217391, 0.090909090909091
50681, 0.73913043478261, 1.0108695652174, 0.090909090909091
50682, 0.73913043478261, 1.0369565217391, 0.11363636363636
50683, 0.76086956521739, 1.0369565217391, 0.13636363636364
50684, 0.73913043478261, 1.0108695652174, 0.13636363636364
50685, 0.73913043478261, 1.0369565217391, 0.15909090909091
50686, 0.76086956521739, 1.0369565217391, 0.18181818181818
50687, 0.73913043478261, 1.0108695652174, 0.18181818181818
50688, 0.73913043478261, 1.0369565217391, 0.20454545454545
50689, 0.76086956521739, 1.0369565217391, 0.22727272727273
50690, 0.73913043478261, 1.0108695652174, 0.22727272727273
50691, 0.73913043478261, 1.0369565217391, 0.25
50692, 0.76086956521739, 1.0369565217391, 0.27272727272727
50693, 0.73913043478261, 1.0108695652174, 0.27272727272727
50694, 0.73913043478261, 1.0369565217391, 0.29545454545455
50695, 0.76086956521739, 1.0369565217391, 0.31818181818182
50696, 0.73913043478261, 1.0108695652174, 0.31818181818182
50697, 0.73913043478261, 1.0369565217391, 0.34090909090909
50698, 0.76086956521739, 1.0369565217391, 0.36363636363636
50699, 0.73913043478261, 1.0108695652174, 0.36363636363636
50700, 0.73913043478261, 1.0369565217391, 0.38636363636364
50701, 0.76086956521739, 1.0369565217391, 0.40909090909091
50702, 0.73913043478261, 1.0108695652174, 0.40909090909091
50703, 0.73913043478261, 1.0369565217391, 0.43181818181818
50704, 0.76086956521739, 1.0369565217391, 0.45454545454545
50705, 0.73913043478261, 1.0108695652174, 0.45454545454545
50706, 0.73913043478261, 1.0369565217391, 0.47727272727273
50707, 0.69565217391304, 1.0369565217391, 0.022727272727273
50708, 0.71739130434783, 1.0369565217391, 0.045454545454545
50709, 0.69565217391304, 1.0108695652174, 0.045454545454545
50710, 0.69565217391304, 1.0369565217391, 0.068181818181818
50711, 0.71739130434783, 1.0369565217391, 0.090909090909091
50712, 0.69565217391304, 1.0108695652174, 0.090909090909091
50713, 0.69565217391304, 1.0369565217391, 0.11363636363636
50714, 0.71739130434783, 1.0369565217391, 0.13636363636364
50715, 0.69565217391304, 1.0108695652174, 0.13636363636364
50716, 0.69565217391304, 1.0369565217391, 0.15909090909091
50717, 0.71739130434783, 1.0369565217391, 0.18181818181818
50718, 0.69565217391304, 1.0108695652174, 0.18181818181818
50719, 0.69565217391304, 1.0369565217391, 0.20454545454545
50720, 0.71739130434783, 1.0369565217391, 0.22727272727273
50721, 0.69565217391304, 1.0108695652174, 0.22727272727273
50722, 0.69565217391304, 1.0369565217391, 0.25
50723, 0.71739130434783, 1.0369565217391, 0.27272727272727
50724, 0.69565217391304, 1.0108695652174, 0.27272727272727
50725, 0.69565217391304, 1.0369565217391, 0.29545454545455
50726, 0.71739130434783, 1.0369565217391, 0.31818181818182
50727, 0.69565217391304, 1.0108695652174, 0.31818181818182
50728, 0.69565217391304, 1.0369565217391, 0.34090909090909
50729, 0.71739130434783, 1.0369565217391, 0.36363636363636
50730, 0.69565217391304, 1.0108695652174, 0.36363636363636
50731, 0.69565217391304, 1.0369565217391, 0.38636363636364
50732, 0.71739130434783, 1.0369565217391, 0.40909090909091
50733, 0.69565217391304, 1.0108695652174, 0.40909090909091
50734, 0.69565217391304, 1.0369565217391, 0.43181818181818
50735, 0.71739130434783, 1.0369565217391, 0.45454545454545
50736, 0.69565217391304, 1.0108695652174, 0.45454545454545
50737, 0.69565217391304, 1.0369565217391, 0.47727272727273
50738, 0.65217391304348, 1.0369565217391, 0.022727272727273
50739, 0.67391304347826, 1.0369565217391, 0.045454545454545
50740, 0.65217391304348, 1.0108695652174, 0.045454545454545
50741, 0.65217391304348, 1.0369565217391, 0.068181818181818
50742, 0.67391304347826, 1.0369565217391, 0.090909090909091
50743, 0.65217391304348, 1.0108695652174, 0.090909090909091
50744, 0.65217391304348, 1.0369565217391, 0.11363636363636
50745, 0.67391304347826, 1.0369565217391, 0.13636363636364
50746, 0.65217391304348, 1.0108695652174, 0.13636363636364
50747, 0.65217391304348, 1.0369565217391, 0.15909090909091
50748, 0.67391304347826, 1.0369565217391, 0.18181818181818
50749, 0.65217391304348, 1.0108695652174, 0.18181818181818
50750, 0.65217391304348, 1.0369565217391, 0.20454545454545
50751, 0.67391304347826, 1.0369565217391, 0.22727272727273
50752, 0.65217391304348, 1.0108695652174, 0.22727272727273
50753, 0.65217391304348, 1.0369565217391, 0.25
50754, 0.67391304347826, 1.0369565217391, 0.27272727272727
50755, 0.65217391304348, 1.0108695652174, 0.27272727272727
50756, 0.65217391304348, 1.0369565217391, 0.29545454545455
50757, 0.67391304347826, 1.0369565217391, 0.31818181818182
50758, 0.65217391304348, 1.0108695652174, 0.31818181818182
50759, 0.65217391304348, 1.0369565217391, 0.34090909090909
50760, 0.67391304347826, 1.0369565217391, 0.36363636363636
50761, 0.65217391304348, 1.0108695652174, 0.36363636363636
50762, 0.65217391304348, 1.0369565217391, 0.38636363636364
50763, 0.67391304347826, 1.0369565217391, 0.40909090909091
50764, 0.65217391304348, 1.0108695652174, 0.40909090909091
50765, 0.65217391304348, 1.0369565217391, 0.43181818181818
50766, 0.67391304347826, 1.0369565217391, 0.45454545454545
50767, 0.65217391304348, 1.0108695652174, 0.45454545454545
50768, 0.65217391304348, 1.0369565217391, 0.47727272727273
50769, 0.60869565217391, 1.0369565217391, 0.022727272727273
50770, 0.6304347826087, 1.0369565217391, 0.045454545454545
50771, 0.60869565217391, 1.0108695652174, 0.045454545454545
50772, 0.60869565217391, 1.0369565217391, 0.068181818181818
50773, 0.6304347826087, 1.0369565217391, 0.090909090909091
50774, 0.60869565217391, 1.0108695652174, 0.090909090909091
50775, 0.60869565217391, 1.0369565217391, 0.11363636363636
50776, 0.6304347826087, 1.0369565217391, 0.13636363636364
50777, 0.60869565217391, 1.0108695652174, 0.13636363636364
50778, 0.60869565217391, 1.0369565217391, 0.15909090909091
50779, 0.6304347826087, 1.0369565217391, 0.18181818181818
50780, 0.60869565217391, 1.0108695652174, 0.18181818181818
50781, 0.60869565217391, 1.0369565217391, 0.20454545454545
50782, 0.6304347826087, 1.0369565217391, 0.22727272727273
50783, 0.60869565217391, 1.0108695652174, 0.22727272727273
50784, 0.60869565217391, 1.0369565217391, 0.25
50785, 0.6304347826087, 1.0369565217391, 0.27272727272727
50786, 0.60869565217391, 1.0108695652174, 0.27272727272727
50787, 0.60869565217391, 1.0369565217391, 0.29545454545455
50788, 0.6304347826087, 1.0369565217391, 0.31818181818182
50789, 0.60869565217391, 1.0108695652174, 0.31818181818182
50790, 0.60869565217391, 1.0369565217391, 0.34090909090909
50791, 0.6304347826087, 1.0369565217391, 0.36363636363636
50792, 0.60869565217391, 1.0108695652174, 0.36363636363636
50793, 0.60869565217391, 1.0369565217391, 0.38636363636364
50794, 0.6304347826087, 1.0369565217391, 0.40909090909091
50795, 0.60869565217391, 1.0108695652174, 0.40909090909091
50796, 0.60869565217391, 1.0369565217391, 0.43181818181818
50797, 0.6304347826087, 1.0369565217391, 0.45454545454545
50798, 0.60869565217391, 1.0108695652174, 0.45454545454545
50799, 0.60869565217391, 1.0369565217391, 0.47727272727273
50800, 0.56521739130435, 1.0369565217391, 0.022727272727273
50801, 0.58695652173913, 1.0369565217391, 0.045454545454545
50802, 0.56521739130435, 1.0108695652174, 0.045454545454545
50803, 0.56521739130435, 1.0369565217391, 0.068181818181818
50804, 0.58695652173913, 1.0369565217391, 0.090909090909091
50805, 0.56521739130435, 1.0108695652174, 0.090909090909091
50806, 0.56521739130435, 1.0369565217391, 0.11363636363636
50807, 0.58695652173913, 1.0369565217391, 0.13636363636364
50808, 0.56521739130435, 1.0108695652174, 0.13636363636364
50809, 0.56521739130435, 1.0369565217391, 0.15909090909091
50810, 0.58695652173913, 1.0369565217391, 0.18181818181818
50811, 0.56521739130435, 1.0108695652174, 0.18181818181818
50812, 0.56521739130435, 1.0369565217391, 0.20454545454545
50813, 0.58695652173913, 1.0369565217391, 0.22727272727273
50814, 0.56521739130435, 1.0108695652174, 0.22727272727273
50815, 0.56521739130435, 1.0369565217391, 0.25
50816, 0.58695652173913, 1.0369565217391, 0.27272727272727
50817, 0.56521739130435, 1.0108695652174, 0.27272727272727
50818, 0.56521739130435, 1.0369565217391, 0.29545454545455
50819, 0.58695652173913, 1.0369565217391, 0.31818181818182
50820, 0.56521739130435, 1.0108695652174, 0.31818181818182
50821, 0.56521739130435, 1.0369565217391, 0.34090909090909
50822, 0.58695652173913, 1.0369565217391, 0.36363636363636
50823, 0.56521739130435, 1.0108695652174, 0.36363636363636
50824, 0.56521739130435, 1.0369565217391, 0.38636363636364
50825, 0.58695652173913, 1.0369565217391, 0.40909090909091
50826, 0.56521739130435, 1.0108695652174, 0.40909090909091
50827, 0.56521739130435, 1.0369565217391, 0.43181818181818
50828, 0.58695652173913, 1.0369565217391, 0.45454545454545
50829, 0.56521739130435, 1.0108695652174, 0.45454545454545
50830, 0.56521739130435, 1.0369565217391, 0.47727272727273
50831, 0.52173913043478, 1.0369565217391, 0.022727272727273
50832, 0.54347826086956, 1.0369565217391, 0.045454545454545
50833, 0.52173913043478, 1.0108695652174, 0.045454545454545
50834, 0.52173913043478, 1.0369565217391, 0.068181818181818
50835, 0.54347826086956, 1.0369565217391, 0.090909090909091
50836, 0.52173913043478, 1.0108695652174, 0.090909090909091
50837, 0.52173913043478, 1.0369565217391, 0.11363636363636
50838, 0.54347826086957, 1.0369565217391, 0.13636363636364
50839, 0.52173913043478, 1.0108695652174, 0.13636363636364
50840, 0.52173913043478, 1.0369565217391, 0.15909090909091
50841, 0.54347826086956, 1.0369565217391, 0.18181818181818
50842, 0.52173913043478, 1.0108695652174, 0.18181818181818
50843, 0.52173913043478, 1.0369565217391, 0.20454545454545
50844, 0.54347826086956, 1.0369565217391, 0.22727272727273
50845, 0.52173913043478, 1.0108695652174, 0.22727272727273
50846, 0.52173913043478, 1.0369565217391, 0.25
50847, 0.54347826086956, 1.0369565217391, 0.27272727272727
50848, 0.52173913043478, 1.0108695652174, 0.27272727272727
50849, 0.52173913043478, 1.0369565217391, 0.29545454545455
50850, 0.54347826086956, 1.0369565217391, 0.31818181818182
50851, 0.52173913043478, 1.0108695652174, 0.31818181818182
50852, 0.52173913043478, 1.0369565217391, 0.34090909090909
50853, 0.54347826086956, 1.0369565217391, 0.36363636363636
50854, 0.52173913043478, 1.0108695652174, 0.36363636363636
50855, 0.52173913043478, 1.0369565217391, 0.38636363636364
50856, 0.54347826086956, 1.0369565217391, 0.40909090909091
50857, 0.52173913043478, 1.0108695652174, 0.40909090909091
50858, 0.52173913043478, 1.0369565217391, 0.43181818181818
50859, 0.54347826086956, 1.0369565217391, 0.45454545454545
50860, 0.52173913043478, 1.0108695652174, 0.45454545454545
50861, 0.52173913043478, 1.0369565217391, 0.47727272727273
50862, 0.47826086956522, 1.0369565217391, 0.022727272727273
50863, 0.5, 1.0369565217391, 0.045454545454545
50864, 0.47826086956522, 1.0108695652174, 0.045454545454545
50865, 0.47826086956522, 1.0369565217391, 0.068181818181818
50866, 0.5, 1.0369565217391, 0.090909090909091
50867, 0.47826086956522, 1.0108695652174, 0.090909090909091
50868, 0.47826086956522, 1.0369565217391, 0.11363636363636
50869, 0.5, 1.0369565217391, 0.13636363636364
50870, 0.47826086956522, 1.0108695652174, 0.13636363636364
50871, 0.47826086956522, 1.0369565217391, 0.15909090909091
50872, 0.5, 1.0369565217391, 0.18181818181818
50873, 0.47826086956522, 1.0108695652174, 0.18181818181818
50874, 0.47826086956522, 1.0369565217391, 0.20454545454545
50875, 0.5, 1.0369565217391, 0.22727272727273
50876, 0.47826086956522, 1.0108695652174, 0.22727272727273
50877, 0.47826086956522, 1.0369565217391, 0.25
50878, 0.5, 1.0369565217391, 0.27272727272727
50879, 0.47826086956522, 1.0108695652174, 0.27272727272727
50880, 0.47826086956522, 1.0369565217391, 0.29545454545455
50881, 0.5, 1.0369565217391, 0.31818181818182
50882, 0.47826086956522, 1.0108695652174, 0.31818181818182
50883, 0.47826086956522, 1.0369565217391, 0.34090909090909
50884, 0.5, 1.0369565217391, 0.36363636363636
50885, 0.47826086956522, 1.0108695652174, 0.36363636363636
50886, 0.47826086956522, 1.0369565217391, 0.38636363636364
50887, 0.5, 1.0369565217391, 0.40909090909091
50888, 0.47826086956522, 1.0108695652174, 0.40909090909091
50889, 0.47826086956522, 1.0369565217391, 0.43181818181818
50890, 0.5, 1.0369565217391, 0.45454545454545
50891, 0.47826086956522, 1.0108695652174, 0.45454545454545
50892, 0.47826086956522, 1.0369565217391, 0.47727272727273
50893, 0.43478260869565, 1.0369565217391, 0.022727272727273
50894, 0.45652173913043, 1.0369565217391, 0.045454545454545
50895, 0.43478260869565, 1.0108695652174, 0.045454545454545
50896, 0.43478260869565, 1.0369565217391, 0.068181818181818
50897, 0.45652173913043, 1.0369565217391, 0.090909090909091
50898, 0.43478260869565, 1.0108695652174, 0.090909090909091
50899, 0.43478260869565, 1.0369565217391, 0.11363636363636
50900, 0.45652173913043, 1.0369565217391, 0.13636363636364
50901, 0.43478260869565, 1.0108695652174, 0.13636363636364
50902, 0.43478260869565, 1.0369565217391, 0.15909090909091
50903, 0.45652173913043, 1.0369565217391, 0.18181818181818
50904, 0.43478260869565, 1.0108695652174, 0.18181818181818
50905, 0.43478260869565, 1.0369565217391, 0.20454545454545
50906, 0.45652173913043, 1.0369565217391, 0.22727272727273
50907, 0.43478260869565, 1.0108695652174, 0.22727272727273
50908, 0.43478260869565, 1.0369565217391, 0.25
50909, 0.45652173913043, 1.0369565217391, 0.27272727272727
50910, 0.43478260869565, 1.0108695652174, 0.27272727272727
50911, 0.43478260869565, 1.0369565217391, 0.29545454545455
50912, 0.45652173913043, 1.0369565217391, 0.31818181818182
50913, 0.43478260869565, 1.0108695652174, 0.31818181818182
50914, 0.43478260869565, 1.0369565217391, 0.34090909090909
50915, 0.45652173913043, 1.0369565217391, 0.36363636363636
50916, 0.43478260869565, 1.0108695652174, 0.36363636363636
50917, 0.43478260869565, 1.0369565217391, 0.38636363636364
50918, 0.45652173913043, 1.0369565217391, 0.40909090909091
50919, 0.43478260869565, 1.0108695652174, 0.40909090909091
50920, 0.43478260869565, 1.0369565217391, 0.43181818181818
50921, 0.45652173913043, 1.0369565217391, 0.45454545454545
50922, 0.43478260869565, 1.0108695652174, 0.45454545454545
50923, 0.43478260869565, 1.0369565217391, 0.47727272727273
50924, 0.39130434782609, 1.0369565217391, 0.022727272727273
50925, 0.41304347826087, 1.0369565217391, 0.045454545454545
50926, 0.39130434782609, 1.0108695652174, 0.045454545454545
50927, 0.39130434782609, 1.0369565217391, 0.068181818181818
50928, 0.41304347826087, 1.0369565217391, 0.090909090909091
50929, 0.39130434782609, 1.0108695652174, 0.090909090909091
50930, 0.39130434782609, 1.0369565217391, 0.11363636363636
50931, 0.41304347826087, 1.0369565217391, 0.13636363636364
50932, 0.39130434782609, 1.0108695652174, 0.13636363636364
50933, 0.39130434782609, 1.0369565217391, 0.15909090909091
50934, 0.41304347826087, 1.0369565217391, 0.18181818181818
50935, 0.39130434782609, 1.0108695652174, 0.18181818181818
50936, 0.39130434782609, 1.0369565217391, 0.20454545454545
50937, 0.41304347826087, 1.0369565217391, 0.22727272727273
50938, 0.39130434782609, 1.0108695652174, 0.22727272727273
50939, 0.39130434782609, 1.0369565217391, 0.25
50940, 0.41304347826087, 1.0369565217391, 0.27272727272727
50941, 0.39130434782609, 1.0108695652174, 0.27272727272727
50942, 0.39130434782609, 1.0369565217391, 0.29545454545455
50943, 0.41304347826087, 1.0369565217391, 0.31818181818182
50944, 0.39130434782609, 1.0108695652174, 0.31818181818182
50945, 0.39130434782609, 1.0369565217391, 0.34090909090909
50946, 0.41304347826087, 1.0369565217391, 0.36363636363636
50947, 0.39130434782609, 1.0108695652174, 0.36363636363636
50948, 0.39130434782609, 1.0369565217391, 0.38636363636364
50949, 0.41304347826087, 1.0369565217391, 0.40909090909091
50950, 0.39130434782609, 1.0108695652174, 0.40909090909091
50951, 0.39130434782609, 1.0369565217391, 0.43181818181818
50952, 0.41304347826087, 1.0369565217391, 0.45454545454545
50953, 0.39130434782609, 1.0108695652174, 0.45454545454545
50954, 0.39130434782609, 1.0369565217391, 0.47727272727273
50955, 0.34782608695652, 1.0369565217391, 0.022727272727273
50956, 0.3695652173913, 1.0369565217391, 0.045454545454545
50957, 0.34782608695652, 1.0108695652174, 0.045454545454545
50958, 0.34782608695652, 1.0369565217391, 0.068181818181818
50959, 0.3695652173913, 1.0369565217391, 0.090909090909091
50960, 0.34782608695652, 1.0108695652174, 0.090909090909091
50961, 0.34782608695652, 1.0369565217391, 0.11363636363636
50962, 0.3695652173913, 1.0369565217391, 0.13636363636364
50963, 0.34782608695652, 1.0108695652174, 0.13636363636364
50964, 0.34782608695652, 1.0369565217391, 0.15909090909091
50965, 0.3695652173913, 1.0369565217391, 0.18181818181818
50966, 0.34782608695652, 1.0108695652174, 0.18181818181818
50967, 0.34782608695652, 1.0369565217391, 0.20454545454545
50968, 0.3695652173913, 1.0369565217391, 0.22727272727273
50969, 0.34782608695652, 1.0108695652174, 0.22727272727273
50970, 0.34782608695652, 1.0369565217391, 0.25
50971, 0.3695652173913, 1.0369565217391, 0.27272727272727
50972, 0.34782608695652, 1.0108695652174, 0.27272727272727
50973, 0.34782608695652, 1.0369565217391, 0.29545454545455
50974, 0.3695652173913, 1.0369565217391, 0.31818181818182
50975, 0.34782608695652, 1.0108695652174, 0.31818181818182
50976, 0.34782608695652, 1.0369565217391, 0.34090909090909
50977, 0.3695652173913, 1.0369565217391, 0.36363636363636
50978, 0.34782608695652, 1.0108695652174, 0.36363636363636
50979, 0.34782608695652, 1.0369565217391, 0.38636363636364
50980, 0.3695652173913, 1.0369565217391, 0.40909090909091
50981, 0.34782608695652, 1.0108695652174, 0.40909090909091
50982, 0.34782608695652, 1.0369565217391, 0.43181818181818
50983, 0.3695652173913, 1.0369565217391, 0.45454545454545
50984, 0.34782608695652, 1.0108695652174, 0.45454545454545
50985, 0.34782608695652, 1.0369565217391, 0.47727272727273
50986, 0.30434782608696, 1.0369565217391, 0.022727272727273
50987, 0.32608695652174, 1.0369565217391, 0.045454545454545
50988, 0.30434782608696, 1.0108695652174, 0.045454545454545
50989, 0.30434782608696, 1.0369565217391, 0.068181818181818
50990, 0.32608695652174, 1.0369565217391, 0.090909090909091
50991, 0.30434782608696, 1.0108695652174, 0.090909090909091
50992, 0.30434782608696, 1.0369565217391, 0.11363636363636
50993, 0.32608695652174, 1.0369565217391, 0.13636363636364
50994, 0.30434782608696, 1.0108695652174, 0.13636363636364
50995, 0.30434782608696, 1.0369565217391, 0.15909090909091
50996, 0.32608695652174, 1.0369565217391, 0.18181818181818
50997, 0.30434782608696, 1.0108695652174, 0.18181818181818
50998, 0.30434782608696, 1.0369565217391, 0.20454545454545
50999, 0.32608695652174, 1.0369565217391, 0.22727272727273
51000, 0.30434782608696, 1.0108695652174, 0.22727272727273
51001, 0.30434782608696, 1.0369565217391, 0.25
51002, 0.32608695652174, 1.0369565217391, 0.27272727272727
51003, 0.30434782608696, 1.0108695652174, 0.27272727272727
51004, 0.30434782608696, 1.0369565217391, 0.29545454545455
51005, 0.32608695652174, 1.0369565217391, 0.31818181818182
51006, 0.30434782608696, 1.0108695652174, 0.31818181818182
51007, 0.30434782608696, 1.0369565217391, 0.34090909090909
51008, 0.32608695652174, 1.0369565217391, 0.36363636363636
51009, 0.30434782608696, 1.0108695652174, 0.36363636363636
51010, 0.30434782608696, 1.0369565217391, 0.38636363636364
51011, 0.32608695652174, 1.0369565217391, 0.40909090909091
51012, 0.30434782608696, 1.0108695652174, 0.40909090909091
51013, 0.30434782608696, 1.0369565217391, 0.43181818181818
51014, 0.32608695652174, 1.0369565217391, 0.45454545454545
51015, 0.30434782608696, 1.0108695652174, 0.45454545454545
51016, 0.30434782608696, 1.0369565217391, 0.47727272727273
51017, 0.26086956521739, 1.0369565217391, 0.022727272727273
51018, 0.28260869565217, 1.0369565217391, 0.045454545454545
51019, 0.26086956521739, 1.0108695652174, 0.045454545454545
51020, 0.26086956521739, 1.0369565217391, 0.068181818181818
51021, 0.28260869565217, 1.0369565217391, 0.090909090909091
51022, 0.26086956521739, 1.0108695652174, 0.090909090909091
51023, 0.26086956521739, 1.0369565217391, 0.11363636363636
51024, 0.28260869565217, 1.0369565217391, 0.13636363636364
51025, 0.26086956521739, 1.0108695652174, 0.13636363636364
51026, 0.26086956521739, 1.0369565217391, 0.15909090909091
51027, 0.28260869565217, 1.0369565217391, 0.18181818181818
51028, 0.26086956521739, 1.0108695652174, 0.18181818181818
51029, 0.26086956521739, 1.0369565217391, 0.20454545454545
51030, 0.28260869565217, 1.0369565217391, 0.22727272727273
51031, 0.26086956521739, 1.0108695652174, 0.22727272727273
51032, 0.26086956521739, 1.0369565217391, 0.25
51033, 0.28260869565217, 1.0369565217391, 0.27272727272727
51034, 0.26086956521739, 1.0108695652174, 0.27272727272727
51035, 0.26086956521739, 1.0369565217391, 0.29545454545455
51036, 0.28260869565217, 1.0369565217391, 0.31818181818182
51037, 0.26086956521739, 1.0108695652174, 0.31818181818182
51038, 0.26086956521739, 1.0369565217391, 0.34090909090909
51039, 0.28260869565217, 1.0369565217391, 0.36363636363636
51040, 0.26086956521739, 1.0108695652174, 0.36363636363636
51041, 0.26086956521739, 1.0369565217391, 0.38636363636364
51042, 0.28260869565217, 1.0369565217391, 0.40909090909091
51043, 0.26086956521739, 1.0108695652174, 0.40909090909091
51044, 0.26086956521739, 1.0369565217391, 0.43181818181818
51045, 0.28260869565217, 1.0369565217391, 0.45454545454545
51046, 0.26086956521739, 1.0108695652174, 0.45454545454545
51047, 0.26086956521739, 1.0369565217391, 0.47727272727273
51048, 0.21739130434783, 1.0369565217391, 0.022727272727273
51049, 0.23913043478261, 1.0369565217391, 0.045454545454545
51050, 0.21739130434783, 1.0108695652174, 0.045454545454545
51051, 0.21739130434783, 1.0369565217391, 0.068181818181818
51052, 0.23913043478261, 1.0369565217391, 0.090909090909091
51053, 0.21739130434783, 1.0108695652174, 0.090909090909091
51054, 0.21739130434783, 1.0369565217391, 0.11363636363636
51055, 0.23913043478261, 1.0369565217391, 0.13636363636364
51056, 0.21739130434783, 1.0108695652174, 0.13636363636364
51057, 0.21739130434783, 1.0369565217391, 0.15909090909091
51058, 0.23913043478261, 1.0369565217391, 0.18181818181818
51059, 0.21739130434783, 1.0108695652174, 0.18181818181818
51060, 0.21739130434783, 1.0369565217391, 0.20454545454545
51061, 0.23913043478261, 1.0369565217391, 0.22727272727273
51062, 0.21739130434783, 1.0108695652174, 0.22727272727273
51063, 0.21739130434783, 1.0369565217391, 0.25
51064, 0.23913043478261, 1.0369565217391, 0.27272727272727
51065, 0.21739130434783, 1.0108695652174, 0.27272727272727
51066, 0.21739130434783, 1.0369565217391, 0.29545454545455
51067, 0.23913043478261, 1.0369565217391, 0.31818181818182
51068, 0.21739130434783, 1.0108695652174, 0.31818181818182
51069, 0.21739130434783, 1.0369565217391, 0.34090909090909
51070, 0.23913043478261, 1.0369565217391, 0.36363636363636
51071, 0.21739130434783, 1.0108695652174, 0.36363636363636
51072, 0.21739130434783, 1.0369565217391, 0.38636363636364
51073, 0.23913043478261, 1.0369565217391, 0.40909090909091
51074, 0.21739130434783, 1.0108695652174, 0.40909090909091
51075, 0.21739130434783, 1.0369565217391, 0.43181818181818
51076, 0.23913043478261, 1.0369565217391, 0.45454545454545
51077, 0.21739130434783, 1.0108695652174, 0.45454545454545
51078, 0.21739130434783, 1.0369565217391, 0.47727272727273
51079, 0.17391304347826, 1.0369565217391, 0.022727272727273
51080, 0.19565217391304, 1.0369565217391, 0.045454545454545
51081, 0.17391304347826, 1.0108695652174, 0.045454545454545
51082, 0.17391304347826, 1.0369565217391, 0.068181818181818
51083, 0.19565217391304, 1.0369565217391, 0.090909090909091
51084, 0.17391304347826, 1.0108695652174, 0.090909090909091
51085, 0.17391304347826, 1.0369565217391, 0.11363636363636
51086, 0.19565217391304, 1.0369565217391, 0.13636363636364
51087, 0.17391304347826, 1.0108695652174, 0.13636363636364
51088, 0.17391304347826, 1.0369565217391, 0.15909090909091
51089, 0.19565217391304, 1.0369565217391, 0.18181818181818
51090, 0.17391304347826, 1.0108695652174, 0.18181818181818
51091, 0.17391304347826, 1.0369565217391, 0.20454545454545
51092, 0.19565217391304, 1.0369565217391, 0.22727272727273
51093, 0.17391304347826, 1.0108695652174, 0.22727272727273
51094, 0.17391304347826, 1.0369565217391, 0.25
51095, 0.19565217391304, 1.0369565217391, 0.27272727272727
51096, 0.17391304347826, 1.0108695652174, 0.27272727272727
51097, 0.17391304347826, 1.0369565217391, 0.29545454545455
51098, 0.19565217391304, 1.0369565217391, 0.31818181818182
51099, 0.17391304347826, 1.0108695652174, 0.31818181818182
51100, 0.17391304347826, 1.0369565217391, 0.34090909090909
51101, 0.19565217391304, 1.0369565217391, 0.36363636363636
51102, 0.17391304347826, 1.0108695652174, 0.36363636363636
51103, 0.17391304347826, 1.0369565217391, 0.38636363636364
51104, 0.19565217391304, 1.0369565217391, 0.40909090909091
51105, 0.17391304347826, 1.0108695652174, 0.40909090909091
51106, 0.17391304347826, 1.0369565217391, 0.43181818181818
51107, 0.19565217391304, 1.0369565217391, 0.45454545454545
51108, 0.17391304347826, 1.0108695652174, 0.45454545454545
51109, 0.17391304347826, 1.0369565217391, 0.47727272727273
51110, 0.1304347826087, 1.0369565217391, 0.022727272727273
51111, 0.15217391304348, 1.0369565217391, 0.045454545454545
51112, 0.1304347826087, 1.0108695652174, 0.045454545454545
51113, 0.1304347826087, 1.0369565217391, 0.068181818181818
51114, 0.15217391304348, 1.0369565217391, 0.090909090909091
51115, 0.1304347826087, 1.0108695652174, 0.090909090909091
51116, 0.1304347826087, 1.0369565217391, 0.11363636363636
51117, 0.15217391304348, 1.0369565217391, 0.13636363636364
51118, 0.1304347826087, 1.0108695652174, 0.13636363636364
51119, 0.1304347826087, 1.0369565217391, 0.15909090909091
51120, 0.15217391304348, 1.0369565217391, 0.18181818181818
51121, 0.1304347826087, 1.0108695652174, 0.18181818181818
51122, 0.1304347826087, 1.0369565217391, 0.20454545454545
51123, 0.15217391304348, 1.0369565217391, 0.22727272727273
51124, 0.1304347826087, 1.0108695652174, 0.22727272727273
51125, 0.1304347826087, 1.0369565217391, 0.25
51126, 0.15217391304348, 1.0369565217391, 0.27272727272727
51127, 0.1304347826087, 1.0108695652174, 0.27272727272727
51128, 0.1304347826087, 1.0369565217391, 0.29545454545455
51129, 0.15217391304348, 1.0369565217391, 0.31818181818182
51130, 0.1304347826087, 1.0108695652174, 0.31818181818182
51131, 0.1304347826087, 1.0369565217391, 0.34090909090909
51132, 0.15217391304348, 1.0369565217391, 0.36363636363636
51133, 0.1304347826087, 1.0108695652174, 0.36363636363636
51134, 0.1304347826087, 1.0369565217391, 0.38636363636364
51135, 0.15217391304348, 1.0369565217391, 0.40909090909091
51136, 0.1304347826087, 1.0108695652174, 0.40909090909091
51137, 0.1304347826087, 1.0369565217391, 0.43181818181818
51138, 0.15217391304348, 1.0369565217391, 0.45454545454545
51139, 0.1304347826087, 1.0108695652174, 0.45454545454545
51140, 0.1304347826087, 1.0369565217391, 0.47727272727273
51141, 0.08695652173913, 1.0369565217391, 0.022727272727273
51142, 0.10869565217391, 1.0369565217391, 0.045454545454545
51143, 0.08695652173913, 1.0108695652174, 0.045454545454545
51144, 0.08695652173913, 1.0369565217391, 0.068181818181818
51145, 0.10869565217391, 1.0369565217391, 0.090909090909091
51146, 0.08695652173913, 1.0108695652174, 0.090909090909091
51147, 0.08695652173913, 1.0369565217391, 0.11363636363636
51148, 0.10869565217391, 1.0369565217391, 0.13636363636364
51149, 0.08695652173913, 1.0108695652174, 0.13636363636364
51150, 0.08695652173913, 1.0369565217391, 0.15909090909091
51151, 0.10869565217391, 1.0369565217391, 0.18181818181818
51152, 0.08695652173913, 1.0108695652174, 0.18181818181818
51153, 0.08695652173913, 1.0369565217391, 0.20454545454545
51154, 0.10869565217391, 1.0369565217391, 0.22727272727273
51155, 0.08695652173913, 1.0108695652174, 0.22727272727273
51156, 0.08695652173913, 1.0369565217391, 0.25
51157, 0.10869565217391, 1.0369565217391, 0.27272727272727
51158, 0.08695652173913, 1.0108695652174, 0.27272727272727
51159, 0.08695652173913, 1.0369565217391, 0.29545454545455
51160, 0.10869565217391, 1.0369565217391, 0.31818181818182
51161, 0.08695652173913, 1.0108695652174, 0.31818181818182
51162, 0.08695652173913, 1.0369565217391, 0.34090909090909
51163, 0.10869565217391, 1.0369565217391, 0.36363636363636
51164, 0.08695652173913, 1.0108695652174, 0.36363636363636
51165, 0.08695652173913, 1.0369565217391, 0.38636363636364
51166, 0.10869565217391, 1.0369565217391, 0.40909090909091
51167, 0.08695652173913, 1.0108695652174, 0.40909090909091
51168, 0.08695652173913, 1.0369565217391, 0.43181818181818
51169, 0.10869565217391, 1.0369565217391, 0.45454545454545
51170, 0.08695652173913, 1.0108695652174, 0.45454545454545
51171, 0.08695652173913, 1.0369565217391, 0.47727272727273
51172, 0.043478260869565, 1.0369565217391, 0.022727272727273
51173, 0.065217391304348, 1.0369565217391, 0.045454545454545
51174, 0.043478260869565, 1.0108695652174, 0.045454545454545
51175, 0.043478260869565, 1.0369565217391, 0.068181818181818
51176, 0.065217391304348, 1.0369565217391, 0.090909090909091
51177, 0.043478260869565, 1.0108695652174, 0.090909090909091
51178, 0.043478260869565, 1.0369565217391, 0.11363636363636
51179, 0.065217391304348, 1.0369565217391, 0.13636363636364
51180, 0.043478260869565, 1.0108695652174, 0.13636363636364
51181, 0.043478260869565, 1.0369565217391, 0.15909090909091
51182, 0.065217391304348, 1.0369565217391, 0.18181818181818
51183, 0.043478260869565, 1.0108695652174, 0.18181818181818
51184, 0.043478260869565, 1.0369565217391, 0.20454545454545
51185, 0.065217391304348, 1.0369565217391, 0.22727272727273
51186, 0.043478260869565, 1.0108695652174, 0.22727272727273
51187, 0.043478260869565, 1.0369565217391, 0.25
51188, 0.065217391304348, 1.0369565217391, 0.27272727272727
51189, 0.043478260869565, 1.0108695652174, 0.27272727272727
51190, 0.043478260869565, 1.0369565217391, 0.29545454545455
51191, 0.065217391304348, 1.0369565217391, 0.31818181818182
51192, 0.043478260869565, 1.0108695652174, 0.31818181818182
51193, 0.043478260869565, 1.0369565217391, 0.34090909090909
51194, 0.065217391304348, 1.0369565217391, 0.36363636363636
51195, 0.043478260869565, 1.0108695652174, 0.36363636363636
51196, 0.043478260869565, 1.0369565217391, 0.38636363636364
51197, 0.065217391304348, 1.0369565217391, 0.40909090909091
51198, 0.043478260869565, 1.0108695652174, 0.40909090909091
51199, 0.043478260869565, 1.0369565217391, 0.43181818181818
51200, 0.065217391304348, 1.0369565217391, 0.45454545454545
51201, 0.043478260869565, 1.0108695652174, 0.45454545454545
51202, 0.043478260869565, 1.0369565217391, 0.47727272727273
51203, 0.021739130434783, 1.0369565217391, 0.045454545454545
51204, 0.021739130434783, 1.0369565217391, 0.090909090909091
51205, 0.021739130434783, 1.0369565217391, 0.13636363636364
51206, 0.021739130434783, 1.0369565217391, 0.18181818181818
51207, 0.021739130434783, 1.0369565217391, 0.22727272727273
51208, 0.021739130434783, 1.0369565217391, 0.27272727272727
51209, 0.021739130434783, 1.0369565217391, 0.31818181818182
51210, 0.021739130434783, 1.0369565217391, 0.36363636363636
51211, 0.021739130434783, 1.0369565217391, 0.40909090909091
51212, 0.021739130434783, 1.0369565217391, 0.45454545454545
51213, 0.95652173913043, 1.0891304347826, 0.022727272727273
51214, 0.97826086956522, 1.0891304347826, 0.045454545454545
51215, 0.95652173913043, 1.0630434782609, 0.045454545454545
51216, 0.95652173913043, 1.0891304347826, 0.068181818181818
51217, 0.97826086956522, 1.0891304347826, 0.090909090909091
51218, 0.95652173913043, 1.0630434782609, 0.090909090909091
51219, 0.95652173913043, 1.0891304347826, 0.11363636363636
51220, 0.97826086956522, 1.0891304347826, 0.13636363636364
51221, 0.95652173913043, 1.0630434782609, 0.13636363636364
51222, 0.95652173913043, 1.0891304347826, 0.15909090909091
51223, 0.97826086956522, 1.0891304347826, 0.18181818181818
51224, 0.95652173913044, 1.0630434782609, 0.18181818181818
51225, 0.95652173913044, 1.0891304347826, 0.20454545454545
51226, 0.97826086956522, 1.0891304347826, 0.22727272727273
51227, 0.95652173913044, 1.0630434782609, 0.22727272727273
51228, 0.95652173913044, 1.0891304347826, 0.25
51229, 0.97826086956522, 1.0891304347826, 0.27272727272727
51230, 0.95652173913044, 1.0630434782609, 0.27272727272727
51231, 0.95652173913044, 1.0891304347826, 0.29545454545455
51232, 0.97826086956522, 1.0891304347826, 0.31818181818182
51233, 0.95652173913044, 1.0630434782609, 0.31818181818182
51234, 0.95652173913043, 1.0891304347826, 0.34090909090909
51235, 0.97826086956522, 1.0891304347826, 0.36363636363636
51236, 0.95652173913043, 1.0630434782609, 0.36363636363636
51237, 0.95652173913043, 1.0891304347826, 0.38636363636364
51238, 0.97826086956522, 1.0891304347826, 0.40909090909091
51239, 0.95652173913043, 1.0630434782609, 0.40909090909091
51240, 0.95652173913043, 1.0891304347826, 0.43181818181818
51241, 0.97826086956522, 1.0891304347826, 0.45454545454545
51242, 0.95652173913044, 1.0630434782609, 0.45454545454545
51243, 0.95652173913043, 1.0891304347826, 0.47727272727273
51244, 0.91304347826087, 1.0891304347826, 0.022727272727273
51245, 0.93478260869565, 1.0891304347826, 0.045454545454545
51246, 0.91304347826087, 1.0630434782609, 0.045454545454545
51247, 0.91304347826087, 1.0891304347826, 0.068181818181818
51248, 0.93478260869565, 1.0891304347826, 0.090909090909091
51249, 0.91304347826087, 1.0630434782609, 0.090909090909091
51250, 0.91304347826087, 1.0891304347826, 0.11363636363636
51251, 0.93478260869565, 1.0891304347826, 0.13636363636364
51252, 0.91304347826087, 1.0630434782609, 0.13636363636364
51253, 0.91304347826087, 1.0891304347826, 0.15909090909091
51254, 0.93478260869565, 1.0891304347826, 0.18181818181818
51255, 0.91304347826087, 1.0630434782609, 0.18181818181818
51256, 0.91304347826087, 1.0891304347826, 0.20454545454545
51257, 0.93478260869565, 1.0891304347826, 0.22727272727273
51258, 0.91304347826087, 1.0630434782609, 0.22727272727273
51259, 0.91304347826087, 1.0891304347826, 0.25
51260, 0.93478260869565, 1.0891304347826, 0.27272727272727
51261, 0.91304347826087, 1.0630434782609, 0.27272727272727
51262, 0.91304347826087, 1.0891304347826, 0.29545454545455
51263, 0.93478260869565, 1.0891304347826, 0.31818181818182
51264, 0.91304347826087, 1.0630434782609, 0.31818181818182
51265, 0.91304347826087, 1.0891304347826, 0.34090909090909
51266, 0.93478260869565, 1.0891304347826, 0.36363636363636
51267, 0.91304347826087, 1.0630434782609, 0.36363636363636
51268, 0.91304347826087, 1.0891304347826, 0.38636363636364
51269, 0.93478260869565, 1.0891304347826, 0.40909090909091
51270, 0.91304347826087, 1.0630434782609, 0.40909090909091
51271, 0.91304347826087, 1.0891304347826, 0.43181818181818
51272, 0.93478260869565, 1.0891304347826, 0.45454545454545
51273, 0.91304347826087, 1.0630434782609, 0.45454545454545
51274, 0.91304347826087, 1.0891304347826, 0.47727272727273
51275, 0.8695652173913, 1.0891304347826, 0.022727272727273
51276, 0.89130434782609, 1.0891304347826, 0.045454545454545
51277, 0.8695652173913, 1.0630434782609, 0.045454545454545
51278, 0.8695652173913, 1.0891304347826, 0.068181818181818
51279, 0.89130434782609, 1.0891304347826, 0.090909090909091
51280, 0.8695652173913, 1.0630434782609, 0.090909090909091
51281, 0.8695652173913, 1.0891304347826, 0.11363636363636
51282, 0.89130434782609, 1.0891304347826, 0.13636363636364
51283, 0.8695652173913, 1.0630434782609, 0.13636363636364
51284, 0.8695652173913, 1.0891304347826, 0.15909090909091
51285, 0.89130434782609, 1.0891304347826, 0.18181818181818
51286, 0.8695652173913, 1.0630434782609, 0.18181818181818
51287, 0.8695652173913, 1.0891304347826, 0.20454545454545
51288, 0.89130434782609, 1.0891304347826, 0.22727272727273
51289, 0.8695652173913, 1.0630434782609, 0.22727272727273
51290, 0.8695652173913, 1.0891304347826, 0.25
51291, 0.89130434782609, 1.0891304347826, 0.27272727272727
51292, 0.8695652173913, 1.0630434782609, 0.27272727272727
51293, 0.8695652173913, 1.0891304347826, 0.29545454545455
51294, 0.89130434782609, 1.0891304347826, 0.31818181818182
51295, 0.8695652173913, 1.0630434782609, 0.31818181818182
51296, 0.8695652173913, 1.0891304347826, 0.34090909090909
51297, 0.89130434782609, 1.0891304347826, 0.36363636363636
51298, 0.8695652173913, 1.0630434782609, 0.36363636363636
51299, 0.8695652173913, 1.0891304347826, 0.38636363636364
51300, 0.89130434782609, 1.0891304347826, 0.40909090909091
51301, 0.8695652173913, 1.0630434782609, 0.40909090909091
51302, 0.8695652173913, 1.0891304347826, 0.43181818181818
51303, 0.89130434782609, 1.0891304347826, 0.45454545454545
51304, 0.8695652173913, 1.0630434782609, 0.45454545454545
51305, 0.8695652173913, 1.0891304347826, 0.47727272727273
51306, 0.82608695652174, 1.0891304347826, 0.022727272727273
51307, 0.84782608695652, 1.0891304347826, 0.045454545454545
51308, 0.82608695652174, 1.0630434782609, 0.045454545454545
51309, 0.82608695652174, 1.0891304347826, 0.068181818181818
51310, 0.84782608695652, 1.0891304347826, 0.090909090909091
51311, 0.82608695652174, 1.0630434782609, 0.090909090909091
51312, 0.82608695652174, 1.0891304347826, 0.11363636363636
51313, 0.84782608695652, 1.0891304347826, 0.13636363636364
51314, 0.82608695652174, 1.0630434782609, 0.13636363636364
51315, 0.82608695652174, 1.0891304347826, 0.15909090909091
51316, 0.84782608695652, 1.0891304347826, 0.18181818181818
51317, 0.82608695652174, 1.0630434782609, 0.18181818181818
51318, 0.82608695652174, 1.0891304347826, 0.20454545454545
51319, 0.84782608695652, 1.0891304347826, 0.22727272727273
51320, 0.82608695652174, 1.0630434782609, 0.22727272727273
51321, 0.82608695652174, 1.0891304347826, 0.25
51322, 0.84782608695652, 1.0891304347826, 0.27272727272727
51323, 0.82608695652174, 1.0630434782609, 0.27272727272727
51324, 0.82608695652174, 1.0891304347826, 0.29545454545455
51325, 0.84782608695652, 1.0891304347826, 0.31818181818182
51326, 0.82608695652174, 1.0630434782609, 0.31818181818182
51327, 0.82608695652174, 1.0891304347826, 0.34090909090909
51328, 0.84782608695652, 1.0891304347826, 0.36363636363636
51329, 0.82608695652174, 1.0630434782609, 0.36363636363636
51330, 0.82608695652174, 1.0891304347826, 0.38636363636364
51331, 0.84782608695652, 1.0891304347826, 0.40909090909091
51332, 0.82608695652174, 1.0630434782609, 0.40909090909091
51333, 0.82608695652174, 1.0891304347826, 0.43181818181818
51334, 0.84782608695652, 1.0891304347826, 0.45454545454545
51335, 0.82608695652174, 1.0630434782609, 0.45454545454545
51336, 0.82608695652174, 1.0891304347826, 0.47727272727273
51337, 0.78260869565217, 1.0891304347826, 0.022727272727273
51338, 0.80434782608696, 1.0891304347826, 0.045454545454545
51339, 0.78260869565217, 1.0630434782609, 0.045454545454545
51340, 0.78260869565217, 1.0891304347826, 0.068181818181818
51341, 0.80434782608696, 1.0891304347826, 0.090909090909091
51342, 0.78260869565217, 1.0630434782609, 0.090909090909091
51343, 0.78260869565217, 1.0891304347826, 0.11363636363636
51344, 0.80434782608696, 1.0891304347826, 0.13636363636364
51345, 0.78260869565217, 1.0630434782609, 0.13636363636364
51346, 0.78260869565217, 1.0891304347826, 0.15909090909091
51347, 0.80434782608696, 1.0891304347826, 0.18181818181818
51348, 0.78260869565217, 1.0630434782609, 0.18181818181818
51349, 0.78260869565217, 1.0891304347826, 0.20454545454545
51350, 0.80434782608696, 1.0891304347826, 0.22727272727273
51351, 0.78260869565217, 1.0630434782609, 0.22727272727273
51352, 0.78260869565217, 1.0891304347826, 0.25
51353, 0.80434782608696, 1.0891304347826, 0.27272727272727
51354, 0.78260869565217, 1.0630434782609, 0.27272727272727
51355, 0.78260869565217, 1.0891304347826, 0.29545454545455
51356, 0.80434782608696, 1.0891304347826, 0.31818181818182
51357, 0.78260869565217, 1.0630434782609, 0.31818181818182
51358, 0.78260869565217, 1.0891304347826, 0.34090909090909
51359, 0.80434782608696, 1.0891304347826, 0.36363636363636
51360, 0.78260869565217, 1.0630434782609, 0.36363636363636
51361, 0.78260869565217, 1.0891304347826, 0.38636363636364
51362, 0.80434782608696, 1.0891304347826, 0.40909090909091
51363, 0.78260869565217, 1.0630434782609, 0.40909090909091
51364, 0.78260869565217, 1.0891304347826, 0.43181818181818
51365, 0.80434782608696, 1.0891304347826, 0.45454545454545
51366, 0.78260869565217, 1.0630434782609, 0.45454545454545
51367, 0.78260869565217, 1.0891304347826, 0.47727272727273
51368, 0.73913043478261, 1.0891304347826, 0.022727272727273
51369, 0.76086956521739, 1.0891304347826, 0.045454545454545
51370, 0.73913043478261, 1.0630434782609, 0.045454545454545
51371, 0.73913043478261, 1.0891304347826, 0.068181818181818
51372, 0.76086956521739, 1.0891304347826, 0.090909090909091
51373, 0.73913043478261, 1.0630434782609, 0.090909090909091
51374, 0.73913043478261, 1.0891304347826, 0.11363636363636
51375, 0.76086956521739, 1.0891304347826, 0.13636363636364
51376, 0.73913043478261, 1.0630434782609, 0.13636363636364
51377, 0.73913043478261, 1.0891304347826, 0.15909090909091
51378, 0.76086956521739, 1.0891304347826, 0.18181818181818
51379, 0.73913043478261, 1.0630434782609, 0.18181818181818
51380, 0.73913043478261, 1.0891304347826, 0.20454545454545
51381, 0.76086956521739, 1.0891304347826, 0.22727272727273
51382, 0.73913043478261, 1.0630434782609, 0.22727272727273
51383, 0.73913043478261, 1.0891304347826, 0.25
51384, 0.76086956521739, 1.0891304347826, 0.27272727272727
51385, 0.73913043478261, 1.0630434782609, 0.27272727272727
51386, 0.73913043478261, 1.0891304347826, 0.29545454545455
51387, 0.76086956521739, 1.0891304347826, 0.31818181818182
51388, 0.73913043478261, 1.0630434782609, 0.31818181818182
51389, 0.73913043478261, 1.0891304347826, 0.34090909090909
51390, 0.76086956521739, 1.0891304347826, 0.36363636363636
51391, 0.73913043478261, 1.0630434782609, 0.36363636363636
51392, 0.73913043478261, 1.0891304347826, 0.38636363636364
51393, 0.76086956521739, 1.0891304347826, 0.40909090909091
51394, 0.73913043478261, 1.0630434782609, 0.40909090909091
51395, 0.73913043478261, 1.0891304347826, 0.43181818181818
51396, 0.76086956521739, 1.0891304347826, 0.45454545454545
51397, 0.73913043478261, 1.0630434782609, 0.45454545454545
51398, 0.73913043478261, 1.0891304347826, 0.47727272727273
51399, 0.69565217391304, 1.0891304347826, 0.022727272727273
51400, 0.71739130434783, 1.0891304347826, 0.045454545454545
51401, 0.69565217391304, 1.0630434782609, 0.045454545454545
51402, 0.69565217391304, 1.0891304347826, 0.068181818181818
51403, 0.71739130434783, 1.0891304347826, 0.090909090909091
51404, 0.69565217391304, 1.0630434782609, 0.090909090909091
51405, 0.69565217391304, 1.0891304347826, 0.11363636363636
51406, 0.71739130434783, 1.0891304347826, 0.13636363636364
51407, 0.69565217391304, 1.0630434782609, 0.13636363636364
51408, 0.69565217391304, 1.0891304347826, 0.15909090909091
51409, 0.71739130434783, 1.0891304347826, 0.18181818181818
51410, 0.69565217391304, 1.0630434782609, 0.18181818181818
51411, 0.69565217391304, 1.0891304347826, 0.20454545454545
51412, 0.71739130434783, 1.0891304347826, 0.22727272727273
51413, 0.69565217391304, 1.0630434782609, 0.22727272727273
51414, 0.69565217391304, 1.0891304347826, 0.25
51415, 0.71739130434783, 1.0891304347826, 0.27272727272727
51416, 0.69565217391304, 1.0630434782609, 0.27272727272727
51417, 0.69565217391304, 1.0891304347826, 0.29545454545455
51418, 0.71739130434783, 1.0891304347826, 0.31818181818182
51419, 0.69565217391304, 1.0630434782609, 0.31818181818182
51420, 0.69565217391304, 1.0891304347826, 0.34090909090909
51421, 0.71739130434783, 1.0891304347826, 0.36363636363636
51422, 0.69565217391304, 1.0630434782609, 0.36363636363636
51423, 0.69565217391304, 1.0891304347826, 0.38636363636364
51424, 0.71739130434783, 1.0891304347826, 0.40909090909091
51425, 0.69565217391304, 1.0630434782609, 0.40909090909091
51426, 0.69565217391304, 1.0891304347826, 0.43181818181818
51427, 0.71739130434783, 1.0891304347826, 0.45454545454545
51428, 0.69565217391304, 1.0630434782609, 0.45454545454545
51429, 0.69565217391304, 1.0891304347826, 0.47727272727273
51430, 0.65217391304348, 1.0891304347826, 0.022727272727273
51431, 0.67391304347826, 1.0891304347826, 0.045454545454545
51432, 0.65217391304348, 1.0630434782609, 0.045454545454545
51433, 0.65217391304348, 1.0891304347826, 0.068181818181818
51434, 0.67391304347826, 1.0891304347826, 0.090909090909091
51435, 0.65217391304348, 1.0630434782609, 0.090909090909091
51436, 0.65217391304348, 1.0891304347826, 0.11363636363636
51437, 0.67391304347826, 1.0891304347826, 0.13636363636364
51438, 0.65217391304348, 1.0630434782609, 0.13636363636364
51439, 0.65217391304348, 1.0891304347826, 0.15909090909091
51440, 0.67391304347826, 1.0891304347826, 0.18181818181818
51441, 0.65217391304348, 1.0630434782609, 0.18181818181818
51442, 0.65217391304348, 1.0891304347826, 0.20454545454545
51443, 0.67391304347826, 1.0891304347826, 0.22727272727273
51444, 0.65217391304348, 1.0630434782609, 0.22727272727273
51445, 0.65217391304348, 1.0891304347826, 0.25
51446, 0.67391304347826, 1.0891304347826, 0.27272727272727
51447, 0.65217391304348, 1.0630434782609, 0.27272727272727
51448, 0.65217391304348, 1.0891304347826, 0.29545454545455
51449, 0.67391304347826, 1.0891304347826, 0.31818181818182
51450, 0.65217391304348, 1.0630434782609, 0.31818181818182
51451, 0.65217391304348, 1.0891304347826, 0.34090909090909
51452, 0.67391304347826, 1.0891304347826, 0.36363636363636
51453, 0.65217391304348, 1.0630434782609, 0.36363636363636
51454, 0.65217391304348, 1.0891304347826, 0.38636363636364
51455, 0.67391304347826, 1.0891304347826, 0.40909090909091
51456, 0.65217391304348, 1.0630434782609, 0.40909090909091
51457, 0.65217391304348, 1.0891304347826, 0.43181818181818
51458, 0.67391304347826, 1.0891304347826, 0.45454545454545
51459, 0.65217391304348, 1.0630434782609, 0.45454545454545
51460, 0.65217391304348, 1.0891304347826, 0.47727272727273
51461, 0.60869565217391, 1.0891304347826, 0.022727272727273
51462, 0.6304347826087, 1.0891304347826, 0.045454545454545
51463, 0.60869565217391, 1.0630434782609, 0.045454545454545
51464, 0.60869565217391, 1.0891304347826, 0.068181818181818
51465, 0.6304347826087, 1.0891304347826, 0.090909090909091
51466, 0.60869565217391, 1.0630434782609, 0.090909090909091
51467, 0.60869565217391, 1.0891304347826, 0.11363636363636
51468, 0.6304347826087, 1.0891304347826, 0.13636363636364
51469, 0.60869565217391, 1.0630434782609, 0.13636363636364
51470, 0.60869565217391, 1.0891304347826, 0.15909090909091
51471, 0.6304347826087, 1.0891304347826, 0.18181818181818
51472, 0.60869565217391, 1.0630434782609, 0.18181818181818
51473, 0.60869565217391, 1.0891304347826, 0.20454545454545
51474, 0.6304347826087, 1.0891304347826, 0.22727272727273
51475, 0.60869565217391, 1.0630434782609, 0.22727272727273
51476, 0.60869565217391, 1.0891304347826, 0.25
51477, 0.6304347826087, 1.0891304347826, 0.27272727272727
51478, 0.60869565217391, 1.0630434782609, 0.27272727272727
51479, 0.60869565217391, 1.0891304347826, 0.29545454545455
51480, 0.6304347826087, 1.0891304347826, 0.31818181818182
51481, 0.60869565217391, 1.0630434782609, 0.31818181818182
51482, 0.60869565217391, 1.0891304347826, 0.34090909090909
51483, 0.6304347826087, 1.0891304347826, 0.36363636363636
51484, 0.60869565217391, 1.0630434782609, 0.36363636363636
51485, 0.60869565217391, 1.0891304347826, 0.38636363636364
51486, 0.6304347826087, 1.0891304347826, 0.40909090909091
51487, 0.60869565217391, 1.0630434782609, 0.40909090909091
51488, 0.60869565217391, 1.0891304347826, 0.43181818181818
51489, 0.6304347826087, 1.0891304347826, 0.45454545454545
51490, 0.60869565217391, 1.0630434782609, 0.45454545454545
51491, 0.60869565217391, 1.0891304347826, 0.47727272727273
51492, 0.56521739130435, 1.0891304347826, 0.022727272727273
51493, 0.58695652173913, 1.0891304347826, 0.045454545454545
51494, 0.56521739130435, 1.0630434782609, 0.045454545454545
51495, 0.56521739130435, 1.0891304347826, 0.068181818181818
51496, 0.58695652173913, 1.0891304347826, 0.090909090909091
51497, 0.56521739130435, 1.0630434782609, 0.090909090909091
51498, 0.56521739130435, 1.0891304347826, 0.11363636363636
51499, 0.58695652173913, 1.0891304347826, 0.13636363636364
51500, 0.56521739130435, 1.0630434782609, 0.13636363636364
51501, 0.56521739130435, 1.0891304347826, 0.15909090909091
51502, 0.58695652173913, 1.0891304347826, 0.18181818181818
51503, 0.56521739130435, 1.0630434782609, 0.18181818181818
51504, 0.56521739130435, 1.0891304347826, 0.20454545454545
51505, 0.58695652173913, 1.0891304347826, 0.22727272727273
51506, 0.56521739130435, 1.0630434782609, 0.22727272727273
51507, 0.56521739130435, 1.0891304347826, 0.25
51508, 0.58695652173913, 1.0891304347826, 0.27272727272727
51509, 0.56521739130435, 1.0630434782609, 0.27272727272727
51510, 0.56521739130435, 1.0891304347826, 0.29545454545455
51511, 0.58695652173913, 1.0891304347826, 0.31818181818182
51512, 0.56521739130435, 1.0630434782609, 0.31818181818182
51513, 0.56521739130435, 1.0891304347826, 0.34090909090909
51514, 0.58695652173913, 1.0891304347826, 0.36363636363636
51515, 0.56521739130435, 1.0630434782609, 0.36363636363636
51516, 0.56521739130435, 1.0891304347826, 0.38636363636364
51517, 0.58695652173913, 1.0891304347826, 0.40909090909091
51518, 0.56521739130435, 1.0630434782609, 0.40909090909091
51519, 0.56521739130435, 1.0891304347826, 0.43181818181818
51520, 0.58695652173913, 1.0891304347826, 0.45454545454545
51521, 0.56521739130435, 1.0630434782609, 0.45454545454545
51522, 0.56521739130435, 1.0891304347826, 0.47727272727273
51523, 0.52173913043478, 1.0891304347826, 0.022727272727273
51524, 0.54347826086956, 1.0891304347826, 0.045454545454545
51525, 0.52173913043478, 1.0630434782609, 0.045454545454545
51526, 0.52173913043478, 1.0891304347826, 0.068181818181818
51527, 0.54347826086956, 1.0891304347826, 0.090909090909091
51528, 0.52173913043478, 1.0630434782609, 0.090909090909091
51529, 0.52173913043478, 1.0891304347826, 0.11363636363636
51530, 0.54347826086956, 1.0891304347826, 0.13636363636364
51531, 0.52173913043478, 1.0630434782609, 0.13636363636364
51532, 0.52173913043478, 1.0891304347826, 0.15909090909091
51533, 0.54347826086956, 1.0891304347826, 0.18181818181818
51534, 0.52173913043478, 1.0630434782609, 0.18181818181818
51535, 0.52173913043478, 1.0891304347826, 0.20454545454545
51536, 0.54347826086956, 1.0891304347826, 0.22727272727273
51537, 0.52173913043478, 1.0630434782609, 0.22727272727273
51538, 0.52173913043478, 1.0891304347826, 0.25
51539, 0.54347826086956, 1.0891304347826, 0.27272727272727
51540, 0.52173913043478, 1.0630434782609, 0.27272727272727
51541, 0.52173913043478, 1.0891304347826, 0.29545454545455
51542, 0.54347826086956, 1.0891304347826, 0.31818181818182
51543, 0.52173913043478, 1.0630434782609, 0.31818181818182
51544, 0.52173913043478, 1.0891304347826, 0.34090909090909
51545, 0.54347826086957, 1.0891304347826, 0.36363636363636
51546, 0.52173913043478, 1.0630434782609, 0.36363636363636
51547, 0.52173913043478, 1.0891304347826, 0.38636363636364
51548, 0.54347826086956, 1.0891304347826, 0.40909090909091
51549, 0.52173913043478, 1.0630434782609, 0.40909090909091
51550, 0.52173913043478, 1.0891304347826, 0.43181818181818
51551, 0.54347826086956, 1.0891304347826, 0.45454545454545
51552, 0.52173913043478, 1.0630434782609, 0.45454545454545
51553, 0.52173913043478, 1.0891304347826, 0.47727272727273
51554, 0.47826086956522, 1.0891304347826, 0.022727272727273
51555, 0.5, 1.0891304347826, 0.045454545454545
51556, 0.47826086956522, 1.0630434782609, 0.045454545454545
51557, 0.47826086956522, 1.0891304347826, 0.068181818181818
51558, 0.5, 1.0891304347826, 0.090909090909091
51559, 0.47826086956522, 1.0630434782609, 0.090909090909091
51560, 0.47826086956522, 1.0891304347826, 0.11363636363636
51561, 0.5, 1.0891304347826, 0.13636363636364
51562, 0.47826086956522, 1.0630434782609, 0.13636363636364
51563, 0.47826086956522, 1.0891304347826, 0.15909090909091
51564, 0.5, 1.0891304347826, 0.18181818181818
51565, 0.47826086956522, 1.0630434782609, 0.18181818181818
51566, 0.47826086956522, 1.0891304347826, 0.20454545454545
51567, 0.5, 1.0891304347826, 0.22727272727273
51568, 0.47826086956522, 1.0630434782609, 0.22727272727273
51569, 0.47826086956522, 1.0891304347826, 0.25
51570, 0.5, 1.0891304347826, 0.27272727272727
51571, 0.47826086956522, 1.0630434782609, 0.27272727272727
51572, 0.47826086956522, 1.0891304347826, 0.29545454545455
51573, 0.5, 1.0891304347826, 0.31818181818182
51574, 0.47826086956522, 1.0630434782609, 0.31818181818182
51575, 0.47826086956522, 1.0891304347826, 0.34090909090909
51576, 0.5, 1.0891304347826, 0.36363636363636
51577, 0.47826086956522, 1.0630434782609, 0.36363636363636
51578, 0.47826086956522, 1.0891304347826, 0.38636363636364
51579, 0.5, 1.0891304347826, 0.40909090909091
51580, 0.47826086956522, 1.0630434782609, 0.40909090909091
51581, 0.47826086956522, 1.0891304347826, 0.43181818181818
51582, 0.5, 1.0891304347826, 0.45454545454545
51583, 0.47826086956522, 1.0630434782609, 0.45454545454545
51584, 0.47826086956522, 1.0891304347826, 0.47727272727273
51585, 0.43478260869565, 1.0891304347826, 0.022727272727273
51586, 0.45652173913043, 1.0891304347826, 0.045454545454545
51587, 0.43478260869565, 1.0630434782609, 0.045454545454545
51588, 0.43478260869565, 1.0891304347826, 0.068181818181818
51589, 0.45652173913043, 1.0891304347826, 0.090909090909091
51590, 0.43478260869565, 1.0630434782609, 0.090909090909091
51591, 0.43478260869565, 1.0891304347826, 0.11363636363636
51592, 0.45652173913043, 1.0891304347826, 0.13636363636364
51593, 0.43478260869565, 1.0630434782609, 0.13636363636364
51594, 0.43478260869565, 1.0891304347826, 0.15909090909091
51595, 0.45652173913043, 1.0891304347826, 0.18181818181818
51596, 0.43478260869565, 1.0630434782609, 0.18181818181818
51597, 0.43478260869565, 1.0891304347826, 0.20454545454545
51598, 0.45652173913043, 1.0891304347826, 0.22727272727273
51599, 0.43478260869565, 1.0630434782609, 0.22727272727273
51600, 0.43478260869565, 1.0891304347826, 0.25
51601, 0.45652173913043, 1.0891304347826, 0.27272727272727
51602, 0.43478260869565, 1.0630434782609, 0.27272727272727
51603, 0.43478260869565, 1.0891304347826, 0.29545454545455
51604, 0.45652173913043, 1.0891304347826, 0.31818181818182
