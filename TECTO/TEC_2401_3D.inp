10150, 0, 0.38478260869565, 0.22727272727273
10151, 0, 0.41086956521739, 0.20454545454545
10152, 0, 0.38478260869565, 0.18181818181818
10153, 0, 0.41086956521739, 0.15909090909091
10154, 0, 0.38478260869565, 0.13636363636364
10155, 0, 0.41086956521739, 0.11363636363636
10156, 0, 0.38478260869565, 0.090909090909091
10157, 0, 0.41086956521739, 0.068181818181818
10158, 0, 0.38478260869565, 0.045454545454545
10159, 0, 0.41086956521739, 0.022727272727273
10160, 0, 0.46304347826087, 0.47727272727273
10161, 0, 0.43695652173913, 0.45454545454545
10162, 0, 0.46304347826087, 0.43181818181818
10163, 0, 0.43695652173913, 0.40909090909091
10164, 0, 0.46304347826087, 0.38636363636364
10165, 0, 0.43695652173913, 0.36363636363636
10166, 0, 0.46304347826087, 0.34090909090909
10167, 0, 0.43695652173913, 0.31818181818182
10168, 0, 0.46304347826087, 0.29545454545455
10169, 0, 0.43695652173913, 0.27272727272727
10170, 0, 0.46304347826087, 0.25
10171, 0, 0.43695652173913, 0.22727272727273
10172, 0, 0.46304347826087, 0.20454545454545
10173, 0, 0.43695652173913, 0.18181818181818
10174, 0, 0.46304347826087, 0.15909090909091
10175, 0, 0.43695652173913, 0.13636363636364
10176, 0, 0.46304347826087, 0.11363636363636
10177, 0, 0.43695652173913, 0.090909090909091
10178, 0, 0.46304347826087, 0.068181818181818
10179, 0, 0.43695652173913, 0.045454545454545
10180, 0, 0.46304347826087, 0.022727272727273
10181, 0, 0.51521739130435, 0.47727272727273
10182, 0, 0.48913043478261, 0.45454545454545
10183, 0, 0.51521739130435, 0.43181818181818
10184, 0, 0.48913043478261, 0.40909090909091
10185, 0, 0.51521739130435, 0.38636363636364
10186, 0, 0.48913043478261, 0.36363636363636
10187, 0, 0.51521739130435, 0.34090909090909
10188, 0, 0.48913043478261, 0.31818181818182
10189, 0, 0.51521739130435, 0.29545454545455
10190, 0, 0.48913043478261, 0.27272727272727
10191, 0, 0.51521739130435, 0.25
10192, 0, 0.48913043478261, 0.22727272727273
10193, 0, 0.51521739130435, 0.20454545454545
10194, 0, 0.48913043478261, 0.18181818181818
10195, 0, 0.51521739130435, 0.15909090909091
10196, 0, 0.48913043478261, 0.13636363636364
10197, 0, 0.51521739130435, 0.11363636363636
10198, 0, 0.48913043478261, 0.090909090909091
10199, 0, 0.51521739130435, 0.068181818181818
10200, 0, 0.48913043478261, 0.045454545454545
10201, 0, 0.51521739130435, 0.022727272727273
10202, 0, 0.56739130434783, 0.47727272727273
10203, 0, 0.54130434782609, 0.45454545454545
10204, 0, 0.56739130434783, 0.43181818181818
10205, 0, 0.54130434782609, 0.40909090909091
10206, 0, 0.56739130434783, 0.38636363636364
10207, 0, 0.54130434782609, 0.36363636363636
10208, 0, 0.56739130434783, 0.34090909090909
10209, 0, 0.54130434782609, 0.31818181818182
10210, 0, 0.56739130434783, 0.29545454545455
10211, 0, 0.54130434782609, 0.27272727272727
10212, 0, 0.56739130434783, 0.25
10213, 0, 0.54130434782609, 0.22727272727273
10214, 0, 0.56739130434783, 0.20454545454545
10215, 0, 0.54130434782609, 0.18181818181818
10216, 0, 0.56739130434783, 0.15909090909091
10217, 0, 0.54130434782609, 0.13636363636364
10218, 0, 0.56739130434783, 0.11363636363636
10219, 0, 0.54130434782609, 0.090909090909091
10220, 0, 0.56739130434783, 0.068181818181818
10221, 0, 0.54130434782609, 0.045454545454545
10222, 0, 0.56739130434783, 0.022727272727273
10223, 0, 0.6195652173913, 0.47727272727273
10224, 0, 0.59347826086956, 0.45454545454545
10225, 0, 0.6195652173913, 0.43181818181818
10226, 0, 0.59347826086956, 0.40909090909091
10227, 0, 0.6195652173913, 0.38636363636364
10228, 0, 0.59347826086956, 0.36363636363636
10229, 0, 0.6195652173913, 0.34090909090909
10230, 0, 0.59347826086956, 0.31818181818182
10231, 0, 0.6195652173913, 0.29545454545455
10232, 0, 0.59347826086956, 0.27272727272727
10233, 0, 0.6195652173913, 0.25
10234, 0, 0.59347826086956, 0.22727272727273
10235, 0, 0.6195652173913, 0.20454545454545
10236, 0, 0.59347826086956, 0.18181818181818
10237, 0, 0.6195652173913, 0.15909090909091
10238, 0, 0.59347826086956, 0.13636363636364
10239, 0, 0.6195652173913, 0.11363636363636
10240, 0, 0.59347826086956, 0.090909090909091
10241, 0, 0.6195652173913, 0.068181818181818
10242, 0, 0.59347826086956, 0.045454545454545
10243, 0, 0.6195652173913, 0.022727272727273
10244, 0, 0.67173913043478, 0.47727272727273
10245, 0, 0.64565217391304, 0.45454545454545
10246, 0, 0.67173913043478, 0.43181818181818
10247, 0, 0.64565217391304, 0.40909090909091
10248, 0, 0.67173913043478, 0.38636363636364
10249, 0, 0.64565217391304, 0.36363636363636
10250, 0, 0.67173913043478, 0.34090909090909
10251, 0, 0.64565217391304, 0.31818181818182
10252, 0, 0.67173913043478, 0.29545454545455
10253, 0, 0.64565217391304, 0.27272727272727
10254, 0, 0.67173913043478, 0.25
10255, 0, 0.64565217391304, 0.22727272727273
10256, 0, 0.67173913043478, 0.20454545454545
10257, 0, 0.64565217391304, 0.18181818181818
10258, 0, 0.67173913043478, 0.15909090909091
10259, 0, 0.64565217391304, 0.13636363636364
10260, 0, 0.67173913043478, 0.11363636363636
10261, 0, 0.64565217391304, 0.090909090909091
10262, 0, 0.67173913043478, 0.068181818181818
10263, 0, 0.64565217391304, 0.045454545454545
10264, 0, 0.67173913043478, 0.022727272727273
10265, 0, 0.72391304347826, 0.47727272727273
10266, 0, 0.69782608695652, 0.45454545454545
10267, 0, 0.72391304347826, 0.43181818181818
10268, 0, 0.69782608695652, 0.40909090909091
10269, 0, 0.72391304347826, 0.38636363636364
10270, 0, 0.69782608695652, 0.36363636363636
10271, 0, 0.72391304347826, 0.34090909090909
10272, 0, 0.69782608695652, 0.31818181818182
10273, 0, 0.72391304347826, 0.29545454545455
10274, 0, 0.69782608695652, 0.27272727272727
10275, 0, 0.72391304347826, 0.25
10276, 0, 0.69782608695652, 0.22727272727273
10277, 0, 0.72391304347826, 0.20454545454545
10278, 0, 0.69782608695652, 0.18181818181818
10279, 0, 0.72391304347826, 0.15909090909091
10280, 0, 0.69782608695652, 0.13636363636364
10281, 0, 0.72391304347826, 0.11363636363636
10282, 0, 0.69782608695652, 0.090909090909091
10283, 0, 0.72391304347826, 0.068181818181818
10284, 0, 0.69782608695652, 0.045454545454545
10285, 0, 0.72391304347826, 0.022727272727273
10286, 0, 0.77608695652174, 0.47727272727273
10287, 0, 0.75, 0.45454545454545
10288, 0, 0.77608695652174, 0.43181818181818
10289, 0, 0.75, 0.40909090909091
10290, 0, 0.77608695652174, 0.38636363636364
10291, 0, 0.75, 0.36363636363636
10292, 0, 0.77608695652174, 0.34090909090909
10293, 0, 0.75, 0.31818181818182
10294, 0, 0.77608695652174, 0.29545454545455
10295, 0, 0.75, 0.27272727272727
10296, 0, 0.77608695652174, 0.25
10297, 0, 0.75, 0.22727272727273
10298, 0, 0.77608695652174, 0.20454545454545
10299, 0, 0.75, 0.18181818181818
10300, 0, 0.77608695652174, 0.15909090909091
10301, 0, 0.75, 0.13636363636364
10302, 0, 0.77608695652174, 0.11363636363636
10303, 0, 0.75, 0.090909090909091
10304, 0, 0.77608695652174, 0.068181818181818
10305, 0, 0.75, 0.045454545454545
10306, 0, 0.77608695652174, 0.022727272727273
10307, 0, 0.82826086956522, 0.47727272727273
10308, 0, 0.80217391304348, 0.45454545454545
10309, 0, 0.82826086956522, 0.43181818181818
10310, 0, 0.80217391304348, 0.40909090909091
10311, 0, 0.82826086956522, 0.38636363636364
10312, 0, 0.80217391304348, 0.36363636363636
10313, 0, 0.82826086956522, 0.34090909090909
10314, 0, 0.80217391304348, 0.31818181818182
10315, 0, 0.82826086956522, 0.29545454545455
10316, 0, 0.80217391304348, 0.27272727272727
10317, 0, 0.82826086956522, 0.25
10318, 0, 0.80217391304348, 0.22727272727273
10319, 0, 0.82826086956522, 0.20454545454545
10320, 0, 0.80217391304348, 0.18181818181818
10321, 0, 0.82826086956522, 0.15909090909091
10322, 0, 0.80217391304348, 0.13636363636364
10323, 0, 0.82826086956522, 0.11363636363636
10324, 0, 0.80217391304348, 0.090909090909091
10325, 0, 0.82826086956522, 0.068181818181818
10326, 0, 0.80217391304348, 0.045454545454545
10327, 0, 0.82826086956522, 0.022727272727273
10328, 0, 0.8804347826087, 0.47727272727273
10329, 0, 0.85434782608696, 0.45454545454545
10330, 0, 0.8804347826087, 0.43181818181818
10331, 0, 0.85434782608696, 0.40909090909091
10332, 0, 0.8804347826087, 0.38636363636364
10333, 0, 0.85434782608696, 0.36363636363636
10334, 0, 0.8804347826087, 0.34090909090909
10335, 0, 0.85434782608696, 0.31818181818182
10336, 0, 0.8804347826087, 0.29545454545455
10337, 0, 0.85434782608696, 0.27272727272727
10338, 0, 0.8804347826087, 0.25
10339, 0, 0.85434782608696, 0.22727272727273
10340, 0, 0.8804347826087, 0.20454545454545
10341, 0, 0.85434782608696, 0.18181818181818
10342, 0, 0.8804347826087, 0.15909090909091
10343, 0, 0.85434782608696, 0.13636363636364
10344, 0, 0.8804347826087, 0.11363636363636
10345, 0, 0.85434782608696, 0.090909090909091
10346, 0, 0.8804347826087, 0.068181818181818
10347, 0, 0.85434782608696, 0.045454545454545
10348, 0, 0.8804347826087, 0.022727272727273
10349, 0, 0.93260869565217, 0.47727272727273
10350, 0, 0.90652173913043, 0.45454545454545
10351, 0, 0.93260869565217, 0.43181818181818
10352, 0, 0.90652173913043, 0.40909090909091
10353, 0, 0.93260869565217, 0.38636363636364
10354, 0, 0.90652173913043, 0.36363636363636
10355, 0, 0.93260869565217, 0.34090909090909
10356, 0, 0.90652173913043, 0.31818181818182
10357, 0, 0.93260869565217, 0.29545454545455
10358, 0, 0.90652173913043, 0.27272727272727
10359, 0, 0.93260869565217, 0.25
10360, 0, 0.90652173913043, 0.22727272727273
10361, 0, 0.93260869565217, 0.20454545454545
10362, 0, 0.90652173913043, 0.18181818181818
10363, 0, 0.93260869565217, 0.15909090909091
10364, 0, 0.90652173913043, 0.13636363636364
10365, 0, 0.93260869565217, 0.11363636363636
10366, 0, 0.90652173913043, 0.090909090909091
10367, 0, 0.93260869565217, 0.068181818181818
10368, 0, 0.90652173913043, 0.045454545454545
10369, 0, 0.93260869565217, 0.022727272727273
10370, 0, 0.98478260869565, 0.47727272727273
10371, 0, 0.95869565217391, 0.45454545454545
10372, 0, 0.98478260869565, 0.43181818181818
10373, 0, 0.95869565217391, 0.40909090909091
10374, 0, 0.98478260869565, 0.38636363636364
10375, 0, 0.95869565217391, 0.36363636363636
10376, 0, 0.98478260869565, 0.34090909090909
10377, 0, 0.95869565217391, 0.31818181818182
10378, 0, 0.98478260869565, 0.29545454545455
10379, 0, 0.95869565217391, 0.27272727272727
10380, 0, 0.98478260869565, 0.25
10381, 0, 0.95869565217391, 0.22727272727273
10382, 0, 0.98478260869565, 0.20454545454545
10383, 0, 0.95869565217391, 0.18181818181818
10384, 0, 0.98478260869565, 0.15909090909091
10385, 0, 0.95869565217391, 0.13636363636364
10386, 0, 0.98478260869565, 0.11363636363636
10387, 0, 0.95869565217391, 0.090909090909091
10388, 0, 0.98478260869565, 0.068181818181818
10389, 0, 0.95869565217391, 0.045454545454545
10390, 0, 0.98478260869565, 0.022727272727273
10391, 0, 1.0369565217391, 0.47727272727273
10392, 0, 1.0108695652174, 0.45454545454545
10393, 0, 1.0369565217391, 0.43181818181818
10394, 0, 1.0108695652174, 0.40909090909091
10395, 0, 1.0369565217391, 0.38636363636364
10396, 0, 1.0108695652174, 0.36363636363636
10397, 0, 1.0369565217391, 0.34090909090909
10398, 0, 1.0108695652174, 0.31818181818182
10399, 0, 1.0369565217391, 0.29545454545455
10400, 0, 1.0108695652174, 0.27272727272727
10401, 0, 1.0369565217391, 0.25
10402, 0, 1.0108695652174, 0.22727272727273
10403, 0, 1.0369565217391, 0.20454545454545
10404, 0, 1.0108695652174, 0.18181818181818
10405, 0, 1.0369565217391, 0.15909090909091
10406, 0, 1.0108695652174, 0.13636363636364
10407, 0, 1.0369565217391, 0.11363636363636
10408, 0, 1.0108695652174, 0.090909090909091
10409, 0, 1.0369565217391, 0.068181818181818
10410, 0, 1.0108695652174, 0.045454545454545
10411, 0, 1.0369565217391, 0.022727272727273
10412, 0, 1.0891304347826, 0.47727272727273
10413, 0, 1.0630434782609, 0.45454545454545
10414, 0, 1.0891304347826, 0.43181818181818
10415, 0, 1.0630434782609, 0.40909090909091
10416, 0, 1.0891304347826, 0.38636363636364
10417, 0, 1.0630434782609, 0.36363636363636
10418, 0, 1.0891304347826, 0.34090909090909
10419, 0, 1.0630434782609, 0.31818181818182
10420, 0, 1.0891304347826, 0.29545454545455
10421, 0, 1.0630434782609, 0.27272727272727
10422, 0, 1.0891304347826, 0.25
10423, 0, 1.0630434782609, 0.22727272727273
10424, 0, 1.0891304347826, 0.20454545454545
10425, 0, 1.0630434782609, 0.18181818181818
10426, 0, 1.0891304347826, 0.15909090909091
10427, 0, 1.0630434782609, 0.13636363636364
10428, 0, 1.0891304347826, 0.11363636363636
10429, 0, 1.0630434782609, 0.090909090909091
10430, 0, 1.0891304347826, 0.068181818181818
10431, 0, 1.0630434782609, 0.045454545454545
10432, 0, 1.0891304347826, 0.022727272727273
10433, 0, 1.1413043478261, 0.47727272727273
10434, 0, 1.1152173913043, 0.45454545454545
10435, 0, 1.1413043478261, 0.43181818181818
10436, 0, 1.1152173913043, 0.40909090909091
10437, 0, 1.1413043478261, 0.38636363636364
10438, 0, 1.1152173913043, 0.36363636363636
10439, 0, 1.1413043478261, 0.34090909090909
10440, 0, 1.1152173913043, 0.31818181818182
10441, 0, 1.1413043478261, 0.29545454545455
10442, 0, 1.1152173913043, 0.27272727272727
10443, 0, 1.1413043478261, 0.25
10444, 0, 1.1152173913043, 0.22727272727273
10445, 0, 1.1413043478261, 0.20454545454545
10446, 0, 1.1152173913043, 0.18181818181818
10447, 0, 1.1413043478261, 0.15909090909091
10448, 0, 1.1152173913043, 0.13636363636364
10449, 0, 1.1413043478261, 0.11363636363636
10450, 0, 1.1152173913043, 0.090909090909091
10451, 0, 1.1413043478261, 0.068181818181818
10452, 0, 1.1152173913043, 0.045454545454545
10453, 0, 1.1413043478261, 0.022727272727273
10454, 0, 1.1934782608696, 0.47727272727273
10455, 0, 1.1673913043478, 0.45454545454545
10456, 0, 1.1934782608696, 0.43181818181818
10457, 0, 1.1673913043478, 0.40909090909091
10458, 0, 1.1934782608696, 0.38636363636364
10459, 0, 1.1673913043478, 0.36363636363636
10460, 0, 1.1934782608696, 0.34090909090909
10461, 0, 1.1673913043478, 0.31818181818182
10462, 0, 1.1934782608696, 0.29545454545455
10463, 0, 1.1673913043478, 0.27272727272727
10464, 0, 1.1934782608696, 0.25
10465, 0, 1.1673913043478, 0.22727272727273
10466, 0, 1.1934782608696, 0.20454545454545
10467, 0, 1.1673913043478, 0.18181818181818
10468, 0, 1.1934782608696, 0.15909090909091
10469, 0, 1.1673913043478, 0.13636363636364
10470, 0, 1.1934782608696, 0.11363636363636
10471, 0, 1.1673913043478, 0.090909090909091
10472, 0, 1.1934782608696, 0.068181818181818
10473, 0, 1.1673913043478, 0.045454545454545
10474, 0, 1.1934782608696, 0.022727272727273
10475, 0, 1.245652173913, 0.47727272727273
10476, 0, 1.2195652173913, 0.45454545454545
10477, 0, 1.245652173913, 0.43181818181818
10478, 0, 1.2195652173913, 0.40909090909091
10479, 0, 1.245652173913, 0.38636363636364
10480, 0, 1.2195652173913, 0.36363636363636
10481, 0, 1.245652173913, 0.34090909090909
10482, 0, 1.2195652173913, 0.31818181818182
10483, 0, 1.245652173913, 0.29545454545455
10484, 0, 1.2195652173913, 0.27272727272727
10485, 0, 1.245652173913, 0.25
10486, 0, 1.2195652173913, 0.22727272727273
10487, 0, 1.245652173913, 0.20454545454545
10488, 0, 1.2195652173913, 0.18181818181818
10489, 0, 1.245652173913, 0.15909090909091
10490, 0, 1.2195652173913, 0.13636363636364
10491, 0, 1.245652173913, 0.11363636363636
10492, 0, 1.2195652173913, 0.090909090909091
10493, 0, 1.245652173913, 0.068181818181818
10494, 0, 1.2195652173913, 0.045454545454545
10495, 0, 1.245652173913, 0.022727272727273
10496, 0, 1.2978260869565, 0.47727272727273
10497, 0, 1.2717391304348, 0.45454545454545
10498, 0, 1.2978260869565, 0.43181818181818
10499, 0, 1.2717391304348, 0.40909090909091
10500, 0, 1.2978260869565, 0.38636363636364
10501, 0, 1.2717391304348, 0.36363636363636
10502, 0, 1.2978260869565, 0.34090909090909
10503, 0, 1.2717391304348, 0.31818181818182
10504, 0, 1.2978260869565, 0.29545454545455
10505, 0, 1.2717391304348, 0.27272727272727
10506, 0, 1.2978260869565, 0.25
10507, 0, 1.2717391304348, 0.22727272727273
10508, 0, 1.2978260869565, 0.20454545454545
10509, 0, 1.2717391304348, 0.18181818181818
10510, 0, 1.2978260869565, 0.15909090909091
10511, 0, 1.2717391304348, 0.13636363636364
10512, 0, 1.2978260869565, 0.11363636363636
10513, 0, 1.2717391304348, 0.090909090909091
10514, 0, 1.2978260869565, 0.068181818181818
10515, 0, 1.2717391304348, 0.045454545454545
10516, 0, 1.2978260869565, 0.022727272727273
10517, 0, 1.3239130434783, 0.45454545454545
10518, 0, 1.3239130434783, 0.40909090909091
10519, 0, 1.3239130434783, 0.36363636363636
10520, 0, 1.3239130434783, 0.31818181818182
10521, 0, 1.3239130434783, 0.27272727272727
10522, 0, 1.3239130434783, 0.22727272727273
10523, 0, 1.3239130434783, 0.18181818181818
10524, 0, 1.3239130434783, 0.13636363636364
10525, 0, 1.3239130434783, 0.090909090909091
10526, 0, 1.3239130434783, 0.045454545454545
10527, 0.043478260869565, 1.35, 0.045454545454545
10528, 0.043478260869565, 1.35, 0.090909090909091
10529, 0.043478260869565, 1.35, 0.13636363636364
10530, 0.043478260869565, 1.35, 0.18181818181818
10531, 0.043478260869565, 1.35, 0.22727272727273
10532, 0.043478260869565, 1.35, 0.27272727272727
10533, 0.043478260869565, 1.35, 0.31818181818182
10534, 0.043478260869565, 1.35, 0.36363636363636
10535, 0.043478260869565, 1.35, 0.40909090909091
10536, 0.043478260869565, 1.35, 0.45454545454545
10537, 0.08695652173913, 1.35, 0.045454545454545
10538, 0.08695652173913, 1.35, 0.090909090909091
10539, 0.08695652173913, 1.35, 0.13636363636364
10540, 0.08695652173913, 1.35, 0.18181818181818
10541, 0.08695652173913, 1.35, 0.22727272727273
10542, 0.08695652173913, 1.35, 0.27272727272727
10543, 0.08695652173913, 1.35, 0.31818181818182
10544, 0.08695652173913, 1.35, 0.36363636363636
10545, 0.08695652173913, 1.35, 0.40909090909091
10546, 0.08695652173913, 1.35, 0.45454545454545
10547, 0.1304347826087, 1.35, 0.045454545454545
10548, 0.1304347826087, 1.35, 0.090909090909091
10549, 0.1304347826087, 1.35, 0.13636363636364
10550, 0.1304347826087, 1.35, 0.18181818181818
10551, 0.1304347826087, 1.35, 0.22727272727273
10552, 0.1304347826087, 1.35, 0.27272727272727
10553, 0.1304347826087, 1.35, 0.31818181818182
10554, 0.1304347826087, 1.35, 0.36363636363636
10555, 0.1304347826087, 1.35, 0.40909090909091
10556, 0.1304347826087, 1.35, 0.45454545454545
10557, 0.17391304347826, 1.35, 0.045454545454545
10558, 0.17391304347826, 1.35, 0.090909090909091
10559, 0.17391304347826, 1.35, 0.13636363636364
10560, 0.17391304347826, 1.35, 0.18181818181818
10561, 0.17391304347826, 1.35, 0.22727272727273
10562, 0.17391304347826, 1.35, 0.27272727272727
10563, 0.17391304347826, 1.35, 0.31818181818182
10564, 0.17391304347826, 1.35, 0.36363636363636
10565, 0.17391304347826, 1.35, 0.40909090909091
10566, 0.17391304347826, 1.35, 0.45454545454545
10567, 0.21739130434783, 1.35, 0.045454545454545
10568, 0.21739130434783, 1.35, 0.090909090909091
10569, 0.21739130434783, 1.35, 0.13636363636364
10570, 0.21739130434783, 1.35, 0.18181818181818
10571, 0.21739130434783, 1.35, 0.22727272727273
10572, 0.21739130434783, 1.35, 0.27272727272727
10573, 0.21739130434783, 1.35, 0.31818181818182
10574, 0.21739130434783, 1.35, 0.36363636363636
10575, 0.21739130434783, 1.35, 0.40909090909091
10576, 0.21739130434783, 1.35, 0.45454545454545
10577, 0.26086956521739, 1.35, 0.045454545454545
10578, 0.26086956521739, 1.35, 0.090909090909091
10579, 0.26086956521739, 1.35, 0.13636363636364
10580, 0.26086956521739, 1.35, 0.18181818181818
10581, 0.26086956521739, 1.35, 0.22727272727273
10582, 0.26086956521739, 1.35, 0.27272727272727
10583, 0.26086956521739, 1.35, 0.31818181818182
10584, 0.26086956521739, 1.35, 0.36363636363636
10585, 0.26086956521739, 1.35, 0.40909090909091
10586, 0.26086956521739, 1.35, 0.45454545454545
10587, 0.30434782608696, 1.35, 0.045454545454545
10588, 0.30434782608696, 1.35, 0.090909090909091
10589, 0.30434782608696, 1.35, 0.13636363636364
10590, 0.30434782608696, 1.35, 0.18181818181818
10591, 0.30434782608696, 1.35, 0.22727272727273
10592, 0.30434782608696, 1.35, 0.27272727272727
10593, 0.30434782608696, 1.35, 0.31818181818182
10594, 0.30434782608696, 1.35, 0.36363636363636
10595, 0.30434782608696, 1.35, 0.40909090909091
10596, 0.30434782608696, 1.35, 0.45454545454545
10597, 0.34782608695652, 1.35, 0.045454545454545
10598, 0.34782608695652, 1.35, 0.090909090909091
10599, 0.34782608695652, 1.35, 0.13636363636364
10600, 0.34782608695652, 1.35, 0.18181818181818
10601, 0.34782608695652, 1.35, 0.22727272727273
10602, 0.34782608695652, 1.35, 0.27272727272727
10603, 0.34782608695652, 1.35, 0.31818181818182
10604, 0.34782608695652, 1.35, 0.36363636363636
10605, 0.34782608695652, 1.35, 0.40909090909091
10606, 0.34782608695652, 1.35, 0.45454545454545
10607, 0.39130434782609, 1.35, 0.045454545454545
10608, 0.39130434782609, 1.35, 0.090909090909091
10609, 0.39130434782609, 1.35, 0.13636363636364
10610, 0.39130434782609, 1.35, 0.18181818181818
10611, 0.39130434782609, 1.35, 0.22727272727273
10612, 0.39130434782609, 1.35, 0.27272727272727
10613, 0.39130434782609, 1.35, 0.31818181818182
10614, 0.39130434782609, 1.35, 0.36363636363636
10615, 0.39130434782609, 1.35, 0.40909090909091
10616, 0.39130434782609, 1.35, 0.45454545454545
10617, 0.43478260869565, 1.35, 0.045454545454545
10618, 0.43478260869565, 1.35, 0.090909090909091
10619, 0.43478260869565, 1.35, 0.13636363636364
10620, 0.43478260869565, 1.35, 0.18181818181818
10621, 0.43478260869565, 1.35, 0.22727272727273
10622, 0.43478260869565, 1.35, 0.27272727272727
10623, 0.43478260869565, 1.35, 0.31818181818182
10624, 0.43478260869565, 1.35, 0.36363636363636
10625, 0.43478260869565, 1.35, 0.40909090909091
10626, 0.43478260869565, 1.35, 0.45454545454545
10627, 0.47826086956522, 1.35, 0.045454545454545
10628, 0.47826086956522, 1.35, 0.090909090909091
10629, 0.47826086956522, 1.35, 0.13636363636364
10630, 0.47826086956522, 1.35, 0.18181818181818
10631, 0.47826086956522, 1.35, 0.22727272727273
10632, 0.47826086956522, 1.35, 0.27272727272727
10633, 0.47826086956522, 1.35, 0.31818181818182
10634, 0.47826086956522, 1.35, 0.36363636363636
10635, 0.47826086956522, 1.35, 0.40909090909091
10636, 0.47826086956522, 1.35, 0.45454545454545
10637, 0.52173913043478, 1.35, 0.045454545454545
10638, 0.52173913043478, 1.35, 0.090909090909091
10639, 0.52173913043478, 1.35, 0.13636363636364
10640, 0.52173913043478, 1.35, 0.18181818181818
10641, 0.52173913043478, 1.35, 0.22727272727273
10642, 0.52173913043478, 1.35, 0.27272727272727
10643, 0.52173913043478, 1.35, 0.31818181818182
10644, 0.52173913043478, 1.35, 0.36363636363636
10645, 0.52173913043478, 1.35, 0.40909090909091
10646, 0.52173913043478, 1.35, 0.45454545454545
10647, 0.56521739130435, 1.35, 0.045454545454545
10648, 0.56521739130435, 1.35, 0.090909090909091
10649, 0.56521739130435, 1.35, 0.13636363636364
10650, 0.56521739130435, 1.35, 0.18181818181818
10651, 0.56521739130435, 1.35, 0.22727272727273
10652, 0.56521739130435, 1.35, 0.27272727272727
10653, 0.56521739130435, 1.35, 0.31818181818182
10654, 0.56521739130435, 1.35, 0.36363636363636
10655, 0.56521739130435, 1.35, 0.40909090909091
10656, 0.56521739130435, 1.35, 0.45454545454545
10657, 0.60869565217391, 1.35, 0.045454545454545
10658, 0.60869565217391, 1.35, 0.090909090909091
10659, 0.60869565217391, 1.35, 0.13636363636364
10660, 0.60869565217391, 1.35, 0.18181818181818
10661, 0.60869565217391, 1.35, 0.22727272727273
10662, 0.60869565217391, 1.35, 0.27272727272727
10663, 0.60869565217391, 1.35, 0.31818181818182
10664, 0.60869565217391, 1.35, 0.36363636363636
10665, 0.60869565217391, 1.35, 0.40909090909091
10666, 0.60869565217391, 1.35, 0.45454545454545
10667, 0.65217391304348, 1.35, 0.045454545454545
10668, 0.65217391304348, 1.35, 0.090909090909091
10669, 0.65217391304348, 1.35, 0.13636363636364
10670, 0.65217391304348, 1.35, 0.18181818181818
10671, 0.65217391304348, 1.35, 0.22727272727273
10672, 0.65217391304348, 1.35, 0.27272727272727
10673, 0.65217391304348, 1.35, 0.31818181818182
10674, 0.65217391304348, 1.35, 0.36363636363636
10675, 0.65217391304348, 1.35, 0.40909090909091
10676, 0.65217391304348, 1.35, 0.45454545454545
10677, 0.69565217391304, 1.35, 0.045454545454545
10678, 0.69565217391304, 1.35, 0.090909090909091
10679, 0.69565217391304, 1.35, 0.13636363636364
10680, 0.69565217391304, 1.35, 0.18181818181818
10681, 0.69565217391304, 1.35, 0.22727272727273
10682, 0.69565217391304, 1.35, 0.27272727272727
10683, 0.69565217391304, 1.35, 0.31818181818182
10684, 0.69565217391304, 1.35, 0.36363636363636
10685, 0.69565217391304, 1.35, 0.40909090909091
10686, 0.69565217391304, 1.35, 0.45454545454545
10687, 0.73913043478261, 1.35, 0.045454545454545
10688, 0.73913043478261, 1.35, 0.090909090909091
10689, 0.73913043478261, 1.35, 0.13636363636364
10690, 0.73913043478261, 1.35, 0.18181818181818
10691, 0.73913043478261, 1.35, 0.22727272727273
10692, 0.73913043478261, 1.35, 0.27272727272727
10693, 0.73913043478261, 1.35, 0.31818181818182
10694, 0.73913043478261, 1.35, 0.36363636363636
10695, 0.73913043478261, 1.35, 0.40909090909091
10696, 0.73913043478261, 1.35, 0.45454545454545
10697, 0.78260869565217, 1.35, 0.045454545454545
10698, 0.78260869565217, 1.35, 0.090909090909091
10699, 0.78260869565217, 1.35, 0.13636363636364
10700, 0.78260869565217, 1.35, 0.18181818181818
10701, 0.78260869565217, 1.35, 0.22727272727273
10702, 0.78260869565217, 1.35, 0.27272727272727
10703, 0.78260869565217, 1.35, 0.31818181818182
10704, 0.78260869565217, 1.35, 0.36363636363636
10705, 0.78260869565217, 1.35, 0.40909090909091
10706, 0.78260869565217, 1.35, 0.45454545454545
10707, 0.82608695652174, 1.35, 0.045454545454545
10708, 0.82608695652174, 1.35, 0.090909090909091
10709, 0.82608695652174, 1.35, 0.13636363636364
10710, 0.82608695652174, 1.35, 0.18181818181818
10711, 0.82608695652174, 1.35, 0.22727272727273
10712, 0.82608695652174, 1.35, 0.27272727272727
10713, 0.82608695652174, 1.35, 0.31818181818182
10714, 0.82608695652174, 1.35, 0.36363636363636
10715, 0.82608695652174, 1.35, 0.40909090909091
10716, 0.82608695652174, 1.35, 0.45454545454545
10717, 0.8695652173913, 1.35, 0.045454545454545
10718, 0.8695652173913, 1.35, 0.090909090909091
10719, 0.8695652173913, 1.35, 0.13636363636364
10720, 0.8695652173913, 1.35, 0.18181818181818
10721, 0.8695652173913, 1.35, 0.22727272727273
10722, 0.8695652173913, 1.35, 0.27272727272727
10723, 0.8695652173913, 1.35, 0.31818181818182
10724, 0.8695652173913, 1.35, 0.36363636363636
10725, 0.8695652173913, 1.35, 0.40909090909091
10726, 0.8695652173913, 1.35, 0.45454545454545
10727, 0.91304347826087, 1.35, 0.045454545454545
10728, 0.91304347826087, 1.35, 0.090909090909091
10729, 0.91304347826087, 1.35, 0.13636363636364
10730, 0.91304347826087, 1.35, 0.18181818181818
10731, 0.91304347826087, 1.35, 0.22727272727273
10732, 0.91304347826087, 1.35, 0.27272727272727
10733, 0.91304347826087, 1.35, 0.31818181818182
10734, 0.91304347826087, 1.35, 0.36363636363636
10735, 0.91304347826087, 1.35, 0.40909090909091
10736, 0.91304347826087, 1.35, 0.45454545454545
10737, 0.95652173913043, 1.35, 0.045454545454545
10738, 0.95652173913043, 1.35, 0.090909090909091
10739, 0.95652173913044, 1.35, 0.13636363636364
10740, 0.95652173913043, 1.35, 0.18181818181818
10741, 0.95652173913043, 1.35, 0.22727272727273
10742, 0.95652173913043, 1.35, 0.27272727272727
10743, 0.95652173913043, 1.35, 0.31818181818182
10744, 0.95652173913043, 1.35, 0.36363636363636
10745, 0.95652173913043, 1.35, 0.40909090909091
10746, 0.95652173913043, 1.35, 0.45454545454545
10747, 0.021739130434783, 1.35, 0.045454545454545
10748, 0.043478260869565, 1.35, 0.022727272727273
10749, 0.021739130434783, 1.35, 0.090909090909091
10750, 0.043478260869565, 1.35, 0.068181818181818
10751, 0.021739130434783, 1.35, 0.13636363636364
10752, 0.043478260869565, 1.35, 0.11363636363636
10753, 0.021739130434783, 1.35, 0.18181818181818
10754, 0.043478260869565, 1.35, 0.15909090909091
10755, 0.021739130434783, 1.35, 0.22727272727273
10756, 0.043478260869565, 1.35, 0.20454545454545
10757, 0.021739130434783, 1.35, 0.27272727272727
10758, 0.043478260869565, 1.35, 0.25
10759, 0.021739130434783, 1.35, 0.31818181818182
10760, 0.043478260869565, 1.35, 0.29545454545455
10761, 0.021739130434783, 1.35, 0.36363636363636
10762, 0.043478260869565, 1.35, 0.34090909090909
10763, 0.021739130434783, 1.35, 0.40909090909091
10764, 0.043478260869565, 1.35, 0.38636363636364
10765, 0.021739130434783, 1.35, 0.45454545454545
10766, 0.043478260869565, 1.35, 0.43181818181818
10767, 0.043478260869565, 1.35, 0.47727272727273
10768, 0.065217391304348, 1.35, 0.045454545454545
10769, 0.08695652173913, 1.35, 0.022727272727273
10770, 0.065217391304348, 1.35, 0.090909090909091
10771, 0.08695652173913, 1.35, 0.068181818181818
10772, 0.065217391304348, 1.35, 0.13636363636364
10773, 0.08695652173913, 1.35, 0.11363636363636
10774, 0.065217391304348, 1.35, 0.18181818181818
10775, 0.08695652173913, 1.35, 0.15909090909091
10776, 0.065217391304348, 1.35, 0.22727272727273
10777, 0.08695652173913, 1.35, 0.20454545454545
10778, 0.065217391304348, 1.35, 0.27272727272727
10779, 0.08695652173913, 1.35, 0.25
10780, 0.065217391304348, 1.35, 0.31818181818182
10781, 0.08695652173913, 1.35, 0.29545454545455
10782, 0.065217391304348, 1.35, 0.36363636363636
10783, 0.08695652173913, 1.35, 0.34090909090909
10784, 0.065217391304348, 1.35, 0.40909090909091
10785, 0.08695652173913, 1.35, 0.38636363636364
10786, 0.065217391304348, 1.35, 0.45454545454545
10787, 0.08695652173913, 1.35, 0.43181818181818
10788, 0.08695652173913, 1.35, 0.47727272727273
10789, 0.10869565217391, 1.35, 0.045454545454545
10790, 0.1304347826087, 1.35, 0.022727272727273
10791, 0.10869565217391, 1.35, 0.090909090909091
10792, 0.1304347826087, 1.35, 0.068181818181818
10793, 0.10869565217391, 1.35, 0.13636363636364
10794, 0.1304347826087, 1.35, 0.11363636363636
10795, 0.10869565217391, 1.35, 0.18181818181818
10796, 0.1304347826087, 1.35, 0.15909090909091
10797, 0.10869565217391, 1.35, 0.22727272727273
10798, 0.1304347826087, 1.35, 0.20454545454545
10799, 0.10869565217391, 1.35, 0.27272727272727
10800, 0.1304347826087, 1.35, 0.25
10801, 0.10869565217391, 1.35, 0.31818181818182
10802, 0.1304347826087, 1.35, 0.29545454545455
10803, 0.10869565217391, 1.35, 0.36363636363636
10804, 0.1304347826087, 1.35, 0.34090909090909
10805, 0.10869565217391, 1.35, 0.40909090909091
10806, 0.1304347826087, 1.35, 0.38636363636364
10807, 0.10869565217391, 1.35, 0.45454545454545
10808, 0.1304347826087, 1.35, 0.43181818181818
10809, 0.1304347826087, 1.35, 0.47727272727273
10810, 0.15217391304348, 1.35, 0.045454545454545
10811, 0.17391304347826, 1.35, 0.022727272727273
10812, 0.15217391304348, 1.35, 0.090909090909091
10813, 0.17391304347826, 1.35, 0.068181818181818
10814, 0.15217391304348, 1.35, 0.13636363636364
10815, 0.17391304347826, 1.35, 0.11363636363636
10816, 0.15217391304348, 1.35, 0.18181818181818
10817, 0.17391304347826, 1.35, 0.15909090909091
10818, 0.15217391304348, 1.35, 0.22727272727273
10819, 0.17391304347826, 1.35, 0.20454545454545
10820, 0.15217391304348, 1.35, 0.27272727272727
10821, 0.17391304347826, 1.35, 0.25
10822, 0.15217391304348, 1.35, 0.31818181818182
10823, 0.17391304347826, 1.35, 0.29545454545455
10824, 0.15217391304348, 1.35, 0.36363636363636
10825, 0.17391304347826, 1.35, 0.34090909090909
10826, 0.15217391304348, 1.35, 0.40909090909091
10827, 0.17391304347826, 1.35, 0.38636363636364
10828, 0.15217391304348, 1.35, 0.45454545454545
10829, 0.17391304347826, 1.35, 0.43181818181818
10830, 0.17391304347826, 1.35, 0.47727272727273
10831, 0.19565217391304, 1.35, 0.045454545454545
10832, 0.21739130434783, 1.35, 0.022727272727273
10833, 0.19565217391304, 1.35, 0.090909090909091
10834, 0.21739130434783, 1.35, 0.068181818181818
10835, 0.19565217391304, 1.35, 0.13636363636364
10836, 0.21739130434783, 1.35, 0.11363636363636
10837, 0.19565217391304, 1.35, 0.18181818181818
10838, 0.21739130434783, 1.35, 0.15909090909091
10839, 0.19565217391304, 1.35, 0.22727272727273
10840, 0.21739130434783, 1.35, 0.20454545454545
10841, 0.19565217391304, 1.35, 0.27272727272727
10842, 0.21739130434783, 1.35, 0.25
10843, 0.19565217391304, 1.35, 0.31818181818182
10844, 0.21739130434783, 1.35, 0.29545454545455
10845, 0.19565217391304, 1.35, 0.36363636363636
10846, 0.21739130434783, 1.35, 0.34090909090909
10847, 0.19565217391304, 1.35, 0.40909090909091
10848, 0.21739130434783, 1.35, 0.38636363636364
10849, 0.19565217391304, 1.35, 0.45454545454545
10850, 0.21739130434783, 1.35, 0.43181818181818
10851, 0.21739130434783, 1.35, 0.47727272727273
10852, 0.23913043478261, 1.35, 0.045454545454545
10853, 0.26086956521739, 1.35, 0.022727272727273
10854, 0.23913043478261, 1.35, 0.090909090909091
10855, 0.26086956521739, 1.35, 0.068181818181818
10856, 0.23913043478261, 1.35, 0.13636363636364
10857, 0.26086956521739, 1.35, 0.11363636363636
10858, 0.23913043478261, 1.35, 0.18181818181818
10859, 0.26086956521739, 1.35, 0.15909090909091
10860, 0.23913043478261, 1.35, 0.22727272727273
10861, 0.26086956521739, 1.35, 0.20454545454545
10862, 0.23913043478261, 1.35, 0.27272727272727
10863, 0.26086956521739, 1.35, 0.25
10864, 0.23913043478261, 1.35, 0.31818181818182
10865, 0.26086956521739, 1.35, 0.29545454545455
10866, 0.23913043478261, 1.35, 0.36363636363636
10867, 0.26086956521739, 1.35, 0.34090909090909
10868, 0.23913043478261, 1.35, 0.40909090909091
10869, 0.26086956521739, 1.35, 0.38636363636364
10870, 0.23913043478261, 1.35, 0.45454545454545
10871, 0.26086956521739, 1.35, 0.43181818181818
10872, 0.26086956521739, 1.35, 0.47727272727273
10873, 0.28260869565217, 1.35, 0.045454545454545
10874, 0.30434782608696, 1.35, 0.022727272727273
10875, 0.28260869565217, 1.35, 0.090909090909091
10876, 0.30434782608696, 1.35, 0.068181818181818
10877, 0.28260869565217, 1.35, 0.13636363636364
10878, 0.30434782608696, 1.35, 0.11363636363636
10879, 0.28260869565217, 1.35, 0.18181818181818
10880, 0.30434782608696, 1.35, 0.15909090909091
10881, 0.28260869565217, 1.35, 0.22727272727273
10882, 0.30434782608696, 1.35, 0.20454545454545
10883, 0.28260869565217, 1.35, 0.27272727272727
10884, 0.30434782608696, 1.35, 0.25
10885, 0.28260869565217, 1.35, 0.31818181818182
10886, 0.30434782608696, 1.35, 0.29545454545455
10887, 0.28260869565217, 1.35, 0.36363636363636
10888, 0.30434782608696, 1.35, 0.34090909090909
10889, 0.28260869565217, 1.35, 0.40909090909091
10890, 0.30434782608696, 1.35, 0.38636363636364
10891, 0.28260869565217, 1.35, 0.45454545454545
10892, 0.30434782608696, 1.35, 0.43181818181818
10893, 0.30434782608696, 1.35, 0.47727272727273
10894, 0.32608695652174, 1.35, 0.045454545454545
10895, 0.34782608695652, 1.35, 0.022727272727273
10896, 0.32608695652174, 1.35, 0.090909090909091
10897, 0.34782608695652, 1.35, 0.068181818181818
10898, 0.32608695652174, 1.35, 0.13636363636364
10899, 0.34782608695652, 1.35, 0.11363636363636
10900, 0.32608695652174, 1.35, 0.18181818181818
10901, 0.34782608695652, 1.35, 0.15909090909091
10902, 0.32608695652174, 1.35, 0.22727272727273
10903, 0.34782608695652, 1.35, 0.20454545454545
10904, 0.32608695652174, 1.35, 0.27272727272727
10905, 0.34782608695652, 1.35, 0.25
10906, 0.32608695652174, 1.35, 0.31818181818182
10907, 0.34782608695652, 1.35, 0.29545454545455
10908, 0.32608695652174, 1.35, 0.36363636363636
10909, 0.34782608695652, 1.35, 0.34090909090909
10910, 0.32608695652174, 1.35, 0.40909090909091
10911, 0.34782608695652, 1.35, 0.38636363636364
10912, 0.32608695652174, 1.35, 0.45454545454545
10913, 0.34782608695652, 1.35, 0.43181818181818
10914, 0.34782608695652, 1.35, 0.47727272727273
10915, 0.3695652173913, 1.35, 0.045454545454545
10916, 0.39130434782609, 1.35, 0.022727272727273
10917, 0.3695652173913, 1.35, 0.090909090909091
10918, 0.39130434782609, 1.35, 0.068181818181818
10919, 0.3695652173913, 1.35, 0.13636363636364
10920, 0.39130434782609, 1.35, 0.11363636363636
10921, 0.3695652173913, 1.35, 0.18181818181818
10922, 0.39130434782609, 1.35, 0.15909090909091
10923, 0.3695652173913, 1.35, 0.22727272727273
10924, 0.39130434782609, 1.35, 0.20454545454545
10925, 0.3695652173913, 1.35, 0.27272727272727
10926, 0.39130434782609, 1.35, 0.25
10927, 0.3695652173913, 1.35, 0.31818181818182
10928, 0.39130434782609, 1.35, 0.29545454545455
10929, 0.3695652173913, 1.35, 0.36363636363636
10930, 0.39130434782609, 1.35, 0.34090909090909
10931, 0.3695652173913, 1.35, 0.40909090909091
10932, 0.39130434782609, 1.35, 0.38636363636364
10933, 0.3695652173913, 1.35, 0.45454545454545
10934, 0.39130434782609, 1.35, 0.43181818181818
10935, 0.39130434782609, 1.35, 0.47727272727273
10936, 0.41304347826087, 1.35, 0.045454545454545
10937, 0.43478260869565, 1.35, 0.022727272727273
10938, 0.41304347826087, 1.35, 0.090909090909091
10939, 0.43478260869565, 1.35, 0.068181818181818
10940, 0.41304347826087, 1.35, 0.13636363636364
10941, 0.43478260869565, 1.35, 0.11363636363636
10942, 0.41304347826087, 1.35, 0.18181818181818
10943, 0.43478260869565, 1.35, 0.15909090909091
10944, 0.41304347826087, 1.35, 0.22727272727273
10945, 0.43478260869565, 1.35, 0.20454545454545
10946, 0.41304347826087, 1.35, 0.27272727272727
10947, 0.43478260869565, 1.35, 0.25
10948, 0.41304347826087, 1.35, 0.31818181818182
10949, 0.43478260869565, 1.35, 0.29545454545455
10950, 0.41304347826087, 1.35, 0.36363636363636
10951, 0.43478260869565, 1.35, 0.34090909090909
10952, 0.41304347826087, 1.35, 0.40909090909091
10953, 0.43478260869565, 1.35, 0.38636363636364
10954, 0.41304347826087, 1.35, 0.45454545454545
10955, 0.43478260869565, 1.35, 0.43181818181818
10956, 0.43478260869565, 1.35, 0.47727272727273
10957, 0.45652173913043, 1.35, 0.045454545454545
10958, 0.47826086956522, 1.35, 0.022727272727273
10959, 0.45652173913043, 1.35, 0.090909090909091
10960, 0.47826086956522, 1.35, 0.068181818181818
10961, 0.45652173913043, 1.35, 0.13636363636364
10962, 0.47826086956522, 1.35, 0.11363636363636
10963, 0.45652173913043, 1.35, 0.18181818181818
10964, 0.47826086956522, 1.35, 0.15909090909091
10965, 0.45652173913043, 1.35, 0.22727272727273
10966, 0.47826086956522, 1.35, 0.20454545454545
10967, 0.45652173913043, 1.35, 0.27272727272727
10968, 0.47826086956522, 1.35, 0.25
10969, 0.45652173913043, 1.35, 0.31818181818182
10970, 0.47826086956522, 1.35, 0.29545454545455
10971, 0.45652173913043, 1.35, 0.36363636363636
10972, 0.47826086956522, 1.35, 0.34090909090909
10973, 0.45652173913043, 1.35, 0.40909090909091
10974, 0.47826086956522, 1.35, 0.38636363636364
10975, 0.45652173913043, 1.35, 0.45454545454545
10976, 0.47826086956522, 1.35, 0.43181818181818
10977, 0.47826086956522, 1.35, 0.47727272727273
10978, 0.5, 1.35, 0.045454545454545
10979, 0.52173913043478, 1.35, 0.022727272727273
10980, 0.5, 1.35, 0.090909090909091
10981, 0.52173913043478, 1.35, 0.068181818181818
10982, 0.5, 1.35, 0.13636363636364
10983, 0.52173913043478, 1.35, 0.11363636363636
10984, 0.5, 1.35, 0.18181818181818
10985, 0.52173913043478, 1.35, 0.15909090909091
10986, 0.5, 1.35, 0.22727272727273
10987, 0.52173913043478, 1.35, 0.20454545454545
10988, 0.5, 1.35, 0.27272727272727
10989, 0.52173913043478, 1.35, 0.25
10990, 0.5, 1.35, 0.31818181818182
10991, 0.52173913043478, 1.35, 0.29545454545455
10992, 0.5, 1.35, 0.36363636363636
10993, 0.52173913043478, 1.35, 0.34090909090909
10994, 0.5, 1.35, 0.40909090909091
10995, 0.52173913043478, 1.35, 0.38636363636364
10996, 0.5, 1.35, 0.45454545454545
10997, 0.52173913043478, 1.35, 0.43181818181818
10998, 0.52173913043478, 1.35, 0.47727272727273
10999, 0.54347826086957, 1.35, 0.045454545454545
11000, 0.56521739130435, 1.35, 0.022727272727273
11001, 0.54347826086957, 1.35, 0.090909090909091
11002, 0.56521739130435, 1.35, 0.068181818181818
11003, 0.54347826086957, 1.35, 0.13636363636364
11004, 0.56521739130435, 1.35, 0.11363636363636
11005, 0.54347826086957, 1.35, 0.18181818181818
11006, 0.56521739130435, 1.35, 0.15909090909091
11007, 0.54347826086957, 1.35, 0.22727272727273
11008, 0.56521739130435, 1.35, 0.20454545454545
11009, 0.54347826086957, 1.35, 0.27272727272727
11010, 0.56521739130435, 1.35, 0.25
11011, 0.54347826086957, 1.35, 0.31818181818182
11012, 0.56521739130435, 1.35, 0.29545454545455
11013, 0.54347826086957, 1.35, 0.36363636363636
11014, 0.56521739130435, 1.35, 0.34090909090909
11015, 0.54347826086957, 1.35, 0.40909090909091
11016, 0.56521739130435, 1.35, 0.38636363636364
11017, 0.54347826086957, 1.35, 0.45454545454545
11018, 0.56521739130435, 1.35, 0.43181818181818
11019, 0.56521739130435, 1.35, 0.47727272727273
11020, 0.58695652173913, 1.35, 0.045454545454545
11021, 0.60869565217391, 1.35, 0.022727272727273
11022, 0.58695652173913, 1.35, 0.090909090909091
11023, 0.60869565217391, 1.35, 0.068181818181818
11024, 0.58695652173913, 1.35, 0.13636363636364
11025, 0.60869565217391, 1.35, 0.11363636363636
11026, 0.58695652173913, 1.35, 0.18181818181818
11027, 0.60869565217391, 1.35, 0.15909090909091
11028, 0.58695652173913, 1.35, 0.22727272727273
11029, 0.60869565217391, 1.35, 0.20454545454545
11030, 0.58695652173913, 1.35, 0.27272727272727
11031, 0.60869565217391, 1.35, 0.25
11032, 0.58695652173913, 1.35, 0.31818181818182
11033, 0.60869565217391, 1.35, 0.29545454545455
11034, 0.58695652173913, 1.35, 0.36363636363636
11035, 0.60869565217391, 1.35, 0.34090909090909
11036, 0.58695652173913, 1.35, 0.40909090909091
11037, 0.60869565217391, 1.35, 0.38636363636364
11038, 0.58695652173913, 1.35, 0.45454545454545
11039, 0.60869565217391, 1.35, 0.43181818181818
11040, 0.60869565217391, 1.35, 0.47727272727273
11041, 0.6304347826087, 1.35, 0.045454545454545
11042, 0.65217391304348, 1.35, 0.022727272727273
11043, 0.6304347826087, 1.35, 0.090909090909091
11044, 0.65217391304348, 1.35, 0.068181818181818
11045, 0.6304347826087, 1.35, 0.13636363636364
11046, 0.65217391304348, 1.35, 0.11363636363636
11047, 0.6304347826087, 1.35, 0.18181818181818
11048, 0.65217391304348, 1.35, 0.15909090909091
11049, 0.6304347826087, 1.35, 0.22727272727273
11050, 0.65217391304348, 1.35, 0.20454545454545
11051, 0.6304347826087, 1.35, 0.27272727272727
11052, 0.65217391304348, 1.35, 0.25
11053, 0.6304347826087, 1.35, 0.31818181818182
11054, 0.65217391304348, 1.35, 0.29545454545455
11055, 0.6304347826087, 1.35, 0.36363636363636
11056, 0.65217391304348, 1.35, 0.34090909090909
11057, 0.6304347826087, 1.35, 0.40909090909091
11058, 0.65217391304348, 1.35, 0.38636363636364
11059, 0.6304347826087, 1.35, 0.45454545454545
11060, 0.65217391304348, 1.35, 0.43181818181818
11061, 0.65217391304348, 1.35, 0.47727272727273
11062, 0.67391304347826, 1.35, 0.045454545454545
11063, 0.69565217391304, 1.35, 0.022727272727273
11064, 0.67391304347826, 1.35, 0.090909090909091
11065, 0.69565217391304, 1.35, 0.068181818181818
11066, 0.67391304347826, 1.35, 0.13636363636364
11067, 0.69565217391304, 1.35, 0.11363636363636
11068, 0.67391304347826, 1.35, 0.18181818181818
11069, 0.69565217391304, 1.35, 0.15909090909091
11070, 0.67391304347826, 1.35, 0.22727272727273
11071, 0.69565217391304, 1.35, 0.20454545454545
11072, 0.67391304347826, 1.35, 0.27272727272727
11073, 0.69565217391304, 1.35, 0.25
11074, 0.67391304347826, 1.35, 0.31818181818182
11075, 0.69565217391304, 1.35, 0.29545454545455
11076, 0.67391304347826, 1.35, 0.36363636363636
11077, 0.69565217391304, 1.35, 0.34090909090909
11078, 0.67391304347826, 1.35, 0.40909090909091
11079, 0.69565217391304, 1.35, 0.38636363636364
11080, 0.67391304347826, 1.35, 0.45454545454545
11081, 0.69565217391304, 1.35, 0.43181818181818
11082, 0.69565217391304, 1.35, 0.47727272727273
11083, 0.71739130434783, 1.35, 0.045454545454545
11084, 0.73913043478261, 1.35, 0.022727272727273
11085, 0.71739130434783, 1.35, 0.090909090909091
11086, 0.73913043478261, 1.35, 0.068181818181818
11087, 0.71739130434783, 1.35, 0.13636363636364
11088, 0.73913043478261, 1.35, 0.11363636363636
11089, 0.71739130434783, 1.35, 0.18181818181818
11090, 0.73913043478261, 1.35, 0.15909090909091
11091, 0.71739130434783, 1.35, 0.22727272727273
11092, 0.73913043478261, 1.35, 0.20454545454545
11093, 0.71739130434783, 1.35, 0.27272727272727
11094, 0.73913043478261, 1.35, 0.25
11095, 0.71739130434783, 1.35, 0.31818181818182
11096, 0.73913043478261, 1.35, 0.29545454545455
11097, 0.71739130434783, 1.35, 0.36363636363636
11098, 0.73913043478261, 1.35, 0.34090909090909
11099, 0.71739130434783, 1.35, 0.40909090909091
11100, 0.73913043478261, 1.35, 0.38636363636364
11101, 0.71739130434783, 1.35, 0.45454545454545
11102, 0.73913043478261, 1.35, 0.43181818181818
11103, 0.73913043478261, 1.35, 0.47727272727273
11104, 0.76086956521739, 1.35, 0.045454545454545
11105, 0.78260869565217, 1.35, 0.022727272727273
11106, 0.76086956521739, 1.35, 0.090909090909091
11107, 0.78260869565217, 1.35, 0.068181818181818
11108, 0.76086956521739, 1.35, 0.13636363636364
11109, 0.78260869565217, 1.35, 0.11363636363636
11110, 0.76086956521739, 1.35, 0.18181818181818
11111, 0.78260869565217, 1.35, 0.15909090909091
11112, 0.76086956521739, 1.35, 0.22727272727273
11113, 0.78260869565217, 1.35, 0.20454545454545
11114, 0.76086956521739, 1.35, 0.27272727272727
11115, 0.78260869565217, 1.35, 0.25
11116, 0.76086956521739, 1.35, 0.31818181818182
11117, 0.78260869565217, 1.35, 0.29545454545455
11118, 0.76086956521739, 1.35, 0.36363636363636
11119, 0.78260869565217, 1.35, 0.34090909090909
11120, 0.76086956521739, 1.35, 0.40909090909091
11121, 0.78260869565217, 1.35, 0.38636363636364
11122, 0.76086956521739, 1.35, 0.45454545454545
11123, 0.78260869565217, 1.35, 0.43181818181818
11124, 0.78260869565217, 1.35, 0.47727272727273
11125, 0.80434782608696, 1.35, 0.045454545454545
11126, 0.82608695652174, 1.35, 0.022727272727273
11127, 0.80434782608696, 1.35, 0.090909090909091
11128, 0.82608695652174, 1.35, 0.068181818181818
11129, 0.80434782608696, 1.35, 0.13636363636364
11130, 0.82608695652174, 1.35, 0.11363636363636
11131, 0.80434782608696, 1.35, 0.18181818181818
11132, 0.82608695652174, 1.35, 0.15909090909091
11133, 0.80434782608696, 1.35, 0.22727272727273
11134, 0.82608695652174, 1.35, 0.20454545454545
11135, 0.80434782608696, 1.35, 0.27272727272727
11136, 0.82608695652174, 1.35, 0.25
11137, 0.80434782608696, 1.35, 0.31818181818182
11138, 0.82608695652174, 1.35, 0.29545454545455
11139, 0.80434782608696, 1.35, 0.36363636363636
11140, 0.82608695652174, 1.35, 0.34090909090909
11141, 0.80434782608696, 1.35, 0.40909090909091
11142, 0.82608695652174, 1.35, 0.38636363636364
11143, 0.80434782608696, 1.35, 0.45454545454545
11144, 0.82608695652174, 1.35, 0.43181818181818
11145, 0.82608695652174, 1.35, 0.47727272727273
11146, 0.84782608695652, 1.35, 0.045454545454545
11147, 0.8695652173913, 1.35, 0.022727272727273
11148, 0.84782608695652, 1.35, 0.090909090909091
11149, 0.8695652173913, 1.35, 0.068181818181818
11150, 0.84782608695652, 1.35, 0.13636363636364
11151, 0.8695652173913, 1.35, 0.11363636363636
11152, 0.84782608695652, 1.35, 0.18181818181818
11153, 0.8695652173913, 1.35, 0.15909090909091
11154, 0.84782608695652, 1.35, 0.22727272727273
11155, 0.8695652173913, 1.35, 0.20454545454545
11156, 0.84782608695652, 1.35, 0.27272727272727
11157, 0.8695652173913, 1.35, 0.25
11158, 0.84782608695652, 1.35, 0.31818181818182
11159, 0.8695652173913, 1.35, 0.29545454545455
11160, 0.84782608695652, 1.35, 0.36363636363636
11161, 0.8695652173913, 1.35, 0.34090909090909
11162, 0.84782608695652, 1.35, 0.40909090909091
11163, 0.8695652173913, 1.35, 0.38636363636364
11164, 0.84782608695652, 1.35, 0.45454545454545
11165, 0.8695652173913, 1.35, 0.43181818181818
11166, 0.8695652173913, 1.35, 0.47727272727273
11167, 0.89130434782609, 1.35, 0.045454545454545
11168, 0.91304347826087, 1.35, 0.022727272727273
11169, 0.89130434782609, 1.35, 0.090909090909091
11170, 0.91304347826087, 1.35, 0.068181818181818
11171, 0.89130434782609, 1.35, 0.13636363636364
11172, 0.91304347826087, 1.35, 0.11363636363636
11173, 0.89130434782609, 1.35, 0.18181818181818
11174, 0.91304347826087, 1.35, 0.15909090909091
11175, 0.89130434782609, 1.35, 0.22727272727273
11176, 0.91304347826087, 1.35, 0.20454545454545
11177, 0.89130434782609, 1.35, 0.27272727272727
11178, 0.91304347826087, 1.35, 0.25
11179, 0.89130434782609, 1.35, 0.31818181818182
11180, 0.91304347826087, 1.35, 0.29545454545455
11181, 0.89130434782609, 1.35, 0.36363636363636
11182, 0.91304347826087, 1.35, 0.34090909090909
11183, 0.89130434782609, 1.35, 0.40909090909091
11184, 0.91304347826087, 1.35, 0.38636363636364
11185, 0.89130434782609, 1.35, 0.45454545454545
11186, 0.91304347826087, 1.35, 0.43181818181818
11187, 0.91304347826087, 1.35, 0.47727272727273
11188, 0.93478260869565, 1.35, 0.045454545454545
11189, 0.95652173913043, 1.35, 0.022727272727273
11190, 0.93478260869565, 1.35, 0.090909090909091
11191, 0.95652173913043, 1.35, 0.068181818181818
11192, 0.93478260869565, 1.35, 0.13636363636364
11193, 0.95652173913044, 1.35, 0.11363636363636
11194, 0.93478260869565, 1.35, 0.18181818181818
11195, 0.95652173913043, 1.35, 0.15909090909091
11196, 0.93478260869565, 1.35, 0.22727272727273
11197, 0.95652173913043, 1.35, 0.20454545454545
11198, 0.93478260869565, 1.35, 0.27272727272727
11199, 0.95652173913043, 1.35, 0.25
11200, 0.93478260869565, 1.35, 0.31818181818182
11201, 0.95652173913043, 1.35, 0.29545454545455
11202, 0.93478260869565, 1.35, 0.36363636363636
11203, 0.95652173913043, 1.35, 0.34090909090909
11204, 0.93478260869565, 1.35, 0.40909090909091
11205, 0.95652173913043, 1.35, 0.38636363636364
11206, 0.93478260869565, 1.35, 0.45454545454545
11207, 0.95652173913043, 1.35, 0.43181818181818
11208, 0.95652173913043, 1.35, 0.47727272727273
11209, 0.97826086956522, 1.35, 0.045454545454545
11210, 0.97826086956522, 1.35, 0.090909090909091
11211, 0.97826086956522, 1.35, 0.13636363636364
11212, 0.97826086956522, 1.35, 0.18181818181818
11213, 0.97826086956522, 1.35, 0.22727272727273
11214, 0.97826086956522, 1.35, 0.27272727272727
11215, 0.97826086956522, 1.35, 0.31818181818182
11216, 0.97826086956522, 1.35, 0.36363636363636
11217, 0.97826086956522, 1.35, 0.40909090909091
11218, 0.97826086956522, 1.35, 0.45454545454545
11219, 0.95652173913043, 1.375, 0
11220, 0.91304347826087, 1.375, 0
11221, 0.8695652173913, 1.375, 0
11222, 0.82608695652174, 1.375, 0
11223, 0.78260869565217, 1.375, 0
11224, 0.73913043478261, 1.375, 0
11225, 0.69565217391304, 1.375, 0
11226, 0.65217391304348, 1.375, 0
11227, 0.60869565217391, 1.375, 0
11228, 0.56521739130435, 1.375, 0
11229, 0.52173913043478, 1.375, 0
11230, 0.47826086956522, 1.375, 0
11231, 0.43478260869565, 1.375, 0
11232, 0.39130434782609, 1.375, 0
11233, 0.34782608695652, 1.375, 0
11234, 0.30434782608696, 1.375, 0
11235, 0.26086956521739, 1.375, 0
11236, 0.21739130434783, 1.375, 0
11237, 0.17391304347826, 1.375, 0
11238, 0.1304347826087, 1.375, 0
11239, 0.08695652173913, 1.375, 0
11240, 0.043478260869565, 1.375, 0
11241, 0.95652173913043, 1.3625, 0
11242, 0.97826086956522, 1.375, 0
11243, 0.91304347826087, 1.3625, 0
11244, 0.93478260869565, 1.375, 0
11245, 0.8695652173913, 1.3625, 0
11246, 0.89130434782609, 1.375, 0
11247, 0.82608695652174, 1.3625, 0
11248, 0.84782608695652, 1.375, 0
11249, 0.78260869565217, 1.3625, 0
11250, 0.80434782608696, 1.375, 0
11251, 0.73913043478261, 1.3625, 0
11252, 0.76086956521739, 1.375, 0
11253, 0.69565217391304, 1.3625, 0
11254, 0.71739130434783, 1.375, 0
11255, 0.65217391304348, 1.3625, 0
11256, 0.67391304347826, 1.375, 0
11257, 0.60869565217391, 1.3625, 0
11258, 0.6304347826087, 1.375, 0
11259, 0.56521739130435, 1.3625, 0
11260, 0.58695652173913, 1.375, 0
11261, 0.52173913043478, 1.3625, 0
11262, 0.54347826086957, 1.375, 0
11263, 0.47826086956522, 1.3625, 0
11264, 0.5, 1.375, 0
11265, 0.43478260869565, 1.3625, 0
11266, 0.45652173913043, 1.375, 0
11267, 0.39130434782609, 1.3625, 0
11268, 0.41304347826087, 1.375, 0
11269, 0.34782608695652, 1.3625, 0
11270, 0.3695652173913, 1.375, 0
11271, 0.30434782608696, 1.3625, 0
11272, 0.32608695652174, 1.375, 0
11273, 0.26086956521739, 1.3625, 0
11274, 0.28260869565217, 1.375, 0
11275, 0.21739130434783, 1.3625, 0
11276, 0.23913043478261, 1.375, 0
11277, 0.17391304347826, 1.3625, 0
11278, 0.19565217391304, 1.375, 0
11279, 0.1304347826087, 1.3625, 0
11280, 0.15217391304348, 1.375, 0
11281, 0.08695652173913, 1.3625, 0
11282, 0.10869565217391, 1.375, 0
11283, 0.043478260869565, 1.3625, 0
11284, 0.065217391304348, 1.375, 0
11285, 0.021739130434783, 1.375, 0
11286, 0.95652173913043, 1.3875, 0
11287, 0.91304347826087, 1.3875, 0
11288, 0.8695652173913, 1.3875, 0
11289, 0.82608695652174, 1.3875, 0
11290, 0.78260869565217, 1.3875, 0
11291, 0.73913043478261, 1.3875, 0
11292, 0.69565217391304, 1.3875, 0
11293, 0.65217391304348, 1.3875, 0
11294, 0.60869565217391, 1.3875, 0
11295, 0.56521739130435, 1.3875, 0
11296, 0.52173913043478, 1.3875, 0
11297, 0.47826086956522, 1.3875, 0
11298, 0.43478260869565, 1.3875, 0
11299, 0.39130434782609, 1.3875, 0
11300, 0.34782608695652, 1.3875, 0
11301, 0.30434782608696, 1.3875, 0
11302, 0.26086956521739, 1.3875, 0
11303, 0.21739130434783, 1.3875, 0
11304, 0.17391304347826, 1.3875, 0
11305, 0.1304347826087, 1.3875, 0
11306, 0.08695652173913, 1.3875, 0
11307, 0.043478260869565, 1.3875, 0
11308, 1, 1.375, 0.45454545454545
11309, 1, 1.375, 0.40909090909091
11310, 1, 1.375, 0.36363636363636
11311, 1, 1.375, 0.31818181818182
11312, 1, 1.375, 0.27272727272727
11313, 1, 1.375, 0.22727272727273
11314, 1, 1.375, 0.18181818181818
11315, 1, 1.375, 0.13636363636364
11316, 1, 1.375, 0.090909090909091
11317, 1, 1.375, 0.045454545454545
11318, 1, 1.3625, 0.45454545454545
11319, 1, 1.375, 0.47727272727273
11320, 1, 1.3625, 0.40909090909091
11321, 1, 1.375, 0.43181818181818
11322, 1, 1.3625, 0.36363636363636
11323, 1, 1.375, 0.38636363636364
11324, 1, 1.3625, 0.31818181818182
11325, 1, 1.375, 0.34090909090909
11326, 1, 1.3625, 0.27272727272727
11327, 1, 1.375, 0.29545454545455
11328, 1, 1.3625, 0.22727272727273
11329, 1, 1.375, 0.25
11330, 1, 1.3625, 0.18181818181818
11331, 1, 1.375, 0.20454545454545
11332, 1, 1.3625, 0.13636363636364
11333, 1, 1.375, 0.15909090909091
11334, 1, 1.3625, 0.090909090909091
11335, 1, 1.375, 0.11363636363636
11336, 1, 1.3625, 0.045454545454545
11337, 1, 1.375, 0.068181818181818
11338, 1, 1.375, 0.022727272727273
11339, 1, 1.3875, 0.45454545454545
11340, 1, 1.3875, 0.40909090909091
11341, 1, 1.3875, 0.36363636363636
11342, 1, 1.3875, 0.31818181818182
11343, 1, 1.3875, 0.27272727272727
11344, 1, 1.3875, 0.22727272727273
11345, 1, 1.3875, 0.18181818181818
11346, 1, 1.3875, 0.13636363636364
11347, 1, 1.3875, 0.090909090909091
11348, 1, 1.3875, 0.045454545454545
11349, 0.95652173913043, 1.375, 0.5
11350, 0.91304347826087, 1.375, 0.5
11351, 0.8695652173913, 1.375, 0.5
11352, 0.82608695652174, 1.375, 0.5
11353, 0.78260869565217, 1.375, 0.5
11354, 0.73913043478261, 1.375, 0.5
11355, 0.69565217391304, 1.375, 0.5
11356, 0.65217391304348, 1.375, 0.5
11357, 0.60869565217391, 1.375, 0.5
11358, 0.56521739130435, 1.375, 0.5
11359, 0.52173913043478, 1.375, 0.5
11360, 0.47826086956522, 1.375, 0.5
11361, 0.43478260869565, 1.375, 0.5
11362, 0.39130434782609, 1.375, 0.5
11363, 0.34782608695652, 1.375, 0.5
11364, 0.30434782608696, 1.375, 0.5
11365, 0.26086956521739, 1.375, 0.5
11366, 0.21739130434783, 1.375, 0.5
11367, 0.17391304347826, 1.375, 0.5
11368, 0.1304347826087, 1.375, 0.5
11369, 0.08695652173913, 1.375, 0.5
11370, 0.043478260869565, 1.375, 0.5
11371, 0.97826086956522, 1.375, 0.5
11372, 0.95652173913043, 1.3625, 0.5
11373, 0.93478260869565, 1.375, 0.5
11374, 0.91304347826087, 1.3625, 0.5
11375, 0.89130434782609, 1.375, 0.5
11376, 0.8695652173913, 1.3625, 0.5
11377, 0.84782608695652, 1.375, 0.5
11378, 0.82608695652174, 1.3625, 0.5
11379, 0.80434782608696, 1.375, 0.5
11380, 0.78260869565217, 1.3625, 0.5
11381, 0.76086956521739, 1.375, 0.5
11382, 0.73913043478261, 1.3625, 0.5
11383, 0.71739130434783, 1.375, 0.5
11384, 0.69565217391304, 1.3625, 0.5
11385, 0.67391304347826, 1.375, 0.5
11386, 0.65217391304348, 1.3625, 0.5
11387, 0.6304347826087, 1.375, 0.5
11388, 0.60869565217391, 1.3625, 0.5
11389, 0.58695652173913, 1.375, 0.5
11390, 0.56521739130435, 1.3625, 0.5
11391, 0.54347826086957, 1.375, 0.5
11392, 0.52173913043478, 1.3625, 0.5
11393, 0.5, 1.375, 0.5
11394, 0.47826086956522, 1.3625, 0.5
11395, 0.45652173913043, 1.375, 0.5
11396, 0.43478260869565, 1.3625, 0.5
11397, 0.41304347826087, 1.375, 0.5
11398, 0.39130434782609, 1.3625, 0.5
11399, 0.3695652173913, 1.375, 0.5
11400, 0.34782608695652, 1.3625, 0.5
11401, 0.32608695652174, 1.375, 0.5
11402, 0.30434782608696, 1.3625, 0.5
11403, 0.28260869565217, 1.375, 0.5
11404, 0.26086956521739, 1.3625, 0.5
11405, 0.23913043478261, 1.375, 0.5
11406, 0.21739130434783, 1.3625, 0.5
11407, 0.19565217391304, 1.375, 0.5
11408, 0.17391304347826, 1.3625, 0.5
11409, 0.15217391304348, 1.375, 0.5
11410, 0.1304347826087, 1.3625, 0.5
11411, 0.10869565217391, 1.375, 0.5
11412, 0.08695652173913, 1.3625, 0.5
11413, 0.065217391304348, 1.375, 0.5
11414, 0.043478260869565, 1.3625, 0.5
11415, 0.021739130434783, 1.375, 0.5
11416, 0.95652173913043, 1.3875, 0.5
11417, 0.91304347826087, 1.3875, 0.5
11418, 0.8695652173913, 1.3875, 0.5
11419, 0.82608695652174, 1.3875, 0.5
11420, 0.78260869565217, 1.3875, 0.5
11421, 0.73913043478261, 1.3875, 0.5
11422, 0.69565217391304, 1.3875, 0.5
11423, 0.65217391304348, 1.3875, 0.5
11424, 0.60869565217391, 1.3875, 0.5
11425, 0.56521739130435, 1.3875, 0.5
11426, 0.52173913043478, 1.3875, 0.5
11427, 0.47826086956522, 1.3875, 0.5
11428, 0.43478260869565, 1.3875, 0.5
11429, 0.39130434782609, 1.3875, 0.5
11430, 0.34782608695652, 1.3875, 0.5
11431, 0.30434782608696, 1.3875, 0.5
11432, 0.26086956521739, 1.3875, 0.5
11433, 0.21739130434783, 1.3875, 0.5
11434, 0.17391304347826, 1.3875, 0.5
11435, 0.1304347826087, 1.3875, 0.5
11436, 0.08695652173913, 1.3875, 0.5
11437, 0.043478260869565, 1.3875, 0.5
11438, 0, 1.375, 0.45454545454545
11439, 0, 1.375, 0.40909090909091
11440, 0, 1.375, 0.36363636363636
11441, 0, 1.375, 0.31818181818182
11442, 0, 1.375, 0.27272727272727
11443, 0, 1.375, 0.22727272727273
11444, 0, 1.375, 0.18181818181818
11445, 0, 1.375, 0.13636363636364
11446, 0, 1.375, 0.090909090909091
11447, 0, 1.375, 0.045454545454545
11448, 0, 1.375, 0.47727272727273
11449, 0, 1.3625, 0.45454545454545
11450, 0, 1.375, 0.43181818181818
11451, 0, 1.3625, 0.40909090909091
11452, 0, 1.375, 0.38636363636364
11453, 0, 1.3625, 0.36363636363636
11454, 0, 1.375, 0.34090909090909
11455, 0, 1.3625, 0.31818181818182
11456, 0, 1.375, 0.29545454545455
11457, 0, 1.3625, 0.27272727272727
11458, 0, 1.375, 0.25
11459, 0, 1.3625, 0.22727272727273
11460, 0, 1.375, 0.20454545454545
11461, 0, 1.3625, 0.18181818181818
11462, 0, 1.375, 0.15909090909091
11463, 0, 1.3625, 0.13636363636364
11464, 0, 1.375, 0.11363636363636
11465, 0, 1.3625, 0.090909090909091
11466, 0, 1.375, 0.068181818181818
11467, 0, 1.3625, 0.045454545454545
11468, 0, 1.375, 0.022727272727273
11469, 0, 1.3875, 0.45454545454545
11470, 0, 1.3875, 0.40909090909091
11471, 0, 1.3875, 0.36363636363636
11472, 0, 1.3875, 0.31818181818182
11473, 0, 1.3875, 0.27272727272727
11474, 0, 1.3875, 0.22727272727273
11475, 0, 1.3875, 0.18181818181818
11476, 0, 1.3875, 0.13636363636364
11477, 0, 1.3875, 0.090909090909091
11478, 0, 1.3875, 0.045454545454545
11479, 0.043478260869565, 1.4, 0.045454545454545
11480, 0.043478260869565, 1.4, 0.090909090909091
11481, 0.043478260869565, 1.4, 0.13636363636364
11482, 0.043478260869565, 1.4, 0.18181818181818
11483, 0.043478260869565, 1.4, 0.22727272727273
11484, 0.043478260869565, 1.4, 0.27272727272727
11485, 0.043478260869565, 1.4, 0.31818181818182
11486, 0.043478260869565, 1.4, 0.36363636363636
11487, 0.043478260869565, 1.4, 0.40909090909091
11488, 0.043478260869565, 1.4, 0.45454545454545
11489, 0.08695652173913, 1.4, 0.045454545454545
11490, 0.08695652173913, 1.4, 0.090909090909091
11491, 0.08695652173913, 1.4, 0.13636363636364
11492, 0.08695652173913, 1.4, 0.18181818181818
11493, 0.08695652173913, 1.4, 0.22727272727273
11494, 0.08695652173913, 1.4, 0.27272727272727
11495, 0.08695652173913, 1.4, 0.31818181818182
11496, 0.08695652173913, 1.4, 0.36363636363636
11497, 0.08695652173913, 1.4, 0.40909090909091
11498, 0.08695652173913, 1.4, 0.45454545454545
11499, 0.1304347826087, 1.4, 0.045454545454545
11500, 0.1304347826087, 1.4, 0.090909090909091
11501, 0.1304347826087, 1.4, 0.13636363636364
11502, 0.1304347826087, 1.4, 0.18181818181818
11503, 0.1304347826087, 1.4, 0.22727272727273
11504, 0.1304347826087, 1.4, 0.27272727272727
11505, 0.1304347826087, 1.4, 0.31818181818182
11506, 0.1304347826087, 1.4, 0.36363636363636
11507, 0.1304347826087, 1.4, 0.40909090909091
11508, 0.1304347826087, 1.4, 0.45454545454545
11509, 0.17391304347826, 1.4, 0.045454545454545
11510, 0.17391304347826, 1.4, 0.090909090909091
11511, 0.17391304347826, 1.4, 0.13636363636364
11512, 0.17391304347826, 1.4, 0.18181818181818
11513, 0.17391304347826, 1.4, 0.22727272727273
11514, 0.17391304347826, 1.4, 0.27272727272727
11515, 0.17391304347826, 1.4, 0.31818181818182
11516, 0.17391304347826, 1.4, 0.36363636363636
11517, 0.17391304347826, 1.4, 0.40909090909091
11518, 0.17391304347826, 1.4, 0.45454545454545
11519, 0.21739130434783, 1.4, 0.045454545454545
11520, 0.21739130434783, 1.4, 0.090909090909091
11521, 0.21739130434783, 1.4, 0.13636363636364
11522, 0.21739130434783, 1.4, 0.18181818181818
11523, 0.21739130434783, 1.4, 0.22727272727273
11524, 0.21739130434783, 1.4, 0.27272727272727
11525, 0.21739130434783, 1.4, 0.31818181818182
11526, 0.21739130434783, 1.4, 0.36363636363636
11527, 0.21739130434783, 1.4, 0.40909090909091
11528, 0.21739130434783, 1.4, 0.45454545454545
11529, 0.26086956521739, 1.4, 0.045454545454545
11530, 0.26086956521739, 1.4, 0.090909090909091
11531, 0.26086956521739, 1.4, 0.13636363636364
11532, 0.26086956521739, 1.4, 0.18181818181818
11533, 0.26086956521739, 1.4, 0.22727272727273
11534, 0.26086956521739, 1.4, 0.27272727272727
11535, 0.26086956521739, 1.4, 0.31818181818182
11536, 0.26086956521739, 1.4, 0.36363636363636
11537, 0.26086956521739, 1.4, 0.40909090909091
11538, 0.26086956521739, 1.4, 0.45454545454545
11539, 0.30434782608696, 1.4, 0.045454545454545
11540, 0.30434782608696, 1.4, 0.090909090909091
11541, 0.30434782608696, 1.4, 0.13636363636364
11542, 0.30434782608696, 1.4, 0.18181818181818
11543, 0.30434782608696, 1.4, 0.22727272727273
11544, 0.30434782608696, 1.4, 0.27272727272727
11545, 0.30434782608696, 1.4, 0.31818181818182
11546, 0.30434782608696, 1.4, 0.36363636363636
11547, 0.30434782608696, 1.4, 0.40909090909091
11548, 0.30434782608696, 1.4, 0.45454545454545
11549, 0.34782608695652, 1.4, 0.045454545454545
11550, 0.34782608695652, 1.4, 0.090909090909091
11551, 0.34782608695652, 1.4, 0.13636363636364
11552, 0.34782608695652, 1.4, 0.18181818181818
11553, 0.34782608695652, 1.4, 0.22727272727273
11554, 0.34782608695652, 1.4, 0.27272727272727
11555, 0.34782608695652, 1.4, 0.31818181818182
11556, 0.34782608695652, 1.4, 0.36363636363636
11557, 0.34782608695652, 1.4, 0.40909090909091
11558, 0.34782608695652, 1.4, 0.45454545454545
11559, 0.39130434782609, 1.4, 0.045454545454545
11560, 0.39130434782609, 1.4, 0.090909090909091
11561, 0.39130434782609, 1.4, 0.13636363636364
11562, 0.39130434782609, 1.4, 0.18181818181818
11563, 0.39130434782609, 1.4, 0.22727272727273
11564, 0.39130434782609, 1.4, 0.27272727272727
11565, 0.39130434782609, 1.4, 0.31818181818182
11566, 0.39130434782609, 1.4, 0.36363636363636
11567, 0.39130434782609, 1.4, 0.40909090909091
11568, 0.39130434782609, 1.4, 0.45454545454545
11569, 0.43478260869565, 1.4, 0.045454545454545
11570, 0.43478260869565, 1.4, 0.090909090909091
11571, 0.43478260869565, 1.4, 0.13636363636364
11572, 0.43478260869565, 1.4, 0.18181818181818
11573, 0.43478260869565, 1.4, 0.22727272727273
11574, 0.43478260869565, 1.4, 0.27272727272727
11575, 0.43478260869565, 1.4, 0.31818181818182
11576, 0.43478260869565, 1.4, 0.36363636363636
11577, 0.43478260869565, 1.4, 0.40909090909091
11578, 0.43478260869565, 1.4, 0.45454545454545
11579, 0.47826086956522, 1.4, 0.045454545454545
11580, 0.47826086956522, 1.4, 0.090909090909091
11581, 0.47826086956522, 1.4, 0.13636363636364
11582, 0.47826086956522, 1.4, 0.18181818181818
11583, 0.47826086956522, 1.4, 0.22727272727273
11584, 0.47826086956522, 1.4, 0.27272727272727
11585, 0.47826086956522, 1.4, 0.31818181818182
11586, 0.47826086956522, 1.4, 0.36363636363636
11587, 0.47826086956522, 1.4, 0.40909090909091
11588, 0.47826086956522, 1.4, 0.45454545454545
11589, 0.52173913043478, 1.4, 0.045454545454545
11590, 0.52173913043478, 1.4, 0.090909090909091
11591, 0.52173913043478, 1.4, 0.13636363636364
11592, 0.52173913043478, 1.4, 0.18181818181818
11593, 0.52173913043478, 1.4, 0.22727272727273
11594, 0.52173913043478, 1.4, 0.27272727272727
11595, 0.52173913043478, 1.4, 0.31818181818182
11596, 0.52173913043478, 1.4, 0.36363636363636
11597, 0.52173913043478, 1.4, 0.40909090909091
11598, 0.52173913043478, 1.4, 0.45454545454545
11599, 0.56521739130435, 1.4, 0.045454545454545
11600, 0.56521739130435, 1.4, 0.090909090909091
11601, 0.56521739130435, 1.4, 0.13636363636364
11602, 0.56521739130435, 1.4, 0.18181818181818
11603, 0.56521739130435, 1.4, 0.22727272727273
11604, 0.56521739130435, 1.4, 0.27272727272727
11605, 0.56521739130435, 1.4, 0.31818181818182
11606, 0.56521739130435, 1.4, 0.36363636363636
11607, 0.56521739130435, 1.4, 0.40909090909091
11608, 0.56521739130435, 1.4, 0.45454545454545
11609, 0.60869565217391, 1.4, 0.045454545454545
11610, 0.60869565217391, 1.4, 0.090909090909091
11611, 0.60869565217391, 1.4, 0.13636363636364
11612, 0.60869565217391, 1.4, 0.18181818181818
11613, 0.60869565217391, 1.4, 0.22727272727273
11614, 0.60869565217391, 1.4, 0.27272727272727
11615, 0.60869565217391, 1.4, 0.31818181818182
11616, 0.60869565217391, 1.4, 0.36363636363636
11617, 0.60869565217391, 1.4, 0.40909090909091
11618, 0.60869565217391, 1.4, 0.45454545454545
11619, 0.65217391304348, 1.4, 0.045454545454545
11620, 0.65217391304348, 1.4, 0.090909090909091
11621, 0.65217391304348, 1.4, 0.13636363636364
11622, 0.65217391304348, 1.4, 0.18181818181818
11623, 0.65217391304348, 1.4, 0.22727272727273
11624, 0.65217391304348, 1.4, 0.27272727272727
11625, 0.65217391304348, 1.4, 0.31818181818182
11626, 0.65217391304348, 1.4, 0.36363636363636
11627, 0.65217391304348, 1.4, 0.40909090909091
11628, 0.65217391304348, 1.4, 0.45454545454545
11629, 0.69565217391304, 1.4, 0.045454545454545
11630, 0.69565217391304, 1.4, 0.090909090909091
11631, 0.69565217391304, 1.4, 0.13636363636364
11632, 0.69565217391304, 1.4, 0.18181818181818
11633, 0.69565217391304, 1.4, 0.22727272727273
11634, 0.69565217391304, 1.4, 0.27272727272727
11635, 0.69565217391304, 1.4, 0.31818181818182
11636, 0.69565217391304, 1.4, 0.36363636363636
11637, 0.69565217391304, 1.4, 0.40909090909091
11638, 0.69565217391304, 1.4, 0.45454545454545
11639, 0.73913043478261, 1.4, 0.045454545454545
11640, 0.73913043478261, 1.4, 0.090909090909091
11641, 0.73913043478261, 1.4, 0.13636363636364
11642, 0.73913043478261, 1.4, 0.18181818181818
11643, 0.73913043478261, 1.4, 0.22727272727273
11644, 0.73913043478261, 1.4, 0.27272727272727
11645, 0.73913043478261, 1.4, 0.31818181818182
11646, 0.73913043478261, 1.4, 0.36363636363636
11647, 0.73913043478261, 1.4, 0.40909090909091
11648, 0.73913043478261, 1.4, 0.45454545454545
11649, 0.78260869565217, 1.4, 0.045454545454545
11650, 0.78260869565217, 1.4, 0.090909090909091
11651, 0.78260869565217, 1.4, 0.13636363636364
11652, 0.78260869565217, 1.4, 0.18181818181818
11653, 0.78260869565217, 1.4, 0.22727272727273
11654, 0.78260869565217, 1.4, 0.27272727272727
11655, 0.78260869565217, 1.4, 0.31818181818182
11656, 0.78260869565217, 1.4, 0.36363636363636
11657, 0.78260869565217, 1.4, 0.40909090909091
11658, 0.78260869565217, 1.4, 0.45454545454545
11659, 0.82608695652174, 1.4, 0.045454545454545
11660, 0.82608695652174, 1.4, 0.090909090909091
11661, 0.82608695652174, 1.4, 0.13636363636364
11662, 0.82608695652174, 1.4, 0.18181818181818
11663, 0.82608695652174, 1.4, 0.22727272727273
11664, 0.82608695652174, 1.4, 0.27272727272727
11665, 0.82608695652174, 1.4, 0.31818181818182
11666, 0.82608695652174, 1.4, 0.36363636363636
11667, 0.82608695652174, 1.4, 0.40909090909091
11668, 0.82608695652174, 1.4, 0.45454545454545
11669, 0.8695652173913, 1.4, 0.045454545454545
11670, 0.8695652173913, 1.4, 0.090909090909091
11671, 0.8695652173913, 1.4, 0.13636363636364
11672, 0.8695652173913, 1.4, 0.18181818181818
11673, 0.8695652173913, 1.4, 0.22727272727273
11674, 0.8695652173913, 1.4, 0.27272727272727
11675, 0.8695652173913, 1.4, 0.31818181818182
11676, 0.8695652173913, 1.4, 0.36363636363636
11677, 0.8695652173913, 1.4, 0.40909090909091
11678, 0.8695652173913, 1.4, 0.45454545454545
11679, 0.91304347826087, 1.4, 0.045454545454545
11680, 0.91304347826087, 1.4, 0.090909090909091
11681, 0.91304347826087, 1.4, 0.13636363636364
11682, 0.91304347826087, 1.4, 0.18181818181818
11683, 0.91304347826087, 1.4, 0.22727272727273
11684, 0.91304347826087, 1.4, 0.27272727272727
11685, 0.91304347826087, 1.4, 0.31818181818182
11686, 0.91304347826087, 1.4, 0.36363636363636
11687, 0.91304347826087, 1.4, 0.40909090909091
11688, 0.91304347826087, 1.4, 0.45454545454545
11689, 0.95652173913043, 1.4, 0.045454545454545
11690, 0.95652173913043, 1.4, 0.090909090909091
11691, 0.95652173913044, 1.4, 0.13636363636364
11692, 0.95652173913043, 1.4, 0.18181818181818
11693, 0.95652173913043, 1.4, 0.22727272727273
11694, 0.95652173913043, 1.4, 0.27272727272727
11695, 0.95652173913043, 1.4, 0.31818181818182
11696, 0.95652173913043, 1.4, 0.36363636363636
11697, 0.95652173913043, 1.4, 0.40909090909091
11698, 0.95652173913043, 1.4, 0.45454545454545
11699, 0.021739130434783, 1.4, 0.045454545454545
11700, 0.043478260869565, 1.4, 0.022727272727273
11701, 0.021739130434783, 1.4, 0.090909090909091
11702, 0.043478260869565, 1.4, 0.068181818181818
11703, 0.021739130434783, 1.4, 0.13636363636364
11704, 0.043478260869565, 1.4, 0.11363636363636
11705, 0.021739130434783, 1.4, 0.18181818181818
11706, 0.043478260869565, 1.4, 0.15909090909091
11707, 0.021739130434783, 1.4, 0.22727272727273
11708, 0.043478260869565, 1.4, 0.20454545454545
11709, 0.021739130434783, 1.4, 0.27272727272727
11710, 0.043478260869565, 1.4, 0.25
11711, 0.021739130434783, 1.4, 0.31818181818182
11712, 0.043478260869565, 1.4, 0.29545454545455
11713, 0.021739130434783, 1.4, 0.36363636363636
11714, 0.043478260869565, 1.4, 0.34090909090909
11715, 0.021739130434783, 1.4, 0.40909090909091
11716, 0.043478260869565, 1.4, 0.38636363636364
11717, 0.021739130434783, 1.4, 0.45454545454545
11718, 0.043478260869565, 1.4, 0.43181818181818
11719, 0.043478260869565, 1.4, 0.47727272727273
11720, 0.065217391304348, 1.4, 0.045454545454545
11721, 0.08695652173913, 1.4, 0.022727272727273
11722, 0.065217391304348, 1.4, 0.090909090909091
11723, 0.08695652173913, 1.4, 0.068181818181818
11724, 0.065217391304348, 1.4, 0.13636363636364
11725, 0.08695652173913, 1.4, 0.11363636363636
11726, 0.065217391304348, 1.4, 0.18181818181818
11727, 0.08695652173913, 1.4, 0.15909090909091
11728, 0.065217391304348, 1.4, 0.22727272727273
11729, 0.08695652173913, 1.4, 0.20454545454545
11730, 0.065217391304348, 1.4, 0.27272727272727
11731, 0.08695652173913, 1.4, 0.25
11732, 0.065217391304348, 1.4, 0.31818181818182
11733, 0.08695652173913, 1.4, 0.29545454545455
11734, 0.065217391304348, 1.4, 0.36363636363636
11735, 0.08695652173913, 1.4, 0.34090909090909
11736, 0.065217391304348, 1.4, 0.40909090909091
11737, 0.08695652173913, 1.4, 0.38636363636364
11738, 0.065217391304348, 1.4, 0.45454545454545
11739, 0.08695652173913, 1.4, 0.43181818181818
11740, 0.08695652173913, 1.4, 0.47727272727273
11741, 0.10869565217391, 1.4, 0.045454545454545
11742, 0.1304347826087, 1.4, 0.022727272727273
11743, 0.10869565217391, 1.4, 0.090909090909091
11744, 0.1304347826087, 1.4, 0.068181818181818
11745, 0.10869565217391, 1.4, 0.13636363636364
11746, 0.1304347826087, 1.4, 0.11363636363636
11747, 0.10869565217391, 1.4, 0.18181818181818
11748, 0.1304347826087, 1.4, 0.15909090909091
11749, 0.10869565217391, 1.4, 0.22727272727273
11750, 0.1304347826087, 1.4, 0.20454545454545
11751, 0.10869565217391, 1.4, 0.27272727272727
11752, 0.1304347826087, 1.4, 0.25
11753, 0.10869565217391, 1.4, 0.31818181818182
11754, 0.1304347826087, 1.4, 0.29545454545455
11755, 0.10869565217391, 1.4, 0.36363636363636
11756, 0.1304347826087, 1.4, 0.34090909090909
11757, 0.10869565217391, 1.4, 0.40909090909091
11758, 0.1304347826087, 1.4, 0.38636363636364
11759, 0.10869565217391, 1.4, 0.45454545454545
11760, 0.1304347826087, 1.4, 0.43181818181818
11761, 0.1304347826087, 1.4, 0.47727272727273
11762, 0.15217391304348, 1.4, 0.045454545454545
11763, 0.17391304347826, 1.4, 0.022727272727273
11764, 0.15217391304348, 1.4, 0.090909090909091
11765, 0.17391304347826, 1.4, 0.068181818181818
11766, 0.15217391304348, 1.4, 0.13636363636364
11767, 0.17391304347826, 1.4, 0.11363636363636
11768, 0.15217391304348, 1.4, 0.18181818181818
11769, 0.17391304347826, 1.4, 0.15909090909091
11770, 0.15217391304348, 1.4, 0.22727272727273
11771, 0.17391304347826, 1.4, 0.20454545454545
11772, 0.15217391304348, 1.4, 0.27272727272727
11773, 0.17391304347826, 1.4, 0.25
11774, 0.15217391304348, 1.4, 0.31818181818182
11775, 0.17391304347826, 1.4, 0.29545454545455
11776, 0.15217391304348, 1.4, 0.36363636363636
11777, 0.17391304347826, 1.4, 0.34090909090909
11778, 0.15217391304348, 1.4, 0.40909090909091
11779, 0.17391304347826, 1.4, 0.38636363636364
11780, 0.15217391304348, 1.4, 0.45454545454545
11781, 0.17391304347826, 1.4, 0.43181818181818
11782, 0.17391304347826, 1.4, 0.47727272727273
11783, 0.19565217391304, 1.4, 0.045454545454545
11784, 0.21739130434783, 1.4, 0.022727272727273
11785, 0.19565217391304, 1.4, 0.090909090909091
11786, 0.21739130434783, 1.4, 0.068181818181818
11787, 0.19565217391304, 1.4, 0.13636363636364
11788, 0.21739130434783, 1.4, 0.11363636363636
11789, 0.19565217391304, 1.4, 0.18181818181818
11790, 0.21739130434783, 1.4, 0.15909090909091
11791, 0.19565217391304, 1.4, 0.22727272727273
11792, 0.21739130434783, 1.4, 0.20454545454545
11793, 0.19565217391304, 1.4, 0.27272727272727
11794, 0.21739130434783, 1.4, 0.25
11795, 0.19565217391304, 1.4, 0.31818181818182
11796, 0.21739130434783, 1.4, 0.29545454545455
11797, 0.19565217391304, 1.4, 0.36363636363636
11798, 0.21739130434783, 1.4, 0.34090909090909
11799, 0.19565217391304, 1.4, 0.40909090909091
11800, 0.21739130434783, 1.4, 0.38636363636364
11801, 0.19565217391304, 1.4, 0.45454545454545
11802, 0.21739130434783, 1.4, 0.43181818181818
11803, 0.21739130434783, 1.4, 0.47727272727273
11804, 0.23913043478261, 1.4, 0.045454545454545
11805, 0.26086956521739, 1.4, 0.022727272727273
11806, 0.23913043478261, 1.4, 0.090909090909091
11807, 0.26086956521739, 1.4, 0.068181818181818
11808, 0.23913043478261, 1.4, 0.13636363636364
11809, 0.26086956521739, 1.4, 0.11363636363636
11810, 0.23913043478261, 1.4, 0.18181818181818
11811, 0.26086956521739, 1.4, 0.15909090909091
11812, 0.23913043478261, 1.4, 0.22727272727273
11813, 0.26086956521739, 1.4, 0.20454545454545
11814, 0.23913043478261, 1.4, 0.27272727272727
11815, 0.26086956521739, 1.4, 0.25
11816, 0.23913043478261, 1.4, 0.31818181818182
11817, 0.26086956521739, 1.4, 0.29545454545455
11818, 0.23913043478261, 1.4, 0.36363636363636
11819, 0.26086956521739, 1.4, 0.34090909090909
11820, 0.23913043478261, 1.4, 0.40909090909091
11821, 0.26086956521739, 1.4, 0.38636363636364
11822, 0.23913043478261, 1.4, 0.45454545454545
11823, 0.26086956521739, 1.4, 0.43181818181818
11824, 0.26086956521739, 1.4, 0.47727272727273
11825, 0.28260869565217, 1.4, 0.045454545454545
11826, 0.30434782608696, 1.4, 0.022727272727273
11827, 0.28260869565217, 1.4, 0.090909090909091
11828, 0.30434782608696, 1.4, 0.068181818181818
11829, 0.28260869565217, 1.4, 0.13636363636364
11830, 0.30434782608696, 1.4, 0.11363636363636
11831, 0.28260869565217, 1.4, 0.18181818181818
11832, 0.30434782608696, 1.4, 0.15909090909091
11833, 0.28260869565217, 1.4, 0.22727272727273
11834, 0.30434782608696, 1.4, 0.20454545454545
11835, 0.28260869565217, 1.4, 0.27272727272727
11836, 0.30434782608696, 1.4, 0.25
11837, 0.28260869565217, 1.4, 0.31818181818182
11838, 0.30434782608696, 1.4, 0.29545454545455
11839, 0.28260869565217, 1.4, 0.36363636363636
11840, 0.30434782608696, 1.4, 0.34090909090909
11841, 0.28260869565217, 1.4, 0.40909090909091
11842, 0.30434782608696, 1.4, 0.38636363636364
11843, 0.28260869565217, 1.4, 0.45454545454545
11844, 0.30434782608696, 1.4, 0.43181818181818
11845, 0.30434782608696, 1.4, 0.47727272727273
11846, 0.32608695652174, 1.4, 0.045454545454545
11847, 0.34782608695652, 1.4, 0.022727272727273
11848, 0.32608695652174, 1.4, 0.090909090909091
11849, 0.34782608695652, 1.4, 0.068181818181818
11850, 0.32608695652174, 1.4, 0.13636363636364
11851, 0.34782608695652, 1.4, 0.11363636363636
11852, 0.32608695652174, 1.4, 0.18181818181818
11853, 0.34782608695652, 1.4, 0.15909090909091
11854, 0.32608695652174, 1.4, 0.22727272727273
11855, 0.34782608695652, 1.4, 0.20454545454545
11856, 0.32608695652174, 1.4, 0.27272727272727
11857, 0.34782608695652, 1.4, 0.25
11858, 0.32608695652174, 1.4, 0.31818181818182
11859, 0.34782608695652, 1.4, 0.29545454545455
11860, 0.32608695652174, 1.4, 0.36363636363636
11861, 0.34782608695652, 1.4, 0.34090909090909
11862, 0.32608695652174, 1.4, 0.40909090909091
11863, 0.34782608695652, 1.4, 0.38636363636364
11864, 0.32608695652174, 1.4, 0.45454545454545
11865, 0.34782608695652, 1.4, 0.43181818181818
11866, 0.34782608695652, 1.4, 0.47727272727273
11867, 0.3695652173913, 1.4, 0.045454545454545
11868, 0.39130434782609, 1.4, 0.022727272727273
11869, 0.3695652173913, 1.4, 0.090909090909091
11870, 0.39130434782609, 1.4, 0.068181818181818
11871, 0.3695652173913, 1.4, 0.13636363636364
11872, 0.39130434782609, 1.4, 0.11363636363636
11873, 0.3695652173913, 1.4, 0.18181818181818
11874, 0.39130434782609, 1.4, 0.15909090909091
11875, 0.3695652173913, 1.4, 0.22727272727273
11876, 0.39130434782609, 1.4, 0.20454545454545
11877, 0.3695652173913, 1.4, 0.27272727272727
11878, 0.39130434782609, 1.4, 0.25
11879, 0.3695652173913, 1.4, 0.31818181818182
11880, 0.39130434782609, 1.4, 0.29545454545455
11881, 0.3695652173913, 1.4, 0.36363636363636
11882, 0.39130434782609, 1.4, 0.34090909090909
11883, 0.3695652173913, 1.4, 0.40909090909091
11884, 0.39130434782609, 1.4, 0.38636363636364
11885, 0.3695652173913, 1.4, 0.45454545454545
11886, 0.39130434782609, 1.4, 0.43181818181818
11887, 0.39130434782609, 1.4, 0.47727272727273
11888, 0.41304347826087, 1.4, 0.045454545454545
11889, 0.43478260869565, 1.4, 0.022727272727273
11890, 0.41304347826087, 1.4, 0.090909090909091
11891, 0.43478260869565, 1.4, 0.068181818181818
11892, 0.41304347826087, 1.4, 0.13636363636364
11893, 0.43478260869565, 1.4, 0.11363636363636
11894, 0.41304347826087, 1.4, 0.18181818181818
11895, 0.43478260869565, 1.4, 0.15909090909091
11896, 0.41304347826087, 1.4, 0.22727272727273
11897, 0.43478260869565, 1.4, 0.20454545454545
11898, 0.41304347826087, 1.4, 0.27272727272727
11899, 0.43478260869565, 1.4, 0.25
11900, 0.41304347826087, 1.4, 0.31818181818182
11901, 0.43478260869565, 1.4, 0.29545454545455
11902, 0.41304347826087, 1.4, 0.36363636363636
11903, 0.43478260869565, 1.4, 0.34090909090909
11904, 0.41304347826087, 1.4, 0.40909090909091
11905, 0.43478260869565, 1.4, 0.38636363636364
11906, 0.41304347826087, 1.4, 0.45454545454545
11907, 0.43478260869565, 1.4, 0.43181818181818
11908, 0.43478260869565, 1.4, 0.47727272727273
11909, 0.45652173913043, 1.4, 0.045454545454545
11910, 0.47826086956522, 1.4, 0.022727272727273
11911, 0.45652173913043, 1.4, 0.090909090909091
11912, 0.47826086956522, 1.4, 0.068181818181818
11913, 0.45652173913043, 1.4, 0.13636363636364
11914, 0.47826086956522, 1.4, 0.11363636363636
11915, 0.45652173913043, 1.4, 0.18181818181818
11916, 0.47826086956522, 1.4, 0.15909090909091
11917, 0.45652173913043, 1.4, 0.22727272727273
11918, 0.47826086956522, 1.4, 0.20454545454545
11919, 0.45652173913043, 1.4, 0.27272727272727
11920, 0.47826086956522, 1.4, 0.25
11921, 0.45652173913043, 1.4, 0.31818181818182
11922, 0.47826086956522, 1.4, 0.29545454545455
11923, 0.45652173913043, 1.4, 0.36363636363636
11924, 0.47826086956522, 1.4, 0.34090909090909
11925, 0.45652173913043, 1.4, 0.40909090909091
11926, 0.47826086956522, 1.4, 0.38636363636364
11927, 0.45652173913043, 1.4, 0.45454545454545
11928, 0.47826086956522, 1.4, 0.43181818181818
11929, 0.47826086956522, 1.4, 0.47727272727273
11930, 0.5, 1.4, 0.045454545454545
11931, 0.52173913043478, 1.4, 0.022727272727273
11932, 0.5, 1.4, 0.090909090909091
11933, 0.52173913043478, 1.4, 0.068181818181818
11934, 0.5, 1.4, 0.13636363636364
11935, 0.52173913043478, 1.4, 0.11363636363636
11936, 0.5, 1.4, 0.18181818181818
11937, 0.52173913043478, 1.4, 0.15909090909091
11938, 0.5, 1.4, 0.22727272727273
11939, 0.52173913043478, 1.4, 0.20454545454545
11940, 0.5, 1.4, 0.27272727272727
11941, 0.52173913043478, 1.4, 0.25
11942, 0.5, 1.4, 0.31818181818182
11943, 0.52173913043478, 1.4, 0.29545454545455
11944, 0.5, 1.4, 0.36363636363636
11945, 0.52173913043478, 1.4, 0.34090909090909
11946, 0.5, 1.4, 0.40909090909091
11947, 0.52173913043478, 1.4, 0.38636363636364
11948, 0.5, 1.4, 0.45454545454545
11949, 0.52173913043478, 1.4, 0.43181818181818
11950, 0.52173913043478, 1.4, 0.47727272727273
11951, 0.54347826086957, 1.4, 0.045454545454545
11952, 0.56521739130435, 1.4, 0.022727272727273
11953, 0.54347826086957, 1.4, 0.090909090909091
11954, 0.56521739130435, 1.4, 0.068181818181818
11955, 0.54347826086957, 1.4, 0.13636363636364
11956, 0.56521739130435, 1.4, 0.11363636363636
11957, 0.54347826086957, 1.4, 0.18181818181818
11958, 0.56521739130435, 1.4, 0.15909090909091
11959, 0.54347826086957, 1.4, 0.22727272727273
11960, 0.56521739130435, 1.4, 0.20454545454545
11961, 0.54347826086957, 1.4, 0.27272727272727
11962, 0.56521739130435, 1.4, 0.25
11963, 0.54347826086957, 1.4, 0.31818181818182
11964, 0.56521739130435, 1.4, 0.29545454545455
11965, 0.54347826086957, 1.4, 0.36363636363636
11966, 0.56521739130435, 1.4, 0.34090909090909
11967, 0.54347826086957, 1.4, 0.40909090909091
11968, 0.56521739130435, 1.4, 0.38636363636364
11969, 0.54347826086957, 1.4, 0.45454545454545
11970, 0.56521739130435, 1.4, 0.43181818181818
11971, 0.56521739130435, 1.4, 0.47727272727273
11972, 0.58695652173913, 1.4, 0.045454545454545
11973, 0.60869565217391, 1.4, 0.022727272727273
11974, 0.58695652173913, 1.4, 0.090909090909091
11975, 0.60869565217391, 1.4, 0.068181818181818
11976, 0.58695652173913, 1.4, 0.13636363636364
11977, 0.60869565217391, 1.4, 0.11363636363636
11978, 0.58695652173913, 1.4, 0.18181818181818
11979, 0.60869565217391, 1.4, 0.15909090909091
11980, 0.58695652173913, 1.4, 0.22727272727273
11981, 0.60869565217391, 1.4, 0.20454545454545
11982, 0.58695652173913, 1.4, 0.27272727272727
11983, 0.60869565217391, 1.4, 0.25
11984, 0.58695652173913, 1.4, 0.31818181818182
11985, 0.60869565217391, 1.4, 0.29545454545455
11986, 0.58695652173913, 1.4, 0.36363636363636
11987, 0.60869565217391, 1.4, 0.34090909090909
11988, 0.58695652173913, 1.4, 0.40909090909091
11989, 0.60869565217391, 1.4, 0.38636363636364
11990, 0.58695652173913, 1.4, 0.45454545454545
11991, 0.60869565217391, 1.4, 0.43181818181818
11992, 0.60869565217391, 1.4, 0.47727272727273
11993, 0.6304347826087, 1.4, 0.045454545454545
11994, 0.65217391304348, 1.4, 0.022727272727273
11995, 0.6304347826087, 1.4, 0.090909090909091
11996, 0.65217391304348, 1.4, 0.068181818181818
11997, 0.6304347826087, 1.4, 0.13636363636364
11998, 0.65217391304348, 1.4, 0.11363636363636
11999, 0.6304347826087, 1.4, 0.18181818181818
12000, 0.65217391304348, 1.4, 0.15909090909091
12001, 0.6304347826087, 1.4, 0.22727272727273
12002, 0.65217391304348, 1.4, 0.20454545454545
12003, 0.6304347826087, 1.4, 0.27272727272727
12004, 0.65217391304348, 1.4, 0.25
12005, 0.6304347826087, 1.4, 0.31818181818182
12006, 0.65217391304348, 1.4, 0.29545454545455
12007, 0.6304347826087, 1.4, 0.36363636363636
12008, 0.65217391304348, 1.4, 0.34090909090909
12009, 0.6304347826087, 1.4, 0.40909090909091
12010, 0.65217391304348, 1.4, 0.38636363636364
12011, 0.6304347826087, 1.4, 0.45454545454545
12012, 0.65217391304348, 1.4, 0.43181818181818
12013, 0.65217391304348, 1.4, 0.47727272727273
12014, 0.67391304347826, 1.4, 0.045454545454545
12015, 0.69565217391304, 1.4, 0.022727272727273
12016, 0.67391304347826, 1.4, 0.090909090909091
12017, 0.69565217391304, 1.4, 0.068181818181818
12018, 0.67391304347826, 1.4, 0.13636363636364
12019, 0.69565217391304, 1.4, 0.11363636363636
12020, 0.67391304347826, 1.4, 0.18181818181818
12021, 0.69565217391304, 1.4, 0.15909090909091
12022, 0.67391304347826, 1.4, 0.22727272727273
12023, 0.69565217391304, 1.4, 0.20454545454545
12024, 0.67391304347826, 1.4, 0.27272727272727
12025, 0.69565217391304, 1.4, 0.25
12026, 0.67391304347826, 1.4, 0.31818181818182
12027, 0.69565217391304, 1.4, 0.29545454545455
12028, 0.67391304347826, 1.4, 0.36363636363636
12029, 0.69565217391304, 1.4, 0.34090909090909
12030, 0.67391304347826, 1.4, 0.40909090909091
12031, 0.69565217391304, 1.4, 0.38636363636364
12032, 0.67391304347826, 1.4, 0.45454545454545
12033, 0.69565217391304, 1.4, 0.43181818181818
12034, 0.69565217391304, 1.4, 0.47727272727273
12035, 0.71739130434783, 1.4, 0.045454545454545
12036, 0.73913043478261, 1.4, 0.022727272727273
12037, 0.71739130434783, 1.4, 0.090909090909091
12038, 0.73913043478261, 1.4, 0.068181818181818
12039, 0.71739130434783, 1.4, 0.13636363636364
12040, 0.73913043478261, 1.4, 0.11363636363636
12041, 0.71739130434783, 1.4, 0.18181818181818
12042, 0.73913043478261, 1.4, 0.15909090909091
12043, 0.71739130434783, 1.4, 0.22727272727273
12044, 0.73913043478261, 1.4, 0.20454545454545
12045, 0.71739130434783, 1.4, 0.27272727272727
12046, 0.73913043478261, 1.4, 0.25
12047, 0.71739130434783, 1.4, 0.31818181818182
12048, 0.73913043478261, 1.4, 0.29545454545455
12049, 0.71739130434783, 1.4, 0.36363636363636
12050, 0.73913043478261, 1.4, 0.34090909090909
12051, 0.71739130434783, 1.4, 0.40909090909091
12052, 0.73913043478261, 1.4, 0.38636363636364
12053, 0.71739130434783, 1.4, 0.45454545454545
12054, 0.73913043478261, 1.4, 0.43181818181818
12055, 0.73913043478261, 1.4, 0.47727272727273
12056, 0.76086956521739, 1.4, 0.045454545454545
12057, 0.78260869565217, 1.4, 0.022727272727273
12058, 0.76086956521739, 1.4, 0.090909090909091
12059, 0.78260869565217, 1.4, 0.068181818181818
12060, 0.76086956521739, 1.4, 0.13636363636364
12061, 0.78260869565217, 1.4, 0.11363636363636
12062, 0.76086956521739, 1.4, 0.18181818181818
12063, 0.78260869565217, 1.4, 0.15909090909091
12064, 0.76086956521739, 1.4, 0.22727272727273
12065, 0.78260869565217, 1.4, 0.20454545454545
12066, 0.76086956521739, 1.4, 0.27272727272727
12067, 0.78260869565217, 1.4, 0.25
12068, 0.76086956521739, 1.4, 0.31818181818182
12069, 0.78260869565217, 1.4, 0.29545454545455
12070, 0.76086956521739, 1.4, 0.36363636363636
12071, 0.78260869565217, 1.4, 0.34090909090909
12072, 0.76086956521739, 1.4, 0.40909090909091
12073, 0.78260869565217, 1.4, 0.38636363636364
12074, 0.76086956521739, 1.4, 0.45454545454545
12075, 0.78260869565217, 1.4, 0.43181818181818
12076, 0.78260869565217, 1.4, 0.47727272727273
12077, 0.80434782608696, 1.4, 0.045454545454545
12078, 0.82608695652174, 1.4, 0.022727272727273
12079, 0.80434782608696, 1.4, 0.090909090909091
12080, 0.82608695652174, 1.4, 0.068181818181818
12081, 0.80434782608696, 1.4, 0.13636363636364
12082, 0.82608695652174, 1.4, 0.11363636363636
12083, 0.80434782608696, 1.4, 0.18181818181818
12084, 0.82608695652174, 1.4, 0.15909090909091
12085, 0.80434782608696, 1.4, 0.22727272727273
12086, 0.82608695652174, 1.4, 0.20454545454545
12087, 0.80434782608696, 1.4, 0.27272727272727
12088, 0.82608695652174, 1.4, 0.25
12089, 0.80434782608696, 1.4, 0.31818181818182
12090, 0.82608695652174, 1.4, 0.29545454545455
12091, 0.80434782608696, 1.4, 0.36363636363636
12092, 0.82608695652174, 1.4, 0.34090909090909
12093, 0.80434782608696, 1.4, 0.40909090909091
12094, 0.82608695652174, 1.4, 0.38636363636364
12095, 0.80434782608696, 1.4, 0.45454545454545
12096, 0.82608695652174, 1.4, 0.43181818181818
12097, 0.82608695652174, 1.4, 0.47727272727273
12098, 0.84782608695652, 1.4, 0.045454545454545
12099, 0.8695652173913, 1.4, 0.022727272727273
12100, 0.84782608695652, 1.4, 0.090909090909091
12101, 0.8695652173913, 1.4, 0.068181818181818
12102, 0.84782608695652, 1.4, 0.13636363636364
12103, 0.8695652173913, 1.4, 0.11363636363636
12104, 0.84782608695652, 1.4, 0.18181818181818
12105, 0.8695652173913, 1.4, 0.15909090909091
12106, 0.84782608695652, 1.4, 0.22727272727273
12107, 0.8695652173913, 1.4, 0.20454545454545
12108, 0.84782608695652, 1.4, 0.27272727272727
12109, 0.8695652173913, 1.4, 0.25
12110, 0.84782608695652, 1.4, 0.31818181818182
12111, 0.8695652173913, 1.4, 0.29545454545455
12112, 0.84782608695652, 1.4, 0.36363636363636
12113, 0.8695652173913, 1.4, 0.34090909090909
12114, 0.84782608695652, 1.4, 0.40909090909091
12115, 0.8695652173913, 1.4, 0.38636363636364
12116, 0.84782608695652, 1.4, 0.45454545454545
12117, 0.8695652173913, 1.4, 0.43181818181818
12118, 0.8695652173913, 1.4, 0.47727272727273
12119, 0.89130434782609, 1.4, 0.045454545454545
12120, 0.91304347826087, 1.4, 0.022727272727273
12121, 0.89130434782609, 1.4, 0.090909090909091
12122, 0.91304347826087, 1.4, 0.068181818181818
12123, 0.89130434782609, 1.4, 0.13636363636364
12124, 0.91304347826087, 1.4, 0.11363636363636
12125, 0.89130434782609, 1.4, 0.18181818181818
12126, 0.91304347826087, 1.4, 0.15909090909091
12127, 0.89130434782609, 1.4, 0.22727272727273
12128, 0.91304347826087, 1.4, 0.20454545454545
12129, 0.89130434782609, 1.4, 0.27272727272727
12130, 0.91304347826087, 1.4, 0.25
12131, 0.89130434782609, 1.4, 0.31818181818182
12132, 0.91304347826087, 1.4, 0.29545454545455
12133, 0.89130434782609, 1.4, 0.36363636363636
12134, 0.91304347826087, 1.4, 0.34090909090909
12135, 0.89130434782609, 1.4, 0.40909090909091
12136, 0.91304347826087, 1.4, 0.38636363636364
12137, 0.89130434782609, 1.4, 0.45454545454545
12138, 0.91304347826087, 1.4, 0.43181818181818
12139, 0.91304347826087, 1.4, 0.47727272727273
12140, 0.93478260869565, 1.4, 0.045454545454545
12141, 0.95652173913043, 1.4, 0.022727272727273
12142, 0.93478260869565, 1.4, 0.090909090909091
12143, 0.95652173913043, 1.4, 0.068181818181818
12144, 0.93478260869565, 1.4, 0.13636363636364
12145, 0.95652173913044, 1.4, 0.11363636363636
12146, 0.93478260869565, 1.4, 0.18181818181818
12147, 0.95652173913043, 1.4, 0.15909090909091
12148, 0.93478260869565, 1.4, 0.22727272727273
12149, 0.95652173913043, 1.4, 0.20454545454545
12150, 0.93478260869565, 1.4, 0.27272727272727
12151, 0.95652173913043, 1.4, 0.25
12152, 0.93478260869565, 1.4, 0.31818181818182
12153, 0.95652173913043, 1.4, 0.29545454545455
12154, 0.93478260869565, 1.4, 0.36363636363636
12155, 0.95652173913043, 1.4, 0.34090909090909
12156, 0.93478260869565, 1.4, 0.40909090909091
12157, 0.95652173913043, 1.4, 0.38636363636364
12158, 0.93478260869565, 1.4, 0.45454545454545
12159, 0.95652173913043, 1.4, 0.43181818181818
12160, 0.95652173913043, 1.4, 0.47727272727273
12161, 0.97826086956522, 1.4, 0.045454545454545
12162, 0.97826086956522, 1.4, 0.090909090909091
12163, 0.97826086956522, 1.4, 0.13636363636364
12164, 0.97826086956522, 1.4, 0.18181818181818
12165, 0.97826086956522, 1.4, 0.22727272727273
12166, 0.97826086956522, 1.4, 0.27272727272727
12167, 0.97826086956522, 1.4, 0.31818181818182
12168, 0.97826086956522, 1.4, 0.36363636363636
12169, 0.97826086956522, 1.4, 0.40909090909091
12170, 0.97826086956522, 1.4, 0.45454545454545
12171, 0.95652173913043, 1.4333333333333, 0
12172, 0.91304347826087, 1.4333333333333, 0
12173, 0.8695652173913, 1.4333333333333, 0
12174, 0.82608695652174, 1.4333333333333, 0
12175, 0.78260869565217, 1.4333333333333, 0
12176, 0.73913043478261, 1.4333333333333, 0
12177, 0.69565217391304, 1.4333333333333, 0
12178, 0.65217391304348, 1.4333333333333, 0
12179, 0.60869565217391, 1.4333333333333, 0
12180, 0.56521739130435, 1.4333333333333, 0
12181, 0.52173913043478, 1.4333333333333, 0
12182, 0.47826086956522, 1.4333333333333, 0
12183, 0.43478260869565, 1.4333333333333, 0
12184, 0.39130434782609, 1.4333333333333, 0
12185, 0.34782608695652, 1.4333333333333, 0
12186, 0.30434782608696, 1.4333333333333, 0
12187, 0.26086956521739, 1.4333333333333, 0
12188, 0.21739130434783, 1.4333333333333, 0
12189, 0.17391304347826, 1.4333333333333, 0
12190, 0.1304347826087, 1.4333333333333, 0
12191, 0.08695652173913, 1.4333333333333, 0
12192, 0.043478260869565, 1.4333333333333, 0
12193, 0.95652173913043, 1.4666666666667, 0
12194, 0.91304347826087, 1.4666666666667, 0
12195, 0.8695652173913, 1.4666666666667, 0
12196, 0.82608695652174, 1.4666666666667, 0
12197, 0.78260869565217, 1.4666666666667, 0
12198, 0.73913043478261, 1.4666666666667, 0
12199, 0.69565217391304, 1.4666666666667, 0
12200, 0.65217391304348, 1.4666666666667, 0
12201, 0.60869565217391, 1.4666666666667, 0
12202, 0.56521739130435, 1.4666666666667, 0
12203, 0.52173913043478, 1.4666666666667, 0
12204, 0.47826086956522, 1.4666666666667, 0
12205, 0.43478260869565, 1.4666666666667, 0
12206, 0.39130434782609, 1.4666666666667, 0
12207, 0.34782608695652, 1.4666666666667, 0
12208, 0.30434782608696, 1.4666666666667, 0
12209, 0.26086956521739, 1.4666666666667, 0
12210, 0.21739130434783, 1.4666666666667, 0
12211, 0.17391304347826, 1.4666666666667, 0
12212, 0.1304347826087, 1.4666666666667, 0
12213, 0.08695652173913, 1.4666666666667, 0
12214, 0.043478260869565, 1.4666666666667, 0
12215, 0.95652173913043, 1.4166666666667, 0
12216, 0.97826086956522, 1.4333333333333, 0
12217, 0.91304347826087, 1.4166666666667, 0
12218, 0.93478260869565, 1.4333333333333, 0
12219, 0.8695652173913, 1.4166666666667, 0
12220, 0.89130434782609, 1.4333333333333, 0
12221, 0.82608695652174, 1.4166666666667, 0
12222, 0.84782608695652, 1.4333333333333, 0
12223, 0.78260869565217, 1.4166666666667, 0
12224, 0.80434782608696, 1.4333333333333, 0
12225, 0.73913043478261, 1.4166666666667, 0
12226, 0.76086956521739, 1.4333333333333, 0
12227, 0.69565217391304, 1.4166666666667, 0
12228, 0.71739130434783, 1.4333333333333, 0
12229, 0.65217391304348, 1.4166666666667, 0
12230, 0.67391304347826, 1.4333333333333, 0
12231, 0.60869565217391, 1.4166666666667, 0
12232, 0.6304347826087, 1.4333333333333, 0
12233, 0.56521739130435, 1.4166666666667, 0
12234, 0.58695652173913, 1.4333333333333, 0
12235, 0.52173913043478, 1.4166666666667, 0
12236, 0.54347826086957, 1.4333333333333, 0
12237, 0.47826086956522, 1.4166666666667, 0
12238, 0.5, 1.4333333333333, 0
12239, 0.43478260869565, 1.4166666666667, 0
12240, 0.45652173913043, 1.4333333333333, 0
12241, 0.39130434782609, 1.4166666666667, 0
12242, 0.41304347826087, 1.4333333333333, 0
12243, 0.34782608695652, 1.4166666666667, 0
12244, 0.3695652173913, 1.4333333333333, 0
12245, 0.30434782608696, 1.4166666666667, 0
12246, 0.32608695652174, 1.4333333333333, 0
12247, 0.26086956521739, 1.4166666666667, 0
12248, 0.28260869565217, 1.4333333333333, 0
12249, 0.21739130434783, 1.4166666666667, 0
12250, 0.23913043478261, 1.4333333333333, 0
12251, 0.17391304347826, 1.4166666666667, 0
12252, 0.19565217391304, 1.4333333333333, 0
12253, 0.1304347826087, 1.4166666666667, 0
12254, 0.15217391304348, 1.4333333333333, 0
12255, 0.08695652173913, 1.4166666666667, 0
12256, 0.10869565217391, 1.4333333333333, 0
12257, 0.043478260869565, 1.4166666666667, 0
12258, 0.065217391304348, 1.4333333333333, 0
12259, 0.021739130434783, 1.4333333333333, 0
12260, 0.95652173913043, 1.45, 0
12261, 0.97826086956522, 1.4666666666667, 0
12262, 0.91304347826087, 1.45, 0
12263, 0.93478260869565, 1.4666666666667, 0
12264, 0.8695652173913, 1.45, 0
12265, 0.89130434782609, 1.4666666666667, 0
12266, 0.82608695652174, 1.45, 0
12267, 0.84782608695652, 1.4666666666667, 0
12268, 0.78260869565217, 1.45, 0
12269, 0.80434782608696, 1.4666666666667, 0
12270, 0.73913043478261, 1.45, 0
12271, 0.76086956521739, 1.4666666666667, 0
12272, 0.69565217391304, 1.45, 0
12273, 0.71739130434783, 1.4666666666667, 0
12274, 0.65217391304348, 1.45, 0
12275, 0.67391304347826, 1.4666666666667, 0
12276, 0.60869565217391, 1.45, 0
12277, 0.6304347826087, 1.4666666666667, 0
12278, 0.56521739130435, 1.45, 0
12279, 0.58695652173913, 1.4666666666667, 0
12280, 0.52173913043478, 1.45, 0
12281, 0.54347826086957, 1.4666666666667, 0
12282, 0.47826086956522, 1.45, 0
12283, 0.5, 1.4666666666667, 0
12284, 0.43478260869565, 1.45, 0
12285, 0.45652173913043, 1.4666666666667, 0
12286, 0.39130434782609, 1.45, 0
12287, 0.41304347826087, 1.4666666666667, 0
12288, 0.34782608695652, 1.45, 0
12289, 0.3695652173913, 1.4666666666667, 0
12290, 0.30434782608696, 1.45, 0
12291, 0.32608695652174, 1.4666666666667, 0
12292, 0.26086956521739, 1.45, 0
12293, 0.28260869565217, 1.4666666666667, 0
12294, 0.21739130434783, 1.45, 0
12295, 0.23913043478261, 1.4666666666667, 0
12296, 0.17391304347826, 1.45, 0
12297, 0.19565217391304, 1.4666666666667, 0
12298, 0.1304347826087, 1.45, 0
12299, 0.15217391304348, 1.4666666666667, 0
12300, 0.08695652173913, 1.45, 0
12301, 0.10869565217391, 1.4666666666667, 0
12302, 0.043478260869565, 1.45, 0
12303, 0.065217391304348, 1.4666666666667, 0
12304, 0.021739130434783, 1.4666666666667, 0
12305, 0.95652173913043, 1.4833333333333, 0
12306, 0.91304347826087, 1.4833333333333, 0
12307, 0.8695652173913, 1.4833333333333, 0
12308, 0.82608695652174, 1.4833333333333, 0
12309, 0.78260869565217, 1.4833333333333, 0
12310, 0.73913043478261, 1.4833333333333, 0
12311, 0.69565217391304, 1.4833333333333, 0
12312, 0.65217391304348, 1.4833333333333, 0
12313, 0.60869565217391, 1.4833333333333, 0
12314, 0.56521739130435, 1.4833333333333, 0
12315, 0.52173913043478, 1.4833333333333, 0
12316, 0.47826086956522, 1.4833333333333, 0
12317, 0.43478260869565, 1.4833333333333, 0
12318, 0.39130434782609, 1.4833333333333, 0
12319, 0.34782608695652, 1.4833333333333, 0
12320, 0.30434782608696, 1.4833333333333, 0
12321, 0.26086956521739, 1.4833333333333, 0
12322, 0.21739130434783, 1.4833333333333, 0
12323, 0.17391304347826, 1.4833333333333, 0
12324, 0.1304347826087, 1.4833333333333, 0
12325, 0.08695652173913, 1.4833333333333, 0
12326, 0.043478260869565, 1.4833333333333, 0
12327, 1, 1.4333333333333, 0.45454545454545
12328, 1, 1.4333333333333, 0.40909090909091
12329, 1, 1.4333333333333, 0.36363636363636
12330, 1, 1.4333333333333, 0.31818181818182
12331, 1, 1.4333333333333, 0.27272727272727
12332, 1, 1.4333333333333, 0.22727272727273
12333, 1, 1.4333333333333, 0.18181818181818
12334, 1, 1.4333333333333, 0.13636363636364
12335, 1, 1.4333333333333, 0.090909090909091
12336, 1, 1.4333333333333, 0.045454545454545
12337, 1, 1.4666666666667, 0.45454545454545
12338, 1, 1.4666666666667, 0.40909090909091
12339, 1, 1.4666666666667, 0.36363636363636
12340, 1, 1.4666666666667, 0.31818181818182
12341, 1, 1.4666666666667, 0.27272727272727
12342, 1, 1.4666666666667, 0.22727272727273
12343, 1, 1.4666666666667, 0.18181818181818
12344, 1, 1.4666666666667, 0.13636363636364
12345, 1, 1.4666666666667, 0.090909090909091
12346, 1, 1.4666666666667, 0.045454545454545
12347, 1, 1.4166666666667, 0.45454545454545
12348, 1, 1.4333333333333, 0.47727272727273
12349, 1, 1.4166666666667, 0.40909090909091
12350, 1, 1.4333333333333, 0.43181818181818
12351, 1, 1.4166666666667, 0.36363636363636
12352, 1, 1.4333333333333, 0.38636363636364
12353, 1, 1.4166666666667, 0.31818181818182
12354, 1, 1.4333333333333, 0.34090909090909
12355, 1, 1.4166666666667, 0.27272727272727
12356, 1, 1.4333333333333, 0.29545454545455
12357, 1, 1.4166666666667, 0.22727272727273
12358, 1, 1.4333333333333, 0.25
12359, 1, 1.4166666666667, 0.18181818181818
12360, 1, 1.4333333333333, 0.20454545454545
12361, 1, 1.4166666666667, 0.13636363636364
12362, 1, 1.4333333333333, 0.15909090909091
12363, 1, 1.4166666666667, 0.090909090909091
12364, 1, 1.4333333333333, 0.11363636363636
12365, 1, 1.4166666666667, 0.045454545454545
12366, 1, 1.4333333333333, 0.068181818181818
12367, 1, 1.4333333333333, 0.022727272727273
12368, 1, 1.45, 0.45454545454545
12369, 1, 1.4666666666667, 0.47727272727273
12370, 1, 1.45, 0.40909090909091
12371, 1, 1.4666666666667, 0.43181818181818
12372, 1, 1.45, 0.36363636363636
12373, 1, 1.4666666666667, 0.38636363636364
12374, 1, 1.45, 0.31818181818182
12375, 1, 1.4666666666667, 0.34090909090909
12376, 1, 1.45, 0.27272727272727
12377, 1, 1.4666666666667, 0.29545454545455
12378, 1, 1.45, 0.22727272727273
12379, 1, 1.4666666666667, 0.25
12380, 1, 1.45, 0.18181818181818
12381, 1, 1.4666666666667, 0.20454545454545
12382, 1, 1.45, 0.13636363636364
12383, 1, 1.4666666666667, 0.15909090909091
12384, 1, 1.45, 0.090909090909091
12385, 1, 1.4666666666667, 0.11363636363636
12386, 1, 1.45, 0.045454545454545
12387, 1, 1.4666666666667, 0.068181818181818
