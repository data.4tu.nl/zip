62432, 1.8086956521739, 1.1413043478261, 0.045454545454545
62433, 1.8521739130435, 1.1413043478261, 0.45454545454545
62434, 1.8521739130435, 1.1413043478261, 0.40909090909091
62435, 1.8521739130435, 1.1413043478261, 0.36363636363636
62436, 1.8521739130435, 1.1413043478261, 0.31818181818182
62437, 1.8521739130435, 1.1413043478261, 0.27272727272727
62438, 1.8521739130435, 1.1413043478261, 0.22727272727273
62439, 1.8521739130435, 1.1413043478261, 0.18181818181818
62440, 1.8521739130435, 1.1413043478261, 0.13636363636364
62441, 1.8521739130435, 1.1413043478261, 0.090909090909091
62442, 1.8521739130435, 1.1413043478261, 0.045454545454545
62443, 1.895652173913, 1.1413043478261, 0.45454545454545
62444, 1.895652173913, 1.1413043478261, 0.40909090909091
62445, 1.895652173913, 1.1413043478261, 0.36363636363636
62446, 1.895652173913, 1.1413043478261, 0.31818181818182
62447, 1.895652173913, 1.1413043478261, 0.27272727272727
62448, 1.895652173913, 1.1413043478261, 0.22727272727273
62449, 1.895652173913, 1.1413043478261, 0.18181818181818
62450, 1.895652173913, 1.1413043478261, 0.13636363636364
62451, 1.895652173913, 1.1413043478261, 0.090909090909091
62452, 1.895652173913, 1.1413043478261, 0.045454545454545
62453, 1.9391304347826, 1.1413043478261, 0.45454545454545
62454, 1.9391304347826, 1.1413043478261, 0.40909090909091
62455, 1.9391304347826, 1.1413043478261, 0.36363636363636
62456, 1.9391304347826, 1.1413043478261, 0.31818181818182
62457, 1.9391304347826, 1.1413043478261, 0.27272727272727
62458, 1.9391304347826, 1.1413043478261, 0.22727272727273
62459, 1.9391304347826, 1.1413043478261, 0.18181818181818
62460, 1.9391304347826, 1.1413043478261, 0.13636363636364
62461, 1.9391304347826, 1.1413043478261, 0.090909090909091
62462, 1.9391304347826, 1.1413043478261, 0.045454545454545
62463, 1.9826086956522, 1.1413043478261, 0.45454545454545
62464, 1.9826086956522, 1.1413043478261, 0.40909090909091
62465, 1.9826086956522, 1.1413043478261, 0.36363636363636
62466, 1.9826086956522, 1.1413043478261, 0.31818181818182
62467, 1.9826086956522, 1.1413043478261, 0.27272727272727
62468, 1.9826086956522, 1.1413043478261, 0.22727272727273
62469, 1.9826086956522, 1.1413043478261, 0.18181818181818
62470, 1.9826086956522, 1.1413043478261, 0.13636363636364
62471, 1.9826086956522, 1.1413043478261, 0.090909090909091
62472, 1.9826086956522, 1.1413043478261, 0.045454545454545
62473, 2.0260869565217, 1.1413043478261, 0.45454545454545
62474, 2.0260869565217, 1.1413043478261, 0.40909090909091
62475, 2.0260869565217, 1.1413043478261, 0.36363636363636
62476, 2.0260869565217, 1.1413043478261, 0.31818181818182
62477, 2.0260869565217, 1.1413043478261, 0.27272727272727
62478, 2.0260869565217, 1.1413043478261, 0.22727272727273
62479, 2.0260869565217, 1.1413043478261, 0.18181818181818
62480, 2.0260869565217, 1.1413043478261, 0.13636363636364
62481, 2.0260869565217, 1.1413043478261, 0.090909090909091
62482, 2.0260869565217, 1.1413043478261, 0.045454545454545
62483, 2.0695652173913, 1.1413043478261, 0.45454545454545
62484, 2.0695652173913, 1.1413043478261, 0.40909090909091
62485, 2.0695652173913, 1.1413043478261, 0.36363636363636
62486, 2.0695652173913, 1.1413043478261, 0.31818181818182
62487, 2.0695652173913, 1.1413043478261, 0.27272727272727
62488, 2.0695652173913, 1.1413043478261, 0.22727272727273
62489, 2.0695652173913, 1.1413043478261, 0.18181818181818
62490, 2.0695652173913, 1.1413043478261, 0.13636363636364
62491, 2.0695652173913, 1.1413043478261, 0.090909090909091
62492, 2.0695652173913, 1.1413043478261, 0.045454545454545
62493, 2.1130434782609, 1.1413043478261, 0.45454545454545
62494, 2.1130434782609, 1.1413043478261, 0.40909090909091
62495, 2.1130434782609, 1.1413043478261, 0.36363636363636
62496, 2.1130434782609, 1.1413043478261, 0.31818181818182
62497, 2.1130434782609, 1.1413043478261, 0.27272727272727
62498, 2.1130434782609, 1.1413043478261, 0.22727272727273
62499, 2.1130434782609, 1.1413043478261, 0.18181818181818
62500, 2.1130434782609, 1.1413043478261, 0.13636363636364
62501, 2.1130434782609, 1.1413043478261, 0.090909090909091
62502, 2.1130434782609, 1.1413043478261, 0.045454545454545
62503, 2.1565217391304, 1.1413043478261, 0.45454545454545
62504, 2.1565217391304, 1.1413043478261, 0.40909090909091
62505, 2.1565217391304, 1.1413043478261, 0.36363636363636
62506, 2.1565217391304, 1.1413043478261, 0.31818181818182
62507, 2.1565217391304, 1.1413043478261, 0.27272727272727
62508, 2.1565217391304, 1.1413043478261, 0.22727272727273
62509, 2.1565217391304, 1.1413043478261, 0.18181818181818
62510, 2.1565217391304, 1.1413043478261, 0.13636363636364
62511, 2.1565217391304, 1.1413043478261, 0.090909090909091
62512, 2.1565217391304, 1.1413043478261, 0.045454545454545
62513, 1.2434782608696, 1.0891304347826, 0.45454545454545
62514, 1.2434782608696, 1.0891304347826, 0.40909090909091
62515, 1.2434782608696, 1.0891304347826, 0.36363636363636
62516, 1.2434782608696, 1.0891304347826, 0.31818181818182
62517, 1.2434782608696, 1.0891304347826, 0.27272727272727
62518, 1.2434782608696, 1.0891304347826, 0.22727272727273
62519, 1.2434782608696, 1.0891304347826, 0.18181818181818
62520, 1.2434782608696, 1.0891304347826, 0.13636363636364
62521, 1.2434782608696, 1.0891304347826, 0.090909090909091
62522, 1.2434782608696, 1.0891304347826, 0.045454545454545
62523, 1.2869565217391, 1.0891304347826, 0.45454545454545
62524, 1.2869565217391, 1.0891304347826, 0.40909090909091
62525, 1.2869565217391, 1.0891304347826, 0.36363636363636
62526, 1.2869565217391, 1.0891304347826, 0.31818181818182
62527, 1.2869565217391, 1.0891304347826, 0.27272727272727
62528, 1.2869565217391, 1.0891304347826, 0.22727272727273
62529, 1.2869565217391, 1.0891304347826, 0.18181818181818
62530, 1.2869565217391, 1.0891304347826, 0.13636363636364
62531, 1.2869565217391, 1.0891304347826, 0.090909090909091
62532, 1.2869565217391, 1.0891304347826, 0.045454545454545
62533, 1.3304347826087, 1.0891304347826, 0.45454545454545
62534, 1.3304347826087, 1.0891304347826, 0.40909090909091
62535, 1.3304347826087, 1.0891304347826, 0.36363636363636
62536, 1.3304347826087, 1.0891304347826, 0.31818181818182
62537, 1.3304347826087, 1.0891304347826, 0.27272727272727
62538, 1.3304347826087, 1.0891304347826, 0.22727272727273
62539, 1.3304347826087, 1.0891304347826, 0.18181818181818
62540, 1.3304347826087, 1.0891304347826, 0.13636363636364
62541, 1.3304347826087, 1.0891304347826, 0.090909090909091
62542, 1.3304347826087, 1.0891304347826, 0.045454545454545
62543, 1.3739130434783, 1.0891304347826, 0.45454545454545
62544, 1.3739130434783, 1.0891304347826, 0.40909090909091
62545, 1.3739130434783, 1.0891304347826, 0.36363636363636
62546, 1.3739130434783, 1.0891304347826, 0.31818181818182
62547, 1.3739130434783, 1.0891304347826, 0.27272727272727
62548, 1.3739130434783, 1.0891304347826, 0.22727272727273
62549, 1.3739130434783, 1.0891304347826, 0.18181818181818
62550, 1.3739130434783, 1.0891304347826, 0.13636363636364
62551, 1.3739130434783, 1.0891304347826, 0.090909090909091
62552, 1.3739130434783, 1.0891304347826, 0.045454545454545
62553, 1.4173913043478, 1.0891304347826, 0.45454545454545
62554, 1.4173913043478, 1.0891304347826, 0.40909090909091
62555, 1.4173913043478, 1.0891304347826, 0.36363636363636
62556, 1.4173913043478, 1.0891304347826, 0.31818181818182
62557, 1.4173913043478, 1.0891304347826, 0.27272727272727
62558, 1.4173913043478, 1.0891304347826, 0.22727272727273
62559, 1.4173913043478, 1.0891304347826, 0.18181818181818
62560, 1.4173913043478, 1.0891304347826, 0.13636363636364
62561, 1.4173913043478, 1.0891304347826, 0.090909090909091
62562, 1.4173913043478, 1.0891304347826, 0.045454545454545
62563, 1.4608695652174, 1.0891304347826, 0.45454545454545
62564, 1.4608695652174, 1.0891304347826, 0.40909090909091
62565, 1.4608695652174, 1.0891304347826, 0.36363636363636
62566, 1.4608695652174, 1.0891304347826, 0.31818181818182
62567, 1.4608695652174, 1.0891304347826, 0.27272727272727
62568, 1.4608695652174, 1.0891304347826, 0.22727272727273
62569, 1.4608695652174, 1.0891304347826, 0.18181818181818
62570, 1.4608695652174, 1.0891304347826, 0.13636363636364
62571, 1.4608695652174, 1.0891304347826, 0.090909090909091
62572, 1.4608695652174, 1.0891304347826, 0.045454545454545
62573, 1.504347826087, 1.0891304347826, 0.45454545454545
62574, 1.504347826087, 1.0891304347826, 0.40909090909091
62575, 1.504347826087, 1.0891304347826, 0.36363636363636
62576, 1.504347826087, 1.0891304347826, 0.31818181818182
62577, 1.504347826087, 1.0891304347826, 0.27272727272727
62578, 1.504347826087, 1.0891304347826, 0.22727272727273
62579, 1.504347826087, 1.0891304347826, 0.18181818181818
62580, 1.504347826087, 1.0891304347826, 0.13636363636364
62581, 1.504347826087, 1.0891304347826, 0.090909090909091
62582, 1.504347826087, 1.0891304347826, 0.045454545454545
62583, 1.5478260869565, 1.0891304347826, 0.45454545454545
62584, 1.5478260869565, 1.0891304347826, 0.40909090909091
62585, 1.5478260869565, 1.0891304347826, 0.36363636363636
62586, 1.5478260869565, 1.0891304347826, 0.31818181818182
62587, 1.5478260869565, 1.0891304347826, 0.27272727272727
62588, 1.5478260869565, 1.0891304347826, 0.22727272727273
62589, 1.5478260869565, 1.0891304347826, 0.18181818181818
62590, 1.5478260869565, 1.0891304347826, 0.13636363636364
62591, 1.5478260869565, 1.0891304347826, 0.090909090909091
62592, 1.5478260869565, 1.0891304347826, 0.045454545454545
62593, 1.5913043478261, 1.0891304347826, 0.45454545454545
62594, 1.5913043478261, 1.0891304347826, 0.40909090909091
62595, 1.5913043478261, 1.0891304347826, 0.36363636363636
62596, 1.5913043478261, 1.0891304347826, 0.31818181818182
62597, 1.5913043478261, 1.0891304347826, 0.27272727272727
62598, 1.5913043478261, 1.0891304347826, 0.22727272727273
62599, 1.5913043478261, 1.0891304347826, 0.18181818181818
62600, 1.5913043478261, 1.0891304347826, 0.13636363636364
62601, 1.5913043478261, 1.0891304347826, 0.090909090909091
62602, 1.5913043478261, 1.0891304347826, 0.045454545454545
62603, 1.6347826086957, 1.0891304347826, 0.45454545454545
62604, 1.6347826086957, 1.0891304347826, 0.40909090909091
62605, 1.6347826086957, 1.0891304347826, 0.36363636363636
62606, 1.6347826086957, 1.0891304347826, 0.31818181818182
62607, 1.6347826086957, 1.0891304347826, 0.27272727272727
62608, 1.6347826086957, 1.0891304347826, 0.22727272727273
62609, 1.6347826086957, 1.0891304347826, 0.18181818181818
62610, 1.6347826086957, 1.0891304347826, 0.13636363636364
62611, 1.6347826086957, 1.0891304347826, 0.090909090909091
62612, 1.6347826086957, 1.0891304347826, 0.045454545454545
62613, 1.6782608695652, 1.0891304347826, 0.45454545454545
62614, 1.6782608695652, 1.0891304347826, 0.40909090909091
62615, 1.6782608695652, 1.0891304347826, 0.36363636363636
62616, 1.6782608695652, 1.0891304347826, 0.31818181818182
62617, 1.6782608695652, 1.0891304347826, 0.27272727272727
62618, 1.6782608695652, 1.0891304347826, 0.22727272727273
62619, 1.6782608695652, 1.0891304347826, 0.18181818181818
62620, 1.6782608695652, 1.0891304347826, 0.13636363636364
62621, 1.6782608695652, 1.0891304347826, 0.090909090909091
62622, 1.6782608695652, 1.0891304347826, 0.045454545454545
62623, 1.7217391304348, 1.0891304347826, 0.45454545454545
62624, 1.7217391304348, 1.0891304347826, 0.40909090909091
62625, 1.7217391304348, 1.0891304347826, 0.36363636363636
62626, 1.7217391304348, 1.0891304347826, 0.31818181818182
62627, 1.7217391304348, 1.0891304347826, 0.27272727272727
62628, 1.7217391304348, 1.0891304347826, 0.22727272727273
62629, 1.7217391304348, 1.0891304347826, 0.18181818181818
62630, 1.7217391304348, 1.0891304347826, 0.13636363636364
62631, 1.7217391304348, 1.0891304347826, 0.090909090909091
62632, 1.7217391304348, 1.0891304347826, 0.045454545454545
62633, 1.7652173913043, 1.0891304347826, 0.45454545454545
62634, 1.7652173913043, 1.0891304347826, 0.40909090909091
62635, 1.7652173913043, 1.0891304347826, 0.36363636363636
62636, 1.7652173913043, 1.0891304347826, 0.31818181818182
62637, 1.7652173913043, 1.0891304347826, 0.27272727272727
62638, 1.7652173913043, 1.0891304347826, 0.22727272727273
62639, 1.7652173913043, 1.0891304347826, 0.18181818181818
62640, 1.7652173913043, 1.0891304347826, 0.13636363636364
62641, 1.7652173913043, 1.0891304347826, 0.090909090909091
62642, 1.7652173913043, 1.0891304347826, 0.045454545454545
62643, 1.8086956521739, 1.0891304347826, 0.45454545454545
62644, 1.8086956521739, 1.0891304347826, 0.40909090909091
62645, 1.8086956521739, 1.0891304347826, 0.36363636363636
62646, 1.8086956521739, 1.0891304347826, 0.31818181818182
62647, 1.8086956521739, 1.0891304347826, 0.27272727272727
62648, 1.8086956521739, 1.0891304347826, 0.22727272727273
62649, 1.8086956521739, 1.0891304347826, 0.18181818181818
62650, 1.8086956521739, 1.0891304347826, 0.13636363636364
62651, 1.8086956521739, 1.0891304347826, 0.090909090909091
62652, 1.8086956521739, 1.0891304347826, 0.045454545454545
62653, 1.8521739130435, 1.0891304347826, 0.45454545454545
62654, 1.8521739130435, 1.0891304347826, 0.40909090909091
62655, 1.8521739130435, 1.0891304347826, 0.36363636363636
62656, 1.8521739130435, 1.0891304347826, 0.31818181818182
62657, 1.8521739130435, 1.0891304347826, 0.27272727272727
62658, 1.8521739130435, 1.0891304347826, 0.22727272727273
62659, 1.8521739130435, 1.0891304347826, 0.18181818181818
62660, 1.8521739130435, 1.0891304347826, 0.13636363636364
62661, 1.8521739130435, 1.0891304347826, 0.090909090909091
62662, 1.8521739130435, 1.0891304347826, 0.045454545454545
62663, 1.895652173913, 1.0891304347826, 0.45454545454545
62664, 1.895652173913, 1.0891304347826, 0.40909090909091
62665, 1.895652173913, 1.0891304347826, 0.36363636363636
62666, 1.895652173913, 1.0891304347826, 0.31818181818182
62667, 1.895652173913, 1.0891304347826, 0.27272727272727
62668, 1.895652173913, 1.0891304347826, 0.22727272727273
62669, 1.895652173913, 1.0891304347826, 0.18181818181818
62670, 1.895652173913, 1.0891304347826, 0.13636363636364
62671, 1.895652173913, 1.0891304347826, 0.090909090909091
62672, 1.895652173913, 1.0891304347826, 0.045454545454545
62673, 1.9391304347826, 1.0891304347826, 0.45454545454545
62674, 1.9391304347826, 1.0891304347826, 0.40909090909091
62675, 1.9391304347826, 1.0891304347826, 0.36363636363636
62676, 1.9391304347826, 1.0891304347826, 0.31818181818182
62677, 1.9391304347826, 1.0891304347826, 0.27272727272727
62678, 1.9391304347826, 1.0891304347826, 0.22727272727273
62679, 1.9391304347826, 1.0891304347826, 0.18181818181818
62680, 1.9391304347826, 1.0891304347826, 0.13636363636364
62681, 1.9391304347826, 1.0891304347826, 0.090909090909091
62682, 1.9391304347826, 1.0891304347826, 0.045454545454545
62683, 1.9826086956522, 1.0891304347826, 0.45454545454545
62684, 1.9826086956522, 1.0891304347826, 0.40909090909091
62685, 1.9826086956522, 1.0891304347826, 0.36363636363636
62686, 1.9826086956522, 1.0891304347826, 0.31818181818182
62687, 1.9826086956522, 1.0891304347826, 0.27272727272727
62688, 1.9826086956522, 1.0891304347826, 0.22727272727273
62689, 1.9826086956522, 1.0891304347826, 0.18181818181818
62690, 1.9826086956522, 1.0891304347826, 0.13636363636364
62691, 1.9826086956522, 1.0891304347826, 0.090909090909091
62692, 1.9826086956522, 1.0891304347826, 0.045454545454545
62693, 2.0260869565217, 1.0891304347826, 0.45454545454545
62694, 2.0260869565217, 1.0891304347826, 0.40909090909091
62695, 2.0260869565217, 1.0891304347826, 0.36363636363636
62696, 2.0260869565217, 1.0891304347826, 0.31818181818182
62697, 2.0260869565217, 1.0891304347826, 0.27272727272727
62698, 2.0260869565217, 1.0891304347826, 0.22727272727273
62699, 2.0260869565217, 1.0891304347826, 0.18181818181818
62700, 2.0260869565217, 1.0891304347826, 0.13636363636364
62701, 2.0260869565217, 1.0891304347826, 0.090909090909091
62702, 2.0260869565217, 1.0891304347826, 0.045454545454545
62703, 2.0695652173913, 1.0891304347826, 0.45454545454545
62704, 2.0695652173913, 1.0891304347826, 0.40909090909091
62705, 2.0695652173913, 1.0891304347826, 0.36363636363636
62706, 2.0695652173913, 1.0891304347826, 0.31818181818182
62707, 2.0695652173913, 1.0891304347826, 0.27272727272727
62708, 2.0695652173913, 1.0891304347826, 0.22727272727273
62709, 2.0695652173913, 1.0891304347826, 0.18181818181818
62710, 2.0695652173913, 1.0891304347826, 0.13636363636364
62711, 2.0695652173913, 1.0891304347826, 0.090909090909091
62712, 2.0695652173913, 1.0891304347826, 0.045454545454545
62713, 2.1130434782609, 1.0891304347826, 0.45454545454545
62714, 2.1130434782609, 1.0891304347826, 0.40909090909091
62715, 2.1130434782609, 1.0891304347826, 0.36363636363636
62716, 2.1130434782609, 1.0891304347826, 0.31818181818182
62717, 2.1130434782609, 1.0891304347826, 0.27272727272727
62718, 2.1130434782609, 1.0891304347826, 0.22727272727273
62719, 2.1130434782609, 1.0891304347826, 0.18181818181818
62720, 2.1130434782609, 1.0891304347826, 0.13636363636364
62721, 2.1130434782609, 1.0891304347826, 0.090909090909091
62722, 2.1130434782609, 1.0891304347826, 0.045454545454545
62723, 2.1565217391304, 1.0891304347826, 0.45454545454545
62724, 2.1565217391304, 1.0891304347826, 0.40909090909091
62725, 2.1565217391304, 1.0891304347826, 0.36363636363636
62726, 2.1565217391304, 1.0891304347826, 0.31818181818182
62727, 2.1565217391304, 1.0891304347826, 0.27272727272727
62728, 2.1565217391304, 1.0891304347826, 0.22727272727273
62729, 2.1565217391304, 1.0891304347826, 0.18181818181818
62730, 2.1565217391304, 1.0891304347826, 0.13636363636364
62731, 2.1565217391304, 1.0891304347826, 0.090909090909091
62732, 2.1565217391304, 1.0891304347826, 0.045454545454545
62733, 1.2434782608696, 1.0369565217391, 0.45454545454545
62734, 1.2434782608696, 1.0369565217391, 0.40909090909091
62735, 1.2434782608696, 1.0369565217391, 0.36363636363636
62736, 1.2434782608696, 1.0369565217391, 0.31818181818182
62737, 1.2434782608696, 1.0369565217391, 0.27272727272727
62738, 1.2434782608696, 1.0369565217391, 0.22727272727273
62739, 1.2434782608696, 1.0369565217391, 0.18181818181818
62740, 1.2434782608696, 1.0369565217391, 0.13636363636364
62741, 1.2434782608696, 1.0369565217391, 0.090909090909091
62742, 1.2434782608696, 1.0369565217391, 0.045454545454545
62743, 1.2869565217391, 1.0369565217391, 0.45454545454545
62744, 1.2869565217391, 1.0369565217391, 0.40909090909091
62745, 1.2869565217391, 1.0369565217391, 0.36363636363636
62746, 1.2869565217391, 1.0369565217391, 0.31818181818182
62747, 1.2869565217391, 1.0369565217391, 0.27272727272727
62748, 1.2869565217391, 1.0369565217391, 0.22727272727273
62749, 1.2869565217391, 1.0369565217391, 0.18181818181818
62750, 1.2869565217391, 1.0369565217391, 0.13636363636364
62751, 1.2869565217391, 1.0369565217391, 0.090909090909091
62752, 1.2869565217391, 1.0369565217391, 0.045454545454545
62753, 1.3304347826087, 1.0369565217391, 0.45454545454545
62754, 1.3304347826087, 1.0369565217391, 0.40909090909091
62755, 1.3304347826087, 1.0369565217391, 0.36363636363636
62756, 1.3304347826087, 1.0369565217391, 0.31818181818182
62757, 1.3304347826087, 1.0369565217391, 0.27272727272727
62758, 1.3304347826087, 1.0369565217391, 0.22727272727273
62759, 1.3304347826087, 1.0369565217391, 0.18181818181818
62760, 1.3304347826087, 1.0369565217391, 0.13636363636364
62761, 1.3304347826087, 1.0369565217391, 0.090909090909091
62762, 1.3304347826087, 1.0369565217391, 0.045454545454545
62763, 1.3739130434783, 1.0369565217391, 0.45454545454545
62764, 1.3739130434783, 1.0369565217391, 0.40909090909091
62765, 1.3739130434783, 1.0369565217391, 0.36363636363636
62766, 1.3739130434783, 1.0369565217391, 0.31818181818182
62767, 1.3739130434783, 1.0369565217391, 0.27272727272727
62768, 1.3739130434783, 1.0369565217391, 0.22727272727273
62769, 1.3739130434783, 1.0369565217391, 0.18181818181818
62770, 1.3739130434783, 1.0369565217391, 0.13636363636364
62771, 1.3739130434783, 1.0369565217391, 0.090909090909091
62772, 1.3739130434783, 1.0369565217391, 0.045454545454545
62773, 1.4173913043478, 1.0369565217391, 0.45454545454545
62774, 1.4173913043478, 1.0369565217391, 0.40909090909091
62775, 1.4173913043478, 1.0369565217391, 0.36363636363636
62776, 1.4173913043478, 1.0369565217391, 0.31818181818182
62777, 1.4173913043478, 1.0369565217391, 0.27272727272727
62778, 1.4173913043478, 1.0369565217391, 0.22727272727273
62779, 1.4173913043478, 1.0369565217391, 0.18181818181818
62780, 1.4173913043478, 1.0369565217391, 0.13636363636364
62781, 1.4173913043478, 1.0369565217391, 0.090909090909091
62782, 1.4173913043478, 1.0369565217391, 0.045454545454545
62783, 1.4608695652174, 1.0369565217391, 0.45454545454545
62784, 1.4608695652174, 1.0369565217391, 0.40909090909091
62785, 1.4608695652174, 1.0369565217391, 0.36363636363636
62786, 1.4608695652174, 1.0369565217391, 0.31818181818182
62787, 1.4608695652174, 1.0369565217391, 0.27272727272727
62788, 1.4608695652174, 1.0369565217391, 0.22727272727273
62789, 1.4608695652174, 1.0369565217391, 0.18181818181818
62790, 1.4608695652174, 1.0369565217391, 0.13636363636364
62791, 1.4608695652174, 1.0369565217391, 0.090909090909091
62792, 1.4608695652174, 1.0369565217391, 0.045454545454545
62793, 1.504347826087, 1.0369565217391, 0.45454545454545
62794, 1.504347826087, 1.0369565217391, 0.40909090909091
62795, 1.504347826087, 1.0369565217391, 0.36363636363636
62796, 1.504347826087, 1.0369565217391, 0.31818181818182
62797, 1.504347826087, 1.0369565217391, 0.27272727272727
62798, 1.504347826087, 1.0369565217391, 0.22727272727273
62799, 1.504347826087, 1.0369565217391, 0.18181818181818
62800, 1.504347826087, 1.0369565217391, 0.13636363636364
62801, 1.504347826087, 1.0369565217391, 0.090909090909091
62802, 1.504347826087, 1.0369565217391, 0.045454545454545
62803, 1.5478260869565, 1.0369565217391, 0.45454545454545
62804, 1.5478260869565, 1.0369565217391, 0.40909090909091
62805, 1.5478260869565, 1.0369565217391, 0.36363636363636
62806, 1.5478260869565, 1.0369565217391, 0.31818181818182
62807, 1.5478260869565, 1.0369565217391, 0.27272727272727
62808, 1.5478260869565, 1.0369565217391, 0.22727272727273
62809, 1.5478260869565, 1.0369565217391, 0.18181818181818
62810, 1.5478260869565, 1.0369565217391, 0.13636363636364
62811, 1.5478260869565, 1.0369565217391, 0.090909090909091
62812, 1.5478260869565, 1.0369565217391, 0.045454545454545
62813, 1.5913043478261, 1.0369565217391, 0.45454545454545
62814, 1.5913043478261, 1.0369565217391, 0.40909090909091
62815, 1.5913043478261, 1.0369565217391, 0.36363636363636
62816, 1.5913043478261, 1.0369565217391, 0.31818181818182
62817, 1.5913043478261, 1.0369565217391, 0.27272727272727
62818, 1.5913043478261, 1.0369565217391, 0.22727272727273
62819, 1.5913043478261, 1.0369565217391, 0.18181818181818
62820, 1.5913043478261, 1.0369565217391, 0.13636363636364
62821, 1.5913043478261, 1.0369565217391, 0.090909090909091
62822, 1.5913043478261, 1.0369565217391, 0.045454545454545
62823, 1.6347826086957, 1.0369565217391, 0.45454545454545
62824, 1.6347826086957, 1.0369565217391, 0.40909090909091
62825, 1.6347826086957, 1.0369565217391, 0.36363636363636
62826, 1.6347826086957, 1.0369565217391, 0.31818181818182
62827, 1.6347826086957, 1.0369565217391, 0.27272727272727
62828, 1.6347826086957, 1.0369565217391, 0.22727272727273
62829, 1.6347826086957, 1.0369565217391, 0.18181818181818
62830, 1.6347826086957, 1.0369565217391, 0.13636363636364
62831, 1.6347826086957, 1.0369565217391, 0.090909090909091
62832, 1.6347826086957, 1.0369565217391, 0.045454545454545
62833, 1.6782608695652, 1.0369565217391, 0.45454545454545
62834, 1.6782608695652, 1.0369565217391, 0.40909090909091
62835, 1.6782608695652, 1.0369565217391, 0.36363636363636
62836, 1.6782608695652, 1.0369565217391, 0.31818181818182
62837, 1.6782608695652, 1.0369565217391, 0.27272727272727
62838, 1.6782608695652, 1.0369565217391, 0.22727272727273
62839, 1.6782608695652, 1.0369565217391, 0.18181818181818
62840, 1.6782608695652, 1.0369565217391, 0.13636363636364
62841, 1.6782608695652, 1.0369565217391, 0.090909090909091
62842, 1.6782608695652, 1.0369565217391, 0.045454545454545
62843, 1.7217391304348, 1.0369565217391, 0.45454545454545
62844, 1.7217391304348, 1.0369565217391, 0.40909090909091
62845, 1.7217391304348, 1.0369565217391, 0.36363636363636
62846, 1.7217391304348, 1.0369565217391, 0.31818181818182
62847, 1.7217391304348, 1.0369565217391, 0.27272727272727
62848, 1.7217391304348, 1.0369565217391, 0.22727272727273
62849, 1.7217391304348, 1.0369565217391, 0.18181818181818
62850, 1.7217391304348, 1.0369565217391, 0.13636363636364
62851, 1.7217391304348, 1.0369565217391, 0.090909090909091
62852, 1.7217391304348, 1.0369565217391, 0.045454545454545
62853, 1.7652173913043, 1.0369565217391, 0.45454545454545
62854, 1.7652173913043, 1.0369565217391, 0.40909090909091
62855, 1.7652173913043, 1.0369565217391, 0.36363636363636
62856, 1.7652173913043, 1.0369565217391, 0.31818181818182
62857, 1.7652173913043, 1.0369565217391, 0.27272727272727
62858, 1.7652173913043, 1.0369565217391, 0.22727272727273
62859, 1.7652173913043, 1.0369565217391, 0.18181818181818
62860, 1.7652173913043, 1.0369565217391, 0.13636363636364
62861, 1.7652173913043, 1.0369565217391, 0.090909090909091
62862, 1.7652173913043, 1.0369565217391, 0.045454545454545
62863, 1.8086956521739, 1.0369565217391, 0.45454545454545
62864, 1.8086956521739, 1.0369565217391, 0.40909090909091
62865, 1.8086956521739, 1.0369565217391, 0.36363636363636
62866, 1.8086956521739, 1.0369565217391, 0.31818181818182
62867, 1.8086956521739, 1.0369565217391, 0.27272727272727
62868, 1.8086956521739, 1.0369565217391, 0.22727272727273
62869, 1.8086956521739, 1.0369565217391, 0.18181818181818
62870, 1.8086956521739, 1.0369565217391, 0.13636363636364
62871, 1.8086956521739, 1.0369565217391, 0.090909090909091
62872, 1.8086956521739, 1.0369565217391, 0.045454545454545
62873, 1.8521739130435, 1.0369565217391, 0.45454545454545
62874, 1.8521739130435, 1.0369565217391, 0.40909090909091
62875, 1.8521739130435, 1.0369565217391, 0.36363636363636
62876, 1.8521739130435, 1.0369565217391, 0.31818181818182
62877, 1.8521739130435, 1.0369565217391, 0.27272727272727
62878, 1.8521739130435, 1.0369565217391, 0.22727272727273
62879, 1.8521739130435, 1.0369565217391, 0.18181818181818
62880, 1.8521739130435, 1.0369565217391, 0.13636363636364
62881, 1.8521739130435, 1.0369565217391, 0.090909090909091
62882, 1.8521739130435, 1.0369565217391, 0.045454545454545
62883, 1.895652173913, 1.0369565217391, 0.45454545454545
62884, 1.895652173913, 1.0369565217391, 0.40909090909091
62885, 1.895652173913, 1.0369565217391, 0.36363636363636
62886, 1.895652173913, 1.0369565217391, 0.31818181818182
62887, 1.895652173913, 1.0369565217391, 0.27272727272727
62888, 1.895652173913, 1.0369565217391, 0.22727272727273
62889, 1.895652173913, 1.0369565217391, 0.18181818181818
62890, 1.895652173913, 1.0369565217391, 0.13636363636364
62891, 1.895652173913, 1.0369565217391, 0.090909090909091
62892, 1.895652173913, 1.0369565217391, 0.045454545454545
62893, 1.9391304347826, 1.0369565217391, 0.45454545454545
62894, 1.9391304347826, 1.0369565217391, 0.40909090909091
62895, 1.9391304347826, 1.0369565217391, 0.36363636363636
62896, 1.9391304347826, 1.0369565217391, 0.31818181818182
62897, 1.9391304347826, 1.0369565217391, 0.27272727272727
62898, 1.9391304347826, 1.0369565217391, 0.22727272727273
62899, 1.9391304347826, 1.0369565217391, 0.18181818181818
62900, 1.9391304347826, 1.0369565217391, 0.13636363636364
62901, 1.9391304347826, 1.0369565217391, 0.090909090909091
62902, 1.9391304347826, 1.0369565217391, 0.045454545454545
62903, 1.9826086956522, 1.0369565217391, 0.45454545454545
62904, 1.9826086956522, 1.0369565217391, 0.40909090909091
62905, 1.9826086956522, 1.0369565217391, 0.36363636363636
62906, 1.9826086956522, 1.0369565217391, 0.31818181818182
62907, 1.9826086956522, 1.0369565217391, 0.27272727272727
62908, 1.9826086956522, 1.0369565217391, 0.22727272727273
62909, 1.9826086956522, 1.0369565217391, 0.18181818181818
62910, 1.9826086956522, 1.0369565217391, 0.13636363636364
62911, 1.9826086956522, 1.0369565217391, 0.090909090909091
62912, 1.9826086956522, 1.0369565217391, 0.045454545454545
62913, 2.0260869565217, 1.0369565217391, 0.45454545454545
62914, 2.0260869565217, 1.0369565217391, 0.40909090909091
62915, 2.0260869565217, 1.0369565217391, 0.36363636363636
62916, 2.0260869565217, 1.0369565217391, 0.31818181818182
62917, 2.0260869565217, 1.0369565217391, 0.27272727272727
62918, 2.0260869565217, 1.0369565217391, 0.22727272727273
62919, 2.0260869565217, 1.0369565217391, 0.18181818181818
62920, 2.0260869565217, 1.0369565217391, 0.13636363636364
62921, 2.0260869565217, 1.0369565217391, 0.090909090909091
62922, 2.0260869565217, 1.0369565217391, 0.045454545454545
62923, 2.0695652173913, 1.0369565217391, 0.45454545454545
62924, 2.0695652173913, 1.0369565217391, 0.40909090909091
62925, 2.0695652173913, 1.0369565217391, 0.36363636363636
62926, 2.0695652173913, 1.0369565217391, 0.31818181818182
62927, 2.0695652173913, 1.0369565217391, 0.27272727272727
62928, 2.0695652173913, 1.0369565217391, 0.22727272727273
62929, 2.0695652173913, 1.0369565217391, 0.18181818181818
62930, 2.0695652173913, 1.0369565217391, 0.13636363636364
62931, 2.0695652173913, 1.0369565217391, 0.090909090909091
62932, 2.0695652173913, 1.0369565217391, 0.045454545454545
62933, 2.1130434782609, 1.0369565217391, 0.45454545454545
62934, 2.1130434782609, 1.0369565217391, 0.40909090909091
62935, 2.1130434782609, 1.0369565217391, 0.36363636363636
62936, 2.1130434782609, 1.0369565217391, 0.31818181818182
62937, 2.1130434782609, 1.0369565217391, 0.27272727272727
62938, 2.1130434782609, 1.0369565217391, 0.22727272727273
62939, 2.1130434782609, 1.0369565217391, 0.18181818181818
62940, 2.1130434782609, 1.0369565217391, 0.13636363636364
62941, 2.1130434782609, 1.0369565217391, 0.090909090909091
62942, 2.1130434782609, 1.0369565217391, 0.045454545454545
62943, 2.1565217391304, 1.0369565217391, 0.45454545454545
62944, 2.1565217391304, 1.0369565217391, 0.40909090909091
62945, 2.1565217391304, 1.0369565217391, 0.36363636363636
62946, 2.1565217391304, 1.0369565217391, 0.31818181818182
62947, 2.1565217391304, 1.0369565217391, 0.27272727272727
62948, 2.1565217391304, 1.0369565217391, 0.22727272727273
62949, 2.1565217391304, 1.0369565217391, 0.18181818181818
62950, 2.1565217391304, 1.0369565217391, 0.13636363636364
62951, 2.1565217391304, 1.0369565217391, 0.090909090909091
62952, 2.1565217391304, 1.0369565217391, 0.045454545454545
62953, 1.2434782608696, 0.98478260869565, 0.45454545454545
62954, 1.2434782608696, 0.98478260869565, 0.40909090909091
62955, 1.2434782608696, 0.98478260869565, 0.36363636363636
62956, 1.2434782608696, 0.98478260869565, 0.31818181818182
62957, 1.2434782608696, 0.98478260869565, 0.27272727272727
62958, 1.2434782608696, 0.98478260869565, 0.22727272727273
62959, 1.2434782608696, 0.98478260869565, 0.18181818181818
62960, 1.2434782608696, 0.98478260869565, 0.13636363636364
62961, 1.2434782608696, 0.98478260869565, 0.090909090909091
62962, 1.2434782608696, 0.98478260869565, 0.045454545454545
62963, 1.2869565217391, 0.98478260869565, 0.45454545454545
62964, 1.2869565217391, 0.98478260869565, 0.40909090909091
62965, 1.2869565217391, 0.98478260869565, 0.36363636363636
62966, 1.2869565217391, 0.98478260869565, 0.31818181818182
62967, 1.2869565217391, 0.98478260869565, 0.27272727272727
62968, 1.2869565217391, 0.98478260869565, 0.22727272727273
62969, 1.2869565217391, 0.98478260869565, 0.18181818181818
62970, 1.2869565217391, 0.98478260869565, 0.13636363636364
62971, 1.2869565217391, 0.98478260869565, 0.090909090909091
62972, 1.2869565217391, 0.98478260869565, 0.045454545454545
62973, 1.3304347826087, 0.98478260869565, 0.45454545454545
62974, 1.3304347826087, 0.98478260869565, 0.40909090909091
62975, 1.3304347826087, 0.98478260869565, 0.36363636363636
62976, 1.3304347826087, 0.98478260869565, 0.31818181818182
62977, 1.3304347826087, 0.98478260869565, 0.27272727272727
62978, 1.3304347826087, 0.98478260869565, 0.22727272727273
62979, 1.3304347826087, 0.98478260869565, 0.18181818181818
62980, 1.3304347826087, 0.98478260869565, 0.13636363636364
62981, 1.3304347826087, 0.98478260869565, 0.090909090909091
62982, 1.3304347826087, 0.98478260869565, 0.045454545454545
62983, 1.3739130434783, 0.98478260869565, 0.45454545454545
62984, 1.3739130434783, 0.98478260869565, 0.40909090909091
62985, 1.3739130434783, 0.98478260869565, 0.36363636363636
62986, 1.3739130434783, 0.98478260869565, 0.31818181818182
62987, 1.3739130434783, 0.98478260869565, 0.27272727272727
62988, 1.3739130434783, 0.98478260869565, 0.22727272727273
62989, 1.3739130434783, 0.98478260869565, 0.18181818181818
62990, 1.3739130434783, 0.98478260869565, 0.13636363636364
62991, 1.3739130434783, 0.98478260869565, 0.090909090909091
62992, 1.3739130434783, 0.98478260869565, 0.045454545454545
62993, 1.4173913043478, 0.98478260869565, 0.45454545454545
62994, 1.4173913043478, 0.98478260869565, 0.40909090909091
62995, 1.4173913043478, 0.98478260869565, 0.36363636363636
62996, 1.4173913043478, 0.98478260869565, 0.31818181818182
62997, 1.4173913043478, 0.98478260869565, 0.27272727272727
62998, 1.4173913043478, 0.98478260869565, 0.22727272727273
62999, 1.4173913043478, 0.98478260869565, 0.18181818181818
63000, 1.4173913043478, 0.98478260869565, 0.13636363636364
63001, 1.4173913043478, 0.98478260869565, 0.090909090909091
63002, 1.4173913043478, 0.98478260869565, 0.045454545454545
63003, 1.4608695652174, 0.98478260869565, 0.45454545454545
63004, 1.4608695652174, 0.98478260869565, 0.40909090909091
63005, 1.4608695652174, 0.98478260869565, 0.36363636363636
63006, 1.4608695652174, 0.98478260869565, 0.31818181818182
63007, 1.4608695652174, 0.98478260869565, 0.27272727272727
63008, 1.4608695652174, 0.98478260869565, 0.22727272727273
63009, 1.4608695652174, 0.98478260869565, 0.18181818181818
63010, 1.4608695652174, 0.98478260869565, 0.13636363636364
63011, 1.4608695652174, 0.98478260869565, 0.090909090909091
63012, 1.4608695652174, 0.98478260869565, 0.045454545454545
63013, 1.504347826087, 0.98478260869565, 0.45454545454545
63014, 1.504347826087, 0.98478260869565, 0.40909090909091
63015, 1.504347826087, 0.98478260869565, 0.36363636363636
63016, 1.504347826087, 0.98478260869565, 0.31818181818182
63017, 1.504347826087, 0.98478260869565, 0.27272727272727
63018, 1.504347826087, 0.98478260869565, 0.22727272727273
63019, 1.504347826087, 0.98478260869565, 0.18181818181818
63020, 1.504347826087, 0.98478260869565, 0.13636363636364
63021, 1.504347826087, 0.98478260869565, 0.090909090909091
63022, 1.504347826087, 0.98478260869565, 0.045454545454545
63023, 1.5478260869565, 0.98478260869565, 0.45454545454545
63024, 1.5478260869565, 0.98478260869565, 0.40909090909091
63025, 1.5478260869565, 0.98478260869565, 0.36363636363636
63026, 1.5478260869565, 0.98478260869565, 0.31818181818182
63027, 1.5478260869565, 0.98478260869565, 0.27272727272727
63028, 1.5478260869565, 0.98478260869565, 0.22727272727273
63029, 1.5478260869565, 0.98478260869565, 0.18181818181818
63030, 1.5478260869565, 0.98478260869565, 0.13636363636364
63031, 1.5478260869565, 0.98478260869565, 0.090909090909091
63032, 1.5478260869565, 0.98478260869565, 0.045454545454546
63033, 1.5913043478261, 0.98478260869565, 0.45454545454545
63034, 1.5913043478261, 0.98478260869565, 0.40909090909091
63035, 1.5913043478261, 0.98478260869565, 0.36363636363636
63036, 1.5913043478261, 0.98478260869565, 0.31818181818182
63037, 1.5913043478261, 0.98478260869565, 0.27272727272727
63038, 1.5913043478261, 0.98478260869565, 0.22727272727273
63039, 1.5913043478261, 0.98478260869565, 0.18181818181818
63040, 1.5913043478261, 0.98478260869565, 0.13636363636364
63041, 1.5913043478261, 0.98478260869565, 0.090909090909091
63042, 1.5913043478261, 0.98478260869565, 0.045454545454545
63043, 1.6347826086957, 0.98478260869565, 0.45454545454545
63044, 1.6347826086957, 0.98478260869565, 0.40909090909091
63045, 1.6347826086957, 0.98478260869565, 0.36363636363636
63046, 1.6347826086957, 0.98478260869565, 0.31818181818182
63047, 1.6347826086957, 0.98478260869565, 0.27272727272727
63048, 1.6347826086957, 0.98478260869565, 0.22727272727273
63049, 1.6347826086957, 0.98478260869565, 0.18181818181818
63050, 1.6347826086957, 0.98478260869565, 0.13636363636364
63051, 1.6347826086957, 0.98478260869565, 0.090909090909091
63052, 1.6347826086957, 0.98478260869565, 0.045454545454545
63053, 1.6782608695652, 0.98478260869565, 0.45454545454545
63054, 1.6782608695652, 0.98478260869565, 0.40909090909091
63055, 1.6782608695652, 0.98478260869565, 0.36363636363636
63056, 1.6782608695652, 0.98478260869565, 0.31818181818182
63057, 1.6782608695652, 0.98478260869565, 0.27272727272727
63058, 1.6782608695652, 0.98478260869565, 0.22727272727273
63059, 1.6782608695652, 0.98478260869565, 0.18181818181818
63060, 1.6782608695652, 0.98478260869565, 0.13636363636364
63061, 1.6782608695652, 0.98478260869565, 0.090909090909091
63062, 1.6782608695652, 0.98478260869565, 0.045454545454545
63063, 1.7217391304348, 0.98478260869565, 0.45454545454545
63064, 1.7217391304348, 0.98478260869565, 0.40909090909091
63065, 1.7217391304348, 0.98478260869565, 0.36363636363636
63066, 1.7217391304348, 0.98478260869565, 0.31818181818182
63067, 1.7217391304348, 0.98478260869565, 0.27272727272727
63068, 1.7217391304348, 0.98478260869565, 0.22727272727273
63069, 1.7217391304348, 0.98478260869565, 0.18181818181818
63070, 1.7217391304348, 0.98478260869565, 0.13636363636364
63071, 1.7217391304348, 0.98478260869565, 0.090909090909091
63072, 1.7217391304348, 0.98478260869565, 0.045454545454545
63073, 1.7652173913043, 0.98478260869565, 0.45454545454545
63074, 1.7652173913043, 0.98478260869565, 0.40909090909091
63075, 1.7652173913043, 0.98478260869565, 0.36363636363636
63076, 1.7652173913043, 0.98478260869565, 0.31818181818182
63077, 1.7652173913043, 0.98478260869565, 0.27272727272727
63078, 1.7652173913043, 0.98478260869565, 0.22727272727273
63079, 1.7652173913043, 0.98478260869565, 0.18181818181818
63080, 1.7652173913043, 0.98478260869565, 0.13636363636364
63081, 1.7652173913043, 0.98478260869565, 0.090909090909091
63082, 1.7652173913043, 0.98478260869565, 0.045454545454545
63083, 1.8086956521739, 0.98478260869565, 0.45454545454545
63084, 1.8086956521739, 0.98478260869565, 0.40909090909091
63085, 1.8086956521739, 0.98478260869565, 0.36363636363636
63086, 1.8086956521739, 0.98478260869565, 0.31818181818182
63087, 1.8086956521739, 0.98478260869565, 0.27272727272727
63088, 1.8086956521739, 0.98478260869565, 0.22727272727273
63089, 1.8086956521739, 0.98478260869565, 0.18181818181818
63090, 1.8086956521739, 0.98478260869565, 0.13636363636364
63091, 1.8086956521739, 0.98478260869565, 0.090909090909091
63092, 1.8086956521739, 0.98478260869565, 0.045454545454545
63093, 1.8521739130435, 0.98478260869565, 0.45454545454545
63094, 1.8521739130435, 0.98478260869565, 0.40909090909091
63095, 1.8521739130435, 0.98478260869565, 0.36363636363636
63096, 1.8521739130435, 0.98478260869565, 0.31818181818182
63097, 1.8521739130435, 0.98478260869565, 0.27272727272727
63098, 1.8521739130435, 0.98478260869565, 0.22727272727273
63099, 1.8521739130435, 0.98478260869565, 0.18181818181818
63100, 1.8521739130435, 0.98478260869565, 0.13636363636364
63101, 1.8521739130435, 0.98478260869565, 0.090909090909091
63102, 1.8521739130435, 0.98478260869565, 0.045454545454545
63103, 1.895652173913, 0.98478260869565, 0.45454545454545
63104, 1.895652173913, 0.98478260869565, 0.40909090909091
63105, 1.895652173913, 0.98478260869565, 0.36363636363636
63106, 1.895652173913, 0.98478260869565, 0.31818181818182
63107, 1.895652173913, 0.98478260869565, 0.27272727272727
63108, 1.895652173913, 0.98478260869565, 0.22727272727273
63109, 1.895652173913, 0.98478260869565, 0.18181818181818
63110, 1.895652173913, 0.98478260869565, 0.13636363636364
63111, 1.895652173913, 0.98478260869565, 0.090909090909091
63112, 1.895652173913, 0.98478260869565, 0.045454545454545
63113, 1.9391304347826, 0.98478260869565, 0.45454545454545
63114, 1.9391304347826, 0.98478260869565, 0.40909090909091
63115, 1.9391304347826, 0.98478260869565, 0.36363636363636
63116, 1.9391304347826, 0.98478260869565, 0.31818181818182
63117, 1.9391304347826, 0.98478260869565, 0.27272727272727
63118, 1.9391304347826, 0.98478260869565, 0.22727272727273
63119, 1.9391304347826, 0.98478260869565, 0.18181818181818
63120, 1.9391304347826, 0.98478260869565, 0.13636363636364
63121, 1.9391304347826, 0.98478260869565, 0.090909090909091
63122, 1.9391304347826, 0.98478260869565, 0.045454545454545
63123, 1.9826086956522, 0.98478260869565, 0.45454545454545
63124, 1.9826086956522, 0.98478260869565, 0.40909090909091
63125, 1.9826086956522, 0.98478260869565, 0.36363636363636
63126, 1.9826086956522, 0.98478260869565, 0.31818181818182
63127, 1.9826086956522, 0.98478260869565, 0.27272727272727
63128, 1.9826086956522, 0.98478260869565, 0.22727272727273
63129, 1.9826086956522, 0.98478260869565, 0.18181818181818
63130, 1.9826086956522, 0.98478260869565, 0.13636363636364
63131, 1.9826086956522, 0.98478260869565, 0.090909090909091
63132, 1.9826086956522, 0.98478260869565, 0.045454545454545
63133, 2.0260869565217, 0.98478260869565, 0.45454545454545
63134, 2.0260869565217, 0.98478260869565, 0.40909090909091
63135, 2.0260869565217, 0.98478260869565, 0.36363636363636
63136, 2.0260869565217, 0.98478260869565, 0.31818181818182
63137, 2.0260869565217, 0.98478260869565, 0.27272727272727
63138, 2.0260869565217, 0.98478260869565, 0.22727272727273
63139, 2.0260869565217, 0.98478260869565, 0.18181818181818
63140, 2.0260869565217, 0.98478260869565, 0.13636363636364
63141, 2.0260869565217, 0.98478260869565, 0.090909090909091
63142, 2.0260869565217, 0.98478260869565, 0.045454545454545
63143, 2.0695652173913, 0.98478260869565, 0.45454545454545
63144, 2.0695652173913, 0.98478260869565, 0.40909090909091
63145, 2.0695652173913, 0.98478260869565, 0.36363636363636
63146, 2.0695652173913, 0.98478260869565, 0.31818181818182
63147, 2.0695652173913, 0.98478260869565, 0.27272727272727
63148, 2.0695652173913, 0.98478260869565, 0.22727272727273
63149, 2.0695652173913, 0.98478260869565, 0.18181818181818
63150, 2.0695652173913, 0.98478260869565, 0.13636363636364
63151, 2.0695652173913, 0.98478260869565, 0.090909090909091
63152, 2.0695652173913, 0.98478260869565, 0.045454545454545
63153, 2.1130434782609, 0.98478260869565, 0.45454545454545
63154, 2.1130434782609, 0.98478260869565, 0.40909090909091
63155, 2.1130434782609, 0.98478260869565, 0.36363636363636
63156, 2.1130434782609, 0.98478260869565, 0.31818181818182
63157, 2.1130434782609, 0.98478260869565, 0.27272727272727
63158, 2.1130434782609, 0.98478260869565, 0.22727272727273
63159, 2.1130434782609, 0.98478260869565, 0.18181818181818
63160, 2.1130434782609, 0.98478260869565, 0.13636363636364
63161, 2.1130434782609, 0.98478260869565, 0.090909090909091
63162, 2.1130434782609, 0.98478260869565, 0.045454545454545
63163, 2.1565217391304, 0.98478260869565, 0.45454545454545
63164, 2.1565217391304, 0.98478260869565, 0.40909090909091
63165, 2.1565217391304, 0.98478260869565, 0.36363636363636
63166, 2.1565217391304, 0.98478260869565, 0.31818181818182
63167, 2.1565217391304, 0.98478260869565, 0.27272727272727
63168, 2.1565217391304, 0.98478260869565, 0.22727272727273
63169, 2.1565217391304, 0.98478260869565, 0.18181818181818
63170, 2.1565217391304, 0.98478260869565, 0.13636363636364
63171, 2.1565217391304, 0.98478260869565, 0.090909090909091
63172, 2.1565217391304, 0.98478260869565, 0.045454545454545
63173, 1.2434782608696, 0.93260869565217, 0.45454545454545
63174, 1.2434782608696, 0.93260869565217, 0.40909090909091
63175, 1.2434782608696, 0.93260869565217, 0.36363636363636
63176, 1.2434782608696, 0.93260869565217, 0.31818181818182
63177, 1.2434782608696, 0.93260869565217, 0.27272727272727
63178, 1.2434782608696, 0.93260869565217, 0.22727272727273
63179, 1.2434782608696, 0.93260869565217, 0.18181818181818
63180, 1.2434782608696, 0.93260869565217, 0.13636363636364
63181, 1.2434782608696, 0.93260869565217, 0.090909090909091
63182, 1.2434782608696, 0.93260869565217, 0.045454545454545
63183, 1.2869565217391, 0.93260869565217, 0.45454545454545
63184, 1.2869565217391, 0.93260869565217, 0.40909090909091
63185, 1.2869565217391, 0.93260869565217, 0.36363636363636
63186, 1.2869565217391, 0.93260869565217, 0.31818181818182
63187, 1.2869565217391, 0.93260869565217, 0.27272727272727
63188, 1.2869565217391, 0.93260869565217, 0.22727272727273
63189, 1.2869565217391, 0.93260869565217, 0.18181818181818
63190, 1.2869565217391, 0.93260869565217, 0.13636363636364
63191, 1.2869565217391, 0.93260869565217, 0.090909090909091
63192, 1.2869565217391, 0.93260869565217, 0.045454545454545
63193, 1.3304347826087, 0.93260869565217, 0.45454545454545
63194, 1.3304347826087, 0.93260869565217, 0.40909090909091
63195, 1.3304347826087, 0.93260869565217, 0.36363636363636
63196, 1.3304347826087, 0.93260869565218, 0.31818181818182
63197, 1.3304347826087, 0.93260869565217, 0.27272727272727
63198, 1.3304347826087, 0.93260869565217, 0.22727272727273
63199, 1.3304347826087, 0.93260869565217, 0.18181818181818
63200, 1.3304347826087, 0.93260869565217, 0.13636363636364
63201, 1.3304347826087, 0.93260869565217, 0.090909090909091
63202, 1.3304347826087, 0.93260869565217, 0.045454545454545
63203, 1.3739130434783, 0.93260869565217, 0.45454545454545
63204, 1.3739130434783, 0.93260869565217, 0.40909090909091
63205, 1.3739130434783, 0.93260869565217, 0.36363636363636
63206, 1.3739130434783, 0.93260869565217, 0.31818181818182
63207, 1.3739130434783, 0.93260869565217, 0.27272727272727
63208, 1.3739130434783, 0.93260869565217, 0.22727272727273
63209, 1.3739130434783, 0.93260869565217, 0.18181818181818
63210, 1.3739130434783, 0.93260869565217, 0.13636363636364
63211, 1.3739130434783, 0.93260869565217, 0.090909090909091
63212, 1.3739130434783, 0.93260869565217, 0.045454545454545
63213, 1.4173913043478, 0.93260869565217, 0.45454545454545
63214, 1.4173913043478, 0.93260869565217, 0.40909090909091
63215, 1.4173913043478, 0.93260869565217, 0.36363636363636
63216, 1.4173913043478, 0.93260869565217, 0.31818181818182
63217, 1.4173913043478, 0.93260869565217, 0.27272727272727
63218, 1.4173913043478, 0.93260869565217, 0.22727272727273
63219, 1.4173913043478, 0.93260869565217, 0.18181818181818
63220, 1.4173913043478, 0.93260869565217, 0.13636363636364
63221, 1.4173913043478, 0.93260869565217, 0.090909090909091
63222, 1.4173913043478, 0.93260869565217, 0.045454545454545
63223, 1.4608695652174, 0.93260869565217, 0.45454545454545
63224, 1.4608695652174, 0.93260869565217, 0.40909090909091
63225, 1.4608695652174, 0.93260869565217, 0.36363636363636
63226, 1.4608695652174, 0.93260869565217, 0.31818181818182
63227, 1.4608695652174, 0.93260869565217, 0.27272727272727
63228, 1.4608695652174, 0.93260869565217, 0.22727272727273
63229, 1.4608695652174, 0.93260869565217, 0.18181818181818
63230, 1.4608695652174, 0.93260869565217, 0.13636363636364
63231, 1.4608695652174, 0.93260869565217, 0.090909090909091
63232, 1.4608695652174, 0.93260869565217, 0.045454545454545
63233, 1.504347826087, 0.93260869565217, 0.45454545454545
63234, 1.504347826087, 0.93260869565217, 0.40909090909091
63235, 1.504347826087, 0.93260869565217, 0.36363636363636
63236, 1.504347826087, 0.93260869565217, 0.31818181818182
63237, 1.504347826087, 0.93260869565217, 0.27272727272727
63238, 1.504347826087, 0.93260869565217, 0.22727272727273
63239, 1.504347826087, 0.93260869565217, 0.18181818181818
63240, 1.504347826087, 0.93260869565217, 0.13636363636364
63241, 1.504347826087, 0.93260869565217, 0.090909090909091
63242, 1.504347826087, 0.93260869565217, 0.045454545454545
63243, 1.5478260869565, 0.93260869565217, 0.45454545454545
63244, 1.5478260869565, 0.93260869565217, 0.40909090909091
63245, 1.5478260869565, 0.93260869565217, 0.36363636363636
63246, 1.5478260869565, 0.93260869565217, 0.31818181818182
63247, 1.5478260869565, 0.93260869565217, 0.27272727272727
63248, 1.5478260869565, 0.93260869565217, 0.22727272727273
63249, 1.5478260869565, 0.93260869565217, 0.18181818181818
63250, 1.5478260869565, 0.93260869565217, 0.13636363636364
63251, 1.5478260869565, 0.93260869565217, 0.090909090909091
63252, 1.5478260869565, 0.93260869565217, 0.045454545454545
63253, 1.5913043478261, 0.93260869565217, 0.45454545454545
63254, 1.5913043478261, 0.93260869565217, 0.40909090909091
63255, 1.5913043478261, 0.93260869565217, 0.36363636363636
63256, 1.5913043478261, 0.93260869565217, 0.31818181818182
63257, 1.5913043478261, 0.93260869565217, 0.27272727272727
63258, 1.5913043478261, 0.93260869565217, 0.22727272727273
63259, 1.5913043478261, 0.93260869565217, 0.18181818181818
63260, 1.5913043478261, 0.93260869565217, 0.13636363636364
63261, 1.5913043478261, 0.93260869565217, 0.090909090909091
63262, 1.5913043478261, 0.93260869565217, 0.045454545454545
63263, 1.6347826086957, 0.93260869565217, 0.45454545454545
63264, 1.6347826086957, 0.93260869565218, 0.40909090909091
63265, 1.6347826086957, 0.93260869565217, 0.36363636363636
63266, 1.6347826086957, 0.93260869565218, 0.31818181818182
63267, 1.6347826086957, 0.93260869565217, 0.27272727272727
63268, 1.6347826086957, 0.93260869565218, 0.22727272727273
63269, 1.6347826086957, 0.93260869565217, 0.18181818181818
63270, 1.6347826086957, 0.93260869565217, 0.13636363636364
63271, 1.6347826086957, 0.93260869565217, 0.090909090909091
63272, 1.6347826086957, 0.93260869565217, 0.045454545454545
63273, 1.6782608695652, 0.93260869565217, 0.45454545454545
63274, 1.6782608695652, 0.93260869565217, 0.40909090909091
63275, 1.6782608695652, 0.93260869565217, 0.36363636363636
63276, 1.6782608695652, 0.93260869565217, 0.31818181818182
63277, 1.6782608695652, 0.93260869565217, 0.27272727272727
63278, 1.6782608695652, 0.93260869565217, 0.22727272727273
63279, 1.6782608695652, 0.93260869565217, 0.18181818181818
63280, 1.6782608695652, 0.93260869565217, 0.13636363636364
63281, 1.6782608695652, 0.93260869565217, 0.090909090909091
63282, 1.6782608695652, 0.93260869565217, 0.045454545454545
63283, 1.7217391304348, 0.93260869565217, 0.45454545454545
63284, 1.7217391304348, 0.93260869565217, 0.40909090909091
63285, 1.7217391304348, 0.93260869565217, 0.36363636363636
63286, 1.7217391304348, 0.93260869565217, 0.31818181818182
63287, 1.7217391304348, 0.93260869565217, 0.27272727272727
63288, 1.7217391304348, 0.93260869565217, 0.22727272727273
63289, 1.7217391304348, 0.93260869565217, 0.18181818181818
63290, 1.7217391304348, 0.93260869565217, 0.13636363636364
63291, 1.7217391304348, 0.93260869565217, 0.090909090909091
63292, 1.7217391304348, 0.93260869565217, 0.045454545454545
63293, 1.7652173913043, 0.93260869565217, 0.45454545454545
63294, 1.7652173913043, 0.93260869565217, 0.40909090909091
63295, 1.7652173913043, 0.93260869565217, 0.36363636363636
63296, 1.7652173913043, 0.93260869565217, 0.31818181818182
63297, 1.7652173913043, 0.93260869565217, 0.27272727272727
63298, 1.7652173913043, 0.93260869565217, 0.22727272727273
63299, 1.7652173913043, 0.93260869565217, 0.18181818181818
63300, 1.7652173913043, 0.93260869565217, 0.13636363636364
63301, 1.7652173913043, 0.93260869565217, 0.090909090909091
63302, 1.7652173913043, 0.93260869565217, 0.045454545454545
63303, 1.8086956521739, 0.93260869565217, 0.45454545454545
63304, 1.8086956521739, 0.93260869565217, 0.40909090909091
63305, 1.8086956521739, 0.93260869565217, 0.36363636363636
63306, 1.8086956521739, 0.93260869565217, 0.31818181818182
63307, 1.8086956521739, 0.93260869565217, 0.27272727272727
63308, 1.8086956521739, 0.93260869565217, 0.22727272727273
63309, 1.8086956521739, 0.93260869565217, 0.18181818181818
63310, 1.8086956521739, 0.93260869565217, 0.13636363636364
63311, 1.8086956521739, 0.93260869565217, 0.090909090909091
63312, 1.8086956521739, 0.93260869565217, 0.045454545454545
63313, 1.8521739130435, 0.93260869565217, 0.45454545454545
63314, 1.8521739130435, 0.93260869565217, 0.40909090909091
63315, 1.8521739130435, 0.93260869565217, 0.36363636363636
63316, 1.8521739130435, 0.93260869565217, 0.31818181818182
63317, 1.8521739130435, 0.93260869565217, 0.27272727272727
63318, 1.8521739130435, 0.93260869565217, 0.22727272727273
63319, 1.8521739130435, 0.93260869565217, 0.18181818181818
63320, 1.8521739130435, 0.93260869565217, 0.13636363636364
63321, 1.8521739130435, 0.93260869565217, 0.090909090909091
63322, 1.8521739130435, 0.93260869565217, 0.045454545454545
63323, 1.895652173913, 0.93260869565217, 0.45454545454545
63324, 1.895652173913, 0.93260869565217, 0.40909090909091
63325, 1.895652173913, 0.93260869565217, 0.36363636363636
63326, 1.895652173913, 0.93260869565217, 0.31818181818182
63327, 1.895652173913, 0.93260869565217, 0.27272727272727
63328, 1.895652173913, 0.93260869565217, 0.22727272727273
63329, 1.895652173913, 0.93260869565217, 0.18181818181818
63330, 1.895652173913, 0.93260869565217, 0.13636363636364
63331, 1.895652173913, 0.93260869565217, 0.090909090909091
63332, 1.895652173913, 0.93260869565217, 0.045454545454545
63333, 1.9391304347826, 0.93260869565217, 0.45454545454545
63334, 1.9391304347826, 0.93260869565217, 0.40909090909091
63335, 1.9391304347826, 0.93260869565217, 0.36363636363636
63336, 1.9391304347826, 0.93260869565217, 0.31818181818182
63337, 1.9391304347826, 0.93260869565217, 0.27272727272727
63338, 1.9391304347826, 0.93260869565217, 0.22727272727273
63339, 1.9391304347826, 0.93260869565217, 0.18181818181818
63340, 1.9391304347826, 0.93260869565218, 0.13636363636364
63341, 1.9391304347826, 0.93260869565217, 0.090909090909091
63342, 1.9391304347826, 0.93260869565218, 0.045454545454545
63343, 1.9826086956522, 0.93260869565217, 0.45454545454545
63344, 1.9826086956522, 0.93260869565217, 0.40909090909091
63345, 1.9826086956522, 0.93260869565217, 0.36363636363636
63346, 1.9826086956522, 0.93260869565217, 0.31818181818182
63347, 1.9826086956522, 0.93260869565217, 0.27272727272727
63348, 1.9826086956522, 0.93260869565217, 0.22727272727273
63349, 1.9826086956522, 0.93260869565217, 0.18181818181818
63350, 1.9826086956522, 0.93260869565217, 0.13636363636364
63351, 1.9826086956522, 0.93260869565217, 0.090909090909091
63352, 1.9826086956522, 0.93260869565217, 0.045454545454545
63353, 2.0260869565217, 0.93260869565217, 0.45454545454545
63354, 2.0260869565217, 0.93260869565217, 0.40909090909091
63355, 2.0260869565217, 0.93260869565217, 0.36363636363636
63356, 2.0260869565217, 0.93260869565217, 0.31818181818182
63357, 2.0260869565217, 0.93260869565217, 0.27272727272727
63358, 2.0260869565217, 0.93260869565217, 0.22727272727273
63359, 2.0260869565217, 0.93260869565217, 0.18181818181818
63360, 2.0260869565217, 0.93260869565217, 0.13636363636364
63361, 2.0260869565217, 0.93260869565217, 0.090909090909091
63362, 2.0260869565217, 0.93260869565217, 0.045454545454545
63363, 2.0695652173913, 0.93260869565217, 0.45454545454545
63364, 2.0695652173913, 0.93260869565217, 0.40909090909091
63365, 2.0695652173913, 0.93260869565217, 0.36363636363636
63366, 2.0695652173913, 0.93260869565217, 0.31818181818182
63367, 2.0695652173913, 0.93260869565217, 0.27272727272727
63368, 2.0695652173913, 0.93260869565217, 0.22727272727273
63369, 2.0695652173913, 0.93260869565217, 0.18181818181818
63370, 2.0695652173913, 0.93260869565217, 0.13636363636364
63371, 2.0695652173913, 0.93260869565217, 0.090909090909091
63372, 2.0695652173913, 0.93260869565217, 0.045454545454545
63373, 2.1130434782609, 0.93260869565217, 0.45454545454545
63374, 2.1130434782609, 0.93260869565217, 0.40909090909091
63375, 2.1130434782609, 0.93260869565217, 0.36363636363636
63376, 2.1130434782609, 0.93260869565217, 0.31818181818182
63377, 2.1130434782609, 0.93260869565217, 0.27272727272727
63378, 2.1130434782609, 0.93260869565217, 0.22727272727273
63379, 2.1130434782609, 0.93260869565217, 0.18181818181818
63380, 2.1130434782609, 0.93260869565217, 0.13636363636364
63381, 2.1130434782609, 0.93260869565217, 0.090909090909091
63382, 2.1130434782609, 0.93260869565217, 0.045454545454545
63383, 2.1565217391304, 0.93260869565217, 0.45454545454545
63384, 2.1565217391304, 0.93260869565217, 0.40909090909091
63385, 2.1565217391304, 0.93260869565217, 0.36363636363636
63386, 2.1565217391304, 0.93260869565217, 0.31818181818182
63387, 2.1565217391304, 0.93260869565217, 0.27272727272727
63388, 2.1565217391304, 0.93260869565217, 0.22727272727273
63389, 2.1565217391304, 0.93260869565217, 0.18181818181818
63390, 2.1565217391304, 0.93260869565217, 0.13636363636364
63391, 2.1565217391304, 0.93260869565217, 0.090909090909091
63392, 2.1565217391304, 0.93260869565217, 0.045454545454545
63393, 1.2434782608696, 0.8804347826087, 0.45454545454545
63394, 1.2434782608696, 0.8804347826087, 0.40909090909091
63395, 1.2434782608696, 0.8804347826087, 0.36363636363636
63396, 1.2434782608696, 0.8804347826087, 0.31818181818182
63397, 1.2434782608696, 0.8804347826087, 0.27272727272727
63398, 1.2434782608696, 0.8804347826087, 0.22727272727273
63399, 1.2434782608696, 0.8804347826087, 0.18181818181818
63400, 1.2434782608696, 0.8804347826087, 0.13636363636364
63401, 1.2434782608696, 0.8804347826087, 0.090909090909091
63402, 1.2434782608696, 0.8804347826087, 0.045454545454545
63403, 1.2869565217391, 0.8804347826087, 0.45454545454545
63404, 1.2869565217391, 0.8804347826087, 0.40909090909091
63405, 1.2869565217391, 0.8804347826087, 0.36363636363636
63406, 1.2869565217391, 0.8804347826087, 0.31818181818182
63407, 1.2869565217391, 0.8804347826087, 0.27272727272727
63408, 1.2869565217391, 0.8804347826087, 0.22727272727273
63409, 1.2869565217391, 0.8804347826087, 0.18181818181818
63410, 1.2869565217391, 0.8804347826087, 0.13636363636364
63411, 1.2869565217391, 0.8804347826087, 0.090909090909091
63412, 1.2869565217391, 0.8804347826087, 0.045454545454545
63413, 1.3304347826087, 0.8804347826087, 0.45454545454545
63414, 1.3304347826087, 0.8804347826087, 0.40909090909091
63415, 1.3304347826087, 0.8804347826087, 0.36363636363636
63416, 1.3304347826087, 0.8804347826087, 0.31818181818182
63417, 1.3304347826087, 0.8804347826087, 0.27272727272727
63418, 1.3304347826087, 0.8804347826087, 0.22727272727273
63419, 1.3304347826087, 0.8804347826087, 0.18181818181818
63420, 1.3304347826087, 0.8804347826087, 0.13636363636364
63421, 1.3304347826087, 0.8804347826087, 0.090909090909091
63422, 1.3304347826087, 0.8804347826087, 0.045454545454545
63423, 1.3739130434783, 0.8804347826087, 0.45454545454545
63424, 1.3739130434783, 0.8804347826087, 0.40909090909091
63425, 1.3739130434783, 0.8804347826087, 0.36363636363636
63426, 1.3739130434783, 0.8804347826087, 0.31818181818182
63427, 1.3739130434783, 0.8804347826087, 0.27272727272727
63428, 1.3739130434783, 0.8804347826087, 0.22727272727273
63429, 1.3739130434783, 0.8804347826087, 0.18181818181818
63430, 1.3739130434783, 0.8804347826087, 0.13636363636364
63431, 1.3739130434783, 0.8804347826087, 0.090909090909091
63432, 1.3739130434783, 0.8804347826087, 0.045454545454545
63433, 1.4173913043478, 0.8804347826087, 0.45454545454545
63434, 1.4173913043478, 0.8804347826087, 0.40909090909091
63435, 1.4173913043478, 0.8804347826087, 0.36363636363636
63436, 1.4173913043478, 0.8804347826087, 0.31818181818182
63437, 1.4173913043478, 0.8804347826087, 0.27272727272727
63438, 1.4173913043478, 0.8804347826087, 0.22727272727273
63439, 1.4173913043478, 0.8804347826087, 0.18181818181818
63440, 1.4173913043478, 0.8804347826087, 0.13636363636364
63441, 1.4173913043478, 0.8804347826087, 0.090909090909091
63442, 1.4173913043478, 0.8804347826087, 0.045454545454545
63443, 1.4608695652174, 0.8804347826087, 0.45454545454545
63444, 1.4608695652174, 0.8804347826087, 0.40909090909091
63445, 1.4608695652174, 0.8804347826087, 0.36363636363636
63446, 1.4608695652174, 0.8804347826087, 0.31818181818182
63447, 1.4608695652174, 0.8804347826087, 0.27272727272727
63448, 1.4608695652174, 0.8804347826087, 0.22727272727273
63449, 1.4608695652174, 0.8804347826087, 0.18181818181818
63450, 1.4608695652174, 0.8804347826087, 0.13636363636364
63451, 1.4608695652174, 0.8804347826087, 0.090909090909091
63452, 1.4608695652174, 0.8804347826087, 0.045454545454545
63453, 1.504347826087, 0.8804347826087, 0.45454545454545
63454, 1.504347826087, 0.8804347826087, 0.40909090909091
63455, 1.504347826087, 0.8804347826087, 0.36363636363636
63456, 1.504347826087, 0.8804347826087, 0.31818181818182
63457, 1.504347826087, 0.8804347826087, 0.27272727272727
63458, 1.504347826087, 0.8804347826087, 0.22727272727273
63459, 1.504347826087, 0.8804347826087, 0.18181818181818
63460, 1.504347826087, 0.8804347826087, 0.13636363636364
63461, 1.504347826087, 0.8804347826087, 0.090909090909091
63462, 1.504347826087, 0.8804347826087, 0.045454545454545
63463, 1.5478260869565, 0.8804347826087, 0.45454545454545
63464, 1.5478260869565, 0.8804347826087, 0.40909090909091
63465, 1.5478260869565, 0.8804347826087, 0.36363636363636
63466, 1.5478260869565, 0.8804347826087, 0.31818181818182
63467, 1.5478260869565, 0.8804347826087, 0.27272727272727
63468, 1.5478260869565, 0.8804347826087, 0.22727272727273
63469, 1.5478260869565, 0.8804347826087, 0.18181818181818
63470, 1.5478260869565, 0.8804347826087, 0.13636363636364
63471, 1.5478260869565, 0.8804347826087, 0.090909090909091
63472, 1.5478260869565, 0.8804347826087, 0.045454545454545
63473, 1.5913043478261, 0.8804347826087, 0.45454545454545
63474, 1.5913043478261, 0.8804347826087, 0.40909090909091
63475, 1.5913043478261, 0.8804347826087, 0.36363636363636
63476, 1.5913043478261, 0.8804347826087, 0.31818181818182
63477, 1.5913043478261, 0.8804347826087, 0.27272727272727
63478, 1.5913043478261, 0.8804347826087, 0.22727272727273
63479, 1.5913043478261, 0.8804347826087, 0.18181818181818
63480, 1.5913043478261, 0.8804347826087, 0.13636363636364
63481, 1.5913043478261, 0.8804347826087, 0.090909090909091
63482, 1.5913043478261, 0.8804347826087, 0.045454545454545
63483, 1.6347826086957, 0.8804347826087, 0.45454545454545
63484, 1.6347826086957, 0.8804347826087, 0.40909090909091
63485, 1.6347826086957, 0.8804347826087, 0.36363636363636
63486, 1.6347826086957, 0.8804347826087, 0.31818181818182
63487, 1.6347826086957, 0.8804347826087, 0.27272727272727
63488, 1.6347826086957, 0.8804347826087, 0.22727272727273
63489, 1.6347826086957, 0.8804347826087, 0.18181818181818
63490, 1.6347826086957, 0.8804347826087, 0.13636363636364
63491, 1.6347826086957, 0.8804347826087, 0.090909090909091
63492, 1.6347826086957, 0.8804347826087, 0.045454545454545
63493, 1.6782608695652, 0.8804347826087, 0.45454545454545
63494, 1.6782608695652, 0.8804347826087, 0.40909090909091
63495, 1.6782608695652, 0.8804347826087, 0.36363636363636
63496, 1.6782608695652, 0.8804347826087, 0.31818181818182
63497, 1.6782608695652, 0.8804347826087, 0.27272727272727
63498, 1.6782608695652, 0.8804347826087, 0.22727272727273
63499, 1.6782608695652, 0.8804347826087, 0.18181818181818
63500, 1.6782608695652, 0.8804347826087, 0.13636363636364
63501, 1.6782608695652, 0.8804347826087, 0.090909090909091
63502, 1.6782608695652, 0.8804347826087, 0.045454545454545
63503, 1.7217391304348, 0.8804347826087, 0.45454545454545
63504, 1.7217391304348, 0.8804347826087, 0.40909090909091
63505, 1.7217391304348, 0.8804347826087, 0.36363636363636
63506, 1.7217391304348, 0.8804347826087, 0.31818181818182
63507, 1.7217391304348, 0.8804347826087, 0.27272727272727
63508, 1.7217391304348, 0.8804347826087, 0.22727272727273
63509, 1.7217391304348, 0.8804347826087, 0.18181818181818
63510, 1.7217391304348, 0.8804347826087, 0.13636363636364
63511, 1.7217391304348, 0.8804347826087, 0.090909090909091
63512, 1.7217391304348, 0.8804347826087, 0.045454545454545
63513, 1.7652173913043, 0.8804347826087, 0.45454545454545
63514, 1.7652173913043, 0.8804347826087, 0.40909090909091
63515, 1.7652173913043, 0.8804347826087, 0.36363636363636
63516, 1.7652173913043, 0.8804347826087, 0.31818181818182
63517, 1.7652173913043, 0.8804347826087, 0.27272727272727
63518, 1.7652173913043, 0.8804347826087, 0.22727272727273
63519, 1.7652173913043, 0.8804347826087, 0.18181818181818
63520, 1.7652173913043, 0.8804347826087, 0.13636363636364
63521, 1.7652173913043, 0.8804347826087, 0.090909090909091
63522, 1.7652173913043, 0.8804347826087, 0.045454545454545
63523, 1.8086956521739, 0.8804347826087, 0.45454545454545
63524, 1.8086956521739, 0.8804347826087, 0.40909090909091
63525, 1.8086956521739, 0.8804347826087, 0.36363636363636
63526, 1.8086956521739, 0.8804347826087, 0.31818181818182
63527, 1.8086956521739, 0.8804347826087, 0.27272727272727
63528, 1.8086956521739, 0.8804347826087, 0.22727272727273
63529, 1.8086956521739, 0.8804347826087, 0.18181818181818
63530, 1.8086956521739, 0.8804347826087, 0.13636363636364
63531, 1.8086956521739, 0.8804347826087, 0.090909090909091
63532, 1.8086956521739, 0.8804347826087, 0.045454545454545
63533, 1.8521739130435, 0.8804347826087, 0.45454545454545
63534, 1.8521739130435, 0.8804347826087, 0.40909090909091
63535, 1.8521739130435, 0.8804347826087, 0.36363636363636
63536, 1.8521739130435, 0.8804347826087, 0.31818181818182
63537, 1.8521739130435, 0.8804347826087, 0.27272727272727
63538, 1.8521739130435, 0.8804347826087, 0.22727272727273
63539, 1.8521739130435, 0.8804347826087, 0.18181818181818
63540, 1.8521739130435, 0.8804347826087, 0.13636363636364
63541, 1.8521739130435, 0.8804347826087, 0.090909090909091
63542, 1.8521739130435, 0.8804347826087, 0.045454545454545
63543, 1.895652173913, 0.8804347826087, 0.45454545454545
63544, 1.895652173913, 0.8804347826087, 0.40909090909091
63545, 1.895652173913, 0.8804347826087, 0.36363636363636
63546, 1.895652173913, 0.8804347826087, 0.31818181818182
63547, 1.895652173913, 0.8804347826087, 0.27272727272727
63548, 1.895652173913, 0.8804347826087, 0.22727272727273
63549, 1.895652173913, 0.8804347826087, 0.18181818181818
63550, 1.895652173913, 0.8804347826087, 0.13636363636364
63551, 1.895652173913, 0.8804347826087, 0.090909090909091
63552, 1.895652173913, 0.8804347826087, 0.045454545454545
63553, 1.9391304347826, 0.8804347826087, 0.45454545454545
63554, 1.9391304347826, 0.8804347826087, 0.40909090909091
63555, 1.9391304347826, 0.8804347826087, 0.36363636363636
63556, 1.9391304347826, 0.8804347826087, 0.31818181818182
63557, 1.9391304347826, 0.8804347826087, 0.27272727272727
63558, 1.9391304347826, 0.8804347826087, 0.22727272727273
63559, 1.9391304347826, 0.8804347826087, 0.18181818181818
63560, 1.9391304347826, 0.8804347826087, 0.13636363636364
63561, 1.9391304347826, 0.8804347826087, 0.090909090909091
63562, 1.9391304347826, 0.8804347826087, 0.045454545454545
63563, 1.9826086956522, 0.8804347826087, 0.45454545454545
63564, 1.9826086956522, 0.8804347826087, 0.40909090909091
63565, 1.9826086956522, 0.8804347826087, 0.36363636363636
63566, 1.9826086956522, 0.8804347826087, 0.31818181818182
63567, 1.9826086956522, 0.8804347826087, 0.27272727272727
63568, 1.9826086956522, 0.8804347826087, 0.22727272727273
63569, 1.9826086956522, 0.8804347826087, 0.18181818181818
63570, 1.9826086956522, 0.8804347826087, 0.13636363636364
63571, 1.9826086956522, 0.8804347826087, 0.090909090909091
63572, 1.9826086956522, 0.8804347826087, 0.045454545454545
63573, 2.0260869565217, 0.8804347826087, 0.45454545454545
63574, 2.0260869565217, 0.8804347826087, 0.40909090909091
63575, 2.0260869565217, 0.8804347826087, 0.36363636363636
63576, 2.0260869565217, 0.8804347826087, 0.31818181818182
63577, 2.0260869565217, 0.8804347826087, 0.27272727272727
63578, 2.0260869565217, 0.8804347826087, 0.22727272727273
63579, 2.0260869565217, 0.8804347826087, 0.18181818181818
63580, 2.0260869565217, 0.8804347826087, 0.13636363636364
63581, 2.0260869565217, 0.8804347826087, 0.090909090909091
63582, 2.0260869565217, 0.8804347826087, 0.045454545454545
63583, 2.0695652173913, 0.8804347826087, 0.45454545454545
63584, 2.0695652173913, 0.8804347826087, 0.40909090909091
63585, 2.0695652173913, 0.8804347826087, 0.36363636363636
63586, 2.0695652173913, 0.8804347826087, 0.31818181818182
63587, 2.0695652173913, 0.8804347826087, 0.27272727272727
63588, 2.0695652173913, 0.8804347826087, 0.22727272727273
63589, 2.0695652173913, 0.8804347826087, 0.18181818181818
63590, 2.0695652173913, 0.8804347826087, 0.13636363636364
63591, 2.0695652173913, 0.8804347826087, 0.090909090909091
63592, 2.0695652173913, 0.8804347826087, 0.045454545454545
63593, 2.1130434782609, 0.8804347826087, 0.45454545454545
63594, 2.1130434782609, 0.8804347826087, 0.40909090909091
63595, 2.1130434782609, 0.8804347826087, 0.36363636363636
63596, 2.1130434782609, 0.8804347826087, 0.31818181818182
63597, 2.1130434782609, 0.8804347826087, 0.27272727272727
63598, 2.1130434782609, 0.8804347826087, 0.22727272727273
63599, 2.1130434782609, 0.8804347826087, 0.18181818181818
63600, 2.1130434782609, 0.8804347826087, 0.13636363636364
63601, 2.1130434782609, 0.8804347826087, 0.090909090909091
63602, 2.1130434782609, 0.8804347826087, 0.045454545454545
63603, 2.1565217391304, 0.8804347826087, 0.45454545454545
63604, 2.1565217391304, 0.8804347826087, 0.40909090909091
63605, 2.1565217391304, 0.8804347826087, 0.36363636363636
63606, 2.1565217391304, 0.8804347826087, 0.31818181818182
63607, 2.1565217391304, 0.8804347826087, 0.27272727272727
63608, 2.1565217391304, 0.8804347826087, 0.22727272727273
63609, 2.1565217391304, 0.8804347826087, 0.18181818181818
63610, 2.1565217391304, 0.8804347826087, 0.13636363636364
63611, 2.1565217391304, 0.8804347826087, 0.090909090909091
63612, 2.1565217391304, 0.8804347826087, 0.045454545454545
63613, 1.2434782608696, 0.82826086956522, 0.45454545454545
63614, 1.2434782608696, 0.82826086956522, 0.40909090909091
63615, 1.2434782608696, 0.82826086956522, 0.36363636363636
63616, 1.2434782608696, 0.82826086956522, 0.31818181818182
63617, 1.2434782608696, 0.82826086956522, 0.27272727272727
63618, 1.2434782608696, 0.82826086956522, 0.22727272727273
63619, 1.2434782608696, 0.82826086956522, 0.18181818181818
63620, 1.2434782608696, 0.82826086956522, 0.13636363636364
63621, 1.2434782608696, 0.82826086956522, 0.090909090909091
63622, 1.2434782608696, 0.82826086956522, 0.045454545454545
63623, 1.2869565217391, 0.82826086956522, 0.45454545454545
63624, 1.2869565217391, 0.82826086956522, 0.40909090909091
63625, 1.2869565217391, 0.82826086956522, 0.36363636363636
63626, 1.2869565217391, 0.82826086956522, 0.31818181818182
63627, 1.2869565217391, 0.82826086956522, 0.27272727272727
63628, 1.2869565217391, 0.82826086956522, 0.22727272727273
63629, 1.2869565217391, 0.82826086956522, 0.18181818181818
63630, 1.2869565217391, 0.82826086956522, 0.13636363636364
63631, 1.2869565217391, 0.82826086956522, 0.090909090909091
63632, 1.2869565217391, 0.82826086956522, 0.045454545454545
63633, 1.3304347826087, 0.82826086956522, 0.45454545454545
63634, 1.3304347826087, 0.82826086956522, 0.40909090909091
63635, 1.3304347826087, 0.82826086956522, 0.36363636363636
63636, 1.3304347826087, 0.82826086956522, 0.31818181818182
63637, 1.3304347826087, 0.82826086956522, 0.27272727272727
63638, 1.3304347826087, 0.82826086956522, 0.22727272727273
63639, 1.3304347826087, 0.82826086956522, 0.18181818181818
63640, 1.3304347826087, 0.82826086956522, 0.13636363636364
63641, 1.3304347826087, 0.82826086956522, 0.090909090909091
63642, 1.3304347826087, 0.82826086956522, 0.045454545454545
63643, 1.3739130434783, 0.82826086956522, 0.45454545454545
63644, 1.3739130434783, 0.82826086956522, 0.40909090909091
63645, 1.3739130434783, 0.82826086956522, 0.36363636363636
63646, 1.3739130434783, 0.82826086956522, 0.31818181818182
63647, 1.3739130434783, 0.82826086956522, 0.27272727272727
63648, 1.3739130434783, 0.82826086956522, 0.22727272727273
63649, 1.3739130434783, 0.82826086956522, 0.18181818181818
63650, 1.3739130434783, 0.82826086956522, 0.13636363636364
63651, 1.3739130434783, 0.82826086956522, 0.090909090909091
63652, 1.3739130434783, 0.82826086956522, 0.045454545454545
63653, 1.4173913043478, 0.82826086956522, 0.45454545454545
63654, 1.4173913043478, 0.82826086956522, 0.40909090909091
63655, 1.4173913043478, 0.82826086956522, 0.36363636363636
63656, 1.4173913043478, 0.82826086956522, 0.31818181818182
63657, 1.4173913043478, 0.82826086956522, 0.27272727272727
63658, 1.4173913043478, 0.82826086956522, 0.22727272727273
63659, 1.4173913043478, 0.82826086956522, 0.18181818181818
63660, 1.4173913043478, 0.82826086956522, 0.13636363636364
63661, 1.4173913043478, 0.82826086956522, 0.090909090909091
63662, 1.4173913043478, 0.82826086956522, 0.045454545454545
63663, 1.4608695652174, 0.82826086956522, 0.45454545454545
63664, 1.4608695652174, 0.82826086956522, 0.40909090909091
63665, 1.4608695652174, 0.82826086956522, 0.36363636363636
63666, 1.4608695652174, 0.82826086956522, 0.31818181818182
63667, 1.4608695652174, 0.82826086956522, 0.27272727272727
63668, 1.4608695652174, 0.82826086956522, 0.22727272727273
63669, 1.4608695652174, 0.82826086956522, 0.18181818181818
63670, 1.4608695652174, 0.82826086956522, 0.13636363636364
63671, 1.4608695652174, 0.82826086956522, 0.090909090909091
63672, 1.4608695652174, 0.82826086956522, 0.045454545454545
63673, 1.504347826087, 0.82826086956522, 0.45454545454545
63674, 1.504347826087, 0.82826086956522, 0.40909090909091
63675, 1.504347826087, 0.82826086956522, 0.36363636363636
63676, 1.504347826087, 0.82826086956522, 0.31818181818182
63677, 1.504347826087, 0.82826086956522, 0.27272727272727
63678, 1.504347826087, 0.82826086956522, 0.22727272727273
63679, 1.504347826087, 0.82826086956522, 0.18181818181818
63680, 1.504347826087, 0.82826086956522, 0.13636363636364
63681, 1.504347826087, 0.82826086956522, 0.090909090909091
63682, 1.504347826087, 0.82826086956522, 0.045454545454545
63683, 1.5478260869565, 0.82826086956522, 0.45454545454545
63684, 1.5478260869565, 0.82826086956522, 0.40909090909091
63685, 1.5478260869565, 0.82826086956522, 0.36363636363636
63686, 1.5478260869565, 0.82826086956522, 0.31818181818182
63687, 1.5478260869565, 0.82826086956522, 0.27272727272727
63688, 1.5478260869565, 0.82826086956522, 0.22727272727273
63689, 1.5478260869565, 0.82826086956522, 0.18181818181818
63690, 1.5478260869565, 0.82826086956522, 0.13636363636364
63691, 1.5478260869565, 0.82826086956522, 0.090909090909091
63692, 1.5478260869565, 0.82826086956522, 0.045454545454545
63693, 1.5913043478261, 0.82826086956522, 0.45454545454545
63694, 1.5913043478261, 0.82826086956522, 0.40909090909091
63695, 1.5913043478261, 0.82826086956522, 0.36363636363636
63696, 1.5913043478261, 0.82826086956522, 0.31818181818182
63697, 1.5913043478261, 0.82826086956522, 0.27272727272727
63698, 1.5913043478261, 0.82826086956522, 0.22727272727273
63699, 1.5913043478261, 0.82826086956522, 0.18181818181818
63700, 1.5913043478261, 0.82826086956522, 0.13636363636364
63701, 1.5913043478261, 0.82826086956522, 0.090909090909091
63702, 1.5913043478261, 0.82826086956522, 0.045454545454545
63703, 1.6347826086957, 0.82826086956522, 0.45454545454545
63704, 1.6347826086957, 0.82826086956522, 0.40909090909091
63705, 1.6347826086957, 0.82826086956522, 0.36363636363636
63706, 1.6347826086957, 0.82826086956522, 0.31818181818182
63707, 1.6347826086957, 0.82826086956522, 0.27272727272727
63708, 1.6347826086957, 0.82826086956522, 0.22727272727273
63709, 1.6347826086957, 0.82826086956522, 0.18181818181818
63710, 1.6347826086957, 0.82826086956522, 0.13636363636364
63711, 1.6347826086957, 0.82826086956522, 0.090909090909091
63712, 1.6347826086957, 0.82826086956522, 0.045454545454545
63713, 1.6782608695652, 0.82826086956522, 0.45454545454545
63714, 1.6782608695652, 0.82826086956522, 0.40909090909091
63715, 1.6782608695652, 0.82826086956522, 0.36363636363636
63716, 1.6782608695652, 0.82826086956522, 0.31818181818182
63717, 1.6782608695652, 0.82826086956522, 0.27272727272727
63718, 1.6782608695652, 0.82826086956522, 0.22727272727273
63719, 1.6782608695652, 0.82826086956522, 0.18181818181818
63720, 1.6782608695652, 0.82826086956522, 0.13636363636364
63721, 1.6782608695652, 0.82826086956522, 0.090909090909091
63722, 1.6782608695652, 0.82826086956522, 0.045454545454545
63723, 1.7217391304348, 0.82826086956522, 0.45454545454545
63724, 1.7217391304348, 0.82826086956522, 0.40909090909091
63725, 1.7217391304348, 0.82826086956522, 0.36363636363636
63726, 1.7217391304348, 0.82826086956522, 0.31818181818182
63727, 1.7217391304348, 0.82826086956522, 0.27272727272727
63728, 1.7217391304348, 0.82826086956522, 0.22727272727273
63729, 1.7217391304348, 0.82826086956522, 0.18181818181818
63730, 1.7217391304348, 0.82826086956522, 0.13636363636364
63731, 1.7217391304348, 0.82826086956522, 0.090909090909091
63732, 1.7217391304348, 0.82826086956522, 0.045454545454545
63733, 1.7652173913043, 0.82826086956522, 0.45454545454545
63734, 1.7652173913043, 0.82826086956522, 0.40909090909091
63735, 1.7652173913043, 0.82826086956522, 0.36363636363636
63736, 1.7652173913043, 0.82826086956522, 0.31818181818182
63737, 1.7652173913043, 0.82826086956522, 0.27272727272727
63738, 1.7652173913043, 0.82826086956522, 0.22727272727273
63739, 1.7652173913043, 0.82826086956522, 0.18181818181818
63740, 1.7652173913043, 0.82826086956522, 0.13636363636364
63741, 1.7652173913043, 0.82826086956522, 0.090909090909091
63742, 1.7652173913043, 0.82826086956522, 0.045454545454545
63743, 1.8086956521739, 0.82826086956522, 0.45454545454545
63744, 1.8086956521739, 0.82826086956522, 0.40909090909091
63745, 1.8086956521739, 0.82826086956522, 0.36363636363636
63746, 1.8086956521739, 0.82826086956522, 0.31818181818182
63747, 1.8086956521739, 0.82826086956522, 0.27272727272727
63748, 1.8086956521739, 0.82826086956522, 0.22727272727273
63749, 1.8086956521739, 0.82826086956522, 0.18181818181818
63750, 1.8086956521739, 0.82826086956522, 0.13636363636364
63751, 1.8086956521739, 0.82826086956522, 0.090909090909091
63752, 1.8086956521739, 0.82826086956522, 0.045454545454545
63753, 1.8521739130435, 0.82826086956522, 0.45454545454545
63754, 1.8521739130435, 0.82826086956522, 0.40909090909091
63755, 1.8521739130435, 0.82826086956522, 0.36363636363636
63756, 1.8521739130435, 0.82826086956522, 0.31818181818182
63757, 1.8521739130435, 0.82826086956522, 0.27272727272727
63758, 1.8521739130435, 0.82826086956522, 0.22727272727273
63759, 1.8521739130435, 0.82826086956522, 0.18181818181818
63760, 1.8521739130435, 0.82826086956522, 0.13636363636364
63761, 1.8521739130435, 0.82826086956522, 0.090909090909091
63762, 1.8521739130435, 0.82826086956522, 0.045454545454545
63763, 1.895652173913, 0.82826086956522, 0.45454545454545
63764, 1.895652173913, 0.82826086956522, 0.40909090909091
63765, 1.895652173913, 0.82826086956522, 0.36363636363636
63766, 1.895652173913, 0.82826086956522, 0.31818181818182
63767, 1.895652173913, 0.82826086956522, 0.27272727272727
63768, 1.895652173913, 0.82826086956522, 0.22727272727273
63769, 1.895652173913, 0.82826086956522, 0.18181818181818
63770, 1.895652173913, 0.82826086956522, 0.13636363636364
63771, 1.895652173913, 0.82826086956522, 0.090909090909091
63772, 1.895652173913, 0.82826086956522, 0.045454545454545
63773, 1.9391304347826, 0.82826086956522, 0.45454545454545
63774, 1.9391304347826, 0.82826086956522, 0.40909090909091
63775, 1.9391304347826, 0.82826086956522, 0.36363636363636
63776, 1.9391304347826, 0.82826086956522, 0.31818181818182
63777, 1.9391304347826, 0.82826086956522, 0.27272727272727
63778, 1.9391304347826, 0.82826086956522, 0.22727272727273
63779, 1.9391304347826, 0.82826086956522, 0.18181818181818
63780, 1.9391304347826, 0.82826086956522, 0.13636363636364
63781, 1.9391304347826, 0.82826086956522, 0.090909090909091
63782, 1.9391304347826, 0.82826086956522, 0.045454545454545
63783, 1.9826086956522, 0.82826086956522, 0.45454545454545
63784, 1.9826086956522, 0.82826086956522, 0.40909090909091
63785, 1.9826086956522, 0.82826086956522, 0.36363636363636
63786, 1.9826086956522, 0.82826086956522, 0.31818181818182
63787, 1.9826086956522, 0.82826086956522, 0.27272727272727
63788, 1.9826086956522, 0.82826086956522, 0.22727272727273
63789, 1.9826086956522, 0.82826086956522, 0.18181818181818
63790, 1.9826086956522, 0.82826086956522, 0.13636363636364
63791, 1.9826086956522, 0.82826086956522, 0.090909090909091
63792, 1.9826086956522, 0.82826086956522, 0.045454545454545
63793, 2.0260869565217, 0.82826086956522, 0.45454545454545
63794, 2.0260869565217, 0.82826086956522, 0.40909090909091
63795, 2.0260869565217, 0.82826086956522, 0.36363636363636
63796, 2.0260869565217, 0.82826086956522, 0.31818181818182
63797, 2.0260869565217, 0.82826086956522, 0.27272727272727
63798, 2.0260869565217, 0.82826086956522, 0.22727272727273
63799, 2.0260869565217, 0.82826086956522, 0.18181818181818
63800, 2.0260869565217, 0.82826086956522, 0.13636363636364
63801, 2.0260869565217, 0.82826086956522, 0.090909090909091
63802, 2.0260869565217, 0.82826086956522, 0.045454545454545
63803, 2.0695652173913, 0.82826086956522, 0.45454545454545
63804, 2.0695652173913, 0.82826086956522, 0.40909090909091
63805, 2.0695652173913, 0.82826086956522, 0.36363636363636
63806, 2.0695652173913, 0.82826086956522, 0.31818181818182
63807, 2.0695652173913, 0.82826086956522, 0.27272727272727
63808, 2.0695652173913, 0.82826086956522, 0.22727272727273
63809, 2.0695652173913, 0.82826086956522, 0.18181818181818
63810, 2.0695652173913, 0.82826086956522, 0.13636363636364
63811, 2.0695652173913, 0.82826086956522, 0.090909090909091
63812, 2.0695652173913, 0.82826086956522, 0.045454545454545
63813, 2.1130434782609, 0.82826086956522, 0.45454545454545
63814, 2.1130434782609, 0.82826086956522, 0.40909090909091
63815, 2.1130434782609, 0.82826086956522, 0.36363636363636
63816, 2.1130434782609, 0.82826086956522, 0.31818181818182
63817, 2.1130434782609, 0.82826086956522, 0.27272727272727
63818, 2.1130434782609, 0.82826086956522, 0.22727272727273
63819, 2.1130434782609, 0.82826086956522, 0.18181818181818
63820, 2.1130434782609, 0.82826086956522, 0.13636363636364
63821, 2.1130434782609, 0.82826086956522, 0.090909090909091
63822, 2.1130434782609, 0.82826086956522, 0.045454545454545
63823, 2.1565217391304, 0.82826086956522, 0.45454545454545
63824, 2.1565217391304, 0.82826086956522, 0.40909090909091
63825, 2.1565217391304, 0.82826086956522, 0.36363636363636
63826, 2.1565217391304, 0.82826086956522, 0.31818181818182
63827, 2.1565217391304, 0.82826086956522, 0.27272727272727
63828, 2.1565217391304, 0.82826086956522, 0.22727272727273
63829, 2.1565217391304, 0.82826086956522, 0.18181818181818
63830, 2.1565217391304, 0.82826086956522, 0.13636363636364
63831, 2.1565217391304, 0.82826086956522, 0.090909090909091
63832, 2.1565217391304, 0.82826086956522, 0.045454545454545
63833, 1.2434782608696, 0.77608695652174, 0.45454545454545
63834, 1.2434782608696, 0.77608695652174, 0.40909090909091
63835, 1.2434782608696, 0.77608695652174, 0.36363636363636
63836, 1.2434782608696, 0.77608695652174, 0.31818181818182
63837, 1.2434782608696, 0.77608695652174, 0.27272727272727
63838, 1.2434782608696, 0.77608695652174, 0.22727272727273
63839, 1.2434782608696, 0.77608695652174, 0.18181818181818
63840, 1.2434782608696, 0.77608695652174, 0.13636363636364
63841, 1.2434782608696, 0.77608695652174, 0.090909090909091
63842, 1.2434782608696, 0.77608695652174, 0.045454545454545
63843, 1.2869565217391, 0.77608695652174, 0.45454545454545
63844, 1.2869565217391, 0.77608695652174, 0.40909090909091
63845, 1.2869565217391, 0.77608695652174, 0.36363636363636
63846, 1.2869565217391, 0.77608695652174, 0.31818181818182
63847, 1.2869565217391, 0.77608695652174, 0.27272727272727
63848, 1.2869565217391, 0.77608695652174, 0.22727272727273
63849, 1.2869565217391, 0.77608695652174, 0.18181818181818
63850, 1.2869565217391, 0.77608695652174, 0.13636363636364
63851, 1.2869565217391, 0.77608695652174, 0.090909090909091
63852, 1.2869565217391, 0.77608695652174, 0.045454545454545
63853, 1.3304347826087, 0.77608695652174, 0.45454545454545
63854, 1.3304347826087, 0.77608695652174, 0.40909090909091
63855, 1.3304347826087, 0.77608695652174, 0.36363636363636
63856, 1.3304347826087, 0.77608695652174, 0.31818181818182
63857, 1.3304347826087, 0.77608695652174, 0.27272727272727
63858, 1.3304347826087, 0.77608695652174, 0.22727272727273
63859, 1.3304347826087, 0.77608695652174, 0.18181818181818
63860, 1.3304347826087, 0.77608695652174, 0.13636363636364
63861, 1.3304347826087, 0.77608695652174, 0.090909090909091
63862, 1.3304347826087, 0.77608695652174, 0.045454545454545
63863, 1.3739130434783, 0.77608695652174, 0.45454545454545
63864, 1.3739130434783, 0.77608695652174, 0.40909090909091
63865, 1.3739130434783, 0.77608695652174, 0.36363636363636
63866, 1.3739130434783, 0.77608695652174, 0.31818181818182
63867, 1.3739130434783, 0.77608695652174, 0.27272727272727
63868, 1.3739130434783, 0.77608695652174, 0.22727272727273
63869, 1.3739130434783, 0.77608695652174, 0.18181818181818
63870, 1.3739130434783, 0.77608695652174, 0.13636363636364
63871, 1.3739130434783, 0.77608695652174, 0.090909090909091
63872, 1.3739130434783, 0.77608695652174, 0.045454545454545
63873, 1.4173913043478, 0.77608695652174, 0.45454545454545
63874, 1.4173913043478, 0.77608695652174, 0.40909090909091
63875, 1.4173913043478, 0.77608695652174, 0.36363636363636
63876, 1.4173913043478, 0.77608695652174, 0.31818181818182
63877, 1.4173913043478, 0.77608695652174, 0.27272727272727
63878, 1.4173913043478, 0.77608695652174, 0.22727272727273
63879, 1.4173913043478, 0.77608695652174, 0.18181818181818
63880, 1.4173913043478, 0.77608695652174, 0.13636363636364
63881, 1.4173913043478, 0.77608695652174, 0.090909090909091
63882, 1.4173913043478, 0.77608695652174, 0.045454545454545
63883, 1.4608695652174, 0.77608695652174, 0.45454545454545
63884, 1.4608695652174, 0.77608695652174, 0.40909090909091
63885, 1.4608695652174, 0.77608695652174, 0.36363636363636
63886, 1.4608695652174, 0.77608695652174, 0.31818181818182
63887, 1.4608695652174, 0.77608695652174, 0.27272727272727
63888, 1.4608695652174, 0.77608695652174, 0.22727272727273
63889, 1.4608695652174, 0.77608695652174, 0.18181818181818
63890, 1.4608695652174, 0.77608695652174, 0.13636363636364
63891, 1.4608695652174, 0.77608695652174, 0.090909090909091
63892, 1.4608695652174, 0.77608695652174, 0.045454545454545
63893, 1.504347826087, 0.77608695652174, 0.45454545454545
63894, 1.504347826087, 0.77608695652174, 0.40909090909091
63895, 1.504347826087, 0.77608695652174, 0.36363636363636
63896, 1.504347826087, 0.77608695652174, 0.31818181818182
63897, 1.504347826087, 0.77608695652174, 0.27272727272727
63898, 1.504347826087, 0.77608695652174, 0.22727272727273
63899, 1.504347826087, 0.77608695652174, 0.18181818181818
63900, 1.504347826087, 0.77608695652174, 0.13636363636364
63901, 1.504347826087, 0.77608695652174, 0.090909090909091
63902, 1.504347826087, 0.77608695652174, 0.045454545454545
63903, 1.5478260869565, 0.77608695652174, 0.45454545454545
63904, 1.5478260869565, 0.77608695652174, 0.40909090909091
63905, 1.5478260869565, 0.77608695652174, 0.36363636363636
63906, 1.5478260869565, 0.77608695652174, 0.31818181818182
63907, 1.5478260869565, 0.77608695652174, 0.27272727272727
63908, 1.5478260869565, 0.77608695652174, 0.22727272727273
63909, 1.5478260869565, 0.77608695652174, 0.18181818181818
63910, 1.5478260869565, 0.77608695652174, 0.13636363636364
63911, 1.5478260869565, 0.77608695652174, 0.090909090909091
63912, 1.5478260869565, 0.77608695652174, 0.045454545454545
63913, 1.5913043478261, 0.77608695652174, 0.45454545454545
63914, 1.5913043478261, 0.77608695652174, 0.40909090909091
63915, 1.5913043478261, 0.77608695652174, 0.36363636363636
63916, 1.5913043478261, 0.77608695652174, 0.31818181818182
63917, 1.5913043478261, 0.77608695652174, 0.27272727272727
63918, 1.5913043478261, 0.77608695652174, 0.22727272727273
63919, 1.5913043478261, 0.77608695652174, 0.18181818181818
63920, 1.5913043478261, 0.77608695652174, 0.13636363636364
63921, 1.5913043478261, 0.77608695652174, 0.090909090909091
63922, 1.5913043478261, 0.77608695652174, 0.045454545454545
63923, 1.6347826086957, 0.77608695652174, 0.45454545454545
63924, 1.6347826086957, 0.77608695652174, 0.40909090909091
63925, 1.6347826086957, 0.77608695652174, 0.36363636363636
63926, 1.6347826086957, 0.77608695652174, 0.31818181818182
63927, 1.6347826086957, 0.77608695652174, 0.27272727272727
63928, 1.6347826086957, 0.77608695652174, 0.22727272727273
63929, 1.6347826086957, 0.77608695652174, 0.18181818181818
63930, 1.6347826086957, 0.77608695652174, 0.13636363636364
63931, 1.6347826086957, 0.77608695652174, 0.090909090909091
63932, 1.6347826086957, 0.77608695652174, 0.045454545454545
63933, 1.6782608695652, 0.77608695652174, 0.45454545454545
63934, 1.6782608695652, 0.77608695652174, 0.40909090909091
63935, 1.6782608695652, 0.77608695652174, 0.36363636363636
63936, 1.6782608695652, 0.77608695652174, 0.31818181818182
63937, 1.6782608695652, 0.77608695652174, 0.27272727272727
63938, 1.6782608695652, 0.77608695652174, 0.22727272727273
63939, 1.6782608695652, 0.77608695652174, 0.18181818181818
63940, 1.6782608695652, 0.77608695652174, 0.13636363636364
63941, 1.6782608695652, 0.77608695652174, 0.090909090909091
63942, 1.6782608695652, 0.77608695652174, 0.045454545454545
63943, 1.7217391304348, 0.77608695652174, 0.45454545454545
63944, 1.7217391304348, 0.77608695652174, 0.40909090909091
63945, 1.7217391304348, 0.77608695652174, 0.36363636363636
63946, 1.7217391304348, 0.77608695652174, 0.31818181818182
63947, 1.7217391304348, 0.77608695652174, 0.27272727272727
63948, 1.7217391304348, 0.77608695652174, 0.22727272727273
63949, 1.7217391304348, 0.77608695652174, 0.18181818181818
63950, 1.7217391304348, 0.77608695652174, 0.13636363636364
63951, 1.7217391304348, 0.77608695652174, 0.090909090909091
63952, 1.7217391304348, 0.77608695652174, 0.045454545454545
63953, 1.7652173913043, 0.77608695652174, 0.45454545454545
63954, 1.7652173913043, 0.77608695652174, 0.40909090909091
63955, 1.7652173913043, 0.77608695652174, 0.36363636363636
63956, 1.7652173913043, 0.77608695652174, 0.31818181818182
63957, 1.7652173913043, 0.77608695652174, 0.27272727272727
63958, 1.7652173913043, 0.77608695652174, 0.22727272727273
63959, 1.7652173913043, 0.77608695652174, 0.18181818181818
63960, 1.7652173913043, 0.77608695652174, 0.13636363636364
63961, 1.7652173913043, 0.77608695652174, 0.090909090909091
63962, 1.7652173913043, 0.77608695652174, 0.045454545454545
63963, 1.8086956521739, 0.77608695652174, 0.45454545454545
63964, 1.8086956521739, 0.77608695652174, 0.40909090909091
63965, 1.8086956521739, 0.77608695652174, 0.36363636363636
63966, 1.8086956521739, 0.77608695652174, 0.31818181818182
63967, 1.8086956521739, 0.77608695652174, 0.27272727272727
63968, 1.8086956521739, 0.77608695652174, 0.22727272727273
63969, 1.8086956521739, 0.77608695652174, 0.18181818181818
63970, 1.8086956521739, 0.77608695652174, 0.13636363636364
63971, 1.8086956521739, 0.77608695652174, 0.090909090909091
63972, 1.8086956521739, 0.77608695652174, 0.045454545454545
63973, 1.8521739130435, 0.77608695652174, 0.45454545454545
63974, 1.8521739130435, 0.77608695652174, 0.40909090909091
63975, 1.8521739130435, 0.77608695652174, 0.36363636363636
63976, 1.8521739130435, 0.77608695652174, 0.31818181818182
63977, 1.8521739130435, 0.77608695652174, 0.27272727272727
63978, 1.8521739130435, 0.77608695652174, 0.22727272727273
63979, 1.8521739130435, 0.77608695652174, 0.18181818181818
63980, 1.8521739130435, 0.77608695652174, 0.13636363636364
63981, 1.8521739130435, 0.77608695652174, 0.090909090909091
63982, 1.8521739130435, 0.77608695652174, 0.045454545454545
63983, 1.895652173913, 0.77608695652174, 0.45454545454545
63984, 1.895652173913, 0.77608695652174, 0.40909090909091
63985, 1.895652173913, 0.77608695652174, 0.36363636363636
63986, 1.895652173913, 0.77608695652174, 0.31818181818182
63987, 1.895652173913, 0.77608695652174, 0.27272727272727
63988, 1.895652173913, 0.77608695652174, 0.22727272727273
63989, 1.895652173913, 0.77608695652174, 0.18181818181818
63990, 1.895652173913, 0.77608695652174, 0.13636363636364
63991, 1.895652173913, 0.77608695652174, 0.090909090909091
63992, 1.895652173913, 0.77608695652174, 0.045454545454545
63993, 1.9391304347826, 0.77608695652174, 0.45454545454545
63994, 1.9391304347826, 0.77608695652174, 0.40909090909091
63995, 1.9391304347826, 0.77608695652174, 0.36363636363636
63996, 1.9391304347826, 0.77608695652174, 0.31818181818182
63997, 1.9391304347826, 0.77608695652174, 0.27272727272727
63998, 1.9391304347826, 0.77608695652174, 0.22727272727273
63999, 1.9391304347826, 0.77608695652174, 0.18181818181818
64000, 1.9391304347826, 0.77608695652174, 0.13636363636364
64001, 1.9391304347826, 0.77608695652174, 0.090909090909091
64002, 1.9391304347826, 0.77608695652174, 0.045454545454545
64003, 1.9826086956522, 0.77608695652174, 0.45454545454545
64004, 1.9826086956522, 0.77608695652174, 0.40909090909091
64005, 1.9826086956522, 0.77608695652174, 0.36363636363636
64006, 1.9826086956522, 0.77608695652174, 0.31818181818182
64007, 1.9826086956522, 0.77608695652174, 0.27272727272727
64008, 1.9826086956522, 0.77608695652174, 0.22727272727273
64009, 1.9826086956522, 0.77608695652174, 0.18181818181818
64010, 1.9826086956522, 0.77608695652174, 0.13636363636364
64011, 1.9826086956522, 0.77608695652174, 0.090909090909091
64012, 1.9826086956522, 0.77608695652174, 0.045454545454545
64013, 2.0260869565217, 0.77608695652174, 0.45454545454545
64014, 2.0260869565217, 0.77608695652174, 0.40909090909091
64015, 2.0260869565217, 0.77608695652174, 0.36363636363636
64016, 2.0260869565217, 0.77608695652174, 0.31818181818182
64017, 2.0260869565217, 0.77608695652174, 0.27272727272727
64018, 2.0260869565217, 0.77608695652174, 0.22727272727273
64019, 2.0260869565217, 0.77608695652174, 0.18181818181818
64020, 2.0260869565217, 0.77608695652174, 0.13636363636364
64021, 2.0260869565217, 0.77608695652174, 0.090909090909091
64022, 2.0260869565217, 0.77608695652174, 0.045454545454545
64023, 2.0695652173913, 0.77608695652174, 0.45454545454545
64024, 2.0695652173913, 0.77608695652174, 0.40909090909091
64025, 2.0695652173913, 0.77608695652174, 0.36363636363636
64026, 2.0695652173913, 0.77608695652174, 0.31818181818182
64027, 2.0695652173913, 0.77608695652174, 0.27272727272727
64028, 2.0695652173913, 0.77608695652174, 0.22727272727273
64029, 2.0695652173913, 0.77608695652174, 0.18181818181818
64030, 2.0695652173913, 0.77608695652174, 0.13636363636364
64031, 2.0695652173913, 0.77608695652174, 0.090909090909091
64032, 2.0695652173913, 0.77608695652174, 0.045454545454545
64033, 2.1130434782609, 0.77608695652174, 0.45454545454545
64034, 2.1130434782609, 0.77608695652174, 0.40909090909091
64035, 2.1130434782609, 0.77608695652174, 0.36363636363636
64036, 2.1130434782609, 0.77608695652174, 0.31818181818182
64037, 2.1130434782609, 0.77608695652174, 0.27272727272727
64038, 2.1130434782609, 0.77608695652174, 0.22727272727273
64039, 2.1130434782609, 0.77608695652174, 0.18181818181818
64040, 2.1130434782609, 0.77608695652174, 0.13636363636364
64041, 2.1130434782609, 0.77608695652174, 0.090909090909091
64042, 2.1130434782609, 0.77608695652174, 0.045454545454545
64043, 2.1565217391304, 0.77608695652174, 0.45454545454545
64044, 2.1565217391304, 0.77608695652174, 0.40909090909091
64045, 2.1565217391304, 0.77608695652174, 0.36363636363636
64046, 2.1565217391304, 0.77608695652174, 0.31818181818182
64047, 2.1565217391304, 0.77608695652174, 0.27272727272727
64048, 2.1565217391304, 0.77608695652174, 0.22727272727273
64049, 2.1565217391304, 0.77608695652174, 0.18181818181818
64050, 2.1565217391304, 0.77608695652174, 0.13636363636364
64051, 2.1565217391304, 0.77608695652174, 0.090909090909091
64052, 2.1565217391304, 0.77608695652174, 0.045454545454545
64053, 1.2434782608696, 0.72391304347826, 0.45454545454545
64054, 1.2434782608696, 0.72391304347826, 0.40909090909091
64055, 1.2434782608696, 0.72391304347826, 0.36363636363636
64056, 1.2434782608696, 0.72391304347826, 0.31818181818182
64057, 1.2434782608696, 0.72391304347826, 0.27272727272727
64058, 1.2434782608696, 0.72391304347826, 0.22727272727273
64059, 1.2434782608696, 0.72391304347826, 0.18181818181818
64060, 1.2434782608696, 0.72391304347826, 0.13636363636364
64061, 1.2434782608696, 0.72391304347826, 0.090909090909091
64062, 1.2434782608696, 0.72391304347826, 0.045454545454545
64063, 1.2869565217391, 0.72391304347826, 0.45454545454545
64064, 1.2869565217391, 0.72391304347826, 0.40909090909091
64065, 1.2869565217391, 0.72391304347826, 0.36363636363636
64066, 1.2869565217391, 0.72391304347826, 0.31818181818182
64067, 1.2869565217391, 0.72391304347826, 0.27272727272727
64068, 1.2869565217391, 0.72391304347826, 0.22727272727273
64069, 1.2869565217391, 0.72391304347826, 0.18181818181818
64070, 1.2869565217391, 0.72391304347826, 0.13636363636364
64071, 1.2869565217391, 0.72391304347826, 0.090909090909091
64072, 1.2869565217391, 0.72391304347826, 0.045454545454545
64073, 1.3304347826087, 0.72391304347826, 0.45454545454545
64074, 1.3304347826087, 0.72391304347826, 0.40909090909091
64075, 1.3304347826087, 0.72391304347826, 0.36363636363636
64076, 1.3304347826087, 0.72391304347826, 0.31818181818182
64077, 1.3304347826087, 0.72391304347826, 0.27272727272727
64078, 1.3304347826087, 0.72391304347826, 0.22727272727273
64079, 1.3304347826087, 0.72391304347826, 0.18181818181818
64080, 1.3304347826087, 0.72391304347826, 0.13636363636364
64081, 1.3304347826087, 0.72391304347826, 0.090909090909091
64082, 1.3304347826087, 0.72391304347826, 0.045454545454545
64083, 1.3739130434783, 0.72391304347826, 0.45454545454545
64084, 1.3739130434783, 0.72391304347826, 0.40909090909091
64085, 1.3739130434783, 0.72391304347826, 0.36363636363636
64086, 1.3739130434783, 0.72391304347826, 0.31818181818182
64087, 1.3739130434783, 0.72391304347826, 0.27272727272727
64088, 1.3739130434783, 0.72391304347826, 0.22727272727273
64089, 1.3739130434783, 0.72391304347826, 0.18181818181818
64090, 1.3739130434783, 0.72391304347826, 0.13636363636364
64091, 1.3739130434783, 0.72391304347826, 0.090909090909091
64092, 1.3739130434783, 0.72391304347826, 0.045454545454545
64093, 1.4173913043478, 0.72391304347826, 0.45454545454545
64094, 1.4173913043478, 0.72391304347826, 0.40909090909091
64095, 1.4173913043478, 0.72391304347826, 0.36363636363636
64096, 1.4173913043478, 0.72391304347826, 0.31818181818182
64097, 1.4173913043478, 0.72391304347826, 0.27272727272727
64098, 1.4173913043478, 0.72391304347826, 0.22727272727273
64099, 1.4173913043478, 0.72391304347826, 0.18181818181818
64100, 1.4173913043478, 0.72391304347826, 0.13636363636364
64101, 1.4173913043478, 0.72391304347826, 0.090909090909091
64102, 1.4173913043478, 0.72391304347826, 0.045454545454545
64103, 1.4608695652174, 0.72391304347826, 0.45454545454545
64104, 1.4608695652174, 0.72391304347826, 0.40909090909091
64105, 1.4608695652174, 0.72391304347826, 0.36363636363636
64106, 1.4608695652174, 0.72391304347826, 0.31818181818182
64107, 1.4608695652174, 0.72391304347826, 0.27272727272727
64108, 1.4608695652174, 0.72391304347826, 0.22727272727273
64109, 1.4608695652174, 0.72391304347826, 0.18181818181818
64110, 1.4608695652174, 0.72391304347826, 0.13636363636364
64111, 1.4608695652174, 0.72391304347826, 0.090909090909091
64112, 1.4608695652174, 0.72391304347826, 0.045454545454545
64113, 1.504347826087, 0.72391304347826, 0.45454545454545
64114, 1.504347826087, 0.72391304347826, 0.40909090909091
64115, 1.504347826087, 0.72391304347826, 0.36363636363636
64116, 1.504347826087, 0.72391304347826, 0.31818181818182
64117, 1.504347826087, 0.72391304347826, 0.27272727272727
64118, 1.504347826087, 0.72391304347826, 0.22727272727273
64119, 1.504347826087, 0.72391304347826, 0.18181818181818
64120, 1.504347826087, 0.72391304347826, 0.13636363636364
64121, 1.504347826087, 0.72391304347826, 0.090909090909091
64122, 1.504347826087, 0.72391304347826, 0.045454545454545
64123, 1.5478260869565, 0.72391304347826, 0.45454545454545
64124, 1.5478260869565, 0.72391304347826, 0.40909090909091
64125, 1.5478260869565, 0.72391304347826, 0.36363636363636
64126, 1.5478260869565, 0.72391304347826, 0.31818181818182
64127, 1.5478260869565, 0.72391304347826, 0.27272727272727
64128, 1.5478260869565, 0.72391304347826, 0.22727272727273
64129, 1.5478260869565, 0.72391304347826, 0.18181818181818
64130, 1.5478260869565, 0.72391304347826, 0.13636363636364
64131, 1.5478260869565, 0.72391304347826, 0.090909090909091
64132, 1.5478260869565, 0.72391304347826, 0.045454545454545
64133, 1.5913043478261, 0.72391304347826, 0.45454545454545
64134, 1.5913043478261, 0.72391304347826, 0.40909090909091
64135, 1.5913043478261, 0.72391304347826, 0.36363636363636
